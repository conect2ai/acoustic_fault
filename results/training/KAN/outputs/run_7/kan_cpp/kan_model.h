
#ifndef KAN_MODEL_H
#define KAN_MODEL_H

#include <cmath>


inline float score_0(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.000234735048577104*x_1 + 0.00376154664146087*x_10 + 0.00216584551035861*x_100 - 0.00101372111854836*x_101 - 0.00140403465119395*x_102 - 0.000183202288078795*x_103 + 0.000868710226794922*x_104 - 0.000287175610194864*x_105 + 0.000162451041308777*x_106 - 0.000379321241330763*x_107 - 0.000401214865850106*x_108 - 4.35752994680223e-6*x_109 + 8.67116070719907e-5*x_11 + 0.000225288808871787*x_110 - 0.00221361522079016*x_111 - 0.000126938992461197*x_112 - 7.16968362800663e-6*x_113 + 0.000384968886882853*x_114 - 0.00111131962888511*x_115 - 0.000567535772894465*x_116 - 1.09887589632301e-5*x_118 + 0.000465953204262504*x_119 - 0.00540803558725125*x_12 - 0.000108279357960535*x_120 - 8.50555901592262e-6*x_13 + 0.000307815508171989*x_14 - 0.000254066706071734*x_15 + 0.00260710213760963*x_16 + 0.00150590380927385*x_17 + 2.51874274970172e-5*x_18 - 0.000185094476977387*x_19 - 0.000184439914917139*x_2 - 0.0051217168052344*x_20 - 0.00103104211464941*x_21 - 0.00216138990597845*x_22 - 9.78991265963009e-5*x_23 - 0.000525316147233326*x_24 + 0.0011058621409063*x_25 - 0.00033136028808436*x_26 - 5.89984898793608e-5*x_27 + 9.62230371051119e-6*x_28 - 0.00275615991597757*x_29 - 0.000985431056236783*x_3 - 0.000223330205606481*x_30 - 0.0106750332818643*x_31 - 5.04113046326006e-5*x_32 - 0.000310425837050891*x_33 + 0.00023341178107137*x_34 - 0.000299808425202574*x_35 + 0.000683936292517027*x_36 - 0.000712423403983665*x_37 - 0.000780359704701503*x_38 - 0.000370160815321591*x_39 - 0.002430177523075*x_4 - 3.33031528052054e-5*x_40 - 4.11418473284997e-5*x_41 + 0.000534877342288649*x_42 - 0.000118216205178267*x_43 - 0.000174183577471389*x_44 - 0.000224920444778622*x_45 + 4.1176337796853e-6*x_46 + 0.000601504110783347*x_47 - 0.000571652392584345*x_48 + 1.35110142974757e-5*x_49 + 0.000718911983971329*x_5 - 0.000885746104544693*x_50 + 5.41204299291262e-5*x_51 - 0.00194883620936873*x_52 + 0.000970691011740481*x_53 - 0.000769930759506062*x_54 - 0.000142474097283755*x_55 + 1.34087506055296e-5*x_56 - 0.000600402585480746*x_57 - 0.000364917459939701*x_58 - 0.000385354473075889*x_59 - 0.000545541887698927*x_6 - 0.00226452165182313*x_60 - 0.00146720326131108*x_61 - 0.00153535638093633*x_62 - 2.56161481614984e-6*x_63 - 0.000333011543485763*x_64 + 0.00108543652988578*x_65 - 0.000356044893486435*x_66 - 6.18049877244086e-5*x_67 - 3.42948610890073e-5*x_68 - 0.00047427026108095*x_7 - 3.63906172409761e-5*x_70 - 0.000238024357165742*x_71 - 0.000305525370296102*x_72 - 0.000561827851492564*x_73 + 5.41445177038316e-5*x_74 + 2.83291451269703e-5*x_75 + 0.00034240067368234*x_76 + 0.000344970701273573*x_77 - 0.000832272185314777*x_78 - 3.23439418283725e-5*x_79 - 0.000211508645534501*x_8 + 1.6813196716964e-5*x_80 - 0.000100244798989169*x_81 - 6.59776003083648e-5*x_82 - 0.0011995395439328*x_83 + 0.00020337287056223*x_84 - 0.00141105242639401*x_85 - 2.66434504085614e-5*x_86 - 0.000988163629927302*x_87 + 0.000668710971801711*x_88 + 0.000459658255597743*x_89 - 0.000551233970079406*x_9 + 5.1360350262091e-5*x_90 + 0.00135514845164094*x_91 - 1.28907964071262e-5*x_92 + 0.000506863411718305*x_93 + 1.21638047591413e-5*x_94 + 2.97587812555769e-5*x_95 - 0.000270680042933453*x_96 - 0.00011272091118973*x_97 + 8.38038265974993e-5*x_98 - 0.000420871902363374*x_99 - 5.94522094745205e-6*std::pow(-4.67039966583252*x_109 - 6.09272003173828, 2) - 0.00115962172214774*std::pow(-0.629119873046875*x_117 - 1.04919981956482, 2) + 1.0215780973241e-5*std::pow(-6.08007955551147*x_18 - 9.70680046081543, 2) - 1.63069876070365e-5*std::pow(-5.23864030838013*x_19 - 8.24680042266846, 2) - 8.45642297802035e-5*std::pow(-4.40183973312378*x_27 - 6.39983987808228, 2) - 5.14577877360496e-6*std::pow(-6.3778395652771*x_49 - 9.52264022827148, 2) - 1.37563892264094e-5*std::pow(-6.50767993927002*x_67 - 9.74536037445068, 2) + 1.29212748818833e-5*std::pow(-4.48536014556885*x_67 - 5.50952005386353, 2) + 5.67879420036296e-6*std::pow(-5.87383985519409*x_69 - 7.69448041915894, 2) - 3.09044261263522e-5*std::pow(-3.67263984680176*x_69 - 4.90823984146118, 2) + 3.69185137932871e-5*std::pow(-5.61768007278442*x_7 - 8.81968021392822, 2) + 1.05593690219921e-5*std::pow(-7.80000019073486*x_70 - 9.99882030487061, 2) + 1.20441629580979e-5*std::pow(-3.24160003662109*x_79 - 4.85735988616943, 2) + 1.00235228420867e-5*std::pow(-7.40000009536743*x_87 - 9.99973964691162, 2) + 1.97199867257655e-5*std::pow(-6.39191961288452*x_90 - 8.79872035980225, 2) + 0.00110713964907046*std::exp(0.97327983379364*x_17) - 1.48254810771757*std::exp(-0.00604356923074462*x_10 + 0.00741669668424122*x_100 + 0.00427529607187722*x_101 + 0.00206132215599589*x_103 + 0.0158071755675365*x_104 + 0.0010789388155962*x_107 - 0.00574853002786715*x_108 - 0.00181691434224177*x_11 - 0.0089518583698799*x_110 + 0.0201470457704028*x_111 + 0.00056016050898535*x_112 + 0.0355832365917195*x_113 + 0.00270093263100172*x_115 - 0.00291041046085418*x_116 - 0.000993914911425134*x_117 - 0.00447370472902622*x_13 - 0.00133888352039384*x_14 - 0.0224287098607445*x_15 - 0.0457430805606748*x_16 + 0.0010071576101083*x_17 - 0.000117055267661016*x_18 - 0.000878033401050479*x_19 - 0.0392349983319681*x_2 + 0.0797214158465143*x_20 + 0.00776007456356312*x_21 - 0.0109256640037959*x_22 + 0.0218118334411703*x_23 + 0.0203478852346705*x_25 - 0.000829438928720664*x_28 + 0.00185455805814939*x_29 - 0.0307184683506525*x_3 - 0.00302151992364495*x_30 + 0.0731206243616038*x_31 + 0.0120510942823912*x_32 - 0.023903281671284*x_33 + 0.00176058413783224*x_34 + 0.00158095662774763*x_38 + 0.00344586248884543*x_39 + 0.0465791621419567*x_4 - 0.0261389195821822*x_40 + 5.4904832562147e-5*x_44 - 0.030155184035812*x_45 - 0.00374133950338305*x_48 - 0.00301196178257215*x_5 + 0.00130547810033757*x_51 - 0.000321331998879854*x_52 + 0.000910012690023541*x_53 + 0.000383443308554996*x_54 + 0.00199131047746558*x_56 + 0.035900881026328*x_57 + 0.00130420529536135*x_58 + 0.000559866265141263*x_59 + 0.0158542737254668*x_6 + 0.000325818302983729*x_60 + 0.000222685774020568*x_61 - 0.016960654130958*x_62 + 0.0292947920223233*x_63 - 0.0215713333106478*x_64 - 0.00119833544833818*x_65 - 0.00718633178291745*x_66 - 0.000197340947615305*x_67 + 0.0199284237452529*x_68 - 0.0216824113501962*x_69 - 0.00505922203258111*x_7 - 0.000247120252156729*x_70 + 0.00649902968141905*x_71 + 0.00728328264284806*x_72 - 0.000193871919668755*x_73 - 0.000186784425895124*x_75 + 0.00686102419574575*x_76 + 0.0281409285112947*x_77 - 0.000171505190145116*x_78 - 0.00445274068592739*x_79 + 0.011855202266841*x_8 + 5.71825355056205e-6*x_80 + 0.00043247551353948*x_82 + 0.000786654344573801*x_83 + 0.000132398102548104*x_84 + 0.000263115916209662*x_85 + 0.00805261417853127*x_86 - 5.37980827529415e-6*x_87 - 0.00224024584366636*x_88 - 0.00527288055243371*x_89 - 0.00106176959213594*x_9 - 0.000318988005444541*x_90 + 0.024485212436639*x_91 + 0.0744840870784862*x_92 + 0.00725187838222097*x_93 - 0.000153976099107196*x_95 + 0.000515992286986626*x_97 - 0.0124332710495292*x_99 + 0.000300579735343885*std::pow(-7.64775991439819*x_81 - 9.46271991729736, 2) + 0.189076251210674*std::sin(0.409919857978821*x_1 + 4.98423957824707) + 0.341000094283839*std::sin(0.158400028944016*x_102 + 8.13687992095947) + 0.355724382393952*std::sin(0.308479934930801*x_105 + 5.12871980667114) - 0.0678267841844882*std::sin(0.448319852352142*x_106 - 1.17631983757019) + 0.224801203289715*std::sin(0.246559977531433*x_109 + 5.04895973205566) - 0.32826987321144*std::sin(0.351679861545563*x_114 + 1.95783984661102) + 0.141003230714976*std::sin(0.305519849061966*x_118 - 1.26919984817505) + 0.407900817852802*std::sin(0.322239845991135*x_119 + 5.13624000549316) - 0.322734817711723*std::sin(0.327839851379395*x_12 + 5.1300802230835) + 0.336106510373302*std::sin(0.349519848823547*x_120 - 7.44911956787109) - 0.11277937852483*std::sin(0.371919840574265*x_24 + 8.35968017578125) + 0.406015250474123*std::sin(0.33815985918045*x_26 + 5.15375995635986) + 2.4490191659936*std::sin(0.160000026226044*x_27 - 7.64448022842407) - 0.294346962173453*std::sin(0.306319922208786*x_35 - 7.54120016098022) + 0.272476772559038*std::sin(0.339599847793579*x_36 - 7.43495988845825) + 0.100080511361011*std::sin(0.378719836473465*x_37 - 4.22504043579102) - 0.208480047112491*std::sin(0.338959842920303*x_41 + 1.93567979335785) - 0.536581799271296*std::sin(0.206640005111694*x_42 - 7.60008001327515) + 0.153354489425217*std::sin(0.371759831905365*x_43 + 5.17224025726318) + 0.617743639676149*std::sin(0.223279997706413*x_46 + 5.03991985321045) + 0.279109318729098*std::sin(0.366639852523804*x_47 - 7.4270396232605) + 0.241577844359409*std::sin(0.34215983748436*x_49 - 4.2454400062561) + 0.149476338866306*std::sin(0.245119974017143*x_50 - 7.54640007019043) - 0.390592095167452*std::sin(0.227199986577034*x_55 + 5.01903963088989) + 0.279071569394773*std::sin(0.30159991979599*x_74 - 7.46799993515015) + 0.424141786371734*std::sin(0.386319845914841*x_94 + 2.00543975830078) + 0.0737786775085736*std::sin(0.397999823093414*x_96 + 1.99415981769562) + 0.322466269184751*std::sin(0.390079826116562*x_98 + 1.9676798582077)) - 0.0162175779393272*std::sin(0.204479992389679*x_1 - 7.40343999862671) - 0.0040083403684192*std::sin(0.408479869365692*x_100 - 7.38679981231689) - 0.00378730390673141*std::sin(0.303759932518005*x_101 + 8.27639961242676) - 0.00423384082261949*std::sin(0.298319935798645*x_102 + 5.09783983230591) - 0.00352234424246031*std::sin(0.401839852333069*x_103 + 1.99063980579376) - 0.00739578004287867*std::sin(0.316479861736298*x_107 + 1.93535983562469) + 0.009251814418312*std::sin(0.409119844436646*x_109 - 1.185919880867) + 0.0126668956333695*std::sin(0.317759841680527*x_11 - 1.07807981967926) - 0.00713514641431507*std::sin(0.369279861450195*x_110 - 7.41311979293823) + 0.00596857311643427*std::sin(0.467359870672226*x_111 + 2.05663967132568) - 0.0101289034868924*std::sin(0.340159833431244*x_112 - 7.43631982803345) - 0.0030599104302257*std::sin(0.37679985165596*x_112 - 7.41648006439209) + 0.0102261355335727*std::sin(0.350399851799011*x_113 + 1.94639980792999) + 0.0144775994998069*std::sin(0.166160017251968*x_115 + 8.14791965484619) + 0.00430453498396573*std::sin(0.297279924154282*x_117 + 5.08855962753296) + 0.00548882944957313*std::sin(0.511359870433807*x_117 - 7.44767951965332) + 0.00656475056575083*std::sin(0.320319831371307*x_118 - 7.46407985687256) - 0.0182156523339201*std::sin(0.388959854841232*x_118 - 7.39264011383057) - 0.0034575191193613*std::sin(0.417999863624573*x_119 + 8.20368003845215) + 0.0147730599830858*std::sin(0.289759933948517*x_14 + 5.12048006057739) - 0.00398464375947052*std::sin(0.406079858541489*x_15 - 0.976399838924408) + 0.0597917771702511*std::sin(0.228879988193512*x_18 + 5.02151966094971) - 0.0136439097987396*std::sin(0.312959939241409*x_21 - 4.29031991958618) - 0.0338448571767579*std::sin(0.250799983739853*x_23 - 7.52175998687744) + 0.000827322721444468*std::sin(0.365439832210541*x_23 - 1.03543972969055) + 0.0224003715699409*std::sin(0.316879838705063*x_26 - 4.26823997497559) + 0.00871437793919199*std::sin(0.337999850511551*x_28 - 4.25271987915039) + 0.000476926366421664*std::sin(1.42767989635468*x_28 - 3.18928003311157) + 0.00017679323996258*std::sin(1.30543982982635*x_29 + 6.19024038314819) + 0.0247977192581745*std::sin(0.294559925794601*x_3 + 8.30103969573975) + 0.0086322293959826*std::sin(0.320479840040207*x_3 + 8.33432006835938) - 0.0116100079475791*std::sin(0.259199976921082*x_32 - 7.40863990783691) - 0.0394359442651978*std::sin(0.27295994758606*x_32 - 7.44280004501343) - 0.0100643488554208*std::sin(0.272799968719482*x_33 - 1.17695987224579) + 0.0034093861963393*std::sin(0.310799926519394*x_33 - 1.39063990116119) - 0.0286268673671721*std::sin(0.355359852313995*x_34 - 7.4049596786499) + 0.0115951092482954*std::sin(0.397919833660126*x_34 - 1.2040798664093) - 0.00433003326683875*std::sin(0.306479930877686*x_35 + 8.26095962524414) + 0.00580925665589522*std::sin(0.343279838562012*x_36 + 5.15208005905151) + 0.000323159389844083*std::sin(1.33471989631653*x_38 - 3.82351994514465) - 0.0449777299633331*std::sin(0.175280019640923*x_40 + 4.95599985122681) + 0.00875034469322985*std::sin(0.265359967947006*x_40 + 5.07607984542847) - 0.0107481772586296*std::sin(0.263679951429367*x_41 + 5.06279993057251) + 0.00334917536405926*std::sin(0.300799936056137*x_41 + 1.88895988464355) + 0.0108571935285308*std::sin(0.343759834766388*x_42 + 8.17296028137207) + 0.00366787718533058*std::sin(0.303439915180206*x_43 - 7.49440002441406) + 7.36609681825783e-5*std::sin(1.93639981746674*x_5 + 7.80280017852783) - 0.0147269288666101*std::sin(0.225919991731644*x_50 - 7.57376003265381) - 0.00287117422428021*std::sin(0.443919867277145*x_50 - 1.38655984401703) - 0.00523177900815827*std::sin(0.329439848661423*x_51 + 1.94511985778809) - 0.00721407519584625*std::sin(0.225359991192818*x_55 - 7.57776021957397) + 0.0177543370416874*std::sin(0.353759855031967*x_56 + 5.14152002334595) - 0.00691797060150118*std::sin(0.353679835796356*x_57 - 4.23112010955811) - 0.00604899193008815*std::sin(0.291439920663834*x_58 - 4.54112005233765) - 0.0914323421485281*std::sin(0.136720046401024*x_64 + 4.91695976257324) + 0.0321286860156342*std::sin(0.173920020461082*x_69 + 4.95703983306885) - 0.000215312506505511*std::sin(1.62239992618561*x_7 + 2.00263977050781) + 0.00710444837513689*std::sin(0.262639969587326*x_74 - 7.51015996932983) + 0.0783944584341497*std::sin(0.146000042557716*x_79 - 7.65496015548706) + 0.02867183795012*std::sin(0.254399985074997*x_8 + 5.06679964065552) + 0.00324978799313074*std::sin(0.328719854354858*x_82 - 7.48216009140015) + 0.00666150762752639*std::sin(0.171040013432503*x_83 + 4.96776008605957) - 0.0184092296606964*std::sin(0.281919926404953*x_84 - 7.49887990951538) + 0.00628439219709464*std::sin(0.23479999601841*x_85 - 7.55768013000488) - 0.00161846707959029*std::sin(0.519279837608337*x_9 - 0.845999836921692) - 0.069703196622954*std::sin(0.183520004153252*x_91 - 7.36463975906372) - 0.00658718857211691*std::sin(0.327599853277206*x_92 - 1.00311982631683) - 0.0402098601314709*std::sin(0.338879853487015*x_92 + 5.19623994827271) + 0.00191734567424505*std::sin(0.329279839992523*x_94 - 1.22063982486725) + 0.00310995176703697*std::sin(0.337919861078262*x_95 - 7.43951988220215) - 0.0110941802472834*std::sin(0.377039849758148*x_95 - 7.42439985275269) + 0.0166125909747696*std::sin(0.355519831180573*x_96 + 1.9670398235321) - 0.00804723554778386*std::sin(0.26463994383812*x_97 + 5.07655954360962) + 0.0149751479158221*std::sin(0.273999959230423*x_98 - 4.30663967132568) - 0.0090308440849185*std::sin(0.00118367803699948*x_1 + 0.00462310217822331*x_10 - 0.0425766165789192*x_100 + 0.00439217071543253*x_101 + 0.00171079574373389*x_102 + 0.00438154516051955*x_103 - 0.00183131677558983*x_105 + 0.017937007933503*x_106 + 0.0297986719086298*x_108 + 0.000346170815193902*x_109 - 0.00898072552004636*x_11 + 0.0102359805516831*x_110 + 0.00194979729153195*x_111 + 0.0032163492361236*x_113 + 0.0859532953110524*x_114 + 0.00273031618248352*x_115 + 0.0146421549825374*x_118 - 0.00253192351928369*x_119 + 0.000270888102824328*x_12 - 0.0242254716531485*x_14 + 0.00409106302988625*x_15 + 0.0297066475041466*x_16 - 0.0016230747826757*x_17 - 0.00571268825499161*x_19 + 0.0462367494962535*x_2 + 0.10691879600062*x_20 + 0.00154105924540085*x_21 + 0.0625836233919439*x_22 - 0.0232835121429813*x_23 + 0.00269319129914414*x_25 + 0.0323563471335717*x_28 + 0.000289231890017768*x_29 - 0.000337248912282374*x_3 + 0.00623308758688967*x_30 - 0.015362129710026*x_32 - 0.00422890705668129*x_33 + 0.00315219178605437*x_37 + 0.0343518467039291*x_39 - 0.0203702786584652*x_41 + 0.00132570527239071*x_42 - 0.00480998064609806*x_43 - 0.0009775862067486*x_44 - 0.00152345069964228*x_46 - 0.0190498400373145*x_47 + 0.00419907653342401*x_48 + 0.000805799911687057*x_49 + 0.0244244437858671*x_51 + 0.00683810349540761*x_52 + 0.0023876624085987*x_53 + 0.00362206541063337*x_54 - 0.00551922072291855*x_55 + 0.0400427699754033*x_56 + 0.042023257475926*x_58 - 0.0107010354767661*x_59 - 0.00287577399790894*x_6 - 0.000295518667144084*x_60 + 0.0170876247759326*x_61 - 0.0081245037162252*x_62 - 0.0188963605143609*x_63 + 0.0018459588008033*x_64 + 0.0367730736360763*x_66 + 0.00180015887016934*x_67 - 0.000709654863664533*x_68 + 0.0182214161376527*x_72 + 0.00262592957858358*x_73 + 0.00207848261899633*x_74 - 0.0172488668158261*x_76 + 0.00220092338721752*x_78 - 7.66582873302333e-5*x_79 + 0.0234804799061851*x_80 - 0.0044452416688038*x_83 + 0.00149275915547431*x_84 + 0.00375636209544379*x_86 + 0.000876120601917984*x_87 + 0.00117565500582477*x_88 - 0.024816190924992*x_89 - 0.0748801700026845*x_9 + 0.00133177738885088*x_90 + 0.142124876908352*x_91 - 0.00120625085062308*x_92 + 0.0047306849566116*x_93 + 0.000451584812997281*x_94 - 0.00119384742011814*x_95 + 0.00354135459967154*x_96 + 0.00241145128511065*x_98 + 0.0117791824025126*x_99 + 0.00193530440091028*std::pow(-5.42967987060547*x_13 - 9.45328044891357, 2) + 0.000515042700611534*std::pow(-7.32359981536865*x_18 - 9.49656009674072, 2) - 0.00108921933773765*std::pow(-5.92095994949341*x_4 - 9.2705602645874, 2) - 0.00114436613034696*std::pow(-5.81791973114014*x_5 - 9.03359985351563, 2) - 0.000704419805894974*std::pow(-5.25591993331909*x_57 - 8.28688049316406, 2) - 0.000856650756452471*std::pow(-5.58383989334106*x_7 - 9.16079998016357, 2) - 0.00124791619831033*std::pow(-3.86879992485046*x_71 - 6.11287975311279, 2) + 0.00109286870360537*std::pow(-3.55695986747742*x_75 - 4.39680004119873, 2) + 0.000365696890777811*std::pow(-8.19999980926514*x_81 - 9.99917984008789, 2) + 0.000973809881009036*std::pow(-3.7960000038147*x_85 - 6.38800001144409, 2) - 0.135052121597994*std::sin(0.410399854183197*x_104 + 1.98927986621857) + 0.487090948465266*std::sin(0.31591984629631*x_107 - 7.4553599357605) + 0.322646477718536*std::sin(0.309759944677353*x_112 + 1.88231992721558) - 0.175328988402953*std::sin(0.773439824581146*x_116 - 1.000079870224) - 0.256068522713463*std::sin(0.470959842205048*x_117 + 2.05343985557556) + 0.563368182826707*std::sin(0.25111997127533*x_120 + 5.06399965286255) + 0.0220533155826601*std::sin(0.868479907512665*x_24 + 1.17119991779327) + 0.555454612158883*std::sin(0.309119910001755*x_26 - 4.26143980026245) + 0.762925400944823*std::sin(0.257519990205765*x_27 + 5.08903980255127) + 1.13489591790221*std::sin(0.207520008087158*x_31 - 7.40839958190918) + 0.299180523221366*std::sin(0.374639838933945*x_34 - 1.20295989513397) - 0.585039991839949*std::sin(0.300959944725037*x_35 - 4.35016012191772) + 0.578089124056078*std::sin(0.346159845590591*x_36 - 7.4475998878479) + 1.12854896214594*std::sin(0.225599989295006*x_38 + 5.01599979400635) - 0.580081880785428*std::sin(0.381999850273132*x_40 + 5.16951990127563) + 0.317538703171977*std::sin(0.373599827289581*x_45 - 1.22919988632202) - 0.0712240480320361*std::sin(0.581999838352203*x_50 + 8.38016033172607) - 1.55021550214769*std::sin(0.158240035176277*x_65 - 7.64480018615723) - 0.870800322137711*std::sin(0.192959994077682*x_69 + 4.99343967437744) + 0.687988828340394*std::sin(0.223359987139702*x_70 - 7.56512022018433) + 0.653406284563289*std::sin(0.254399985074997*x_77 + 5.06759977340698) - 0.693722168559361*std::sin(0.325119823217392*x_8 + 5.11800003051758) + 2.21953243559074*std::sin(0.146640032529831*x_82 + 4.93063974380493) + 0.36567669150179*std::sin(0.381359845399857*x_97 + 1.97151982784271) + 14.205759954766) - 0.114184914120632);
}

inline float score_1(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.000506550105918724*x_1 - 0.000370821657495573*x_10 + 0.000390387992834685*x_100 + 0.000332865920033378*x_101 + 0.000312339376357384*x_102 - 3.07045888085352e-6*x_103 + 0.000205888379080344*x_104 - 2.53338691345678e-5*x_105 + 0.00037335455079624*x_106 + 9.16510565094223e-5*x_107 + 0.000438977681458013*x_108 - 1.27288830337916e-6*x_109 - 0.000124989531002881*x_11 - 9.57281789238213e-5*x_110 + 0.00089756315778609*x_111 - 0.000180788480541475*x_112 + 0.000879801379409463*x_113 + 0.00204170316266308*x_114 + 0.000304402862113849*x_115 - 0.000893724856556532*x_116 - 2.31374273391539e-5*x_117 + 0.000210815448774126*x_118 + 0.000404298864740406*x_119 + 0.00314040843846805*x_12 + 2.92600364905961e-5*x_120 + 0.000131740500844704*x_13 - 0.000462066430612159*x_14 - 0.000271402824527995*x_15 + 0.00147928526765803*x_16 - 0.000273644305859627*x_17 + 3.5734806488623e-5*x_18 - 6.90138343231577e-5*x_19 - 0.00153445577523507*x_2 + 0.00112306608015937*x_20 - 0.00165513603805713*x_21 + 0.00119133328008947*x_22 - 3.64096273803487e-6*x_23 - 2.91401556593895e-5*x_24 + 0.000385848867363368*x_25 + 5.98917304392699e-5*x_26 - 0.000123797371350429*x_27 + 0.000481258513035374*x_28 - 0.00182493988628638*x_29 - 0.0022250361468394*x_3 - 5.76794999867845e-5*x_30 + 0.00352985824304976*x_31 - 3.5222516207846e-5*x_32 - 0.000566381375812199*x_33 - 1.65857436249508e-5*x_34 + 0.000494677905195686*x_35 + 0.00113621283418522*x_36 - 0.000568178262097893*x_37 - 0.000890103278837706*x_38 + 0.000171995986769981*x_39 - 0.00228182383385318*x_4 - 0.000659342057642139*x_40 - 0.000309236270131482*x_41 + 0.00106342117475988*x_42 - 4.93968319924541e-5*x_43 - 0.000358689111258971*x_44 - 0.000804650854916071*x_45 + 0.000200017422469508*x_46 - 0.000717133547989145*x_47 - 0.000612611374304529*x_48 + 1.05809009376585e-5*x_49 - 0.000262500163807162*x_5 - 0.00135248309780778*x_50 + 0.000614962180714232*x_51 + 0.000436836011297247*x_52 + 0.00136562739821237*x_53 - 0.000944290869768891*x_54 + 0.000997623716685465*x_55 + 0.000652715267416042*x_56 + 0.000979359791059853*x_57 + 0.000766604134882696*x_58 - 9.80348433017948e-5*x_59 - 0.000679502582359909*x_6 - 0.00158601918335139*x_60 - 0.00155028804802146*x_61 - 0.000233348202233864*x_62 + 0.000396039361926963*x_63 - 0.00114216036335115*x_64 - 0.000279531140514482*x_65 + 0.00045683520076265*x_66 - 7.09852600208074e-5*x_67 + 0.000811953152284299*x_68 - 0.000504746645196699*x_69 - 7.9628052378161e-7*x_7 - 4.42297338953722e-5*x_70 + 0.000199898436655567*x_71 + 0.000384618021303723*x_72 + 0.000157446823603163*x_73 + 0.000127715554202206*x_74 + 2.28270725717921e-5*x_75 - 0.000178778716177866*x_76 + 0.000696688755605066*x_77 + 0.000241860748081793*x_78 - 0.000154234608385557*x_79 - 0.000117731004841432*x_8 + 0.000263917329530363*x_80 + 3.58758782516888e-6*x_81 + 5.09562866169453e-5*x_82 - 0.000142216030112275*x_83 + 0.000300721304473706*x_84 + 0.000260775710349032*x_85 + 0.000341824388609318*x_86 - 0.00148405716481569*x_87 + 0.00103075352808126*x_88 + 0.00026661503190955*x_89 - 0.00277509203183144*x_9 + 8.11576179785501e-5*x_90 + 0.00278931404786982*x_91 + 0.00171835098947049*x_92 - 5.59745872453378e-5*x_93 + 0.000107768674861658*x_94 + 2.32985973347238e-5*x_95 - 0.000337965791649939*x_96 + 7.45054101791453e-5*x_97 + 0.000119291895423806*x_98 - 0.000118775711351941*x_99 + 1.46637630223503e-6*std::pow(-4.67039966583252*x_109 - 6.09272003173828, 2) - 0.00177067533349386*std::pow(-0.629119873046875*x_117 - 1.04919981956482, 2) + 3.00819739528391e-5*std::pow(-5.42967987060547*x_13 - 9.45328044891357, 2) + 8.00571791037557e-6*std::pow(-7.32359981536865*x_18 - 9.49656009674072, 2) - 2.51970099351887e-6*std::pow(-6.08007955551147*x_18 - 9.70680046081543, 2) - 2.48998273901693e-5*std::pow(-5.23864030838013*x_19 - 8.24680042266846, 2) + 1.52002326707856e-5*std::pow(-4.40183973312378*x_27 - 6.39983987808228, 2) - 1.69306015794419e-5*std::pow(-5.92095994949341*x_4 - 9.2705602645874, 2) - 7.8573067165068e-6*std::pow(-6.3778395652771*x_49 - 9.52264022827148, 2) - 1.77877919925242e-5*std::pow(-5.81791973114014*x_5 - 9.03359985351563, 2) - 1.0949356722813e-5*std::pow(-5.25591993331909*x_57 - 8.28688049316406, 2) + 2.47268044059289e-6*std::pow(-6.50767993927002*x_67 - 9.74536037445068, 2) - 3.18700540298318e-6*std::pow(-4.48536014556885*x_67 - 5.50952005386353, 2) - 1.40066270274628e-6*std::pow(-5.87383985519409*x_69 - 7.69448041915894, 2) - 4.71892721502017e-5*std::pow(-3.67263984680176*x_69 - 4.90823984146118, 2) - 6.63602093906781e-6*std::pow(-5.61768007278442*x_7 - 8.81968021392822, 2) - 1.33156033387627e-5*std::pow(-5.58383989334106*x_7 - 9.16079998016357, 2) - 1.89802315243862e-6*std::pow(-7.80000019073486*x_70 - 9.99882030487061, 2) - 1.93973529720907e-5*std::pow(-3.86879992485046*x_71 - 6.11287975311279, 2) + 1.69873265726396e-5*std::pow(-3.55695986747742*x_75 - 4.39680004119873, 2) - 2.97066758294003e-6*std::pow(-3.24160003662109*x_79 - 4.85735988616943, 2) + 5.68431732901452e-6*std::pow(-8.19999980926514*x_81 - 9.99917984008789, 2) + 6.99722049261671e-6*std::pow(-7.64775991439819*x_81 - 9.46271991729736, 2) + 1.51367006977055e-5*std::pow(-3.7960000038147*x_85 - 6.38800001144409, 2) - 1.80170599054305e-6*std::pow(-7.40000009536743*x_87 - 9.99973964691162, 2) - 3.54462385899494e-6*std::pow(-6.39191961288452*x_90 - 8.79872035980225, 2) + 0.00169053824182535*std::exp(0.97327983379364*x_17) + 0.00400003165232588*std::sin(0.204479992389679*x_1 - 7.40343999862671) + 0.00440152167319215*std::sin(0.409919857978821*x_1 + 4.98423957824707) + 0.000988648761668141*std::sin(0.408479869365692*x_100 - 7.38679981231689) + 0.000934130581063302*std::sin(0.303759932518005*x_101 + 8.27639961242676) + 0.0079381693678627*std::sin(0.158400028944016*x_102 + 8.13687992095947) + 0.00104426797668222*std::sin(0.298319935798645*x_102 + 5.09783983230591) + 0.000868778834480728*std::sin(0.401839852333069*x_103 + 1.99063980579376) - 0.00209922242840745*std::sin(0.410399854183197*x_104 + 1.98927986621857) + 0.00828093728728149*std::sin(0.308479934930801*x_105 + 5.12871980667114) - 0.00157894531280033*std::sin(0.448319852352142*x_106 - 1.17631983757019) + 0.0075712416183748*std::sin(0.31591984629631*x_107 - 7.4553599357605) - 0.0112929285850365*std::sin(0.316479861736298*x_107 + 1.93535983562469) + 0.00523316578419394*std::sin(0.246559977531433*x_109 + 5.04895973205566) - 0.00166299311364618*std::sin(0.409119844436646*x_109 - 1.185919880867) - 0.00227684638462643*std::sin(0.317759841680527*x_11 - 1.07807981967926) - 0.0108949561011115*std::sin(0.369279861450195*x_110 - 7.41311979293823) + 0.00911366611333479*std::sin(0.467359870672226*x_111 + 2.05663967132568) + 0.00501515055416558*std::sin(0.309759944677353*x_112 + 1.88231992721558) + 0.00182064792762694*std::sin(0.340159833431244*x_112 - 7.43631982803345) + 0.000754720502653104*std::sin(0.37679985165596*x_112 - 7.41648006439209) + 0.0156147178001512*std::sin(0.350399851799011*x_113 + 1.94639980792999) - 0.00764182149976233*std::sin(0.351679861545563*x_114 + 1.95783984661102) + 0.0221064575049804*std::sin(0.166160017251968*x_115 + 8.14791965484619) - 0.00272527777017119*std::sin(0.773439824581146*x_116 - 1.000079870224) - 0.00106170454360223*std::sin(0.297279924154282*x_117 + 5.08855962753296) - 0.00398027650161143*std::sin(0.470959842205048*x_117 + 2.05343985557556) - 0.000986604914875048*std::sin(0.511359870433807*x_117 - 7.44767951965332) + 0.00328242585733603*std::sin(0.305519849061966*x_118 - 1.26919984817505) - 0.00161918198579762*std::sin(0.320319831371307*x_118 - 7.46407985687256) + 0.00327422308989731*std::sin(0.388959854841232*x_118 - 7.39264011383057) + 0.00949555683908418*std::sin(0.322239845991135*x_119 + 5.13624000549316) + 0.000852789853559406*std::sin(0.417999863624573*x_119 + 8.20368003845215) - 0.00751297048548461*std::sin(0.327839851379395*x_12 + 5.1300802230835) + 0.00875687927629375*std::sin(0.25111997127533*x_120 + 5.06399965286255) + 0.00782425122370712*std::sin(0.349519848823547*x_120 - 7.44911956787109) + 0.0225576085827605*std::sin(0.289759933948517*x_14 + 5.12048006057739) + 0.000982804042672361*std::sin(0.406079858541489*x_15 - 0.976399838924408) - 0.0107474392795847*std::sin(0.228879988193512*x_18 + 5.02151966094971) + 0.00245246251304005*std::sin(0.312959939241409*x_21 - 4.29031991958618) + 0.00608353798211571*std::sin(0.250799983739853*x_23 - 7.52175998687744) - 0.000204057417503834*std::sin(0.365439832210541*x_23 - 1.03543972969055) - 0.00262540047037995*std::sin(0.371919840574265*x_24 + 8.35968017578125) + 0.000342792206031922*std::sin(0.868479907512665*x_24 + 1.17119991779327) + 0.00863387235986681*std::sin(0.309119910001755*x_26 - 4.26143980026245) + 0.0342040724509111*std::sin(0.316879838705063*x_26 - 4.26823997497559) + 0.00945166256029254*std::sin(0.33815985918045*x_26 + 5.15375995635986) + 0.0570109195002661*std::sin(0.160000026226044*x_27 - 7.64448022842407) + 0.011858755670884*std::sin(0.257519990205765*x_27 + 5.08903980255127) - 0.00156639009899536*std::sin(0.337999850511551*x_28 - 4.25271987915039) + 0.000728238991032033*std::sin(1.42767989635468*x_28 - 3.18928003311157) - 4.3605682575613e-5*std::sin(1.30543982982635*x_29 + 6.19024038314819) - 0.00445733501515689*std::sin(0.294559925794601*x_3 + 8.30103969573975) - 0.00212912131165628*std::sin(0.320479840040207*x_3 + 8.33432006835938) + 0.0176405889561662*std::sin(0.207520008087158*x_31 - 7.40839958190918) + 0.00286358415836281*std::sin(0.259199976921082*x_32 - 7.40863990783691) + 0.00708852348068648*std::sin(0.27295994758606*x_32 - 7.44280004501343) + 0.00248235057863412*std::sin(0.272799968719482*x_33 - 1.17695987224579) + 0.00520593562962194*std::sin(0.310799926519394*x_33 - 1.39063990116119) + 0.00514561589158589*std::sin(0.355359852313995*x_34 - 7.4049596786499) + 0.00465040057910722*std::sin(0.374639838933945*x_34 - 1.20295989513397) + 0.0177050615239402*std::sin(0.397919833660126*x_34 - 1.2040798664093) - 0.00909374142260034*std::sin(0.300959944725037*x_35 - 4.35016012191772) - 0.00685212725103778*std::sin(0.306319922208786*x_35 - 7.54120016098022) + 0.00106799364170021*std::sin(0.306479930877686*x_35 + 8.26095962524414) + 0.00634300930011432*std::sin(0.339599847793579*x_36 - 7.43495988845825) - 0.00143284099432111*std::sin(0.343279838562012*x_36 + 5.15208005905151) + 0.00898569856199108*std::sin(0.346159845590591*x_36 - 7.4475998878479) + 0.00232978249250786*std::sin(0.378719836473465*x_37 - 4.22504043579102) + 0.0175419331800257*std::sin(0.225599989295006*x_38 + 5.01599979400635) - 5.80871832942431e-5*std::sin(1.33471989631653*x_38 - 3.82351994514465) + 0.00808464716374057*std::sin(0.175280019640923*x_40 + 4.95599985122681) - 0.00215825420248501*std::sin(0.265359967947006*x_40 + 5.07607984542847) - 0.00901667356313223*std::sin(0.381999850273132*x_40 + 5.16951990127563) - 0.016411845335759*std::sin(0.263679951429367*x_41 + 5.06279993057251) - 0.000826067093097803*std::sin(0.300799936056137*x_41 + 1.88895988464355) - 0.0048532242411095*std::sin(0.338959842920303*x_41 + 1.93567979335785) - 0.0124911320369976*std::sin(0.206640005111694*x_42 - 7.60008001327515) - 0.00195155644667209*std::sin(0.343759834766388*x_42 + 8.17296028137207) - 0.000904674230212144*std::sin(0.303439915180206*x_43 - 7.49440002441406) + 0.0035699518292983*std::sin(0.371759831905365*x_43 + 5.17224025726318) + 0.00493575635612919*std::sin(0.373599827289581*x_45 - 1.22919988632202) + 0.0143805052252785*std::sin(0.223279997706413*x_46 + 5.03991985321045) + 0.00649740889038036*std::sin(0.366639852523804*x_47 - 7.4270396232605) + 0.00562371059772181*std::sin(0.34215983748436*x_49 - 4.2454400062561) - 1.81683236161162e-5*std::sin(1.93639981746674*x_5 + 7.80280017852783) + 0.00363236617874616*std::sin(0.225919991731644*x_50 - 7.57376003265381) + 0.00347967204202913*std::sin(0.245119974017143*x_50 - 7.54640007019043) + 0.000516087196215891*std::sin(0.443919867277145*x_50 - 1.38655984401703) - 0.00110709196791353*std::sin(0.581999838352203*x_50 + 8.38016033172607) + 0.00129040734127499*std::sin(0.329439848661423*x_51 + 1.94511985778809) + 0.00177933654665335*std::sin(0.225359991192818*x_55 - 7.57776021957397) - 0.00909262565366549*std::sin(0.227199986577034*x_55 + 5.01903963088989) - 0.00319130268969082*std::sin(0.353759855031967*x_56 + 5.14152002334595) - 0.0105633411895964*std::sin(0.353679835796356*x_57 - 4.23112010955811) - 0.00923646099287708*std::sin(0.291439920663834*x_58 - 4.54112005233765) + 0.0164347606299355*std::sin(0.136720046401024*x_64 + 4.91695976257324) - 0.0240962312362644*std::sin(0.158240035176277*x_65 - 7.64480018615723) - 0.00577506002376647*std::sin(0.173920020461082*x_69 + 4.95703983306885) - 0.013535541280405*std::sin(0.192959994077682*x_69 + 4.99343967437744) - 0.000328769750497545*std::sin(1.62239992618561*x_7 + 2.00263977050781) + 0.0106939569838448*std::sin(0.223359987139702*x_70 - 7.56512022018433) - 0.00127700883198898*std::sin(0.262639969587326*x_74 - 7.51015996932983) + 0.0064965301205078*std::sin(0.30159991979599*x_74 - 7.46799993515015) + 0.0101564130291902*std::sin(0.254399985074997*x_77 + 5.06759977340698) - 0.0140912299609008*std::sin(0.146000042557716*x_79 - 7.65496015548706) - 0.00515369925408947*std::sin(0.254399985074997*x_8 + 5.06679964065552) - 0.0107830748461556*std::sin(0.325119823217392*x_8 + 5.11800003051758) + 0.0344999561224154*std::sin(0.146640032529831*x_82 + 4.93063974380493) - 0.00080155340609455*std::sin(0.328719854354858*x_82 - 7.48216009140015) - 0.00164304691255403*std::sin(0.171040013432503*x_83 + 4.96776008605957) + 0.00330901818487349*std::sin(0.281919926404953*x_84 - 7.49887990951538) - 0.00155003218101082*std::sin(0.23479999601841*x_85 - 7.55768013000488) + 0.000399191517428106*std::sin(0.519279837608337*x_9 - 0.845999836921692) + 0.0125289949346225*std::sin(0.183520004153252*x_91 - 7.36463975906372) - 0.0100582561528061*std::sin(0.327599853277206*x_92 - 1.00311982631683) + 0.00722763314047455*std::sin(0.338879853487015*x_92 + 5.19623994827271) - 0.000472909297191173*std::sin(0.329279839992523*x_94 - 1.22063982486725) + 0.00987363168704624*std::sin(0.386319845914841*x_94 + 2.00543975830078) - 0.000767063093631771*std::sin(0.337919861078262*x_95 - 7.43951988220215) + 0.00199415428353868*std::sin(0.377039849758148*x_95 - 7.42439985275269) - 0.00298607636748327*std::sin(0.355519831180573*x_96 + 1.9670398235321) + 0.00171749992923018*std::sin(0.397999823093414*x_96 + 1.99415981769562) + 0.00198483380349907*std::sin(0.26463994383812*x_97 + 5.07655954360962) + 0.00568400335561847*std::sin(0.381359845399857*x_97 + 1.97151982784271) - 0.00269174961081729*std::sin(0.273999959230423*x_98 - 4.30663967132568) + 0.00750671892213807*std::sin(0.390079826116562*x_98 + 1.9676798582077) + 0.237310773958568);
}

inline float score_2(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (3.52066298574107e-5*x_1 - 0.000473305929167849*x_10 - 0.000210332557419973*x_100 + 0.000251979626021781*x_101 + 0.000353456043175531*x_102 + 1.46944264969851e-5*x_103 - 0.000185009549394029*x_104 + 5.39203974685103e-5*x_105 - 6.92475598908315e-5*x_106 + 0.00014108133966453*x_107 - 0.000166606303691337*x_108 - 9.3172054889373e-7*x_109 + 8.05553772875685e-5*x_11 + 5.98621844318129e-5*x_110 + 0.000588609598472144*x_111 - 6.20340691240981e-6*x_112 + 7.74056778324554e-5*x_113 - 2.60761093796489e-5*x_114 + 0.000296615263317885*x_115 - 4.40607865857393e-5*x_116 - 2.41485912347188e-6*x_117 - 2.90809306298867e-5*x_118 - 1.58703132278565e-5*x_119 + 0.00165814196838196*x_12 - 0.000389547501829856*x_120 - 0.00107173346135488*x_13 - 5.92785644529e-5*x_14 + 2.6673318209538e-5*x_15 - 0.000429433372558358*x_16 - 0.00033932042872957*x_17 + 1.21653660918569e-6*x_18 - 0.000129212025975619*x_19 + 0.000279053265875052*x_2 - 0.00122617219594924*x_20 + 0.000190168005590013*x_21 + 0.000599127708983416*x_22 + 9.23634231746802e-5*x_23 + 0.000166427029031345*x_24 - 0.000178558439979708*x_25 + 7.4008787700949e-5*x_26 + 2.43298756723877e-5*x_27 - 5.01609619461091e-5*x_28 + 0.000263154606239274*x_29 - 0.000132702837598224*x_3 + 2.68369107977354e-5*x_30 - 0.000701410229395155*x_31 + 5.60996668384153e-5*x_32 + 2.76776997955146e-5*x_33 + 0.000360145287320498*x_34 + 0.000154798427963198*x_35 + 5.74127055577062e-5*x_36 + 0.000239691918334528*x_37 - 0.000261277052801814*x_38 - 3.05570295687449e-5*x_39 - 0.00014708656408865*x_4 - 6.54928236789208e-5*x_40 + 4.98238228337211e-5*x_41 - 0.000157455992372639*x_42 + 3.96151550265121e-5*x_43 - 7.71659446493166e-5*x_44 - 0.000209569954146603*x_45 - 6.32428189684976e-5*x_46 - 0.0001975641301973*x_47 - 0.000271912635629395*x_48 - 1.77844771697275e-5*x_49 - 0.000198351821195887*x_5 - 5.27823277844845e-5*x_50 - 1.8852539927898e-5*x_51 + 0.000483175711178478*x_52 + 4.87427105631187e-5*x_53 + 4.05393825496719e-5*x_54 + 0.000238064543913648*x_55 - 4.19250365304087e-5*x_56 - 0.000709665305618858*x_57 - 0.00045008121378054*x_58 - 0.000290974980850993*x_59 - 1.4073798977414e-5*x_6 - 0.000991972592841588*x_60 - 0.000389495835619108*x_61 - 1.47145580194717e-5*x_62 + 0.000119791839059823*x_63 + 5.64944350288607e-5*x_64 - 0.00027837566949681*x_65 - 0.000510655923781201*x_66 - 7.65728400625048e-6*x_67 + 0.000113899646620553*x_68 - 5.26805345870247e-5*x_69 - 0.000735380992713893*x_7 - 1.6885341390031e-5*x_70 + 5.66649763380204e-5*x_71 + 4.56857453988441e-6*x_72 - 0.000754009247763282*x_73 - 1.1326088903175e-5*x_74 - 2.96457508711228e-6*x_75 + 0.000195069441262056*x_76 + 2.43411995308418e-5*x_77 + 0.000200841671452957*x_78 - 1.2597151671657e-5*x_79 + 7.46399299672039e-5*x_8 - 8.82640707675562e-5*x_80 + 3.51040694827533e-5*x_81 + 2.2794393057097e-5*x_82 + 0.000254523766429938*x_83 + 3.93647141603834e-5*x_84 + 0.000353303800354896*x_85 + 8.39086103739133e-5*x_86 - 6.99489454330387e-5*x_87 + 3.91705077190145e-5*x_88 + 5.81619551064832e-5*x_89 - 2.50658066534778e-5*x_9 + 8.40795026206171e-6*x_90 + 0.00156518693765161*x_91 + 0.000163657839993808*x_92 + 0.00125050637110034*x_93 + 1.47450712951031e-5*x_94 + 3.71696367598634e-6*x_95 - 3.97743964655037e-5*x_96 + 3.70672010004348e-5*x_97 + 3.84377667950928e-5*x_98 + 0.000393351812720424*x_99 - 9.06429001085004e-6*std::pow(-4.67039966583252*x_109 - 6.09272003173828, 2) - 6.91027976644314e-5*std::pow(-0.629119873046875*x_117 - 1.04919981956482, 2) - 3.75717642380182e-6*std::pow(-5.42967987060547*x_13 - 9.45328044891357, 2) - 9.99897634231955e-7*std::pow(-7.32359981536865*x_18 - 9.49656009674072, 2) + 1.55753339105867e-5*std::pow(-6.08007955551147*x_18 - 9.70680046081543, 2) - 9.71746599432765e-7*std::pow(-5.23864030838013*x_19 - 8.24680042266846, 2) + 2.11240997042294e-5*std::pow(-4.40183973312378*x_27 - 6.39983987808228, 2) + 2.11459717353613e-6*std::pow(-5.92095994949341*x_4 - 9.2705602645874, 2) - 3.06641124969412e-7*std::pow(-6.3778395652771*x_49 - 9.52264022827148, 2) + 2.22165848592842e-6*std::pow(-5.81791973114014*x_5 - 9.03359985351563, 2) + 1.36755204293588e-6*std::pow(-5.25591993331909*x_57 - 8.28688049316406, 2) + 3.43633872553626e-6*std::pow(-6.50767993927002*x_67 - 9.74536037445068, 2) + 1.97002237384462e-5*std::pow(-4.48536014556885*x_67 - 5.50952005386353, 2) + 8.658086553719e-6*std::pow(-5.87383985519409*x_69 - 7.69448041915894, 2) - 1.84161978407007e-6*std::pow(-3.67263984680176*x_69 - 4.90823984146118, 2) - 9.22222514564819e-6*std::pow(-5.61768007278442*x_7 - 8.81968021392822, 2) + 1.66309135868308e-6*std::pow(-5.58383989334106*x_7 - 9.16079998016357, 2) - 2.63772477576009e-6*std::pow(-7.80000019073486*x_70 - 9.99882030487061, 2) + 2.42268932833855e-6*std::pow(-3.86879992485046*x_71 - 6.11287975311279, 2) - 2.12168200804257e-6*std::pow(-3.55695986747742*x_75 - 4.39680004119873, 2) + 1.83629484850222e-5*std::pow(-3.24160003662109*x_79 - 4.85735988616943, 2) - 7.09959495592405e-7*std::pow(-8.19999980926514*x_81 - 9.99917984008789, 2) + 7.30301666553292e-7*std::pow(-7.64775991439819*x_81 - 9.46271991729736, 2) - 1.89054265802914e-6*std::pow(-3.7960000038147*x_85 - 6.38800001144409, 2) - 2.50387068449866e-6*std::pow(-7.40000009536743*x_87 - 9.99973964691162, 2) - 4.92604221482153e-6*std::pow(-6.39191961288452*x_90 - 8.79872035980225, 2) + 6.59753484216283e-5*std::exp(0.97327983379364*x_17) - 0.0247258816812563*std::sin(0.204479992389679*x_1 - 7.40343999862671) + 0.000459387926490877*std::sin(0.409919857978821*x_1 + 4.98423957824707) - 0.00611125471747527*std::sin(0.408479869365692*x_100 - 7.38679981231689) - 0.00577425486340442*std::sin(0.303759932518005*x_101 + 8.27639961242676) + 0.00082850873784091*std::sin(0.158400028944016*x_102 + 8.13687992095947) - 0.00645506052932249*std::sin(0.298319935798645*x_102 + 5.09783983230591) - 0.00537028817160972*std::sin(0.401839852333069*x_103 + 1.99063980579376) + 0.000262188546160353*std::sin(0.410399854183197*x_104 + 1.98927986621857) + 0.000864283511989686*std::sin(0.308479934930801*x_105 + 5.12871980667114) - 0.000164794920290324*std::sin(0.448319852352142*x_106 - 1.17631983757019) - 0.000945632442607052*std::sin(0.31591984629631*x_107 - 7.4553599357605) - 0.000440720523005668*std::sin(0.316479861736298*x_107 + 1.93535983562469) + 0.000546186831982664*std::sin(0.246559977531433*x_109 + 5.04895973205566) - 0.00231109832993715*std::sin(0.409119844436646*x_109 - 1.185919880867) - 0.00316418380440338*std::sin(0.317759841680527*x_11 - 1.07807981967926) - 0.000425189153978*std::sin(0.369279861450195*x_110 - 7.41311979293823) + 0.00035567210628517*std::sin(0.467359870672226*x_111 + 2.05663967132568) - 0.000626381947323946*std::sin(0.309759944677353*x_112 + 1.88231992721558) + 0.00253019471362489*std::sin(0.340159833431244*x_112 - 7.43631982803345) - 0.00466524554628663*std::sin(0.37679985165596*x_112 - 7.41648006439209) + 0.000609383699157282*std::sin(0.350399851799011*x_113 + 1.94639980792999) - 0.000797578836149007*std::sin(0.351679861545563*x_114 + 1.95783984661102) + 0.00086273188040054*std::sin(0.166160017251968*x_115 + 8.14791965484619) + 0.000340381565466784*std::sin(0.773439824581146*x_116 - 1.000079870224) + 0.00656284329907654*std::sin(0.297279924154282*x_117 + 5.08855962753296) + 0.000497128315299783*std::sin(0.470959842205048*x_117 + 2.05343985557556) - 0.00137110668250226*std::sin(0.511359870433807*x_117 - 7.44767951965332) + 0.000342587614107565*std::sin(0.305519849061966*x_118 - 1.26919984817505) + 0.0100088463494968*std::sin(0.320319831371307*x_118 - 7.46407985687256) + 0.00455026028238462*std::sin(0.388959854841232*x_118 - 7.39264011383057) + 0.00099105366077172*std::sin(0.322239845991135*x_119 + 5.13624000549316) - 0.00527145354108009*std::sin(0.417999863624573*x_119 + 8.20368003845215) - 0.000784130623310295*std::sin(0.327839851379395*x_12 + 5.1300802230835) - 0.00109371613759623*std::sin(0.25111997127533*x_120 + 5.06399965286255) + 0.000816619072420869*std::sin(0.349519848823547*x_120 - 7.44911956787109) + 0.000880338609908885*std::sin(0.289759933948517*x_14 + 5.12048006057739) - 0.00607512604577693*std::sin(0.406079858541489*x_15 - 0.976399838924408) - 0.0149359541938751*std::sin(0.228879988193512*x_18 + 5.02151966094971) + 0.00340824142421929*std::sin(0.312959939241409*x_21 - 4.29031991958618) + 0.00845442735463317*std::sin(0.250799983739853*x_23 - 7.52175998687744) + 0.00126136490906234*std::sin(0.365439832210541*x_23 - 1.03543972969055) - 0.00027401370885931*std::sin(0.371919840574265*x_24 + 8.35968017578125) - 4.28140386260989e-5*std::sin(0.868479907512665*x_24 + 1.17119991779327) - 0.00107835282775864*std::sin(0.309119910001755*x_26 - 4.26143980026245) + 0.00133485628515029*std::sin(0.316879838705063*x_26 - 4.26823997497559) + 0.000986472403830123*std::sin(0.33815985918045*x_26 + 5.15375995635986) + 0.00595024403857393*std::sin(0.160000026226044*x_27 - 7.64448022842407) - 0.00148113409353133*std::sin(0.257519990205765*x_27 + 5.08903980255127) - 0.00217684698277619*std::sin(0.337999850511551*x_28 - 4.25271987915039) + 2.84204284640591e-5*std::sin(1.42767989635468*x_28 - 3.18928003311157) + 0.000269545104066388*std::sin(1.30543982982635*x_29 + 6.19024038314819) - 0.00619445710566616*std::sin(0.294559925794601*x_3 + 8.30103969573975) + 0.0131609962652279*std::sin(0.320479840040207*x_3 + 8.33432006835938) - 0.00220327313067936*std::sin(0.207520008087158*x_31 - 7.40839958190918) - 0.0177010207013807*std::sin(0.259199976921082*x_32 - 7.40863990783691) + 0.00985107794103609*std::sin(0.27295994758606*x_32 - 7.44280004501343) - 0.0153444552527518*std::sin(0.272799968719482*x_33 - 1.17695987224579) + 0.000203168084889949*std::sin(0.310799926519394*x_33 - 1.39063990116119) + 0.0071509762704119*std::sin(0.355359852313995*x_34 - 7.4049596786499) - 0.000580825428691889*std::sin(0.374639838933945*x_34 - 1.20295989513397) + 0.000690961951624991*std::sin(0.397919833660126*x_34 - 1.2040798664093) + 0.00113578952400893*std::sin(0.300959944725037*x_35 - 4.35016012191772) - 0.000715158248357093*std::sin(0.306319922208786*x_35 - 7.54120016098022) - 0.00660171886531412*std::sin(0.306479930877686*x_35 + 8.26095962524414) + 0.000662021479489522*std::sin(0.339599847793579*x_36 - 7.43495988845825) + 0.00885699413729314*std::sin(0.343279838562012*x_36 + 5.15208005905151) - 0.00112229519384038*std::sin(0.346159845590591*x_36 - 7.4475998878479) + 0.000243159985994509*std::sin(0.378719836473465*x_37 - 4.22504043579102) - 0.00219095122797549*std::sin(0.225599989295006*x_38 + 5.01599979400635) - 8.07250440188176e-5*std::sin(1.33471989631653*x_38 - 3.82351994514465) + 0.0112354130663149*std::sin(0.175280019640923*x_40 + 4.95599985122681) + 0.0133410789431351*std::sin(0.265359967947006*x_40 + 5.07607984542847) + 0.00112616390751579*std::sin(0.381999850273132*x_40 + 5.16951990127563) - 0.000640492588383837*std::sin(0.263679951429367*x_41 + 5.06279993057251) + 0.00510626889485712*std::sin(0.300799936056137*x_41 + 1.88895988464355) - 0.000506532237361818*std::sin(0.338959842920303*x_41 + 1.93567979335785) - 0.00130370259925097*std::sin(0.206640005111694*x_42 - 7.60008001327515) - 0.00271212117937943*std::sin(0.343759834766388*x_42 + 8.17296028137207) + 0.00559217274275825*std::sin(0.303439915180206*x_43 - 7.49440002441406) + 0.000372596772275865*std::sin(0.371759831905365*x_43 + 5.17224025726318) - 0.000616465775947804*std::sin(0.373599827289581*x_45 - 1.22919988632202) + 0.00150089695515252*std::sin(0.223279997706413*x_46 + 5.03991985321045) + 0.00067813620364398*std::sin(0.366639852523804*x_47 - 7.4270396232605) + 0.000586948092612382*std::sin(0.34215983748436*x_49 - 4.2454400062561) + 0.000112306066332663*std::sin(1.93639981746674*x_5 + 7.80280017852783) - 0.0224531864157752*std::sin(0.225919991731644*x_50 - 7.57376003265381) + 0.000363174248122407*std::sin(0.245119974017143*x_50 - 7.54640007019043) + 0.000717217796928448*std::sin(0.443919867277145*x_50 - 1.38655984401703) + 0.000138273500513835*std::sin(0.581999838352203*x_50 + 8.38016033172607) - 0.0079765516911441*std::sin(0.329439848661423*x_51 + 1.94511985778809) - 0.0109988291962899*std::sin(0.225359991192818*x_55 - 7.57776021957397) - 0.000948999631385615*std::sin(0.227199986577034*x_55 + 5.01903963088989) - 0.00443502396729564*std::sin(0.353759855031967*x_56 + 5.14152002334595) - 0.000412247471389741*std::sin(0.353679835796356*x_57 - 4.23112010955811) - 0.000360464328526441*std::sin(0.291439920663834*x_58 - 4.54112005233765) + 0.0228397505275791*std::sin(0.136720046401024*x_64 + 4.91695976257324) + 0.00300956951978297*std::sin(0.158240035176277*x_65 - 7.64480018615723) - 0.00802572870969397*std::sin(0.173920020461082*x_69 + 4.95703983306885) + 0.0016905611533958*std::sin(0.192959994077682*x_69 + 4.99343967437744) - 1.28306466561484e-5*std::sin(1.62239992618561*x_7 + 2.00263977050781) - 0.00133565314297004*std::sin(0.223359987139702*x_70 - 7.56512022018433) - 0.00177468743238142*std::sin(0.262639969587326*x_74 - 7.51015996932983) + 0.000678044486210876*std::sin(0.30159991979599*x_74 - 7.46799993515015) - 0.00126851501312684*std::sin(0.254399985074997*x_77 + 5.06759977340698) - 0.019582894097496*std::sin(0.146000042557716*x_79 - 7.65496015548706) - 0.00716220989815755*std::sin(0.254399985074997*x_8 + 5.06679964065552) + 0.00134678377993351*std::sin(0.325119823217392*x_8 + 5.11800003051758) - 0.00430897327311537*std::sin(0.146640032529831*x_82 + 4.93063974380493) + 0.00495473946281841*std::sin(0.328719854354858*x_82 - 7.48216009140015) + 0.0101563655209932*std::sin(0.171040013432503*x_83 + 4.96776008605957) + 0.0045986157958438*std::sin(0.281919926404953*x_84 - 7.49887990951538) + 0.00958140225903662*std::sin(0.23479999601841*x_85 - 7.55768013000488) - 0.00246757103093152*std::sin(0.519279837608337*x_9 - 0.845999836921692) + 0.017411821511221*std::sin(0.183520004153252*x_91 - 7.36463975906372) - 0.000392535902340106*std::sin(0.327599853277206*x_92 - 1.00311982631683) + 0.0100444017135618*std::sin(0.338879853487015*x_92 + 5.19623994827271) + 0.00292325170014989*std::sin(0.329279839992523*x_94 - 1.22063982486725) + 0.00103051342795212*std::sin(0.386319845914841*x_94 + 2.00543975830078) + 0.00474154030360467*std::sin(0.337919861078262*x_95 - 7.43951988220215) + 0.00277132033590838*std::sin(0.377039849758148*x_95 - 7.42439985275269) - 0.0041498164059287*std::sin(0.355519831180573*x_96 + 1.9670398235321) + 0.00017925590053157*std::sin(0.397999823093414*x_96 + 1.99415981769562) - 0.0122690943592257*std::sin(0.26463994383812*x_97 + 5.07655954360962) - 0.000709920280963631*std::sin(0.381359845399857*x_97 + 1.97151982784271) - 0.00374078399911666*std::sin(0.273999959230423*x_98 - 4.30663967132568) + 0.00078347814606803*std::sin(0.390079826116562*x_98 + 1.9676798582077) + 0.0789504073014626);
}

inline float score_3(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (8.16762339435721e-6*x_1 + 0.000526158721699334*x_10 - 0.000420684672467427*x_100 - 9.16626427958289e-5*x_101 - 0.000198839991121796*x_102 + 5.14762669702931e-5*x_103 + 0.000139239146079677*x_104 - 6.59334211710716e-5*x_105 + 0.000292908315677853*x_106 - 7.08989180115815e-5*x_107 + 0.000439328397692895*x_108 + 5.26055998919543e-6*x_109 - 0.000149075197455565*x_11 + 0.000152643402006465*x_110 - 0.000317871731749572*x_111 - 8.57375060403768e-7*x_112 + 4.91645513900886e-5*x_113 + 0.00128138282370277*x_114 - 0.000138444691100384*x_115 - 4.78825791703661e-6*x_116 + 0.000223679127736181*x_118 - 1.17887126735508e-5*x_119 - 0.00102173588224871*x_12 + 8.71819612724851e-5*x_120 + 0.000255770417197693*x_13 - 0.000314989882746506*x_14 + 9.79431530234439e-6*x_15 + 0.000658015330190693*x_16 + 0.000205522616502448*x_17 + 1.7012166043678e-7*x_18 - 7.0510093264367e-5*x_19 + 0.000631509420910521*x_2 + 0.00159332056783061*x_20 - 3.03702021135787e-5*x_21 + 0.000558841951730374*x_22 - 0.000356467042414091*x_23 - 8.65903708430638e-5*x_24 + 0.000199606015303923*x_25 - 5.0209631830864e-5*x_26 - 5.94478392303938e-6*x_27 + 0.000491709008564227*x_28 - 0.000221381839972062*x_29 - 1.18094794382529e-5*x_3 + 6.76887742086865e-5*x_30 - 0.000792796104946035*x_31 - 0.000235096095106102*x_32 - 0.000113712167536136*x_33 - 6.65347687046445e-5*x_34 - 8.65058926962766e-5*x_35 - 3.53015095177014e-6*x_36 - 4.94051375732381e-5*x_37 + 3.82731907368349e-5*x_38 + 0.000504616007335801*x_39 - 2.25429957591244e-6*x_4 - 2.24937129989646e-7*x_40 - 0.000317793232876459*x_41 + 6.1069449250568e-5*x_42 - 9.25626502003971e-5*x_43 + 4.58285508995475e-6*x_44 + 1.89930240069035e-5*x_45 - 1.59249217177586e-5*x_46 - 0.000161307865467079*x_47 + 0.000103598957465383*x_48 + 1.76585205444395e-5*x_49 + 0.000119285413417076*x_5 - 5.98253227918561e-6*x_50 + 0.00036276018575159*x_51 - 0.000205766325173076*x_52 + 5.22625956997865e-5*x_53 + 1.97276238125857e-5*x_54 - 0.000200695323688455*x_55 + 0.000605991609086555*x_56 + 0.000141549181844083*x_57 + 0.000700066375313196*x_58 - 0.000120949700808206*x_59 - 3.38096241839024e-5*x_6 + 0.000115386775184431*x_60 + 0.000300865043797163*x_61 - 0.000273732145107216*x_62 - 0.000292323951734612*x_63 - 3.98441956178514e-7*x_64 + 0.000175167066728447*x_65 + 0.000634532926658096*x_66 + 2.70915913653973e-5*x_67 - 4.54477890649977e-5*x_68 + 0.000135192242566641*x_7 + 2.56590982752885e-6*x_70 - 3.32187198495723e-5*x_71 + 0.000249037098275286*x_72 + 0.000173844982678676*x_73 + 3.42227993192127e-5*x_74 + 1.94042155671878e-6*x_75 - 0.000266992756185069*x_76 + 3.94891336391978e-5*x_77 - 0.000100055640313747*x_78 - 1.38990812684851e-6*x_79 - 1.30686524361421e-5*x_8 + 0.000375384775126416*x_80 - 1.77592948325965e-5*x_81 - 1.3007996878346e-5*x_82 - 0.000230381506519049*x_83 + 1.82452240959262e-5*x_84 - 0.000223223119085026*x_85 + 3.29215778438891e-5*x_86 + 8.57634465552232e-6*x_87 + 1.88328616836961e-5*x_88 - 0.000378125337883236*x_89 - 0.0010819436415946*x_9 + 1.89639550260583e-5*x_90 + 0.00184224948348561*x_91 - 1.47586987487722e-5*x_92 - 0.000182690876763647*x_93 - 3.05716798363885e-7*x_94 - 1.80427211355984e-5*x_95 + 5.56288865195175e-5*x_96 - 2.15706799819719e-5*x_97 + 2.98226862249977e-5*x_98 + 3.14510198873163e-5*x_99 + 1.6947040925744e-6*std::pow(-4.67039966583252*x_109 - 6.09272003173828, 2) - 7.83235099629343e-6*std::pow(-0.629119873046875*x_117 - 1.04919981956482, 2) + 2.95742559934128e-5*std::pow(-5.42967987060547*x_13 - 9.45328044891357, 2) + 7.87059889300089e-6*std::pow(-7.32359981536865*x_18 - 9.49656009674072, 2) - 2.91204077648534e-6*std::pow(-6.08007955551147*x_18 - 9.70680046081543, 2) - 1.10141133260217e-7*std::pow(-5.23864030838013*x_19 - 8.24680042266846, 2) - 1.33723327089108e-5*std::pow(-4.40183973312378*x_27 - 6.39983987808228, 2) - 1.66448500360342e-5*std::pow(-5.92095994949341*x_4 - 9.2705602645874, 2) - 3.47557696914336e-8*std::pow(-6.3778395652771*x_49 - 9.52264022827148, 2) - 1.74875729488104e-5*std::pow(-5.81791973114014*x_5 - 9.03359985351563, 2) - 1.07645555172454e-5*std::pow(-5.25591993331909*x_57 - 8.28688049316406, 2) - 2.17532890782489e-6*std::pow(-6.50767993927002*x_67 - 9.74536037445068, 2) - 3.68325039845511e-6*std::pow(-4.48536014556885*x_67 - 5.50952005386353, 2) - 1.61875830306481e-6*std::pow(-5.87383985519409*x_69 - 7.69448041915894, 2) - 2.08735580006471e-7*std::pow(-3.67263984680176*x_69 - 4.90823984146118, 2) + 5.8380079951715e-6*std::pow(-5.61768007278442*x_7 - 8.81968021392822, 2) - 1.3090865063067e-5*std::pow(-5.58383989334106*x_7 - 9.16079998016357, 2) + 1.66977687995569e-6*std::pow(-7.80000019073486*x_70 - 9.99882030487061, 2) - 1.90699680576333e-5*std::pow(-3.86879992485046*x_71 - 6.11287975311279, 2) + 1.67006176353508e-5*std::pow(-3.55695986747742*x_75 - 4.39680004119873, 2) - 3.43322686189976e-6*std::pow(-3.24160003662109*x_79 - 4.85735988616943, 2) + 5.58837847874016e-6*std::pow(-8.19999980926514*x_81 - 9.99917984008789, 2) + 1.48812262796127e-5*std::pow(-3.7960000038147*x_85 - 6.38800001144409, 2) + 1.5850423129039e-6*std::pow(-7.40000009536743*x_87 - 9.99973964691162, 2) + 3.11836605379895e-6*std::pow(-6.39191961288452*x_90 - 8.79872035980225, 2) + 7.47787504133026e-6*std::exp(0.97327983379364*x_17) - 0.77798053543108*std::exp(-0.00418498055572057*x_10 + 0.00513582789013611*x_100 + 0.00296050731738705*x_101 + 0.00142740040074893*x_103 + 0.0109459691558544*x_104 + 0.000747131006808363*x_107 - 0.00398067523876709*x_108 - 0.00125815571947287*x_11 - 0.00619887880574439*x_110 + 0.0139511920167016*x_111 + 0.000387893436590515*x_112 + 0.0246402659687251*x_113 + 0.00187031042608917*x_115 - 0.00201536719822431*x_116 - 0.000688254642173169*x_117 - 0.00309789903750356*x_13 - 0.000927134493755531*x_14 - 0.0155311722383544*x_15 - 0.031675636597547*x_16 + 0.000697424792191865*x_17 - 8.10570708140395e-5*x_18 - 0.000608010361158172*x_19 - 0.0271689954816294*x_2 + 0.0552045591692625*x_20 + 0.00537360621174718*x_21 - 0.00756567678278892*x_22 + 0.0151040048274034*x_23 + 0.0140902669938701*x_25 - 0.000574360225939861*x_28 + 0.00128422280220224*x_29 - 0.0212715678170793*x_3 - 0.00209230698721034*x_30 + 0.0506337198254873*x_31 + 0.00834500165736475*x_32 - 0.0165522665816984*x_33 + 0.00121914883444301*x_34 + 0.00109476246468781*x_38 + 0.00238615079316767*x_39 + 0.0322545966503021*x_4 - 0.0181003751297307*x_40 + 3.8019860104981e-5*x_44 - 0.020881511243729*x_45 - 0.00259075928084937*x_48 - 0.00208568827680739*x_5 + 0.000904002296861021*x_51 - 0.000222512246637625*x_52 + 0.000630155007381003*x_53 + 0.000265522364228151*x_54 + 0.00137891952758673*x_56 + 0.0248602246937293*x_57 + 0.000903120919669276*x_58 + 0.000387689682034369*x_59 + 0.0109785831406742*x_6 + 0.000225618870343738*x_60 + 0.000154202855751325*x_61 - 0.0117447165806051*x_62 + 0.0202857169855231*x_63 - 0.0149374660931791*x_64 - 0.000829809398891934*x_65 - 0.00497630748159077*x_66 - 0.000136652365032272*x_67 + 0.0137998031785213*x_68 - 0.0150143841225636*x_69 - 0.00350335125238837*x_7 - 0.000171122959085098*x_70 + 0.00450037251322071*x_71 + 0.00504344288588231*x_72 - 0.000134250172892285*x_73 - 0.000129342307606231*x_75 + 0.00475104226579474*x_76 + 0.019486702996729*x_77 - 0.000118761920077159*x_78 - 0.00308338210067563*x_79 + 0.008209352631963*x_8 + 3.95970973577046e-6*x_80 + 0.000299475615465895*x_82 + 0.000544733254542174*x_83 + 9.16814987341256e-5*x_84 + 0.000182199450555871*x_85 + 0.0055761806431265*x_86 - 3.72534708646609e-6*x_87 - 0.00155129939574174*x_88 - 0.00365130302012828*x_89 - 0.000735241862563522*x_9 - 0.000220889105315835*x_90 + 0.0169552352323093*x_91 + 0.0515778746354588*x_92 + 0.00502169642860297*x_93 - 0.000106623578916117*x_95 + 0.000357308339739951*x_97 - 0.00860964698171784*x_99 + 0.000208141960459152*std::pow(-7.64775991439819*x_81 - 9.46271991729736, 2) + 0.130929324154977*std::sin(0.409919857978821*x_1 + 4.98423957824707) + 0.236131780673077*std::sin(0.158400028944016*x_102 + 8.13687992095947) + 0.246327884512539*std::sin(0.308479934930801*x_105 + 5.12871980667114) - 0.0469679029281451*std::sin(0.448319852352142*x_106 - 1.17631983757019) + 0.155667723616716*std::sin(0.246559977531433*x_109 + 5.04895973205566) - 0.227316505191993*std::sin(0.351679861545563*x_114 + 1.95783984661102) + 0.097640277840128*std::sin(0.305519849061966*x_118 - 1.26919984817505) + 0.28245841591297*std::sin(0.322239845991135*x_119 + 5.13624000549316) - 0.223483654312531*std::sin(0.327839851379395*x_12 + 5.1300802230835) + 0.23274312858166*std::sin(0.349519848823547*x_120 - 7.44911956787109) - 0.0780961528183752*std::sin(0.371919840574265*x_24 + 8.35968017578125) + 0.281152720137015*std::sin(0.33815985918045*x_26 + 5.15375995635986) + 1.69586831869674*std::sin(0.160000026226044*x_27 - 7.64448022842407) - 0.203825962159044*std::sin(0.306319922208786*x_35 - 7.54120016098022) + 0.188681547527267*std::sin(0.339599847793579*x_36 - 7.43495988845825) + 0.0693025889273713*std::sin(0.378719836473465*x_37 - 4.22504043579102) - 0.144365839144029*std::sin(0.338959842920303*x_41 + 1.93567979335785) - 0.371565925824143*std::sin(0.206640005111694*x_42 - 7.60008001327515) + 0.106193133870647*std::sin(0.371759831905365*x_43 + 5.17224025726318) + 0.427767933444557*std::sin(0.223279997706413*x_46 + 5.03991985321045) + 0.193274375986221*std::sin(0.366639852523804*x_47 - 7.4270396232605) + 0.167285016972073*std::sin(0.34215983748436*x_49 - 4.2454400062561) + 0.103507637260691*std::sin(0.245119974017143*x_50 - 7.54640007019043) - 0.270472672866617*std::sin(0.227199986577034*x_55 + 5.01903963088989) + 0.193248235766077*std::sin(0.30159991979599*x_74 - 7.46799993515015) + 0.29370477296834*std::sin(0.386319845914841*x_94 + 2.00543975830078) + 0.0510894008178866*std::sin(0.397999823093414*x_96 + 1.99415981769562) + 0.223297692950837*std::sin(0.390079826116562*x_98 + 1.9676798582077)) + 0.00462287204266159*std::sin(0.204479992389679*x_1 - 7.40343999862671) + 0.00114259013867306*std::sin(0.408479869365692*x_100 - 7.38679981231689) + 0.00107958299402*std::sin(0.303759932518005*x_101 + 8.27639961242676) + 0.00120686975855403*std::sin(0.298319935798645*x_102 + 5.09783983230591) + 0.00100405540112208*std::sin(0.401839852333069*x_103 + 1.99063980579376) - 0.00206379214283498*std::sin(0.410399854183197*x_104 + 1.98927986621857) + 0.00744345561101933*std::sin(0.31591984629631*x_107 - 7.4553599357605) - 4.99527941576692e-5*std::sin(0.316479861736298*x_107 + 1.93535983562469) + 0.00146301031635161*std::sin(0.409119844436646*x_109 - 1.185919880867) + 0.00200304482449292*std::sin(0.317759841680527*x_11 - 1.07807981967926) - 4.81924148707351e-5*std::sin(0.369279861450195*x_110 - 7.41311979293823) + 4.03131113380424e-5*std::sin(0.467359870672226*x_111 + 2.05663967132568) + 0.00493050577621422*std::sin(0.309759944677353*x_112 + 1.88231992721558) - 0.00160170639235077*std::sin(0.340159833431244*x_112 - 7.43631982803345) + 0.000872237175850799*std::sin(0.37679985165596*x_112 - 7.41648006439209) + 6.90696641024163e-5*std::sin(0.350399851799011*x_113 + 1.94639980792999) + 9.77850265310944e-5*std::sin(0.166160017251968*x_115 + 8.14791965484619) - 0.00267928103902215*std::sin(0.773439824581146*x_116 - 1.000079870224) - 0.00122702135352645*std::sin(0.297279924154282*x_117 + 5.08855962753296) - 0.00391309813537394*std::sin(0.470959842205048*x_117 + 2.05343985557556) + 0.000867961001630766*std::sin(0.511359870433807*x_117 - 7.44767951965332) - 0.00187130297575837*std::sin(0.320319831371307*x_118 - 7.46407985687256) - 0.00288048225771283*std::sin(0.388959854841232*x_118 - 7.39264011383057) + 0.000985576794121843*std::sin(0.417999863624573*x_119 + 8.20368003845215) + 0.00860908229714362*std::sin(0.25111997127533*x_120 + 5.06399965286255) + 9.97806343800822e-5*std::sin(0.289759933948517*x_14 + 5.12048006057739) + 0.00113583534511359*std::sin(0.406079858541489*x_15 - 0.976399838924408) + 0.00945500880994047*std::sin(0.228879988193512*x_18 + 5.02151966094971) - 0.00215754228180561*std::sin(0.312959939241409*x_21 - 4.29031991958618) - 0.0053519637301672*std::sin(0.250799983739853*x_23 - 7.52175998687744) - 0.000235830966469398*std::sin(0.365439832210541*x_23 - 1.03543972969055) + 0.000337006622957267*std::sin(0.868479907512665*x_24 + 1.17119991779327) + 0.0084881514685659*std::sin(0.309119910001755*x_26 - 4.26143980026245) + 0.000151297245672686*std::sin(0.316879838705063*x_26 - 4.26823997497559) + 0.0116586057990705*std::sin(0.257519990205765*x_27 + 5.08903980255127) + 0.00137802427169209*std::sin(0.337999850511551*x_28 - 4.25271987915039) + 3.22127003130201e-6*std::sin(1.42767989635468*x_28 - 3.18928003311157) - 5.03954739365032e-5*std::sin(1.30543982982635*x_29 + 6.19024038314819) + 0.00392131937113797*std::sin(0.294559925794601*x_3 + 8.30103969573975) - 0.00246064437549328*std::sin(0.320479840040207*x_3 + 8.33432006835938) + 0.017342854377912*std::sin(0.207520008087158*x_31 - 7.40839958190918) + 0.00330946959877345*std::sin(0.259199976921082*x_32 - 7.40863990783691) - 0.00623609496325999*std::sin(0.27295994758606*x_32 - 7.44280004501343) + 0.00286887457087491*std::sin(0.272799968719482*x_33 - 1.17695987224579) + 2.30277760942504e-5*std::sin(0.310799926519394*x_33 - 1.39063990116119) - 0.0045268312127086*std::sin(0.355359852313995*x_34 - 7.4049596786499) + 0.00457191198337076*std::sin(0.374639838933945*x_34 - 1.20295989513397) + 7.83160264580206e-5*std::sin(0.397919833660126*x_34 - 1.2040798664093) - 0.00894025894682028*std::sin(0.300959944725037*x_35 - 4.35016012191772) + 0.00123428971995395*std::sin(0.306479930877686*x_35 + 8.26095962524414) - 0.00165594703991278*std::sin(0.343279838562012*x_36 + 5.15208005905151) + 0.00883403961351029*std::sin(0.346159845590591*x_36 - 7.4475998878479) + 0.0172458636956056*std::sin(0.225599989295006*x_38 + 5.01599979400635) + 5.1101924421658e-5*std::sin(1.33471989631653*x_38 - 3.82351994514465) - 0.00711243005611857*std::sin(0.175280019640923*x_40 + 4.95599985122681) - 0.00249431351570015*std::sin(0.265359967947006*x_40 + 5.07607984542847) - 0.00886449182434529*std::sin(0.381999850273132*x_40 + 5.16951990127563) - 7.25956536102565e-5*std::sin(0.263679951429367*x_41 + 5.06279993057251) - 0.000954693062947153*std::sin(0.300799936056137*x_41 + 1.88895988464355) + 0.00171687254204182*std::sin(0.343759834766388*x_42 + 8.17296028137207) - 0.0010455400281976*std::sin(0.303439915180206*x_43 - 7.49440002441406) + 0.00485245157868048*std::sin(0.373599827289581*x_45 - 1.22919988632202) - 2.09972926734553e-5*std::sin(1.93639981746674*x_5 + 7.80280017852783) + 0.00419795779532674*std::sin(0.225919991731644*x_50 - 7.57376003265381) - 0.000454025266854757*std::sin(0.443919867277145*x_50 - 1.38655984401703) - 0.00108840667566085*std::sin(0.581999838352203*x_50 + 8.38016033172607) + 0.00149133520434939*std::sin(0.329439848661423*x_51 + 1.94511985778809) + 0.0020563950215811*std::sin(0.225359991192818*x_55 - 7.57776021957397) + 0.00280753342831442*std::sin(0.353759855031967*x_56 + 5.14152002334595) - 4.6725559635639e-5*std::sin(0.353679835796356*x_57 - 4.23112010955811) - 4.08562784443605e-5*std::sin(0.291439920663834*x_58 - 4.54112005233765) - 0.0144584028346618*std::sin(0.136720046401024*x_64 + 4.91695976257324) - 0.0236895395287216*std::sin(0.158240035176277*x_65 - 7.64480018615723) + 0.00508058170715779*std::sin(0.173920020461082*x_69 + 4.95703983306885) - 0.0133070909330511*std::sin(0.192959994077682*x_69 + 4.99343967437744) - 1.45427003705957e-6*std::sin(1.62239992618561*x_7 + 2.00263977050781) + 0.0105134663675527*std::sin(0.223359987139702*x_70 - 7.56512022018433) + 0.00112344247245602*std::sin(0.262639969587326*x_74 - 7.51015996932983) + 0.00998499497975115*std::sin(0.254399985074997*x_77 + 5.06759977340698) + 0.0123966928267552*std::sin(0.146000042557716*x_79 - 7.65496015548706) + 0.00453394251259102*std::sin(0.254399985074997*x_8 + 5.06679964065552) - 0.0106010801151644*std::sin(0.325119823217392*x_8 + 5.11800003051758) + 0.0339176722819257*std::sin(0.146640032529831*x_82 + 4.93063974380493) - 0.0009263623775527*std::sin(0.328719854354858*x_82 - 7.48216009140015) - 0.00189888388318399*std::sin(0.171040013432503*x_83 + 4.96776008605957) - 0.0029110930777402*std::sin(0.281919926404953*x_84 - 7.49887990951538) - 0.00179138593332234*std::sin(0.23479999601841*x_85 - 7.55768013000488) + 0.000461349175702898*std::sin(0.519279837608337*x_9 - 0.845999836921692) - 0.0110223239606088*std::sin(0.183520004153252*x_91 - 7.36463975906372) - 4.4491381965523e-5*std::sin(0.327599853277206*x_92 - 1.00311982631683) - 0.00635847602768177*std::sin(0.338879853487015*x_92 + 5.19623994827271) - 0.000546545467316143*std::sin(0.329279839992523*x_94 - 1.22063982486725) - 0.00088650161766743*std::sin(0.337919861078262*x_95 - 7.43951988220215) - 0.00175434778729612*std::sin(0.377039849758148*x_95 - 7.42439985275269) + 0.00262698654323548*std::sin(0.355519831180573*x_96 + 1.9670398235321) + 0.00229389002314274*std::sin(0.26463994383812*x_97 + 5.07655954360962) + 0.00558806980452867*std::sin(0.381359845399857*x_97 + 1.97151982784271) + 0.00236805397289156*std::sin(0.273999959230423*x_98 - 4.30663967132568) + 0.202556906082816);
}

inline float score_4(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-3.76529437913716e-6*x_1 + 8.94801101216537e-5*x_10 + 0.000357667096629757*x_100 + 0.00010683309991978*x_101 - 0.000143061808233937*x_102 + 9.92161322401332e-5*x_103 + 0.000821970968922385*x_104 - 3.23574323562405e-5*x_105 + 6.67858898798009e-5*x_106 + 8.79458841810533e-6*x_107 - 0.000208249555810528*x_108 + 1.08848530775561e-6*x_109 - 0.000110517549866978*x_11 - 0.000363488106802801*x_110 + 0.000707030806160744*x_111 + 2.57253499507447e-5*x_112 + 0.00165467007069622*x_113 + 0.000261598231899129*x_114 + 1.69611904912323e-5*x_115 - 0.000137386873473353*x_116 - 4.5950834465046e-5*x_117 + 4.6275152557404e-5*x_118 + 8.78393632185807e-6*x_119 - 0.000690702904692238*x_12 + 3.50596165093405e-6*x_120 - 0.000181183754752941*x_13 - 0.000105468086984629*x_14 - 0.00105902970307271*x_15 - 0.00190018257351014*x_16 + 0.000197428337394802*x_17 - 5.37757343133541e-6*x_18 - 7.15499109194146e-5*x_19 - 0.00162869831156931*x_2 + 0.00375900895522826*x_20 + 0.000368879320430165*x_21 - 0.000544874104786085*x_22 + 0.000934666450501035*x_23 - 4.94617175769203e-5*x_24 + 0.00105892118166832*x_25 - 3.42599764704344e-5*x_26 + 7.04324949925199e-7*x_27 + 6.43554587769379e-5*x_28 - 5.79939739724896e-5*x_29 - 0.00142258323905637*x_3 - 0.00013625889506513*x_30 + 0.00240232991917343*x_31 + 0.00050851360168907*x_32 - 0.00115085073438954*x_33 + 9.13436806904706e-5*x_34 - 5.7863974327524e-5*x_35 - 4.61559468543483e-6*x_36 - 2.68588009038618e-5*x_37 + 6.58756017058575e-5*x_38 + 0.000258974214055974*x_39 + 0.00213591842525309*x_4 - 0.00120850389173929*x_40 - 6.86906418451866e-5*x_41 - 3.43992677652645e-7*x_42 - 2.77862023081419e-5*x_43 + 5.97170846792679e-6*x_44 - 0.00140284169327643*x_45 - 1.40314580225849e-5*x_46 + 2.24095465166151e-5*x_47 - 0.00016749004586824*x_48 + 4.40341011317193e-6*x_49 - 6.04484691528511e-5*x_5 - 1.20073510586943e-6*x_50 + 0.000130267641093791*x_51 - 0.000196248446394446*x_52 + 6.05639905066845e-5*x_53 + 1.58173814367292e-5*x_54 - 9.61222119865172e-5*x_55 + 0.000219522858136899*x_56 + 0.00163006604622653*x_57 + 0.00017117526472771*x_58 - 3.23317762849598e-5*x_59 + 0.000733258388175773*x_6 - 5.76315697466382e-5*x_60 + 4.97443243552848e-5*x_61 - 0.000956885056745467*x_62 + 0.00129354550522378*x_63 - 0.00098817762283748*x_64 + 6.1014108956053e-5*x_65 - 0.000233718700206154*x_66 - 3.51621848981384e-6*x_67 + 0.000894534781945375*x_68 - 0.00100242473807673*x_69 - 0.000254112290948012*x_7 - 1.18718392513282e-5*x_70 + 0.000276006772678413*x_71 + 0.000371050799081526*x_72 - 2.76499500805612e-5*x_73 + 6.34812623216763e-6*x_74 - 7.57969225967765e-6*x_75 + 0.000290381610624646*x_76 + 0.00132989116527026*x_77 - 9.10283889767907e-5*x_78 - 0.000206146020831651*x_79 + 0.000549450926801703*x_8 + 8.29334119461629e-5*x_80 - 1.0052587610956e-5*x_81 + 1.13608612740145e-5*x_82 - 8.42877755174581e-5*x_83 + 1.19559583815899e-5*x_84 - 0.000135085985618583*x_85 + 0.000374102529327464*x_86 + 9.18153757080691e-7*x_87 - 0.000101543954831204*x_88 - 0.000325368088129733*x_89 - 0.00024163606291168*x_9 - 1.02223006788627e-5*x_90 + 0.00163106496644738*x_91 + 0.00343919744663424*x_92 + 0.000363862289045107*x_93 - 3.51311388982151e-6*x_94 - 1.08525632327803e-5*x_95 + 1.03564574333823e-5*x_96 + 9.54969042680853e-6*x_97 + 8.81106965184499e-6*x_98 - 0.000589309689388287*x_99 - 2.53386865587959e-7*std::pow(-4.67039966583252*x_109 - 6.09272003173828, 2) - 1.5720063618313e-6*std::pow(-0.629119873046875*x_117 - 1.04919981956482, 2) + 6.11831632180444e-6*std::pow(-5.42967987060547*x_13 - 9.45328044891357, 2) + 1.62826796657705e-6*std::pow(-7.32359981536865*x_18 - 9.49656009674072, 2) + 4.35399246423639e-7*std::pow(-6.08007955551147*x_18 - 9.70680046081543, 2) - 2.21060780174827e-8*std::pow(-5.23864030838013*x_19 - 8.24680042266846, 2) - 8.82102484484252e-6*std::pow(-4.40183973312378*x_27 - 6.39983987808228, 2) - 3.44348333469956e-6*std::pow(-5.92095994949341*x_4 - 9.2705602645874, 2) - 6.97572045623761e-9*std::pow(-6.3778395652771*x_49 - 9.52264022827148, 2) - 3.61782568681639e-6*std::pow(-5.81791973114014*x_5 - 9.03359985351563, 2) - 2.2269691495469e-6*std::pow(-5.25591993331909*x_57 - 8.28688049316406, 2) - 1.43495011374051e-6*std::pow(-6.50767993927002*x_67 - 9.74536037445068, 2) + 5.50708101626403e-7*std::pow(-4.48536014556885*x_67 - 5.50952005386353, 2) + 2.42031688219382e-7*std::pow(-5.87383985519409*x_69 - 7.69448041915894, 2) - 4.1894657155432e-8*std::pow(-3.67263984680176*x_69 - 4.90823984146118, 2) + 3.85102694427288e-6*std::pow(-5.61768007278442*x_7 - 8.81968021392822, 2) - 2.70823561545358e-6*std::pow(-5.58383989334106*x_7 - 9.16079998016357, 2) + 1.10146402008214e-6*std::pow(-7.80000019073486*x_70 - 9.99882030487061, 2) - 3.94519127883707e-6*std::pow(-3.86879992485046*x_71 - 6.11287975311279, 2) + 3.45502052478821e-6*std::pow(-3.55695986747742*x_75 - 4.39680004119873, 2) + 5.13325362935581e-7*std::pow(-3.24160003662109*x_79 - 4.85735988616943, 2) + 1.1561226516235e-6*std::pow(-8.19999980926514*x_81 - 9.99917984008789, 2) + 1.3896450796306e-5*std::pow(-7.64775991439819*x_81 - 9.46271991729736, 2) + 3.07862519534892e-6*std::pow(-3.7960000038147*x_85 - 6.38800001144409, 2) + 1.04556908107253e-6*std::pow(-7.40000009536743*x_87 - 9.99973964691162, 2) + 2.05702213926703e-6*std::pow(-6.39191961288452*x_90 - 8.79872035980225, 2) + 1.50086061560746e-6*std::exp(0.97327983379364*x_17) - 0.000691197396664576*std::sin(0.204479992389679*x_1 - 7.40343999862671) + 0.00874140373665936*std::sin(0.409919857978821*x_1 + 4.98423957824707) - 0.000170836510726941*std::sin(0.408479869365692*x_100 - 7.38679981231689) - 0.000161415879146928*std::sin(0.303759932518005*x_101 + 8.27639961242676) + 0.0157651713490587*std::sin(0.158400028944016*x_102 + 8.13687992095947) - 0.000180447398830765*std::sin(0.298319935798645*x_102 + 5.09783983230591) - 0.000150123229230247*std::sin(0.401839852333069*x_103 + 1.99063980579376) - 0.00042695691668901*std::sin(0.410399854183197*x_104 + 1.98927986621857) + 0.0164459070114237*std::sin(0.308479934930801*x_105 + 5.12871980667114) - 0.0031357788242546*std::sin(0.448319852352142*x_106 - 1.17631983757019) + 0.00153990064756557*std::sin(0.31591984629631*x_107 - 7.4553599357605) - 1.00258671048153e-5*std::sin(0.316479861736298*x_107 + 1.93535983562469) + 0.0103930454822308*std::sin(0.246559977531433*x_109 + 5.04895973205566) + 0.000965070988713806*std::sin(0.409119844436646*x_109 - 1.185919880867) + 0.00132130336170976*std::sin(0.317759841680527*x_11 - 1.07807981967926) - 9.67254695361086e-6*std::sin(0.369279861450195*x_110 - 7.41311979293823) + 8.091116896907e-6*std::sin(0.467359870672226*x_111 + 2.05663967132568) + 0.00102002207501286*std::sin(0.309759944677353*x_112 + 1.88231992721558) - 0.00105656149817858*std::sin(0.340159833431244*x_112 - 7.43631982803345) - 0.000130414179682773*std::sin(0.37679985165596*x_112 - 7.41648006439209) + 1.3862753524444e-5*std::sin(0.350399851799011*x_113 + 1.94639980792999) - 0.0151766257155472*std::sin(0.351679861545563*x_114 + 1.95783984661102) + 1.96261229701616e-5*std::sin(0.166160017251968*x_115 + 8.14791965484619) - 0.000554289139696417*std::sin(0.773439824581146*x_116 - 1.000079870224) + 0.000183460402404093*std::sin(0.297279924154282*x_117 + 5.08855962753296) - 0.000809540980365271*std::sin(0.470959842205048*x_117 + 2.05343985557556) + 0.000572548240191296*std::sin(0.511359870433807*x_117 - 7.44767951965332) + 0.00651888410078309*std::sin(0.305519849061966*x_118 - 1.26919984817505) + 0.000279791379315394*std::sin(0.320319831371307*x_118 - 7.46407985687256) - 0.00190010270560211*std::sin(0.388959854841232*x_118 - 7.39264011383057) + 0.0188581363895986*std::sin(0.322239845991135*x_119 + 5.13624000549316) - 0.000147360365595978*std::sin(0.417999863624573*x_119 + 8.20368003845215) - 0.0149207281370939*std::sin(0.327839851379395*x_12 + 5.1300802230835) + 0.00178104526944325*std::sin(0.25111997127533*x_120 + 5.06399965286255) + 0.0155389303885609*std::sin(0.349519848823547*x_120 - 7.44911956787109) + 2.00266551010396e-5*std::sin(0.289759933948517*x_14 + 5.12048006057739) - 0.000169826555080273*std::sin(0.406079858541489*x_15 - 0.976399838924408) + 0.0062369722198965*std::sin(0.228879988193512*x_18 + 5.02151966094971) - 0.00142321721167793*std::sin(0.312959939241409*x_21 - 4.29031991958618) - 0.00353040909616631*std::sin(0.250799983739853*x_23 - 7.52175998687744) + 3.52607099163164e-5*std::sin(0.365439832210541*x_23 - 1.03543972969055) - 0.00521403441491237*std::sin(0.371919840574265*x_24 + 8.35968017578125) + 6.97198645421512e-5*std::sin(0.868479907512665*x_24 + 1.17119991779327) + 0.00175602712317234*std::sin(0.309119910001755*x_26 - 4.26143980026245) + 3.03663909900834e-5*std::sin(0.316879838705063*x_26 - 4.26823997497559) + 0.0187709625344784*std::sin(0.33815985918045*x_26 + 5.15375995635986) + 0.113223449014301*std::sin(0.160000026226044*x_27 - 7.64448022842407) + 0.00241193009777913*std::sin(0.257519990205765*x_27 + 5.08903980255127) + 0.000909010163147674*std::sin(0.337999850511551*x_28 - 4.25271987915039) + 6.46530905570968e-7*std::sin(1.42767989635468*x_28 - 3.18928003311157) + 7.53497394414869e-6*std::sin(1.30543982982635*x_29 + 6.19024038314819) + 0.00258668822787522*std::sin(0.294559925794601*x_3 + 8.30103969573975) + 0.000367907865665057*std::sin(0.320479840040207*x_3 + 8.33432006835938) + 0.00358788633704567*std::sin(0.207520008087158*x_31 - 7.40839958190918) - 0.00049482156328423*std::sin(0.259199976921082*x_32 - 7.40863990783691) - 0.00411362398791185*std::sin(0.27295994758606*x_32 - 7.44280004501343) - 0.000428945170112099*std::sin(0.272799968719482*x_33 - 1.17695987224579) + 4.62183200626728e-6*std::sin(0.310799926519394*x_33 - 1.39063990116119) - 0.00298611255529879*std::sin(0.355359852313995*x_34 - 7.4049596786499) + 0.000945836260967683*std::sin(0.374639838933945*x_34 - 1.20295989513397) + 1.57185616277435e-5*std::sin(0.397919833660126*x_34 - 1.2040798664093) - 0.00184955903024821*std::sin(0.300959944725037*x_35 - 4.35016012191772) - 0.0136082962219853*std::sin(0.306319922208786*x_35 - 7.54120016098022) - 0.000184547145862776*std::sin(0.306479930877686*x_35 + 8.26095962524414) + 0.0125971900889158*std::sin(0.339599847793579*x_36 - 7.43495988845825) + 0.000247592032061337*std::sin(0.343279838562012*x_36 + 5.15208005905151) + 0.00182758439525396*std::sin(0.346159845590591*x_36 - 7.4475998878479) + 0.00462693834035852*std::sin(0.378719836473465*x_37 - 4.22504043579102) + 0.00356782092357423*std::sin(0.225599989295006*x_38 + 5.01599979400635) + 3.37092528846769e-5*std::sin(1.33471989631653*x_38 - 3.82351994514465) - 0.00469169617582278*std::sin(0.175280019640923*x_40 + 4.95599985122681) + 0.00037294197040431*std::sin(0.265359967947006*x_40 + 5.07607984542847) - 0.00183388434270245*std::sin(0.381999850273132*x_40 + 5.16951990127563) - 1.4570443711043e-5*std::sin(0.263679951429367*x_41 + 5.06279993057251) + 0.000142742726520045*std::sin(0.300799936056137*x_41 + 1.88895988464355) - 0.00963848315787411*std::sin(0.338959842920303*x_41 + 1.93567979335785) - 0.0248073362738045*std::sin(0.206640005111694*x_42 - 7.60008001327515) + 0.00113253055233117*std::sin(0.343759834766388*x_42 + 8.17296028137207) + 0.000156325881168607*std::sin(0.303439915180206*x_43 - 7.49440002441406) + 0.00708990948525536*std::sin(0.371759831905365*x_43 + 5.17224025726318) + 0.00100387423782425*std::sin(0.373599827289581*x_45 - 1.22919988632202) + 0.0285596235676679*std::sin(0.223279997706413*x_46 + 5.03991985321045) + 0.0129038270330233*std::sin(0.366639852523804*x_47 - 7.4270396232605) + 0.0111686658575883*std::sin(0.34215983748436*x_49 - 4.2454400062561) + 3.13944965358388e-6*std::sin(1.93639981746674*x_5 + 7.80280017852783) - 0.000627665544851857*std::sin(0.225919991731644*x_50 - 7.57376003265381) + 0.00691061420322006*std::sin(0.245119974017143*x_50 - 7.54640007019043) - 0.000299496598408991*std::sin(0.443919867277145*x_50 - 1.38655984401703) - 0.000225169361147747*std::sin(0.581999838352203*x_50 + 8.38016033172607) - 0.000222979784274334*std::sin(0.329439848661423*x_51 + 1.94511985778809) - 0.000307465764207592*std::sin(0.225359991192818*x_55 - 7.57776021957397) - 0.0180579167311819*std::sin(0.227199986577034*x_55 + 5.01903963088989) + 0.00185198219809359*std::sin(0.353759855031967*x_56 + 5.14152002334595) - 9.37813908520099e-6*std::sin(0.353679835796356*x_57 - 4.23112010955811) - 8.20013424649638e-6*std::sin(0.291439920663834*x_58 - 4.54112005233765) - 0.00953744820724563*std::sin(0.136720046401024*x_64 + 4.91695976257324) - 0.00490088732534445*std::sin(0.158240035176277*x_65 - 7.64480018615723) + 0.00335139264335143*std::sin(0.173920020461082*x_69 + 4.95703983306885) - 0.00275296838133668*std::sin(0.192959994077682*x_69 + 4.99343967437744) - 2.91881933171811e-7*std::sin(1.62239992618561*x_7 + 2.00263977050781) + 0.00217502387514557*std::sin(0.223359987139702*x_70 - 7.56512022018433) + 0.000741075934693304*std::sin(0.262639969587326*x_74 - 7.51015996932983) + 0.0129020817997112*std::sin(0.30159991979599*x_74 - 7.46799993515015) + 0.00206569381733066*std::sin(0.254399985074997*x_77 + 5.06759977340698) + 0.00817744650832844*std::sin(0.146000042557716*x_79 - 7.65496015548706) + 0.00299080350595844*std::sin(0.254399985074997*x_8 + 5.06679964065552) - 0.00219314939019306*std::sin(0.325119823217392*x_8 + 5.11800003051758) + 0.00701688143790809*std::sin(0.146640032529831*x_82 + 4.93063974380493) + 0.000138506810879365*std::sin(0.328719854354858*x_82 - 7.48216009140015) + 0.000283915190494745*std::sin(0.171040013432503*x_83 + 4.96776008605957) - 0.0019202950542267*std::sin(0.281919926404953*x_84 - 7.49887990951538) + 0.000267842432606258*std::sin(0.23479999601841*x_85 - 7.55768013000488) - 6.89794885639094e-5*std::sin(0.519279837608337*x_9 - 0.845999836921692) - 0.0072708476240383*std::sin(0.183520004153252*x_91 - 7.36463975906372) - 8.92972436112314e-6*std::sin(0.327599853277206*x_92 - 1.00311982631683) - 0.00419435234199202*std::sin(0.338879853487015*x_92 + 5.19623994827271) + 8.17177721298648e-5*std::sin(0.329279839992523*x_94 - 1.22063982486725) + 0.0196089914652061*std::sin(0.386319845914841*x_94 + 2.00543975830078) + 0.000132546954494089*std::sin(0.337919861078262*x_95 - 7.43951988220215) - 0.00115725100138449*std::sin(0.377039849758148*x_95 - 7.42439985275269) + 0.00173288491016274*std::sin(0.355519831180573*x_96 + 1.9670398235321) + 0.00341094771622394*std::sin(0.397999823093414*x_96 + 1.99415981769562) - 0.000342975275456304*std::sin(0.26463994383812*x_97 + 5.07655954360962) + 0.00115605879316273*std::sin(0.381359845399857*x_97 + 1.97151982784271) + 0.00156208070674798*std::sin(0.273999959230423*x_98 - 4.30663967132568) + 0.0149083125582885*std::sin(0.390079826116562*x_98 + 1.9676798582077) + 0.219803349421071);
}

inline float score_5(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.000123320208078129*x_1 + 0.000710117154303291*x_10 + 0.000588054458807505*x_100 - 0.000300265443190027*x_101 - 0.000383799626687458*x_102 - 4.5461711592162e-5*x_103 + 0.000211953423645207*x_104 - 3.53301414013943e-5*x_105 - 0.0001862959147294*x_106 - 0.000103960476912054*x_107 - 0.000390093312514959*x_108 - 2.39480375667383e-6*x_109 + 8.16776177197855e-5*x_11 - 7.24225900432166e-5*x_110 - 0.00059207104745919*x_111 + 3.70172821279991e-5*x_112 - 5.88594861575953e-5*x_113 - 0.00108178501903695*x_114 - 0.000314717725754862*x_115 + 0.000157960400807272*x_116 + 6.60449195392619e-7*x_117 - 0.000152346189360504*x_118 - 2.44495898881741e-5*x_119 - 0.00204881701034174*x_12 + 4.44582504189695e-5*x_120 + 0.00012376425980102*x_13 + 0.000340517110276483*x_14 - 0.000138156076744439*x_15 - 0.000431455640650336*x_16 + 0.000391984626482537*x_17 - 7.34109988472662e-6*x_18 + 4.55370683654588e-5*x_19 - 0.000191066078827942*x_2 - 0.00108172612298768*x_20 + 0.000322168335286316*x_21 - 0.00126555910003134*x_22 + 0.000261745310995613*x_23 - 0.000103487232351724*x_24 + 0.000207913382989022*x_25 - 8.22872884563597e-5*x_26 + 2.21036045496277e-5*x_27 - 0.000343698885629467*x_28 + 5.83991878671413e-5*x_29 + 0.000314251500049263*x_3 - 8.31284122272053e-5*x_30 - 0.00208542214659092*x_31 + 0.000170073755511516*x_32 - 1.76522082348975e-5*x_33 - 1.18857660834002e-5*x_34 - 0.000217146530128556*x_35 - 0.000230917637259336*x_36 - 1.09569778106328e-5*x_37 + 0.000191700091284915*x_38 - 0.000302659699952112*x_39 + 0.000606219923666607*x_4 + 2.71784661811399e-5*x_40 + 0.000206048106962868*x_41 - 0.000203328035185905*x_42 + 1.99050364127723e-5*x_43 + 9.67004377694764e-5*x_44 + 3.8916845785403e-5*x_45 - 3.57784834641964e-5*x_46 + 0.000459757209310029*x_47 + 8.44756073769311e-5*x_48 - 2.98456631925875e-6*x_49 + 0.000203986897155724*x_5 + 0.000260893894699537*x_50 - 0.000315551247915875*x_51 - 0.000563410210849106*x_52 - 0.000260296264326984*x_53 + 0.000123581192851876*x_54 - 0.000316604918763342*x_55 - 0.000425633178669571*x_56 - 1.62393940062695e-5*x_57 - 0.00046172998456864*x_58 + 9.33158132462885e-5*x_59 + 0.000234554545590926*x_6 + 0.000285147857090596*x_60 + 0.00017789156337652*x_61 - 0.000227106200713864*x_62 + 0.000176533034717941*x_63 + 0.000115265685943862*x_64 + 0.000292244953377504*x_65 - 0.000381137416464316*x_66 - 7.92309414694402e-7*x_67 - 0.000126034216477903*x_68 + 1.44078038932687e-5*x_69 + 2.51354335524951e-5*x_7 + 8.48722175966396e-6*x_70 - 6.28353753149429e-5*x_71 - 0.00023052453769947*x_72 - 1.63352459999944e-5*x_73 - 3.98183573891202e-5*x_74 - 2.83275921041347e-6*x_75 + 0.000226527542059363*x_76 + 3.10927005444175e-5*x_77 - 0.000251114725778929*x_78 + 1.33001726783134e-5*x_79 + 6.43395885258873e-5*x_8 - 0.000210058246806318*x_80 - 2.29843338464575e-5*x_81 - 2.62751160583236e-5*x_82 - 0.000158044484060943*x_83 - 7.07912688709307e-5*x_84 - 0.000357192963698521*x_85 - 8.99262837393314e-5*x_86 + 0.000280168132892752*x_87 - 0.000221783996892454*x_88 + 0.000111519880122975*x_89 + 0.00119756255431428*x_9 - 2.75892777369879e-5*x_90 - 0.00163694036394854*x_91 - 3.60850795953983e-5*x_92 - 0.000112501977760613*x_93 - 3.47348258196712e-5*x_94 + 4.02239912837208e-6*x_95 + 3.92527380585763e-5*x_96 - 4.23807350434832e-5*x_97 - 4.38371028859685e-5*x_98 - 0.000259062207323965*x_99 + 2.72943461535943e-7*std::pow(-4.67039966583252*x_109 - 6.09272003173828, 2) + 0.000341563147630013*std::pow(-0.629119873046875*x_117 - 1.04919981956482, 2) - 2.05639308773085e-5*std::pow(-5.42967987060547*x_13 - 9.45328044891357, 2) - 5.47268041619512e-6*std::pow(-7.32359981536865*x_18 - 9.49656009674072, 2) - 4.69003699908651e-7*std::pow(-6.08007955551147*x_18 - 9.70680046081543, 2) + 4.80317495700841e-6*std::pow(-5.23864030838013*x_19 - 8.24680042266846, 2) - 2.1376512817344e-5*std::pow(-4.40183973312378*x_27 - 6.39983987808228, 2) + 1.15736992903697e-5*std::pow(-5.92095994949341*x_4 - 9.2705602645874, 2) + 1.515673914477e-6*std::pow(-6.3778395652771*x_49 - 9.52264022827148, 2) + 1.21596716215389e-5*std::pow(-5.81791973114014*x_5 - 9.03359985351563, 2) + 7.48494148528674e-6*std::pow(-5.25591993331909*x_57 - 8.28688049316406, 2) - 3.47739973961845e-6*std::pow(-6.50767993927002*x_67 - 9.74536037445068, 2) - 5.93212182506042e-7*std::pow(-4.48536014556885*x_67 - 5.50952005386353, 2) - 2.60711882720117e-7*std::pow(-5.87383985519409*x_69 - 7.69448041915894, 2) + 9.10280728776416e-6*std::pow(-3.67263984680176*x_69 - 4.90823984146118, 2) + 9.33242205777464e-6*std::pow(-5.61768007278442*x_7 - 8.81968021392822, 2) + 9.10249929333953e-6*std::pow(-5.58383989334106*x_7 - 9.16079998016357, 2) + 2.66924310465986e-6*std::pow(-7.80000019073486*x_70 - 9.99882030487061, 2) + 1.3259961807898e-5*std::pow(-3.86879992485046*x_71 - 6.11287975311279, 2) - 1.16124762948629e-5*std::pow(-3.55695986747742*x_75 - 4.39680004119873, 2) - 5.52944214881552e-7*std::pow(-3.24160003662109*x_79 - 4.85735988616943, 2) - 3.88577919859244e-6*std::pow(-8.19999980926514*x_81 - 9.99917984008789, 2) - 1.99733037584222e-7*std::pow(-7.64775991439819*x_81 - 9.46271991729736, 2) - 1.03473949996139e-5*std::pow(-3.7960000038147*x_85 - 6.38800001144409, 2) + 2.53378958296818e-6*std::pow(-7.40000009536743*x_87 - 9.99973964691162, 2) + 4.98490378374929e-6*std::pow(-6.39191961288452*x_90 - 8.79872035980225, 2) - 0.000326104708268233*std::exp(0.97327983379364*x_17) + 0.000744544550928083*std::sin(0.204479992389679*x_1 - 7.40343999862671) - 0.000125639787213665*std::sin(0.409919857978821*x_1 + 4.98423957824707) + 0.00018402180589091*std::sin(0.408479869365692*x_100 - 7.38679981231689) + 0.00017387408261671*std::sin(0.303759932518005*x_101 + 8.27639961242676) - 0.000226592070719257*std::sin(0.158400028944016*x_102 + 8.13687992095947) + 0.000194374469835844*std::sin(0.298319935798645*x_102 + 5.09783983230591) + 0.000161709857170295*std::sin(0.401839852333069*x_103 + 1.99063980579376) + 0.0014350210189512*std::sin(0.410399854183197*x_104 + 1.98927986621857) - 0.00023637625256749*std::sin(0.308479934930801*x_105 + 5.12871980667114) + 4.50704024316153e-5*std::sin(0.448319852352142*x_106 - 1.17631983757019) - 0.00517567396141459*std::sin(0.31591984629631*x_107 - 7.4553599357605) + 0.00217840513193063*std::sin(0.316479861736298*x_107 + 1.93535983562469) - 0.00014937875680233*std::sin(0.246559977531433*x_109 + 5.04895973205566) + 0.00233871378017367*std::sin(0.409119844436646*x_109 - 1.185919880867) + 0.0032019928232832*std::sin(0.317759841680527*x_11 - 1.07807981967926) + 0.00210163626769658*std::sin(0.369279861450195*x_110 - 7.41311979293823) - 0.00175802555399996*std::sin(0.467359870672226*x_111 + 2.05663967132568) - 0.00342833916074923*std::sin(0.309759944677353*x_112 + 1.88231992721558) - 0.00256042815947084*std::sin(0.340159833431244*x_112 - 7.43631982803345) + 0.00014047964780412*std::sin(0.37679985165596*x_112 - 7.41648006439209) - 0.00301207796838184*std::sin(0.350399851799011*x_113 + 1.94639980792999) + 0.000218132931845508*std::sin(0.351679861545563*x_114 + 1.95783984661102) - 0.00426433410209157*std::sin(0.166160017251968*x_115 + 8.14791965484619) + 0.00186299023379005*std::sin(0.773439824581146*x_116 - 1.000079870224) - 0.000197620019375344*std::sin(0.297279924154282*x_117 + 5.08855962753296) + 0.00272090292279467*std::sin(0.470959842205048*x_117 + 2.05343985557556) + 0.00138749011710957*std::sin(0.511359870433807*x_117 - 7.44767951965332) - 9.36956163983259e-5*std::sin(0.305519849061966*x_118 - 1.26919984817505) - 0.000301385896230482*std::sin(0.320319831371307*x_118 - 7.46407985687256) - 0.00460463161084074*std::sin(0.388959854841232*x_118 - 7.39264011383057) - 0.000271047112639246*std::sin(0.322239845991135*x_119 + 5.13624000549316) + 0.000158733753565479*std::sin(0.417999863624573*x_119 + 8.20368003845215) + 0.000214454927914568*std::sin(0.327839851379395*x_12 + 5.1300802230835) - 0.00598617166615972*std::sin(0.25111997127533*x_120 + 5.06399965286255) - 0.000223340319971634*std::sin(0.349519848823547*x_120 - 7.44911956787109) - 0.00435136111335012*std::sin(0.289759933948517*x_14 + 5.12048006057739) + 0.000182933901079586*std::sin(0.406079858541489*x_15 - 0.976399838924408) + 0.0151144247913538*std::sin(0.228879988193512*x_18 + 5.02151966094971) - 0.00344896670199107*std::sin(0.312959939241409*x_21 - 4.29031991958618) - 0.00855544980567554*std::sin(0.250799983739853*x_23 - 7.52175998687744) - 3.79821590138154e-5*std::sin(0.365439832210541*x_23 - 1.03543972969055) + 7.49410728699124e-5*std::sin(0.371919840574265*x_24 + 8.35968017578125) - 0.000234331538255164*std::sin(0.868479907512665*x_24 + 1.17119991779327) - 0.00590208457364379*std::sin(0.309119910001755*x_26 - 4.26143980026245) - 0.00659796317659536*std::sin(0.316879838705063*x_26 - 4.26823997497559) - 0.000269794166895307*std::sin(0.33815985918045*x_26 + 5.15375995635986) - 0.00162735533906256*std::sin(0.160000026226044*x_27 - 7.64448022842407) - 0.00810660338610969*std::sin(0.257519990205765*x_27 + 5.08903980255127) + 0.0022028582557483*std::sin(0.337999850511551*x_28 - 4.25271987915039) - 0.000140477250289017*std::sin(1.42767989635468*x_28 - 3.18928003311157) - 8.11652911103695e-6*std::sin(1.30543982982635*x_29 + 6.19024038314819) + 0.00626847503892669*std::sin(0.294559925794601*x_3 + 8.30103969573975) - 0.000396303281734478*std::sin(0.320479840040207*x_3 + 8.33432006835938) - 0.0120590441471138*std::sin(0.207520008087158*x_31 - 7.40839958190918) + 0.000533012277538675*std::sin(0.259199976921082*x_32 - 7.40863990783691) - 0.00996878905229989*std::sin(0.27295994758606*x_32 - 7.44280004501343) + 0.000462051492952694*std::sin(0.272799968719482*x_33 - 1.17695987224579) - 0.00100422461779274*std::sin(0.310799926519394*x_33 - 1.39063990116119) - 0.00723642370758065*std::sin(0.355359852313995*x_34 - 7.4049596786499) - 0.00317899736933756*std::sin(0.374639838933945*x_34 - 1.20295989513397) - 0.00341530512607721*std::sin(0.397919833660126*x_34 - 1.2040798664093) + 0.00621644943658432*std::sin(0.300959944725037*x_35 - 4.35016012191772) + 0.000195591405359816*std::sin(0.306319922208786*x_35 - 7.54120016098022) + 0.000198790638541914*std::sin(0.306479930877686*x_35 + 8.26095962524414) - 0.000181058824182204*std::sin(0.339599847793579*x_36 - 7.43495988845825) - 0.000266701378237305*std::sin(0.343279838562012*x_36 + 5.15208005905151) - 0.00614259171963933*std::sin(0.346159845590591*x_36 - 7.4475998878479) - 6.65027684392888e-5*std::sin(0.378719836473465*x_37 - 4.22504043579102) - 0.0119916034078731*std::sin(0.225599989295006*x_38 + 5.01599979400635) + 8.16896323303861e-5*std::sin(1.33471989631653*x_38 - 3.82351994514465) - 0.0113696656796289*std::sin(0.175280019640923*x_40 + 4.95599985122681) - 0.000401725922604508*std::sin(0.265359967947006*x_40 + 5.07607984542847) + 0.00616376612074046*std::sin(0.381999850273132*x_40 + 5.16951990127563) + 0.00316584381408746*std::sin(0.263679951429367*x_41 + 5.06279993057251) - 0.000153759721503539*std::sin(0.300799936056137*x_41 + 1.88895988464355) + 0.000138533467792964*std::sin(0.338959842920303*x_41 + 1.93567979335785) + 0.000356554684427577*std::sin(0.206640005111694*x_42 - 7.60008001327515) + 0.0027445284752934*std::sin(0.343759834766388*x_42 + 8.17296028137207) - 0.000168391234623819*std::sin(0.303439915180206*x_43 - 7.49440002441406) - 0.000101902937551772*std::sin(0.371759831905365*x_43 + 5.17224025726318) - 0.00337406556809739*std::sin(0.373599827289581*x_45 - 1.22919988632202) - 0.000410486134268801*std::sin(0.223279997706413*x_46 + 5.03991985321045) - 0.000185466102643435*std::sin(0.366639852523804*x_47 - 7.4270396232605) - 0.000160526712194188*std::sin(0.34215983748436*x_49 - 4.2454400062561) - 3.38175482686786e-6*std::sin(1.93639981746674*x_5 + 7.80280017852783) + 0.000676109261232562*std::sin(0.225919991731644*x_50 - 7.57376003265381) - 9.93259348458041e-5*std::sin(0.245119974017143*x_50 - 7.54640007019043) - 0.000725787874680339*std::sin(0.443919867277145*x_50 - 1.38655984401703) + 0.000756804149178802*std::sin(0.581999838352203*x_50 + 8.38016033172607) + 0.00024018953796659*std::sin(0.329439848661423*x_51 + 1.94511985778809) + 0.00033119621173688*std::sin(0.225359991192818*x_55 - 7.57776021957397) + 0.000259545592902086*std::sin(0.227199986577034*x_55 + 5.01903963088989) + 0.00448801833022695*std::sin(0.353759855031967*x_56 + 5.14152002334595) + 0.00203766777452587*std::sin(0.353679835796356*x_57 - 4.23112010955811) + 0.00178171267765044*std::sin(0.291439920663834*x_58 - 4.54112005233765) - 0.0231126640535588*std::sin(0.136720046401024*x_64 + 4.91695976257324) + 0.0164720983510931*std::sin(0.158240035176277*x_65 - 7.64480018615723) + 0.00812162861534636*std::sin(0.173920020461082*x_69 + 4.95703983306885) + 0.0092528480914709*std::sin(0.192959994077682*x_69 + 4.99343967437744) + 6.34196618099919e-5*std::sin(1.62239992618561*x_7 + 2.00263977050781) - 0.00731035112806952*std::sin(0.223359987139702*x_70 - 7.56512022018433) + 0.00179589327716936*std::sin(0.262639969587326*x_74 - 7.51015996932983) - 0.000185441018486638*std::sin(0.30159991979599*x_74 - 7.46799993515015) - 0.0069428879840497*std::sin(0.254399985074997*x_77 + 5.06759977340698) + 0.0198168912539265*std::sin(0.146000042557716*x_79 - 7.65496015548706) + 0.00724779156660672*std::sin(0.254399985074997*x_8 + 5.06679964065552) + 0.00737127178318893*std::sin(0.325119823217392*x_8 + 5.11800003051758) - 0.023584047844858*std::sin(0.146640032529831*x_82 + 4.93063974380493) - 0.000149196874589361*std::sin(0.328719854354858*x_82 - 7.48216009140015) - 0.000305827986373555*std::sin(0.171040013432503*x_83 + 4.96776008605957) - 0.00465356492718191*std::sin(0.281919926404953*x_84 - 7.49887990951538) - 0.000288514720493206*std::sin(0.23479999601841*x_85 - 7.55768013000488) + 7.43033793007583e-5*std::sin(0.519279837608337*x_9 - 0.845999836921692) - 0.0176198763932837*std::sin(0.183520004153252*x_91 - 7.36463975906372) + 0.00194023690635734*std::sin(0.327599853277206*x_92 - 1.00311982631683) - 0.0101644228619844*std::sin(0.338879853487015*x_92 + 5.19623994827271) - 8.80248135292084e-5*std::sin(0.329279839992523*x_94 - 1.22063982486725) - 0.000281839117535667*std::sin(0.386319845914841*x_94 + 2.00543975830078) - 0.000142777031839108*std::sin(0.337919861078262*x_95 - 7.43951988220215) - 0.00280443500603487*std::sin(0.377039849758148*x_95 - 7.42439985275269) + 0.00419940280688974*std::sin(0.355519831180573*x_96 + 1.9670398235321) - 4.90253920507151e-5*std::sin(0.397999823093414*x_96 + 1.99415981769562) + 0.000369446374764011*std::sin(0.26463994383812*x_97 + 5.07655954360962) - 0.00388556456749064*std::sin(0.381359845399857*x_97 + 1.97151982784271) + 0.00378548284772688*std::sin(0.273999959230423*x_98 - 4.30663967132568) - 0.000214276479380872*std::sin(0.390079826116562*x_98 + 1.9676798582077) - 0.00560374436156118);
}

inline float score_6(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.000184932111022167*x_1 + 0.00199077993221879*x_10 + 0.000736743487546337*x_100 - 0.000593686729549598*x_101 - 0.000951735235855907*x_102 + 8.55169103600797e-6*x_103 + 0.000829230793244899*x_104 - 0.00015418550046762*x_105 + 3.4626472080415e-5*x_106 - 0.000250749967862649*x_107 - 0.00030029952397074*x_108 + 1.88703761798007e-6*x_109 - 4.75873365824108e-5*x_11 - 4.99141797654705e-5*x_110 - 0.00114746836725908*x_111 + 6.37491804542739e-5*x_112 + 0.000554571601420122*x_113 - 0.000280465892600388*x_114 - 0.000700659123917207*x_115 + 0.000178247226943284*x_116 - 1.55751158286902e-5*x_117 + 4.75870545737687e-6*x_118 - 2.98429484088414e-5*x_119 - 0.00493925527589745*x_12 + 8.71874044662894e-5*x_120 + 0.000210380278261629*x_13 + 0.000192746893107773*x_14 - 0.000610624853618849*x_15 - 0.000598674371908574*x_16 + 0.00100191901198234*x_17 - 1.2741780385125e-5*x_18 - 6.75427237795816e-5*x_19 - 0.000119038771949968*x_2 + 0.00073065073163988*x_20 + 0.000637783207887843*x_21 - 0.00173332035091368*x_22 + 0.000384197151200366*x_23 - 0.000291496388820942*x_24 + 0.000991080056295437*x_25 - 0.000216285480790524*x_26 + 3.37803117966069e-5*x_27 - 1.29976995406232e-5*x_28 - 0.000276955384739346*x_29 - 5.46298830879482e-5*x_3 - 0.000120632847510433*x_30 - 0.00447517506316262*x_31 + 0.000210677058758258*x_32 - 0.000580262985751475*x_33 + 2.75891845043088e-5*x_34 - 0.000481626315868507*x_35 - 0.000355165629574192*x_36 - 7.37773975181229e-5*x_37 + 0.000298090107835947*x_38 + 0.000124445423644201*x_39 + 0.00163134900373328*x_4 - 0.000395187207239419*x_40 - 2.72604712844039e-5*x_41 - 0.000286832970839726*x_42 - 8.09742783554423e-5*x_43 + 0.000148416371390745*x_44 - 0.000463941705964218*x_45 - 9.95494379711575e-5*x_46 + 0.000610320261504071*x_47 + 0.000115146215540424*x_48 + 1.37488759609998e-5*x_49 + 0.000469698248999*x_5 + 0.000383574235785053*x_50 - 8.14829145890452e-5*x_51 - 0.0012934411313922*x_52 - 0.000303725939434084*x_53 + 0.000208137885380672*x_54 - 0.000773484758977261*x_55 + 3.43178948507735e-5*x_56 + 0.000518333186250498*x_57 - 4.85316419622622e-5*x_58 - 7.69079846180784e-5*x_59 + 0.000592286553948361*x_6 + 0.000258835886508458*x_60 + 0.000506132161346508*x_61 - 0.00114259902812361*x_62 + 0.00044871794254683*x_63 - 0.000154705252624137*x_64 + 0.000734379591292831*x_65 - 0.000140285900888017*x_66 + 2.3672355677324e-5*x_67 + 6.63417513567811e-5*x_68 - 0.000339773620802599*x_69 - 7.92803974009476e-5*x_7 + 7.71388403822023e-6*x_70 - 5.1853490367887e-5*x_71 + 3.24766402973379e-6*x_72 - 3.58031640433349e-5*x_73 - 2.65562543765083e-5*x_74 - 4.36404233245434e-6*x_75 + 0.00024842390052424*x_76 + 0.00059382307182902*x_77 - 0.000588601304049583*x_78 - 5.57699355667442e-5*x_79 + 0.000294645152055448*x_8 + 8.24257636811681e-5*x_80 - 6.21646721987737e-5*x_81 - 5.55755258311215e-5*x_82 - 0.000585368122180236*x_83 - 7.71812608129755e-5*x_84 - 0.000931489114717597*x_85 + 3.08593870836024e-5*x_86 + 0.000425078437516389*x_87 - 0.000352313939372336*x_88 - 0.000321637978128609*x_89 + 0.000700184585933076*x_9 - 2.46664437294125e-5*x_90 + 0.000299602409883902*x_91 + 0.00116720080391817*x_92 + 2.71611528166366e-5*x_93 - 5.80222945270707e-5*x_94 - 1.52999817167229e-5*x_95 + 0.000112261759857181*x_96 - 9.37146871335947e-5*x_97 - 2.50219460136715e-5*x_98 - 0.000558245249973807*x_99 + 0.000502176654901812*std::pow(-0.629119873046875*x_117 - 1.04919981956482, 2) + 7.0617756908348e-6*std::pow(-5.23864030838013*x_19 - 8.24680042266846, 2) - 5.6032018669567e-5*std::pow(-4.40183973312378*x_27 - 6.39983987808228, 2) + 2.22839045012687e-6*std::pow(-6.3778395652771*x_49 - 9.52264022827148, 2) - 9.11494446249243e-6*std::pow(-6.50767993927002*x_67 - 9.74536037445068, 2) + 1.33832275106472e-5*std::pow(-3.67263984680176*x_69 - 4.90823984146118, 2) + 2.44621024692688e-5*std::pow(-5.61768007278442*x_7 - 8.81968021392822, 2) + 6.99660794779233e-6*std::pow(-7.80000019073486*x_70 - 9.99882030487061, 2) + 4.71022633821375e-6*std::pow(-7.64775991439819*x_81 - 9.46271991729736, 2) + 6.64155778965201e-6*std::pow(-7.40000009536743*x_87 - 9.99973964691162, 2) + 1.30664072416157e-5*std::pow(-6.39191961288452*x_90 - 8.79872035980225, 2) - 0.000479449181453448*std::exp(0.97327983379364*x_17) + 0.0104272326234588*std::exp(-0.000560872883849377*x_1 - 0.00219060637266144*x_10 + 0.0201744638142493*x_100 - 0.00208118202629496*x_101 - 0.000810641840493733*x_102 - 0.00207614722338382*x_103 + 0.000867749412475802*x_105 - 0.00849925490954886*x_106 - 0.0141197745720122*x_108 - 0.000164029252341681*x_109 + 0.00425541850405247*x_11 - 0.00485020736348357*x_110 - 0.000923890108323189*x_111 - 0.00152403188632635*x_113 - 0.0407280283240469*x_114 - 0.00129373044292688*x_115 - 0.00693802489707671*x_118 + 0.00119972425064716*x_119 - 0.000128357362967303*x_12 + 0.0114789746231632*x_14 - 0.00193850544477314*x_15 - 0.0140761698150482*x_16 + 0.000769076223100456*x_17 + 0.00270689481088261*x_19 - 0.0219087777412198*x_2 - 0.0506623013827175*x_20 - 0.000730214058327669*x_21 - 0.0296545650391233*x_22 + 0.0110326374179245*x_23 - 0.00127613922324529*x_25 - 0.015331700986563*x_28 - 0.000137049365777446*x_29 + 0.00015980170628693*x_3 - 0.00295348033913558*x_30 + 0.00727917704240908*x_32 + 0.00200382132832702*x_33 - 0.0014936315807399*x_37 - 0.0162772466195492*x_39 + 0.00965223361324716*x_41 - 0.000628170935016198*x_42 + 0.00227915668949587*x_43 + 0.000463218525520974*x_44 + 0.000721870441625077*x_46 + 0.00902655822328366*x_47 - 0.00198968646134202*x_48 - 0.000381819469607757*x_49 - 0.0115732553907328*x_51 - 0.00324016050618962*x_52 - 0.00113136770211957*x_53 - 0.00171627605552498*x_54 + 0.00261522233808747*x_55 - 0.0189738283311846*x_56 - 0.0199122606591693*x_58 + 0.00507056855024753*x_59 + 0.00136265403689918*x_6 + 0.000140028286317269*x_60 - 0.00809678399584735*x_61 + 0.00384970717266608*x_62 + 0.00895383363098738*x_63 - 0.000874687375883227*x_64 - 0.0174245185038274*x_66 - 0.000852985579979429*x_67 + 0.000336262190798289*x_68 - 0.00863401862456734*x_72 - 0.00124426799305916*x_73 - 0.000984866242430575*x_74 + 0.0081731867718438*x_76 - 0.00104288346048003*x_78 + 3.63236905154142e-5*x_79 - 0.011125968436935*x_80 + 0.00210632911674993*x_83 - 0.000707327589304425*x_84 - 0.00177991106990099*x_86 - 0.000415140159095313*x_87 - 0.000557071258330006*x_88 + 0.0117588804853892*x_89 + 0.0354811490791864*x_9 - 0.000631048140948578*x_90 - 0.0673443175311363*x_91 + 0.000571568764551663*x_92 - 0.00224158329483204*x_93 - 0.000213978521566906*x_94 + 0.000565691534748052*x_95 - 0.0016780321210369*x_96 - 0.0011426398009131*x_98 - 0.00558143667194527*x_99 - 0.000917022810709982*std::pow(-5.42967987060547*x_13 - 9.45328044891357, 2) - 0.000244047347139963*std::pow(-7.32359981536865*x_18 - 9.49656009674072, 2) + 0.00051611466294503*std::pow(-5.92095994949341*x_4 - 9.2705602645874, 2) + 0.000542245367105291*std::pow(-5.81791973114014*x_5 - 9.03359985351563, 2) + 0.000333781615965817*std::pow(-5.25591993331909*x_57 - 8.28688049316406, 2) + 0.000405914585896349*std::pow(-5.58383989334106*x_7 - 9.16079998016357, 2) + 0.000591311433574375*std::pow(-3.86879992485046*x_71 - 6.11287975311279, 2) - 0.000517843875023374*std::pow(-3.55695986747742*x_75 - 4.39680004119873, 2) - 0.000173281469566873*std::pow(-8.19999980926514*x_81 - 9.99917984008789, 2) - 0.000461429154896786*std::pow(-3.7960000038147*x_85 - 6.38800001144409, 2) + 0.0639929698304242*std::sin(0.410399854183197*x_104 + 1.98927986621857) - 0.230802715284952*std::sin(0.31591984629631*x_107 - 7.4553599357605) - 0.15288250247556*std::sin(0.309759944677353*x_112 + 1.88231992721558) + 0.0830777223823755*std::sin(0.773439824581146*x_116 - 1.000079870224) + 0.121335267114881*std::sin(0.470959842205048*x_117 + 2.05343985557556) - 0.266945848021287*std::sin(0.25111997127533*x_120 + 5.06399965286255) - 0.0104497222408904*std::sin(0.868479907512665*x_24 + 1.17119991779327) - 0.263196089165188*std::sin(0.309119910001755*x_26 - 4.26143980026245) - 0.361503851904327*std::sin(0.257519990205765*x_27 + 5.08903980255127) - 0.537758010578834*std::sin(0.207520008087158*x_31 - 7.40839958190918) - 0.141763416744723*std::sin(0.374639838933945*x_34 - 1.20295989513397) + 0.277214797549405*std::sin(0.300959944725037*x_35 - 4.35016012191772) - 0.273921204919201*std::sin(0.346159845590591*x_36 - 7.4475998878479) - 0.534750575053792*std::sin(0.225599989295006*x_38 + 5.01599979400635) + 0.274865450886994*std::sin(0.381999850273132*x_40 + 5.16951990127563) - 0.150462239405339*std::sin(0.373599827289581*x_45 - 1.22919988632202) + 0.0337487356954078*std::sin(0.581999838352203*x_50 + 8.38016033172607) + 0.734552650382554*std::sin(0.158240035176277*x_65 - 7.64480018615723) + 0.41261920274572*std::sin(0.192959994077682*x_69 + 4.99343967437744) - 0.325995977069566*std::sin(0.223359987139702*x_70 - 7.56512022018433) - 0.309609417166604*std::sin(0.254399985074997*x_77 + 5.06759977340698) + 0.328712657587566*std::sin(0.325119823217392*x_8 + 5.11800003051758) - 1.05170115439724*std::sin(0.146640032529831*x_82 + 4.93063974380493) - 0.173271898360988*std::sin(0.381359845399857*x_97 + 1.97151982784271)) + 0.00296291410784673*std::sin(0.409919857978821*x_1 + 4.98423957824707) + 0.00534363244279098*std::sin(0.158400028944016*x_102 + 8.13687992095947) + 0.00557436898791553*std::sin(0.308479934930801*x_105 + 5.12871980667114) - 0.00106287772506223*std::sin(0.448319852352142*x_106 - 1.17631983757019) + 0.00320275828866306*std::sin(0.316479861736298*x_107 + 1.93535983562469) + 0.00352274097049803*std::sin(0.246559977531433*x_109 + 5.04895973205566) + 0.00613022597807169*std::sin(0.409119844436646*x_109 - 1.185919880867) + 0.00839304909959188*std::sin(0.317759841680527*x_11 - 1.07807981967926) + 0.00308989034108393*std::sin(0.369279861450195*x_110 - 7.41311979293823) - 0.00258470329151526*std::sin(0.467359870672226*x_111 + 2.05663967132568) - 0.00671138270584305*std::sin(0.340159833431244*x_112 - 7.43631982803345) - 0.00442844975800466*std::sin(0.350399851799011*x_113 + 1.94639980792999) - 0.00514414386942492*std::sin(0.351679861545563*x_114 + 1.95783984661102) - 0.00626955527735013*std::sin(0.166160017251968*x_115 + 8.14791965484619) + 0.00363688281666994*std::sin(0.511359870433807*x_117 - 7.44767951965332) + 0.00220958718433584*std::sin(0.305519849061966*x_118 - 1.26919984817505) - 0.0120696395426934*std::sin(0.388959854841232*x_118 - 7.39264011383057) + 0.00639199836087115*std::sin(0.322239845991135*x_119 + 5.13624000549316) - 0.00505740693698198*std::sin(0.327839851379395*x_12 + 5.1300802230835) + 0.00526694767295013*std::sin(0.349519848823547*x_120 - 7.44911956787109) - 0.00639750506848879*std::sin(0.289759933948517*x_14 + 5.12048006057739) + 0.0396178618713606*std::sin(0.228879988193512*x_18 + 5.02151966094971) - 0.00904041591292108*std::sin(0.312959939241409*x_21 - 4.29031991958618) - 0.0224255063178128*std::sin(0.250799983739853*x_23 - 7.52175998687744) - 0.00176730609775567*std::sin(0.371919840574265*x_24 + 8.35968017578125) - 0.00970052858505996*std::sin(0.316879838705063*x_26 - 4.26823997497559) + 0.00636245062998581*std::sin(0.33815985918045*x_26 + 5.15375995635986) + 0.0383772863638195*std::sin(0.160000026226044*x_27 - 7.64448022842407) + 0.00577412209218484*std::sin(0.337999850511551*x_28 - 4.25271987915039) - 0.000206533978063576*std::sin(1.42767989635468*x_28 - 3.18928003311157) + 0.0164308984076148*std::sin(0.294559925794601*x_3 + 8.30103969573975) - 0.0261301447558013*std::sin(0.27295994758606*x_32 - 7.44280004501343) - 0.00147644194882369*std::sin(0.310799926519394*x_33 - 1.39063990116119) - 0.0189680810779892*std::sin(0.355359852313995*x_34 - 7.4049596786499) - 0.00502128673887347*std::sin(0.397919833660126*x_34 - 1.2040798664093) - 0.00461255584052071*std::sin(0.306319922208786*x_35 - 7.54120016098022) + 0.00426983964567913*std::sin(0.339599847793579*x_36 - 7.43495988845825) + 0.00156830885493734*std::sin(0.378719836473465*x_37 - 4.22504043579102) + 0.000214124494624421*std::sin(1.33471989631653*x_38 - 3.82351994514465) - 0.0298021162324853*std::sin(0.175280019640923*x_40 + 4.95599985122681) + 0.00465452103814826*std::sin(0.263679951429367*x_41 + 5.06279993057251) - 0.00326698074897776*std::sin(0.338959842920303*x_41 + 1.93567979335785) - 0.00840849008214819*std::sin(0.206640005111694*x_42 - 7.60008001327515) + 0.00719394562063585*std::sin(0.343759834766388*x_42 + 8.17296028137207) + 0.00240313723860185*std::sin(0.371759831905365*x_43 + 5.17224025726318) + 0.00968033443285091*std::sin(0.223279997706413*x_46 + 5.03991985321045) + 0.00437377477498481*std::sin(0.366639852523804*x_47 - 7.4270396232605) + 0.00378563885528997*std::sin(0.34215983748436*x_49 - 4.2454400062561) + 0.00234236478870517*std::sin(0.245119974017143*x_50 - 7.54640007019043) - 0.00190243189297172*std::sin(0.443919867277145*x_50 - 1.38655984401703) - 0.00612076250599858*std::sin(0.227199986577034*x_55 + 5.01903963088989) + 0.0117639733392156*std::sin(0.353759855031967*x_56 + 5.14152002334595) + 0.00299584189311034*std::sin(0.353679835796356*x_57 - 4.23112010955811) + 0.00261952882993056*std::sin(0.291439920663834*x_58 - 4.54112005233765) - 0.0605828104339678*std::sin(0.136720046401024*x_64 + 4.91695976257324) + 0.0212883761767331*std::sin(0.173920020461082*x_69 + 4.95703983306885) + 9.32415392109108e-5*std::sin(1.62239992618561*x_7 + 2.00263977050781) + 0.00470738733182236*std::sin(0.262639969587326*x_74 - 7.51015996932983) + 0.00437318322509678*std::sin(0.30159991979599*x_74 - 7.46799993515015) + 0.0519439456847176*std::sin(0.146000042557716*x_79 - 7.65496015548706) + 0.0189978784586295*std::sin(0.254399985074997*x_8 + 5.06679964065552) - 0.0121979033300669*std::sin(0.281919926404953*x_84 - 7.49887990951538) - 0.0461851402733424*std::sin(0.183520004153252*x_91 - 7.36463975906372) + 0.00285259603125275*std::sin(0.327599853277206*x_92 - 1.00311982631683) - 0.0266429392125167*std::sin(0.338879853487015*x_92 + 5.19623994827271) + 0.0066465020039343*std::sin(0.386319845914841*x_94 + 2.00543975830078) - 0.00735097234794243*std::sin(0.377039849758148*x_95 - 7.42439985275269) + 0.0110074556354095*std::sin(0.355519831180573*x_96 + 1.9670398235321) + 0.00115614670297677*std::sin(0.397999823093414*x_96 + 1.99415981769562) + 0.00992249051141129*std::sin(0.273999959230423*x_98 - 4.30663967132568) + 0.00505319865479894*std::sin(0.390079826116562*x_98 + 1.9676798582077) + 0.104323081672192*std::sin(-0.00942954626361788*x_10 + 0.000119170978184248*x_104 + 0.000281021725904041*x_105 + 0.000363577546842262*x_106 - 0.000982896679841204*x_107 + 0.00450768051942033*x_108 - 0.0016987838184811*x_11 - 0.00354788860759511*x_110 + 0.000213985990204691*x_111 + 0.000103352967865016*x_113 - 0.00215523948865832*x_114 - 0.000399101288027838*x_115 + 0.00023527866903806*x_116 + 0.00188896921258564*x_12 + 0.00934489182169386*x_120 + 0.0246922172765307*x_13 + 0.000588412172473918*x_14 + 0.00160415845167597*x_16 - 0.000702904846681723*x_17 + 0.00414710178322627*x_19 - 0.0148974477703594*x_2 + 0.0422311997737888*x_20 - 0.00642131826111162*x_21 - 0.00428771992340864*x_22 - 0.00128664537472869*x_24 - 0.00091472664129861*x_25 + 0.000197112431850775*x_26 - 0.000758467053155842*x_27 - 0.000383980483333585*x_28 - 0.000291202170823056*x_30 + 0.0788286031909218*x_31 - 0.00931435664555386*x_34 - 0.00453304524212197*x_37 + 0.00595471939754719*x_38 - 0.00061458869547458*x_39 + 0.00397385539377176*x_4 + 0.00508691125688347*x_42 + 0.00121804293417277*x_44 + 0.00372007869608756*x_45 + 0.00236448312812511*x_46 + 0.000615760660104781*x_47 + 0.00606975611121331*x_48 + 0.000288872657857744*x_49 - 0.000282295751921996*x_52 - 0.000558887886419681*x_53 - 0.00139391346591739*x_54 - 0.000821950007430046*x_56 + 0.0212942051729968*x_57 + 0.0104084214754671*x_58 + 0.00908717268812832*x_59 - 0.000118531429004021*x_6 + 0.0267403513231358*x_60 + 0.0077157418748252*x_61 + 0.00837495187903995*x_62 - 0.00022245918725325*x_63 - 0.00360452801224931*x_64 - 0.000132346607079207*x_65 + 0.0113617449834356*x_66 + 0.000188488209459792*x_68 + 0.0189258757112058*x_7 + 0.000384505741705629*x_70 + 0.000438668792280269*x_71 + 0.0007094208418372*x_72 + 0.0199338087959167*x_73 + 0.000286477477251573*x_74 + 2.86709915854622e-5*x_75 - 0.0051830721668498*x_76 - 0.000521805959795534*x_77 + 0.000304159059081821*x_78 - 0.00159180384130504*x_8 + 0.000462297058292778*x_80 - 0.000283204061472808*x_81 - 0.000812296972782511*x_84 - 0.00108218932338522*x_86 + 0.000254664537743361*x_87 + 1.89279311920158e-5*x_88 + 0.000399175181643816*x_89 - 0.000237187255545034*x_90 - 0.0463285242161826*x_91 + 0.000514410517884206*x_92 - 0.0314104719568748*x_93 + 0.000456764227949923*x_96 - 0.00103846955652414*x_98 - 0.00797994064018635*x_99 + 0.000237245557987726*std::pow(-4.67039966583252*x_109 - 6.09272003173828, 2) - 0.000407663344844343*std::pow(-6.08007955551147*x_18 - 9.70680046081543, 2) - 0.000515626769191646*std::pow(-4.48536014556885*x_67 - 5.50952005386353, 2) - 0.00022661373070415*std::pow(-5.87383985519409*x_69 - 7.69448041915894, 2) - 0.000480625394202322*std::pow(-3.24160003662109*x_79 - 4.85735988616943, 2) + 0.64716658328301*std::sin(0.204479992389679*x_1 - 7.40343999862671) + 0.159953844561134*std::sin(0.408479869365692*x_100 - 7.38679981231689) + 0.151133328191388*std::sin(0.303759932518005*x_101 + 8.27639961242676) + 0.168952497690444*std::sin(0.298319935798645*x_102 + 5.09783983230591) + 0.140560045221783*std::sin(0.401839852333069*x_103 + 1.99063980579376) + 0.122106506020181*std::sin(0.37679985165596*x_112 - 7.41648006439209) - 0.171773566226552*std::sin(0.297279924154282*x_117 + 5.08855962753296) - 0.261968045391026*std::sin(0.320319831371307*x_118 - 7.46407985687256) + 0.137973182153583*std::sin(0.417999863624573*x_119 + 8.20368003845215) + 0.159008225338209*std::sin(0.406079858541489*x_15 - 0.976399838924408) - 0.0330145241732582*std::sin(0.365439832210541*x_23 - 1.03543972969055) - 0.00705497932441956*std::sin(1.30543982982635*x_29 + 6.19024038314819) - 0.344471315335326*std::sin(0.320479840040207*x_3 + 8.33432006835938) + 0.463300327794514*std::sin(0.259199976921082*x_32 - 7.40863990783691) + 0.401620407566305*std::sin(0.272799968719482*x_33 - 1.17695987224579) + 0.172791081706869*std::sin(0.306479930877686*x_35 + 8.26095962524414) - 0.231819868261152*std::sin(0.343279838562012*x_36 + 5.15208005905151) - 0.349184736392338*std::sin(0.265359967947006*x_40 + 5.07607984542847) - 0.133649696969718*std::sin(0.300799936056137*x_41 + 1.88895988464355) - 0.146367574419104*std::sin(0.303439915180206*x_43 - 7.49440002441406) - 0.00293945971947124*std::sin(1.93639981746674*x_5 + 7.80280017852783) + 0.587681851908606*std::sin(0.225919991731644*x_50 - 7.57376003265381) + 0.208775475466716*std::sin(0.329439848661423*x_51 + 1.94511985778809) + 0.28787951033804*std::sin(0.225359991192818*x_55 - 7.57776021957397) - 0.129683618588228*std::sin(0.328719854354858*x_82 - 7.48216009140015) - 0.265829160615016*std::sin(0.171040013432503*x_83 + 4.96776008605957) - 0.250780273196138*std::sin(0.23479999601841*x_85 - 7.55768013000488) + 0.0645853415333075*std::sin(0.519279837608337*x_9 - 0.845999836921692) - 0.0765121680694758*std::sin(0.329279839992523*x_94 - 1.22063982486725) - 0.124103418326582*std::sin(0.337919861078262*x_95 - 7.43951988220215) + 0.321126986644771*std::sin(0.26463994383812*x_97 + 5.07655954360962) + 1.66592771051239) - 0.149440226812444);
}

inline float score_7(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.000562048542628888*x_1 + 0.00114497054787437*x_10 + 0.00159275780791155*x_100 - 0.000287570961808304*x_101 - 0.000267014141067137*x_102 - 0.000212478314473143*x_103 - 2.22833857291248e-5*x_104 - 0.000105115810771593*x_105 + 0.000157216738042232*x_106 - 0.00010619485528421*x_107 + 6.90940195461247e-5*x_108 - 8.11984052656258e-6*x_109 + 9.49031605994322e-5*x_11 + 0.000121000937945535*x_110 - 0.000727815260970934*x_111 - 0.00024341694485654*x_112 - 0.000457083553765633*x_113 + 0.0008057701039148*x_114 - 0.000276235691768074*x_115 - 0.000977210463846747*x_116 + 1.27556964558783e-5*x_117 - 2.09007577180376e-5*x_118 + 0.000608598806677445*x_119 + 0.000956196591518718*x_12 + 8.07700249401739e-5*x_120 + 0.000531272846246552*x_13 + 9.04173267206206e-5*x_14 + 0.000370163007372619*x_15 + 0.00362097672231717*x_16 + 0.000299780637126959*x_17 + 4.83749734977189e-5*x_18 + 2.06015167567395e-5*x_19 - 0.00101328576261156*x_2 - 0.0048923220840365*x_20 - 0.00235877807137367*x_21 - 0.000284115594829729*x_22 - 0.000461397135816821*x_23 - 0.000244240676428266*x_24 + 3.18877596430307e-5*x_25 - 6.82997408804742e-5*x_26 - 0.000150002409947167*x_27 + 7.19853275163429e-6*x_28 - 0.00289752509151077*x_29 - 0.0014395996742156*x_3 - 0.000132028774124941*x_30 - 0.00250498256718544*x_31 - 0.000248001142839966*x_32 + 0.000240751303580125*x_33 - 8.20097680976382e-5*x_34 + 0.000361709340127153*x_35 + 0.00136149060615559*x_36 - 0.000917237912637323*x_37 - 0.00115682641913179*x_38 - 0.000621547550925988*x_39 - 0.00474738654023299*x_4 + 0.000273485712835777*x_40 - 8.13927865014799e-6*x_41 + 0.00126501622534349*x_42 - 2.10650809749789e-5*x_43 - 0.000388607813658017*x_44 + 0.00023848716153401*x_45 + 0.000241507958805038*x_46 - 0.000167142044110207*x_47 - 0.000682257908701696*x_48 + 6.23946254144746e-6*x_49 + 0.000130863369207696*x_5 - 0.00164833510118905*x_50 + 0.000201278802499136*x_51 - 0.000426065749601852*x_52 + 0.00162018413734555*x_53 - 0.00129152259936212*x_54 + 0.000991155387187207*x_55 - 4.54109696753994e-5*x_56 - 0.000339142981529929*x_57 + 2.61805686156699e-5*x_58 - 1.07072432334828e-5*x_59 - 0.00138478388575547*x_6 - 0.00214389718470975*x_60 - 0.00225105087382084*x_61 - 1.32795510415955e-5*x_62 - 0.000371082664487689*x_63 - 0.000534022558793352*x_64 + 0.000190756649517476*x_65 + 0.000118909554544375*x_66 - 0.000112539236676676*x_67 + 7.96011515564824e-5*x_68 + 0.000278267540244491*x_69 + 0.000185654148775376*x_7 - 4.41659852479348e-5*x_70 - 0.000124075332893613*x_71 - 0.000270808382444347*x_72 + 0.000103480763623869*x_73 + 0.000115883650487329*x_74 + 3.9878597904091e-5*x_75 - 7.544236970489e-5*x_76 - 0.000192884475186488*x_77 - 0.000112238797159662*x_78 - 3.04276727153611e-6*x_79 - 0.000630142252065351*x_8 - 8.73307659783001e-5*x_80 - 3.81553669780698e-5*x_81 + 8.41930283649153e-6*x_82 - 0.000562033421853586*x_83 + 0.000333660455725342*x_84 - 0.000303076293543567*x_85 - 3.20222315756267e-5*x_86 - 0.0018253870412835*x_87 + 0.00131539426358069*x_88 + 0.00099857655647821*x_89 - 0.00172897048314787*x_9 + 8.70581167028248e-5*x_90 - 0.000252768812227935*x_91 - 0.000952594712388985*x_92 - 0.000502529501323564*x_93 + 0.000101965991801077*x_94 + 5.73926836986499e-5*x_95 - 0.000479618400487027*x_96 + 1.01347865724947e-5*x_97 + 0.00010082837529578*x_98 - 9.61270545721761e-5*x_99 + 1.51335166184539e-6*std::pow(-4.67039966583252*x_109 - 6.09272003173828, 2) - 0.00215800575233685*std::pow(-0.629119873046875*x_117 - 1.04919981956482, 2) - 5.96305462084763e-8*std::pow(-5.42967987060547*x_13 - 9.45328044891357, 2) - 1.5869481588379e-8*std::pow(-7.32359981536865*x_18 - 9.49656009674072, 2) - 2.60041960585646e-6*std::pow(-6.08007955551147*x_18 - 9.70680046081543, 2) - 3.03465969868984e-5*std::pow(-5.23864030838013*x_19 - 8.24680042266846, 2) - 1.80198140687936e-5*std::pow(-4.40183973312378*x_27 - 6.39983987808228, 2) + 3.35609964094439e-8*std::pow(-5.92095994949341*x_4 - 9.2705602645874, 2) - 9.57607121495231e-6*std::pow(-6.3778395652771*x_49 - 9.52264022827148, 2) + 3.52601778732965e-8*std::pow(-5.81791973114014*x_5 - 9.03359985351563, 2) + 2.17045637708616e-8*std::pow(-5.25591993331909*x_57 - 8.28688049316406, 2) - 2.93135261519149e-6*std::pow(-6.50767993927002*x_67 - 9.74536037445068, 2) - 3.28910110969715e-6*std::pow(-4.48536014556885*x_67 - 5.50952005386353, 2) - 1.44553292743147e-6*std::pow(-5.87383985519409*x_69 - 7.69448041915894, 2) - 5.75117972348923e-5*std::pow(-3.67263984680176*x_69 - 4.90823984146118, 2) + 7.86697585941904e-6*std::pow(-5.61768007278442*x_7 - 8.81968021392822, 2) + 2.63950996510618e-8*std::pow(-5.58383989334106*x_7 - 9.16079998016357, 2) + 2.25009873506376e-6*std::pow(-7.80000019073486*x_70 - 9.99882030487061, 2) + 3.84507597319829e-8*std::pow(-3.86879992485046*x_71 - 6.11287975311279, 2) - 3.36734405706334e-8*std::pow(-3.55695986747742*x_75 - 4.39680004119873, 2) - 3.06583290836076e-6*std::pow(-3.24160003662109*x_79 - 4.85735988616943, 2) - 1.1267842585159e-8*std::pow(-8.19999980926514*x_81 - 9.99917984008789, 2) - 3.85757756600842e-6*std::pow(-7.64775991439819*x_81 - 9.46271991729736, 2) - 3.00050033888557e-8*std::pow(-3.7960000038147*x_85 - 6.38800001144409, 2) + 2.13591513099776e-6*std::pow(-7.40000009536743*x_87 - 9.99973964691162, 2) + 4.20213718212757e-6*std::pow(-6.39191961288452*x_90 - 8.79872035980225, 2) + 0.00206033888957271*std::exp(0.97327983379364*x_17) + 0.00412817265203682*std::sin(0.204479992389679*x_1 - 7.40343999862671) - 0.00242656513121488*std::sin(0.409919857978821*x_1 + 4.98423957824707) + 0.00102032012122088*std::sin(0.408479869365692*x_100 - 7.38679981231689) + 0.000964055450894872*std::sin(0.303759932518005*x_101 + 8.27639961242676) - 0.00437632401336418*std::sin(0.158400028944016*x_102 + 8.13687992095947) + 0.00107772109758949*std::sin(0.298319935798645*x_102 + 5.09783983230591) + 0.000896610161343687*std::sin(0.401839852333069*x_103 + 1.99063980579376) + 4.16122227268955e-6*std::sin(0.410399854183197*x_104 + 1.98927986621857) - 0.00456529245271699*std::sin(0.308479934930801*x_105 + 5.12871980667114) + 0.000870474786815662*std::sin(0.448319852352142*x_106 - 1.17631983757019) - 1.50082329666211e-5*std::sin(0.31591984629631*x_107 - 7.4553599357605) - 0.0137632260337366*std::sin(0.316479861736298*x_107 + 1.93535983562469) - 0.00288505170726156*std::sin(0.246559977531433*x_109 + 5.04895973205566) + 0.00197147157906231*std::sin(0.409119844436646*x_109 - 1.185919880867) + 0.00269919213756697*std::sin(0.317759841680527*x_11 - 1.07807981967926) - 0.013278198150117*std::sin(0.369279861450195*x_110 - 7.41311979293823) + 0.0111072558167096*std::sin(0.467359870672226*x_111 + 2.05663967132568) - 9.94137443678001e-6*std::sin(0.309759944677353*x_112 + 1.88231992721558) - 0.00215837072044478*std::sin(0.340159833431244*x_112 - 7.43631982803345) + 0.000778897971262903*std::sin(0.37679985165596*x_112 - 7.41648006439209) + 0.0190303948987381*std::sin(0.350399851799011*x_113 + 1.94639980792999) + 0.00421294701403642*std::sin(0.351679861545563*x_114 + 1.95783984661102) + 0.0269421850280173*std::sin(0.166160017251968*x_115 + 8.14791965484619) + 5.40223198982556e-6*std::sin(0.773439824581146*x_116 - 1.000079870224) - 0.00109571624486858*std::sin(0.297279924154282*x_117 + 5.08855962753296) + 7.88997631019666e-6*std::sin(0.470959842205048*x_117 + 2.05343985557556) + 0.00116961611775693*std::sin(0.511359870433807*x_117 - 7.44767951965332) - 0.00180960602323541*std::sin(0.305519849061966*x_118 - 1.26919984817505) - 0.00167105247493573*std::sin(0.320319831371307*x_118 - 7.46407985687256) - 0.00388157816906963*std::sin(0.388959854841232*x_118 - 7.39264011383057) - 0.00523491393159039*std::sin(0.322239845991135*x_119 + 5.13624000549316) + 0.000880108973475596*std::sin(0.417999863624573*x_119 + 8.20368003845215) + 0.00414191126740536*std::sin(0.327839851379395*x_12 + 5.1300802230835) - 1.73584850231479e-5*std::sin(0.25111997127533*x_120 + 5.06399965286255) - 0.00431352077917718*std::sin(0.349519848823547*x_120 - 7.44911956787109) + 0.0274920241784285*std::sin(0.289759933948517*x_14 + 5.12048006057739) + 0.00101428816667292*std::sin(0.406079858541489*x_15 - 0.976399838924408) + 0.0127410455963603*std::sin(0.228879988193512*x_18 + 5.02151966094971) - 0.00290738434422819*std::sin(0.312959939241409*x_21 - 4.29031991958618) - 0.00721200955883151*std::sin(0.250799983739853*x_23 - 7.52175998687744) - 0.000210594396145533*std::sin(0.365439832210541*x_23 - 1.03543972969055) + 0.00144738699702434*std::sin(0.371919840574265*x_24 + 8.35968017578125) - 6.79506155870563e-7*std::sin(0.868479907512665*x_24 + 1.17119991779327) - 1.71146523004198e-5*std::sin(0.309119910001755*x_26 - 4.26143980026245) + 0.0416861203780182*std::sin(0.316879838705063*x_26 - 4.26823997497559) - 0.00521071495353598*std::sin(0.33815985918045*x_26 + 5.15375995635986) - 0.0314302006509295*std::sin(0.160000026226044*x_27 - 7.64448022842407) - 2.35072365635414e-5*std::sin(0.257519990205765*x_27 + 5.08903980255127) + 0.00185694909771646*std::sin(0.337999850511551*x_28 - 4.25271987915039) + 0.000887539291927771*std::sin(1.42767989635468*x_28 - 3.18928003311157) - 4.50025904613463e-5*std::sin(1.30543982982635*x_29 + 6.19024038314819) + 0.00528415254917931*std::sin(0.294559925794601*x_3 + 8.30103969573975) - 0.00219732770527891*std::sin(0.320479840040207*x_3 + 8.33432006835938) - 3.49683819467616e-5*std::sin(0.207520008087158*x_31 - 7.40839958190918) + 0.00295531906665926*std::sin(0.259199976921082*x_32 - 7.40863990783691) - 0.00840341578387472*std::sin(0.27295994758606*x_32 - 7.44280004501343) + 0.00256187267056413*std::sin(0.272799968719482*x_33 - 1.17695987224579) + 0.00634471990573899*std::sin(0.310799926519394*x_33 - 1.39063990116119) - 0.00610010673152512*std::sin(0.355359852313995*x_34 - 7.4049596786499) - 9.21834208935637e-6*std::sin(0.374639838933945*x_34 - 1.20295989513397) + 0.0215779956333103*std::sin(0.397919833660126*x_34 - 1.2040798664093) + 1.8026236209048e-5*std::sin(0.300959944725037*x_35 - 4.35016012191772) + 0.00377758745646637*std::sin(0.306319922208786*x_35 - 7.54120016098022) + 0.00110220681420169*std::sin(0.306479930877686*x_35 + 8.26095962524414) - 0.00349691000918472*std::sin(0.339599847793579*x_36 - 7.43495988845825) - 0.00147874205046209*std::sin(0.343279838562012*x_36 + 5.15208005905151) - 1.78120662612195e-5*std::sin(0.346159845590591*x_36 - 7.4475998878479) - 0.00128441238721299*std::sin(0.378719836473465*x_37 - 4.22504043579102) - 3.47728197197912e-5*std::sin(0.225599989295006*x_38 + 5.01599979400635) + 6.88621197722821e-5*std::sin(1.33471989631653*x_38 - 3.82351994514465) - 0.00958431636263072*std::sin(0.175280019640923*x_40 + 4.95599985122681) - 0.0022273938681614*std::sin(0.265359967947006*x_40 + 5.07607984542847) + 1.78734670269987e-5*std::sin(0.381999850273132*x_40 + 5.16951990127563) - 0.0200018919172194*std::sin(0.263679951429367*x_41 + 5.06279993057251) - 0.000852530149477948*std::sin(0.300799936056137*x_41 + 1.88895988464355) + 0.00267558939654209*std::sin(0.338959842920303*x_41 + 1.93567979335785) + 0.00688637878009063*std::sin(0.206640005111694*x_42 - 7.60008001327515) + 0.0023135622378581*std::sin(0.343759834766388*x_42 + 8.17296028137207) - 0.000933655465949292*std::sin(0.303439915180206*x_43 - 7.49440002441406) - 0.00196811949872997*std::sin(0.371759831905365*x_43 + 5.17224025726318) - 9.78399382731216e-6*std::sin(0.373599827289581*x_45 - 1.22919988632202) - 0.00792799289424081*std::sin(0.223279997706413*x_46 + 5.03991985321045) - 0.00358203072193625*std::sin(0.366639852523804*x_47 - 7.4270396232605) - 0.00310035961599128*std::sin(0.34215983748436*x_49 - 4.2454400062561) - 1.87503457983375e-5*std::sin(1.93639981746674*x_5 + 7.80280017852783) + 0.00374872901632273*std::sin(0.225919991731644*x_50 - 7.57376003265381) - 0.00191834812416759*std::sin(0.245119974017143*x_50 - 7.54640007019043) - 0.000611819274120013*std::sin(0.443919867277145*x_50 - 1.38655984401703) + 2.19455341771114e-6*std::sin(0.581999838352203*x_50 + 8.38016033172607) + 0.00133174553584882*std::sin(0.329439848661423*x_51 + 1.94511985778809) + 0.00183633758657707*std::sin(0.225359991192818*x_55 - 7.57776021957397) + 0.00501277739849751*std::sin(0.227199986577034*x_55 + 5.01903963088989) + 0.00378327637155158*std::sin(0.353759855031967*x_56 + 5.14152002334595) - 0.0128740433775997*std::sin(0.353679835796356*x_57 - 4.23112010955811) - 0.0112569117425573*std::sin(0.291439920663834*x_58 - 4.54112005233765) - 0.0194833419481637*std::sin(0.136720046401024*x_64 + 4.91695976257324) + 4.77651976042812e-5*std::sin(0.158240035176277*x_65 - 7.64480018615723) + 0.00684631019263313*std::sin(0.173920020461082*x_69 + 4.95703983306885) + 2.6831075681513e-5*std::sin(0.192959994077682*x_69 + 4.99343967437744) - 0.000400687240256579*std::sin(1.62239992618561*x_7 + 2.00263977050781) - 2.11982929403618e-5*std::sin(0.223359987139702*x_70 - 7.56512022018433) + 0.0015138887815103*std::sin(0.262639969587326*x_74 - 7.51015996932983) - 0.00358154625486112*std::sin(0.30159991979599*x_74 - 7.46799993515015) - 2.01327365484384e-5*std::sin(0.254399985074997*x_77 + 5.06759977340698) + 0.0167050958623861*std::sin(0.146000042557716*x_79 - 7.65496015548706) + 0.00610968952492835*std::sin(0.254399985074997*x_8 + 5.06679964065552) + 2.13749484621987e-5*std::sin(0.325119823217392*x_8 + 5.11800003051758) - 6.83881726303383e-5*std::sin(0.146640032529831*x_82 + 4.93063974380493) - 0.000827231166599005*std::sin(0.328719854354858*x_82 - 7.48216009140015) - 0.00169568191453563*std::sin(0.171040013432503*x_83 + 4.96776008605957) - 0.00392282761278254*std::sin(0.281919926404953*x_84 - 7.49887990951538) - 0.0015996874563993*std::sin(0.23479999601841*x_85 - 7.55768013000488) + 0.00041197961626468*std::sin(0.519279837608337*x_9 - 0.845999836921692) - 0.0148530725864925*std::sin(0.183520004153252*x_91 - 7.36463975906372) - 0.0122584723611661*std::sin(0.327599853277206*x_92 - 1.00311982631683) - 0.00856832972031545*std::sin(0.338879853487015*x_92 + 5.19623994827271) - 0.000488058944839446*std::sin(0.329279839992523*x_94 - 1.22063982486725) - 0.00544334713064556*std::sin(0.386319845914841*x_94 + 2.00543975830078) - 0.000791635957099536*std::sin(0.337919861078262*x_95 - 7.43951988220215) - 0.00236406180037756*std::sin(0.377039849758148*x_95 - 7.42439985275269) + 0.00353998140046142*std::sin(0.355519831180573*x_96 + 1.9670398235321) - 0.000946860143053997*std::sin(0.397999823093414*x_96 + 1.99415981769562) + 0.00204841794731267*std::sin(0.26463994383812*x_97 + 5.07655954360962) - 1.12672202056193e-5*std::sin(0.381359845399857*x_97 + 1.97151982784271) + 0.0031910582263586*std::sin(0.273999959230423*x_98 - 4.30663967132568) - 0.00413846477167988*std::sin(0.390079826116562*x_98 + 1.9676798582077) - 0.0452592066184593);
}

inline float score_8(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.000246328483265151*x_1 - 0.00396496598030856*x_10 - 0.00213492632793157*x_100 + 0.00141322044406782*x_101 + 0.00138856360232009*x_102 + 0.000423684111226867*x_103 + 0.000502238416903567*x_104 + 0.000252673703547537*x_105 + 7.06956071971689e-5*x_106 + 0.000480031016944318*x_107 + 0.000217958427395688*x_108 + 9.41859669261899e-6*x_109 - 0.000334535472740608*x_11 - 0.000778495509942123*x_110 + 0.00389926095244659*x_111 + 0.000185278002979274*x_112 + 0.00308804466805446*x_113 + 0.000783105196269445*x_114 + 0.00135762887848498*x_115 + 0.00035888381532257*x_116 - 8.48947204161439e-5*x_117 + 0.000210731639996243*x_118 - 0.000521792448135832*x_119 + 0.00509774862008047*x_12 - 6.94347166804735e-5*x_120 - 0.000849238775406012*x_13 - 0.000754164492806389*x_14 - 0.0016217443556698*x_15 - 0.006235312948901*x_16 - 0.0013895045785675*x_17 - 3.72677173504526e-5*x_18 - 5.00807587983231e-5*x_19 - 0.00217845332315706*x_2 + 0.012673195640741*x_20 + 0.00193794917330635*x_21 + 0.0020963181071769*x_22 + 0.00165285746152826*x_23 + 0.000543496044891691*x_24 + 0.000710181315779895*x_25 + 0.00031903098315268*x_26 + 8.01671536224839e-5*x_27 + 0.000366370029236248*x_28 + 0.0029975328646489*x_29 - 0.00156149152306842*x_3 + 5.74261974519385e-5*x_30 + 0.0151782558771524*x_31 + 0.000875304882694992*x_32 - 0.00179677427123907*x_33 + 9.77427091196103e-5*x_34 + 0.000263920204091148*x_35 - 0.000746325496358062*x_36 + 0.000868674866981391*x_37 + 0.000851997722782864*x_38 + 0.00116519414218388*x_39 + 0.00651354132077411*x_4 - 0.00219658599384298*x_40 - 0.000236550059103796*x_41 - 0.000670354917060132*x_42 + 4.95565274682587e-5*x_43 + 0.000162301527904895*x_44 - 0.00241688751488626*x_45 - 8.30890016753013e-5*x_46 - 0.000836074332732933*x_47 + 0.000225202637061397*x_48 - 7.6345192619029e-6*x_49 - 0.000953425149601555*x_5 + 0.0009589647912759*x_50 + 0.000376797127071103*x_51 + 0.00196952483701066*x_52 - 0.000919218923673209*x_53 + 0.000930926267019103*x_54 - 3.56749598049638e-6*x_55 + 0.000716989370019441*x_56 + 0.00325183498775852*x_57 + 0.000842253590964622*x_58 + 0.000109249136746449*x_59 + 0.00191886514219098*x_6 + 0.00185782097769797*x_60 + 0.00166895664267812*x_61 - 0.00022058666563038*x_62 + 0.00225177000325724*x_63 - 0.00137947314109916*x_64 - 0.00115344563150822*x_65 + 2.11657067031096e-5*x_66 + 7.45036437426391e-5*x_67 + 0.00169994574512693*x_68 - 0.00185199178356565*x_69 - 0.000325178168381532*x_7 + 1.00320658448352e-5*x_70 + 0.00077838325196073*x_71 + 0.0011617134350433*x_72 + 0.000193269454153908*x_73 - 3.65487863247326e-5*x_74 - 4.61353014940045e-5*x_75 + 0.000115537568029746*x_76 + 0.00207079051901337*x_77 + 0.000816204733821948*x_78 - 0.000346351898207935*x_79 + 0.00127579001371624*x_8 + 0.000300600715659603*x_80 + 0.000103833900982962*x_81 + 9.934932115566e-5*x_82 + 0.00119467564872181*x_83 - 0.000171156658248685*x_84 + 0.00139670172377396*x_85 + 0.000779141653206913*x_86 + 0.00107581621329679*x_87 - 0.000902500227488015*x_88 - 0.0012971379160912*x_89 - 0.000463292029866588*x_9 - 5.96724489655356e-5*x_90 + 0.00354934355100815*x_91 + 0.00634854580383193*x_92 + 0.00078895821438667*x_93 - 1.22714992195945e-5*x_94 - 6.15824904691507e-5*x_95 + 0.000331334337511181*x_96 + 0.000151167432399434*x_97 - 3.56787702963014e-5*x_98 - 0.000337691529349493*x_99 + 1.34070601344407e-6*std::pow(-4.67039966583252*x_109 - 6.09272003173828, 2) + 0.0012554798683648*std::pow(-0.629119873046875*x_117 - 1.04919981956482, 2) + 2.62806472537024e-5*std::pow(-5.42967987060547*x_13 - 9.45328044891357, 2) + 6.99407056016586e-6*std::pow(-7.32359981536865*x_18 - 9.49656009674072, 2) - 2.30375945720261e-6*std::pow(-6.08007955551147*x_18 - 9.70680046081543, 2) + 1.76549768457168e-5*std::pow(-5.23864030838013*x_19 - 8.24680042266846, 2) + 8.23612172307919e-5*std::pow(-4.40183973312378*x_27 - 6.39983987808228, 2) - 1.47911559460777e-5*std::pow(-5.92095994949341*x_4 - 9.2705602645874, 2) + 5.57114577446391e-6*std::pow(-6.3778395652771*x_49 - 9.52264022827148, 2) - 1.55400269779717e-5*std::pow(-5.81791973114014*x_5 - 9.03359985351563, 2) - 9.56573468677065e-6*std::pow(-5.25591993331909*x_57 - 8.28688049316406, 2) + 1.33980166830878e-5*std::pow(-6.50767993927002*x_67 - 9.74536037445068, 2) - 2.91387504158767e-6*std::pow(-4.48536014556885*x_67 - 5.50952005386353, 2) - 1.28062415187461e-6*std::pow(-5.87383985519409*x_69 - 7.69448041915894, 2) + 3.34590876524294e-5*std::pow(-3.67263984680176*x_69 - 4.90823984146118, 2) - 3.59567365808223e-5*std::pow(-5.61768007278442*x_7 - 8.81968021392822, 2) - 1.16329691284511e-5*std::pow(-5.58383989334106*x_7 - 9.16079998016357, 2) - 1.02842831786068e-5*std::pow(-7.80000019073486*x_70 - 9.99882030487061, 2) - 1.69461948180087e-5*std::pow(-3.86879992485046*x_71 - 6.11287975311279, 2) + 1.48407128514535e-5*std::pow(-3.55695986747742*x_75 - 4.39680004119873, 2) - 2.71607764413577e-6*std::pow(-3.24160003662109*x_79 - 4.85735988616943, 2) + 4.96601515698871e-6*std::pow(-8.19999980926514*x_81 - 9.99917984008789, 2) + 2.56738603088155e-5*std::pow(-7.64775991439819*x_81 - 9.46271991729736, 2) + 1.32239424262824e-5*std::pow(-3.7960000038147*x_85 - 6.38800001144409, 2) - 9.76239651635979e-6*std::pow(-7.40000009536743*x_87 - 9.99973964691162, 2) - 1.92062544024888e-5*std::pow(-6.39191961288452*x_90 - 8.79872035980225, 2) - 0.00119865945448316*std::exp(0.97327983379364*x_17) + 0.00365722392135355*std::sin(0.204479992389679*x_1 - 7.40343999862671) + 0.0161498487439403*std::sin(0.409919857978821*x_1 + 4.98423957824707) + 0.000903920322452167*std::sin(0.408479869365692*x_100 - 7.38679981231689) + 0.000854074418322695*std::sin(0.303759932518005*x_101 + 8.27639961242676) + 0.0291263440495085*std::sin(0.158400028944016*x_102 + 8.13687992095947) + 0.000954772900960669*std::sin(0.298319935798645*x_102 + 5.09783983230591) + 0.000794323398411377*std::sin(0.401839852333069*x_103 + 1.99063980579376) - 0.00183395292591263*std::sin(0.410399854183197*x_104 + 1.98927986621857) + 0.0303840113891024*std::sin(0.308479934930801*x_105 + 5.12871980667114) - 0.00579338916629382*std::sin(0.448319852352142*x_106 - 1.17631983757019) + 0.00661449712565422*std::sin(0.31591984629631*x_107 - 7.4553599357605) + 0.00800713955020702*std::sin(0.316479861736298*x_107 + 1.93535983562469) + 0.0192012767724037*std::sin(0.246559977531433*x_109 + 5.04895973205566) - 0.00901079214067352*std::sin(0.409119844436646*x_109 - 1.185919880867) - 0.0123369058715644*std::sin(0.317759841680527*x_11 - 1.07807981967926) + 0.0077249610885321*std::sin(0.369279861450195*x_110 - 7.41311979293823) - 0.00646195500431641*std::sin(0.467359870672226*x_111 + 2.05663967132568) + 0.00438140804339725*std::sin(0.309759944677353*x_112 + 1.88231992721558) + 0.00986503185285277*std::sin(0.340159833431244*x_112 - 7.43631982803345) + 0.000690040008716919*std::sin(0.37679985165596*x_112 - 7.41648006439209) - 0.0110714615364326*std::sin(0.350399851799011*x_113 + 1.94639980792999) - 0.0280389988991803*std::sin(0.351679861545563*x_114 + 1.95783984661102) - 0.0156743654996316*std::sin(0.166160017251968*x_115 + 8.14791965484619) - 0.0023808964085439*std::sin(0.773439824581146*x_116 - 1.000079870224) - 0.000970715132220032*std::sin(0.297279924154282*x_117 + 5.08855962753296) - 0.00347730647181078*std::sin(0.470959842205048*x_117 + 2.05343985557556) - 0.00534583801938547*std::sin(0.511359870433807*x_117 - 7.44767951965332) + 0.0120437169336327*std::sin(0.305519849061966*x_118 - 1.26919984817505) - 0.00148041605821807*std::sin(0.320319831371307*x_118 - 7.46407985687256) + 0.0177411099559945*std::sin(0.388959854841232*x_118 - 7.39264011383057) + 0.0348406342344512*std::sin(0.322239845991135*x_119 + 5.13624000549316) + 0.000779704693214501*std::sin(0.417999863624573*x_119 + 8.20368003845215) - 0.0275662250392303*std::sin(0.327839851379395*x_12 + 5.1300802230835) + 0.00765031096909826*std::sin(0.25111997127533*x_120 + 5.06399965286255) + 0.0287083611486158*std::sin(0.349519848823547*x_120 - 7.44911956787109) - 0.0159942497183982*std::sin(0.289759933948517*x_14 + 5.12048006057739) + 0.000898576503207005*std::sin(0.406079858541489*x_15 - 0.976399838924408) - 0.0582341205132928*std::sin(0.228879988193512*x_18 + 5.02151966094971) + 0.0132884674966246*std::sin(0.312959939241409*x_21 - 4.29031991958618) + 0.0329631528759296*std::sin(0.250799983739853*x_23 - 7.52175998687744) - 0.000186569440816977*std::sin(0.365439832210541*x_23 - 1.03543972969055) - 0.00963299141457048*std::sin(0.371919840574265*x_24 + 8.35968017578125) + 0.000299475063111448*std::sin(0.868479907512665*x_24 + 1.17119991779327) + 0.00754284789551639*std::sin(0.309119910001755*x_26 - 4.26143980026245) - 0.0242520599716474*std::sin(0.316879838705063*x_26 - 4.26823997497559) + 0.0346795794866064*std::sin(0.33815985918045*x_26 + 5.15375995635986) + 0.209181686481283*std::sin(0.160000026226044*x_27 - 7.64448022842407) + 0.0103602168907846*std::sin(0.257519990205765*x_27 + 5.08903980255127) - 0.00848735660865715*std::sin(0.337999850511551*x_28 - 4.25271987915039) - 0.000516350668755832*std::sin(1.42767989635468*x_28 - 3.18928003311157) - 3.98686208719753e-5*std::sin(1.30543982982635*x_29 + 6.19024038314819) - 0.0241517051353647*std::sin(0.294559925794601*x_3 + 8.30103969573975) - 0.00194665294408991*std::sin(0.320479840040207*x_3 + 8.33432006835938) + 0.0154114253416807*std::sin(0.207520008087158*x_31 - 7.40839958190918) + 0.00261817140338976*std::sin(0.259199976921082*x_32 - 7.40863990783691) + 0.0384085845843973*std::sin(0.27295994758606*x_32 - 7.44280004501343) + 0.00226961001973264*std::sin(0.272799968719482*x_33 - 1.17695987224579) - 0.00369121727476531*std::sin(0.310799926519394*x_33 - 1.39063990116119) + 0.0278810987576296*std::sin(0.355359852313995*x_34 - 7.4049596786499) + 0.00406274991792538*std::sin(0.374639838933945*x_34 - 1.20295989513397) - 0.012553599121758*std::sin(0.397919833660126*x_34 - 1.2040798664093) - 0.00794460532804185*std::sin(0.300959944725037*x_35 - 4.35016012191772) - 0.0251414912602796*std::sin(0.306319922208786*x_35 - 7.54120016098022) + 0.000976465246720824*std::sin(0.306479930877686*x_35 + 8.26095962524414) + 0.0232734604948476*std::sin(0.339599847793579*x_36 - 7.43495988845825) - 0.00131004472349116*std::sin(0.343279838562012*x_36 + 5.15208005905151) + 0.00785021536838015*std::sin(0.346159845590591*x_36 - 7.4475998878479) + 0.00854832434188484*std::sin(0.378719836473465*x_37 - 4.22504043579102) + 0.0153252362619231*std::sin(0.225599989295006*x_38 + 5.01599979400635) - 0.000314740650701811*std::sin(1.33471989631653*x_38 - 3.82351994514465) + 0.0438059992704525*std::sin(0.175280019640923*x_40 + 4.95599985122681) - 0.00197328910962501*std::sin(0.265359967947006*x_40 + 5.07607984542847) - 0.00787727619490536*std::sin(0.381999850273132*x_40 + 5.16951990127563) + 0.011636656947779*std::sin(0.263679951429367*x_41 + 5.06279993057251) - 0.000755272106850354*std::sin(0.300799936056137*x_41 + 1.88895988464355) - 0.0178072137851135*std::sin(0.338959842920303*x_41 + 1.93567979335785) - 0.045831852712836*std::sin(0.206640005111694*x_42 - 7.60008001327515) - 0.0105743489539759*std::sin(0.343759834766388*x_42 + 8.17296028137207) - 0.000827142513694891*std::sin(0.303439915180206*x_43 - 7.49440002441406) + 0.0130986932127287*std::sin(0.371759831905365*x_43 + 5.17224025726318) + 0.00431204654086234*std::sin(0.373599827289581*x_45 - 1.22919988632202) + 0.0527642487061208*std::sin(0.223279997706413*x_46 + 5.03991985321045) + 0.0238399759442909*std::sin(0.366639852523804*x_47 - 7.4270396232605) + 0.0206342447626831*std::sin(0.34215983748436*x_49 - 4.2454400062561) - 1.66112754885619e-5*std::sin(1.93639981746674*x_5 + 7.80280017852783) + 0.00332106784012612*std::sin(0.225919991731644*x_50 - 7.57376003265381) + 0.0127674430185261*std::sin(0.245119974017143*x_50 - 7.54640007019043) + 0.00279637625279656*std::sin(0.443919867277145*x_50 - 1.38655984401703) - 0.00096719362671334*std::sin(0.581999838352203*x_50 + 8.38016033172607) + 0.00117981781320581*std::sin(0.329439848661423*x_51 + 1.94511985778809) + 0.00162684517228142*std::sin(0.225359991192818*x_55 - 7.57776021957397) - 0.0333622187722801*std::sin(0.227199986577034*x_55 + 5.01903963088989) - 0.0172918125510017*std::sin(0.353759855031967*x_56 + 5.14152002334595) + 0.00748983280861458*std::sin(0.353679835796356*x_57 - 4.23112010955811) + 0.00654902150165075*std::sin(0.291439920663834*x_58 - 4.54112005233765) + 0.0890504059835699*std::sin(0.136720046401024*x_64 + 4.91695976257324) - 0.0210512965092221*std::sin(0.158240035176277*x_65 - 7.64480018615723) - 0.0312916902944822*std::sin(0.173920020461082*x_69 + 4.95703983306885) - 0.0118251144800516*std::sin(0.192959994077682*x_69 + 4.99343967437744) + 0.000233110946580211*std::sin(1.62239992618561*x_7 + 2.00263977050781) + 0.00934260868915379*std::sin(0.223359987139702*x_70 - 7.56512022018433) - 0.00691936788699488*std::sin(0.262639969587326*x_74 - 7.51015996932983) + 0.0238367516047155*std::sin(0.30159991979599*x_74 - 7.46799993515015) + 0.00887299179905921*std::sin(0.254399985074997*x_77 + 5.06759977340698) - 0.0763521767722266*std::sin(0.146000042557716*x_79 - 7.65496015548706) - 0.027924897796074*std::sin(0.254399985074997*x_8 + 5.06679964065552) - 0.00942046511928915*std::sin(0.325119823217392*x_8 + 5.11800003051758) + 0.0301403484539564*std::sin(0.146640032529831*x_82 + 4.93063974380493) - 0.000732859273577712*std::sin(0.328719854354858*x_82 - 7.48216009140015) - 0.00150223573081094*std::sin(0.171040013432503*x_83 + 4.96776008605957) + 0.0179296443316167*std::sin(0.281919926404953*x_84 - 7.49887990951538) - 0.00141719247845561*std::sin(0.23479999601841*x_85 - 7.55768013000488) + 0.000364980303565996*std::sin(0.519279837608337*x_9 - 0.845999836921692) + 0.0678873340851696*std::sin(0.183520004153252*x_91 - 7.36463975906372) + 0.00713170724854862*std::sin(0.327599853277206*x_92 - 1.00311982631683) + 0.0391623388957196*std::sin(0.338879853487015*x_92 + 5.19623994827271) - 0.000432380377118363*std::sin(0.329279839992523*x_94 - 1.22063982486725) + 0.036227848035002*std::sin(0.386319845914841*x_94 + 2.00543975830078) - 0.000701324824163921*std::sin(0.337919861078262*x_95 - 7.43951988220215) + 0.0108051618482071*std::sin(0.377039849758148*x_95 - 7.42439985275269) - 0.0161798105132105*std::sin(0.355519831180573*x_96 + 1.9670398235321) + 0.00630176701019843*std::sin(0.397999823093414*x_96 + 1.99415981769562) + 0.00181473105640229*std::sin(0.26463994383812*x_97 + 5.07655954360962) + 0.00496574085902936*std::sin(0.381359845399857*x_97 + 1.97151982784271) - 0.0145850250604068*std::sin(0.273999959230423*x_98 - 4.30663967132568) + 0.0275432871077702*std::sin(0.390079826116562*x_98 + 1.9676798582077) + 0.648388216292162);
}

inline float score_9(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (2.88242240838214e-5*x_1 + 4.21550859460332e-5*x_10 - 0.000908176806427429*x_100 + 7.95694031459458e-5*x_101 + 1.32585153094783e-5*x_102 + 9.421306425543e-5*x_103 + 1.67641827916829e-5*x_104 - 4.16973822538885e-5*x_105 + 0.000404354654913954*x_106 - 1.96307784023667e-5*x_107 + 0.000712177306364665*x_108 + 7.60736582307729e-6*x_109 - 0.000219970921834394*x_11 + 0.000183565819190387*x_110 + 7.3360947373789e-6*x_111 - 1.61354960419404e-6*x_112 + 7.24388249940459e-5*x_113 + 0.0018786766097368*x_114 + 3.57495622824072e-5*x_115 - 4.2125987225831e-6*x_116 + 0.000323975601567367*x_118 - 4.93775706327733e-5*x_119 - 6.94622811937308e-5*x_12 + 0.00012178744850585*x_120 + 0.00032606904074991*x_13 - 0.000523087481063389*x_14 + 8.57282648834744e-5*x_15 + 0.000717239850337133*x_16 - 1.8932361423398e-5*x_17 + 3.20162960808922e-7*x_18 - 7.48079326877609e-5*x_19 + 0.000826878243621542*x_2 + 0.00284556706303541*x_20 - 6.3202689459448e-5*x_21 + 0.00129059764113975*x_22 - 0.000516642739333339*x_23 - 2.58617859458411e-5*x_24 + 6.66259868846434e-5*x_25 - 3.17805888205857e-6*x_26 - 1.06965082172796e-5*x_27 + 0.0007113192297091*x_28 - 3.5135075763051e-5*x_29 - 1.99912942875929e-5*x_3 + 0.000130565576144699*x_30 + 0.000857353430435205*x_31 - 0.00034069326175982*x_32 - 9.90309826298968e-5*x_33 - 0.000119181873425685*x_34 - 6.46267230855033e-6*x_35 + 8.43786017452684e-6*x_36 - 5.9737081272278e-7*x_37 + 6.81710886138187e-5*x_38 + 0.000747220836378553*x_39 + 2.07551002172272e-5*x_4 - 4.23323739895596e-7*x_40 - 0.000451630124681155*x_41 + 0.00010285438766865*x_42 - 0.000108548446130396*x_43 - 7.51012903141637e-6*x_44 + 4.57162194458468e-5*x_45 - 2.97519326502581e-6*x_46 - 0.000402156368211799*x_47 + 0.00016524806486504*x_48 + 2.18956193171528e-5*x_49 + 1.27300423997798e-5*x_5 - 1.12589146068839e-5*x_50 + 0.000541001202661972*x_51 + 0.000113631761524168*x_52 + 5.82797874280707e-5*x_53 + 5.14756139233762e-5*x_54 - 0.000127605162148877*x_55 + 0.000875768650706252*x_56 + 0.000271303829566614*x_57 + 0.00106158019370391*x_58 - 0.000123272018648636*x_59 - 7.1685351183477e-5*x_6 + 0.000313453576337491*x_60 + 0.000460569698993526*x_61 - 9.58207587807493e-5*x_62 - 0.000421295414763831*x_63 - 1.06411911023514e-5*x_64 + 1.73601397228662e-5*x_65 + 0.000958218687314734*x_66 + 3.90622744274981e-5*x_67 - 1.47949818278314e-5*x_68 + 0.000242166089330482*x_7 + 4.57985352652656e-6*x_70 + 1.63422344010671e-6*x_71 + 0.000407743452346879*x_72 + 0.000312139059774094*x_73 + 5.04539193308565e-5*x_74 + 7.84410888211193e-7*x_75 - 0.000444425314297493*x_76 - 1.17183981325254e-6*x_77 + 3.80389966908434e-5*x_78 - 2.1080207276911e-6*x_79 - 2.35635084083422e-5*x_8 + 0.000526445054374799*x_80 - 5.45936637491803e-6*x_81 - 1.23297154687968e-6*x_82 - 0.000118491261889267*x_83 + 2.49759884431634e-5*x_84 - 2.46437178708093e-5*x_85 + 6.81050167011416e-5*x_86 + 1.01725124519327e-5*x_87 + 3.46534793221133e-5*x_88 - 0.000538402202951862*x_89 - 0.0016624631620614*x_9 + 2.70222797323336e-5*x_90 + 0.00255571427341054*x_91 - 2.01191426895915e-5*x_92 - 0.000301659311443448*x_93 + 9.92200773172706e-6*x_94 - 2.60484538841027e-5*x_95 + 8.09399377649746e-5*x_96 - 2.0859972198258e-6*x_97 + 4.08260359975414e-5*x_98 + 0.000148000177324457*x_99 + 3.03567612223611e-6*std::pow(-4.67039966583252*x_109 - 6.09272003173828, 2) - 1.47402081465099e-5*std::pow(-0.629119873046875*x_117 - 1.04919981956482, 2) + 4.28394408215757e-5*std::pow(-5.42967987060547*x_13 - 9.45328044891357, 2) + 1.1400863493647e-5*std::pow(-7.32359981536865*x_18 - 9.49656009674072, 2) - 5.21625733417906e-6*std::pow(-6.08007955551147*x_18 - 9.70680046081543, 2) - 2.0728172556572e-7*std::pow(-5.23864030838013*x_19 - 8.24680042266846, 2) - 1.47672583223006e-6*std::pow(-4.40183973312378*x_27 - 6.39983987808228, 2) - 2.41107018300482e-5*std::pow(-5.92095994949341*x_4 - 9.2705602645874, 2) - 6.54091319179049e-8*std::pow(-6.3778395652771*x_49 - 9.52264022827148, 2) - 2.53314181976519e-5*std::pow(-5.81791973114014*x_5 - 9.03359985351563, 2) - 1.55928703381183e-5*std::pow(-5.25591993331909*x_57 - 8.28688049316406, 2) - 2.40224683434717e-7*std::pow(-6.50767993927002*x_67 - 9.74536037445068, 2) - 6.59770359663304e-6*std::pow(-4.48536014556885*x_67 - 5.50952005386353, 2) - 2.89963655001298e-6*std::pow(-5.87383985519409*x_69 - 7.69448041915894, 2) - 3.92832994631359e-7*std::pow(-3.67263984680176*x_69 - 4.90823984146118, 2) + 6.4469957507792e-7*std::pow(-5.61768007278442*x_7 - 8.81968021392822, 2) - 1.89626186808351e-5*std::pow(-5.58383989334106*x_7 - 9.16079998016357, 2) + 1.84395849726949e-7*std::pow(-7.80000019073486*x_70 - 9.99882030487061, 2) - 2.76235780286842e-5*std::pow(-3.86879992485046*x_71 - 6.11287975311279, 2) + 2.41914833303915e-5*std::pow(-3.55695986747742*x_75 - 4.39680004119873, 2) - 6.14984341665015e-6*std::pow(-3.24160003662109*x_79 - 4.85735988616943, 2) + 8.09497994410678e-6*std::pow(-8.19999980926514*x_81 - 9.99917984008789, 2) + 2.15560253722e-5*std::pow(-3.7960000038147*x_85 - 6.38800001144409, 2) + 1.75038490261548e-7*std::pow(-7.40000009536743*x_87 - 9.99973964691162, 2) + 3.44365624624763e-7*std::pow(-6.39191961288452*x_90 - 8.79872035980225, 2) + 1.40730969098502e-5*std::exp(0.97327983379364*x_17) + 0.00828082161219221*std::sin(0.204479992389679*x_1 - 7.40343999862671) + 0.00204668981249892*std::sin(0.408479869365692*x_100 - 7.38679981231689) + 0.00193382687354006*std::sin(0.303759932518005*x_101 + 8.27639961242676) + 0.00216183210080405*std::sin(0.298319935798645*x_102 + 5.09783983230591) + 0.00179853640523069*std::sin(0.401839852333069*x_103 + 1.99063980579376) - 0.00298948184497707*std::sin(0.410399854183197*x_104 + 1.98927986621857) + 0.0107821301143573*std::sin(0.31591984629631*x_107 - 7.4553599357605) - 9.40093956121552e-5*std::sin(0.316479861736298*x_107 + 1.93535983562469) + 0.000161562322296681*std::sin(0.409119844436646*x_109 - 1.185919880867) + 0.000221199105633407*std::sin(0.317759841680527*x_11 - 1.07807981967926) - 9.0696423923515e-5*std::sin(0.369279861450195*x_110 - 7.41311979293823) + 7.58678527606055e-5*std::sin(0.467359870672226*x_111 + 2.05663967132568) + 0.00714202617531993*std::sin(0.309759944677353*x_112 + 1.88231992721558) - 0.000176878728395403*std::sin(0.340159833431244*x_112 - 7.43631982803345) + 0.00156241409887354*std::sin(0.37679985165596*x_112 - 7.41648006439209) + 0.000129986670153182*std::sin(0.350399851799011*x_113 + 1.94639980792999) + 0.000184027968787716*std::sin(0.166160017251968*x_115 + 8.14791965484619) - 0.00388104104938851*std::sin(0.773439824581146*x_116 - 1.000079870224) - 0.00219792909021405*std::sin(0.297279924154282*x_117 + 5.08855962753296) - 0.00566827229860688*std::sin(0.470959842205048*x_117 + 2.05343985557556) + 9.58501751622083e-5*std::sin(0.511359870433807*x_117 - 7.44767951965332) - 0.00335201277076617*std::sin(0.320319831371307*x_118 - 7.46407985687256) - 0.000318095776693501*std::sin(0.388959854841232*x_118 - 7.39264011383057) + 0.00176543619246282*std::sin(0.417999863624573*x_119 + 8.20368003845215) + 0.0124705849465395*std::sin(0.25111997127533*x_120 + 5.06399965286255) + 0.000187783632328179*std::sin(0.289759933948517*x_14 + 5.12048006057739) + 0.00203459013940026*std::sin(0.406079858541489*x_15 - 0.976399838924408) + 0.00104413014973056*std::sin(0.228879988193512*x_18 + 5.02151966094971) - 0.000238260480876896*std::sin(0.312959939241409*x_21 - 4.29031991958618) - 0.000591025011532187*std::sin(0.250799983739853*x_23 - 7.52175998687744) - 0.000422437425466706*std::sin(0.365439832210541*x_23 - 1.03543972969055) + 0.000488166981575888*std::sin(0.868479907512665*x_24 + 1.17119991779327) + 0.012295412016559*std::sin(0.309119910001755*x_26 - 4.26143980026245) + 0.000284736076596214*std::sin(0.316879838705063*x_26 - 4.26823997497559) + 0.0168879363627138*std::sin(0.257519990205765*x_27 + 5.08903980255127) + 0.000152177191799282*std::sin(0.337999850511551*x_28 - 4.25271987915039) + 6.06231651007167e-6*std::sin(1.42767989635468*x_28 - 3.18928003311157) - 9.02720053418996e-5*std::sin(1.30543982982635*x_29 + 6.19024038314819) + 0.000433036908207112*std::sin(0.294559925794601*x_3 + 8.30103969573975) - 0.00440768356477645*std::sin(0.320479840040207*x_3 + 8.33432006835938) + 0.0251217878131998*std::sin(0.207520008087158*x_31 - 7.40839958190918) + 0.00592816048670859*std::sin(0.259199976921082*x_32 - 7.40863990783691) - 0.000688660888488757*std::sin(0.27295994758606*x_32 - 7.44280004501343) + 0.00513893491533715*std::sin(0.272799968719482*x_33 - 1.17695987224579) + 4.33374618861066e-5*std::sin(0.310799926519394*x_33 - 1.39063990116119) - 0.000499904447149865*std::sin(0.355359852313995*x_34 - 7.4049596786499) + 0.00662258935260076*std::sin(0.374639838933945*x_34 - 1.20295989513397) + 0.000147387997772968*std::sin(0.397919833660126*x_34 - 1.2040798664093) - 0.0129503069888614*std::sin(0.300959944725037*x_35 - 4.35016012191772) + 0.00221094871205146*std::sin(0.306479930877686*x_35 + 8.26095962524414) - 0.00296625169596097*std::sin(0.343279838562012*x_36 + 5.15208005905151) + 0.0127964442223914*std::sin(0.346159845590591*x_36 - 7.4475998878479) + 0.0249812931006419*std::sin(0.225599989295006*x_38 + 5.01599979400635) + 5.64325862307065e-6*std::sin(1.33471989631653*x_38 - 3.82351994514465) - 0.000785435826525682*std::sin(0.175280019640923*x_40 + 4.95599985122681) - 0.00446799415553388*std::sin(0.265359967947006*x_40 + 5.07607984542847) - 0.0128405554143768*std::sin(0.381999850273132*x_40 + 5.16951990127563) - 0.000136622457963581*std::sin(0.263679951429367*x_41 + 5.06279993057251) - 0.00171011502713174*std::sin(0.300799936056137*x_41 + 1.88895988464355) + 0.000189596691068731*std::sin(0.343759834766388*x_42 + 8.17296028137207) - 0.00187284665939532*std::sin(0.303439915180206*x_43 - 7.49440002441406) + 0.00702896168514756*std::sin(0.373599827289581*x_45 - 1.22919988632202) - 3.76118640886644e-5*std::sin(1.93639981746674*x_5 + 7.80280017852783) + 0.00751968458521256*std::sin(0.225919991731644*x_50 - 7.57376003265381) - 5.01386597719626e-5*std::sin(0.443919867277145*x_50 - 1.38655984401703) - 0.00157659869388316*std::sin(0.581999838352203*x_50 + 8.38016033172607) + 0.00267138711113651*std::sin(0.329439848661423*x_51 + 1.94511985778809) + 0.00368356298438863*std::sin(0.225359991192818*x_55 - 7.57776021957397) + 0.00031003993309848*std::sin(0.353759855031967*x_56 + 5.14152002334595) - 8.79358541410388e-5*std::sin(0.353679835796356*x_57 - 4.23112010955811) - 7.6890074084606e-5*std::sin(0.291439920663834*x_58 - 4.54112005233765) - 0.00159666211000762*std::sin(0.136720046401024*x_64 + 4.91695976257324) - 0.0343152039718967*std::sin(0.158240035176277*x_65 - 7.64480018615723) + 0.000561055906477405*std::sin(0.173920020461082*x_69 + 4.95703983306885) - 0.0192758301226831*std::sin(0.192959994077682*x_69 + 4.99343967437744) - 2.73688488394291e-6*std::sin(1.62239992618561*x_7 + 2.00263977050781) + 0.0152291581023279*std::sin(0.223359987139702*x_70 - 7.56512022018433) + 0.000124063359491102*std::sin(0.262639969587326*x_74 - 7.51015996932983) + 0.0144636470866437*std::sin(0.254399985074997*x_77 + 5.06759977340698) + 0.00136898452424024*std::sin(0.146000042557716*x_79 - 7.65496015548706) + 0.000500689758169692*std::sin(0.254399985074997*x_8 + 5.06679964065552) - 0.0153560699663762*std::sin(0.325119823217392*x_8 + 5.11800003051758) + 0.0491310454217612*std::sin(0.146640032529831*x_82 + 4.93063974380493) - 0.00165936706142176*std::sin(0.328719854354858*x_82 - 7.48216009140015) - 0.00340141768013555*std::sin(0.171040013432503*x_83 + 4.96776008605957) - 0.000321476173342624*std::sin(0.281919926404953*x_84 - 7.49887990951538) - 0.00320885960405949*std::sin(0.23479999601841*x_85 - 7.55768013000488) + 0.000826401896845079*std::sin(0.519279837608337*x_9 - 0.845999836921692) - 0.001217211004105*std::sin(0.183520004153252*x_91 - 7.36463975906372) - 8.37312106170983e-5*std::sin(0.327599853277206*x_92 - 1.00311982631683) - 0.000702175604517848*std::sin(0.338879853487015*x_92 + 5.19623994827271) - 0.000979011635197994*std::sin(0.329279839992523*x_94 - 1.22063982486725) - 0.00158796559521412*std::sin(0.337919861078262*x_95 - 7.43951988220215) - 0.000193735136016282*std::sin(0.377039849758148*x_95 - 7.42439985275269) + 0.000290101882279038*std::sin(0.355519831180573*x_96 + 1.9670398235321) + 0.0041089811494536*std::sin(0.26463994383812*x_97 + 5.07655954360962) + 0.00809453281770674*std::sin(0.381359845399857*x_97 + 1.97151982784271) + 0.00026150758809297*std::sin(0.273999959230423*x_98 - 4.30663967132568) - 0.284022033214569*std::sin(-0.00308113959700432*x_10 + 0.00378118905572142*x_100 + 0.00217963648847867*x_101 + 0.00105090569405767*x_103 + 0.00805883290128788*x_104 + 0.000550065860181898*x_107 - 0.00293072236242879*x_108 - 0.000926301414033181*x_11 - 0.00456384699787962*x_110 + 0.0102713906494289*x_111 + 0.000285581691715014*x_112 + 0.018141087669614*x_113 + 0.00137699266120513*x_115 - 0.00148378889561732*x_116 - 0.000506718873023931*x_117 - 0.00228078942420088*x_13 - 0.000682591176332687*x_14 - 0.0114346313284719*x_15 - 0.0233207913111121*x_16 + 0.000513470281293786*x_17 - 5.96772546914066e-5*x_18 - 0.000447640024657364*x_19 - 0.0200028331493327*x_2 + 0.0406436663030794*x_20 + 0.00395625037136448*x_21 - 0.00557013491537562*x_22 + 0.0111201346642922*x_23 + 0.0103737828621049*x_25 - 0.00042286553342969*x_28 + 0.000945492977699124*x_29 - 0.0156609257842253*x_3 - 0.00154043485305336*x_30 + 0.0372784429988995*x_31 + 0.00614390310808652*x_32 - 0.0121863992690072*x_33 + 0.000897583082747983*x_34 + 0.000806005173585059*x_38 + 0.00175677368039439*x_39 + 0.0237470434095093*x_4 - 0.0133261748269326*x_40 + 2.79916465279376e-5*x_44 - 0.015373751510123*x_45 - 0.00190741412062714*x_48 - 0.00153556191029243*x_5 + 0.000665560385659132*x_51 - 0.000163821858860592*x_52 + 0.000463943743499152*x_53 + 0.000195487520054367*x_54 + 0.00101521225749123*x_56 + 0.0183030295301063*x_57 + 0.000664911482724166*x_58 + 0.000285431679971196*x_59 + 0.00808284453974267*x_6 + 0.000166109071712947*x_60 + 0.000113529924094175*x_61 - 0.00864690070366762*x_62 + 0.0149351054384903*x_63 - 0.0109975226039441*x_64 - 0.00061093679238184*x_65 - 0.00366374414988368*x_66 - 0.000100608594787778*x_67 + 0.0101599325105794*x_68 - 0.0110541525411457*x_69 - 0.00257929854684592*x_7 - 0.00012598713857175*x_70 + 0.0033133429814387*x_71 + 0.00371317175170152*x_72 - 9.88400108664005e-5*x_73 - 9.52266564270464e-5*x_75 + 0.0034978954519087*x_76 + 0.0143468413816673*x_77 - 8.74369784265324e-5*x_78 - 0.00227010151100936*x_79 + 0.006044033209554*x_8 + 2.91528677304098e-6*x_80 + 0.000220485176660596*x_82 + 0.000401053046251476*x_83 + 6.74993568790377e-5*x_84 + 0.000134142066895092*x_85 + 0.00410539326308241*x_86 - 2.74274020341751e-6*x_87 - 0.00114212477964687*x_88 - 0.00268822618556747*x_89 - 0.000541312626416642*x_9 - 0.000162626841361344*x_90 + 0.0124830798985149*x_91 + 0.0379735651701909*x_92 + 0.00369716119448965*x_93 - 7.85002765481666e-5*x_95 + 0.000263063796654387*x_97 - 0.00633874491850109*x_99 + 0.000153241915375728*std::pow(-7.64775991439819*x_81 - 9.46271991729736, 2) + 0.0963950775139155*std::sin(0.409919857978821*x_1 + 4.98423957824707) + 0.173849070469023*std::sin(0.158400028944016*x_102 + 8.13687992095947) + 0.181355824408893*std::sin(0.308479934930801*x_105 + 5.12871980667114) - 0.034579531152743*std::sin(0.448319852352142*x_106 - 1.17631983757019) + 0.114608414740509*std::sin(0.246559977531433*x_109 + 5.04895973205566) - 0.167358934139443*std::sin(0.351679861545563*x_114 + 1.95783984661102) + 0.0718864334756564*std::sin(0.305519849061966*x_118 - 1.26919984817505) + 0.20795647630595*std::sin(0.322239845991135*x_119 + 5.13624000549316) - 0.164537045612869*std::sin(0.327839851379395*x_12 + 5.1300802230835) + 0.171354217745021*std::sin(0.349519848823547*x_120 - 7.44911956787109) - 0.0574973158461822*std::sin(0.371919840574265*x_24 + 8.35968017578125) + 0.206995174119866*std::sin(0.33815985918045*x_26 + 5.15375995635986) + 1.24856184120119*std::sin(0.160000026226044*x_27 - 7.64448022842407) - 0.15006431560292*std::sin(0.306319922208786*x_35 - 7.54120016098022) + 0.138914429725521*std::sin(0.339599847793579*x_36 - 7.43495988845825) + 0.0510231644032744*std::sin(0.378719836473465*x_37 - 4.22504043579102) - 0.106287543638262*std::sin(0.338959842920303*x_41 + 1.93567979335785) - 0.273560766104257*std::sin(0.206640005111694*x_42 - 7.60008001327515) + 0.0781833667665621*std::sin(0.371759831905365*x_43 + 5.17224025726318) + 0.314938791355459*std::sin(0.223279997706413*x_46 + 5.03991985321045) + 0.142295842240756*std::sin(0.366639852523804*x_47 - 7.4270396232605) + 0.123161501688136*std::sin(0.34215983748436*x_49 - 4.2454400062561) + 0.07620620347216*std::sin(0.245119974017143*x_50 - 7.54640007019043) - 0.19913212288114*std::sin(0.227199986577034*x_55 + 5.01903963088989) + 0.142276596830584*std::sin(0.30159991979599*x_74 - 7.46799993515015) + 0.216236466041622*std::sin(0.386319845914841*x_94 + 2.00543975830078) + 0.0376139324308311*std::sin(0.397999823093414*x_96 + 1.99415981769562) + 0.164400133885945*std::sin(0.390079826116562*x_98 + 1.9676798582077) + 6.93745711496788) - 0.0559828398092908);
}

inline float score_10(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.000192341639516611*x_1 - 0.000249371129902185*x_10 - 0.000278349896388862*x_100 + 0.000329922703010426*x_101 + 0.000141372521909389*x_102 + 0.000172356968168545*x_103 + 0.000691165311480561*x_104 + 2.84868805559957e-5*x_105 - 7.2400989477481e-5*x_106 + 0.000155226729316281*x_107 - 0.00052011911297309*x_108 + 2.94017510908323e-6*x_109 - 2.27107765666885e-5*x_11 - 0.000250073439890983*x_110 + 0.00123319810456288*x_111 + 0.00011008968557081*x_112 + 0.00177429052221029*x_113 - 0.000124467263951515*x_114 + 0.000280271982916905*x_115 + 0.000194362323997952*x_116 - 4.96838118884168e-5*x_117 + 1.22776910350735e-5*x_118 - 0.000217644372223741*x_119 - 0.000215559219895054*x_12 - 0.00056087256941018*x_120 - 0.00180138051408367*x_13 - 0.00014482381874221*x_14 - 0.00113700893627443*x_15 - 0.00346033636292529*x_16 - 6.93074935460152e-5*x_17 - 2.21394600039799e-5*x_18 - 0.000280868435653664*x_19 - 0.00058374243415361*x_2 + 0.00304824356285214*x_20 + 0.00153661700993336*x_21 - 5.64883702654838e-5*x_22 + 0.00114541518409799*x_23 + 0.000174032316009832*x_24 + 0.000932853837710699*x_25 + 2.35935515820756e-5*x_26 + 9.50158674929192e-5*x_27 - 7.46905529745005e-6*x_28 + 0.0011375619201412*x_29 - 0.000898419198556746*x_3 - 6.77543866227899e-5*x_30 + 3.07710207212651e-5*x_31 + 0.000629583978428734*x_32 - 0.00116291742803235*x_33 + 0.000635372107998652*x_34 - 0.000106875602921044*x_35 - 0.0004712979671484*x_36 + 0.000589434358045251*x_37 + 0.000137237912108968*x_38 + 0.000422359643564168*x_39 + 0.00354897104384741*x_4 - 0.00128509578981454*x_40 - 2.76098310458814e-6*x_41 - 0.000726794424869705*x_42 + 9.74004196054543e-6*x_43 + 6.56992680685505e-5*x_44 - 0.00166466402385183*x_45 - 0.000215935071025245*x_46 - 1.02675522220284e-5*x_47 - 0.000274811662267837*x_48 - 1.89273172700497e-5*x_49 - 0.000208091907527817*x_5 + 0.000572790649775181*x_50 + 2.73452011064802e-7*x_51 + 0.000217447760890715*x_52 - 0.000492118473799428*x_53 + 0.000550827892326956*x_54 - 0.000320611226044695*x_55 + 0.000166635718340015*x_56 + 0.000550442584841804*x_57 - 0.000520403224755972*x_58 - 0.000483587510768862*x_59 + 0.0012054719708724*x_6 - 0.000738970533648141*x_60 + 0.000363413510192047*x_61 - 0.00119930503752757*x_62 + 0.00146922676292152*x_63 - 0.000592070394032209*x_64 - 0.000150960354672282*x_65 - 0.000996601002327746*x_66 + 3.07389232737485e-5*x_67 + 0.000876707055211342*x_68 - 0.0010838602323269*x_69 - 0.00136509137377047*x_7 - 1.76468568041513e-5*x_70 + 0.000321954682133868*x_71 + 0.000399071109063954*x_72 - 0.00116928500802474*x_73 - 5.57573236311331e-5*x_74 - 2.43258534171722e-5*x_75 + 0.000618608262292172*x_76 + 0.00136861614965416*x_77 + 4.37690822780855e-5*x_78 - 0.000201694599301572*x_79 + 0.000848734297858383*x_8 + 9.59452288672129e-6*x_80 + 3.26173497099273e-5*x_81 + 1.9562313463815e-5*x_82 + 0.00026397681555082*x_83 - 6.34721376955812e-5*x_84 + 0.000164894640710505*x_85 + 0.000443882795359691*x_86 + 0.000619969676437018*x_87 - 0.000558913457281775*x_88 - 0.000617043071332456*x_89 + 0.000512111678426043*x_9 - 3.09065494400572e-5*x_90 + 0.00387111420484186*x_91 + 0.0036926543432083*x_92 + 0.00228904038385226*x_93 - 3.36546802769409e-5*x_94 - 2.73629026282178e-5*x_95 + 0.000142049013014384*x_96 + 2.46054794082449e-5*x_97 + 2.45128063319004e-5*x_98 - 5.79124070469091e-5*x_99 - 1.39418847733562e-5*std::pow(-4.67039966583252*x_109 - 6.09272003173828, 2) + 0.000749899408322943*std::pow(-0.629119873046875*x_117 - 1.04919981956482, 2) + 6.83538467518182e-7*std::pow(-5.42967987060547*x_13 - 9.45328044891357, 2) + 1.81910141948132e-7*std::pow(-7.32359981536865*x_18 - 9.49656009674072, 2) + 2.3956593448358e-5*std::pow(-6.08007955551147*x_18 - 9.70680046081543, 2) + 1.05453357111986e-5*std::pow(-5.23864030838013*x_19 - 8.24680042266846, 2) + 9.11312971843003e-6*std::pow(-4.40183973312378*x_27 - 6.39983987808228, 2) - 3.84706052731638e-7*std::pow(-5.92095994949341*x_4 - 9.2705602645874, 2) + 3.32765106412477e-6*std::pow(-6.3778395652771*x_49 - 9.52264022827148, 2) - 4.04183585098632e-7*std::pow(-5.81791973114014*x_5 - 9.03359985351563, 2) - 2.48797054553501e-7*std::pow(-5.25591993331909*x_57 - 8.28688049316406, 2) + 1.48246793949787e-6*std::pow(-6.50767993927002*x_67 - 9.74536037445068, 2) + 3.03011321396364e-5*std::pow(-4.48536014556885*x_67 - 5.50952005386353, 2) + 1.33170987407953e-5*std::pow(-5.87383985519409*x_69 - 7.69448041915894, 2) + 1.99851472459387e-5*std::pow(-3.67263984680176*x_69 - 4.90823984146118, 2) - 3.9785522328335e-6*std::pow(-5.61768007278442*x_7 - 8.81968021392822, 2) - 3.02564157343101e-7*std::pow(-5.58383989334106*x_7 - 9.16079998016357, 2) - 1.13793858103244e-6*std::pow(-7.80000019073486*x_70 - 9.99882030487061, 2) - 4.40756878030633e-7*std::pow(-3.86879992485046*x_71 - 6.11287975311279, 2) + 3.85994987925223e-7*std::pow(-3.55695986747742*x_75 - 4.39680004119873, 2) + 2.82442542737274e-5*std::pow(-3.24160003662109*x_79 - 4.85735988616943, 2) + 1.29162054393539e-7*std::pow(-8.19999980926514*x_81 - 9.99917984008789, 2) + 1.50253777829759e-5*std::pow(-7.64775991439819*x_81 - 9.46271991729736, 2) + 3.43944091382159e-7*std::pow(-3.7960000038147*x_85 - 6.38800001144409, 2) - 1.08019270243465e-6*std::pow(-7.40000009536743*x_87 - 9.99973964691162, 2) - 2.12513964290478e-6*std::pow(-6.39191961288452*x_90 - 8.79872035980225, 2) - 0.000715960517047847*std::exp(0.97327983379364*x_17) - 0.0380311522366423*std::sin(0.204479992389679*x_1 - 7.40343999862671) + 0.00945154237020997*std::sin(0.409919857978821*x_1 + 4.98423957824707) - 0.00939978850959994*std::sin(0.408479869365692*x_100 - 7.38679981231689) - 0.0088814453047301*std::sin(0.303759932518005*x_101 + 8.27639961242676) + 0.0170459104130332*std::sin(0.158400028944016*x_102 + 8.13687992095947) - 0.00992860003344201*std::sin(0.298319935798645*x_102 + 5.09783983230591) - 0.00826009966568568*std::sin(0.401839852333069*x_103 + 1.99063980579376) - 4.76996384593307e-5*std::sin(0.410399854183197*x_104 + 1.98927986621857) + 0.017781948027767*std::sin(0.308479934930801*x_105 + 5.12871980667114) - 0.00339052483032617*std::sin(0.448319852352142*x_106 - 1.17631983757019) + 0.000172037742641066*std::sin(0.31591984629631*x_107 - 7.4553599357605) + 0.00478267263566727*std::sin(0.316479861736298*x_107 + 1.93535983562469) + 0.0112373610337742*std::sin(0.246559977531433*x_109 + 5.04895973205566) - 0.000997028946447713*std::sin(0.409119844436646*x_109 - 1.185919880867) - 0.00136505781861606*std::sin(0.317759841680527*x_11 - 1.07807981967926) + 0.00461412715215657*std::sin(0.369279861450195*x_110 - 7.41311979293823) - 0.00385973232741501*std::sin(0.467359870672226*x_111 + 2.05663967132568) + 0.000113956894236449*std::sin(0.309759944677353*x_112 + 1.88231992721558) + 0.0010915491292409*std::sin(0.340159833431244*x_112 - 7.43631982803345) - 0.00717566580150074*std::sin(0.37679985165596*x_112 - 7.41648006439209) - 0.00661299528940645*std::sin(0.350399851799011*x_113 + 1.94639980792999) - 0.0164095522079307*std::sin(0.351679861545563*x_114 + 1.95783984661102) - 0.00936231453023659*std::sin(0.166160017251968*x_115 + 8.14791965484619) - 6.19251979110358e-5*std::sin(0.773439824581146*x_116 - 1.000079870224) + 0.0100943819043514*std::sin(0.297279924154282*x_117 + 5.08855962753296) - 9.04419405613287e-5*std::sin(0.470959842205048*x_117 + 2.05343985557556) - 0.000591507956807627*std::sin(0.511359870433807*x_117 - 7.44767951965332) + 0.00704846854592096*std::sin(0.305519849061966*x_118 - 1.26919984817505) + 0.0153947173305221*std::sin(0.320319831371307*x_118 - 7.46407985687256) + 0.00196302388203975*std::sin(0.388959854841232*x_118 - 7.39264011383057) + 0.0203901433315567*std::sin(0.322239845991135*x_119 + 5.13624000549316) - 0.00810808102673966*std::sin(0.417999863624573*x_119 + 8.20368003845215) - 0.0161328658909445*std::sin(0.327839851379395*x_12 + 5.1300802230835) + 0.000198978426420539*std::sin(0.25111997127533*x_120 + 5.06399965286255) + 0.0168012899735202*std::sin(0.349519848823547*x_120 - 7.44911956787109) - 0.00955338170098886*std::sin(0.289759933948517*x_14 + 5.12048006057739) - 0.00934421859985194*std::sin(0.406079858541489*x_15 - 0.976399838924408) - 0.00644350717631109*std::sin(0.228879988193512*x_18 + 5.02151966094971) + 0.00147034650685816*std::sin(0.312959939241409*x_21 - 4.29031991958618) + 0.00364731724696364*std::sin(0.250799983739853*x_23 - 7.52175998687744) + 0.00194011932520381*std::sin(0.365439832210541*x_23 - 1.03543972969055) - 0.00563761481300833*std::sin(0.371919840574265*x_24 + 8.35968017578125) + 7.78910518158078e-6*std::sin(0.868479907512665*x_24 + 1.17119991779327) + 0.000196183398432003*std::sin(0.309119910001755*x_26 - 4.26143980026245) - 0.0144857802037384*std::sin(0.316879838705063*x_26 - 4.26823997497559) + 0.0202958876021494*std::sin(0.33815985918045*x_26 + 5.15375995635986) + 0.122421553551185*std::sin(0.160000026226044*x_27 - 7.64448022842407) + 0.000269460896770159*std::sin(0.257519990205765*x_27 + 5.08903980255127) - 0.000939111688023353*std::sin(0.337999850511551*x_28 - 4.25271987915039) - 0.000308416782095819*std::sin(1.42767989635468*x_28 - 3.18928003311157) + 0.000414590307417079*std::sin(1.30543982982635*x_29 + 6.19024038314819) - 0.00267234542203397*std::sin(0.294559925794601*x_3 + 8.30103969573975) + 0.0202430739983761*std::sin(0.320479840040207*x_3 + 8.33432006835938) + 0.00040083876011993*std::sin(0.207520008087158*x_31 - 7.40839958190918) - 0.0272261358246523*std::sin(0.259199976921082*x_32 - 7.40863990783691) + 0.0042498450774237*std::sin(0.27295994758606*x_32 - 7.44280004501343) - 0.0236014764297819*std::sin(0.272799968719482*x_33 - 1.17695987224579) - 0.00220476785019514*std::sin(0.310799926519394*x_33 - 1.39063990116119) + 0.0030849965337283*std::sin(0.355359852313995*x_34 - 7.4049596786499) + 0.000105668853053728*std::sin(0.374639838933945*x_34 - 1.20295989513397) - 0.00749827758368674*std::sin(0.397919833660126*x_34 - 1.2040798664093) - 0.000206632785659473*std::sin(0.300959944725037*x_35 - 4.35016012191772) - 0.0147138139597721*std::sin(0.306319922208786*x_35 - 7.54120016098022) - 0.010154176842988*std::sin(0.306479930877686*x_35 + 8.26095962524414) + 0.01362056706884*std::sin(0.339599847793579*x_36 - 7.43495988845825) + 0.0136230406962511*std::sin(0.343279838562012*x_36 + 5.15208005905151) + 0.000204177778834359*std::sin(0.346159845590591*x_36 - 7.4475998878479) + 0.00500282392687655*std::sin(0.378719836473465*x_37 - 4.22504043579102) + 0.000398597051575782*std::sin(0.225599989295006*x_38 + 5.01599979400635) - 3.48255219379678e-5*std::sin(1.33471989631653*x_38 - 3.82351994514465) + 0.00484705990537297*std::sin(0.175280019640923*x_40 + 4.95599985122681) + 0.0205200611581044*std::sin(0.265359967947006*x_40 + 5.07607984542847) - 0.000204881609136339*std::sin(0.381999850273132*x_40 + 5.16951990127563) + 0.00695058708616499*std::sin(0.263679951429367*x_41 + 5.06279993057251) + 0.0078540086944101*std::sin(0.300799936056137*x_41 + 1.88895988464355) - 0.0104214991888725*std::sin(0.338959842920303*x_41 + 1.93567979335785) - 0.0268226473627581*std::sin(0.206640005111694*x_42 - 7.60008001327515) - 0.00117003386964878*std::sin(0.343759834766388*x_42 + 8.17296028137207) + 0.0086013827799986*std::sin(0.303439915180206*x_43 - 7.49440002441406) + 0.00766588318301993*std::sin(0.371759831905365*x_43 + 5.17224025726318) + 0.000112152857422219*std::sin(0.373599827289581*x_45 - 1.22919988632202) + 0.0308797648934836*std::sin(0.223279997706413*x_46 + 5.03991985321045) + 0.0139521147420528*std::sin(0.366639852523804*x_47 - 7.4270396232605) + 0.0120759916544085*std::sin(0.34215983748436*x_49 - 4.2454400062561) + 0.000172739203432884*std::sin(1.93639981746674*x_5 + 7.80280017852783) - 0.0345354944985998*std::sin(0.225919991731644*x_50 - 7.57376003265381) + 0.00747202221903899*std::sin(0.245119974017143*x_50 - 7.54640007019043) + 0.000309414314043733*std::sin(0.443919867277145*x_50 - 1.38655984401703) - 2.51559272119468e-5*std::sin(0.581999838352203*x_50 + 8.38016033172607) - 0.0122688224266361*std::sin(0.329439848661423*x_51 + 1.94511985778809) - 0.0169174209025688*std::sin(0.225359991192818*x_55 - 7.57776021957397) - 0.0195249150187079*std::sin(0.227199986577034*x_55 + 5.01903963088989) - 0.00191330988227722*std::sin(0.353759855031967*x_56 + 5.14152002334595) + 0.00447368479028916*std::sin(0.353679835796356*x_57 - 4.23112010955811) + 0.00391173723524424*std::sin(0.291439920663834*x_58 - 4.54112005233765) + 0.00985327716725063*std::sin(0.136720046401024*x_64 + 4.91695976257324) - 0.000547527266595664*std::sin(0.158240035176277*x_65 - 7.64480018615723) - 0.00346237273258682*std::sin(0.173920020461082*x_69 + 4.95703983306885) - 0.000307561703176195*std::sin(0.192959994077682*x_69 + 4.99343967437744) + 0.000139237406603566*std::sin(1.62239992618561*x_7 + 2.00263977050781) + 0.000242993727070652*std::sin(0.223359987139702*x_70 - 7.56512022018433) - 0.000765616381640225*std::sin(0.262639969587326*x_74 - 7.51015996932983) + 0.0139502277285831*std::sin(0.30159991979599*x_74 - 7.46799993515015) + 0.000230779370008701*std::sin(0.254399985074997*x_77 + 5.06759977340698) - 0.00844823953074924*std::sin(0.146000042557716*x_79 - 7.65496015548706) - 0.00308984282343002*std::sin(0.254399985074997*x_8 + 5.06679964065552) - 0.000245018710109594*std::sin(0.325119823217392*x_8 + 5.11800003051758) + 0.000783926186969347*std::sin(0.146640032529831*x_82 + 4.93063974380493) + 0.00762093959812931*std::sin(0.328719854354858*x_82 - 7.48216009140015) + 0.0156216182006843*std::sin(0.171040013432503*x_83 + 4.96776008605957) + 0.00198388489258812*std::sin(0.281919926404953*x_84 - 7.49887990951538) + 0.0147372608447836*std::sin(0.23479999601841*x_85 - 7.55768013000488) - 0.0037953983094251*std::sin(0.519279837608337*x_9 - 0.845999836921692) + 0.00751161897016318*std::sin(0.183520004153252*x_91 - 7.36463975906372) + 0.00425977602730073*std::sin(0.327599853277206*x_92 - 1.00311982631683) + 0.00433324672016117*std::sin(0.338879853487015*x_92 + 5.19623994827271) + 0.00449628578942448*std::sin(0.329279839992523*x_94 - 1.22063982486725) + 0.0212019967563366*std::sin(0.386319845914841*x_94 + 2.00543975830078) + 0.00729301561202821*std::sin(0.337919861078262*x_95 - 7.43951988220215) + 0.00119557292694465*std::sin(0.377039849758148*x_95 - 7.42439985275269) - 0.00179026873307768*std::sin(0.355519831180573*x_96 + 1.9670398235321) + 0.00368804803366535*std::sin(0.397999823093414*x_96 + 1.99415981769562) - 0.0188712298067478*std::sin(0.26463994383812*x_97 + 5.07655954360962) + 0.000129154920124548*std::sin(0.381359845399857*x_97 + 1.97151982784271) - 0.0016138084136079*std::sin(0.273999959230423*x_98 - 4.30663967132568) + 0.0161194416889896*std::sin(0.390079826116562*x_98 + 1.9676798582077) + 0.2437209899204);
}

inline float score_11(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (3.81146620015937e-5*x_1 - 0.00265057669998591*x_10 - 0.0015213390597168*x_100 + 0.000744397418936399*x_101 + 0.00120968127585989*x_102 + 3.78084262990547e-5*x_103 - 0.00116564643381202*x_104 + 0.000214000585775341*x_105 - 7.07639065675932e-5*x_106 + 0.000314811490678203*x_107 + 0.000443563484296174*x_108 + 7.81931992080266e-7*x_109 + 3.51626944345152e-5*x_11 + 0.000136415210857802*x_110 + 0.00134007249598472*x_111 - 3.60571352517928e-6*x_112 - 0.000943051946181247*x_113 + 0.000163824085773872*x_114 + 0.000883800493606969*x_115 + 0.000141330339480019*x_116 + 2.65505878509836e-5*x_117 + 1.75655197905066e-5*x_118 - 0.000163845603051396*x_119 + 0.00551642073661746*x_12 - 0.000113689531345981*x_120 - 0.000323903292158368*x_13 - 0.00026597874625016*x_14 + 0.000882634827611613*x_15 + 0.000140690883933459*x_16 - 0.00129289586542746*x_17 + 8.73255535394953e-7*x_18 + 8.41239988182837e-5*x_19 + 0.000980520172840789*x_2 - 8.29043817479486e-5*x_20 - 9.60744070663841e-5*x_21 + 0.00233302737943113*x_22 - 0.000600271641856434*x_23 + 0.000420199445405722*x_24 - 0.00142872630524038*x_25 + 0.000277242980154293*x_26 + 7.31328136106784e-6*x_27 + 5.89695532314552e-5*x_28 + 0.00123776295466615*x_29 + 0.000908376756340228*x_3 + 0.000228669335426772*x_30 + 0.00530386707035197*x_31 - 0.000334809655974269*x_32 + 0.000897482729306394*x_33 - 4.29323975346508e-5*x_34 + 0.000451039591025646*x_35 - 2.02729325234282e-5*x_36 + 0.000378826788364629*x_37 + 1.16190234024129e-5*x_38 + 4.85865072729689e-5*x_39 - 0.000962678003252595*x_4 + 0.00070123242659713*x_40 + 1.18850272008738e-5*x_41 - 6.00011787551292e-5*x_42 + 9.68248381182565e-5*x_43 - 4.94648221801033e-5*x_44 + 0.000849284371964455*x_45 + 4.15901003784144e-5*x_46 - 0.00068582147986749*x_47 + 0.000145055758025714*x_48 - 1.68438800160599e-5*x_49 - 0.000558465609997342*x_5 + 7.92525935108181e-5*x_50 + 4.24084869985793e-5*x_51 + 0.00167295400235464*x_52 - 0.000173775573143791*x_53 + 0.000168068511911699*x_54 + 0.000585925607336073*x_55 - 6.84068942278117e-6*x_56 - 0.000911654926985164*x_57 + 9.6607303854333e-5*x_58 + 8.98349906675899e-5*x_59 - 0.000451397515986534*x_6 + 0.000424856112554436*x_60 + 0.000157982808845648*x_61 + 0.00156532664850739*x_62 - 0.000793508437486503*x_63 + 0.000617793043132311*x_64 - 0.000912387123970485*x_65 + 0.000275625985507471*x_66 + 1.28403163293133e-5*x_67 - 0.000351076142911762*x_68 + 0.000579205282823559*x_69 + 0.000126820287940887*x_7 + 8.82610569014e-6*x_70 + 2.13511319554431e-5*x_71 + 1.48906213779634e-5*x_72 + 4.64049771204157e-5*x_73 - 3.2591096707701e-6*x_74 - 5.35215675743786e-6*x_75 - 0.00038115526990576*x_76 - 0.000986951190896619*x_77 + 0.000734975606089988*x_78 + 0.000121753859093371*x_79 - 0.000293495290679213*x_8 - 4.19599294348164e-5*x_80 + 8.51070265699777e-5*x_81 + 5.74315184262375e-5*x_82 + 0.000856336197323992*x_83 - 1.78643636909817e-5*x_84 + 0.00119226579086009*x_85 - 0.000123280886533141*x_86 + 8.8869314904262e-5*x_87 + 2.03119778207249e-5*x_88 + 9.52652697018972e-5*x_89 - 0.00033881697804607*x_9 + 6.07010371865696e-6*x_90 - 0.000490110166346956*x_91 - 0.00199129624651963*x_92 - 5.26643237605783e-6*x_93 + 3.60228971266532e-5*x_94 + 9.84659723239969e-8*x_95 + 2.70047016041669e-5*x_96 + 0.000100794386422854*x_97 - 1.9820297844907e-6*x_98 + 0.00084318393485473*x_99 - 1.04388440811763e-7*std::pow(-4.67039966583252*x_109 - 6.09272003173828, 2) + 0.000103757756878797*std::pow(-0.629119873046875*x_117 - 1.04919981956482, 2) + 2.19173941735222e-6*std::pow(-5.42967987060547*x_13 - 9.45328044891357, 2) + 5.8328777014039e-7*std::pow(-7.32359981536865*x_18 - 9.49656009674072, 2) + 1.79372550977796e-7*std::pow(-6.08007955551147*x_18 - 9.70680046081543, 2) + 1.45907619979964e-6*std::pow(-5.23864030838013*x_19 - 8.24680042266846, 2) + 7.18464477083756e-5*std::pow(-4.40183973312378*x_27 - 6.39983987808228, 2) - 1.23354494287256e-6*std::pow(-5.92095994949341*x_4 - 9.2705602645874, 2) + 4.60421232843855e-7*std::pow(-6.3778395652771*x_49 - 9.52264022827148, 2) - 1.29599889019244e-6*std::pow(-5.81791973114014*x_5 - 9.03359985351563, 2) - 7.97758044789974e-7*std::pow(-5.25591993331909*x_57 - 8.28688049316406, 2) + 1.16875385938022e-5*std::pow(-6.50767993927002*x_67 - 9.74536037445068, 2) + 2.26876637578637e-7*std::pow(-4.48536014556885*x_67 - 5.50952005386353, 2) + 9.97104190923013e-8*std::pow(-5.87383985519409*x_69 - 7.69448041915894, 2) + 2.76518960558783e-6*std::pow(-3.67263984680176*x_69 - 4.90823984146118, 2) - 3.13662653537381e-5*std::pow(-5.61768007278442*x_7 - 8.81968021392822, 2) - 9.70160161336048e-7*std::pow(-5.58383989334106*x_7 - 9.16079998016357, 2) - 8.97132459248862e-6*std::pow(-7.80000019073486*x_70 - 9.99882030487061, 2) - 1.41326972651052e-6*std::pow(-3.86879992485046*x_71 - 6.11287975311279, 2) + 1.2376778632632e-6*std::pow(-3.55695986747742*x_75 - 4.39680004119873, 2) + 2.11475974264248e-7*std::pow(-3.24160003662109*x_79 - 4.85735988616943, 2) + 4.14153086172844e-7*std::pow(-8.19999980926514*x_81 - 9.99917984008789, 2) - 8.02942845281415e-6*std::pow(-7.64775991439819*x_81 - 9.46271991729736, 2) + 1.10284330475903e-6*std::pow(-3.7960000038147*x_85 - 6.38800001144409, 2) - 8.51606538130238e-6*std::pow(-7.40000009536743*x_87 - 9.99973964691162, 2) - 1.6754258848985e-5*std::pow(-6.39191961288452*x_90 - 8.79872035980225, 2) - 9.90618960865706e-5*std::exp(0.97327983379364*x_17) - 0.000284754374949707*std::sin(0.204479992389679*x_1 - 7.40343999862671) - 0.00505082030724898*std::sin(0.409919857978821*x_1 + 4.98423957824707) - 7.03799581210608e-5*std::sin(0.408479869365692*x_100 - 7.38679981231689) - 6.649891622168e-5*std::sin(0.303759932518005*x_101 + 8.27639961242676) - 0.00910918314676953*std::sin(0.158400028944016*x_102 + 8.13687992095947) - 7.43393804914608e-5*std::sin(0.298319935798645*x_102 + 5.09783983230591) - 6.18466540979111e-5*std::sin(0.401839852333069*x_103 + 1.99063980579376) - 0.000152947028986316*std::sin(0.410399854183197*x_104 + 1.98927986621857) - 0.00950251511162574*std::sin(0.308479934930801*x_105 + 5.12871980667114) + 0.00181186635942287*std::sin(0.448319852352142*x_106 - 1.17631983757019) + 0.000551632307085471*std::sin(0.31591984629631*x_107 - 7.4553599357605) + 0.000661741266968348*std::sin(0.316479861736298*x_107 + 1.93535983562469) - 0.00600514594191194*std::sin(0.246559977531433*x_109 + 5.04895973205566) - 0.00786041571643875*std::sin(0.409119844436646*x_109 - 1.185919880867) - 0.0107618961009373*std::sin(0.317759841680527*x_11 - 1.07807981967926) + 0.000638420937458778*std::sin(0.369279861450195*x_110 - 7.41311979293823) - 0.00053404118472473*std::sin(0.467359870672226*x_111 + 2.05663967132568) + 0.00036539833359184*std::sin(0.309759944677353*x_112 + 1.88231992721558) + 0.008605597622135*std::sin(0.340159833431244*x_112 - 7.43631982803345) - 5.37270661020271e-5*std::sin(0.37679985165596*x_112 - 7.41648006439209) - 0.00091498879698192*std::sin(0.350399851799011*x_113 + 1.94639980792999) + 0.00876911897320709*std::sin(0.351679861545563*x_114 + 1.95783984661102) - 0.00129539074717175*std::sin(0.166160017251968*x_115 + 8.14791965484619) - 0.00019856073013966*std::sin(0.773439824581146*x_116 - 1.000079870224) + 7.5580655347796e-5*std::sin(0.297279924154282*x_117 + 5.08855962753296) - 0.000289998552429411*std::sin(0.470959842205048*x_117 + 2.05343985557556) - 0.00466335351310994*std::sin(0.511359870433807*x_117 - 7.44767951965332) - 0.00376663899629245*std::sin(0.305519849061966*x_118 - 1.26919984817505) + 0.000115266376461679*std::sin(0.320319831371307*x_118 - 7.46407985687256) + 0.0154761642870106*std::sin(0.388959854841232*x_118 - 7.39264011383057) - 0.0108963115196251*std::sin(0.322239845991135*x_119 + 5.13624000549316) - 6.07084300376873e-5*std::sin(0.417999863624573*x_119 + 8.20368003845215) + 0.00862126026255088*std::sin(0.327839851379395*x_12 + 5.1300802230835) + 0.000638016558120064*std::sin(0.25111997127533*x_120 + 5.06399965286255) - 0.0089784601562707*std::sin(0.349519848823547*x_120 - 7.44911956787109) - 0.00132182722762554*std::sin(0.289759933948517*x_14 + 5.12048006057739) - 6.99638840873885e-5*std::sin(0.406079858541489*x_15 - 0.976399838924408) - 0.0507995733304597*std::sin(0.228879988193512*x_18 + 5.02151966094971) + 0.0115919751701259*std::sin(0.312959939241409*x_21 - 4.29031991958618) + 0.0287548620458981*std::sin(0.250799983739853*x_23 - 7.52175998687744) + 1.45264456448411e-5*std::sin(0.365439832210541*x_23 - 1.03543972969055) + 0.0030126912906552*std::sin(0.371919840574265*x_24 + 8.35968017578125) + 2.49754617532464e-5*std::sin(0.868479907512665*x_24 + 1.17119991779327) + 0.00062905440996574*std::sin(0.309119910001755*x_26 - 4.26143980026245) - 0.00200428489994475*std::sin(0.316879838705063*x_26 - 4.26823997497559) - 0.0108459420948775*std::sin(0.33815985918045*x_26 + 5.15375995635986) - 0.0654209910405933*std::sin(0.160000026226044*x_27 - 7.64448022842407) + 0.000864015848340717*std::sin(0.257519990205765*x_27 + 5.08903980255127) - 0.00740380537428781*std::sin(0.337999850511551*x_28 - 4.25271987915039) - 4.2673234755051e-5*std::sin(1.42767989635468*x_28 - 3.18928003311157) + 3.10420265770997e-6*std::sin(1.30543982982635*x_29 + 6.19024038314819) - 0.0210683411248487*std::sin(0.294559925794601*x_3 + 8.30103969573975) + 0.000151567952703638*std::sin(0.320479840040207*x_3 + 8.33432006835938) + 0.00128527383944792*std::sin(0.207520008087158*x_31 - 7.40839958190918) - 0.000203852916177887*std::sin(0.259199976921082*x_32 - 7.40863990783691) + 0.0335050944689528*std::sin(0.27295994758606*x_32 - 7.44280004501343) - 0.000176713648506753*std::sin(0.272799968719482*x_33 - 1.17695987224579) - 0.000305056603640123*std::sin(0.310799926519394*x_33 - 1.39063990116119) + 0.0243216160626774*std::sin(0.355359852313995*x_34 - 7.4049596786499) + 0.000338823053024582*std::sin(0.374639838933945*x_34 - 1.20295989513397) - 0.00103747843231109*std::sin(0.397919833660126*x_34 - 1.2040798664093) - 0.000662559962267396*std::sin(0.300959944725037*x_35 - 4.35016012191772) + 0.0078629315125685*std::sin(0.306319922208786*x_35 - 7.54120016098022) - 7.60283638545139e-5*std::sin(0.306479930877686*x_35 + 8.26095962524414) - 0.0072787100827455*std::sin(0.339599847793579*x_36 - 7.43495988845825) + 0.000102001128291818*std::sin(0.343279838562012*x_36 + 5.15208005905151) + 0.000654688078702439*std::sin(0.346159845590591*x_36 - 7.4475998878479) - 0.00267346467843193*std::sin(0.378719836473465*x_37 - 4.22504043579102) + 0.00127808588849578*std::sin(0.225599989295006*x_38 + 5.01599979400635) - 0.000274558808898875*std::sin(1.33471989631653*x_38 - 3.82351994514465) + 0.0382134400354764*std::sin(0.175280019640923*x_40 + 4.95599985122681) + 0.000153641865822198*std::sin(0.265359967947006*x_40 + 5.07607984542847) - 0.000656944883094997*std::sin(0.381999850273132*x_40 + 5.16951990127563) + 0.000961698751921988*std::sin(0.263679951429367*x_41 + 5.06279993057251) + 5.88060893530206e-5*std::sin(0.300799936056137*x_41 + 1.88895988464355) + 0.00556915661734123*std::sin(0.338959842920303*x_41 + 1.93567979335785) + 0.0143337845493875*std::sin(0.206640005111694*x_42 - 7.60008001327515) - 0.00922435868138081*std::sin(0.343759834766388*x_42 + 8.17296028137207) + 6.44019766212037e-5*std::sin(0.303439915180206*x_43 - 7.49440002441406) - 0.00409657989534415*std::sin(0.371759831905365*x_43 + 5.17224025726318) + 0.000359613759959198*std::sin(0.373599827289581*x_45 - 1.22919988632202) - 0.0165018721281589*std::sin(0.223279997706413*x_46 + 5.03991985321045) - 0.00745588621496731*std::sin(0.366639852523804*x_47 - 7.4270396232605) - 0.00645330269803368*std::sin(0.34215983748436*x_49 - 4.2454400062561) + 1.29336717427797e-6*std::sin(1.93639981746674*x_5 + 7.80280017852783) - 0.000258580994031857*std::sin(0.225919991731644*x_50 - 7.57376003265381) - 0.0039929823177949*std::sin(0.245119974017143*x_50 - 7.54640007019043) + 0.00243937264375907*std::sin(0.443919867277145*x_50 - 1.38655984401703) - 8.06614987604932e-5*std::sin(0.581999838352203*x_50 + 8.38016033172607) - 9.18615570658334e-5*std::sin(0.329439848661423*x_51 + 1.94511985778809) - 0.000126667464211897*std::sin(0.225359991192818*x_55 - 7.57776021957397) + 0.0104339411929875*std::sin(0.227199986577034*x_55 + 5.01903963088989) - 0.0150842271156248*std::sin(0.353759855031967*x_56 + 5.14152002334595) + 0.000618989018622209*std::sin(0.353679835796356*x_57 - 4.23112010955811) + 0.000541236699914051*std::sin(0.291439920663834*x_58 - 4.54112005233765) + 0.0776816510491811*std::sin(0.136720046401024*x_64 + 4.91695976257324) - 0.00175562481015879*std::sin(0.158240035176277*x_65 - 7.64480018615723) - 0.0272967892661096*std::sin(0.173920020461082*x_69 + 4.95703983306885) - 0.000986184596993906*std::sin(0.192959994077682*x_69 + 4.99343967437744) + 1.92651985352487e-5*std::sin(1.62239992618561*x_7 + 2.00263977050781) + 0.000779149901722112*std::sin(0.223359987139702*x_70 - 7.56512022018433) - 0.00603599630727812*std::sin(0.262639969587326*x_74 - 7.51015996932983) - 0.00745487781172696*std::sin(0.30159991979599*x_74 - 7.46799993515015) + 0.000739985042533583*std::sin(0.254399985074997*x_77 + 5.06759977340698) - 0.0666045604998119*std::sin(0.146000042557716*x_79 - 7.65496015548706) - 0.0243598234305512*std::sin(0.254399985074997*x_8 + 5.06679964065552) - 0.000785642930800685*std::sin(0.325119823217392*x_8 + 5.11800003051758) + 0.00251362872160467*std::sin(0.146640032529831*x_82 + 4.93063974380493) + 5.70610082569084e-5*std::sin(0.328719854354858*x_82 - 7.48216009140015) + 0.000116965273593603*std::sin(0.171040013432503*x_83 + 4.96776008605957) + 0.0156406291360598*std::sin(0.281919926404953*x_84 - 7.49887990951538) + 0.000110343738054928*std::sin(0.23479999601841*x_85 - 7.55768013000488) - 2.84176578863743e-5*std::sin(0.519279837608337*x_9 - 0.845999836921692) + 0.0592203947732289*std::sin(0.183520004153252*x_91 - 7.36463975906372) + 0.000589392124454719*std::sin(0.327599853277206*x_92 - 1.00311982631683) + 0.0341626195946637*std::sin(0.338879853487015*x_92 + 5.19623994827271) + 3.36654814346971e-5*std::sin(0.329279839992523*x_94 - 1.22063982486725) - 0.0113301587800799*std::sin(0.386319845914841*x_94 + 2.00543975830078) + 5.46057108440872e-5*std::sin(0.337919861078262*x_95 - 7.43951988220215) + 0.00942570449793582*std::sin(0.377039849758148*x_95 - 7.42439985275269) - 0.0141141905019612*std::sin(0.355519831180573*x_96 + 1.9670398235321) - 0.00197086011710201*std::sin(0.397999823093414*x_96 + 1.99415981769562) - 0.00014129640918361*std::sin(0.26463994383812*x_97 + 5.07655954360962) + 0.000414130210417776*std::sin(0.381359845399857*x_97 + 1.97151982784271) - 0.0127230057490712*std::sin(0.273999959230423*x_98 - 4.30663967132568) - 0.00861408648824117*std::sin(0.390079826116562*x_98 + 1.9676798582077) + 0.153488680097785);
}

int predict(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120)
{
    float s0 = score_0(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s1 = score_1(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s2 = score_2(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s3 = score_3(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s4 = score_4(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s5 = score_5(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s6 = score_6(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s7 = score_7(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s8 = score_8(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s9 = score_9(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s10 = score_10(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s11 = score_11(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);

    float max_score = s0;
    int max_index = 0;

    if(s1 > max_score) {
        max_score = s1;
        max_index = 1;
    }

    if(s2 > max_score) {
        max_score = s2;
        max_index = 2;
    }

    if(s3 > max_score) {
        max_score = s3;
        max_index = 3;
    }

    if(s4 > max_score) {
        max_score = s4;
        max_index = 4;
    }

    if(s5 > max_score) {
        max_score = s5;
        max_index = 5;
    }

    if(s6 > max_score) {
        max_score = s6;
        max_index = 6;
    }

    if(s7 > max_score) {
        max_score = s7;
        max_index = 7;
    }

    if(s8 > max_score) {
        max_score = s8;
        max_index = 8;
    }

    if(s9 > max_score) {
        max_score = s9;
        max_index = 9;
    }

    if(s10 > max_score) {
        max_score = s10;
        max_index = 10;
    }

    if(s11 > max_score) {
        max_score = s11;
        max_index = 11;
    }

    return max_index;
}

#endif
