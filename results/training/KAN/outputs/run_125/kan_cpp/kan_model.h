
#ifndef KAN_MODEL_H
#define KAN_MODEL_H

#include <cmath>


inline float score_0(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-63.2357197710655*x_1 - 60.4840777813853*x_10 + 7.04866757275879*x_100 + 0.164750972375194*x_101 + 2.50682204981689*x_102 + 1.71907819382716*x_103 - 84.8400280157724*x_104 - 3.26983113289338*x_105 + 17.2647503699717*x_106 + 4.83254858835665*x_107 - 4.71625039918271*x_108 - 4.07751582817334*x_109 + 10.8233842708389*x_11 - 7.57695996893621*x_110 - 3.49781487289328*x_111 + 10.9695985962908*x_112 + 8.68569334379063*x_113 + 5.85749283127327*x_114 - 4.61802294271173*x_115 + 43.2172875825162*x_116 + 17.0622948296383*x_117 - 0.993108079232688*x_118 + 12.4156738617132*x_119 + 16.6793229723646*x_12 - 2.86183238621301*x_120 - 0.216950934490995*x_13 + 41.4560499621054*x_14 + 42.6849633859482*x_15 + 0.0854600871532867*x_16 + 4.05245813577015*x_17 + 84.4649781049321*x_18 - 85.5914007449632*x_19 + 3.04335888260583*x_2 + 29.4176325680386*x_20 + 70.8071520035828*x_21 + 14.8285465234524*x_22 - 46.8218523184592*x_23 - 78.2224700066988*x_24 + 8.3471698500001*x_25 + 2.4306491821496*x_26 - 44.3279343466033*x_27 - 325.991105034625*x_28 + 322.990147508736*x_29 + 2.3575959393204*x_3 - 4.43094815153188*x_30 - 5.13153947978669*x_31 + 11.5852571706532*x_32 + 20.2014208183321*x_33 - 868.564716437988*x_34 + 0.333527126704087*x_35 + 74.2386214442278*x_36 + 642.554713051317*x_37 - 7.19309358853044*x_38 - 414.999181134009*x_39 + 61.4862205345729*x_4 + 7.05515555996331*x_40 + 322.54133658912*x_41 + 1211.81695321165*x_42 + 64.791759640487*x_43 + 8.71977354361861*x_44 + 216.78149245547*x_45 - 815.560132908299*x_46 + 535.572987520986*x_47 + 33.5530087777425*x_48 - 111.372462790958*x_49 + 17.4718393785421*x_5 - 421.122657913209*x_50 - 7.86422059421361*x_51 - 30.0175481411497*x_52 + 29.8808383940515*x_53 - 46.3274936864624*x_54 - 165.713885519042*x_55 + 127.235775989576*x_56 + 32.6410855129224*x_57 + 103.436339331686*x_58 + 729.819624244264*x_59 + 0.354001305422097*x_6 + 10.7396037010496*x_60 - 4.26712007683157*x_61 + 9.26917182431852*x_62 - 0.24347730402772*x_63 + 3.61665913210756*x_64 + 1.47311055092483*x_65 + 15.4428001119043*x_66 + 6.45145803237546*x_67 - 1.38193171807706*x_68 + 1.25414043777763*x_69 + 3.20593174580035*x_7 - 4.66629762696811*x_70 + 0.521013232819887*x_71 + 3.57633599481676*x_72 + 4.86737942068728*x_73 + 6.92725040329935*x_74 + 5.50911708331763*x_75 - 3.59591635670407*x_76 + 2.59963283788594*x_77 + 3.56172264053811*x_78 - 3.46435835542538*x_79 - 0.788502627076079*x_8 + 1.27547623230706*x_80 - 1.74326026305365*x_81 + 3.87169017745334*x_82 + 24.0344496188375*x_83 + 6.80124011402231*x_84 + 261.606049071616*x_85 + 26.7878526312569*x_86 - 342.813292483752*x_87 + 4.4700658527021*x_88 + 14.0470044956727*x_89 + 11.8643610237893*x_9 - 2.66656166632324*x_90 + 1.55459255292744*x_91 + 18.5417731180804*x_92 + 9.88993006502942*x_93 + 0.69574118336872*x_94 + 4.21060329893595*x_95 - 4.63852105102796*x_96 - 1.51667731299323*x_97 + 1.97082518294027*x_98 - 2.29148873058884*x_99 - 0.0557191244390762*std::exp(0.974319815635681*x_13) - 0.0242283028841844*std::exp(0.917599856853485*x_23) - 0.0162683082611564*std::exp(0.962479829788208*x_23) + 2.85095420166714*std::exp(0.991839826107025*x_23) - 5.08456123456237*std::exp(0.46383985877037*x_24) + 0.0169071559391719*std::exp(0.505679845809937*x_3) + 0.00268187263489083*std::exp(0.962799787521362*x_4) - 0.000144777418636739*std::exp(1.48031985759735*x_6) + 0.0661272172768031*std::exp(1.60375988483429*x_6) + 0.00418510566119208*std::exp(1.61999988555908*x_6) + 0.3060598812882*std::exp(0.964879810810089*x_8) + 1.08947339954528*std::sin(0.255999982357025*x_100 + 1.97703981399536) - 5.22745581612028*std::sin(0.303279936313629*x_25 - 1.17663979530334) - 0.203864810066898*std::sin(0.349359840154648*x_91 + 1.99583983421326) + 20.5339871507163*std::sin(0.362639844417572*x_91 + 2.0079197883606) + 0.766447392343147*std::sin(0.406319856643677*x_91 + 1.99735975265503) + 0.0492727039541871*std::sin(0.281519949436188*x_94 - 7.42751979827881) + 0.289848880042129*std::sin(0.29615992307663*x_94 + 1.97567975521088) - 0.0603918948176499*std::sin(0.289999932050705*x_95 + 1.96423983573914) - 0.0815239541637569*std::sin(0.296799927949905*x_97 + 1.95119988918304) - 452.651742996151 + 1.03231064771896e-6*std::exp(-7.87896013259888*x_113));
}

inline float score_1(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (5.61970049482291*x_1 + 5.63232332618677*x_10 - 0.49702020829446*x_100 + 0.15298153725346*x_101 - 0.451609833114277*x_102 - 0.118386668275073*x_103 + 4.99602743305207*x_104 + 0.476711198619635*x_105 + 0.346919984539069*x_106 - 0.583870926566491*x_107 + 0.408895670092521*x_108 + 0.227913815692357*x_109 - 1.41627487878576*x_11 + 1.031636699225*x_110 + 0.639669699460588*x_111 - 0.597735911889054*x_112 - 0.843278667742489*x_113 - 0.150556183208585*x_114 + 0.547065257639316*x_115 - 4.36681741485602*x_116 - 1.01215441522175*x_117 - 0.0143560027351566*x_118 - 0.821677708773376*x_119 - 0.489374418569475*x_12 + 0.228076491352068*x_120 - 0.0686760836053601*x_13 - 4.34004889226959*x_14 - 2.07363288259079*x_15 - 0.486064395841267*x_16 + 0.564923736920161*x_17 - 11.4915286819202*x_18 + 8.14166052267538*x_19 - 0.449212483892191*x_2 - 0.572753172230726*x_20 - 3.0425944844876*x_21 - 13.1388287135401*x_22 - 0.142059266861122*x_23 - 1.4141696877187*x_24 - 0.374358594506758*x_25 + 5.66404297174016*x_26 + 3.27995038862204*x_27 + 11.5041905739659*x_28 - 32.4196252019604*x_29 - 0.687523015085292*x_3 - 1.00192823037604*x_30 + 0.494676905971518*x_31 - 0.736099506675175*x_32 - 1.14690012658434*x_33 + 43.1096996775667*x_34 - 0.71846666026975*x_35 - 6.76123809134799*x_36 - 58.0959798344944*x_37 + 0.796057934797543*x_38 + 31.6824982968057*x_39 - 8.36329107871555*x_4 - 0.0102469028854596*x_40 - 231.419887548903*x_41 - 71.8965568611164*x_42 - 2.39098226155247*x_43 - 0.526090682417729*x_44 - 6.58063892905671*x_45 + 85.6904169443737*x_46 - 29.0884408267185*x_47 - 3.52225158846905*x_48 + 12.8988344052916*x_49 - 0.889663782129396*x_5 + 37.2173734852523*x_50 - 0.834581554349331*x_51 + 0.499908141868181*x_52 - 1.67878216945095*x_53 + 3.24833628622488*x_54 + 5.29842326642062*x_55 - 4.55160603633831*x_56 - 1.90826569344537*x_57 - 3.75898343684222*x_58 - 28.2014884270224*x_59 + 0.165077187747031*x_6 - 1.27633497552378*x_60 + 0.342306364671957*x_61 - 0.405662428634055*x_62 - 0.163595328896774*x_63 - 0.512428714444042*x_64 + 0.0729413791421159*x_65 - 1.66011893721221*x_66 - 0.571776918214594*x_67 + 0.0373773021713392*x_68 - 0.263383405606784*x_69 - 0.021277524200097*x_7 + 0.129125594300468*x_70 - 0.185364712683601*x_71 - 0.0860879610990486*x_72 - 0.597141595123348*x_73 - 0.986544952120831*x_74 - 0.352541268924926*x_75 + 0.414760262407426*x_76 - 0.43359673066992*x_77 + 0.147932399947644*x_78 + 0.215717327230257*x_79 - 0.0674121000608387*x_8 - 0.304077219789762*x_80 - 0.0843856625087157*x_81 - 0.439479752357555*x_82 - 1.17009369083716*x_83 + 0.156303212358702*x_84 - 22.1357446855716*x_85 - 1.70729488767796*x_86 + 30.4873248294884*x_87 - 0.434615323711656*x_88 - 1.49711167254533*x_89 - 0.723009523603365*x_9 + 0.238771497074015*x_90 + 0.00863834316356816*x_91 - 1.30972869328832*x_92 - 0.507677993947005*x_93 + 0.232872791700444*x_94 - 0.186715911099148*x_95 + 0.328199213242849*x_96 - 0.242467766848008*x_97 - 0.448938681152453*x_98 - 0.209461371638909*x_99 + 0.00460182984727471*std::exp(0.974319815635681*x_13) - 0.0371672359052151*std::exp(0.917599856853485*x_23) - 0.006442649732394*std::exp(0.962479829788208*x_23) - 0.235459660763158*std::exp(0.991839826107025*x_23) + 0.419932758905588*std::exp(0.46383985877037*x_24) + 0.0348259819282429*std::exp(0.505679845809937*x_3) + 0.00552421993696544*std::exp(0.962799787521362*x_4) - 0.000298217854215147*std::exp(1.48031985759735*x_6) - 0.00546143187361717*std::exp(1.60375988483429*x_6) - 3.58361267701231e-5*std::exp(1.61999988555908*x_6) - 0.0252774161644516*std::exp(0.964879810810089*x_8) + 1.67129802887633*std::sin(0.255999982357025*x_100 + 1.97703981399536) + 0.0447615387704082*std::sin(0.303279936313629*x_25 - 1.17663979530334) - 0.0807354731012879*std::sin(0.349359840154648*x_91 + 1.99583983421326) - 1.69589734054493*std::sin(0.362639844417572*x_91 + 2.0079197883606) + 1.17576254417515*std::sin(0.406319856643677*x_91 + 1.99735975265503) + 0.101493728669556*std::sin(0.281519949436188*x_94 - 7.42751979827881) + 0.114787277168633*std::sin(0.29615992307663*x_94 + 1.97567975521088) - 0.1243974471578*std::sin(0.289999932050705*x_95 + 1.96423983573914) - 0.167926040585449*std::sin(0.296799927949905*x_97 + 1.95119988918304) - 4954.25512076927 + 2.12639145762524e-6*std::exp(-7.87896013259888*x_113));
}

inline float score_2(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (15.4094741707167*x_1 + 16.4968751329519*x_10 - 1.70444078813201*x_100 + 0.0670083119085085*x_101 - 0.801750782187505*x_102 - 0.460796407418062*x_103 + 21.6110816566379*x_104 + 0.880186221996236*x_105 - 3.42861554624966*x_106 - 1.41670585380798*x_107 + 1.16019527973562*x_108 + 1.04768756139236*x_109 - 3.08075629815299*x_11 + 2.04845092209047*x_110 + 0.988275359976964*x_111 - 2.57348952301166*x_112 - 2.24977353315072*x_113 - 1.34884214421138*x_114 + 1.10830537066094*x_115 - 10.6815177844114*x_116 - 4.02040278981532*x_117 + 0.181126669744513*x_118 - 3.04683660183471*x_119 - 3.82687844306675*x_12 + 0.707892660264041*x_120 - 0.00508870694288496*x_13 - 10.5679345239002*x_14 - 9.61571775227285*x_15 - 0.212229575968263*x_16 - 0.688500117853249*x_17 - 22.960341112374*x_18 + 22.4670430969342*x_19 - 0.892375122471176*x_2 - 6.39743284889245*x_20 - 16.7637686959039*x_21 - 8.44253522157449*x_22 + 10.3903799330348*x_23 + 16.7480082375115*x_24 - 1.88083175592582*x_25 + 1.86077353546304*x_26 + 11.1311604236489*x_27 + 78.6646105854743*x_28 - 82.8369589832534*x_29 - 0.857913714473185*x_3 + 0.472050481071547*x_30 + 1.27937639501339*x_31 - 2.81674007476472*x_32 - 4.9089664907064*x_33 + 204.493716745382*x_34 - 0.319674581664204*x_35 - 18.630759194438*x_36 - 165.996526116969*x_37 + 1.89848480776675*x_38 + 101.303647766802*x_39 - 16.5130532660541*x_4 - 1.48076503186263*x_40 - 171.705960301181*x_41 - 289.129729934165*x_42 - 11.4785116626227*x_43 - 2.10045766240538*x_44 - 49.8284571879359*x_45 + 208.363849514736*x_46 - 125.587362072844*x_47 - 8.48124256555333*x_48 + 27.2566031027222*x_49 - 4.16703176614379*x_5 + 107.562848514134*x_50 + 0.594006616161407*x_51 + 7.41376741892671*x_52 - 7.99499065490807*x_53 + 11.8492754962309*x_54 + 36.8546253944884*x_55 - 31.0872831729859*x_56 - 7.56955453034337*x_57 - 21.2981039688102*x_58 - 176.501181938379*x_59 - 0.169987223978009*x_6 - 2.91055924796271*x_60 + 1.01741982789169*x_61 - 2.21902088269015*x_62 - 0.021993410915171*x_63 - 0.992966605372831*x_64 - 0.277315389940563*x_65 - 4.0584295258356*x_66 - 1.64463488748194*x_67 + 0.274044341725269*x_68 - 0.398615439411941*x_69 - 0.681056978622279*x_7 + 1.09491769476789*x_70 - 0.236501975756922*x_71 - 0.825172520330861*x_72 - 1.23684742991121*x_73 - 1.80708028480399*x_74 - 1.33292660161946*x_75 + 0.858047915260159*x_76 - 0.749558156398705*x_77 - 0.800828547475053*x_78 + 0.837855464547731*x_79 + 0.211162949565793*x_8 - 0.401065620787939*x_80 + 0.325282938572893*x_81 - 0.965546532124617*x_82 - 5.58592587343596*x_83 - 1.62092551510384*x_84 - 63.7785143085973*x_85 - 6.33831138347523*x_86 + 86.4809006957694*x_87 - 1.15569010657645*x_88 - 3.47733283295274*x_89 - 2.95322724859416*x_9 + 0.756837802515571*x_90 - 0.341725175150284*x_91 - 4.53933462518194*x_92 - 2.3151049566119*x_93 - 0.0400261437773904*x_94 - 0.990771321906629*x_95 + 1.17009031991191*x_96 + 0.234012146204722*x_97 - 0.642016377396027*x_98 + 0.407465292301665*x_99 + 0.0137905813718967*std::exp(0.974319815635681*x_13) - 0.0166712463134942*std::exp(0.917599856853485*x_23) + 0.00906309934272542*std::exp(0.962479829788208*x_23) - 0.705616182979155*std::exp(0.991839826107025*x_23) + 1.25843785507241*std::exp(0.46383985877037*x_24) + 0.0251485405266115*std::exp(0.505679845809937*x_3) + 0.00398915009055425*std::exp(0.962799787521362*x_4) - 0.000215349097921821*std::exp(1.48031985759735*x_6) - 0.0163666026688908*std::exp(1.60375988483429*x_6) - 0.000969064980405202*std::exp(1.61999988555908*x_6) - 0.0757503593257818*std::exp(0.964879810810089*x_8) + 0.749655453897908*std::sin(0.255999982357025*x_100 + 1.97703981399536) + 1.21042209638615*std::sin(0.303279936313629*x_25 - 1.17663979530334) + 0.113573396597957*std::sin(0.349359840154648*x_91 + 1.99583983421326) - 5.08219796240806*std::sin(0.362639844417572*x_91 + 2.0079197883606) + 0.52738457683839*std::sin(0.406319856643677*x_91 + 1.99735975265503) + 0.0732906585061222*std::sin(0.281519949436188*x_94 - 7.42751979827881) - 0.161475253113552*std::sin(0.29615992307663*x_94 + 1.97567975521088) - 0.0898298933164576*std::sin(0.289999932050705*x_95 + 1.96423983573914) - 0.121262764272894*std::sin(0.296799927949905*x_97 + 1.95119988918304) - 7443.598595541 + 1.53550994937379e-6*std::exp(-7.87896013259888*x_113));
}

inline float score_3(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-32.3431239848246*x_1 - 16.7097095444192*x_10 + 2.77825096062233*x_100 + 0.141461620935912*x_101 + 0.512250180669994*x_102 + 0.278266161925257*x_103 - 21.5865665186879*x_104 - 2.00328339857996*x_105 + 5.12964641753338*x_106 + 0.892305984032978*x_107 - 1.92558204224916*x_108 - 0.685917015278843*x_109 + 3.21529844964434*x_11 - 3.66566896419263*x_110 - 1.99125186893079*x_111 + 4.17371401946285*x_112 + 3.43097211078583*x_113 + 1.66627138536239*x_114 - 3.13488207467539*x_115 + 22.8933014872265*x_116 + 7.02182093109195*x_117 - 0.606181442350132*x_118 + 4.39573942435413*x_119 + 6.16749006512656*x_12 - 1.29829510789124*x_120 - 0.097202977908751*x_13 + 20.0850322568031*x_14 + 18.2085085757778*x_15 + 0.524715609305127*x_16 - 0.687721493203837*x_17 + 38.9173101040765*x_18 - 30.110482791746*x_19 + 0.996702301985786*x_2 + 10.4914149836699*x_20 + 23.045705502739*x_21 + 27.5501497887348*x_22 - 7.48898845760742*x_23 - 13.2966226706859*x_24 + 3.72749437428264*x_25 - 8.89188213644868*x_26 - 18.18499576672*x_27 - 94.621855556228*x_28 + 147.832538337227*x_29 + 0.903871523279025*x_3 - 1.77424046065924*x_30 - 2.59627315160185*x_31 + 4.13640313500207*x_32 + 6.96913441445658*x_33 - 310.947408956696*x_34 + 1.33144113453671*x_35 + 33.4484992732435*x_36 + 245.884069602059*x_37 - 2.83757958397795*x_38 - 176.606310598626*x_39 + 31.5665592118239*x_4 + 2.23458943670366*x_40 + 391.510762754062*x_41 + 492.994035341529*x_42 + 61.4011736709847*x_43 + 3.01272290248*x_44 + 62.8837294514347*x_45 - 390.022607719836*x_46 + 216.579895251149*x_47 + 16.5613975209404*x_48 - 53.7909038210458*x_49 + 5.87372020673352*x_5 - 155.809126943039*x_50 - 7.5387939634967*x_51 - 2.61421618703431*x_52 + 1.24283771961259*x_53 - 13.5951985334883*x_54 - 63.6645663860002*x_55 + 22.9951249242368*x_56 + 14.3888953807721*x_57 + 56.0346564923854*x_58 + 178.732817227949*x_59 - 0.352847437039087*x_6 + 5.26827743827662*x_60 - 2.00688803037779*x_61 + 2.42251009108764*x_62 + 0.0491088400386338*x_63 + 1.70692157153852*x_64 + 0.617244083276224*x_65 + 6.51294147734238*x_66 + 2.66797003110983*x_67 - 0.741389848453062*x_68 + 0.465089857231427*x_69 + 1.17003760866461*x_7 - 1.33064680671034*x_70 + 0.257738648639982*x_71 + 0.849286662184037*x_72 + 2.67801297680061*x_73 + 4.8079114314549*x_74 + 2.0858112758328*x_75 - 2.1013105650304*x_76 + 1.21279561117049*x_77 + 0.177581147692818*x_78 - 1.34388322574995*x_79 + 0.0225464943048995*x_8 + 0.482285306258851*x_80 - 0.511324943284207*x_81 + 2.25107210159403*x_82 + 9.41186614977126*x_83 - 0.09888165361363*x_84 + 123.125175250292*x_85 + 10.9775394275077*x_86 - 149.656134251488*x_87 + 1.68409286858418*x_88 + 6.99532233236779*x_89 + 3.18119942220358*x_9 - 0.3947536842134*x_90 + 0.250654693772533*x_91 + 6.89809127006892*x_92 + 3.59621714074156*x_93 - 0.000229144585201013*x_94 + 1.48554143113885*x_95 - 1.34357132994768*x_96 - 0.154934722392824*x_97 + 0.910123033496959*x_98 - 0.584722490191641*x_99 - 0.0237598991241417*std::exp(0.974319815635681*x_13) - 0.0238793808826663*std::exp(0.917599856853485*x_23) + 0.0183384097025248*std::exp(0.962479829788208*x_23) + 1.2157115697901*std::exp(0.991839826107025*x_23) - 2.16817229703271*std::exp(0.46383985877037*x_24) + 0.0204669231042348*std::exp(0.505679845809937*x_3) + 0.00324653544281148*std::exp(0.962799787521362*x_4) - 0.000175260008550728*std::exp(1.48031985759735*x_6) + 0.028198146106459*std::exp(1.60375988483429*x_6) + 0.000644601940257214*std::exp(1.61999988555908*x_6) + 0.130510878958725*std::exp(0.964879810810089*x_8) + 1.07378343392998*std::sin(0.255999982357025*x_100 + 1.97703981399536) - 0.805147691473144*std::sin(0.303279936313629*x_25 - 1.17663979530334) + 0.229806096056138*std::sin(0.349359840154648*x_91 + 1.99583983421326) + 8.75615810960739*std::sin(0.362639844417572*x_91 + 2.0079197883606) + 0.755409460405733*std::sin(0.406319856643677*x_91 + 1.99735975265503) + 0.0596469711757722*std::sin(0.281519949436188*x_94 - 7.42751979827881) - 0.326731423372519*std::sin(0.29615992307663*x_94 + 1.97567975521088) - 0.0731072849744127*std::sin(0.289999932050705*x_95 + 1.96423983573914) - 0.09868865627228*std::sin(0.296799927949905*x_97 + 1.95119988918304) - 5954.19827909702 + 1.24966154701365e-6*std::exp(-7.87896013259888*x_113));
}

inline float score_4(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (12.2733309708014*x_1 + 2.31402560127201*x_10 - 0.824314189426561*x_100 + 0.043210502731493*x_101 - 0.235729342844349*x_102 + 0.0742213688219615*x_103 + 0.118880810790214*x_104 + 0.957764832913214*x_105 + 0.184497656531526*x_106 - 0.0863018513625497*x_107 + 0.71104181837736*x_108 - 0.158542736356778*x_109 - 1.19566543804222*x_11 + 1.69288304507581*x_110 + 1.16937290362701*x_111 - 1.02741419283807*x_112 - 1.13643041030367*x_113 - 0.0125633009805875*x_114 + 1.54600456193915*x_115 - 9.50971093932228*x_116 - 1.92513542100924*x_117 + 0.146922918609025*x_118 - 1.01291874120455*x_119 - 0.681232011118383*x_12 + 0.406477493361685*x_120 - 0.00333275549550834*x_13 - 7.92860641803274*x_14 - 5.23371487225556*x_15 - 0.805761891887185*x_16 + 1.50713121875098*x_17 - 17.8043452110456*x_18 + 8.68236699563381*x_19 - 0.403570702052692*x_2 - 1.4632485610088*x_20 - 2.796344083204*x_21 - 24.3332498453837*x_22 - 3.82284856719804*x_23 - 7.34345280289638*x_24 - 0.978118563056435*x_25 + 10.1043823611646*x_26 + 4.38678234595549*x_27 - 2.11153322388654*x_28 - 53.7094265739825*x_29 - 0.704366177521478*x_3 - 0.976738789201494*x_30 + 0.995168177314553*x_31 - 0.962661872944847*x_32 - 1.24507875446677*x_33 + 62.2823162510782*x_34 - 1.45831977579141*x_35 - 11.6825909675873*x_36 - 71.6847344275161*x_37 + 1.06830104995846*x_38 + 55.6205766107378*x_39 - 14.6387706583257*x_4 - 0.112552571080812*x_40 - 358.861411152641*x_41 - 122.655411569794*x_42 - 26.315528721318*x_43 - 0.689436848468968*x_44 - 4.00581931998872*x_45 + 153.59984111416*x_46 - 53.7452582986136*x_47 - 6.77872164349346*x_48 + 28.4476599457094*x_49 - 1.02131065079005*x_5 + 47.2997903454135*x_50 + 2.85518308045536*x_51 - 4.01331679632588*x_52 + 3.34946128844603*x_53 + 1.83316056395858*x_54 + 12.6911318490479*x_55 + 6.18020346698238*x_56 - 4.26444717696265*x_57 - 19.4252461675519*x_58 + 9.26715890706453*x_59 + 0.882918040629626*x_6 - 1.88664161189453*x_60 + 0.750077103720581*x_61 - 0.119303587227042*x_62 - 0.230849952772768*x_63 - 0.799413104821435*x_64 + 0.0291152884078477*x_65 - 2.37757106050618*x_66 - 0.81949046832569*x_67 + 0.256381094465238*x_68 - 0.284228128405781*x_69 - 0.115453508332323*x_7 - 0.0343546196633309*x_70 - 0.102420929614346*x_71 + 0.0614574764875194*x_72 - 1.27211709728768*x_73 - 2.31202537131673*x_74 - 0.521660813362393*x_75 + 1.08721645770862*x_76 - 0.626108939095708*x_77 + 0.80836966972615*x_78 + 0.321575916980812*x_79 - 0.401343900059307*x_8 - 0.410831315300887*x_80 - 0.0824043767744942*x_81 - 1.0126044748573*x_82 - 2.13742954992538*x_83 + 1.6445095642037*x_84 - 44.5568051053304*x_85 - 3.21802137997718*x_86 + 49.3250226262277*x_87 - 0.570559922259769*x_88 - 3.14918848854578*x_89 - 0.35582659935177*x_9 - 0.121811698029406*x_90 + 0.125539063113548*x_91 - 1.85918792617521*x_92 - 0.807788314682578*x_93 + 0.327501761994875*x_94 - 0.236967781947686*x_95 + 0.241228239207522*x_96 - 0.445761604182272*x_97 - 0.552147231003383*x_98 - 0.330994171714029*x_99 + 0.00777751636345611*std::exp(0.974319815635681*x_13) - 0.0219982103723218*std::exp(0.917599856853485*x_23) - 0.0422737489682392*std::exp(0.962479829788208*x_23) - 0.397948517284666*std::exp(0.991839826107025*x_23) + 0.709725046847111*std::exp(0.46383985877037*x_24) - 0.0109296989226101*std::exp(0.505679845809937*x_3) - 0.00173370734578908*std::exp(0.962799787521362*x_4) + 9.35919442740849e-5*std::exp(1.48031985759735*x_6) - 0.00923032297469964*std::exp(1.60375988483429*x_6) + 0.000358880784869976*std::exp(1.61999988555908*x_6) - 0.0427211618789729*std::exp(0.964879810810089*x_8) + 0.98919289365044*std::sin(0.255999982357025*x_100 + 1.97703981399536) - 0.448264296779547*std::sin(0.303279936313629*x_25 - 1.17663979530334) - 0.529749600627078*std::sin(0.349359840154648*x_91 + 1.99583983421326) - 2.86622273195112*std::sin(0.362639844417572*x_91 + 2.0079197883606) + 0.695899793587609*std::sin(0.406319856643677*x_91 + 1.99735975265503) - 0.0318525375444394*std::sin(0.281519949436188*x_94 - 7.42751979827881) + 0.753182113156939*std::sin(0.29615992307663*x_94 + 1.97567975521088) + 0.0390405831765919*std::sin(0.289999932050705*x_95 + 1.96423983573914) + 0.0527014878904684*std::sin(0.296799927949905*x_97 + 1.95119988918304) - 1796.16435416671 - 6.6734136804356e-7*std::exp(-7.87896013259888*x_113));
}

inline float score_5(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-124.62435044943*x_1 - 62.469187265106*x_10 + 9.901408286648*x_100 - 0.0417418446312575*x_101 + 2.31707232660789*x_102 + 0.849990207875088*x_103 - 72.2981459198424*x_104 - 8.60834119484462*x_105 + 12.0355476225079*x_106 + 3.40576183461523*x_107 - 6.97942986950382*x_108 - 1.82992942755946*x_109 + 13.5506866869491*x_11 - 14.9155584096732*x_110 - 8.49018595272821*x_111 + 14.2199057378125*x_112 + 13.1354495599649*x_113 + 4.84654432787556*x_114 - 12.4923123281865*x_115 + 88.9012359496404*x_116 + 24.9880162164139*x_117 - 2.05656723372811*x_118 + 15.5149214827783*x_119 + 21.202702057197*x_12 - 5.08251948658108*x_120 - 0.0130551058991967*x_13 + 79.1426670087698*x_14 + 62.0567505748317*x_15 + 3.37516524368554*x_16 - 6.76661145515226*x_17 + 156.451434761774*x_18 - 114.30034544434*x_19 + 4.2254098335675*x_2 + 32.0128895276866*x_20 + 75.815862013638*x_21 + 149.634538587828*x_22 - 10.246150763366*x_23 - 16.6402106630041*x_24 + 12.902476763618*x_25 - 57.0036646287749*x_26 - 69.0317013522814*x_27 - 314.430341091459*x_28 + 579.127540696471*x_29 + 4.71663596889283*x_3 - 4.23714807604356*x_30 - 10.172014285799*x_31 + 14.4964441658462*x_32 + 24.3074686136406*x_33 - 1053.81359086493*x_34 + 7.20806491425118*x_35 + 127.567030649193*x_36 + 938.365104279458*x_37 - 10.6220952981105*x_38 - 652.400695109223*x_39 + 129.742726368724*x_4 + 6.15836178581975*x_40 + 2142.65132642092*x_41 + 1774.72622296098*x_42 + 238.931908180366*x_43 + 10.3442530282819*x_44 + 185.274688844064*x_45 - 1531.21053687099*x_46 + 757.624751590574*x_47 + 64.9447210265809*x_48 - 197.595950995698*x_49 + 19.7110647252809*x_5 - 578.404324034428*x_50 - 23.8336230914096*x_51 - 1.77662244633329*x_52 - 3.57770331134961*x_53 - 47.8757071707685*x_54 - 212.353370244179*x_55 + 51.6279500870703*x_56 + 50.8876029149104*x_57 + 193.092874315316*x_58 + 528.082655360984*x_59 - 0.329238997388325*x_6 + 21.8987802847956*x_60 - 7.32068430605197*x_61 + 6.88610328355027*x_62 + 0.782960545204064*x_63 + 7.02362518973667*x_64 + 1.90476664239246*x_65 + 25.6325665888847*x_66 + 10.2193618520716*x_67 - 2.43320506165846*x_68 + 2.02191341524625*x_69 + 3.67065452145252*x_7 - 4.03077215967961*x_70 + 1.68064828350217*x_71 + 2.15237523745101*x_72 + 10.6272254549129*x_73 + 20.3443892165308*x_74 + 7.44089570581285*x_75 - 7.8829355375378*x_76 + 5.17212198218228*x_77 - 0.722928736861605*x_78 - 4.83799945007992*x_79 - 0.0271033703494507*x_8 + 2.10437653349639*x_80 - 1.11704735770885*x_81 + 8.97380571060288*x_82 + 32.5195441182997*x_83 - 3.12245719882153*x_84 + 464.032445241611*x_85 + 38.5060272239726*x_86 - 576.608281152001*x_87 + 6.33013836114357*x_88 + 26.397737337691*x_89 + 10.0503821658936*x_9 - 1.35038821482983*x_90 + 0.336067978764326*x_91 + 24.33825510418*x_92 + 11.9384694224619*x_93 - 0.991028136053254*x_94 + 5.04104997100384*x_95 - 4.52689687461196*x_96 + 0.534399187537919*x_97 + 4.39589135977441*x_98 - 1.09482066416665*x_99 - 0.0887242937401172*std::exp(0.974319815635681*x_13) + 0.0194357035922272*std::exp(0.917599856853485*x_23) + 0.0152672849465762*std::exp(0.962479829788208*x_23) + 4.5397141569393*std::exp(0.991839826107025*x_23) - 8.09639614865426*std::exp(0.46383985877037*x_24) - 0.0329015515673611*std::exp(0.505679845809937*x_3) - 0.00521896001381987*std::exp(0.962799787521362*x_4) + 0.000281738792864024*std::exp(1.48031985759735*x_6) + 0.105297610272013*std::exp(1.60375988483429*x_6) + 0.000966921196136538*std::exp(1.61999988555908*x_6) + 0.487354155020349*std::exp(0.964879810810089*x_8) - 0.873964724908591*std::sin(0.255999982357025*x_100 + 1.97703981399536) - 1.20774437724332*std::sin(0.303279936313629*x_25 - 1.17663979530334) + 0.191320578385065*std::sin(0.349359840154648*x_91 + 1.99583983421326) + 32.6972745167234*std::sin(0.362639844417572*x_91 + 2.0079197883606) - 0.614836474837902*std::sin(0.406319856643677*x_91 + 1.99735975265503) - 0.0958853408488408*std::sin(0.281519949436188*x_94 - 7.42751979827881) - 0.272013867208011*std::sin(0.29615992307663*x_94 + 1.97567975521088) + 0.117523434972877*std::sin(0.289999932050705*x_95 + 1.96423983573914) + 0.158646705072349*std::sin(0.296799927949905*x_97 + 1.95119988918304) - 8496.64519893641 - 2.00889032618248e-6*std::exp(-7.87896013259888*x_113));
}

inline float score_6(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-139.310211911428*x_1 - 50.0701365404572*x_10 + 9.94115818031663*x_100 + 0.161719635499717*x_101 + 1.26770281285048*x_102 + 0.125630596143228*x_103 - 52.4227651103814*x_104 - 9.94467899924641*x_105 + 9.59542092748471*x_106 + 1.4279806106062*x_107 - 7.03369088836356*x_108 - 0.139048757218898*x_109 + 11.2268317486755*x_11 - 16.0269422402081*x_110 - 9.41726033242785*x_111 + 14.1038682272412*x_112 + 13.1614476787295*x_113 + 3.84858945936728*x_114 - 14.9084818825292*x_115 + 99.9531891204757*x_116 + 25.856631978968*x_117 - 2.55158203959404*x_118 + 14.7552751577007*x_119 + 21.369116508971*x_12 - 5.4726291315836*x_120 - 0.0433895732948425*x_13 + 86.2575441955062*x_14 + 65.2517780435706*x_15 + 3.96323133453987*x_16 - 10.826055689756*x_17 + 164.951843833239*x_18 - 107.665538678978*x_19 + 3.75619646032479*x_2 + 30.8978073138316*x_20 + 68.8634099140376*x_21 + 185.911101236774*x_22 + 9.0486093349819*x_23 + 12.9815102900131*x_24 + 13.9956128583192*x_25 - 73.4079309531675*x_26 - 72.059874043049*x_27 - 268.161257264502*x_28 + 620.415621616217*x_29 + 4.39706698758415*x_3 - 5.46682988773446*x_30 - 11.306367494826*x_31 + 13.8465971231448*x_32 + 22.9648567522463*x_33 - 1013.38460659617*x_34 + 9.03442348488297*x_35 + 136.134084836609*x_36 + 931.646386648433*x_37 - 10.5289994595098*x_38 - 681.69184156719*x_39 + 142.492501302918*x_4 + 5.37429020026206*x_40 + 2558.25778379953*x_41 + 1836.98380240423*x_42 + 310.868548177958*x_43 + 9.62268986377342*x_44 + 148.032572259718*x_45 - 1660.63510663715*x_46 + 781.17141997194*x_47 + 71.1023169654705*x_48 - 208.915612941446*x_49 + 18.1722139106494*x_5 - 559.477787420436*x_50 - 32.7161494484791*x_51 + 14.3136542592023*x_52 - 23.3818324258797*x_53 - 39.9715345119022*x_54 - 213.890539041642*x_55 + 3.3049756218376*x_56 + 54.3715238021835*x_57 + 223.806728878554*x_58 + 344.563886129276*x_59 - 0.659781835563358*x_6 + 24.1510040208426*x_60 - 7.92710004968351*x_61 + 4.70653978805247*x_62 + 0.944017007873731*x_63 + 7.46069358121278*x_64 + 2.15988025400766*x_65 + 26.4199124182472*x_66 + 10.5541096267164*x_67 - 2.82283051871576*x_68 + 1.86956692508673*x_69 + 3.65156411749963*x_7 - 3.29617381850006*x_70 + 1.83147535440672*x_71 + 1.18112834692513*x_72 + 11.9510457499114*x_73 + 24.3151502537947*x_74 + 7.37093750920134*x_75 - 9.00628040508734*x_76 + 5.41865698779232*x_77 - 2.6921987260714*x_78 - 4.88218602973714*x_79 + 0.337891217528834*x_8 + 1.85531441064653*x_80 - 0.904397550641763*x_81 + 10.3255316943676*x_82 + 33.0300722484919*x_83 - 7.85932257399475*x_84 + 503.492297928788*x_85 + 39.5756637164935*x_86 - 608.567567546407*x_87 + 6.14787476351429*x_88 + 28.7999964954144*x_89 + 7.32787284877737*x_9 - 0.159461268680013*x_90 - 0.302343977998131*x_91 + 23.7180307691452*x_92 + 11.5189515746932*x_93 - 1.3600140962332*x_94 + 4.8509298914987*x_95 - 3.62752365789372*x_96 + 1.12616897124334*x_97 + 4.52144449098453*x_98 - 0.794863427955425*x_99 - 0.0925766870042152*std::exp(0.974319815635681*x_13) - 0.0299203919764076*std::exp(0.917599856853485*x_23) + 0.0336394017707168*std::exp(0.962479829788208*x_23) + 4.73682774896574*std::exp(0.991839826107025*x_23) - 8.44794024860398*std::exp(0.46383985877037*x_24) - 0.0201992686946586*std::exp(0.505679845809937*x_3) - 0.00320407915748279*std::exp(0.962799787521362*x_4) + 0.000172968061008243*std::exp(1.48031985759735*x_6) + 0.109869614031498*std::exp(1.60375988483429*x_6) - 0.00078516602426707*std::exp(1.61999988555908*x_6) + 0.508514986906258*std::exp(0.964879810810089*x_8) + 1.34542940618193*std::sin(0.255999982357025*x_100 + 1.97703981399536) + 0.980720926172707*std::sin(0.303279936313629*x_25 - 1.17663979530334) + 0.421549072138357*std::sin(0.349359840154648*x_91 + 1.99583983421326) + 34.1169844382421*std::sin(0.362639844417572*x_91 + 2.0079197883606) + 0.946513113932225*std::sin(0.406319856643677*x_91 + 1.99735975265503) - 0.0588669430898819*std::sin(0.281519949436188*x_94 - 7.42751979827881) - 0.599345842973128*std::sin(0.29615992307663*x_94 + 1.97567975521088) + 0.0721512308036959*std::sin(0.289999932050705*x_95 + 1.96423983573914) + 0.0973980639398664*std::sin(0.296799927949905*x_97 + 1.95119988918304) - 3144.5705074498 - 1.23331920665147e-6*std::exp(-7.87896013259888*x_113));
}

inline float score_7(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (17.7646581981647*x_1 - 0.647144495392875*x_10 - 0.950520274027883*x_100 - 0.19355767887472*x_101 + 0.431437092115997*x_102 + 0.254043628731483*x_103 - 1.82892472178544*x_104 + 1.262966019075*x_105 - 0.994266817182861*x_106 + 0.736602239315498*x_107 + 0.637067640140077*x_108 - 0.572634578381351*x_109 + 0.247865709761561*x_11 + 1.61463339522007*x_110 + 0.984803148284392*x_111 - 1.39870502814566*x_112 - 1.10336160250098*x_113 - 0.162696066451111*x_114 + 2.15640752210991*x_115 - 12.6786271014624*x_116 - 2.85981803779955*x_117 + 0.476123801863811*x_118 - 1.13742606687581*x_119 - 2.46114132570599*x_12 + 0.631670623457676*x_120 + 0.0679147217917404*x_13 - 9.834276353531*x_14 - 7.91971345757268*x_15 - 0.29341002766845*x_16 + 1.97072868390198*x_17 - 15.3818534777687*x_18 + 6.35001675180761*x_19 - 0.0348487542419748*x_2 - 3.44832733880141*x_20 - 5.11125489547515*x_21 - 23.2713833894867*x_22 - 5.84874302976934*x_23 - 7.8121853435336*x_24 - 1.86161630869747*x_25 + 9.25590805293189*x_26 + 7.77206254306603*x_27 + 14.7547421162784*x_28 - 67.4966383461785*x_29 + 0.0224155567725778*x_3 + 1.71551774606779*x_30 + 1.39518200160513*x_31 - 1.10828694900108*x_32 - 1.82383241885265*x_33 + 91.3076617585851*x_34 - 1.09660438663839*x_35 - 15.0413459746996*x_36 - 76.9042402330828*x_37 + 0.803975310728501*x_38 + 73.2940081364797*x_39 - 15.5975139837127*x_4 - 0.517220985429237*x_40 - 268.409000454322*x_41 - 203.312081130466*x_42 - 56.7750464455902*x_43 - 0.688421251144989*x_44 - 5.68275818583644*x_45 + 186.282122551409*x_46 - 87.6602786319413*x_47 - 8.22394021719355*x_48 + 20.9491044985713*x_49 - 1.349534901303*x_5 + 40.9671260878571*x_50 + 7.22982150464932*x_51 - 6.33866893136439*x_52 + 9.14542338071135*x_53 + 0.838988735818859*x_54 + 24.3330334018276*x_55 + 14.4721178522828*x_56 - 6.66518624703938*x_57 - 34.6801907055292*x_58 + 20.7781097157027*x_59 + 0.115800442765868*x_6 - 2.77676555522575*x_60 + 0.94964149582392*x_61 + 0.183088758422795*x_62 - 0.0348406816874218*x_63 - 0.704848489548238*x_64 - 0.402662873109648*x_65 - 2.4168897658817*x_66 - 1.04081073233899*x_67 + 0.451237209708534*x_68 - 0.0201502731399096*x_69 - 0.456631829703588*x_7 + 0.166944646176255*x_70 - 0.133510784532803*x_71 + 0.139027971543237*x_72 - 1.45736378225401*x_73 - 3.42909599917902*x_74 - 0.685549481758852*x_75 + 1.17526035792658*x_76 - 0.446977406403214*x_77 + 0.744263006659884*x_78 + 0.490496678204981*x_79 - 0.106602561420541*x_8 + 0.046112783214435*x_80 + 0.13474175202227*x_81 - 1.36561981201897*x_82 - 3.61019476749964*x_83 + 2.10160067130612*x_84 - 59.6034346138192*x_85 - 4.25251184820576*x_86 + 64.7714468920425*x_87 - 0.438040870420271*x_88 - 3.30977380802909*x_89 + 0.229003530937316*x_9 - 0.453165276723611*x_90 + 0.191568510858198*x_91 - 2.0136843858129*x_92 - 1.05718655497318*x_93 + 0.089440344636653*x_94 - 0.451522260250376*x_95 + 0.0111991760265768*x_96 - 0.112827397485648*x_97 - 0.273798883244039*x_98 + 0.187151344286334*x_99 + 0.00970408003016657*std::exp(0.974319815635681*x_13) + 0.0447895538639626*std::exp(0.917599856853485*x_23) - 0.00765195866434461*std::exp(0.962479829788208*x_23) - 0.496524093187568*std::exp(0.991839826107025*x_23) + 0.885530589993847*std::exp(0.46383985877037*x_24) - 0.0211482867995035*std::exp(0.505679845809937*x_3) - 0.00335461575243442*std::exp(0.962799787521362*x_4) + 0.000181094583999649*std::exp(1.48031985759735*x_6) - 0.0115167604496003*std::exp(1.60375988483429*x_6) + 0.000555245261172979*std::exp(1.61999988555908*x_6) - 0.0533035939086127*std::exp(0.964879810810089*x_8) - 2.01405058148506*std::sin(0.255999982357025*x_100 + 1.97703981399536) - 0.69353567266093*std::sin(0.303279936313629*x_25 - 1.17663979530334) - 0.0958898168576675*std::sin(0.349359840154648*x_91 + 1.99583983421326) - 3.57621295479687*std::sin(0.362639844417572*x_91 + 2.0079197883606) - 1.41688986336951*std::sin(0.406319856643677*x_91 + 1.99735975265503) - 0.0616326766227965*std::sin(0.281519949436188*x_94 - 7.42751979827881) + 0.136333269162635*std::sin(0.29615992307663*x_94 + 1.97567975521088) + 0.0755410973060239*std::sin(0.289999932050705*x_95 + 1.96423983573914) + 0.101974097233597*std::sin(0.296799927949905*x_97 + 1.95119988918304) - 4138.34900812749 - 1.29126399038885e-6*std::exp(-7.87896013259888*x_113));
}

inline float score_8(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-2.49381896748098*x_1 - 3.25054862627101*x_10 + 0.335865978187342*x_100 + 0.0663489691840801*x_101 + 0.00765207295914509*x_102 + 0.113578464185445*x_103 - 5.82940364093762*x_104 - 0.051575611896831*x_105 + 1.54014429689316*x_106 + 0.185711360237895*x_107 - 0.15969800575922*x_108 - 0.269871109207178*x_109 + 0.267037401234444*x_11 - 0.113615186217177*x_110 + 0.0665850973951042*x_111 + 0.615375909624446*x_112 + 0.344909982313125*x_113 + 0.452159127039472*x_114 - 0.0562705079148099*x_115 + 1.31413442578331*x_116 + 0.938647850731183*x_117 - 0.0909952346629813*x_118 + 0.681800915780585*x_119 + 1.35783907081193*x_12 - 0.148438559850208*x_120 - 0.0318958502801556*x_13 + 1.37132104451064*x_14 + 2.31397677503387*x_15 - 0.282265772986969*x_16 + 0.609493315702188*x_17 + 1.23940394788893*x_18 - 3.6887089942956*x_19 + 0.0571915273847216*x_2 + 2.15061006811678*x_20 + 4.8978579444154*x_21 - 5.32687488961089*x_22 - 4.14022360253586*x_23 - 7.60930687718885*x_24 + 0.515295594660102*x_25 + 2.92132285675047*x_26 - 2.67441449496434*x_27 - 27.1920422907556*x_28 + 12.4023080718835*x_29 - 0.13268136509606*x_3 - 1.04367115583458*x_30 - 0.193947041739543*x_31 + 0.639031285186094*x_32 + 1.27057538024028*x_33 - 53.5750285674811*x_34 - 0.404663817326238*x_35 + 3.05291695941569*x_36 + 29.8070935795877*x_37 - 0.204511258814717*x_38 - 19.5910145423115*x_39 + 0.975603175865274*x_4 + 0.569991215114848*x_40 - 86.2317098696487*x_41 + 71.949992808978*x_42 + 3.43926586056181*x_43 + 0.475399851345653*x_44 + 15.3540377541346*x_45 - 26.6636904624008*x_46 + 31.6237677724824*x_47 + 1.01273323202711*x_48 - 0.0149626982399784*x_49 + 1.08998828550034*x_5 - 18.0106408481298*x_50 - 0.642618751525473*x_51 - 2.83820217386099*x_52 + 2.03098165337331*x_53 - 2.75876296018288*x_54 - 11.2239653640143*x_55 + 9.43304331233335*x_56 + 1.7384063035906*x_57 + 5.42836519291732*x_58 + 54.0181779488315*x_59 + 0.369272115397775*x_6 + 0.440041392091632*x_60 - 0.159801369302305*x_61 + 0.597119341587003*x_62 - 0.10934085652883*x_63 + 0.0469885454683733*x_64 + 0.188213731830988*x_65 + 0.537690998723208*x_66 + 0.302141940156866*x_67 - 0.071400088680024*x_68 - 0.028166574572491*x_69 + 0.269005944266612*x_7 - 0.381941207976984*x_70 + 0.00994532751991322*x_71 + 0.266668552062144*x_72 + 0.0705849106461489*x_73 + 0.110473240623502*x_74 + 0.304014598737871*x_75 - 0.00859274922303649*x_76 + 0.00145826813565693*x_77 + 0.476928465785978*x_78 - 0.202692086590902*x_79 - 0.204672549422436*x_8 - 0.0839333710394383*x_80 - 0.188534521429599*x_81 + 0.0895708500037084*x_82 + 1.48896133003025*x_83 + 0.834829060956249*x_84 + 10.6162295693646*x_85 + 1.34207861019864*x_86 - 15.3619339371149*x_87 + 0.163130386303179*x_88 + 0.272349930157239*x_89 + 0.682771742263145*x_9 - 0.16510167754294*x_90 + 0.137770289411288*x_91 + 0.922629639366462*x_92 + 0.568804894947965*x_93 + 0.176778574289719*x_94 + 0.28714507153562*x_95 - 0.242248828677542*x_96 - 0.282419510038659*x_97 - 0.0422591082450763*x_98 - 0.341133441604192*x_99 - 0.00246850597220026*std::exp(0.974319815635681*x_13) - 0.0191274753083002*std::exp(0.917599856853485*x_23) - 0.01724177154267*std::exp(0.962479829788208*x_23) + 0.126304882643656*std::exp(0.991839826107025*x_23) - 0.225259637510256*std::exp(0.46383985877037*x_24) + 0.00420310172267355*std::exp(0.505679845809937*x_3) + 0.00066671080176083*std::exp(0.962799787521362*x_4) - 3.59915186129236e-5*std::exp(1.48031985759735*x_6) + 0.00292961227255564*std::exp(1.60375988483429*x_6) + 0.000366288497885035*std::exp(1.61999988555908*x_6) + 0.013559269863203*std::exp(0.964879810810089*x_8) + 0.860104632522787*std::sin(0.255999982357025*x_100 + 1.97703981399536) - 0.457516988496222*std::sin(0.303279936313629*x_25 - 1.17663979530334) - 0.21606367572687*std::sin(0.349359840154648*x_91 + 1.99583983421326) + 0.909710452648078*std::sin(0.362639844417572*x_91 + 2.0079197883606) + 0.605085863513965*std::sin(0.406319856643677*x_91 + 1.99735975265503) + 0.0122491439492082*std::sin(0.281519949436188*x_94 - 7.42751979827881) + 0.307192861812044*std::sin(0.29615992307663*x_94 + 1.97567975521088) - 0.0150133634572732*std::sin(0.289999932050705*x_95 + 1.96423983573914) - 0.0202667718578828*std::sin(0.296799927949905*x_97 + 1.95119988918304) - 2571.17037732408 + 2.56631374157319e-7*std::exp(-7.87896013259888*x_113));
}

inline float score_9(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-118.621541593332*x_1 - 56.147673030602*x_10 + 9.31465840451198*x_100 + 0.0150742497461904*x_101 + 2.02347207572204*x_102 + 0.690537941384943*x_103 - 64.5382053687483*x_104 - 8.21182645122049*x_105 + 11.1899903923217*x_106 + 2.89196392512966*x_107 - 6.59395798367741*x_108 - 1.49586407608548*x_109 + 12.422157002421*x_11 - 14.1130461468716*x_110 - 8.10388175751514*x_111 + 13.3574351005109*x_112 + 12.2929111632229*x_113 + 4.41316009232556*x_114 - 12.047688729216*x_115 + 84.7657974734138*x_116 + 23.5717314568301*x_117 - 1.98597914077591*x_118 + 14.4449473019401*x_119 + 19.7663565701307*x_12 - 4.79914562982197*x_120 - 0.0419424114802266*x_13 + 74.9994958541736*x_14 + 58.9232999762527*x_15 + 3.2653876405507*x_16 - 6.74965365034618*x_17 + 147.637907183742*x_18 - 105.97306571654*x_19 + 3.88110357685247*x_2 + 30.0382942132511*x_20 + 70.0472674439216*x_21 + 143.997239607275*x_22 - 7.59612417500978*x_23 - 12.3870466764995*x_24 + 12.2356276438723*x_25 - 54.9847316674762*x_26 - 64.5152689811269*x_27 - 285.108554917883*x_28 + 546.441960947244*x_29 + 4.35741444453208*x_3 - 4.02709464112272*x_30 - 9.66254471711211*x_31 + 13.5195993920918*x_32 + 22.5502997966117*x_33 - 984.358840757654*x_34 + 7.01636269367749*x_35 + 120.441336683621*x_36 + 875.075582127319*x_37 - 9.93604785223061*x_38 - 615.369352093112*x_39 + 123.089103261275*x_4 + 5.7440286762945*x_40 + 2042.15254975455*x_41 + 1668.1957052296*x_42 + 233.352033788769*x_43 + 9.64428896697234*x_44 + 169.918616345351*x_45 - 1450.04909241061*x_46 + 713.153427589653*x_47 + 61.6830290477843*x_48 - 189.711897224077*x_49 + 18.2976589505849*x_5 - 539.70767755668*x_50 - 23.8648458945169*x_51 + 0.551161819450109*x_52 - 5.91875789973555*x_53 - 43.6024111630868*x_54 - 200.253353412564*x_55 + 42.1722952118788*x_56 + 48.2273491996259*x_57 + 186.261093848609*x_58 + 469.924483886208*x_59 - 0.586408457318544*x_6 + 20.5915519179973*x_60 - 6.96590526772036*x_61 + 6.20446088642424*x_62 + 0.754512123996627*x_63 + 6.63364940366905*x_64 + 1.79511215142526*x_65 + 24.0647877394687*x_66 + 9.58139951797414*x_67 - 2.35483039936515*x_68 + 1.87071771060571*x_69 + 3.448931907362*x_7 - 3.65191055072866*x_70 + 1.52350288132956*x_71 + 1.91161078377188*x_72 + 10.1564200589371*x_73 + 19.4978086218428*x_74 + 6.96851370191347*x_75 - 7.60383319601149*x_76 + 4.87382546136636*x_77 - 0.978005791442574*x_78 - 4.53114287387358*x_79 + 0.113158678531429*x_8 + 1.98342068319941*x_80 - 1.03591874805684*x_81 + 8.58523123962166*x_82 + 30.5727176366571*x_83 - 3.60925714770339*x_84 + 440.306990731781*x_85 + 36.3379838295716*x_86 - 543.061082853305*x_87 + 5.9166453442411*x_88 + 25.188979290648*x_89 + 9.09267174930358*x_9 - 1.07009889716495*x_90 + 0.251010646674408*x_91 + 22.7661917317175*x_92 + 11.1793896835131*x_93 - 0.96050606511035*x_94 + 4.69244974104057*x_95 - 4.13724910233394*x_96 + 0.584197373434495*x_97 + 4.11661820324068*x_98 - 0.967933047497238*x_99 - 0.0836387673467166*std::exp(0.974319815635681*x_13) + 0.00951755228473663*std::exp(0.917599856853485*x_23) + 0.0283021321928195*std::exp(0.962479829788208*x_23) + 4.27950542277645*std::exp(0.991839826107025*x_23) - 7.63232442072355*std::exp(0.46383985877037*x_24) - 0.0078805618257091*std::exp(0.505679845809937*x_3) - 0.00125004247810645*std::exp(0.962799787521362*x_4) + 6.7481923195018e-5*std::exp(1.48031985759735*x_6) + 0.099262129417481*std::exp(1.60375988483429*x_6) + 0.000693795770820041*std::exp(1.61999988555908*x_6) + 0.459419839470326*std::exp(0.964879810810089*x_8) - 0.427975500082206*std::sin(0.255999982357025*x_100 + 1.97703981399536) - 0.866593828443468*std::sin(0.303279936313629*x_25 - 1.17663979530334) + 0.354665568868883*std::sin(0.349359840154648*x_91 + 1.99583983421326) + 30.8231220660527*std::sin(0.362639844417572*x_91 + 2.0079197883606) - 0.301081886131106*std::sin(0.406319856643677*x_91 + 1.99735975265503) - 0.0229664049487587*std::sin(0.281519949436188*x_94 - 7.42751979827881) - 0.504252881566059*std::sin(0.29615992307663*x_94 + 1.97567975521088) + 0.0281491495432153*std::sin(0.289999932050705*x_95 + 1.96423983573914) + 0.0379989729422953*std::sin(0.296799927949905*x_97 + 1.95119988918304) + 1786.00188758 - 4.81168323753301e-7*std::exp(-7.87896013259888*x_113));
}

inline float score_10(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (85.0506414033515*x_1 + 19.330388649505*x_10 - 5.20838003341682*x_100 + 0.0646065627095264*x_101 - 0.230179178401515*x_102 + 0.379796044056368*x_103 + 14.9154812719356*x_104 + 6.7406738648058*x_105 - 0.625755454138165*x_106 + 0.359293285318104*x_107 + 3.73884767796561*x_108 - 1.10921225472121*x_109 - 6.31508681732564*x_11 + 9.6954709143099*x_110 + 6.05077748908373*x_111 - 6.9171369561144*x_112 - 7.29321148599391*x_113 - 0.87522899545283*x_114 + 9.65427812738878*x_115 - 60.9236738806047*x_116 - 14.1030181082753*x_117 + 1.51149256253068*x_118 - 7.27683696732831*x_119 - 11.3116811102878*x_12 + 3.42393866030637*x_120 - 0.106619095969786*x_13 - 52.4752865567749*x_14 - 34.2090509817928*x_15 - 3.07834720275437*x_16 + 9.95364079831215*x_17 - 95.9726043703455*x_18 + 56.0499206548116*x_19 - 2.01383955854945*x_2 - 12.7644651324793*x_20 - 29.3518347259155*x_21 - 140.618620435604*x_22 - 21.792462052416*x_23 - 36.6843129798237*x_24 - 7.52696926546491*x_25 + 59.4803076281918*x_26 + 41.0254383787247*x_27 + 110.197991377093*x_28 - 369.36239880707*x_29 - 2.73034967148902*x_3 + 3.48269575500195*x_30 + 6.96142894910919*x_31 - 6.84343921904179*x_32 - 11.171656938983*x_33 + 488.093443235421*x_34 - 6.76697693778644*x_35 - 78.6946057043434*x_36 - 512.98504622799*x_37 + 5.2362522785959*x_38 + 383.088864730541*x_39 - 88.9590269823993*x_4 - 1.62067620219206*x_40 - 1821.39630261034*x_41 - 1007.68969120518*x_42 - 214.221942047369*x_43 - 4.57579902056133*x_44 - 38.8182538031813*x_45 + 999.568045970116*x_46 - 410.293178208464*x_47 - 43.3044773712499*x_48 + 115.95852317795*x_49 - 8.17679026733704*x_5 + 292.631481052217*x_50 + 20.2766295545564*x_51 - 18.4962925892039*x_52 + 27.6886927861171*x_53 + 16.5068449474656*x_54 + 111.134211821101*x_55 + 42.3579514340434*x_56 - 29.642063915739*x_57 - 128.66557040829*x_58 - 30.6535651539901*x_59 - 0.517749963868416*x_6 - 15.0850303348798*x_60 + 4.44628955699301*x_61 - 0.135507853414128*x_62 - 0.882100651545304*x_63 - 4.52580924288497*x_64 - 1.16514901171923*x_65 - 15.3243625287282*x_66 - 6.01657922702046*x_67 + 1.51669892970309*x_68 - 0.919667407575753*x_69 - 1.77276123296204*x_7 + 0.911699516408041*x_70 - 1.36711956284165*x_71 + 0.365570171324249*x_72 - 7.40094297254264*x_73 - 16.3782684638213*x_74 - 3.87526107714955*x_75 + 5.29630293933652*x_76 - 3.32040059171986*x_77 + 2.90592765337612*x_78 + 2.62359319335688*x_79 - 0.128334698908234*x_8 - 0.991463519915698*x_80 + 0.0485689762829745*x_81 - 6.53936404815138*x_82 - 17.1638764529042*x_83 + 7.75902796574516*x_84 - 295.061122571555*x_85 - 20.5939386054923*x_86 + 358.008278769739*x_87 - 3.25092643283327*x_88 - 16.5842518495036*x_89 - 1.57261836080898*x_9 - 0.635785228103479*x_90 + 0.719590940574666*x_91 - 11.7345187438272*x_92 - 5.22997748067215*x_93 + 1.3493648907658*x_94 - 2.34819028920334*x_95 + 1.27020199210606*x_96 - 1.32707324158092*x_97 - 3.03582284645595*x_98 - 0.112460696258657*x_99 + 0.0522063735956441*std::exp(0.974319815635681*x_13) - 0.000963484668472503*std::exp(0.917599856853485*x_23) + 0.0254024904369455*std::exp(0.962479829788208*x_23) - 2.67121893343904*std::exp(0.991839826107025*x_23) + 4.76401067055054*std::exp(0.46383985877037*x_24) - 0.0273220827713822*std::exp(0.505679845809937*x_3) - 0.00433392501828318*std::exp(0.962799787521362*x_4) + 0.000233961325586128*std::exp(1.48031985759735*x_6) - 0.0619582996816084*std::exp(1.60375988483429*x_6) + 0.00199700395290015*std::exp(1.61999988555908*x_6) - 0.286764673099648*std::exp(0.964879810810089*x_8) + 0.04332498739958*std::sin(0.255999982357025*x_100 + 1.97703981399536) - 2.49438145019965*std::sin(0.303279936313629*x_25 - 1.17663979530334) + 0.318328974655535*std::sin(0.349359840154648*x_91 + 1.99583983421326) - 19.2394445424316*std::sin(0.362639844417572*x_91 + 2.0079197883606) + 0.0304792422004679*std::sin(0.406319856643677*x_91 + 1.99735975265503) - 0.0796250357333633*std::sin(0.281519949436188*x_94 - 7.42751979827881) - 0.45259060040126*std::sin(0.29615992307663*x_94 + 1.97567975521088) + 0.0975937262816334*std::sin(0.289999932050705*x_95 + 1.96423983573914) + 0.131743282638797*std::sin(0.296799927949905*x_97 + 1.95119988918304) - 19.6886093757903 - 1.66822125875169e-6*std::exp(-7.87896013259888*x_113));
}

inline float score_11(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-61.6113781341007*x_1 - 31.4855640404285*x_10 + 5.04714018099839*x_100 - 0.0530341717716948*x_101 + 1.37254032043459*x_102 + 0.468421976424734*x_103 - 36.3382580823488*x_104 - 4.24210224987012*x_105 + 6.09446503822221*x_106 + 1.92444140383912*x_107 - 3.64921145429252*x_108 - 1.05782637717582*x_109 + 7.3812127093032*x_11 - 7.60953295076481*x_110 - 4.42762474968393*x_111 + 7.191632125976*x_112 + 6.66522818243088*x_113 + 2.41654946491116*x_114 - 6.21558263480434*x_115 + 44.3158033291512*x_116 + 12.4849356395883*x_117 - 0.934741667757216*x_118 + 7.85900897873687*x_119 + 10.0177734629514*x_12 - 2.49149781215371*x_120 - 0.024069075115541*x_13 + 39.5562301043024*x_14 + 31.2917406509893*x_15 + 1.92652683741213*x_16 - 3.12574747778662*x_17 + 80.3627177888064*x_18 - 58.4581732424726*x_19 + 2.23966281292073*x_2 + 15.9395113098066*x_20 + 37.655364019998*x_21 + 75.1931815227804*x_22 - 6.55024532457329*x_23 - 9.48387112644489*x_24 + 6.29376924953405*x_25 - 28.4686016169075*x_26 - 33.1694383553555*x_27 - 148.767643883432*x_28 + 287.961699013052*x_29 + 2.60136953059432*x_3 - 1.12049147845762*x_30 - 5.02635678305364*x_31 + 7.35721495629574*x_32 + 12.0920258264663*x_33 - 529.968468594256*x_34 + 3.83269703446952*x_35 + 63.5565609059706*x_36 + 470.522611857814*x_37 - 5.48756753507095*x_38 - 326.775164963491*x_39 + 65.5514179025221*x_4 + 3.11652212326087*x_40 + 1091.78768391126*x_41 + 872.755302797671*x_42 + 112.231406583886*x_43 + 5.32951903644634*x_44 + 95.3652508646933*x_45 - 766.791702621575*x_46 + 375.009211592615*x_47 + 32.6507021339252*x_48 - 107.873189133109*x_49 + 9.95895536191682*x_5 - 296.549591543234*x_50 - 11.3534836458488*x_51 - 1.36681709240584*x_52 - 0.0198630582893973*x_53 - 24.2791513454733*x_54 - 105.915119542405*x_55 + 28.8856239424964*x_56 + 25.2849291639603*x_57 + 95.5948886980508*x_58 + 269.896013398858*x_59 - 0.792364199131644*x_6 + 10.5229167926353*x_60 - 3.70772970112885*x_61 + 3.65071682909409*x_62 + 0.461904486487231*x_63 + 3.59983688526786*x_64 + 0.794981273859332*x_65 + 12.9460761799387*x_66 + 5.07077166063328*x_67 - 1.21598876032807*x_68 + 1.10870109057586*x_69 + 1.77491502211123*x_7 - 1.9374582378742*x_70 + 0.735096722241453*x_71 + 1.14921468144261*x_72 + 5.39595718037761*x_73 + 9.88210344421268*x_74 + 3.74043102427778*x_75 - 4.10222949909497*x_76 + 2.68378709345194*x_77 - 0.470252981251123*x_78 - 2.39466428758554*x_79 + 0.228207054552475*x_8 + 1.28590215547302*x_80 - 0.523573950690942*x_81 + 4.4603290169569*x_82 + 16.1273409905777*x_83 - 1.57242051783414*x_84 + 232.034655645043*x_85 + 19.4537800760468*x_86 - 286.348338787176*x_87 + 3.27674966802381*x_88 + 13.6184899890829*x_89 + 5.33747013598803*x_9 - 0.725554063698747*x_90 + 0.218605092316307*x_91 + 12.3983833945029*x_92 + 6.06826037617703*x_93 - 0.5577734095571*x_94 + 2.48442256923534*x_95 - 2.39279173557818*x_96 + 0.393326494911545*x_97 + 2.29662597996586*x_98 - 0.3577877415125*x_99 - 0.0445451037436859*std::exp(0.974319815635681*x_13) + 0.0276749327711849*std::exp(0.917599856853485*x_23) + 0.0375873915731827*std::exp(0.962479829788208*x_23) + 2.27921834666693*std::exp(0.991839826107025*x_23) - 4.06489351663005*std::exp(0.46383985877037*x_24) + 0.0123141807454359*std::exp(0.505679845809937*x_3) + 0.00195331872972017*std::exp(0.962799787521362*x_4) - 0.00010544738023146*std::exp(1.48031985759735*x_6) + 0.0528659375668626*std::exp(1.60375988483429*x_6) + 0.000571599120164528*std::exp(1.61999988555908*x_6) + 0.244682042315113*std::exp(0.964879810810089*x_8) - 1.24445790662836*std::sin(0.255999982357025*x_100 + 1.97703981399536) - 0.7139626540139*std::sin(0.303279936313629*x_25 - 1.17663979530334) + 0.471022943564035*std::sin(0.349359840154648*x_91 + 1.99583983421326) + 16.4160617581186*std::sin(0.362639844417572*x_91 + 2.0079197883606) - 0.875479399326514*std::sin(0.406319856643677*x_91 + 1.99735975265503) + 0.0358873476113411*std::sin(0.281519949436188*x_94 - 7.42751979827881) - 0.669686311342219*std::sin(0.29615992307663*x_94 + 1.97567975521088) - 0.043985914072093*std::sin(0.289999932050705*x_95 + 1.96423983573914) - 0.0593772666595693*std::sin(0.296799927949905*x_97 + 1.95119988918304) + 3492.07786170941 + 7.51874528583298e-7*std::exp(-7.87896013259888*x_113));
}

int predict(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120)
{
    float s0 = score_0(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s1 = score_1(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s2 = score_2(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s3 = score_3(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s4 = score_4(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s5 = score_5(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s6 = score_6(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s7 = score_7(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s8 = score_8(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s9 = score_9(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s10 = score_10(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s11 = score_11(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);

    float max_score = s0;
    int max_index = 0;

    if(s1 > max_score) {
        max_score = s1;
        max_index = 1;
    }

    if(s2 > max_score) {
        max_score = s2;
        max_index = 2;
    }

    if(s3 > max_score) {
        max_score = s3;
        max_index = 3;
    }

    if(s4 > max_score) {
        max_score = s4;
        max_index = 4;
    }

    if(s5 > max_score) {
        max_score = s5;
        max_index = 5;
    }

    if(s6 > max_score) {
        max_score = s6;
        max_index = 6;
    }

    if(s7 > max_score) {
        max_score = s7;
        max_index = 7;
    }

    if(s8 > max_score) {
        max_score = s8;
        max_index = 8;
    }

    if(s9 > max_score) {
        max_score = s9;
        max_index = 9;
    }

    if(s10 > max_score) {
        max_score = s10;
        max_index = 10;
    }

    if(s11 > max_score) {
        max_score = s11;
        max_index = 11;
    }

    return max_index;
}

#endif
