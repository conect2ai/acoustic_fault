
#ifndef KAN_MODEL_H
#define KAN_MODEL_H

#include <cmath>


inline float score_0(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.00014351834503114*x_1 + 0.000748480139448644*x_10 + 0.000398978870075299*x_100 + 0.00187620524753077*x_101 - 0.000389991376839317*x_102 - 0.000334972725956527*x_103 + 0.000130668540714295*x_104 + 0.00167153861326111*x_105 + 0.000256399226671954*x_106 - 7.26627931227868e-5*x_107 - 0.000606292259726285*x_108 + 7.28323590574931e-6*x_109 - 6.42944796824842e-5*x_11 - 0.000193526443378101*x_110 - 8.22273993833866e-5*x_111 + 0.00102923143088606*x_112 + 6.86043699267416e-5*x_113 - 0.000698403636369579*x_114 - 0.00162690568749295*x_115 + 0.00153529096732293*x_116 + 0.000222877076956528*x_117 - 0.000782085067585597*x_118 - 0.000563100872956277*x_119 - 0.000911560334514566*x_12 - 0.000355399737899347*x_120 - 7.44761453685522e-5*x_13 - 0.000442811115871057*x_14 + 6.60839284984536e-5*x_15 - 6.89782296517738e-5*x_16 - 0.000107502651359409*x_17 - 0.000406095092399793*x_18 - 0.000228939823244868*x_19 + 2.2541173679102e-5*x_2 + 0.00157083330388735*x_20 - 5.36962417442295e-5*x_21 + 0.000461920087268388*x_22 + 0.000277129289110081*x_23 + 0.0004089067967442*x_24 - 0.000209704853173509*x_25 - 0.00010626744015398*x_26 + 0.000641335608611536*x_27 + 0.000484365557505591*x_28 - 8.06450324083525e-5*x_29 - 0.000424016179806531*x_3 - 1.4710995762694e-5*x_30 - 4.94038305952395e-5*x_31 + 0.000861476755920631*x_32 - 0.000896202155030724*x_33 - 0.000484530668541779*x_34 - 0.000306258307832288*x_35 - 0.000130549919457054*x_36 - 0.000627234057418089*x_37 - 0.00147777980624889*x_38 - 0.00172971975181026*x_39 - 0.000124137962194195*x_4 - 0.000132687318803889*x_40 + 0.00118357049340385*x_41 - 0.000937774974669702*x_42 - 0.00158939222815521*x_43 + 3.82207523873357e-5*x_44 + 0.000672054632470978*x_45 - 0.000584427259625096*x_46 - 0.00188028388486412*x_47 - 0.00254812148747873*x_48 + 0.000313653330631435*x_49 - 0.000145633140331521*x_5 - 0.00191720885691087*x_50 - 0.00200900160993885*x_51 + 0.00058388790210787*x_52 + 5.92208943752603e-5*x_53 - 0.00135794856428041*x_54 - 3.62017361301477e-5*x_55 + 0.00147663340552459*x_56 + 4.71571612820997e-5*x_57 + 0.00114357022193191*x_58 + 0.000188864709130912*x_59 - 2.45002023322231e-5*x_6 - 0.000215227300823176*x_60 + 0.000191855673134235*x_61 - 5.07144780181874e-6*x_62 + 5.60944442753377e-5*x_63 + 1.59621857947746e-5*x_64 - 1.28342307708759e-5*x_65 + 2.91020147915288e-5*x_66 - 4.82200566405832e-5*x_67 + 9.21878669678538e-6*x_68 + 8.21425700257026e-5*x_69 + 0.000638295027795466*x_7 - 1.59506634826083e-5*x_70 + 0.000107123401239594*x_71 - 4.48005944228763e-6*x_72 - 2.41872197093492e-5*x_73 + 3.09940592002942e-5*x_74 + 8.51574959116743e-6*x_75 + 2.86171859995422e-5*x_76 + 0.000108059385613723*x_77 + 8.57532398044557e-6*x_78 + 7.85795492637235e-6*x_79 + 2.02110866238386e-5*x_8 + 1.21021742125069e-5*x_80 + 3.95664432288993e-5*x_81 - 4.37341682495579e-5*x_82 - 0.000157620873985295*x_83 - 1.38558950267711e-5*x_84 - 3.685096115656e-6*x_85 + 1.40533930257729e-5*x_86 - 4.27659680822917e-5*x_87 + 3.28485380849485e-6*x_88 - 9.42957299970508e-5*x_89 - 0.000961688800929015*x_9 + 4.77630156109035e-5*x_90 + 6.30947218058752e-6*x_91 - 6.39443060542314e-5*x_92 + 0.000210529835274622*x_93 - 8.41958696415187e-5*x_94 - 1.76133604887184e-7*x_95 + 0.000425036303542639*x_96 + 0.000301916601722217*x_97 + 0.000260883651289823*x_98 - 9.69161532572356e-5*x_99 + 1.36322988336e-6*std::pow(0.814879834651947 - 5.53343963623047*x_19, 2) - 8.43725102935427e-9*std::pow(0.817359864711761 - 6.45175981521606*x_23, 2) - 2.58430114300571e-10*std::pow(1.38503980636597 - 7.12336015701294*x_10, 2) - 1.02618790458422e-8*std::pow(2.25367975234985 - 5.73983955383301*x_4, 2) + 6.59443194608045e-7*std::pow(2.6431999206543 - 7.30952024459839*x_59, 2) + 3.7165939660015e-8*std::pow(5.20296001434326 - 9.00399971008301*x_15, 2) - 2.04788701975182e-7*std::pow(7.96920013427734 - 7.90776014328003*x_27, 2) - 2.5118319296946e-7*std::pow(-8.08119964599609*x_14 - 7.46519994735718, 2) - 2.05514363537308e-6*std::pow(-6.89904022216797*x_22 - 1.4171998500824, 2) - 1.64789891854504e-6*std::pow(-4.69047975540161*x_26 - 6.72648000717163, 2) - 3.89454354189483e-6*std::pow(-2.57999992370605*x_28 - 7.52744007110596, 2) + 1.39489889226082e-6*std::pow(-4.49319982528687*x_42 - 6.96000003814697, 2) + 2.07079358803334e-7*std::pow(-3.42927980422974*x_42 - 6.80200004577637, 2) + 6.51237118535309e-8*std::pow(-8.52272033691406*x_57 - 2.62191987037659, 2) - 3.48037001447283e-6*std::pow(-6.33992004394531*x_60 - 9.99560070037842, 2) - 2.54486124713569e-6*std::pow(-5.4445595741272*x_9 - 8.69223976135254, 2) + 1.12562052057202e-7*std::exp(0.629279851913452*x_1) - 8.26469329307326e-5*std::exp(0.49567985534668*x_13) + 0.000151272915638681*std::exp(0.526799857616425*x_14) - 0.000816788765458103*std::exp(0.362639844417572*x_16) + 1.96707419872538e-5*std::exp(0.359759837388992*x_19) - 0.000225195894942677*std::exp(0.451119869947433*x_2) + 2.05640663198963e-5*std::exp(0.299999833106995*x_24) - 0.00011690861269651*std::exp(0.411119878292084*x_26) - 7.95763050245362e-5*std::exp(0.428639858961105*x_27) + 8.63195238967253e-6*std::exp(0.789199888706207*x_3) - 1.75558066783999e-5*std::exp(0.5655198097229*x_30) + 0.00030994416810089*std::exp(0.292399853467941*x_59) - 7.69249393033452e-5*std::exp(0.325199842453003*x_60) + 1.84923507427994e-5*std::log(4.99583959579468*x_24 + 9.18455982208252) + 1.24248013293788e-6*std::sin(0.278239965438843*x_10 - 1.21111989021301) + 0.000442202955000219*std::sin(0.324959933757782*x_10 + 4.96639966964722) + 3.47539365843269e-5*std::sin(0.254079967737198*x_100 + 1.78135991096497) + 0.0111590963498864*std::sin(0.262799948453903*x_102 + 1.76351988315582) - 0.000627034209319769*std::sin(0.247759968042374*x_104 + 4.57936000823975) + 0.00417541597004515*std::sin(0.222719997167587*x_105 + 1.78591990470886) - 1.81419424551921e-5*std::sin(0.284959942102432*x_107 - 7.83568000793457) + 0.0012309834661002*std::sin(0.256959974765778*x_109 + 7.99103975296021) - 0.00606854886123186*std::sin(0.259119987487793*x_109 - 7.63520002365112) - 0.00330281181548193*std::sin(0.271839946508408*x_109 + 1.74463987350464) + 2.67535532640831e-5*std::sin(1.23983979225159*x_109 - 5.41856002807617) + 0.00617305647540977*std::sin(0.130800053477287*x_11 + 4.94279956817627) + 0.00636496211445216*std::sin(0.259599983692169*x_11 + 1.96687984466553) + 0.00126842242763239*std::sin(0.277599930763245*x_11 + 7.97864007949829) - 5.26423773121291e-7*std::sin(0.491999864578247*x_11 - 7.40000009536743) - 0.00236823353443419*std::sin(0.219919994473457*x_110 + 1.97583973407745) + 0.000432725496366332*std::sin(0.226159989833832*x_111 + 8.16951942443848) + 2.3940314510962e-6*std::sin(0.314239919185638*x_111 - 2.16447973251343) + 5.23700272654393e-7*std::sin(0.219359993934631*x_112 + 4.78791999816895) + 0.00936413193554419*std::sin(0.243999972939491*x_112 + 1.78271985054016) + 0.00592710076605815*std::sin(0.222879990935326*x_115 + 4.98295974731445) + 0.000447265026005741*std::sin(0.266079962253571*x_115 + 1.5596798658371) - 0.000694152889780527*std::sin(0.327519834041595*x_116 + 1.41927993297577) + 0.000105765914604772*std::sin(0.298719942569733*x_117 + 7.94647979736328) + 0.00333565646403389*std::sin(0.2882399559021*x_119 - 1.63407981395721) + 2.11709058023753e-5*std::sin(0.31687992811203*x_119 + 4.7346396446228) - 0.000477059296254776*std::sin(0.323039829730988*x_119 - 8.13776016235352) - 2.62315177627925e-6*std::sin(0.349839836359024*x_119 - 4.97839975357056) - 0.00456545554414059*std::sin(0.334239840507507*x_120 + 4.82775974273682) - 0.000824772590076138*std::sin(0.373439848423004*x_120 + 4.61023998260498) + 0.00474280511804676*std::sin(0.429599851369858*x_13 - 1.23991990089417) - 2.37034271979904e-5*std::sin(0.467999845743179*x_13 - 10.0) + 5.53220019457873e-5*std::sin(0.470319837331772*x_13 + 1.72207987308502) + 0.00307579903088722*std::sin(0.148880034685135*x_15 - 1.42711985111237) + 0.00345910715450049*std::sin(0.338799834251404*x_15 + 1.84023988246918) - 6.45630098257169e-5*std::sin(0.589119851589203*x_16 - 4.59656000137329) + 0.000211058470074141*std::sin(0.797439873218536*x_16 + 7.98800039291382) + 0.0025614442682198*std::sin(0.239039987325668*x_17 - 4.38751983642578) + 0.000827838610743753*std::sin(0.420719861984253*x_17 - 1.38295984268188) - 0.000169823615189256*std::sin(0.189040005207062*x_20 + 1.59415984153748) - 0.00128213442126702*std::sin(0.194240003824234*x_20 + 7.61240005493164) + 0.0029533773645804*std::sin(0.192159995436668*x_21 - 1.5998398065567) - 0.00235704463524801*std::sin(0.35471984744072*x_21 - 1.15311980247498) - 9.14035473915602e-6*std::sin(1.03207981586456*x_21 + 3.58415985107422) + 7.38454991044751e-5*std::sin(0.359679847955704*x_22 - 1.39007985591888) + 0.00136876376231777*std::sin(0.501279830932617*x_22 - 7.46343994140625) + 1.87370651433946e-7*std::sin(0.398959845304489*x_23 + 2.00783967971802) - 9.42662310352374e-5*std::sin(0.550239861011505*x_23 + 8.02112007141113) - 0.000868379008543673*std::sin(0.284879922866821*x_24 - 4.38207960128784) - 1.14052098107708e-5*std::sin(0.54671984910965*x_24 + 8.00600051879883) + 8.92885452083512e-5*std::sin(0.255519956350327*x_26 + 7.79239988327026) - 5.04408028800765e-6*std::sin(0.547199845314026*x_26 - 4.34791994094849) - 0.00342802402470894*std::sin(0.378799855709076*x_27 - 1.19023990631104) + 7.06836536003896e-5*std::sin(0.430399864912033*x_27 - 7.43319988250732) - 2.35003875162669e-5*std::sin(0.422399878501892*x_28 + 1.96871984004974) - 1.19604525321461e-7*std::sin(0.532399833202362*x_28 - 7.56040000915527) - 0.000187255925260723*std::sin(0.250159978866577*x_29 + 2.00159978866577) + 0.000254504896503127*std::sin(0.349919855594635*x_29 + 4.61783981323242) - 0.00186757578604823*std::sin(0.397999823093414*x_29 - 4.60591983795166) + 1.53306416300993e-6*std::sin(0.704639852046967*x_29 - 1.58823990821838) + 0.0158317332240179*std::sin(0.186480015516281*x_30 + 4.79576015472412) - 1.05356378827964e-5*std::sin(0.536159813404083*x_31 - 7.41943979263306) + 0.00308728140952519*std::sin(0.215360000729561*x_32 - 4.59135961532593) - 0.00694557259585302*std::sin(0.219119995832443*x_33 - 4.39343976974487) + 0.0126909355326881*std::sin(0.235119983553886*x_33 + 8.20096015930176) + 0.0144244862612471*std::sin(0.217759996652603*x_34 + 8.19967937469482) - 0.0046806329156745*std::sin(0.231279984116554*x_35 - 1.20599985122681) + 0.00201898375704419*std::sin(0.249599978327751*x_35 + 8.18247985839844) - 0.00223445930148639*std::sin(0.256719976663589*x_35 - 1.22463989257813) - 0.00193592322006068*std::sin(0.240879982709885*x_36 - 1.20711994171143) + 0.0011030247637388*std::sin(0.258319973945618*x_37 - 7.43327951431274) + 0.000352672463331282*std::sin(0.289519935846329*x_38 + 1.55455982685089) + 0.00161776646542891*std::sin(0.538479864597321*x_4 - 4.58392000198364) + 9.13122705650957e-6*std::sin(0.726399838924408*x_4 + 5.0065598487854) + 3.04198872229302e-7*std::sin(1.04535984992981*x_4 + 3.9663200378418) - 0.014013777780092*std::sin(0.226799994707108*x_40 - 1.39975988864899) + 2.64903756467914e-5*std::sin(0.213839992880821*x_41 + 1.59519982337952) - 0.00141081870444325*std::sin(0.218319997191429*x_41 + 1.57967984676361) - 0.00396880688303771*std::sin(0.350719839334488*x_41 + 1.61295986175537) + 1.08299058371349e-5*std::sin(0.249279975891113*x_43 - 1.22215986251831) + 0.00121756276681506*std::sin(0.457919865846634*x_43 + 4.92479991912842) + 0.000513519116080587*std::sin(0.489919871091843*x_43 + 7.90343999862671) - 0.00436242938725729*std::sin(0.279279947280884*x_44 + 1.93007981777191) + 0.00122801531174807*std::sin(0.292959928512573*x_44 - 7.64568042755127) - 0.00730515027764223*std::sin(0.29751992225647*x_44 - 4.45015954971313) + 1.11186308092385e-5*std::sin(0.340239852666855*x_44 + 8.0444803237915) + 1.2071143546771e-5*std::sin(0.557119846343994*x_44 + 7.60111999511719) + 0.000307193577979469*std::sin(0.169520020484924*x_45 - 7.79071998596191) - 0.000586733409985086*std::sin(0.58927983045578*x_45 - 7.79103994369507) - 0.0028314851205512*std::sin(0.268879950046539*x_46 - 1.40031981468201) - 1.64546431181641e-5*std::sin(0.189680010080338*x_47 + 2.01359987258911) + 0.000230387572108699*std::sin(0.607679843902588*x_47 - 4.6101598739624) - 0.000268289555822483*std::sin(0.661439836025238*x_47 + 7.74631977081299) - 6.71304158057946e-6*std::sin(0.218559995293617*x_48 - 4.41095972061157) - 2.14744839471413e-6*std::sin(0.211199998855591*x_49 + 1.38191986083984) - 1.79532937991935e-5*std::sin(0.37407985329628*x_49 - 4.56288003921509) + 4.69170028080982e-7*std::sin(0.647999823093414*x_5 + 9.99600028991699) + 0.00123159327395411*std::sin(0.575759828090668*x_50 - 4.5734395980835) - 0.00208454333918319*std::sin(0.211119994521141*x_51 - 1.40071988105774) - 0.00368205963643899*std::sin(0.213199988007545*x_52 - 1.20551991462708) - 0.000184208634109806*std::sin(0.213359996676445*x_53 + 1.97695982456207) + 0.00517087042193196*std::sin(0.247039973735809*x_53 + 8.1988000869751) + 0.00491622648514769*std::sin(0.269999951124191*x_53 - 4.61583995819092) + 0.0022529266712807*std::sin(0.210720002651215*x_54 + 1.98495984077454) + 0.000530037169375736*std::sin(0.446799844503403*x_55 + 1.52711987495422) + 0.00334315179408365*std::sin(0.495999842882156*x_55 - 1.39999985694885) - 0.00411025299292253*std::sin(0.184000000357628*x_56 + 1.57647979259491) - 0.00046147581386463*std::sin(0.572159826755524*x_56 + 4.83112001419067) - 0.00479647018957065*std::sin(0.19080001115799*x_57 - 7.40759992599487) - 0.0162408896066456*std::sin(0.193999990820885*x_57 - 1.18895995616913) + 0.00376906207429807*std::sin(0.210400000214577*x_57 - 4.38695955276489) - 0.016143213305447*std::sin(0.234479993581772*x_57 + 1.76807987689972) - 1.59562211191186e-6*std::sin(0.409359842538834*x_57 - 8.01327991485596) - 0.000988779506008942*std::sin(0.503999829292297*x_57 + 1.79999983310699) - 3.55206506934334e-6*std::sin(0.522399842739105*x_57 + 1.65279984474182) + 0.00187020451109955*std::sin(0.156560033559799*x_58 - 1.73479986190796) - 4.3014485485495e-5*std::sin(0.0999200716614723*x_59 - 7.80351972579956) + 0.0178543463946441*std::sin(0.106240063905716*x_59 - 1.25135982036591) + 0.00507900378575123*std::sin(0.146480038762093*x_59 - 7.96208000183105) - 0.00218630262244713*std::sin(0.356559842824936*x_59 - 1.33015990257263) - 0.000291334552408811*std::sin(0.434719860553741*x_59 - 1.43583977222443) + 2.68564581597176e-6*std::sin(0.561039865016937*x_59 - 4.54360008239746) + 0.000971625647711308*std::sin(0.568239867687225*x_59 - 1.55663979053497) - 0.000564144343391165*std::sin(0.23735998570919*x_6 - 7.57872009277344) - 0.00039820390395731*std::sin(0.428959846496582*x_6 - 1.40255987644196) - 0.000331550127496517*std::sin(0.588399827480316*x_6 - 8.19416046142578) - 0.000117263875111994*std::sin(0.580399870872498*x_60 - 4.56799983978271) + 2.00660289576356e-7*std::sin(0.985839784145355*x_64 + 5.59231996536255) - 6.31039252859361e-6*std::sin(1.30951976776123*x_65 + 8.57479953765869) + 9.07514049912109e-6*std::sin(0.747679829597473*x_7 + 7.62128019332886) - 0.00216966721298461*std::sin(0.301279932260513*x_8 + 4.78895998001099) - 0.00749715855661386*std::sin(0.346559852361679*x_8 - 1.35543990135193) + 0.00354628138111988*std::sin(0.225839987397194*x_9 + 4.99991989135742) - 0.000149430606351503*std::sin(0.20456001162529*x_91 + 7.79360008239746) + 5.65933564498468e-5*std::sin(0.287119954824448*x_92 + 1.81895983219147) + 0.00273574720690414*std::sin(0.339519828557968*x_92 + 1.80711996555328) - 5.03957643184452e-5*std::sin(0.43767985701561*x_92 + 4.59567975997925) - 0.00923418645228644*std::sin(0.254879981279373*x_93 - 7.62007999420166) - 8.53696319460495e-5*std::sin(0.255519956350327*x_93 - 4.41703987121582) - 1.97312805905219e-5*std::sin(0.289679944515228*x_93 + 1.5745598077774) + 1.95199401750951e-5*std::sin(0.19080001115799*x_94 + 4.79112005233765) - 0.00303723744730263*std::sin(0.290399938821793*x_94 - 1.39271986484528) - 0.00466511938043583*std::sin(0.331199824810028*x_94 + 1.63039982318878) + 0.00532234940929615*std::sin(0.26199996471405*x_95 - 7.79631996154785) + 0.008750568892784*std::sin(0.291839927434921*x_95 + 7.97679996490479) + 0.000276802271420737*std::sin(0.296879917383194*x_95 - 4.83536005020142) - 3.55073804918183e-6*std::sin(0.306639939546585*x_95 - 4.60048007965088) - 0.00113773614512733*std::sin(0.422399878501892*x_96 + 4.39903974533081) + 0.00253290709872688*std::sin(0.279439955949783*x_97 + 8.17615985870361) + 0.00114473217054025*std::sin(0.330079853534698*x_97 - 1.55287981033325) - 9.46812431707698e-5*std::sin(0.244639977812767*x_98 - 7.41063976287842) - 0.00456054391680087*std::sin(0.277279943227768*x_98 + 8.17543983459473) + 0.00175507317746356*std::sin(0.306719928979874*x_98 + 4.77415990829468) + 0.00415605589366937*std::sin(0.328239858150482*x_98 + 7.83935976028442) - 3.55459223245308e-5*std::sin(0.36287984251976*x_98 - 1.97687971591949) - 0.0649339631199837*std::sin(-0.00065872323921127*x_1 + 0.00155442318759092*x_10 - 0.0229671149998413*x_100 - 0.000671529284911457*x_102 - 0.000205602964828263*x_103 - 0.000447961445351367*x_104 - 0.0223462003955252*x_106 - 0.000470577395954789*x_107 + 3.61042121355829e-5*x_108 - 0.000182942956831163*x_109 - 0.0261628857216618*x_11 + 8.38531127981115e-5*x_110 - 0.000588789660186578*x_111 - 0.00446196174791562*x_113 + 0.015069738983644*x_115 + 0.0221925965870053*x_116 + 0.04392979855731*x_119 - 0.0274013007002385*x_12 - 8.77463957615499e-5*x_120 - 0.000168640871521779*x_13 + 0.00124324026205588*x_14 + 0.000318366299527924*x_15 - 0.00287422767822733*x_16 - 0.00925280609866178*x_17 + 0.00154196409098664*x_18 + 0.00115868124422223*x_19 + 0.00150750033467289*x_2 - 0.000768531051564363*x_21 + 0.00112057370144897*x_22 + 0.000617002570858829*x_23 + 0.000878027307098758*x_24 + 5.30685277662416e-6*x_25 - 0.000594876241677451*x_26 + 0.00127570311391229*x_27 - 0.000352068252865747*x_28 + 0.000136715434762832*x_3 - 0.00429941921857858*x_30 + 0.000219713741190629*x_31 + 0.0309379033569926*x_33 - 0.00367837875292646*x_34 - 0.00137058775760832*x_35 + 0.023411535912488*x_36 + 0.0252179680824459*x_37 + 0.0331983311941048*x_39 + 0.00541262906088192*x_4 - 0.000532415230816923*x_41 - 0.00053749712104895*x_44 + 0.0185123889889459*x_45 + 0.00895597913189365*x_46 + 0.0189942716841085*x_47 - 0.0457754139727317*x_48 - 0.0009601684256806*x_51 - 0.0025037194851968*x_53 - 0.00127792166376817*x_54 - 0.00222101646535247*x_55 - 0.00144357421580822*x_56 + 0.00940222191521779*x_57 + 0.0570650794236972*x_58 - 0.00251315962451186*x_6 - 0.00186433781066816*x_60 - 0.000416106655226782*x_61 - 4.86671511461076e-5*x_62 + 0.000168870372174281*x_63 - 1.09503774992453e-5*x_64 - 0.000345423778887684*x_65 - 0.000384719932769821*x_66 + 7.38201979760926e-5*x_67 + 0.000446322111622147*x_68 + 0.000210711120079328*x_69 + 0.00130612317917096*x_7 + 1.75105389533284e-6*x_70 + 0.000958729257229065*x_71 + 0.000178993390305836*x_72 + 4.52132631664554e-5*x_73 + 0.000718749160678593*x_74 + 0.000137063415849929*x_75 + 0.000356023073047181*x_76 + 0.00038967923812385*x_77 - 0.00269593282240532*x_78 + 0.00134569120761014*x_79 - 0.000222450171195587*x_8 + 0.000416406309875938*x_80 + 0.000347523058638179*x_81 + 6.5133550077651e-5*x_82 + 0.00186981793602986*x_83 + 0.000454229884357837*x_84 - 0.000624334149477143*x_85 - 0.000250661282995113*x_86 - 0.000157984003010253*x_87 + 9.09358520888238e-5*x_88 + 0.000411222601856412*x_89 + 0.000760667795670424*x_9 + 6.68537090879386e-5*x_90 - 0.000814006273318076*x_91 - 0.00124458287164741*x_92 + 0.00402060775696623*x_93 - 0.00318059239685357*x_94 - 0.000603478524412785*x_96 - 6.15592644844559e-5*x_97 - 0.00227536893291101*x_98 - 0.0267574197999638*x_99 + 0.000116602626917227*std::pow(-5.76231956481934*x_5 - 1.65471994876862, 2) + 0.000316916202801623*std::pow(-2.19055986404419*x_52 - 3.38007998466492, 2) - 0.103906503160719*std::sin(0.295599937438965*x_101 - 1.60279989242554) + 0.177203582113741*std::sin(0.265759944915771*x_105 - 4.62527990341187) - 0.223844190838481*std::sin(0.273279964923859*x_112 + 4.96903991699219) + 0.148723441684691*std::sin(0.25503996014595*x_114 + 8.14727973937988) + 0.143047562622474*std::sin(0.252879977226257*x_117 - 1.39735984802246) + 0.054007767086647*std::sin(0.359679847955704*x_118 - 8.16823959350586) + 0.190693910276355*std::sin(0.274879962205887*x_20 - 7.58160018920898) + 0.0890803573621461*std::sin(0.213119998574257*x_29 - 1.81263983249664) + 0.235635580851142*std::sin(0.250159978866577*x_32 + 5.01207971572876) - 0.0758940770708616*std::sin(0.277759939432144*x_38 - 1.41191983222961) + 0.196968645098739*std::sin(0.236719980835915*x_40 + 8.16784000396729) + 0.0728526265397047*std::sin(0.307519912719727*x_42 + 1.74847984313965) + 0.16402924901184*std::sin(0.46383985877037*x_43 + 4.89663982391357) + 0.192427371098795*std::sin(0.288879930973053*x_49 + 1.89487981796265) - 0.0097282611921421*std::sin(0.626239836215973*x_50 + 4.7673602104187) - 0.238139276741755*std::sin(0.350399851799011*x_59 + 8.05471992492676) - 0.00523141797195437*std::sin(0.249279975891113*x_95 + 5.17112016677856) + 1.70115351883459) + 0.100409644729032);
}

inline float score_1(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-1.45097834432325e-5*x_1 + 1.05590228375688e-5*x_10 + 0.000151913902722465*x_100 - 9.1097793561291e-5*x_101 - 0.000227679873040912*x_102 - 8.6602530172211e-5*x_103 - 2.25586619916618e-5*x_104 + 1.48905466041974e-5*x_105 - 0.000107269636110798*x_106 - 4.08500437528135e-5*x_107 - 0.000224834383813782*x_108 + 3.43785087853902e-5*x_109 + 0.000130592856025065*x_11 + 7.92969379360098e-5*x_110 + 3.60996340956116e-5*x_111 - 4.75478107078988e-5*x_112 + 5.02521371719054e-7*x_113 + 5.70327123453917e-5*x_114 - 0.00027506481131141*x_115 - 0.000103940033654864*x_116 + 3.20173039611896e-5*x_117 - 0.00014619086216301*x_118 - 0.000162705321046266*x_119 + 0.000155800303700459*x_12 + 6.79515409359246e-5*x_120 - 1.07923837618193e-5*x_13 + 5.96233986681894e-5*x_14 + 1.2594204316603e-6*x_15 + 1.56813711146761e-5*x_16 - 1.62943363807691e-5*x_17 - 0.000299744948025402*x_18 - 4.71645266866951e-5*x_19 - 2.72409961682843e-6*x_2 - 1.68602599259431e-5*x_20 - 4.57236648451109e-6*x_21 + 2.15960211054385e-5*x_22 - 8.52351708429044e-5*x_23 + 1.03454770693036e-5*x_24 - 2.88512348440546e-5*x_25 - 7.04064780526217e-5*x_26 - 5.05574924511757e-5*x_27 - 2.70532919475292e-5*x_28 - 3.54381978439388e-5*x_29 + 6.69593717862082e-7*x_3 - 8.8550558488549e-5*x_30 + 1.64366603756273e-6*x_31 + 4.19296578922724e-6*x_32 - 0.000665548199750503*x_33 + 7.6602366632365e-5*x_34 - 7.59691194677839e-5*x_35 + 9.00993850594311e-5*x_36 - 0.000163561381062768*x_37 - 5.96386883896995e-5*x_38 - 0.000538825682572692*x_39 - 6.81243126327882e-5*x_4 - 5.16204257147376e-5*x_40 - 7.23519533664106e-5*x_41 - 0.000171427187875552*x_42 + 8.45832022840841e-5*x_43 + 1.36223464689396e-6*x_44 - 0.000110269692846491*x_45 - 7.74129914429269e-5*x_46 - 0.000161688605753934*x_47 - 0.000186289171074573*x_48 - 1.58092062207527e-5*x_49 - 6.5272079139861e-6*x_5 - 8.09012195775458e-5*x_50 - 1.95911169705597e-5*x_51 + 3.71005228649219e-5*x_52 - 3.31619097574212e-5*x_53 + 4.17012573082049e-6*x_54 - 4.6609935089992e-5*x_55 + 5.67096450152474e-5*x_56 - 4.19988774795376e-5*x_57 + 2.05106470380283e-5*x_58 + 3.85299803934866e-5*x_59 + 4.7239980925418e-6*x_6 + 3.39576825791493e-5*x_60 + 1.38069074356224e-5*x_61 + 9.11347432527939e-6*x_62 + 1.9775795166515e-6*x_63 + 1.39405096754078e-5*x_64 - 5.90700960724419e-6*x_65 - 1.35620610348764e-5*x_66 - 5.51906383123451e-6*x_67 - 6.520886251847e-6*x_68 + 1.02200804797565e-5*x_69 - 2.23253692045793e-5*x_7 - 6.6184341897706e-6*x_70 - 6.15021423852192e-6*x_71 - 6.18948723039845e-6*x_72 - 1.49559058109571e-5*x_73 - 1.53824469109321e-5*x_74 + 2.75395733698694e-6*x_75 - 2.8357977763543e-7*x_76 - 8.29028923467107e-6*x_77 - 3.6145345825862e-6*x_78 - 1.98332233445334e-5*x_79 + 4.78405856006926e-6*x_8 + 1.98785601509496e-5*x_80 + 8.54377502780175e-6*x_81 - 2.79365295062886e-6*x_82 + 1.44443176558345e-5*x_83 + 2.63413867215516e-6*x_84 + 6.99461978749232e-6*x_85 + 8.13866429722664e-6*x_86 - 3.15559372969252e-6*x_87 + 1.95161137004178e-6*x_88 - 8.10803673565109e-6*x_89 - 8.72543904936828e-6*x_9 + 8.1407026690607e-6*x_90 + 1.21640388761014e-5*x_91 - 4.4718487330926e-6*x_92 + 2.29972879339966e-5*x_93 + 4.0692445404985e-5*x_94 + 2.91467643802715e-6*x_95 - 0.000163765632400009*x_96 + 7.59349955416018e-6*x_97 + 1.32129600834673e-5*x_98 + 0.000181754780523341*x_99 + 8.37446508803896e-9*std::pow(0.814879834651947 - 5.53343963623047*x_19, 2) - 1.43455130308514e-7*std::pow(0.817359864711761 - 6.45175981521606*x_23, 2) - 1.74478534609176e-7*std::pow(2.25367975234985 - 5.73983955383301*x_4, 2) + 5.35831172932984e-8*std::pow(2.6431999206543 - 7.30952024459839*x_59, 2) - 4.54808654255526e-8*std::pow(5.20296001434326 - 9.00399971008301*x_15, 2) - 2.91000893082443e-8*std::pow(7.96920013427734 - 7.90776014328003*x_27, 2) - 2.04099133951751e-8*std::pow(-8.08119964599609*x_14 - 7.46519994735718, 2) - 1.27558842155615e-6*std::pow(-6.89904022216797*x_22 - 1.4171998500824, 2) + 4.51738055506278e-7*std::pow(-4.69047975540161*x_26 - 6.72648000717163, 2) + 7.5069530547421e-7*std::pow(-2.57999992370605*x_28 - 7.52744007110596, 2) + 3.18938637251949e-7*std::pow(-4.49319982528687*x_42 - 6.96000003814697, 2) + 2.45392518953472e-7*std::pow(-3.42927980422974*x_42 - 6.80200004577637, 2) - 7.15212732842533e-7*std::pow(-5.76231956481934*x_5 - 1.65471994876862, 2) - 1.94388848245013e-6*std::pow(-2.19055986404419*x_52 - 3.38007998466492, 2) + 7.71726925739386e-8*std::pow(-8.52272033691406*x_57 - 2.62191987037659, 2) - 9.76439091580007e-8*std::pow(-6.33992004394531*x_60 - 9.99560070037842, 2) - 1.57954679441368e-6*std::pow(-5.4445595741272*x_9 - 8.69223976135254, 2) + 0.000437347072875127*std::pow(-0.00288035280058542*x_1 - 0.0042454892695003*x_10 - 0.00284564909537007*x_100 - 0.000507750846333349*x_101 + 0.00580299227549543*x_102 - 0.0317355272913612*x_103 + 0.0044765514128866*x_104 + 0.0015324740912108*x_105 - 0.00289862068474832*x_106 - 0.00160840525976354*x_107 + 0.00164041081873573*x_108 + 0.00390252017613948*x_109 - 0.00541160175544553*x_11 - 0.00284231138460176*x_110 + 0.0175655692215116*x_112 - 0.0039585463783825*x_113 + 0.00561062662842147*x_114 - 0.00159734511506697*x_116 + 0.0161051441154887*x_117 - 0.00497784065545318*x_118 - 0.0048077494661219*x_119 - 0.00607058524297395*x_12 - 0.00439008050198068*x_120 - 0.00393285532073073*x_14 - 0.00436722574716389*x_15 - 0.00472149476135014*x_16 - 0.00207265659812239*x_17 - 0.00643882367420398*x_18 - 0.0160064435345069*x_19 - 0.00256537253498278*x_2 + 0.00277176892345282*x_20 - 0.0134324434930647*x_22 + 0.000997283231667348*x_23 - 0.00265982105752682*x_25 - 0.0157295301184628*x_26 + 0.0137193677969752*x_27 - 0.00478246009882665*x_3 - 0.0272986635133309*x_30 + 0.0108002347705756*x_31 + 0.00896464554031584*x_32 + 0.00518695145120407*x_33 + 0.0543175113355378*x_34 + 0.00390636211679194*x_35 + 0.0350658553959816*x_36 + 0.122393949961771*x_37 + 0.0762549951446741*x_38 + 0.155704235988234*x_39 + 0.0193168497966046*x_40 + 0.0141879481723106*x_41 + 0.00959007737649147*x_42 + 0.011301621856893*x_43 + 0.00688485309949586*x_45 + 0.0650114067853836*x_46 - 0.000497764642136611*x_47 + 0.000366616935678436*x_48 + 0.0170868952393862*x_49 - 0.00728026302504832*x_5 - 0.0265332223155806*x_50 + 0.0337645350335682*x_51 + 0.00811959290679109*x_52 - 0.00233686073402048*x_53 + 0.0488415114242731*x_54 + 0.0744003575905581*x_55 + 0.0124134777387019*x_56 + 0.021954515955337*x_57 - 0.00432725540440226*x_58 - 0.00387824066828819*x_6 + 2.78471478552336e-5*x_61 + 0.000157067693080209*x_62 - 0.00163235247721014*x_63 + 0.00036272080901899*x_64 - 0.000156072154715136*x_65 + 0.000116839921462572*x_66 - 0.00193498287074842*x_67 - 0.000727838209009157*x_68 + 0.00296966113919682*x_69 - 0.00704205657241634*x_7 + 0.00140314171378045*x_70 - 0.00348535188734154*x_71 - 0.000375222224818794*x_72 - 0.000927101457623451*x_73 - 0.00655903879581111*x_74 + 2.89713559877436e-5*x_75 + 0.00157657520408456*x_76 + 0.00128041909212289*x_77 - 0.00262216324567341*x_78 + 0.000797234711324582*x_79 - 0.00593026592385214*x_8 - 0.000517308518195876*x_80 - 0.00340808582980949*x_81 + 0.00198207120999228*x_82 + 0.0101137219775918*x_83 - 0.0042205267007465*x_84 + 0.000388208417895495*x_85 + 0.000408489354035298*x_86 - 0.00256185952558396*x_87 - 0.00683734926654556*x_88 - 0.00919162892210241*x_89 - 0.0026554601233209*x_9 + 0.00634241917229083*x_90 + 0.0146946498889451*x_92 + 0.00347419675320454*x_93 - 0.00192997426007141*x_94 - 0.000946930450271737*x_95 + 0.00207334708606235*x_96 - 0.00110990006708097*x_97 + 0.00750268023154056*x_99 + 0.121791641844778*std::exp(0.325199842453003*x_60) - 0.0292780700112572*std::log(4.99583959579468*x_24 + 9.18455982208252) - 0.685113945462163*std::sin(0.226159989833832*x_111 + 8.16951942443848) - 0.708133699555844*std::sin(0.266079962253571*x_115 + 1.5596798658371) + 0.0375285225043509*std::sin(0.467999845743179*x_13 - 10.0) + 0.0144714941709041*std::sin(1.03207981586456*x_21 + 3.58415985107422) + 0.0372070593167204*std::sin(0.422399878501892*x_28 + 1.96871984004974) + 0.296473507671326*std::sin(0.250159978866577*x_29 + 2.00159978866577) - 0.0144570427398621*std::sin(0.726399838924408*x_4 + 5.0065598487854) - 0.0191116743778998*std::sin(0.557119846343994*x_44 + 7.60111999511719) + 0.46125630758138*std::sin(0.434719860553741*x_59 - 1.43583977222443) + 0.23658645758098*std::sin(0.20456001162529*x_91 + 7.79360008239746) + 0.056278188582247*std::sin(0.36287984251976*x_98 - 1.97687971591949) - 6.95195279372955, 2) + 0.00153498840518296*std::pow(-0.00125606327258809*x_1 + 0.000118317504584313*x_100 - 0.00890525675176675*x_101 - 0.00214479694167117*x_102 - 0.000472955805644444*x_103 - 0.0258793084246651*x_104 + 0.00137935021206669*x_105 + 0.000416742274539312*x_106 - 0.00763138198368458*x_107 - 0.0167227439245049*x_108 + 0.000955167024731451*x_109 - 0.0274925389352959*x_110 + 0.0770939497285363*x_111 - 0.00029821284871126*x_113 + 0.0310224588898622*x_114 - 0.000602782874401773*x_115 + 0.0292015223615795*x_116 - 0.00016657251431472*x_117 + 0.000458563890702139*x_118 - 0.00549720441934923*x_12 - 0.0134980985185721*x_120 - 0.00390703673658418*x_13 - 0.00450680746614762*x_14 - 0.0126668201085544*x_15 + 0.0264386388845152*x_16 - 0.00204823754609552*x_17 - 0.00794361047163368*x_18 - 0.0147450559397343*x_19 + 0.000172949805673283*x_2 - 0.00546964414201919*x_20 - 0.000711508698602644*x_21 - 0.0108422533338208*x_22 - 0.00544480532974088*x_24 + 0.0274350789171351*x_25 - 0.00754552575536912*x_26 - 0.00214359265550885*x_27 - 0.00351956173092684*x_3 - 0.00257953390934215*x_30 - 0.000175132664433665*x_31 - 0.000610959058544823*x_32 - 0.00813352410946194*x_33 + 0.00126052451443627*x_34 - 0.00163231068455978*x_35 - 0.0206609568620849*x_36 + 0.0268446481536746*x_37 + 0.025388199537478*x_38 + 0.0838878643668913*x_39 + 0.004609417852402*x_40 + 0.115360964820658*x_41 - 0.000500882369017562*x_42 + 0.001303894933566*x_44 - 0.00106025955073314*x_45 - 0.00817566973254376*x_46 - 0.000784967615097015*x_47 + 0.00874755759137043*x_50 - 0.00535759150206756*x_51 + 0.000765534942554777*x_52 - 0.00433948705834974*x_53 + 0.0558717017823137*x_54 - 0.0052338589202586*x_55 - 0.00544900681005443*x_56 + 0.0478017653016802*x_58 - 0.000796346140715065*x_6 - 0.000135964478841085*x_60 + 0.000123126990068976*x_61 - 1.95184667199073e-5*x_62 - 0.000806320255666543*x_63 - 0.00575165268370825*x_64 - 0.000388139250878309*x_65 + 0.000379344436182786*x_66 - 0.000329626752653528*x_67 + 0.00201821859138757*x_68 + 0.00147280839722514*x_69 + 0.0040139256012748*x_7 + 0.000482864549479762*x_70 + 0.00322120405553253*x_71 - 0.000184776707013275*x_72 + 0.00342675917312859*x_73 - 0.00302176140991636*x_74 - 0.000814681280197548*x_75 + 0.000261351121346053*x_76 - 0.00114494645455558*x_77 - 0.00293544579661707*x_78 + 0.00132345366551846*x_79 - 0.00568954094353427*x_8 + 0.00169281830779755*x_80 - 0.0045088307175019*x_81 - 0.000787770574342813*x_82 + 0.00621148998474594*x_83 + 0.000243904678451657*x_84 + 0.00147099077841156*x_85 + 0.000164331203027173*x_86 + 0.000417129310069328*x_87 + 0.000145591490029892*x_88 + 0.000735783681085072*x_89 - 0.00564961523734564*x_9 + 0.000620876848495148*x_90 + 0.000729043061645795*x_91 + 0.000559249088000496*x_92 - 0.0247227213678153*x_93 + 0.00131781610278306*x_94 - 0.00262657389647621*x_96 + 0.000161873800280218*x_97 - 0.00316694633377902*x_98 + 0.00109979027188408*x_99 - 2.18664282813414e-5*std::pow(1.38503980636597 - 7.12336015701294*x_10, 2) - 0.0445420523521567*std::sin(0.491999864578247*x_11 - 7.40000009536743) + 0.0443116100610375*std::sin(0.219359993934631*x_112 + 4.78791999816895) - 0.221951533559945*std::sin(0.349839836359024*x_119 - 4.97839975357056) + 0.0158539066652402*std::sin(0.398959845304489*x_23 + 2.00783967971802) - 0.0101200426356807*std::sin(0.532399833202362*x_28 - 7.56040000915527) + 0.129716452209445*std::sin(0.704639852046967*x_29 - 1.58823990821838) + 0.0257390391242507*std::sin(1.04535984992981*x_4 + 3.9663200378418) + 0.916345836561305*std::sin(0.249279975891113*x_43 - 1.22215986251831) - 0.568007496605745*std::sin(0.218559995293617*x_48 - 4.41095972061157) - 0.181701062347108*std::sin(0.211199998855591*x_49 + 1.38191986083984) + 0.0396976675824079*std::sin(0.647999823093414*x_5 + 9.99600028991699) - 0.300549246358797*std::sin(0.522399842739105*x_57 + 1.65279984474182) + 0.227239312968495*std::sin(0.561039865016937*x_59 - 4.54360008239746) - 0.300436963812825*std::sin(0.306639939546585*x_95 - 4.60048007965088) - 2.88671945088676, 2) + 1.91384655849163e-6*std::exp(0.629279851913452*x_1) - 5.12973735309903e-5*std::exp(0.49567985534668*x_13) + 1.84263851905543e-6*std::exp(0.526799857616425*x_14) - 2.29155083177979e-5*std::exp(0.362639844417572*x_16) - 5.3923348305449e-6*std::exp(0.359759837388992*x_19) - 0.00013977479297631*std::exp(0.451119869947433*x_2) + 2.43687640493329e-5*std::exp(0.299999833106995*x_24) - 2.67307356994223e-5*std::exp(0.411119878292084*x_26) + 2.18142295571728e-5*std::exp(0.428639858961105*x_27) + 5.30269947947123e-8*std::exp(0.789199888706207*x_3) - 4.01407233809787e-6*std::exp(0.5655198097229*x_30) + 7.08676242749523e-5*std::exp(0.292399853467941*x_59) + 2.11253818045976e-5*std::sin(0.278239965438843*x_10 - 1.21111989021301) - 0.000121220968581799*std::sin(0.324959933757782*x_10 + 4.96639966964722) + 0.000590906977176902*std::sin(0.254079967737198*x_100 + 1.78135991096497) + 0.0006373377345816*std::sin(0.295599937438965*x_101 - 1.60279989242554) + 0.000135927708442302*std::sin(0.262799948453903*x_102 + 1.76351988315582) - 5.09497222196095e-5*std::sin(0.247759968042374*x_104 + 4.57936000823975) + 0.00259160098345309*std::sin(0.222719997167587*x_105 + 1.78591990470886) - 0.00108692455379262*std::sin(0.265759944915771*x_105 - 4.62527990341187) - 0.000308460031579542*std::sin(0.284959942102432*x_107 - 7.83568000793457) + 0.000764047937797507*std::sin(0.256959974765778*x_109 + 7.99103975296021) - 7.3920317059166e-5*std::sin(0.259119987487793*x_109 - 7.63520002365112) + 0.000636635666818279*std::sin(0.271839946508408*x_109 + 1.74463987350464) + 1.64349902042081e-7*std::sin(1.23983979225159*x_109 - 5.41856002807617) - 0.00118989156666679*std::sin(0.130800053477287*x_11 + 4.94279956817627) + 0.000178572904580038*std::sin(0.259599983692169*x_11 + 1.96687984466553) - 0.000347712274442849*std::sin(0.277599930763245*x_11 + 7.97864007949829) - 0.000192431033167207*std::sin(0.219919994473457*x_110 + 1.97583973407745) + 4.07047381409926e-5*std::sin(0.314239919185638*x_111 - 2.16447973251343) + 0.000262716448037294*std::sin(0.243999972939491*x_112 + 1.78271985054016) + 0.0013730069355484*std::sin(0.273279964923859*x_112 + 4.96903991699219) - 0.000912234157816731*std::sin(0.25503996014595*x_114 + 8.14727973937988) - 0.00114248221191735*std::sin(0.222879990935326*x_115 + 4.98295974731445) + 0.000190287931574334*std::sin(0.327519834041595*x_116 + 1.41927993297577) - 0.000877419667931751*std::sin(0.252879977226257*x_117 - 1.39735984802246) - 2.03869785300586e-5*std::sin(0.298719942569733*x_117 + 7.94647979736328) - 0.00033127077591643*std::sin(0.359679847955704*x_118 - 8.16823959350586) + 9.35838820016261e-5*std::sin(0.2882399559021*x_119 - 1.63407981395721) + 0.000359960257204941*std::sin(0.31687992811203*x_119 + 4.7346396446228) - 3.87634968956979e-5*std::sin(0.323039829730988*x_119 - 8.13776016235352) - 5.56113049527123e-5*std::sin(0.334239840507507*x_120 + 4.82775974273682) + 0.000226094672363053*std::sin(0.373439848423004*x_120 + 4.61023998260498) + 5.77715803386784e-5*std::sin(0.429599851369858*x_13 - 1.23991990089417) + 6.55575016721901e-5*std::sin(0.470319837331772*x_13 + 1.72207987308502) + 0.000249924332512981*std::sin(0.148880034685135*x_15 - 1.42711985111237) + 0.00214700177605925*std::sin(0.338799834251404*x_15 + 1.84023988246918) - 5.24607328817153e-6*std::sin(0.589119851589203*x_16 - 4.59656000137329) + 0.000130999963245419*std::sin(0.797439873218536*x_16 + 7.98800039291382) - 0.00049373287696018*std::sin(0.239039987325668*x_17 - 4.38751983642578) + 0.000189282334253794*std::sin(0.420719861984253*x_17 - 1.38295984268188) + 4.65536986773281e-5*std::sin(0.189040005207062*x_20 + 1.59415984153748) + 0.000247138664821233*std::sin(0.194240003824234*x_20 + 7.61240005493164) - 0.00116967101266079*std::sin(0.274879962205887*x_20 - 7.58160018920898) + 8.28588080856869e-5*std::sin(0.192159995436668*x_21 - 1.5998398065567) + 0.000454333691083336*std::sin(0.35471984744072*x_21 - 1.15311980247498) + 8.75081569855225e-5*std::sin(0.359679847955704*x_22 - 1.39007985591888) - 0.000263836960511998*std::sin(0.501279830932617*x_22 - 7.46343994140625) - 0.000111707067375826*std::sin(0.550239861011505*x_23 + 8.02112007141113) - 0.000538986273151479*std::sin(0.284879922866821*x_24 - 4.38207960128784) - 0.000193918120239369*std::sin(0.54671984910965*x_24 + 8.00600051879883) + 0.000105808426049731*std::sin(0.255519956350327*x_26 + 7.79239988327026) + 6.17256388169216e-6*std::sin(0.547199845314026*x_26 - 4.34791994094849) - 0.00212770907077803*std::sin(0.378799855709076*x_27 - 1.19023990631104) + 5.74340675975845e-6*std::sin(0.430399864912033*x_27 - 7.43319988250732) - 0.000546397688594075*std::sin(0.213119998574257*x_29 - 1.81263983249664) - 6.97673539131015e-5*std::sin(0.349919855594635*x_29 + 4.61783981323242) + 0.000359985800677837*std::sin(0.397999823093414*x_29 - 4.60591983795166) + 0.000192844577225334*std::sin(0.186480015516281*x_30 + 4.79576015472412) + 2.88813137573682e-6*std::sin(0.536159813404083*x_31 - 7.41943979263306) + 0.00191621663434779*std::sin(0.215360000729561*x_32 - 4.59135961532593) - 0.0014453325125781*std::sin(0.250159978866577*x_32 + 5.01207971572876) + 0.00133879842026375*std::sin(0.219119995832443*x_33 - 4.39343976974487) + 0.000356051957444397*std::sin(0.235119983553886*x_33 + 8.20096015930176) + 0.000404687783277944*std::sin(0.217759996652603*x_34 + 8.19967937469482) + 0.000902218480457751*std::sin(0.231279984116554*x_35 - 1.20599985122681) + 0.000164052710455621*std::sin(0.249599978327751*x_35 + 8.18247985839844) - 0.00138688623235673*std::sin(0.256719976663589*x_35 - 1.22463989257813) + 0.000530694074252928*std::sin(0.240879982709885*x_36 - 1.20711994171143) + 8.96263783993686e-5*std::sin(0.258319973945618*x_37 - 7.43327951431274) + 0.000465516186929004*std::sin(0.277759939432144*x_38 - 1.41191983222961) - 9.66780007092576e-5*std::sin(0.289519935846329*x_38 + 1.55455982685089) + 1.97058329407463e-5*std::sin(0.538479864597321*x_4 - 4.58392000198364) - 0.000393165105672528*std::sin(0.226799994707108*x_40 - 1.39975988864899) - 0.00120815874110077*std::sin(0.236719980835915*x_40 + 8.16784000396729) + 0.000450405028499287*std::sin(0.213839992880821*x_41 + 1.59519982337952) - 0.000322578645306254*std::sin(0.218319997191429*x_41 + 1.57967984676361) - 0.000111347304206585*std::sin(0.350719839334488*x_41 + 1.61295986175537) - 0.000446860653998873*std::sin(0.307519912719727*x_42 + 1.74847984313965) - 0.000333770130284144*std::sin(0.457919865846634*x_43 + 4.92479991912842) - 0.00100611633334081*std::sin(0.46383985877037*x_43 + 4.89663982391357) + 3.15460214168577e-6*std::sin(0.489919871091843*x_43 + 7.90343999862671) + 0.000840882949759871*std::sin(0.279279947280884*x_44 + 1.93007981777191) + 7.54382770018528e-6*std::sin(0.292959928512573*x_44 - 7.64568042755127) - 8.89832210362319e-5*std::sin(0.29751992225647*x_44 - 4.45015954971313) + 0.000189045534622861*std::sin(0.340239852666855*x_44 + 8.0444803237915) + 0.000364029550517895*std::sin(0.169520020484924*x_45 - 7.79071998596191) + 0.000113096184880855*std::sin(0.58927983045578*x_45 - 7.79103994369507) + 0.00077619419987367*std::sin(0.268879950046539*x_46 - 1.40031981468201) - 0.000279771570679103*std::sin(0.189680010080338*x_47 + 2.01359987258911) + 0.000142997167883567*std::sin(0.607679843902588*x_47 - 4.6101598739624) + 7.35461385986573e-5*std::sin(0.661439836025238*x_47 + 7.74631977081299) - 0.00118030364834722*std::sin(0.288879930973053*x_49 + 1.89487981796265) - 0.000305252515596594*std::sin(0.37407985329628*x_49 - 4.56288003921509) + 1.50019003521945e-5*std::sin(0.575759828090668*x_50 - 4.5734395980835) + 5.96708363867055e-5*std::sin(0.626239836215973*x_50 + 4.7673602104187) + 0.00040180752428332*std::sin(0.211119994521141*x_51 - 1.40071988105774) + 0.000709737830330172*std::sin(0.213199988007545*x_52 - 1.20551991462708) - 0.000218290325981326*std::sin(0.213359996676445*x_53 + 1.97695982456207) + 0.00320946055840335*std::sin(0.247039973735809*x_53 + 8.1988000869751) + 0.000137927740533252*std::sin(0.269999951124191*x_53 - 4.61583995819092) + 0.00139834857624392*std::sin(0.210720002651215*x_54 + 1.98495984077454) - 0.000102167663680456*std::sin(0.446799844503403*x_55 + 1.52711987495422) + 9.37941680699016e-5*std::sin(0.495999842882156*x_55 - 1.39999985694885) - 0.000115315661320027*std::sin(0.184000000357628*x_56 + 1.57647979259491) - 3.74972596040301e-5*std::sin(0.572159826755524*x_56 + 4.83112001419067) + 0.000924546770481301*std::sin(0.19080001115799*x_57 - 7.40759992599487) - 0.000455648089945005*std::sin(0.193999990820885*x_57 - 1.18895995616913) - 0.00103321189993203*std::sin(0.210400000214577*x_57 - 4.38695955276489) - 0.000196638681368409*std::sin(0.234479993581772*x_57 + 1.76807987689972) - 2.71297105172157e-5*std::sin(0.409359842538834*x_57 - 8.01327991485596) - 8.03433694985324e-5*std::sin(0.503999829292297*x_57 + 1.79999983310699) + 0.000265752542854017*std::sin(0.156560033559799*x_58 - 1.73479986190796) - 0.00073135771343141*std::sin(0.0999200716614723*x_59 - 7.80351972579956) - 0.00344152629867596*std::sin(0.106240063905716*x_59 - 1.25135982036591) + 0.000142494557247285*std::sin(0.146480038762093*x_59 - 7.96208000183105) + 0.00146068958666361*std::sin(0.350399851799011*x_59 + 8.05471992492676) - 0.0013569963009934*std::sin(0.356559842824936*x_59 - 1.33015990257263) + 5.96879892725533e-6*std::sin(0.568239867687225*x_59 - 1.55663979053497) + 0.00015464872622976*std::sin(0.23735998570919*x_6 - 7.57872009277344) - 9.10478968627666e-5*std::sin(0.428959846496582*x_6 - 1.40255987644196) - 2.03674743456399e-6*std::sin(0.588399827480316*x_6 - 8.19416046142578) - 0.000138959661949245*std::sin(0.580399870872498*x_60 - 4.56799983978271) + 3.4117448786069e-6*std::sin(0.985839784145355*x_64 + 5.59231996536255) + 1.21636386805164e-6*std::sin(1.30951976776123*x_65 + 8.57479953765869) - 1.11054704262613e-5*std::sin(0.747679829597473*x_7 + 7.62128019332886) - 0.00134667101991183*std::sin(0.301279932260513*x_8 + 4.78895998001099) - 0.00021033736815366*std::sin(0.346559852361679*x_8 - 1.35543990135193) - 0.000683565803298748*std::sin(0.225839987397194*x_9 + 4.99991989135742) - 1.55139204896132e-5*std::sin(0.287119954824448*x_92 + 1.81895983219147) - 0.000527330754707114*std::sin(0.339519828557968*x_92 + 1.80711996555328) - 7.16114330663469e-6*std::sin(0.43767985701561*x_92 + 4.59567975997925) - 0.000112480595599573*std::sin(0.254879981279373*x_93 - 7.62007999420166) - 5.24434661415157e-7*std::sin(0.255519956350327*x_93 - 4.41703987121582) - 0.00033548289821167*std::sin(0.289679944515228*x_93 + 1.5745598077774) + 2.31314570272396e-5*std::sin(0.19080001115799*x_94 + 4.79112005233765) - 0.00188515530234103*std::sin(0.290399938821793*x_94 - 1.39271986484528) - 5.68252990304961e-5*std::sin(0.331199824810028*x_94 + 1.63039982318878) + 3.20882714505143e-5*std::sin(0.249279975891113*x_95 + 5.17112016677856) + 0.000149321767532573*std::sin(0.26199996471405*x_95 - 7.79631996154785) + 0.000106589704028743*std::sin(0.291839927434921*x_95 + 7.97679996490479) + 3.93330820566677e-5*std::sin(0.296879917383194*x_95 - 4.83536005020142) - 3.19198833280991e-5*std::sin(0.422399878501892*x_96 + 4.39903974533081) - 0.000488232176059187*std::sin(0.279439955949783*x_97 + 8.17615985870361) + 9.30153175664025e-5*std::sin(0.330079853534698*x_97 - 1.55287981033325) + 2.59549418969483e-5*std::sin(0.244639977812767*x_98 - 7.41063976287842) + 0.000879070646385863*std::sin(0.277279943227768*x_98 + 8.17543983459473) + 0.000142608632093395*std::sin(0.306719928979874*x_98 + 4.77415990829468) + 5.06244534567846e-5*std::sin(0.328239858150482*x_98 + 7.83935976028442) - 0.0231555381402963);
}

inline float score_2(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-1.75924471321103e-5*x_1 + 0.00108696874559806*x_10 + 0.000493266881063206*x_100 + 0.00199088730509379*x_101 + 0.000268084492020802*x_102 + 0.000316180335598672*x_103 + 9.62531410286133e-5*x_104 + 0.00121722999576272*x_105 + 0.000790185495466972*x_106 + 5.72050388664394e-5*x_107 + 9.25764423138564e-6*x_108 - 7.42938434194834e-5*x_109 + 7.72313320851061e-5*x_11 - 0.000162224151141336*x_110 - 0.000290057528914339*x_111 + 0.000698276692421486*x_112 + 0.000144892162268155*x_113 - 0.000617252214851138*x_114 - 0.00164924521589154*x_115 + 0.00160263912995196*x_116 + 0.000197820865673013*x_117 - 3.32182845784731e-5*x_118 - 0.000639136611989298*x_119 - 0.000524809619528987*x_12 - 0.000442644910732237*x_120 - 5.00579906900083e-5*x_13 - 0.000518282529783118*x_14 + 2.29067598713231e-5*x_15 + 5.10804099653281e-6*x_16 + 9.80929488539195e-5*x_17 + 0.000641740271879526*x_18 + 5.61336551753834e-5*x_19 - 1.76177024831485e-5*x_2 + 0.00121627168284542*x_20 - 1.19731361021346e-5*x_21 + 0.000682225572225563*x_22 + 0.000832720926734286*x_23 + 0.000559450428555309*x_24 - 0.000350627635393073*x_25 + 0.000196614346837108*x_26 + 0.000753968466247637*x_27 + 0.000748511283110978*x_28 + 9.06282057525116e-5*x_29 - 0.000463913639580309*x_3 + 0.000263888457216137*x_30 - 8.54132467586734e-5*x_31 + 0.000487862835145083*x_32 + 0.000531906103643387*x_33 - 0.000976592388910626*x_34 - 0.000184607104061913*x_35 - 0.000897383208242761*x_36 - 0.000709884998233896*x_37 - 0.0020222549098214*x_38 - 0.00107681283037354*x_39 + 3.79639992813006e-5*x_4 - 0.00018430648624194*x_40 + 0.000637996509368915*x_41 - 0.00067235391454703*x_42 - 0.00151831651977713*x_43 + 3.96017009878395e-5*x_44 + 0.000901861665271936*x_45 - 0.000569588153882168*x_46 - 0.00200747714067884*x_47 - 0.000945382085525645*x_48 + 0.000422526719218538*x_49 - 0.000141894722557287*x_5 - 0.00216234941174939*x_50 - 0.00268890011235812*x_51 + 0.000973435110545458*x_52 - 0.000325399210211394*x_53 - 0.00157931623984971*x_54 - 0.000220312910923561*x_55 + 0.00077150324408602*x_56 - 0.000267213944934587*x_57 - 6.4557860080243e-6*x_58 + 6.96479772669952e-5*x_59 + 2.84410377407962e-5*x_6 - 0.000198811621923373*x_60 + 0.000108120610603048*x_61 - 2.5511166132929e-5*x_62 + 5.93070825648072e-5*x_63 - 2.03606646183624e-5*x_64 - 3.12761526000856e-5*x_65 + 2.57160949453016e-5*x_66 - 1.21773410361919e-5*x_67 + 4.83977785858656e-5*x_68 + 5.0898739420517e-7*x_69 + 0.00103610729052821*x_7 - 8.58418968230108e-6*x_70 + 4.79214895520105e-5*x_71 - 1.28558135622539e-6*x_72 + 2.0592622365528e-5*x_73 + 9.62531774380981e-5*x_74 + 2.33479426110391e-5*x_75 + 2.43393528586126e-5*x_76 + 0.000102673035267823*x_77 + 2.71928297054718e-6*x_78 + 1.00155977092088e-6*x_79 + 3.54349655326622e-5*x_8 - 3.85731523022906e-5*x_80 - 9.70531861192879e-6*x_81 - 4.44367182320324e-5*x_82 - 0.000273575379135092*x_83 - 2.25856058956489e-5*x_84 + 5.28566347887265e-7*x_85 - 8.18657967049361e-6*x_86 - 1.91267670384913e-5*x_87 + 3.76031753724318e-6*x_88 - 4.56339498461048e-5*x_89 - 0.00130477640728705*x_9 - 3.53057415227053e-5*x_90 + 7.78465649430218e-6*x_91 - 5.22872145026152e-6*x_92 + 8.76051833806076e-5*x_93 - 6.81004014337567e-5*x_94 - 2.02579864654958e-5*x_95 + 0.000679916643943816*x_96 + 0.000137800151162359*x_97 + 0.000577826456003316*x_98 - 3.41015415069817e-5*x_99 + 3.10793229648785e-6*std::pow(0.814879834651947 - 5.53343963623047*x_19, 2) + 5.08413998674916e-8*std::pow(0.817359864711761 - 6.45175981521606*x_23, 2) + 6.18362893490234e-8*std::pow(2.25367975234985 - 5.73983955383301*x_4, 2) + 5.68370728697809e-7*std::pow(2.6431999206543 - 7.30952024459839*x_59, 2) - 2.28882760406724e-7*std::pow(5.20296001434326 - 9.00399971008301*x_15, 2) + 8.3244044262355e-8*std::pow(7.96920013427734 - 7.90776014328003*x_27, 2) - 2.16493513909943e-7*std::pow(-8.08119964599609*x_14 - 7.46519994735718, 2) + 1.8864577773418e-6*std::pow(-6.89904022216797*x_22 - 1.4171998500824, 2) - 1.60507428189136e-6*std::pow(-4.69047975540161*x_26 - 6.72648000717163, 2) - 4.52158294605054e-6*std::pow(-2.57999992370605*x_28 - 7.52744007110596, 2) - 1.3102237898204e-6*std::pow(-4.49319982528687*x_42 - 6.96000003814697, 2) - 1.09722719355169e-6*std::pow(-3.42927980422974*x_42 - 6.80200004577637, 2) - 3.45063399865852e-7*std::pow(-8.52272033691406*x_57 - 2.62191987037659, 2) - 4.2659245380518e-6*std::pow(-6.33992004394531*x_60 - 9.99560070037842, 2) + 2.33597944653799e-6*std::pow(-5.4445595741272*x_9 - 8.69223976135254, 2) - 6.7827924979774e-7*std::exp(0.629279851913452*x_1) + 7.58632860093614e-5*std::exp(0.49567985534668*x_13) + 0.000103680062768671*std::exp(0.526799857616425*x_14) - 0.00100114620643303*std::exp(0.362639844417572*x_16) + 1.91595502091462e-5*std::exp(0.359759837388992*x_19) + 0.000206711852217054*std::exp(0.451119869947433*x_2) - 0.0001089604145318*std::exp(0.299999833106995*x_24) + 0.000109811862665976*std::exp(0.411119878292084*x_26) - 7.75083223888492e-5*std::exp(0.428639858961105*x_27) + 1.96793834562121e-5*std::exp(0.789199888706207*x_3) + 1.6490109560734e-5*std::exp(0.5655198097229*x_30) - 0.000291129503948268*std::exp(0.292399853467941*x_59) - 0.000444939394389131*std::exp(0.325199842453003*x_60) + 0.000106961089795423*std::log(4.99583959579468*x_24 + 9.18455982208252) - 7.48696809497958e-6*std::sin(0.278239965438843*x_10 - 1.21111989021301) + 0.000430711242333892*std::sin(0.324959933757782*x_10 + 4.96639966964722) - 0.000209421146852903*std::sin(0.254079967737198*x_100 + 1.78135991096497) + 0.00764826806644839*std::sin(0.262799948453903*x_102 + 1.76351988315582) - 0.000540437589444469*std::sin(0.247759968042374*x_104 + 4.57936000823975) - 0.00383269850085146*std::sin(0.222719997167587*x_105 + 1.78591990470886) + 0.000109320174015024*std::sin(0.284959942102432*x_107 - 7.83568000793457) - 0.00112994454179955*std::sin(0.256959974765778*x_109 + 7.99103975296021) - 0.004159287366088*std::sin(0.259119987487793*x_109 - 7.63520002365112) - 0.00383457969290836*std::sin(0.271839946508408*x_109 + 1.74463987350464) + 6.09935516013728e-5*std::sin(1.23983979225159*x_109 - 5.41856002807617) + 0.00716694693074082*std::sin(0.130800053477287*x_11 + 4.94279956817627) + 0.0078015980929902*std::sin(0.259599983692169*x_11 + 1.96687984466553) + 0.00123545940485506*std::sin(0.277599930763245*x_11 + 7.97864007949829) - 0.00204116841404815*std::sin(0.219919994473457*x_110 + 1.97583973407745) + 0.00250291546582474*std::sin(0.226159989833832*x_111 + 8.16951942443848) - 1.44260150464965e-5*std::sin(0.314239919185638*x_111 - 2.16447973251343) + 0.0114777107133085*std::sin(0.243999972939491*x_112 + 1.78271985054016) + 0.00688139122211291*std::sin(0.222879990935326*x_115 + 4.98295974731445) + 0.00258701315340237*std::sin(0.266079962253571*x_115 + 1.5596798658371) - 0.000676113649052581*std::sin(0.327519834041595*x_116 + 1.41927993297577) + 0.000122794712809322*std::sin(0.298719942569733*x_117 + 7.94647979736328) + 0.00408854768351078*std::sin(0.2882399559021*x_119 - 1.63407981395721) - 0.00012757217768095*std::sin(0.31687992811203*x_119 + 4.7346396446228) - 0.000411174976194201*std::sin(0.323039829730988*x_119 - 8.13776016235352) - 0.00312909099018538*std::sin(0.334239840507507*x_120 + 4.82775974273682) - 0.000803338880705715*std::sin(0.373439848423004*x_120 + 4.61023998260498) + 0.0032506435819164*std::sin(0.429599851369858*x_13 - 1.23991990089417) - 0.000137102331674665*std::sin(0.467999845743179*x_13 - 10.0) - 0.000293128225272737*std::sin(0.470319837331772*x_13 + 1.72207987308502) + 0.00265101550945941*std::sin(0.148880034685135*x_15 - 1.42711985111237) - 0.00317518419732327*std::sin(0.338799834251404*x_15 + 1.84023988246918) - 5.56465291348976e-5*std::sin(0.589119851589203*x_16 - 4.59656000137329) - 0.000193734824900911*std::sin(0.797439873218536*x_16 + 7.98800039291382) + 0.00297384856424191*std::sin(0.239039987325668*x_17 - 4.38751983642578) - 0.000777585994186542*std::sin(0.420719861984253*x_17 - 1.38295984268188) - 0.000165410338055658*std::sin(0.189040005207062*x_20 + 1.59415984153748) - 0.00148856395399928*std::sin(0.194240003824234*x_20 + 7.61240005493164) + 0.00361998434571579*std::sin(0.192159995436668*x_21 - 1.5998398065567) - 0.00273653965122496*std::sin(0.35471984744072*x_21 - 1.15311980247498) - 5.28684707322875e-5*std::sin(1.03207981586456*x_21 + 3.58415985107422) - 0.000391276514506587*std::sin(0.359679847955704*x_22 - 1.39007985591888) + 0.00158914101698728*std::sin(0.501279830932617*x_22 - 7.46343994140625) + 0.000499477459864647*std::sin(0.550239861011505*x_23 + 8.02112007141113) + 0.000797102599619608*std::sin(0.284879922866821*x_24 - 4.38207960128784) + 6.87258006837346e-5*std::sin(0.54671984910965*x_24 + 8.00600051879883) - 0.0004731027778018*std::sin(0.255519956350327*x_26 + 7.79239988327026) + 3.10634691492654e-5*std::sin(0.547199845314026*x_26 - 4.34791994094849) + 0.00314665236581032*std::sin(0.378799855709076*x_27 - 1.19023990631104) + 6.09218808115164e-5*std::sin(0.430399864912033*x_27 - 7.43319988250732) - 0.000135927935518605*std::sin(0.422399878501892*x_28 + 1.96871984004974) - 0.00108310177084091*std::sin(0.250159978866577*x_29 + 2.00159978866577) + 0.000247890971585358*std::sin(0.349919855594635*x_29 + 4.61783981323242) - 0.00216826406838531*std::sin(0.397999823093414*x_29 - 4.60591983795166) + 0.0108508194442661*std::sin(0.186480015516281*x_30 + 4.79576015472412) - 1.0261843865962e-5*std::sin(0.536159813404083*x_31 - 7.41943979263306) - 0.00283387784950821*std::sin(0.215360000729561*x_32 - 4.59135961532593) - 0.00806384169598612*std::sin(0.219119995832443*x_33 - 4.39343976974487) + 0.0155554073488154*std::sin(0.235119983553886*x_33 + 8.20096015930176) + 0.0176802379157279*std::sin(0.217759996652603*x_34 + 8.19967937469482) - 0.00543423632078322*std::sin(0.231279984116554*x_35 - 1.20599985122681) + 0.00174015181080504*std::sin(0.249599978327751*x_35 + 8.18247985839844) + 0.00205105524250986*std::sin(0.256719976663589*x_35 - 1.22463989257813) - 0.00188561357572781*std::sin(0.240879982709885*x_36 - 1.20711994171143) + 0.000950691422497098*std::sin(0.258319973945618*x_37 - 7.43327951431274) + 0.00034350741690158*std::sin(0.289519935846329*x_38 + 1.55455982685089) + 0.00110879153728581*std::sin(0.538479864597321*x_4 - 4.58392000198364) + 5.2815675557853e-5*std::sin(0.726399838924408*x_4 + 5.0065598487854) - 0.0171768283987915*std::sin(0.226799994707108*x_40 - 1.39975988864899) - 0.000159626373117603*std::sin(0.213839992880821*x_41 + 1.59519982337952) + 0.00132517721530996*std::sin(0.218319997191429*x_41 + 1.57967984676361) - 0.00486460652135687*std::sin(0.350719839334488*x_41 + 1.61295986175537) + 0.00118592145526062*std::sin(0.457919865846634*x_43 + 4.92479991912842) + 0.0011707362530794*std::sin(0.489919871091843*x_43 + 7.90343999862671) - 0.00506480056226958*std::sin(0.279279947280884*x_44 + 1.93007981777191) + 0.00279966606846715*std::sin(0.292959928512573*x_44 - 7.64568042755127) - 0.00500683440999828*std::sin(0.29751992225647*x_44 - 4.45015954971313) - 6.69989257146437e-5*std::sin(0.340239852666855*x_44 + 8.0444803237915) + 6.98203644738008e-5*std::sin(0.557119846343994*x_44 + 7.60111999511719) - 0.00162769070462319*std::sin(0.169520020484924*x_45 - 7.79071998596191) - 0.00068120018480417*std::sin(0.58927983045578*x_45 - 7.79103994369507) - 0.00275790213550684*std::sin(0.268879950046539*x_46 - 1.40031981468201) + 9.91528031508005e-5*std::sin(0.189680010080338*x_47 + 2.01359987258911) - 0.000211477397358872*std::sin(0.607679843902588*x_47 - 4.6101598739624) - 0.000261317403212406*std::sin(0.661439836025238*x_47 + 7.74631977081299) + 0.000108183410189849*std::sin(0.37407985329628*x_49 - 4.56288003921509) + 0.000844114542315219*std::sin(0.575759828090668*x_50 - 4.5734395980835) - 0.0024201643944564*std::sin(0.211119994521141*x_51 - 1.40071988105774) - 0.00427488815553552*std::sin(0.213199988007545*x_52 - 1.20551991462708) + 0.000976044757914518*std::sin(0.213359996676445*x_53 + 1.97695982456207) - 0.00474644621192592*std::sin(0.247039973735809*x_53 + 8.1988000869751) + 0.00602586825837492*std::sin(0.269999951124191*x_53 - 4.61583995819092) - 0.00206800681357083*std::sin(0.210720002651215*x_54 + 1.98495984077454) + 0.000615375588959572*std::sin(0.446799844503403*x_55 + 1.52711987495422) + 0.00409773478495318*std::sin(0.495999842882156*x_55 - 1.39999985694885) - 0.00503797844114138*std::sin(0.184000000357628*x_56 + 1.57647979259491) - 0.000397743652140579*std::sin(0.572159826755524*x_56 + 4.83112001419067) - 0.0055687239280038*std::sin(0.19080001115799*x_57 - 7.40759992599487) - 0.019906621768569*std::sin(0.193999990820885*x_57 - 1.18895995616913) + 0.00367111388582574*std::sin(0.210400000214577*x_57 - 4.38695955276489) - 0.0110643029634897*std::sin(0.234479993581772*x_57 + 1.76807987689972) + 9.61493993089488e-6*std::sin(0.409359842538834*x_57 - 8.01327991485596) - 0.00085222401709035*std::sin(0.503999829292297*x_57 + 1.79999983310699) - 0.000760214726691776*std::sin(0.156560033559799*x_58 - 1.73479986190796) + 0.000259197770583559*std::sin(0.0999200716614723*x_59 - 7.80351972579956) + 0.0207289781979491*std::sin(0.106240063905716*x_59 - 1.25135982036591) + 0.00622538603320772*std::sin(0.146480038762093*x_59 - 7.96208000183105) + 0.00200685125591693*std::sin(0.356559842824936*x_59 - 1.33015990257263) - 0.00168510005321211*std::sin(0.434719860553741*x_59 - 1.43583977222443) + 0.00221514123734951*std::sin(0.568239867687225*x_59 - 1.55663979053497) - 0.000549483688994177*std::sin(0.23735998570919*x_6 - 7.57872009277344) + 0.000374031573943405*std::sin(0.428959846496582*x_6 - 1.40255987644196) - 0.000755877905648121*std::sin(0.588399827480316*x_6 - 8.19416046142578) + 0.000621332388402482*std::sin(0.580399870872498*x_60 - 4.56799983978271) - 1.20914382947534e-6*std::sin(0.985839784145355*x_64 + 5.59231996536255) - 7.32639471949293e-6*std::sin(1.30951976776123*x_65 + 8.57479953765869) - 5.58883544320121e-5*std::sin(0.747679829597473*x_7 + 7.62128019332886) + 0.00199158127817927*std::sin(0.301279932260513*x_8 + 4.78895998001099) - 0.00918934266165041*std::sin(0.346559852361679*x_8 - 1.35543990135193) + 0.00411724897726184*std::sin(0.225839987397194*x_9 + 4.99991989135742) - 0.000864317399472387*std::sin(0.20456001162529*x_91 + 7.79360008239746) + 5.51226412866152e-5*std::sin(0.287119954824448*x_92 + 1.81895983219147) + 0.00317621507690854*std::sin(0.339519828557968*x_92 + 1.80711996555328) + 2.04852474530956e-5*std::sin(0.43767985701561*x_92 + 4.59567975997925) - 0.00632896528072109*std::sin(0.254879981279373*x_93 - 7.62007999420166) - 0.000194628242457873*std::sin(0.255519956350327*x_93 - 4.41703987121582) + 0.000118897247801477*std::sin(0.289679944515228*x_93 + 1.5745598077774) - 0.00010342802537339*std::sin(0.19080001115799*x_94 + 4.79112005233765) + 0.00278794148763119*std::sin(0.290399938821793*x_94 - 1.39271986484528) - 0.00319739900658892*std::sin(0.331199824810028*x_94 + 1.63039982318878) + 0.00652365721195912*std::sin(0.26199996471405*x_95 - 7.79631996154785) + 0.00599750145777867*std::sin(0.291839927434921*x_95 + 7.97679996490479) - 0.000112516658935905*std::sin(0.296879917383194*x_95 - 4.83536005020142) - 0.00139453463831268*std::sin(0.422399878501892*x_96 + 4.39903974533081) + 0.00294071677934345*std::sin(0.279439955949783*x_97 + 8.17615985870361) + 0.000986638823864888*std::sin(0.330079853534698*x_97 - 1.55287981033325) - 9.22207222061179e-5*std::sin(0.244639977812767*x_98 - 7.41063976287842) - 0.00529481244132877*std::sin(0.277279943227768*x_98 + 8.17543983459473) + 0.00151268862723779*std::sin(0.306719928979874*x_98 + 4.77415990829468) + 0.00284849494773379*std::sin(0.328239858150482*x_98 + 7.83935976028442) - 0.000205600177202766*std::sin(0.36287984251976*x_98 - 1.97687971591949) + 0.0820315256714821*std::sin(-0.000693288382015789*x_1 + 0.00163598833704893*x_10 - 0.0241722669703834*x_100 - 0.000706766398540806*x_102 - 0.000216391556177842*x_103 - 0.000471467297897314*x_104 - 0.0235187711533666*x_106 - 0.000495269973844149*x_107 + 3.79987061719635e-5*x_108 - 0.000192542511016501*x_109 - 0.0275357291668549*x_11 + 8.8253131874318e-5*x_110 - 0.000619685182728855*x_111 - 0.00469609398407245*x_113 + 0.0158604924427449*x_115 + 0.0233571073019323*x_116 + 0.0462349240942886*x_119 - 0.0288391274161554*x_12 - 9.23507068280782e-5*x_120 - 0.000177489953290639*x_13 + 0.00130847672957408*x_14 + 0.000335071914196241*x_15 - 0.00302504684511991*x_16 - 0.0097383280069608*x_17 + 0.00162287547505776*x_18 + 0.00121948065175401*x_19 + 0.00158660330424205*x_2 - 0.000808858132750744*x_21 + 0.00117937349430272*x_22 + 0.000649378507675672*x_23 + 0.000924099978365791*x_24 + 5.58531892621105e-6*x_25 - 0.000626091145024746*x_26 + 0.0013426430025996*x_27 - 0.000370542307996719*x_28 + 0.000143889295110947*x_3 - 0.0045250223708897*x_30 + 0.000231242766414428*x_31 + 0.0325613060000924*x_33 - 0.00387139408822304*x_34 - 0.00144250652219385*x_35 + 0.0246400079534277*x_36 + 0.0265412289242119*x_37 + 0.0349403451239153*x_39 + 0.00569664560273231*x_4 - 0.000560352621497906*x_41 - 0.000565701173434167*x_44 + 0.0194837884037015*x_45 + 0.00942592565756785*x_46 + 0.0199909568990027*x_47 - 0.0481773843704938*x_48 - 0.00101055128265977*x_51 - 0.00263509699914622*x_53 - 0.00134497796628153*x_54 - 0.00233755972164933*x_55 - 0.00151932279419158*x_56 + 0.00989558411019426*x_57 + 0.0600594517215275*x_58 - 0.00264503249029357*x_6 - 0.00196216509051147*x_60 - 0.000437940993388353*x_61 - 5.12208594853921e-5*x_62 + 0.000177731496516342*x_63 - 1.15249759641151e-5*x_64 - 0.000363549178956498*x_65 - 0.00040490731743209*x_66 + 7.76937605483751e-5*x_67 + 0.000469741943513163*x_68 + 0.000221767751335822*x_69 + 0.00137465929801564*x_7 + 1.84293683546269e-6*x_70 + 0.00100903659681324*x_71 + 0.000188385699137075*x_72 + 4.7585735860569e-5*x_73 + 0.000756464039857943*x_74 + 0.000144255535787584*x_75 + 0.000374704649207017*x_76 + 0.000410126852101815*x_77 - 0.00283739633462239*x_78 + 0.00141630357710468*x_79 - 0.000234122784937698*x_8 + 0.000438256371796933*x_80 + 0.000365758614080362*x_81 + 6.85512987250115e-5*x_82 + 0.00196793277414413*x_83 + 0.000478064660306698*x_84 - 0.000657094795754408*x_85 - 0.000263814216619657*x_86 - 0.000166273887592764*x_87 + 9.5707523295178e-5*x_88 + 0.000432800659394858*x_89 + 0.000800582268728378*x_9 + 7.0361719530083e-5*x_90 - 0.000856719572934926*x_91 - 0.00130988978983366*x_92 + 0.0042315808531134*x_93 - 0.00334748742022006*x_94 - 0.000635144814797142*x_96 - 6.47894598702967e-5*x_97 - 0.00239476422279512*x_98 - 0.028161460194187*x_99 + 0.000122721109173298*std::pow(-5.76231956481934*x_5 - 1.65471994876862, 2) + 0.000333545726636277*std::pow(-2.19055986404419*x_52 - 3.38007998466492, 2) - 0.109358782519147*std::sin(0.295599937438965*x_101 - 1.60279989242554) + 0.18650197445309*std::sin(0.265759944915771*x_105 - 4.62527990341187) - 0.235589952885009*std::sin(0.273279964923859*x_112 + 4.96903991699219) + 0.156527397419373*std::sin(0.25503996014595*x_114 + 8.14727973937988) + 0.150553688314661*std::sin(0.252879977226257*x_117 - 1.39735984802246) + 0.0568417132278798*std::sin(0.359679847955704*x_118 - 8.16823959350586) + 0.200700179750841*std::sin(0.274879962205887*x_20 - 7.58160018920898) + 0.0937546653112431*std::sin(0.213119998574257*x_29 - 1.81263983249664) + 0.248000071758883*std::sin(0.250159978866577*x_32 + 5.01207971572876) - 0.0798764621695147*std::sin(0.277759939432144*x_38 - 1.41191983222961) + 0.207304168336089*std::sin(0.236719980835915*x_40 + 8.16784000396729) + 0.0766754177972961*std::sin(0.307519912719727*x_42 + 1.74847984313965) + 0.172636345404857*std::sin(0.46383985877037*x_43 + 4.89663982391357) + 0.202524600353211*std::sin(0.288879930973053*x_49 + 1.89487981796265) - 0.0102387316254438*std::sin(0.626239836215973*x_50 + 4.7673602104187) - 0.250635143925368*std::sin(0.350399851799011*x_59 + 8.05471992492676) - 0.00550592583581422*std::sin(0.249279975891113*x_95 + 5.17112016677856) + 1.68555432109856) - 0.0210247002542019*std::sin(0.000564177971014657*x_1 - 5.31439228649317e-5*x_100 + 0.00399991767550387*x_101 + 0.000963364834557422*x_102 + 0.00021243455853803*x_103 + 0.0116240447730042*x_104 - 0.000619553983422316*x_105 - 0.00018718548342009*x_106 + 0.00342773942806374*x_107 + 0.00751124879058445*x_108 - 0.000429026312410789*x_109 + 0.0123486492862714*x_110 - 0.0346278002745289*x_111 + 0.000133946373234649*x_113 - 0.0139341610365736*x_114 + 0.000270748159319756*x_115 - 0.0131162625291551*x_116 + 7.48183194300811e-5*x_117 - 0.000205970233413362*x_118 + 0.00246914443184927*x_12 + 0.00606285527246788*x_120 + 0.00175489890265158*x_13 + 0.00202429411598495*x_14 + 0.00568947522311276*x_15 - 0.011875275686965*x_16 + 0.000919993863470892*x_17 + 0.00356798111705218*x_18 + 0.00662294322596993*x_19 - 7.7682766928677e-5*x_2 + 0.002456765356938*x_20 + 0.000319583847961581*x_21 + 0.0048699461409281*x_22 + 0.00244560866521759*x_24 - 0.0123228403344711*x_25 + 0.00338917593070888*x_26 + 0.000962823912982528*x_27 + 0.00158085921270807*x_3 + 0.00115863288012356*x_30 + 7.86632277488603e-5*x_31 + 0.000274420604077227*x_32 + 0.00365328342084233*x_33 - 0.000566181798711113*x_34 + 0.000733174633936203*x_35 + 0.0092801509096389*x_36 - 0.0120576402944544*x_37 - 0.0114034565100024*x_38 - 0.0376793798084294*x_39 - 0.00207038297216394*x_40 - 0.0518159526571523*x_41 + 0.000224978155827356*x_42 - 0.000585662214706599*x_44 + 0.000476230055552063*x_45 + 0.00367221370296773*x_46 + 0.000352578923420905*x_47 - 0.00392908494415604*x_50 + 0.00240643538357249*x_51 - 0.000343850473186322*x_52 + 0.00194913986998407*x_53 - 0.0250955378097571*x_54 + 0.0023508592048267*x_55 + 0.0024474958174736*x_56 - 0.0214708156407219*x_58 + 0.000357689743581344*x_6 + 6.10703023300514e-5*x_60 - 5.53041689461427e-5*x_61 + 8.76698586104236e-6*x_62 + 0.000362169753513007*x_63 + 0.00258343334439623*x_64 + 0.000174338044755079*x_65 - 0.000170387733637275*x_66 + 0.000148056357161876*x_67 - 0.000906510440040943*x_68 - 0.000661532003501484*x_69 - 0.00180290949584483*x_7 - 0.000216885206140197*x_70 - 0.00144684778859106*x_71 + 8.29949811674061e-5*x_72 - 0.00153917567661064*x_73 + 0.00135726540082991*x_74 + 0.00036592522185481*x_75 - 0.000117389425024431*x_76 + 0.00051426833484321*x_77 + 0.00131849556443644*x_78 - 0.00059444728624668*x_79 + 0.00255553500813221*x_8 - 0.000760352459173354*x_80 + 0.00202520288695917*x_81 + 0.000353837910841875*x_82 - 0.00278997554745082*x_83 - 0.000109553116959072*x_84 - 0.000660715595190926*x_85 - 7.38116038591248e-5*x_86 - 0.000187359325713548*x_87 - 6.53944058668466e-5*x_88 - 0.000330487287829808*x_89 + 0.00253760183199339*x_9 - 0.000278875314865479*x_90 - 0.000327459646562345*x_91 - 0.0002511943646834*x_92 + 0.0111045479026826*x_93 - 0.000591915097960517*x_94 + 0.00117976153269785*x_96 - 7.27078278583458e-5*x_97 + 0.00142247719195089*x_98 - 0.000493985818767506*x_99 + 9.82160485887428e-6*std::pow(1.38503980636597 - 7.12336015701294*x_10, 2) + 0.0200066710565379*std::sin(0.491999864578247*x_11 - 7.40000009536743) - 0.0199031647546843*std::sin(0.219359993934631*x_112 + 4.78791999816895) + 0.0996925621504943*std::sin(0.349839836359024*x_119 - 4.97839975357056) - 0.00712099867120641*std::sin(0.398959845304489*x_23 + 2.00783967971802) + 0.00454555534373347*std::sin(0.532399833202362*x_28 - 7.56040000915527) - 0.0582639158487233*std::sin(0.704639852046967*x_29 - 1.58823990821838) - 0.0115610409012801*std::sin(1.04535984992981*x_4 + 3.9663200378418) - 0.411589245622679*std::sin(0.249279975891113*x_43 - 1.22215986251831) + 0.255128323508615*std::sin(0.218559995293617*x_48 - 4.41095972061157) + 0.0816135133662304*std::sin(0.211199998855591*x_49 + 1.38191986083984) - 0.0178307494848644*std::sin(0.647999823093414*x_5 + 9.99600028991699) + 0.134995798142644*std::sin(0.522399842739105*x_57 + 1.65279984474182) - 0.102067640478946*std::sin(0.561039865016937*x_59 - 4.54360008239746) + 0.134945364903849*std::sin(0.306639939546585*x_95 - 4.60048007965088) - 2.41554881072644) - 0.0376266553920243);
}

inline float score_3(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (2.84088555762029e-6*x_1 - 6.49811080859726e-5*x_10 - 4.04172445430288e-5*x_100 + 0.000471159876075171*x_101 - 0.000119009488104031*x_102 - 0.000315629700514573*x_103 - 0.000213887715591595*x_104 + 7.25359280162589e-6*x_105 + 0.000639992233737426*x_106 + 9.38374652948318e-5*x_107 - 0.000122566218619993*x_108 + 2.82260764240615e-7*x_109 - 3.0185644835045e-5*x_11 - 0.000420309064964135*x_110 + 1.98279308439287e-5*x_111 + 0.000333807420183244*x_112 + 5.22103408088375e-5*x_113 + 4.62219032976435e-5*x_114 + 0.000143541549251773*x_115 - 0.000114327691024544*x_116 - 8.70409854227456e-6*x_117 + 0.000932820128290736*x_118 - 0.000458938511284477*x_119 - 5.05188115406139e-5*x_12 - 0.00037726893602898*x_120 + 1.55979130967989e-6*x_13 - 0.000648365295776465*x_14 - 2.68319396812211e-5*x_15 + 1.29096626652399e-8*x_16 - 4.85332844410103e-5*x_17 - 2.36783617023017e-5*x_18 - 0.000124110725448781*x_19 - 2.4199171804448e-5*x_2 - 0.000160716776852477*x_20 - 1.07377943849083e-5*x_21 - 1.15216243374544e-5*x_22 + 0.000108217627386746*x_23 - 6.62726051629233e-5*x_24 - 9.37330842105457e-5*x_25 - 0.0001312070681402*x_26 + 0.000343943431305747*x_27 - 6.69849059194593e-5*x_28 + 7.28550651320387e-5*x_29 + 6.31334571473323e-6*x_3 + 0.000171986194340467*x_30 + 5.11637938987312e-6*x_31 - 7.0776290502453e-5*x_32 - 0.000223116277509632*x_33 - 0.000788253281902993*x_34 + 4.46840926651123e-6*x_35 + 0.000198510494633908*x_36 - 9.89004242331699e-5*x_37 + 3.93529652364548e-6*x_38 - 0.000998909548469819*x_39 - 0.000147757567566263*x_4 - 9.53922393151311e-5*x_40 - 0.000324675101077967*x_41 - 0.000265572791016789*x_42 - 0.000530613974866899*x_43 - 1.17394758853859e-7*x_44 + 1.77063502910101e-5*x_45 - 0.000438671541899012*x_46 - 1.31810785178395e-5*x_47 - 0.000185127846633602*x_48 - 0.000120238852176536*x_49 - 2.16913563600914e-5*x_5 + 0.000365399643340781*x_50 + 5.33483958667257e-5*x_51 - 3.02939511849996e-5*x_52 - 9.50753309343604e-5*x_53 + 3.0639936137894e-5*x_54 + 8.30899444632426e-5*x_55 - 0.000143270227695441*x_56 - 1.55609940116089e-5*x_57 - 0.000373139475147606*x_58 - 3.40790462234021e-5*x_59 - 2.47465990348701e-5*x_6 - 9.75298624434858e-5*x_60 + 2.21590184129868e-5*x_61 + 1.06391623289675e-6*x_62 - 1.21066559471101e-6*x_63 + 5.94119085584847e-6*x_64 - 1.12790367116739e-5*x_65 - 3.05495547083995e-5*x_66 + 6.28511635600077e-6*x_67 + 1.70740635604857e-5*x_68 + 2.0292495858055e-5*x_69 - 7.73849342982203e-5*x_7 + 1.32332268397029e-5*x_70 - 8.83152243005752e-6*x_71 - 3.09670165378559e-6*x_72 + 1.21315496916218e-6*x_73 - 4.45999832951217e-6*x_74 + 1.5857870401575e-5*x_75 + 9.15958433373775e-6*x_76 + 7.48561555413192e-6*x_77 - 3.95135056323229e-6*x_78 + 1.62511076112795e-5*x_79 - 2.45150020898857e-5*x_8 + 1.26131558253858e-5*x_80 + 5.25995965631199e-6*x_81 - 2.08572473994991e-5*x_82 + 5.34234811820552e-5*x_83 + 2.82299202607336e-5*x_84 - 1.13207506295697e-6*x_85 - 1.39828100489194e-5*x_86 + 1.09907746827943e-5*x_87 + 6.0631289911161e-8*x_88 + 6.58738314347951e-6*x_89 + 5.36412006360438e-5*x_9 + 1.31485312644334e-5*x_90 - 1.61263442377487e-5*x_91 + 1.85942263591121e-6*x_92 + 6.25162851924439e-5*x_93 - 0.000154908130741602*x_94 - 2.20176430326263e-5*x_95 + 0.000717556316349981*x_96 - 3.3833265645827e-5*x_97 + 9.53986902988949e-5*x_98 - 0.000265197779081422*x_99 + 3.74975574001615e-7*std::pow(0.814879834651947 - 5.53343963623047*x_19, 2) - 5.79971586016646e-8*std::pow(0.817359864711761 - 6.45175981521606*x_23, 2) - 7.05395423820119e-8*std::pow(2.25367975234985 - 5.73983955383301*x_4, 2) - 6.37492627579124e-7*std::pow(2.6431999206543 - 7.30952024459839*x_59, 2) - 3.77819963546389e-9*std::pow(5.20296001434326 - 9.00399971008301*x_15, 2) + 1.5482217463531e-7*std::pow(7.96920013427734 - 7.90776014328003*x_27, 2) + 2.42822179376634e-7*std::pow(-8.08119964599609*x_14 - 7.46519994735718, 2) - 7.21374605973932e-7*std::pow(-6.89904022216797*x_22 - 1.4171998500824, 2) - 1.54633963159273e-7*std::pow(-4.69047975540161*x_26 - 6.72648000717163, 2) - 4.49147672289588e-6*std::pow(-2.57999992370605*x_28 - 7.52744007110596, 2) - 2.71034614656439e-7*std::pow(-4.49319982528687*x_42 - 6.96000003814697, 2) - 1.704430096083e-7*std::pow(-3.42927980422974*x_42 - 6.80200004577637, 2) + 2.88962954376387e-8*std::pow(-5.76231956481934*x_5 - 1.65471994876862, 2) + 7.85377179506524e-8*std::pow(-2.19055986404419*x_52 - 3.38007998466492, 2) - 5.36020659389875e-8*std::pow(-8.52272033691406*x_57 - 2.62191987037659, 2) + 1.81108572550954e-7*std::pow(-6.33992004394531*x_60 - 9.99560070037842, 2) - 8.93270060453743e-7*std::pow(-5.4445595741272*x_9 - 8.69223976135254, 2) + 7.73744808940456e-7*std::exp(0.629279851913452*x_1) - 2.90098451766064e-5*std::exp(0.49567985534668*x_13) - 1.13583290137396e-5*std::exp(0.526799857616425*x_14) + 4.25033679673794e-5*std::exp(0.362639844417572*x_16) + 1.84584427936768e-6*std::exp(0.359759837388992*x_19) - 7.9045861897497e-5*std::exp(0.451119869947433*x_2) - 1.69258847120372e-5*std::exp(0.299999833106995*x_24) + 2.27158261921487e-5*std::exp(0.411119878292084*x_26) - 7.46720522784227e-6*std::exp(0.428639858961105*x_27) + 2.37434004461103e-6*std::exp(0.789199888706207*x_3) + 3.41116572997704e-6*std::exp(0.5655198097229*x_30) - 6.0223431699828e-5*std::exp(0.292399853467941*x_59) + 7.43332349983968e-5*std::exp(0.325199842453003*x_60) - 1.78693186616205e-5*std::log(4.99583959579468*x_24 + 9.18455982208252) + 8.54073407069539e-6*std::sin(0.278239965438843*x_10 - 1.21111989021301) + 4.14950181002599e-5*std::sin(0.324959933757782*x_10 + 4.96639966964722) + 0.000238896480038436*std::sin(0.254079967737198*x_100 + 1.78135991096497) - 2.57499602933943e-5*std::sin(0.295599937438965*x_101 - 1.60279989242554) - 0.000837880907516666*std::sin(0.262799948453903*x_102 + 1.76351988315582) + 0.000606162424526719*std::sin(0.247759968042374*x_104 + 4.57936000823975) + 0.00146560999354276*std::sin(0.222719997167587*x_105 + 1.78591990470886) + 4.3914337067221e-5*std::sin(0.265759944915771*x_105 - 4.62527990341187) - 0.000124706626631752*std::sin(0.284959942102432*x_107 - 7.83568000793457) + 0.000432086690941801*std::sin(0.256959974765778*x_109 + 7.99103975296021) + 0.000455657077215748*std::sin(0.259119987487793*x_109 - 7.63520002365112) - 0.00380904776895243*std::sin(0.271839946508408*x_109 + 1.74463987350464) + 7.35894152133481e-6*std::sin(1.23983979225159*x_109 - 5.41856002807617) + 0.00711922698261448*std::sin(0.130800053477287*x_11 + 4.94279956817627) - 0.000331214554227199*std::sin(0.259599983692169*x_11 + 1.96687984466553) + 0.000119025011023175*std::sin(0.277599930763245*x_11 + 7.97864007949829) + 0.00228940328891375*std::sin(0.219919994473457*x_110 + 1.97583973407745) - 0.00041814639442683*std::sin(0.226159989833832*x_111 + 8.16951942443848) + 1.64564289107357e-5*std::sin(0.314239919185638*x_111 - 2.16447973251343) - 0.000487282835150528*std::sin(0.243999972939491*x_112 + 1.78271985054016) - 5.54727456960259e-5*std::sin(0.273279964923859*x_112 + 4.96903991699219) + 3.68564295937687e-5*std::sin(0.25503996014595*x_114 + 8.14727973937988) + 0.00683557260013487*std::sin(0.222879990935326*x_115 + 4.98295974731445) - 0.000432196067825861*std::sin(0.266079962253571*x_115 + 1.5596798658371) - 6.5137255190383e-5*std::sin(0.327519834041595*x_116 + 1.41927993297577) + 3.54498414011498e-5*std::sin(0.252879977226257*x_117 - 1.39735984802246) + 0.000121977104226186*std::sin(0.298719942569733*x_117 + 7.94647979736328) + 1.3384127227003e-5*std::sin(0.359679847955704*x_118 - 8.16823959350586) - 0.000173578090320676*std::sin(0.2882399559021*x_119 - 1.63407981395721) + 0.000145527539395167*std::sin(0.31687992811203*x_119 + 4.7346396446228) + 0.000461179653937086*std::sin(0.323039829730988*x_119 - 8.13776016235352) + 0.000342797294208365*std::sin(0.334239840507507*x_120 + 4.82775974273682) - 7.73942217409892e-5*std::sin(0.373439848423004*x_120 + 4.61023998260498) - 0.000356113589477534*std::sin(0.429599851369858*x_13 - 1.23991990089417) + 2.29048269668116e-5*std::sin(0.467999845743179*x_13 - 10.0) - 4.55344683491672e-5*std::sin(0.470319837331772*x_13 + 1.72207987308502) - 0.00297341639452518*std::sin(0.148880034685135*x_15 - 1.42711985111237) + 0.0012141789107341*std::sin(0.338799834251404*x_15 + 1.84023988246918) + 6.241393210931e-5*std::sin(0.589119851589203*x_16 - 4.59656000137329) + 7.40834937600629e-5*std::sin(0.797439873218536*x_16 + 7.98800039291382) + 0.00295404767823109*std::sin(0.239039987325668*x_17 - 4.38751983642578) - 0.000160852460422415*std::sin(0.420719861984253*x_17 - 1.38295984268188) - 1.59357460334616e-5*std::sin(0.189040005207062*x_20 + 1.59415984153748) - 0.00147865259350589*std::sin(0.194240003824234*x_20 + 7.61240005493164) + 4.72574908060671e-5*std::sin(0.274879962205887*x_20 - 7.58160018920898) - 0.000153685371520611*std::sin(0.192159995436668*x_21 - 1.5998398065567) - 0.00271831884793674*std::sin(0.35471984744072*x_21 - 1.15311980247498) + 8.83240393749454e-6*std::sin(1.03207981586456*x_21 + 3.58415985107422) - 6.07808001054673e-5*std::sin(0.359679847955704*x_22 - 1.39007985591888) + 0.00157855998051123*std::sin(0.501279830932617*x_22 - 7.46343994140625) + 7.75887090578462e-5*std::sin(0.550239861011505*x_23 + 8.02112007141113) - 0.000304809140510759*std::sin(0.284879922866821*x_24 - 4.38207960128784) - 7.83987296311556e-5*std::sin(0.54671984910965*x_24 + 8.00600051879883) - 7.34916722593848e-5*std::sin(0.255519956350327*x_26 + 7.79239988327026) + 5.12769015925197e-7*std::sin(0.547199845314026*x_26 - 4.34791994094849) - 0.00120326844193772*std::sin(0.378799855709076*x_27 - 1.19023990631104) - 6.83308409716588e-5*std::sin(0.430399864912033*x_27 - 7.43319988250732) + 2.27086279640925e-5*std::sin(0.422399878501892*x_28 + 1.96871984004974) + 2.20757661476554e-5*std::sin(0.213119998574257*x_29 - 1.81263983249664) + 0.000180947022166091*std::sin(0.250159978866577*x_29 + 2.00159978866577) + 2.38819871454654e-5*std::sin(0.349919855594635*x_29 + 4.61783981323242) - 0.00215382703545239*std::sin(0.397999823093414*x_29 - 4.60591983795166) - 0.00118872591340578*std::sin(0.186480015516281*x_30 + 4.79576015472412) - 9.8863311450328e-7*std::sin(0.536159813404083*x_31 - 7.41943979263306) + 0.00108366460231505*std::sin(0.215360000729561*x_32 - 4.59135961532593) + 5.83948710240268e-5*std::sin(0.250159978866577*x_32 + 5.01207971572876) - 0.00801014992023417*std::sin(0.219119995832443*x_33 - 4.39343976974487) - 0.000660400247417214*std::sin(0.235119983553886*x_33 + 8.20096015930176) - 0.00075060930466929*std::sin(0.217759996652603*x_34 + 8.19967937469482) - 0.00539805334386989*std::sin(0.231279984116554*x_35 - 1.20599985122681) - 0.00195177882013428*std::sin(0.249599978327751*x_35 + 8.18247985839844) - 0.000784316079144472*std::sin(0.256719976663589*x_35 - 1.22463989257813) - 0.000181661312184338*std::sin(0.240879982709885*x_36 - 1.20711994171143) - 0.00106630891132122*std::sin(0.258319973945618*x_37 - 7.43327951431274) - 1.88079611153472e-5*std::sin(0.277759939432144*x_38 - 1.41191983222961) + 3.30937414232964e-5*std::sin(0.289519935846329*x_38 + 1.55455982685089) - 0.000121470017974834*std::sin(0.538479864597321*x_4 - 4.58392000198364) - 8.82358377870997e-6*std::sin(0.726399838924408*x_4 + 5.0065598487854) + 0.000729237201574718*std::sin(0.226799994707108*x_40 - 1.39975988864899) + 4.88124865725789e-5*std::sin(0.236719980835915*x_40 + 8.16784000396729) + 0.000182093256732486*std::sin(0.213839992880821*x_41 + 1.59519982337952) + 0.000274127899900414*std::sin(0.218319997191429*x_41 + 1.57967984676361) + 0.000206525440205596*std::sin(0.350719839334488*x_41 + 1.61295986175537) + 1.80542332154632e-5*std::sin(0.307519912719727*x_42 + 1.74847984313965) + 0.000114252490798413*std::sin(0.457919865846634*x_43 + 4.92479991912842) + 4.0649492770217e-5*std::sin(0.46383985877037*x_43 + 4.89663982391357) + 0.000141250663342648*std::sin(0.489919871091843*x_43 + 7.90343999862671) - 0.00503107741314661*std::sin(0.279279947280884*x_44 + 1.93007981777191) + 0.000337782902228167*std::sin(0.292959928512573*x_44 - 7.64568042755127) + 0.000548507312085246*std::sin(0.29751992225647*x_44 - 4.45015954971313) + 7.64288027265337e-5*std::sin(0.340239852666855*x_44 + 8.0444803237915) - 1.16644505421468e-5*std::sin(0.557119846343994*x_44 + 7.60111999511719) - 0.000252845084443635*std::sin(0.169520020484924*x_45 - 7.79071998596191) - 0.000676664524390238*std::sin(0.58927983045578*x_45 - 7.79103994369507) - 0.000265698193554203*std::sin(0.268879950046539*x_46 - 1.40031981468201) - 0.000113108231974816*std::sin(0.189680010080338*x_47 + 2.01359987258911) + 8.08681890601933e-5*std::sin(0.607679843902588*x_47 - 4.6101598739624) - 2.51754988271372e-5*std::sin(0.661439836025238*x_47 + 7.74631977081299) + 4.76870745759966e-5*std::sin(0.288879930973053*x_49 + 1.89487981796265) - 0.000123409867061144*std::sin(0.37407985329628*x_49 - 4.56288003921509) - 9.24741984222217e-5*std::sin(0.575759828090668*x_50 - 4.5734395980835) - 2.41084370854017e-6*std::sin(0.626239836215973*x_50 + 4.7673602104187) - 0.00240405012425505*std::sin(0.211119994521141*x_51 - 1.40071988105774) - 0.00424642450943916*std::sin(0.213199988007545*x_52 - 1.20551991462708) + 0.000151618559063281*std::sin(0.213359996676445*x_53 + 1.97695982456207) + 0.00181502380123727*std::sin(0.247039973735809*x_53 + 8.1988000869751) - 0.000255826465967629*std::sin(0.269999951124191*x_53 - 4.61583995819092) + 0.000790798298381827*std::sin(0.210720002651215*x_54 + 1.98495984077454) + 0.000611278210889503*std::sin(0.446799844503403*x_55 + 1.52711987495422) - 0.000173968126012417*std::sin(0.495999842882156*x_55 - 1.39999985694885) + 0.000213885894107795*std::sin(0.184000000357628*x_56 + 1.57647979259491) + 0.000446114891396574*std::sin(0.572159826755524*x_56 + 4.83112001419067) - 0.00553164548727552*std::sin(0.19080001115799*x_57 - 7.40759992599487) + 0.000845129776829983*std::sin(0.193999990820885*x_57 - 1.18895995616913) + 0.000353677643320869*std::sin(0.210400000214577*x_57 - 4.38695955276489) + 0.00121211339973247*std::sin(0.234479993581772*x_57 + 1.76807987689972) - 1.09682108984207e-5*std::sin(0.409359842538834*x_57 - 8.01327991485596) + 0.000955866480291278*std::sin(0.503999829292297*x_57 + 1.79999983310699) - 0.00141389210746738*std::sin(0.156560033559799*x_58 - 1.73479986190796) - 0.000295678998786668*std::sin(0.0999200716614723*x_59 - 7.80351972579956) + 0.0205909576748621*std::sin(0.106240063905716*x_59 - 1.25135982036591) - 0.000264296934461901*std::sin(0.146480038762093*x_59 - 7.96208000183105) - 5.90153333416771e-5*std::sin(0.350399851799011*x_59 + 8.05471992492676) - 0.000767412635137429*std::sin(0.356559842824936*x_59 - 1.33015990257263) + 0.000281519100872598*std::sin(0.434719860553741*x_59 - 1.43583977222443) + 0.000267259315110704*std::sin(0.568239867687225*x_59 - 1.55663979053497) - 5.2937637515706e-5*std::sin(0.23735998570919*x_6 - 7.57872009277344) + 7.73726628234921e-5*std::sin(0.428959846496582*x_6 - 1.40255987644196) - 9.11975308683018e-5*std::sin(0.588399827480316*x_6 - 8.19416046142578) + 9.65176244890827e-5*std::sin(0.580399870872498*x_60 - 4.56799983978271) + 1.37932682091913e-6*std::sin(0.985839784145355*x_64 + 5.59231996536255) - 7.27761311425072e-6*std::sin(1.30951976776123*x_65 + 8.57479953765869) - 9.22556858220684e-7*std::sin(0.747679829597473*x_7 + 7.62128019332886) - 0.000761573451082508*std::sin(0.301279932260513*x_8 + 4.78895998001099) + 0.000390130842045588*std::sin(0.346559852361679*x_8 - 1.35543990135193) + 0.00408983494594323*std::sin(0.225839987397194*x_9 + 4.99991989135742) + 0.000144396088946881*std::sin(0.20456001162529*x_91 + 7.79360008239746) + 5.31055327352955e-6*std::sin(0.287119954824448*x_92 + 1.81895983219147) + 0.00315506676645321*std::sin(0.339519828557968*x_92 + 1.80711996555328) + 3.80996693124984e-5*std::sin(0.43767985701561*x_92 + 4.59567975997925) + 0.000693349020586116*std::sin(0.254879981279373*x_93 - 7.62007999420166) - 2.34821192903845e-5*std::sin(0.255519956350327*x_93 - 4.41703987121582) - 0.000135631641851247*std::sin(0.289679944515228*x_93 + 1.5745598077774) - 1.60664847044312e-5*std::sin(0.19080001115799*x_94 + 4.79112005233765) - 0.00106609870428811*std::sin(0.290399938821793*x_94 - 1.39271986484528) + 0.000350280554768482*std::sin(0.331199824810028*x_94 + 1.63039982318878) - 1.29644248394744e-6*std::sin(0.249279975891113*x_95 + 5.17112016677856) - 0.000276959949696912*std::sin(0.26199996471405*x_95 - 7.79631996154785) - 0.000657036589279703*std::sin(0.291839927434921*x_95 + 7.97679996490479) - 0.000209265106873646*std::sin(0.296879917383194*x_95 - 4.83536005020142) + 5.92045582299521e-5*std::sin(0.422399878501892*x_96 + 4.39903974533081) + 0.00292113649592282*std::sin(0.279439955949783*x_97 + 8.17615985870361) - 0.00110662802382214*std::sin(0.330079853534698*x_97 - 1.55287981033325) - 8.88460797174967e-6*std::sin(0.244639977812767*x_98 - 7.41063976287842) - 0.00525955779559459*std::sin(0.277279943227768*x_98 + 8.17543983459473) - 0.00169665290451576*std::sin(0.306719928979874*x_98 + 4.77415990829468) - 0.000312057515652969*std::sin(0.328239858150482*x_98 + 7.83935976028442) + 3.43483325604549e-5*std::sin(0.36287984251976*x_98 - 1.97687971591949) - 0.00918675307184458*std::sin(0.000718106478792965*x_1 - 6.76435402983674e-5*x_100 + 0.0050912423827041*x_101 + 0.00122620620562838*x_102 + 0.000270394522018159*x_103 + 0.0147955118599569*x_104 - 0.000788591104784551*x_105 - 0.000238256570241854*x_106 + 0.00436295285772992*x_107 + 0.00956059381518176*x_108 - 0.000546080475210257*x_109 + 0.0157178151441565*x_110 - 0.0440755382184925*x_111 + 0.000170491872019802*x_113 - 0.0177359128342287*x_114 + 0.000344618218572267*x_115 - 0.0166948615217927*x_116 + 9.52315096927935e-5*x_117 - 0.000262166491163463*x_118 + 0.00314281787783676*x_12 + 0.00771702525590134*x_120 + 0.00223369988968964*x_13 + 0.00257659602883273*x_14 + 0.00724177339165054*x_15 - 0.0151152878105561*x_16 + 0.00117100203792086*x_17 + 0.00454145763925896*x_18 + 0.00842992580992396*x_19 - 9.88774838580106e-5*x_2 + 0.00312706133583769*x_20 + 0.000406778079842532*x_21 + 0.00619864662365986*x_22 + 0.00311286068813797*x_24 - 0.0156849645607398*x_25 + 0.00431386781946507*x_26 + 0.00122551770074622*x_27 + 0.00201217576904598*x_3 + 0.00147475055834405*x_30 + 0.000100125450463141*x_31 + 0.000349292641376487*x_32 + 0.00465003354997292*x_33 - 0.000720657024410019*x_34 + 0.00093321164909959*x_35 + 0.0118121175139165*x_36 - 0.0153474081925434*x_37 - 0.0145147390029055*x_38 - 0.0479597009232235*x_39 - 0.0026352596206826*x_40 - 0.0659532509591091*x_41 + 0.000286360474153148*x_42 - 0.000745452414614252*x_44 + 0.000606163136204738*x_45 + 0.00467412870954674*x_46 + 0.000448775425844876*x_47 - 0.00500108387616051*x_50 + 0.00306299949399327*x_51 - 0.000437665533248391*x_52 + 0.00248093693944119*x_53 - 0.0319425238414923*x_54 + 0.00299226008892197*x_55 + 0.00311526272496169*x_56 - 0.0273288441036476*x_58 + 0.000455280665782827*x_6 + 7.77325277096219e-5*x_60 - 7.03931809904965e-5*x_61 + 1.11589421596493e-5*x_62 + 0.000460982987252767*x_63 + 0.00328828901065426*x_64 + 0.000221903877624934*x_65 - 0.000216875776293999*x_66 + 0.000188451578698145*x_67 - 0.00115383984049592*x_68 - 0.000842022273200321*x_69 - 0.00229480953911598*x_7 - 0.000276059470034815*x_70 - 0.00184160109786974*x_71 + 0.000105639065588518*x_72 - 0.00195911943067684*x_73 + 0.00172757733880426*x_74 + 0.000465763085529735*x_75 - 0.000149417579173142*x_76 + 0.000654579657594226*x_77 + 0.00167822966461943*x_78 - 0.000756634376891591*x_79 + 0.00325277898181937*x_8 - 0.00096780458499037*x_80 + 0.0025777527459643*x_81 + 0.000450377911355063*x_82 - 0.00355118352582103*x_83 - 0.000139443237953418*x_84 - 0.000840983118665277*x_85 - 9.39501250749125e-5*x_86 - 0.000238477843108988*x_87 - 8.32364057840522e-5*x_88 - 0.000420656379267129*x_89 + 0.00322995297543089*x_9 - 0.000354962761165884*x_90 - 0.000416802686068658*x_91 - 0.000319729429334181*x_92 + 0.0141342771300371*x_93 - 0.00075341131447647*x_94 + 0.00150164388470786*x_96 - 9.25451983708974e-5*x_97 + 0.001810581305821*x_98 - 0.000628763324896955*x_99 + 1.25013000217246e-5*std::pow(1.38503980636597 - 7.12336015701294*x_10, 2) + 0.0254652270079618*std::sin(0.491999864578247*x_11 - 7.40000009536743) - 0.0253334803787497*std::sin(0.219359993934631*x_112 + 4.78791999816895) + 0.12689236100266*std::sin(0.349839836359024*x_119 - 4.97839975357056) - 0.00906386910512069*std::sin(0.398959845304489*x_23 + 2.00783967971802) + 0.00578575008197579*std::sin(0.532399833202362*x_28 - 7.56040000915527) - 0.0741604557433693*std::sin(0.704639852046967*x_29 - 1.58823990821838) - 0.0147153182139825*std::sin(1.04535984992981*x_4 + 3.9663200378418) - 0.523885935056256*std::sin(0.249279975891113*x_43 - 1.22215986251831) + 0.324736716865473*std::sin(0.218559995293617*x_48 - 4.41095972061157) + 0.103880682544097*std::sin(0.211199998855591*x_49 + 1.38191986083984) - 0.0226956339748381*std::sin(0.647999823093414*x_5 + 9.99600028991699) + 0.17182761865323*std::sin(0.522399842739105*x_57 + 1.65279984474182) - 0.129915448083205*std::sin(0.561039865016937*x_59 - 4.54360008239746) + 0.171763425371349*std::sin(0.306639939546585*x_95 - 4.60048007965088) - 11.3528462262285) + 0.105678990099033);
}

inline float score_4(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-1.47246425207769e-6*x_1 + 0.00141406401843218*x_10 + 0.000508612968091136*x_100 + 0.000408318688242015*x_101 + 0.000134847922884436*x_102 - 0.000361037864117666*x_103 + 0.000300054969760835*x_104 + 0.000253161542622192*x_105 - 0.000192562439971144*x_106 + 4.37963046587207e-5*x_107 + 0.000161648076193968*x_108 - 9.71982260621355e-5*x_109 - 3.56358325327446e-5*x_11 + 0.000460670307570713*x_110 - 4.87046997610384e-5*x_111 - 1.43920678337342e-5*x_112 - 2.89645592856271e-6*x_113 - 3.95820902373868e-5*x_114 - 0.00141904778885187*x_115 + 0.00109023488608714*x_116 + 0.000422294053620602*x_117 - 0.000347086317377829*x_118 + 9.91127143535368e-5*x_119 + 4.36026131342522e-5*x_12 - 6.08541344800077e-5*x_120 + 6.64556930819528e-5*x_13 + 0.000269719689192982*x_14 + 2.04908350651646e-5*x_15 - 1.34226234931812e-5*x_16 + 8.42855219300382e-5*x_17 + 0.000154432185585491*x_18 + 8.7582119921647e-5*x_19 - 1.99224594236972e-5*x_2 - 2.54027057521214e-5*x_20 - 4.55468097900156e-6*x_21 + 0.000677851703034504*x_22 + 0.000711560704189288*x_23 + 0.000801368504992326*x_24 - 7.40824187978158e-5*x_25 + 3.01747493599484e-5*x_26 + 0.000485157174714618*x_27 + 0.000930190342671682*x_28 + 0.00028611787356887*x_29 - 0.000648526145293365*x_3 - 0.000449212719033156*x_30 + 1.94081154689545e-5*x_31 + 1.48762789740041e-5*x_32 + 0.000120953672827306*x_33 + 0.000507930222599736*x_34 + 0.000279954891673504*x_35 - 0.000161534296334647*x_36 + 0.000230237102629684*x_37 - 0.00114354553279344*x_38 + 0.000888388126905326*x_39 + 9.26751898218897e-5*x_4 - 9.04710119643906e-5*x_40 + 5.57925608026793e-5*x_41 + 0.000195622269696772*x_42 + 0.000218199923992875*x_43 + 8.50074499097059e-5*x_44 + 0.000978698913457874*x_45 + 0.000366502436737219*x_46 - 0.00247698176668066*x_47 - 0.00039177218376629*x_48 + 0.000143945423048623*x_49 - 4.25392151046839e-7*x_5 - 0.0024224619732783*x_50 - 0.00207960234148631*x_51 + 0.00147190905852705*x_52 + 2.5108076729148e-5*x_53 - 0.00131785916682338*x_54 + 0.000312341367347032*x_55 - 9.01186834950243e-5*x_56 + 1.1325326029396e-5*x_57 + 0.000306067337855792*x_58 - 2.18718908389286e-5*x_59 - 2.0830023036002e-7*x_6 - 2.28381417311565e-5*x_60 - 6.30054050014532e-6*x_61 - 1.43071535164078e-6*x_62 + 1.76115235752792e-5*x_63 + 9.18983948445976e-7*x_64 - 7.2721046471129e-6*x_65 - 3.43770447146378e-5*x_66 - 4.66141535027922e-6*x_67 - 1.88273197115724e-5*x_68 + 5.62139951625826e-7*x_69 + 0.00121843837897202*x_7 - 2.44143864717331e-6*x_70 - 3.11496370286962e-5*x_71 - 3.13269319007644e-5*x_72 - 1.67410711000129e-6*x_73 - 2.46094957070193e-5*x_74 - 5.64768638439944e-6*x_75 + 2.91506712356081e-5*x_76 + 5.77137984930096e-5*x_77 - 1.08385872735926e-5*x_78 + 2.7659087205236e-6*x_79 - 3.40930158200102e-5*x_8 - 2.09150795591751e-5*x_80 - 4.83392569393595e-5*x_81 - 8.19646395200053e-6*x_82 - 0.000183789198270212*x_83 - 4.14750758558993e-5*x_84 - 6.49796523657192e-6*x_85 + 3.68661057638759e-5*x_86 - 1.98257525006374e-6*x_87 - 8.50002142912615e-5*x_88 - 9.44542710884255e-5*x_89 - 0.00139797132622367*x_9 + 3.15439930938627e-5*x_90 + 6.09703385731899e-5*x_91 + 0.000170428746073026*x_92 + 0.00036065652031177*x_93 + 7.23574350013956e-5*x_94 - 7.90725938972748e-6*x_95 - 0.000247973206539431*x_96 - 3.54478919492722e-5*x_97 - 3.82103576214397e-5*x_98 + 4.1915048674158e-6*x_99 + 8.79597973367242e-9*std::pow(0.814879834651947 - 5.53343963623047*x_19, 2) + 4.55273052799425e-7*std::pow(0.817359864711761 - 6.45175981521606*x_23, 2) + 5.53729761554409e-7*std::pow(2.25367975234985 - 5.73983955383301*x_4, 2) - 3.97630195568101e-7*std::pow(2.6431999206543 - 7.30952024459839*x_59, 2) - 5.2748168018683e-8*std::pow(5.20296001434326 - 9.00399971008301*x_15, 2) + 1.51458113390997e-7*std::pow(-8.08119964599609*x_14 - 7.46519994735718, 2) + 3.61287799217199e-7*std::pow(-6.89904022216797*x_22 - 1.4171998500824, 2) - 2.30207692242022e-7*std::pow(-4.69047975540161*x_26 - 6.72648000717163, 2) + 1.59372030453658e-6*std::pow(-2.57999992370605*x_28 - 7.52744007110596, 2) - 1.44064219909596e-6*std::pow(-4.49319982528687*x_42 - 6.96000003814697, 2) - 9.2366874191673e-8*std::pow(-3.42927980422974*x_42 - 6.80200004577637, 2) - 2.90481568729535e-8*std::pow(-8.52272033691406*x_57 - 2.62191987037659, 2) - 4.96778331477788e-6*std::pow(-6.33992004394531*x_60 - 9.99560070037842, 2) + 4.47378617954302e-7*std::pow(-5.4445595741272*x_9 - 8.69223976135254, 2) - 2.33981645578751e-5*std::pow(-0.0295206815743051*x_1 - 0.0157573522330533*x_10 + 0.00867513044313242*x_100 + 0.039645571339923*x_101 - 0.0246108837451408*x_103 + 0.018343374699388*x_104 + 0.29527328690551*x_105 - 0.034992490984161*x_106 - 0.0292637360632408*x_107 - 0.0226020610403789*x_108 - 0.00258730218248623*x_11 - 0.015501303895961*x_110 - 0.0334856737919011*x_111 + 0.142629529246591*x_112 - 0.0139795845444141*x_113 - 0.0779604488693913*x_114 - 0.0375018287041014*x_115 + 0.139394696936744*x_116 - 0.0138602468112698*x_117 - 0.282659333294815*x_118 - 0.0121458845128479*x_119 - 0.153621926548218*x_12 + 0.00326496225515846*x_15 - 0.0119510997101734*x_16 - 0.0118470033374771*x_17 - 0.0122017749352809*x_18 - 0.0406165349251036*x_19 + 0.00185902623085794*x_2 + 0.279587634470728*x_20 - 0.0123094954942307*x_21 - 0.0199159349103359*x_22 - 0.104778919922042*x_23 - 0.0256647838525839*x_24 - 0.0188306686666133*x_25 - 0.00357823784361888*x_26 - 0.000929544196044753*x_27 - 0.0305002080759778*x_28 - 0.0173550439503307*x_29 - 0.00324605362844034*x_3 - 0.00389428963738301*x_31 + 0.155557117639684*x_32 - 0.0458595606037469*x_33 + 0.0557657985295656*x_34 - 0.0532400763741931*x_35 - 0.017477612706049*x_36 - 0.0505861506024352*x_37 - 0.043819498560701*x_38 - 0.0362169510342072*x_39 - 0.0145330833905213*x_40 + 0.2819288392762*x_41 - 0.0452018555384183*x_42 - 0.188568251758592*x_43 - 0.0293323051340499*x_45 - 0.0596923317345439*x_46 - 0.0477492916061168*x_47 - 0.249782069411446*x_48 + 0.0137812181793468*x_49 - 0.0276920373088112*x_5 - 0.0488658317181699*x_51 - 0.0429519625887567*x_52 + 0.0206727499964117*x_53 - 0.0589361529220545*x_54 + 0.00942999471517514*x_55 + 0.282719446973596*x_56 + 0.340078947832612*x_58 + 0.0558418223160441*x_59 + 0.000429401442524338*x_6 - 0.0170956772078816*x_60 + 0.0196230351083861*x_61 - 0.00128823139034264*x_62 + 0.00598037121129222*x_63 - 0.000495474357999427*x_64 + 0.000782384314656294*x_65 + 0.0104168546798548*x_66 - 0.00966085515531528*x_67 - 0.000624909887311931*x_68 + 0.00369479835371882*x_69 - 0.0374177214909591*x_7 - 0.00112957688387069*x_70 + 0.0189332349214285*x_71 + 0.00196107107722789*x_72 - 0.00134076257778254*x_73 + 0.00684401183916943*x_74 + 0.00213429237431422*x_75 + 0.00128510249058883*x_76 + 0.00727495998768916*x_77 - 0.00095454121131447*x_78 + 0.000353055686692237*x_79 + 0.00180410822829509*x_8 - 0.00140519090059465*x_80 + 0.00259532344725786*x_81 + 0.0015350651791853*x_82 - 0.0138497876513286*x_83 - 0.00038805498165696*x_84 + 0.00120249055269289*x_85 - 0.000448216664803937*x_86 - 0.00781288883676107*x_87 + 0.00590941735589708*x_88 - 0.0100120148118423*x_89 - 0.000538392809221329*x_9 + 0.0022679338843036*x_90 - 0.00163602074000679*x_91 - 0.0200524733329618*x_92 - 0.0275350171049844*x_96 + 0.0490526084304042*x_97 - 0.0818894313940357*x_99 + 0.0266049810408874*std::exp(0.526799857616425*x_14) + 1.9625955219326*std::sin(0.262799948453903*x_102 + 1.76351988315582) - 1.06730029441891*std::sin(0.259119987487793*x_109 - 7.63520002365112) - 0.802945178137463*std::sin(0.334239840507507*x_120 + 4.82775974273682) + 0.83413636680109*std::sin(0.429599851369858*x_13 - 1.23991990089417) + 2.78439111516457*std::sin(0.186480015516281*x_30 + 4.79576015472412) + 0.284523147845732*std::sin(0.538479864597321*x_4 - 4.58392000198364) - 1.28478639958075*std::sin(0.29751992225647*x_44 - 4.45015954971313) + 0.216605302841501*std::sin(0.575759828090668*x_50 - 4.5734395980835) - 2.83917238004631*std::sin(0.234479993581772*x_57 + 1.76807987689972) - 1.62405381329398*std::sin(0.254879981279373*x_93 - 7.62007999420166) - 0.820473461134469*std::sin(0.331199824810028*x_94 + 1.63039982318878) + 1.53899803217627*std::sin(0.291839927434921*x_95 + 7.97679996490479) + 0.730942401613021*std::sin(0.328239858150482*x_98 + 7.83935976028442) - 0.584191590377722, 2) - 6.07383481789949e-6*std::exp(0.629279851913452*x_1) + 1.4529071348911e-5*std::exp(0.49567985534668*x_13) - 0.00116586155606084*std::exp(0.362639844417572*x_16) + 2.74795745455801e-6*std::exp(0.359759837388992*x_19) + 3.9588731354934e-5*std::exp(0.451119869947433*x_2) - 9.17251500881362e-6*std::exp(0.299999833106995*x_24) + 0.000120742429306387*std::exp(0.411119878292084*x_26) - 1.11166269548984e-5*std::exp(0.428639858961105*x_27) + 5.56960195843463e-8*std::exp(0.789199888706207*x_3) + 1.81315191232832e-5*std::exp(0.5655198097229*x_30) - 0.000320108253298652*std::exp(0.292399853467941*x_59) + 0.000531457798260734*std::exp(0.325199842453003*x_60) + 0.0204684046645042*std::exp(0.00114842123570145*x_1 - 0.0200710671787828*x_10 + 0.00058459200596222*x_100 + 3.84223210610662e-5*x_101 + 0.0011078736691914*x_102 + 0.00426924888451172*x_103 - 0.00547753926917099*x_104 - 0.00121160642958794*x_105 + 0.00111454174759232*x_106 - 0.000312680680293185*x_107 - 0.000528986761159572*x_108 + 0.000729362583222591*x_109 - 0.00267106042382318*x_11 - 0.000444673996787649*x_110 + 0.00259798694597628*x_111 + 0.00126368822252395*x_112 + 0.00118568998662084*x_113 - 0.00357386697161681*x_114 - 0.000645083812303861*x_115 + 0.000703576465712968*x_116 + 0.00443438739575453*x_117 + 0.00154008093278832*x_118 - 0.00114982129182743*x_119 + 0.000265487256107394*x_12 + 0.000948033250791432*x_120 - 0.0130924728251748*x_13 - 0.00192239245976399*x_14 + 0.00741582449502314*x_15 - 0.000114810386772666*x_16 + 0.00173104593412905*x_17 + 0.00205229215254639*x_18 + 0.0101625452999825*x_19 + 0.00181560786334661*x_2 + 0.00410097964768708*x_20 + 0.00321311597480291*x_21 - 0.00506820144152452*x_22 + 0.0029588976710979*x_23 + 0.00286475885650664*x_24 + 0.000503559847902744*x_25 + 0.00817360056073637*x_26 - 0.00250965976948279*x_28 + 0.000118672915879097*x_29 + 0.000543891361467393*x_3 + 0.000306394778549663*x_30 - 0.000119579717075483*x_31 - 0.000114819487160632*x_32 - 0.00102785884674002*x_33 - 0.000570139689084512*x_34 - 0.00437937545333802*x_35 - 0.0337832462295123*x_36 + 0.0246933504773176*x_37 + 0.0176866968713048*x_38 - 0.00246010433595074*x_39 + 0.00178914134435588*x_4 + 0.00142643235235702*x_40 - 0.00579336753054238*x_41 - 0.00600464026639822*x_42 + 0.00617128742739878*x_43 - 0.000341941456226234*x_44 - 0.0285414603703027*x_45 - 0.0105025281067978*x_46 + 0.00234812815190055*x_47 + 0.00300073392265052*x_48 + 0.000222708371571236*x_49 + 8.52540850050514e-5*x_5 - 0.000348436157461973*x_50 + 0.0108384067981758*x_51 - 0.0210266604883749*x_52 + 0.00333287327438636*x_53 - 0.00390320882280241*x_54 - 0.0372895997324474*x_55 - 0.000973189385374799*x_56 + 0.00311175252217961*x_57 - 0.001419689331128*x_59 - 0.00420952722488135*x_6 + 4.33272097276188e-5*x_60 + 0.000881016288369384*x_61 + 0.00122798743412045*x_62 + 0.000159824208851957*x_63 + 0.000372593749643492*x_64 - 0.00249829127196907*x_65 - 0.00134089164400547*x_66 + 0.000341161003792061*x_67 - 0.00198593358596168*x_68 - 0.000106977334442422*x_69 + 0.000981401493540194*x_7 - 0.00313154829935812*x_70 + 0.000277711800700668*x_71 + 0.000313180827204617*x_72 + 0.00144815469760625*x_73 - 0.00130551505445367*x_74 - 0.00108966394146154*x_75 + 0.000459603293107215*x_76 - 0.00154197795010824*x_77 - 0.000730760815043199*x_78 + 0.000342651560904997*x_79 + 0.00029247138760749*x_8 - 0.00045953089171659*x_80 - 9.17088846038831e-5*x_81 - 0.000699074731302848*x_82 + 3.18501658060129e-6*x_83 - 0.00080889444897603*x_84 + 0.000726020060137609*x_85 - 0.000888407389743827*x_86 - 0.000353150995134659*x_87 - 0.000442482284363833*x_88 - 0.0036097906695931*x_89 - 0.00245942466406645*x_9 + 5.09806118713298e-6*x_90 + 9.3913425690269e-5*x_91 - 4.39715067306313e-5*x_93 - 0.0116937125472979*x_94 + 0.000537365426677571*x_96 + 0.000862650366047425*x_97 - 0.00485091771053944*x_98 + 0.00777884480875418*x_99 - 5.54104898074976e-5*std::pow(7.96920013427734 - 7.90776014328003*x_27, 2) + 0.5060286383024*std::sin(0.156560033559799*x_58 - 1.73479986190796) - 0.0136357814575467*std::sin(0.43767985701561*x_92 + 4.59567975997925) + 0.0748954863784901*std::sin(0.296879917383194*x_95 - 4.83536005020142)) - 0.000127759658953752*std::log(4.99583959579468*x_24 + 9.18455982208252) - 6.70440788353027e-5*std::sin(0.278239965438843*x_10 - 1.21111989021301) + 6.17747366829287e-5*std::sin(0.324959933757782*x_10 + 4.96639966964722) - 0.00187531824648758*std::sin(0.254079967737198*x_100 + 1.78135991096497) + 0.000378088267978719*std::sin(0.247759968042374*x_104 + 4.57936000823975) - 0.000734025019307279*std::sin(0.222719997167587*x_105 + 1.78591990470886) + 0.000978937037259037*std::sin(0.284959942102432*x_107 - 7.83568000793457) - 0.000216403028812809*std::sin(0.256959974765778*x_109 + 7.99103975296021) + 0.00135157257731823*std::sin(0.271839946508408*x_109 + 1.74463987350464) + 1.72622178538655e-7*std::sin(1.23983979225159*x_109 - 5.41856002807617) - 0.00252613055678534*std::sin(0.130800053477287*x_11 + 4.94279956817627) + 0.0090851698123707*std::sin(0.259599983692169*x_11 + 1.96687984466553) + 0.000177195698454058*std::sin(0.277599930763245*x_11 + 7.97864007949829) + 0.00142799436122426*std::sin(0.219919994473457*x_110 + 1.97583973407745) - 0.00298960703294482*std::sin(0.226159989833832*x_111 + 8.16951942443848) - 0.000129181649739515*std::sin(0.314239919185638*x_111 - 2.16447973251343) + 0.0133661013608696*std::sin(0.243999972939491*x_112 + 1.78271985054016) - 0.00242548086477557*std::sin(0.222879990935326*x_115 + 4.98295974731445) - 0.00309005750427293*std::sin(0.266079962253571*x_115 + 1.5596798658371) - 9.69715636202948e-5*std::sin(0.327519834041595*x_116 + 1.41927993297577) - 4.32813971188768e-5*std::sin(0.298719942569733*x_117 + 7.94647979736328) + 0.00476122321964336*std::sin(0.2882399559021*x_119 - 1.63407981395721) - 0.00114237953589893*std::sin(0.31687992811203*x_119 + 4.7346396446228) + 0.000287656590921551*std::sin(0.323039829730988*x_119 - 8.13776016235352) - 0.000115218835602818*std::sin(0.373439848423004*x_120 + 4.61023998260498) + 0.000163761861159242*std::sin(0.467999845743179*x_13 - 10.0) - 2.46761455283961e-5*std::sin(0.470319837331772*x_13 + 1.72207987308502) - 0.00185464127946122*std::sin(0.148880034685135*x_15 - 1.42711985111237) - 0.000608100178301687*std::sin(0.338799834251404*x_15 + 1.84023988246918) + 3.89301192784677e-5*std::sin(0.589119851589203*x_16 - 4.59656000137329) - 3.71034164458257e-5*std::sin(0.797439873218536*x_16 + 7.98800039291382) - 0.00104819106405846*std::sin(0.239039987325668*x_17 - 4.38751983642578) - 0.000854986152254703*std::sin(0.420719861984253*x_17 - 1.38295984268188) - 2.37239688071603e-5*std::sin(0.189040005207062*x_20 + 1.59415984153748) + 0.000524673466437697*std::sin(0.194240003824234*x_20 + 7.61240005493164) + 0.00421556867028332*std::sin(0.192159995436668*x_21 - 1.5998398065567) + 0.000964546898367995*std::sin(0.35471984744072*x_21 - 1.15311980247498) + 6.31487375744044e-5*std::sin(1.03207981586456*x_21 + 3.58415985107422) - 3.29384732733417e-5*std::sin(0.359679847955704*x_22 - 1.39007985591888) - 0.00056012381853057*std::sin(0.501279830932617*x_22 - 7.46343994140625) + 4.20470545827032e-5*std::sin(0.550239861011505*x_23 + 8.02112007141113) + 0.000152658303528358*std::sin(0.284879922866821*x_24 - 4.38207960128784) + 0.000615423752393079*std::sin(0.54671984910965*x_24 + 8.00600051879883) - 3.98267788237159e-5*std::sin(0.255519956350327*x_26 + 7.79239988327026) + 7.15886634282524e-6*std::sin(0.547199845314026*x_26 - 4.34791994094849) + 0.000602635861666158*std::sin(0.378799855709076*x_27 - 1.19023990631104) - 4.2620737061812e-5*std::sin(0.430399864912033*x_27 - 7.43319988250732) + 0.000162359103832613*std::sin(0.422399878501892*x_28 + 1.96871984004974) + 0.00129371076079631*std::sin(0.250159978866577*x_29 + 2.00159978866577) + 3.55537492190411e-5*std::sin(0.349919855594635*x_29 + 4.61783981323242) + 0.000764247059627893*std::sin(0.397999823093414*x_29 - 4.60591983795166) - 1.47180440256468e-6*std::sin(0.536159813404083*x_31 - 7.41943979263306) - 0.000542734379638163*std::sin(0.215360000729561*x_32 - 4.59135961532593) + 0.00284225865074247*std::sin(0.219119995832443*x_33 - 4.39343976974487) + 0.0181146882446518*std::sin(0.235119983553886*x_33 + 8.20096015930176) + 0.0205891103172603*std::sin(0.217759996652603*x_34 + 8.19967937469482) + 0.00191540282848226*std::sin(0.231279984116554*x_35 - 1.20599985122681) - 0.00121740418693602*std::sin(0.249599978327751*x_35 + 8.18247985839844) + 0.000392810930379505*std::sin(0.256719976663589*x_35 - 1.22463989257813) - 0.000270444025317643*std::sin(0.240879982709885*x_36 - 1.20711994171143) - 0.00066510043034504*std::sin(0.258319973945618*x_37 - 7.43327951431274) + 4.92675327273627e-5*std::sin(0.289519935846329*x_38 + 1.55455982685089) - 6.30856763855827e-5*std::sin(0.726399838924408*x_4 + 5.0065598487854) - 0.020002876459528*std::sin(0.226799994707108*x_40 - 1.39975988864899) - 0.00142941749019423*std::sin(0.213839992880821*x_41 + 1.59519982337952) + 0.00145708407410134*std::sin(0.218319997191429*x_41 + 1.57967984676361) - 0.00566496450984874*std::sin(0.350719839334488*x_41 + 1.61295986175537) + 0.000170090720707421*std::sin(0.457919865846634*x_43 + 4.92479991912842) + 3.31338374622866e-6*std::sin(0.489919871091843*x_43 + 7.90343999862671) + 0.00178518797306767*std::sin(0.279279947280884*x_44 + 1.93007981777191) + 7.92353360693091e-6*std::sin(0.292959928512573*x_44 - 7.64568042755127) - 0.000599959983869199*std::sin(0.340239852666855*x_44 + 8.0444803237915) - 8.33969247158993e-5*std::sin(0.557119846343994*x_44 + 7.60111999511719) - 0.000137022399208157*std::sin(0.169520020484924*x_45 - 7.79071998596191) + 0.00024010232233487*std::sin(0.58927983045578*x_45 - 7.79103994369507) - 0.000395551964919806*std::sin(0.268879950046539*x_46 - 1.40031981468201) + 0.000887890567563804*std::sin(0.189680010080338*x_47 + 2.01359987258911) - 4.05014119020616e-5*std::sin(0.607679843902588*x_47 - 4.6101598739624) - 3.74794344504224e-5*std::sin(0.661439836025238*x_47 + 7.74631977081299) + 0.000968757578425328*std::sin(0.37407985329628*x_49 - 4.56288003921509) + 0.00085303425410578*std::sin(0.211119994521141*x_51 - 1.40071988105774) + 0.00150676790283164*std::sin(0.213199988007545*x_52 - 1.20551991462708) + 8.21654839485937e-5*std::sin(0.213359996676445*x_53 + 1.97695982456207) - 0.000909022786836974*std::sin(0.247039973735809*x_53 + 8.1988000869751) + 0.00701728488724642*std::sin(0.269999951124191*x_53 - 4.61583995819092) - 0.000396057436013212*std::sin(0.210720002651215*x_54 + 1.98495984077454) - 0.000216901156684004*std::sin(0.446799844503403*x_55 + 1.52711987495422) + 0.00477192184519326*std::sin(0.495999842882156*x_55 - 1.39999985694885) - 0.00586686075125526*std::sin(0.184000000357628*x_56 + 1.57647979259491) + 0.000278260083078129*std::sin(0.572159826755524*x_56 + 4.83112001419067) + 0.00196280561482796*std::sin(0.19080001115799*x_57 - 7.40759992599487) - 0.0231817939097099*std::sin(0.193999990820885*x_57 - 1.18895995616913) + 0.000526529310916208*std::sin(0.210400000214577*x_57 - 4.38695955276489) + 8.60995776322156e-5*std::sin(0.409359842538834*x_57 - 8.01327991485596) + 0.000596212974161867*std::sin(0.503999829292297*x_57 + 1.79999983310699) + 0.00232105647366008*std::sin(0.0999200716614723*x_59 - 7.80351972579956) - 0.00730633360938866*std::sin(0.106240063905716*x_59 - 1.25135982036591) + 0.00724962867672861*std::sin(0.146480038762093*x_59 - 7.96208000183105) + 0.000384345137386625*std::sin(0.356559842824936*x_59 - 1.33015990257263) + 0.0020127675261452*std::sin(0.434719860553741*x_59 - 1.43583977222443) + 6.26922840403145e-6*std::sin(0.568239867687225*x_59 - 1.55663979053497) - 7.88096684341145e-5*std::sin(0.23735998570919*x_6 - 7.57872009277344) + 0.000411262315188929*std::sin(0.428959846496582*x_6 - 1.40255987644196) - 2.13926369848051e-6*std::sin(0.588399827480316*x_6 - 8.19416046142578) + 5.23050566811166e-5*std::sin(0.580399870872498*x_60 - 4.56799983978271) - 1.08276051397793e-5*std::sin(0.985839784145355*x_64 + 5.59231996536255) + 2.58233104707374e-6*std::sin(1.30951976776123*x_65 + 8.57479953765869) - 1.28799928165358e-5*std::sin(0.747679829597473*x_7 + 7.62128019332886) + 0.000381420684628022*std::sin(0.301279932260513*x_8 + 4.78895998001099) - 0.0107012355097054*std::sin(0.346559852361679*x_8 - 1.35543990135193) - 0.001451204892664*std::sin(0.225839987397194*x_9 + 4.99991989135742) + 0.00103238379859057*std::sin(0.20456001162529*x_91 + 7.79360008239746) + 7.90596185113842e-6*std::sin(0.287119954824448*x_92 + 1.81895983219147) - 0.00111951909763501*std::sin(0.339519828557968*x_92 + 1.80711996555328) - 5.50831199957069e-7*std::sin(0.255519956350327*x_93 - 4.41703987121582) + 0.00106469753226916*std::sin(0.289679944515228*x_93 + 1.5745598077774) - 8.70678694777262e-6*std::sin(0.19080001115799*x_94 + 4.79112005233765) + 0.000533936808186562*std::sin(0.290399938821793*x_94 - 1.39271986484528) + 0.00759697344850392*std::sin(0.26199996471405*x_95 - 7.79631996154785) - 0.00162397291520148*std::sin(0.422399878501892*x_96 + 4.39903974533081) - 0.00103651311875739*std::sin(0.279439955949783*x_97 + 8.17615985870361) - 0.000690249107985051*std::sin(0.330079853534698*x_97 - 1.55287981033325) - 1.32267521045484e-5*std::sin(0.244639977812767*x_98 - 7.41063976287842) + 0.00186626015648552*std::sin(0.277279943227768*x_98 + 8.17543983459473) - 0.00105827173060139*std::sin(0.306719928979874*x_98 + 4.77415990829468) + 0.000245579103302857*std::sin(0.36287984251976*x_98 - 1.97687971591949) + 0.0202842075377703*std::sin(-0.000783442864969172*x_1 + 0.00184873051832646*x_10 - 0.0273156028275194*x_100 - 0.000798673548411117*x_102 - 0.000244530883719966*x_103 - 0.000532776403276773*x_104 - 0.0265771271103288*x_106 - 0.000559674353857598*x_107 + 4.29400174598726e-5*x_108 - 0.000217580534121356*x_109 - 0.0311164460664576*x_11 + 9.97294751674393e-5*x_110 - 0.000700268384022887*x_111 - 0.00530676904515388*x_113 + 0.0179229739910497*x_115 + 0.0263944406638008*x_116 + 0.0522472643905299*x_119 - 0.0325893368361814*x_12 - 0.000104359894404908*x_120 - 0.000200570557817448*x_13 + 0.00147862965016434*x_14 + 0.000378644309119014*x_15 - 0.00341842071565642*x_16 - 0.0110046898111862*x_17 + 0.00183391247372511*x_18 + 0.00137806061715149*x_19 + 0.00179292350844073*x_2 - 0.000914041183025948*x_21 + 0.0013327379676531*x_22 + 0.00073382299732703*x_23 + 0.00104426895553019*x_24 + 6.31162785188238e-6*x_25 - 0.000707507370834385*x_26 + 0.00151723886895235*x_27 - 0.000418727235158872*x_28 + 0.000162600505827526*x_3 - 0.00511345146155743*x_30 + 0.000261313329521496*x_31 + 0.0367955435596341*x_33 - 0.00437482605302493*x_34 - 0.00163008853429558*x_35 + 0.0278441683499276*x_36 + 0.0299926220712489*x_37 + 0.0394839503978135*x_39 + 0.00643743133087292*x_4 - 0.000633220279709385*x_41 - 0.000639264351644065*x_44 + 0.0220174395005243*x_45 + 0.0106516629929379*x_46 + 0.0225905596468991*x_47 - 0.0544423201326357*x_48 - 0.00114196229537742*x_51 - 0.00297776220694805*x_53 - 0.00151987746882511*x_54 - 0.00264153349871624*x_55 - 0.00171689391250654*x_56 + 0.0111823953306309*x_57 + 0.0678695188694502*x_58 - 0.00298898969878446*x_6 - 0.00221732294948192*x_60 - 0.00049489037382975*x_61 - 5.78815655106493e-5*x_62 + 0.000200843511067015*x_63 - 1.30236715661875e-5*x_64 - 0.000410824727064852*x_65 - 0.000457561033827845*x_66 + 8.77969744383537e-5*x_67 + 0.00053082668564574*x_68 + 0.00025060619357148*x_69 + 0.00155341852933194*x_7 + 2.08259037910608e-6*x_70 + 0.00114025064139631*x_71 + 0.000212883174851485*x_72 + 5.37737342804936e-5*x_73 + 0.000854833818084901*x_74 + 0.000163014372051765*x_75 + 0.000423430842787913*x_76 + 0.000463459311228031*x_77 - 0.00320636833259232*x_78 + 0.00160047818612906*x_79 - 0.000264567862586761*x_8 + 0.000495246763710753*x_80 + 0.000413321474779519*x_81 + 7.74656366147751e-5*x_82 + 0.00222384065655249*x_83 + 0.000540231679668712*x_84 - 0.000742542703290883*x_85 - 0.0002981203364279*x_86 - 0.000187895966879581*x_87 + 0.000108153227710904*x_88 + 0.000489081596277395*x_89 + 0.000904689134458618*x_9 + 7.95114826135225e-5*x_90 - 0.000968126473926716*x_91 - 0.00148022646327539*x_92 + 0.00478185112127892*x_93 - 0.00378279111979369*x_94 - 0.000717738370183238*x_96 - 7.32146122411646e-5*x_97 - 0.00270617681227717*x_98 - 0.0318235464902781*x_99 + 0.000138679631531361*std::pow(-5.76231956481934*x_5 - 1.65471994876862, 2) + 0.000376919657753903*std::pow(-2.19055986404419*x_52 - 3.38007998466492, 2) - 0.123579682147897*std::sin(0.295599937438965*x_101 - 1.60279989242554) + 0.210754492615468*std::sin(0.265759944915771*x_105 - 4.62527990341187) - 0.266225819491636*std::sin(0.273279964923859*x_112 + 4.96903991699219) + 0.176882053502533*std::sin(0.25503996014595*x_114 + 8.14727973937988) + 0.170131529626913*std::sin(0.252879977226257*x_117 - 1.39735984802246) + 0.0642333490884779*std::sin(0.359679847955704*x_118 - 8.16823959350586) + 0.226799017411265*std::sin(0.274879962205887*x_20 - 7.58160018920898) + 0.105946422154227*std::sin(0.213119998574257*x_29 - 1.81263983249664) + 0.280249737009028*std::sin(0.250159978866577*x_32 + 5.01207971572876) - 0.0902635122540696*std::sin(0.277759939432144*x_38 - 1.41191983222961) + 0.234261781639921*std::sin(0.236719980835915*x_40 + 8.16784000396729) + 0.0866462074803005*std::sin(0.307519912719727*x_42 + 1.74847984313965) + 0.195085791930534*std::sin(0.46383985877037*x_43 + 4.89663982391357) + 0.228860683726044*std::sin(0.288879930973053*x_49 + 1.89487981796265) - 0.0115701653833649*std::sin(0.626239836215973*x_50 + 4.7673602104187) - 0.283227471154103*std::sin(0.350399851799011*x_59 + 8.05471992492676) - 0.00622191056855159*std::sin(0.249279975891113*x_95 + 5.17112016677856) + 4.52078878600155) - 0.0396762043237686*std::sin(0.000369234169323695*x_1 - 3.47807841173682e-5*x_100 + 0.00261780210528544*x_101 + 0.000630487599159074*x_102 + 0.000139030770053582*x_103 + 0.00760751879096344*x_104 - 0.000405475775682461*x_105 - 0.000122506159458459*x_106 + 0.00224333204308382*x_107 + 0.0049158418978805*x_108 - 0.000280782274777777*x_109 + 0.00808174635618239*x_110 - 0.0226626485377968*x_111 + 8.76630786669486e-5*x_113 - 0.00911940671187279*x_114 + 0.000177194922238027*x_115 - 0.00858412158644575*x_116 + 4.89658963026814e-5*x_117 - 0.000134800102001527*x_118 + 0.00161596613138659*x_12 + 0.00396792048834056*x_120 + 0.00114851814827557*x_13 + 0.00132482761607707*x_14 + 0.00372355668924055*x_15 - 0.00777194037881438*x_16 + 0.000602102860114591*x_17 + 0.00233511517925461*x_18 + 0.00433447788845954*x_19 - 5.08405740587328e-5*x_2 + 0.00160786447255429*x_20 + 0.000209156122170355*x_21 + 0.00318720441133638*x_22 + 0.00160056281950964*x_24 - 0.00806485532645646*x_25 + 0.00221809362250807*x_26 + 0.000630133585463687*x_27 + 0.00103461543734541*x_3 + 0.000758283504536953*x_30 + 5.14822503649589e-5*x_31 + 0.000179598405108819*x_32 + 0.0023909424658548*x_33 - 0.000370545602405065*x_34 + 0.000479836400637496*x_35 + 0.0060735246471189*x_36 - 0.00789129144854743*x_37 - 0.00746315171490494*x_38 - 0.0246597974734395*x_39 - 0.00135499111305963*x_40 - 0.0339116754287142*x_41 + 0.000147240102858842*x_42 - 0.000383294833299772*x_44 + 0.000311675425136681*x_45 + 0.0024033316539386*x_46 + 0.000230750211101345*x_47 - 0.00257144463288518*x_50 + 0.00157492531707066*x_51 - 0.000225037754682579*x_52 + 0.00127564186792853*x_53 - 0.0164241259548866*x_54 + 0.00153855270905038*x_55 + 0.00160179789271603*x_56 - 0.0140518758000181*x_58 + 0.000234095058886005*x_6 + 3.99683140953365e-5*x_60 - 3.61945873998611e-5*x_61 + 5.73767659884484e-6*x_62 + 0.00023702706408767*x_63 + 0.00169076410978212*x_64 + 0.000114097973412341*x_65 - 0.000111512637013032*x_66 + 9.68975551304138e-5*x_67 - 0.000593278444937864*x_68 - 0.000432948878444537*x_69 - 0.0011799393529436*x_7 - 0.000141943558667755*x_70 - 0.000946909785218051*x_71 + 5.43172270166266e-5*x_72 - 0.00100733506374676*x_73 + 0.000888281337759294*x_74 + 0.00023948488290522*x_75 - 7.68271521809491e-5*x_76 + 0.000336570109399715*x_77 + 0.000862907875711829*x_78 - 0.00038904434632439*x_79 + 0.00167250565315108*x_8 - 0.000497623308742781*x_80 + 0.00132542237396024*x_81 + 0.000231574173039694*x_82 - 0.00182593854532059*x_83 - 7.16985706911867e-5*x_84 - 0.000432414568599302*x_85 - 4.83070372073524e-5*x_86 - 0.000122619932980496*x_87 - 4.27982841748254e-5*x_88 - 0.000216292030995854*x_89 + 0.00166076903503562*x_9 - 0.000182513852931992*x_90 - 0.000214310548793719*x_91 - 0.000164397667664799*x_92 + 0.00726752679334173*x_93 - 0.000387387120260191*x_94 + 0.000772111446929262*x_96 - 4.75846555552753e-5*x_97 + 0.000930960107157826*x_98 - 0.000323295932881376*x_99 + 6.42788676234542e-6*std::pow(1.38503980636597 - 7.12336015701294*x_10, 2) + 0.0130936458848395*std::sin(0.491999864578247*x_11 - 7.40000009536743) - 0.0130259047369249*std::sin(0.219359993934631*x_112 + 4.78791999816895) + 0.0652451925891171*std::sin(0.349839836359024*x_119 - 4.97839975357056) - 0.00466043724534174*std::sin(0.398959845304489*x_23 + 2.00783967971802) + 0.00297490231396275*std::sin(0.532399833202362*x_28 - 7.56040000915527) - 0.0381316351846537*std::sin(0.704639852046967*x_29 - 1.58823990821838) - 0.00756628502531609*std::sin(1.04535984992981*x_4 + 3.9663200378418) - 0.269370342370401*std::sin(0.249279975891113*x_43 - 1.22215986251831) + 0.166972302077358*std::sin(0.218559995293617*x_48 - 4.41095972061157) + 0.053413106079226*std::sin(0.211199998855591*x_49 + 1.38191986083984) - 0.0116695835582205*std::sin(0.647999823093414*x_5 + 9.99600028991699) + 0.0883498894856589*std::sin(0.522399842739105*x_57 + 1.65279984474182) - 0.0667995958425931*std::sin(0.561039865016937*x_59 - 4.54360008239746) + 0.0883168827466703*std::sin(0.306639939546585*x_95 - 4.60048007965088) + 6.06524085087422) + 0.0031420555187295);
}

inline float score_5(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-1.32700036385085e-6*x_1 - 0.000581513198887148*x_10 - 0.000208908703184841*x_100 + 0.000359410387842079*x_101 - 7.66196950189553e-5*x_102 + 0.000328803140276751*x_103 - 0.000112358238242226*x_104 - 0.000104331375186069*x_105 + 0.000240135351887998*x_106 - 6.07164236849065e-6*x_107 - 5.63620023093128e-5*x_108 - 4.48947413564574e-5*x_109 + 4.97251833937549e-5*x_11 - 0.000307394406723662*x_110 - 0.000210655481973452*x_111 + 3.3582036394664e-5*x_112 + 1.9864205485881e-5*x_113 - 0.000136021574546755*x_114 + 0.000771337956176518*x_115 - 0.000430420698810225*x_116 - 0.000256349156427776*x_117 + 0.000135510926174383*x_118 - 0.000171058590232046*x_119 - 8.85612257540323e-5*x_12 - 5.353632714634e-5*x_120 - 3.91018298769746e-6*x_13 - 0.00021996143049957*x_14 + 7.1605508884121e-6*x_15 + 2.70013051074843e-5*x_16 + 5.0652248511411e-6*x_17 - 0.000133639465705472*x_18 + 2.99986204603053e-5*x_19 - 6.54422148114426e-6*x_2 + 0.000208603084264567*x_20 + 6.42987806718983e-6*x_21 - 0.00027264441466856*x_22 - 0.000148585950785692*x_23 - 0.000341201079993901*x_24 - 4.38840096589671e-5*x_25 + 3.73632494549346e-5*x_26 - 0.000156309224245651*x_27 - 0.000258763534431776*x_28 - 0.000271585438547818*x_29 + 0.000268570969937419*x_3 + 0.000383019923171236*x_30 - 4.68234550418284e-5*x_31 + 5.03408263878263e-5*x_32 - 4.59659641006925e-5*x_33 - 0.000351735727718724*x_34 - 3.96429729871569e-5*x_35 - 0.000249611357925347*x_36 - 0.000657237431625921*x_37 + 0.000237748518688599*x_38 - 0.0012076978257476*x_39 - 3.30006108514841e-5*x_4 - 0.00030178590593193*x_40 + 0.000249592084041572*x_41 - 4.86811381553443e-5*x_42 - 0.000347242810392206*x_43 - 4.85887419943653e-5*x_44 - 0.000658035034141638*x_45 - 0.000280005670949896*x_46 + 0.00117737859966162*x_47 + 9.52437251906038e-5*x_48 - 0.000255398097862012*x_49 + 3.37133360122298e-5*x_5 + 0.000690904096167092*x_50 + 0.000691198858684695*x_51 - 0.000723151372955497*x_52 + 5.96716423006575e-5*x_53 + 0.000281910810204937*x_54 - 0.00041813689325618*x_55 + 6.44247352903504e-5*x_56 - 0.000171767966748896*x_57 - 0.000529162769119984*x_58 + 1.99405898801897e-5*x_59 + 1.9937003887647e-5*x_6 - 1.67523233201291e-5*x_60 + 1.71739497903217e-5*x_61 - 1.17029282108363e-5*x_62 + 3.35685029295518e-6*x_63 - 4.18607233918072e-6*x_64 + 1.73495151714957e-5*x_65 + 2.42024434009266e-5*x_66 + 7.49982169924093e-7*x_67 + 2.46836737198296e-5*x_68 - 1.58129467738303e-5*x_69 - 0.000470960557824654*x_7 - 2.19437104659959e-6*x_70 + 2.99370594293428e-5*x_71 + 2.8552455561314e-5*x_72 + 2.37457160745696e-5*x_73 + 5.03747669691527e-5*x_74 + 7.52861335852364e-6*x_75 - 2.53273806502342e-5*x_76 - 1.43107730990111e-5*x_77 + 8.43470786053202e-6*x_78 - 1.92204364118426e-5*x_79 + 4.30596050688315e-5*x_8 + 1.65554736907794e-6*x_80 + 7.88079701098327e-6*x_81 - 9.92724881273821e-6*x_82 + 4.29775313589024e-5*x_83 + 1.87908253960423e-5*x_84 + 9.22767814043429e-6*x_85 - 2.52902542949874e-5*x_86 + 4.97717642534499e-6*x_87 + 4.96628103384599e-5*x_88 + 4.75936087355969e-5*x_89 + 0.000460824871346221*x_9 - 6.26596528020614e-5*x_90 - 2.17981686242743e-5*x_91 - 0.000120085723181205*x_92 - 0.000265520766708468*x_93 - 9.99525112778356e-6*x_94 + 1.66897584702294e-5*x_95 + 0.00024339441218283*x_96 + 6.28969998302425e-6*x_97 - 2.9768232985062e-5*x_98 + 0.000263289723618013*x_99 - 2.15002480231486e-7*std::pow(0.814879834651947 - 5.53343963623047*x_19, 2) + 4.05474319639533e-8*std::pow(0.817359864711761 - 6.45175981521606*x_23, 2) - 1.04838668222782e-9*std::pow(1.38503980636597 - 7.12336015701294*x_10, 2) + 4.93161624545677e-8*std::pow(2.25367975234985 - 5.73983955383301*x_4, 2) + 9.64256231188171e-7*std::pow(2.6431999206543 - 7.30952024459839*x_59, 2) + 5.21150932546307e-9*std::pow(5.20296001434326 - 9.00399971008301*x_15, 2) + 3.93649541661457e-8*std::pow(7.96920013427734 - 7.90776014328003*x_27, 2) - 3.67287070320746e-7*std::pow(-8.08119964599609*x_14 - 7.46519994735718, 2) + 1.91805282497124e-7*std::pow(-6.89904022216797*x_22 - 1.4171998500824, 2) - 8.5125925160446e-8*std::pow(-4.69047975540161*x_26 - 6.72648000717163, 2) - 1.57400582262178e-6*std::pow(-2.57999992370605*x_28 - 7.52744007110596, 2) - 1.31731358549832e-6*std::pow(-4.49319982528687*x_42 - 6.96000003814697, 2) - 9.73066042187748e-7*std::pow(-3.42927980422974*x_42 - 6.80200004577637, 2) - 3.06016364509192e-7*std::pow(-8.52272033691406*x_57 - 2.62191987037659, 2) + 2.0694867505584e-6*std::pow(-6.33992004394531*x_60 - 9.99560070037842, 2) + 2.37510323863195e-7*std::pow(-5.4445595741272*x_9 - 8.69223976135254, 2) - 5.40946586943221e-7*std::exp(0.629279851913452*x_1) + 7.71338705745611e-6*std::exp(0.49567985534668*x_13) + 1.74578741119733e-5*std::exp(0.526799857616425*x_14) + 0.000485676385295639*std::exp(0.362639844417572*x_16) + 1.01613642160518e-6*std::exp(0.359759837388992*x_19) + 2.10173933846875e-5*std::exp(0.451119869947433*x_2) - 9.66305610603701e-5*std::exp(0.299999833106995*x_24) + 0.000110406069301027*std::exp(0.411119878292084*x_26) - 4.11069302238779e-6*std::exp(0.428639858961105*x_27) - 1.36139267167869e-6*std::exp(0.789199888706207*x_3) + 1.65793397429367e-5*std::exp(0.5655198097229*x_30) - 0.000292704844523551*std::exp(0.292399853467941*x_59) - 0.00058341900074818*std::exp(0.325199842453003*x_60) - 0.0319759947208505*std::exp(0.00183592399976939*x_1 - 0.00433232451205643*x_10 + 0.0640115227817983*x_100 + 0.00187161566091568*x_102 + 0.0005730349182821*x_103 + 0.00124851093681877*x_104 + 0.0622809750251468*x_106 + 0.0013115437311986*x_107 - 0.000100625855604925*x_108 + 0.000509879331777128*x_109 + 0.0729184381852623*x_11 - 0.00023370656002019*x_110 + 0.00164101249752008*x_111 + 0.0124359096072879*x_113 - 0.0420007885306423*x_115 - 0.0618528666759481*x_116 - 0.122436505463158*x_119 + 0.0763700179163269*x_12 + 0.000244557508043564*x_120 + 0.000470018066676345*x_13 - 0.0034650282527165*x_14 - 0.000887317002389257*x_15 + 0.00801074451476361*x_16 + 0.0257884461493811*x_17 - 0.00429759983087072*x_18 - 0.00322935426856557*x_19 - 0.00420154608087037*x_2 + 0.00214196876342856*x_21 - 0.00312314494090706*x_22 - 0.00171964454922749*x_23 - 0.00244714518875277*x_24 - 1.47907008526266e-5*x_25 + 0.00165797637608162*x_26 - 0.00355550529265742*x_27 + 0.000981247535409623*x_28 - 0.000381038853465269*x_3 + 0.0119828881973398*x_30 - 0.000612362987244819*x_31 - 0.0862268641738802*x_33 + 0.0102519896532352*x_34 + 0.00381995777315544*x_35 - 0.0652501659189441*x_36 - 0.0702848633113606*x_37 - 0.0925268904502722*x_39 - 0.0150855093659983*x_4 + 0.00148389162840214*x_41 + 0.00149805533735576*x_44 - 0.0515957798582717*x_45 - 0.0249611613055659*x_46 - 0.0529388325281334*x_47 + 0.127580410268421*x_48 + 0.00267608025889372*x_51 + 0.00697810312122418*x_53 + 0.00356168860103739*x_54 + 0.00619018305397265*x_55 + 0.00402337793854662*x_56 - 0.0262048821686853*x_57 - 0.159045776171729*x_58 + 0.00700441368277417*x_6 + 0.00519608589243262*x_60 + 0.00115972862246264*x_61 + 0.00013563995540301*x_62 - 0.000470657706711506*x_63 + 3.05197382765349e-5*x_64 + 0.000962728757695368*x_65 + 0.00107225085698737*x_66 - 0.00020574387704055*x_67 - 0.00124394195859248*x_68 - 0.000587271830329118*x_69 - 0.00364028889305054*x_7 - 4.88035290083361e-6*x_70 - 0.0026720691602371*x_71 - 0.000498871516140904*x_72 - 0.000126013642777467*x_73 - 0.00200322192288818*x_74 - 0.00038200870968293*x_75 - 0.000992269993482548*x_76 - 0.00108607291028634*x_77 + 0.0075138198803284*x_78 - 0.00375056873245931*x_79 + 0.000619989676604991*x_8 - 0.00116056378832484*x_80 - 0.000968579649005619*x_81 - 0.000181533367368246*x_82 - 0.00521135952037587*x_83 - 0.00126598166948466*x_84 + 0.00174007835259182*x_85 + 0.000698616714683901*x_86 + 0.00044031636572205*x_87 - 0.000253446824631923*x_88 - 0.0011461163035629*x_89 - 0.00212005312518677*x_9 - 0.000186327613301012*x_90 + 0.0022687125095767*x_91 + 0.00346877023269334*x_92 - 0.0112058142711219*x_93 + 0.00886461197552299*x_94 + 0.00168195175206124*x_96 + 0.000171571495201061*x_97 + 0.00634166852419363*x_98 + 0.0745754609196391*x_99 - 0.000324982554812878*std::pow(-5.76231956481934*x_5 - 1.65471994876862, 2) - 0.000883275445596771*std::pow(-2.19055986404419*x_52 - 3.38007998466492, 2) + 0.289597256525049*std::sin(0.295599937438965*x_101 - 1.60279989242554) - 0.493883151347845*std::sin(0.265759944915771*x_105 - 4.62527990341187) + 0.623874941259693*std::sin(0.273279964923859*x_112 + 4.96903991699219) - 0.414506305021455*std::sin(0.25503996014595*x_114 + 8.14727973937988) - 0.398687092991544*std::sin(0.252879977226257*x_117 - 1.39735984802246) - 0.150524757388329*std::sin(0.359679847955704*x_118 - 8.16823959350586) - 0.531481972467567*std::sin(0.274879962205887*x_20 - 7.58160018920898) - 0.248275385251354*std::sin(0.213119998574257*x_29 - 1.81263983249664) - 0.656738660992438*std::sin(0.250159978866577*x_32 + 5.01207971572876) + 0.211523974319743*std::sin(0.277759939432144*x_38 - 1.41191983222961) - 0.548970252168154*std::sin(0.236719980835915*x_40 + 8.16784000396729) - 0.2030471638903*std::sin(0.307519912719727*x_42 + 1.74847984313965) - 0.457165038363556*std::sin(0.46383985877037*x_43 + 4.89663982391357) - 0.536313291809492*std::sin(0.288879930973053*x_49 + 1.89487981796265) + 0.0271135844851385*std::sin(0.626239836215973*x_50 + 4.7673602104187) + 0.663716698353326*std::sin(0.350399851799011*x_59 + 8.05471992492676) + 0.0145804569139476*std::sin(0.249279975891113*x_95 + 5.17112016677856)) + 0.000140250858688422*std::log(4.99583959579468*x_24 + 9.18455982208252) - 5.97106551429917e-6*std::sin(0.278239965438843*x_10 - 1.21111989021301) + 2.28429882618724e-5*std::sin(0.324959933757782*x_10 + 4.96639966964722) - 0.000167019195497422*std::sin(0.254079967737198*x_100 + 1.78135991096497) + 0.00128783198537018*std::sin(0.262799948453903*x_102 + 1.76351988315582) - 0.000916866909005112*std::sin(0.247759968042374*x_104 + 4.57936000823975) - 0.000389688986157957*std::sin(0.222719997167587*x_105 + 1.78591990470886) + 8.7185882562529e-5*std::sin(0.284959942102432*x_107 - 7.83568000793457) - 0.000114886924398243*std::sin(0.256959974765778*x_109 + 7.99103975296021) - 0.000700349838663745*std::sin(0.259119987487793*x_109 - 7.63520002365112) - 0.00133485348736485*std::sin(0.271839946508408*x_109 + 1.74463987350464) - 4.21944998198372e-6*std::sin(1.23983979225159*x_109 - 5.41856002807617) + 0.00249488206541932*std::sin(0.130800053477287*x_11 + 4.94279956817627) - 0.00378471389791585*std::sin(0.259599983692169*x_11 + 1.96687984466553) + 6.55232134879969e-5*std::sin(0.277599930763245*x_11 + 7.97864007949829) - 2.1355702853832e-6*std::sin(0.491999864578247*x_11 - 7.40000009536743) - 0.00346289712466326*std::sin(0.219919994473457*x_110 + 1.97583973407745) + 0.00328190413895234*std::sin(0.226159989833832*x_111 + 8.16951942443848) - 1.1505148660999e-5*std::sin(0.314239919185638*x_111 - 2.16447973251343) + 2.12452172153349e-6*std::sin(0.219359993934631*x_112 + 4.78791999816895) - 0.00556807089203267*std::sin(0.243999972939491*x_112 + 1.78271985054016) + 0.00239547742031471*std::sin(0.222879990935326*x_115 + 4.98295974731445) + 0.00339217576126876*std::sin(0.266079962253571*x_115 + 1.5596798658371) - 3.58580288392545e-5*std::sin(0.327519834041595*x_116 + 1.41927993297577) + 4.27460018438599e-5*std::sin(0.298719942569733*x_117 + 7.94647979736328) - 0.00198343763106413*std::sin(0.2882399559021*x_119 - 1.63407981395721) - 0.000101742363673963*std::sin(0.31687992811203*x_119 + 4.7346396446228) - 0.000697569408284404*std::sin(0.323039829730988*x_119 - 8.13776016235352) - 1.06414741763218e-5*std::sin(0.349839836359024*x_119 - 4.97839975357056) - 0.000526883135800659*std::sin(0.334239840507507*x_120 + 4.82775974273682) - 4.26054832533039e-5*std::sin(0.373439848423004*x_120 + 4.61023998260498) + 0.000547350425149806*std::sin(0.429599851369858*x_13 - 1.23991990089417) - 0.000179773035057272*std::sin(0.467999845743179*x_13 - 10.0) - 0.000259958123254646*std::sin(0.470319837331772*x_13 + 1.72207987308502) + 0.00449751912775196*std::sin(0.148880034685135*x_15 - 1.42711985111237) - 0.000322836328097498*std::sin(0.338799834251404*x_15 + 1.84023988246918) - 9.44058336453277e-5*std::sin(0.589119851589203*x_16 - 4.59656000137329) - 1.96979562786776e-5*std::sin(0.797439873218536*x_16 + 7.98800039291382) + 0.00103522483421448*std::sin(0.239039987325668*x_17 - 4.38751983642578) - 0.000781793615711675*std::sin(0.420719861984253*x_17 - 1.38295984268188) - 8.77262081696174e-6*std::sin(0.189040005207062*x_20 + 1.59415984153748) - 0.00051818320240842*std::sin(0.194240003824234*x_20 + 7.61240005493164) - 0.00175612802661271*std::sin(0.192159995436668*x_21 - 1.5998398065567) - 0.000952615355342707*std::sin(0.35471984744072*x_21 - 1.15311980247498) - 6.93228577974373e-5*std::sin(1.03207981586456*x_21 + 3.58415985107422) - 0.000347000048494518*std::sin(0.359679847955704*x_22 - 1.39007985591888) + 0.000553195030048026*std::sin(0.501279830932617*x_22 - 7.46343994140625) + 7.60116119343708e-7*std::sin(0.398959845304489*x_23 + 2.00783967971802) + 0.000442957081166786*std::sin(0.550239861011505*x_23 + 8.02112007141113) + 8.10452749780943e-5*std::sin(0.284879922866821*x_24 - 4.38207960128784) + 5.4810739567652e-5*std::sin(0.54671984910965*x_24 + 8.00600051879883) - 0.000419566932217067*std::sin(0.255519956350327*x_26 + 7.79239988327026) - 7.07294681630705e-7*std::sin(0.547199845314026*x_26 - 4.34791994094849) + 0.000319935358847492*std::sin(0.378799855709076*x_27 - 1.19023990631104) + 0.000103355609678909*std::sin(0.430399864912033*x_27 - 7.43319988250732) - 0.000178233128632956*std::sin(0.422399878501892*x_28 + 1.96871984004974) - 4.85205804364429e-7*std::sin(0.532399833202362*x_28 - 7.56040000915527) - 0.00142019825805747*std::sin(0.250159978866577*x_29 + 2.00159978866577) + 1.31470228719008e-5*std::sin(0.349919855594635*x_29 + 4.61783981323242) - 0.000754793245936378*std::sin(0.397999823093414*x_29 - 4.60591983795166) + 6.21925991810316e-6*std::sin(0.704639852046967*x_29 - 1.58823990821838) + 0.00182708454076082*std::sin(0.186480015516281*x_30 + 4.79576015472412) - 5.44242072032145e-7*std::sin(0.536159813404083*x_31 - 7.41943979263306) - 0.000288134061634383*std::sin(0.215360000729561*x_32 - 4.59135961532593) - 0.00280709962277016*std::sin(0.219119995832443*x_33 - 4.39343976974487) - 0.00754624445902972*std::sin(0.235119983553886*x_33 + 8.20096015930176) - 0.00857704298023727*std::sin(0.217759996652603*x_34 + 8.19967937469482) - 0.00189170910109849*std::sin(0.231279984116554*x_35 - 1.20599985122681) + 0.00295221435950173*std::sin(0.249599978327751*x_35 + 8.18247985839844) + 0.00020854070254419*std::sin(0.256719976663589*x_35 - 1.22463989257813) - 0.000100004468291512*std::sin(0.240879982709885*x_36 - 1.20711994171143) + 0.00161287357316983*std::sin(0.258319973945618*x_37 - 7.43327951431274) + 1.82180893389962e-5*std::sin(0.289519935846329*x_38 + 1.55455982685089) + 0.00018670072680749*std::sin(0.538479864597321*x_4 - 4.58392000198364) + 6.92536310481287e-5*std::sin(0.726399838924408*x_4 + 5.0065598487854) + 1.23405914692666e-6*std::sin(1.04535984992981*x_4 + 3.9663200378418) + 0.00833282878560912*std::sin(0.226799994707108*x_40 - 1.39975988864899) - 0.000127306477014949*std::sin(0.213839992880821*x_41 + 1.59519982337952) + 0.00133234792596761*std::sin(0.218319997191429*x_41 + 1.57967984676361) + 0.00235991955620144*std::sin(0.350719839334488*x_41 + 1.61295986175537) + 4.39342337488896e-5*std::sin(0.249279975891113*x_43 - 1.22215986251831) + 6.28959433128067e-5*std::sin(0.457919865846634*x_43 + 4.92479991912842) - 8.09899232339892e-5*std::sin(0.489919871091843*x_43 + 7.90343999862671) - 0.00176310501666097*std::sin(0.279279947280884*x_44 + 1.93007981777191) - 0.000193677046704201*std::sin(0.292959928512573*x_44 - 7.64568042755127) - 0.000843061650379892*std::sin(0.29751992225647*x_44 - 4.45015954971313) - 5.34335086986759e-5*std::sin(0.340239852666855*x_44 + 8.0444803237915) + 9.1550732047685e-5*std::sin(0.557119846343994*x_44 + 7.60111999511719) - 0.00144350282344588*std::sin(0.169520020484924*x_45 - 7.79071998596191) - 0.00023713223223945*std::sin(0.58927983045578*x_45 - 7.79103994369507) - 0.000146266732596542*std::sin(0.268879950046539*x_46 - 1.40031981468201) + 7.90771212096975e-5*std::sin(0.189680010080338*x_47 + 2.01359987258911) - 2.15019293987758e-5*std::sin(0.607679843902588*x_47 - 4.6101598739624) - 1.3859100454073e-5*std::sin(0.661439836025238*x_47 + 7.74631977081299) - 2.72331396415188e-5*std::sin(0.218559995293617*x_48 - 4.41095972061157) - 8.71166390141103e-6*std::sin(0.211199998855591*x_49 + 1.38191986083984) + 8.62792817612039e-5*std::sin(0.37407985329628*x_49 - 4.56288003921509) + 1.90330608517426e-6*std::sin(0.647999823093414*x_5 + 9.99600028991699) + 0.000142133839643836*std::sin(0.575759828090668*x_50 - 4.5734395980835) - 0.000842482133807504*std::sin(0.211119994521141*x_51 - 1.40071988105774) - 0.00148812903095079*std::sin(0.213199988007545*x_52 - 1.20551991462708) + 0.000865596491924016*std::sin(0.213359996676445*x_53 + 1.97695982456207) - 0.000482594133550493*std::sin(0.247039973735809*x_53 + 8.1988000869751) - 0.00292327124169253*std::sin(0.269999951124191*x_53 - 4.61583995819092) - 0.000210264250728078*std::sin(0.210720002651215*x_54 + 1.98495984077454) + 0.000214218067362387*std::sin(0.446799844503403*x_55 + 1.52711987495422) - 0.00198789448081416*std::sin(0.495999842882156*x_55 - 1.39999985694885) + 0.00244402580039599*std::sin(0.184000000357628*x_56 + 1.57647979259491) - 0.000674782805706391*std::sin(0.572159826755524*x_56 + 4.83112001419067) - 0.00193852551016616*std::sin(0.19080001115799*x_57 - 7.40759992599487) + 0.0096571070657628*std::sin(0.193999990820885*x_57 - 1.18895995616913) + 0.000194699378979538*std::sin(0.210400000214577*x_57 - 4.38695955276489) - 0.00186303135931071*std::sin(0.234479993581772*x_57 + 1.76807987689972) + 7.66818230224888e-6*std::sin(0.409359842538834*x_57 - 8.01327991485596) - 0.00144582097098899*std::sin(0.503999829292297*x_57 + 1.79999983310699) - 1.44098443139449e-5*std::sin(0.522399842739105*x_57 + 1.65279984474182) - 0.000359495002168989*std::sin(0.156560033559799*x_58 - 1.73479986190796) + 0.000206717438845843*std::sin(0.0999200716614723*x_59 - 7.80351972579956) + 0.00721595352111609*std::sin(0.106240063905716*x_59 - 1.25135982036591) - 0.00302006137190565*std::sin(0.146480038762093*x_59 - 7.96208000183105) + 0.000204046269518553*std::sin(0.356559842824936*x_59 - 1.33015990257263) - 0.0022095579793636*std::sin(0.434719860553741*x_59 - 1.43583977222443) + 1.08949969482695e-5*std::sin(0.561039865016937*x_59 - 4.54360008239746) - 0.000153240423104258*std::sin(0.568239867687225*x_59 - 1.55663979053497) - 2.91421449548652e-5*std::sin(0.23735998570919*x_6 - 7.57872009277344) + 0.000376055508676501*std::sin(0.428959846496582*x_6 - 1.40255987644196) + 5.22905935403353e-5*std::sin(0.588399827480316*x_6 - 8.19416046142578) + 0.000551023025695161*std::sin(0.580399870872498*x_60 - 4.56799983978271) - 9.64325870020623e-7*std::sin(0.985839784145355*x_64 + 5.59231996536255) - 2.55038734993903e-6*std::sin(1.30951976776123*x_65 + 8.57479953765869) + 1.27254092789532e-6*std::sin(0.747679829597473*x_7 + 7.62128019332886) + 0.000202493697057682*std::sin(0.301279932260513*x_8 + 4.78895998001099) + 0.00445793701107323*std::sin(0.346559852361679*x_8 - 1.35543990135193) + 0.00143325334085805*std::sin(0.225839987397194*x_9 + 4.99991989135742) - 0.00113332107673171*std::sin(0.20456001162529*x_91 + 7.79360008239746) + 2.92345711955537e-6*std::sin(0.287119954824448*x_92 + 1.81895983219147) + 0.00110567053277656*std::sin(0.339519828557968*x_92 + 1.80711996555328) + 9.68718944663211e-6*std::sin(0.43767985701561*x_92 + 4.59567975997925) - 0.00106568491742142*std::sin(0.254879981279373*x_93 - 7.62007999420166) + 1.34641140345385e-5*std::sin(0.255519956350327*x_93 - 4.41703987121582) + 9.48238655602841e-5*std::sin(0.289679944515228*x_93 + 1.5745598077774) - 9.17242116243968e-5*std::sin(0.19080001115799*x_94 + 4.79112005233765) + 0.000283463489638265*std::sin(0.290399938821793*x_94 - 1.39271986484528) - 0.000538384987934682*std::sin(0.331199824810028*x_94 + 1.63039982318878) - 0.00316475878673178*std::sin(0.26199996471405*x_95 - 7.79631996154785) + 0.00100987231913516*std::sin(0.291839927434921*x_95 + 7.97679996490479) - 5.32075677147601e-5*std::sin(0.296879917383194*x_95 - 4.83536005020142) - 1.44044609232818e-5*std::sin(0.306639939546585*x_95 - 4.60048007965088) + 0.000676517114037096*std::sin(0.422399878501892*x_96 + 4.39903974533081) + 0.00102369134628199*std::sin(0.279439955949783*x_97 + 8.17615985870361) + 0.00167385930662469*std::sin(0.330079853534698*x_97 - 1.55287981033325) - 4.89097257698858e-6*std::sin(0.244639977812767*x_98 - 7.41063976287842) - 0.00184317432894187*std::sin(0.277279943227768*x_98 + 8.17543983459473) + 0.00256631694950821*std::sin(0.306719928979874*x_98 + 4.77415990829468) + 0.000479635764853676*std::sin(0.328239858150482*x_98 + 7.83935976028442) - 0.00026958963726278*std::sin(0.36287984251976*x_98 - 1.97687971591949) + 0.162094132878387);
}

inline float score_6(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-8.43282732811245e-5*x_1 - 4.16486872540048e-5*x_10 + 8.66523782261627e-7*x_100 + 0.000100644833977638*x_101 - 0.000515174834867313*x_102 - 0.000254821892263468*x_103 + 0.000102426438609883*x_104 + 0.000517718101355454*x_105 - 0.000628997357651742*x_106 - 0.000161636646606458*x_107 - 0.000600363619353839*x_108 + 3.94879634559573e-5*x_109 - 7.01968707522139e-5*x_11 + 0.000136813673469794*x_110 - 4.85994265160356e-5*x_111 + 0.000154157094635737*x_112 - 5.82040777235533e-5*x_113 - 0.000141778147187367*x_114 - 0.000278816490489361*x_115 + 0.000292127415961108*x_116 + 2.88647222683277e-5*x_117 - 0.000873835321435979*x_118 + 0.000175571759428717*x_119 - 0.000354824557039323*x_12 + 0.000181191286014346*x_120 - 1.56685863363437e-5*x_13 + 0.000206530807577116*x_14 - 1.32491670624273e-5*x_15 - 3.55018507811744e-5*x_16 - 0.000160294495314261*x_17 - 0.000686793581788344*x_18 - 0.000192213403071391*x_19 + 7.77999388337841e-6*x_2 + 0.000579111621249969*x_20 - 3.84178832328953e-5*x_21 - 5.74498593464219e-5*x_22 - 0.000303278753505478*x_23 - 4.41287582915131e-5*x_24 - 0.000155898257408351*x_25 - 0.000214776333398053*x_26 - 0.000143624380443545*x_27 - 3.53644303175189e-5*x_28 - 0.000237452454314001*x_29 - 6.5864817560947e-6*x_3 - 0.000237001700997566*x_30 + 1.73663195767607e-5*x_31 + 0.000371054474993753*x_32 - 0.00106351187315215*x_33 + 0.000389351953039204*x_34 - 0.000162835084455154*x_35 + 0.000319170336100491*x_36 - 4.05281998282299e-5*x_37 - 6.87239867039297e-5*x_38 - 0.00052115249877065*x_39 - 6.29301658087242e-5*x_4 - 0.000145416934027599*x_40 + 0.000445820697233644*x_41 - 0.000541173309952649*x_42 - 0.000112202381274266*x_43 - 1.15178345187299e-5*x_44 - 5.26816047159039e-5*x_45 + 0.00013968528051864*x_46 + 9.20476657233109e-5*x_47 - 0.00151121123695926*x_48 + 0.000136667724043214*x_49 - 0.000102998881742639*x_5 - 0.000337278128566513*x_50 - 0.000181498864873392*x_51 - 0.000102862421566875*x_52 - 0.000108733526010778*x_53 + 0.000121718730405738*x_54 + 0.000133030766318628*x_55 + 0.000689185996191183*x_56 + 7.1214324316971e-5*x_57 + 0.00104924410290141*x_58 + 0.000146212905723174*x_59 - 1.29545938870533e-5*x_6 + 4.87759850652887e-5*x_60 + 6.59304687478075e-5*x_61 + 7.54861171974004e-6*x_62 + 1.17955313547531e-5*x_63 + 2.58924842904986e-5*x_64 - 1.22170054027772e-5*x_65 + 1.6881206896628e-6*x_66 - 3.39435448825691e-5*x_67 + 2.94466480985011e-6*x_68 + 4.76924817256306e-5*x_69 - 0.000167008338816612*x_7 + 6.50616927976701e-6*x_70 + 4.03917735335609e-5*x_71 + 2.88379500578852e-6*x_72 - 4.04801882788371e-5*x_73 - 1.71425162401257e-5*x_74 + 6.91538009639583e-6*x_75 - 1.2281140671825e-6*x_76 + 2.51215446588205e-5*x_77 - 2.31093459332207e-5*x_78 - 2.95262991770663e-5*x_79 + 7.96845309597743e-6*x_8 + 3.76530831714292e-5*x_80 + 2.28360389920222e-5*x_81 + 1.44321724811963e-6*x_82 + 6.67770734629664e-5*x_83 - 2.06437673012169e-5*x_84 + 1.22065820949817e-5*x_85 + 7.78976650799131e-6*x_86 - 3.65593452673988e-5*x_87 - 2.71629750908236e-6*x_88 - 4.08812051649967e-5*x_89 - 1.616921452886e-5*x_9 + 3.28363800252409e-5*x_90 - 1.87182911277821e-6*x_91 - 4.12655177042612e-5*x_92 + 3.08170418426572e-5*x_93 + 0.000106522446338712*x_94 + 2.25954030206535e-5*x_95 - 0.000440193997931519*x_96 + 0.00011800447241006*x_97 + 0.000154902831606163*x_98 + 0.000170810408565325*x_99 + 6.59630716518723e-7*std::pow(0.814879834651947 - 5.53343963623047*x_19, 2) - 9.98494834776814e-8*std::pow(0.817359864711761 - 6.45175981521606*x_23, 2) - 1.21442792050743e-7*std::pow(2.25367975234985 - 5.73983955383301*x_4, 2) + 7.87131654163861e-7*std::pow(2.6431999206543 - 7.30952024459839*x_59, 2) + 1.57004962694827e-8*std::pow(5.20296001434326 - 9.00399971008301*x_15, 2) + 4.48804211077504e-9*std::pow(7.96920013427734 - 7.90776014328003*x_27, 2) - 2.99819975089329e-7*std::pow(-8.08119964599609*x_14 - 7.46519994735718, 2) - 2.71419529731637e-6*std::pow(-6.89904022216797*x_22 - 1.4171998500824, 2) + 2.70387687177848e-7*std::pow(-4.69047975540161*x_26 - 6.72648000717163, 2) + 1.82851725946471e-6*std::pow(-2.57999992370605*x_28 - 7.52744007110596, 2) + 7.25402786432799e-7*std::pow(-4.49319982528687*x_42 - 6.96000003814697, 2) + 4.7784457809972e-8*std::pow(-6.33992004394531*x_60 - 9.99560070037842, 2) - 3.36095750701359e-6*std::pow(-5.4445595741272*x_9 - 8.69223976135254, 2) + 1.33210007833081e-6*std::exp(0.629279851913452*x_1) - 0.000109150481181572*std::exp(0.49567985534668*x_13) + 5.91941133076527e-5*std::exp(0.526799857616425*x_14) + 1.12142697875196e-5*std::exp(0.362639844417572*x_16) - 3.22758050942938e-6*std::exp(0.359759837388992*x_19) - 0.000297412613166284*std::exp(0.451119869947433*x_2) - 6.07971186145185e-5*std::exp(0.411119878292084*x_26) + 1.30569010195969e-5*std::exp(0.428639858961105*x_27) + 4.17677239125747e-6*std::exp(0.789199888706207*x_3) - 9.12971624914417e-6*std::exp(0.5655198097229*x_30) + 0.000161183268856551*std::exp(0.292399853467941*x_59) + 0.000226743308605609*std::exp(0.325199842453003*x_60) - 5.45078985994778e-5*std::log(4.99583959579468*x_24 + 9.18455982208252) + 1.47039597463089e-5*std::sin(0.278239965438843*x_10 - 1.21111989021301) - 7.25567769479976e-5*std::sin(0.324959933757782*x_10 + 4.96639966964722) + 0.000411290668570605*std::sin(0.254079967737198*x_100 + 1.78135991096497) + 0.00436662974966342*std::sin(0.262799948453903*x_102 + 1.76351988315582) - 0.000748447293769641*std::sin(0.247759968042374*x_104 + 4.57936000823975) + 0.00551440502511587*std::sin(0.222719997167587*x_105 + 1.78591990470886) - 0.0002146983154976*std::sin(0.284959942102432*x_107 - 7.83568000793457) + 0.00162574015618954*std::sin(0.256959974765778*x_109 + 7.99103975296021) - 0.00237466414518509*std::sin(0.259119987487793*x_109 - 7.63520002365112) + 0.00155069479758194*std::sin(0.271839946508408*x_109 + 1.74463987350464) + 1.29453335232885e-5*std::sin(1.23983979225159*x_109 - 5.41856002807617) - 0.00289829608720855*std::sin(0.130800053477287*x_11 + 4.94279956817627) - 8.73890598859726e-5*std::sin(0.259599983692169*x_11 + 1.96687984466553) - 0.00020812308492492*std::sin(0.277599930763245*x_11 + 7.97864007949829) - 0.00282679629518883*std::sin(0.219919994473457*x_110 + 1.97583973407745) - 0.00127549805892196*std::sin(0.226159989833832*x_111 + 8.16951942443848) + 2.83318349767738e-5*std::sin(0.314239919185638*x_111 - 2.16447973251343) - 0.000128566780411364*std::sin(0.243999972939491*x_112 + 1.78271985054016) - 0.00278281804600156*std::sin(0.222879990935326*x_115 + 4.98295974731445) - 0.00131835465505145*std::sin(0.266079962253571*x_115 + 1.5596798658371) + 0.000113896788391178*std::sin(0.327519834041595*x_116 + 1.41927993297577) - 4.96578862805068e-5*std::sin(0.298719942569733*x_117 + 7.94647979736328) - 4.57975832774582e-5*std::sin(0.2882399559021*x_119 - 1.63407981395721) + 0.000250544164416501*std::sin(0.31687992811203*x_119 + 4.7346396446228) - 0.000569432630536829*std::sin(0.323039829730988*x_119 - 8.13776016235352) - 0.00178649358108759*std::sin(0.334239840507507*x_120 + 4.82775974273682) + 0.000135328903107278*std::sin(0.373439848423004*x_120 + 4.61023998260498) + 0.00185589166684896*std::sin(0.429599851369858*x_13 - 1.23991990089417) + 6.9868024035357e-5*std::sin(0.467999845743179*x_13 - 10.0) + 0.0036713682070779*std::sin(0.148880034685135*x_15 - 1.42711985111237) + 0.00456838744020646*std::sin(0.338799834251404*x_15 + 1.84023988246918) - 7.70643918042401e-5*std::sin(0.589119851589203*x_16 - 4.59656000137329) + 0.000278741542476193*std::sin(0.797439873218536*x_16 + 7.98800039291382) - 0.00120261720101814*std::sin(0.239039987325668*x_17 - 4.38751983642578) + 0.00043050893386034*std::sin(0.420719861984253*x_17 - 1.38295984268188) + 2.78647033640545e-5*std::sin(0.189040005207062*x_20 + 1.59415984153748) + 0.000601971679869806*std::sin(0.194240003824234*x_20 + 7.61240005493164) - 4.05490035507315e-5*std::sin(0.192159995436668*x_21 - 1.5998398065567) + 0.0011066500478212*std::sin(0.35471984744072*x_21 - 1.15311980247498) + 2.69420332879621e-5*std::sin(1.03207981586456*x_21 + 3.58415985107422) - 0.000642644802042751*std::sin(0.501279830932617*x_22 - 7.46343994140625) - 0.00114685425422813*std::sin(0.284879922866821*x_24 - 4.38207960128784) - 0.000134973382277948*std::sin(0.54671984910965*x_24 + 8.00600051879883) - 2.13083711778279e-6*std::sin(0.547199845314026*x_26 - 4.34791994094849) - 0.00452733644831763*std::sin(0.378799855709076*x_27 - 1.19023990631104) + 8.43701802304432e-5*std::sin(0.430399864912033*x_27 - 7.43319988250732) + 6.92695459653172e-5*std::sin(0.422399878501892*x_28 + 1.96871984004974) + 0.00055195400131794*std::sin(0.250159978866577*x_29 + 2.00159978866577) - 4.17592302334151e-5*std::sin(0.349919855594635*x_29 + 4.61783981323242) + 0.00087684077001899*std::sin(0.397999823093414*x_29 - 4.60591983795166) + 0.00619506410888145*std::sin(0.186480015516281*x_30 + 4.79576015472412) + 1.72869022973072e-6*std::sin(0.536159813404083*x_31 - 7.41943979263306) + 0.00407732313157973*std::sin(0.215360000729561*x_32 - 4.59135961532593) + 0.00326099817135522*std::sin(0.219119995832443*x_33 - 4.39343976974487) - 0.000174242816427283*std::sin(0.235119983553886*x_33 + 8.20096015930176) - 0.000198043958635095*std::sin(0.217759996652603*x_34 + 8.19967937469482) + 0.00219759208735547*std::sin(0.231279984116554*x_35 - 1.20599985122681) + 0.00240992103248066*std::sin(0.249599978327751*x_35 + 8.18247985839844) - 0.00295101462678944*std::sin(0.256719976663589*x_35 - 1.22463989257813) + 0.000317646790185567*std::sin(0.240879982709885*x_36 - 1.20711994171143) + 0.00131660424122123*std::sin(0.258319973945618*x_37 - 7.43327951431274) - 5.78665903705145e-5*std::sin(0.289519935846329*x_38 + 1.55455982685089) + 0.000633042941332934*std::sin(0.538479864597321*x_4 - 4.58392000198364) - 2.69151286068288e-5*std::sin(0.726399838924408*x_4 + 5.0065598487854) + 0.000192405051849798*std::sin(0.226799994707108*x_40 - 1.39975988864899) + 0.000313496696525848*std::sin(0.213839992880821*x_41 + 1.59519982337952) - 0.000733681720612683*std::sin(0.218319997191429*x_41 + 1.57967984676361) + 5.44905525187866e-5*std::sin(0.350719839334488*x_41 + 1.61295986175537) - 0.000199778018425823*std::sin(0.457919865846634*x_43 + 4.92479991912842) + 0.000248478254930424*std::sin(0.489919871091843*x_43 + 7.90343999862671) + 0.00204819315588266*std::sin(0.279279947280884*x_44 + 1.93007981777191) + 0.00059420397826654*std::sin(0.292959928512573*x_44 - 7.64568042755127) - 0.00285855462915142*std::sin(0.29751992225647*x_44 - 4.45015954971313) + 0.000131581902614846*std::sin(0.340239852666855*x_44 + 8.0444803237915) - 3.55808018990413e-5*std::sin(0.557119846343994*x_44 + 7.60111999511719) + 0.000275475715015457*std::sin(0.58927983045578*x_45 - 7.79103994369507) + 0.000464590821929957*std::sin(0.268879950046539*x_46 - 1.40031981468201) - 0.000194730204238574*std::sin(0.189680010080338*x_47 + 2.01359987258911) + 0.000304269178083044*std::sin(0.607679843902588*x_47 - 4.6101598739624) + 4.40210207534222e-5*std::sin(0.661439836025238*x_47 + 7.74631977081299) - 0.000212465779000264*std::sin(0.37407985329628*x_49 - 4.56288003921509) + 0.000481930764007437*std::sin(0.575759828090668*x_50 - 4.5734395980835) + 0.000978708655531983*std::sin(0.211119994521141*x_51 - 1.40071988105774) + 0.00172875448000032*std::sin(0.213199988007545*x_52 - 1.20551991462708) + 0.00682908578294687*std::sin(0.247039973735809*x_53 + 8.1988000869751) - 6.74983453158471e-5*std::sin(0.269999951124191*x_53 - 4.61583995819092) + 0.00297540418642254*std::sin(0.210720002651215*x_54 + 1.98495984077454) - 0.000248856406902517*std::sin(0.446799844503403*x_55 + 1.52711987495422) - 4.59004919570081e-5*std::sin(0.495999842882156*x_55 - 1.39999985694885) + 5.6432566052425e-5*std::sin(0.184000000357628*x_56 + 1.57647979259491) - 0.000550831707255363*std::sin(0.572159826755524*x_56 + 4.83112001419067) + 0.00225197855198988*std::sin(0.19080001115799*x_57 - 7.40759992599487) + 0.000222982642931061*std::sin(0.193999990820885*x_57 - 1.18895995616913) - 0.000618428694642863*std::sin(0.210400000214577*x_57 - 4.38695955276489) - 0.00631694836790658*std::sin(0.234479993581772*x_57 + 1.76807987689972) - 1.88831697842893e-5*std::sin(0.409359842538834*x_57 - 8.01327991485596) - 0.00118023759215643*std::sin(0.503999829292297*x_57 + 1.79999983310699) - 4.0986424156316e-5*std::sin(0.156560033559799*x_58 - 1.73479986190796) - 0.000509048995086449*std::sin(0.0999200716614723*x_59 - 7.80351972579956) - 0.00838274888645466*std::sin(0.106240063905716*x_59 - 1.25135982036591) - 6.97332298312192e-5*std::sin(0.146480038762093*x_59 - 7.96208000183105) - 0.00288741487174896*std::sin(0.356559842824936*x_59 - 1.33015990257263) + 0.000858735293424344*std::sin(0.434719860553741*x_59 - 1.43583977222443) + 0.000470143832680732*std::sin(0.568239867687225*x_59 - 1.55663979053497) + 9.25649519684622e-5*std::sin(0.23735998570919*x_6 - 7.57872009277344) - 0.00020708183446248*std::sin(0.428959846496582*x_6 - 1.40255987644196) - 0.000160428296673898*std::sin(0.588399827480316*x_6 - 8.19416046142578) + 2.3746865180346e-6*std::sin(0.985839784145355*x_64 + 5.59231996536255) + 2.96277638917257e-6*std::sin(1.30951976776123*x_65 + 8.57479953765869) + 3.83373085289631e-6*std::sin(0.747679829597473*x_7 + 7.62128019332886) - 0.00286544475279719*std::sin(0.301279932260513*x_8 + 4.78895998001099) + 0.000102933784411842*std::sin(0.346559852361679*x_8 - 1.35543990135193) - 0.00166500557576027*std::sin(0.225839987397194*x_9 + 4.99991989135742) + 0.00044046040722204*std::sin(0.20456001162529*x_91 + 7.79360008239746) - 9.28585278374728e-6*std::sin(0.287119954824448*x_92 + 1.81895983219147) - 0.00128445373162339*std::sin(0.339519828557968*x_92 + 1.80711996555328) + 1.10444721942369e-6*std::sin(0.43767985701561*x_92 + 4.59567975997925) - 0.00361339950944175*std::sin(0.254879981279373*x_93 - 7.62007999420166) - 4.13080964383769e-5*std::sin(0.255519956350327*x_93 - 4.41703987121582) - 0.000233507118427836*std::sin(0.289679944515228*x_93 + 1.5745598077774) - 0.00401123087185362*std::sin(0.290399938821793*x_94 - 1.39271986484528) - 0.00182549271317563*std::sin(0.331199824810028*x_94 + 1.63039982318878) - 7.30742937506212e-5*std::sin(0.26199996471405*x_95 - 7.79631996154785) + 0.00342415669294752*std::sin(0.291839927434921*x_95 + 7.97679996490479) - 6.06625384365686e-6*std::sin(0.296879917383194*x_95 - 4.83536005020142) + 1.56207830200928e-5*std::sin(0.422399878501892*x_96 + 4.39903974533081) - 0.00118921878695684*std::sin(0.279439955949783*x_97 + 8.17615985870361) + 0.00136638748316676*std::sin(0.330079853534698*x_97 - 1.55287981033325) + 1.5535323236131e-5*std::sin(0.244639977812767*x_98 - 7.41063976287842) + 0.0021412094061118*std::sin(0.277279943227768*x_98 + 8.17543983459473) + 0.00209490925776651*std::sin(0.306719928979874*x_98 + 4.77415990829468) + 0.00162629273352814*std::sin(0.328239858150482*x_98 + 7.83935976028442) + 0.000104774863760622*std::sin(0.36287984251976*x_98 - 1.97687971591949) + 0.0341402888298035*std::sin(-0.000711207269911854*x_1 + 0.00167827246061323*x_10 - 0.0247970288346694*x_100 - 0.000725033642292007*x_102 - 0.000221984461146957*x_103 - 0.000483652948020454*x_104 - 0.024126642617367*x_106 - 0.000508070833298617*x_107 + 3.89808293024726e-5*x_108 - 0.000197519008185111*x_109 - 0.0282474238337158*x_11 + 9.05341422266543e-5*x_110 - 0.000635701705734598*x_111 - 0.00481747028841107*x_113 + 0.0162704263078294*x_115 + 0.0239608003655644*x_116 + 0.0474299223709361*x_119 - 0.0295845100081554*x_12 - 9.47376240268969e-5*x_120 - 0.00018207739865709*x_13 + 0.00134229591425979*x_14 + 0.000343732258467617*x_15 - 0.00310323288819255*x_16 - 0.0099900270291548*x_17 + 0.00166482068063337*x_18 + 0.00125099962373889*x_19 + 0.0016276110111094*x_2 - 0.00082976406249161*x_21 + 0.00120985584764976*x_22 + 0.000666162491055461*x_23 + 0.000947984474841768*x_24 + 5.72967833897309e-6*x_25 - 0.000642273237976884*x_26 + 0.00137734525648429*x_27 - 0.000380119428066778*x_28 + 0.000147608290287298*x_3 - 0.00464197711972799*x_30 + 0.000237219519113079*x_31 + 0.0334028928593278*x_33 - 0.00397145501303856*x_34 - 0.00147978987113067*x_35 + 0.0252768591566627*x_36 + 0.0272272195134872*x_37 + 0.0358434211649486*x_39 + 0.00584388238988598*x_4 - 0.000574835621743333*x_41 - 0.000580322413559331*x_44 + 0.0199873707934445*x_45 + 0.00966955025817562*x_46 + 0.0205076476800695*x_47 - 0.0494225879135712*x_48 - 0.00103667021904604*x_51 - 0.00270320431054478*x_53 - 0.00137974057016421*x_54 - 0.00239797681746276*x_55 - 0.00155859155382072*x_56 + 0.0101513476091023*x_57 + 0.0616117618574165*x_58 - 0.00271339659663733*x_6 - 0.00201287965201647*x_60 - 0.000449260115083138*x_61 - 5.25447253727594e-5*x_62 + 0.000182325184863486*x_63 - 1.18228530923966e-5*x_64 - 0.000372945553036051*x_65 - 0.000415372643287207*x_66 + 7.97018510077048e-5*x_67 + 0.000481882999737729*x_68 + 0.000227499610657616*x_69 + 0.00141018905229308*x_7 + 1.8905697965952e-6*x_70 + 0.00103511638428747*x_71 + 0.00019325475840826*x_72 + 4.88156475228098e-5*x_73 + 0.000776015780056165*x_74 + 0.000147983996903071*x_75 + 0.000384389350086834*x_76 + 0.000420727083227296*x_77 - 0.00291073232027525*x_78 + 0.00145290967881252*x_79 - 0.000240173975244703*x_8 + 0.000449583644833201*x_80 + 0.000375212093718474*x_81 + 7.03230910539289e-5*x_82 + 0.00201879640850124*x_83 + 0.000490420827346738*x_84 - 0.000674078216056326*x_85 - 0.000270632818366957*x_86 - 0.000170571439995351*x_87 + 9.81812015295512e-5*x_88 + 0.00044398692285782*x_89 + 0.000821274298621061*x_9 + 7.21803044034773e-5*x_90 - 0.000878862540254168*x_91 - 0.00134374549679356*x_92 + 0.00434095124629611*x_93 - 0.00343400733512474*x_94 - 0.000651560910940316*x_96 - 6.64640228636745e-5*x_97 - 0.00245665983904792*x_98 - 0.028889327646317*x_99 + 0.00012589298664132*std::pow(-5.76231956481934*x_5 - 1.65471994876862, 2) + 0.000342166624719739*std::pow(-2.19055986404419*x_52 - 3.38007998466492, 2) - 0.112185294278529*std::sin(0.295599937438965*x_101 - 1.60279989242554) + 0.19132234655121*std::sin(0.265759944915771*x_105 - 4.62527990341187) - 0.241679063945707*std::sin(0.273279964923859*x_112 + 4.96903991699219) + 0.160573039838571*std::sin(0.25503996014595*x_114 + 8.14727973937988) + 0.15444493290094*std::sin(0.252879977226257*x_117 - 1.39735984802246) + 0.0583108569688857*std::sin(0.359679847955704*x_118 - 8.16823959350586) + 0.205887521865559*std::sin(0.274879962205887*x_20 - 7.58160018920898) + 0.0961778695376871*std::sin(0.213119998574257*x_29 - 1.81263983249664) + 0.254409937551156*std::sin(0.250159978866577*x_32 + 5.01207971572876) - 0.0819409672272631*std::sin(0.277759939432144*x_38 - 1.41191983222961) + 0.212662198629342*std::sin(0.236719980835915*x_40 + 8.16784000396729) + 0.0786571879401894*std::sin(0.307519912719727*x_42 + 1.74847984313965) + 0.177098343327138*std::sin(0.46383985877037*x_43 + 4.89663982391357) + 0.207759096854325*std::sin(0.288879930973053*x_49 + 1.89487981796265) - 0.0105033641924295*std::sin(0.626239836215973*x_50 + 4.7673602104187) - 0.25711311638721*std::sin(0.350399851799011*x_59 + 8.05471992492676) - 0.00564823323685437*std::sin(0.249279975891113*x_95 + 5.17112016677856) - 4.85453698771976) - 0.0115211997181177*std::sin(-0.000127808641638822*x_1 + 0.00218754780839914*x_10 + 0.000947321467166854*x_100 + 0.00270206755366905*x_101 + 0.0047801164134507*x_102 + 0.00349407179071751*x_103 - 0.00145123062652211*x_104 + 0.000869618489177357*x_105 - 2.63383416620852e-5*x_106 - 0.00390027477889768*x_107 + 0.00796604529383716*x_108 + 0.00460410314740098*x_109 + 0.00124576999206917*x_11 + 0.00151209736320723*x_110 - 1.97402785799171e-5*x_111 + 0.000954200671727547*x_112 + 5.80648454383633e-5*x_113 + 0.0010940372372893*x_114 + 0.0131032054460288*x_115 + 0.00353648969138476*x_116 - 0.001138102721303*x_117 - 0.000905542001881281*x_118 - 3.23151942916229e-5*x_119 - 0.00197699052667537*x_12 + 0.000790194151070241*x_120 + 0.00367746641214278*x_14 - 0.00102895217836498*x_15 - 0.000603691743889482*x_16 - 0.000885697047501561*x_17 + 0.00784396043275134*x_18 - 0.00874115015363767*x_19 + 0.00124402581148194*x_2 + 0.00199151676233005*x_20 - 0.000643386467046958*x_21 - 0.00102070866098403*x_25 - 0.000970599769513069*x_27 - 0.0275546950933807*x_28 - 0.00418656815854562*x_29 + 0.00210089381300843*x_3 - 0.0180281888684568*x_30 - 0.000519849002877875*x_31 + 7.26783354641111e-5*x_32 + 0.00792880121852093*x_33 + 0.000334305137571293*x_34 - 0.000492488385647962*x_35 + 0.0124847827072281*x_36 + 0.0174916823121402*x_37 + 0.00236136791581991*x_38 + 0.000209916020310162*x_39 + 0.000530160135045019*x_4 + 0.00280698993975831*x_40 - 0.00581140974051835*x_41 + 0.000481027811634342*x_43 - 0.000593567868473676*x_44 + 0.0410658078919888*x_46 + 0.00426406613672415*x_47 + 0.000928266134142795*x_48 + 0.00249088540547074*x_49 + 0.00660401690695217*x_5 + 0.00289815887168697*x_50 + 0.000183496012918328*x_51 - 0.000552995508905493*x_52 + 0.0016929450268225*x_54 + 0.00267921750456029*x_55 - 0.000215103794789133*x_56 + 0.0131610239296036*x_58 + 0.00509465230639118*x_59 + 0.000960841625113662*x_6 - 0.000551860068587691*x_61 - 0.00106690819884322*x_62 - 0.00204569667503914*x_63 - 0.000590626136424442*x_64 + 0.000758029570652642*x_65 - 1.39661801381587e-5*x_66 + 0.000262403367782309*x_67 - 0.000310759073272505*x_68 + 0.000318615238122565*x_69 + 0.000782051336084943*x_7 + 0.000702064395353583*x_70 + 8.90787261003532e-5*x_71 - 0.000667310081098205*x_72 - 0.00101578902343512*x_73 - 0.0030824658664028*x_74 + 0.000240420863827956*x_75 - 0.00036236791054468*x_76 - 0.00304152461645046*x_77 + 3.22519694080259e-5*x_78 + 0.0026513756125919*x_79 - 0.00106212082767705*x_8 - 0.00116467421733778*x_80 + 9.62433732568975e-5*x_81 + 7.5346899807296e-5*x_82 + 0.00225148989687345*x_83 + 0.000147639771153554*x_84 - 0.000739270937562658*x_85 - 0.000469895131514861*x_86 + 0.000413113531873284*x_87 + 0.000856370100138509*x_88 + 0.000233602473945588*x_89 + 0.0471707625839829*x_9 + 0.000187869665787376*x_90 + 0.00071324761107166*x_91 - 0.000119023694849887*x_92 + 0.000370176808149951*x_93 - 0.0021766100864641*x_95 - 0.000134225291074594*x_96 + 0.00127319459483644*x_97 + 0.000467609726476345*x_98 - 0.00050099031170414*x_99 + 0.000435107198831913*std::pow(-3.42927980422974*x_42 - 6.80200004577637, 2) + 0.000136835443213041*std::pow(-8.52272033691406*x_57 - 2.62191987037659, 2) + 0.0432084266860291*std::exp(0.299999833106995*x_24) + 0.116240466647696*std::sin(0.470319837331772*x_13 + 1.72207987308502) + 0.155161327750719*std::sin(0.359679847955704*x_22 - 1.39007985591888) - 0.198068585720982*std::sin(0.550239861011505*x_23 + 8.02112007141113) + 0.18760966335751*std::sin(0.255519956350327*x_26 + 7.79239988327026) + 0.645463352727205*std::sin(0.169520020484924*x_45 - 7.79071998596191) - 0.38705211012504*std::sin(0.213359996676445*x_53 + 1.97695982456207) - 0.246390352563395*std::sin(0.580399870872498*x_60 - 4.56799983978271) + 0.0410145489151255*std::sin(0.19080001115799*x_94 + 4.79112005233765) + 0.843080343689474) + 0.00643830141052604*std::sin(0.000615487457528114*x_1 - 5.79771271614526e-5*x_100 + 0.00436369246390459*x_101 + 0.0010509785974581*x_102 + 0.000231754540310265*x_103 + 0.0126812001373649*x_104 - 0.000675899672885509*x_105 - 0.000204209173692479*x_106 + 0.00373947714026044*x_107 + 0.00819436358470977*x_108 - 0.000468044354449846*x_109 + 0.0134717042202914*x_110 - 0.0377770452689431*x_111 + 0.000146128202345505*x_113 - 0.0152014112386624*x_114 + 0.000295371504687489*x_115 - 0.0143091284862152*x_116 + 8.16227140519647e-5*x_117 - 0.000224702313459823*x_118 + 0.00269370217680677*x_12 + 0.00661424509415175*x_120 + 0.0019144991816489*x_13 + 0.00220839469590763*x_14 + 0.00620690778380623*x_15 - 0.0129552793897116*x_16 + 0.001003663228734*x_17 + 0.00389247318943212*x_18 + 0.00722527056519791*x_19 - 8.47476703577963e-5*x_2 + 0.0026801972798857*x_20 + 0.000348648582813623*x_21 + 0.00531284616304315*x_22 + 0.00266802593649017*x_24 - 0.0134435480586878*x_25 + 0.00369740646370132*x_26 + 0.00105038848146287*x_27 + 0.00172463135309888*x_3 + 0.00126400540650886*x_30 + 8.58172997450183e-5*x_31 + 0.000299377942022543*x_32 + 0.00398553335976573*x_33 - 0.000617673524474326*x_34 + 0.000799853618094876*x_35 + 0.0101241395132432*x_36 - 0.0131542292501695*x_37 - 0.0124405503493001*x_38 - 0.0411061524394824*x_39 - 0.00225867512933003*x_40 - 0.0565283839476946*x_41 + 0.000245438922190647*x_42 - 0.000638925597984194*x_44 + 0.000519541068863529*x_45 + 0.00400618526716775*x_46 + 0.000384644414180246*x_47 - 0.00428641780951027*x_50 + 0.00262529001846165*x_51 - 0.000375122150073794*x_52 + 0.00212640550425179*x_53 - 0.0273778657717687*x_54 + 0.00256465943252464*x_55 + 0.00267008471688163*x_56 - 0.0234234911831031*x_58 + 0.000390220040787528*x_6 + 6.66243757160453e-5*x_60 - 6.03338380514017e-5*x_61 + 9.56430437738185e-6*x_62 + 0.000395107487770935*x_63 + 0.00281838515951996*x_64 + 0.000190193317409656*x_65 - 0.00018588374300006*x_66 + 0.00016152142678763*x_67 - 0.000988953547690002*x_68 - 0.000721695407880486*x_69 - 0.00196687612555152*x_7 - 0.000236609954590416*x_70 - 0.00157843218378151*x_71 + 9.05430069423846e-5*x_72 - 0.00167915688409888*x_73 + 0.00148070267480539*x_74 + 0.000399204499317427*x_75 - 0.000128065473061686*x_76 + 0.000561038761103349*x_77 + 0.00143840689358642*x_78 - 0.000648509632852983*x_79 + 0.0027879495931941*x_8 - 0.000829503146108658*x_80 + 0.00220938611557507*x_81 + 0.000386017900928407*x_82 - 0.0030437114607254*x_83 - 0.000119516487501544*x_84 - 0.000720804750851701*x_85 - 8.05244421607253e-5*x_86 - 0.000204398826172208*x_87 - 7.13417373088134e-5*x_88 - 0.00036054364222322*x_89 + 0.00276838547414982*x_9 - 0.000304237789017549*x_90 - 0.000357240650398377*x_91 - 0.000274039379074514*x_92 + 0.0121144573286498*x_93 - 0.00064574715326267*x_94 + 0.00128705561641082*x_96 - 7.9320282623659e-5*x_97 + 0.00155184518936639*x_98 - 0.000538911640065183*x_99 + 1.07148362999045e-5*std::pow(1.38503980636597 - 7.12336015701294*x_10, 2) + 0.0218261891368139*std::sin(0.491999864578247*x_11 - 7.40000009536743) - 0.0217132693954575*std::sin(0.219359993934631*x_112 + 4.78791999816895) + 0.108759158926603*std::sin(0.349839836359024*x_119 - 4.97839975357056) - 0.00776862194622635*std::sin(0.398959845304489*x_23 + 2.00783967971802) + 0.00495895346026398*std::sin(0.532399833202362*x_28 - 7.56040000915527) - 0.0635627608197256*std::sin(0.704639852046967*x_29 - 1.58823990821838) - 0.0126124663426863*std::sin(1.04535984992981*x_4 + 3.9663200378418) - 0.449021463703403*std::sin(0.249279975891113*x_43 - 1.22215986251831) + 0.278331114022969*std::sin(0.218559995293617*x_48 - 4.41095972061157) + 0.0890359007661661*std::sin(0.211199998855591*x_49 + 1.38191986083984) - 0.019452377140005*std::sin(0.647999823093414*x_5 + 9.99600028991699) + 0.147273067798735*std::sin(0.522399842739105*x_57 + 1.65279984474182) - 0.111350240104728*std::sin(0.561039865016937*x_59 - 4.54360008239746) + 0.147218047880349*std::sin(0.306639939546585*x_95 - 4.60048007965088) - 8.76342089819606) + 0.00532937323289555);
}

inline float score_7(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.000118563064471791*x_1 + 0.000951488495900282*x_10 + 0.000327190318483369*x_100 + 0.000618058068314543*x_101 + 0.000345889163348143*x_102 + 3.01563471742275e-5*x_103 + 4.57854935883062e-5*x_104 - 0.00068027645354213*x_105 + 0.00055504753493636*x_106 + 0.000207937285641127*x_107 + 0.000402146644706938*x_108 - 0.000127855854893158*x_109 + 2.47805012887646e-5*x_11 + 0.00013019528312103*x_110 + 7.69481481656857e-5*x_111 - 0.00029094803548463*x_112 + 9.90620028925149e-5*x_113 + 0.000142327478660572*x_114 - 0.000618372339512218*x_115 + 0.000350882401601678*x_116 + 0.000236417297417375*x_117 + 0.00114949773701189*x_118 - 0.000159789936473353*x_119 + 0.0004513607861017*x_12 - 0.000257854092444389*x_120 + 2.6404089422736e-5*x_13 - 0.000196293432457251*x_14 + 1.0993180932814e-5*x_15 + 2.44917961886305e-5*x_16 + 0.000192704090879265*x_17 + 0.000548720978563061*x_18 + 0.000245217128779207*x_19 - 2.21769203545325e-5*x_2 - 0.000792547685975979*x_20 + 3.97348979715876e-5*x_21 + 0.000497050743153013*x_22 + 0.00100206986576994*x_23 + 0.000595341734668691*x_24 - 1.21999751922728e-6*x_25 + 0.000148687297179464*x_26 + 0.000471524789318235*x_27 + 0.000799180026807649*x_28 + 0.000283897609542405*x_29 - 0.000455450917816932*x_3 - 3.66346773374925e-5*x_30 - 1.53243423714767e-5*x_31 - 0.000476341104597001*x_32 + 0.000775823083055338*x_33 - 0.000364534982570572*x_34 + 0.000512945207460719*x_35 - 0.000659099369307843*x_36 - 0.000111768855831921*x_37 - 0.000856526017181044*x_38 + 0.000450587131756458*x_39 + 6.20276537682917e-5*x_4 + 8.27330683775149e-5*x_40 - 0.00085581163909696*x_41 + 0.0002751037331245*x_42 + 0.000341407606679833*x_43 + 6.37185894016115e-5*x_44 + 0.000764469383610206*x_45 + 0.000176153039833363*x_46 - 0.00150688986239553*x_47 + 0.000995801469908993*x_48 + 0.000126397343214342*x_49 + 5.46808321109168e-5*x_5 - 0.00146896225340105*x_50 - 0.00155154566409032*x_51 + 0.00110757819673076*x_52 - 0.000156392896554695*x_53 - 0.000836103602625313*x_54 + 6.53154573647323e-5*x_55 - 0.000920106791341829*x_56 - 5.89806929951641e-5*x_57 - 0.00143556005379279*x_58 - 0.000189275302738198*x_59 + 9.48792351632212e-6*x_6 + 3.68775974580892e-5*x_60 - 5.51731193463963e-5*x_61 - 7.56157760966178e-6*x_62 - 8.30380073861038e-6*x_63 - 1.76776277287622e-5*x_64 - 1.59137897391327e-5*x_65 - 3.69757627909408e-5*x_66 + 4.10457171437133e-5*x_67 - 1.00357229859977e-5*x_68 - 2.90606001979678e-5*x_69 + 0.000983643564786482*x_7 + 4.80755808345689e-6*x_70 - 6.56157105597286e-5*x_71 - 2.36484225170723e-5*x_72 + 2.6255670762116e-5*x_73 - 7.20885391908163e-6*x_74 - 1.74410630000435e-5*x_75 + 1.51064498184574e-5*x_76 + 1.62834549162033e-5*x_77 + 2.1466603658402e-5*x_78 + 1.84499820106027e-5*x_79 - 2.7023892444445e-5*x_8 - 3.88259674787157e-5*x_80 - 4.15929237993672e-5*x_81 - 2.16040127091716e-5*x_82 - 0.000131962255781288*x_83 - 2.49897361710362e-5*x_84 - 2.08863073842401e-5*x_85 + 5.39740510236408e-6*x_86 + 3.45548156845132e-5*x_87 - 5.71882447586234e-5*x_88 - 1.40949802054958e-6*x_89 - 0.000935875697841477*x_9 - 7.43373591375343e-6*x_90 + 3.09864027100061e-5*x_91 + 0.000147521848669603*x_92 + 0.000174063380760068*x_93 - 4.14043030201298e-5*x_94 - 1.25883636842573e-5*x_95 + 0.000402707137350436*x_96 - 0.000155256955792282*x_97 + 0.000101579904799534*x_98 + 0.000240166708654431*x_99 + 6.60685400012797e-7*std::pow(0.814879834651947 - 5.53343963623047*x_19, 2) + 6.44614986701983e-7*std::pow(0.817359864711761 - 6.45175981521606*x_23, 2) + 7.84018515231873e-7*std::pow(2.25367975234985 - 5.73983955383301*x_4, 2) - 3.02835139060978e-7*std::pow(2.6431999206543 - 7.30952024459839*x_59, 2) - 4.05590824213796e-8*std::pow(7.96920013427734 - 7.90776014328003*x_27, 2) + 1.15350492346652e-7*std::pow(-8.08119964599609*x_14 - 7.46519994735718, 2) + 1.73966759474498e-6*std::pow(-6.89904022216797*x_22 - 1.4171998500824, 2) - 2.86735244140423e-7*std::pow(-4.69047975540161*x_26 - 6.72648000717163, 2) - 1.60861485188253e-6*std::pow(-2.57999992370605*x_28 - 7.52744007110596, 2) - 7.57396538756424e-7*std::pow(-4.49319982528687*x_42 - 6.96000003814697, 2) - 4.95818926001255e-8*std::pow(-3.42927980422974*x_42 - 6.80200004577637, 2) - 1.55928476189164e-8*std::pow(-8.52272033691406*x_57 - 2.62191987037659, 2) - 3.32485898960226e-6*std::pow(-6.33992004394531*x_60 - 9.99560070037842, 2) + 2.15421081454512e-6*std::pow(-5.4445595741272*x_9 - 8.69223976135254, 2) + 0.000478068017400801*std::pow(-0.00297216243344256*x_1 - 0.00438081186298695*x_10 - 0.0029363525670535*x_100 - 0.00052393512027899*x_101 + 0.0059879594052782*x_102 - 0.0327470794555806*x_103 + 0.00461923898282585*x_104 + 0.00158132084486145*x_105 - 0.00299101259618527*x_106 - 0.00165967227689921*x_107 + 0.00169269799514426*x_108 + 0.00402691082179793*x_109 - 0.00558409353153474*x_11 - 0.00293290846862317*x_110 + 0.0181254619057779*x_112 - 0.00408472282786931*x_113 + 0.00578946221090608*x_114 - 0.00164825959628283*x_116 + 0.0166184865671682*x_117 - 0.00513650653933574*x_118 - 0.00496099378857575*x_119 - 0.00626408174877426*x_12 - 0.00453001186004842*x_120 - 0.00405821288213888*x_14 - 0.00450642862271784*x_15 - 0.00487198976338197*x_16 - 0.00213872136674166*x_17 - 0.00664405757382919*x_18 - 0.0165166399604284*x_19 - 0.00264714234822604*x_2 + 0.00286011750602066*x_20 - 0.013860595108805*x_22 + 0.00102907107631449*x_23 - 0.00274460136454602*x_25 - 0.0162309000842871*x_26 + 0.0141566649642585*x_27 - 0.00493489833685706*x_3 - 0.0281687931287516*x_30 + 0.0111444862070162*x_31 + 0.00925038859775781*x_32 + 0.00535228262462354*x_33 + 0.0560488515978889*x_34 + 0.00403087522215765*x_35 + 0.0361835599039406*x_36 + 0.12629518859047*x_37 + 0.0786855804210099*x_38 + 0.160667221334153*x_39 + 0.0199325635686892*x_40 + 0.0146401810767073*x_41 + 0.00989575572354267*x_42 + 0.0116618547259918*x_43 + 0.0071043039373278*x_45 + 0.0670836089778647*x_46 - 0.00051363061141459*x_47 + 0.000378302645240475*x_48 + 0.0176315304584738*x_49 - 0.00751231733287382*x_5 - 0.0273789539213809*x_50 + 0.0348407606835629*x_51 + 0.00837840038467034*x_52 - 0.00241134686154802*x_53 + 0.0503983072553737*x_54 + 0.0767718273332371*x_55 + 0.0128091503915237*x_56 + 0.0226543038594459*x_57 - 0.00446518424765941*x_58 - 0.00400185741822758*x_6 + 2.87347601019653e-5*x_61 + 0.000162074137857558*x_62 - 0.00168438279849427*x_63 + 0.000374282331725136*x_64 - 0.000161046867264483*x_65 + 0.000120564128542467*x_66 - 0.00199665936638887*x_67 - 0.000751037644416843*x_68 + 0.00306431742534495*x_69 - 0.00726651818293202*x_7 + 0.00144786607031154*x_70 - 0.00359644552736013*x_71 - 0.000387182223154225*x_72 - 0.000956652297516546*x_73 - 0.0067681044851311*x_74 + 2.98948017392737e-5*x_75 + 0.00162682765601658*x_76 + 0.001321231733799*x_77 - 0.00270574323102376*x_78 + 0.000822646121389628*x_79 - 0.00611928982991789*x_8 - 0.000533797437580953*x_80 - 0.00351671665750422*x_81 + 0.00204524862008215*x_82 + 0.0104360912031232*x_83 - 0.00435505362633024*x_84 + 0.000400582343864492*x_85 + 0.000421509723488793*x_86 - 0.0026435173636195*x_87 - 0.00705528594629882*x_88 - 0.0094846069477546*x_89 - 0.0027401014280039*x_9 + 0.00654458023239283*x_90 + 0.0151630336268657*x_92 + 0.00358493482956808*x_93 - 0.00199149110905077*x_94 - 0.000977113328203575*x_95 + 0.00213943386359811*x_96 - 0.00114527751030463*x_97 + 0.00774182396329531*x_99 + 0.12567368223947*std::exp(0.325199842453003*x_60) - 0.0302112921005626*std::log(4.99583959579468*x_24 + 9.18455982208252) - 0.706951568889892*std::sin(0.226159989833832*x_111 + 8.16951942443848) - 0.730705064756933*std::sin(0.266079962253571*x_115 + 1.5596798658371) + 0.0387247231475829*std::sin(0.467999845743179*x_13 - 10.0) + 0.0149327649452533*std::sin(1.03207981586456*x_21 + 3.58415985107422) + 0.0383930135008286*std::sin(0.422399878501892*x_28 + 1.96871984004974) + 0.305923434737775*std::sin(0.250159978866577*x_29 + 2.00159978866577) - 0.014917852882938*std::sin(0.726399838924408*x_4 + 5.0065598487854) - 0.0197208482983875*std::sin(0.557119846343994*x_44 + 7.60111999511719) + 0.475958594135818*std::sin(0.434719860553741*x_59 - 1.43583977222443) + 0.24412751845556*std::sin(0.20456001162529*x_91 + 7.79360008239746) + 0.0580720243340864*std::sin(0.36287984251976*x_98 - 1.97687971591949) - 7.55373767356164, 2) - 8.59986095442208e-6*std::exp(0.629279851913452*x_1) + 6.99601665547608e-5*std::exp(0.49567985534668*x_13) - 7.88040237424749e-5*std::exp(0.526799857616425*x_14) - 0.000780292744204339*std::exp(0.362639844417572*x_16) + 3.42271904099457e-6*std::exp(0.359759837388992*x_19) + 0.000190627065747767*std::exp(0.451119869947433*x_2) - 4.92374195857583e-6*std::exp(0.299999833106995*x_24) + 6.34785640008923e-5*std::exp(0.411119878292084*x_26) - 1.38463172663217e-5*std::exp(0.428639858961105*x_27) + 4.183450632263e-6*std::exp(0.789199888706207*x_3) + 9.53238065287009e-6*std::exp(0.5655198097229*x_30) - 0.000168292226361206*std::exp(0.292399853467941*x_59) - 9.49268086945291e-5*std::sin(0.278239965438843*x_10 - 1.21111989021301) + 7.69435375159743e-5*std::sin(0.324959933757782*x_10 + 4.96639966964722) - 0.00265523786019936*std::sin(0.254079967737198*x_100 + 1.78135991096497) - 0.00581321309229894*std::sin(0.262799948453903*x_102 + 1.76351988315582) + 0.000287952007887816*std::sin(0.247759968042374*x_104 + 4.57936000823975) - 0.00353446626923942*std::sin(0.222719997167587*x_105 + 1.78591990470886) + 0.0013860637728823*std::sin(0.284959942102432*x_107 - 7.83568000793457) - 0.00104202062025344*std::sin(0.256959974765778*x_109 + 7.99103975296021) + 0.00316134627619089*std::sin(0.259119987487793*x_109 - 7.63520002365112) - 0.00136420406710163*std::sin(0.271839946508408*x_109 + 1.74463987350464) + 1.29660318159095e-5*std::sin(1.23983979225159*x_109 - 5.41856002807617) + 0.00254973919819688*std::sin(0.130800053477287*x_11 + 4.94279956817627) + 0.00608056080724495*std::sin(0.259599983692169*x_11 + 1.96687984466553) + 0.000220706143057293*std::sin(0.277599930763245*x_11 + 7.97864007949829) + 0.00108756044128338*std::sin(0.219919994473457*x_110 + 1.97583973407745) - 0.000182906558859446*std::sin(0.314239919185638*x_111 - 2.16447973251343) + 0.0089457207470027*std::sin(0.243999972939491*x_112 + 1.78271985054016) + 0.00244814885706647*std::sin(0.222879990935326*x_115 + 4.98295974731445) - 0.00012078295342152*std::sin(0.327519834041595*x_116 + 1.41927993297577) + 4.36858952085045e-5*std::sin(0.298719942569733*x_117 + 7.94647979736328) + 0.00318661157708769*std::sin(0.2882399559021*x_119 - 1.63407981395721) - 0.00161747980648995*std::sin(0.31687992811203*x_119 + 4.7346396446228) + 0.000219079246708303*std::sin(0.323039829730988*x_119 - 8.13776016235352) + 0.00237832572722405*std::sin(0.334239840507507*x_120 + 4.82775974273682) - 0.000143510847245784*std::sin(0.373439848423004*x_120 + 4.61023998260498) - 0.00247071410999443*std::sin(0.429599851369858*x_13 - 1.23991990089417) - 1.3245982481069e-5*std::sin(0.470319837331772*x_13 + 1.72207987308502) - 0.00141249471502392*std::sin(0.148880034685135*x_15 - 1.42711985111237) - 0.00292811486256171*std::sin(0.338799834251404*x_15 + 1.84023988246918) + 2.96491770915725e-5*std::sin(0.589119851589203*x_16 - 4.59656000137329) - 0.00017865981465465*std::sin(0.797439873218536*x_16 + 7.98800039291382) + 0.00105798721924753*std::sin(0.239039987325668*x_17 - 4.38751983642578) - 0.000449496448742613*std::sin(0.420719861984253*x_17 - 1.38295984268188) - 2.95493948167e-5*std::sin(0.189040005207062*x_20 + 1.59415984153748) - 0.000529576945275718*std::sin(0.194240003824234*x_20 + 7.61240005493164) + 0.00282141359668056*std::sin(0.192159995436668*x_21 - 1.5998398065567) - 0.000973561334216139*std::sin(0.35471984744072*x_21 - 1.15311980247498) - 1.76811422768506e-5*std::sin(0.359679847955704*x_22 - 1.39007985591888) + 0.000565358608293209*std::sin(0.501279830932617*x_22 - 7.46343994140625) + 2.25705650723336e-5*std::sin(0.550239861011505*x_23 + 8.02112007141113) + 0.000735077974657455*std::sin(0.284879922866821*x_24 - 4.38207960128784) + 0.000871370206353337*std::sin(0.54671984910965*x_24 + 8.00600051879883) - 2.13787365603464e-5*std::sin(0.255519956350327*x_26 + 7.79239988327026) + 0.00290180316701358*std::sin(0.378799855709076*x_27 - 1.19023990631104) - 3.24599514293795e-5*std::sin(0.430399864912033*x_27 - 7.43319988250732) + 4.42839805357652e-5*std::sin(0.349919855594635*x_29 + 4.61783981323242) - 0.000771389538757529*std::sin(0.397999823093414*x_29 - 4.60591983795166) - 0.00824737379855867*std::sin(0.186480015516281*x_30 + 4.79576015472412) - 1.83320631290052e-6*std::sin(0.536159813404083*x_31 - 7.41943979263306) - 0.00261336644873222*std::sin(0.215360000729561*x_32 - 4.59135961532593) - 0.00286882175339129*std::sin(0.219119995832443*x_33 - 4.39343976974487) + 0.0121238750238779*std::sin(0.235119983553886*x_33 + 8.20096015930176) + 0.0137799666749991*std::sin(0.217759996652603*x_34 + 8.19967937469482) - 0.00193330374750437*std::sin(0.231279984116554*x_35 - 1.20599985122681) - 0.000927174974016898*std::sin(0.249599978327751*x_35 + 8.18247985839844) + 0.00189145730335618*std::sin(0.256719976663589*x_35 - 1.22463989257813) - 0.000336851618078199*std::sin(0.240879982709885*x_36 - 1.20711994171143) - 0.00050654045783744*std::sin(0.258319973945618*x_37 - 7.43327951431274) + 6.13651867459099e-5*std::sin(0.289519935846329*x_38 + 1.55455982685089) - 0.000842758311447793*std::sin(0.538479864597321*x_4 - 4.58392000198364) - 0.0133876096037693*std::sin(0.226799994707108*x_40 - 1.39975988864899) - 0.00202389298195314*std::sin(0.213839992880821*x_41 + 1.59519982337952) + 0.000766040613758219*std::sin(0.218319997191429*x_41 + 1.57967984676361) - 0.00379147136315677*std::sin(0.350719839334488*x_41 + 1.61295986175537) + 0.000211856536387102*std::sin(0.457919865846634*x_43 + 4.92479991912842) + 0.00024887554679017*std::sin(0.489919871091843*x_43 + 7.90343999862671) - 0.00180187193367894*std::sin(0.279279947280884*x_44 + 1.93007981777191) + 0.000595154050954632*std::sin(0.292959928512573*x_44 - 7.64568042755127) + 0.00380554069108232*std::sin(0.29751992225647*x_44 - 4.45015954971313) - 0.000849475264669241*std::sin(0.340239852666855*x_44 + 8.0444803237915) - 7.35526663731445e-5*std::sin(0.169520020484924*x_45 - 7.79071998596191) - 0.000242346264008769*std::sin(0.58927983045578*x_45 - 7.79103994369507) - 0.000492679841090041*std::sin(0.268879950046539*x_46 - 1.40031981468201) + 0.00125715230208257*std::sin(0.189680010080338*x_47 + 2.01359987258911) - 0.000195021791436352*std::sin(0.607679843902588*x_47 - 4.6101598739624) - 4.66825182196285e-5*std::sin(0.661439836025238*x_47 + 7.74631977081299) + 0.00137165081415264*std::sin(0.37407985329628*x_49 - 4.56288003921509) - 0.00064158547610445*std::sin(0.575759828090668*x_50 - 4.5734395980835) - 0.000861006518153196*std::sin(0.211119994521141*x_51 - 1.40071988105774) - 0.00152084981281559*std::sin(0.213199988007545*x_52 - 1.20551991462708) + 4.41058576056456e-5*std::sin(0.213359996676445*x_53 + 1.97695982456207) - 0.00437711289606642*std::sin(0.247039973735809*x_53 + 8.1988000869751) + 0.00469655805448602*std::sin(0.269999951124191*x_53 - 4.61583995819092) - 0.00190708982861541*std::sin(0.210720002651215*x_54 + 1.98495984077454) + 0.000218928265542706*std::sin(0.446799844503403*x_55 + 1.52711987495422) + 0.00319377199836253*std::sin(0.495999842882156*x_55 - 1.39999985694885) - 0.00392659733195869*std::sin(0.184000000357628*x_56 + 1.57647979259491) + 0.000211922866757367*std::sin(0.572159826755524*x_56 + 4.83112001419067) - 0.00198114954950567*std::sin(0.19080001115799*x_57 - 7.40759992599487) - 0.0155152088953888*std::sin(0.193999990820885*x_57 - 1.18895995616913) + 0.000655818704589267*std::sin(0.210400000214577*x_57 - 4.38695955276489) + 0.00840963604906541*std::sin(0.234479993581772*x_57 + 1.76807987689972) + 0.000121907232921357*std::sin(0.409359842538834*x_57 - 8.01327991485596) + 0.000454075774306596*std::sin(0.503999829292297*x_57 + 1.79999983310699) + 0.00037040021338538*std::sin(0.156560033559799*x_58 - 1.73479986190796) + 0.0032863526156513*std::sin(0.0999200716614723*x_59 - 7.80351972579956) + 0.00737461694088701*std::sin(0.106240063905716*x_59 - 1.25135982036591) + 0.00485206208680565*std::sin(0.146480038762093*x_59 - 7.96208000183105) + 0.0018506929438471*std::sin(0.356559842824936*x_59 - 1.33015990257263) + 0.000470895545613061*std::sin(0.568239867687225*x_59 - 1.55663979053497) - 9.81614006856225e-5*std::sin(0.23735998570919*x_6 - 7.57872009277344) + 0.000216215139498561*std::sin(0.428959846496582*x_6 - 1.40255987644196) - 0.000160684805463205*std::sin(0.588399827480316*x_6 - 8.19416046142578) + 2.80769889151493e-5*std::sin(0.580399870872498*x_60 - 4.56799983978271) - 1.53306603592637e-5*std::sin(0.985839784145355*x_64 + 5.59231996536255) - 2.60646492548018e-6*std::sin(1.30951976776123*x_65 + 8.57479953765869) + 0.00183661116276419*std::sin(0.301279932260513*x_8 + 4.78895998001099) - 0.00716216807976572*std::sin(0.346559852361679*x_8 - 1.35543990135193) + 0.00146476752339722*std::sin(0.225839987397194*x_9 + 4.99991989135742) + 9.84727260619852e-6*std::sin(0.287119954824448*x_92 + 1.81895983219147) + 0.00112998186839658*std::sin(0.339519828557968*x_92 + 1.80711996555328) - 9.98104846100321e-6*std::sin(0.43767985701561*x_92 + 4.59567975997925) + 0.00481045166185946*std::sin(0.254879981279373*x_93 - 7.62007999420166) - 4.13741439501045e-5*std::sin(0.255519956350327*x_93 - 4.41703987121582) + 0.00150749090328367*std::sin(0.289679944515228*x_93 + 1.5745598077774) - 4.67374238994822e-6*std::sin(0.19080001115799*x_94 + 4.79112005233765) + 0.00257100451456239*std::sin(0.290399938821793*x_94 - 1.39271986484528) + 0.0024302445475133*std::sin(0.331199824810028*x_94 + 1.63039982318878) + 0.00508453446205862*std::sin(0.26199996471405*x_95 - 7.79631996154785) - 0.00455851621472141*std::sin(0.291839927434921*x_95 + 7.97679996490479) + 5.48216089691281e-5*std::sin(0.296879917383194*x_95 - 4.83536005020142) - 0.00108689944867687*std::sin(0.422399878501892*x_96 + 4.39903974533081) + 0.00104620013452677*std::sin(0.279439955949783*x_97 + 8.17615985870361) - 0.000525693689596994*std::sin(0.330079853534698*x_97 - 1.55287981033325) - 1.64745841329025e-5*std::sin(0.244639977812767*x_98 - 7.41063976287842) - 0.00188370179927661*std::sin(0.277279943227768*x_98 + 8.17543983459473) - 0.000805979702429531*std::sin(0.306719928979874*x_98 + 4.77415990829468) - 0.00216505331398548*std::sin(0.328239858150482*x_98 + 7.83935976028442) - 0.0538325496017933*std::sin(-0.000637749941117965*x_1 + 0.00150493141481617*x_10 - 0.0222358577425269*x_100 - 0.000650148251068327*x_102 - 0.000199056706834734*x_103 - 0.000433698658844986*x_104 - 0.0216347126351886*x_106 - 0.000455594533025664*x_107 + 3.49546786768117e-5*x_108 - 0.000177118178017704*x_109 - 0.0253298773069617*x_11 + 8.11832869500479e-5*x_110 - 0.000570042999491663*x_111 - 0.00431989593294299*x_113 + 0.0145899287855542*x_115 + 0.0214859994670357*x_116 + 0.0425311037709768*x_119 - 0.0265288619983361*x_12 - 8.49526104426598e-5*x_120 - 0.000163271461337654*x_13 + 0.00120365634112284*x_14 + 0.000308229733963823*x_15 - 0.00278271423176737*x_16 - 0.00895820307123686*x_17 + 0.00149286900733944*x_18 + 0.00112178962467152*x_19 + 0.00145950255349136*x_2 - 0.00074406154771367*x_21 + 0.00108489540003646*x_22 + 0.000597357630354752*x_23 + 0.000850071517247023*x_24 + 5.13788620827491e-6*x_25 - 0.000575935788384403*x_26 + 0.00123508559794507*x_27 - 0.000340858640122489*x_28 + 0.000132362508683179*x_3 - 0.00416252864673947*x_30 + 0.000212718205713994*x_31 + 0.0299528616416509*x_33 - 0.00356126168540417*x_34 - 0.0013269491793827*x_35 + 0.0226661285968107*x_36 + 0.0244150452000926*x_37 + 0.0321413190000793*x_39 + 0.00524029464787671*x_4 - 0.000515463493454947*x_41 - 0.000520383579772418*x_44 + 0.0179229671656787*x_45 + 0.008670826872387*x_46 + 0.0183895070449058*x_47 - 0.0443179560519452*x_48 - 0.000929597318707524*x_51 - 0.00242400276658228*x_53 - 0.00123723351068859*x_54 - 0.00215030081783143*x_55 - 0.00139761179859609*x_56 + 0.00910286159023003*x_57 + 0.0552481662646831*x_58 - 0.00243314233830823*x_6 - 0.00180497856793584*x_60 - 0.000402858103484279*x_61 - 4.71176222884929e-5*x_62 + 0.000163493654846106*x_63 - 1.06017249577001e-5*x_64 - 0.000334425721658366*x_65 - 0.000372470712836304*x_66 + 7.14698132844682e-5*x_67 + 0.0004321115203822*x_68 + 0.000204002221910972*x_69 + 0.00126453710909982*x_7 + 1.69530153510302e-6*x_70 + 0.000928203972396674*x_71 + 0.000173294362993378*x_72 + 4.3773703743447e-5*x_73 + 0.000695864678237568*x_74 + 0.000132699410290099*x_75 + 0.0003446875415301*x_76 + 0.000377272117294577*x_77 - 0.00261009616239689*x_78 + 0.00130284531853456*x_79 - 0.000215367509656307*x_8 + 0.000403148217334041*x_80 + 0.000336458161775206*x_81 + 6.30597423229868e-5*x_82 + 0.00181028420984841*x_83 + 0.000439767515034217*x_84 - 0.000604455776516606*x_85 - 0.00024268039892155*x_86 - 0.000152953900241942*x_87 + 8.80405166585583e-5*x_88 + 0.000398129555037893*x_89 + 0.000736448652517563*x_9 + 6.47251326450863e-5*x_90 - 0.000788088869461848*x_91 - 0.00120495620294184*x_92 + 0.00389259435166406*x_93 - 0.00307932450696952*x_94 - 0.000584264180311957*x_96 - 5.95992595421935e-5*x_97 - 0.0022029227399403*x_98 - 0.0259054818262188*x_99 + 0.000112890078904308*std::pow(-5.76231956481934*x_5 - 1.65471994876862, 2) + 0.000306825807327014*std::pow(-2.19055986404419*x_52 - 3.38007998466492, 2) - 0.100598191058003*std::sin(0.295599937438965*x_101 - 1.60279989242554) + 0.171561541071856*std::sin(0.265759944915771*x_105 - 4.62527990341187) - 0.216717144665749*std::sin(0.273279964923859*x_112 + 4.96903991699219) + 0.143988188864933*std::sin(0.25503996014595*x_114 + 8.14727973937988) + 0.13849302591599*std::sin(0.252879977226257*x_117 - 1.39735984802246) + 0.0522881966646009*std::sin(0.359679847955704*x_118 - 8.16823959350586) + 0.18462234639834*std::sin(0.274879962205887*x_20 - 7.58160018920898) + 0.0862440996168576*std::sin(0.213119998574257*x_29 - 1.81263983249664) + 0.228133104872766*std::sin(0.250159978866577*x_32 + 5.01207971572876) - 0.0734776614851151*std::sin(0.277759939432144*x_38 - 1.41191983222961) + 0.190697297949006*std::sin(0.236719980835915*x_40 + 8.16784000396729) + 0.0705330486618587*std::sin(0.307519912719727*x_42 + 1.74847984313965) + 0.158806669739146*std::sin(0.46383985877037*x_43 + 4.89663982391357) + 0.186300615011977*std::sin(0.288879930973053*x_49 + 1.89487981796265) - 0.00941851999922982*std::sin(0.626239836215973*x_50 + 4.7673602104187) - 0.230557084796001*std::sin(0.350399851799011*x_59 + 8.05471992492676) - 0.00506485319627126*std::sin(0.249279975891113*x_95 + 5.17112016677856) - 1.26815038382974) - 0.0619813017547131*std::sin(0.000408695574605837*x_1 - 3.84979336449975e-5*x_100 + 0.0028975761847384*x_101 + 0.000697870113408371*x_102 + 0.00015388949662762*x_103 + 0.00842056213078107*x_104 - 0.000448810453904697*x_105 - 0.000135598840498254*x_106 + 0.00248308513824479*x_107 + 0.00544121588964976*x_108 - 0.000310790502784796*x_109 + 0.00894547212926816*x_110 - 0.025084688622426*x_111 + 9.70319523058456e-5*x_113 - 0.0100940310399761*x_114 + 0.000196132391251742*x_115 - 0.00950153803664692*x_116 + 5.41990606182773e-5*x_117 - 0.000149206681617112*x_118 + 0.00178867033844755*x_12 + 0.00439198665427673*x_120 + 0.00127126448078865*x_13 + 0.00146641678585177*x_14 + 0.00412150680278039*x_15 - 0.00860255605471131*x_16 + 0.000666451793551707*x_17 + 0.00258467747365934*x_18 + 0.00479771938356895*x_19 - 5.62740920383476e-5*x_2 + 0.00177970282572306*x_20 + 0.00023150940144384*x_21 + 0.00352783259648822*x_22 + 0.00177162081832889*x_24 - 0.00892677589345617*x_25 + 0.00245514939541189*x_26 + 0.000697478264975384*x_27 + 0.00114518857080982*x_3 + 0.000839324034307272*x_30 + 5.69843466368437e-5*x_31 + 0.000198792743122028*x_32 + 0.00264647122643565*x_33 - 0.000410147165334099*x_34 + 0.000531118270647963*x_35 + 0.00672262442580415*x_36 - 0.00873466260951287*x_37 - 0.00826076601762077*x_38 - 0.027295280164701*x_39 - 0.00149980396600898*x_40 - 0.0375359401340638*x_41 + 0.000162976190836126*x_42 - 0.000424258953134883*x_44 + 0.000344985317041675*x_45 + 0.00266018449233431*x_46 + 0.000255411329588533*x_47 - 0.00284626431981918*x_50 + 0.00174324334229532*x_51 - 0.000249088362072404*x_52 + 0.00141197437701727*x_53 - 0.0181794323283402*x_54 + 0.00170298346070855*x_55 + 0.00177298788832322*x_56 - 0.0155536511284892*x_58 + 0.000259113653481862*x_6 + 4.42398739129149e-5*x_60 - 4.00628352519545e-5*x_61 + 6.35088306903582e-6*x_62 + 0.00026235901279635*x_63 + 0.00187146225019209*x_64 + 0.000126292040876201*x_65 - 0.000123430400126104*x_66 + 0.000107253351022364*x_67 - 0.000656684280870475*x_68 - 0.000479219707577285*x_69 - 0.00130604378444879*x_7 - 0.000157113585607671*x_70 - 0.00104810949506223*x_71 + 6.01223076055419e-5*x_72 - 0.0011149926439708*x_73 + 0.000983215211127751*x_74 + 0.000265079507694629*x_75 - 8.50379507493434e-5*x_76 + 0.000372540587205722*x_77 + 0.000955129994447447*x_78 - 0.000430622937631778*x_79 + 0.00185125244556349*x_8 - 0.000550806130636289*x_80 + 0.00146707510768384*x_81 + 0.000256323351350938*x_82 - 0.00202108327173949*x_83 - 7.93612590100321e-5*x_84 - 0.000478628294085907*x_85 - 5.34697868432012e-5*x_86 - 0.000135724773412451*x_87 - 4.73722932387658e-5*x_88 - 0.000239407950928342*x_89 + 0.00183826149217092*x_9 - 0.000202019775510465*x_90 - 0.000237214700480649*x_91 - 0.000181967447306381*x_92 + 0.00804423394565155*x_93 - 0.000428788597760687*x_94 + 0.00085462981944626*x_96 - 5.26702016235529e-5*x_97 + 0.00103045521660924*x_98 - 0.000357847750923752*x_99 + 7.11485851553185e-6*std::pow(1.38503980636597 - 7.12336015701294*x_10, 2) + 0.0144930116798008*std::sin(0.491999864578247*x_11 - 7.40000009536743) - 0.0144180307878045*std::sin(0.219359993934631*x_112 + 4.78791999816895) + 0.0722181848021251*std::sin(0.349839836359024*x_119 - 4.97839975357056) - 0.0051585152083517*std::sin(0.398959845304489*x_23 + 2.00783967971802) + 0.00329284099797211*std::sin(0.532399833202362*x_28 - 7.56040000915527) - 0.0422069024137093*std::sin(0.704639852046967*x_29 - 1.58823990821838) - 0.00837492156188335*std::sin(1.04535984992981*x_4 + 3.9663200378418) - 0.298158935448711*std::sin(0.249279975891113*x_43 - 1.22215986251831) + 0.184817242309286*std::sin(0.218559995293617*x_48 - 4.41095972061157) + 0.059121559958863*std::sin(0.211199998855591*x_49 + 1.38191986083984) - 0.0129167546071736*std::sin(0.647999823093414*x_5 + 9.99600028991699) + 0.0977921651071485*std::sin(0.522399842739105*x_57 + 1.65279984474182) - 0.0739387128128781*std::sin(0.561039865016937*x_59 - 4.54360008239746) + 0.0977556308173195*std::sin(0.306639939546585*x_95 - 4.60048007965088) - 6.47634946385728) + 0.0194081086665392*std::sin(0.000564369087380688*x_1 + 0.0033378885765698*x_10 - 0.00160967791347739*x_100 + 0.00468074641908151*x_101 + 0.00418659216551264*x_102 + 0.00453761952314427*x_103 - 0.00264530016506909*x_104 + 0.00158755295638812*x_105 + 0.00270459625216168*x_106 + 0.00426101248951388*x_107 + 0.00587011118007073*x_108 - 0.000106436984688753*x_109 + 0.000350973510756035*x_11 + 0.00135456831993969*x_110 + 0.00254521620532155*x_111 + 0.0061620580801367*x_112 + 0.000525986063554371*x_113 + 0.00254486062432015*x_114 + 0.0020839889352349*x_115 - 0.00737371772779211*x_116 + 0.00216403158126091*x_117 + 0.00142595918082484*x_118 + 0.00254729792607954*x_119 - 0.003090946561156*x_12 + 0.00560018528396435*x_120 - 0.000975759874341403*x_13 + 1.54518882355014e-5*x_14 - 0.00032504050815153*x_16 + 0.00115770200676013*x_17 + 0.00449526397978245*x_18 + 0.000845983877141855*x_19 - 0.000413187276859285*x_2 + 0.000708997041289348*x_20 + 0.000313576873662236*x_21 + 0.000337498546958488*x_22 - 0.000682966294453238*x_23 + 0.00120198169193733*x_24 + 6.43766795661252e-5*x_25 - 0.00460825028825149*x_27 - 0.00409578031073612*x_28 - 0.00172398216376073*x_29 - 0.000670238107966313*x_3 - 0.000430835334271019*x_30 - 0.000343940872824074*x_31 + 0.010628596200546*x_32 + 0.00401866291062603*x_33 + 0.0096136384232009*x_34 + 0.0029067114528659*x_35 - 0.000558648544445945*x_36 - 0.00554471112330517*x_37 + 4.98304854301082e-5*x_38 + 0.00387671029676414*x_39 - 0.00191257929056472*x_4 - 0.00637154928611227*x_40 + 0.0128455329508877*x_41 + 0.00740257301153488*x_42 + 0.00789825540717168*x_43 + 0.00398199188337482*x_44 - 0.00081228493662782*x_45 + 0.0042755294676144*x_46 + 0.00206568391442755*x_47 + 0.00335154756994199*x_48 + 0.00216348610923445*x_49 - 0.0010954659814733*x_5 + 0.00696913593225892*x_50 + 0.00656905406893262*x_51 - 0.00062210844382795*x_52 - 0.00203750496729879*x_53 + 0.00235213806580378*x_54 - 0.00146884323713004*x_55 + 0.0235234779385923*x_56 + 0.00579027528355892*x_57 - 0.0416085415543683*x_58 + 0.00249640045044627*x_59 + 0.00193174550034586*x_6 + 0.014357336097138*x_60 - 0.000806782716337026*x_61 + 0.000719632949981695*x_62 - 0.000378152831042185*x_63 - 0.0012794959353405*x_64 - 0.000480694559645515*x_65 + 0.000555272612310029*x_66 + 0.000643668830409838*x_67 + 0.00142946311902263*x_68 + 0.00124215916474858*x_69 + 0.00484156137799986*x_70 + 0.00426800286989317*x_71 + 0.000433741568342632*x_72 - 0.000426654916083213*x_73 - 0.000938563775860546*x_74 - 0.000521740356626816*x_75 - 0.00125704455086432*x_76 + 0.000116856955113959*x_77 + 0.00950339750390658*x_78 + 0.00286219630278906*x_79 - 0.000868228080656504*x_8 - 0.000713312373338046*x_80 + 0.000442763493398248*x_81 + 0.000158189955205717*x_82 - 0.00237966984047982*x_83 - 0.000183502523053071*x_84 + 0.000252550838761406*x_85 - 0.000336368569394287*x_86 - 0.000553580720491385*x_87 - 0.00108933244718678*x_88 + 0.000789986748925018*x_89 - 0.000621010588028746*x_9 + 0.00127924495347272*x_90 - 0.00105794813119625*x_91 - 0.000669098930178336*x_92 + 0.00416077576585437*x_93 + 0.00496267586522047*x_94 + 0.00269059396638217*x_95 + 0.000447953408282038*x_96 + 0.00319887841089087*x_97 + 0.00726118184326769*x_98 + 0.00109664440386499*x_99 + 4.5015684049134e-5*std::pow(5.20296001434326 - 9.00399971008301*x_15, 2) - 0.00610943047964163*std::sin(0.547199845314026*x_26 - 4.34791994094849) + 0.010991882921487*std::sin(0.747679829597473*x_7 + 7.62128019332886) + 1.38903344629386) - 0.0158151288105651);
}

inline float score_8(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (7.00421607269869e-5*x_1 + 0.000604397727705582*x_10 + 0.000241641165841419*x_100 - 0.000177346933428153*x_101 - 0.000117582912684219*x_102 + 0.000294170873180249*x_103 + 3.47047118223962e-5*x_104 - 0.000218136647331252*x_105 - 0.000347445102740073*x_106 + 2.11208367059784e-5*x_107 - 0.000112372379848533*x_108 - 6.35077594123529e-5*x_109 + 6.36878835739343e-5*x_11 + 0.000424130609708628*x_110 + 7.00084026843068e-6*x_111 - 0.000490245694668712*x_112 + 2.58727873632878e-5*x_113 + 0.00011693851399408*x_114 - 0.000705251031001821*x_115 + 0.000318529562263171*x_116 + 4.75374190081719e-5*x_117 - 1.94363963645596e-5*x_118 + 0.00030638399180711*x_119 + 0.0002980430657088*x_12 + 0.000216945044566307*x_120 - 1.46461881142878e-5*x_13 + 0.00032173946292194*x_14 + 2.81141576185417e-5*x_15 + 6.63725633156891e-5*x_16 + 3.58955053683163e-5*x_17 + 7.94963915430495e-5*x_18 + 0.000272250637279248*x_19 + 5.5572479972819e-6*x_2 - 0.00030873340534536*x_20 + 1.12681661344417e-5*x_21 + 0.00041831930922613*x_22 + 0.000290911127711229*x_23 + 0.000341007930686146*x_24 - 0.000129214865294248*x_25 + 0.000148570057000719*x_26 - 0.000125421274700567*x_27 + 0.000442564789563006*x_28 + 9.28659520538414e-5*x_29 - 0.000184493532335346*x_3 + 1.4962294519277e-5*x_30 - 8.84857980527622e-5*x_31 - 0.000228415950455738*x_32 - 0.000223761524317222*x_33 - 0.000243981746376565*x_34 + 5.53104536028306e-5*x_35 - 0.000508473668127176*x_36 - 0.00103325645123399*x_37 - 0.00125455933030625*x_38 - 0.00104219886627117*x_39 + 4.8302685487156e-5*x_4 - 0.000265866559915264*x_40 - 0.000559529213102541*x_41 - 0.000223951074717427*x_42 + 0.000436790845851068*x_43 + 4.2001913869913e-5*x_44 + 0.000311207043866131*x_45 - 0.000439653298202621*x_46 - 0.000773011303458881*x_47 - 6.63897399212008e-5*x_48 + 4.006178231795e-5*x_49 - 2.30208507570176e-6*x_5 - 0.000677996105211252*x_50 - 0.00126312452216657*x_51 + 0.000585404311493676*x_52 - 0.00033386692227057*x_53 - 0.00073496034217388*x_54 - 0.000690509586461605*x_55 - 0.000331358653746899*x_56 - 0.000251537122058511*x_57 - 1.16050505766449e-5*x_58 - 1.39366579082249e-5*x_59 + 4.27762557885209e-5*x_6 + 0.000163463964112228*x_60 - 3.33903565944727e-5*x_61 + 1.31127103974687e-5*x_62 + 2.36230224908139e-5*x_63 + 1.83516424378902e-6*x_64 - 4.00552853545709e-5*x_65 - 4.10712199799401e-5*x_66 + 2.70100691173349e-5*x_67 + 1.14089305719908e-5*x_68 - 3.68968131278928e-5*x_69 + 0.000548824177834026*x_7 + 1.16442446940682e-6*x_70 + 4.11055891190615e-6*x_71 - 1.06732261872715e-5*x_72 - 3.47159094065192e-6*x_73 + 5.10734101595178e-5*x_74 + 5.93328799514575e-7*x_75 - 9.4260908716003e-6*x_76 + 7.73565536057811e-7*x_77 + 2.61137353156893e-5*x_78 - 3.06888758774158e-5*x_79 + 4.80475836286423e-5*x_8 + 1.21462788438671e-5*x_80 + 1.19854616652394e-5*x_81 - 1.80202464392991e-5*x_82 - 0.000145564447762543*x_83 + 1.00433216163724e-5*x_84 + 6.98965917741899e-6*x_85 + 6.56320498347746e-6*x_86 + 1.68650754918086e-5*x_87 + 2.086170836228e-5*x_88 + 6.32539677506932e-5*x_89 - 0.000682147026547537*x_9 - 5.35827535725838e-5*x_90 + 2.11401465007749e-5*x_91 - 5.53464855911887e-5*x_92 + 0.000114425727380675*x_93 + 0.00013154034171866*x_94 + 2.58624581895492e-5*x_95 - 0.000436406283193695*x_96 - 5.90169607921204e-5*x_97 + 0.000258709831356556*x_98 + 0.000128706177390998*x_99 + 1.2849877910826e-6*std::pow(0.814879834651947 - 5.53343963623047*x_19, 2) + 3.53342926545428e-8*std::pow(0.817359864711761 - 6.45175981521606*x_23, 2) + 4.29756369852918e-8*std::pow(2.25367975234985 - 5.73983955383301*x_4, 2) + 1.00293667802964e-8*std::pow(2.6431999206543 - 7.30952024459839*x_59, 2) - 9.16404769936163e-10*std::pow(7.96920013427734 - 7.90776014328003*x_27, 2) - 3.82020527611031e-9*std::pow(-8.08119964599609*x_14 - 7.46519994735718, 2) - 4.12879606768297e-7*std::pow(-6.89904022216797*x_22 - 1.4171998500824, 2) + 8.03072755120504e-7*std::pow(-4.69047975540161*x_26 - 6.72648000717163, 2) + 2.61286711201408e-6*std::pow(-2.57999992370605*x_28 - 7.52744007110596, 2) - 6.52475069038254e-7*std::pow(-4.49319982528687*x_42 - 6.96000003814697, 2) - 1.49967219961707e-6*std::pow(-3.42927980422974*x_42 - 6.80200004577637, 2) - 1.37093150816816e-7*std::pow(-5.76231956481934*x_5 - 1.65471994876862, 2) - 3.72607735654338e-7*std::pow(-2.19055986404419*x_52 - 3.38007998466492, 2) - 4.7162701665194e-7*std::pow(-8.52272033691406*x_57 - 2.62191987037659, 2) - 1.8876303298941e-6*std::pow(-6.33992004394531*x_60 - 9.99560070037842, 2) - 5.11264172932866e-7*std::pow(-5.4445595741272*x_9 - 8.69223976135254, 2) - 4.7139767151025e-7*std::exp(0.629279851913452*x_1) - 1.6603819111092e-5*std::exp(0.49567985534668*x_13) - 2.79551142918514e-5*std::exp(0.526799857616425*x_14) - 0.000442997508995895*std::exp(0.362639844417572*x_16) - 9.5861686570654e-6*std::exp(0.359759837388992*x_19) - 4.52419923111059e-5*std::exp(0.451119869947433*x_2) - 0.000148925314185074*std::exp(0.299999833106995*x_24) + 5.46849349178917e-5*std::exp(0.411119878292084*x_26) + 3.87800257644365e-5*std::exp(0.428639858961105*x_27) + 8.13652456517216e-6*std::exp(0.789199888706207*x_3) + 8.21186842864693e-6*std::exp(0.5655198097229*x_30) - 0.000144978853737464*std::exp(0.292399853467941*x_59) - 0.000967337273771477*std::exp(0.325199842453003*x_60) + 0.000232542791910759*std::log(4.99583959579468*x_24 + 9.18455982208252) - 5.20337210330014e-6*std::sin(0.278239965438843*x_10 - 1.21111989021301) - 0.000215499349746522*std::sin(0.324959933757782*x_10 + 4.96639966964722) - 0.000145545718847957*std::sin(0.254079967737198*x_100 + 1.78135991096497) + 0.000122165943300509*std::sin(0.295599937438965*x_101 - 1.60279989242554) - 0.0020621921150774*std::sin(0.262799948453903*x_102 + 1.76351988315582) - 9.53646367189973e-6*std::sin(0.247759968042374*x_104 + 4.57936000823975) + 0.000838843608852357*std::sin(0.222719997167587*x_105 + 1.78591990470886) - 0.000208343482906644*std::sin(0.265759944915771*x_105 - 4.62527990341187) + 7.59764882902499e-5*std::sin(0.284959942102432*x_107 - 7.83568000793457) + 0.000247305327313271*std::sin(0.256959974765778*x_109 + 7.99103975296021) + 0.00112146299478108*std::sin(0.259119987487793*x_109 - 7.63520002365112) + 0.00221587158469553*std::sin(0.271839946508408*x_109 + 1.74463987350464) + 2.52180426295321e-5*std::sin(1.23983979225159*x_109 - 5.41856002807617) - 0.00414153188215639*std::sin(0.130800053477287*x_11 + 4.94279956817627) + 0.0034521316658587*std::sin(0.259599983692169*x_11 + 1.96687984466553) - 0.000618141975913638*std::sin(0.277599930763245*x_11 + 7.97864007949829) - 3.60180875812294e-5*std::sin(0.219919994473457*x_110 + 1.97583973407745) + 0.00544155778005553*std::sin(0.226159989833832*x_111 + 8.16951942443848) - 1.00259441876162e-5*std::sin(0.314239919185638*x_111 - 2.16447973251343) + 0.00507877592932903*std::sin(0.243999972939491*x_112 + 1.78271985054016) + 0.000263180223511364*std::sin(0.273279964923859*x_112 + 4.96903991699219) - 0.000174858541011678*std::sin(0.25503996014595*x_114 + 8.14727973937988) - 0.00397651906947019*std::sin(0.222879990935326*x_115 + 4.98295974731445) + 0.00562439352995248*std::sin(0.266079962253571*x_115 + 1.5596798658371) + 0.000338282444024597*std::sin(0.327519834041595*x_116 + 1.41927993297577) - 0.000168185242434563*std::sin(0.252879977226257*x_117 - 1.39735984802246) - 7.09588368624178e-5*std::sin(0.298719942569733*x_117 + 7.94647979736328) - 6.34985261845356e-5*std::sin(0.359679847955704*x_118 - 8.16823959350586) + 0.00180914278810422*std::sin(0.2882399559021*x_119 - 1.63407981395721) - 8.86614584276674e-5*std::sin(0.31687992811203*x_119 + 4.7346396446228) - 7.25551904578085e-6*std::sin(0.323039829730988*x_119 - 8.13776016235352) + 0.00084369254728757*std::sin(0.334239840507507*x_120 + 4.82775974273682) + 0.00040193751498127*std::sin(0.373439848423004*x_120 + 4.61023998260498) - 0.000876466607252143*std::sin(0.429599851369858*x_13 - 1.23991990089417) - 0.000298072495765331*std::sin(0.467999845743179*x_13 - 10.0) - 0.00040064286863111*std::sin(0.470319837331772*x_13 + 1.72207987308502) + 4.67793388050409e-5*std::sin(0.148880034685135*x_15 - 1.42711985111237) + 0.000694936731981897*std::sin(0.338799834251404*x_15 + 1.84023988246918) - 9.81928559239842e-7*std::sin(0.589119851589203*x_16 - 4.59656000137329) + 4.24017750533094e-5*std::sin(0.797439873218536*x_16 + 7.98800039291382) - 0.00171848469934739*std::sin(0.239039987325668*x_17 - 4.38751983642578) - 0.000387228104986239*std::sin(0.420719861984253*x_17 - 1.38295984268188) + 8.27603665490434e-5*std::sin(0.189040005207062*x_20 + 1.59415984153748) + 0.000860189859600307*std::sin(0.194240003824234*x_20 + 7.61240005493164) - 0.000224204459989763*std::sin(0.274879962205887*x_20 - 7.58160018920898) + 0.00160180804507049*std::sin(0.192159995436668*x_21 - 1.5998398065567) + 0.00158135204876727*std::sin(0.35471984744072*x_21 - 1.15311980247498) - 0.000114940693028209*std::sin(1.03207981586456*x_21 + 3.58415985107422) - 0.000534790346627467*std::sin(0.359679847955704*x_22 - 1.39007985591888) - 0.000918309881557185*std::sin(0.501279830932617*x_22 - 7.46343994140625) + 0.000682677630755487*std::sin(0.550239861011505*x_23 + 8.02112007141113) - 0.000174457871168829*std::sin(0.284879922866821*x_24 - 4.38207960128784) + 4.77637822838466e-5*std::sin(0.54671984910965*x_24 + 8.00600051879883) - 0.000646629146270374*std::sin(0.255519956350327*x_26 + 7.79239988327026) - 0.000688692112294702*std::sin(0.378799855709076*x_27 - 1.19023990631104) + 1.07501645801514e-6*std::sin(0.430399864912033*x_27 - 7.43319988250732) - 0.000295519255503272*std::sin(0.422399878501892*x_28 + 1.96871984004974) - 0.0001047344059867*std::sin(0.213119998574257*x_29 - 1.81263983249664) - 0.00235475826019126*std::sin(0.250159978866577*x_29 + 2.00159978866577) - 0.000124028207146881*std::sin(0.349919855594635*x_29 + 4.61783981323242) + 0.00125296515446971*std::sin(0.397999823093414*x_29 - 4.60591983795166) - 0.0029256916867566*std::sin(0.186480015516281*x_30 + 4.79576015472412) + 5.1343463159497e-6*std::sin(0.536159813404083*x_31 - 7.41943979263306) + 0.000620236713584467*std::sin(0.215360000729561*x_32 - 4.59135961532593) - 0.000277043708855422*std::sin(0.250159978866577*x_32 + 5.01207971572876) + 0.00465981648801416*std::sin(0.219119995832443*x_33 - 4.39343976974487) + 0.00688311723368911*std::sin(0.235119983553886*x_33 + 8.20096015930176) + 0.00782333419913542*std::sin(0.217759996652603*x_34 + 8.19967937469482) + 0.00314025807574517*std::sin(0.231279984116554*x_35 - 1.20599985122681) + 3.0706403202618e-5*std::sin(0.249599978327751*x_35 + 8.18247985839844) - 0.000448904233192434*std::sin(0.256719976663589*x_35 - 1.22463989257813) + 0.000943436018156105*std::sin(0.240879982709885*x_36 - 1.20711994171143) + 1.67757283928931e-5*std::sin(0.258319973945618*x_37 - 7.43327951431274) + 8.92309069620241e-5*std::sin(0.277759939432144*x_38 - 1.41191983222961) - 0.000171868337065631*std::sin(0.289519935846329*x_38 + 1.55455982685089) - 0.000298961953946932*std::sin(0.538479864597321*x_4 - 4.58392000198364) + 0.000114825911687761*std::sin(0.726399838924408*x_4 + 5.0065598487854) - 0.00760058035901232*std::sin(0.226799994707108*x_40 - 1.39975988864899) - 0.000231581850963564*std::sin(0.236719980835915*x_40 + 8.16784000396729) - 0.000110938821468743*std::sin(0.213839992880821*x_41 + 1.59519982337952) + 0.000659921688008588*std::sin(0.218319997191429*x_41 + 1.57967984676361) - 0.00215254131450423*std::sin(0.350719839334488*x_41 + 1.61295986175537) - 8.56549837826452e-5*std::sin(0.307519912719727*x_42 + 1.74847984313965) - 0.000593356470275266*std::sin(0.457919865846634*x_43 + 4.92479991912842) - 0.000192854030545232*std::sin(0.46383985877037*x_43 + 4.89663982391357) + 0.000484045869816678*std::sin(0.489919871091843*x_43 + 7.90343999862671) + 0.00292677387011638*std::sin(0.279279947280884*x_44 + 1.93007981777191) + 0.0011575338115164*std::sin(0.292959928512573*x_44 - 7.64568042755127) + 0.00134998595134117*std::sin(0.29751992225647*x_44 - 4.45015954971313) - 4.65636204925762e-5*std::sin(0.340239852666855*x_44 + 8.0444803237915) + 0.000151795597053267*std::sin(0.557119846343994*x_44 + 7.60111999511719) - 0.0022247010588546*std::sin(0.169520020484924*x_45 - 7.79071998596191) + 0.000393642133918477*std::sin(0.58927983045578*x_45 - 7.79103994369507) + 0.00137987138122004*std::sin(0.268879950046539*x_46 - 1.40031981468201) + 6.89102615817e-5*std::sin(0.189680010080338*x_47 + 2.01359987258911) + 4.62850034125591e-5*std::sin(0.607679843902588*x_47 - 4.6101598739624) + 0.000130745903368058*std::sin(0.661439836025238*x_47 + 7.74631977081299) - 0.000226242541054047*std::sin(0.288879930973053*x_49 + 1.89487981796265) + 7.51864481697475e-5*std::sin(0.37407985329628*x_49 - 4.56288003921509) - 0.000227597455824132*std::sin(0.575759828090668*x_50 - 4.5734395980835) + 1.14378038819525e-5*std::sin(0.626239836215973*x_50 + 4.7673602104187) + 0.00139852968028951*std::sin(0.211119994521141*x_51 - 1.40071988105774) + 0.00247031068597197*std::sin(0.213199988007545*x_52 - 1.20551991462708) + 0.00133404202669118*std::sin(0.213359996676445*x_53 + 1.97695982456207) + 0.001038831013906*std::sin(0.247039973735809*x_53 + 8.1988000869751) + 0.00266638839646453*std::sin(0.269999951124191*x_53 - 4.61583995819092) + 0.000452614339020309*std::sin(0.210720002651215*x_54 + 1.98495984077454) - 0.000355604366239307*std::sin(0.446799844503403*x_55 + 1.52711987495422) + 0.0018132079915957*std::sin(0.495999842882156*x_55 - 1.39999985694885) - 0.00222925671141715*std::sin(0.184000000357628*x_56 + 1.57647979259491) - 7.01851233787487e-6*std::sin(0.572159826755524*x_56 + 4.83112001419067) + 0.00321797383371597*std::sin(0.19080001115799*x_57 - 7.40759992599487) - 0.00880848751094919*std::sin(0.193999990820885*x_57 - 1.18895995616913) - 0.00183678199564521*std::sin(0.210400000214577*x_57 - 4.38695955276489) + 0.00298325295765048*std::sin(0.234479993581772*x_57 + 1.76807987689972) + 6.68229242820908e-6*std::sin(0.409359842538834*x_57 - 8.01327991485596) - 1.50381904183548e-5*std::sin(0.503999829292297*x_57 + 1.79999983310699) + 8.36893987899514e-6*std::sin(0.156560033559799*x_58 - 1.73479986190796) + 0.000180140002145389*std::sin(0.0999200716614723*x_59 - 7.80351972579956) - 0.0119785628275131*std::sin(0.106240063905716*x_59 - 1.25135982036591) + 0.00275467308124224*std::sin(0.146480038762093*x_59 - 7.96208000183105) + 0.000279987378028287*std::sin(0.350399851799011*x_59 + 8.05471992492676) - 0.000439229527073225*std::sin(0.356559842824936*x_59 - 1.33015990257263) - 0.0036635553337423*std::sin(0.434719860553741*x_59 - 1.43583977222443) + 0.000915859540677365*std::sin(0.568239867687225*x_59 - 1.55663979053497) + 0.000274925207507748*std::sin(0.23735998570919*x_6 - 7.57872009277344) + 0.000186263048287852*std::sin(0.428959846496582*x_6 - 1.40255987644196) - 0.000312520926342101*std::sin(0.588399827480316*x_6 - 8.19416046142578) + 0.000849226955989565*std::sin(0.580399870872498*x_60 - 4.56799983978271) - 8.40343539781926e-7*std::sin(0.985839784145355*x_64 + 5.59231996536255) + 4.23367126968607e-6*std::sin(1.30951976776123*x_65 + 8.57479953765869) - 0.000435887463190635*std::sin(0.301279932260513*x_8 + 4.78895998001099) - 0.00406619520931396*std::sin(0.346559852361679*x_8 - 1.35543990135193) - 0.00237921643216955*std::sin(0.225839987397194*x_9 + 4.99991989135742) - 0.00187910184493049*std::sin(0.20456001162529*x_91 + 7.79360008239746) - 2.75797150991655e-5*std::sin(0.287119954824448*x_92 + 1.81895983219147) - 0.0018354253397887*std::sin(0.339519828557968*x_92 + 1.80711996555328) - 2.25514974022339e-7*std::sin(0.43767985701561*x_92 + 4.59567975997925) + 0.00170647029956448*std::sin(0.254879981279373*x_93 - 7.62007999420166) - 8.04698724103006e-5*std::sin(0.255519956350327*x_93 - 4.41703987121582) + 8.26324641057597e-5*std::sin(0.289679944515228*x_93 + 1.5745598077774) - 0.000141363735081776*std::sin(0.19080001115799*x_94 + 4.79112005233765) - 0.000610182851125443*std::sin(0.290399938821793*x_94 - 1.39271986484528) + 0.000862110344833381*std::sin(0.331199824810028*x_94 + 1.63039982318878) + 6.15073255188372e-6*std::sin(0.249279975891113*x_95 + 5.17112016677856) + 0.00288665519169033*std::sin(0.26199996471405*x_95 - 7.79631996154785) - 0.00161709815986349*std::sin(0.291839927434921*x_95 + 7.97679996490479) + 1.23865681755172e-6*std::sin(0.296879917383194*x_95 - 4.83536005020142) - 0.000617068083573996*std::sin(0.422399878501892*x_96 + 4.39903974533081) - 0.00169933898154095*std::sin(0.279439955949783*x_97 + 8.17615985870361) + 1.74100497168326e-5*std::sin(0.330079853534698*x_97 - 1.55287981033325) + 4.61411352090199e-5*std::sin(0.244639977812767*x_98 - 7.41063976287842) + 0.00305968981600018*std::sin(0.277279943227768*x_98 + 8.17543983459473) + 2.66926291255529e-5*std::sin(0.306719928979874*x_98 + 4.77415990829468) - 0.000768035818046605*std::sin(0.328239858150482*x_98 + 7.83935976028442) - 0.000446992820618437*std::sin(0.36287984251976*x_98 - 1.97687971591949) - 0.0291246883571148*std::sin(0.000558577594889688*x_1 - 5.26163837335036e-5*x_100 + 0.00396021204252524*x_101 + 0.000953801885104811*x_102 + 0.000210325802984149*x_103 + 0.011508657384331*x_104 - 0.000613403911077861*x_105 - 0.000185327365652037*x_106 + 0.00339371358685442*x_107 + 0.00743668753410746*x_108 - 0.000424767534435663*x_109 + 0.0122260690293464*x_110 - 0.0342840635179007*x_111 + 0.000132616739485674*x_113 - 0.0137958420188169*x_114 + 0.000268060547244782*x_115 - 0.0129860624729831*x_116 + 7.40756269617933e-5*x_117 - 0.000203925646710361*x_118 + 0.00244463419175542*x_12 + 0.00600267165725866*x_120 + 0.00173747870118843*x_13 + 0.00200419973261743*x_14 + 0.0056329980069857*x_15 - 0.0117573944263495*x_16 + 0.000910861440843979*x_17 + 0.00353256315093354*x_18 + 0.00655719983465488*x_19 - 7.69116401999137e-5*x_2 + 0.00243237799912447*x_20 + 0.000316411462927067*x_21 + 0.00482160407246966*x_22 + 0.00242133205556006*x_24 - 0.0122005162730107*x_25 + 0.0033555328943962*x_26 + 0.000953266333048809*x_27 + 0.00156516663581454*x_3 + 0.00114713158044009*x_30 + 7.7882368365419e-5*x_31 + 0.000271696537066051*x_32 + 0.00361701869180473*x_33 - 0.000560561531364993*x_34 + 0.00072589669341693*x_35 + 0.00918803044719515*x_36 - 0.0119379487710384*x_37 - 0.0112902588155482*x_38 - 0.0373053512041164*x_39 - 0.00204983108257847*x_40 - 0.0513015957714488*x_41 + 0.000222744884843257*x_42 - 0.000579848572818667*x_44 + 0.000471502704308076*x_45 + 0.0036357610603541*x_46 + 0.000349079009056397*x_47 - 0.00389008244025705*x_50 + 0.00238254763190399*x_51 - 0.000340437202765415*x_52 + 0.00192979151369775*x_53 - 0.0248464241292987*x_54 + 0.00232752313635136*x_55 + 0.00242320047478681*x_56 - 0.0212576831728206*x_58 + 0.000354139096085313*x_6 + 6.04640811007845e-5*x_60 - 5.47551858888635e-5*x_61 + 8.67995938920792e-6*x_62 + 0.000358574634694184*x_63 + 0.00255778860254929*x_64 + 0.000172607458532855*x_65 - 0.000168696360622952*x_66 + 0.000146586659069432*x_67 - 0.000897511862134206*x_68 - 0.000654965231616276*x_69 - 0.00178501271182498*x_7 - 0.000214732270731992*x_70 - 0.0014324854911814*x_71 + 8.21711221461362e-5*x_72 - 0.00152389687602947*x_73 + 0.00134379235307446*x_74 + 0.000362292823956831*x_75 - 0.000116224145685275*x_76 + 0.000509163392338802*x_77 + 0.00130540736982532*x_78 - 0.000588546438357385*x_79 + 0.00253016720226002*x_8 - 0.000752804734913122*x_80 + 0.0020050994825743*x_81 + 0.000350325498997039*x_82 - 0.00276228054117986*x_83 - 0.000108465625613868*x_84 - 0.000654156927474697*x_85 - 7.30789046662533e-5*x_86 - 0.000185499482280404*x_87 - 6.47452609371632e-5*x_88 - 0.000327206668572309*x_89 + 0.00251241204181244*x_9 - 0.000276107027666305*x_90 - 0.000324209081526634*x_91 - 0.000248700855551574*x_92 + 0.0109943173581597*x_93 - 0.000586039386123232*x_94 + 0.00116805049706668*x_96 - 7.19860854221711e-5*x_97 + 0.00140835681201158*x_98 - 0.000489082212941629*x_99 + 9.72410959286524e-6*std::pow(1.38503980636597 - 7.12336015701294*x_10, 2) + 0.0198080725846344*std::sin(0.491999864578247*x_11 - 7.40000009536743) - 0.0197055937497354*std::sin(0.219359993934631*x_112 + 4.78791999816895) + 0.0987029527123582*std::sin(0.349839836359024*x_119 - 4.97839975357056) - 0.00705031127646033*std::sin(0.398959845304489*x_23 + 2.00783967971802) + 0.0045004333770321*std::sin(0.532399833202362*x_28 - 7.56040000915527) - 0.0576855525307094*std::sin(0.704639852046967*x_29 - 1.58823990821838) - 0.0114462789276304*std::sin(1.04535984992981*x_4 + 3.9663200378418) - 0.407503558653488*std::sin(0.249279975891113*x_43 - 1.22215986251831) + 0.252595763491762*std::sin(0.218559995293617*x_48 - 4.41095972061157) + 0.0808033676405668*std::sin(0.211199998855591*x_49 + 1.38191986083984) - 0.0176537505433323*std::sin(0.647999823093414*x_5 + 9.99600028991699) + 0.133655747159211*std::sin(0.522399842739105*x_57 + 1.65279984474182) - 0.101054454558478*std::sin(0.561039865016937*x_59 - 4.54360008239746) + 0.133605814551638*std::sin(0.306639939546585*x_95 - 4.60048007965088) - 5.60822398925411) + 0.0130824018269777*std::sin(0.000604414817074723*x_1 + 0.00357473390824184*x_10 - 0.00172389523696112*x_100 + 0.00501287642062858*x_101 + 0.00448365864549544*x_102 + 0.00485959372219469*x_103 - 0.00283300175563918*x_104 + 0.00170020036743175*x_105 + 0.00289650529336775*x_106 + 0.00456335958504657*x_107 + 0.00628663449937947*x_108 - 0.000113989394651666*x_109 + 0.000375877409030716*x_11 + 0.00145068392585312*x_110 + 0.00272581617518211*x_111 + 0.00659929696822209*x_112 + 0.000563308263148411*x_113 + 0.00272543536335042*x_114 + 0.00223186177138385*x_115 - 0.00789693190370976*x_116 + 0.00231758397399512*x_117 + 0.00152714044178841*x_118 + 0.00272804560783404*x_119 - 0.00331026971909372*x_12 + 0.00599755557077256*x_120 - 0.00104499650874942*x_13 + 1.65483021840633e-5*x_14 - 0.000348104287901515*x_16 + 0.00123984864211914*x_17 + 0.00481423277212574*x_18 + 0.000906012043862976*x_19 - 0.000442505654446044*x_2 + 0.000759305083498245*x_20 + 0.000335827232517395*x_21 + 0.000361446307184613*x_22 - 0.000731427282535959*x_23 + 0.00128727026462634*x_24 + 6.8944631933023e-5*x_25 - 0.00493523620851558*x_27 - 0.00438640308735049*x_28 - 0.00184631013187769*x_29 - 0.000717795946803358*x_3 - 0.000461405958574577*x_30 - 0.000368345758796422*x_31 + 0.0113827655907398*x_32 + 0.00430381369625335*x_33 + 0.0102957898278047*x_34 + 0.00311296190800734*x_35 - 0.000598288363679627*x_36 - 0.00593814515050521*x_37 + 5.33662888514438e-5*x_38 + 0.00415178860299601*x_39 - 0.0020482894756208*x_4 - 0.00682365296462534*x_40 + 0.0137570087064336*x_41 + 0.0079278346612048*x_42 + 0.00845868901022036*x_43 + 0.00426454061641325*x_44 - 0.000869921940025196*x_45 + 0.00457890663902117*x_46 + 0.00221225788794975*x_47 + 0.00358936209778141*x_48 + 0.00231699979711077*x_49 - 0.00117319655808353*x_5 + 0.00746364234656219*x_50 + 0.00703517202165552*x_51 - 0.000666251163794302*x_52 - 0.002182079457637*x_53 + 0.00251903786115471*x_54 - 0.00157306740629922*x_55 + 0.0251926247080663*x_56 + 0.00620113371653161*x_57 - 0.0445609435290806*x_58 + 0.00267353661874815*x_59 + 0.00206881565509787*x_6 + 0.0153760843123191*x_60 - 0.000864029300713572*x_61 + 0.000770695680450577*x_62 - 0.00040498528234676*x_63 - 0.00137028465768011*x_64 - 0.000514803026660069*x_65 + 0.000594672886769195*x_66 + 0.000689341402794515*x_67 + 0.00153089300763976*x_68 + 0.00133029859559402*x_69 + 0.00518510226742084*x_70 + 0.00457084597927457*x_71 + 0.000464518409227966*x_72 - 0.000456928911991452*x_73 - 0.00100516110039362*x_74 - 0.000558761295156452*x_75 - 0.00134624019857583*x_76 + 0.000125148731084681*x_77 + 0.0101777265841592*x_78 + 0.00306528811280424*x_79 - 0.000929834621142462*x_8 - 0.000763926616975452*x_80 + 0.000474180499700461*x_81 + 0.000169414581656964*x_82 - 0.00254852319783711*x_83 - 0.000196523244068217*x_84 + 0.000270470995710433*x_85 - 0.000360236150218123*x_86 - 0.000592860944005247*x_87 - 0.00116662780886125*x_88 + 0.00084604154802138*x_89 - 0.00066507540784507*x_9 + 0.00137001586698427*x_90 - 0.00113301656750771*x_91 - 0.000716575936796199*x_92 + 0.00445601040106483*x_93 + 0.00531481063075146*x_94 + 0.00288150945254782*x_95 + 0.000479738673465218*x_96 + 0.00342586004938061*x_97 + 0.00777641085183066*x_98 + 0.00117445859735931*x_99 + 4.82098453803122e-5*std::pow(5.20296001434326 - 9.00399971008301*x_15, 2) - 0.00654293509044113*std::sin(0.547199845314026*x_26 - 4.34791994094849) + 0.0117718299138804*std::sin(0.747679829597473*x_7 + 7.62128019332886) + 1.23691230796534) + 0.0331877417212671);
}

inline float score_9(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (2.87616785926418e-7*x_1 - 0.000171307933680265*x_10 - 9.19161556990519e-5*x_100 - 0.000911358787863164*x_101 - 0.000278983635719246*x_102 - 0.000266744711580866*x_103 + 0.000323262123804308*x_104 - 3.91756328877427e-5*x_105 - 0.000813824292432527*x_106 - 0.000124342396529231*x_107 - 0.000301804766224684*x_108 + 7.18268948210082e-6*x_109 - 3.65955672617479e-5*x_11 + 0.000323829328543653*x_110 + 0.000102969116874406*x_111 - 0.00032313247731378*x_112 - 8.13829191649542e-6*x_113 - 0.000109249843929549*x_114 + 0.000235684332880981*x_115 - 0.000179895562862787*x_116 - 8.28363119753395e-5*x_117 - 0.000770051342333634*x_118 + 0.000383013223608741*x_119 + 5.2837163702283e-5*x_12 + 0.000391176516546205*x_120 + 2.43000379331291e-5*x_13 + 0.000702064038675861*x_14 + 7.15062654194631e-6*x_15 + 1.21254711057475e-5*x_16 - 6.52585067108618e-5*x_17 - 0.000347645765216277*x_18 + 2.85204860285747e-6*x_19 + 3.29523839887238e-5*x_2 - 6.76304603640596e-5*x_20 - 3.40032648143729e-6*x_21 - 9.95198323012194e-5*x_22 - 0.00043999464135389*x_23 - 9.46375150748073e-5*x_24 + 8.78236397152721e-5*x_25 - 6.25990336961281e-5*x_26 - 0.000463822124268719*x_27 - 7.92583949156902e-5*x_28 - 6.34431284323473e-5*x_29 + 9.3360906937435e-5*x_3 - 9.25483714631727e-5*x_30 - 4.01218044643353e-6*x_31 + 2.33784922580819e-5*x_32 - 0.000502965895640194*x_33 + 0.000552547091296431*x_34 - 1.90160879323731e-5*x_35 + 0.000192954452368819*x_36 - 0.000262065798966334*x_37 + 0.000137938493346787*x_38 - 4.39925405530912e-5*x_39 + 3.28017270831167e-5*x_4 - 1.2844304282645e-5*x_40 - 2.17658749758786e-5*x_41 - 0.00010416388596603*x_42 + 0.000599299680611148*x_43 - 1.94182929824865e-5*x_44 - 8.92143053321184e-5*x_45 + 1.78409935768204e-5*x_46 + 0.000389373329581952*x_47 - 0.000436355772843328*x_48 + 1.68272677134379e-5*x_49 + 3.41055247825448e-5*x_5 + 0.000459748244040025*x_50 + 0.000366379006422388*x_51 - 0.00036273633603756*x_52 + 0.000243787815218448*x_53 + 0.000264263754515987*x_54 - 2.77203102936958e-5*x_55 - 6.76603964184007e-5*x_56 + 6.25007131170157e-5*x_57 + 0.000804121243446262*x_58 - 9.63916485152992e-5*x_59 + 1.00892928361797e-5*x_6 - 1.74052656405203e-5*x_60 - 1.37998217399122e-5*x_61 + 4.19401897549208e-6*x_62 + 1.85088089855129e-6*x_63 + 1.84560773827081e-5*x_64 + 1.623599534769e-5*x_65 + 2.04673843672256e-6*x_66 - 9.29675524519201e-6*x_67 - 7.92094531268147e-6*x_68 + 2.2172454145808e-5*x_69 - 0.000247730779251982*x_7 - 1.06009621597656e-7*x_70 + 1.78261573956545e-5*x_71 + 7.23927472400895e-6*x_72 - 3.52806349756159e-5*x_73 - 5.75905104920162e-6*x_74 - 1.17667719689964e-5*x_75 - 1.35445724066128e-5*x_76 + 2.24422718712051e-5*x_77 + 1.37457565367288e-5*x_78 - 2.29205191722823e-5*x_79 + 2.86125585697678e-5*x_8 + 2.36300744560164e-5*x_80 + 3.68402222223399e-5*x_81 + 1.41428316554567e-5*x_82 + 3.91611757735358e-5*x_83 - 6.18198605511683e-6*x_84 + 9.61597160792533e-6*x_85 + 1.86195076384527e-5*x_86 - 7.51875141022988e-6*x_87 + 1.25185396836399e-5*x_88 + 2.8652802033332e-5*x_89 + 0.000172557799925204*x_9 + 1.77400064721839e-5*x_90 - 1.19216852337539e-5*x_91 - 5.97543200741186e-5*x_92 + 1.45998069588175e-5*x_93 + 0.000141153892887932*x_94 + 2.65112669262309e-5*x_95 - 0.000746040866375947*x_96 + 2.64768374410481e-5*x_97 - 4.70614186248583e-5*x_98 - 1.66758930696601e-5*x_99 - 3.6074398551179e-7*std::pow(0.814879834651947 - 5.53343963623047*x_19, 2) - 3.15658690581282e-8*std::pow(0.817359864711761 - 6.45175981521606*x_23, 2) - 3.83922594129803e-8*std::pow(2.25367975234985 - 5.73983955383301*x_4, 2) + 2.14489064031486e-8*std::pow(2.6431999206543 - 7.30952024459839*x_59, 2) + 9.72170961856987e-8*std::pow(5.20296001434326 - 9.00399971008301*x_15, 2) + 2.03735412356395e-9*std::pow(7.96920013427734 - 7.90776014328003*x_27, 2) - 8.16993008662135e-9*std::pow(-8.08119964599609*x_14 - 7.46519994735718, 2) - 1.52696876953033e-6*std::pow(-6.89904022216797*x_22 - 1.4171998500824, 2) - 1.20158111986323e-6*std::pow(-4.69047975540161*x_26 - 6.72648000717163, 2) + 4.24207589756739e-6*std::pow(-2.57999992370605*x_28 - 7.52744007110596, 2) + 1.35918350690652e-6*std::pow(-4.49319982528687*x_42 - 6.96000003814697, 2) - 7.33372131593421e-7*std::pow(-3.42927980422974*x_42 - 6.80200004577637, 2) - 2.30635808683656e-7*std::pow(-8.52272033691406*x_57 - 2.62191987037659, 2) + 8.45893131891718e-7*std::pow(-6.33992004394531*x_60 - 9.99560070037842, 2) - 1.89082825174833e-6*std::pow(-5.4445595741272*x_9 - 8.69223976135254, 2) + 4.21122825881333e-7*std::exp(0.629279851913452*x_1) - 6.14065524718356e-5*std::exp(0.49567985534668*x_13) + 0.000198517974822851*std::exp(0.362639844417572*x_16) + 1.43431080144489e-5*std::exp(0.359759837388992*x_19) - 0.000167320226521041*std::exp(0.451119869947433*x_2) - 7.28276987064344e-5*std::exp(0.299999833106995*x_24) - 0.000113915251545492*std::exp(0.411119878292084*x_26) - 5.80238172559652e-5*std::exp(0.428639858961105*x_27) - 2.28422582706556e-6*std::exp(0.789199888706207*x_3) - 1.71063028439618e-5*std::exp(0.5655198097229*x_30) + 0.000302008270048738*std::exp(0.292399853467941*x_59) - 0.000194310458527577*std::exp(0.325199842453003*x_60) - 0.0216550464790264*std::exp(0.00710517939828558*x_1 + 0.0037925552015462*x_10 - 0.00208797205263834*x_100 - 0.00954208648633862*x_101 + 0.00592346568013453*x_103 - 0.00441497150670692*x_104 - 0.0710677925814279*x_105 + 0.00842216076243177*x_106 + 0.00704333651884189*x_107 + 0.00543997258527639*x_108 + 0.000622724313389204*x_11 + 0.00373092825824226*x_110 + 0.00805949276493045*x_111 - 0.0343287599996378*x_112 + 0.00336467353748423*x_113 + 0.0187638951964453*x_114 + 0.00902612021459362*x_115 - 0.0335501850257848*x_116 + 0.00333595075881665*x_117 + 0.0680318056547695*x_118 + 0.00292332980854201*x_119 + 0.0369744629671896*x_12 - 0.000785826793773072*x_15 + 0.00287644806688647*x_16 + 0.00285139365203984*x_17 + 0.00293678178379648*x_18 + 0.00977578266454326*x_19 - 0.000447439360203027*x_2 - 0.0672924944316291*x_20 + 0.00296270848519378*x_21 + 0.00479346284964109*x_22 + 0.025218693590486*x_23 + 0.00617712341877474*x_24 + 0.00453225575870235*x_25 + 0.000861227466738976*x_26 + 0.000223727160733368*x_27 + 0.00734093654035026*x_28 + 0.0041770953161041*x_29 + 0.000781275774696182*x_3 + 0.000937296330128589*x_31 - 0.037440234051784*x_32 + 0.011037699261652*x_33 - 0.0134219801749459*x_34 + 0.012814077238187*x_35 + 0.00420659575280002*x_36 + 0.0121753176394084*x_37 + 0.0105466873328458*x_38 + 0.00871686968707885*x_39 + 0.00349789229764182*x_40 - 0.0678559868465699*x_41 + 0.0108793996482587*x_42 + 0.0453855123295004*x_43 + 0.0070598400520698*x_45 + 0.0143670370417555*x_46 + 0.0114925287937055*x_47 + 0.0601187479081815*x_48 - 0.0033169297681935*x_49 + 0.00666505251539921*x_5 + 0.0117612630294497*x_51 + 0.0103378846092496*x_52 - 0.00497561673874972*x_53 + 0.014185036294029*x_54 - 0.00226965641045778*x_55 - 0.0680462741036417*x_56 - 0.0818518342081264*x_58 - 0.0134402779449384*x_59 - 0.000103350401153123*x_6 + 0.00411466968306404*x_60 - 0.00472296631881616*x_61 + 0.000310057717056717*x_62 - 0.00143938446060671*x_63 + 0.000119253147728828*x_64 - 0.000188308013825678*x_65 - 0.00250717860561392*x_66 + 0.00232522100977213*x_67 + 0.000150406312467337*x_68 - 0.000889281810028142*x_69 + 0.00900587688665547*x_7 + 0.000271871988587261*x_70 - 0.0045569418974298*x_71 - 0.000472000003842096*x_72 + 0.000322701175502145*x_73 - 0.00164724963408755*x_74 - 0.000513691737425693*x_75 - 0.000309304638439135*x_76 - 0.00175097230386686*x_77 + 0.000229743562403023*x_78 - 8.49751380305759e-5*x_79 - 0.000434221431632427*x_8 + 0.000338208093618465*x_80 - 0.000624654909912192*x_81 - 0.000369466858640093*x_82 + 0.0033334333979776*x_83 + 9.33989364077217e-5*x_84 - 0.000289421200527537*x_85 + 0.000107878939201226*x_86 + 0.00188044360237157*x_87 - 0.001422306945973*x_88 + 0.0024097398021579*x_89 + 0.000129582966661383*x_9 - 0.000545857217790442*x_90 + 0.000393765327802659*x_91 + 0.00482632557285003*x_92 + 0.00662726013873822*x_96 - 0.0118062173454436*x_97 + 0.0197095415772737*x_99 - 0.00640341459284011*std::exp(0.526799857616425*x_14) - 0.472366914513941*std::sin(0.262799948453903*x_102 + 1.76351988315582) + 0.256882959988634*std::sin(0.259119987487793*x_109 - 7.63520002365112) + 0.193256701180665*std::sin(0.334239840507507*x_120 + 4.82775974273682) - 0.200763946246909*std::sin(0.429599851369858*x_13 - 1.23991990089417) - 0.670160624118395*std::sin(0.186480015516281*x_30 + 4.79576015472412) - 0.0684803974908377*std::sin(0.538479864597321*x_4 - 4.58392000198364) + 0.309228560137456*std::sin(0.29751992225647*x_44 - 4.45015954971313) - 0.0521336044167899*std::sin(0.575759828090668*x_50 - 4.5734395980835) + 0.683345642007296*std::sin(0.234479993581772*x_57 + 1.76807987689972) + 0.390885070416779*std::sin(0.254879981279373*x_93 - 7.62007999420166) + 0.197475492502409*std::sin(0.331199824810028*x_94 + 1.63039982318878) - 0.370413436583341*std::sin(0.291839927434921*x_95 + 7.97679996490479) - 0.175926727172676*std::sin(0.328239858150482*x_98 + 7.83935976028442)) + 4.67112120546044e-5*std::log(4.99583959579468*x_24 + 9.18455982208252) + 4.64842933405581e-6*std::sin(0.278239965438843*x_10 - 1.21111989021301) + 0.000322436477077807*std::sin(0.324959933757782*x_10 + 4.96639966964722) + 0.00013002318025843*std::sin(0.254079967737198*x_100 + 1.78135991096497) - 2.03947787728189e-5*std::sin(0.247759968042374*x_104 + 4.57936000823975) + 0.0031023280691034*std::sin(0.222719997167587*x_105 + 1.78591990470886) - 6.78735500470845e-5*std::sin(0.284959942102432*x_107 - 7.83568000793457) + 0.000914618947401198*std::sin(0.256959974765778*x_109 + 7.99103975296021) + 0.00359754057078534*std::sin(0.271839946508408*x_109 + 1.74463987350464) - 7.07964485586222e-6*std::sin(1.23983979225159*x_109 - 5.41856002807617) - 0.00672391354903619*std::sin(0.130800053477287*x_11 + 4.94279956817627) - 0.00154698429045671*std::sin(0.259599983692169*x_11 + 1.96687984466553) + 0.000924882238772162*std::sin(0.277599930763245*x_11 + 7.97864007949829) - 7.70286505891816e-5*std::sin(0.219919994473457*x_110 + 1.97583973407745) + 0.00109305370114031*std::sin(0.226159989833832*x_111 + 8.16951942443848) + 8.95667120053995e-6*std::sin(0.314239919185638*x_111 - 2.16447973251343) - 0.00227592320858577*std::sin(0.243999972939491*x_112 + 1.78271985054016) - 0.00645600980748451*std::sin(0.222879990935326*x_115 + 4.98295974731445) + 0.00112978018668056*std::sin(0.266079962253571*x_115 + 1.5596798658371) - 0.000506148160710735*std::sin(0.327519834041595*x_116 + 1.41927993297577) - 0.000115204011022761*std::sin(0.298719942569733*x_117 + 7.94647979736328) - 0.00081072095252604*std::sin(0.2882399559021*x_119 - 1.63407981395721) + 7.92056604781252e-5*std::sin(0.31687992811203*x_119 + 4.7346396446228) - 1.55167272598855e-5*std::sin(0.323039829730988*x_119 - 8.13776016235352) - 0.000601390753561014*std::sin(0.373439848423004*x_120 + 4.61023998260498) - 5.98742598853925e-5*std::sin(0.467999845743179*x_13 - 10.0) - 0.000195923025478985*std::sin(0.470319837331772*x_13 + 1.72207987308502) + 0.000100042772550875*std::sin(0.148880034685135*x_15 - 1.42711985111237) + 0.00257011164790061*std::sin(0.338799834251404*x_15 + 1.84023988246918) - 2.09996246254457e-6*std::sin(0.589119851589203*x_16 - 4.59656000137329) + 0.000156816140147577*std::sin(0.797439873218536*x_16 + 7.98800039291382) - 0.00279001656453191*std::sin(0.239039987325668*x_17 - 4.38751983642578) + 0.000806642397055488*std::sin(0.420719861984253*x_17 - 1.38295984268188) - 0.0001238284990796*std::sin(0.189040005207062*x_20 + 1.59415984153748) + 0.00139654659586939*std::sin(0.194240003824234*x_20 + 7.61240005493164) - 0.000717809203674979*std::sin(0.192159995436668*x_21 - 1.5998398065567) + 0.00256737718531485*std::sin(0.35471984744072*x_21 - 1.15311980247498) - 2.30883057764451e-5*std::sin(1.03207981586456*x_21 + 3.58415985107422) - 0.000261524042762089*std::sin(0.359679847955704*x_22 - 1.39007985591888) - 0.00149090636762193*std::sin(0.501279830932617*x_22 - 7.46343994140625) + 0.000333844122326291*std::sin(0.550239861011505*x_23 + 8.02112007141113) - 0.000645204356201207*std::sin(0.284879922866821*x_24 - 4.38207960128784) - 4.26697461311428e-5*std::sin(0.54671984910965*x_24 + 8.00600051879883) - 0.000316215633971095*std::sin(0.255519956350327*x_26 + 7.79239988327026) - 1.31940923063811e-5*std::sin(0.547199845314026*x_26 - 4.34791994094849) - 0.00254701692710639*std::sin(0.378799855709076*x_27 - 1.19023990631104) + 2.29904119521388e-6*std::sin(0.430399864912033*x_27 - 7.43319988250732) - 5.93613867650201e-5*std::sin(0.422399878501892*x_28 + 1.96871984004974) - 0.000473003749225376*std::sin(0.250159978866577*x_29 + 2.00159978866577) + 0.000185574658196212*std::sin(0.349919855594635*x_29 + 4.61783981323242) + 0.00203423023613729*std::sin(0.397999823093414*x_29 - 4.60591983795166) - 7.68216024855528e-6*std::sin(0.536159813404083*x_31 - 7.41943979263306) + 0.00229384565339188*std::sin(0.215360000729561*x_32 - 4.59135961532593) + 0.00756536569349475*std::sin(0.219119995832443*x_33 - 4.39343976974487) - 0.00308449249928601*std::sin(0.235119983553886*x_33 + 8.20096015930176) - 0.00350582662438652*std::sin(0.217759996652603*x_34 + 8.19967937469482) + 0.00509831251425242*std::sin(0.231279984116554*x_35 - 1.20599985122681) + 6.56690280351707e-5*std::sin(0.249599978327751*x_35 + 8.18247985839844) - 0.00166020005192332*std::sin(0.256719976663589*x_35 - 1.22463989257813) - 0.00141159677001521*std::sin(0.240879982709885*x_36 - 1.20711994171143) + 3.58767443674217e-5*std::sin(0.258319973945618*x_37 - 7.43327951431274) + 0.000257154470256389*std::sin(0.289519935846329*x_38 + 1.55455982685089) + 2.30652494800556e-5*std::sin(0.726399838924408*x_4 + 5.0065598487854) + 0.00340600520253364*std::sin(0.226799994707108*x_40 - 1.39975988864899) + 9.91071293313462e-5*std::sin(0.213839992880821*x_41 + 1.59519982337952) - 0.00137469570371982*std::sin(0.218319997191429*x_41 + 1.57967984676361) + 0.000964606197101339*std::sin(0.350719839334488*x_41 + 1.61295986175537) + 0.000887797434896748*std::sin(0.457919865846634*x_43 + 4.92479991912842) - 0.000135889723980238*std::sin(0.489919871091843*x_43 + 7.90343999862671) + 0.00475171386824967*std::sin(0.279279947280884*x_44 + 1.93007981777191) - 0.000324962901148872*std::sin(0.292959928512573*x_44 - 7.64568042755127) + 4.15975823178695e-5*std::sin(0.340239852666855*x_44 + 8.0444803237915) + 3.04914044621583e-5*std::sin(0.557119846343994*x_44 + 7.60111999511719) - 0.00108792692036762*std::sin(0.169520020484924*x_45 - 7.79071998596191) + 0.000639090982042093*std::sin(0.58927983045578*x_45 - 7.79103994369507) - 0.00206460422040443*std::sin(0.268879950046539*x_46 - 1.40031981468201) - 6.15609406735824e-5*std::sin(0.189680010080338*x_47 + 2.01359987258911) + 0.000171177635199223*std::sin(0.607679843902588*x_47 - 4.6101598739624) - 0.000195625873228568*std::sin(0.661439836025238*x_47 + 7.74631977081299) - 6.71677681813411e-5*std::sin(0.37407985329628*x_49 - 4.56288003921509) + 0.00227055904278871*std::sin(0.211119994521141*x_51 - 1.40071988105774) + 0.00401063084007635*std::sin(0.213199988007545*x_52 - 1.20551991462708) + 0.00065237539576951*std::sin(0.213359996676445*x_53 + 1.97695982456207) + 0.00384194929720562*std::sin(0.247039973735809*x_53 + 8.1988000869751) - 0.00119487359140476*std::sin(0.269999951124191*x_53 - 4.61583995819092) + 0.00167392128115806*std::sin(0.210720002651215*x_54 + 1.98495984077454) - 0.000577335412182785*std::sin(0.446799844503403*x_55 + 1.52711987495422) - 0.000812542669235466*std::sin(0.495999842882156*x_55 - 1.39999985694885) + 0.00099898423517971*std::sin(0.184000000357628*x_56 + 1.57647979259491) - 1.50098622896283e-5*std::sin(0.572159826755524*x_56 + 4.83112001419067) + 0.00522448660945734*std::sin(0.19080001115799*x_57 - 7.40759992599487) + 0.00394729782090538*std::sin(0.193999990820885*x_57 - 1.18895995616913) + 0.00274824734521198*std::sin(0.210400000214577*x_57 - 4.38695955276489) - 5.96962191543548e-6*std::sin(0.409359842538834*x_57 - 8.01327991485596) - 3.21608278789546e-5*std::sin(0.503999829292297*x_57 + 1.79999983310699) - 1.86058548926118e-5*std::sin(0.156560033559799*x_58 - 1.73479986190796) - 0.000160927962403153*std::sin(0.0999200716614723*x_59 - 7.80351972579956) - 0.0194475916606876*std::sin(0.106240063905716*x_59 - 1.25135982036591) - 0.00123443610919333*std::sin(0.146480038762093*x_59 - 7.96208000183105) - 0.00162441970855871*std::sin(0.356559842824936*x_59 - 1.33015990257263) - 0.000735903739101432*std::sin(0.434719860553741*x_59 - 1.43583977222443) - 0.00025711592216343*std::sin(0.568239867687225*x_59 - 1.55663979053497) - 0.000411351196525428*std::sin(0.23735998570919*x_6 - 7.57872009277344) - 0.00038800817869125*std::sin(0.428959846496582*x_6 - 1.40255987644196) + 8.77362768011231e-5*std::sin(0.588399827480316*x_6 - 8.19416046142578) + 0.000415290343502858*std::sin(0.580399870872498*x_60 - 4.56799983978271) + 7.50720395054798e-7*std::sin(0.985839784145355*x_64 + 5.59231996536255) + 6.87350488234936e-6*std::sin(1.30951976776123*x_65 + 8.57479953765869) + 2.37383694552721e-5*std::sin(0.747679829597473*x_7 + 7.62128019332886) - 0.00161205962321946*std::sin(0.301279932260513*x_8 + 4.78895998001099) + 0.00182216112234362*std::sin(0.346559852361679*x_8 - 1.35543990135193) - 0.00386273631582545*std::sin(0.225839987397194*x_9 + 4.99991989135742) - 0.000377457946683772*std::sin(0.20456001162529*x_91 + 7.79360008239746) + 4.12655824059072e-5*std::sin(0.287119954824448*x_92 + 1.81895983219147) - 0.00297987354959678*std::sin(0.339519828557968*x_92 + 1.80711996555328) + 5.0136563811408e-7*std::sin(0.43767985701561*x_92 + 4.59567975997925) + 2.25908936165536e-5*std::sin(0.255519956350327*x_93 - 4.41703987121582) - 7.38196620324178e-5*std::sin(0.289679944515228*x_93 + 1.5745598077774) - 6.91299230281134e-5*std::sin(0.19080001115799*x_94 + 4.79112005233765) - 0.00225666306133255*std::sin(0.290399938821793*x_94 - 1.39271986484528) - 0.00129358050785686*std::sin(0.26199996471405*x_95 - 7.79631996154785) - 2.75378594449634e-6*std::sin(0.296879917383194*x_95 - 4.83536005020142) + 0.000276523239502149*std::sin(0.422399878501892*x_96 + 4.39903974533081) - 0.00275893286047559*std::sin(0.279439955949783*x_97 + 8.17615985870361) + 3.72333104403098e-5*std::sin(0.330079853534698*x_97 - 1.55287981033325) - 6.90377261122444e-5*std::sin(0.244639977812767*x_98 - 7.41063976287842) + 0.00496750728837557*std::sin(0.277279943227768*x_98 + 8.17543983459473) + 5.70851297304955e-5*std::sin(0.306719928979874*x_98 + 4.77415990829468) - 8.9788104198931e-5*std::sin(0.36287984251976*x_98 - 1.97687971591949) - 0.0967714190483093*std::sin(-0.000755597257715793*x_1 + 0.00178302180332951*x_10 - 0.0263447349030865*x_100 - 0.000770286602856903*x_102 - 0.000235839616936069*x_103 - 0.00051384013728615*x_104 - 0.0256325065431782*x_106 - 0.000539782064395086*x_107 + 4.14138169989266e-5*x_108 - 0.000209847153207405*x_109 - 0.0300104862383321*x_11 + 9.61848289382502e-5*x_110 - 0.000675379015231167*x_111 - 0.005118152601986*x_113 + 0.0172859446467504*x_115 + 0.0254563132504817*x_116 + 0.0503902600455617*x_119 - 0.0314310266201275*x_12 - 0.00010065067097262*x_120 - 0.000193441755923521*x_13 + 0.00142607528742432*x_14 + 0.000365186300638881*x_15 - 0.00329692110805106*x_16 - 0.0106135543702634*x_17 + 0.00176873043076601*x_18 + 0.00132908074072099*x_19 + 0.00172919832044843*x_2 - 0.000881553770179378*x_21 + 0.00128536897665412*x_22 + 0.00070774100987046*x_23 + 0.00100715290724793*x_24 + 6.08729610013439e-6*x_25 - 0.00068236070952948*x_26 + 0.0014633122336564*x_27 - 0.000403844574714979*x_28 + 0.000156821258830808*x_3 - 0.0049317060306212*x_30 + 0.000252025570746369*x_31 + 0.0354877337620729*x_33 - 0.00421933329979247*x_34 - 0.00157215092691687*x_35 + 0.026854513825217*x_36 + 0.0289266058854638*x_37 + 0.0380805875940274*x_39 + 0.00620862819464533*x_4 - 0.000610713975801243*x_41 - 0.000616543225620834*x_44 + 0.0212348821495415*x_45 + 0.0102730750479084*x_46 + 0.021787632107842*x_47 - 0.0525072977689619*x_48 - 0.00110137397043748*x_51 - 0.00287192475457443*x_53 - 0.00146585705079268*x_54 - 0.00254764649349756*x_55 - 0.00165587101508663*x_56 + 0.0107849437710446*x_57 + 0.0654572587654682*x_58 - 0.00288275319200356*x_6 - 0.00213851349602215*x_60 - 0.000477300676355534*x_61 - 5.58243033764365e-5*x_62 + 0.00019370500770113*x_63 - 1.25607762362985e-5*x_64 - 0.000396222942414896*x_65 - 0.000441298118672033*x_66 + 8.4676440475304e-5*x_67 + 0.000511959717716069*x_68 + 0.000241698994395277*x_69 + 0.00149820597433649*x_7 + 2.0085696733734e-6*x_70 + 0.00109972315311293*x_71 + 0.000205316750364359*x_72 + 5.18624752056139e-5*x_73 + 0.000824450789749792*x_74 + 0.000157220415167636*x_75 + 0.000408381003834177*x_76 + 0.000446986755875976*x_77 - 0.00309240562096235*x_78 + 0.00154359300792234*x_79 - 0.000255164429199507*x_8 + 0.000477644399208603*x_80 + 0.000398630949189563*x_81 + 7.47123054029416e-5*x_82 + 0.00214479954674688*x_83 + 0.000521030433667857*x_84 - 0.000716150794692017*x_85 - 0.000287524360417903*x_86 - 0.000181217653077554*x_87 + 0.00010430917929757*x_88 + 0.000471698357940887*x_89 + 0.000872534117863343*x_9 + 7.66854366872799e-5*x_90 - 0.000933716728468607*x_91 - 0.0014276153456235*x_92 + 0.00461189163320254*x_93 - 0.00364834083560164*x_94 - 0.000692228072418782*x_96 - 7.06123735472733e-5*x_97 - 0.00260999221472412*x_98 - 0.0306924544648083*x_99 + 0.000133750594933629*std::pow(-5.76231956481934*x_5 - 1.65471994876862, 2) + 0.000363522947891333*std::pow(-2.19055986404419*x_52 - 3.38007998466492, 2) - 0.119187337220838*std::sin(0.295599937438965*x_101 - 1.60279989242554) + 0.203263727059149*std::sin(0.265759944915771*x_105 - 4.62527990341187) - 0.256763457982268*std::sin(0.273279964923859*x_112 + 4.96903991699219) + 0.17059520297107*std::sin(0.25503996014595*x_114 + 8.14727973937988) + 0.164084610359106*std::sin(0.252879977226257*x_117 - 1.39735984802246) + 0.0619503279630544*std::sin(0.359679847955704*x_118 - 8.16823959350586) + 0.218737987505103*std::sin(0.274879962205887*x_20 - 7.58160018920898) + 0.102180809378721*std::sin(0.213119998574257*x_29 - 1.81263983249664) + 0.270288928814134*std::sin(0.250159978866577*x_32 + 5.01207971572876) - 0.0870553110897943*std::sin(0.277759939432144*x_38 - 1.41191983222961) + 0.225935505586238*std::sin(0.236719980835915*x_40 + 8.16784000396729) + 0.0835665747829166*std::sin(0.307519912719727*x_42 + 1.74847984313965) + 0.188151932952795*std::sin(0.46383985877037*x_43 + 4.89663982391357) + 0.220726376810088*std::sin(0.288879930973053*x_49 + 1.89487981796265) - 0.0111589314625167*std::sin(0.626239836215973*x_50 + 4.7673602104187) - 0.273160826504228*std::sin(0.350399851799011*x_59 + 8.05471992492676) - 0.00600076760356416*std::sin(0.249279975891113*x_95 + 5.17112016677856) - 1.65415623944125) - 0.057596854865551*std::sin(0.000514487060203808*x_1 - 4.84631836888334e-5*x_100 + 0.00364761829006927*x_101 + 0.000878514878458981*x_102 + 0.000193724032349866*x_103 + 0.0106002377444563*x_104 - 0.000564985738445688*x_105 - 0.000170698811413055*x_106 + 0.00312583559105923*x_107 + 0.00684968309162643*x_108 - 0.000391239108158254*x_109 + 0.0112610215130441*x_110 - 0.0315778993152219*x_111 + 0.000122148824184889*x_113 - 0.012706886685455*x_114 + 0.000246901565996087*x_115 - 0.0119610259460326*x_116 + 6.82285718170514e-5*x_117 - 0.000187829063385354*x_118 + 0.00225167043951762*x_12 + 0.00552885923561188*x_120 + 0.00160033327029113*x_13 + 0.00184600105326322*x_14 + 0.00518836525356933*x_15 - 0.010829341078859*x_16 + 0.000838963877606604*x_17 + 0.00325372526061849*x_18 + 0.00603961651338115*x_19 - 7.08407283498744e-5*x_2 + 0.00224038167216698*x_20 + 0.000291435970338699*x_21 + 0.00444101755495854*x_22 + 0.00223020762457964*x_24 - 0.0112374857274926*x_25 + 0.00309066863771364*x_26 + 0.000878021599449226*x_27 + 0.00144162241478435*x_3 + 0.00105658436694749*x_30 + 7.17348334566618e-5*x_31 + 0.000250250554088681*x_32 + 0.00333151442247938*x_33 - 0.000516314397451397*x_34 + 0.000668599061660351*x_35 + 0.00846278622180336*x_36 - 0.0109956436209873*x_37 - 0.010399078158691*x_38 - 0.0343607059188739*x_39 - 0.00188803055696936*x_40 - 0.0472521766603067*x_41 + 0.000205162831497162*x_42 - 0.000534079043488604*x_44 + 0.000434285303307796*x_45 + 0.00334877738859982*x_46 + 0.000321524949785628*x_47 - 0.00358302426905174*x_50 + 0.00219448459470686*x_51 - 0.000313565272286612*x_52 + 0.00177746614216542*x_53 - 0.022885206681776*x_54 + 0.00214380338010916*x_55 + 0.00223192856276977*x_56 - 0.0195797379314656*x_58 + 0.000326185625981201*x_6 + 5.56914341321024e-5*x_60 - 5.04331625124309e-5*x_61 + 7.99481903624142e-6*x_62 + 0.000330271051605459*x_63 + 0.0023558931664781*x_64 + 0.000158982932223332*x_65 - 0.000155380551311093*x_66 + 0.0001350160478682*x_67 - 0.000826668029065262*x_68 - 0.000603266474761688*x_69 - 0.00164411525083569*x_7 - 0.000197782681780512*x_70 - 0.00131941426918148*x_71 + 7.56850605061641e-5*x_72 - 0.00140361022528482*x_73 + 0.00123772199884632*x_74 + 0.000333695750842453*x_75 - 0.00010705015665751*x_76 + 0.000468973298042006*x_77 + 0.00120236688011529*x_78 - 0.000542090355277697*x_79 + 0.00233045202246597*x_8 - 0.000693383154849681*x_80 + 0.00184682978272617*x_81 + 0.000322673049800741*x_82 - 0.00254424382232959*x_83 - 9.99040444260322e-5*x_84 - 0.000602521972967566*x_85 - 6.7310524390224e-5*x_86 - 0.000170857342258099*x_87 - 5.96346850758809e-5*x_88 - 0.000301379071650904*x_89 + 0.00231409834056807*x_9 - 0.000254312908833557*x_90 - 0.000298618094911157*x_91 - 0.000229070004263545*x_92 + 0.0101264964228728*x_93 - 0.00053978119367593*x_94 + 0.00107585207839228*x_96 - 6.63039652919612e-5*x_97 + 0.00129719015327305*x_98 - 0.00045047719821989*x_99 + 8.95655071614696e-6*std::pow(1.38503980636597 - 7.12336015701294*x_10, 2) + 0.0182445503106596*std::sin(0.491999864578247*x_11 - 7.40000009536743) - 0.0181501604980666*std::sin(0.219359993934631*x_112 + 4.78791999816895) + 0.0909119743416227*std::sin(0.349839836359024*x_119 - 4.97839975357056) - 0.00649380489896695*std::sin(0.398959845304489*x_23 + 2.00783967971802) + 0.00414519801541557*std::sin(0.532399833202362*x_28 - 7.56040000915527) - 0.0531322247961237*std::sin(0.704639852046967*x_29 - 1.58823990821838) - 0.0105427830432625*std::sin(1.04535984992981*x_4 + 3.9663200378418) - 0.375337839956913*std::sin(0.249279975891113*x_43 - 1.22215986251831) + 0.232657473138495*std::sin(0.218559995293617*x_48 - 4.41095972061157) + 0.074425267773536*std::sin(0.211199998855591*x_49 + 1.38191986083984) - 0.016260276641429*std::sin(0.647999823093414*x_5 + 9.99600028991699) + 0.123105819253037*std::sin(0.522399842739105*x_57 + 1.65279984474182) - 0.0930778637058625*std::sin(0.561039865016937*x_59 - 4.54360008239746) + 0.123059828005422*std::sin(0.306639939546585*x_95 - 4.60048007965088) - 9.03931750222911) - 0.102206311397143);
}

inline float score_10(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (5.41881062204379e-6*x_1 + 0.000287370160524348*x_10 + 0.000575483282728603*x_100 - 0.000373640053656213*x_101 + 0.000342046120562357*x_102 + 0.000239683050254526*x_103 + 6.62387918984185e-5*x_104 + 9.82855695155961e-5*x_105 + 0.000217032325477062*x_106 + 3.69794148604912e-5*x_107 + 0.000418517035259583*x_108 - 1.72619957238532e-5*x_109 + 0.000486988907448828*x_11 + 0.000294529679192609*x_110 + 7.33243246538228e-5*x_111 - 0.000132846226567611*x_112 + 3.06995723157788e-5*x_113 + 4.70924250083507e-5*x_114 - 0.000784699363847343*x_115 - 0.000123462748028477*x_116 + 0.00011723862077272*x_117 - 0.000555204802349613*x_118 - 0.000514516412991495*x_119 + 0.000581629987274945*x_12 + 0.000132127610483999*x_120 - 2.17333995282196e-5*x_13 + 0.000301919269628862*x_14 + 8.4477261349108e-5*x_15 + 5.10887957702973e-5*x_16 + 0.000270530231922999*x_17 + 0.00024287312878468*x_18 + 0.000209795810919334*x_19 - 2.59550774888291e-6*x_2 + 6.55419429013345e-6*x_20 + 3.4978262982073e-5*x_21 + 0.000176152265878727*x_22 + 6.1552621707439e-5*x_23 + 0.000234490037232062*x_24 + 0.000223163250756017*x_25 + 0.000253202633441594*x_26 - 3.62908194390828e-5*x_27 + 0.00025729301207146*x_28 + 0.000210972383232467*x_29 - 0.000156463369568942*x_3 + 4.55836449933245e-6*x_30 - 2.22781704770054e-5*x_31 - 6.67703006827435e-6*x_32 - 4.17048020416218e-5*x_33 + 0.000549479452282893*x_34 + 1.98240403690791e-5*x_35 - 0.000685829448702346*x_36 - 0.000364407476618801*x_37 - 0.000218994157767546*x_38 + 0.000354136791207701*x_39 + 3.35997291553383e-5*x_4 + 0.000140953107020539*x_40 + 0.00033509745395955*x_41 + 0.000585681233374315*x_42 + 0.000286672095599522*x_43 + 4.95694143434775e-5*x_44 - 0.000220191519464614*x_45 - 0.000265830467000402*x_46 - 0.00120902241818428*x_47 + 0.00135067345387134*x_48 - 9.18276730716056e-5*x_49 + 6.11526945971185e-5*x_5 - 0.000538576071114744*x_50 - 0.000236391178728436*x_51 + 0.000364657472538364*x_52 + 0.000324738448235724*x_53 - 0.000605203585268172*x_54 - 0.000281855375215556*x_55 + 6.76209599601645e-5*x_56 - 0.000143280787768693*x_57 - 0.000728770672768967*x_58 + 2.14325468309147e-5*x_59 + 4.23059326687049e-5*x_6 + 5.40731430029875e-5*x_60 - 1.61494435874511e-5*x_61 + 1.27101570196723e-5*x_62 + 1.11809045916818e-5*x_63 - 1.10945390161015e-5*x_64 + 1.41912458339814e-5*x_65 + 1.89926235006409e-5*x_66 + 3.389458451009e-6*x_67 - 4.70346430178803e-5*x_68 - 4.25824985301216e-5*x_69 + 0.000379267966021922*x_7 - 4.00643258935244e-5*x_70 - 1.35539959454224e-5*x_71 - 1.26311077603368e-5*x_72 + 2.86378907992154e-5*x_73 + 1.10519816535075e-6*x_74 - 2.24607855980445e-5*x_75 + 3.40865988058835e-6*x_76 - 2.06988730024474e-5*x_77 + 5.71721015149667e-5*x_78 - 1.58589480377062e-5*x_79 + 1.37002162617259e-5*x_8 - 2.94097535633698e-5*x_80 - 2.23277270793223e-5*x_81 + 7.6383833040829e-6*x_82 - 0.000190361845263912*x_83 - 3.76498673541534e-6*x_84 + 3.88570235731927e-6*x_85 + 2.59725346636761e-5*x_86 + 1.25469280295244e-5*x_87 - 6.76553453902826e-6*x_88 - 3.10677698144859e-5*x_89 - 0.00049807228034316*x_9 - 1.44046583180621e-5*x_90 + 4.94008682979502e-5*x_91 + 4.42156323119034e-5*x_92 + 1.65246306974258e-5*x_93 + 4.60543842161989e-5*x_94 + 4.48970106016092e-6*x_95 - 0.000312031290352169*x_96 + 1.40167727611643e-5*x_97 - 0.000343647888985884*x_98 + 0.000340543913634166*x_99 - 1.6150664911295e-6*std::pow(0.814879834651947 - 5.53343963623047*x_19, 2) + 3.76225634933657e-8*std::pow(0.817359864711761 - 6.45175981521606*x_23, 2) + 4.57587660507222e-8*std::pow(2.25367975234985 - 5.73983955383301*x_4, 2) - 4.84994079637894e-7*std::pow(2.6431999206543 - 7.30952024459839*x_59, 2) + 7.48427181229101e-9*std::pow(5.20296001434326 - 9.00399971008301*x_15, 2) - 3.82164139779197e-7*std::pow(7.96920013427734 - 7.90776014328003*x_27, 2) + 1.84735186428209e-7*std::pow(-8.08119964599609*x_14 - 7.46519994735718, 2) + 1.62632134631608e-6*std::pow(-6.89904022216797*x_22 - 1.4171998500824, 2) + 5.28521013603072e-7*std::pow(-4.69047975540161*x_26 - 6.72648000717163, 2) + 2.29814651392837e-6*std::pow(-2.57999992370605*x_28 - 7.52744007110596, 2) - 9.35990524036895e-8*std::pow(-4.49319982528687*x_42 - 6.96000003814697, 2) - 8.71689204668651e-7*std::pow(-3.42927980422974*x_42 - 6.80200004577637, 2) - 2.09573496728594e-6*std::pow(-5.76231956481934*x_5 - 1.65471994876862, 2) - 5.69603263211491e-6*std::pow(-2.19055986404419*x_52 - 3.38007998466492, 2) - 2.74134693668758e-7*std::pow(-8.52272033691406*x_57 - 2.62191987037659, 2) - 1.40757764887097e-6*std::pow(-6.33992004394531*x_60 - 9.99560070037842, 2) + 2.01385543005027e-6*std::pow(-5.4445595741272*x_9 - 8.69223976135254, 2) - 3.57766220986377e-5*std::pow(-0.0228634103177098*x_1 - 0.0122038784476628*x_10 + 0.00671878345294137*x_100 + 0.0307050148060829*x_101 - 0.0190608313676733*x_103 + 0.0142067215253135*x_104 + 0.228685584287308*x_105 - 0.0271012604297727*x_106 - 0.0226644091315763*x_107 - 0.0175050225141786*x_108 - 0.00200383420230978*x_11 - 0.0120055721119039*x_110 - 0.0259342487652994*x_111 + 0.11046484283835*x_112 - 0.0108270189055612*x_113 - 0.0603794233736518*x_114 - 0.0290447121001651*x_115 + 0.10795950439544*x_116 - 0.0107345932766883*x_117 - 0.218916229999062*x_118 - 0.00940684044132864*x_119 - 0.118978321405903*x_12 + 0.00252867372061278*x_15 - 0.00925598197093758*x_16 - 0.0091753605911246*x_17 - 0.0094501268965448*x_18 - 0.031457014342261*x_19 + 0.00143979329882702*x_2 + 0.216537236464961*x_20 - 0.00953355516471411*x_21 - 0.0154246503614655*x_22 - 0.0811500043721632*x_23 - 0.0198770642357966*x_24 - 0.0145841248007078*x_25 - 0.00277130186940616*x_26 - 0.000719920720973975*x_27 - 0.0236220417289949*x_28 - 0.0134412713310681*x_29 - 0.00251402921824542*x_3 - 0.0030160801555812*x_31 + 0.120477103466744*x_32 - 0.0355176742255832*x_33 + 0.0431899355123954*x_34 - 0.0412337942952132*x_35 - 0.0135361993477897*x_36 - 0.0391783609299733*x_37 - 0.0339376708829659*x_38 - 0.0280495899075791*x_39 - 0.0112556970577602*x_40 + 0.218350471229564*x_41 - 0.035008289618768*x_42 - 0.146043827003049*x_43 - 0.0227175150463929*x_45 - 0.0462309879205373*x_46 - 0.0369812479980427*x_47 - 0.193453187338714*x_48 + 0.0106733865584777*x_49 - 0.0214471474830636*x_5 - 0.0378459947910256*x_51 - 0.0332657747804992*x_52 + 0.016010794478905*x_53 - 0.0456453365892838*x_54 + 0.00730341668854099*x_55 + 0.218962787315167*x_56 + 0.263387025978416*x_58 + 0.0432488150142046*x_59 + 0.000332566216221637*x_6 - 0.0132403949305536*x_60 + 0.0151978030125281*x_61 - 0.000997719608452194*x_62 + 0.00463172506745254*x_63 - 0.000383738888966063*x_64 + 0.000605947175274462*x_65 + 0.00806772777810031*x_66 - 0.0074822153031924*x_67 - 0.000483985138664361*x_68 + 0.00286157657266965*x_69 - 0.0289795720823131*x_7 - 0.000874843614851176*x_70 + 0.0146635611227551*x_71 + 0.00151882579634884*x_72 - 0.00103840437685403*x_73 + 0.00530060427312061*x_74 + 0.00165298359284422*x_75 + 0.000995296313490857*x_76 + 0.0056343683944016*x_77 - 0.000739280606530516*x_78 + 0.000273437353047816*x_79 + 0.00139725997102213*x_8 - 0.00108830333250068*x_80 + 0.00201004657471992*x_81 + 0.00118888938820067*x_82 - 0.0107264927839977*x_83 - 0.000300543883078122*x_84 + 0.000931314368206089*x_85 - 0.000347138377982692*x_86 - 0.00605098777248431*x_87 + 0.00457677216585915*x_88 - 0.00775418420384246*x_89 - 0.000416978709598831*x_9 + 0.00175648732363291*x_90 - 0.0012670782472589*x_91 - 0.015530397716003*x_92 - 0.0213255372370661*x_96 + 0.0379906510923667*x_97 - 0.0634223727502084*x_99 + 0.0206052355702433*std::exp(0.526799857616425*x_14) + 1.5200064603082*std::sin(0.262799948453903*x_102 + 1.76351988315582) - 0.826611150629795*std::sin(0.259119987487793*x_109 - 7.63520002365112) - 0.621871315002508*std::sin(0.334239840507507*x_120 + 4.82775974273682) + 0.646028512827314*std::sin(0.429599851369858*x_13 - 1.23991990089417) + 2.15647719348064*std::sin(0.186480015516281*x_30 + 4.79576015472412) + 0.220359731793778*std::sin(0.538479864597321*x_4 - 4.58392000198364) - 0.995051504833668*std::sin(0.29751992225647*x_44 - 4.45015954971313) + 0.167758183475261*std::sin(0.575759828090668*x_50 - 4.5734395980835) - 2.1989046196077*std::sin(0.234479993581772*x_57 + 1.76807987689972) - 1.25781000746612*std::sin(0.254879981279373*x_93 - 7.62007999420166) - 0.635446757876913*std::sin(0.331199824810028*x_94 + 1.63039982318878) + 1.19193533520651*std::sin(0.291839927434921*x_95 + 7.97679996490479) + 0.56610603669926*std::sin(0.328239858150482*x_98 + 7.83935976028442) - 0.748952361556378, 2) - 5.01925678841599e-7*std::exp(0.629279851913452*x_1) + 6.54019840362172e-5*std::exp(0.49567985534668*x_13) - 0.000330336603673412*std::exp(0.362639844417572*x_16) - 6.30888240560715e-6*std::exp(0.359759837388992*x_19) + 0.000178206955827466*std::exp(0.451119869947433*x_2) - 8.65633094419993e-5*std::exp(0.299999833106995*x_24) + 7.84467994557505e-6*std::exp(0.411119878292084*x_26) + 2.55220444148896e-5*std::exp(0.428639858961105*x_27) - 1.02265782372846e-5*std::exp(0.789199888706207*x_3) + 1.17801145186754e-6*std::exp(0.5655198097229*x_30) - 2.07975506993727e-5*std::exp(0.292399853467941*x_59) - 0.000158496351131472*std::exp(0.325199842453003*x_60) + 3.8101689037662e-5*std::log(4.99583959579468*x_24 + 9.18455982208252) - 5.54034572730717e-6*std::sin(0.278239965438843*x_10 - 1.21111989021301) - 0.000141825175904199*std::sin(0.324959933757782*x_10 + 4.96639966964722) - 0.000154971350412495*std::sin(0.254079967737198*x_100 + 1.78135991096497) + 0.00186754362023857*std::sin(0.295599937438965*x_101 - 1.60279989242554) + 0.000461158567920728*std::sin(0.247759968042374*x_104 + 4.57936000823975) - 0.00330418176372415*std::sin(0.222719997167587*x_105 + 1.78591990470886) - 0.00318493462096458*std::sin(0.265759944915771*x_105 - 4.62527990341187) + 8.08967730767743e-5*std::sin(0.284959942102432*x_107 - 7.83568000793457) - 0.000974128841129629*std::sin(0.256959974765778*x_109 + 7.99103975296021) + 0.00194896921250449*std::sin(0.271839946508408*x_109 + 1.74463987350464) - 3.16958775059792e-5*std::sin(1.23983979225159*x_109 - 5.41856002807617) - 0.00364268317111782*std::sin(0.130800053477287*x_11 + 4.94279956817627) + 0.00257420284939744*std::sin(0.259599983692169*x_11 + 1.96687984466553) - 0.000406813730857373*std::sin(0.277599930763245*x_11 + 7.97864007949829) + 0.00174174099117543*std::sin(0.219919994473457*x_110 + 1.97583973407745) + 0.000891588772597657*std::sin(0.226159989833832*x_111 + 8.16951942443848) - 1.06752305888041e-5*std::sin(0.314239919185638*x_111 - 2.16447973251343) + 0.00378716709968763*std::sin(0.243999972939491*x_112 + 1.78271985054016) + 0.00402322066291908*std::sin(0.273279964923859*x_112 + 4.96903991699219) - 0.00267305227535719*std::sin(0.25503996014595*x_114 + 8.14727973937988) - 0.00349754619936575*std::sin(0.222879990935326*x_115 + 4.98295974731445) + 0.000921546058438687*std::sin(0.266079962253571*x_115 + 1.5596798658371) + 0.000222631609726539*std::sin(0.327519834041595*x_116 + 1.41927993297577) - 0.00257103795084957*std::sin(0.252879977226257*x_117 - 1.39735984802246) - 6.24118244735666e-5*std::sin(0.298719942569733*x_117 + 7.94647979736328) - 0.00097069825081101*std::sin(0.359679847955704*x_118 - 8.16823959350586) + 0.00134905066517684*std::sin(0.2882399559021*x_119 - 1.63407981395721) - 9.44032297949643e-5*std::sin(0.31687992811203*x_119 + 4.7346396446228) + 0.00035085802114814*std::sin(0.323039829730988*x_119 - 8.13776016235352) + 0.000264524504745681*std::sin(0.373439848423004*x_120 + 4.61023998260498) - 4.88386049337915e-5*std::sin(0.467999845743179*x_13 - 10.0) - 0.000232874933337028*std::sin(0.470319837331772*x_13 + 1.72207987308502) - 0.00226212709803295*std::sin(0.148880034685135*x_15 - 1.42711985111237) - 0.00273733655776209*std::sin(0.338799834251404*x_15 + 1.84023988246918) + 4.74835100052663e-5*std::sin(0.589119851589203*x_16 - 4.59656000137329) - 0.000167019418640332*std::sin(0.797439873218536*x_16 + 7.98800039291382) - 0.00151149272111286*std::sin(0.239039987325668*x_17 - 4.38751983642578) - 5.55487640994654e-5*std::sin(0.420719861984253*x_17 - 1.38295984268188) + 5.44665381010202e-5*std::sin(0.189040005207062*x_20 + 1.59415984153748) + 0.000756579742638794*std::sin(0.194240003824234*x_20 + 7.61240005493164) - 0.00342740044869094*std::sin(0.274879962205887*x_20 - 7.58160018920898) + 0.00119444425442635*std::sin(0.192159995436668*x_21 - 1.5998398065567) + 0.00139087773789102*std::sin(0.35471984744072*x_21 - 1.15311980247498) - 1.88328114045127e-5*std::sin(1.03207981586456*x_21 + 3.58415985107422) - 0.000310848578799555*std::sin(0.359679847955704*x_22 - 1.39007985591888) - 0.000807699191169294*std::sin(0.501279830932617*x_22 - 7.46343994140625) + 0.00039680852999094*std::sin(0.550239861011505*x_23 + 8.02112007141113) + 0.000687184727130273*std::sin(0.284879922866821*x_24 - 4.38207960128784) + 5.08569946263317e-5*std::sin(0.54671984910965*x_24 + 8.00600051879883) - 0.00037585523447852*std::sin(0.255519956350327*x_26 + 7.79239988327026) - 1.01574905044263e-6*std::sin(0.547199845314026*x_26 - 4.34791994094849) + 0.00271273917360838*std::sin(0.378799855709076*x_27 - 1.19023990631104) - 5.19849985619163e-5*std::sin(0.430399864912033*x_27 - 7.43319988250732) - 4.84202614293378e-5*std::sin(0.422399878501892*x_28 + 1.96871984004974) - 0.00160106873024999*std::sin(0.213119998574257*x_29 - 1.81263983249664) - 0.000385822610331026*std::sin(0.250159978866577*x_29 + 2.00159978866577) - 8.16258718013724e-5*std::sin(0.349919855594635*x_29 + 4.61783981323242) + 0.00110204513983058*std::sin(0.397999823093414*x_29 - 4.60591983795166) + 3.37903371991215e-6*std::sin(0.536159813404083*x_31 - 7.41943979263306) - 0.00244309525231025*std::sin(0.215360000729561*x_32 - 4.59135961532593) - 0.0042351509514192*std::sin(0.250159978866577*x_32 + 5.01207971572876) + 0.00409854024654966*std::sin(0.219119995832443*x_33 - 4.39343976974487) + 0.00513263737039176*std::sin(0.235119983553886*x_33 + 8.20096015930176) + 0.00583374307138235*std::sin(0.217759996652603*x_34 + 8.19967937469482) + 0.00276201308379831*std::sin(0.231279984116554*x_35 - 1.20599985122681) - 0.00148488175639376*std::sin(0.249599978327751*x_35 + 8.18247985839844) + 0.00176822135296745*std::sin(0.256719976663589*x_35 - 1.22463989257813) + 0.000620897368770393*std::sin(0.240879982709885*x_36 - 1.20711994171143) - 0.000811230572218238*std::sin(0.258319973945618*x_37 - 7.43327951431274) + 0.00136406764866633*std::sin(0.277759939432144*x_38 - 1.41191983222961) - 0.000113110583235477*std::sin(0.289519935846329*x_38 + 1.55455982685089) + 1.8814004702722e-5*std::sin(0.726399838924408*x_4 + 5.0065598487854) - 0.00566763887100375*std::sin(0.226799994707108*x_40 - 1.39975988864899) - 0.00354017819242952*std::sin(0.236719980835915*x_40 + 8.16784000396729) - 0.000118123288766341*std::sin(0.213839992880821*x_41 + 1.59519982337952) + 9.46672870571022e-5*std::sin(0.218319997191429*x_41 + 1.57967984676361) - 0.00160511780012428*std::sin(0.350719839334488*x_41 + 1.61295986175537) - 0.00130940272045729*std::sin(0.307519912719727*x_42 + 1.74847984313965) - 0.000390501808333378*std::sin(0.457919865846634*x_43 + 4.92479991912842) - 0.00294814826989956*std::sin(0.46383985877037*x_43 + 4.89663982391357) - 0.000608384196282454*std::sin(0.489919871091843*x_43 + 7.90343999862671) + 0.00257424311237929*std::sin(0.279279947280884*x_44 + 1.93007981777191) - 0.00145487302237675*std::sin(0.292959928512573*x_44 - 7.64568042755127) - 4.95791096086284e-5*std::sin(0.340239852666855*x_44 + 8.0444803237915) + 2.48714165194567e-5*std::sin(0.557119846343994*x_44 + 7.60111999511719) - 0.00129311452003554*std::sin(0.169520020484924*x_45 - 7.79071998596191) + 0.000346227825227109*std::sin(0.58927983045578*x_45 - 7.79103994369507) + 0.000908125716374048*std::sin(0.268879950046539*x_46 - 1.40031981468201) + 7.337293311767e-5*std::sin(0.189680010080338*x_47 + 2.01359987258911) - 0.00018231534769505*std::sin(0.607679843902588*x_47 - 4.6101598739624) + 8.60469452262346e-5*std::sin(0.661439836025238*x_47 + 7.74631977081299) - 0.00345855647455462*std::sin(0.288879930973053*x_49 + 1.89487981796265) + 8.00555694651297e-5*std::sin(0.37407985329628*x_49 - 4.56288003921509) + 0.000174849038055856*std::sin(0.626239836215973*x_50 + 4.7673602104187) + 0.00123007637648485*std::sin(0.211119994521141*x_51 - 1.40071988105774) + 0.00217276105056502*std::sin(0.213199988007545*x_52 - 1.20551991462708) + 0.000775416143299795*std::sin(0.213359996676445*x_53 + 1.97695982456207) - 0.00409192661840191*std::sin(0.247039973735809*x_53 + 8.1988000869751) + 0.00198828586860169*std::sin(0.269999951124191*x_53 - 4.61583995819092) - 0.00178283535716154*std::sin(0.210720002651215*x_54 + 1.98495984077454) - 0.000312771717647984*std::sin(0.446799844503403*x_55 + 1.52711987495422) + 0.00135208202649907*std::sin(0.495999842882156*x_55 - 1.39999985694885) - 0.00166232332194112*std::sin(0.184000000357628*x_56 + 1.57647979259491) + 0.000339396993479405*std::sin(0.572159826755524*x_56 + 4.83112001419067) + 0.00283036795628174*std::sin(0.19080001115799*x_57 - 7.40759992599487) - 0.00656835713244063*std::sin(0.193999990820885*x_57 - 1.18895995616913) - 0.00120882930707892*std::sin(0.210400000214577*x_57 - 4.38695955276489) + 7.11504185521627e-6*std::sin(0.409359842538834*x_57 - 8.01327991485596) + 0.000727207757093697*std::sin(0.503999829292297*x_57 + 1.79999983310699) + 0.0034900611767252*std::sin(0.156560033559799*x_58 - 1.73479986190796) + 0.000191805981081062*std::sin(0.0999200716614723*x_59 - 7.80351972579956) - 0.0105357414762289*std::sin(0.106240063905716*x_59 - 1.25135982036591) + 0.00205411843500132*std::sin(0.146480038762093*x_59 - 7.96208000183105) + 0.00428015064966042*std::sin(0.350399851799011*x_59 + 8.05471992492676) + 0.00173011295327157*std::sin(0.356559842824936*x_59 - 1.33015990257263) - 0.000600266492680993*std::sin(0.434719860553741*x_59 - 1.43583977222443) - 0.00115111915069876*std::sin(0.568239867687225*x_59 - 1.55663979053497) + 0.000180934726536983*std::sin(0.23735998570919*x_6 - 7.57872009277344) + 2.67198635547306e-5*std::sin(0.428959846496582*x_6 - 1.40255987644196) + 0.000392799121839623*std::sin(0.588399827480316*x_6 - 8.19416046142578) + 0.000493615851543253*std::sin(0.580399870872498*x_60 - 4.56799983978271) - 8.94764711743011e-7*std::sin(0.985839784145355*x_64 + 5.59231996536255) + 3.72372434281508e-6*std::sin(1.30951976776123*x_65 + 8.57479953765869) + 1.82750170859329e-6*std::sin(0.747679829597473*x_7 + 7.62128019332886) + 0.00171694865611591*std::sin(0.301279932260513*x_8 + 4.78895998001099) - 0.00303210083136228*std::sin(0.346559852361679*x_8 - 1.35543990135193) - 0.00209263912593581*std::sin(0.225839987397194*x_9 + 4.99991989135742) - 0.000307887221862868*std::sin(0.20456001162529*x_91 + 7.79360008239746) - 1.81508572992339e-5*std::sin(0.287119954824448*x_92 + 1.81895983219147) - 0.00161434782764737*std::sin(0.339519828557968*x_92 + 1.80711996555328) - 9.40454904665968e-5*std::sin(0.43767985701561*x_92 + 4.59567975997925) + 0.000101140411899049*std::sin(0.255519956350327*x_93 - 4.41703987121582) + 8.79837940390329e-5*std::sin(0.289679944515228*x_93 + 1.5745598077774) - 8.21681176952454e-5*std::sin(0.19080001115799*x_94 + 4.79112005233765) + 0.00240349336628343*std::sin(0.290399938821793*x_94 - 1.39271986484528) + 9.40258882854817e-5*std::sin(0.249279975891113*x_95 + 5.17112016677856) + 0.00215253551687136*std::sin(0.26199996471405*x_95 - 7.79631996154785) + 0.000516551454871047*std::sin(0.296879917383194*x_95 - 4.83536005020142) - 0.000460138422505179*std::sin(0.422399878501892*x_96 + 4.39903974533081) - 0.00149465311054437*std::sin(0.279439955949783*x_97 + 8.17615985870361) - 0.000841904700848488*std::sin(0.330079853534698*x_97 - 1.55287981033325) + 3.03665631712388e-5*std::sin(0.244639977812767*x_98 - 7.41063976287842) + 0.00269114929420301*std::sin(0.277279943227768*x_98 + 8.17543983459473) - 0.00129078608644529*std::sin(0.306719928979874*x_98 + 4.77415990829468) - 7.32389136353322e-5*std::sin(0.36287984251976*x_98 - 1.97687971591949) + 0.0225088149309158*std::sin(0.000551229220679977*x_1 - 5.19241882699318e-5*x_100 + 0.00390811342578064*x_101 + 0.000941254133032761*x_102 + 0.000207558859375194*x_103 + 0.0113572551048892*x_104 - 0.000605334268611822*x_105 - 0.000182889289283471*x_106 + 0.00334906754729798*x_107 + 0.00733885410258197*x_108 - 0.000419179500071725*x_109 + 0.0120652288324546*x_110 - 0.0338330391115086*x_111 + 0.000130872098388129*x_113 - 0.0136143506546451*x_114 + 0.000264534073519312*x_115 - 0.0128152241732818*x_116 + 7.31011241680647e-5*x_117 - 0.000201242900433577*x_118 + 0.00241247377749745*x_12 + 0.00592370343869938*x_120 + 0.00171462127941831*x_13 + 0.00197783345913812*x_14 + 0.00555889303454036*x_15 - 0.0116027198837856*x_16 + 0.000898878592298399*x_17 + 0.0034860904742813*x_18 + 0.00647093651404602*x_19 - 7.58998282002161e-5*x_2 + 0.00240037882135479*x_20 + 0.000312248908153832*x_21 + 0.00475817340260441*x_22 + 0.00238947819283265*x_24 - 0.0120400122357096*x_25 + 0.00331138914139464*x_26 + 0.000940725626438218*x_27 + 0.00154457606747499*x_3 + 0.00113204047725591*x_30 + 7.68577859397657e-5*x_31 + 0.000268122230033134*x_32 + 0.00356943495927756*x_33 - 0.000553187057455326*x_34 + 0.000716347150811533*x_35 + 0.00906715720309459*x_36 - 0.0117808989436402*x_37 - 0.011141729681082*x_38 - 0.0368145802115443*x_39 - 0.00202286450533067*x_40 - 0.0506266970165885*x_41 + 0.000219814561854827*x_42 - 0.000572220368005189*x_44 + 0.00046529984485964*x_45 + 0.00358793076237401*x_46 + 0.000344486695990549*x_47 - 0.00383890641433127*x_50 + 0.00235120399812443*x_51 - 0.000335958577085269*x_52 + 0.00190440411842964*x_53 - 0.0245195567004121*x_54 + 0.00229690337797912*x_55 + 0.00239132203204798*x_56 - 0.0209780274683769*x_58 + 0.000349480214984223*x_6 + 5.96686451609262e-5*x_60 - 5.40348533880351e-5*x_61 + 8.56577007996864e-6*x_62 + 0.000353857401812039*x_63 + 0.00252413958409093*x_64 + 0.00017033671905406*x_65 - 0.000166477073639344*x_66 + 0.000144658236528234*x_67 - 0.000885704634130514*x_68 - 0.000646348828702341*x_69 - 0.00176152995581116*x_7 - 0.000211907357784041*x_70 - 0.00141364041122208*x_71 + 8.10901189689843e-5*x_72 - 0.00150384923250685*x_73 + 0.00132611407675102*x_74 + 0.000357526676391508*x_75 - 0.000114695157550926*x_76 + 0.000502465087259934*x_77 + 0.0012882340676067*x_78 - 0.000580803808670105*x_79 + 0.00249688155746252*x_8 - 0.000742901203246987*x_80 + 0.00197872137242371*x_81 + 0.000345716787717915*x_82 - 0.00272594132658461*x_83 - 0.000107038704782826*x_84 - 0.000645551158215534*x_85 - 7.2117514264568e-5*x_86 - 0.000183059141629481*x_87 - 6.38935038849213e-5*x_88 - 0.000322902097342492*x_89 + 0.0024793599752399*x_9 - 0.000272474698371708*x_90 - 0.000319943945088938*x_91 - 0.000245429068481008*x_92 + 0.0108496814850649*x_93 - 0.000578329737991511*x_94 + 0.00115268419482539*x_96 - 7.10390716170815e-5*x_97 + 0.00138982915717878*x_98 - 0.000482648086057757*x_99 + 9.59618395317193e-6*std::pow(1.38503980636597 - 7.12336015701294*x_10, 2) + 0.0195474872495678*std::sin(0.491999864578247*x_11 - 7.40000009536743) - 0.0194463565762032*std::sin(0.219359993934631*x_112 + 4.78791999816895) + 0.0974044648410768*std::sin(0.349839836359024*x_119 - 4.97839975357056) - 0.00695756082239923*std::sin(0.398959845304489*x_23 + 2.00783967971802) + 0.00444122787208012*std::sin(0.532399833202362*x_28 - 7.56040000915527) - 0.0569266695565842*std::sin(0.704639852046967*x_29 - 1.58823990821838) - 0.0112956972687195*std::sin(1.04535984992981*x_4 + 3.9663200378418) - 0.402142640728798*std::sin(0.249279975891113*x_43 - 1.22215986251831) + 0.249272736913348*std::sin(0.218559995293617*x_48 - 4.41095972061157) + 0.0797403579741212*std::sin(0.211199998855591*x_49 + 1.38191986083984) - 0.0174215064175669*std::sin(0.647999823093414*x_5 + 9.99600028991699) + 0.131897437383828*std::sin(0.522399842739105*x_57 + 1.65279984474182) - 0.0997250314766225*std::sin(0.561039865016937*x_59 - 4.54360008239746) + 0.131848161665269*std::sin(0.306639939546585*x_95 - 4.60048007965088) - 5.60617978266291) + 0.045882436328983);
}

inline float score_11(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.000154946713502088*x_1 + 9.88557923096621e-5*x_10 - 0.000119869094298552*x_100 + 0.00249942393186124*x_101 - 0.000150197766464838*x_102 - 0.000679881290756452*x_103 - 7.33014970141119e-5*x_104 + 0.00150166178169155*x_105 + 0.00110554607643585*x_106 + 5.68595013979478e-5*x_107 - 0.00027023628077572*x_108 - 0.000144253316444712*x_109 - 0.000419075113543996*x_11 - 0.00096803677634677*x_110 - 0.000268803310654479*x_111 + 0.0014984588962867*x_112 + 5.45460411358517e-5*x_113 - 0.000773167243011815*x_114 + 1.82536535700233e-5*x_115 + 0.001255989981391*x_116 + 2.14123694154151e-5*x_117 + 0.000324744548768635*x_118 - 0.000716838583274749*x_119 - 0.00137093959770343*x_12 - 0.000961627040263227*x_120 - 5.33317409566241e-5*x_13 - 0.00133918493198324*x_14 + 7.62744409212101e-5*x_15 - 0.000132903415970497*x_16 - 0.000116559744980859*x_17 - 0.000197271761812928*x_18 - 0.000293983791418721*x_19 + 1.25207131470989e-7*x_2 + 0.00148104128966093*x_20 - 5.3958304453965e-5*x_21 + 1.86721383310836e-5*x_22 + 0.000365001932503274*x_23 + 8.84048324934122e-5*x_24 - 0.000186520370172956*x_25 - 0.000153539542770448*x_26 + 0.00102849863810813*x_27 + 0.000364157771156014*x_28 - 0.000116592289510122*x_29 - 0.000321422395254527*x_3 + 0.000352281294527041*x_30 - 2.19592230016167e-5*x_31 + 0.000768695802915278*x_32 + 1.50305963079086e-5*x_33 - 0.00111495052580672*x_34 + 9.34808218610821e-5*x_35 - 0.000306612727070263*x_36 - 0.000275460999516824*x_37 - 0.0004741134890201*x_38 - 0.00167287832473091*x_39 - 0.000144443311144645*x_4 - 0.000236285405862574*x_40 + 0.00127575802519782*x_41 - 0.000597715922846601*x_42 - 0.00226826140288235*x_43 - 1.80161540615256e-5*x_44 + 0.000168294125548168*x_45 - 0.000697347953044798*x_46 - 0.000806630210599373*x_47 - 0.00229953452697608*x_48 - 0.000106943508667403*x_49 - 0.000115077068932685*x_5 - 0.00104436454644325*x_50 - 0.00109070844663236*x_51 - 7.21258118216182e-5*x_52 + 0.000300552412670149*x_53 - 0.000999544545097484*x_54 + 0.00010211359198938*x_55 + 0.001121936504558*x_56 + 0.000133479642980657*x_57 + 0.000889638300966079*x_58 + 0.000117381151506092*x_59 - 0.000107819986960238*x_6 - 0.000457516372865343*x_60 + 0.000201015846951927*x_61 - 2.87065749135866e-5*x_62 + 3.54080712902865e-5*x_63 + 7.6260737834217e-6*x_64 + 7.75508673042019e-6*x_65 + 2.85110663073745e-5*x_66 - 4.55932546766098e-5*x_67 - 2.40962414658032e-6*x_68 + 7.13335281118352e-5*x_69 + 0.000210176902073367*x_7 - 3.97369316356085e-5*x_70 + 8.92485071781801e-5*x_71 + 1.64598790003237e-5*x_72 + 3.49624282362977e-5*x_73 + 3.78238359155857e-5*x_74 + 7.6491090247148e-6*x_75 + 3.80227951606478e-5*x_76 + 0.00010171395851094*x_77 - 7.15774757290999e-5*x_78 + 3.98297637504326e-5*x_79 - 2.44663285780929e-5*x_8 - 1.69152834860644e-5*x_80 + 2.2798188526672e-6*x_81 - 5.58705191083696e-5*x_82 - 2.02875403833953e-5*x_83 + 3.3375184236403e-7*x_84 - 1.98886873028815e-5*x_85 - 2.91802921728252e-5*x_86 - 2.22531305961927e-5*x_87 - 2.33887432357646e-6*x_88 - 0.000114773993236375*x_89 - 0.000503959475265394*x_9 + 2.99121013425352e-5*x_90 - 2.5990707467024e-5*x_91 - 6.30447320288327e-5*x_92 + 7.46539736866195e-5*x_93 - 0.000432534289242887*x_94 - 3.60029682104862e-5*x_95 + 0.00154290540240868*x_96 + 0.000232324447834332*x_97 - 8.40284098315679e-5*x_98 - 0.000492747823122399*x_99 + 1.0924519615997e-8*std::pow(0.814879834651947 - 5.53343963623047*x_19, 2) + 7.76936480310103e-7*std::pow(0.817359864711761 - 6.45175981521606*x_23, 2) + 9.44955668559125e-7*std::pow(2.25367975234985 - 5.73983955383301*x_4, 2) + 4.09269370541212e-7*std::pow(2.6431999206543 - 7.30952024459839*x_59, 2) - 1.16286147989815e-7*std::pow(5.20296001434326 - 9.00399971008301*x_15, 2) - 3.14322948936534e-7*std::pow(7.96920013427734 - 7.90776014328003*x_27, 2) - 1.55891497732788e-7*std::pow(-8.08119964599609*x_14 - 7.46519994735718, 2) - 4.9385647188473e-7*std::pow(-6.89904022216797*x_22 - 1.4171998500824, 2) - 2.06975459688492e-6*std::pow(-4.69047975540161*x_26 - 6.72648000717163, 2) - 1.03178763878913e-5*std::pow(-2.57999992370605*x_28 - 7.52744007110596, 2) - 7.12409432963729e-7*std::pow(-4.49319982528687*x_42 - 6.96000003814697, 2) - 4.43223336891675e-7*std::pow(-3.42927980422974*x_42 - 6.80200004577637, 2) + 1.53430168313873e-6*std::pow(-5.76231956481934*x_5 - 1.65471994876862, 2) + 4.1701038495268e-6*std::pow(-2.19055986404419*x_52 - 3.38007998466492, 2) - 1.39387860988631e-7*std::pow(-8.52272033691406*x_57 - 2.62191987037659, 2) - 1.58395454842973e-6*std::pow(-6.33992004394531*x_60 - 9.99560070037842, 2) - 6.11536914167292e-7*std::pow(-5.4445595741272*x_9 - 8.69223976135254, 2) - 1.03651727603627e-5*std::exp(0.629279851913452*x_1) - 1.98602774067692e-5*std::exp(0.49567985534668*x_13) + 0.000141832362778503*std::exp(0.526799857616425*x_14) - 0.00037172952150883*std::exp(0.362639844417572*x_16) + 2.47063750052111e-5*std::exp(0.359759837388992*x_19) - 5.41151714386743e-5*std::exp(0.451119869947433*x_2) - 4.40144017590004e-5*std::exp(0.299999833106995*x_24) + 5.97081257586403e-5*std::exp(0.411119878292084*x_26) - 9.99475278939255e-5*std::exp(0.428639858961105*x_27) + 6.91739040908533e-8*std::exp(0.789199888706207*x_3) + 8.96618554245803e-6*std::exp(0.5655198097229*x_30) - 0.000158296167752553*std::exp(0.292399853467941*x_59) + 0.000244055716611253*std::exp(0.325199842453003*x_60) - 5.86697104116439e-5*std::log(4.99583959579468*x_24 + 9.18455982208252) - 0.000114412637241856*std::sin(0.278239965438843*x_10 - 1.21111989021301) + 0.000555405182058065*std::sin(0.324959933757782*x_10 + 4.96639966964722) - 0.00320028420071958*std::sin(0.254079967737198*x_100 + 1.78135991096497) - 0.0013672412612258*std::sin(0.295599937438965*x_101 - 1.60279989242554) + 0.0104626859018023*std::sin(0.262799948453903*x_102 + 1.76351988315582) - 0.000389155424234289*std::sin(0.247759968042374*x_104 + 4.57936000823975) + 0.00100336354312448*std::sin(0.222719997167587*x_105 + 1.78591990470886) + 0.00233171208473997*std::sin(0.265759944915771*x_105 - 4.62527990341187) + 0.00167058404071262*std::sin(0.284959942102432*x_107 - 7.83568000793457) + 0.000295808595104021*std::sin(0.256959974765778*x_109 + 7.99103975296021) - 0.00568982636443093*std::sin(0.259119987487793*x_109 - 7.63520002365112) - 0.0087501920772028*std::sin(0.271839946508408*x_109 + 1.74463987350464) + 2.14395034174815e-7*std::sin(1.23983979225159*x_109 - 5.41856002807617) + 0.0163543770825993*std::sin(0.130800053477287*x_11 + 4.94279956817627) + 0.00289676403653779*std::sin(0.259599983692169*x_11 + 1.96687984466553) + 0.00159313360840239*std::sin(0.277599930763245*x_11 + 7.97864007949829) - 0.00146979369240221*std::sin(0.219919994473457*x_110 + 1.97583973407745) - 0.00137288546559897*std::sin(0.226159989833832*x_111 + 8.16951942443848) - 0.000220452178428158*std::sin(0.314239919185638*x_111 - 2.16447973251343) + 0.00426171910162487*std::sin(0.243999972939491*x_112 + 1.78271985054016) - 0.00294542694143683*std::sin(0.273279964923859*x_112 + 4.96903991699219) + 0.00195695957228296*std::sin(0.25503996014595*x_114 + 8.14727973937988) + 0.0157027626947547*std::sin(0.222879990935326*x_115 + 4.98295974731445) - 0.00141901426800651*std::sin(0.266079962253571*x_115 + 1.5596798658371) - 0.000871853314785051*std::sin(0.327519834041595*x_116 + 1.41927993297577) + 0.00188227419830221*std::sin(0.252879977226257*x_117 - 1.39735984802246) + 0.000280207326277154*std::sin(0.298719942569733*x_117 + 7.94647979736328) + 0.000710654726521985*std::sin(0.359679847955704*x_118 - 8.16823959350586) + 0.00151809382514916*std::sin(0.2882399559021*x_119 - 1.63407981395721) - 0.00194950333726565*std::sin(0.31687992811203*x_119 + 4.7346396446228) - 0.00029607668937288*std::sin(0.323039829730988*x_119 - 8.13776016235352) - 0.00428053722804095*std::sin(0.334239840507507*x_120 + 4.82775974273682) - 0.0010359111475126*std::sin(0.373439848423004*x_120 + 4.61023998260498) + 0.00444681887203962*std::sin(0.429599851369858*x_13 - 1.23991990089417) + 7.5202619115965e-5*std::sin(0.467999845743179*x_13 - 10.0) - 0.000118408722374047*std::sin(0.470319837331772*x_13 + 1.72207987308502) + 0.00190892914442873*std::sin(0.148880034685135*x_15 - 1.42711985111237) + 0.000831232632984662*std::sin(0.338799834251404*x_15 + 1.84023988246918) - 4.0069656655298e-5*std::sin(0.589119851589203*x_16 - 4.59656000137329) + 5.07179107086023e-5*std::sin(0.797439873218536*x_16 + 7.98800039291382) + 0.00678607519717346*std::sin(0.239039987325668*x_17 - 4.38751983642578) - 0.000422797694182384*std::sin(0.420719861984253*x_17 - 1.38295984268188) - 0.00021329779651043*std::sin(0.189040005207062*x_20 + 1.59415984153748) - 0.00339677919350142*std::sin(0.194240003824234*x_20 + 7.61240005493164) + 0.00250922295008854*std::sin(0.274879962205887*x_20 - 7.58160018920898) + 0.0013441144161119*std::sin(0.192159995436668*x_21 - 1.5998398065567) - 0.00624455598598826*std::sin(0.35471984744072*x_21 - 1.15311980247498) + 2.89991236411515e-5*std::sin(1.03207981586456*x_21 + 3.58415985107422) - 0.000158055581766606*std::sin(0.359679847955704*x_22 - 1.39007985591888) + 0.0036262876899172*std::sin(0.501279830932617*x_22 - 7.46343994140625) + 0.000201763197052003*std::sin(0.550239861011505*x_23 + 8.02112007141113) - 0.000208673781256309*std::sin(0.284879922866821*x_24 - 4.38207960128784) + 0.00105023822768216*std::sin(0.54671984910965*x_24 + 8.00600051879883) - 0.000191109182403029*std::sin(0.255519956350327*x_26 + 7.79239988327026) + 1.57821024359789e-5*std::sin(0.547199845314026*x_26 - 4.34791994094849) - 0.000823763274371583*std::sin(0.378799855709076*x_27 - 1.19023990631104) + 4.38683038252884e-5*std::sin(0.430399864912033*x_27 - 7.43319988250732) + 7.45584457767035e-5*std::sin(0.422399878501892*x_28 + 1.96871984004974) + 0.00117215319970761*std::sin(0.213119998574257*x_29 - 1.81263983249664) + 0.000594097043729766*std::sin(0.250159978866577*x_29 + 2.00159978866577) + 0.000319657154658586*std::sin(0.349919855594635*x_29 + 4.61783981323242) - 0.00494779834868385*std::sin(0.397999823093414*x_29 - 4.60591983795166) + 0.0148437155492176*std::sin(0.186480015516281*x_30 + 4.79576015472412) - 1.32327199767118e-5*std::sin(0.536159813404083*x_31 - 7.41943979263306) + 0.000741881919288159*std::sin(0.215360000729561*x_32 - 4.59135961532593) + 0.0031005825328783*std::sin(0.250159978866577*x_32 + 5.01207971572876) - 0.0184010163748921*std::sin(0.219119995832443*x_33 - 4.39343976974487) + 0.00577578388999957*std::sin(0.235119983553886*x_33 + 8.20096015930176) + 0.00656474183125761*std::sin(0.217759996652603*x_34 + 8.19967937469482) - 0.012400475516966*std::sin(0.231279984116554*x_35 - 1.20599985122681) + 0.00125303925817226*std::sin(0.249599978327751*x_35 + 8.18247985839844) - 0.000536946502525971*std::sin(0.256719976663589*x_35 - 1.22463989257813) - 0.00243151199314737*std::sin(0.240879982709885*x_36 - 1.20711994171143) + 0.000684568821754343*std::sin(0.258319973945618*x_37 - 7.43327951431274) - 0.000998643111812088*std::sin(0.277759939432144*x_38 - 1.41191983222961) + 0.000442955234668842*std::sin(0.289519935846329*x_38 + 1.55455982685089) + 0.00151680582903326*std::sin(0.538479864597321*x_4 - 4.58392000198364) - 2.89701647215937e-5*std::sin(0.726399838924408*x_4 + 5.0065598487854) - 0.00637782389894034*std::sin(0.226799994707108*x_40 - 1.39975988864899) + 0.00259178829577382*std::sin(0.236719980835915*x_40 + 8.16784000396729) - 0.00243934181233977*std::sin(0.213839992880821*x_41 + 1.59519982337952) + 0.000720540075573525*std::sin(0.218319997191429*x_41 + 1.57967984676361) - 0.00180624752198337*std::sin(0.350719839334488*x_41 + 1.61295986175537) + 0.0009586225497329*std::sin(0.307519912719727*x_42 + 1.74847984313965) + 0.0015292540733241*std::sin(0.457919865846634*x_43 + 4.92479991912842) + 0.00215835920250323*std::sin(0.46383985877037*x_43 + 4.89663982391357) + 4.11518976020741e-6*std::sin(0.489919871091843*x_43 + 7.90343999862671) - 0.0115574538285238*std::sin(0.279279947280884*x_44 + 1.93007981777191) + 9.84095017699503e-6*std::sin(0.292959928512573*x_44 - 7.64568042755127) - 0.00684925467295675*std::sin(0.29751992225647*x_44 - 4.45015954971313) - 0.00102384886460565*std::sin(0.340239852666855*x_44 + 8.0444803237915) - 3.82974834339114e-5*std::sin(0.557119846343994*x_44 + 7.60111999511719) - 0.000657503304484644*std::sin(0.169520020484924*x_45 - 7.79071998596191) - 0.00155444219117054*std::sin(0.58927983045578*x_45 - 7.79103994369507) - 0.00355633423768881*std::sin(0.268879950046539*x_46 - 1.40031981468201) + 0.00151521063726887*std::sin(0.189680010080338*x_47 + 2.01359987258911) + 5.53627452453151e-5*std::sin(0.607679843902588*x_47 - 4.6101598739624) - 0.000336970632852939*std::sin(0.661439836025238*x_47 + 7.74631977081299) + 0.00253203248644154*std::sin(0.288879930973053*x_49 + 1.89487981796265) + 0.00165321250319444*std::sin(0.37407985329628*x_49 - 4.56288003921509) + 0.00115473271133511*std::sin(0.575759828090668*x_50 - 4.5734395980835) - 0.000128008158269988*std::sin(0.626239836215973*x_50 + 4.7673602104187) - 0.00552261395142342*std::sin(0.211119994521141*x_51 - 1.40071988105774) - 0.00975493938453633*std::sin(0.213199988007545*x_52 - 1.20551991462708) + 0.000394271867395272*std::sin(0.213359996676445*x_53 + 1.97695982456207) + 0.00124257389079515*std::sin(0.247039973735809*x_53 + 8.1988000869751) + 0.00223742856934132*std::sin(0.269999951124191*x_53 - 4.61583995819092) + 0.000541384260517496*std::sin(0.210720002651215*x_54 + 1.98495984077454) + 0.00140423593568192*std::sin(0.446799844503403*x_55 + 1.52711987495422) + 0.00152150503202514*std::sin(0.495999842882156*x_55 - 1.39999985694885) - 0.00187062119724723*std::sin(0.184000000357628*x_56 + 1.57647979259491) - 0.000286405133004108*std::sin(0.572159826755524*x_56 + 4.83112001419067) - 0.0127073650562184*std::sin(0.19080001115799*x_57 - 7.40759992599487) - 0.00739140690674174*std::sin(0.193999990820885*x_57 - 1.18895995616913) + 0.00473392722480254*std::sin(0.210400000214577*x_57 - 4.38695955276489) - 0.0151357569613965*std::sin(0.234479993581772*x_57 + 1.76807987689972) + 0.000146931390712533*std::sin(0.409359842538834*x_57 - 8.01327991485596) - 0.000613664936323832*std::sin(0.503999829292297*x_57 + 1.79999983310699) + 0.00287051087962097*std::sin(0.156560033559799*x_58 - 1.73479986190796) + 0.00396094922850816*std::sin(0.0999200716614723*x_59 - 7.80351972579956) + 0.0473018049753018*std::sin(0.106240063905716*x_59 - 1.25135982036591) + 0.00231151030335234*std::sin(0.146480038762093*x_59 - 7.96208000183105) - 0.00313352711500819*std::sin(0.350399851799011*x_59 + 8.05471992492676) - 0.000525374324699239*std::sin(0.356559842824936*x_59 - 1.33015990257263) + 0.000924301840283144*std::sin(0.434719860553741*x_59 - 1.43583977222443) + 7.78631951763406e-6*std::sin(0.568239867687225*x_59 - 1.55663979053497) - 0.000708563088973574*std::sin(0.23735998570919*x_6 - 7.57872009277344) + 0.000203372602126296*std::sin(0.428959846496582*x_6 - 1.40255987644196) - 2.65694430244932e-6*std::sin(0.588399827480316*x_6 - 8.19416046142578) + 0.000250986319082374*std::sin(0.580399870872498*x_60 - 4.56799983978271) - 1.84776177192148e-5*std::sin(0.985839784145355*x_64 + 5.59231996536255) - 1.67182236810796e-5*std::sin(1.30951976776123*x_65 + 8.57479953765869) - 2.83946306958175e-5*std::sin(0.747679829597473*x_7 + 7.62128019332886) - 0.000521376791639206*std::sin(0.301279932260513*x_8 + 4.78895998001099) - 0.0034120390494877*std::sin(0.346559852361679*x_8 - 1.35543990135193) + 0.00939521988481173*std::sin(0.225839987397194*x_9 + 4.99991989135742) + 0.000474090640136316*std::sin(0.20456001162529*x_91 + 7.79360008239746) + 7.10810343686839e-5*std::sin(0.287119954824448*x_92 + 1.81895983219147) + 0.00724785875564312*std::sin(0.339519828557968*x_92 + 1.80711996555328) - 7.73506795135792e-5*std::sin(0.43767985701561*x_92 + 4.59567975997925) - 0.00865790467074281*std::sin(0.254879981279373*x_93 - 7.62007999420166) - 6.84126888787381e-7*std::sin(0.255519956350327*x_93 - 4.41703987121582) + 0.0018169367772366*std::sin(0.289679944515228*x_93 + 1.5745598077774) - 4.17796011651173e-5*std::sin(0.19080001115799*x_94 + 4.79112005233765) - 0.000729856222301836*std::sin(0.290399938821793*x_94 - 1.39271986484528) - 0.00437398130112993*std::sin(0.331199824810028*x_94 + 1.63039982318878) - 6.88369860249343e-5*std::sin(0.249279975891113*x_95 + 5.17112016677856) + 0.00242225956439401*std::sin(0.26199996471405*x_95 - 7.79631996154785) + 0.00820446843692791*std::sin(0.291839927434921*x_95 + 7.97679996490479) + 0.000424854034358989*std::sin(0.296879917383194*x_95 - 4.83536005020142) - 0.000517796192500616*std::sin(0.422399878501892*x_96 + 4.39903974533081) + 0.00671047121839628*std::sin(0.279439955949783*x_97 + 8.17615985870361) + 0.000710453635288099*std::sin(0.330079853534698*x_97 - 1.55287981033325) - 0.000118919271131328*std::sin(0.244639977812767*x_98 - 7.41063976287842) - 0.0120823218148454*std::sin(0.277279943227768*x_98 + 8.17543983459473) + 0.00108924877907219*std::sin(0.306719928979874*x_98 + 4.77415990829468) + 0.00389668715480168*std::sin(0.328239858150482*x_98 + 7.83935976028442) + 0.000112774681710331*std::sin(0.36287984251976*x_98 - 1.97687971591949) - 0.0425364561378956*std::sin(0.000442588947299061*x_1 - 4.16905907081607e-5*x_100 + 0.00313787394091318*x_101 + 0.000755744906567127*x_102 + 0.000166651646224671*x_103 + 0.00911888447219682*x_104 - 0.000486030577948069*x_105 - 0.000146844134852637*x_106 + 0.00268900889971616*x_107 + 0.00589245923435701*x_108 - 0.000336564548296687*x_109 + 0.00968732557626606*x_110 - 0.027164977113911*x_111 + 0.00010507887115449*x_113 - 0.0109311351763369*x_114 + 0.000212397769804763*x_115 - 0.0102895063677097*x_116 + 5.86938216954667e-5*x_117 - 0.00016158048251585*x_118 + 0.00193700585802049*x_12 + 0.00475621678003874*x_120 + 0.00137669121774459*x_13 + 0.00158802762221672*x_14 + 0.00446330586987089*x_15 - 0.00931597126298186*x_16 + 0.000721721046326709*x_17 + 0.00279902634932555*x_18 + 0.00519559717145944*x_19 - 6.09409367338596e-5*x_2 + 0.00192729466400903*x_20 + 0.000250708616978994*x_21 + 0.00382039790040029*x_22 + 0.00191854241082376*x_24 - 0.00966707885024152*x_25 + 0.00265875642873123*x_26 + 0.000755320561905153*x_27 + 0.00124015975583405*x_3 + 0.000908929687200852*x_30 + 6.17100931783986e-5*x_31 + 0.000215278746274475*x_32 + 0.00286594469562108*x_33 - 0.000444160919329709*x_34 + 0.000575164232018142*x_35 + 0.00728013576015147*x_36 - 0.00945903349475992*x_37 - 0.00894583637013624*x_38 - 0.0295588943579313*x_39 - 0.00162418362154047*x_40 - 0.0406488184899925*x_41 + 0.00017649190551314*x_42 - 0.000459443006279832*x_44 + 0.000373595159307426*x_45 + 0.00288079521100524*x_46 + 0.000276592746569044*x_47 - 0.00308230675181296*x_50 + 0.00188781157343503*x_51 - 0.000269745411509278*x_52 + 0.00152907027128939*x_53 - 0.0196870637135097*x_54 + 0.00184421291537015*x_55 + 0.00192002285276458*x_56 - 0.0168435248809678*x_58 + 0.00028060210643571*x_6 + 4.79087135764658e-5*x_60 - 4.33852705576249e-5*x_61 + 6.87756566646181e-6*x_62 + 0.000284116605372949*x_63 + 0.00202666375338486*x_64 + 0.000136765516674742*x_65 - 0.000133666558315931*x_66 + 0.000116147936686288*x_67 - 0.000711143507875294*x_68 - 0.000518961689531749*x_69 - 0.00141435479022047*x_7 - 0.000170143110865695*x_70 - 0.00113502985326213*x_71 + 6.51082871596796e-5*x_72 - 0.00120745966240806*x_73 + 0.0010647538468728*x_74 + 0.000287062712568563*x_75 - 9.20901997505595e-5*x_76 + 0.000403435604793552*x_77 + 0.00103433950608335*x_78 - 0.000466334759883538*x_79 + 0.00200477793736074*x_8 - 0.000596484818215357*x_80 + 0.00158874053907892*x_81 + 0.000277580402851171*x_82 - 0.00218869293729354*x_83 - 8.59427365110415e-5*x_84 - 0.000518321229759656*x_85 - 5.79040688024606e-5*x_86 - 0.000146980511460039*x_87 - 5.13009063430859e-5*x_88 - 0.000259262197978511*x_89 + 0.00199070963629834*x_9 - 0.000218773398422534*x_90 - 0.000256887059936598*x_91 - 0.000197058118438648*x_92 + 0.0087113471616789*x_93 - 0.000464348297090742*x_94 + 0.000925504790414982*x_96 - 5.70381734939995e-5*x_97 + 0.0011159114947544*x_98 - 0.000387524282658131*x_99 + 7.70489806161464e-6*std::pow(1.38503980636597 - 7.12336015701294*x_10, 2) + 0.0156949259574009*std::sin(0.491999864578247*x_11 - 7.40000009536743) - 0.0156137268544054*std::sin(0.219359993934631*x_112 + 4.78791999816895) + 0.0782072828125138*std::sin(0.349839836359024*x_119 - 4.97839975357056) - 0.0055863140135356*std::sin(0.398959845304489*x_23 + 2.00783967971802) + 0.00356591830562691*std::sin(0.532399833202362*x_28 - 7.56040000915527) - 0.0457071465137684*std::sin(0.704639852046967*x_29 - 1.58823990821838) - 0.00906945890314814*std::sin(1.04535984992981*x_4 + 3.9663200378418) - 0.322885437395115*std::sin(0.249279975891113*x_43 - 1.22215986251831) + 0.200144248675244*std::sin(0.218559995293617*x_48 - 4.41095972061157) + 0.0640245469017069*std::sin(0.211199998855591*x_49 + 1.38191986083984) - 0.0139879489265886*std::sin(0.647999823093414*x_5 + 9.99600028991699) + 0.105902128865994*std::sin(0.522399842739105*x_57 + 1.65279984474182) - 0.0800704952581395*std::sin(0.561039865016937*x_59 - 4.54360008239746) + 0.105862564765278*std::sin(0.306639939546585*x_95 - 4.60048007965088) - 3.19388483067184) + 0.0916900380492725);
}

int predict(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120)
{
    float s0 = score_0(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s1 = score_1(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s2 = score_2(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s3 = score_3(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s4 = score_4(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s5 = score_5(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s6 = score_6(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s7 = score_7(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s8 = score_8(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s9 = score_9(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s10 = score_10(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s11 = score_11(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);

    float max_score = s0;
    int max_index = 0;

    if(s1 > max_score) {
        max_score = s1;
        max_index = 1;
    }

    if(s2 > max_score) {
        max_score = s2;
        max_index = 2;
    }

    if(s3 > max_score) {
        max_score = s3;
        max_index = 3;
    }

    if(s4 > max_score) {
        max_score = s4;
        max_index = 4;
    }

    if(s5 > max_score) {
        max_score = s5;
        max_index = 5;
    }

    if(s6 > max_score) {
        max_score = s6;
        max_index = 6;
    }

    if(s7 > max_score) {
        max_score = s7;
        max_index = 7;
    }

    if(s8 > max_score) {
        max_score = s8;
        max_index = 8;
    }

    if(s9 > max_score) {
        max_score = s9;
        max_index = 9;
    }

    if(s10 > max_score) {
        max_score = s10;
        max_index = 10;
    }

    if(s11 > max_score) {
        max_score = s11;
        max_index = 11;
    }

    return max_index;
}

#endif
