
#ifndef KAN_MODEL_H
#define KAN_MODEL_H

#include <cmath>


inline float score_0(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.00033371138707946*x_1 + 0.000158551130209814*x_10 - 0.000378250832398285*x_100 - 0.00943174475380552*x_101 + 0.000163526010901228*x_102 - 0.00530321754746691*x_103 + 0.00492264486038369*x_104 + 9.06500398315682e-5*x_105 + 0.00203480398780776*x_106 - 0.000116794360456315*x_107 + 0.000591621305447642*x_108 - 0.000623272448926974*x_109 + 0.00418449066698625*x_11 + 0.00111484077923677*x_110 - 0.00102241187628828*x_111 - 0.00861696525918343*x_112 - 0.00390049115678349*x_113 - 0.0028234079739364*x_114 + 0.000972011175310468*x_115 + 0.00217268605458698*x_116 - 0.000210226068465041*x_117 - 0.00577383631118955*x_118 + 0.000601870422330426*x_119 - 0.00758133585035064*x_12 + 5.82864271542165e-5*x_120 - 0.00290206425836505*x_13 - 0.000119448966174113*x_14 + 0.00239226672681984*x_15 + 0.00248058988100506*x_16 - 0.0019494112114244*x_17 + 0.00174509063565817*x_18 - 0.00915683520120401*x_19 + 0.00669650506234201*x_2 - 0.00491961394342842*x_20 + 0.0109704543253922*x_21 - 0.01352959888461*x_22 + 0.000912616074943025*x_23 - 0.00107683558949655*x_24 - 0.00118443790648757*x_25 + 0.000165492473983285*x_26 + 0.000113491054918552*x_27 - 0.00178007849063155*x_28 + 0.00213077412931015*x_29 + 0.00358440553741756*x_3 + 0.00156422420812241*x_30 + 0.00683053455084172*x_32 + 0.00502824481880542*x_33 - 0.0111261844704144*x_34 + 0.00212191504309963*x_35 - 0.00251402406700093*x_36 + 0.00160381740390273*x_37 - 0.00371068534309029*x_38 - 0.00510084061820947*x_39 + 0.0019032312671468*x_4 + 2.47075027239158e-5*x_40 + 0.000954478164990702*x_41 - 0.00538821823611893*x_42 + 0.00210714350267153*x_43 + 0.00332083855176165*x_44 + 0.00256302824519133*x_45 - 0.000204864916145163*x_46 + 0.00117428407047835*x_47 - 0.00324317185648356*x_48 - 0.00411278213188299*x_49 + 0.00430086875926443*x_5 - 0.000714566907992623*x_50 - 0.00110662568962279*x_51 - 0.00402034169062325*x_52 + 0.000139362600367385*x_53 + 0.00290496926509097*x_54 + 2.97978557008797e-5*x_55 - 0.000232693195236951*x_56 + 0.000188173380177005*x_57 + 0.000875854534734014*x_58 + 0.0027703091198263*x_59 - 0.000178155416686164*x_6 - 0.000510358758839372*x_60 - 0.0214657634681708*x_61 + 0.00362504517651385*x_62 + 0.00634696808143741*x_63 + 0.00409705192793714*x_64 + 0.00923329342449365*x_65 + 0.00189673699841492*x_66 + 0.000226032774512615*x_67 - 0.00204305282245895*x_68 - 0.00455763735004806*x_69 + 0.000977445841822684*x_7 - 0.00428197486939594*x_70 + 0.000609867864624095*x_71 - 4.13336262510748e-5*x_72 - 6.35229384523018e-6*x_73 - 1.15403455624639e-5*x_74 - 0.000318777665406997*x_75 - 0.00187267758135613*x_76 - 0.00520665393599707*x_77 + 0.00208308763995799*x_78 - 0.00235197586462773*x_79 - 0.00638663968725638*x_8 - 0.000402901151046782*x_80 - 4.88434115958426e-5*x_81 - 0.000634790205267525*x_82 + 0.000231559135152523*x_83 - 0.000273440368914499*x_84 - 0.00274698946242301*x_85 + 0.000333810724758027*x_86 + 0.00153973706415639*x_87 + 0.00147280045241656*x_88 - 0.00209895261302066*x_89 - 0.00441019926376206*x_9 + 0.00237674582493901*x_90 + 0.0162710516628181*x_91 - 0.00295654383783284*x_92 + 0.0116738911635056*x_93 + 0.00497631613880937*x_94 + 0.000569199789507345*x_95 + 0.0028769549799819*x_96 + 0.00134149248001331*x_97 - 0.00309711086837881*x_98 + 0.00114768286765014*x_99 + 0.000172036334997464*std::pow(-3.32999968528748*x_107 - 4.77767992019653, 2) - 6.24050558668581e-6*std::pow(-7.90552043914795*x_120 - 8.69736003875732, 2) + 1.10143612082463e-5*std::pow(-5.1595196723938*x_44 - 5.36368036270142, 2) + 3.37201774718514e-5*std::pow(-4.45591974258423*x_46 - 6.28136014938354, 2) + 2.92975680217679e-7*std::pow(-6.60648012161255*x_7 - 9.8500804901123, 2) - 6.56970776844355e-6*std::exp(1.07223987579346*x_1) + 0.000245122802270804*std::exp(1.1743198633194*x_1) - 2.94843355789707e-5*std::exp(1.23903977870941*x_1) + 1.56224162628016e-5*std::exp(1.2526398897171*x_1) + 2.92206424084657e-5*std::exp(1.01119983196259*x_100) + 0.000341609105247673*std::exp(1.49047994613647*x_100) - 1.14879306603753e-5*std::exp(1.55599987506866*x_100) + 7.97578005338681e-5*std::exp(1.71359992027283*x_100) + 0.000414687219861181*std::exp(0.988239824771881*x_104) + 1.12634402496303e-5*std::exp(1.10151982307434*x_104) - 1.97124931343204e-6*std::exp(1.85015988349915*x_108) - 0.000717713188607288*std::exp(0.709599852561951*x_110) + 1.46236931359326e-6*std::exp(1.53679978847504*x_110) - 2.10543786122314e-5*std::exp(1.75319993495941*x_110) - 1.87776448043505e-5*std::exp(0.931999802589417*x_26) + 0.000268878394386159*std::exp(1.02751982212067*x_26) + 0.000315874868608408*std::exp(1.12487983703613*x_26) - 2.24861999870044e-6*std::exp(1.42727982997894*x_26) - 0.000185645861232424*std::exp(0.650559842586517*x_31) - 0.00122114167385091*std::exp(0.656399846076965*x_31) + 1.45429255585418e-5*std::exp(0.662319839000702*x_31) + 0.000464453200142472*std::exp(0.669119834899902*x_31) - 0.00143726324272911*std::exp(0.672959864139557*x_31) - 1.62545927419139e-6*std::exp(2.07623982429504*x_50) + 0.000361500351491215*std::exp(2.4347198009491*x_6) + 2.42386281441024e-6*std::exp(2.55671977996826*x_6) + 5.17499785248933e-5*std::exp(1.11615991592407*x_60) + 0.000717753996551478*std::exp(1.21999990940094*x_60) - 0.000108371819068509*std::exp(1.80375993251801*x_66) - 5.70686238661283e-6*std::exp(1.27743983268738*x_68) + 0.00179553056833989*std::exp(1.09599983692169*x_72) + 5.40713107744997e-5*std::exp(1.20895993709564*x_72) - 0.000291061671570894*std::exp(1.28823983669281*x_74) - 9.52923358096312e-6*std::exp(1.41407978534698*x_74) + 8.69620250860277e-6*std::exp(1.6594398021698*x_74) - 0.000677561541271152*std::exp(1.68279981613159*x_74) + 0.000372873412575859*std::exp(0.702319860458374*x_81) - 0.000289506141170804*std::exp(1.94055986404419*x_81) - 9.41762052084547e-7*std::exp(2.382239818573*x_81) - 0.0354090908582134*std::sin(0.419039845466614*x_102 - 4.19719982147217) - 0.000251977096500684*std::sin(0.410159856081009*x_116 + 5.20904016494751) - 0.00647991951913763*std::sin(0.421519875526428*x_117 + 5.20256042480469) - 0.000128036824652115*std::sin(0.60207986831665*x_117 + 2.21143984794617) + 0.00659483530588655*std::sin(0.347279846668243*x_119 + 5.15664005279541) + 0.00273865597280026*std::sin(0.357359826564789*x_34 + 2.00071978569031) + 0.00113554685555684*std::sin(0.660639822483063*x_38 + 2.207279920578) + 0.00208997829223895*std::sin(0.299599945545197*x_40 - 7.49639987945557) - 0.000277580870183701*std::sin(0.347039848566055*x_40 - 4.26104021072388) + 0.000153290893109127*std::sin(0.391039848327637*x_40 + 8.38735961914063) - 0.000213838618851639*std::sin(0.297999918460846*x_42 + 5.08511972427368) - 0.00802986598808304*std::sin(0.693439841270447*x_53 + 2.23831987380981) - 0.00494114929358305*std::sin(0.345199853181839*x_54 + 5.14368009567261) - 0.000589221321160995*std::sin(0.473919868469238*x_60 + 8.46807956695557) - 0.000751949628472691*std::sin(0.218639999628067*x_64 - 4.37271976470947) + 0.00276951716238464*std::sin(0.25247997045517*x_64 - 4.33031988143921) - 0.000387690600369832*std::sin(0.263599961996078*x_70 + 5.06279993057251) + 0.000381140492904614*std::sin(0.442879855632782*x_76 - 4.1482400894165) + 0.0189881512128641*std::sin(0.286719918251038*x_83 + 5.0959997177124) - 5.35779511403252e-5*std::sin(0.399679869413376*x_98 + 5.18943977355957) + 0.122104751659629 + 4.77950651914751e-7*std::exp(-2.00783967971802*x_30));
}

inline float score_1(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.00126934036253169*x_1 + 2.88478533471786e-6*x_10 + 0.000276629519629399*x_100 + 0.00830416332336587*x_101 + 6.7227769077091e-5*x_102 + 0.00430723113480946*x_103 - 0.00495344657732379*x_104 - 3.63360496765402e-5*x_105 - 0.00209943062313895*x_106 + 1.2116924571065e-5*x_107 - 0.000897439593597635*x_108 + 0.000523721915807811*x_109 - 0.00330315846723792*x_11 - 0.00101931347645066*x_110 + 0.00110253529447344*x_111 + 0.00680489387426414*x_112 + 0.00346883676506*x_113 + 0.00234130280474085*x_114 - 0.000807381916938712*x_115 - 0.00251937826349818*x_116 + 0.000115358975486333*x_117 + 0.00460341136265035*x_118 - 0.000337773978486599*x_119 + 0.0073641664256123*x_12 + 0.000196475540643418*x_120 + 0.00302185800566898*x_13 + 0.000163526628821373*x_14 - 0.00190830676082424*x_15 - 0.00188921019401968*x_16 + 0.00159419304162911*x_17 - 0.00155696817709963*x_18 + 0.00794503565112109*x_19 - 0.00778125668311288*x_2 + 0.0046001787102916*x_20 - 0.00935380757107375*x_21 + 0.013381788271567*x_22 - 0.000509218995732653*x_23 + 0.00096486518887689*x_24 + 0.00154909088347069*x_25 - 0.00012103107160402*x_26 - 0.000397802310964047*x_27 + 0.00155786265971078*x_28 - 0.00200236423217386*x_29 - 0.00289865540943932*x_3 - 0.00147585980205172*x_30 - 0.00587676186296048*x_32 - 0.00412690190978772*x_33 + 0.00986460696608344*x_34 - 0.00162801394070423*x_35 + 0.00183026990188963*x_36 - 0.0017514128723048*x_37 + 0.00347472988178636*x_38 + 0.00353417438325152*x_39 - 0.00210655234176187*x_4 + 0.00015067525941414*x_40 - 0.000446150152081903*x_41 + 0.00509483902556173*x_42 - 0.0016514947639752*x_43 - 0.00311545607703919*x_44 - 0.00172840691946784*x_45 + 0.000110284900168416*x_46 - 0.00103510563507489*x_47 + 0.00306100751610339*x_48 + 0.004122704458762*x_49 - 0.00351061022156079*x_5 + 0.00114438033429809*x_50 + 0.00141147414072792*x_51 + 0.00380110762948765*x_52 + 0.000159362664006794*x_53 - 0.00260134756813852*x_54 - 7.23712089805144e-5*x_55 - 6.70407671353131e-5*x_56 + 9.37208570477879e-5*x_57 - 0.00077362882316515*x_58 - 0.0025039103304414*x_59 + 0.000270909158070188*x_6 + 0.000354067974558832*x_60 + 0.0192616657180852*x_61 - 0.00311209476578657*x_62 - 0.00628386318498525*x_63 - 0.0035630925438774*x_64 - 0.00932072361734486*x_65 - 0.0019033554820758*x_66 - 0.000344106110324845*x_67 + 0.0021366123609673*x_68 + 0.00446990788549529*x_69 - 0.0012172224532199*x_7 + 0.00390551336810897*x_70 - 0.00062707541421468*x_71 - 2.02513442087896e-5*x_72 - 4.68341334448408e-5*x_73 + 4.38960940116527e-5*x_74 + 0.000293553166327081*x_75 + 0.0018726378017785*x_76 + 0.00446147642752732*x_77 - 0.00182557633105875*x_78 + 0.00240271329393893*x_79 + 0.00663557421525381*x_8 + 0.000676054756062232*x_80 + 2.7789966939135e-5*x_81 + 0.000406484864654896*x_82 - 0.000111804938750903*x_83 + 0.000319380639231255*x_84 + 0.00256698668157228*x_85 - 0.000443522237646694*x_86 - 0.0015363260921503*x_87 - 0.00136645073667164*x_88 + 0.00210199959719249*x_89 + 0.00462222008122527*x_9 - 0.00209121428905796*x_90 - 0.0136938125484285*x_91 + 0.00315770354123579*x_92 - 0.00984777977852323*x_93 - 0.00466463169239913*x_94 - 0.000565827078150285*x_95 - 0.00235330046513609*x_96 - 9.32268187072333e-6*x_97 + 0.00294951262893529*x_98 - 0.000777432682808735*x_99 - 0.000159385845513385*std::pow(-3.32999968528748*x_107 - 4.77767992019653, 2) + 5.78161735065784e-6*std::pow(-7.90552043914795*x_120 - 8.69736003875732, 2) + 9.35761332392503e-8*std::pow(-5.1595196723938*x_44 - 5.36368036270142, 2) - 3.12406038950531e-5*std::pow(-4.45591974258423*x_46 - 6.28136014938354, 2) - 1.1143936663208e-6*std::pow(-6.60648012161255*x_7 - 9.8500804901123, 2) - 5.65012833505183e-6*std::exp(1.07223987579346*x_1) - 0.000227097985405923*std::exp(1.1743198633194*x_1) - 2.50493883616498e-7*std::exp(1.23903977870941*x_1) - 1.14252795660177e-5*std::exp(1.2526398897171*x_1) + 2.51305515343499e-5*std::exp(1.01119983196259*x_100) - 0.000316489281614689*std::exp(1.49047994613647*x_100) + 4.36967230779799e-5*std::exp(1.55599987506866*x_100) + 6.77608662773744e-7*std::exp(1.71359992027283*x_100) + 3.52311185412109e-6*std::exp(0.988239824771881*x_104) + 9.68686662293906e-6*std::exp(1.10151982307434*x_104) - 1.69532831502374e-6*std::exp(1.85015988349915*x_108) + 0.000524891520627407*std::exp(0.709599852561951*x_110) + 1.25767759941034e-6*std::exp(1.53679978847504*x_110) - 1.78874407787964e-7*std::exp(1.75319993495941*x_110) + 7.14246603091498e-5*std::exp(0.931999802589417*x_26) - 0.000249106738004801*std::exp(1.02751982212067*x_26) + 2.68361898007313e-6*std::exp(1.12487983703613*x_26) - 1.9338746892895e-6*std::exp(1.42727982997894*x_26) - 0.000159660517302267*std::exp(0.650559842586517*x_31) - 1.03746112748438e-5*std::exp(0.656399846076965*x_31) - 5.53170287723968e-5*std::exp(0.662319839000702*x_31) - 0.000339672658037835*std::exp(0.669119834899902*x_31) + 0.00133157578119219*std::exp(0.672959864139557*x_31) - 1.39793942535703e-6*std::exp(2.07623982429504*x_50) - 0.000334917848468829*std::exp(2.4347198009491*x_6) - 9.21966412503028e-6*std::exp(2.55671977996826*x_6) + 4.45063966781425e-5*std::exp(1.11615991592407*x_60) - 0.000664974800891074*std::exp(1.21999990940094*x_60) + 7.92565189089102e-5*std::exp(1.80375993251801*x_66) - 4.90805771144396e-6*std::exp(1.27743983268738*x_68) - 0.00166349834053487*std::exp(1.09599983692169*x_72) + 4.59380629143276e-7*std::exp(1.20895993709564*x_72) + 0.000212864701126171*std::exp(1.28823983669281*x_74) - 8.19540146454382e-6*std::exp(1.41407978534698*x_74) + 7.38814525177606e-8*std::exp(1.6594398021698*x_74) + 0.000627737850521212*std::exp(1.68279981613159*x_74) + 3.16786888289529e-6*std::exp(0.702319860458374*x_81) + 0.000268217647699285*std::exp(1.94055986404419*x_81) + 3.58218697621772e-6*std::exp(2.382239818573*x_81) + 0.0328053250226461*std::sin(0.419039845466614*x_102 - 4.19719982147217) - 0.000216707193516447*std::sin(0.410159856081009*x_116 + 5.20904016494751) + 0.00600342626127013*std::sin(0.421519875526428*x_117 + 5.20256042480469) + 0.000487014575210238*std::sin(0.60207986831665*x_117 + 2.21143984794617) - 0.00610989185084505*std::sin(0.347279846668243*x_119 + 5.15664005279541) - 0.00200288544345674*std::sin(0.357359826564789*x_34 + 2.00071978569031) + 9.64741230525863e-6*std::sin(0.660639822483063*x_38 + 2.207279920578) + 1.77560989188615e-5*std::sin(0.299599945545197*x_40 - 7.49639987945557) - 0.000238727139040591*std::sin(0.347039848566055*x_40 - 4.26104021072388) - 0.0005830736539584*std::sin(0.391039848327637*x_40 + 8.38735961914063) + 0.000813379466466287*std::sin(0.297999918460846*x_42 + 5.08511972427368) + 0.00743939924021666*std::sin(0.693439841270447*x_53 + 2.23831987380981) - 4.19791611977625e-5*std::sin(0.345199853181839*x_54 + 5.14368009567261) - 5.00592379475333e-6*std::sin(0.473919868469238*x_60 + 8.46807956695557) - 0.000646697243182219*std::sin(0.218639999628067*x_64 - 4.37271976470947) - 0.00202545542961061*std::sin(0.25247997045517*x_64 - 4.33031988143921) - 0.000333424518043944*std::sin(0.263599961996078*x_70 + 5.06279993057251) - 0.00144974678770507*std::sin(0.442879855632782*x_76 - 4.1482400894165) - 0.0175918798540028*std::sin(0.286719918251038*x_83 + 5.0959997177124) + 0.000203794831573944*std::sin(0.399679869413376*x_98 + 5.18943977355957) + 0.0322610514466547 - 1.8179842740256e-6*std::exp(-2.00783967971802*x_30));
}

inline float score_2(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.000940632939245348*x_1 + 8.8632520039014e-5*x_10 - 0.000208917779855166*x_100 - 0.000918643062458857*x_101 + 9.33836983962838e-5*x_102 + 9.03486599343312e-5*x_103 + 0.000219559991522021*x_104 + 0.000106332543563389*x_105 - 0.000501898756732892*x_106 - 3.79487963078187e-5*x_107 - 0.000692624562106456*x_108 - 7.93575943227038e-5*x_109 + 0.000963644148987987*x_11 + 6.74846556975218e-5*x_110 + 0.000292691045534649*x_111 - 0.00138735042489942*x_112 - 0.000644684321389009*x_113 - 0.000346553380152921*x_114 - 0.000171645078053991*x_115 - 0.000319845714777122*x_116 - 0.000113845128045441*x_117 - 7.36940327707261e-5*x_118 + 0.000323791079941548*x_119 - 0.000840652846437885*x_12 - 4.68947596634177e-5*x_120 - 0.000440524065700236*x_13 + 0.000129473233481494*x_14 + 0.000347305116341865*x_15 + 0.000333953587342276*x_16 - 0.000678732706444242*x_17 + 0.000103122301465104*x_18 - 0.000951458397748321*x_19 + 0.00125774698334013*x_2 - 0.000126326141573219*x_20 + 0.00176425805471678*x_21 - 0.000383595959261277*x_22 + 0.000225590701910122*x_23 - 9.94591024464489e-5*x_24 + 3.90944424674819e-5*x_25 + 9.1405800822987e-5*x_26 - 0.000204116598841682*x_27 - 0.00022897511078062*x_28 - 1.44147726479463e-5*x_29 + 0.000345885237447578*x_3 + 0.000139557756571103*x_30 + 0.000578276152154661*x_32 + 0.000177441888431748*x_33 - 0.000797090848505936*x_34 + 0.000230617274176718*x_35 - 0.000689367242299523*x_36 + 0.000446319371330402*x_37 - 0.000160906297183514*x_38 - 0.000108178606858186*x_39 + 0.000776075200733798*x_4 + 0.000428913269314061*x_40 - 3.14214490859706e-5*x_41 + 0.000224297627892337*x_42 - 7.7728574095628e-5*x_43 + 0.000239101352984766*x_44 + 0.000301186399254055*x_45 - 7.61754127571712e-5*x_46 + 0.000341949257863458*x_47 - 0.000268854063216816*x_48 - 0.000218285889590599*x_49 + 0.000669642613011916*x_5 + 0.000216241165472295*x_50 + 0.00023941701519541*x_51 - 0.000257452907690221*x_52 + 6.50847355179316e-5*x_53 + 0.000318704573422568*x_54 - 7.35470026694505e-5*x_55 - 9.26225975423678e-5*x_56 + 1.88323170119873e-5*x_57 + 8.80113531234212e-5*x_58 + 0.000280039449963547*x_59 - 0.000122024155507207*x_6 - 0.000267738092444753*x_60 - 0.00270102589289595*x_61 + 0.000324623658807263*x_62 + 0.000582023383363757*x_63 + 0.000327128537821012*x_64 + 0.00107959538015707*x_65 + 0.0002849373307584*x_66 - 0.000148350668147099*x_67 - 0.000471461879484309*x_68 - 0.00085119463782121*x_69 - 8.55306327376616e-5*x_7 - 0.0002498805039083*x_70 - 3.79515725145222e-5*x_71 + 4.08371190304397e-5*x_72 + 0.000136644724482708*x_73 - 3.25287946010147e-5*x_74 + 3.37467193115059e-5*x_75 + 2.29008261646775e-5*x_76 - 0.0012455435600086*x_77 + 0.000381467751552244*x_78 - 0.000153327183193768*x_79 - 0.00133069965486335*x_8 + 0.000145843427486589*x_80 - 2.96126362236405e-5*x_81 - 0.000290437189662327*x_82 + 0.000154989333802296*x_83 - 5.93544405830947e-5*x_84 - 0.000283354220432859*x_85 - 0.000122906287113878*x_86 - 0.000132662167820225*x_87 + 0.000214351538949353*x_88 - 3.93325747835315e-5*x_89 - 0.000721532595854052*x_9 + 0.00027185694758588*x_90 + 0.00296504015443346*x_91 - 0.00021085942246138*x_92 + 0.000786518564941565*x_93 + 2.62552065810112e-6*x_94 + 4.67453716966486e-5*x_95 + 0.000139297735320808*x_96 + 6.68806505342383e-7*x_97 - 0.000173394967793995*x_98 + 0.000393272243782931*x_99 + 1.24096990612558e-5*std::pow(-3.32999968528748*x_107 - 4.77767992019653, 2) - 4.50153720852039e-7*std::pow(-7.90552043914795*x_120 - 8.69736003875732, 2) + 3.94398366628096e-6*std::pow(-5.1595196723938*x_44 - 5.36368036270142, 2) + 2.43237717615863e-6*std::pow(-4.45591974258423*x_46 - 6.28136014938354, 2) + 8.2581112266613e-7*std::pow(-6.60648012161255*x_7 - 9.8500804901123, 2) - 7.10227797918098e-6*std::exp(1.07223987579346*x_1) + 1.76817310673192e-5*std::exp(1.1743198633194*x_1) - 1.05576470333609e-5*std::exp(1.23903977870941*x_1) + 8.62866712256452e-6*std::exp(1.2526398897171*x_1) + 3.15893997769608e-5*std::exp(1.01119983196259*x_100) + 2.46416909123934e-5*std::exp(1.49047994613647*x_100) - 3.23810526140139e-5*std::exp(1.55599987506866*x_100) + 2.85593922894558e-5*std::exp(1.71359992027283*x_100) + 0.000148489739062077*std::exp(0.988239824771881*x_104) + 1.21765056337844e-5*std::exp(1.10151982307434*x_104) - 2.13104769401042e-6*std::exp(1.85015988349915*x_108) - 0.000396411674723617*std::exp(0.709599852561951*x_110) + 1.58091558094129e-6*std::exp(1.53679978847504*x_110) - 7.53907773499986e-6*std::exp(1.75319993495941*x_110) - 5.29285841247474e-5*std::exp(0.931999802589417*x_26) + 1.93953211015281e-5*std::exp(1.02751982212067*x_26) + 0.0001131073603658*std::exp(1.12487983703613*x_26) - 2.43090330090888e-6*std::exp(1.42727982997894*x_26) - 0.000200695153974787*std::exp(0.650559842586517*x_31) - 0.000437262109424666*std::exp(0.656399846076965*x_31) + 4.09921727067116e-5*std::exp(0.662319839000702*x_31) + 0.000256529591237542*std::exp(0.669119834899902*x_31) - 0.000103675797989627*std::exp(0.672959864139557*x_31) - 1.75722635101014e-6*std::exp(2.07623982429504*x_50) + 2.60765295459839e-5*std::exp(2.4347198009491*x_6) + 6.83214685420167e-6*std::exp(2.55671977996826*x_6) + 5.59450657251249e-5*std::exp(1.11615991592407*x_60) + 5.17745922531351e-5*std::exp(1.21999990940094*x_60) - 5.98565763758018e-5*std::exp(1.80375993251801*x_66) - 6.16948645011938e-6*std::exp(1.27743983268738*x_68) + 0.000129519115881607*std::exp(1.09599983692169*x_72) + 1.93616645102728e-5*std::exp(1.20895993709564*x_72) - 0.000160760936968662*std::exp(1.28823983669281*x_74) - 1.03017163328987e-5*std::exp(1.41407978534698*x_74) + 3.11390556421217e-6*std::exp(1.6594398021698*x_74) - 4.88753426581634e-5*std::exp(1.68279981613159*x_74) + 0.000133517198227402*std::exp(0.702319860458374*x_81) - 2.08832865938934e-5*std::exp(1.94055986404419*x_81) - 2.65454653757766e-6*std::exp(2.382239818573*x_81) - 0.0025542055495984*std::sin(0.419039845466614*x_102 - 4.19719982147217) - 0.00027240349903094*std::sin(0.410159856081009*x_116 + 5.20904016494751) - 0.000467423647305905*std::sin(0.421519875526428*x_117 + 5.20256042480469) - 0.000360897647989108*std::sin(0.60207986831665*x_117 + 2.21143984794617) + 0.000475713002754931*std::sin(0.347279846668243*x_119 + 5.15664005279541) + 0.00151263097557988*std::sin(0.357359826564789*x_34 + 2.00071978569031) + 0.000406612618374985*std::sin(0.660639822483063*x_38 + 2.207279920578) + 0.00074837206549036*std::sin(0.299599945545197*x_40 - 7.49639987945557) - 0.000300082830353147*std::sin(0.347039848566055*x_40 - 4.26104021072388) + 0.000432081340126549*std::sin(0.391039848327637*x_40 + 8.38735961914063) - 0.000602747333062052*std::sin(0.297999918460846*x_42 + 5.08511972427368) - 0.000579227756832838*std::sin(0.693439841270447*x_53 + 2.23831987380981) - 0.00176930933515754*std::sin(0.345199853181839*x_54 + 5.14368009567261) - 0.000210986295305405*std::sin(0.473919868469238*x_60 + 8.46807956695557) - 0.000812906064620917*std::sin(0.218639999628067*x_64 - 4.37271976470947) + 0.0015296764138431*std::sin(0.25247997045517*x_64 - 4.33031988143921) - 0.00041911855303032*std::sin(0.263599961996078*x_70 + 5.06279993057251) + 0.0010743214525698*std::sin(0.442879855632782*x_76 - 4.1482400894165) + 0.0013696946187835*std::sin(0.286719918251038*x_83 + 5.0959997177124) - 0.000151020275636767*std::sin(0.399679869413376*x_98 + 5.18943977355957) + 0.0595122791637725 + 1.34720043705837e-6*std::exp(-2.00783967971802*x_30));
}

inline float score_3(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.0023749109067137*x_1 - 0.000174785242509778*x_10 + 0.00190658167261141*x_100 + 0.013507109950414*x_101 + 0.000132781721456994*x_102 + 0.000674815797732846*x_103 - 0.00383424373674044*x_104 - 0.00111020332326118*x_105 + 0.00241836407394906*x_106 + 0.000332362958758046*x_107 + 0.00317192155816217*x_108 + 0.0019475618437658*x_109 - 0.00697510909571003*x_11 - 0.00138353810590388*x_110 + 0.000969300559760882*x_111 + 0.014112025825427*x_112 + 0.00726947802153469*x_113 + 0.00619128192081957*x_114 + 0.000850967794477317*x_115 - 0.00133894346637462*x_116 + 0.000850800088338083*x_117 + 0.0041858570406369*x_118 - 0.0024636707638569*x_119 + 0.00927192305823036*x_12 - 4.63056717610115e-5*x_120 + 0.0083985801590343*x_13 - 0.000712253378847078*x_14 - 0.00303698724961651*x_15 - 0.00343345598825196*x_16 + 0.00710562514427348*x_17 - 0.00195619585302982*x_18 + 0.0115867666640466*x_19 - 0.0157548958807832*x_2 + 0.00343081907338336*x_20 - 0.0160706474762635*x_21 + 0.0113851073200646*x_22 - 0.00209628814165345*x_23 + 0.00220621733449361*x_24 + 0.00396080139746175*x_25 - 0.000834168469243224*x_26 - 0.000400264503284449*x_27 + 0.00276415550428629*x_28 - 0.000626748305706297*x_29 - 0.00413834771807251*x_3 - 0.0023482473804218*x_30 - 0.00920146509889187*x_32 - 0.00293723051833944*x_33 + 0.0133007002047032*x_34 - 0.00207205033928019*x_35 + 0.00471378095613922*x_36 - 0.00385013642557269*x_37 + 0.00398863403098703*x_38 + 0.000899155926242703*x_39 - 0.00587729749802735*x_4 - 0.00338895151836355*x_40 + 0.00177059319476822*x_41 + 0.00130879810955035*x_42 - 0.000696996743103443*x_43 - 0.00373152174997375*x_44 - 0.00212547355364515*x_45 + 0.000461168132135869*x_46 - 0.00329615662759785*x_47 + 0.00480630591143372*x_48 + 0.00758824365886527*x_49 - 0.00549321285101908*x_5 + 0.000344177708130631*x_50 - 0.00173550304375638*x_51 + 0.00613611443576913*x_52 + 0.000879520384821857*x_53 - 0.00397416171823271*x_54 + 0.000537786418516856*x_55 - 1.99109545221753e-6*x_56 + 0.00234678353296148*x_57 - 0.00108508892677812*x_58 - 0.0040496005927905*x_59 + 0.00175987202122404*x_6 + 0.00255951568449151*x_60 + 0.0365014803738085*x_61 - 0.00400671134408989*x_62 - 0.00705096488757988*x_63 - 0.00486310981315581*x_64 - 0.017186535584956*x_65 - 0.00270048187984348*x_66 + 0.000588556874565583*x_67 + 0.00647195907208305*x_68 + 0.0126325231744727*x_69 - 0.000996477708694116*x_7 + 0.00469674642093513*x_70 - 0.000440649180740417*x_71 + 0.000230807511399404*x_72 - 0.00146508330260003*x_73 + 8.21287304080358e-5*x_74 + 0.00110781496859922*x_75 + 0.00144519789453672*x_76 + 0.0119236779482364*x_77 - 0.00465725658466053*x_78 + 0.00376532959756253*x_79 + 0.0100898134399185*x_8 + 0.000239034160446477*x_80 + 0.000222671956449199*x_81 + 0.00215472825595787*x_82 - 0.000902531027624158*x_83 + 0.00169451653532956*x_84 + 0.00493547164540268*x_85 + 0.000823996518083962*x_86 - 0.00029793922740273*x_87 - 0.00230344297931634*x_88 + 0.0020652403297325*x_89 + 0.0131089546333795*x_9 - 0.00208727921629525*x_90 - 0.0267080872947564*x_91 + 0.00498019423756831*x_92 - 0.00980567207546473*x_93 - 0.00432520918912726*x_94 - 0.000287265443832061*x_95 - 0.00123249716981589*x_96 + 0.00145820229844965*x_97 + 0.00381094220456562*x_98 - 0.00219511734466646*x_99 - 0.000217751928040008*std::pow(-3.32999968528748*x_107 - 4.77767992019653, 2) + 7.89880883864045e-6*std::pow(-7.90552043914795*x_120 - 8.69736003875732, 2) - 7.00283339919298e-7*std::pow(-5.1595196723938*x_44 - 5.36368036270142, 2) - 4.26807142715237e-5*std::pow(-4.45591974258423*x_46 - 6.28136014938354, 2) - 2.08500867902705e-6*std::pow(-6.60648012161255*x_7 - 9.8500804901123, 2) + 2.10493552755909e-6*std::exp(1.07223987579346*x_1) - 0.000310259822739331*std::exp(1.1743198633194*x_1) + 1.87458796785096e-6*std::exp(1.23903977870941*x_1) - 7.87451341209502e-5*std::exp(1.2526398897171*x_1) - 9.3622989806518e-6*std::exp(1.01119983196259*x_100) - 0.000432385642863174*std::exp(1.49047994613647*x_100) + 8.17557113039109e-5*std::exp(1.55599987506866*x_100) - 5.07093038683512e-6*std::exp(1.71359992027283*x_100) - 2.63654465162099e-5*std::exp(0.988239824771881*x_104) - 3.60880824225804e-6*std::exp(1.10151982307434*x_104) + 6.31588627647982e-7*std::exp(1.85015988349915*x_108) + 0.00361764917452792*std::exp(0.709599852561951*x_110) - 4.68543385960059e-7*std::exp(1.53679978847504*x_110) + 1.33861876288025e-6*std::exp(1.75319993495941*x_110) + 0.000133634137685656*std::exp(0.931999802589417*x_26) - 0.000340328040508134*std::exp(1.02751982212067*x_26) - 2.00830446544693e-5*std::exp(1.12487983703613*x_26) + 7.20458244121532e-7*std::exp(1.42727982997894*x_26) + 5.94809666770023e-5*std::exp(0.650559842586517*x_31) + 7.76391071357568e-5*std::exp(0.656399846076965*x_31) - 0.000103497075202539*std::exp(0.662319839000702*x_31) - 0.00234108661060378*std::exp(0.669119834899902*x_31) + 0.00181919036004755*std::exp(0.672959864139557*x_31) + 5.20797438096164e-7*std::exp(2.07623982429504*x_50) - 0.000457562633646625*std::exp(2.4347198009491*x_6) - 1.72498106363688e-5*std::exp(2.55671977996826*x_6) - 1.65807022453412e-5*std::exp(1.11615991592407*x_60) - 0.000908484342042102*std::exp(1.21999990940094*x_60) + 0.00054625054690168*std::exp(1.80375993251801*x_66) + 1.82847971506013e-6*std::exp(1.27743983268738*x_68) - 0.00227266084874771*std::exp(1.09599983692169*x_72) - 3.43780609579352e-6*std::exp(1.20895993709564*x_72) + 0.00146710278229443*std::exp(1.28823983669281*x_74) + 3.05316811979454e-6*std::exp(1.41407978534698*x_74) - 5.52896860943652e-7*std::exp(1.6594398021698*x_74) + 0.000857611457368747*std::exp(1.68279981613159*x_74) - 2.37069616466031e-5*std::exp(0.702319860458374*x_81) + 0.000366437243738624*std::exp(1.94055986404419*x_81) + 6.70220152988699e-6*std::exp(2.382239818573*x_81) + 0.0448184263204251*std::sin(0.419039845466614*x_102 - 4.19719982147217) + 8.07335061542823e-5*std::sin(0.410159856081009*x_116 + 5.20904016494751) + 0.00820184276104871*std::sin(0.421519875526428*x_117 + 5.20256042480469) + 0.000911194712258631*std::sin(0.60207986831665*x_117 + 2.21143984794617) - 0.00834729537213335*std::sin(0.347279846668243*x_119 + 5.15664005279541) - 0.0138042559013611*std::sin(0.357359826564789*x_34 + 2.00071978569031) - 7.21970643244242e-5*std::sin(0.660639822483063*x_38 + 2.207279920578) - 0.000132878970570909*std::sin(0.299599945545197*x_40 - 7.49639987945557) + 8.89369597574758e-5*std::sin(0.347039848566055*x_40 - 4.26104021072388) - 0.00109091936337811*std::sin(0.391039848327637*x_40 + 8.38735961914063) + 0.00152181701868755*std::sin(0.297999918460846*x_42 + 5.08511972427368) + 0.0101636599084359*std::sin(0.693439841270447*x_53 + 2.23831987380981) + 0.000314153900069992*std::sin(0.345199853181839*x_54 + 5.14368009567261) + 3.74621702460019e-5*std::sin(0.473919868469238*x_60 + 8.46807956695557) + 0.000240924793566885*std::sin(0.218639999628067*x_64 - 4.37271976470947) - 0.0139598124088867*std::sin(0.25247997045517*x_64 - 4.33031988143921) + 0.000124216136726658*std::sin(0.263599961996078*x_70 + 5.06279993057251) - 0.00271244778762635*std::sin(0.442879855632782*x_76 - 4.1482400894165) - 0.024033914327327*std::sin(0.286719918251038*x_83 + 5.0959997177124) + 0.000381296130276292*std::sin(0.399679869413376*x_98 + 5.18943977355957) + 0.00175880700418651 - 3.40141289764556e-6*std::exp(-2.00783967971802*x_30));
}

inline float score_4(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.00161598009400666*x_1 - 0.000199852235079101*x_10 + 0.000502655344937611*x_100 - 0.0104075387277471*x_101 - 3.43074546637383e-5*x_102 - 0.00891927097460016*x_103 + 0.00778791001192894*x_104 - 0.000551413119874288*x_105 + 0.00591011696712119*x_106 + 7.43437746316579e-5*x_107 + 0.00434738716773081*x_108 - 0.000228092382408488*x_109 + 0.00224939444798558*x_11 + 0.00145710537511638*x_110 - 0.00273387500633147*x_111 - 0.00656216236099271*x_112 - 0.00318616101246055*x_113 - 0.0020768392549457*x_114 + 0.00221441209027093*x_115 + 0.00516464605693713*x_116 + 0.000239148338936189*x_117 - 0.00832129312127864*x_118 - 0.000690059225184344*x_119 - 0.00917794514623639*x_12 + 0.000141723773228017*x_120 - 0.00196130410401641*x_13 - 0.000811549492599654*x_14 + 0.00226691394961568*x_15 + 0.00224179747371606*x_16 + 0.000477907257379909*x_17 + 0.00228873891363143*x_18 - 0.0103444008564757*x_19 + 0.00693251959501418*x_2 - 0.00765568867119635*x_20 + 0.00990840374567353*x_21 - 0.0213266689945564*x_22 + 0.000193226350074497*x_23 - 0.000972541724964317*x_24 - 0.00149189327874953*x_25 - 0.000219921992153226*x_26 + 0.000972135921382641*x_27 - 0.00170500688419206*x_28 + 0.00382975775995833*x_29 + 0.00411828090216532*x_3 + 0.00186411983691308*x_30 + 0.00848729540013538*x_32 + 0.00759997697397407*x_33 - 0.013534802244931*x_34 + 0.00241511351297518*x_35 - 0.000620076152893879*x_36 + 0.00120263643939241*x_37 - 0.00526878560154172*x_38 - 0.00808245923025175*x_39 + 0.000353975882045238*x_4 - 0.00228997560475604*x_40 + 0.00186785600894694*x_41 - 0.0103146241144624*x_42 + 0.00354803472929066*x_43 + 0.00449506545421883*x_44 + 0.00247289257719886*x_45 + 0.000185250241713448*x_46 + 0.000413974430635971*x_47 - 0.00385853356497335*x_48 - 0.00514240534035046*x_49 + 0.00379445359623364*x_5 - 0.00243451140647671*x_50 - 0.00375537659534859*x_51 - 0.00522206444499819*x_52 + 9.7249746900996e-5*x_53 + 0.00338636642602716*x_54 + 0.000457647438886922*x_55 + 0.000124591691855007*x_56 + 0.000473438445179388*x_57 + 0.000984910955334195*x_58 + 0.00310035704324922*x_59 + 0.000400106962899563*x_6 + 0.000656281797720773*x_60 - 0.0214147957044049*x_61 + 0.00441830311158743*x_62 + 0.00867175369972519*x_63 + 0.00495460419550197*x_64 + 0.00993803256711247*x_65 + 0.00208503716143754*x_66 + 0.00115561125646607*x_67 - 0.000973786031209438*x_68 - 0.00288464429430065*x_69 + 0.00221773063204433*x_7 - 0.00576811871451063*x_70 + 0.00127828164070815*x_71 - 1.52857244181078e-5*x_72 - 0.000721219458829038*x_73 + 5.58835251925619e-5*x_74 - 0.000348075106308094*x_75 - 0.00325927736853306*x_76 - 0.00242991382324873*x_77 + 0.00141913683015094*x_78 - 0.00304130885036527*x_79 - 0.00624077243853888*x_8 - 0.00152624356331153*x_80 + 5.98461643726108e-5*x_81 + 0.000422137004594561*x_82 - 0.000269544426097096*x_83 + 2.70149184242814e-6*x_84 - 0.00291499175948831*x_85 + 0.00132898544273011*x_86 + 0.00330641044201747*x_87 + 0.00139793461697321*x_88 - 0.00345742443245442*x_89 - 0.00199542503379889*x_9 + 0.00292302334870462*x_90 + 0.0117870917297133*x_91 - 0.003915633874412*x_92 + 0.0155473531696023*x_93 + 0.00817691931457131*x_94 + 0.00095165852418112*x_95 + 0.00431089458631949*x_96 + 0.00130985034490645*x_97 - 0.00420617720318726*x_98 - 5.12145403422929e-7*x_99 + 0.000220403023355749*std::pow(-3.32999968528748*x_107 - 4.77767992019653, 2) - 7.99497558811789e-6*std::pow(-7.90552043914795*x_120 - 8.69736003875732, 2) - 4.36398420186855e-6*std::pow(-5.1595196723938*x_44 - 5.36368036270142, 2) + 4.32003452235717e-5*std::pow(-4.45591974258423*x_46 - 6.28136014938354, 2) - 1.41871954506334e-6*std::pow(-6.60648012161255*x_7 - 9.8500804901123, 2) + 2.05828596801022e-6*std::exp(1.07223987579346*x_1) + 0.00031403718705537*std::exp(1.1743198633194*x_1) + 1.168194616433e-5*std::exp(1.23903977870941*x_1) - 2.07605386762741e-5*std::exp(1.2526398897171*x_1) - 9.15481180677212e-6*std::exp(1.01119983196259*x_100) + 0.000437649869741467*std::exp(1.49047994613647*x_100) + 5.56297087461234e-5*std::exp(1.55599987506866*x_100) - 3.16007233578824e-5*std::exp(1.71359992027283*x_100) - 0.000164302626541437*std::exp(0.988239824771881*x_104) - 3.52882987104737e-6*std::exp(1.10151982307434*x_104) + 6.17591366967027e-7*std::exp(1.85015988349915*x_108) + 0.000953764908059208*std::exp(0.709599852561951*x_110) - 4.58159532251288e-7*std::exp(1.53679978847504*x_110) + 8.34192504737785e-6*std::exp(1.75319993495941*x_110) + 9.09297716260807e-5*std::exp(0.931999802589417*x_26) + 0.000344471480624268*std::exp(1.02751982212067*x_26) - 0.000125152327067533*std::exp(1.12487983703613*x_26) + 7.04491455912779e-7*std::exp(1.42727982997894*x_26) + 5.81627501042408e-5*std::exp(0.650559842586517*x_31) + 0.00048382678506484*std::exp(0.656399846076965*x_31) - 7.04233631848721e-5*std::exp(0.662319839000702*x_31) - 0.000617209173195331*std::exp(0.669119834899902*x_31) - 0.00184133871522114*std::exp(0.672959864139557*x_31) + 5.09255530620483e-7*std::exp(2.07623982429504*x_50) + 0.000463133386409355*std::exp(2.4347198009491*x_6) - 1.17374300378825e-5*std::exp(2.55671977996826*x_6) - 1.62132408924261e-5*std::exp(1.11615991592407*x_60) + 0.000919544995351998*std::exp(1.21999990940094*x_60) + 0.00014401468398631*std::exp(1.80375993251801*x_66) + 1.7879569663893e-6*std::exp(1.27743983268738*x_68) + 0.00230033013546593*std::exp(1.09599983692169*x_72) - 2.14235162196765e-5*std::exp(1.20895993709564*x_72) + 0.000386790173055145*std::exp(1.28823983669281*x_74) + 2.98550383927275e-6*std::exp(1.41407978534698*x_74) - 3.44550987989928e-6*std::exp(1.6594398021698*x_74) - 0.000868052741346441*std::exp(1.68279981613159*x_74) - 0.00014773563813756*std::exp(0.702319860458374*x_81) - 0.000370898559278434*std::exp(1.94055986404419*x_81) + 4.56043392099508e-6*std::exp(2.382239818573*x_81) - 0.0453640835788772*std::sin(0.419039845466614*x_102 - 4.19719982147217) + 7.89442910198407e-5*std::sin(0.410159856081009*x_116 + 5.20904016494751) - 0.00830169890064747*std::sin(0.421519875526428*x_117 + 5.20256042480469) + 0.000620011686590642*std::sin(0.60207986831665*x_117 + 2.21143984794617) + 0.00844892237428832*std::sin(0.347279846668243*x_119 + 5.15664005279541) - 0.00363938409320895*std::sin(0.357359826564789*x_34 + 2.00071978569031) - 0.000449913385301132*std::sin(0.660639822483063*x_38 + 2.207279920578) - 0.000828067291160787*std::sin(0.299599945545197*x_40 - 7.49639987945557) + 8.6965939768511e-5*std::sin(0.347039848566055*x_40 - 4.26104021072388) - 0.000742303204049396*std::sin(0.391039848327637*x_40 + 8.38735961914063) + 0.00103550242746689*std::sin(0.297999918460846*x_42 + 5.08511972427368) - 0.0102874008618069*std::sin(0.693439841270447*x_53 + 2.23831987380981) + 0.00195772565004735*std::sin(0.345199853181839*x_54 + 5.14368009567261) + 0.000233454531618734*std::sin(0.473919868469238*x_60 + 8.46807956695557) + 0.000235585420765606*std::sin(0.218639999628067*x_64 - 4.37271976470947) - 0.0036803953496743*std::sin(0.25247997045517*x_64 - 4.33031988143921) + 0.000121463259979939*std::sin(0.263599961996078*x_70 + 5.06279993057251) - 0.00184565308047785*std::sin(0.442879855632782*x_76 - 4.1482400894165) + 0.024326523436535*std::sin(0.286719918251038*x_83 + 5.0959997177124) + 0.000259448451184589*std::sin(0.399679869413376*x_98 + 5.18943977355957) + 0.123075229782795 - 2.31445125733104e-6*std::exp(-2.00783967971802*x_30));
}

inline float score_5(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.000463172323337962*x_1 - 0.00013026175821516*x_10 + 0.000614840274246138*x_100 + 0.00390270521300529*x_101 + 7.06098088695641e-5*x_102 + 0.000243619243581963*x_103 - 0.000749822641928153*x_104 - 0.000414207444803025*x_105 + 0.00089818838247339*x_106 + 0.000120808865461919*x_107 + 0.00126364211198745*x_108 + 0.000666163117006654*x_109 - 0.00232612875517436*x_11 - 0.000368541341314735*x_110 + 3.70165151191386e-5*x_111 + 0.00449804684202363*x_112 + 0.00210748942407147*x_113 + 0.00195965863813761*x_114 + 0.000161694970339685*x_115 + 1.85014209886209e-5*x_116 + 0.000275743239617358*x_117 + 0.00126414436414898*x_118 - 0.000804866814640144*x_119 + 0.00249288758769034*x_12 + 6.13488768291609e-5*x_120 + 0.00247414652158384*x_13 - 0.000239343958016102*x_14 - 0.000905468660509756*x_15 - 0.00105983948268052*x_16 + 0.00217812234371659*x_17 - 0.000537591311143013*x_18 + 0.00327303957458327*x_19 - 0.00335865022600594*x_2 + 0.000833034868764554*x_20 - 0.00468011137493762*x_21 + 0.00254775244056799*x_22 - 0.000649946362824402*x_23 + 0.000697503560645918*x_24 + 0.0011379591669975*x_25 - 0.000269005192782799*x_26 - 6.15871844728259e-6*x_27 + 0.000839555658682822*x_28 - 2.6356808292433e-5*x_29 - 0.00113554569976383*x_3 - 0.000624969068392346*x_30 - 0.00211979547683793*x_32 - 0.00057154050697925*x_33 + 0.00402036955948635*x_34 - 0.000555554749390735*x_35 + 0.00171318933145752*x_36 - 0.000807314558331909*x_37 + 0.00101698022526004*x_38 - 9.32844936328696e-5*x_39 - 0.00142020271416404*x_4 - 0.00115614097286834*x_40 + 0.000472623117853185*x_41 - 4.38676481479133e-5*x_42 - 0.000187954267762583*x_43 - 0.000899201592079242*x_44 - 0.000823454781708206*x_45 + 0.000273486596456665*x_46 - 0.000844376796054878*x_47 + 0.0013409168266121*x_48 + 0.00201916425110045*x_49 - 0.00180405151818466*x_5 - 0.00020124159961011*x_50 - 0.000891494049258299*x_51 + 0.00148836885586225*x_52 + 0.000250741828426209*x_53 - 0.000985079446837113*x_54 + 0.000190788539922854*x_55 + 7.98109848470608e-5*x_56 + 0.000498287171625101*x_57 - 0.000328714827589122*x_58 - 0.00113058477047003*x_59 + 0.000519104075060375*x_6 + 0.000831062139700029*x_60 + 0.0100812006649701*x_61 - 0.00107948723743991*x_62 - 0.00155211314825786*x_63 - 0.00139093022336622*x_64 - 0.00460659874875293*x_65 - 0.000697998362737437*x_66 + 0.000271546410873992*x_67 + 0.00177396011973797*x_68 + 0.0035028040694097*x_69 - 2.89968543861713e-5*x_7 + 0.00123940389730012*x_70 + 1.61737235315096e-5*x_71 + 0.000123129829872117*x_72 - 0.000431730011626275*x_73 + 1.60173397529783e-5*x_74 + 0.000337215806983869*x_75 + 0.000267817297366108*x_76 + 0.00355443479767859*x_77 - 0.00132482942792838*x_78 + 0.000987218222299031*x_79 + 0.00238334403925286*x_8 - 0.000166061717948359*x_80 + 6.32989055193858e-5*x_81 + 0.000701152591085643*x_82 - 0.000233240521884711*x_83 + 0.000441138525327254*x_84 + 0.00136068846089739*x_85 + 0.000333919527182598*x_86 + 0.000118510545815964*x_87 - 0.000694048562709536*x_88 + 0.000357002834812982*x_89 + 0.00449349703107737*x_9 - 0.000540380042470479*x_90 - 0.00869465977547703*x_91 + 0.00122101140262911*x_92 - 0.00261283084425692*x_93 - 0.000840048116514307*x_94 + 1.8164234900024e-5*x_95 - 0.000233639665961611*x_96 - 6.17010035833672e-5*x_97 + 0.000986492037223364*x_98 - 0.000814314447405788*x_99 - 5.76364657302698e-5*std::pow(-3.32999968528748*x_107 - 4.77767992019653, 2) + 2.09072511566743e-6*std::pow(-7.90552043914795*x_120 - 8.69736003875732, 2) - 5.21490108596795e-6*std::pow(-5.1595196723938*x_44 - 5.36368036270142, 2) - 1.12971010066195e-5*std::pow(-4.45591974258423*x_46 - 6.28136014938354, 2) - 4.06633491519517e-7*std::pow(-6.60648012161255*x_7 - 9.8500804901123, 2) - 1.05378065384881e-5*std::exp(1.07223987579346*x_1) - 8.21222562838088e-5*std::exp(1.1743198633194*x_1) + 1.39597649580169e-5*std::exp(1.23903977870941*x_1) - 2.53939710813226e-5*std::exp(1.2526398897171*x_1) + 4.6869889420318e-5*std::exp(1.01119983196259*x_100) - 0.000114447575787091*std::exp(1.49047994613647*x_100) + 1.59445908660122e-5*std::exp(1.55599987506866*x_100) - 3.7762429681994e-5*std::exp(1.71359992027283*x_100) - 0.000196339378408257*std::exp(0.988239824771881*x_104) + 1.80665500646072e-5*std::exp(1.10151982307434*x_104) - 3.16188248187417e-6*std::exp(1.85015988349915*x_108) + 0.001166630542266*std::exp(0.709599852561951*x_110) + 2.34563932789941e-6*std::exp(1.53679978847504*x_110) + 9.96848567187925e-6*std::exp(1.75319993495941*x_110) + 2.60622972651967e-5*std::exp(0.931999802589417*x_26) - 9.00809725101169e-5*std::exp(1.02751982212067*x_26) - 0.000149555309127023*std::exp(1.12487983703613*x_26) - 3.60678486167954e-6*std::exp(1.42727982997894*x_26) - 0.000297775827980515*std::exp(0.650559842586517*x_31) + 0.000578166352154686*std::exp(0.656399846076965*x_31) - 2.01847490972101e-5*std::exp(0.662319839000702*x_31) - 0.000754960752206368*std::exp(0.669119834899902*x_31) + 0.000481519056053791*std::exp(0.672959864139557*x_31) - 2.60723550747498e-6*std::exp(2.07623982429504*x_50) - 0.000121111639703967*std::exp(2.4347198009491*x_6) - 3.36418298766522e-6*std::exp(2.55671977996826*x_6) + 8.30069283577032e-5*std::exp(1.11615991592407*x_60) - 0.000240465501811657*std::exp(1.21999990940094*x_60) + 0.000176156542826783*std::exp(1.80375993251801*x_66) - 9.15380316621725e-6*std::exp(1.27743983268738*x_68) - 0.000601547551401275*std::exp(1.09599983692169*x_72) - 2.56008071595234e-5*std::exp(1.20895993709564*x_72) + 0.00047311578096609*std::exp(1.28823983669281*x_74) - 1.52848838145572e-5*std::exp(1.41407978534698*x_74) - 4.1173369066521e-6*std::exp(1.6594398021698*x_74) + 0.000227000026210738*std::exp(1.68279981613159*x_74) - 0.000176542055177435*std::exp(0.702319860458374*x_81) + 9.69917824890867e-5*std::exp(1.94055986404419*x_81) + 1.30711187746094e-6*std::exp(2.382239818573*x_81) + 0.0118629291412161*std::sin(0.419039845466614*x_102 - 4.19719982147217) - 0.000404171081674038*std::sin(0.410159856081009*x_116 + 5.20904016494751) + 0.00217093475808577*std::sin(0.421519875526428*x_117 + 5.20256042480469) + 0.000177707791352096*std::sin(0.60207986831665*x_117 + 2.21143984794617) - 0.00220943441459682*std::sin(0.347279846668243*x_119 + 5.15664005279541) - 0.00445163855610321*std::sin(0.357359826564789*x_34 + 2.00071978569031) - 0.000537640305983185*std::sin(0.660639822483063*x_38 + 2.207279920578) - 0.000989529021227883*std::sin(0.299599945545197*x_40 - 7.49639987945557) - 0.000445239516258426*std::sin(0.347039848566055*x_40 - 4.26104021072388) - 0.000212758994319243*std::sin(0.391039848327637*x_40 + 8.38735961914063) + 0.000296795775474425*std::sin(0.297999918460846*x_42 + 5.08511972427368) + 0.00269020550715423*std::sin(0.693439841270447*x_53 + 2.23831987380981) + 0.00233945521940429*std::sin(0.345199853181839*x_54 + 5.14368009567261) + 0.00027897495365391*std::sin(0.473919868469238*x_60 + 8.46807956695557) - 0.00120612666359291*std::sin(0.218639999628067*x_64 - 4.37271976470947) - 0.00450180289321071*std::sin(0.25247997045517*x_64 - 4.33031988143921) - 0.000621855444333636*std::sin(0.263599961996078*x_70 + 5.06279993057251) - 0.000529001210182772*std::sin(0.442879855632782*x_76 - 4.1482400894165) - 0.0063615045430813*std::sin(0.286719918251038*x_83 + 5.0959997177124) + 7.4363132545559e-5*std::sin(0.399679869413376*x_98 + 5.18943977355957) + 0.0239030301074279 - 6.63368175193666e-7*std::exp(-2.00783967971802*x_30));
}

inline float score_6(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.000623921158261275*x_1 + 0.000407265531867572*x_10 - 0.00122665277618251*x_100 + 0.0081617920851851*x_101 + 0.000123153995957691*x_102 + 0.00985526316012475*x_103 - 0.00936830306220139*x_104 + 0.00110280416772625*x_105 - 0.00799247876785113*x_106 - 0.000336624589732066*x_107 - 0.00617913392836938*x_108 - 0.000586554603529923*x_109 - 0.000680660944539399*x_11 - 0.00133493518602182*x_110 + 0.00267374173839929*x_111 + 0.00267224302060773*x_112 + 0.00179485113342118*x_113 - 5.06052891808797e-5*x_114 - 0.00267498529807721*x_115 - 0.00617515009422155*x_116 - 0.000597165231743504*x_117 + 0.0075259427927847*x_118 + 0.0017242576474071*x_119 + 0.00981320747489621*x_12 + 0.000352500332135771*x_120 - 1.35560790240404e-6*x_13 + 0.00118300792613076*x_14 - 0.00170645504938257*x_15 - 0.0012710993054878*x_16 - 0.00288140445925044*x_17 - 0.00212558626860495*x_18 + 0.00893305629178793*x_19 - 0.00708038448910575*x_2 + 0.00854048610284653*x_20 - 0.00759314026161873*x_21 + 0.0242770388307763*x_22 + 0.000825633773943275*x_23 + 0.000333651011617051*x_24 + 0.000656581349438685*x_25 + 0.000536685673265496*x_26 - 0.0010971478887283*x_27 + 0.0012067554020856*x_28 - 0.0046527878847817*x_29 - 0.00336879791164282*x_3 - 0.00162734464893798*x_30 - 0.007110259404703*x_32 - 0.00789128333292198*x_33 + 0.0119266202958435*x_34 - 0.00206243373373527*x_35 - 0.000826355537336773*x_36 - 0.00122414667549871*x_37 + 0.0052775602381479*x_38 + 0.00824803756016351*x_39 - 3.94972370684457e-5*x_4 + 0.00392258427968588*x_40 - 0.0024336282577199*x_41 + 0.0123323199363868*x_42 - 0.00352306549166667*x_43 - 0.00460652174415176*x_44 - 0.00169317797595739*x_45 - 0.000453306679228383*x_46 + 0.000342399823547865*x_47 + 0.00333489868686964*x_48 + 0.00397157670991387*x_49 - 0.00288980007928909*x_5 + 0.00333549870371049*x_50 + 0.00584473342290386*x_51 + 0.00450059760849752*x_52 - 0.000216685701945874*x_53 - 0.00303231692114561*x_54 - 0.000761263409726566*x_55 - 0.000439320876361322*x_56 - 0.00129551823774351*x_57 - 0.000870492288295372*x_58 - 0.0025553063014132*x_59 - 0.000909867544829981*x_6 - 0.00168698566413577*x_60 + 0.0150026600657701*x_61 - 0.00406794414523824*x_62 - 0.00982561096374495*x_63 - 0.0043516711836918*x_64 - 0.00825233338603464*x_65 - 0.00228368889365742*x_66 - 0.00167422060253437*x_67 - 0.000373137888135597*x_68 - 2.21500535367275e-5*x_69 - 0.00274602974426184*x_7 + 0.00560887635501908*x_70 - 0.00147486267942026*x_71 - 0.000299536805575619*x_72 + 0.00123284600478498*x_73 + 2.15763262772733e-5*x_74 - 0.00017800468594162*x_75 + 0.00368743079487717*x_76 - 0.000435631185613599*x_77 - 0.000266850903286512*x_78 + 0.00282122161488124*x_79 + 0.00750981702335837*x_8 + 0.00206810046925276*x_80 - 0.000145430735112106*x_81 - 0.00124033783061491*x_82 + 0.000591054484770883*x_83 - 0.000566632332513687*x_84 + 0.00204378486544712*x_85 - 0.00206750684883509*x_86 - 0.00401792704282282*x_87 - 0.0011634677426802*x_88 + 0.00383926634452048*x_89 - 0.00141685903167761*x_9 - 0.0031878861011482*x_90 - 0.00641759673958847*x_91 + 0.00384043262893504*x_92 - 0.0153946460649329*x_93 - 0.00856885249773198*x_94 - 0.00127712759488619*x_95 - 0.00475004364369884*x_96 - 0.000194204645653738*x_97 + 0.0040994548070251*x_98 + 0.000682139130872862*x_99 - 0.000206486562248263*std::pow(-3.32999968528748*x_107 - 4.77767992019653, 2) + 7.4901650590547e-6*std::pow(-7.90552043914795*x_120 - 8.69736003875732, 2) + 1.53532488345075e-5*std::pow(-5.1595196723938*x_44 - 5.36368036270142, 2) - 4.04726334391311e-5*std::pow(-4.45591974258423*x_46 - 6.28136014938354, 2) - 5.47759929151815e-7*std::pow(-6.60648012161255*x_7 - 9.8500804901123, 2) - 4.21277456782926e-6*std::exp(1.07223987579346*x_1) - 0.000294208573847527*std::exp(1.1743198633194*x_1) - 4.10991007381475e-5*std::exp(1.23903977870941*x_1) + 5.06628899081074e-5*std::exp(1.2526398897171*x_1) + 1.87375121592633e-5*std::exp(1.01119983196259*x_100) - 0.000410016231607916*std::exp(1.49047994613647*x_100) + 2.14783291225837e-5*std::exp(1.55599987506866*x_100) + 0.000111176793182767*std::exp(1.71359992027283*x_100) + 0.000578044968259447*std::exp(0.988239824771881*x_104) + 7.22259441398997e-6*std::exp(1.10151982307434*x_104) - 1.26404845804044e-6*std::exp(1.85015988349915*x_108) - 0.00232751602878408*std::exp(0.709599852561951*x_110) + 9.37733072796807e-7*std::exp(1.53679978847504*x_110) - 2.9348330582032e-5*std::exp(1.75319993495941*x_110) + 3.51074921304964e-5*std::exp(0.931999802589417*x_26) - 0.000322721216540966*std::exp(1.02751982212067*x_26) + 0.000440307464647276*std::exp(1.12487983703613*x_26) - 1.4419102762438e-6*std::exp(1.42727982997894*x_26) - 0.000119043980400365*std::exp(0.650559842586517*x_31) - 0.00170218604840954*std::exp(0.656399846076965*x_31) - 2.71900789433727e-5*std::exp(0.662319839000702*x_31) + 0.0015062037107739*std::exp(0.669119834899902*x_31) + 0.00172507479911903*std::exp(0.672959864139557*x_31) - 1.04231325543085e-6*std::exp(2.07623982429504*x_50) - 0.000433890694265605*std::exp(2.4347198009491*x_6) - 4.53175813947631e-6*std::exp(2.55671977996826*x_6) + 3.31842756328613e-5*std::exp(1.11615991592407*x_60) - 0.000861484030626735*std::exp(1.21999990940094*x_60) - 0.000351445605228329*std::exp(1.80375993251801*x_66) - 3.65948160432709e-6*std::exp(1.27743983268738*x_68) - 0.00215508505498934*std::exp(1.09599983692169*x_72) + 7.53716237767236e-5*std::exp(1.20895993709564*x_72) - 0.000943901709902429*std::exp(1.28823983669281*x_74) - 6.11054772841088e-6*std::exp(1.41407978534698*x_74) + 1.21218978119117e-5*std::exp(1.6594398021698*x_74) + 0.000813243047585137*std::exp(1.68279981613159*x_74) + 0.000519759446672498*std::exp(0.702319860458374*x_81) + 0.000347479663764058*std::exp(1.94055986404419*x_81) + 1.76075882661803e-6*std::exp(2.382239818573*x_81) + 0.0424997512517148*std::sin(0.419039845466614*x_102 - 4.19719982147217) - 0.000161578374750911*std::sin(0.410159856081009*x_116 + 5.20904016494751) + 0.00777752156352245*std::sin(0.421519875526428*x_117 + 5.20256042480469) + 0.000239383152718196*std::sin(0.60207986831665*x_117 + 2.21143984794617) - 0.00791544920394905*std::sin(0.347279846668243*x_119 + 5.15664005279541) + 0.00888135508055389*std::sin(0.357359826564789*x_34 + 2.00071978569031) + 0.00158287286089309*std::sin(0.660639822483063*x_38 + 2.207279920578) + 0.00291328350076623*std::sin(0.299599945545197*x_40 - 7.49639987945557) - 0.000177996597663408*std::sin(0.347039848566055*x_40 - 4.26104021072388) - 0.000286599244984046*std::sin(0.391039848327637*x_40 + 8.38735961914063) + 0.000399801876473389*std::sin(0.297999918460846*x_42 + 5.08511972427368) + 0.00963784437292253*std::sin(0.693439841270447*x_53 + 2.23831987380981) - 0.0068876163763391*std::sin(0.345199853181839*x_54 + 5.14368009567261) - 0.000821333293083673*std::sin(0.473919868469238*x_60 + 8.46807956695557) - 0.000482181914747314*std::sin(0.218639999628067*x_64 - 4.37271976470947) + 0.00898143672119416*std::sin(0.25247997045517*x_64 - 4.33031988143921) - 0.000248603615105916*std::sin(0.263599961996078*x_70 + 5.06279993057251) - 0.000712596653876534*std::sin(0.442879855632782*x_76 - 4.1482400894165) - 0.0227905231034613*std::sin(0.286719918251038*x_83 + 5.0959997177124) + 0.000100171641205573*std::sin(0.399679869413376*x_98 + 5.18943977355957) + 0.0220129398770334 - 8.93597089821144e-7*std::exp(-2.00783967971802*x_30));
}

inline float score_7(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.00178313774705509*x_1 + 3.07708877090516e-5*x_10 + 0.00175919682533292*x_100 + 0.00451702709916765*x_101 + 0.000402382332049917*x_102 - 0.00560407243646421*x_103 + 0.00150189882845422*x_104 - 0.00119056129093684*x_105 + 0.00518757737672655*x_106 + 0.000251634859686255*x_107 + 0.00420267579521359*x_108 + 0.00159035358399842*x_109 - 0.00285219254383743*x_11 - 0.000296192127035651*x_110 + 0.00014893531269325*x_111 + 0.00600189075766441*x_112 + 0.00377209375964032*x_113 + 0.00397490642375118*x_114 + 0.00214137465669988*x_115 + 0.000826485435925197*x_116 + 0.000724928038246121*x_117 - 0.00191709850186961*x_118 - 0.00210987937836814*x_119 + 0.00151883257884752*x_12 - 5.78927395188993e-5*x_120 + 0.00649380175139651*x_13 - 0.000946801557889409*x_14 - 0.000603759694059424*x_15 - 0.00100547718056778*x_16 + 0.00596079010908073*x_17 - 0.000207386891817919*x_18 + 0.00246677745027439*x_19 - 0.0103400756770051*x_2 - 0.00191134883219539*x_20 - 0.00524883269451437*x_21 - 0.00291599805777843*x_22 - 0.00135605732885917*x_23 + 0.00133735924399211*x_24 + 0.00342972887637654*x_25 - 0.000769684584702598*x_26 - 0.000474792084789189*x_27 + 0.0010778215495864*x_28 + 0.00184060624163657*x_29 - 0.000520055967618005*x_3 - 0.000885792040444736*x_30 - 0.00268436005065047*x_32 + 0.00261068365548495*x_33 + 0.00222585477167726*x_34 + 0.000168382727801033*x_35 + 0.00228932616376684*x_36 - 0.00248659676284718*x_37 + 0.000256494316458238*x_38 - 0.00509628355200226*x_39 - 0.00439354144802297*x_4 - 0.00388872674594858*x_40 + 0.00331364104694058*x_41 - 0.00486700608226389*x_42 + 0.00165264860036177*x_43 - 0.000369720363758535*x_44 + 0.000686152329412141*x_45 + 0.000261537930853152*x_46 - 0.00242292359189997*x_47 + 0.00176645318575427*x_48 + 0.00416538623623951*x_49 - 0.00106735993155856*x_5 - 0.000336037805359749*x_50 - 0.00337220743866891*x_51 + 0.00248745689502506*x_52 + 0.0012766230423834*x_53 - 0.0011464078439869*x_54 + 0.000656491993512328*x_55 - 0.000328703565589901*x_56 + 0.00315166034679775*x_57 - 0.000205095931729553*x_58 - 0.00141789789325171*x_59 + 0.00186863428446276*x_6 + 0.00236929175922971*x_60 + 0.0170233438342683*x_61 - 0.000300342476708716*x_62 - 0.000491554267318604*x_63 - 0.000770135453308735*x_64 - 0.0091141309134899*x_65 - 0.000797503052751143*x_66 + 0.000915083983813111*x_67 + 0.0051670150634166*x_68 + 0.00945168687330223*x_69 - 7.50958926928249e-5*x_7 + 0.000377104254778345*x_70 + 0.000174382164459207*x_71 + 0.000266017169214445*x_72 - 0.00172745203335082*x_73 + 6.1664140281762e-5*x_74 + 0.00100505214438805*x_75 - 0.000510510890817238*x_76 + 0.00753834222870008*x_77 - 0.00295871340851294*x_78 + 0.00164211043080796*x_79 + 0.00366348731705766*x_8 - 0.000113721149067024*x_80 + 0.000198035477792747*x_81 + 0.00170469381710795*x_82 - 0.000743011796216365*x_83 + 0.00172435106301849*x_84 + 0.00253875378184802*x_85 + 0.00136012419152387*x_86 + 0.00143869365180205*x_87 - 0.00088548085594433*x_88 - 5.63463313069751e-5*x_89 + 0.0101914986717399*x_9 + 0.000521248045089886*x_90 - 0.011040160228335*x_91 + 0.002351047741274*x_92 + 0.00268638599363619*x_93 + 0.000757024986272935*x_94 + 0.000375654724285423*x_95 + 0.00208053626419935*x_96 + 0.00337348980755694*x_97 + 0.000780113217778147*x_98 - 0.00104908076007878*x_99 - 4.93810299237181e-5*std::pow(-3.32999968528748*x_107 - 4.77767992019653, 2) + 1.79126457861245e-6*std::pow(-7.90552043914795*x_120 - 8.69736003875732, 2) + 1.47802572715608e-5*std::pow(-5.1595196723938*x_44 - 5.36368036270142, 2) - 9.67898492370885e-6*std::pow(-4.45591974258423*x_46 - 6.28136014938354, 2) - 1.56547248488375e-6*std::pow(-6.60648012161255*x_7 - 9.8500804901123, 2) - 7.84309133539363e-6*std::exp(1.07223987579346*x_1) - 7.03596506755313e-5*std::exp(1.1743198633194*x_1) - 3.95652600363198e-5*std::exp(1.23903977870941*x_1) - 7.26578839742284e-5*std::exp(1.2526398897171*x_1) + 3.48843777175753e-5*std::exp(1.01119983196259*x_100) - 9.80549222273224e-5*std::exp(1.49047994613647*x_100) + 6.13840689565357e-5*std::exp(1.55599987506866*x_100) + 0.0001070276150397*std::exp(1.71359992027283*x_100) + 0.000556472016932556*std::exp(0.988239824771881*x_104) + 1.34465936297693e-5*std::exp(1.10151982307434*x_104) - 2.35332969973827e-6*std::exp(1.85015988349915*x_108) + 0.00333799334925993*std::exp(0.709599852561951*x_110) + 1.7458152625419e-6*std::exp(1.53679978847504*x_110) - 2.82530349875074e-5*std::exp(1.75319993495941*x_110) + 0.000100335585022928*std::exp(0.931999802589417*x_26) - 7.71784172176181e-5*std::exp(1.02751982212067*x_26) + 0.000423874951563901*std::exp(1.12487983703613*x_26) - 2.68446217853287e-6*std::exp(1.42727982997894*x_26) - 0.000221628951698208*std::exp(0.650559842586517*x_31) - 0.00163865954305439*std::exp(0.656399846076965*x_31) - 7.77079851634598e-5*std::exp(0.662319839000702*x_31) - 0.00216011314509418*std::exp(0.669119834899902*x_31) + 0.000412549704680191*std::exp(0.672959864139557*x_31) - 1.94051638197388e-6*std::exp(2.07623982429504*x_50) - 0.000103764473212507*std::exp(2.4347198009491*x_6) - 1.29515546828762e-5*std::exp(2.55671977996826*x_6) + 6.17804965580007e-5*std::exp(1.11615991592407*x_60) - 0.000206022940340477*std::exp(1.21999990940094*x_60) + 0.000504023636516758*std::exp(1.80375993251801*x_66) - 6.81300363948015e-6*std::exp(1.27743983268738*x_68) - 0.000515386175399806*std::exp(1.09599983692169*x_72) + 7.25587139505901e-5*std::exp(1.20895993709564*x_72) + 0.00135369105563383*std::exp(1.28823983669281*x_74) - 1.137625172474e-5*std::exp(1.41407978534698*x_74) + 1.16695020194644e-5*std::exp(1.6594398021698*x_74) + 0.000194486163316398*std::exp(1.68279981613159*x_74) + 0.000500361742582935*std::exp(0.702319860458374*x_81) + 8.3099372120816e-5*std::exp(1.94055986404419*x_81) + 5.03216710257527e-6*std::exp(2.382239818573*x_81) + 0.0101637678765179*std::sin(0.419039845466614*x_102 - 4.19719982147217) - 0.000300816939190945*std::sin(0.410159856081009*x_116 + 5.20904016494751) + 0.00185998556457586*std::sin(0.421519875526428*x_117 + 5.20256042480469) + 0.000684145953329121*std::sin(0.60207986831665*x_117 + 2.21143984794617) - 0.00189297080518937*std::sin(0.347279846668243*x_119 + 5.15664005279541) - 0.0127371428702006*std::sin(0.357359826564789*x_34 + 2.00071978569031) + 0.00152379918832481*std::sin(0.660639822483063*x_38 + 2.207279920578) + 0.00280455818247014*std::sin(0.299599945545197*x_40 - 7.49639987945557) - 0.000331383403119709*std::sin(0.347039848566055*x_40 - 4.26104021072388) - 0.000819087356217747*std::sin(0.391039848327637*x_40 + 8.38735961914063) + 0.00114261522925405*std::sin(0.297999918460846*x_42 + 5.08511972427368) + 0.00230487967932368*std::sin(0.693439841270447*x_53 + 2.23831987380981) - 0.00663056680233716*std::sin(0.345199853181839*x_54 + 5.14368009567261) - 0.000790680689691585*std::sin(0.473919868469238*x_60 + 8.46807956695557) - 0.000897697405058832*std::sin(0.218639999628067*x_64 - 4.37271976470947) - 0.0128806743633069*std::sin(0.25247997045517*x_64 - 4.33031988143921) - 0.000462835318669672*std::sin(0.263599961996078*x_70 + 5.06279993057251) - 0.0020365682027733*std::sin(0.442879855632782*x_76 - 4.1482400894165) - 0.0054503280557119*std::sin(0.286719918251038*x_83 + 5.0959997177124) + 0.000286285906885878*std::sin(0.399679869413376*x_98 + 5.18943977355957) + 0.0230431958691608 - 2.55385905802445e-6*std::exp(-2.00783967971802*x_30));
}

inline float score_8(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.00173774008529688*x_1 - 0.000335045439049794*x_10 - 0.00117006690588155*x_100 - 0.0149167305588814*x_101 - 0.000421733511550877*x_102 - 0.00317015654439911*x_103 + 0.00717589112256753*x_104 + 0.000496265415017616*x_105 + 0.00103015601621316*x_106 - 9.89585597464968e-5*x_107 + 0.000473223553543415*x_108 - 0.0015902658722679*x_109 + 0.00494312594965885*x_11 + 0.00179441535055653*x_110 - 0.00295367419477147*x_111 - 0.0119261256268913*x_112 - 0.00704855193225962*x_113 - 0.0056030349419965*x_114 - 7.40104878854022e-5*x_115 + 0.00485283676950319*x_116 - 0.000439439276890859*x_117 - 0.0059861657737139*x_118 + 0.00127861968210602*x_119 - 0.0116170891584287*x_12 + 7.53449810717312e-5*x_120 - 0.00840004413161203*x_13 + 0.000103488860744069*x_14 + 0.00286330569115648*x_15 + 0.00308172409603651*x_16 - 0.00527781056339313*x_17 + 0.00253172824633149*x_18 - 0.0130347301206277*x_19 + 0.0197602630165938*x_2 - 0.00613434867195331*x_20 + 0.0155545192256754*x_21 - 0.020126505057402*x_22 + 0.00135762516367058*x_23 - 0.00217558230193041*x_24 - 0.00486010126902637*x_25 + 0.000511928197890685*x_26 + 0.00152561705851204*x_27 - 0.00276084588653069*x_28 + 0.00228587779170411*x_29 + 0.00464029785325321*x_3 + 0.00284840101636754*x_30 + 0.0116593902313567*x_32 + 0.00525403094977259*x_33 - 0.0155984098874358*x_34 + 0.00226547075034968*x_35 - 0.00258173459280101*x_36 + 0.00436838766073704*x_37 - 0.00575446230039133*x_38 - 0.00306647900928438*x_39 + 0.00557859888751818*x_4 + 0.00134651557752176*x_40 - 0.00153013851060789*x_41 - 0.00609785308337854*x_42 + 0.00174845537836471*x_43 + 0.00521453381078154*x_44 + 0.00142441058354922*x_45 + 8.95977459540547e-5*x_46 + 0.00300792782251766*x_47 - 0.0057454694572579*x_48 - 0.00946190389769202*x_49 + 0.00475405349496213*x_5 - 0.00256145210276056*x_50 - 0.00111966253513577*x_51 - 0.0080225274810514*x_52 - 0.00119914311740321*x_53 + 0.00479715890365503*x_54 - 0.000141882083126899*x_55 + 0.000615022154955655*x_56 - 0.0027661432922659*x_57 + 0.00119469996940258*x_58 + 0.00460346743468673*x_59 - 0.00147121450625946*x_6 - 0.00156552967050351*x_60 - 0.0391574181116917*x_61 + 0.0048515251811857*x_62 + 0.0103375161838217*x_63 + 0.0057461168166359*x_64 + 0.0199700258215581*x_65 + 0.00322473267789355*x_66 + 0.000379049987300995*x_67 - 0.00635181357444025*x_68 - 0.0125369845181804*x_69 + 0.00267958044614108*x_7 - 0.00635175853724493*x_70 + 0.00127382973565967*x_71 - 0.000118600889751754*x_72 + 0.00100696176269627*x_73 - 6.00942067262946e-5*x_74 - 0.0012081442920235*x_75 - 0.00299172080784078*x_76 - 0.0100066977190589*x_77 + 0.00438933526116729*x_78 - 0.00489235107782243*x_79 - 0.0117473277263194*x_8 - 0.00173883970011298*x_80 - 0.000137454391274005*x_81 - 0.00118568601358005*x_82 + 0.000513301871664384*x_83 - 0.00171867771257764*x_84 - 0.00552868665295221*x_85 + 0.000160535040625241*x_86 + 0.00214075108732472*x_87 + 0.00234412602429345*x_88 - 0.00377206978480466*x_89 - 0.0114248198371522*x_9 + 0.00265076867478999*x_90 + 0.0222963211692947*x_91 - 0.00671210949222502*x_92 + 0.0132197042437807*x_93 + 0.00788707920441535*x_94 + 0.000779347239216095*x_95 + 0.00242152291232698*x_96 - 0.00313019578866469*x_97 - 0.00519782755105573*x_98 + 0.000911768865190903*x_99 + 0.000279508033685564*std::pow(-3.32999968528748*x_107 - 4.77767992019653, 2) - 1.01389711991019e-5*std::pow(-7.90552043914795*x_120 - 8.69736003875732, 2) - 2.6679638037686e-5*std::pow(-5.1595196723938*x_44 - 5.36368036270142, 2) + 5.47852899843766e-5*std::pow(-4.45591974258423*x_46 - 6.28136014938354, 2) + 1.52561645554563e-6*std::pow(-6.60648012161255*x_7 - 9.8500804901123, 2) - 2.34751292211549e-6*std::exp(1.07223987579346*x_1) + 0.000398251872054923*std::exp(1.1743198633194*x_1) + 7.14187038318357e-5*std::exp(1.23903977870941*x_1) + 4.83257951955079e-5*std::exp(1.2526398897171*x_1) + 1.04412308833397e-5*std::exp(1.01119983196259*x_100) + 0.000555013505131166*std::exp(1.49047994613647*x_100) - 5.9821265855971e-5*std::exp(1.55599987506866*x_100) - 0.000193194068062015*std::exp(1.71359992027283*x_100) - 0.00100447994355472*std::exp(0.988239824771881*x_104) + 4.02469523233407e-6*std::exp(1.10151982307434*x_104) - 7.04374288643484e-7*std::exp(1.85015988349915*x_108) - 0.00222014699764061*std::exp(0.709599852561951*x_110) + 5.22539355107213e-7*std::exp(1.53679978847504*x_110) + 5.09991628077511e-5*std::exp(1.75319993495941*x_110) - 9.77810987199453e-5*std::exp(0.931999802589417*x_26) + 0.000436847665445295*std::exp(1.02751982212067*x_26) - 0.000765130814246806*std::exp(1.12487983703613*x_26) - 8.03485434958273e-7*std::exp(1.42727982997894*x_26) - 6.63356839513767e-5*std::exp(0.650559842586517*x_31) + 0.00295792168379991*std::exp(0.656399846076965*x_31) + 7.57295845423136e-5*std::exp(0.662319839000702*x_31) + 0.00143672206977528*std::exp(0.669119834899902*x_31) - 0.00233512660490978*std::exp(0.672959864139557*x_31) - 5.80815279009096e-7*std::exp(2.07623982429504*x_50) + 0.000587330882301342*std::exp(2.4347198009491*x_6) + 1.26218155476315e-5*std::exp(2.55671977996826*x_6) + 1.84914987984568e-5*std::exp(1.11615991592407*x_60) + 0.00116613742235915*std::exp(1.21999990940094*x_60) - 0.00033523331123493*std::exp(1.80375993251801*x_66) - 2.03919773443475e-6*std::exp(1.27743983268738*x_68) + 0.00291720477878352*std::exp(1.09599983692169*x_72) - 0.000130974731299608*std::exp(1.20895993709564*x_72) - 0.000900359233359384*std::exp(1.28823983669281*x_74) - 3.40502192146479e-6*std::exp(1.41407978534698*x_74) - 2.10644567438223e-5*std::exp(1.6594398021698*x_74) - 0.00110083660003831*std::exp(1.68279981613159*x_74) - 0.000903196063150046*std::exp(0.702319860458374*x_81) - 0.000470361637614167*std::exp(1.94055986404419*x_81) - 4.90405102157659e-6*std::exp(2.382239818573*x_81) - 0.0575292734556256*std::sin(0.419039845466614*x_102 - 4.19719982147217) - 9.00374127680016e-5*std::sin(0.410159856081009*x_116 + 5.20904016494751) - 0.0105279478504443*std::sin(0.421519875526428*x_117 + 5.20256042480469) - 0.000666727990732692*std::sin(0.60207986831665*x_117 + 2.21143984794617) + 0.0107146519301034*std::sin(0.347279846668243*x_119 + 5.15664005279541) + 0.00847165543576201*std::sin(0.357359826564789*x_34 + 2.00071978569031) - 0.00275058884562519*std::sin(0.660639822483063*x_38 + 2.207279920578) - 0.00506246919719771*std::sin(0.299599945545197*x_40 - 7.49639987945557) - 9.9186250386702e-5*std::sin(0.347039848566055*x_40 - 4.26104021072388) + 0.000798233863093386*std::sin(0.391039848327637*x_40 + 8.38735961914063) - 0.00111352490250665*std::sin(0.297999918460846*x_42 + 5.08511972427368) - 0.0130461512861267*std::sin(0.693439841270447*x_53 + 2.23831987380981) + 0.0119687444555809*std::sin(0.345199853181839*x_54 + 5.14368009567261) + 0.00142724678040275*std::sin(0.473919868469238*x_60 + 8.46807956695557) - 0.000268689496068375*std::sin(0.218639999628067*x_64 - 4.37271976470947) + 0.00856712027950039*std::sin(0.25247997045517*x_64 - 4.33031988143921) - 0.0001385310772151*std::sin(0.263599961996078*x_70 + 5.06279993057251) + 0.00198471834733183*std::sin(0.442879855632782*x_76 - 4.1482400894165) + 0.0308501155230379*std::sin(0.286719918251038*x_83 + 5.0959997177124) - 0.000278997232307364*std::sin(0.399679869413376*x_98 + 5.18943977355957) + 0.187763411435945 + 2.48883927484403e-6*std::exp(-2.00783967971802*x_30));
}

inline float score_9(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.00106214628561862*x_1 + 3.58901027102962e-5*x_10 - 0.000351483846507677*x_100 + 0.0140970170951412*x_101 - 0.000106115282478948*x_102 + 0.0112074976682046*x_103 - 0.0104361754051516*x_104 + 0.000555574085247304*x_105 - 0.00673846689718173*x_106 - 8.73930001928381e-5*x_107 - 0.00408030901823725*x_108 + 0.000236555580499963*x_109 - 0.00477970477378855*x_11 - 0.00187394445813588*x_110 + 0.00236554649737727*x_111 + 0.0102354165186138*x_112 + 0.00491059738001966*x_113 + 0.00267153838703205*x_114 - 0.00259580405196662*x_115 - 0.00558871236416631*x_116 - 0.000139621137203674*x_117 + 0.0101300012821099*x_118 + 0.000407279811976796*x_119 + 0.0134504853024065*x_12 + 0.000242345452419018*x_120 + 0.0027145020499971*x_13 + 0.000807743749397191*x_14 - 0.00342433422183071*x_15 - 0.00322461117909593*x_16 + 0.000169978910181987*x_17 - 0.00297098979097937*x_18 + 0.0143733501900557*x_19 - 0.010432582901144*x_2 + 0.00995313002214273*x_20 - 0.0155516201173178*x_21 + 0.0277069802326786*x_22 - 0.000390349815592473*x_23 + 0.00123204931546703*x_24 + 0.00139075122406419*x_25 + 0.000153781370301038*x_26 - 0.000641321297092311*x_27 + 0.00248968475069877*x_28 - 0.00487014422181615*x_29 - 0.0055212186157388*x_3 - 0.00247967053646013*x_30 - 0.0106806149017892*x_32 - 0.00960640087610266*x_33 + 0.0181211025096509*x_34 - 0.00333181712043553*x_35 + 0.00219906188363829*x_36 - 0.00225932942327971*x_37 + 0.00674419003174981*x_38 + 0.00987348114353345*x_39 - 0.0019088217468897*x_4 + 0.00228565582997408*x_40 - 0.00249713659955101*x_41 + 0.0125718581045172*x_42 - 0.00414733044456953*x_43 - 0.00597885764601911*x_44 - 0.00365859887217569*x_45 - 6.1477787070836e-6*x_46 - 0.000902729621566858*x_47 + 0.00513812379216735*x_48 + 0.00618892618745486*x_49 - 0.00614973918130041*x_5 + 0.00254447664625409*x_50 + 0.00452589170555942*x_51 + 0.00644725493821232*x_52 - 0.000325269767502909*x_53 - 0.00462047605981465*x_54 - 0.000477124934106306*x_55 + 1.69897805290351e-5*x_56 - 0.00117130700716082*x_57 - 0.00139560530086794*x_58 - 0.00422727570582435*x_59 - 0.000398495144237656*x_6 - 0.00049990993681993*x_60 + 0.0297215275148646*x_61 - 0.00599635535986511*x_62 - 0.0120911531089372*x_63 - 0.00662521744016063*x_64 - 0.0137984411692473*x_65 - 0.00326762087152262*x_66 - 0.00117709025068283*x_67 + 0.00167832978602565*x_68 + 0.00423673872884091*x_69 - 0.00247750935604606*x_7 + 0.00752164484356397*x_70 - 0.00141198352019161*x_71 - 0.000156710014497445*x_72 + 0.000763299776612728*x_73 + 3.67309467057766e-5*x_74 + 0.000138729889775432*x_75 + 0.00398535846385135*x_76 + 0.00492125982835648*x_77 - 0.00216173684548996*x_78 + 0.00392593171652966*x_79 + 0.0109373355877876*x_8 + 0.00150915444551211*x_80 - 3.97114145042378e-5*x_81 - 8.04967346153051e-5*x_82 + 0.000124152108618137*x_83 - 0.000151392966669274*x_84 + 0.00384107031841628*x_85 - 0.00155382821519656*x_86 - 0.00383560704972479*x_87 - 0.00217825690314141*x_88 + 0.00426432088612815*x_89 + 0.00354772059274054*x_9 - 0.00431010288607002*x_90 - 0.0205057059885403*x_91 + 0.00508463088247653*x_92 - 0.0207500738581002*x_93 - 0.00980599461870787*x_94 - 0.00131788943393428*x_95 - 0.00569909311357744*x_96 - 0.00162549535680407*x_97 + 0.00543971022315045*x_98 - 0.000857445024824124*x_99 - 0.000290263998604448*std::pow(-3.32999968528748*x_107 - 4.77767992019653, 2) + 1.05291367950353e-5*std::pow(-7.90552043914795*x_120 - 8.69736003875732, 2) - 4.71373614412246e-6*std::pow(-5.1595196723938*x_44 - 5.36368036270142, 2) - 5.68935251194202e-5*std::pow(-4.45591974258423*x_46 - 6.28136014938354, 2) - 9.32491495849679e-7*std::pow(-6.60648012161255*x_7 - 9.8500804901123, 2) + 1.37676373698564e-6*std::exp(1.07223987579346*x_1) - 0.00041357731049839*std::exp(1.1743198633194*x_1) + 1.2618196886441e-5*std::exp(1.23903977870941*x_1) + 1.45168932609558e-5*std::exp(1.2526398897171*x_1) - 6.12354799594555e-6*std::exp(1.01119983196259*x_100) - 0.000576371409274319*std::exp(1.49047994613647*x_100) + 3.65641190345612e-5*std::exp(1.55599987506866*x_100) - 3.41333664335186e-5*std::exp(1.71359992027283*x_100) - 0.000177470676674542*std::exp(0.988239824771881*x_104) - 2.36039358765409e-6*std::exp(1.10151982307434*x_104) + 4.13099740041258e-7*std::exp(1.85015988349915*x_108) - 0.000666924090084629*std::exp(0.709599852561951*x_110) - 3.06457625209221e-7*std::exp(1.53679978847504*x_110) + 9.01048944919392e-6*std::exp(1.75319993495941*x_110) + 5.97660327271292e-5*std::exp(0.931999802589417*x_26) - 0.000453658338478442*std::exp(1.02751982212067*x_26) - 0.000135182672606072*std::exp(1.12487983703613*x_26) + 4.7122620694663e-7*std::exp(1.42727982997894*x_26) + 3.89043925049383e-5*std::exp(0.650559842586517*x_31) + 0.000522603130249234*std::exp(0.656399846076965*x_31) - 4.62876454388275e-5*std::exp(0.662319839000702*x_31) + 0.000431586088717398*std::exp(0.669119834899902*x_31) + 0.00242498641864171*std::exp(0.672959864139557*x_31) + 3.40635149009663e-7*std::exp(2.07623982429504*x_50) - 0.000609932416441563*std::exp(2.4347198009491*x_6) - 7.71474089543707e-6*std::exp(2.55671977996826*x_6) - 1.08448497762844e-5*std::exp(1.11615991592407*x_60) - 0.00121101245882985*std::exp(1.21999990940094*x_60) - 0.000100702868458264*std::exp(1.80375993251801*x_66) + 1.19594378666211e-6*std::exp(1.27743983268738*x_68) - 0.00302946399311829*std::exp(1.09599983692169*x_72) - 2.31405060301648e-5*std::exp(1.20895993709564*x_72) - 0.000270464641798779*std::exp(1.28823983669281*x_74) + 1.99696907350325e-6*std::exp(1.41407978534698*x_74) - 3.72165060745596e-6*std::exp(1.6594398021698*x_74) + 0.00114319874503753*std::exp(1.68279981613159*x_74) - 0.000159575925358721*std::exp(0.702319860458374*x_81) + 0.000488461987742415*std::exp(1.94055986404419*x_81) + 2.99746758512617e-6*std::exp(2.382239818573*x_81) + 0.0597431019418354*std::sin(0.419039845466614*x_102 - 4.19719982147217) + 5.28049254609785e-5*std::sin(0.410159856081009*x_116 + 5.20904016494751) + 0.0109330819578761*std::sin(0.421519875526428*x_117 + 5.20256042480469) + 0.000407519320562667*std::sin(0.60207986831665*x_117 + 2.21143984794617) - 0.0111269707416903*std::sin(0.347279846668243*x_119 + 5.15664005279541) + 0.00254485450693598*std::sin(0.357359826564789*x_34 + 2.00071978569031) - 0.000485971737732319*std::sin(0.660639822483063*x_38 + 2.207279920578) - 0.000894432825498976*std::sin(0.299599945545197*x_40 - 7.49639987945557) + 5.81705137609764e-5*std::sin(0.347039848566055*x_40 - 4.26104021072388) - 0.000487898702408534*std::sin(0.391039848327637*x_40 + 8.38735961914063) + 0.00068061176072785*std::sin(0.297999918460846*x_42 + 5.08511972427368) + 0.0135481903284745*std::sin(0.693439841270447*x_53 + 2.23831987380981) + 0.00211462776445262*std::sin(0.345199853181839*x_54 + 5.14368009567261) + 0.00025216476797263*std::sin(0.473919868469238*x_60 + 8.46807956695557) + 0.000157580369935738*std::sin(0.218639999628067*x_64 - 4.37271976470947) + 0.00257353179907607*std::sin(0.25247997045517*x_64 - 4.33031988143921) + 8.12453732452443e-5*std::sin(0.263599961996078*x_70 + 5.06279993057251) - 0.00121310501982089*std::sin(0.442879855632782*x_76 - 4.1482400894165) - 0.0320372826893405*std::sin(0.286719918251038*x_83 + 5.0959997177124) + 0.000170529457483577*std::sin(0.399679869413376*x_98 + 5.18943977355957) + 0.00971762159528435 - 1.52123520291915e-6*std::exp(-2.00783967971802*x_30));
}

inline float score_10(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.000883994766603913*x_1 - 0.000113561571076127*x_10 - 0.00115689505023556*x_100 - 0.00708920774489131*x_101 - 0.000321689352411146*x_102 + 0.00106923594767494*x_103 + 0.00107486220776186*x_104 + 0.000739287629791106*x_105 - 0.00188676694003937*x_106 - 0.000215518038355266*x_107 - 0.0014406299228121*x_108 - 0.00142421048840356*x_109 + 0.00255100095787455*x_11 + 0.000739973664135185*x_110 - 0.00144417734609427*x_111 - 0.00686848310374237*x_112 - 0.00384335724034973*x_113 - 0.00405490042743165*x_114 - 0.000795852048701446*x_115 + 0.00128786721838577*x_116 - 0.00046556222472602*x_117 - 0.00187600941293893*x_118 + 0.00135762366591397*x_119 - 0.0035159713542695*x_12 + 0.000358144796421699*x_120 - 0.00569759696738998*x_13 + 0.000407752385009426*x_14 + 0.00117582221122723*x_15 + 0.00160906718761987*x_16 - 0.00440084061975705*x_17 + 0.000962611887494701*x_18 - 0.00529087632416722*x_19 + 0.00919961080927969*x_2 - 0.00101112941243002*x_20 + 0.0067627919314842*x_21 - 0.00441660298929838*x_22 + 0.00123586478797688*x_23 - 0.00144437724524482*x_24 - 0.00332223750068092*x_25 + 0.000506165241695758*x_26 + 0.000841388734543018*x_27 - 0.00137239655824445*x_28 - 0.000177388284222611*x_29 + 0.00189483071741056*x_3 + 0.0012992077440062*x_30 + 0.00525100978335527*x_32 + 0.000744265223309744*x_33 - 0.00636655880778542*x_34 + 0.000723732637269852*x_35 - 0.00172268191208822*x_36 + 0.00194355968902643*x_37 - 0.0019964034912128*x_38 + 0.000697287802549931*x_39 + 0.00284292807702322*x_4 + 0.00215861777824995*x_40 - 0.00188232508870386*x_41 + 0.000183860670566941*x_42 + 0.000187348594421945*x_43 + 0.00171231125902165*x_44 + 0.000391651729858292*x_45 - 0.000107310562571801*x_46 + 0.00193075047924848*x_47 - 0.00264573235582559*x_48 - 0.00514904212317112*x_49 + 0.00185473410905338*x_5 - 0.000571337957140894*x_50 + 0.00151615256317838*x_51 - 0.00382879455188281*x_52 - 0.000966109161840351*x_53 + 0.00197832347115991*x_54 - 0.00034697188648554*x_55 + 0.000256842385223382*x_56 - 0.00246958143686204*x_57 + 0.000467713833788696*x_58 + 0.00212403760825024*x_59 - 0.0012760364672666*x_6 - 0.00159657770610566*x_60 - 0.0202950979787867*x_61 + 0.00171182468320847*x_62 + 0.00273067984025933*x_63 + 0.0023088431030709*x_64 + 0.00995338463602568*x_65 + 0.00103702820704417*x_66 - 0.000278095572050745*x_67 - 0.00419444246792592*x_68 - 0.00824416344626404*x_69 + 0.000811369499097064*x_7 - 0.00224984498468465*x_70 + 0.000346194978899162*x_71 - 0.000328988715638895*x_72 + 0.00105116359864561*x_73 + 3.05701437739363e-5*x_74 - 0.00106455865607263*x_75 - 0.000718390512293681*x_76 - 0.00629605279358113*x_77 + 0.00276120601573533*x_78 - 0.00225659710252289*x_79 - 0.00346739960954272*x_8 - 0.000462977313371148*x_80 - 0.000129193457469807*x_81 - 0.00111412256241168*x_82 + 0.000443292182900211*x_83 - 0.00141304616682954*x_84 - 0.00298624294690958*x_85 - 0.000640410597770497*x_86 + 7.75061806155079e-5*x_87 + 0.00103736631911868*x_88 - 0.0011152055771644*x_89 - 0.00840463037372394*x_9 + 0.000384532248437939*x_90 + 0.0114017716340895*x_91 - 0.00301393443398669*x_92 + 0.00321387635377044*x_93 + 0.0024112212639366*x_94 - 4.9687216581242e-5*x_95 - 0.000155512102229441*x_96 - 0.0016565886429671*x_97 - 0.00201163280937545*x_98 + 0.000625082667404115*x_99 + 0.000111791718259175*std::pow(-3.32999968528748*x_107 - 4.77767992019653, 2) - 4.05517149822956e-6*std::pow(-7.90552043914795*x_120 - 8.69736003875732, 2) - 1.27682727040242e-5*std::pow(-5.1595196723938*x_44 - 5.36368036270142, 2) + 2.19118628610529e-5*std::pow(-4.45591974258423*x_46 - 6.28136014938354, 2) - 7.76086696714912e-7*std::pow(-6.60648012161255*x_7 - 9.8500804901123, 2) + 6.52874143407786e-6*std::exp(1.07223987579346*x_1) + 0.000159284370076596*std::exp(1.1743198633194*x_1) + 3.4179379997762e-5*std::exp(1.23903977870941*x_1) + 4.77817746825839e-5*std::exp(1.2526398897171*x_1) - 2.90384329937586e-5*std::exp(1.01119983196259*x_100) + 0.000221982576234141*std::exp(1.49047994613647*x_100) + 3.04312977502992e-5*std::exp(1.55599987506866*x_100) - 9.24583212984836e-5*std::exp(1.71359992027283*x_100) - 0.000480721433585908*std::exp(0.988239824771881*x_104) - 1.11932054879578e-5*std::exp(1.10151982307434*x_104) + 1.95895731181819e-6*std::exp(1.85015988349915*x_108) - 0.00219515402021444*std::exp(0.709599852561951*x_110) - 1.45325050460231e-6*std::exp(1.53679978847504*x_110) + 2.44070484571976e-5*std::exp(1.75319993495941*x_110) + 4.97416042091501e-5*std::exp(0.931999802589417*x_26) + 0.000174721100118995*std::exp(1.02751982212067*x_26) - 0.00036617434152426*std::exp(1.12487983703613*x_26) + 2.23459841327002e-6*std::exp(1.42727982997894*x_26) + 0.000184488240422959*std::exp(0.650559842586517*x_31) + 0.00141559456850785*std::exp(0.656399846076965*x_31) - 3.85239179201283e-5*std::exp(0.662319839000702*x_31) + 0.00142054838294476*std::exp(0.669119834899902*x_31) - 0.000933954606146483*std::exp(0.672959864139557*x_31) + 1.61532349487345e-6*std::exp(2.07623982429504*x_50) + 0.000234908197998373*std::exp(2.4347198009491*x_6) - 6.42076394712384e-6*std::exp(2.55671977996826*x_6) - 5.14272842744959e-5*std::exp(1.11615991592407*x_60) + 0.000466407009676547*std::exp(1.21999990940094*x_60) - 0.000331459471669757*std::exp(1.80375993251801*x_66) + 5.67127644566247e-6*std::exp(1.27743983268738*x_68) + 0.00116676193679985*std::exp(1.09599983692169*x_72) - 6.26815507844395e-5*std::exp(1.20895993709564*x_72) - 0.000890223572063664*std::exp(1.28823983669281*x_74) + 9.46981270824157e-6*std::exp(1.41407978534698*x_74) - 1.00809736506669e-5*std::exp(1.6594398021698*x_74) - 0.000440289366348997*std::exp(1.68279981613159*x_74) - 0.000432249254027025*std::exp(0.702319860458374*x_81) - 0.000188125310670822*std::exp(1.94055986404419*x_81) + 2.49470877429385e-6*std::exp(2.382239818573*x_81) - 0.0230093433988424*std::sin(0.419039845466614*x_102 - 4.19719982147217) + 0.000250405857968991*std::sin(0.410159856081009*x_116 + 5.20904016494751) - 0.00421074616147944*std::sin(0.421519875526428*x_117 + 5.20256042480469) + 0.000339166978734538*std::sin(0.60207986831665*x_117 + 2.21143984794617) + 0.00428542011483911*std::sin(0.347279846668243*x_119 + 5.15664005279541) + 0.00837628702398869*std::sin(0.357359826564789*x_34 + 2.00071978569031) - 0.0013163697508932*std::sin(0.660639822483063*x_38 + 2.207279920578) - 0.00242278351656187*std::sin(0.299599945545197*x_40 - 7.49639987945557) + 0.0002758499757296*std::sin(0.347039848566055*x_40 - 4.26104021072388) - 0.000406064499214233*std::sin(0.391039848327637*x_40 + 8.38735961914063) + 0.000566454209480262*std::sin(0.297999918460846*x_42 + 5.08511972427368) - 0.00521792397060741*std::sin(0.693439841270447*x_53 + 2.23831987380981) + 0.00572797100611973*std::sin(0.345199853181839*x_54 + 5.14368009567261) + 0.000683048101416572*std::sin(0.473919868469238*x_60 + 8.46807956695557) + 0.000747260741083494*std::sin(0.218639999628067*x_64 - 4.37271976470947) + 0.00847067718632665*std::sin(0.25247997045517*x_64 - 4.33031988143921) + 0.000385273101247349*std::sin(0.263599961996078*x_70 + 5.06279993057251) - 0.00100963351600672*std::sin(0.442879855632782*x_76 - 4.1482400894165) + 0.0123387774488594*std::sin(0.286719918251038*x_83 + 5.0959997177124) + 0.000141926917232016*std::sin(0.399679869413376*x_98 + 5.18943977355957) + 0.154653196792529 - 1.26608168419187e-6*std::exp(-2.00783967971802*x_30));
}

inline float score_11(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.00120631032870948*x_1 + 0.000240641229183374*x_10 + 0.000928610661195459*x_100 + 0.00909896742398718*x_101 + 0.000352965268956665*x_102 + 0.000921493654091076*x_103 - 0.00304934965851885*x_104 - 0.000516670899830649*x_105 + 0.000241802880003989*x_106 + 0.000160340079708314*x_107 + 2.07926627704704e-5*x_108 + 0.0013682319927296*x_109 - 0.0025622028247834*x_11 - 0.00106294361461123*x_110 + 0.00226899229154621*x_111 + 0.0075641268351162*x_112 + 0.00434201867792065*x_113 + 0.00425240629929981*x_114 + 0.000292640599320099*x_115 - 0.00281560912998284*x_116 + 0.000350160824919927*x_117 + 0.00361899141781733*x_118 - 0.00102276479549161*x_119 + 0.00552424506239862*x_12 - 0.000406549928471759*x_120 + 0.00596173352974263*x_13 - 0.000159358976556833*x_14 - 0.00154559447532976*x_15 - 0.00193338800649958*x_16 + 0.00396367734847888*x_17 - 0.00145735206012357*x_18 + 0.00734086964202308*x_19 - 0.0112165913092303*x_2 + 0.00282133780270816*x_20 - 0.00840864037565991*x_21 + 0.00968260191001456*x_22 - 0.00114178291123137*x_23 + 0.00158199622438028*x_24 + 0.00367301881139374*x_25 - 0.000406286153328733*x_26 - 0.00119302480590587*x_27 + 0.0016547456321382*x_28 - 0.000801425782398422*x_29 - 0.00271401707170413*x_3 - 0.00170722924535899*x_30 - 0.00723075505926095*x_32 - 0.00253249135584194*x_33 + 0.00903461182609389*x_34 - 0.0011983842898463*x_35 + 0.0014211696160322*x_36 - 0.00229091130226578*x_37 + 0.00321827119529258*x_38 + 0.00120603987923772*x_39 - 0.00289937616348627*x_4 - 0.00137581644906808*x_40 + 0.00148691886031696*x_41 + 0.00249462104322405*x_42 - 0.000988802765340145*x_43 - 0.00276867551168667*x_44 - 0.000689410205100138*x_45 - 4.32994305174972e-5*x_46 - 0.00196972318897201*x_47 + 0.0034600165811921*x_48 + 0.00632715155337588*x_49 - 0.00236485520442904*x_5 + 0.00139842765849408*x_50 - 0.00030338471990689*x_51 + 0.00507455966827524*x_52 + 0.000977842093656047*x_53 - 0.00273239052137113*x_54 + 0.00019351518661264*x_55 - 0.000381437169602997*x_56 + 0.00245468833441411*x_57 - 0.000653127355318439*x_58 - 0.00275156345130672*x_59 + 0.00114063680721654*x_6 + 0.00129082425656978*x_60 + 0.0244428751729717*x_61 - 0.00263970372408699*x_62 - 0.00487124734754517*x_63 - 0.00331425469548488*x_64 - 0.0121171037545552*x_65 - 0.0014990500361098*x_66 - 9.97725878052441e-5*x_67 + 0.00432189866569469*x_68 + 0.0086831350240053*x_69 - 0.00151069170955625*x_7 + 0.00354015028389929*x_70 - 0.000731370861878816*x_71 + 0.000296588217767901*x_72 - 0.000837438682501794*x_73 - 4.17164010215873e-5*x_74 + 0.00112306324271307*x_75 + 0.00156214830630425*x_76 + 0.00635825152347134*x_77 - 0.00295209259292091*x_78 + 0.00296590425378367*x_79 + 0.00493328750465331*x_8 + 0.00100833379218125*x_80 + 0.000104955290412773*x_81 + 0.000865578022363555*x_82 - 0.000341814701755508*x_83 + 0.00140919218971092*x_84 + 0.00357976632634407*x_85 + 0.000225028797909788*x_86 - 0.000995778804026989*x_87 - 0.0012767204002156*x_88 + 0.00203687487168036*x_89 + 0.00821722466651644*x_9 - 0.00101174068174898*x_90 - 0.0125265775211162*x_91 + 0.00398806862539238*x_92 - 0.00656561792110132*x_93 - 0.00448745752907722*x_94 - 0.000221762836739462*x_95 - 0.000839682242367887*x_96 + 0.00174905950918172*x_97 + 0.00297935932482008*x_98 - 0.000389336002423303*x_99 - 0.000160722210452186*std::pow(-3.32999968528748*x_107 - 4.77767992019653, 2) + 5.83009311519071e-6*std::pow(-7.90552043914795*x_120 - 8.69736003875732, 2) + 1.85124504317177e-5*std::pow(-5.1595196723938*x_44 - 5.36368036270142, 2) - 3.15025396245267e-5*std::pow(-4.45591974258423*x_46 - 6.28136014938354, 2) + 1.05905762521409e-6*std::pow(-6.60648012161255*x_7 - 9.8500804901123, 2) - 3.58619297501729e-6*std::exp(1.07223987579346*x_1) - 0.000229002080367374*std::exp(1.1743198633194*x_1) - 4.95559652165002e-5*std::exp(1.23903977870941*x_1) - 3.8353232967893e-5*std::exp(1.2526398897171*x_1) + 1.59506124509947e-5*std::exp(1.01119983196259*x_100) - 0.000319142874711954*std::exp(1.49047994613647*x_100) - 4.15269299989734e-5*std::exp(1.55599987506866*x_100) + 0.000134053378222299*std::exp(1.71359992027283*x_100) + 0.000696987910347386*std::exp(0.988239824771881*x_104) + 6.14835114763722e-6*std::exp(1.10151982307434*x_104) - 1.07604184067268e-6*std::exp(1.85015988349915*x_108) + 0.00176199511418269*std::exp(0.709599852561951*x_110) + 7.98260553457076e-7*std::exp(1.53679978847504*x_110) - 3.53872669563203e-5*std::exp(1.75319993495941*x_110) - 6.78780160142763e-5*std::exp(0.931999802589417*x_26) - 0.000251195364567695*std::exp(1.02751982212067*x_26) + 0.00053090848730841*std::exp(1.12487983703613*x_26) - 1.22744961070519e-6*std::exp(1.42727982997894*x_26) - 0.000101338127487287*std::exp(0.650559842586517*x_31) - 0.00205244083427596*std::exp(0.656399846076965*x_31) + 5.25702208260125e-5*std::exp(0.662319839000702*x_31) - 0.00114023858333379*std::exp(0.669119834899902*x_31) + 0.00134274033085222*std::exp(0.672959864139557*x_31) - 8.87286137487192e-7*std::exp(2.07623982429504*x_50) - 0.000337725955227811*std::exp(2.4347198009491*x_6) + 8.76185488900232e-6*std::exp(2.55671977996826*x_6) + 2.82486551890017e-5*std::exp(1.11615991592407*x_60) - 0.000670550258399451*std::exp(1.21999990940094*x_60) + 0.000266054210435146*std::exp(1.80375993251801*x_66) - 3.11519332694915e-6*std::exp(1.27743983268738*x_68) - 0.00167744588305901*std::exp(1.09599983692169*x_72) + 9.08806640317458e-5*std::exp(1.20895993709564*x_72) + 0.000714560149338958*std::exp(1.28823983669281*x_74) - 5.20170329181095e-6*std::exp(1.41407978534698*x_74) + 1.46161919734535e-5*std::exp(1.6594398021698*x_74) + 0.000633001096146898*std::exp(1.68279981613159*x_74) + 0.000626709115227486*std::exp(0.702319860458374*x_81) + 0.000270466509003113*std::exp(1.94055986404419*x_81) - 3.40431083445684e-6*std::exp(2.382239818573*x_81) + 0.0330803801006238*std::sin(0.419039845466614*x_102 - 4.19719982147217) - 0.000137546223543835*std::sin(0.410159856081009*x_116 + 5.20904016494751) + 0.00605376177470542*std::sin(0.421519875526428*x_117 + 5.20256042480469) - 0.00046283150654441*std::sin(0.60207986831665*x_117 + 2.21143984794617) - 0.0061611200212201*std::sin(0.347279846668243*x_119 + 5.15664005279541) - 0.00672343565660974*std::sin(0.357359826564789*x_34 + 2.00071978569031) + 0.00190857685515618*std::sin(0.660639822483063*x_38 + 2.207279920578) + 0.00351274293687339*std::sin(0.299599945545197*x_40 - 7.49639987945557) - 0.000151522503243369*std::sin(0.347039848566055*x_40 - 4.26104021072388) + 0.000554120700743756*std::sin(0.391039848327637*x_40 + 8.38735961914063) - 0.000772990507921385*std::sin(0.297999918460846*x_42 + 5.08511972427368) + 0.00750177461789428*std::sin(0.693439841270447*x_53 + 2.23831987380981) - 0.00830486486176688*std::sin(0.345199853181839*x_54 + 5.14368009567261) - 0.000990337096729449*std::sin(0.473919868469238*x_60 + 8.46807956695557) - 0.000410465209449414*std::sin(0.218639999628067*x_64 - 4.37271976470947) - 0.00679920027418777*std::sin(0.25247997045517*x_64 - 4.33031988143921) - 0.000211627876997018*std::sin(0.263599961996078*x_70 + 5.06279993057251) + 0.00137775853950942*std::sin(0.442879855632782*x_76 - 4.1482400894165) - 0.0177393783433997*std::sin(0.286719918251038*x_83 + 5.0959997177124) - 0.000193675248595209*std::sin(0.399679869413376*x_98 + 5.18943977355957) + 0.00864261249285767 + 1.72771092129652e-6*std::exp(-2.00783967971802*x_30));
}

int predict(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120)
{
    float s0 = score_0(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s1 = score_1(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s2 = score_2(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s3 = score_3(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s4 = score_4(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s5 = score_5(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s6 = score_6(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s7 = score_7(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s8 = score_8(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s9 = score_9(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s10 = score_10(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s11 = score_11(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);

    float max_score = s0;
    int max_index = 0;

    if(s1 > max_score) {
        max_score = s1;
        max_index = 1;
    }

    if(s2 > max_score) {
        max_score = s2;
        max_index = 2;
    }

    if(s3 > max_score) {
        max_score = s3;
        max_index = 3;
    }

    if(s4 > max_score) {
        max_score = s4;
        max_index = 4;
    }

    if(s5 > max_score) {
        max_score = s5;
        max_index = 5;
    }

    if(s6 > max_score) {
        max_score = s6;
        max_index = 6;
    }

    if(s7 > max_score) {
        max_score = s7;
        max_index = 7;
    }

    if(s8 > max_score) {
        max_score = s8;
        max_index = 8;
    }

    if(s9 > max_score) {
        max_score = s9;
        max_index = 9;
    }

    if(s10 > max_score) {
        max_score = s10;
        max_index = 10;
    }

    if(s11 > max_score) {
        max_score = s11;
        max_index = 11;
    }

    return max_index;
}

#endif
