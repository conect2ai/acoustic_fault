
#ifndef KAN_MODEL_H
#define KAN_MODEL_H

#include <cmath>


inline float score_0(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.00106551747601254*x_1 + 0.00117238710394174*x_10 + 0.0443976006725319*x_100 - 0.0450347936254103*x_101 - 0.0261645865757629*x_102 - 0.00887627471235161*x_103 - 0.00865075124537789*x_104 + 0.0212548204997076*x_105 - 0.002955198334317*x_106 + 0.110927273153128*x_107 - 0.0190744111626596*x_108 - 0.00343187512722258*x_109 + 0.0219356394422826*x_11 + 0.0177740277156486*x_110 - 0.0368321360870699*x_111 + 0.00242953501322377*x_112 - 0.0385722539300688*x_113 + 0.0100659690646727*x_114 - 0.0158046466656111*x_115 - 0.0164511828100205*x_116 + 0.0102554802668364*x_117 + 0.0372925111662057*x_118 - 0.0246797105154173*x_119 + 0.0754432986807388*x_12 + 0.027723850161807*x_120 + 0.0194016478844713*x_13 + 0.0447882210910919*x_14 - 0.025298952625617*x_15 - 0.000322246506381763*x_16 + 0.00486696792274212*x_17 + 0.0455546835718074*x_18 + 0.0790133815373378*x_19 - 0.0183217593298133*x_2 + 0.00408305162605854*x_20 - 0.035536922665331*x_21 - 0.00926061862532067*x_22 - 0.015779270795301*x_23 + 0.0369908881053015*x_24 - 0.0244293249829477*x_25 - 0.0197772351459712*x_26 - 0.00702287111366576*x_27 + 0.00547412971205991*x_28 + 0.0118229244694089*x_29 - 0.0118645164576974*x_3 - 0.0245217901065799*x_30 - 0.0647173339165489*x_32 + 0.00391151031951787*x_33 - 0.0654436035955313*x_34 + 0.0343308136360907*x_35 + 0.00881334913387971*x_36 - 0.0626256719833546*x_37 - 0.0297211914485547*x_38 - 0.0478347001950237*x_39 + 0.0149329736219228*x_4 + 0.0650643679787677*x_40 - 0.0306432570848212*x_41 - 0.031765118869323*x_42 + 0.0480826234988895*x_43 + 0.0223072117918881*x_44 + 0.00661403960449144*x_45 - 0.0206038165640697*x_46 + 0.0762754683346041*x_47 - 0.0391176590137172*x_48 + 0.00543996956014462*x_49 - 0.00281499239007022*x_5 + 0.0298383360388025*x_50 + 0.000936923185852357*x_51 - 0.05187686024759*x_52 + 0.00176309063994779*x_53 - 0.0269456803447476*x_54 - 0.00732303654125728*x_55 - 0.00219549478177256*x_56 - 0.0661672797260773*x_57 - 0.025859429442022*x_58 - 0.00978427681435576*x_59 + 0.0066587529233981*x_6 - 0.0407915928376574*x_60 - 0.0155482680943388*x_61 - 0.0799248122743112*x_62 + 0.0359422131923136*x_63 - 0.00746547143248611*x_64 - 0.015890619057174*x_65 - 0.00185038836041425*x_66 - 0.039939514613566*x_67 - 0.0236382118242187*x_68 - 0.00420027635883824*x_69 - 0.023204062292986*x_7 - 0.000824843575124809*x_70 - 0.0187161976788244*x_71 - 0.0556715501527824*x_72 + 0.00286769878374945*x_73 + 0.00311598555915988*x_74 + 0.00523916690557716*x_75 + 0.00850393645191199*x_76 - 0.00291789964147567*x_77 - 0.013361313653622*x_78 - 0.0509007490606713*x_79 + 0.0863822930562482*x_8 - 0.0202672972360673*x_80 + 0.00174509682708897*x_81 - 0.0245928889401562*x_82 + 0.0186786183515456*x_83 - 0.00151508215913344*x_84 + 0.00345172838732997*x_85 + 0.0157053009279215*x_86 - 0.0166954319836024*x_87 - 0.00686358966314514*x_88 + 0.0651540662731924*x_89 - 0.0237044434958965*x_9 + 0.027806420371156*x_90 + 0.0633117989014326*x_91 - 0.00630062059763889*x_92 + 0.10852937132285*x_93 + 0.0284421501554225*x_94 - 6.63952992016787e-5*x_95 - 0.00233693863013424*x_96 + 0.103237886767268*x_97 - 0.00655878245584368*x_98 - 0.0147352496210166*x_99 + 0.000115646958913502*std::pow(-5.51063966751099*x_106 - 6.32424020767212, 2) - 4.26259406590814e-5*std::pow(-7.38335990905762*x_115 - 8.98408031463623, 2) - 2.69786300627584e-5*std::pow(-7.0025200843811*x_12 - 5.83999967575073, 2) - 0.000236234803311312*std::pow(-5.19456005096436*x_24 - 7.38416004180908, 2) - 0.000466593759933963*std::pow(-5.73055982589722*x_46 - 7.90679979324341, 2) + 3.96389734415708e-7*std::pow(-7.17063999176025*x_48 - 8.56703948974609, 2) + 0.000204187681868435*std::pow(-5.29519987106323*x_55 - 8.13951969146729, 2) + 5.65114955544391e-7*std::pow(-3.55464005470276*x_56 - 3.35920000076294, 2) - 9.31307912376092e-5*std::pow(-6.81983995437622*x_66 - 9.83775997161865, 2) + 3.80800231404001e-7*std::pow(-8.48000049591064*x_67 - 7.86736011505127, 2) + 0.000188251798817862*std::pow(-6.06615972518921*x_70 - 8.89816093444824, 2) - 6.21460831999579e-7*std::pow(-8.0*x_78 - 9.99958038330078, 2) + 0.000841321277797055*std::pow(-4.9223198890686*x_84 - 5.95056009292603, 2) + 9.55989656156761e-7*std::pow(-6.52711963653564*x_87 - 9.1879997253418, 2) - 2.47072264264483e-5*std::pow(-6.90120029449463*x_97 - 9.54792022705078, 2) + 0.00143463601041359*std::exp(0.647199809551239*x_1) - 0.00189117300187224*std::exp(1.04399979114532*x_1) - 8.56473562347153e-5*std::exp(1.09967982769012*x_1) - 3.08318403226189e-5*std::exp(1.19815981388092*x_1) - 2.04947305606467e-5*std::exp(1.27311992645264*x_1) - 3.37313994900057e-5*std::exp(1.29047989845276*x_1) - 6.59503887714534e-7*std::exp(1.31015980243683*x_1) - 0.000112809000151503*std::exp(1.54399979114532*x_100) - 0.000160535622145038*std::exp(1.70759987831116*x_100) + 0.00430229807173683*std::exp(0.54095983505249*x_104) - 0.00440820292922174*std::exp(0.627919852733612*x_104) - 0.0252967825029596*std::exp(0.683999836444855*x_104) - 0.00518762179043165*std::exp(0.887759864330292*x_104) - 0.0041081640901331*std::exp(0.580479860305786*x_106) - 0.00050456492878515*std::exp(0.845199882984161*x_106) + 0.00042688771568166*std::exp(1.07079982757568*x_106) + 8.15447253685233e-6*std::exp(1.07351982593536*x_106) - 4.75798894589202e-5*std::exp(1.21335983276367*x_106) - 0.0382804780045825*std::exp(0.737759828567505*x_109) - 0.0200022812081662*std::exp(0.857519865036011*x_109) + 0.00107923010566958*std::exp(0.90423983335495*x_109) - 3.58435720312056e-5*std::exp(1.03247976303101*x_109) - 2.32958954338591e-5*std::exp(1.1775997877121*x_109) + 0.00266901008699596*std::exp(0.931599855422974*x_110) + 0.000493484137568401*std::exp(1.26071989536285*x_110) + 2.74762919567646e-5*std::exp(1.28839981555939*x_110) - 0.000243989906566519*std::exp(1.36871981620789*x_110) + 8.51188700731297e-5*std::exp(0.541999876499176*x_112) - 0.0376835924757965*std::exp(0.607759833335876*x_114) - 0.000611312151963687*std::exp(0.76911985874176*x_114) + 0.00711061581575575*std::exp(1.25623989105225*x_23) - 1.61091733114673e-5*std::exp(1.3840799331665*x_23) + 0.0623506650382534*std::exp(0.684879839420319*x_26) + 9.08375887566311e-5*std::exp(0.75959986448288*x_26) - 0.00102350943709969*std::exp(0.774799823760986*x_26) - 0.00162187081702974*std::exp(0.96783983707428*x_26) - 1.64703116596535e-5*std::exp(1.06383979320526*x_26) + 6.38774495988532e-6*std::exp(1.18863987922668*x_26) + 0.000104092420047773*std::exp(1.24711990356445*x_26) + 0.000115831306818887*std::exp(0.523999869823456*x_31) + 0.00151726815834493*std::exp(0.626479864120483*x_31) - 0.309753824750612*std::exp(0.638719856739044*x_31) - 0.0579917803557014*std::exp(0.644239842891693*x_31) + 0.00753506560073532*std::exp(0.646319806575775*x_31) + 0.00240600100926952*std::exp(0.647919833660126*x_31) + 0.000399330347430822*std::exp(0.657999873161316*x_31) + 0.00281372683551825*std::exp(0.658879816532135*x_31) + 0.00334408314559806*std::exp(0.66103982925415*x_31) - 6.9488412795409e-5*std::exp(0.678959846496582*x_31) - 0.000139199202060405*std::exp(0.578719854354858*x_45) + 0.000143139900078838*std::exp(0.62255984544754*x_45) + 0.000170594840965305*std::exp(1.25087988376617*x_45) - 0.000641842917178145*std::exp(1.30271983146667*x_50) + 1.5568118007025e-6*std::exp(2.01959991455078*x_52) - 0.000574860457759833*std::exp(1.48807990550995*x_6) + 4.76518148992888e-7*std::exp(2.34247994422913*x_6) - 0.00329273101285326*std::exp(0.804639875888824*x_60) - 2.5387119090133e-5*std::exp(1.35599982738495*x_60) - 6.94329846618085e-5*std::exp(0.81471985578537*x_66) - 0.0103138710953643*std::exp(0.986879825592041*x_66) + 0.000953860456618372*std::exp(1.02383983135223*x_66) + 0.000203658535668565*std::exp(0.675039827823639*x_68) + 0.000104942703109409*std::exp(1.33207988739014*x_68) - 0.00221519932515337*std::exp(0.761759877204895*x_70) + 0.0100776465006732*std::exp(0.909759819507599*x_72) + 1.1268295160168e-5*std::exp(1.14007985591888*x_72) - 0.000628963608013523*std::exp(1.38855981826782*x_72) + 0.00664669087216722*std::exp(0.693999886512756*x_74) - 0.0258151729408471*std::exp(1.27359986305237*x_74) - 0.00132458040442414*std::exp(1.36911988258362*x_74) - 0.000928911601020237*std::exp(1.59695994853973*x_74) - 0.0187485194078263*std::exp(0.961679816246033*x_78) + 4.66981060817154e-6*std::exp(1.70751988887787*x_81) - 9.63194019010073e-7*std::exp(2.25271987915039*x_81) + 0.00348309937263388*std::exp(0.698479831218719*x_87) + 0.00154576432610208*std::exp(0.681999802589417*x_90) - 0.0149280701857553*std::sin(0.344079852104187*x_100 - 7.44199991226196) - 0.0222547071041397*std::sin(0.284079939126968*x_102 + 1.83591985702515) - 0.00952843405492069*std::sin(0.37391984462738*x_102 + 1.97303986549377) + 0.000673916310595455*std::sin(0.379999846220016*x_102 + 5.19024038314819) + 0.0642814651942138*std::sin(0.260319977998734*x_105 + 1.8659999370575) - 0.154240499215883*std::sin(0.538719832897186*x_106 - 4.02383995056152) - 0.00468961805379447*std::sin(0.448079854249954*x_108 - 7.36272001266479) + 0.000597917052149593*std::sin(0.701519846916199*x_109 + 2.04247975349426) + 0.0172933578539992*std::sin(0.624799847602844*x_112 - 1.0033597946167) - 0.081177697600342*std::sin(0.218639984726906*x_115 - 7.58960008621216) - 0.000855568630658072*std::sin(0.371519833803177*x_117 - 4.40263986587524) - 0.0731711285718556*std::sin(0.53279983997345*x_117 + 8.3557596206665) + 0.530255228615212*std::sin(0.115120060741901*x_120 + 1.71199989318848) - 0.0583765708890214*std::sin(0.246319964528084*x_120 - 7.54536008834839) + 0.0107908800764565*std::sin(0.427439838647842*x_120 + 8.41648006439209) - 0.00843556590148895*std::sin(0.469439834356308*x_120 - 4.14560031890869) - 0.00306899813571483*std::sin(0.337999850511551*x_16 - 4.26512002944946) - 0.136994393991842*std::sin(0.348639845848083*x_16 + 8.34088039398193) - 0.108460095570958*std::sin(0.139280036091805*x_21 + 4.914719581604) - 0.00810101562104904*std::sin(0.465199857950211*x_22 + 2.07911992073059) + 0.0307446121474392*std::sin(0.314799845218658*x_24 - 4.29608011245728) - 0.021839160230121*std::sin(0.382959842681885*x_24 - 7.40751981735229) + 6.89254401340949e-5*std::sin(0.577679872512817*x_24 + 2.16567993164063) - 0.0897771820735541*std::sin(0.389759838581085*x_27 - 4.21016025543213) - 0.0300854051044716*std::sin(0.289839953184128*x_28 - 4.28480005264282) + 0.0181435947460176*std::sin(0.349679857492447*x_34 - 7.41232013702393) + 0.000913114915050949*std::sin(0.371519833803177*x_34 - 4.4049596786499) + 0.262911182743535*std::sin(0.312079936265945*x_35 + 8.25303936004639) + 0.0121530389150294*std::sin(0.359519839286804*x_35 - 1.20879983901978) + 0.000873620316214504*std::sin(0.317679852247238*x_36 + 1.92295980453491) + 0.0110852274786457*std::sin(0.421999841928482*x_36 + 5.22056007385254) + 0.000678327005066406*std::sin(0.435679852962494*x_37 + 2.00375986099243) - 0.0062963703037148*std::sin(0.558719873428345*x_38 - 1.00023984909058) + 0.0223392083180636*std::sin(0.399599850177765*x_41 + 8.18295955657959) - 0.0866222953640867*std::sin(0.438479870557785*x_43 - 0.969679832458496) + 0.0014110076757237*std::sin(0.347359836101532*x_44 + 5.13503980636597) - 0.0130155016483024*std::sin(0.369119822978973*x_53 - 4.2370400428772) - 0.0272749800334385*std::sin(0.379039853811264*x_55 + 1.9871199131012) - 0.0131624719188351*std::sin(0.410559862852097*x_55 - 7.37951993942261) - 0.00157687215531478*std::sin(0.155360028147697*x_59 - 7.65199995040894) - 0.00101869311854392*std::sin(0.313919842243195*x_64 - 4.30408000946045) + 0.0263855259006784*std::sin(0.411039859056473*x_64 + 1.98383975028992) + 0.00185584396795946*std::sin(0.268879950046539*x_70 - 7.51600027084351) - 0.00112098726718061*std::sin(0.195999994874001*x_73 - 1.40735983848572) - 0.135454366868908*std::sin(0.44159984588623*x_73 - 4.15431976318359) + 0.018227378197928*std::sin(0.474239856004715*x_75 - 1.12807989120483) - 0.0454143855898765*std::sin(0.483839839696884*x_79 + 8.25088024139404) - 9.06292596453037e-5*std::sin(0.961759805679321*x_87 + 5.5685601234436) - 0.0165654485912273*std::sin(0.334479838609695*x_92 - 4.40520000457764) + 0.0160633394646682*std::sin(0.350399851799011*x_92 - 1.18759989738464) + 0.377437670862697*std::sin(0.353919863700867*x_92 + 8.19999980926514) - 0.00943569041715372*std::sin(0.396079838275909*x_92 + 4.99959993362427) - 0.0124740891192455*std::sin(0.400879859924316*x_92 + 5.00224018096924) + 0.0411876507426868*std::sin(0.146240040659904*x_95 - 4.48023986816406) - 0.000745221018535947*std::sin(0.391919851303101*x_96 - 7.39015960693359) - 0.000909158770031106*std::sin(0.268799960613251*x_97 + 5.07791996002197) + 0.0268712227351032*std::sin(0.279279947280884*x_97 + 5.09632015228271) + 0.00553289265112987*std::sin(0.316559940576553*x_97 + 8.07672023773193) - 0.0106451089378222*std::sin(0.420239865779877*x_98 + 2.02239966392517) - 3.66082535088303 + 0.000750548074658546*std::exp(-1.24647986888885*x_9) - 0.00153290323810046*std::exp(-1.23735988140106*x_9) - 1.63553309796629e-6*std::exp(-2.09863996505737*x_54));
}

inline float score_1(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.00215314757017867*x_1 - 0.00123813304657913*x_10 + 0.00632112297289243*x_100 + 0.0159337890601596*x_101 - 0.0271687766980046*x_102 - 0.00512134214357659*x_103 - 0.00412782399377541*x_104 + 0.0143148328635904*x_105 - 0.000579422073010553*x_106 + 0.0469120721759704*x_107 - 0.00669842351095216*x_108 + 0.00191288717536672*x_109 + 0.00824679824834736*x_11 + 0.00823831792658769*x_110 - 0.0151447771832183*x_111 - 0.000546734721116522*x_112 - 0.0194052346530775*x_113 - 0.00502283007656578*x_114 + 0.0017449522296084*x_115 - 0.00708821085256202*x_116 + 0.00677173187155728*x_117 + 0.0102182103500718*x_118 + 0.000962080944705498*x_119 + 0.0388657424931581*x_12 + 0.011114510190236*x_120 + 0.00886000576621862*x_13 + 0.0101869841799425*x_14 - 0.0111134470738826*x_15 - 0.00187782775647126*x_16 + 0.00237892093917342*x_17 + 0.0253364151750416*x_18 + 0.0286972004015965*x_19 - 0.0170480068666944*x_2 + 0.00897835782048568*x_20 - 0.0109595835579188*x_21 - 0.00305253171778345*x_22 - 0.00561193569376626*x_23 + 0.0187962832814492*x_24 + 0.000535849563751135*x_25 + 0.0028642859684959*x_26 - 0.000596546894004885*x_27 + 0.00397144843011007*x_28 - 0.00100687953359753*x_29 + 0.0069071529102619*x_3 - 0.00142391394080174*x_30 - 0.0620340088926167*x_32 - 0.0148453235795613*x_33 - 0.0360525170539845*x_34 + 0.0121530007613164*x_35 + 0.0107563285395352*x_36 - 0.00149329872461368*x_37 - 0.00988002438777346*x_38 + 0.00465419464933207*x_39 + 0.00214975217849425*x_4 + 0.0191813441623158*x_40 + 0.00220856406329729*x_41 - 0.000318326302976569*x_42 + 0.028292120656345*x_43 - 0.0107796757218155*x_44 + 0.00084092131567981*x_45 + 0.00391464029978623*x_46 + 0.0326419789903209*x_47 - 0.0240125804568686*x_48 + 0.0168144406592169*x_49 + 0.00445152250629566*x_5 + 0.0269021005309461*x_50 - 0.0064932789811732*x_51 - 0.0228325178291315*x_52 + 0.000954258329063723*x_53 + 0.000880271370991149*x_54 - 0.00577386954068603*x_55 - 0.0120817478980171*x_56 - 0.00901926024593082*x_57 - 0.00632788965994836*x_58 - 0.00431064767526876*x_59 + 0.0022094246989174*x_6 - 0.0181451336047422*x_60 - 0.0148941716694196*x_61 - 0.0315905465171463*x_62 + 0.0248763317020223*x_63 - 2.0691928978904e-5*x_64 - 0.0111550393256471*x_65 + 0.00225021649525972*x_66 - 0.0210680848044462*x_67 - 0.00635440311089037*x_68 + 0.00299786893986379*x_69 - 0.0184040957617489*x_7 - 0.00249705311058488*x_70 - 0.00545219622731627*x_71 - 0.0288648257884052*x_72 + 0.000275258916509292*x_73 + 0.00254948375074984*x_74 + 0.00467182764661619*x_75 - 0.000271897296825343*x_76 + 0.0126087414806184*x_77 - 9.89578847320621e-8*x_78 - 0.0232703212410615*x_79 + 0.0472561240995686*x_8 - 0.00936168835685161*x_80 + 0.000114240052177188*x_81 - 2.15249525158506e-5*x_82 + 0.0141350662285925*x_83 + 0.000256651870855632*x_84 - 0.00247076058588973*x_85 + 0.0008740077113412*x_86 - 0.00658275207153747*x_87 - 0.00315011948836362*x_88 + 0.0210435844038949*x_89 - 0.00761956717063683*x_9 + 0.010137326387791*x_90 + 0.0803471452973881*x_91 + 0.00114427844367586*x_92 + 0.019186647091191*x_93 + 0.0203517768311135*x_94 - 0.000107850814606543*x_95 + 0.00281818795259038*x_96 + 0.0629493663328972*x_97 + 0.00575176283066468*x_98 - 0.00162680905554707*x_99 - 1.47401391035806e-5*std::pow(-5.51063966751099*x_106 - 6.32424020767212, 2) - 2.68180482253232e-6*std::pow(-7.38335990905762*x_115 - 8.98408031463623, 2) - 1.69735656478015e-6*std::pow(-7.0025200843811*x_12 - 5.83999967575073, 2) + 3.01100339743493e-5*std::pow(-5.19456005096436*x_24 - 7.38416004180908, 2) - 0.000235251580311558*std::pow(-5.73055982589722*x_46 - 7.90679979324341, 2) + 6.6329008507129e-7*std::pow(-7.17063999176025*x_48 - 8.56703948974609, 2) - 2.60253694714922e-5*std::pow(-5.29519987106323*x_55 - 8.13951969146729, 2) + 2.50943753868644e-6*std::pow(-3.55464005470276*x_56 - 3.35920000076294, 2) - 4.69555482641134e-5*std::pow(-6.81983995437622*x_66 - 9.83775997161865, 2) + 1.69097346663766e-6*std::pow(-8.48000049591064*x_67 - 7.86736011505127, 2) - 2.39942124474712e-5*std::pow(-6.06615972518921*x_70 - 8.89816093444824, 2) + 2.87301761569914e-6*std::pow(-8.0*x_78 - 9.99958038330078, 2) + 0.000424185184515773*std::pow(-4.9223198890686*x_84 - 5.95056009292603, 2) - 4.41954662488914e-6*std::pow(-6.52711963653564*x_87 - 9.1879997253418, 2) - 1.55445153719395e-6*std::pow(-6.90120029449463*x_97 - 9.54792022705078, 2) + 9.02599147799926e-5*std::exp(0.647199809551239*x_1) - 0.000953509188369695*std::exp(1.04399979114532*x_1) - 9.38167398801663e-5*std::exp(1.09967982769012*x_1) + 2.91757614450429e-6*std::exp(1.19815981388092*x_1) + 9.34019028372345e-6*std::exp(1.27311992645264*x_1) + 6.10546455866487e-5*std::exp(1.29047989845276*x_1) - 1.10356639389722e-6*std::exp(1.31015980243683*x_1) + 1.06749660183582e-5*std::exp(1.54399979114532*x_100) + 0.000290573343006462*std::exp(1.70759987831116*x_100) - 0.000407120758582728*std::exp(0.54095983505249*x_104) + 0.0020089775782297*std::exp(0.627919852733612*x_104) + 0.00322427927608143*std::exp(0.683999836444855*x_104) - 0.000326378466256542*std::exp(0.887759864330292*x_104) + 0.00187223902285798*std::exp(0.580479860305786*x_106) + 4.7746309794459e-5*std::exp(0.845199882984161*x_106) - 0.000772677048100543*std::exp(1.07079982757568*x_106) + 3.62105785582195e-5*std::exp(1.07351982593536*x_106) + 0.000219962149712097*std::exp(1.21335983276367*x_106) - 0.0193006073354569*std::exp(0.737759828567505*x_109) + 0.00254945231735688*std::exp(0.857519865036011*x_109) - 0.000491844209273606*std::exp(0.90423983335495*x_109) + 0.000165705075127413*std::exp(1.03247976303101*x_109) - 3.89816766746318e-5*std::exp(1.1775997877121*x_109) + 0.000167920379281254*std::exp(0.931599855422974*x_110) - 0.000893218175866044*std::exp(1.26071989536285*x_110) + 4.59768516869134e-5*std::exp(1.28839981555939*x_110) + 0.000111195028785355*std::exp(1.36871981620789*x_110) + 0.000142431797975798*std::exp(0.541999876499176*x_112) - 0.0189996640396617*std::exp(0.607759833335876*x_114) + 5.78476579001474e-5*std::exp(0.76911985874176*x_114) - 0.000906305424898832*std::exp(1.25623989105225*x_23) - 2.69559325292353e-5*std::exp(1.3840799331665*x_23) + 0.0314365380407181*std::exp(0.684879839420319*x_26) + 0.000152001090701478*std::exp(0.75959986448288*x_26) - 0.00112113581605636*std::exp(0.774799823760986*x_26) - 0.000102039765255201*std::exp(0.96783983707428*x_26) - 7.31377181706047e-5*std::exp(1.06383979320526*x_26) - 2.9530588010342e-5*std::exp(1.18863987922668*x_26) - 0.000188409787626995*std::exp(1.24711990356445*x_26) - 0.000535488912260749*std::exp(0.523999869823456*x_31) - 0.000143577072833877*std::exp(0.626479864120483*x_31) - 0.156174563479898*std::exp(0.638719856739044*x_31) + 0.0073915208608873*std::exp(0.644239842891693*x_31) + 0.000474067550268693*std::exp(0.646319806575775*x_31) + 0.00263549490330402*std::exp(0.647919833660126*x_31) + 0.000668210695489801*std::exp(0.657999873161316*x_31) - 0.00128231712890253*std::exp(0.658879816532135*x_31) - 0.00605287104459655*std::exp(0.66103982925415*x_31) - 0.000308568778549767*std::exp(0.678959846496582*x_31) + 0.00064351884948894*std::exp(0.578719854354858*x_45) + 0.000239520018449363*std::exp(0.62255984544754*x_45) - 0.000308780771373966*std::exp(1.25087988376617*x_45) - 0.000703064433650574*std::exp(1.30271983146667*x_50) + 2.60505694793046e-6*std::exp(2.01959991455078*x_52) + 5.43982824388356e-5*std::exp(1.48807990550995*x_6) + 2.11601643031406e-6*std::exp(2.34247994422913*x_6) + 0.00150061666447185*std::exp(0.804639875888824*x_60) - 0.000112733504960087*std::exp(1.35599982738495*x_60) - 0.000116184164988455*std::exp(0.81471985578537*x_66) + 0.0013145861860127*std::exp(0.986879825592041*x_66) + 0.00104484344029606*std::exp(1.02383983135223*x_66) + 0.000340787552554095*std::exp(0.675039827823639*x_68) - 0.000485150823910043*std::exp(1.33207988739014*x_68) + 0.00400956413744692*std::exp(0.761759877204895*x_70) - 0.00128447745320947*std::exp(0.909759819507599*x_72) + 5.00377535481862e-5*std::exp(1.14007985591888*x_72) + 0.000286641474158428*std::exp(1.38855981826782*x_72) + 0.000418175584145426*std::exp(0.693999886512756*x_74) - 0.0130157339249671*std::exp(1.27359986305237*x_74) + 0.000603659218002545*std::exp(1.36911988258362*x_74) + 0.00011839728724911*std::exp(1.59695994853973*x_74) + 0.00238965024808165*std::exp(0.961679816246033*x_78) + 2.07366623794498e-5*std::exp(1.70751988887787*x_81) - 1.6117396272915e-6*std::exp(2.25271987915039*x_81) - 0.0015873744141817*std::exp(0.698479831218719*x_87) - 0.000146273627382294*std::exp(0.681999802589417*x_90) - 0.000939197352510048*std::sin(0.344079852104187*x_100 - 7.44199991226196) + 0.0402815559218202*std::sin(0.284079939126968*x_102 + 1.83591985702515) + 0.000901663073051276*std::sin(0.37391984462738*x_102 + 1.97303986549377) + 0.00112768310623555*std::sin(0.379999846220016*x_102 + 5.19024038314819) + 0.00404425898154482*std::sin(0.260319977998734*x_105 + 1.8659999370575) - 0.0777664090358079*std::sin(0.538719832897186*x_106 - 4.02383995056152) + 0.000443772334619601*std::sin(0.448079854249954*x_108 - 7.36272001266479) - 5.65800973762892e-5*std::sin(0.701519846916199*x_109 + 2.04247975349426) + 0.00108800908023485*std::sin(0.624799847602844*x_112 - 1.0033597946167) + 0.0369956140744614*std::sin(0.218639984726906*x_115 - 7.58960008621216) + 0.0039552995470548*std::sin(0.371519833803177*x_117 - 4.40263986587524) + 0.00932625140901308*std::sin(0.53279983997345*x_117 + 8.3557596206665) + 0.0333609301586238*std::sin(0.115120060741901*x_120 + 1.71199989318848) - 0.0639447591491627*std::sin(0.246319964528084*x_120 - 7.54536008834839) - 0.0195317528651986*std::sin(0.427439838647842*x_120 + 8.41648006439209) + 0.000798246409622278*std::sin(0.469439834356308*x_120 - 4.14560031890869) + 0.000290415221880895*std::sin(0.337999850511551*x_16 - 4.26512002944946) - 0.069071107348213*std::sin(0.348639845848083*x_16 + 8.34088039398193) + 0.196315385530948*std::sin(0.139280036091805*x_21 + 4.914719581604) + 0.000766588360438862*std::sin(0.465199857950211*x_22 + 2.07911992073059) + 0.0336771548750245*std::sin(0.314799845218658*x_24 - 4.29608011245728) + 0.0099528955300215*std::sin(0.382959842681885*x_24 - 7.40751981735229) + 0.000306068854037604*std::sin(0.577679872512817*x_24 + 2.16567993164063) + 0.0114428270706318*std::sin(0.389759838581085*x_27 - 4.21016025543213) + 0.0137110076957168*std::sin(0.289839953184128*x_28 - 4.28480005264282) - 0.00171690429934212*std::sin(0.349679857492447*x_34 - 7.41232013702393) + 0.00405475881054318*std::sin(0.371519833803177*x_34 - 4.4049596786499) - 0.0335101540233767*std::sin(0.312079936265945*x_35 + 8.25303936004639) + 0.0133122438422999*std::sin(0.359519839286804*x_35 - 1.20879983901978) + 0.00146185343249637*std::sin(0.317679852247238*x_36 + 1.92295980453491) - 0.0010489803693091*std::sin(0.421999841928482*x_36 + 5.22056007385254) + 0.00113506364527794*std::sin(0.435679852962494*x_37 + 2.00375986099243) + 0.000595817168318907*std::sin(0.558719873428345*x_38 - 1.00023984909058) + 0.0244700103779168*std::sin(0.399599850177765*x_41 + 8.18295955657959) + 0.0110407112745012*std::sin(0.438479870557785*x_43 - 0.969679832458496) - 0.00652309799669504*std::sin(0.347359836101532*x_44 + 5.13503980636597) + 0.00123163965305*std::sin(0.369119822978973*x_53 - 4.2370400428772) + 0.0124301953003589*std::sin(0.379039853811264*x_55 + 1.9871199131012) - 0.000828114995765093*std::sin(0.410559862852097*x_55 - 7.37951993942261) + 0.00728989060396312*std::sin(0.155360028147697*x_59 - 7.65199995040894) - 0.00170460783061531*std::sin(0.313919842243195*x_64 - 4.30408000946045) + 0.0289022817381721*std::sin(0.411039859056473*x_64 + 1.98383975028992) - 0.00857957917441227*std::sin(0.268879950046539*x_70 - 7.51600027084351) - 0.00187577950500676*std::sin(0.195999994874001*x_73 - 1.40735983848572) + 0.0172647532506972*std::sin(0.44159984588623*x_73 - 4.15431976318359) + 0.00114677283357287*std::sin(0.474239856004715*x_75 - 1.12807989120483) + 0.00578843029844917*std::sin(0.483839839696884*x_79 + 8.25088024139404) - 0.00040244637666366*std::sin(0.961759805679321*x_87 + 5.5685601234436) - 0.00104221277542411*std::sin(0.334479838609695*x_92 - 4.40520000457764) - 0.0290750313589547*std::sin(0.350399851799011*x_92 - 1.18759989738464) + 0.190300034342786*std::sin(0.353919863700867*x_92 + 8.19999980926514) + 0.000892886865654245*std::sin(0.396079838275909*x_92 + 4.99959993362427) + 0.00568489376550267*std::sin(0.400879859924316*x_92 + 5.00224018096924) + 0.00259131502279192*std::sin(0.146240040659904*x_95 - 4.48023986816406) + 0.00344516179234363*std::sin(0.391919851303101*x_96 - 7.39015960693359) + 0.00420304712263588*std::sin(0.268799960613251*x_97 + 5.07791996002197) - 0.002542788156829*std::sin(0.279279947280884*x_97 + 5.09632015228271) + 0.00606064183946798*std::sin(0.316559940576553*x_97 + 8.07672023773193) + 0.00100733253570513*std::sin(0.420239865779877*x_98 + 2.02239966392517) - 1.2416824723376 - 0.000342051914937295*std::exp(-1.24647986888885*x_9) - 9.6442383038353e-5*std::exp(-1.23735988140106*x_9) - 2.73678350748929e-6*std::exp(-2.09863996505737*x_54));
}

inline float score_2(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.000839150506181626*x_1 + 0.0048965630643395*x_10 + 0.0118757676757547*x_100 - 0.034268168557066*x_101 + 0.0110176966330969*x_102 + 0.0014104262821281*x_103 + 0.000334742644789363*x_104 - 0.00202932688259636*x_105 - 0.00332081921807469*x_106 + 0.00782672545314711*x_107 + 0.00154000211725411*x_108 - 0.00148977107725054*x_109 + 0.00721974031517963*x_11 - 5.99617199306104e-5*x_110 - 0.000722856947766898*x_111 + 0.00120864635290588*x_112 + 0.00141029517197194*x_113 + 0.00572806954288579*x_114 - 0.000944403354046545*x_115 + 0.00269027629064224*x_116 - 0.00142615025765441*x_117 + 0.00215555039729507*x_118 - 0.00696339583157427*x_119 + 0.0150947895578549*x_12 + 0.00833820939176168*x_120 + 0.00618873182286764*x_13 + 0.0137962289442439*x_14 - 0.00285348810177132*x_15 - 0.00077386398047938*x_16 + 0.0049429109027509*x_17 - 0.00170503927714009*x_18 - 0.000601054274303059*x_19 - 2.65176555856892e-5*x_2 - 0.00422824825386804*x_20 - 0.00336784918024362*x_21 - 0.00943960454599229*x_22 + 0.000307461814431194*x_23 - 0.000969632369291422*x_24 - 0.0105241263297962*x_25 - 0.00971429166061048*x_26 - 0.0034226625443374*x_27 + 0.00150278034578413*x_28 + 0.00876234986912965*x_29 - 0.00803927869409159*x_3 - 0.00818931999623662*x_30 + 0.0246685429698967*x_32 + 0.000649344839875358*x_33 - 0.00355133653234141*x_34 + 0.000170952729405763*x_35 - 0.00573069159428414*x_36 - 0.0177587898689668*x_37 - 0.00231558101026675*x_38 - 0.0110683884989316*x_39 + 0.0199974249173921*x_4 + 0.00718042457422825*x_40 - 0.0136881331115553*x_41 - 0.0238962149722472*x_42 - 0.00321734049241652*x_43 + 0.0135377403794628*x_44 - 0.000232460691451886*x_45 - 0.00557522786576499*x_46 - 0.000670587261630462*x_47 + 0.00210373606336886*x_48 - 0.0118310170396213*x_49 - 0.000539093260451706*x_5 - 0.00648507406945805*x_50 + 0.00885856174525974*x_51 + 0.000271579984740015*x_52 - 0.00320587226590566*x_53 - 0.00411731882443335*x_54 - 0.00138995133662184*x_55 + 0.00854253150191626*x_56 - 0.0154043037979962*x_57 - 0.00284213993010807*x_58 + 0.00185203658173023*x_59 + 0.000978639437581601*x_6 - 0.00224135864845543*x_60 + 0.00384519122223053*x_61 - 0.0115888123509087*x_62 - 0.0096026134534629*x_63 + 0.00841009074662078*x_64 - 0.0107274069679814*x_65 + 0.00152003375033783*x_66 + 0.00503172960961016*x_67 - 0.00646774122999208*x_68 - 0.00616526596414706*x_69 + 0.00932889484923513*x_7 + 0.00541733435548479*x_70 - 0.00119412196342016*x_71 + 0.0023812127346185*x_72 + 0.000448104020524003*x_73 + 0.000553833578400406*x_74 + 0.00444812312248668*x_75 + 0.00343442873818557*x_76 - 0.0089114995164365*x_77 + 0.00098626219098849*x_78 + 0.00133537189466934*x_79 + 0.0158498300064828*x_8 - 0.00204858205425033*x_80 - 0.00580104728647653*x_81 - 0.00593921588751873*x_82 - 0.00312600373689324*x_83 + 0.0020148254698568*x_84 + 0.00464527016867314*x_85 + 0.009025909250183*x_86 - 0.00125313975370017*x_87 - 0.00159249182097653*x_88 + 0.00916625818818293*x_89 - 0.00177398232180316*x_9 + 0.0069136748781821*x_90 - 0.0198168363860496*x_91 - 0.00348807204401744*x_92 + 0.0766982859281321*x_93 + 0.0140128249237121*x_94 + 0.0018320995413622*x_95 - 0.00430884465982095*x_96 - 0.0100440023755526*x_97 - 0.00354899025126*x_98 - 0.000350518126728073*x_99 + 6.10712100255989e-5*std::pow(-5.51063966751099*x_106 - 6.32424020767212, 2) - 5.50492998414788e-5*std::pow(-7.38335990905762*x_115 - 8.98408031463623, 2) - 3.48415700081614e-5*std::pow(-7.0025200843811*x_12 - 5.83999967575073, 2) - 0.000124751618407639*std::pow(-5.19456005096436*x_24 - 7.38416004180908, 2) + 1.72536490944075e-5*std::pow(-5.73055982589722*x_46 - 7.90679979324341, 2) + 9.44641918602657e-8*std::pow(-7.17063999176025*x_48 - 8.56703948974609, 2) + 0.000107828073657814*std::pow(-5.29519987106323*x_55 - 8.13951969146729, 2) - 1.60688834522025e-6*std::pow(-3.55464005470276*x_56 - 3.35920000076294, 2) + 3.44377942843823e-6*std::pow(-6.81983995437622*x_66 - 9.83775997161865, 2) - 1.08279465566577e-6*std::pow(-8.48000049591064*x_67 - 7.86736011505127, 2) + 9.94126023832707e-5*std::pow(-6.06615972518921*x_70 - 8.89816093444824, 2) + 1.24031216502549e-6*std::pow(-8.0*x_78 - 9.99958038330078, 2) - 3.11102791105122e-5*std::pow(-4.9223198890686*x_84 - 5.95056009292603, 2) - 1.90796513491387e-6*std::pow(-6.52711963653564*x_87 - 9.1879997253418, 2) - 3.19081642485957e-5*std::pow(-6.90120029449463*x_97 - 9.54792022705078, 2) + 0.00185276164418943*std::exp(0.647199809551239*x_1) + 6.99315725005388e-5*std::exp(1.04399979114532*x_1) - 1.32226971619288e-5*std::exp(1.19815981388092*x_1) + 3.67338641371128e-6*std::exp(1.27311992645264*x_1) + 4.9834396324021e-5*std::exp(1.29047989845276*x_1) - 1.57167293632083e-7*std::exp(1.31015980243683*x_1) - 4.8379831710824e-5*std::exp(1.54399979114532*x_100) + 0.000237173551618262*std::exp(1.70759987831116*x_100) + 0.00184510505722852*std::exp(0.54095983505249*x_104) + 0.000790107130277611*std::exp(0.627919852733612*x_104) - 0.0133588045178572*std::exp(0.683999836444855*x_104) - 0.00669955766348161*std::exp(0.887759864330292*x_104) + 0.000736329473048477*std::exp(0.580479860305786*x_106) - 0.000216390237561061*std::exp(0.845199882984161*x_106) - 0.000630679187071351*std::exp(1.07079982757568*x_106) - 2.31870113369479e-5*std::exp(1.07351982593536*x_106) + 9.49599921150086e-5*std::exp(1.21335983276367*x_106) + 0.0014155310065671*std::exp(0.737759828567505*x_109) - 0.0105628676113193*std::exp(0.857519865036011*x_109) - 0.000193436512653999*std::exp(0.90423983335495*x_109) + 7.15366377720516e-5*std::exp(1.03247976303101*x_109) - 5.55167741431184e-6*std::exp(1.1775997877121*x_109) + 0.00344689487873318*std::exp(0.931599855422974*x_110) - 0.000729068003789404*std::exp(1.26071989536285*x_110) + 6.54791355492185e-6*std::exp(1.28839981555939*x_110) + 4.37316902123673e-5*std::exp(1.36871981620789*x_110) + 2.02847969445258e-5*std::exp(0.541999876499176*x_112) + 0.00139345944379125*std::exp(0.607759833335876*x_114) - 0.000262170385297852*std::exp(0.76911985874176*x_114) + 0.00375499637841893*std::exp(1.25623989105225*x_23) - 3.83899961649566e-6*std::exp(1.3840799331665*x_23) - 0.00230559554745272*std::exp(0.684879839420319*x_26) + 2.16476327901853e-5*std::exp(0.75959986448288*x_26) - 0.00209456616159842*std::exp(0.96783983707428*x_26) + 4.68328639834828e-5*std::exp(1.06383979320526*x_26) - 1.27486679334787e-5*std::exp(1.18863987922668*x_26) - 0.000153784989458387*std::exp(1.24711990356445*x_26) - 0.000231176240787388*std::exp(0.523999869823456*x_31) + 0.000650703206857044*std::exp(0.626479864120483*x_31) + 0.0114540404454917*std::exp(0.638719856739044*x_31) - 0.0306244818811914*std::exp(0.644239842891693*x_31) + 0.00973116555708709*std::exp(0.646319806575775*x_31) + 9.51649734596075e-5*std::exp(0.657999873161316*x_31) - 0.000504320166537551*std::exp(0.658879816532135*x_31) - 0.00494051143260715*std::exp(0.66103982925415*x_31) + 0.000197588330574673*std::exp(0.678959846496582*x_31) + 0.000277813910044581*std::exp(0.578719854354858*x_45) + 3.41118697330493e-5*std::exp(0.62255984544754*x_45) - 0.000252034930184774*std::exp(1.25087988376617*x_45) + 3.71005997036383e-7*std::exp(2.01959991455078*x_52) - 0.000246537529508079*std::exp(1.48807990550995*x_6) - 1.35496583905653e-6*std::exp(2.34247994422913*x_6) + 0.000590174793019543*std::exp(0.804639875888824*x_60) + 7.21875529649627e-5*std::exp(1.35599982738495*x_60) - 1.6546671659376e-5*std::exp(0.81471985578537*x_66) - 0.00544658150771664*std::exp(0.986879825592041*x_66) + 4.85341504005754e-5*std::exp(0.675039827823639*x_68) - 0.000209444754351544*std::exp(1.33207988739014*x_68) + 0.00327271096887353*std::exp(0.761759877204895*x_70) + 0.0053218352803093*std::exp(0.909759819507599*x_72) - 3.20410776351387e-5*std::exp(1.14007985591888*x_72) + 0.000112732702953027*std::exp(1.38855981826782*x_72) + 0.00858387341412488*std::exp(0.693999886512756*x_74) + 0.000954590424217971*std::exp(1.27359986305237*x_74) + 0.000237412033648433*std::exp(1.36911988258362*x_74) - 0.000490542561724886*std::exp(1.59695994853973*x_74) - 0.00990077713397349*std::exp(0.961679816246033*x_78) - 1.3278473993717e-5*std::exp(1.70751988887787*x_81) - 2.29540113455628e-7*std::exp(2.25271987915039*x_81) - 0.000624295590282493*std::exp(0.698479831218719*x_87) + 0.000662924215807064*std::exp(0.681999802589417*x_90) - 0.0192788663195215*std::sin(0.344079852104187*x_100 - 7.44199991226196) + 0.0328788579979109*std::sin(0.284079939126968*x_102 + 1.83591985702515) - 0.00408641185921022*std::sin(0.37391984462738*x_102 + 1.97303986549377) + 0.000160601938280995*std::sin(0.379999846220016*x_102 + 5.19024038314819) + 0.0830163416222923*std::sin(0.260319977998734*x_105 + 1.8659999370575) + 0.0057034870119003*std::sin(0.538719832897186*x_106 - 4.02383995056152) - 0.00201121304085591*std::sin(0.448079854249954*x_108 - 7.36272001266479) + 0.000256425695832603*std::sin(0.701519846916199*x_109 + 2.04247975349426) + 0.0223335186755104*std::sin(0.624799847602844*x_112 - 1.0033597946167) + 0.0145499376329469*std::sin(0.218639984726906*x_115 - 7.58960008621216) + 0.00170754474936905*std::sin(0.371519833803177*x_117 - 4.40263986587524) - 0.038640439859419*std::sin(0.53279983997345*x_117 + 8.3557596206665) + 0.684798472977084*std::sin(0.115120060741901*x_120 + 1.71199989318848) - 0.0159423268096079*std::sin(0.427439838647842*x_120 + 8.41648006439209) - 0.00361771895993677*std::sin(0.469439834356308*x_120 - 4.14560031890869) - 0.00131618588168772*std::sin(0.337999850511551*x_16 - 4.26512002944946) + 0.00506576256435745*std::sin(0.348639845848083*x_16 + 8.34088039398193) + 0.16023774494224*std::sin(0.139280036091805*x_21 + 4.914719581604) - 0.00347424205432858*std::sin(0.465199857950211*x_22 + 2.07911992073059) + 0.0039143561433412*std::sin(0.382959842681885*x_24 - 7.40751981735229) - 0.000195987533782325*std::sin(0.577679872512817*x_24 + 2.16567993164063) - 0.0474098168549446*std::sin(0.389759838581085*x_27 - 4.21016025543213) + 0.00539237722763596*std::sin(0.289839953184128*x_28 - 4.28480005264282) + 0.00778115273837069*std::sin(0.349679857492447*x_34 - 7.41232013702393) - 0.00259641635820571*std::sin(0.371519833803177*x_34 - 4.4049596786499) + 0.13883896481375*std::sin(0.312079936265945*x_35 + 8.25303936004639) + 0.000208193679096051*std::sin(0.317679852247238*x_36 + 1.92295980453491) + 0.00475406606895574*std::sin(0.421999841928482*x_36 + 5.22056007385254) + 0.000161653057047617*std::sin(0.435679852962494*x_37 + 2.00375986099243) - 0.00270029284253606*std::sin(0.558719873428345*x_38 - 1.00023984909058) - 0.0457437743523919*std::sin(0.438479870557785*x_43 - 0.969679832458496) - 0.00281609056441006*std::sin(0.347359836101532*x_44 + 5.13503980636597) - 0.00558189309834456*std::sin(0.369119822978973*x_53 - 4.2370400428772) + 0.00488864885501173*std::sin(0.379039853811264*x_55 + 1.9871199131012) - 0.0169986832457298*std::sin(0.410559862852097*x_55 - 7.37951993942261) + 0.00314712306266183*std::sin(0.155360028147697*x_59 - 7.65199995040894) - 0.000242766181467116*std::sin(0.313919842243195*x_64 - 4.30408000946045) - 0.00370389529207022*std::sin(0.268879950046539*x_70 - 7.51600027084351) - 0.000267144043061442*std::sin(0.195999994874001*x_73 - 1.40735983848572) - 0.0715311683562977*std::sin(0.44159984588623*x_73 - 4.15431976318359) + 0.0235397598792462*std::sin(0.474239856004715*x_75 - 1.12807989120483) - 0.0239825716698466*std::sin(0.483839839696884*x_79 + 8.25088024139404) + 0.000257701728880433*std::sin(0.961759805679321*x_87 + 5.5685601234436) - 0.021393459766683*std::sin(0.334479838609695*x_92 - 4.40520000457764) - 0.0237317999630209*std::sin(0.350399851799011*x_92 - 1.18759989738464) - 0.0139568457344931*std::sin(0.353919863700867*x_92 + 8.19999980926514) - 0.00404663735911369*std::sin(0.396079838275909*x_92 + 4.99959993362427) + 0.00223580150802501*std::sin(0.400879859924316*x_92 + 5.00224018096924) + 0.0531918193579435*std::sin(0.146240040659904*x_95 - 4.48023986816406) + 0.00148731287207405*std::sin(0.391919851303101*x_96 - 7.39015960693359) + 0.00181450000441855*std::sin(0.268799960613251*x_97 + 5.07791996002197) + 0.0115241269051443*std::sin(0.279279947280884*x_97 + 5.09632015228271) - 0.00456531463148837*std::sin(0.420239865779877*x_98 + 2.02239966392517) + 2.48453187942505*std::sin(-8.08549812011894e-5*x_10 + 9.15717567845468e-5*x_100 + 0.00177921386169895*x_101 + 0.000332194936224725*x_102 - 0.000366648828156211*x_103 - 0.000336484819572074*x_104 - 0.00160504072206246*x_105 + 0.000342226306789603*x_106 + 0.000132327186135545*x_107 - 0.000414207803164788*x_108 + 6.40681929311053e-5*x_109 + 0.00136209772787165*x_11 + 4.90110781963937e-5*x_110 + 0.000205170591396457*x_111 - 0.000184007639252017*x_112 - 0.00033963102229142*x_113 + 0.0024395304844705*x_114 + 0.000308766874741758*x_115 + 0.000635833529946682*x_116 - 0.000107557117341401*x_117 - 0.000251793039093998*x_118 - 0.000149361378646343*x_119 - 0.00470275564324811*x_12 + 0.000479724804410908*x_13 + 0.00153773752105245*x_14 + 1.87344764453015e-5*x_15 + 0.000822302541478459*x_16 + 2.36512356818595e-5*x_17 + 6.98357283372807e-5*x_18 - 0.000588912233706995*x_19 + 0.00133270265848093*x_2 + 0.00077669084770531*x_20 + 0.000602372376276464*x_21 + 0.00145497020414498*x_22 - 0.000221247356386293*x_23 - 0.00249894922670895*x_25 - 0.00011710735048887*x_27 - 0.000214481448638695*x_28 + 0.000755502007493408*x_29 + 0.000164886720767458*x_3 - 0.000304330075301597*x_30 + 0.0105115675392337*x_32 + 0.00781667875603488*x_33 - 0.00108721816691876*x_34 + 0.000295608137191274*x_36 - 0.00328141419694768*x_37 + 0.00101476835513909*x_38 + 0.000167073756866004*x_39 - 0.000486995548178912*x_4 + 0.00189667027632263*x_40 + 0.00771431702977556*x_42 - 0.000531014812533039*x_43 + 0.00571464315595751*x_44 - 0.000219846488214099*x_45 + 0.00145583031838815*x_46 + 0.000689362780183841*x_47 - 0.000588759415556564*x_48 + 0.000634997161504125*x_49 + 0.000178358396911513*x_5 - 2.48270136235064e-5*x_51 + 0.000144668964337809*x_52 - 0.000344778177482348*x_53 + 0.000369049431086203*x_54 - 0.000921798195589132*x_55 + 0.000970951824747469*x_56 + 0.00245212227922968*x_57 - 8.62061463574238e-5*x_58 + 0.000538717044034998*x_59 + 0.000316184971325572*x_6 + 0.00145411442549393*x_60 + 0.00285413584414083*x_61 + 0.00228497206942721*x_62 + 0.00123479468718669*x_63 + 0.00038133605332697*x_65 + 0.00075073850028305*x_67 + 0.00281215809638395*x_68 - 0.000654577108577478*x_69 - 0.000182635492308774*x_7 - 0.000476150616027509*x_70 - 0.000837570008019291*x_71 - 0.00114117861765277*x_72 - 0.000115185423185093*x_73 - 0.00204395037803623*x_74 - 3.21315860158574e-5*x_75 + 0.000528436380539369*x_76 - 0.000178409795781301*x_77 + 0.000400021294580178*x_78 - 0.000689486261780343*x_79 + 0.00016641320891862*x_8 + 0.000128102666894118*x_80 + 0.000695175285690635*x_81 - 4.41196037010566e-5*x_82 + 0.000491793522327588*x_83 + 0.000562183954563822*x_84 - 0.000277630208616535*x_85 - 0.000206299102344374*x_86 - 0.000358875618878654*x_87 + 0.000588975859677024*x_88 + 0.00065625172955105*x_89 + 0.000557998566299475*x_9 + 5.5118362040722e-5*x_90 + 0.00730230774148686*x_91 - 0.000250847214278654*x_92 + 0.00320817834038912*x_93 + 0.000994660344130416*x_94 - 9.48528608271411e-5*x_95 + 0.000458323849219351*x_96 - 0.00107687904482431*x_98 - 0.00103558790959621*x_99 + 7.57856863705358e-5*std::exp(1.09967982769012*x_1) + 0.00090565977290354*std::exp(0.774799823760986*x_26) - 0.00212896750012915*std::exp(0.647919833660126*x_31) + 0.00056793937558456*std::exp(1.30271983146667*x_50) - 0.000844030365729318*std::exp(1.02383983135223*x_66) + 0.0516549335236749*std::sin(0.246319964528084*x_120 - 7.54536008834839) - 0.0272045937694125*std::sin(0.314799845218658*x_24 - 4.29608011245728) - 0.0107537049145951*std::sin(0.359519839286804*x_35 - 1.20879983901978) - 0.01976701102973*std::sin(0.399599850177765*x_41 + 8.18295955657959) - 0.0233474245854182*std::sin(0.411039859056473*x_64 + 1.98383975028992) - 0.00489582032201025*std::sin(0.316559940576553*x_97 + 8.07672023773193) - 4.81729429109671) - 3.07154884263348 - 0.000134524974218586*std::exp(-1.24647986888885*x_9) - 0.00197966892172708*std::exp(-1.23735988140106*x_9) - 3.89766179459313e-7*std::exp(-2.09863996505737*x_54));
}

inline float score_3(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.00211780472129305*x_1 + 0.000666917714974*x_10 + 0.0123995677322976*x_100 + 0.02272333865066*x_101 - 0.0457218337765178*x_102 - 0.00695357999325702*x_103 - 0.00873252518432004*x_104 + 0.0195322133915828*x_105 - 0.00314680812403506*x_106 + 0.0887195007385367*x_107 - 0.00745427397319722*x_108 - 0.00318870496811626*x_109 + 0.0154720511171523*x_11 + 0.0150708047821892*x_110 - 0.0295690559165227*x_111 - 0.00192186075284136*x_112 - 0.0340705904166075*x_113 - 0.00289676740013465*x_114 - 0.00349106089332213*x_115 - 0.0137872039256386*x_116 + 0.0123347382287204*x_117 + 0.0198785284654701*x_118 - 0.0133964106188191*x_119 + 0.0401819931827647*x_12 + 0.0130460464022323*x_120 + 0.0261625050231903*x_13 + 0.0223522897802235*x_14 - 0.0182658443269422*x_15 + 0.00350447805535368*x_16 + 0.00859307362449007*x_17 + 0.0449346597525222*x_18 + 0.046790507389877*x_19 - 0.00833240932632092*x_2 + 0.0174282754488087*x_20 - 0.0152233946543859*x_21 - 0.00343432187101549*x_22 - 0.0136813987396326*x_23 + 0.0349551558965083*x_24 - 0.0129069855310611*x_25 + 0.00402687936457618*x_26 - 0.00654469267083927*x_27 + 0.0108664171406232*x_28 - 0.00718544031736221*x_29 + 0.00562638546236148*x_3 - 0.00701603357890607*x_30 - 0.0613414520366827*x_32 - 0.0122267606379402*x_33 - 0.0518877597506695*x_34 + 0.0229785254264941*x_35 + 0.0147114062386063*x_36 - 0.0260798659590361*x_37 - 0.0220426380421839*x_38 - 0.0023030159154981*x_39 - 0.00165717902921269*x_4 + 0.0505673939665338*x_40 + 3.95130476927949e-5*x_41 + 0.0234669341412815*x_42 + 0.0424439613397786*x_43 + 0.00213303539243096*x_44 + 0.00477296711663675*x_45 + 0.00485585848556781*x_46 + 0.0453020099073289*x_47 - 0.0506242920544186*x_48 + 0.0367578833844098*x_49 + 0.0112147902466917*x_5 + 0.0499382220299861*x_50 - 0.00582622869376045*x_51 - 0.0483332594194994*x_52 - 0.000750716052971645*x_53 - 0.00570530748751432*x_54 - 0.00761097234856191*x_55 - 0.0217476470577169*x_56 - 0.0294560012269924*x_57 - 0.0140787917241626*x_58 - 0.00868860222509782*x_59 + 0.00467081752142307*x_6 - 0.0268139797897497*x_60 - 0.0120382784025563*x_61 - 0.0533205395345151*x_62 + 0.0344200318631905*x_63 - 0.000497640290911368*x_64 - 0.0191150746736764*x_65 - 0.00107958032198777*x_66 - 0.0401069806208548*x_67 - 0.00138901027507139*x_68 + 0.00466331818433325*x_69 - 0.0319595382051857*x_7 - 0.000370068306737066*x_70 - 0.01277597941148*x_71 - 0.0522946353193825*x_72 + 0.0017063494073408*x_73 - 0.00201433504690383*x_74 + 0.00278775919255292*x_75 - 0.00612948103776047*x_76 + 0.0200600831130312*x_77 - 0.00868558734689573*x_78 - 0.0432712254543961*x_79 + 0.0721179751520773*x_8 - 0.0162076132428661*x_80 + 0.00278184574051043*x_81 + 0.0027456889681811*x_82 + 0.0345373266625645*x_83 + 0.00178760884813929*x_84 + 0.00378347841323548*x_85 + 0.00711307236171287*x_86 - 0.0169379034340819*x_87 - 0.00465114048496958*x_88 + 0.0417041164335698*x_89 - 0.0143319702460868*x_9 + 0.0254725423295237*x_90 + 0.119740092146373*x_91 + 0.0012380530472518*x_92 - 0.013903856304826*x_93 + 0.0251328326487267*x_94 - 0.00314779334181419*x_95 + 0.00136105601690362*x_96 + 0.10922229130436*x_97 - 0.00144827602955198*x_98 - 0.0171538160434341*x_99 - 2.61600547370442e-5*std::pow(-5.51063966751099*x_106 - 6.32424020767212, 2) - 5.66052538294802e-5*std::pow(-7.38335990905762*x_115 - 8.98408031463623, 2) - 3.58263578248737e-5*std::pow(-7.0025200843811*x_12 - 5.83999967575073, 2) + 5.34377682169837e-5*std::pow(-5.19456005096436*x_24 - 7.38416004180908, 2) - 0.000420253444860779*std::pow(-5.73055982589722*x_46 - 7.90679979324341, 2) - 7.11775482906404e-7*std::pow(-7.17063999176025*x_48 - 8.56703948974609, 2) - 4.61885118682939e-5*std::pow(-5.29519987106323*x_55 - 8.13951969146729, 2) + 2.37912115502448e-6*std::pow(-3.55464005470276*x_56 - 3.35920000076294, 2) - 8.38813957686758e-5*std::pow(-6.81983995437622*x_66 - 9.83775997161865, 2) + 1.60316034371933e-6*std::pow(-8.48000049591064*x_67 - 7.86736011505127, 2) - 4.25837169233796e-5*std::pow(-6.06615972518921*x_70 - 8.89816093444824, 2) - 2.56916444742773e-6*std::pow(-8.0*x_78 - 9.99958038330078, 2) + 0.000757764452912796*std::pow(-4.9223198890686*x_84 - 5.95056009292603, 2) + 3.95213102779787e-6*std::pow(-6.52711963653564*x_87 - 9.1879997253418, 2) - 3.28100401226826e-5*std::pow(-6.90120029449463*x_97 - 9.54792022705078, 2) + 0.00190512946498632*std::exp(0.647199809551239*x_1) - 0.00170334890243066*std::exp(1.04399979114532*x_1) + 6.09535248752074e-5*std::exp(1.09967982769012*x_1) + 1.84340567587594e-5*std::exp(1.19815981388092*x_1) - 3.71839561261514e-6*std::exp(1.27311992645264*x_1) - 1.03337421469578e-5*std::exp(1.29047989845276*x_1) + 1.18423525485241e-6*std::exp(1.31015980243683*x_1) + 6.74474014503152e-5*std::exp(1.54399979114532*x_100) - 4.91806966129523e-5*std::exp(1.70759987831116*x_100) - 0.00257230207530995*std::exp(0.54095983505249*x_104) - 0.000799788139835789*std::exp(0.627919852733612*x_104) + 0.00572228808406011*std::exp(0.683999836444855*x_104) - 0.00688891889958011*std::exp(0.887759864330292*x_104) - 0.000745351556755083*std::exp(0.580479860305786*x_106) + 0.000301674452072239*std::exp(0.845199882984161*x_106) + 0.00013077867050447*std::exp(1.07079982757568*x_106) + 3.43301445664316e-5*std::exp(1.07351982593536*x_106) - 0.000196698736454693*std::exp(1.21335983276367*x_106) - 0.0344786067319458*std::exp(0.737759828567505*x_109) + 0.00452463926580851*std::exp(0.857519865036011*x_109) + 0.000195806647862431*std::exp(0.90423983335495*x_109) - 0.000148179943432784*std::exp(1.03247976303101*x_109) + 4.18311721584157e-5*std::exp(1.1775997877121*x_109) + 0.00354432045631964*std::exp(0.931599855422974*x_110) + 0.000151180736890464*std::exp(1.26071989536285*x_110) - 4.93376827854311e-5*std::exp(1.28839981555939*x_110) - 4.4267525031112e-5*std::exp(1.36871981620789*x_110) - 0.000152843324613475*std::exp(0.541999876499176*x_112) - 0.0339410016004598*std::exp(0.607759833335876*x_114) + 0.000365497576164819*std::exp(0.76911985874176*x_114) - 0.00160846511401472*std::exp(1.25623989105225*x_23) + 2.89263661933477e-5*std::exp(1.3840799331665*x_23) + 0.0561582344680199*std::exp(0.684879839420319*x_26) - 0.000163112116661168*std::exp(0.75959986448288*x_26) + 0.00072841136816058*std::exp(0.774799823760986*x_26) - 0.00215376852351141*std::exp(0.96783983707428*x_26) - 6.93396388024807e-5*std::exp(1.06383979320526*x_26) + 2.64074039829177e-5*std::exp(1.18863987922668*x_26) + 3.18891076115952e-5*std::exp(1.24711990356445*x_26) + 0.000478855078317115*std::exp(0.523999869823456*x_31) - 0.000907159840493521*std::exp(0.626479864120483*x_31) - 0.278990254667508*std::exp(0.638719856739044*x_31) + 0.0131180980689555*std::exp(0.644239842891693*x_31) + 0.010006214393313*std::exp(0.646319806575775*x_31) - 0.00171230320252245*std::exp(0.647919833660126*x_31) - 0.000717055781731394*std::exp(0.657999873161316*x_31) + 0.000510499491043731*std::exp(0.658879816532135*x_31) + 0.00102447255278681*std::exp(0.66103982925415*x_31) - 0.000292544642976884*std::exp(0.678959846496582*x_31) - 0.000575459663150814*std::exp(0.578719854354858*x_45) - 0.00025702853191183*std::exp(0.62255984544754*x_45) + 5.22623764442104e-5*std::exp(1.25087988376617*x_45) + 0.000456786875136914*std::exp(1.30271983146667*x_50) - 2.79548226159991e-6*std::exp(2.01959991455078*x_52) + 0.000343703463556697*std::exp(1.48807990550995*x_6) + 2.00613060740884e-6*std::exp(2.34247994422913*x_6) - 0.000597406075453624*std::exp(0.804639875888824*x_60) - 0.000106879195993454*std::exp(1.35599982738495*x_60) + 0.000124677033476004*std::exp(0.81471985578537*x_66) + 0.00233306119711589*std::exp(0.986879825592041*x_66) - 0.000678843570029524*std::exp(1.02383983135223*x_66) - 0.000365698553690294*std::exp(0.675039827823639*x_68) + 0.000433840795691271*std::exp(1.33207988739014*x_68) - 0.000678634713541377*std::exp(0.761759877204895*x_70) - 0.00227962573815171*std::exp(0.909759819507599*x_72) + 4.74392672386281e-5*std::exp(1.14007985591888*x_72) - 0.000114113992063054*std::exp(1.38855981826782*x_72) + 0.00882649433954387*std::exp(0.693999886512756*x_74) - 0.0232513082892561*std::exp(1.27359986305237*x_74) - 0.00024032099128076*std::exp(1.36911988258362*x_74) + 0.000210125528218516*std::exp(1.59695994853973*x_74) + 0.00424103062073694*std::exp(0.961679816246033*x_78) + 1.96597968233844e-5*std::exp(1.70751988887787*x_81) + 1.72955510319665e-6*std::exp(2.25271987915039*x_81) + 0.000631944947369715*std::exp(0.698479831218719*x_87) - 0.000924197421395141*std::exp(0.681999802589417*x_90) - 0.0198237784077839*std::sin(0.344079852104187*x_100 - 7.44199991226196) - 0.00681781391366191*std::sin(0.284079939126968*x_102 + 1.83591985702515) + 0.00569695783166225*std::sin(0.37391984462738*x_102 + 1.97303986549377) - 0.00121011485859906*std::sin(0.379999846220016*x_102 + 5.19024038314819) + 0.0853627766939181*std::sin(0.260319977998734*x_105 + 1.8659999370575) - 0.138921920305353*std::sin(0.538719832897186*x_106 - 4.02383995056152) + 0.00280387691671876*std::sin(0.448079854249954*x_108 - 7.36272001266479) - 0.000357488776570683*std::sin(0.701519846916199*x_109 + 2.04247975349426) + 0.0229647697095714*std::sin(0.624799847602844*x_112 - 1.0033597946167) - 0.0147282148309339*std::sin(0.218639984726906*x_115 - 7.58960008621216) - 0.00353698317744124*std::sin(0.371519833803177*x_117 - 4.40263986587524) + 0.0165517601724636*std::sin(0.53279983997345*x_117 + 8.3557596206665) + 0.704154121787772*std::sin(0.115120060741901*x_120 + 1.71199989318848) + 0.0415454477784687*std::sin(0.246319964528084*x_120 - 7.54536008834839) + 0.00330582703163218*std::sin(0.427439838647842*x_120 + 8.41648006439209) + 0.00504354261676112*std::sin(0.469439834356308*x_120 - 4.14560031890869) + 0.00183492406662439*std::sin(0.337999850511551*x_16 - 4.26512002944946) - 0.123388632565156*std::sin(0.348639845848083*x_16 + 8.34088039398193) - 0.0332271615708314*std::sin(0.139280036091805*x_21 + 4.914719581604) + 0.00484351826551395*std::sin(0.465199857950211*x_22 + 2.07911992073059) - 0.0218803307386616*std::sin(0.314799845218658*x_24 - 4.29608011245728) - 0.00396231789154677*std::sin(0.382959842681885*x_24 - 7.40751981735229) + 0.000290174540832016*std::sin(0.577679872512817*x_24 + 2.16567993164063) + 0.0203081518030955*std::sin(0.389759838581085*x_27 - 4.21016025543213) - 0.00545844884435926*std::sin(0.289839953184128*x_28 - 4.28480005264282) - 0.0108478784223156*std::sin(0.349679857492447*x_34 - 7.41232013702393) + 0.00384419309744396*std::sin(0.371519833803177*x_34 - 4.4049596786499) - 0.0594721296276893*std::sin(0.312079936265945*x_35 + 8.25303936004639) - 0.0086490767769473*std::sin(0.359519839286804*x_35 - 1.20879983901978) - 0.0015687124778017*std::sin(0.317679852247238*x_36 + 1.92295980453491) - 0.00662774944300686*std::sin(0.421999841928482*x_36 + 5.22056007385254) - 0.00121803490272341*std::sin(0.435679852962494*x_37 + 2.00375986099243) + 0.00376453842321231*std::sin(0.558719873428345*x_38 - 1.00023984909058) - 0.0158983715291332*std::sin(0.399599850177765*x_41 + 8.18295955657959) + 0.0195944969886133*std::sin(0.438479870557785*x_43 - 0.969679832458496) + 0.00583320873795539*std::sin(0.347359836101532*x_44 + 5.13503980636597) + 0.00778184155139503*std::sin(0.369119822978973*x_53 - 4.2370400428772) - 0.00494854839835001*std::sin(0.379039853811264*x_55 + 1.9871199131012) - 0.0174791465588533*std::sin(0.410559862852097*x_55 - 7.37951993942261) - 0.00651890460503908*std::sin(0.155360028147697*x_59 - 7.65199995040894) + 0.00182921181713705*std::sin(0.313919842243195*x_64 - 4.30408000946045) - 0.0187780555061727*std::sin(0.411039859056473*x_64 + 1.98383975028992) + 0.00767219444403839*std::sin(0.268879950046539*x_70 - 7.51600027084351) + 0.00201289585515004*std::sin(0.195999994874001*x_73 - 1.40735983848572) + 0.0306406124722452*std::sin(0.44159984588623*x_73 - 4.15431976318359) + 0.0242051050038196*std::sin(0.474239856004715*x_75 - 1.12807989120483) + 0.0102730138694697*std::sin(0.483839839696884*x_79 + 8.25088024139404) - 0.00038154712907684*std::sin(0.961759805679321*x_87 + 5.5685601234436) - 0.0219981402828199*std::sin(0.334479838609695*x_92 - 4.40520000457764) + 0.00492106495895952*std::sin(0.350399851799011*x_92 - 1.18759989738464) + 0.339951998978139*std::sin(0.353919863700867*x_92 + 8.19999980926514) + 0.00564150731477059*std::sin(0.396079838275909*x_92 + 4.99959993362427) - 0.00226319629404824*std::sin(0.400879859924316*x_92 + 5.00224018096924) + 0.0546952721483944*std::sin(0.146240040659904*x_95 - 4.48023986816406) - 0.00308079809332173*std::sin(0.391919851303101*x_96 - 7.39015960693359) - 0.0037585287258017*std::sin(0.268799960613251*x_97 + 5.07791996002197) - 0.0160660421140272*std::sin(0.279279947280884*x_97 + 5.09632015228271) - 0.00393764997156795*std::sin(0.316559940576553*x_97 + 8.07672023773193) + 0.00636460685802888*std::sin(0.420239865779877*x_98 + 2.02239966392517) - 2.81577781673901 + 0.000136173279253836*std::exp(-1.24647986888885*x_9) - 0.00203562374336066*std::exp(-1.23735988140106*x_9) + 2.93683781274087e-6*std::exp(-2.09863996505737*x_54));
}

inline float score_4(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (8.49616997195253e-5*x_1 + 0.000600533541051165*x_10 + 0.00402943340792239*x_100 - 0.0101940039025256*x_101 + 0.00717576993849096*x_102 + 0.00220789997838901*x_103 + 0.000407205068644272*x_104 - 0.00464639731169511*x_105 + 0.000681829405306484*x_106 - 0.00297492565812168*x_107 - 0.00199159705901768*x_108 - 0.00162944996291641*x_109 + 0.000361831095815686*x_11 - 0.000386728544603687*x_110 + 0.00115015627030736*x_111 - 0.000729812606929561*x_112 + 0.00160158324793797*x_113 + 0.00570099171480739*x_114 - 0.0049603752874038*x_115 + 0.00495897174496267*x_116 + 0.0012959089285534*x_117 + 0.00202143141137093*x_118 - 0.0052735351941069*x_119 - 0.0079826693490868*x_12 + 0.00228615566052668*x_120 - 0.00348003441073354*x_13 + 0.000126047349423968*x_14 + 0.00106397609720613*x_15 + 0.000538349100345221*x_16 - 0.00181157322523019*x_17 - 0.00383071047827942*x_18 - 0.00173359114251281*x_19 + 0.00979467986405822*x_2 - 0.00114032361530849*x_20 - 0.00211761211448962*x_21 + 0.0059516822751533*x_22 + 0.000613678551768287*x_23 - 0.00227172810696367*x_24 - 0.00327538948358376*x_25 - 0.00410420172535814*x_26 + 0.0002322896875149*x_27 - 0.00361040855075295*x_28 + 0.00239973821552891*x_29 - 0.00116705359777548*x_3 - 0.00418281024660325*x_30 + 0.0228313999504226*x_32 + 0.00975994030286636*x_33 + 0.00656447263170825*x_34 - 0.00542945228604571*x_35 - 0.00128684806488854*x_36 - 0.0103210736661663*x_37 - 0.0024669097891162*x_38 - 0.00977896613162114*x_39 - 0.00713184205058323*x_4 + 0.00199459827959551*x_40 - 0.0044374182734764*x_41 - 0.00312643432183537*x_42 - 0.00463987540256998*x_43 + 0.0105240863120571*x_44 - 0.00197408164510604*x_45 - 0.00561233322364604*x_46 - 0.00115468305559301*x_47 + 0.00549054873663635*x_48 - 0.00508421520088825*x_49 - 0.003853326881079*x_5 - 0.00749596780063197*x_50 + 0.00262031301529388*x_51 + 0.00341722463882271*x_52 + 0.000490634137608797*x_53 - 0.00644274163686778*x_54 + 0.0013189990881533*x_55 + 0.00567290083275888*x_56 - 0.00271236934392922*x_57 - 0.000320373390734166*x_58 + 0.00218541306488165*x_59 + 0.000171834211393872*x_6 + 0.00574478476788092*x_60 + 0.00988466137660913*x_61 + 0.00121712420607798*x_62 - 0.00443992827536322*x_63 - 0.00681277350932383*x_64 + 0.0042283026193827*x_65 - 0.00259309739010079*x_66 + 0.00301713963830703*x_67 + 0.00119561348793893*x_68 - 0.000961252238893523*x_69 + 0.00470250275618187*x_7 - 0.000574209036227142*x_70 + 0.000316911223690632*x_71 + 0.00318466810535003*x_72 + 0.000162862278744074*x_73 - 0.00327411502344061*x_74 - 0.00172651102818364*x_75 + 0.00355424338957471*x_76 - 0.00515561690519099*x_77 - 0.00246136883848961*x_78 + 0.00381006301215435*x_79 - 0.0125977677018582*x_8 - 0.000455764873668674*x_80 + 0.00250467812657088*x_81 - 0.0040580784665121*x_82 - 0.00385093802652896*x_83 + 0.00180114829767885*x_84 - 0.000576454689430907*x_85 + 0.00177680462876817*x_86 - 0.00116702083320263*x_87 + 0.000995872279822128*x_88 + 0.00106722872075194*x_89 - 0.00047096599999351*x_9 - 0.000339368892460309*x_90 - 0.018151511737005*x_91 - 0.00166138686160734*x_92 + 0.0100477251664028*x_93 - 0.0097542602790277*x_94 - 0.000403985243731115*x_95 - 9.41841116330133e-5*x_96 - 0.0104511976779196*x_97 - 0.0043653616684888*x_98 - 0.00660581290420863*x_99 + 2.51277897452604e-5*std::pow(-5.51063966751099*x_106 - 6.32424020767212, 2) + 5.51404821871292e-6*std::pow(-7.38335990905762*x_115 - 8.98408031463623, 2) + 3.48992807526874e-6*std::pow(-7.0025200843811*x_12 - 5.83999967575073, 2) - 5.13291358794783e-5*std::pow(-5.19456005096436*x_24 - 7.38416004180908, 2) + 2.80916448703154e-5*std::pow(-5.73055982589722*x_46 - 7.90679979324341, 2) + 5.41424845780347e-7*std::pow(-7.17063999176025*x_48 - 8.56703948974609, 2) + 4.43659322023305e-5*std::pow(-5.29519987106323*x_55 - 8.13951969146729, 2) + 1.28609577973325e-6*std::pow(-3.55464005470276*x_56 - 3.35920000076294, 2) + 5.60701264909473e-6*std::pow(-6.81983995437622*x_66 - 9.83775997161865, 2) + 8.66629993995371e-7*std::pow(-8.48000049591064*x_67 - 7.86736011505127, 2) + 4.09033809821178e-5*std::pow(-6.06615972518921*x_70 - 8.89816093444824, 2) + 3.79702436107606e-7*std::pow(-8.0*x_78 - 9.99958038330078, 2) - 5.06524102702526e-5*std::pow(-4.9223198890686*x_84 - 5.95056009292603, 2) - 5.84094093538369e-7*std::pow(-6.52711963653564*x_87 - 9.1879997253418, 2) + 3.19610161698729e-6*std::pow(-6.90120029449463*x_97 - 9.54792022705078, 2) - 0.000185583051433192*std::exp(0.647199809551239*x_1) + 0.000113859560325972*std::exp(1.04399979114532*x_1) + 7.62171405703995e-5*std::exp(1.09967982769012*x_1) + 2.75327058229513e-5*std::exp(1.19815981388092*x_1) + 6.90433743014005e-7*std::exp(1.27311992645264*x_1) - 6.45981559740553e-5*std::exp(1.29047989845276*x_1) - 9.00809884049387e-7*std::exp(1.31015980243683*x_1) + 0.000100737970320701*std::exp(1.54399979114532*x_100) - 0.000307437737998086*std::exp(1.70759987831116*x_100) - 0.00384193437473403*std::exp(0.54095983505249*x_104) + 0.000148505101805634*std::exp(0.627919852733612*x_104) - 0.00549648895170157*std::exp(0.683999836444855*x_104) + 0.000671065465080634*std::exp(0.887759864330292*x_104) + 0.000138397287111093*std::exp(0.580479860305786*x_106) + 0.000450574393466496*std::exp(0.845199882984161*x_106) + 0.000817521942698599*std::exp(1.07079982757568*x_106) + 1.85580519727948e-5*std::exp(1.07351982593536*x_106) + 2.90705367209608e-5*std::exp(1.21335983276367*x_106) + 0.00230470633324125*std::exp(0.737759828567505*x_109) - 0.00434609886283564*std::exp(0.857519865036011*x_109) - 3.63574860975063e-5*std::exp(0.90423983335495*x_109) + 2.18998381205406e-5*std::exp(1.03247976303101*x_109) - 3.18196348126528e-5*std::exp(1.1775997877121*x_109) - 0.00034526042330966*std::exp(0.931599855422974*x_110) + 0.000945059077635096*std::exp(1.26071989536285*x_110) + 3.75295973727355e-5*std::exp(1.28839981555939*x_110) + 8.21961840141624e-6*std::exp(1.36871981620789*x_110) + 0.000116263028784722*std::exp(0.541999876499176*x_112) + 0.00226877036979146*std::exp(0.607759833335876*x_114) + 0.00054589922203456*std::exp(0.76911985874176*x_114) + 0.00154499574270061*std::exp(1.25623989105225*x_23) - 2.20033616376732e-5*std::exp(1.3840799331665*x_23) - 0.00375387090459697*std::exp(0.684879839420319*x_26) + 0.000124074170477985*std::exp(0.75959986448288*x_26) + 0.000910815769126314*std::exp(0.774799823760986*x_26) + 0.000209803555096912*std::exp(0.96783983707428*x_26) - 3.748334406752e-5*std::exp(1.06383979320526*x_26) - 3.90280802524363e-6*std::exp(1.18863987922668*x_26) + 0.000199344779274729*std::exp(1.24711990356445*x_26) - 7.07710399626421e-5*std::exp(0.523999869823456*x_31) - 0.00135491418679913*std::exp(0.626479864120483*x_31) + 0.0186489730238734*std::exp(0.638719856739044*x_31) - 0.0126004633188954*std::exp(0.644239842891693*x_31) - 0.000974728402733036*std::exp(0.646319806575775*x_31) - 0.00214108788873146*std::exp(0.647919833660126*x_31) + 0.000545441400221533*std::exp(0.657999873161316*x_31) - 9.47898263466859e-5*std::exp(0.658879816532135*x_31) + 0.00640416964299266*std::exp(0.66103982925415*x_31) - 0.000158142610737396*std::exp(0.678959846496582*x_31) + 8.50484429670487e-5*std::exp(0.578719854354858*x_45) + 0.00019551338391605*std::exp(0.62255984544754*x_45) + 0.000326701895315996*std::exp(1.25087988376617*x_45) + 0.00057117270156733*std::exp(1.30271983146667*x_50) + 2.1264339510377e-6*std::exp(2.01959991455078*x_52) + 0.000513348009951167*std::exp(1.48807990550995*x_6) + 1.08446604425055e-6*std::exp(2.34247994422913*x_6) + 0.000110926688751298*std::exp(0.804639875888824*x_60) - 5.77763274552741e-5*std::exp(1.35599982738495*x_60) - 9.4837831933266e-5*std::exp(0.81471985578537*x_66) - 0.00224099956262468*std::exp(0.986879825592041*x_66) - 0.000848835500624131*std::exp(1.02383983135223*x_66) + 0.000278175193988663*std::exp(0.675039827823639*x_68) - 6.41182806230124e-5*std::exp(1.33207988739014*x_68) - 0.0042422725912181*std::exp(0.761759877204895*x_70) + 0.00218967264487584*std::exp(0.909759819507599*x_72) + 2.56445289725522e-5*std::exp(1.14007985591888*x_72) + 2.1188748825721e-5*std::exp(1.38855981826782*x_72) - 0.00085980915370605*std::exp(0.693999886512756*x_74) + 0.00155422282248843*std::exp(1.27359986305237*x_74) + 4.46229338728475e-5*std::exp(1.36911988258362*x_74) - 0.000201834061367994*std::exp(1.59695994853973*x_74) - 0.00407368129815811*std::exp(0.961679816246033*x_78) + 1.06276141807951e-5*std::exp(1.70751988887787*x_81) - 1.31561725221715e-6*std::exp(2.25271987915039*x_81) - 0.00011733988549013*std::exp(0.698479831218719*x_87) - 0.00138036114668636*std::exp(0.681999802589417*x_90) + 0.00193107993733034*std::sin(0.344079852104187*x_100 - 7.44199991226196) - 0.0426194306315718*std::sin(0.284079939126968*x_102 + 1.83591985702515) + 0.00850885218145933*std::sin(0.37391984462738*x_102 + 1.97303986549377) + 0.000920495670935684*std::sin(0.379999846220016*x_102 + 5.19024038314819) - 0.00831538479080803*std::sin(0.260319977998734*x_105 + 1.8659999370575) + 0.00928617075634699*std::sin(0.538719832897186*x_106 - 4.02383995056152) + 0.00418780951594383*std::sin(0.448079854249954*x_108 - 7.36272001266479) - 0.000533937453330797*std::sin(0.701519846916199*x_109 + 2.04247975349426) - 0.0022370511382508*std::sin(0.624799847602844*x_112 - 1.0033597946167) + 0.00273474303248877*std::sin(0.218639984726906*x_115 - 7.58960008621216) + 0.000522738484214463*std::sin(0.371519833803177*x_117 - 4.40263986587524) - 0.0158986345291812*std::sin(0.53279983997345*x_117 + 8.3557596206665) - 0.0685932756814365*std::sin(0.115120060741901*x_120 + 1.71199989318848) + 0.0519490093456382*std::sin(0.246319964528084*x_120 - 7.54536008834839) + 0.0206653434134209*std::sin(0.427439838647842*x_120 + 8.41648006439209) + 0.00753292544283926*std::sin(0.469439834356308*x_120 - 4.14560031890869) + 0.00274060263538121*std::sin(0.337999850511551*x_16 - 4.26512002944946) + 0.0082478554059265*std::sin(0.348639845848083*x_16 + 8.34088039398193) - 0.207709204971754*std::sin(0.139280036091805*x_21 + 4.914719581604) + 0.00723417342680795*std::sin(0.465199857950211*x_22 + 2.07911992073059) - 0.027359471778698*std::sin(0.314799845218658*x_24 - 4.29608011245728) + 0.000735725365959104*std::sin(0.382959842681885*x_24 - 7.40751981735229) + 0.00015686139041803*std::sin(0.577679872512817*x_24 + 2.16567993164063) - 0.0195068004922942*std::sin(0.389759838581085*x_27 - 4.21016025543213) + 0.00101352778436905*std::sin(0.289839953184128*x_28 - 4.28480005264282) - 0.0162021550282379*std::sin(0.349679857492447*x_34 - 7.41232013702393) + 0.00207807849913868*std::sin(0.371519833803177*x_34 - 4.4049596786499) + 0.0571253838728132*std::sin(0.312079936265945*x_35 + 8.25303936004639) - 0.0108149266488262*std::sin(0.359519839286804*x_35 - 1.20879983901978) + 0.00119326941116231*std::sin(0.317679852247238*x_36 + 1.92295980453491) - 0.0098990622666835*std::sin(0.421999841928482*x_36 + 5.22056007385254) + 0.000926520195201528*std::sin(0.435679852962494*x_37 + 2.00375986099243) + 0.00562263262622594*std::sin(0.558719873428345*x_38 - 1.00023984909058) - 0.0198795462634393*std::sin(0.399599850177765*x_41 + 8.18295955657959) - 0.0188213062030331*std::sin(0.438479870557785*x_43 - 0.969679832458496) - 0.000862102684918979*std::sin(0.347359836101532*x_44 + 5.13503980636597) + 0.0116227891125251*std::sin(0.369119822978973*x_53 - 4.2370400428772) + 0.000918849189033933*std::sin(0.379039853811264*x_55 + 1.9871199131012) + 0.00170268394587203*std::sin(0.410559862852097*x_55 - 7.37951993942261) + 0.000963443177708872*std::sin(0.155360028147697*x_59 - 7.65199995040894) - 0.00139142292728176*std::sin(0.313919842243195*x_64 - 4.30408000946045) - 0.0234803434105394*std::sin(0.411039859056473*x_64 + 1.98383975028992) - 0.00113389040690225*std::sin(0.268879950046539*x_70 - 7.51600027084351) - 0.00153114550039907*std::sin(0.195999994874001*x_73 - 1.40735983848572) - 0.0294315465165413*std::sin(0.44159984588623*x_73 - 4.15431976318359) - 0.00235787505753679*std::sin(0.474239856004715*x_75 - 1.12807989120483) - 0.00986764497081267*std::sin(0.483839839696884*x_79 + 8.25088024139404) - 0.00020625521799877*std::sin(0.961759805679321*x_87 + 5.5685601234436) + 0.00214288953825532*std::sin(0.334479838609695*x_92 - 4.40520000457764) + 0.0307624979660356*std::sin(0.350399851799011*x_92 - 1.18759989738464) - 0.0227239322961681*std::sin(0.353919863700867*x_92 + 8.19999980926514) + 0.0084260324967156*std::sin(0.396079838275909*x_92 + 4.99959993362427) + 0.000420231532969184*std::sin(0.400879859924316*x_92 + 5.00224018096924) - 0.00532799250172786*std::sin(0.146240040659904*x_95 - 4.48023986816406) + 0.000455317892305854*std::sin(0.391919851303101*x_96 - 7.39015960693359) + 0.000555481185642347*std::sin(0.268799960613251*x_97 + 5.07791996002197) - 0.0239958907067197*std::sin(0.279279947280884*x_97 + 5.09632015228271) - 0.00492369263327205*std::sin(0.316559940576553*x_97 + 8.07672023773193) + 0.00950603823098137*std::sin(0.420239865779877*x_98 + 2.02239966392517) + 0.0905453057351502 - 2.52847294071527e-5*std::exp(-1.24647986888885*x_9) + 0.000198294799805346*std::exp(-1.23735988140106*x_9) - 2.23395859794486e-6*std::exp(-2.09863996505737*x_54));
}

inline float score_5(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.0011796503194399*x_1 - 0.00078308171256751*x_10 + 0.0169033889071489*x_100 + 0.00609035141174329*x_101 - 0.0320913122104525*x_102 - 0.00702216642376414*x_103 - 0.0062924759569074*x_104 + 0.0172615443933792*x_105 - 5.95069404093273e-5*x_106 + 0.0693173803066854*x_107 - 0.0134973992634144*x_108 + 0.000868594027890039*x_109 + 0.0156773469934861*x_11 + 0.0119985554345896*x_110 - 0.0225507869028911*x_111 - 4.83228187656207e-5*x_112 - 0.0285217304849703*x_113 + 0.000260749524222837*x_114 - 0.00425355357503335*x_115 - 0.00488146321693603*x_116 + 0.00934699163180509*x_117 + 0.0177264325117177*x_118 - 0.00488044581662547*x_119 + 0.0512854729696421*x_12 + 0.021498873097988*x_120 + 0.0096288089096785*x_13 + 0.0198049386907649*x_14 - 0.0169884382108157*x_15 - 0.00296770551351182*x_16 + 0.00179693938566023*x_17 + 0.0340301142824323*x_18 + 0.045190037314041*x_19 - 0.0174409182571051*x_2 + 0.0133040521353491*x_20 - 0.0189640670584703*x_21 + 0.00215849707575274*x_22 - 0.00825210587091109*x_23 + 0.0262783683113942*x_24 - 0.00291817322613712*x_25 - 0.00213516457904568*x_26 - 0.00114981930707356*x_27 + 0.00312639890820675*x_28 + 0.00431922987031923*x_29 + 0.00773656817541968*x_3 - 0.00816856743644123*x_30 - 0.0688664467365921*x_32 - 0.0050876588402213*x_33 - 0.0483149907996855*x_34 + 0.0151762417379257*x_35 + 0.0138542466233225*x_36 - 0.013903836415994*x_37 - 0.0182269123872481*x_38 - 0.00668811411432938*x_39 - 0.00165866384382484*x_4 + 0.0328970438536503*x_40 - 0.00508355234678237*x_41 - 0.00686352538001181*x_42 + 0.0383337517836666*x_43 - 0.00239686776723128*x_44 - 0.000392988724093909*x_45 - 0.00244627989019965*x_46 + 0.0517094375221836*x_47 - 0.0296219345955177*x_48 + 0.0156286748619046*x_49 + 5.86516044481456e-5*x_5 + 0.0310600952317061*x_50 - 0.00680974536040064*x_51 - 0.0324753915232293*x_52 + 0.00170780352005376*x_53 - 0.00492178454510251*x_54 - 0.00640966020722515*x_55 - 0.00903967048592273*x_56 - 0.019436275561742*x_57 - 0.012771501567768*x_58 - 0.00554012229830226*x_59 + 0.00412089727185675*x_6 - 0.0250742400806836*x_60 - 0.0147059550567922*x_61 - 0.0484230092811728*x_62 + 0.0351154940153099*x_63 - 0.00943114888943209*x_64 - 0.00950074666910694*x_65 + 0.00101666263936141*x_66 - 0.0278779992806008*x_67 - 0.0103434377843347*x_68 + 0.00327195814037527*x_69 - 0.0222392648121274*x_7 - 0.00486600388783251*x_70 - 0.0092231922187261*x_71 - 0.0406012035895478*x_72 + 0.00173986711317723*x_73 + 0.00168593070534308*x_74 + 0.00435850401069636*x_75 + 0.00465594469239936*x_76 + 0.0117791484404124*x_77 - 0.00314630439324754*x_78 - 0.0325589352494934*x_79 + 0.0581231213010516*x_8 - 0.0134952594331476*x_80 + 0.00268687443216999*x_81 - 0.0068204442557643*x_82 + 0.0152824418334156*x_83 + 0.00176419530729798*x_84 - 0.0040374027918671*x_85 + 0.0043894799067532*x_86 - 0.00996803892287691*x_87 - 0.00417388591782829*x_88 + 0.0361048418687089*x_89 - 0.0132992668907334*x_9 + 0.0159717938991019*x_90 + 0.1001885483227*x_91 - 0.000915191710735468*x_92 + 0.0523996343040911*x_93 + 0.0218129900630367*x_94 + 0.000484633055758284*x_95 + 0.00440253419544*x_96 + 0.083979438453545*x_97 + 0.00319194383803225*x_98 - 0.00677322884969131*x_99 + 1.82239817490645e-5*std::pow(-5.51063966751099*x_106 - 6.32424020767212, 2) + 3.81790162525326e-6*std::pow(-7.38335990905762*x_115 - 8.98408031463623, 2) + 2.41641014769647e-6*std::pow(-7.0025200843811*x_12 - 5.83999967575073, 2) - 3.72265625009577e-5*std::pow(-5.19456005096436*x_24 - 7.38416004180908, 2) - 0.00032906853155136*std::pow(-5.73055982589722*x_46 - 7.90679979324341, 2) - 3.75466318198188e-7*std::pow(-7.17063999176025*x_48 - 8.56703948974609, 2) + 3.21764845588142e-5*std::pow(-5.29519987106323*x_55 - 8.13951969146729, 2) + 1.56526399790498e-6*std::pow(-3.55464005470276*x_56 - 3.35920000076294, 2) - 6.56811456696585e-5*std::pow(-6.81983995437622*x_66 - 9.83775997161865, 2) + 1.05474627199765e-6*std::pow(-8.48000049591064*x_67 - 7.86736011505127, 2) + 2.96652620883118e-5*std::pow(-6.06615972518921*x_70 - 8.89816093444824, 2) + 1.74327984622403e-6*std::pow(-8.0*x_78 - 9.99958038330078, 2) + 0.000593347749628656*std::pow(-4.9223198890686*x_84 - 5.95056009292603, 2) - 2.68167745248642e-6*std::pow(-6.52711963653564*x_87 - 9.1879997253418, 2) + 2.21296605941154e-6*std::pow(-6.90120029449463*x_97 - 9.54792022705078, 2) - 0.000128496851239293*std::exp(0.647199809551239*x_1) - 0.00133376306344893*std::exp(1.04399979114532*x_1) - 6.3435438445965e-5*std::exp(1.09967982769012*x_1) + 3.06011058824552e-7*std::exp(1.19815981388092*x_1) + 1.63070611051724e-5*std::exp(1.27311992645264*x_1) + 1.88902277386041e-5*std::exp(1.29047989845276*x_1) + 6.24692001478216e-7*std::exp(1.31015980243683*x_1) + 1.11964778034917e-6*std::exp(1.54399979114532*x_100) + 8.99030134630724e-5*std::exp(1.70759987831116*x_100) - 4.27010121528544e-5*std::exp(0.54095983505249*x_104) + 0.00350747887697777*std::exp(0.627919852733612*x_104) - 0.00398634003846826*std::exp(0.683999836444855*x_104) + 0.000464642641514789*std::exp(0.887759864330292*x_104) + 0.00326874669806646*std::exp(0.580479860305786*x_106) + 5.00788945738038e-6*std::exp(0.845199882984161*x_106) - 0.000239065271229802*std::exp(1.07079982757568*x_106) + 2.25863820424713e-5*std::exp(1.07351982593536*x_106) + 0.00013346788423081*std::exp(1.21335983276367*x_106) - 0.0269975764052972*std::exp(0.737759828567505*x_109) - 0.00315201723505689*std::exp(0.857519865036011*x_109) - 0.000858712010271009*std::exp(0.90423983335495*x_109) + 0.000100545961259748*std::exp(1.03247976303101*x_109) + 2.20662225286287e-5*std::exp(1.1775997877121*x_109) - 0.000239056729104423*std::exp(0.931599855422974*x_110) - 0.000276360538993283*std::exp(1.26071989536285*x_110) - 2.60259569889004e-5*std::exp(1.28839981555939*x_110) + 0.000194135673247904*std::exp(1.36871981620789*x_110) - 8.0625873933534e-5*std::exp(0.541999876499176*x_112) - 0.0265766186871965*std::exp(0.607759833335876*x_114) + 6.06737310965787e-6*std::exp(0.76911985874176*x_114) + 0.00112051137417166*std::exp(1.25623989105225*x_23) + 1.52588512449465e-5*std::exp(1.3840799331665*x_23) + 0.043973245137896*std::exp(0.684879839420319*x_26) - 8.60427302809126e-5*std::exp(0.75959986448288*x_26) - 0.000758070917192948*std::exp(0.774799823760986*x_26) + 0.00014526701657596*std::exp(0.96783983707428*x_26) - 4.5619719708701e-5*std::exp(1.06383979320526*x_26) - 1.79184696412127e-5*std::exp(1.18863987922668*x_26) - 5.82937426342914e-5*std::exp(1.24711990356445*x_26) - 0.000324922138840916*std::exp(0.523999869823456*x_31) - 1.50591346736863e-5*std::exp(0.626479864120483*x_31) - 0.218456063937776*std::exp(0.638719856739044*x_31) - 0.00913851221620551*std::exp(0.644239842891693*x_31) - 0.000674897462874132*std::exp(0.646319806575775*x_31) + 0.00178202498751015*std::exp(0.647919833660126*x_31) - 0.000378251711073354*std::exp(0.657999873161316*x_31) - 0.00223880061776288*std::exp(0.658879816532135*x_31) - 0.00187275040918156*std::exp(0.66103982925415*x_31) - 0.000192470062512209*std::exp(0.678959846496582*x_31) + 0.000390472176310117*std::exp(0.578719854354858*x_45) - 0.000135584266199726*std::exp(0.62255984544754*x_45) - 9.55363680602807e-5*std::exp(1.25087988376617*x_45) - 0.000475386382657888*std::exp(1.30271983146667*x_50) - 1.47463555230278e-6*std::exp(2.01959991455078*x_52) + 5.70558408173901e-6*std::exp(1.48807990550995*x_6) + 1.31986721577446e-6*std::exp(2.34247994422913*x_6) + 0.00261993031187233*std::exp(0.804639875888824*x_60) - 7.03176285328195e-5*std::exp(1.35599982738495*x_60) + 6.57679673539179e-5*std::exp(0.81471985578537*x_66) - 0.00162528959144275*std::exp(0.986879825592041*x_66) + 0.000706484810996757*std::exp(1.02383983135223*x_66) - 0.000192908428039453*std::exp(0.675039827823639*x_68) - 0.000294378164992751*std::exp(1.33207988739014*x_68) + 0.00124055391626866*std::exp(0.761759877204895*x_70) + 0.00158806463764565*std::exp(0.909759819507599*x_72) + 3.12110952982776e-5*std::exp(1.14007985591888*x_72) + 0.000500448052169104*std::exp(1.38855981826782*x_72) - 0.000595327903408903*std::exp(0.693999886512756*x_74) - 0.0182063323191276*std::exp(1.27359986305237*x_74) + 0.00105393010802172*std::exp(1.36911988258362*x_74) - 0.000146380572585126*std::exp(1.59695994853973*x_74) - 0.00295444582996566*std::exp(0.961679816246033*x_78) + 1.29345124390916e-5*std::exp(1.70751988887787*x_81) + 9.12351861385379e-7*std::exp(2.25271987915039*x_81) - 0.00277140087969696*std::exp(0.698479831218719*x_87) - 1.53419638002179e-5*std::exp(0.681999802589417*x_90) + 0.00133707086677388*std::sin(0.344079852104187*x_100 - 7.44199991226196) + 0.0124630608812329*std::sin(0.284079939126968*x_102 + 1.83591985702515) + 9.45712667027243e-5*std::sin(0.37391984462738*x_102 + 1.97303986549377) - 0.000638343665195974*std::sin(0.379999846220016*x_102 + 5.19024038314819) - 0.00575753418326883*std::sin(0.260319977998734*x_105 + 1.8659999370575) - 0.108779197111215*std::sin(0.538719832897186*x_106 - 4.02383995056152) + 4.6545226334465e-5*std::sin(0.448079854249954*x_108 - 7.36272001266479) - 5.93442455276734e-6*std::sin(0.701519846916199*x_109 + 2.04247975349426) - 0.00154892391900338*std::sin(0.624799847602844*x_112 - 1.0033597946167) + 0.0645907332730613*std::sin(0.218639984726906*x_115 - 7.58960008621216) + 0.00239998319136019*std::sin(0.371519833803177*x_117 - 4.40263986587524) - 0.0115305177427909*std::sin(0.53279983997345*x_117 + 8.3557596206665) - 0.0474936685930414*std::sin(0.115120060741901*x_120 + 1.71199989318848) - 0.0432371007362868*std::sin(0.246319964528084*x_120 - 7.54536008834839) - 0.00604309887007873*std::sin(0.427439838647842*x_120 + 8.41648006439209) + 8.37243715032205e-5*std::sin(0.469439834356308*x_120 - 4.14560031890869) + 3.04603085386276e-5*std::sin(0.337999850511551*x_16 - 4.26512002944946) - 0.0966162600803839*std::sin(0.348639845848083*x_16 + 8.34088039398193) + 0.0607397243180858*std::sin(0.139280036091805*x_21 + 4.914719581604) + 8.04039052424906e-5*std::sin(0.465199857950211*x_22 + 2.07911992073059) + 0.0227712568976348*std::sin(0.314799845218658*x_24 - 4.29608011245728) + 0.0173767846961632*std::sin(0.382959842681885*x_24 - 7.40751981735229) + 0.000190910732273442*std::sin(0.577679872512817*x_24 + 2.16567993164063) - 0.0141473476082895*std::sin(0.389759838581085*x_27 - 4.21016025543213) + 0.0239380819357795*std::sin(0.289839953184128*x_28 - 4.28480005264282) - 0.000180078145871794*std::sin(0.349679857492447*x_34 - 7.41232013702393) + 0.00252915957798791*std::sin(0.371519833803177*x_34 - 4.4049596786499) + 0.0414303034075176*std::sin(0.312079936265945*x_35 + 8.25303936004639) + 0.00900125101250101*std::sin(0.359519839286804*x_35 - 1.20879983901978) - 0.000827506302895814*std::sin(0.317679852247238*x_36 + 1.92295980453491) - 0.000110022696101043*std::sin(0.421999841928482*x_36 + 5.22056007385254) - 0.000642521541336349*std::sin(0.435679852962494*x_37 + 2.00375986099243) + 6.24925052552806e-5*std::sin(0.558719873428345*x_38 - 1.00023984909058) + 0.0165457234933041*std::sin(0.399599850177765*x_41 + 8.18295955657959) - 0.0136501914499792*std::sin(0.438479870557785*x_43 - 0.969679832458496) - 0.00395806319127479*std::sin(0.347359836101532*x_44 + 5.13503980636597) + 0.000129180982998533*std::sin(0.369119822978973*x_53 - 4.2370400428772) + 0.0217019084359997*std::sin(0.379039853811264*x_55 + 1.9871199131012) + 0.00117893053277558*std::sin(0.410559862852097*x_55 - 7.37951993942261) + 0.00442333499858278*std::sin(0.155360028147697*x_59 - 7.65199995040894) + 0.000964921443178423*std::sin(0.313919842243195*x_64 - 4.30408000946045) + 0.0195426628178684*std::sin(0.411039859056473*x_64 + 1.98383975028992) - 0.00520588783796812*std::sin(0.268879950046539*x_70 - 7.51600027084351) + 0.00106181599928606*std::sin(0.195999994874001*x_73 - 1.40735983848572) - 0.0213452902941994*std::sin(0.44159984588623*x_73 - 4.15431976318359) - 0.00163258184499792*std::sin(0.474239856004715*x_75 - 1.12807989120483) - 0.00715653002820341*std::sin(0.483839839696884*x_79 + 8.25088024139404) - 0.000251026301618437*std::sin(0.961759805679321*x_87 + 5.5685601234436) + 0.00148372686025456*std::sin(0.334479838609695*x_92 - 4.40520000457764) - 0.00899577679307364*std::sin(0.350399851799011*x_92 - 1.18759989738464) + 0.266190572545444*std::sin(0.353919863700867*x_92 + 8.19999980926514) + 9.36507709264313e-5*std::sin(0.396079838275909*x_92 + 4.99959993362427) + 0.00992526995643922*std::sin(0.400879859924316*x_92 + 5.00224018096924) - 0.00368907750255984*std::sin(0.146240040659904*x_95 - 4.48023986816406) + 0.00209044354157648*std::sin(0.391919851303101*x_96 - 7.39015960693359) + 0.00255031062169036*std::sin(0.268799960613251*x_97 + 5.07791996002197) - 0.00026670128137135*std::sin(0.279279947280884*x_97 + 5.09632015228271) + 0.00409798371635689*std::sin(0.316559940576553*x_97 + 8.07672023773193) + 0.000105654447586637*std::sin(0.420239865779877*x_98 + 2.02239966392517) - 1.58651648897842 - 0.000597189276512267*std::exp(-1.24647986888885*x_9) + 0.000137298407345596*std::exp(-1.23735988140106*x_9) + 1.54920154905087e-6*std::exp(-2.09863996505737*x_54));
}

inline float score_6(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.000822800464512003*x_1 + 0.00198927891189508*x_10 - 0.00433461857605646*x_100 - 0.0262610455934233*x_101 + 0.0321815653217685*x_102 + 0.00650524464162027*x_103 + 0.00504061854506406*x_104 - 0.0144249986392047*x_105 + 0.000687796712138753*x_106 - 0.0524373552989493*x_107 + 0.00588010015764544*x_108 - 0.00133984336786201*x_109 - 0.00868804422129512*x_11 - 0.0092312251344556*x_110 + 0.0169963304454811*x_111 + 0.00110579464149786*x_112 + 0.0215219033905948*x_113 + 0.00441507313275238*x_114 - 0.0033648035175376*x_115 + 0.011509087877176*x_116 - 0.00708265244618407*x_117 - 0.0104493833792553*x_118 + 3.79938538711778e-5*x_119 - 0.0319668326486393*x_12 - 0.00741240465640064*x_120 - 0.013027628403045*x_13 - 0.0117296679343885*x_14 + 0.0113566848729786*x_15 - 0.00064924326987124*x_16 - 0.00359122777387633*x_17 - 0.0290822332640499*x_18 - 0.0311033570008518*x_19 + 0.0155719809770585*x_2 - 0.0104482481141521*x_20 + 0.00938468462180682*x_21 + 0.00421682396680229*x_22 + 0.00762903279865642*x_23 - 0.0216139556154127*x_24 + 0.00443899160707906*x_25 - 0.00543572323348816*x_26 + 0.00211770282980539*x_27 - 0.0061260621343608*x_28 + 0.004132457773638*x_29 - 0.0061512777067868*x_3 + 0.000296089710017649*x_30 + 0.0560867914880485*x_32 + 0.00739058595280633*x_33 + 0.0399161286062505*x_34 - 0.0165625587591297*x_35 - 0.0115092974701625*x_36 + 0.00560786094410978*x_37 + 0.00801812668557239*x_38 - 0.0070979682883384*x_39 - 0.00190380647263364*x_4 - 0.0251302862873112*x_40 - 0.00506430508543059*x_41 - 0.0184242159338685*x_42 - 0.0300403091280975*x_43 + 0.00555150464128343*x_44 - 0.00275734795890261*x_45 - 0.00848655001682026*x_46 - 0.0335075839752865*x_47 + 0.0308566976076441*x_48 - 0.0240250861913034*x_49 - 0.00791766526401559*x_5 - 0.0330472808852467*x_50 + 0.00781172822639467*x_51 + 0.0278527687743132*x_52 - 0.000110777222120164*x_53 - 0.00170703232814366*x_54 + 0.00722841255916793*x_55 + 0.0158689046969347*x_56 + 0.00820905554320463*x_57 + 0.00696895972591716*x_58 + 0.00532756412867922*x_59 - 0.00250830356107847*x_6 + 0.0183555552812751*x_60 + 0.0133496630023498*x_61 + 0.0291298420809925*x_62 - 0.0286430432215768*x_63 - 0.00341974747997288*x_64 + 0.0123496336094242*x_65 - 0.00224242553200023*x_66 + 0.0244169937340705*x_67 + 0.00115844559896891*x_68 - 0.00279531001291469*x_69 + 0.0229298745581395*x_7 + 0.00226786090570123*x_70 + 0.00754611704686619*x_71 + 0.0341202110807255*x_72 + 0.000122728592902107*x_73 - 0.00014736510593576*x_74 - 0.00437414766679754*x_75 + 0.00318474116507321*x_76 - 0.0156006576128237*x_77 + 0.000883716293045078*x_78 + 0.0279576914275037*x_79 - 0.0533690109297717*x_8 + 0.00961906798234818*x_80 - 0.00090816500913656*x_81 - 0.00282074480612019*x_82 - 0.0206776078646495*x_83 + 0.000422732114944533*x_84 + 0.000894994220115913*x_85 + 0.000463888496875549*x_86 + 0.00834101565722692*x_87 + 0.00247400350522022*x_88 - 0.0225527144601519*x_89 + 0.00717285191707841*x_9 - 0.0115947372499665*x_90 - 0.0962405549835229*x_91 - 0.00201712274662747*x_92 + 0.000103798505030558*x_93 - 0.0231084213902458*x_94 + 0.00140857759884804*x_95 - 0.00271275239422389*x_96 - 0.0719360055478806*x_97 - 0.00448587480975443*x_98 + 0.003083474095499*x_99 + 3.33639343009993e-5*std::pow(-5.51063966751099*x_106 - 6.32424020767212, 2) + 1.18080589726075e-5*std::pow(-7.38335990905762*x_115 - 8.98408031463623, 2) + 7.47350673921941e-6*std::pow(-7.0025200843811*x_12 - 5.83999967575073, 2) - 6.81533049492741e-5*std::pow(-5.19456005096436*x_24 - 7.38416004180908, 2) + 0.000267645410672092*std::pow(-5.73055982589722*x_46 - 7.90679979324341, 2) - 1.17850523518085e-6*std::pow(-7.17063999176025*x_48 - 8.56703948974609, 2) + 5.89077695335437e-5*std::pow(-5.29519987106323*x_55 - 8.13951969146729, 2) + 1.18040760478915e-6*std::pow(-3.55464005470276*x_56 - 3.35920000076294, 2) + 5.34212649361932e-5*std::pow(-6.81983995437622*x_66 - 9.83775997161865, 2) + 7.95412481380421e-7*std::pow(-8.48000049591064*x_67 - 7.86736011505127, 2) + 5.43102966719756e-5*std::pow(-6.06615972518921*x_70 - 8.89816093444824, 2) - 7.24024957101825e-7*std::pow(-8.0*x_78 - 9.99958038330078, 2) - 0.000482594921404502*std::pow(-4.9223198890686*x_84 - 5.95056009292603, 2) + 1.11376346528812e-6*std::pow(-6.52711963653564*x_87 - 9.1879997253418, 2) + 6.84429204803747e-6*std::pow(-6.90120029449463*x_97 - 9.54792022705078, 2) - 0.000397416839447059*std::exp(0.647199809551239*x_1) + 0.00108480613801973*std::exp(1.04399979114532*x_1) - 3.0908943177174e-6*std::exp(1.09967982769012*x_1) - 6.24664265970897e-7*std::exp(1.19815981388092*x_1) - 2.69925665302211e-7*std::exp(1.27311992645264*x_1) - 6.38982951858009e-5*std::exp(1.29047989845276*x_1) + 1.96076920468025e-6*std::exp(1.31015980243683*x_1) - 2.28555125276944e-6*std::exp(1.54399979114532*x_100) - 0.000304106936763746*std::exp(1.70759987831116*x_100) + 8.71661191433288e-5*std::exp(0.54095983505249*x_104) - 5.80581972003143e-5*std::exp(0.627919852733612*x_104) - 0.00729807508459152*std::exp(0.683999836444855*x_104) + 0.00143705319065962*std::exp(0.887759864330292*x_104) - 5.41065383571864e-5*std::exp(0.580479860305786*x_106) - 1.02226684354942e-5*std::exp(0.845199882984161*x_106) + 0.00080866485471203*std::exp(1.07079982757568*x_106) + 1.70329970939667e-5*std::exp(1.07351982593536*x_106) - 5.54323388548285e-5*std::exp(1.21335983276367*x_106) + 0.0219582753479398*std::exp(0.737759828567505*x_109) - 0.00577062122834127*std::exp(0.857519865036011*x_109) + 1.42139904413482e-5*std::exp(0.90423983335495*x_109) - 4.17590930369164e-5*std::exp(1.03247976303101*x_109) + 6.92609629951626e-5*std::exp(1.1775997877121*x_109) - 0.00073935795945932*std::exp(0.931599855422974*x_110) + 0.000934820243707911*std::exp(1.26071989536285*x_110) - 8.16896884631367e-5*std::exp(1.28839981555939*x_110) - 3.21346687930861e-6*std::exp(1.36871981620789*x_110) - 0.000253066679796153*std::exp(0.541999876499176*x_112) + 0.0216158925597543*std::exp(0.607759833335876*x_114) - 1.23854058885139e-5*std::exp(0.76911985874176*x_114) + 0.00205139954517924*std::exp(1.25623989105225*x_23) + 4.78941391102978e-5*std::exp(1.3840799331665*x_23) - 0.035765307603349*std::exp(0.684879839420319*x_26) - 0.000270068986672156*std::exp(0.75959986448288*x_26) - 3.69370362652162e-5*std::exp(0.774799823760986*x_26) + 0.000449283838839063*std::exp(0.96783983707428*x_26) - 3.4403055423606e-5*std::exp(1.06383979320526*x_26) + 7.44196018866963e-6*std::exp(1.18863987922668*x_26) + 0.000197185064461605*std::exp(1.24711990356445*x_26) + 0.000134947775680012*std::exp(0.523999869823456*x_31) + 3.07404031188574e-5*std::exp(0.626479864120483*x_31) + 0.177679593581282*std::exp(0.638719856739044*x_31) - 0.0167305216493652*std::exp(0.644239842891693*x_31) - 0.00208733221133016*std::exp(0.646319806575775*x_31) + 8.68292399778615e-5*std::exp(0.647919833660126*x_31) - 0.00118724796369288*std::exp(0.657999873161316*x_31) + 3.70581640880076e-5*std::exp(0.658879816532135*x_31) + 0.00633478643619864*std::exp(0.66103982925415*x_31) - 0.00014514684154733*std::exp(0.678959846496582*x_31) - 0.000162172241774461*std::exp(0.578719854354858*x_45) - 0.000425568845406231*std::exp(0.62255984544754*x_45) + 0.000323162384899137*std::exp(1.25087988376617*x_45) - 2.31632208253612e-5*std::exp(1.30271983146667*x_50) - 4.62855290645621e-6*std::exp(2.01959991455078*x_52) - 1.16468813448933e-5*std::exp(1.48807990550995*x_6) + 9.95347303009163e-7*std::exp(2.34247994422913*x_6) - 4.3366884315731e-5*std::exp(0.804639875888824*x_60) - 5.30284115535617e-5*std::exp(1.35599982738495*x_60) + 0.000206431016783997*std::exp(0.81471985578537*x_66) - 0.00297553278397997*std::exp(0.986879825592041*x_66) + 3.44235011431915e-5*std::exp(1.02383983135223*x_66) - 0.000605496635346668*std::exp(0.675039827823639*x_68) + 0.000122262147837164*std::exp(1.33207988739014*x_68) - 0.00419631152321373*std::exp(0.761759877204895*x_70) + 0.0029073824241988*std::exp(0.909759819507599*x_72) + 2.35371249151559e-5*std::exp(1.14007985591888*x_72) - 8.28375956646743e-6*std::exp(1.38855981826782*x_72) - 0.00184123837685964*std::exp(0.693999886512756*x_74) + 0.0148079832107098*std::exp(1.27359986305237*x_74) - 1.74453743537859e-5*std::exp(1.36911988258362*x_74) - 0.000267989283237925*std::exp(1.59695994853973*x_74) - 0.00540891326188339*std::exp(0.961679816246033*x_78) + 9.75426309413557e-6*std::exp(1.70751988887787*x_81) + 2.86366950337772e-6*std::exp(2.25271987915039*x_81) + 4.58741290933199e-5*std::exp(0.698479831218719*x_87) + 3.13177458116303e-5*std::exp(0.681999802589417*x_90) + 0.00413531127700915*std::sin(0.344079852104187*x_100 - 7.44199991226196) - 0.0421576888393022*std::sin(0.284079939126968*x_102 + 1.83591985702515) - 0.00019304952939843*std::sin(0.37391984462738*x_102 + 1.97303986549377) - 0.00200361873972647*std::sin(0.379999846220016*x_102 + 5.19024038314819) - 0.0178069813855751*std::sin(0.260319977998734*x_105 + 1.8659999370575) + 0.0884747403410328*std::sin(0.538719832897186*x_106 - 4.02383995056152) - 9.50133624397466e-5*std::sin(0.448079854249954*x_108 - 7.36272001266479) + 1.21140163086049e-5*std::sin(0.701519846916199*x_109 + 2.04247975349426) - 0.00479053332822867*std::sin(0.624799847602844*x_112 - 1.0033597946167) - 0.00106915013923377*std::sin(0.218639984726906*x_115 - 7.58960008621216) - 0.000996769239851786*std::sin(0.371519833803177*x_117 - 4.40263986587524) - 0.0211097356068593*std::sin(0.53279983997345*x_117 + 8.3557596206665) - 0.146889075366081*std::sin(0.115120060741901*x_120 + 1.71199989318848) - 0.00210672949150026*std::sin(0.246319964528084*x_120 - 7.54536008834839) + 0.0204414536860319*std::sin(0.427439838647842*x_120 + 8.41648006439209) - 0.000170907624285955*std::sin(0.469439834356308*x_120 - 4.14560031890869) - 6.21790151885916e-5*std::sin(0.337999850511551*x_16 - 4.26512002944946) + 0.078582107152291*std::sin(0.348639845848083*x_16 + 8.34088039398193) - 0.205458869405246*std::sin(0.139280036091805*x_21 + 4.914719581604) - 0.000164129514281019*std::sin(0.465199857950211*x_22 + 2.07911992073059) + 0.00110953041827142*std::sin(0.314799845218658*x_24 - 4.29608011245728) - 0.000287632464223574*std::sin(0.382959842681885*x_24 - 7.40751981735229) + 0.000143970908749616*std::sin(0.577679872512817*x_24 + 2.16567993164063) - 0.0259005514072466*std::sin(0.389759838581085*x_27 - 4.21016025543213) - 0.000396239558489458*std::sin(0.289839953184128*x_28 - 4.28480005264282) + 0.000367595809251123*std::sin(0.349679857492447*x_34 - 7.41232013702393) + 0.00190730714025116*std::sin(0.371519833803177*x_34 - 4.4049596786499) + 0.0758493912028771*std::sin(0.312079936265945*x_35 + 8.25303936004639) + 0.000438586321596664*std::sin(0.359519839286804*x_35 - 1.20879983901978) - 0.0025973581725994*std::sin(0.317679852247238*x_36 + 1.92295980453491) + 0.000224590728727556*std::sin(0.421999841928482*x_36 + 5.22056007385254) - 0.00201673216339386*std::sin(0.435679852962494*x_37 + 2.00375986099243) - 0.000127566745704944*std::sin(0.558719873428345*x_38 - 1.00023984909058) + 0.000806191050000221*std::sin(0.399599850177765*x_41 + 8.18295955657959) - 0.0249903724117013*std::sin(0.438479870557785*x_43 - 0.969679832458496) + 0.00164387636240749*std::sin(0.347359836101532*x_44 + 5.13503980636597) - 0.000263698783410448*std::sin(0.369119822978973*x_53 - 4.2370400428772) - 0.000359224880261031*std::sin(0.379039853811264*x_55 + 1.9871199131012) + 0.00364621266392586*std::sin(0.410559862852097*x_55 - 7.37951993942261) - 0.00183711464314395*std::sin(0.155360028147697*x_59 - 7.65199995040894) + 0.00302867372439994*std::sin(0.313919842243195*x_64 - 4.30408000946045) + 0.00095221704045239*std::sin(0.411039859056473*x_64 + 1.98383975028992) + 0.00216212716892581*std::sin(0.268879950046539*x_70 - 7.51600027084351) + 0.00333280417791533*std::sin(0.195999994874001*x_73 - 1.40735983848572) - 0.0390783349554213*std::sin(0.44159984588623*x_73 - 4.15431976318359) - 0.00504927171926936*std::sin(0.474239856004715*x_75 - 1.12807989120483) - 0.0131019664622065*std::sin(0.483839839696884*x_79 + 8.25088024139404) - 0.000189305673566311*std::sin(0.961759805679321*x_87 + 5.5685601234436) + 0.00458889096283758*std::sin(0.334479838609695*x_92 - 4.40520000457764) + 0.030429214983719*std::sin(0.350399851799011*x_92 - 1.18759989738464) - 0.216504096487406*std::sin(0.353919863700867*x_92 + 8.19999980926514) - 0.000191170509664189*std::sin(0.396079838275909*x_92 + 4.99959993362427) - 0.000164289879029528*std::sin(0.400879859924316*x_92 + 5.00224018096924) - 0.0114096299434788*std::sin(0.146240040659904*x_95 - 4.48023986816406) - 0.000868210172217634*std::sin(0.391919851303101*x_96 - 7.39015960693359) - 0.00105920374314268*std::sin(0.268799960613251*x_97 + 5.07791996002197) + 0.00054442071734685*std::sin(0.279279947280884*x_97 + 5.09632015228271) + 0.00019967442321338*std::sin(0.316559940576553*x_97 + 8.07672023773193) - 0.000215673767483372*std::sin(0.420239865779877*x_98 + 2.02239966392517) + 1.35071192644726 + 9.88508669552908e-6*std::exp(-1.24647986888885*x_9) + 0.000424638413954506*std::exp(-1.23735988140106*x_9) + 4.86259898003163e-6*std::exp(-2.09863996505737*x_54));
}

inline float score_7(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-6.64504804890405e-5*x_1 + 0.00549472000037922*x_10 - 0.0302880934538425*x_100 - 0.000772479590427266*x_101 + 0.0354951866686141*x_102 + 0.0104440913528947*x_103 + 0.00935809489204347*x_104 - 0.0193940810806384*x_105 - 0.00279916353491409*x_106 - 0.0929383412922525*x_107 + 0.022696713935988*x_108 - 0.0013805153650133*x_109 - 0.0143351604870937*x_11 - 0.0170197591489791*x_110 + 0.0324311375294542*x_111 + 0.000336230768741291*x_112 + 0.0397363493056765*x_113 - 0.00837451382323193*x_114 + 0.0104867154970859*x_115 + 0.017561002160865*x_116 - 0.0120332877627172*x_117 - 0.0311565536598575*x_118 + 0.01028828303905*x_119 - 0.055378899408033*x_12 - 0.0192991836630474*x_120 - 0.00603351580832203*x_13 - 0.0286658542368149*x_14 + 0.0210034852550561*x_15 + 0.000279073757702783*x_16 + 0.00374929954441049*x_17 - 0.0450339027334725*x_18 - 0.0786998395142394*x_19 + 0.0211381080513312*x_2 - 0.00960653863396525*x_20 + 0.0308002878932248*x_21 - 0.00341522198430345*x_22 + 0.0140900755500892*x_23 - 0.0362218000345964*x_24 + 0.0129578909168915*x_25 + 0.00883207037234507*x_26 + 0.000743767387970058*x_27 + 0.000603843854045766*x_28 - 0.00589426800197284*x_29 - 4.7218535974419e-5*x_3 + 0.0127398934946946*x_30 + 0.0807350861097645*x_32 - 0.0164889156886019*x_33 + 0.0665516003805281*x_34 - 0.0291420199223239*x_35 - 0.0162896235818247*x_36 + 0.0417145259168498*x_37 + 0.0188825268237614*x_38 + 0.0318715041981143*x_39 + 0.00563835941724765*x_4 - 0.0510484677212175*x_40 + 0.013853296024746*x_41 - 0.00649512778761588*x_42 - 0.0504263381876936*x_43 - 0.0149188059014062*x_44 - 0.00380390875608543*x_45 + 0.00891510706535898*x_46 - 0.0808787424705792*x_47 + 0.0355003345126427*x_48 - 0.0164585880845366*x_49 + 0.00355663135216474*x_5 - 0.0328035330719328*x_50 + 0.010582028093457*x_51 + 0.0441716996698172*x_52 - 0.00503556084525801*x_53 + 0.0202099634843058*x_54 + 0.00810537352627547*x_55 + 0.00829676671100292*x_56 + 0.0332395744129336*x_57 + 0.0217315257833703*x_58 + 0.00748997238903476*x_59 - 0.00624713282418735*x_6 + 0.0317545448586303*x_60 + 0.0153951332087978*x_61 + 0.05852556557787*x_62 - 0.0496858742666693*x_63 + 0.0145045063739582*x_64 + 0.00302399259430653*x_65 + 0.00110773053152821*x_66 + 0.0412175676695705*x_67 + 0.0120906279984311*x_68 + 0.000654153253450861*x_69 + 0.0307590418525532*x_7 + 0.00996293943282226*x_70 + 0.0165542375960541*x_71 + 0.0578842697574344*x_72 - 0.000203850511619804*x_73 + 0.00120176478429706*x_74 - 0.0046626468444369*x_75 - 0.0091752414576364*x_76 - 0.00622359859752216*x_77 + 0.00725868989072108*x_78 + 0.0493377896088169*x_79 - 0.0660745620719954*x_8 + 0.0185079058371243*x_80 - 0.00854200457447755*x_81 + 0.0184075143428715*x_82 - 0.0157659127180569*x_83 + 0.00209502180103909*x_84 + 0.00615076558389761*x_85 - 0.00226547114003606*x_86 + 0.0134917624897333*x_87 + 0.00352193321188989*x_88 - 0.0514211845065603*x_89 + 0.0198158161125195*x_9 - 0.0157260032986715*x_90 - 0.109187453211092*x_91 + 0.0030154231748881*x_92 - 0.0569439790966828*x_93 - 0.0203055806899663*x_94 + 0.00251756666961684*x_95 - 0.0043165403734154*x_96 - 0.108347100381559*x_97 + 0.000555730344042154*x_98 + 0.0113021670841199*x_99 - 4.86880748230471e-5*std::pow(-5.51063966751099*x_106 - 6.32424020767212, 2) - 4.42516948022025e-5*std::pow(-7.38335990905762*x_115 - 8.98408031463623, 2) - 2.80075954984084e-5*std::pow(-7.0025200843811*x_12 - 5.83999967575073, 2) + 9.94562925604616e-5*std::pow(-5.19456005096436*x_24 - 7.38416004180908, 2) + 0.000455326408121822*std::pow(-5.73055982589722*x_46 - 7.90679979324341, 2) + 1.48998354445887e-6*std::pow(-7.17063999176025*x_48 - 8.56703948974609, 2) - 8.59642590359042e-5*std::pow(-5.29519987106323*x_55 - 8.13951969146729, 2) + 1.86879081163435e-6*std::pow(-3.55464005470276*x_56 - 3.35920000076294, 2) + 9.08818597697606e-5*std::pow(-6.81983995437622*x_66 - 9.83775997161865, 2) + 1.25927648265917e-6*std::pow(-8.48000049591064*x_67 - 7.86736011505127, 2) - 7.92551551076468e-5*std::pow(-6.06615972518921*x_70 - 8.89816093444824, 2) - 1.72830708968805e-7*std::pow(-8.0*x_78 - 9.99958038330078, 2) - 0.000821004969183494*std::pow(-4.9223198890686*x_84 - 5.95056009292603, 2) + 2.65864494643693e-7*std::pow(-6.52711963653564*x_87 - 9.1879997253418, 2) - 2.56495604865713e-5*std::pow(-6.90120029449463*x_97 - 9.54792022705078, 2) + 0.00148935305364449*std::exp(0.647199809551239*x_1) + 0.00184550477100534*std::exp(1.04399979114532*x_1) - 3.15779263737224e-5*std::exp(1.09967982769012*x_1) - 6.37334630542432e-6*std::exp(1.19815981388092*x_1) + 1.78335417613357e-5*std::exp(1.27311992645264*x_1) + 2.851598124439e-5*std::exp(1.29047989845276*x_1) - 2.47899946664806e-6*std::exp(1.31015980243683*x_1) - 2.33191018379379e-5*std::exp(1.54399979114532*x_100) + 0.000135714226488016*std::exp(1.70759987831116*x_100) + 0.000889341512975536*std::exp(0.54095983505249*x_104) + 0.00383580895577471*std::exp(0.627919852733612*x_104) + 0.0106500996728124*std::exp(0.683999836444855*x_104) - 0.00538547777878843*std::exp(0.887759864330292*x_104) + 0.00357472939919911*std::exp(0.580479860305786*x_106) - 0.000104300197168586*std::exp(0.845199882984161*x_106) - 0.000360883991707651*std::exp(1.07079982757568*x_106) + 2.69662007722201e-5*std::exp(1.07351982593536*x_106) - 1.32321549555807e-5*std::exp(1.21335983276367*x_106) + 0.0373560772726146*std::exp(0.737759828567505*x_109) + 0.0084210823461707*std::exp(0.857519865036011*x_109) - 0.000939094812815238*std::exp(0.90423983335495*x_109) - 9.96823878054458e-6*std::exp(1.03247976303101*x_109) - 8.75665988198435e-5*std::exp(1.1775997877121*x_109) + 0.00277080617970087*std::exp(0.931599855422974*x_110) - 0.000417183532971229*std::exp(1.26071989536285*x_110) + 0.000103280229844178*std::exp(1.28839981555939*x_110) + 0.000212308435830499*std::exp(1.36871981620789*x_110) + 0.000319952069189787*std::exp(0.541999876499176*x_112) + 0.0367736053940356*std::exp(0.607759833335876*x_114) - 0.000126366250097646*std::exp(0.76911985874176*x_114) - 0.00299361261314617*std::exp(1.25623989105225*x_23) - 6.0552534702501e-5*std::exp(1.3840799331665*x_23) - 0.0608450150724106*std::exp(0.684879839420319*x_26) + 0.000341448076765176*std::exp(0.75959986448288*x_26) - 0.000377364895642205*std::exp(0.774799823760986*x_26) - 0.00168372899915132*std::exp(0.96783983707428*x_26) - 5.44660281812287e-5*std::exp(1.06383979320526*x_26) + 1.77645707224496e-6*std::exp(1.18863987922668*x_26) - 8.79980535241333e-5*std::exp(1.24711990356445*x_26) + 3.22131433671832e-5*std::exp(0.523999869823456*x_31) + 0.000313639254424635*std::exp(0.626479864120483*x_31) + 0.302273859053867*std::exp(0.638719856739044*x_31) + 0.0244148931161427*std::exp(0.644239842891693*x_31) + 0.00782245313822243*std::exp(0.646319806575775*x_31) + 0.000887085440414555*std::exp(0.647919833660126*x_31) + 0.00150103697148467*std::exp(0.657999873161316*x_31) - 0.00244837154007563*std::exp(0.658879816532135*x_31) - 0.00282703397135387*std::exp(0.66103982925415*x_31) - 0.000229792728139743*std::exp(0.678959846496582*x_31) - 3.87118472174415e-5*std::exp(0.578719854354858*x_45) + 0.000538046465777759*std::exp(0.62255984544754*x_45) - 0.000144218127884011*std::exp(1.25087988376617*x_45) - 0.000236645581056843*std::exp(1.30271983146667*x_50) + 5.85187698739302e-6*std::exp(2.01959991455078*x_52) - 0.000118831206190126*std::exp(1.48807990550995*x_6) + 1.57580812483906e-6*std::exp(2.34247994422913*x_6) + 0.00286517823948943*std::exp(0.804639875888824*x_60) - 8.3953210623853e-5*std::exp(1.35599982738495*x_60) - 0.000260990625151417*std::exp(0.81471985578537*x_66) + 0.00434220261668922*std::exp(0.986879825592041*x_66) + 0.000351685522987472*std::exp(1.02383983135223*x_66) + 0.000765529075272458*std::exp(0.675039827823639*x_68) + 2.91849797213193e-5*std::exp(1.33207988739014*x_68) + 0.00187269379165175*std::exp(0.761759877204895*x_70) - 0.00424275062202012*std::exp(0.909759819507599*x_72) + 3.72633678360539e-5*std::exp(1.14007985591888*x_72) + 0.000547294278237908*std::exp(1.38855981826782*x_72) + 0.00690019578153441*std::exp(0.693999886512756*x_74) + 0.0251917856163853*std::exp(1.27359986305237*x_74) + 0.0011525869973574*std::exp(1.36911988258362*x_74) + 0.000391077447771861*std::exp(1.59695994853973*x_74) + 0.00789324098381475*std::exp(0.961679816246033*x_78) + 1.54426972264727e-5*std::exp(1.70751988887787*x_81) - 3.6205358359284e-6*std::exp(2.25271987915039*x_81) - 0.00303082775042779*std::exp(0.698479831218719*x_87) + 0.000319529786536678*std::exp(0.681999802589417*x_90) - 0.015497427051036*std::sin(0.344079852104187*x_100 - 7.44199991226196) + 0.0188137705513544*std::sin(0.284079939126968*x_102 + 1.83591985702515) - 0.001969652454896*std::sin(0.37391984462738*x_102 + 1.97303986549377) + 0.00253317411110501*std::sin(0.379999846220016*x_102 + 5.19024038314819) + 0.0667331614324557*std::sin(0.260319977998734*x_105 + 1.8659999370575) + 0.150515884534813*std::sin(0.538719832897186*x_106 - 4.02383995056152) - 0.000969405639892186*std::sin(0.448079854249954*x_108 - 7.36272001266479) + 0.000123597307049887*std::sin(0.701519846916199*x_109 + 2.04247975349426) + 0.0179529268334729*std::sin(0.624799847602844*x_112 - 1.0033597946167) + 0.0706369793914041*std::sin(0.218639984726906*x_115 - 7.58960008621216) - 0.0002379370113034*std::sin(0.371519833803177*x_117 - 4.40263986587524) + 0.03080549126638*std::sin(0.53279983997345*x_117 + 8.3557596206665) + 0.550479172568205*std::sin(0.115120060741901*x_120 + 1.71199989318848) - 0.0215232686509559*std::sin(0.246319964528084*x_120 - 7.54536008834839) - 0.00912243602468573*std::sin(0.427439838647842*x_120 + 8.41648006439209) - 0.00174374225507961*std::sin(0.469439834356308*x_120 - 4.14560031890869) - 0.000634402219424531*std::sin(0.337999850511551*x_16 - 4.26512002944946) + 0.133686239948771*std::sin(0.348639845848083*x_16 + 8.34088039398193) + 0.0916904159871153*std::sin(0.139280036091805*x_21 + 4.914719581604) - 0.00167458631850529*std::sin(0.465199857950211*x_22 + 2.07911992073059) + 0.0113354473676909*std::sin(0.314799845218658*x_24 - 4.29608011245728) + 0.0190034006470039*std::sin(0.382959842681885*x_24 - 7.40751981735229) + 0.000227931021727016*std::sin(0.577679872512817*x_24 + 2.16567993164063) + 0.0377967410407121*std::sin(0.389759838581085*x_27 - 4.21016025543213) + 0.0261788915326129*std::sin(0.289839953184128*x_28 - 4.28480005264282) + 0.0037505193115837*std::sin(0.349679857492447*x_34 - 7.41232013702393) + 0.00301959936906935*std::sin(0.371519833803177*x_34 - 4.4049596786499) - 0.110687210952146*std::sin(0.312079936265945*x_35 + 8.25303936004639) + 0.00448078942476721*std::sin(0.359519839286804*x_35 - 1.20879983901978) + 0.00328383856151897*std::sin(0.317679852247238*x_36 + 1.92295980453491) + 0.00229146210075512*std::sin(0.421999841928482*x_36 + 5.22056007385254) + 0.00254975340570011*std::sin(0.435679852962494*x_37 + 2.00375986099243) - 0.00130154243122895*std::sin(0.558719873428345*x_38 - 1.00023984909058) + 0.00823639989052144*std::sin(0.399599850177765*x_41 + 8.18295955657959) + 0.0364685145001104*std::sin(0.438479870557785*x_43 - 0.969679832458496) + 0.000392406800877706*std::sin(0.347359836101532*x_44 + 5.13503980636597) - 0.00269047512167467*std::sin(0.369119822978973*x_53 - 4.2370400428772) + 0.0237333930312755*std::sin(0.379039853811264*x_55 + 1.9871199131012) - 0.0136644888344713*std::sin(0.410559862852097*x_55 - 7.37951993942261) - 0.000438534366967805*std::sin(0.155360028147697*x_59 - 7.65199995040894) - 0.0038291505851464*std::sin(0.313919842243195*x_64 - 4.30408000946045) + 0.00972826518941454*std::sin(0.411039859056473*x_64 + 1.98383975028992) + 0.000516117528575204*std::sin(0.268879950046539*x_70 - 7.51600027084351) - 0.00421366255639549*std::sin(0.195999994874001*x_73 - 1.40735983848572) + 0.057027114341628*std::sin(0.44159984588623*x_73 - 4.15431976318359) + 0.0189225707301121*std::sin(0.474239856004715*x_75 - 1.12807989120483) + 0.0191197332330756*std::sin(0.483839839696884*x_79 + 8.25088024139404) - 0.000299703849683489*std::sin(0.961759805679321*x_87 + 5.5685601234436) - 0.0171972550983316*std::sin(0.334479838609695*x_92 - 4.40520000457764) - 0.0135796881784424*std::sin(0.350399851799011*x_92 - 1.18759989738464) - 0.368323269021216*std::sin(0.353919863700867*x_92 + 8.19999980926514) - 0.00195048112697887*std::sin(0.396079838275909*x_92 + 4.99959993362427) + 0.0108543602749208*std::sin(0.400879859924316*x_92 + 5.00224018096924) + 0.0427585484825373*std::sin(0.146240040659904*x_95 - 4.48023986816406) - 0.000207248905063916*std::sin(0.391919851303101*x_96 - 7.39015960693359) - 0.000252840640469823*std::sin(0.268799960613251*x_97 + 5.07791996002197) + 0.00555463463578474*std::sin(0.279279947280884*x_97 + 5.09632015228271) + 0.00203996112025079*std::sin(0.316559940576553*x_97 + 8.07672023773193) - 0.00220048381834464*std::sin(0.420239865779877*x_98 + 2.02239966392517) + 1.65393974558931 - 0.000653091310164115*std::exp(-1.24647986888885*x_9) - 0.00159136819516211*std::exp(-1.23735988140106*x_9) - 6.14778131421519e-6*std::exp(-2.09863996505737*x_54));
}

inline float score_8(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.000329418386590791*x_1 - 0.0014714493148688*x_10 + 0.0132898829715883*x_100 - 0.0143706527112578*x_101 + 0.000149377930120794*x_102 - 0.00217861566941939*x_103 - 0.00139171931991198*x_104 + 0.00298991783976595*x_105 + 0.00122993839091226*x_106 + 0.0175375393494272*x_107 - 0.00796083589288063*x_108 + 0.00270727137680256*x_109 + 0.00348380699538862*x_11 + 0.00334305268934354*x_110 - 0.00560025284092485*x_111 - 5.72435899782129e-5*x_112 - 0.00767746234823443*x_113 + 0.00557059814596069*x_114 - 0.00102586694185196*x_115 - 0.00349849901977377*x_116 + 0.00233991229249323*x_117 + 0.00811677067614004*x_118 + 0.000143332418702386*x_119 + 0.0256697149074095*x_12 + 0.0087760542690297*x_120 - 0.00429475908215142*x_13 + 0.00993250578080106*x_14 - 0.0051802065410147*x_15 - 0.00253420792479905*x_16 - 0.00314271973429293*x_17 + 0.00713398007742808*x_18 + 0.0224578216684876*x_19 - 0.0101577599471403*x_2 - 0.00191133320853047*x_20 - 0.0110570893662014*x_21 - 0.00264926645607253*x_22 - 0.00156708078435979*x_23 + 0.00626833641924671*x_24 - 0.00428830802300851*x_25 - 0.00790305135677551*x_26 + 0.00144121103553606*x_27 - 0.00417250631344206*x_28 + 0.00824125366316622*x_29 - 0.00259950949901629*x_3 - 0.0051325944964063*x_30 - 0.0193957774127708*x_32 + 0.00851683000528615*x_33 - 0.0200886559161549*x_34 + 0.00482325870496594*x_35 + 0.00123002917974934*x_36 - 0.0138088463460447*x_37 - 0.000760997833137625*x_38 - 0.0143540435654709*x_39 + 0.00764252141929598*x_4 + 0.00719159487187818*x_40 - 0.00911942018244892*x_41 - 0.0144738144048732*x_42 + 0.0104675831782107*x_43 + 0.00766810594622748*x_44 - 0.000865297831203092*x_45 - 0.00504678223110016*x_46 + 0.0241707554349204*x_47 + 0.000903917999524477*x_48 - 0.00702377164558523*x_49 - 0.00475196577646912*x_5 - 0.0015192071263644*x_50 - 0.00073519839201499*x_51 - 0.00329166841714622*x_52 + 0.00111507998441669*x_53 - 0.00783473313912143*x_54 - 0.002441204649431*x_55 + 0.00460112344048995*x_56 - 0.00716808438826918*x_57 - 0.00606086156192604*x_58 + 0.00136045938282673*x_59 + 0.00174347188289364*x_6 - 0.00605819708762254*x_60 - 0.00425639499424615*x_61 - 0.0144427322479023*x_62 + 0.00938721248506072*x_63 - 0.000305205517940694*x_64 - 0.00151467550241803*x_65 + 0.0020479114347322*x_66 - 0.0046512116830198*x_67 - 0.00810334497486631*x_68 - 0.00456415295299919*x_69 - 0.000885984880461766*x_7 - 0.00288312669367063*x_70 - 0.00303848099911677*x_71 - 0.0102200720287141*x_72 - 0.00143835722476932*x_73 + 0.000735440269829434*x_74 + 0.00597480475082723*x_75 + 0.00796152864343822*x_76 - 0.00506578548031921*x_77 + 0.00296679310377975*x_78 - 0.00764843302729669*x_79 + 0.0191181651061317*x_8 - 0.00553952085232729*x_80 - 0.000402602152239311*x_81 - 0.0101256093595993*x_82 - 0.00501309538460201*x_83 - 0.000370490890195358*x_84 - 0.00334857809923629*x_85 + 0.000799046240385852*x_86 - 0.00119388741796443*x_87 - 0.000631383401471505*x_88 + 0.0127466298326346*x_89 - 0.00507941208772104*x_9 + 0.000830642089450839*x_90 + 0.0204409091563025*x_91 - 0.00262719795932369*x_92 + 0.0724785219925*x_93 + 0.0124022404890971*x_94 + 3.24136729849373e-5*x_95 + 0.000311098584600691*x_96 + 0.0143781381618816*x_97 + 0.00145402326560949*x_98 + 0.00245434495697914*x_99 + 4.79150481708402e-5*std::pow(-5.51063966751099*x_106 - 6.32424020767212, 2) + 2.25598886523957e-5*std::pow(-7.38335990905762*x_115 - 8.98408031463623, 2) + 1.42785093020659e-5*std::pow(-7.0025200843811*x_12 - 5.83999967575073, 2) - 9.78772125668833e-5*std::pow(-5.19456005096436*x_24 - 7.38416004180908, 2) - 7.58432666190194e-5*std::pow(-5.73055982589722*x_46 - 7.90679979324341, 2) - 4.38232526622228e-8*std::pow(-7.17063999176025*x_48 - 8.56703948974609, 2) + 8.45993937457179e-5*std::pow(-5.29519987106323*x_55 - 8.13951969146729, 2) - 2.60589637481019e-6*std::pow(-3.55464005470276*x_56 - 3.35920000076294, 2) - 1.51381009280405e-5*std::pow(-6.81983995437622*x_66 - 9.83775997161865, 2) - 1.75597182981405e-6*std::pow(-8.48000049591064*x_67 - 7.86736011505127, 2) + 7.7996811099475e-5*std::pow(-6.06615972518921*x_70 - 8.89816093444824, 2) + 4.24377422807506e-7*std::pow(-8.0*x_78 - 9.99958038330078, 2) + 0.000136753980578838*std::pow(-4.9223198890686*x_84 - 5.95056009292603, 2) - 6.52817370975867e-7*std::pow(-6.52711963653564*x_87 - 9.1879997253418, 2) + 1.30763630895135e-5*std::pow(-6.90120029449463*x_97 - 9.54792022705078, 2) - 0.000759284795859456*std::exp(0.647199809551239*x_1) - 0.000307403892893869*std::exp(1.04399979114532*x_1) - 2.89938983526579e-5*std::exp(1.09967982769012*x_1) + 8.83693759471356e-6*std::exp(1.19815981388092*x_1) - 1.90995130808044e-6*std::exp(1.27311992645264*x_1) + 5.23493939912701e-5*std::exp(1.29047989845276*x_1) + 7.29120938150283e-8*std::exp(1.31015980243683*x_1) + 3.23330065292769e-5*std::exp(1.54399979114532*x_100) + 0.000249143013938519*std::exp(1.70759987831116*x_100) - 0.00123311288512036*std::exp(0.54095983505249*x_104) - 0.000410810619150946*std::exp(0.627919852733612*x_104) - 0.0104810067085565*std::exp(0.683999836444855*x_104) + 0.00274556216597994*std::exp(0.887759864330292*x_104) - 0.00038284930629072*std::exp(0.580479860305786*x_106) + 0.000144617017391738*std::exp(0.845199882984161*x_106) - 0.000662507739261567*std::exp(1.07079982757568*x_106) - 3.760245630343e-5*std::exp(1.07351982593536*x_106) + 3.24909146745008e-5*std::exp(1.21335983276367*x_106) - 0.00622236461116831*std::exp(0.737759828567505*x_109) - 0.0082873797687392*std::exp(0.857519865036011*x_109) + 0.000100575947848829*std::exp(0.90423983335495*x_109) + 2.4476526821289e-5*std::exp(1.03247976303101*x_109) + 2.57550037993687e-6*std::exp(1.1775997877121*x_109) - 0.00141258044851901*std::exp(0.931599855422974*x_110) - 0.000765861954635608*std::exp(1.26071989536285*x_110) - 3.03766818385744e-6*std::exp(1.28839981555939*x_110) - 2.27379832989833e-5*std::exp(1.36871981620789*x_110) - 9.41039947726219e-6*std::exp(0.541999876499176*x_112) - 0.00612534285008185*std::exp(0.607759833335876*x_114) + 0.000175212614014157*std::exp(0.76911985874176*x_114) + 0.00294608265134844*std::exp(1.25623989105225*x_23) + 1.78096532506971e-6*std::exp(1.3840799331665*x_23) + 0.0101348936021748*std::exp(0.684879839420319*x_26) - 1.00426379839951e-5*std::exp(0.75959986448288*x_26) - 0.000346485050874533*std::exp(0.774799823760986*x_26) + 0.000858379298498029*std::exp(0.96783983707428*x_26) + 7.59490171420771e-5*std::exp(1.06383979320526*x_26) - 4.36200417475321e-6*std::exp(1.18863987922668*x_26) - 0.00016154607253103*std::exp(1.24711990356445*x_26) - 7.90978110560282e-5*std::exp(0.523999869823456*x_31) - 0.000434875242263877*std::exp(0.626479864120483*x_31) - 0.0503494558524456*std::exp(0.638719856739044*x_31) - 0.0240272548051568*std::exp(0.644239842891693*x_31) - 0.00398795283605946*std::exp(0.646319806575775*x_31) + 0.000814495061680343*std::exp(0.647919833660126*x_31) - 4.41483549944845e-5*std::exp(0.657999873161316*x_31) + 0.000262217706847937*std::exp(0.658879816532135*x_31) - 0.005189844737404*std::exp(0.66103982925415*x_31) + 0.00032042967756964*std::exp(0.678959846496582*x_31) + 9.50550631440214e-5*std::exp(0.578719854354858*x_45) - 1.58249708874188e-5*std::exp(0.62255984544754*x_45) - 0.000264754403244277*std::exp(1.25087988376617*x_45) - 0.000217280825902406*std::exp(1.30271983146667*x_50) - 1.72114842959496e-7*std::exp(2.01959991455078*x_52) + 0.000164764929298278*std::exp(1.48807990550995*x_6) - 2.19735277718073e-6*std::exp(2.34247994422913*x_6) - 0.000306857213201523*std::exp(0.804639875888824*x_60) + 0.000117066803762293*std::exp(1.35599982738495*x_60) + 7.67623115773125e-6*std::exp(0.81471985578537*x_66) - 0.00427326092276966*std::exp(0.986879825592041*x_66) + 0.000322907026412137*std::exp(1.02383983135223*x_66) - 2.25156675123728e-5*std::exp(0.675039827823639*x_68) - 7.16623021031425e-5*std::exp(1.33207988739014*x_68) + 0.00343787521404228*std::exp(0.761759877204895*x_70) + 0.00417538793985598*std::exp(0.909759819507599*x_72) - 5.19611261745604e-5*std::exp(1.14007985591888*x_72) - 5.8614572282648e-5*std::exp(1.38855981826782*x_72) - 0.00351777822763522*std::exp(0.693999886512756*x_74) - 0.00419617065698835*std::exp(1.27359986305237*x_74) - 0.000123440709239935*std::exp(1.36911988258362*x_74) - 0.000384868262230978*std::exp(1.59695994853973*x_74) - 0.00776791900969775*std::exp(0.961679816246033*x_78) - 2.15337470995819e-5*std::exp(1.70751988887787*x_81) + 1.06486851684087e-7*std::exp(2.25271987915039*x_81) + 0.000324598080626161*std::exp(0.698479831218719*x_87) - 0.000443042735787567*std::exp(0.681999802589417*x_90) + 0.00790071951442176*std::sin(0.344079852104187*x_100 - 7.44199991226196) + 0.0345381587473153*std::sin(0.284079939126968*x_102 + 1.83591985702515) + 0.00273101366112437*std::sin(0.37391984462738*x_102 + 1.97303986549377) - 7.45054732457958e-5*std::sin(0.379999846220016*x_102 + 5.19024038314819) - 0.0340211306723469*std::sin(0.260319977998734*x_105 + 1.8659999370575) - 0.0250712810800052*std::sin(0.538719832897186*x_106 - 4.02383995056152) + 0.0013441254771296*std::sin(0.448079854249954*x_108 - 7.36272001266479) - 0.000171373347207716*std::sin(0.701519846916199*x_109 + 2.04247975349426) - 0.009152554092179*std::sin(0.624799847602844*x_112 - 1.0033597946167) - 0.00756513725613182*std::sin(0.218639984726906*x_115 - 7.58960008621216) + 0.000584242790242114*std::sin(0.371519833803177*x_117 - 4.40263986587524) - 0.0303163886294451*std::sin(0.53279983997345*x_117 + 8.3557596206665) - 0.280638942623809*std::sin(0.115120060741901*x_120 + 1.71199989318848) - 0.019762015279194*std::sin(0.246319964528084*x_120 - 7.54536008834839) - 0.0167468898763699*std::sin(0.427439838647842*x_120 + 8.41648006439209) + 0.00241777878542216*std::sin(0.469439834356308*x_120 - 4.14560031890869) + 0.000879627836672077*std::sin(0.337999850511551*x_16 - 4.26512002944946) - 0.0222679839316856*std::sin(0.348639845848083*x_16 + 8.34088039398193) + 0.168324479897645*std::sin(0.139280036091805*x_21 + 4.914719581604) + 0.00232189090070278*std::sin(0.465199857950211*x_22 + 2.07911992073059) + 0.010407865445979*std::sin(0.314799845218658*x_24 - 4.29608011245728) - 0.00203524181620574*std::sin(0.382959842681885*x_24 - 7.40751981735229) - 0.000317833659887145*std::sin(0.577679872512817*x_24 + 2.16567993164063) - 0.0371966374568834*std::sin(0.389759838581085*x_27 - 4.21016025543213) - 0.00280372843465195*std::sin(0.289839953184128*x_28 - 4.28480005264282) - 0.00520026741305825*std::sin(0.349679857492447*x_34 - 7.41232013702393) - 0.00421061736832671*std::sin(0.371519833803177*x_34 - 4.4049596786499) + 0.108929816262883*std::sin(0.312079936265945*x_35 + 8.25303936004639) + 0.00411412553135453*std::sin(0.359519839286804*x_35 - 1.20879983901978) - 9.65839438419171e-5*std::sin(0.317679852247238*x_36 + 1.92295980453491) - 0.00317721752665315*std::sin(0.421999841928482*x_36 + 5.22056007385254) - 7.49931018633766e-5*std::sin(0.435679852962494*x_37 + 2.00375986099243) + 0.0018046484045364*std::sin(0.558719873428345*x_38 - 1.00023984909058) + 0.00756241364272555*std::sin(0.399599850177765*x_41 + 8.18295955657959) - 0.035889499335156*std::sin(0.438479870557785*x_43 - 0.969679832458496) - 0.00096353586606346*std::sin(0.347359836101532*x_44 + 5.13503980636597) + 0.00373046742025193*std::sin(0.369119822978973*x_53 - 4.2370400428772) - 0.00254181842686737*std::sin(0.379039853811264*x_55 + 1.9871199131012) + 0.00696627209365624*std::sin(0.410559862852097*x_55 - 7.37951993942261) + 0.00107679986720363*std::sin(0.155360028147697*x_59 - 7.65199995040894) + 0.00011262260861781*std::sin(0.313919842243195*x_64 - 4.30408000946045) + 0.00893219930629461*std::sin(0.411039859056473*x_64 + 1.98383975028992) - 0.00126730155739891*std::sin(0.268879950046539*x_70 - 7.51600027084351) + 0.000123931837723302*std::sin(0.195999994874001*x_73 - 1.40735983848572) - 0.0561216877162223*std::sin(0.44159984588623*x_73 - 4.15431976318359) - 0.00964688675985274*std::sin(0.474239856004715*x_75 - 1.12807989120483) - 0.0188161668376909*std::sin(0.483839839696884*x_79 + 8.25088024139404) + 0.000417915783053236*std::sin(0.961759805679321*x_87 + 5.5685601234436) + 0.00876730624396097*std::sin(0.334479838609695*x_92 - 4.40520000457764) - 0.0249294751823323*std::sin(0.350399851799011*x_92 - 1.18759989738464) + 0.0613512403323881*std::sin(0.353919863700867*x_92 + 8.19999980926514) + 0.00270443173378311*std::sin(0.396079838275909*x_92 + 4.99959993362427) - 0.00116248919496228*std::sin(0.400879859924316*x_92 + 5.00224018096924) - 0.0217986700174045*std::sin(0.146240040659904*x_95 - 4.48023986816406) + 0.000508889633882002*std::sin(0.391919851303101*x_96 - 7.39015960693359) + 0.000620837928767334*std::sin(0.268799960613251*x_97 + 5.07791996002197) - 0.00770175623378374*std::sin(0.279279947280884*x_97 + 5.09632015228271) + 0.00187303069441394*std::sin(0.316559940576553*x_97 + 8.07672023773193) + 0.00305107195639732*std::sin(0.420239865779877*x_98 + 2.02239966392517) - 0.236923743986064 + 6.99453097336115e-5*std::exp(-1.24647986888885*x_9) + 0.00081129297868235*std::exp(-1.23735988140106*x_9) + 1.80817952551812e-7*std::exp(-2.09863996505737*x_54));
}

inline float score_9(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.00231690373072877*x_1 + 0.0034346217048542*x_10 + 0.00498950020685308*x_100 - 0.0210034008346068*x_101 + 0.0099692819017837*x_102 + 0.00315541713450465*x_103 + 0.00104942091949858*x_104 - 0.00364516593681805*x_105 - 0.00224289448404785*x_106 - 0.00190132348866247*x_107 + 0.00287995005809671*x_108 - 0.00170847948221498*x_109 + 0.00189608780642082*x_11 - 0.00110568480688236*x_110 + 0.00189954175289341*x_111 - 1.5373476957486e-5*x_112 + 0.00405833376482294*x_113 + 0.00304583462380514*x_114 - 0.00127697707753318*x_115 + 0.00347084603291054*x_116 - 0.000212229387833123*x_117 + 0.000228472252851514*x_118 - 0.0054149538135005*x_119 + 0.00231360195503731*x_12 + 0.00271760653233722*x_120 + 0.00300855007198708*x_13 + 0.00433477020548882*x_14 + 0.000488759356014513*x_15 + 0.000265380909579824*x_16 + 0.0029429833121965*x_17 - 0.00454033027997274*x_18 - 0.00750957580829659*x_19 + 0.00517972167447555*x_2 - 0.00429235966781297*x_20 - 0.000680861453579042*x_21 - 0.00465115517153325*x_22 + 0.00123954549991194*x_23 - 0.00346344390865694*x_24 - 0.00599721080008256*x_25 - 0.00538543392371668*x_26 - 0.00196179081168012*x_27 - 5.00823148105254e-5*x_28 + 0.00329768923741527*x_29 - 0.00498585495828268*x_3 - 0.00456637993611845*x_30 + 0.0251675089357366*x_32 - 0.00417609187142344*x_33 + 0.00514202291454681*x_34 - 0.00390784676634528*x_35 - 0.00416931952330692*x_36 - 0.0110437721724118*x_37 - 0.00138327994952538*x_38 - 0.00646385032252997*x_39 + 0.00876391853818875*x_4 + 0.00155048074032631*x_40 - 0.00722742283627243*x_41 - 0.014978831933224*x_42 - 0.00643029540361475*x_43 + 0.00789730733162876*x_44 - 0.000648532387562164*x_45 - 0.00387387240944338*x_46 - 0.00790355466190445*x_47 + 0.00377535858279893*x_48 - 0.00701030126748141*x_49 + 0.000431687629853191*x_5 - 0.00680785659485059*x_50 + 0.00681049515976425*x_51 + 0.00368568658465904*x_52 - 0.00176395314861547*x_53 - 0.00371576103200522*x_54 - 0.000258701005920709*x_55 + 0.00521451519083024*x_56 - 0.00847837586294106*x_57 + 0.000899944729047772*x_58 + 0.00230267329086572*x_59 - 6.93694291659613e-5*x_6 + 0.00326794790486421*x_60 + 0.00710586643672931*x_61 - 0.00321787745952586*x_62 - 0.0116603330370817*x_63 + 0.00474524761964356*x_64 - 0.00676211649339544*x_65 - 0.000398021302576019*x_66 + 0.00514433770055171*x_67 - 0.00224218043510252*x_68 - 0.00352336638937367*x_69 + 0.00821472504581774*x_7 + 0.0042394115053769*x_70 + 0.000920394057154163*x_71 + 0.00599226876136189*x_72 - 7.94400705400879e-6*x_73 - 0.000828657827104463*x_74 + 0.00165170895703557*x_75 + 0.00126213319640902*x_76 - 0.00632547211533533*x_77 - 0.000269318312924651*x_78 + 0.00492070007420318*x_79 + 0.000881298872873687*x_8 - 0.000699661666979349*x_80 - 0.0030677252907401*x_81 - 0.00242675960114897*x_82 - 0.0026611167497478*x_83 + 0.00188570191473123*x_84 + 0.00322464707246266*x_85 + 0.00570794361062224*x_86 - 0.000997005006626985*x_87 - 0.000537086433725797*x_88 + 0.00137662396712859*x_89 + 0.000385369555029831*x_9 + 0.0030862930279575*x_90 - 0.0277711137883726*x_91 - 0.00192438460227959*x_92 + 0.0322346985659728*x_93 + 0.00235780156259052*x_94 + 0.000654843104901778*x_95 - 0.00330900328333639*x_96 - 0.0149353413340213*x_97 - 0.00317656709320303*x_98 - 0.00347205646074075*x_99 + 3.33360103935456e-5*std::pow(-5.51063966751099*x_106 - 6.32424020767212, 2) - 3.78315782855668e-5*std::pow(-7.38335990905762*x_115 - 8.98408031463623, 2) - 2.39442025085056e-5*std::pow(-7.0025200843811*x_12 - 5.83999967575073, 2) - 6.80962641170121e-5*std::pow(-5.19456005096436*x_24 - 7.38416004180908, 2) + 4.47508115668016e-5*std::pow(-5.73055982589722*x_46 - 7.90679979324341, 2) + 8.83309072348191e-7*std::pow(-7.17063999176025*x_48 - 8.56703948974609, 2) + 5.88584667417951e-5*std::pow(-5.29519987106323*x_55 - 8.13951969146729, 2) + 2.13141567622063e-6*std::pow(-3.55464005470276*x_56 - 3.35920000076294, 2) + 8.93213507684122e-6*std::pow(-6.81983995437622*x_66 - 9.83775997161865, 2) + 1.43624509448888e-6*std::pow(-8.48000049591064*x_67 - 7.86736011505127, 2) + 5.42648417299905e-5*std::pow(-6.06615972518921*x_70 - 8.89816093444824, 2) + 3.31484288615475e-6*std::pow(-8.0*x_78 - 9.99958038330078, 2) - 8.06907704362898e-5*std::pow(-4.9223198890686*x_84 - 5.95056009292603, 2) - 5.09920392046672e-6*std::pow(-6.52711963653564*x_87 - 9.1879997253418, 2) - 2.19282755129596e-5*std::pow(-6.90120029449463*x_97 - 9.54792022705078, 2) + 0.00127327499874638*std::exp(0.647199809551239*x_1) + 0.000181381608401675*std::exp(1.04399979114532*x_1) + 7.04500082240739e-6*std::exp(1.09967982769012*x_1) + 1.32611130731006e-5*std::exp(1.19815981388092*x_1) + 1.17546840303671e-6*std::exp(1.27311992645264*x_1) + 5.95419104491415e-6*std::exp(1.29047989845276*x_1) - 1.4696287938078e-6*std::exp(1.31015980243683*x_1) + 4.85203896692155e-5*std::exp(1.54399979114532*x_100) + 2.83373882559755e-5*std::exp(1.70759987831116*x_100) - 0.00185046564222212*std::exp(0.54095983505249*x_104) + 0.000252831001712399*std::exp(0.627919852733612*x_104) - 0.00729196696882156*std::exp(0.683999836444855*x_104) - 0.00460414284931012*std::exp(0.887759864330292*x_104) + 0.000235622374646585*std::exp(0.580479860305786*x_106) + 0.000217018916267288*std::exp(0.845199882984161*x_106) - 7.53532629041583e-5*std::exp(1.07079982757568*x_106) + 3.0755814238918e-5*std::exp(1.07351982593536*x_106) + 0.000253788895415114*std::exp(1.21335983276367*x_106) + 0.00367146456933461*std::exp(0.737759828567505*x_109) - 0.00576579151336592*std::exp(0.857519865036011*x_109) - 6.18988810351325e-5*std::exp(0.90423983335495*x_109) + 0.000191187929542916*std::exp(1.03247976303101*x_109) - 5.19122318228913e-5*std::exp(1.1775997877121*x_109) + 0.00236881257023106*std::exp(0.931599855422974*x_110) - 8.71087140510593e-5*std::exp(1.26071989536285*x_110) + 6.12277661420085e-5*std::exp(1.28839981555939*x_110) + 1.39939593243314e-5*std::exp(1.36871981620789*x_110) + 0.000189677642067218*std::exp(0.541999876499176*x_112) + 0.00361421752893392*std::exp(0.607759833335876*x_114) + 0.00026293206909883*std::exp(0.76911985874176*x_114) + 0.00204968262862697*std::exp(1.25623989105225*x_23) - 3.58974456163024e-5*std::exp(1.3840799331665*x_23) - 0.00598002609933434*std::exp(0.684879839420319*x_26) + 0.000202421150934293*std::exp(0.75959986448288*x_26) + 8.41896953170212e-5*std::exp(0.774799823760986*x_26) - 0.00143945052789033*std::exp(0.96783983707428*x_26) - 6.21202467200806e-5*std::exp(1.06383979320526*x_26) - 3.40719315660123e-5*std::exp(1.18863987922668*x_26) - 1.83741607126477e-5*std::exp(1.24711990356445*x_26) - 0.000617838749655676*std::exp(0.523999869823456*x_31) - 0.000652593695332103*std::exp(0.626479864120483*x_31) + 0.0297083592491091*std::exp(0.638719856739044*x_31) - 0.0167165190580049*std::exp(0.644239842891693*x_31) + 0.00668755738297982*std::exp(0.646319806575775*x_31) - 0.000197907791135605*std::exp(0.647919833660126*x_31) + 0.000889861891276118*std::exp(0.657999873161316*x_31) - 0.000161380359704705*std::exp(0.658879816532135*x_31) - 0.000590290062671956*std::exp(0.66103982925415*x_31) - 0.000262085954184575*std::exp(0.678959846496582*x_31) + 0.000742482005219381*std::exp(0.578719854354858*x_45) + 0.00031897085463382*std::exp(0.62255984544754*x_45) - 3.01130190191227e-5*std::exp(1.25087988376617*x_45) + 5.27953702036582e-5*std::exp(1.30271983146667*x_50) + 3.4691765908778e-6*std::exp(2.01959991455078*x_52) + 0.000247253795162364*std::exp(1.48807990550995*x_6) + 1.79725955365784e-6*std::exp(2.34247994422913*x_6) + 0.00018885348377012*std::exp(0.804639875888824*x_60) - 9.57513211637859e-5*std::exp(1.35599982738495*x_60) - 0.0001547234450014*std::exp(0.81471985578537*x_66) - 0.0029730424151483*std::exp(0.986879825592041*x_66) - 7.8460655375309e-5*std::exp(1.02383983135223*x_66) + 0.000453829694864223*std::exp(0.675039827823639*x_68) - 0.000559759448937096*std::exp(1.33207988739014*x_68) + 0.000391022020549015*std::exp(0.761759877204895*x_70) + 0.00290494909373443*std::exp(0.909759819507599*x_72) + 4.2500062532457e-5*std::exp(1.14007985591888*x_72) + 3.60739969570273e-5*std::exp(1.38855981826782*x_72) + 0.00589910280412274*std::exp(0.693999886512756*x_74) + 0.00247592239554114*std::exp(1.27359986305237*x_74) + 7.59708651975092e-5*std::exp(1.36911988258362*x_74) - 0.000267764989907402*std::exp(1.59695994853973*x_74) - 0.00540438627798554*std::exp(0.961679816246033*x_78) + 1.76128899750139e-5*std::exp(1.70751988887787*x_81) - 2.14636742971464e-6*std::exp(2.25271987915039*x_81) - 0.000199771997248395*std::exp(0.698479831218719*x_87) - 0.000664850209987843*std::exp(0.681999802589417*x_90) - 0.0132490320953074*std::sin(0.344079852104187*x_100 - 7.44199991226196) + 0.00392835102456739*std::sin(0.284079939126968*x_102 + 1.83591985702515) + 0.00409828411439934*std::sin(0.37391984462738*x_102 + 1.97303986549377) + 0.00150174522564224*std::sin(0.379999846220016*x_102 + 5.19024038314819) + 0.057051392771733*std::sin(0.260319977998734*x_105 + 1.8659999370575) + 0.0147931415056993*std::sin(0.538719832897186*x_106 - 4.02383995056152) + 0.00201705621948875*std::sin(0.448079854249954*x_108 - 7.36272001266479) - 0.000257170689583321*std::sin(0.701519846916199*x_109 + 2.04247975349426) + 0.0153482834949358*std::sin(0.624799847602844*x_112 - 1.0033597946167) + 0.00465591964130023*std::sin(0.218639984726906*x_115 - 7.58960008621216) + 0.00456356288750953*std::sin(0.371519833803177*x_117 - 4.40263986587524) - 0.021092067837281*std::sin(0.53279983997345*x_117 + 8.3557596206665) + 0.470614651137644*std::sin(0.115120060741901*x_120 + 1.71199989318848) + 0.00480181768594723*std::sin(0.246319964528084*x_120 - 7.54536008834839) - 0.0019047819684154*std::sin(0.427439838647842*x_120 + 8.41648006439209) + 0.00362822952132281*std::sin(0.469439834356308*x_120 - 4.14560031890869) + 0.00132000979743633*std::sin(0.337999850511551*x_16 - 4.26512002944946) + 0.0131390747962527*std::sin(0.348639845848083*x_16 + 8.34088039398193) + 0.0191451330079107*std::sin(0.139280036091805*x_21 + 4.914719581604) + 0.00348433577216193*std::sin(0.465199857950211*x_22 + 2.07911992073059) - 0.0025289259048432*std::sin(0.314799845218658*x_24 - 4.29608011245728) + 0.00125257771617921*std::sin(0.382959842681885*x_24 - 7.40751981735229) + 0.000259962618491835*std::sin(0.577679872512817*x_24 + 2.16567993164063) - 0.0258788739697487*std::sin(0.389759838581085*x_27 - 4.21016025543213) + 0.0017255383274358*std::sin(0.289839953184128*x_28 - 4.28480005264282) - 0.00780375932678081*std::sin(0.349679857492447*x_34 - 7.41232013702393) + 0.0034439496336734*std::sin(0.371519833803177*x_34 - 4.4049596786499) + 0.0757859091398429*std::sin(0.312079936265945*x_35 + 8.25303936004639) - 0.00099965921792724*std::sin(0.359519839286804*x_35 - 1.20879983901978) + 0.00194676270372502*std::sin(0.317679852247238*x_36 + 1.92295980453491) - 0.00476787806038029*std::sin(0.421999841928482*x_36 + 5.22056007385254) + 0.00151157395253218*std::sin(0.435679852962494*x_37 + 2.00375986099243) + 0.00270813800519133*std::sin(0.558719873428345*x_38 - 1.00023984909058) - 0.00183753180356661*std::sin(0.399599850177765*x_41 + 8.18295955657959) - 0.0249694567474945*std::sin(0.438479870557785*x_43 - 0.969679832458496) - 0.00752624866338418*std::sin(0.347359836101532*x_44 + 5.13503980636597) + 0.00559811017620776*std::sin(0.369119822978973*x_53 - 4.2370400428772) + 0.00156434733932664*std::sin(0.379039853811264*x_55 + 1.9871199131012) - 0.0116820198951526*std::sin(0.410559862852097*x_55 - 7.37951993942261) + 0.00841096200641049*std::sin(0.155360028147697*x_59 - 7.65199995040894) - 0.00227004080939403*std::sin(0.313919842243195*x_64 - 4.30408000946045) - 0.00217036531939775*std::sin(0.411039859056473*x_64 + 1.98383975028992) - 0.00989898455098096*std::sin(0.268879950046539*x_70 - 7.51600027084351) - 0.00249799159039018*std::sin(0.195999994874001*x_73 - 1.40735983848572) - 0.0390456283867387*std::sin(0.44159984588623*x_73 - 4.15431976318359) + 0.016177249688181*std::sin(0.474239856004715*x_75 - 1.12807989120483) - 0.013091000786047*std::sin(0.483839839696884*x_79 + 8.25088024139404) - 0.000341821823749445*std::sin(0.961759805679321*x_87 + 5.5685601234436) - 0.0147022459921018*std::sin(0.334479838609695*x_92 - 4.40520000457764) - 0.00283546468388547*std::sin(0.350399851799011*x_92 - 1.18759989738464) - 0.0361998885055375*std::sin(0.353919863700867*x_92 + 8.19999980926514) + 0.00405839405742028*std::sin(0.396079838275909*x_92 + 4.99959993362427) + 0.000715447201071886*std::sin(0.400879859924316*x_92 + 5.00224018096924) + 0.036555060354746*std::sin(0.146240040659904*x_95 - 4.48023986816406) + 0.0039749739077821*std::sin(0.391919851303101*x_96 - 7.39015960693359) + 0.00484941017364849*std::sin(0.268799960613251*x_97 + 5.07791996002197) - 0.0115576079589792*std::sin(0.279279947280884*x_97 + 5.09632015228271) - 0.000455113093866899*std::sin(0.316559940576553*x_97 + 8.07672023773193) + 0.00457857824323163*std::sin(0.420239865779877*x_98 + 2.02239966392517) - 0.450725864878092 - 4.30474332956207e-5*std::exp(-1.24647986888885*x_9) - 0.00136048959764226*std::exp(-1.23735988140106*x_9) - 3.64459797549721e-6*std::exp(-2.09863996505737*x_54));
}

inline float score_10(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.0026280967827716*x_1 - 0.000989436090813211*x_10 + 0.0288354621357518*x_100 - 0.00887867378767336*x_101 - 0.0351656260887906*x_102 - 0.00748486929083677*x_103 - 0.0083677619946567*x_104 + 0.0204998807301744*x_105 - 0.0016362672821674*x_106 + 0.0975152788519757*x_107 - 0.0150858954461065*x_108 - 0.00207796103112287*x_109 + 0.0157727286489039*x_11 + 0.016530372089607*x_110 - 0.0326559215701318*x_111 - 8.59197581049706e-5*x_112 - 0.0364810588456423*x_113 + 0.00332716979735643*x_114 - 0.0100653843539686*x_115 - 0.0168183808352419*x_116 + 0.0121843024144354*x_117 + 0.030029961746978*x_118 - 0.0166377654912933*x_119 + 0.058809875497295*x_12 + 0.0188371865488758*x_120 + 0.0174441696031938*x_13 + 0.0302453070166709*x_14 - 0.0210281746166938*x_15 + 0.00105184874000665*x_16 + 0.00362840850517631*x_17 + 0.0448808454209706*x_18 + 0.0663211496442209*x_19 - 0.0163857773728702*x_2 + 0.00779439747588762*x_20 - 0.028047608294712*x_21 - 0.00509749893767107*x_22 - 0.0141415062344435*x_23 + 0.0352867280245587*x_24 - 0.0163559017514155*x_25 - 0.00819113514926734*x_26 - 0.00500388635535892*x_27 + 0.0053320837578496*x_28 + 0.00199913580944756*x_29 - 0.00318956107448641*x_3 - 0.0145751223890762*x_30 - 0.0708580782998081*x_32 - 0.00640118560843393*x_33 - 0.0598963183922289*x_34 + 0.0285977619590192*x_35 + 0.0136404537420213*x_36 - 0.043554204733635*x_37 - 0.0238263011920991*x_38 - 0.0275213886365331*x_39 + 0.00299055039483359*x_4 + 0.054802997380426*x_40 - 0.0148612848304576*x_41 - 0.00547110766251888*x_42 + 0.0467847513451604*x_43 + 0.00990858478541745*x_44 + 0.00551706821549356*x_45 - 0.0088837899223286*x_46 + 0.0657351832041306*x_47 - 0.0421012627548019*x_48 + 0.0199923921029723*x_49 + 0.00311659424303502*x_5 + 0.0373804147997038*x_50 - 0.00449726637766108*x_51 - 0.0480003203336112*x_52 + 0.00245141123994278*x_53 - 0.0187309121120987*x_54 - 0.00834198850556528*x_55 - 0.0120132483778567*x_56 - 0.0456656230805596*x_57 - 0.0189508966501498*x_58 - 0.00872344590815394*x_59 + 0.00537375465156282*x_6 - 0.033120300328918*x_60 - 0.0134351894961123*x_61 - 0.0656474601950097*x_62 + 0.0378752720398129*x_63 - 0.00607996744702071*x_64 - 0.0154496890486607*x_65 - 0.00187578861457504*x_66 - 0.041151868733462*x_67 - 0.0137058680804065*x_68 - 0.00017649215774911*x_69 - 0.0283306429949019*x_7 - 0.00265400750560708*x_70 - 0.0153310093318773*x_71 - 0.0542162811604692*x_72 + 0.00137423410440939*x_73 + 0.000491112101229537*x_74 + 0.00417225951202918*x_75 + 0.00305428806793421*x_76 + 0.00751392252422549*x_77 - 0.0105483101082913*x_78 - 0.0476715709842012*x_79 + 0.0751268133506165*x_8 - 0.0187402713702332*x_80 + 0.00402544570501744*x_81 - 0.013513299787559*x_82 + 0.0231987554677063*x_83 - 0.000989201573602289*x_84 + 0.000612450025372934*x_85 + 0.00872516742736855*x_86 - 0.016134506645224*x_87 - 0.00543178290353769*x_88 + 0.0517470136052079*x_89 - 0.0189572187133885*x_9 + 0.0229514567117055*x_90 + 0.08530473999127*x_91 - 0.00247002905263058*x_92 + 0.0431930273187126*x_93 + 0.0228742659331063*x_94 - 0.00189980338713543*x_95 + 0.000214053538411579*x_96 + 0.105719235640505*x_97 - 0.00231654618099425*x_98 - 0.0157306131790261*x_99 + 4.50620555618762e-5*std::pow(-5.51063966751099*x_106 - 6.32424020767212, 2) - 2.40069084480307e-5*std::pow(-7.38335990905762*x_115 - 8.98408031463623, 2) - 1.51943509505155e-5*std::pow(-7.0025200843811*x_12 - 5.83999967575073, 2) - 9.20493364674231e-5*std::pow(-5.19456005096436*x_24 - 7.38416004180908, 2) - 0.000444609092725776*std::pow(-5.73055982589722*x_46 - 7.90679979324341, 2) + 5.05975028888408e-7*std::pow(-7.17063999176025*x_48 - 8.56703948974609, 2) + 7.95621151809796e-5*std::pow(-5.29519987106323*x_55 - 8.13951969146729, 2) + 1.79175994172232e-6*std::pow(-3.55464005470276*x_56 - 3.35920000076294, 2) - 8.87427140106788e-5*std::pow(-6.81983995437622*x_66 - 9.83775997161865, 2) + 1.20736956920738e-6*std::pow(-8.48000049591064*x_67 - 7.86736011505127, 2) + 7.33526683075037e-5*std::pow(-6.06615972518921*x_70 - 8.89816093444824, 2) + 3.73832739792406e-6*std::pow(-8.0*x_78 - 9.99958038330078, 2) + 0.000801680438386444*std::pow(-4.9223198890686*x_84 - 5.95056009292603, 2) - 5.75064773148124e-6*std::pow(-6.52711963653564*x_87 - 9.1879997253418, 2) - 1.3915097559217e-5*std::pow(-6.90120029449463*x_97 - 9.54792022705078, 2) + 0.0008079862831346*std::exp(0.647199809551239*x_1) - 0.00180206591847457*std::exp(1.04399979114532*x_1) - 4.25849212947099e-5*std::exp(1.09967982769012*x_1) + 7.09714744901414e-6*std::exp(1.19815981388092*x_1) - 1.67899815427143e-5*std::exp(1.27311992645264*x_1) - 2.67718542268777e-5*std::exp(1.29047989845276*x_1) - 8.41829315106389e-7*std::exp(1.31015980243683*x_1) + 2.59673798019678e-5*std::exp(1.54399979114532*x_100) - 0.000127413517946727*std::exp(1.70759987831116*x_100) - 0.000990341266211248*std::exp(0.54095983505249*x_104) - 0.00361135002966522*std::exp(0.627919852733612*x_104) - 0.00985693899255633*std::exp(0.683999836444855*x_104) - 0.00292166599634603*std::exp(0.887759864330292*x_104) - 0.00336554799018544*std::exp(0.580479860305786*x_106) + 0.000116145246593096*std::exp(0.845199882984161*x_106) + 0.000338811192783755*std::exp(1.07079982757568*x_106) + 2.58546638945907e-5*std::exp(1.07351982593536*x_106) + 0.000286211447601898*std::exp(1.21335983276367*x_106) - 0.0364768028555187*std::exp(0.737759828567505*x_109) - 0.00779392658168219*std::exp(0.857519865036011*x_109) + 0.000884142072564147*std::exp(0.90423983335495*x_109) + 0.000215612956543996*std::exp(1.03247976303101*x_109) - 2.97362427473124e-5*std::exp(1.1775997877121*x_109) + 0.00150318514535189*std::exp(0.931599855422974*x_110) + 0.000391667277195899*std::exp(1.26071989536285*x_110) + 3.50723452439121e-5*std::exp(1.28839981555939*x_110) - 0.000199884844337821*std::exp(1.36871981620789*x_110) + 0.000108650701582079*std::exp(0.541999876499176*x_112) - 0.0359080409984116*std::exp(0.607759833335876*x_114) + 0.000140717272613712*std::exp(0.76911985874176*x_114) + 0.00277066485776246*std::exp(1.25623989105225*x_23) - 2.05626905138012e-5*std::exp(1.3840799331665*x_23) + 0.0594128661674129*std::exp(0.684879839420319*x_26) + 0.000115950408410648*std::exp(0.75959986448288*x_26) - 0.000508901508924995*std::exp(0.774799823760986*x_26) - 0.000913436832523492*std::exp(0.96783983707428*x_26) - 5.22209585322699e-5*std::exp(1.06383979320526*x_26) - 3.84247578687418e-5*std::exp(1.18863987922668*x_26) + 8.26158160579009e-5*std::exp(1.24711990356445*x_26) - 0.000696770135014216*std::exp(0.523999869823456*x_31) - 0.000349258290351492*std::exp(0.626479864120483*x_31) - 0.295159041582982*std::exp(0.638719856739044*x_31) - 0.0225966065435001*std::exp(0.644239842891693*x_31) + 0.00424374517558521*std::exp(0.646319806575775*x_31) + 0.00119629336057901*std::exp(0.647919833660126*x_31) + 0.000509728599241246*std::exp(0.657999873161316*x_31) + 0.00230510088897215*std::exp(0.658879816532135*x_31) + 0.00265412369039226*std::exp(0.66103982925415*x_31) - 0.000220320756403868*std::exp(0.678959846496582*x_31) + 0.000837337067820122*std::exp(0.578719854354858*x_45) + 0.000182712136035085*std::exp(0.62255984544754*x_45) + 0.000135397294011881*std::exp(1.25087988376617*x_45) - 0.000319132210417483*std::exp(1.30271983146667*x_50) + 1.98720558945698e-6*std::exp(2.01959991455078*x_52) + 0.000132326497174293*std::exp(1.48807990550995*x_6) + 1.51085389351734e-6*std::exp(2.34247994422913*x_6) - 0.0026975174309969*std::exp(0.804639875888824*x_60) - 8.04926901600308e-5*std::exp(1.35599982738495*x_60) - 8.86283204882987e-5*std::exp(0.81471985578537*x_66) - 0.00401881931633805*std::exp(0.986879825592041*x_66) + 0.000474271177266823*std::exp(1.02383983135223*x_66) + 0.000259961660258853*std::exp(0.675039827823639*x_68) - 0.000631270970020487*std::exp(1.33207988739014*x_68) - 0.00175815395486497*std::exp(0.761759877204895*x_70) + 0.00392677395767874*std::exp(0.909759819507599*x_72) + 3.57273855193638e-5*std::exp(1.14007985591888*x_72) - 0.000515268416841916*std::exp(1.38855981826782*x_72) + 0.0037434129730222*std::exp(0.693999886512756*x_74) - 0.0245988300859691*std::exp(1.27359986305237*x_74) - 0.00108514139653176*std::exp(1.36911988258362*x_74) - 0.000361952156550465*std::exp(1.59695994853973*x_74) - 0.00730539593254918*std::exp(0.961679816246033*x_78) + 1.48061549266403e-5*std::exp(1.70751988887787*x_81) - 1.22947715160217e-6*std::exp(2.25271987915039*x_81) + 0.00285347367729031*std::exp(0.698479831218719*x_87) - 0.000355817791898857*std::exp(0.681999802589417*x_90) - 0.00840748165821071*std::sin(0.344079852104187*x_100 - 7.44199991226196) - 0.0176630612266893*std::sin(0.284079939126968*x_102 + 1.83591985702515) + 0.00219333976624058*std::sin(0.37391984462738*x_102 + 1.97303986549377) + 0.000860226174183164*std::sin(0.379999846220016*x_102 + 5.19024038314819) + 0.036203289029212*std::sin(0.260319977998734*x_105 + 1.8659999370575) - 0.146973093741438*std::sin(0.538719832897186*x_106 - 4.02383995056152) + 0.00107949802733381*std::sin(0.448079854249954*x_108 - 7.36272001266479) - 0.000137633869304662*std::sin(0.701519846916199*x_109 + 2.04247975349426) + 0.00973961048931227*std::sin(0.624799847602844*x_112 - 1.0033597946167) - 0.0665035356457392*std::sin(0.218639984726906*x_115 - 7.58960008621216) + 0.00514657640209192*std::sin(0.371519833803177*x_117 - 4.40263986587524) - 0.0285112681925021*std::sin(0.53279983997345*x_117 + 8.3557596206665) + 0.29863947940215*std::sin(0.115120060741901*x_120 + 1.71199989318848) - 0.029025550653908*std::sin(0.246319964528084*x_120 - 7.54536008834839) + 0.00856447917235709*std::sin(0.427439838647842*x_120 + 8.41648006439209) + 0.00194177364673305*std::sin(0.469439834356308*x_120 - 4.14560031890869) + 0.000706449308961246*std::sin(0.337999850511551*x_16 - 4.26512002944946) - 0.130539579504558*std::sin(0.348639845848083*x_16 + 8.34088039398193) - 0.0860823420302868*std::sin(0.139280036091805*x_21 + 4.914719581604) + 0.00186476388524797*std::sin(0.465199857950211*x_22 + 2.07911992073059) + 0.0152866001484866*std::sin(0.314799845218658*x_24 - 4.29608011245728) - 0.0178913841334512*std::sin(0.382959842681885*x_24 - 7.40751981735229) + 0.000218535788844736*std::sin(0.577679872512817*x_24 + 2.16567993164063) - 0.0349818482456855*std::sin(0.389759838581085*x_27 - 4.21016025543213) - 0.0246469888888953*std::sin(0.289839953184128*x_28 - 4.28480005264282) - 0.00417645414027324*std::sin(0.349679857492447*x_34 - 7.41232013702393) + 0.00289513259368863*std::sin(0.371519833803177*x_34 - 4.4049596786499) + 0.102443838004326*std::sin(0.312079936265945*x_35 + 8.25303936004639) + 0.00604264075904193*std::sin(0.359519839286804*x_35 - 1.20879983901978) + 0.0011151400411156*std::sin(0.317679852247238*x_36 + 1.92295980453491) - 0.00255169633400362*std::sin(0.421999841928482*x_36 + 5.22056007385254) + 0.000865856242443248*std::sin(0.435679852962494*x_37 + 2.00375986099243) + 0.00144935456240914*std::sin(0.558719873428345*x_38 - 1.00023984909058) + 0.0111073297511228*std::sin(0.399599850177765*x_41 + 8.18295955657959) - 0.0337525406916513*std::sin(0.438479870557785*x_43 - 0.969679832458496) - 0.00848775720244044*std::sin(0.347359836101532*x_44 + 5.13503980636597) + 0.00299602402433052*std::sin(0.369119822978973*x_53 - 4.2370400428772) - 0.0223445929178824*std::sin(0.379039853811264*x_55 + 1.9871199131012) - 0.00741309759783397*std::sin(0.410559862852097*x_55 - 7.37951993942261) + 0.00948549623355958*std::sin(0.155360028147697*x_59 - 7.65199995040894) - 0.0013003194465756*std::sin(0.313919842243195*x_64 - 4.30408000946045) + 0.0131192087321486*std::sin(0.411039859056473*x_64 + 1.98383975028992) - 0.011163619643369*std::sin(0.268879950046539*x_70 - 7.51600027084351) - 0.0014308936777369*std::sin(0.195999994874001*x_73 - 1.40735983848572) - 0.052780049413239*std::sin(0.44159984588623*x_73 - 4.15431976318359) + 0.0102656502796041*std::sin(0.474239856004715*x_75 - 1.12807989120483) - 0.0176958009617021*std::sin(0.483839839696884*x_79 + 8.25088024139404) - 0.000287350167230976*std::sin(0.961759805679321*x_87 + 5.5685601234436) - 0.00932965235678447*std::sin(0.334479838609695*x_92 - 4.40520000457764) + 0.0127491117785483*std::sin(0.350399851799011*x_92 - 1.18759989738464) + 0.359653803399651*std::sin(0.353919863700867*x_92 + 8.19999980926514) + 0.00217199121016015*std::sin(0.396079838275909*x_92 + 4.99959993362427) - 0.0102191988059831*std::sin(0.400879859924316*x_92 + 5.00224018096924) + 0.0231968642868762*std::sin(0.146240040659904*x_95 - 4.48023986816406) + 0.00448279281276361*std::sin(0.391919851303101*x_96 - 7.39015960693359) + 0.00546894182877889*std::sin(0.268799960613251*x_97 + 5.07791996002197) - 0.00618545723806243*std::sin(0.279279947280884*x_97 + 5.09632015228271) + 0.00275102243009974*std::sin(0.316559940576553*x_97 + 8.07672023773193) + 0.00245038593064837*std::sin(0.420239865779877*x_98 + 2.02239966392517) - 2.86566610900921 + 0.000614874554371264*std::exp(-1.24647986888885*x_9) - 0.000863330336592287*std::exp(-1.23735988140106*x_9) - 2.08769005512028e-6*std::exp(-2.09863996505737*x_54));
}

inline float score_11(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.00206544196975385*x_1 + 0.00597255671256304*x_10 - 0.00207470022638958*x_100 - 0.0199375840319618*x_101 + 0.0153230720054876*x_102 + 0.00470285719005054*x_103 + 0.00266282110573561*x_104 - 0.0071003288532859*x_105 - 0.00321971419368823*x_106 - 0.0209089587682003*x_107 + 0.00717374649617008*x_108 - 0.0016940541673725*x_109 + 0.00242141570236218*x_11 - 0.00471057490792079*x_110 + 0.00883472853266948*x_111 - 1.68511767202385e-5*x_112 + 0.0115346443554027*x_113 + 0.00130168909592055*x_114 + 0.00219149835465392*x_115 + 0.0117766562671956*x_116 - 0.00275599036677173*x_117 - 0.00881425575985086*x_118 - 0.00213075898857623*x_119 - 0.00409089957102204*x_12 + 0.00406852589818181*x_120 + 0.00283072341769837*x_13 - 0.000138969639419871*x_14 + 0.00356292568088139*x_15 - 0.00138263809398013*x_16 + 0.00491173251145286*x_17 - 0.0135174414065189*x_18 - 0.0260986821535903*x_19 + 0.00998456485692249*x_2 - 0.00101127045396534*x_20 + 0.00745562252820803*x_21 - 0.00380749368621466*x_22 + 0.00483383259807019*x_23 - 0.0101562510515099*x_24 - 0.00105370119168126*x_25 - 0.00283166819733518*x_26 - 0.00171430073319003*x_27 + 0.000683900670600788*x_28 + 0.00446245298392027*x_29 - 0.000800833016515636*x_3 - 0.00223825658869082*x_30 + 0.0390206030684041*x_32 - 0.00563429445412757*x_33 + 0.0176326448306107*x_34 - 0.0136127045776851*x_35 - 0.00792216518335164*x_36 + 0.00363530102566621*x_37 + 0.000848651294019997*x_38 + 0.00542964124863042*x_39 + 0.0113663149399636*x_4 - 0.0106036217012213*x_40 - 0.00335010597759875*x_41 - 0.0198151364017189*x_42 - 0.0164535614372005*x_43 + 0.00309619975080447*x_44 - 0.00380580198337246*x_45 - 0.000648097564779128*x_46 - 0.0258115316690745*x_47 + 0.0115037168901812*x_48 - 0.0108286467460221*x_49 - 0.000159611783176016*x_5 - 0.0118012603076896*x_50 + 0.00939341825902081*x_51 + 0.0135683487904654*x_52 - 0.00427893507942438*x_53 + 0.00445516740214343*x_54 + 0.00255801217351408*x_55 + 0.00791281390054296*x_56 + 0.00253334064540473*x_57 + 0.00441127915050156*x_58 + 0.0046600819815745*x_59 - 0.00091326609816278*x_6 + 0.00983131100612129*x_60 + 0.00812216126587185*x_61 + 0.00737723139107037*x_62 - 0.0216769242635273*x_63 + 0.0068994550555066*x_64 - 0.00635274545837907*x_65 + 0.00131206338636974*x_66 + 0.0157766424972212*x_67 - 1.12720583533968e-5*x_68 - 0.00230800991634346*x_69 + 0.0158500492420295*x_7 + 0.00630901446357978*x_70 + 0.00528901788235545*x_71 + 0.0182360895836129*x_72 + 0.000582962802791525*x_73 + 0.000122969544748254*x_74 + 0.00208757822615809*x_75 + 0.00017803300355453*x_76 - 0.00526785926528152*x_77 + 0.00351730662236353*x_78 + 0.0176685681460667*x_79 - 0.00954681193096946*x_8 + 0.00294425377064256*x_80 - 0.00645070194046804*x_81 + 0.00368714219305086*x_82 - 0.00588221558609351*x_83 + 0.00449396820197222*x_84 + 0.00452450305287465*x_85 + 0.00655628017676579*x_86 + 0.00215910109458451*x_87 - 8.74412380426043e-5*x_88 - 0.00848671281884686*x_89 + 0.00407447217734979*x_9 + 0.0019406539403147*x_90 - 0.0305702637418077*x_91 - 0.0013620183071322*x_92 + 0.0421852597909255*x_93 + 0.00361909090513975*x_94 + 0.00188550385357948*x_95 - 0.00309632723027516*x_96 - 0.0356750150907979*x_97 - 0.00224479960909239*x_98 + 0.000892195233143862*x_99 + 2.38766704764451e-5*std::pow(-5.51063966751099*x_106 - 6.32424020767212, 2) - 5.33354537793533e-5*std::pow(-7.38335990905762*x_115 - 8.98408031463623, 2) - 3.37568498077464e-5*std::pow(-7.0025200843811*x_12 - 5.83999967575073, 2) - 4.87734446865205e-5*std::pow(-5.19456005096436*x_24 - 7.38416004180908, 2) + 0.000142045842937788*std::pow(-5.73055982589722*x_46 - 7.90679979324341, 2) - 1.58739528828091e-7*std::pow(-7.17063999176025*x_48 - 8.56703948974609, 2) + 4.21569407542164e-5*std::pow(-5.29519987106323*x_55 - 8.13951969146729, 2) + 1.16450854235123e-6*std::pow(-3.55464005470276*x_56 - 3.35920000076294, 2) + 2.83519474128451e-5*std::pow(-6.81983995437622*x_66 - 9.83775997161865, 2) + 7.84698967968567e-7*std::pow(-8.48000049591064*x_67 - 7.86736011505127, 2) + 3.88667908711203e-5*std::pow(-6.06615972518921*x_70 - 8.89816093444824, 2) - 2.34038718091253e-6*std::pow(-8.0*x_78 - 9.99958038330078, 2) - 0.000256124707075152*std::pow(-4.9223198890686*x_84 - 5.95056009292603, 2) + 3.60020426252024e-6*std::pow(-6.52711963653564*x_87 - 9.1879997253418, 2) - 3.09147695677445e-5*std::pow(-6.90120029449463*x_97 - 9.54792022705078, 2) + 0.00179507974347325*std::exp(0.647199809551239*x_1) + 0.000575732652811623*std::exp(1.04399979114532*x_1) + 8.85379914035592e-6*std::exp(1.19815981388092*x_1) + 2.10221668887145e-5*std::exp(1.27311992645264*x_1) + 3.47380018646354e-5*std::exp(1.29047989845276*x_1) + 2.64107082768971e-7*std::exp(1.31015980243683*x_1) + 3.23947003524487e-5*std::exp(1.54399979114532*x_100) + 0.000165326278355781*std::exp(1.70759987831116*x_100) - 0.00123546575781769*std::exp(0.54095983505249*x_104) + 0.00452164898597699*std::exp(0.627919852733612*x_104) - 0.00522281731929699*std::exp(0.683999836444855*x_104) - 0.00649098079597185*std::exp(0.887759864330292*x_104) + 0.00421388858240628*std::exp(0.580479860305786*x_106) + 0.000144892957604427*std::exp(0.845199882984161*x_106) - 0.000439626771718534*std::exp(1.07079982757568*x_106) + 1.68035774568828e-5*std::exp(1.07351982593536*x_106) - 0.000179183236698282*std::exp(1.21335983276367*x_106) + 0.0116537837261089*std::exp(0.737759828567505*x_109) - 0.00412970545591071*std::exp(0.857519865036011*x_109) - 0.00110700432609128*std::exp(0.90423983335495*x_109) - 0.000134984913256779*std::exp(1.03247976303101*x_109) + 9.3291504388988e-6*std::exp(1.1775997877121*x_109) + 0.00333958293777319*std::exp(0.931599855422974*x_110) - 0.000508210544187421*std::exp(1.26071989536285*x_110) - 1.10032456960294e-5*std::exp(1.28839981555939*x_110) + 0.000250269039635591*std::exp(1.36871981620789*x_110) - 3.40869809600516e-5*std::exp(0.541999876499176*x_112) + 0.0114720729632265*std::exp(0.607759833335876*x_114) + 0.000175546932940442*std::exp(0.76911985874176*x_114) + 0.0014680699977972*std::exp(1.25623989105225*x_23) + 6.45113220462616e-6*std::exp(1.3840799331665*x_23) - 0.0189815071130481*std::exp(0.684879839420319*x_26) - 3.6377117738335e-5*std::exp(0.75959986448288*x_26) - 0.00202935617748865*std::exp(0.96783983707428*x_26) - 3.39396762281352e-5*std::exp(1.06383979320526*x_26) + 2.40558948356448e-5*std::exp(1.18863987922668*x_26) - 0.000107198715036573*std::exp(1.24711990356445*x_26) + 0.000436214306145448*std::exp(0.523999869823456*x_31) - 0.000435705017134139*std::exp(0.626479864120483*x_31) + 0.0942988246266557*std::exp(0.638719856739044*x_31) - 0.0119730829319179*std::exp(0.644239842891693*x_31) + 0.00942820584973512*std::exp(0.646319806575775*x_31) - 0.000159917136328884*std::exp(0.657999873161316*x_31) - 0.00288613870479949*std::exp(0.658879816532135*x_31) - 0.00344387627859022*std::exp(0.66103982925415*x_31) - 0.000143191839997811*std::exp(0.678959846496582*x_31) - 0.000524216509425402*std::exp(0.578719854354858*x_45) - 5.7322272304826e-5*std::exp(0.62255984544754*x_45) - 0.000175685681387331*std::exp(1.25087988376617*x_45) - 6.23445942871861e-7*std::exp(2.01959991455078*x_52) + 0.000165079313251525*std::exp(1.48807990550995*x_6) + 9.81940841670091e-7*std::exp(2.34247994422913*x_6) + 0.00337747015834216*std::exp(0.804639875888824*x_60) - 5.23141650315529e-5*std::exp(1.35599982738495*x_60) + 2.7805360011631e-5*std::exp(0.81471985578537*x_66) - 0.00212941960423478*std::exp(0.986879825592041*x_66) - 8.15577629463604e-5*std::exp(0.675039827823639*x_68) + 0.00039520842576244*std::exp(1.33207988739014*x_68) + 0.0022813046434826*std::exp(0.761759877204895*x_70) + 0.00208064826723759*std::exp(0.909759819507599*x_72) + 2.32201003406642e-5*std::exp(1.14007985591888*x_72) + 0.000645150122635771*std::exp(1.38855981826782*x_72) + 0.00831663227407505*std::exp(0.693999886512756*x_74) + 0.00785895208175607*std::exp(1.27359986305237*x_74) + 0.00135866876790239*std::exp(1.36911988258362*x_74) - 0.000191784690299519*std::exp(1.59695994853973*x_74) - 0.00387085163351959*std::exp(0.961679816246033*x_78) + 9.62288166509335e-6*std::exp(1.70751988887787*x_81) + 3.85723825499845e-7*std::exp(2.25271987915039*x_81) - 0.0035727376890763*std::exp(0.698479831218719*x_87) - 0.000443888094853525*std::exp(0.681999802589417*x_90) - 0.0186786587016389*std::sin(0.344079852104187*x_100 - 7.44199991226196) + 0.022918825443622*std::sin(0.284079939126968*x_102 + 1.83591985702515) + 0.00273622464185196*std::sin(0.37391984462738*x_102 + 1.97303986549377) - 0.000269878728749563*std::sin(0.379999846220016*x_102 + 5.19024038314819) + 0.0804317995737805*std::sin(0.260319977998734*x_105 + 1.8659999370575) + 0.0469556680941602*std::sin(0.538719832897186*x_106 - 4.02383995056152) + 0.00134669017025307*std::sin(0.448079854249954*x_108 - 7.36272001266479) - 0.000171700340522409*std::sin(0.701519846916199*x_109 + 2.04247975349426) + 0.0216382107761248*std::sin(0.624799847602844*x_112 - 1.0033597946167) + 0.0832668232229809*std::sin(0.218639984726906*x_115 - 7.58960008621216) - 0.00322202422498671*std::sin(0.371519833803177*x_117 - 4.40263986587524) - 0.0151070373290708*std::sin(0.53279983997345*x_117 + 8.3557596206665) + 0.663478689262468*std::sin(0.115120060741901*x_120 + 1.71199989318848) - 0.0111128983049774*std::sin(0.427439838647842*x_120 + 8.41648006439209) + 0.00242239209030369*std::sin(0.469439834356308*x_120 - 4.14560031890869) + 0.000881306233147933*std::sin(0.337999850511551*x_16 - 4.26512002944946) + 0.0417054102375412*std::sin(0.348639845848083*x_16 + 8.34088039398193) + 0.111696729431544*std::sin(0.139280036091805*x_21 + 4.914719581604) + 0.00232632124424421*std::sin(0.465199857950211*x_22 + 2.07911992073059) + 0.0224011957468005*std::sin(0.382959842681885*x_24 - 7.40751981735229) + 0.00014203174599078*std::sin(0.577679872512817*x_24 + 2.16567993164063) - 0.0185355517586705*std::sin(0.389759838581085*x_27 - 4.21016025543213) + 0.0308596595182967*std::sin(0.289839953184128*x_28 - 4.28480005264282) - 0.00521018991679871*std::sin(0.349679857492447*x_34 - 7.41232013702393) + 0.00188161737411606*std::sin(0.371519833803177*x_34 - 4.4049596786499) + 0.0542810959658264*std::sin(0.312079936265945*x_35 + 8.25303936004639) - 0.000349852847665076*std::sin(0.317679852247238*x_36 + 1.92295980453491) - 0.00318327989812145*std::sin(0.421999841928482*x_36 + 5.22056007385254) - 0.000271645049875804*std::sin(0.435679852962494*x_37 + 2.00375986099243) + 0.0018080918102542*std::sin(0.558719873428345*x_38 - 1.00023984909058) - 0.0178841884105965*std::sin(0.438479870557785*x_43 - 0.969679832458496) + 0.005313777001533*std::sin(0.347359836101532*x_44 + 5.13503980636597) + 0.00373758543438293*std::sin(0.369119822978973*x_53 - 4.2370400428772) + 0.0279769075496062*std::sin(0.379039853811264*x_55 + 1.9871199131012) - 0.0164694644105056*std::sin(0.410559862852097*x_55 - 7.37951993942261) - 0.00593841347388265*std::sin(0.155360028147697*x_59 - 7.65199995040894) + 0.000407949176323758*std::sin(0.313919842243195*x_64 - 4.30408000946045) + 0.00698900591757502*std::sin(0.268879950046539*x_70 - 7.51600027084351) + 0.000448914225482746*std::sin(0.195999994874001*x_73 - 1.40735983848572) - 0.0279661420646903*std::sin(0.44159984588623*x_73 - 4.15431976318359) + 0.0228068981555076*std::sin(0.474239856004715*x_75 - 1.12807989120483) - 0.00937633232907341*std::sin(0.483839839696884*x_79 + 8.25088024139404) - 0.000186755891006735*std::sin(0.961759805679321*x_87 + 5.5685601234436) - 0.020727418656588*std::sin(0.334479838609695*x_92 - 4.40520000457764) - 0.0165426968555292*std::sin(0.350399851799011*x_92 - 1.18759989738464) - 0.114903920107622*std::sin(0.353919863700867*x_92 + 8.19999980926514) + 0.00270959199418181*std::sin(0.396079838275909*x_92 + 4.99959993362427) + 0.0127951125033577*std::sin(0.400879859924316*x_92 + 5.00224018096924) + 0.0515358021078346*std::sin(0.146240040659904*x_95 - 4.48023986816406) - 0.00280646121030085*std::sin(0.391919851303101*x_96 - 7.39015960693359) - 0.0034238417310207*std::sin(0.268799960613251*x_97 + 5.07791996002197) - 0.00771645176748762*std::sin(0.279279947280884*x_97 + 5.09632015228271) + 0.00305689363257184*std::sin(0.420239865779877*x_98 + 2.02239966392517) + 1.88018083572388*std::sin(-8.22945346354484e-5*x_10 + 9.32021131955182e-5*x_100 + 0.00181089123502635*x_101 + 0.000338109381496759*x_102 - 0.000373176695356204*x_103 - 0.00034247564252936*x_104 - 0.00163361709236451*x_105 + 0.000348319351991196*x_106 + 0.000134683157931188*x_107 - 0.000421582417031299*x_108 + 6.52088720307795e-5*x_109 + 0.00138634870700521*x_11 + 4.98836783118869e-5*x_110 + 0.000208823477403799*x_111 - 0.000187283737088909*x_112 - 0.000345677860683528*x_113 + 0.00248296422763297*x_114 + 0.000314264203518744*x_115 + 0.00064715399936061*x_116 - 0.000109472079355461*x_117 - 0.000256275997704159*x_118 - 0.000152020629596399*x_119 - 0.00478648416480789*x_12 + 0.000488265892163691*x_13 + 0.00156511561571692*x_14 + 1.9068027693539e-5*x_15 + 0.000836942931346831*x_16 + 2.407232560167e-5*x_17 + 7.10790934468682e-5*x_18 - 0.000599397309776713*x_19 + 0.00135643028367311*x_2 + 0.000790519160575603*x_20 + 0.00061309709861378*x_21 + 0.00148087469788185*x_22 - 0.000225186475374078*x_23 - 0.00254344086949837*x_25 - 0.000119192346194375*x_27 - 0.000218300106455267*x_28 + 0.000768953071278465*x_29 + 0.000167822387087803*x_3 - 0.000309748410678593*x_30 + 0.010698716963125*x_32 + 0.00795584800177066*x_33 - 0.00110657515176652*x_34 + 0.000300871185957926*x_36 - 0.00333983695589543*x_37 + 0.00103283543336873*x_38 + 0.000170048361484025*x_39 - 0.000495666085274276*x_4 + 0.00193043886014239*x_40 + 0.00785166381296933*x_42 - 0.000540469074789588*x_43 + 0.00581638746482395*x_44 - 0.000223760665948318*x_45 + 0.00148175012571974*x_46 + 0.000701636291882455*x_47 - 0.000599241770830481*x_48 + 0.000646302740096908*x_49 + 0.000181533914844836*x_5 - 2.52690372588244e-5*x_51 + 0.00014724467088488*x_52 - 0.00035091665654794*x_53 + 0.000375620038957715*x_54 - 0.000938210020048682*x_55 + 0.000988238787319848*x_56 + 0.00249578020847345*x_57 - 8.77409726872238e-5*x_58 + 0.000548308437902307*x_59 + 0.000321814372935354*x_6 + 0.00148000368282759*x_60 + 0.00290495127932164*x_61 + 0.00232565403287416*x_62 + 0.00125677914511541*x_63 + 0.00038812541394543*x_65 + 0.000764104753917119*x_67 + 0.00286222615385163*x_68 - 0.000666231291296232*x_69 - 0.000185887160248891*x_7 - 0.000484628068428634*x_70 - 0.000852482222004925*x_71 - 0.00116149632193938*x_72 - 0.000117236200627117*x_73 - 0.0020803411574594*x_74 - 3.27036612833319e-5*x_75 + 0.000537844736030789*x_76 - 0.000181586228827316*x_77 + 0.000407143329856604*x_78 - 0.000701761971962633*x_79 + 0.000169376053048269*x_8 + 0.000130383424756226*x_80 + 0.000707552284053146*x_81 - 4.49051153180585e-5*x_82 + 0.000500549483228147*x_83 + 0.000572193156600045*x_84 - 0.000282573175819428*x_85 - 0.000209972080519033*x_86 - 0.000365265090769608*x_87 + 0.000599462068552443*x_88 + 0.00066793572745667*x_89 + 0.000567933251095571*x_9 + 5.60996970950091e-5*x_90 + 0.00743231905348156*x_91 - 0.000255313333291045*x_92 + 0.00326529719786719*x_93 + 0.00101236941650966*x_94 - 9.65416344750287e-5*x_95 + 0.000466483911362026*x_96 - 0.00109605195049107*x_98 - 0.00105402566209568*x_99 + 7.71349853680944e-5*std::exp(1.09967982769012*x_1) + 0.000921784266620377*std::exp(0.774799823760986*x_26) - 0.00216687193632722*std::exp(0.647919833660126*x_31) + 0.000578051047944478*std::exp(1.30271983146667*x_50) - 0.000859057600830409*std::exp(1.02383983135223*x_66) + 0.0525746052105114*std::sin(0.246319964528084*x_120 - 7.54536008834839) - 0.0276889481753697*std::sin(0.314799845218658*x_24 - 4.29608011245728) - 0.0109451653863042*std::sin(0.359519839286804*x_35 - 1.20879983901978) - 0.0201189456686371*std::sin(0.399599850177765*x_41 + 8.18295955657959) - 0.0237631054098242*std::sin(0.411039859056473*x_64 + 1.98383975028992) - 0.00498298619420962*std::sin(0.316559940576553*x_97 + 8.07672023773193) - 4.80378093088582) - 1.95991300255772 - 0.000769863591852826*std::exp(-1.24647986888885*x_9) - 0.00191803602547618*std::exp(-1.23735988140106*x_9) + 6.54970930911245e-7*std::exp(-2.09863996505737*x_54));
}

int predict(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120)
{
    float s0 = score_0(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s1 = score_1(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s2 = score_2(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s3 = score_3(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s4 = score_4(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s5 = score_5(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s6 = score_6(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s7 = score_7(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s8 = score_8(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s9 = score_9(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s10 = score_10(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s11 = score_11(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);

    float max_score = s0;
    int max_index = 0;

    if(s1 > max_score) {
        max_score = s1;
        max_index = 1;
    }

    if(s2 > max_score) {
        max_score = s2;
        max_index = 2;
    }

    if(s3 > max_score) {
        max_score = s3;
        max_index = 3;
    }

    if(s4 > max_score) {
        max_score = s4;
        max_index = 4;
    }

    if(s5 > max_score) {
        max_score = s5;
        max_index = 5;
    }

    if(s6 > max_score) {
        max_score = s6;
        max_index = 6;
    }

    if(s7 > max_score) {
        max_score = s7;
        max_index = 7;
    }

    if(s8 > max_score) {
        max_score = s8;
        max_index = 8;
    }

    if(s9 > max_score) {
        max_score = s9;
        max_index = 9;
    }

    if(s10 > max_score) {
        max_score = s10;
        max_index = 10;
    }

    if(s11 > max_score) {
        max_score = s11;
        max_index = 11;
    }

    return max_index;
}

#endif
