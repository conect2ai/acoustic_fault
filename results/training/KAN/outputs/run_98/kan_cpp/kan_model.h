
#ifndef KAN_MODEL_H
#define KAN_MODEL_H

#include <cmath>


inline float score_0(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-7.53118172716769e-5*x_1 + 3.61759298057629e-5*x_10 - 3.25596786503848e-6*x_100 + 0.000121145444894443*x_101 + 5.73067709414896e-5*x_102 - 3.0804668269538e-5*x_103 + 9.19738906693934e-5*x_104 + 2.60561789826833e-5*x_105 + 3.88307577097376e-7*x_106 - 9.14613825434515e-6*x_107 + 2.15699167363416e-5*x_108 + 1.91522151934956e-5*x_109 + 1.10353201885975e-5*x_11 + 4.03921454616849e-5*x_110 - 2.79775566677646e-5*x_111 - 1.76719299790115e-5*x_112 - 9.67610225534e-7*x_113 + 5.14578342709498e-6*x_114 + 1.1055543343596e-5*x_115 + 8.11626999075597e-5*x_116 + 3.01814297660758e-5*x_117 + 4.22925474733549e-5*x_118 - 6.13849680758262e-5*x_119 - 1.05660280449013e-5*x_12 + 1.28921989457894e-7*x_120 - 1.136842309049e-5*x_13 + 2.30381340323781e-5*x_14 + 9.72526642937257e-6*x_15 + 1.25824849867892e-5*x_16 + 2.47890319841201e-5*x_17 + 5.61175405886429e-6*x_18 - 2.85761841038214e-6*x_19 + 4.58407126198489e-5*x_2 + 5.64749888930147e-7*x_20 + 1.42231214840692e-5*x_21 + 2.93716077295425e-6*x_22 + 1.96272705376569e-7*x_23 + 2.44951437043158e-5*x_24 + 1.82367018442753e-5*x_25 - 7.01395684882941e-6*x_26 - 3.15406205066171e-6*x_27 + 1.6025165983746e-5*x_28 - 1.45866996652691e-6*x_29 - 2.62921910525695e-6*x_3 + 1.82186311393582e-5*x_30 + 4.25335640883695e-6*x_31 + 3.16721061272143e-5*x_32 - 1.01979469215027e-5*x_33 + 1.87778422674265e-5*x_34 + 1.17692777826278e-5*x_35 + 1.52022068655025e-6*x_36 + 4.31337070579223e-5*x_37 - 1.0289107851759e-5*x_38 - 2.96770020673857e-5*x_39 - 1.01450269194288e-5*x_4 - 4.42234261985172e-5*x_40 + 1.13864458144498e-5*x_41 + 5.78417831577745e-5*x_42 - 3.12160196267975e-5*x_43 + 3.60452322473932e-5*x_44 + 4.37958040778756e-5*x_45 + 1.52883840211391e-5*x_46 + 2.68039621364759e-5*x_47 + 2.78284738950792e-5*x_48 + 8.76986252688039e-6*x_49 - 1.76687786750809e-5*x_5 + 2.01612765528594e-5*x_50 - 3.09233413176431e-5*x_51 - 9.72959430437866e-6*x_52 + 1.4137769081072e-5*x_53 + 2.8261691121551e-5*x_54 + 5.26003210427473e-6*x_55 - 1.22472328632215e-6*x_56 + 1.52487882678627e-7*x_57 + 3.96154576504769e-5*x_58 - 1.17996647156439e-5*x_59 + 1.47972470019209e-7*x_6 + 1.24044718364772e-5*x_60 + 2.57856106045494e-5*x_61 - 1.6328364549503e-5*x_62 - 8.86387864731479e-6*x_63 + 8.04742599532637e-6*x_64 - 9.81057522681276e-6*x_65 + 3.91628646214464e-5*x_66 + 1.00036056192327e-5*x_67 + 4.0946698174402e-5*x_68 - 1.58656275340061e-5*x_69 - 3.6255939728361e-6*x_7 - 5.86904892386037e-6*x_70 + 4.99266726281746e-6*x_71 - 1.13007931789119e-5*x_72 + 2.51190395017236e-5*x_73 + 2.48457193594015e-5*x_74 - 1.25070640304003e-5*x_75 - 7.08664041949285e-6*x_76 + 1.48399546096448e-5*x_77 - 5.81472178350634e-5*x_78 + 2.48201486835715e-5*x_79 + 4.56972298199772e-5*x_8 + 2.59537629858103e-5*x_80 + 6.80799521251672e-6*x_81 - 3.40991948931014e-6*x_82 - 5.86603482446736e-5*x_83 + 3.57327071992584e-5*x_84 - 1.09695643995988e-5*x_85 - 1.45927001290754e-5*x_86 - 3.31443443653892e-5*x_87 + 1.66457519129378e-5*x_88 - 1.25890750619135e-5*x_89 - 0.000208865858123813*x_9 + 2.13329372757886e-5*x_90 - 4.0774808112604e-5*x_91 + 3.00242747724465e-6*x_92 - 5.48130876241091e-5*x_93 + 1.99371771972533e-5*x_94 - 4.10427251947462e-6*x_95 + 1.10097877556821e-5*x_96 + 4.05408225723136e-5*x_97 + 4.85208921886088e-6*x_98 + 1.64650711977876e-5*x_99 + 1.18599761110785e-5*std::sin(1.89367985725403*x_110 + 6.00559997558594) - 2.89341711515736e-6*std::sin(1.79559993743896*x_26 - 1.20503985881805) + 2.00791228642949e-5*std::sin(0.96343982219696*x_29 - 5.38064002990723) + 1.47839246270051e-5*std::sin(1.55023980140686*x_29 + 3.79512000083923) - 0.000484149787870884*std::sin(0.656719863414764*x_31 - 1.67615985870361) + 1.10873208159093e-5*std::sin(2.1275999546051*x_36 - 1.59095978736877) - 1.3688177362398e-5*std::sin(1.72559988498688*x_37 + 3.60359978675842) + 3.90649372507761e-5*std::sin(2.70616006851196*x_43 - 0.786399841308594) - 3.87762112801072e-6*std::sin(2.33879995346069*x_44 - 8.58600044250488) - 7.16775291270315e-6*std::sin(2.27631998062134*x_49 - 0.396399855613708) + 5.36354485194612e-6*std::sin(1.97167980670929*x_53 - 2.37071990966797) - 4.0897648773118e-6*std::sin(2.68039989471436*x_53 - 2.58656001091003) + 5.02658421180396e-6*std::sin(1.70199990272522*x_57 - 7.82288026809692) + 2.84226400063321e-6*std::sin(1.83415985107422*x_57 - 5.21352005004883) - 3.04945211679366e-5*std::sin(0.849999845027924*x_71 - 4.59991979598999) - 3.3131878511138e-6*std::sin(2.38175988197327*x_75 - 1.79751992225647) + 2.41812127726137e-6*std::sin(2.45063996315002*x_77 - 0.411519855260849) + 2.99905237137257e-5*std::sin(1.21999990940094*x_79 - 2.38879990577698) + 1.03122731570633e-5*std::sin(1.86287987232208*x_80 + 6.00504016876221) - 5.34018450568701e-6*std::sin(1.36455988883972*x_86 + 4.39143991470337) + 8.64190900019578e-6*std::sin(1.6237598657608*x_93 + 7.59344005584717) + 0.0372111713081053 - 3.08539749282986e-7*std::exp(-1.91511988639832*x_111));
}

inline float score_1(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.000108872503036128*x_1 + 3.10216559586261e-5*x_10 - 1.81656779787061e-5*x_100 + 3.93631684166677e-6*x_101 + 1.63291848424836e-5*x_102 - 2.00094921073356e-5*x_103 + 9.26352574949614e-5*x_104 + 1.20289809573035e-6*x_105 - 2.02464184401664e-5*x_106 - 2.21501270255174e-6*x_107 + 3.61228632793037e-5*x_108 + 1.76801453162044e-5*x_109 + 2.8543527623063e-5*x_11 + 1.53806635644725e-6*x_110 - 2.47718084930648e-6*x_111 + 1.48313008045953e-5*x_112 + 1.86220978158342e-5*x_113 - 3.85590075974584e-6*x_114 + 5.26100412313278e-5*x_115 + 8.98129680583016e-5*x_116 + 4.62156995558066e-5*x_117 + 3.56380797519132e-5*x_118 - 6.87093982875589e-5*x_119 - 1.4760422280476e-5*x_12 + 4.13740659173837e-5*x_120 - 6.27394997181855e-6*x_13 + 3.01731313465814e-5*x_14 + 4.1448613558167e-5*x_15 + 6.95436849114019e-5*x_16 + 2.97659772721039e-5*x_17 + 2.1862116263848e-5*x_18 - 2.20488650266136e-5*x_19 + 7.50234088744429e-5*x_2 + 7.95462931603224e-6*x_20 + 2.40752882003166e-5*x_21 + 5.48344329209614e-6*x_22 + 1.20053028846401e-5*x_23 + 1.72638341916044e-5*x_24 + 3.2999578730991e-6*x_25 - 1.33028529094409e-5*x_26 - 1.43100800574434e-5*x_27 - 5.16633472209294e-6*x_28 - 1.13860988292782e-5*x_29 + 2.010511546448e-5*x_3 + 3.63115781405713e-6*x_30 - 1.60123271999891e-5*x_31 - 1.78130546304897e-5*x_32 + 2.32635153317657e-5*x_33 + 2.06806043274412e-5*x_34 + 1.01926920978362e-5*x_35 - 5.59400538451601e-6*x_36 + 3.05595581243202e-5*x_37 - 2.62451850021493e-5*x_38 - 1.5727219615705e-5*x_39 + 5.83940300594988e-6*x_4 - 5.97889824276856e-5*x_40 - 1.9710840358383e-5*x_41 + 5.76553026635404e-5*x_42 - 6.93163571582165e-6*x_43 + 4.49882844483133e-5*x_44 + 5.03664026924248e-5*x_45 + 8.4785895506509e-6*x_46 + 1.15979002816399e-5*x_47 + 5.80009365936017e-5*x_48 + 6.53109307618554e-5*x_49 + 7.10476617141951e-6*x_5 + 7.67233154953716e-5*x_50 - 6.56246760991907e-6*x_51 - 2.03597863822183e-5*x_52 + 9.18781620895741e-6*x_53 - 2.41780192138689e-5*x_54 + 3.17983301129758e-5*x_55 - 3.73685759610923e-6*x_56 - 2.17789395173639e-7*x_57 + 1.58614497383817e-5*x_58 - 1.35649786114647e-5*x_59 + 1.05187601769795e-5*x_6 + 5.95849187677062e-6*x_60 + 2.3230021121979e-5*x_61 + 9.35388818492509e-6*x_62 + 4.29540489147144e-5*x_63 - 1.15849735658709e-5*x_64 - 5.33402485568194e-7*x_65 + 5.32182325246852e-5*x_66 + 4.04873372400247e-5*x_67 + 4.54003592829716e-5*x_68 - 1.2948525110454e-5*x_69 + 2.39288029339273e-5*x_7 + 5.00847477249452e-5*x_70 + 3.38962245587522e-6*x_71 + 4.13237925736283e-5*x_72 + 1.55517504244099e-5*x_73 + 3.7835883283479e-5*x_74 - 7.54280799865675e-6*x_75 - 5.18839221138076e-6*x_76 + 2.22870824320884e-5*x_77 - 7.32107242339596e-5*x_78 - 1.18899199120197e-5*x_79 + 1.28453599945652e-5*x_8 + 1.64237949437202e-5*x_80 + 3.13720484577473e-5*x_81 + 1.45418729146685e-6*x_82 - 3.46159271904746e-5*x_83 + 4.13339983549273e-5*x_84 + 2.37274475833198e-5*x_85 - 3.80567681501162e-5*x_86 - 9.56065718748989e-6*x_87 + 1.72586776539531e-5*x_88 + 1.76171472710883e-5*x_89 - 0.00011174625683973*x_9 + 3.66576409152441e-5*x_90 - 3.63575466092113e-5*x_91 - 1.20359283456713e-5*x_92 + 4.60203116729478e-5*x_93 + 4.20266573653318e-5*x_94 + 8.13481996937602e-7*x_95 + 1.44994107488594e-5*x_96 - 8.86895205252448e-8*x_97 + 1.75309224739466e-5*x_98 + 1.73866247355982e-5*x_99 + 1.74046655601339e-5*std::sin(1.89367985725403*x_110 + 6.00559997558594) - 2.49058160820361e-6*std::sin(1.79559993743896*x_26 - 1.20503985881805) + 1.63041424917443e-5*std::sin(0.96343982219696*x_29 - 5.38064002990723) + 5.19106745258863e-6*std::sin(1.55023980140686*x_29 + 3.79512000083923) - 0.000169999121978977*std::sin(0.656719863414764*x_31 - 1.67615985870361) - 7.63739496784926e-6*std::sin(2.1275999546051*x_36 - 1.59095978736877) - 7.40806935408781e-6*std::sin(1.72559988498688*x_37 + 3.60359978675842) - 1.74141390042669e-6*std::sin(2.70616006851196*x_43 - 0.786399841308594) + 5.09867063227237e-7*std::sin(2.33879995346069*x_44 - 8.58600044250488) + 9.43898536577888e-6*std::sin(2.27631998062134*x_49 - 0.396399855613708) - 7.05250660616312e-7*std::sin(1.97167980670929*x_53 - 2.37071990966797) + 5.38568102117574e-6*std::sin(2.68039989471436*x_53 - 2.58656001091003) + 4.3267588777378e-6*std::sin(1.70199990272522*x_57 - 7.82288026809692) - 3.21414910279202e-6*std::sin(1.83415985107422*x_57 - 5.21352005004883) - 8.93446755075258e-5*std::sin(0.849999845027924*x_71 - 4.59991979598999) + 3.74668917337248e-6*std::sin(2.38175988197327*x_75 - 1.79751992225647) - 3.18434684157393e-6*std::sin(2.45063996315002*x_77 - 0.411519855260849) + 2.43521480163914e-5*std::sin(1.21999990940094*x_79 - 2.38879990577698) - 8.57001033978224e-6*std::sin(1.86287987232208*x_80 + 6.00504016876221) + 7.03231877739622e-6*std::sin(1.36455988883972*x_86 + 4.39143991470337) - 9.77262634758818e-6*std::sin(1.6237598657608*x_93 + 7.59344005584717) + 0.0872332480003292 + 3.48909446171309e-7*std::exp(-1.91511988639832*x_111));
}

inline float score_2(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.000101422977023414*x_1 - 2.9842758039111e-5*x_10 + 4.85925542936379e-6*x_100 - 2.68806301808055e-5*x_101 - 4.87697113462284e-5*x_102 + 4.62382981028149e-5*x_103 - 7.70557428589326e-5*x_104 + 5.49435618455637e-5*x_105 + 2.08495067593929e-5*x_106 + 6.81531935794631e-6*x_107 - 7.93013038741443e-6*x_108 - 1.51433287338365e-5*x_109 - 7.00984675763983e-6*x_11 + 1.47634417405236e-5*x_110 + 3.91955094652105e-5*x_111 + 1.95601703072415e-5*x_112 - 4.41752043348676e-5*x_113 - 1.48026241181193e-5*x_114 - 5.37665537656013e-5*x_115 + 9.47559455535182e-6*x_116 - 1.53632034187406e-5*x_117 - 2.95975919340992e-5*x_118 + 5.124339612789e-5*x_119 + 1.61180891612363e-5*x_12 - 2.81717479387622e-5*x_120 + 1.06483276148711e-6*x_13 - 2.30080944986857e-5*x_14 - 2.89668687619566e-5*x_15 + 1.58085113030403e-5*x_16 - 1.43327707205278e-6*x_17 + 6.32230700966421e-6*x_18 + 3.437396038632e-5*x_19 - 3.60450442416894e-5*x_2 - 8.42423189597704e-6*x_20 - 1.17130032255639e-5*x_21 + 1.02790965403119e-5*x_22 + 1.87599942550853e-5*x_23 + 3.36086944457413e-7*x_24 - 1.54937498251021e-5*x_25 + 1.64203508604109e-5*x_26 + 3.45594156984458e-5*x_27 + 1.5954279829781e-5*x_28 + 2.69844635346221e-5*x_29 - 2.40692754601424e-6*x_3 - 1.35147346735831e-5*x_30 - 2.27500854707574e-5*x_31 - 1.77229486094027e-5*x_32 - 4.08533224201842e-5*x_33 + 1.35945687846747e-5*x_34 - 1.23093248573684e-5*x_35 - 7.93858896601295e-6*x_36 - 4.2386275351176e-5*x_37 - 2.23116098931648e-5*x_38 + 8.86073319221633e-6*x_39 + 9.64084772009838e-6*x_4 + 5.86431378333971e-5*x_40 + 6.19988455813041e-5*x_41 - 7.08719554251248e-5*x_42 + 8.32299729105829e-6*x_43 - 1.7111012229353e-5*x_44 - 5.0256889149851e-6*x_45 - 3.59094314442627e-5*x_46 - 3.25609613494317e-6*x_47 + 2.36242082157928e-5*x_48 - 3.91934674181935e-5*x_49 + 1.42563017676188e-5*x_5 - 8.04909362021035e-5*x_50 + 1.92688058318095e-5*x_51 + 5.36725518223482e-5*x_52 - 4.23531220780457e-6*x_53 + 6.20504693735841e-5*x_54 - 2.04890055097557e-5*x_55 - 2.17178472013363e-5*x_56 - 6.5397659605279e-6*x_57 + 2.04981228467993e-6*x_58 - 1.19229242512442e-5*x_59 - 1.05706915191804e-5*x_6 + 4.32982284456753e-5*x_60 - 2.49656163151111e-6*x_61 + 9.46050968802274e-6*x_62 - 2.64768911158563e-5*x_63 + 1.47060597369512e-5*x_64 + 3.99797293297268e-5*x_65 - 1.80435881410101e-5*x_66 - 1.47807723933996e-5*x_67 + 1.24499477334694e-5*x_68 + 1.79173907041374e-6*x_69 - 8.05949460076901e-6*x_7 - 0.000101718107710102*x_70 - 3.03684396613409e-6*x_71 + 2.92961980893441e-6*x_72 + 6.89838218927156e-6*x_73 - 2.77952676080409e-5*x_74 + 3.63673332441593e-5*x_75 + 2.49400667526132e-5*x_76 - 2.20549570777721e-5*x_77 + 7.60300425794229e-5*x_78 + 2.15400400595048e-5*x_79 - 0.000117782509442591*x_8 + 1.28700655954278e-5*x_80 - 1.64216171740559e-5*x_81 + 1.42534568428969e-5*x_82 + 2.31217768546601e-5*x_83 + 2.35210267798916e-5*x_84 + 3.42812501021574e-6*x_85 + 7.74738993284449e-5*x_86 + 6.43373025204845e-5*x_87 + 7.31596934863111e-6*x_88 - 4.19136705248058e-5*x_89 + 9.43540993764177e-5*x_9 + 1.69826372887204e-5*x_90 + 5.01602502937618e-5*x_91 + 6.52012302476698e-6*x_92 - 3.8074942139622e-6*x_93 + 3.79025004572096e-6*x_94 + 5.65414734118104e-6*x_95 + 2.80896286225623e-5*x_96 + 4.83817430777166e-5*x_97 - 4.31246457424901e-5*x_98 - 2.03073189001029e-5*x_99 - 6.25323724639935e-6*std::sin(1.89367985725403*x_110 + 6.00559997558594) - 7.82970552556349e-7*std::sin(1.79559993743896*x_26 - 1.20503985881805) - 1.28594464694177e-5*std::sin(0.96343982219696*x_29 - 5.38064002990723) - 5.44446301351244e-6*std::sin(1.55023980140686*x_29 + 3.79512000083923) + 0.000178297419634295*std::sin(0.656719863414764*x_31 - 1.67615985870361) + 2.91718835964735e-6*std::sin(2.1275999546051*x_36 - 1.59095978736877) - 1.56047793823872e-5*std::sin(1.72559988498688*x_37 + 3.60359978675842) + 1.32367809847794e-5*std::sin(2.70616006851196*x_43 - 0.786399841308594) + 1.49372104587712e-5*std::sin(2.33879995346069*x_44 - 8.58600044250488) + 1.33540710282307e-5*std::sin(2.27631998062134*x_49 - 0.396399855613708) - 2.06612238828188e-5*std::sin(1.97167980670929*x_53 - 2.37071990966797) + 7.61954427357461e-6*std::sin(2.68039989471436*x_53 - 2.58656001091003) + 1.36021432830058e-6*std::sin(1.70199990272522*x_57 - 7.82288026809692) + 1.02085949466053e-5*std::sin(1.83415985107422*x_57 - 5.21352005004883) + 0.000133783220492887*std::sin(0.849999845027924*x_71 - 4.59991979598999) - 1.19000179949854e-5*std::sin(2.38175988197327*x_75 - 1.79751992225647) - 4.50514459478574e-6*std::sin(2.45063996315002*x_77 - 0.411519855260849) - 1.92070907127248e-5*std::sin(1.21999990940094*x_79 - 2.38879990577698) - 2.45984225983668e-6*std::sin(1.86287987232208*x_80 + 6.00504016876221) + 9.9491715271624e-6*std::sin(1.36455988883972*x_86 + 4.39143991470337) + 3.1039251993751e-5*std::sin(1.6237598657608*x_93 + 7.59344005584717) + 0.0403774217476763 - 1.10818605332067e-6*std::exp(-1.91511988639832*x_111));
}

inline float score_3(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (1.19676714484e-5*x_1 + 1.53897352373354e-5*x_10 + 1.44274733024298e-5*x_100 + 5.5628320628213e-6*x_101 + 1.51175792975775e-5*x_102 - 6.46540722126675e-6*x_103 - 7.10873761005766e-6*x_104 - 6.75774643273736e-5*x_105 - 3.42065698078986e-6*x_106 + 9.76151864268586e-6*x_107 + 1.81076949638083e-5*x_108 + 5.81091423334568e-6*x_109 - 3.84200216807223e-6*x_11 + 1.25538696765551e-5*x_110 - 5.23251704334449e-5*x_111 - 3.05969853407835e-5*x_112 + 2.11715007036639e-5*x_113 + 2.47114434698646e-5*x_114 + 3.16996166621775e-5*x_115 - 1.76428176964943e-5*x_116 + 3.46490077534842e-6*x_117 + 2.58707815655824e-7*x_118 + 5.69720555500881e-5*x_119 + 8.39371245443987e-6*x_12 + 2.37107879396312e-5*x_120 + 2.4964463367139e-5*x_13 + 1.23550054457196e-5*x_14 + 2.70809128823867e-5*x_15 + 6.2654253803329e-5*x_16 - 4.62806547922656e-6*x_17 - 1.15155813125891e-5*x_18 + 2.40507540382624e-5*x_19 + 6.09039637188644e-5*x_2 + 2.08791440895338e-5*x_20 + 6.32037498196922e-6*x_21 - 2.40287763124905e-6*x_22 - 1.67486536302099e-5*x_23 - 8.03288839822896e-6*x_24 + 8.76829394139121e-6*x_25 + 6.34632356039944e-6*x_26 - 8.34078214685277e-6*x_27 + 1.53035121221792e-5*x_28 - 1.2389200179869e-5*x_29 + 1.62585666210165e-5*x_3 - 1.45191156119911e-6*x_30 - 9.66923997460158e-5*x_31 + 9.94312007082258e-6*x_32 + 3.42001288260993e-5*x_33 - 2.76056107459417e-5*x_34 - 2.71016310229385e-5*x_35 + 2.00276864170021e-5*x_36 - 2.35026095753602e-6*x_37 + 4.5833262311537e-5*x_38 + 5.50454520009921e-6*x_39 + 2.84619344239719e-5*x_4 - 1.65664862597142e-7*x_40 - 4.38961529418615e-5*x_41 + 2.23313656025931e-5*x_42 + 8.74244331819507e-6*x_43 + 5.93920702099857e-5*x_44 + 1.23598130358381e-6*x_45 + 3.03003985822545e-5*x_46 + 1.09489486387238e-5*x_47 + 2.2871347488452e-5*x_48 + 8.86265076486554e-6*x_49 + 4.62282856703568e-5*x_5 + 5.27204550014394e-5*x_50 + 3.00978240995062e-5*x_51 - 2.29206916985447e-5*x_52 - 3.98397732759449e-6*x_53 - 0.000100270272680897*x_54 + 3.44517032303639e-5*x_55 + 1.39224906744034e-5*x_56 + 4.89782009449795e-5*x_57 - 1.44444936604878e-5*x_58 + 4.20128639361175e-5*x_59 + 2.04614830161394e-5*x_6 + 2.06961577560412e-5*x_60 + 4.18619293796498e-6*x_61 + 3.18882099011053e-6*x_62 + 1.58160649019498e-5*x_63 + 1.86398199320982e-5*x_64 + 1.91521935108533e-5*x_65 + 1.49191103700115e-5*x_66 - 5.69703289097503e-6*x_67 + 2.08670826133122e-5*x_68 + 1.33233535396502e-5*x_69 + 2.82081149837068e-5*x_7 + 8.72754612478483e-5*x_70 + 8.72716326558175e-6*x_71 + 5.09815338004509e-6*x_72 - 6.5105755279316e-6*x_73 + 2.77132558138667e-5*x_74 - 2.16688741929308e-5*x_75 + 1.50118349022275e-5*x_76 + 3.91563980431875e-6*x_77 + 9.79573094521257e-5*x_78 - 1.25507672443235e-7*x_79 + 2.36911669028522e-5*x_8 + 1.077027717494e-5*x_80 + 2.69065525896951e-5*x_81 + 5.9454275341189e-6*x_82 + 4.90869742352858e-5*x_83 + 3.6115844988091e-5*x_84 + 3.36079156115899e-5*x_85 - 5.64811023359249e-5*x_86 + 9.67742785143746e-5*x_87 + 1.6110304464736e-5*x_88 + 3.78027606645784e-5*x_89 - 2.06260844468166e-5*x_9 - 6.32741323323767e-6*x_90 - 5.24402062843136e-5*x_91 - 2.41572491797222e-6*x_92 + 1.30182934387122e-5*x_93 - 6.60544889626956e-5*x_94 - 2.29592692526106e-5*x_95 - 1.94321954730675e-5*x_96 - 2.09357723693509e-5*x_97 + 2.86518720860861e-5*x_98 - 1.49400134098221e-5*x_99 + 2.23979012482873e-6*std::sin(1.89367985725403*x_110 + 6.00559997558594) + 4.25435729978404e-6*std::sin(1.79559993743896*x_26 - 1.20503985881805) - 1.34600746590641e-5*std::sin(0.96343982219696*x_29 - 5.38064002990723) + 4.30224123969957e-6*std::sin(1.55023980140686*x_29 + 3.79512000083923) - 0.000140891491002675*std::sin(0.656719863414764*x_31 - 1.67615985870361) + 4.42572324162096e-6*std::sin(2.1275999546051*x_36 - 1.59095978736877) - 2.40365075454508e-5*std::sin(1.72559988498688*x_37 + 3.60359978675842) - 8.16332215680319e-6*std::sin(2.70616006851196*x_43 - 0.786399841308594) - 1.34772668552459e-5*std::sin(2.33879995346069*x_44 - 8.58600044250488) + 4.81336673261763e-6*std::sin(2.27631998062134*x_49 - 0.396399855613708) + 1.86418226209846e-5*std::sin(1.97167980670929*x_53 - 2.37071990966797) + 2.74640301422677e-6*std::sin(2.68039989471436*x_53 - 2.58656001091003) - 7.39087535027054e-6*std::sin(1.70199990272522*x_57 - 7.82288026809692) + 1.54629259288262e-5*std::sin(1.83415985107422*x_57 - 5.21352005004883) - 8.18154526417685e-5*std::sin(0.849999845027924*x_71 - 4.59991979598999) - 1.80249189796043e-5*std::sin(2.38175988197327*x_75 - 1.79751992225647) - 1.62384287700219e-6*std::sin(2.45063996315002*x_77 - 0.411519855260849) - 2.0104199320828e-5*std::sin(1.21999990940094*x_79 - 2.38879990577698) + 6.17057170328128e-6*std::sin(1.86287987232208*x_80 + 6.00504016876221) + 3.58609828753433e-6*std::sin(1.36455988883972*x_86 + 4.39143991470337) + 4.70150551545927e-5*std::sin(1.6237598657608*x_93 + 7.59344005584717) + 0.0667376955328995 - 1.67856585039199e-6*std::exp(-1.91511988639832*x_111));
}

inline float score_4(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.000107480023466718*x_1 - 6.99510227012525e-5*x_10 - 2.69358895177913e-5*x_100 - 0.000292009067916822*x_101 - 0.000129193435368187*x_102 + 0.000146189003801237*x_103 - 0.000199141295532918*x_104 - 2.63419377836108e-5*x_105 + 1.42379499329667e-5*x_106 + 3.59346338438546e-5*x_107 + 6.6755332446201e-6*x_108 - 1.79569255064371e-5*x_109 - 2.27512249427704e-5*x_11 - 5.65901485980171e-5*x_110 + 1.40941737357197e-5*x_111 - 6.88338024436694e-6*x_112 - 6.54835150717402e-5*x_113 - 6.60977330066355e-6*x_114 - 1.15677996788634e-5*x_115 + 5.05879630271025e-5*x_116 + 3.19485284685809e-5*x_117 - 3.04871083775916e-5*x_118 + 0.000218069551506448*x_119 + 4.59179205565075e-5*x_12 - 7.32307469625218e-6*x_120 - 5.49339139234741e-5*x_13 - 2.29780914351002e-5*x_14 - 2.43217459900778e-5*x_15 - 1.16067710408518e-5*x_16 - 5.77735874821078e-5*x_17 - 6.4983908525331e-6*x_18 + 5.80436930721183e-6*x_19 - 5.12483076662977e-5*x_2 + 4.65484252892062e-6*x_20 - 2.74124530706331e-5*x_21 - 3.48996374098573e-5*x_22 - 3.28183759297437e-6*x_23 - 1.82613116094748e-5*x_24 - 2.41995130139172e-5*x_25 + 1.77409528383512e-5*x_26 - 6.2933431414532e-6*x_27 + 7.84711814233926e-6*x_28 + 3.69375848730329e-6*x_29 + 2.67075771055067e-5*x_3 + 2.57137619507755e-6*x_30 - 0.000435874724680848*x_31 - 7.81469206041022e-5*x_32 - 4.10363443298107e-5*x_33 - 0.000190550552159789*x_34 - 7.35853198291528e-5*x_35 - 3.02309768291396e-5*x_36 - 0.000134308961441493*x_37 - 5.34586170714541e-6*x_38 - 0.000159452865842074*x_39 + 9.23971505218113e-6*x_4 - 1.10539054194676e-5*x_40 + 1.80107263142469e-5*x_41 - 0.000143442802890622*x_42 + 6.90135473343959e-5*x_43 - 4.5565312826744e-5*x_44 + 4.83680795508425e-5*x_45 - 1.29588551756737e-5*x_46 + 2.29768013182051e-6*x_47 + 1.89505396424581e-5*x_48 - 1.54795579886908e-5*x_49 + 8.0521907449378e-6*x_5 + 1.99735768331565e-5*x_50 + 4.63436264016551e-5*x_51 - 1.85860819848892e-6*x_52 - 9.37162948315493e-6*x_53 - 0.000101384028947399*x_54 + 8.14472284828529e-6*x_55 - 1.47786197265717e-5*x_56 + 6.56502523748415e-5*x_57 + 3.34052693744537e-6*x_58 + 3.91504569047369e-5*x_59 - 2.09159209059995e-5*x_6 - 1.58333830859482e-5*x_60 - 2.81963231846363e-5*x_61 + 2.05527524939939e-5*x_62 - 1.08440631649035e-5*x_63 - 4.83144148356827e-5*x_64 + 6.79285389893075e-5*x_65 - 1.47338366635865e-5*x_66 + 3.70705402847868e-5*x_67 - 5.05215526980305e-5*x_68 + 8.18247413379508e-6*x_69 + 3.56253164443519e-8*x_7 - 6.06011244878787e-5*x_70 - 6.64197423299659e-5*x_71 + 6.90225067647528e-6*x_72 - 5.34901694754727e-5*x_73 - 0.000105412774353624*x_74 + 3.22436936322365e-5*x_75 + 3.5327579066104e-5*x_76 - 3.10946095137761e-5*x_77 + 9.20295865993599e-5*x_78 + 6.26647387184299e-6*x_79 - 0.000210446929196178*x_8 + 6.84760883262652e-6*x_80 + 1.79893506514946e-5*x_81 + 2.11262210664276e-5*x_82 + 5.32342079257624e-6*x_83 - 1.32580373157224e-5*x_84 - 2.06553635784204e-5*x_85 + 9.22215568936205e-5*x_86 - 1.4194474619391e-5*x_87 + 2.82595340857239e-5*x_88 + 2.20441367277545e-6*x_89 + 0.000148194731255954*x_9 - 8.07580812335198e-6*x_90 - 0.000398949119845705*x_91 - 5.48822511120852e-5*x_92 + 8.19231026029272e-5*x_93 - 0.000156698677517817*x_94 - 4.65022834950757e-5*x_95 - 1.28367399791773e-6*x_96 + 1.51827079228871e-5*x_97 - 2.766673510067e-5*x_98 - 0.000127284336906498*x_99 - 4.12351370803612e-6*std::sin(1.89367985725403*x_110 + 6.00559997558594) + 9.53346316588825e-6*std::sin(1.79559993743896*x_26 - 1.20503985881805) - 7.11791359970225e-5*std::sin(0.96343982219696*x_29 - 5.38064002990723) - 8.90083627298614e-6*std::sin(1.55023980140686*x_29 + 3.79512000083923) + 0.000291488092787489*std::sin(0.656719863414764*x_31 - 1.67615985870361) - 2.46977694690883e-6*std::sin(2.1275999546051*x_36 - 1.59095978736877) - 1.79285311610554e-5*std::sin(1.72559988498688*x_37 + 3.60359978675842) + 2.02016881721733e-5*std::sin(2.70616006851196*x_43 - 0.786399841308594) + 2.10232894835926e-5*std::sin(2.33879995346069*x_44 - 8.58600044250488) - 4.56452009309632e-6*std::sin(2.27631998062134*x_49 - 0.396399855613708) - 2.90795186941183e-5*std::sin(1.97167980670929*x_53 - 2.37071990966797) - 2.60441650066439e-6*std::sin(2.68039989471436*x_53 - 2.58656001091003) - 1.65619934928955e-5*std::sin(1.70199990272522*x_57 - 7.82288026809692) + 3.54060219007125e-6*std::sin(1.83415985107422*x_57 - 5.21352005004883) + 4.99933947234769e-5*std::sin(0.849999845027924*x_71 - 4.59991979598999) - 4.12723102398565e-6*std::sin(2.38175988197327*x_75 - 1.79751992225647) + 1.53989169158465e-6*std::sin(2.45063996315002*x_77 - 0.411519855260849) - 0.000106314383375639*std::sin(1.21999990940094*x_79 - 2.38879990577698) - 9.62217617460546e-6*std::sin(1.86287987232208*x_80 + 6.00504016876221) - 3.40070029951094e-6*std::sin(1.36455988883972*x_86 + 4.39143991470337) + 1.07652075689214e-5*std::sin(1.6237598657608*x_93 + 7.59344005584717) + 0.0541226080814778 - 3.84347306158752e-7*std::exp(-1.91511988639832*x_111));
}

inline float score_5(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (3.73123046419961e-5*x_1 - 3.45317136838894e-6*x_10 - 3.69133435415043e-7*x_100 - 8.18294357737704e-5*x_101 - 2.06220538785534e-5*x_102 + 5.4519037817819e-5*x_103 + 4.97288387386626e-5*x_104 - 1.75527555323511e-5*x_105 - 9.76633012030046e-6*x_106 + 2.52601076958636e-6*x_107 + 1.98552116710667e-5*x_108 + 5.4630843668778e-5*x_109 + 3.69539201338832e-5*x_11 - 5.86495678641086e-6*x_110 - 2.89535863799875e-6*x_111 - 1.05061530971829e-5*x_112 + 5.18548538445739e-5*x_113 - 2.6714518371792e-6*x_114 + 4.79452028156249e-5*x_115 + 1.81695871113133e-5*x_116 + 2.03290915836037e-5*x_117 + 7.30032106774241e-7*x_118 + 0.000111456792941928*x_119 + 6.72012408440384e-6*x_12 + 1.79776643939317e-5*x_120 - 5.76065288154596e-6*x_13 + 8.03502581172546e-6*x_14 + 3.192244138483e-5*x_15 + 8.01416554252827e-5*x_16 - 2.15279207278207e-5*x_17 + 2.94446000325209e-5*x_18 - 2.44693911433541e-6*x_19 + 4.12755886292457e-5*x_2 + 6.61467079493303e-7*x_20 + 3.90510646998883e-5*x_21 + 1.95157990308174e-6*x_22 + 1.97189836494893e-5*x_23 + 2.75908900474365e-5*x_24 - 1.31056761111744e-6*x_25 + 5.30308309433523e-6*x_26 + 1.68103155105681e-6*x_27 + 1.27269200718363e-5*x_28 - 4.46530200629534e-6*x_29 - 1.03889323291504e-5*x_3 + 1.21642622565086e-5*x_30 - 4.09192219782908e-5*x_31 - 1.29852630797136e-5*x_32 + 1.0731805432955e-5*x_33 - 1.24708592890167e-6*x_34 + 1.95245427044387e-6*x_35 - 6.02884898144384e-6*x_36 + 3.14923983461516e-5*x_37 + 1.54130894205242e-5*x_38 + 5.73431051992788e-5*x_39 - 1.19740407841502e-5*x_4 - 4.56999429382687e-5*x_40 - 3.34201783686636e-5*x_41 - 4.29448673380408e-6*x_42 + 3.8716744916256e-5*x_43 + 5.2482086718518e-6*x_44 + 3.98391553740835e-5*x_45 + 1.46726025524704e-6*x_46 + 1.14449235352449e-5*x_47 - 1.13373188487088e-5*x_48 + 2.70958003798786e-5*x_49 + 7.85752030881859e-6*x_5 + 5.20901920083075e-5*x_50 - 6.24096033544564e-6*x_51 + 7.61367242258252e-6*x_52 + 1.97184995363506e-5*x_53 - 9.86289633159737e-5*x_54 + 2.84504819134929e-5*x_55 - 7.20375207605737e-6*x_56 + 1.18028518385912e-5*x_57 - 2.18144415333272e-6*x_58 + 1.02181583760877e-6*x_59 + 1.9103169211589e-5*x_6 + 4.91857742280485e-6*x_60 + 4.12077766372838e-6*x_61 - 7.78677107690631e-6*x_62 + 2.10161933028665e-5*x_63 + 3.02766631553115e-5*x_64 - 1.17751231891924e-5*x_65 - 2.97433133073485e-6*x_66 + 3.8517899751834e-5*x_67 + 1.86054886967562e-5*x_68 + 8.05820099116678e-6*x_69 + 1.51784868106464e-5*x_7 + 2.87152593407617e-5*x_70 + 2.27580808538773e-5*x_71 + 3.57128642653827e-5*x_72 + 1.28478509263943e-5*x_73 + 2.51929366811951e-5*x_74 + 1.05534714488439e-5*x_75 + 3.02276136019375e-5*x_76 + 1.59943290830914e-5*x_77 - 1.72987865118676e-5*x_78 - 1.75876693919125e-5*x_79 - 1.88936535655602e-5*x_8 + 6.54438798745015e-6*x_80 + 1.13916075416426e-5*x_81 + 2.16687079863958e-5*x_82 - 0.00011630871254295*x_83 + 1.9604082701385e-5*x_84 + 4.68903769597416e-5*x_85 - 7.02206302452825e-5*x_86 - 1.75867666139552e-5*x_87 + 1.86524764533533e-5*x_88 + 2.62196475738259e-5*x_89 - 2.37947913060388e-5*x_9 + 1.80920297123944e-5*x_90 - 4.61009504928729e-5*x_91 + 3.7013044078692e-6*x_92 + 6.24840317115852e-5*x_93 + 3.74641511829182e-5*x_94 - 5.64087738793659e-6*x_95 + 9.6870163051809e-6*x_96 - 1.62108970451687e-6*x_97 - 3.17268246545832e-6*x_98 - 6.14013043848204e-6*x_99 - 2.12445493404586e-6*std::sin(1.89367985725403*x_110 + 6.00559997558594) - 1.44355388713804e-5*std::sin(1.79559993743896*x_26 - 1.20503985881805) - 5.02572738139867e-6*std::sin(0.96343982219696*x_29 - 5.38064002990723) - 2.17724972772794e-6*std::sin(1.55023980140686*x_29 + 3.79512000083923) + 7.13014318197971e-5*std::sin(0.656719863414764*x_31 - 1.67615985870361) + 7.59156061155615e-6*std::sin(2.1275999546051*x_36 - 1.59095978736877) + 1.26916430601756e-6*std::sin(1.72559988498688*x_37 + 3.60359978675842) - 9.66137036700176e-6*std::sin(2.70616006851196*x_43 - 0.786399841308594) - 1.10697307506761e-5*std::sin(2.33879995346069*x_44 - 8.58600044250488) + 3.85270311973173e-5*std::sin(2.27631998062134*x_49 - 0.396399855613708) + 1.53117066933967e-5*std::sin(1.97167980670929*x_53 - 2.37071990966797) + 2.19826912195361e-5*std::sin(2.68039989471436*x_53 - 2.58656001091003) + 2.50781165977229e-5*std::sin(1.70199990272522*x_57 - 7.82288026809692) + 1.22541865689087e-5*std::sin(1.83415985107422*x_57 - 5.21352005004883) - 7.00479405900844e-5*std::sin(0.849999845027924*x_71 - 4.59991979598999) - 1.42845358687107e-5*std::sin(2.38175988197327*x_75 - 1.79751992225647) - 1.29975230762818e-5*std::sin(2.45063996315002*x_77 - 0.411519855260849) - 7.50651297017451e-6*std::sin(1.21999990940094*x_79 - 2.38879990577698) + 1.94982069194532e-5*std::sin(1.86287987232208*x_80 + 6.00504016876221) + 2.8703759400719e-5*std::sin(1.36455988883972*x_86 + 4.39143991470337) + 3.7258877140314e-5*std::sin(1.6237598657608*x_93 + 7.59344005584717) + 0.0659673524051247 - 1.33024365463437e-6*std::exp(-1.91511988639832*x_111));
}

inline float score_6(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-2.18660827356159e-6*x_1 + 1.94170539396537e-5*x_10 - 5.3693476929343e-6*x_100 - 5.13541174396929e-5*x_101 - 1.38847741500834e-6*x_102 + 7.67733806140804e-6*x_103 + 9.65389900823699e-6*x_104 + 5.7177615162394e-5*x_105 + 1.30935549995652e-5*x_106 - 7.87435934690758e-6*x_107 + 6.51932725127838e-6*x_108 - 6.98132462817557e-6*x_109 + 8.88614770462193e-6*x_11 + 1.37145164843792e-5*x_110 + 9.84256913032008e-6*x_111 - 2.79766538130531e-6*x_112 - 2.44684699257188e-5*x_113 - 2.13161386393017e-5*x_114 - 3.82129025722872e-5*x_115 + 3.06909561437912e-5*x_116 + 3.38462057778724e-5*x_117 + 1.66671824027707e-5*x_118 + 3.72947925335099e-6*x_119 - 2.14265204268277e-5*x_12 - 1.14572612710601e-5*x_120 - 3.11435968264696e-5*x_13 - 1.6516964911498e-5*x_14 - 1.32137122055152e-5*x_15 + 4.86203383805532e-5*x_16 + 5.44695144363656e-6*x_17 - 3.47097130963886e-7*x_18 + 5.16198823019363e-6*x_19 + 8.73902687214747e-6*x_2 + 8.10667603203532e-7*x_20 + 4.39937750384662e-6*x_21 + 8.19577570442568e-6*x_22 - 2.11046278828311e-5*x_23 + 1.08428078278676e-5*x_24 + 1.74581286208981e-6*x_25 - 2.65456560620704e-6*x_26 - 6.63836352879843e-6*x_27 + 2.82508530279614e-5*x_28 + 2.04065107265668e-5*x_29 + 1.70987335474324e-5*x_3 + 5.10181469026307e-6*x_30 - 0.00014659034734417*x_31 + 1.17573491401579e-5*x_32 - 1.182538955812e-5*x_33 - 1.49193109878309e-5*x_34 + 7.64816350694007e-6*x_35 + 2.91276474125484e-6*x_36 - 4.39281054076705e-5*x_37 - 2.96135373926685e-5*x_38 - 8.07833278315024e-5*x_39 + 2.03110210835265e-6*x_4 - 1.73325139731025e-5*x_40 + 6.11486499058291e-5*x_41 + 3.45674091235033e-5*x_42 - 1.23808972502495e-5*x_43 - 5.61923176220708e-6*x_44 + 9.77894364988127e-6*x_45 - 1.92935062173695e-5*x_46 + 8.82868762366952e-6*x_47 + 4.06018143867482e-5*x_48 + 3.94112438571024e-5*x_49 - 2.34328526360942e-6*x_5 - 8.20649685935089e-5*x_50 + 1.3032247390361e-5*x_51 - 1.04594575826381e-5*x_52 + 2.96932706536942e-6*x_53 - 3.61048401358328e-5*x_54 - 2.03929265047301e-5*x_55 - 1.04536673715998e-5*x_56 - 2.88556561949323e-5*x_57 + 2.77208846520302e-5*x_58 - 8.40890436918597e-6*x_59 - 8.91634856767448e-6*x_6 + 4.20568568579043e-5*x_60 + 1.33235886745526e-5*x_61 + 2.69162964445088e-5*x_62 - 5.74006136580586e-6*x_63 - 1.17471602001006e-5*x_64 + 1.94251784946117e-5*x_65 + 1.02857223517431e-5*x_66 + 2.58349717730625e-5*x_67 + 8.34782729742624e-5*x_68 - 8.49156520818735e-6*x_69 - 1.16193905444881e-5*x_7 - 5.2178554247173e-5*x_70 - 3.38081010057582e-5*x_71 - 2.56541041044332e-5*x_72 + 1.02600578993979e-5*x_73 - 3.75908057076989e-5*x_74 + 4.82487887891504e-5*x_75 - 1.12740428103722e-5*x_76 - 1.06156514759735e-5*x_77 - 1.91142290092987e-5*x_78 + 1.11761288724842e-5*x_79 - 3.38056517101526e-5*x_8 + 9.09226635394827e-6*x_80 - 3.53699846812109e-6*x_81 + 7.24155355287512e-6*x_82 - 4.50523708376995e-6*x_83 + 1.48524057576895e-5*x_84 - 9.68877119810805e-7*x_85 + 2.0755567198192e-5*x_86 + 1.66555862470667e-5*x_87 + 3.06796489757582e-5*x_88 - 2.90158188920614e-5*x_89 - 8.49409862996921e-5*x_9 + 5.66856022134197e-5*x_90 - 9.93038063075672e-5*x_91 - 8.50702849369039e-6*x_92 - 8.21102279978899e-6*x_93 + 3.88064200696515e-5*x_94 + 6.98713790216474e-6*x_95 + 4.1839001724043e-5*x_96 + 3.89173409569287e-5*x_97 - 6.66991764235336e-6*x_98 - 3.0435056522591e-5*x_99 + 2.32592505120124e-5*std::sin(1.89367985725403*x_110 + 6.00559997558594) - 8.61074385595675e-6*std::sin(1.79559993743896*x_26 - 1.20503985881805) - 4.63626415042591e-6*std::sin(0.96343982219696*x_29 - 5.38064002990723) + 1.99415996129577e-5*std::sin(1.55023980140686*x_29 + 3.79512000083923) - 0.000653055360197369*std::sin(0.656719863414764*x_31 - 1.67615985870361) - 3.92346250148536e-7*std::sin(2.1275999546051*x_36 - 1.59095978736877) + 1.04845460146803e-5*std::sin(1.72559988498688*x_37 + 3.60359978675842) + 1.28437471928088e-6*std::sin(2.70616006851196*x_43 - 0.786399841308594) + 1.2281679452734e-5*std::sin(2.33879995346069*x_44 - 8.58600044250488) + 1.89023963050343e-5*std::sin(2.27631998062134*x_49 - 0.396399855613708) - 1.69880801726902e-5*std::sin(1.97167980670929*x_53 - 2.37071990966797) + 1.07852987466058e-5*std::sin(2.68039989471436*x_53 - 2.58656001091003) + 1.49590008614732e-5*std::sin(1.70199990272522*x_57 - 7.82288026809692) + 2.69613495430643e-6*std::sin(1.83415985107422*x_57 - 5.21352005004883) + 7.07466093182985e-5*std::sin(0.849999845027924*x_71 - 4.59991979598999) - 3.14284724205114e-6*std::sin(2.38175988197327*x_75 - 1.79751992225647) - 6.37693392240448e-6*std::sin(2.45063996315002*x_77 - 0.411519855260849) - 6.92480398103919e-6*std::sin(1.21999990940094*x_79 - 2.38879990577698) - 9.43820552826958e-6*std::sin(1.86287987232208*x_80 + 6.00504016876221) + 1.40828353178307e-5*std::sin(1.36455988883972*x_86 + 4.39143991470337) + 8.19760336202843e-6*std::sin(1.6237598657608*x_93 + 7.59344005584717) + 0.0329468091437353 - 2.92676824759936e-7*std::exp(-1.91511988639832*x_111));
}

inline float score_7(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-7.83123666304789e-5*x_1 + 4.36682078168312e-5*x_10 + 8.35633503847529e-6*x_100 + 4.87804634209158e-5*x_101 - 5.75697485955811e-6*x_102 + 2.1503883677826e-5*x_103 + 5.29118278224204e-5*x_104 + 4.1628541143212e-5*x_105 + 9.58019714230129e-6*x_106 - 5.61441906577762e-6*x_107 + 2.94403100674528e-5*x_108 + 3.13395326247329e-5*x_109 + 1.51497705638645e-5*x_11 + 2.3351900273589e-7*x_110 + 7.72119312523283e-5*x_111 + 2.94448817231669e-5*x_112 - 4.5345266638941e-5*x_113 - 1.43223207962299e-5*x_114 + 1.5939093707948e-5*x_115 + 0.000113071014424566*x_116 + 5.93783932218487e-5*x_117 - 2.19969719219165e-5*x_118 - 6.33219368033851e-5*x_119 + 2.37593811343934e-5*x_12 + 2.01538099311695e-5*x_120 + 1.49598379787616e-6*x_13 + 3.68074659935043e-5*x_14 + 4.82769746546496e-6*x_15 + 3.63628646457277e-5*x_16 + 6.32408852708056e-5*x_17 + 4.86195227498144e-5*x_18 - 7.24827889674442e-8*x_19 + 3.36084628732128e-5*x_2 - 1.78129048354688e-5*x_20 - 4.76884134132546e-6*x_21 + 2.70262813036155e-5*x_22 + 5.13404928285284e-5*x_23 + 3.33725476013633e-5*x_24 - 3.18013986265335e-5*x_25 + 2.15958839922791e-5*x_26 + 3.25196594194718e-5*x_27 - 2.19102400089416e-5*x_28 + 4.88319751490838e-6*x_29 + 2.07339666753722e-5*x_3 - 4.39184084836056e-5*x_30 - 2.05751429519809e-5*x_31 - 4.9036986297713e-5*x_32 - 3.14032672849291e-5*x_33 + 5.18548377996373e-5*x_34 + 2.05030217973958e-5*x_35 - 1.94930387263569e-5*x_36 + 3.10282094816075e-5*x_37 - 5.4694915196016e-5*x_38 + 4.28001039223974e-5*x_39 + 1.50859005713103e-5*x_4 - 1.73091224034728e-5*x_40 + 1.39153444005875e-5*x_41 - 7.36947132585896e-5*x_42 - 8.83699823119476e-6*x_43 + 6.38662922198187e-5*x_44 + 3.73271449959466e-5*x_45 - 2.65672065042272e-5*x_46 + 3.8289643888969e-5*x_47 + 0.000151946128237004*x_48 - 4.01278429579838e-5*x_49 + 9.13444661377424e-6*x_5 - 4.51721886451288e-6*x_50 - 1.38299076207495e-6*x_51 + 9.57340785187134e-5*x_52 + 6.91401438211751e-8*x_53 + 0.000131412637206223*x_54 + 3.07824546214112e-5*x_55 - 1.89532476637342e-5*x_56 - 2.72865055309845e-5*x_57 + 4.64342276457493e-5*x_58 - 6.47357078167067e-5*x_59 + 5.52759104418096e-6*x_6 + 5.60758076803832e-5*x_60 + 3.14903197514409e-5*x_61 + 1.69027213773369e-5*x_62 - 4.34498371643311e-6*x_63 - 5.15289518251024e-6*x_64 + 8.62166288057509e-6*x_65 + 2.8068215184414e-5*x_66 - 3.21014226513487e-5*x_67 + 3.39772442807864e-5*x_68 - 2.51340621490151e-5*x_69 + 3.58310225061979e-5*x_7 - 4.42474667800436e-5*x_70 + 2.26405548837582e-6*x_71 + 1.68055983098945e-5*x_72 + 3.30249934193352e-6*x_73 + 4.89192297769417e-5*x_74 + 1.3346173450636e-5*x_75 + 1.09260620348483e-5*x_76 + 2.6711627339591e-6*x_77 - 3.53990913784825e-5*x_78 + 3.64653909830121e-5*x_79 - 1.07080473866382e-5*x_8 + 4.71302761212501e-6*x_80 + 3.26698666510638e-5*x_81 + 1.27724356370869e-5*x_82 - 2.47643023418997e-5*x_83 + 8.2244890016193e-5*x_84 - 7.81628729292399e-7*x_85 + 7.03484043721799e-5*x_86 + 7.6018267193711e-5*x_87 + 1.64595087842751e-5*x_88 - 2.93878114496031e-5*x_89 - 7.96759673901314e-5*x_9 + 4.2187567458451e-5*x_90 + 8.71654230862699e-5*x_91 + 5.62592647613953e-7*x_92 - 4.32506116805961e-5*x_93 + 4.4477617483079e-5*x_94 + 4.12236431955095e-6*x_95 + 4.36519538973358e-5*x_96 + 6.40613910233817e-5*x_97 - 1.67306237300399e-5*x_98 + 3.19549629817581e-5*x_99 + 2.28451825849283e-5*std::sin(1.89367985725403*x_110 + 6.00559997558594) + 3.63956484151917e-7*std::sin(1.79559993743896*x_26 - 1.20503985881805) + 1.98503149010704e-5*std::sin(0.96343982219696*x_29 - 5.38064002990723) - 1.50910968480806e-5*std::sin(1.55023980140686*x_29 + 3.79512000083923) + 0.00049420918477838*std::sin(0.656719863414764*x_31 - 1.67615985870361) + 3.48410366609913e-6*std::sin(2.1275999546051*x_36 - 1.59095978736877) - 4.01677804625034e-7*std::sin(1.72559988498688*x_37 + 3.60359978675842) + 6.18514239672574e-5*std::sin(2.70616006851196*x_43 - 0.786399841308594) + 2.87279917309877e-5*std::sin(2.33879995346069*x_44 - 8.58600044250488) + 1.27254803602989e-5*std::sin(2.27631998062134*x_49 - 0.396399855613708) - 3.97367012064268e-5*std::sin(1.97167980670929*x_53 - 2.37071990966797) + 7.26088402576424e-6*std::sin(2.68039989471436*x_53 - 2.58656001091003) - 6.32282814474957e-7*std::sin(1.70199990272522*x_57 - 7.82288026809692) + 1.79941840846524e-5*std::sin(1.83415985107422*x_57 - 5.21352005004883) + 1.89489529093508e-5*std::sin(0.849999845027924*x_71 - 4.59991979598999) - 2.0975571617096e-5*std::sin(2.38175988197327*x_75 - 1.79751992225647) - 4.29308253191523e-6*std::sin(2.45063996315002*x_77 - 0.411519855260849) + 2.96487721993118e-5*std::sin(1.21999990940094*x_79 - 2.38879990577698) - 1.14654743680714e-5*std::sin(1.86287987232208*x_80 + 6.00504016876221) + 9.480853187204e-6*std::sin(1.36455988883972*x_86 + 4.39143991470337) + 5.47113503030308e-5*std::sin(1.6237598657608*x_93 + 7.59344005584717) + 0.0548560981369483 - 1.95334460303254e-6*std::exp(-1.91511988639832*x_111));
}

inline float score_8(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (2.20187243971888e-5*x_1 + 5.53808365325465e-5*x_10 + 2.93077617713741e-5*x_100 - 7.01242738130151e-5*x_101 + 3.44218053226108e-5*x_102 + 3.97278585959143e-5*x_103 + 1.20090699415111e-5*x_104 - 3.87689777839484e-5*x_105 + 4.09901267855116e-5*x_106 + 6.09444515924925e-6*x_107 + 1.60323297346215e-5*x_108 + 1.51228959766034e-5*x_109 + 1.32052976190062e-5*x_11 + 8.90441777679956e-6*x_110 - 9.1910289861146e-5*x_111 - 2.73730247018424e-5*x_112 + 4.82190867158101e-5*x_113 + 2.24918808286842e-5*x_114 + 7.30438966118969e-6*x_115 + 0.00011004679923536*x_116 + 6.51036922886685e-5*x_117 + 3.77808066297945e-5*x_118 + 9.49271107081402e-5*x_119 + 3.63771153880254e-5*x_12 + 2.96421212239186e-5*x_120 - 2.62151057531223e-5*x_13 + 7.27539936388492e-6*x_14 + 2.18340424082741e-5*x_15 + 2.70263705302949e-5*x_16 - 1.7284354418603e-7*x_17 - 2.64032053811455e-5*x_18 - 9.17066403701945e-6*x_19 + 7.36322540812036e-5*x_2 + 3.10110213767085e-5*x_20 + 2.46934807219325e-5*x_21 + 6.27946309568903e-6*x_22 - 3.1694796898874e-5*x_23 + 3.48166845583923e-5*x_24 + 3.00057945868958e-5*x_25 - 9.55973875632205e-6*x_26 - 1.70464930340335e-5*x_27 + 3.05142070710781e-5*x_28 + 4.8175259581261e-6*x_29 + 3.89283634938625e-5*x_3 - 3.25190125174903e-6*x_30 - 0.000278545691440868*x_31 + 3.52357063240294e-5*x_32 + 1.4164235467714e-5*x_33 - 5.9514813080237e-5*x_34 - 9.7057253085722e-6*x_35 + 2.17023491455943e-5*x_36 - 2.56055246243495e-5*x_37 + 4.91075898879786e-5*x_38 - 8.99333849616713e-5*x_39 + 7.90471622810856e-6*x_4 - 3.45177980451492e-5*x_40 - 2.77621124892157e-5*x_41 + 6.93713294849887e-5*x_42 + 2.27678035010084e-5*x_43 + 2.84234219473551e-6*x_44 + 3.45941538907768e-5*x_45 + 3.65437130963691e-5*x_46 + 2.28672000659784e-5*x_47 + 2.07794337095552e-5*x_48 + 3.47723612783537e-5*x_49 + 2.86195482402436e-5*x_5 + 5.21784651941714e-5*x_50 + 3.851105711516e-5*x_51 + 1.22288436095289e-6*x_52 + 1.16781982168273e-5*x_53 - 0.00013980037960913*x_54 + 1.62026740443926e-5*x_55 + 3.28314010308487e-5*x_56 + 4.10052175846154e-5*x_57 + 4.57780656536661e-6*x_58 + 3.68572622647434e-5*x_59 + 2.45114702143706e-5*x_6 + 3.8190704055316e-5*x_60 + 1.57095414495818e-5*x_61 + 5.03931297176689e-5*x_62 + 2.91391018289926e-5*x_63 - 1.68925632032001e-5*x_64 + 3.50510029953819e-5*x_65 + 4.17761735459564e-5*x_66 + 1.54205696804182e-5*x_67 + 7.31874756263284e-5*x_68 + 1.07468423829174e-5*x_69 + 1.09829404469687e-5*x_7 + 6.54016981403824e-5*x_70 - 5.42997727770768e-5*x_71 - 7.54243000931063e-5*x_72 - 1.08195319168627e-5*x_73 - 2.97406503320697e-5*x_74 + 3.46591460578551e-5*x_75 - 2.98876042434963e-5*x_76 + 5.99192774957345e-7*x_77 + 6.4253888948301e-5*x_78 + 2.48289212691181e-5*x_79 + 8.82585947210024e-5*x_8 + 2.22876031967792e-5*x_80 + 2.04040901659155e-5*x_81 + 2.40211213280317e-5*x_82 + 6.9515516102642e-5*x_83 - 1.27872402302692e-5*x_84 + 2.15138309196317e-5*x_85 - 1.58177940983366e-5*x_86 + 5.82446353249927e-5*x_87 + 4.52292718831158e-5*x_88 + 2.1383421111866e-5*x_89 + 7.64269188439953e-6*x_9 + 1.10590275081073e-5*x_90 - 0.000248169462571444*x_91 + 1.29379838127147e-6*x_92 - 3.15187017984372e-6*x_93 - 3.75644685510398e-5*x_94 - 1.01160823153876e-5*x_95 - 1.21295579484014e-5*x_96 + 3.52924077134619e-5*x_97 + 4.36970635799147e-5*x_98 - 2.40030901002836e-5*x_99 + 2.11403068816849e-5*std::sin(1.89367985725403*x_110 + 6.00559997558594) - 1.28984984282551e-5*std::sin(1.79559993743896*x_26 - 1.20503985881805) - 2.96166736945164e-5*std::sin(0.96343982219696*x_29 - 5.38064002990723) + 1.66154412529151e-5*std::sin(1.55023980140686*x_29 + 3.79512000083923) - 0.000544129015869423*std::sin(0.656719863414764*x_31 - 1.67615985870361) - 1.73444908740758e-6*std::sin(2.1275999546051*x_36 - 1.59095978736877) - 8.01991337757738e-6*std::sin(1.72559988498688*x_37 + 3.60359978675842) + 3.16585786041331e-5*std::sin(2.70616006851196*x_43 - 0.786399841308594) - 1.31455182869657e-6*std::sin(2.33879995346069*x_44 - 8.58600044250488) + 2.15511853359809e-5*std::sin(2.27631998062134*x_49 - 0.396399855613708) + 1.81829463494772e-6*std::sin(1.97167980670929*x_53 - 2.37071990966797) + 1.22966405127227e-5*std::sin(2.68039989471436*x_53 - 2.58656001091003) + 2.24078955694984e-5*std::sin(1.70199990272522*x_57 - 7.82288026809692) - 2.07234384630656e-5*std::sin(1.83415985107422*x_57 - 5.21352005004883) - 4.61394846454805e-5*std::sin(0.849999845027924*x_71 - 4.59991979598999) + 2.41570257139509e-5*std::sin(2.38175988197327*x_75 - 1.79751992225647) - 7.27053240336732e-6*std::sin(2.45063996315002*x_77 - 0.411519855260849) - 4.42359738899013e-5*std::sin(1.21999990940094*x_79 - 2.38879990577698) - 1.21530899255513e-5*std::sin(1.86287987232208*x_80 + 6.00504016876221) + 1.60562602271668e-5*std::sin(1.36455988883972*x_86 + 4.39143991470337) - 6.3009653335887e-5*std::sin(1.6237598657608*x_93 + 7.59344005584717) + 0.057621208801627 + 2.24961668101597e-6*std::exp(-1.91511988639832*x_111));
}

inline float score_9(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-1.24340829577345e-5*x_1 - 2.34653460581229e-5*x_10 - 8.90837374994367e-6*x_100 - 3.81867277686537e-5*x_101 - 1.3251054148529e-5*x_102 + 1.08587315687159e-5*x_103 + 1.39179381492725e-5*x_104 - 1.0305395767163e-5*x_105 - 8.12643292306806e-6*x_106 + 3.84455756811474e-8*x_107 - 6.4197702438947e-6*x_108 + 2.20746948475026e-5*x_109 + 2.17274344533622e-5*x_11 - 1.98022734056898e-5*x_110 - 1.34289002330398e-5*x_111 + 9.04447811195085e-6*x_112 + 2.96669782058948e-5*x_113 + 1.43556741905744e-6*x_114 + 8.32085060960977e-6*x_115 + 4.64651513940576e-5*x_116 - 2.29470603277671e-5*x_117 - 6.43799192580759e-6*x_118 + 2.73670757162165e-5*x_119 - 7.55582385183744e-6*x_12 - 1.38209848122035e-5*x_120 + 5.56906252671554e-6*x_13 + 1.49866056095108e-6*x_14 + 1.8081771489159e-5*x_15 - 1.33332132892911e-5*x_16 - 1.33124591604073e-5*x_17 + 1.00256929674543e-5*x_18 - 1.81847418705372e-6*x_19 + 6.93711357396163e-6*x_2 - 5.44513910912375e-6*x_20 + 8.45201665776972e-6*x_21 - 3.26311208672518e-6*x_22 + 1.24829992938366e-5*x_23 + 8.30063045311178e-6*x_24 + 2.24526539097737e-6*x_25 - 5.24403615857709e-7*x_26 - 3.37835740064607e-6*x_27 + 6.27615290092485e-6*x_28 - 9.17787677752314e-6*x_29 - 1.57732607671547e-5*x_3 - 8.78133759310449e-6*x_30 + 5.05580357662808e-5*x_31 - 9.72476104413598e-6*x_32 - 7.62615953467674e-6*x_33 + 2.92100257975242e-5*x_34 + 8.42286357993503e-6*x_35 - 7.33259801291112e-6*x_36 - 2.36824180036883e-6*x_37 + 1.33303444217319e-5*x_38 + 2.37010560701161e-5*x_39 - 7.15499775489938e-6*x_4 - 4.29469504704916e-6*x_40 - 3.2082728877047e-5*x_41 - 3.68302345849723e-5*x_42 + 2.11812773364573e-5*x_43 - 4.27174678453472e-6*x_44 + 2.38845907383272e-5*x_45 - 8.79707583896297e-6*x_46 + 4.09846624187783e-6*x_47 - 3.2337259934806e-5*x_48 + 5.58837344250914e-6*x_49 + 4.62272289459403e-6*x_5 + 3.53399230671567e-5*x_50 - 2.01275457947647e-6*x_51 + 8.44061207870805e-6*x_52 + 1.05536315845813e-5*x_53 - 5.42901652168114e-5*x_54 - 2.20970633257961e-6*x_55 - 1.8654597611483e-6*x_56 + 1.47584463396335e-5*x_57 + 3.03262177242521e-6*x_58 - 6.04954022405864e-6*x_59 + 7.63885287762789e-6*x_6 - 8.82939453611283e-6*x_60 + 3.59362246968734e-6*x_61 - 1.01775393154517e-5*x_62 + 2.12158800591716e-5*x_63 + 1.65684027089518e-6*x_64 - 5.84646290104185e-6*x_65 - 1.21128855836226e-5*x_66 + 6.66218300025055e-7*x_67 - 2.33177082159264e-5*x_68 + 1.35449880995111e-5*x_69 + 8.68635945844534e-6*x_7 + 2.16573617062884e-6*x_70 - 1.68201521248619e-7*x_71 + 3.49446088760099e-6*x_72 + 2.18329619217811e-5*x_73 - 7.81278965096696e-6*x_74 + 3.2637023534424e-6*x_75 + 1.04143900349545e-5*x_76 + 7.33212725813356e-6*x_77 - 6.1016622661554e-7*x_78 - 2.00856566988564e-5*x_79 - 6.3734672111284e-5*x_8 + 3.26761463034469e-7*x_80 + 1.22359017495475e-6*x_81 + 1.053008199149e-5*x_82 - 3.84321342116382e-5*x_83 - 4.97709762385597e-6*x_84 + 2.22557399871086e-5*x_85 - 2.00129791301417e-5*x_86 - 3.45275154764366e-5*x_87 + 3.73037623770297e-6*x_88 + 6.46037020948837e-6*x_89 + 8.02159154646206e-5*x_9 - 7.667902095217e-6*x_90 + 3.07261471954214e-5*x_91 + 9.3063234665015e-6*x_92 + 4.08374453409826e-5*x_93 + 2.93822703729174e-5*x_94 + 7.07576401148823e-6*x_95 - 1.99014330696523e-5*x_96 - 3.29537061524354e-5*x_97 - 2.79059955547421e-6*x_98 + 1.80001763295877e-6*x_99 - 1.57241178215096e-5*std::sin(1.89367985725403*x_110 + 6.00559997558594) - 9.07912016776653e-6*std::sin(1.79559993743896*x_26 - 1.20503985881805) - 1.71890800101468e-6*std::sin(0.96343982219696*x_29 - 5.38064002990723) - 3.36468142770471e-6*std::sin(1.55023980140686*x_29 + 3.79512000083923) + 0.000110187912924062*std::sin(0.656719863414764*x_31 - 1.67615985870361) + 4.80884369121143e-6*std::sin(2.1275999546051*x_36 - 1.59095978736877) + 3.8018370628916e-6*std::sin(1.72559988498688*x_37 + 3.60359978675842) - 4.06595100133849e-7*std::sin(2.70616006851196*x_43 - 0.786399841308594) - 9.55781960373836e-6*std::sin(2.33879995346069*x_44 - 8.58600044250488) - 1.23752867874739e-5*std::sin(2.27631998062134*x_49 - 0.396399855613708) + 1.32204236667546e-5*std::sin(1.97167980670929*x_53 - 2.37071990966797) - 7.06107114272505e-6*std::sin(2.68039989471436*x_53 - 2.58656001091003) + 1.5772686852958e-5*std::sin(1.70199990272522*x_57 - 7.82288026809692) + 5.98504449294151e-6*std::sin(1.83415985107422*x_57 - 5.21352005004883) - 1.58188064790201e-5*std::sin(0.849999845027924*x_71 - 4.59991979598999) - 6.97668362191958e-6*std::sin(2.38175988197327*x_75 - 1.79751992225647) + 4.17494082977767e-6*std::sin(2.45063996315002*x_77 - 0.411519855260849) - 2.56739059343137e-6*std::sin(1.21999990940094*x_79 - 2.38879990577698) - 3.03006234937255e-6*std::sin(1.86287987232208*x_80 + 6.00504016876221) - 9.21994878461548e-6*std::sin(1.36455988883972*x_86 + 4.39143991470337) + 1.8197538954369e-5*std::sin(1.6237598657608*x_93 + 7.59344005584717) + 0.0558325578343496 - 6.49701831669503e-7*std::exp(-1.91511988639832*x_111));
}

inline float score_10(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (1.27029121634131e-5*x_1 + 3.03269529756227e-5*x_10 + 5.08103583405552e-6*x_100 + 1.74282841008962e-5*x_101 + 2.46950694033264e-5*x_102 + 2.14595467848597e-5*x_103 + 2.07484094777794e-5*x_104 + 3.51420851700058e-5*x_105 + 2.60444440010444e-5*x_106 + 1.28382559082404e-6*x_107 + 1.76612335116603e-5*x_108 + 5.57268743419979e-6*x_109 + 9.29049249189967e-6*x_11 + 4.45098495941662e-5*x_110 - 3.84325330565432e-5*x_111 - 2.72780608674718e-5*x_112 - 1.75677173651021e-5*x_113 + 1.81838104616718e-6*x_114 - 2.20582171917564e-5*x_115 + 8.80808399201568e-5*x_116 + 5.46653600708047e-5*x_117 + 3.21396259430419e-5*x_118 + 1.8301570706325e-5*x_119 + 1.00162503022462e-5*x_12 - 5.94440080595285e-6*x_120 - 2.94582331262569e-5*x_13 + 1.13757714482647e-6*x_14 - 2.15841247120998e-6*x_15 + 5.10301760887829e-5*x_16 + 1.56951711896156e-5*x_17 - 9.29454690910711e-6*x_18 + 1.22070041535589e-5*x_19 + 4.43368424790528e-5*x_2 + 1.19065028833677e-5*x_20 + 1.20571645317478e-5*x_21 + 6.11568496647397e-6*x_22 - 1.91446139216058e-5*x_23 + 2.90557258379422e-5*x_24 + 1.76402852284238e-5*x_25 + 3.71430889435008e-7*x_26 + 2.49626893559021e-6*x_27 + 3.62113790284544e-5*x_28 + 1.69922654278383e-5*x_29 + 1.92166919156008e-5*x_3 + 6.80068482331989e-6*x_30 - 0.00019714245870553*x_31 + 1.94767960024654e-5*x_32 - 2.18656356092364e-5*x_33 - 2.83017410963611e-5*x_34 - 1.04639449311713e-5*x_35 + 9.30279223447581e-6*x_36 - 2.25078499148132e-5*x_37 - 9.05584284774679e-7*x_38 - 9.03420846400978e-5*x_39 + 3.90660261017344e-6*x_4 - 2.41663960141086e-5*x_40 + 5.00721225816647e-5*x_41 + 4.55726144770927e-5*x_42 - 1.23920326009133e-5*x_43 + 2.10390655466101e-5*x_44 + 4.05751683618872e-5*x_45 + 9.65457777299772e-6*x_46 + 2.24888081980357e-5*x_47 + 4.74520863007928e-5*x_48 + 1.78839918855371e-5*x_49 + 4.85947453641996e-6*x_5 - 2.02239375168825e-5*x_50 + 1.35120892880572e-5*x_51 + 3.63931693536583e-6*x_52 + 1.1829307382716e-5*x_53 - 3.65344284279128e-5*x_54 - 3.07706451537317e-6*x_55 - 9.77083376279896e-7*x_56 + 1.31468930881712e-5*x_57 + 4.25725021375179e-5*x_58 + 6.69977318922803e-6*x_59 + 1.79936717770221e-6*x_6 + 4.78709842051533e-5*x_60 + 2.31137329174618e-5*x_61 + 1.73513485005267e-5*x_62 - 9.18359828196109e-6*x_63 + 5.40796195252775e-7*x_64 + 3.49743398119558e-5*x_65 + 4.18140708849917e-5*x_66 + 1.54212703505827e-5*x_67 + 7.74064302115485e-5*x_68 - 5.00845956010248e-6*x_69 - 5.90336183275608e-6*x_7 - 3.93784588237137e-5*x_70 - 3.25968828521613e-5*x_71 - 3.15045741994125e-5*x_72 + 1.8020811097376e-5*x_73 - 2.52802216170534e-5*x_74 + 3.25720503587813e-5*x_75 - 4.07391090276364e-6*x_76 - 4.04957201919999e-6*x_77 + 1.6664830537471e-5*x_78 + 3.73160669160141e-5*x_79 - 6.17935480335581e-6*x_8 + 3.60148628047482e-5*x_80 + 7.23290114445124e-6*x_81 + 1.36900020347127e-5*x_82 + 6.38166963657418e-8*x_83 + 3.0138693365834e-5*x_84 + 3.1161281435257e-6*x_85 + 1.78012727332313e-5*x_86 + 2.29931972811425e-5*x_87 + 3.97442547548246e-5*x_88 - 2.56368311531202e-5*x_89 - 0.000125844417529587*x_9 + 4.2219112906653e-5*x_90 - 0.000179715573037456*x_91 - 5.7471130330939e-6*x_92 - 3.23056936835041e-5*x_93 - 5.34156834651615e-6*x_94 - 8.39086669727238e-6*x_95 + 2.67679195809478e-5*x_96 + 7.12431979761467e-5*x_97 + 3.40461892570163e-6*x_98 - 2.37840610001018e-5*x_99 + 1.82249587460008e-5*std::sin(1.89367985725403*x_110 + 6.00559997558594) - 8.28640350538098e-6*std::sin(1.79559993743896*x_26 - 1.20503985881805) - 9.15663444392175e-6*std::sin(0.96343982219696*x_29 - 5.38064002990723) + 2.16434151588157e-5*std::sin(1.55023980140686*x_29 + 3.79512000083923) - 0.000708787086130107*std::sin(0.656719863414764*x_31 - 1.67615985870361) + 6.21391455952547e-6*std::sin(2.1275999546051*x_36 - 1.59095978736877) - 2.52318300562853e-5*std::sin(1.72559988498688*x_37 + 3.60359978675842) + 3.9029066245737e-5*std::sin(2.70616006851196*x_43 - 0.786399841308594) + 1.08894109763577e-5*std::sin(2.33879995346069*x_44 - 8.58600044250488) + 1.49102047755707e-5*std::sin(2.27631998062134*x_49 - 0.396399855613708) - 1.50622874837007e-5*std::sin(1.97167980670929*x_53 - 2.37071990966797) + 8.50744055317313e-6*std::sin(2.68039989471436*x_53 - 2.58656001091003) + 1.4395541111092e-5*std::sin(1.70199990272522*x_57 - 7.82288026809692) + 5.48737830421169e-6*std::sin(1.83415985107422*x_57 - 5.21352005004883) + 3.40621189941462e-5*std::sin(0.849999845027924*x_71 - 4.59991979598999) - 6.39656102597409e-6*std::sin(2.38175988197327*x_75 - 1.79751992225647) - 5.03012364617552e-6*std::sin(2.45063996315002*x_77 - 0.411519855260849) - 1.36765069014381e-5*std::sin(1.21999990940094*x_79 - 2.38879990577698) - 6.24822166303044e-7*std::sin(1.86287987232208*x_80 + 6.00504016876221) + 1.11085364533157e-5*std::sin(1.36455988883972*x_86 + 4.39143991470337) + 1.66843839784345e-5*std::sin(1.6237598657608*x_93 + 7.59344005584717) + 0.0607889934738235 - 5.95678067141257e-7*std::exp(-1.91511988639832*x_111));
}

inline float score_11(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-7.43544886132921e-5*x_1 + 1.18747286595096e-5*x_10 - 1.67462194452377e-5*x_100 - 0.00017175576140531*x_101 - 4.21284313026278e-5*x_102 + 7.00656165021718e-5*x_103 - 8.08430374843375e-6*x_104 - 7.55997436495382e-5*x_105 - 2.18179483555361e-6*x_106 + 1.46563024579065e-5*x_107 + 1.93876042219514e-5*x_108 + 4.46285149164051e-5*x_109 + 1.87712890263629e-5*x_11 - 6.14410744477047e-5*x_110 - 2.78494091242162e-5*x_111 - 2.79867932770842e-5*x_112 + 1.64363916316877e-5*x_113 + 4.85206328803156e-6*x_114 + 6.54699562829951e-5*x_115 + 9.92263865731664e-5*x_116 + 7.59303712226626e-5*x_117 - 6.37755223813647e-6*x_118 + 9.49297853548074e-5*x_119 + 3.08224710436512e-5*x_12 + 3.29662060520234e-5*x_120 - 2.7214740969991e-5*x_13 + 2.35946493327147e-5*x_14 + 3.37405381558715e-5*x_15 + 1.3574037824387e-5*x_16 - 3.15903682797599e-5*x_17 + 1.80512024539348e-5*x_18 - 2.97054318906777e-5*x_19 + 4.26044554410986e-5*x_2 + 8.14171637261995e-6*x_20 - 7.70948722687182e-7*x_21 - 1.58660040223432e-5*x_22 + 1.14652715882453e-5*x_23 + 1.68430015961569e-5*x_24 - 1.47201606888307e-5*x_25 + 5.63136824531422e-6*x_26 - 2.68703664850253e-5*x_27 - 8.6542044263012e-6*x_28 - 2.39506460290205e-5*x_29 + 2.99464205709033e-5*x_3 - 1.51590830744884e-5*x_30 - 0.000302370000306188*x_31 - 5.57750437052394e-5*x_32 - 4.91596906753875e-6*x_33 - 8.37379455065651e-5*x_34 - 1.87822397770276e-5*x_35 - 1.6528641194938e-5*x_36 - 3.08724075732462e-5*x_37 + 2.59598670824536e-5*x_38 - 3.80102447919775e-5*x_39 - 1.33432056501428e-6*x_4 - 8.67599628858666e-5*x_40 - 8.15394896875225e-5*x_41 - 7.09789628713248e-5*x_42 + 5.28534910801798e-5*x_43 + 3.40268795951304e-5*x_44 + 5.43350742286177e-5*x_45 + 1.89209283519786e-5*x_46 + 3.11633978728504e-5*x_47 + 2.54705338379926e-5*x_48 + 1.67397624892048e-5*x_49 + 9.77684546724697e-6*x_5 + 0.000107567238316195*x_50 + 2.16855851723145e-5*x_51 - 1.52455895821905e-5*x_52 + 6.52445209807962e-6*x_53 - 0.000158219919001739*x_54 + 4.73749982010181e-5*x_55 + 4.29949956404978e-6*x_56 + 5.40583003954399e-5*x_57 + 1.69214709275245e-5*x_58 + 6.87204297524915e-6*x_59 + 1.13603903792868e-5*x_6 - 2.44050347150251e-5*x_60 + 4.60947450412631e-6*x_61 + 3.31289765936301e-6*x_62 + 2.3812293437279e-5*x_63 - 3.39397616052206e-5*x_64 + 9.78638826956034e-6*x_65 + 1.3060560555001e-5*x_66 + 7.03967529169909e-6*x_67 - 3.0144298995743e-5*x_68 + 5.81019655351433e-6*x_69 + 3.47038777313152e-5*x_7 + 6.1711592145161e-5*x_70 - 3.58518301371271e-5*x_71 - 6.12895060821063e-6*x_72 - 2.95743202400584e-5*x_73 - 1.94880014247861e-5*x_74 + 7.93290091038755e-7*x_75 - 1.12389898513422e-6*x_76 + 8.45719920769188e-6*x_77 - 2.43991161769248e-5*x_78 - 1.14090252391147e-5*x_79 - 1.37518529735305e-5*x_8 - 5.31671590619474e-6*x_80 + 5.09870256128669e-5*x_81 + 2.5307976124006e-5*x_82 - 4.57767226368288e-5*x_83 + 6.73088693882683e-6*x_84 + 1.72147187703658e-5*x_85 - 3.00132631837081e-5*x_86 - 3.26762725064894e-5*x_87 + 2.56311617858206e-5*x_88 + 3.6552305515345e-5*x_89 + 8.64846720151995e-6*x_9 + 7.74686440481427e-6*x_90 - 0.000263381581263384*x_91 - 2.65836975961441e-5*x_92 + 6.81880824514925e-5*x_93 - 5.63515554716503e-5*x_94 - 3.23806375888211e-5*x_95 - 2.41929716764362e-5*x_96 - 2.7840434089808e-5*x_97 + 2.87702197582451e-5*x_98 - 3.87609879863699e-5*x_99 + 1.20037094559609e-5*std::sin(1.89367985725403*x_110 + 6.00559997558594) - 5.03302049147755e-6*std::sin(1.79559993743896*x_26 - 1.20503985881805) - 2.62755908964262e-5*std::sin(0.96343982219696*x_29 - 5.38064002990723) - 9.95004322568223e-6*std::sin(1.55023980140686*x_29 + 3.79512000083923) + 0.00032584793541362*std::sin(0.656719863414764*x_31 - 1.67615985870361) + 8.90629937370089e-6*std::sin(2.1275999546051*x_36 - 1.59095978736877) - 6.54104235035208e-6*std::sin(1.72559988498688*x_37 + 3.60359978675842) + 1.56489886866454e-5*std::sin(2.70616006851196*x_43 - 0.786399841308594) - 6.59228854985216e-7*std::sin(2.33879995346069*x_44 - 8.58600044250488) + 3.23523109352946e-6*std::sin(2.27631998062134*x_49 - 0.396399855613708) + 9.11848634687064e-7*std::sin(1.97167980670929*x_53 - 2.37071990966797) + 1.84595293077896e-6*std::sin(2.68039989471436*x_53 - 2.58656001091003) + 8.74360672286649e-6*std::sin(1.70199990272522*x_57 - 7.82288026809692) + 1.18479580482187e-5*std::sin(1.83415985107422*x_57 - 5.21352005004883) - 0.000120327338856363*std::sin(0.849999845027924*x_71 - 4.59991979598999) - 1.38110008982694e-5*std::sin(2.38175988197327*x_75 - 1.79751992225647) - 1.09144124238106e-6*std::sin(2.45063996315002*x_77 - 0.411519855260849) - 3.92456750823859e-5*std::sin(1.21999990940094*x_79 - 2.38879990577698) - 9.39677670353689e-6*std::sin(1.86287987232208*x_80 + 6.00504016876221) + 2.41034131176089e-6*std::sin(1.36455988883972*x_86 + 4.39143991470337) + 3.60237385647612e-5*std::sin(1.6237598657608*x_93 + 7.59344005584717) + 0.0302879196966264 - 1.28614583476353e-6*std::exp(-1.91511988639832*x_111));
}

int predict(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120)
{
    float s0 = score_0(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s1 = score_1(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s2 = score_2(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s3 = score_3(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s4 = score_4(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s5 = score_5(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s6 = score_6(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s7 = score_7(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s8 = score_8(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s9 = score_9(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s10 = score_10(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s11 = score_11(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);

    float max_score = s0;
    int max_index = 0;

    if(s1 > max_score) {
        max_score = s1;
        max_index = 1;
    }

    if(s2 > max_score) {
        max_score = s2;
        max_index = 2;
    }

    if(s3 > max_score) {
        max_score = s3;
        max_index = 3;
    }

    if(s4 > max_score) {
        max_score = s4;
        max_index = 4;
    }

    if(s5 > max_score) {
        max_score = s5;
        max_index = 5;
    }

    if(s6 > max_score) {
        max_score = s6;
        max_index = 6;
    }

    if(s7 > max_score) {
        max_score = s7;
        max_index = 7;
    }

    if(s8 > max_score) {
        max_score = s8;
        max_index = 8;
    }

    if(s9 > max_score) {
        max_score = s9;
        max_index = 9;
    }

    if(s10 > max_score) {
        max_score = s10;
        max_index = 10;
    }

    if(s11 > max_score) {
        max_score = s11;
        max_index = 11;
    }

    return max_index;
}

#endif
