
#ifndef KAN_MODEL_H
#define KAN_MODEL_H

#include <cmath>


inline float score_0(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.00348657655049938*x_1 + 0.00375818407755245*x_10 - 0.0065262646034601*x_100 + 0.00462596615865456*x_101 + 0.00354088101957638*x_102 - 0.00511967739718893*x_103 + 0.0127471447620563*x_104 + 0.00138272705911726*x_105 + 0.00208096778817703*x_106 + 0.00157933483147879*x_107 - 0.00338702179026247*x_108 + 0.000455927780561968*x_109 - 0.00281036080241666*x_11 + 0.00174184534931923*x_110 + 0.00889296427476282*x_111 - 0.00771425837089614*x_112 - 0.00266780638716917*x_113 + 0.0016704661971736*x_114 - 0.00532431516942425*x_115 - 0.0153539648828656*x_116 - 0.00608503623603895*x_117 + 0.00398746238076358*x_118 - 0.0112454123733373*x_119 - 0.00163513583360041*x_12 - 0.00940519576830491*x_120 + 0.00178653041445616*x_13 - 0.00363546660542754*x_14 - 0.00699563364280046*x_15 - 0.000603055299498966*x_16 - 0.00278223813825115*x_17 - 0.00276254491235896*x_18 - 0.00263526544087765*x_19 + 0.000113084929881607*x_2 - 0.00113879118900656*x_20 - 0.00371211077398967*x_21 - 0.000804018999041721*x_22 - 0.00798037882702431*x_23 - 0.000850943312848385*x_24 + 0.00252756943848281*x_25 - 0.00363871101587175*x_26 - 2.37730981116419e-5*x_27 - 0.00231299670908241*x_28 - 0.000614863298093481*x_29 - 0.000595845827647512*x_3 + 0.00032843405630457*x_30 - 0.000464713182227155*x_32 - 0.00882495990461755*x_33 + 0.000544081609303872*x_34 + 0.0102145642335736*x_35 - 0.00390461733947045*x_36 - 0.00337845277826316*x_37 - 0.00941862425153136*x_38 + 0.00442739448760848*x_39 + 0.000674448602483264*x_4 - 0.000364753743923689*x_40 - 8.19931313494533e-5*x_41 - 0.00496773054006011*x_42 + 0.00382191178743632*x_43 - 0.00775293942800314*x_44 + 0.00655879360999722*x_45 - 0.00165236545379392*x_46 - 0.00734344854092181*x_47 - 0.00438800468144938*x_48 - 0.00638335789556894*x_49 + 0.00193847254917063*x_5 - 0.00893114106955925*x_50 - 0.0061736994860685*x_51 - 0.00916992125018278*x_52 - 0.0047849203144206*x_53 + 0.00718702957995869*x_54 + 0.0092527474427943*x_55 + 0.00544444689462568*x_56 + 0.0126120970819473*x_57 - 0.00262791225104319*x_58 - 0.00237807663023295*x_59 - 0.00951248570395798*x_6 + 0.00319284272172769*x_60 + 0.00425363376126763*x_61 - 0.00759739975467824*x_62 - 0.00313527562993977*x_63 + 0.00133035941680689*x_64 - 0.000726841302110058*x_65 - 0.00196694445093996*x_66 + 0.00294277893585317*x_67 + 0.00145670153026513*x_68 - 0.00480958987429419*x_69 - 0.00208245242220154*x_7 + 0.000452916419991208*x_70 - 0.00266908192189878*x_71 + 0.0022525696540293*x_72 + 0.000325041079336432*x_73 + 0.00152887054535519*x_74 + 0.00316938391494352*x_75 - 0.00623389311153499*x_76 + 0.00231472089496236*x_77 - 0.000381098050884525*x_78 - 0.00324577680083447*x_79 - 1.41307567262482e-5*x_8 + 0.00292801416868716*x_80 + 0.00162238995235435*x_81 - 0.00036244320431762*x_82 - 0.00111409029833375*x_83 - 0.00202149397998572*x_84 + 0.00305971904087568*x_85 + 0.00731618811641569*x_86 - 0.00684924712352478*x_87 + 0.00739084610921393*x_88 - 0.00440615154723485*x_89 - 0.00850336363921904*x_9 - 9.63351326760595e-5*x_90 - 0.000596535248552579*x_91 + 0.00145308266729483*x_92 - 0.0053996150528109*x_93 - 0.00112683203196709*x_94 - 5.37268873718978e-5*x_95 + 0.000628106150527461*x_96 + 0.000366604575001912*x_97 + 0.00547158623651599*x_98 + 0.00357182409908513*x_99 - 1.26419531512286e-5*std::pow(-3.34895968437195*x_1 - 4.17543983459473, 2) - 9.30487461751931e-6*std::pow(-5.60767984390259*x_22 - 9.60639953613281, 2) - 1.52555255936353e-5*std::pow(-4.01999998092651*x_27 - 6.62815999984741, 2) + 0.000896108220331371*std::pow(0.077285545415195*x_1 - 0.0858889116874909*x_100 + 0.188659407703213*x_101 - 0.00519139809335242*x_102 - 0.27533190430581*x_103 + 0.213279784108894*x_104 + 0.190920049015156*x_105 - 0.258163488621396*x_106 - 0.185385705840303*x_107 + 0.0454906774588763*x_108 + 0.000856110803537664*x_11 - 0.126665894646825*x_110 - 0.26338177862485*x_111 - 0.167586146364681*x_112 - 0.0684405336845563*x_113 + 0.0254650858509289*x_114 + 0.0293716323967535*x_115 - 0.211534865647385*x_116 - 0.0886220090504858*x_118 - 0.0963844494985745*x_119 - 0.0161736518198645*x_12 - 0.411682417985753*x_120 + 0.104855812397106*x_13 - 0.0106869298815571*x_17 + 0.0466138228740917*x_2 - 0.117189157989148*x_21 + 0.0318622435435952*x_23 + 0.00937023409726414*x_24 + 0.0267862546214551*x_27 - 0.110668053765342*x_31 - 0.0419785273096018*x_32 + 0.0316946054453094*x_34 - 0.0320831163161734*x_38 + 0.220556918019311*x_39 + 0.19028992599834*x_40 + 0.193326524554007*x_41 + 0.233851963164472*x_43 - 0.0693190612833737*x_44 - 0.115349093028593*x_45 - 0.187429376821673*x_46 + 0.213681389238579*x_47 - 0.0512012739773674*x_48 - 0.228153224037169*x_49 + 0.013404899975307*x_5 + 0.159092412795609*x_50 + 0.111403900403332*x_51 - 0.0328354567778024*x_52 + 0.146695199235155*x_53 + 0.146895272231774*x_54 + 0.189061257197903*x_55 + 0.0369090694712813*x_56 + 0.265041659469356*x_58 - 0.015869688607837*x_6 - 0.0197201719293506*x_60 + 0.0686375614821562*x_61 + 0.0910759189828006*x_62 - 0.0121395471369076*x_63 + 0.0895288142033673*x_64 + 0.00379417998227838*x_65 + 0.0144628816351141*x_66 - 0.0396363936086912*x_67 - 0.0915402706848821*x_68 + 0.0642927926917913*x_69 - 0.0686439809205887*x_70 - 0.0533549175059446*x_71 - 0.0581804317799174*x_72 + 0.00381785812099541*x_73 + 0.0684513193655657*x_74 - 0.136706297840119*x_75 - 0.0852831985127264*x_76 + 0.0117951704014096*x_77 + 0.00332717894796291*x_78 - 0.08253422157757*x_79 + 0.00217543509319647*x_80 + 0.080815729521864*x_81 - 0.103384600341059*x_82 + 0.117481588190367*x_83 + 0.0164656372058033*x_84 + 0.0711682757803194*x_85 - 0.113406397114713*x_86 - 0.0755315216967627*x_87 - 0.108862146971233*x_88 + 0.112625886571383*x_89 + 0.0934058819282893*x_90 + 0.114623766590947*x_93 - 0.116580539498954*x_94 - 0.0354789508647618*x_98 + 0.0870573296800499*x_99 - 2.25559214186177*std::sin(0.146240040659904*x_10 + 8.17375946044922) + 1.24882945101896*std::sin(0.23327998816967*x_109 + 1.95511984825134) - 1.35593389049518*std::sin(0.232319980859756*x_117 + 5.17903995513916) + 1.68544809238095*std::sin(0.247759968042374*x_14 + 8.37184047698975) - 0.66058065160626*std::sin(0.333999842405319*x_15 + 8.27744007110596) + 0.87064497414741*std::sin(0.274159938097*x_16 - 1.17031991481781) - 0.304774279122938*std::sin(0.269839972257614*x_18 + 8.2186393737793) + 1.48603782632784*std::sin(0.249119967222214*x_19 - 7.57503986358643) - 1.51716692546879*std::sin(0.262159943580627*x_20 + 8.19703960418701) - 1.08272096228177*std::sin(0.398239850997925*x_22 + 5.19063997268677) + 0.216081859763104*std::sin(0.374479830265045*x_25 - 7.5918402671814) + 0.995142378558938*std::sin(0.296079933643341*x_26 + 1.99919974803925) - 1.20955716609858*std::sin(0.231039986014366*x_28 - 1.15839993953705) + 2.40326285688374*std::sin(0.106960065662861*x_29 - 4.49688005447388) - 0.89172812628231*std::sin(0.396639823913574*x_3 + 2.00367975234985) - 2.51611831238228*std::sin(0.145920038223267*x_30 - 4.45616006851196) + 0.646714877931103*std::sin(0.210879996418953*x_33 + 2.16375994682312) - 1.07579447628031*std::sin(0.216480001807213*x_35 - 7.40999984741211) - 1.47160391083283*std::sin(0.231439992785454*x_36 + 1.96879982948303) + 1.91863181426497*std::sin(0.2223199903965*x_37 - 1.1904798746109) + 0.364864697522275*std::sin(0.443599849939346*x_4 + 5.17671966552734) - 0.372926896196859*std::sin(0.222159996628761*x_42 + 4.99399995803833) + 1.61794289133195*std::sin(0.214560002088547*x_57 - 7.41511964797974) - 1.49067563778151*std::sin(0.222719997167587*x_59 - 1.18319988250732) - 1.15486830211026*std::sin(0.364639848470688*x_7 + 1.99303984642029) + 0.989785630000739*std::sin(0.34215983748436*x_8 - 1.14503979682922) - 0.858498410961744*std::sin(0.259759962558746*x_9 + 5.17736005783081) - 0.912722508136035*std::sin(0.356399834156036*x_91 + 5.21304035186768) + 1.98538249797487*std::sin(0.299279928207397*x_92 - 7.40520000457764) - 1.61626040301023*std::sin(0.278959959745407*x_95 + 1.97447979450226) - 0.728183878605563*std::sin(0.278159946203232*x_96 - 7.4423999786377) + 1.64165519441468*std::sin(0.27567994594574*x_97 + 1.97919988632202) - 4.36824930933441, 2) - 0.00276045921782756*std::exp(0.163839861750603*x_49) + 0.0164572620751364*std::sin(0.329999834299088*x_1 + 5.14520025253296) - 0.00516658661588492*std::sin(0.342239856719971*x_1 + 8.34768009185791) + 0.00936163974098402*std::sin(0.359039843082428*x_1 - 1.03663980960846) - 0.0064773520178013*std::sin(0.408399850130081*x_1 + 8.39400005340576) + 0.0366678577391964*std::sin(0.339839845895767*x_10 + 5.03247976303101) - 0.00707406596032941*std::sin(0.352079838514328*x_10 + 8.25903987884521) + 0.00622196130601004*std::sin(0.366479843854904*x_10 + 8.24079990386963) - 0.00579116331493533*std::sin(0.242079973220825*x_100 + 1.9755197763443) + 0.0134741248739436*std::sin(0.257839977741241*x_100 + 1.95887982845306) - 0.00810500259513379*std::sin(0.229919984936714*x_101 + 1.98535978794098) + 0.0401407684901545*std::sin(0.221599996089935*x_102 + 1.97327971458435) + 0.010954756127464*std::sin(0.239359974861145*x_102 - 1.2099198102951) - 0.0134981625413184*std::sin(0.247999966144562*x_107 + 5.15144014358521) + 0.0159615470770067*std::sin(0.23471999168396*x_109 + 1.98399984836578) - 0.00885223359556746*std::sin(0.246079966425896*x_109 - 7.44191980361938) + 0.0481769025978513*std::sin(0.247759968042374*x_109 - 1.21407985687256) + 0.0101439471813836*std::sin(0.252159982919693*x_109 - 1.214399933815) - 0.0133383685058668*std::sin(0.216800004243851*x_11 + 5.18383979797363) - 0.00841013389250262*std::sin(0.218799993395805*x_11 + 2.00231981277466) - 0.0393819817068534*std::sin(0.248719975352287*x_11 - 7.41408014297485) + 0.0105278359344053*std::sin(0.25655996799469*x_11 + 8.37376022338867) + 0.033151220638076*std::sin(0.210319995880127*x_110 + 5.17592000961304) - 0.0448301645703063*std::sin(0.216240003705025*x_110 - 7.42695951461792) - 0.00277560424316949*std::sin(0.219759985804558*x_110 - 4.41991996765137) + 0.0149191519355905*std::sin(0.216879993677139*x_111 + 1.98231983184814) - 0.0181989564994828*std::sin(0.267279952764511*x_112 - 1.20023989677429) - 0.00738845994085012*std::sin(0.278399974107742*x_112 + 1.96583986282349) + 0.021484442321067*std::sin(0.290479928255081*x_112 + 1.95439982414246) + 0.0147384063285426*std::sin(0.293919950723648*x_113 + 1.96367979049683) + 0.00364831340997563*std::sin(0.237119987607002*x_116 + 8.16991996765137) - 0.0102180088033653*std::sin(0.250639975070953*x_116 - 4.40895986557007) + 0.00347134420745895*std::sin(0.265759944915771*x_119 + 8.15824031829834) + 0.00976953616450669*std::sin(0.277439951896667*x_12 - 7.43567991256714) + 0.0110051023704779*std::sin(0.285599917173386*x_12 + 5.13567972183228) + 0.0186699677531051*std::sin(0.248639971017838*x_13 + 1.98823988437653) + 0.0108012749842456*std::sin(0.289919942617416*x_13 - 7.4443998336792) + 0.0361956365538907*std::sin(0.310239940881729*x_13 + 8.31328010559082) - 0.0424802775738649*std::sin(0.265839964151382*x_14 + 1.98951983451843) - 0.0133589079377564*std::sin(0.281199961900711*x_14 + 5.17095994949341) + 0.00669376318659451*std::sin(0.304159939289093*x_14 - 4.2577600479126) - 0.003585466385892*std::sin(0.346159845590591*x_14 - 1.13391983509064) - 0.0074574468180214*std::sin(0.357839852571487*x_14 + 8.01512050628662) - 0.00442268414851357*std::sin(0.300879925489426*x_15 - 7.43351984024048) - 0.0077434830493268*std::sin(0.279039949178696*x_16 - 1.19951987266541) + 0.00685247954660852*std::sin(0.306239932775497*x_16 + 1.99111986160278) - 0.022571740881715*std::sin(0.310719937086105*x_16 + 1.98639988899231) + 0.0099098058396359*std::sin(0.321919918060303*x_16 + 1.98375976085663) - 0.00628953411637477*std::sin(0.328959852457047*x_16 - 7.32767963409424) + 0.00926208494327611*std::sin(0.461359858512878*x_16 - 1.4119998216629) + 0.00805157327870672*std::sin(0.288959950208664*x_17 + 2.01887989044189) - 0.0109681956449234*std::sin(0.3503198325634*x_17 + 2.00575995445251) + 0.00701309192004363*std::sin(0.351999849081039*x_17 - 4.17120027542114) + 0.0311531198204448*std::sin(0.359679847955704*x_17 + 2.02319979667664) - 0.00338070189242531*std::sin(0.389599829912186*x_17 + 8.19871997833252) + 0.0550040320044145*std::sin(0.22095999121666*x_18 + 5.01007986068726) + 0.0111720058711572*std::sin(0.275279939174652*x_18 - 1.15727984905243) + 0.00821162326465318*std::sin(0.303439915180206*x_18 - 4.37415981292725) + 0.00434184518966338*std::sin(0.316159933805466*x_18 + 2.18255996704102) + 0.00750816903880803*std::sin(0.39743983745575*x_18 - 1.19631993770599) + 0.00525751769176254*std::sin(0.417519867420197*x_18 - 1.214479804039) + 0.0122744443613757*std::sin(0.270559966564178*x_19 + 5.01200008392334) + 0.0253117311630733*std::sin(0.345519840717316*x_2 - 7.40919971466064) + 0.0142231115709323*std::sin(0.391199827194214*x_2 - 4.21216011047363) - 0.00291929336378209*std::sin(0.423679858446121*x_2 + 5.21167993545532) + 0.0058860376074275*std::sin(0.269199967384338*x_20 + 2.0066397190094) + 0.0116531287723833*std::sin(0.273679971694946*x_20 - 7.41055965423584) - 0.0103336315069754*std::sin(0.282879948616028*x_20 + 1.99935972690582) - 0.0114788142020737*std::sin(0.289679944515228*x_20 + 1.98439979553223) + 0.04289219499795*std::sin(0.327519834041595*x_20 + 8.24312019348145) - 0.00909837274055312*std::sin(0.341679841279984*x_20 + 8.24327945709229) + 0.00824321868524215*std::sin(0.311999946832657*x_21 + 1.99287974834442) - 0.0202306483514519*std::sin(0.343839854001999*x_21 + 8.24991989135742) + 0.00369793088520068*std::sin(0.436479866504669*x_21 + 1.78887987136841) + 0.00800053630683042*std::sin(0.353279858827591*x_22 - 7.37287998199463) - 0.0412975093950294*std::sin(0.373279839754105*x_22 + 1.98695981502533) + 0.0109603380648139*std::sin(0.212559998035431*x_23 - 1.18399977684021) - 0.00705599097470463*std::sin(0.323359936475754*x_23 + 5.21583986282349) - 0.00694783973677764*std::sin(0.344639837741852*x_23 - 1.16903984546661) + 0.00278851465569702*std::sin(0.3503198325634*x_23 + 2.028639793396) - 0.00595457289498438*std::sin(0.294959932565689*x_24 + 8.21343994140625) - 0.0137488452604724*std::sin(0.331279844045639*x_24 + 2.03863978385925) - 0.0141004464950359*std::sin(0.366319835186005*x_24 + 1.78495991230011) - 0.026905748780917*std::sin(0.410559862852097*x_24 + 1.98767983913422) + 0.00874443867251399*std::sin(0.439119875431061*x_25 - 1.39551985263824) - 0.00814536512106049*std::sin(0.313919931650162*x_26 - 1.18519985675812) + 0.00863820423027881*std::sin(0.339119851589203*x_26 + 5.02279996871948) - 0.0033582841784276*std::sin(0.359279841184616*x_26 - 1.14727985858917) + 0.00408685235876727*std::sin(0.399359852075577*x_26 - 1.20367991924286) + 0.0189960340368505*std::sin(0.20040000975132*x_27 + 8.20024013519287) - 0.00815319792112577*std::sin(0.223039999604225*x_27 + 8.21224021911621) + 0.00905085152478123*std::sin(0.329599827528*x_27 + 2.0319197177887) - 0.02481256901856*std::sin(0.112960062921047*x_28 + 5.09511995315552) + 0.00290661967431369*std::sin(0.284159928560257*x_28 - 1.17151987552643) - 0.0220347855040462*std::sin(0.310159921646118*x_28 + 1.99215984344482) + 0.0120642559915769*std::sin(0.326479852199554*x_28 - 1.12615978717804) - 0.00913520637041455*std::sin(0.335039854049683*x_28 + 8.22056007385254) - 0.133683113025276*std::sin(0.0978400707244873*x_29 - 7.69432020187378) + 0.0323096218826017*std::sin(0.271039962768555*x_29 + 5.00927972793579) - 0.00670091513073869*std::sin(0.314319908618927*x_29 + 1.99423980712891) + 0.00550939392721671*std::sin(0.3572798371315*x_29 + 8.236159324646) + 0.00741052609009685*std::sin(0.263759940862656*x_3 + 8.26399993896484) + 0.00893924855015454*std::sin(0.291919946670532*x_3 - 4.32488012313843) - 0.0324074328226234*std::sin(0.308879911899567*x_3 - 1.10775983333588) - 0.0102086540980951*std::sin(0.319359928369522*x_3 + 5.25487995147705) + 0.00414060016061451*std::sin(0.37967985868454*x_3 - 1.19287979602814) - 0.00661609083160364*std::sin(0.383679836988449*x_3 + 8.18943977355957) - 0.00638502429620038*std::sin(0.386799842119217*x_3 - 1.1865599155426) + 0.00417814478948294*std::sin(0.338719844818115*x_31 + 2.12823987007141) + 0.0060784740934069*std::sin(0.34079983830452*x_31 - 1.05159986019135) - 0.015752262117486*std::sin(0.346719831228256*x_31 - 4.22328042984009) + 0.00637144800951062*std::sin(0.35335984826088*x_31 + 5.17592000961304) - 0.0124356509396944*std::sin(0.382319837808609*x_31 - 4.20591974258423) + 0.0124166878654074*std::sin(0.410959839820862*x_31 - 4.19831991195679) + 0.00588143072827219*std::sin(0.443759858608246*x_31 - 1.16527986526489) + 0.000301290661334082*std::sin(0.591199815273285*x_31 - 4.39583969116211) + 0.00408099048076495*std::sin(0.254879981279373*x_32 - 1.16591989994049) - 0.0058508591056385*std::sin(0.311599940061569*x_32 + 2.01239991188049) + 0.00843790100311473*std::sin(0.312719941139221*x_32 - 7.36104011535645) + 0.00870420771275184*std::sin(0.316399931907654*x_32 - 4.34007978439331) + 0.00915906243310006*std::sin(0.319839835166931*x_32 + 2.00407981872559) + 0.00227075267514366*std::sin(0.348159849643707*x_32 - 1.19095981121063) + 0.00135732662416654*std::sin(0.366799831390381*x_32 + 7.98663997650146) + 0.0143534855938539*std::sin(0.251279979944229*x_33 - 7.4314398765564) + 0.00589049546019221*std::sin(0.254719972610474*x_33 + 1.96607983112335) + 0.0568354740530292*std::sin(0.264319956302643*x_33 - 1.22359991073608) + 0.00310448682554044*std::sin(0.289119929075241*x_33 + 4.96567964553833) - 0.00389629179554867*std::sin(0.224159985780716*x_34 + 5.17888021469116) + 0.0151077993885567*std::sin(0.239119976758957*x_34 + 1.97639977931976) - 0.0605445416727148*std::sin(0.243359968066216*x_34 + 1.97447979450226) + 0.00229881405463827*std::sin(0.230159983038902*x_35 + 5.16847991943359) - 0.0143056316976171*std::sin(0.241999983787537*x_36 + 1.98503983020782) - 0.0162278516750502*std::sin(0.243279978632927*x_36 + 5.17535972595215) + 0.0563085424755205*std::sin(0.261199980974197*x_36 - 1.21743988990784) + 0.00307242393119433*std::sin(0.233679980039597*x_38 - 4.23104000091553) - 0.00766346296918784*std::sin(0.246639966964722*x_38 - 4.40207958221436) - 0.0154255417664431*std::sin(0.32551982998848*x_4 + 5.22919988632202) + 0.0049526663136704*std::sin(0.332879841327667*x_4 - 1.16815984249115) - 0.00392687484050902*std::sin(0.382559835910797*x_4 + 2.01575970649719) - 0.00230126222132362*std::sin(0.416159868240356*x_4 - 4.40927982330322) + 0.00928850443427703*std::sin(0.225519984960556*x_40 + 1.99303984642029) - 0.00905584226446534*std::sin(0.23047998547554*x_40 + 1.9651198387146) - 0.0186289367854063*std::sin(0.236319988965988*x_41 - 7.4236798286438) + 0.00801617313291389*std::sin(0.241679981350899*x_41 - 7.42560005187988) + 0.0280427426960862*std::sin(0.229359999299049*x_42 + 1.96647977828979) + 0.0147660503157751*std::sin(0.25639995932579*x_42 + 5.14743995666504) - 0.0593629605757931*std::sin(0.211759999394417*x_43 - 1.20295989513397) - 0.0122494561621959*std::sin(0.242719978094101*x_44 - 1.20631992816925) + 0.0266409711660478*std::sin(0.260479986667633*x_44 + 1.94247984886169) - 0.00426736240462307*std::sin(0.267679959535599*x_44 - 7.4443998336792) + 0.0175347189291277*std::sin(0.194399997591972*x_46 - 7.60128021240234) - 0.00718799101373962*std::sin(0.249199971556664*x_46 + 1.97567975521088) + 0.0352364198187652*std::sin(0.207040011882782*x_47 - 7.58816003799438) - 0.0154363215340297*std::sin(0.253199964761734*x_48 - 1.20247983932495) - 0.00656272838083608*std::sin(0.309839934110641*x_5 + 1.81447994709015) + 0.00638164682726351*std::sin(0.364319831132889*x_5 - 1.16543984413147) + 0.0361773192763599*std::sin(0.388639837503433*x_5 + 2.00431990623474) + 0.00272745128849616*std::sin(0.388959854841232*x_5 + 4.98991966247559) + 0.0214049926416521*std::sin(0.408159852027893*x_5 - 1.17863988876343) + 0.011769502599157*std::sin(0.181120008230209*x_50 - 7.37967967987061) + 0.0144207369286896*std::sin(0.242479979991913*x_53 + 1.96927976608276) - 0.022100532240485*std::sin(0.247439980506897*x_53 + 1.98375976085663) + 0.0126817131839881*std::sin(0.265359938144684*x_6 + 5.20975971221924) + 0.0052777645181889*std::sin(0.477919846773148*x_6 + 4.96743965148926) + 0.0051470260584143*std::sin(0.255839973688126*x_60 + 8.34751987457275) + 0.0242402582490433*std::sin(0.327759832143784*x_60 - 7.52952003479004) - 0.00630364308174762*std::sin(0.390639841556549*x_60 - 4.37255954742432) - 0.00379612498512122*std::sin(0.490879863500595*x_60 + 1.69871997833252) + 0.0511638260373103*std::sin(0.149440035223961*x_61 - 1.27567994594574) + 0.00838370135765457*std::sin(0.240959972143173*x_61 + 8.25207996368408) - 0.0123380222085866*std::sin(0.285119920969009*x_7 + 8.39744091033936) - 0.0124225947317085*std::sin(0.336559861898422*x_7 + 5.23784017562866) - 0.00496165575956116*std::sin(0.349679857492447*x_7 + 2.00879979133606) - 0.0112289700745153*std::sin(0.352479845285416*x_7 - 7.59647989273071) - 0.00461208422243625*std::sin(0.39031982421875*x_7 + 1.9793598651886) + 0.00641889419294778*std::sin(0.457919865846634*x_7 + 7.9870400428772) + 0.00566631095012316*std::sin(0.323199838399887*x_8 - 1.12079977989197) + 0.0122635246963024*std::sin(0.334079831838608*x_8 + 8.25943946838379) - 0.00430864477269386*std::sin(0.335839837789536*x_8 - 4.34151983261108) - 0.00574825794974131*std::sin(0.334879845380783*x_9 + 5.06487989425659) + 0.0292115266302465*std::sin(0.333039849996567*x_91 + 8.41728019714355) - 0.00469837779746845*std::sin(0.34775984287262*x_91 + 5.19016027450562) - 0.00421829810334404*std::sin(0.353039860725403*x_91 + 5.20071983337402) + 0.0272273612101606*std::sin(0.367759823799133*x_91 + 5.19528007507324) + 0.00221015416967991*std::sin(0.484399855136871*x_91 - 7.60904026031494) + 0.0267805559030835*std::sin(0.268319964408875*x_92 - 7.3744797706604) - 0.00695840345154003*std::sin(0.289279937744141*x_92 + 2.00223970413208) - 0.006613252157212*std::sin(0.300959944725037*x_92 + 1.80455982685089) - 0.00360260834216561*std::sin(0.316799849271774*x_92 + 8.22192001342773) - 0.00767501507292732*std::sin(0.285599917173386*x_94 + 1.98791980743408) + 0.0161387262061184*std::sin(0.287359952926636*x_94 + 1.9755197763443) - 0.00713403238206418*std::sin(0.261279970407486*x_95 - 7.41343975067139) - 0.00913403784168194*std::sin(0.281039953231812*x_95 + 1.97343981266022) - 0.00706106192956972*std::sin(0.281679958105087*x_95 + 1.96399986743927) - 0.0364949260603993*std::sin(0.28263995051384*x_95 - 4.40463972091675) + 0.0100202205604565*std::sin(0.273119956254959*x_96 + 8.19167995452881) - 0.00881220597650115*std::sin(0.262239962816238*x_97 + 5.17519998550415) - 0.0132723978512684*std::sin(0.273119956254959*x_97 + 1.97847986221313) - 0.0480980642627497*std::sin(0.28383994102478*x_97 + 8.18407917022705) - 0.00564007587944762*std::sin(0.284799933433533*x_97 + 8.18175983428955) - 0.0272502957507742*std::sin(0.248399972915649*x_99 + 1.98031985759735) + 0.00760063482448459*std::sin(0.0119927355422544*x_1 - 0.0154447621798775*x_10 + 0.0452463304471529*x_100 + 0.132034932078636*x_101 + 0.0348047875074846*x_102 - 0.0187730923046057*x_103 - 0.247747578303853*x_104 + 0.149721881670313*x_105 + 0.0622206404698517*x_106 - 0.0911558986463845*x_107 + 0.112554857856233*x_109 + 0.155409944856561*x_11 - 0.0301294357516481*x_110 + 0.082656136078175*x_112 + 0.052170483074845*x_113 - 0.0463226522528929*x_114 + 0.0777860475660229*x_115 + 0.240040719692949*x_116 - 0.0996989897919612*x_119 - 0.143522897288294*x_12 + 0.0305006167003303*x_120 - 0.186634562585763*x_14 + 0.0867633358052754*x_16 + 0.0156421292408191*x_19 + 0.0922853179458372*x_2 + 0.0154657538728079*x_21 - 0.101423151554714*x_23 + 0.0595240859932556*x_24 - 0.312019018317097*x_25 - 0.261778473800592*x_26 - 0.0287161765077394*x_27 - 0.0094669402638329*x_28 - 0.0160348430914803*x_29 - 0.124680499339138*x_30 - 0.0441439128794199*x_32 + 0.115659124338327*x_33 + 0.230451875140237*x_34 - 0.174147504339351*x_35 + 0.016600575474814*x_37 + 0.122959765511707*x_38 - 0.175143119069781*x_39 + 0.190272278750024*x_40 + 0.0851239895679479*x_42 + 0.181804766921989*x_43 + 0.0281301179559583*x_44 + 0.114097712690027*x_45 - 0.041701338474559*x_46 - 0.0828089170800816*x_47 + 0.0707397713678762*x_48 + 0.155043284995433*x_5 - 0.0517577239893402*x_50 + 0.111741509960204*x_51 - 0.0201825410072283*x_53 + 0.354887999087525*x_54 - 0.143189638939492*x_55 + 0.144342583047945*x_56 - 0.299304760925661*x_57 - 0.28160697944802*x_58 + 0.0153812523709955*x_59 + 0.171450451994333*x_6 - 0.195305979523774*x_60 - 0.0105444305115496*x_61 + 0.0599076255273589*x_62 + 0.0435181559441902*x_63 - 0.147428035468694*x_64 - 0.124748943459455*x_65 + 0.0364409936460307*x_66 - 0.0651329363478558*x_67 - 0.0520159411709521*x_68 + 0.0859492367383897*x_69 + 0.112650562576561*x_7 - 0.0354351337053182*x_70 - 0.0414477321401909*x_71 + 0.078370444150791*x_72 - 0.00468167371425494*x_73 + 0.0414021365686777*x_74 - 0.0472147830760453*x_75 - 0.109991938708653*x_76 - 0.133346627808886*x_77 + 0.0832451974000935*x_78 - 0.0562732129916176*x_79 - 0.0570699293188713*x_8 + 0.0541369238633309*x_80 + 0.00296816997914418*x_81 - 0.0335037299858218*x_82 - 0.0292352728903791*x_83 + 0.0509748120716008*x_84 - 0.114838754199298*x_85 + 0.117404538413014*x_86 - 0.13014428294505*x_87 + 0.136233349860719*x_88 + 0.0567776082396429*x_89 + 0.0465038192908639*x_90 - 0.289878374511743*x_93 - 0.0844515741115684*x_95 + 0.0950498499321393*x_96 + 0.0123041834607245*x_97 - 0.00411268749028151*x_98 + 0.199764431863474*x_99 + 0.762500429212487*std::sin(0.246319979429245*x_108 + 1.97391986846924) + 1.53693984221519*std::sin(0.213039994239807*x_111 - 7.41463994979858) + 0.877126948763873*std::sin(0.225919991731644*x_117 - 7.40279960632324) + 1.64716858628289*std::sin(0.23471999168396*x_118 - 7.41639995574951) + 0.834264512381289*std::sin(0.389119833707809*x_13 + 4.99919986724854) + 1.14080162673851*std::sin(0.280799955129623*x_15 - 1.3802398443222) + 0.613890804312689*std::sin(0.257359951734543*x_17 + 8.24071979522705) - 1.09786425406817*std::sin(0.341119825839996*x_18 - 7.36839962005615) - 0.919583927356626*std::sin(0.366719841957092*x_20 + 1.7992799282074) + 0.594757995856732*std::sin(0.338159829378128*x_22 + 2.02815985679626) - 1.01984431743887*std::sin(0.377999842166901*x_3 + 1.98583984375) + 1.75133226668329*std::sin(0.40871986746788*x_31 - 4.19944000244141) - 1.63141651872074*std::sin(0.209199994802475*x_36 + 1.98423981666565) - 0.529832040560585*std::sin(0.313199937343597*x_4 + 2.00671982765198) + 0.693745117590971*std::sin(0.26199996471405*x_41 + 1.97463977336884) + 1.40521422963644*std::sin(0.296239942312241*x_49 + 5.06767988204956) - 0.925374774915078*std::sin(0.215199992060661*x_52 - 1.20711994171143) - 1.06800541559693*std::sin(0.280479967594147*x_9 + 1.99911975860596) + 1.80627347752349*std::sin(0.400319844484329*x_91 + 1.97431981563568) + 2.49076263701014*std::sin(0.286079943180084*x_92 + 5.21439981460571) - 0.500168354813546*std::sin(0.270399957895279*x_94 + 5.1864800453186) + 13.0513828790187) + 0.300798301739382);
}

inline float score_1(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.00406921941817487*x_1 - 0.000250001966014518*x_10 + 0.00659940080392674*x_100 - 0.00226023483804906*x_101 - 0.00224083295309371*x_102 + 0.00507171507411903*x_103 - 0.0152609367454628*x_104 + 0.0038621137109839*x_105 - 0.00131744602408738*x_106 - 0.00547131230635192*x_107 + 0.00367811547015277*x_108 + 0.00100793418831637*x_109 + 0.000931302402267*x_11 + 0.000430651283693083*x_110 - 0.00492760524685948*x_111 + 0.0116836011503724*x_112 + 0.000736492097869446*x_113 + 0.000516661258807425*x_114 + 0.00186050644584518*x_115 + 0.0215240767987969*x_116 + 0.0096871890181379*x_117 - 0.00979102665366783*x_118 + 0.0127860540715929*x_119 - 0.000692633799600656*x_12 + 0.00859594452439129*x_120 - 0.00118940567994108*x_13 + 0.000257091504443646*x_14 + 0.00399280496432599*x_15 + 0.00136632477547165*x_16 + 0.00584906178165695*x_17 + 0.00208431169178423*x_18 - 0.00370768149605235*x_19 + 0.00124170962387716*x_2 + 0.000297639462227542*x_20 + 0.00264175016538803*x_21 + 0.00172935192710086*x_22 + 0.00702439239127036*x_23 - 0.00177522751597791*x_24 - 0.00890441494392935*x_25 - 0.00137024033922125*x_26 - 0.00196996797389984*x_27 + 0.00224902987871051*x_28 - 4.34190440353076e-5*x_29 - 0.000264736930259011*x_3 - 0.00787567173633227*x_30 - 0.000184675969087776*x_32 + 0.00965816066158747*x_33 + 0.00483874471100736*x_34 - 0.0115752556681392*x_35 + 0.00330085382151682*x_36 + 0.00415419552355776*x_37 + 0.00813438071238852*x_38 - 0.011001253178069*x_39 + 0.00254460189991187*x_4 - 0.00105863343485484*x_40 - 0.000839065116262356*x_41 + 0.0130253319424275*x_42 + 0.000562280689161305*x_43 + 0.00542075063848827*x_44 - 0.0141701452194593*x_45 - 0.000287120575232331*x_46 + 0.00424794918985668*x_47 - 0.00231121405043564*x_48 + 0.0104708750973401*x_49 + 0.00383670279071695*x_5 + 0.0118965109194861*x_50 + 4.0518624127128e-5*x_51 + 0.0057248168044684*x_52 + 0.0023662790630931*x_53 - 0.00897976204768282*x_54 - 0.00726381171241634*x_55 + 0.000467848169849879*x_56 - 0.0182518550043768*x_57 - 0.0056324552688524*x_58 + 0.00633317597975545*x_59 + 0.0136358097492582*x_6 - 0.0071489227091655*x_60 - 0.00200341998519706*x_61 + 0.0091209643345193*x_62 + 0.00317752009952426*x_63 - 0.000346182448114921*x_64 - 0.00165905482529653*x_65 + 0.00271309672137946*x_66 - 0.00454908073751718*x_67 - 0.0037883918588337*x_68 + 0.00281438066454077*x_69 + 0.00288103596964118*x_7 - 6.88669974350895e-5*x_70 + 0.00188934846812579*x_71 + 0.000225827979704027*x_72 - 0.00364869280060183*x_73 - 0.000380431446877289*x_74 - 0.00312239316898025*x_75 + 0.00395361837681372*x_76 - 0.00109107837559752*x_77 + 0.000850964524697137*x_78 + 0.00239867966405583*x_79 - 0.000539139063006935*x_8 - 0.00325192731583112*x_80 + 0.00016310756011311*x_81 - 0.00211446360417483*x_82 + 0.00142090595187911*x_83 - 0.000420952095455995*x_84 - 0.00464785627680461*x_85 - 0.00401065996611412*x_86 + 0.00277448750342702*x_87 - 0.00303945253882394*x_88 + 0.00554715083003423*x_89 + 0.00657471526885338*x_9 + 0.00145719169438743*x_90 - 0.000193535543850247*x_91 + 0.000189258816454619*x_92 + 0.0043409492805097*x_93 + 0.00215314011816796*x_94 - 0.0017650731451891*x_95 + 0.00498278477648118*x_96 - 0.00177478637670407*x_97 - 0.00749835012553229*x_98 + 0.00220555090379927*x_99 - 1.46314406669573e-5*std::pow(-3.34895968437195*x_1 - 4.17543983459473, 2) - 1.07691999211751e-5*std::pow(-5.60767984390259*x_22 - 9.60639953613281, 2) - 6.7780973328154e-6*std::pow(-4.01999998092651*x_27 - 6.62815999984741, 2) + 0.00234631547668999*std::exp(0.163839861750603*x_49) - 0.0164152438291006*std::exp(-0.0235074218730369*x_1 + 0.0261242496304735*x_100 - 0.0573832566409597*x_101 + 0.00157903246248322*x_102 + 0.0837458439977675*x_103 - 0.0648718700903711*x_104 - 0.0580708606261289*x_105 + 0.0785238430632197*x_106 + 0.0563875168766281*x_107 - 0.0138365918306091*x_108 - 0.000260397435519265*x_11 + 0.0385271088712939*x_110 + 0.0801110550562003*x_111 + 0.0509735452018498*x_112 + 0.0208170944501394*x_113 - 0.00774554301085638*x_114 - 0.00893377086415041*x_115 + 0.0643411300381609*x_116 + 0.0269555573787317*x_118 + 0.0293166064131565*x_119 + 0.0049194303348012*x_12 + 0.12521865796913*x_120 - 0.0318932835967817*x_13 + 0.00325057121488508*x_17 - 0.0141782113787199*x_2 + 0.0356446339480094*x_21 - 0.00969132321932837*x_23 - 0.00285008075947661*x_24 - 0.00814739398424855*x_27 + 0.0336611537610802*x_31 + 0.0127683248630033*x_32 - 0.00964033387226191*x_34 + 0.00975850459739034*x_38 - 0.0670853067160652*x_39 - 0.0578792003679445*x_40 - 0.0588028220222089*x_41 - 0.0711291707189572*x_43 + 0.021084310250734*x_44 + 0.0350849538284062*x_45 + 0.0570091264631381*x_46 - 0.0649940236076836*x_47 + 0.0155735453681133*x_48 + 0.0693958237639706*x_49 - 0.00407727780392229*x_5 - 0.0483900636825992*x_50 - 0.0338849712583905*x_51 + 0.00998733890953314*x_52 - 0.0446192870431887*x_53 - 0.0446801418940107*x_54 - 0.0575054844851237*x_55 - 0.0112263821435366*x_56 - 0.080615929791329*x_58 + 0.00482697589949083*x_6 + 0.00599815138085216*x_60 - 0.0208770230633622*x_61 - 0.0277019465735994*x_62 + 0.00369240398527093*x_63 - 0.0272313741717802*x_64 - 0.00115405007529537*x_65 - 0.00439907693307914*x_66 + 0.0120559338887975*x_67 + 0.0278431852916501*x_68 - 0.019555504112474*x_69 + 0.0208789756205527*x_70 + 0.0162286045608566*x_71 + 0.0176963486154949*x_72 - 0.00116125209467686*x_73 - 0.0208203750578173*x_74 + 0.0415810304341448*x_75 + 0.0259400139489273*x_76 - 0.00358765724173539*x_77 - 0.00101200552776941*x_78 + 0.025103876218556*x_79 - 0.0006616873856353*x_80 - 0.0245811741075477*x_81 + 0.0314457949715751*x_82 - 0.0357335804653888*x_83 - 0.00500824155572421*x_84 - 0.021646773322967*x_85 + 0.0344940571455496*x_86 + 0.022973912336383*x_87 + 0.0331118633000445*x_88 - 0.034256654530095*x_89 - 0.0284106356514069*x_90 - 0.0348643361893145*x_93 + 0.0354595145763095*x_94 + 0.0107913926350674*x_98 - 0.0264796394323773*x_99 + 0.686068213239608*std::sin(0.146240040659904*x_10 + 8.17375946044922) - 0.379848011615429*std::sin(0.23327998816967*x_109 + 1.95511984825134) + 0.4124252449094*std::sin(0.232319980859756*x_117 + 5.17903995513916) - 0.512651352071774*std::sin(0.247759968042374*x_14 + 8.37184047698975) + 0.200924351054924*std::sin(0.333999842405319*x_15 + 8.27744007110596) - 0.264818195937821*std::sin(0.274159938097*x_16 - 1.17031991481781) + 0.092701132105681*std::sin(0.269839972257614*x_18 + 8.2186393737793) - 0.451998079525893*std::sin(0.249119967222214*x_19 - 7.57503986358643) + 0.461466407168565*std::sin(0.262159943580627*x_20 + 8.19703960418701) + 0.329323915544677*std::sin(0.398239850997925*x_22 + 5.19063997268677) - 0.0657241584991519*std::sin(0.374479830265045*x_25 - 7.5918402671814) - 0.302685729793957*std::sin(0.296079933643341*x_26 + 1.99919974803925) + 0.367902826204858*std::sin(0.231039986014366*x_28 - 1.15839993953705) - 0.730984216324863*std::sin(0.106960065662861*x_29 - 4.49688005447388) + 0.271230915793597*std::sin(0.396639823913574*x_3 + 2.00367975234985) + 0.765310697283567*std::sin(0.145920038223267*x_30 - 4.45616006851196) - 0.196706892413378*std::sin(0.210879996418953*x_33 + 2.16375994682312) + 0.327217133122954*std::sin(0.216480001807213*x_35 - 7.40999984741211) + 0.447607813027826*std::sin(0.231439992785454*x_36 + 1.96879982948303) - 0.583577268357988*std::sin(0.2223199903965*x_37 - 1.1904798746109) - 0.110978428439062*std::sin(0.443599849939346*x_4 + 5.17671966552734) + 0.113430652906775*std::sin(0.222159996628761*x_42 + 4.99399995803833) - 0.492118751426233*std::sin(0.214560002088547*x_57 - 7.41511964797974) + 0.453408731282611*std::sin(0.222719997167587*x_59 - 1.18319988250732) + 0.351268484160379*std::sin(0.364639848470688*x_7 + 1.99303984642029) - 0.301056403798405*std::sin(0.34215983748436*x_8 - 1.14503979682922) + 0.26112365792843*std::sin(0.259759962558746*x_9 + 5.17736005783081) + 0.277616634993064*std::sin(0.356399834156036*x_91 + 5.21304035186768) - 0.603880372565282*std::sin(0.299279928207397*x_92 - 7.40520000457764) + 0.491607000327594*std::sin(0.278959959745407*x_95 + 1.97447979450226) + 0.221486767591081*std::sin(0.278159946203232*x_96 - 7.4423999786377) - 0.499331162351879*std::sin(0.27567994594574*x_97 + 1.97919988632202)) - 0.0133661014609658*std::sin(0.329999834299088*x_1 + 5.14520025253296) - 0.00572707755614293*std::sin(0.342239856719971*x_1 + 8.34768009185791) + 0.00415941784304146*std::sin(0.359039843082428*x_1 - 1.03663980960846) - 0.0422641810424296*std::sin(0.339839845895767*x_10 + 5.03247976303101) + 0.00574534712612841*std::sin(0.352079838514328*x_10 + 8.25903987884521) + 0.00276444486126012*std::sin(0.366479843854904*x_10 + 8.24079990386963) - 0.00641941070782644*std::sin(0.242079973220825*x_100 + 1.9755197763443) - 0.0109432856656602*std::sin(0.257839977741241*x_100 + 1.95887982845306) + 0.00658264336639672*std::sin(0.229919984936714*x_101 + 1.98535978794098) - 0.0462671345219233*std::sin(0.221599996089935*x_102 + 1.97327971458435) + 0.00486724648282097*std::sin(0.239359974861145*x_102 - 1.2099198102951) + 0.0114730721153334*std::sin(0.247999966144562*x_107 + 5.15144014358521) + 0.0100126669453054*std::sin(0.246319979429245*x_108 + 1.97391986846924) - 0.0129634964024527*std::sin(0.23471999168396*x_109 + 1.98399984836578) - 0.0555297598223885*std::sin(0.247759968042374*x_109 - 1.21407985687256) + 0.0117403188840909*std::sin(0.252159982919693*x_109 - 1.214399933815) + 0.015248250881486*std::sin(0.216800004243851*x_11 + 5.18383979797363) + 0.00683046198050931*std::sin(0.218799993395805*x_11 + 2.00231981277466) + 0.0453925401507403*std::sin(0.248719975352287*x_11 - 7.41408014297485) - 0.00894837504912969*std::sin(0.25655996799469*x_11 + 8.37376022338867) - 0.0378980479580045*std::sin(0.210319995880127*x_110 + 5.17592000961304) + 0.0516722358049288*std::sin(0.216240003705025*x_110 - 7.42695951461792) - 0.00321240620915783*std::sin(0.219759985804558*x_110 - 4.41991996765137) + 0.0201821089739773*std::sin(0.213039994239807*x_111 - 7.41463994979858) - 0.0121168939020505*std::sin(0.216879993677139*x_111 + 1.98231983184814) + 0.01546861950308*std::sin(0.267279952764511*x_112 - 1.20023989677429) + 0.00600068861751205*std::sin(0.278399974107742*x_112 + 1.96583986282349) - 0.0245607374257467*std::sin(0.290479928255081*x_112 + 1.95439982414246) - 0.0125272457013946*std::sin(0.293919950723648*x_113 + 1.96367979049683) + 0.00404409630602274*std::sin(0.237119987607002*x_116 + 8.16991996765137) - 0.00453990639599266*std::sin(0.250639975070953*x_116 - 4.40895986557007) + 0.0115178689352281*std::sin(0.225919991731644*x_117 - 7.40279960632324) + 0.021629562194809*std::sin(0.23471999168396*x_118 - 7.41639995574951) + 0.00384792881223763*std::sin(0.265759944915771*x_119 + 8.15824031829834) + 0.00434064802376349*std::sin(0.277439951896667*x_12 - 7.43567991256714) - 0.00935403857722306*std::sin(0.285599917173386*x_12 + 5.13567972183228) - 0.0151631955620354*std::sin(0.248639971017838*x_13 + 1.98823988437653) + 0.0125010915773027*std::sin(0.289919942617416*x_13 - 7.4443998336792) - 0.0417198884958133*std::sin(0.310239940881729*x_13 + 8.31328010559082) + 0.0109550268914454*std::sin(0.389119833707809*x_13 + 4.99919986724854) + 0.0489637042579471*std::sin(0.265839964151382*x_14 + 1.98951983451843) + 0.0113547094786287*std::sin(0.281199961900711*x_14 + 5.17095994949341) - 0.00414971785300835*std::sin(0.346159845590591*x_14 - 1.13391983509064) + 0.00605671771855794*std::sin(0.357839852571487*x_14 + 8.01512050628662) + 0.0149802758157034*std::sin(0.280799955129623*x_15 - 1.3802398443222) + 0.0037591615913585*std::sin(0.300879925489426*x_15 - 7.43351984024048) - 0.00896208927817483*std::sin(0.279039949178696*x_16 - 1.19951987266541) - 0.00556538119530451*std::sin(0.306239932775497*x_16 + 1.99111986160278) + 0.026016686053842*std::sin(0.310719937086105*x_16 + 1.98639988899231) - 0.00842306622838977*std::sin(0.321919918060303*x_16 + 1.98375976085663) - 0.00697184666676021*std::sin(0.328959852457047*x_16 - 7.32767963409424) - 0.010588296075235*std::sin(0.461359858512878*x_16 - 1.4119998216629) + 0.008061220595924*std::sin(0.257359951734543*x_17 + 8.24071979522705) - 0.00653924965600348*std::sin(0.288959950208664*x_17 + 2.01887989044189) - 0.00487321771972702*std::sin(0.3503198325634*x_17 + 2.00575995445251) - 0.00596093795017108*std::sin(0.351999849081039*x_17 - 4.17120027542114) - 0.0359077725645348*std::sin(0.359679847955704*x_17 + 2.02319979667664) - 0.0633988596561277*std::sin(0.22095999121666*x_18 + 5.01007986068726) + 0.0129301650685874*std::sin(0.275279939174652*x_18 - 1.15727984905243) + 0.00364846044841955*std::sin(0.303439915180206*x_18 - 4.37415981292725) + 0.00481286504740215*std::sin(0.316159933805466*x_18 + 2.18255996704102) - 0.014416449756617*std::sin(0.341119825839996*x_18 - 7.36839962005615) - 0.00638174007556026*std::sin(0.39743983745575*x_18 - 1.19631993770599) - 0.0042700003548639*std::sin(0.417519867420197*x_18 - 1.214479804039) - 0.0104329448473182*std::sin(0.270559966564178*x_19 + 5.01200008392334) - 0.0291748592454554*std::sin(0.345519840717316*x_2 - 7.40919971466064) - 0.0120892591312507*std::sin(0.391199827194214*x_2 - 4.21216011047363) - 0.00323598939619244*std::sin(0.423679858446121*x_2 + 5.21167993545532) + 0.0051775365303703*std::sin(0.273679971694946*x_20 - 7.41055965423584) - 0.0119598541823275*std::sin(0.282879948616028*x_20 + 1.99935972690582) + 0.00975668078790531*std::sin(0.289679944515228*x_20 + 1.98439979553223) - 0.0494384893601991*std::sin(0.327519834041595*x_20 + 8.24312019348145) + 0.00738942921518191*std::sin(0.341679841279984*x_20 + 8.24327945709229) - 0.0120753867671751*std::sin(0.366719841957092*x_20 + 1.7992799282074) + 0.00954046923407184*std::sin(0.311999946832657*x_21 + 1.99287974834442) + 0.02331829120242*std::sin(0.343839854001999*x_21 + 8.24991989135742) + 0.00164300700858*std::sin(0.436479866504669*x_21 + 1.78887987136841) + 0.00780998081761243*std::sin(0.338159829378128*x_22 + 2.02815985679626) + 0.00355467358168534*std::sin(0.353279858827591*x_22 - 7.37287998199463) + 0.0476004195851124*std::sin(0.373279839754105*x_22 + 1.98695981502533) + 0.00486972656221459*std::sin(0.212559998035431*x_23 - 1.18399977684021) + 0.00599740098329123*std::sin(0.323359936475754*x_23 + 5.21583986282349) + 0.00322734835714896*std::sin(0.3503198325634*x_23 + 2.028639793396) + 0.00483612797242388*std::sin(0.294959932565689*x_24 + 8.21343994140625) - 0.00610867261290423*std::sin(0.331279844045639*x_24 + 2.03863978385925) + 0.0161194486119278*std::sin(0.366319835186005*x_24 + 1.78495991230011) + 0.0310121590862191*std::sin(0.410559862852097*x_24 + 1.98767983913422) - 0.00743253573890245*std::sin(0.439119875431061*x_25 - 1.39551985263824) - 0.00361902166287222*std::sin(0.313919931650162*x_26 - 1.18519985675812) - 0.00734223934388087*std::sin(0.339119851589203*x_26 + 5.02279996871948) + 0.00473000786244065*std::sin(0.399359852075577*x_26 - 1.20367991924286) - 0.015428016952838*std::sin(0.20040000975132*x_27 + 8.20024013519287) - 0.0076929783539892*std::sin(0.329599827528*x_27 + 2.0319197177887) + 0.0210900107955598*std::sin(0.112960062921047*x_28 + 5.09511995315552) + 0.0253977794502734*std::sin(0.310159921646118*x_28 + 1.99215984344482) + 0.013962830238347*std::sin(0.326479852199554*x_28 - 1.12615978717804) + 0.00741934439983752*std::sin(0.335039854049683*x_28 + 8.22056007385254) + 0.154086102640685*std::sin(0.0978400707244873*x_29 - 7.69432020187378) - 0.0369359431129199*std::sin(0.271039962768555*x_29 + 5.00927972793579) - 0.00297724615886269*std::sin(0.314319908618927*x_29 + 1.99423980712891) + 0.00637641742479736*std::sin(0.3572798371315*x_29 + 8.236159324646) - 0.00847161786959871*std::sin(0.263759940862656*x_3 + 8.26399993896484) - 0.0072601932545433*std::sin(0.291919946670532*x_3 - 4.32488012313843) + 0.0373535213777054*std::sin(0.308879911899567*x_3 - 1.10775983333588) - 0.0133919419522478*std::sin(0.377999842166901*x_3 + 1.98583984375) + 0.00458978819321614*std::sin(0.37967985868454*x_3 - 1.19287979602814) + 0.00562349779092012*std::sin(0.383679836988449*x_3 + 8.18943977355957) - 0.00738984736214255*std::sin(0.386799842119217*x_3 - 1.1865599155426) - 0.00493675686085561*std::sin(0.34079983830452*x_31 - 1.05159986019135) + 0.0181564045190884*std::sin(0.346719831228256*x_31 - 4.22328042984009) + 0.0073741345501425*std::sin(0.35335984826088*x_31 + 5.17592000961304) + 0.0142162758001208*std::sin(0.382319837808609*x_31 - 4.20591974258423) + 0.0229973728866976*std::sin(0.40871986746788*x_31 - 4.19944000244141) + 0.00551678920443305*std::sin(0.410959839820862*x_31 - 4.19831991195679) - 0.004999056625689*std::sin(0.443759858608246*x_31 - 1.16527986526489) + 0.000333975816663308*std::sin(0.591199815273285*x_31 - 4.39583969116211) + 0.00181320207705321*std::sin(0.254879981279373*x_32 - 1.16591989994049) - 0.00685301360641311*std::sin(0.312719941139221*x_32 - 7.36104011535645) - 0.0100326616629532*std::sin(0.316399931907654*x_32 - 4.34007978439331) + 0.0106004410039945*std::sin(0.319839835166931*x_32 + 2.00407981872559) - 0.00259589517752237*std::sin(0.348159849643707*x_32 - 1.19095981121063) + 0.00150457457186905*std::sin(0.366799831390381*x_32 + 7.98663997650146) + 0.00637731698086465*std::sin(0.251279979944229*x_33 - 7.4314398765564) - 0.0655098201289734*std::sin(0.264319956302643*x_33 - 1.22359991073608) + 0.00359304565092705*std::sin(0.289119929075241*x_33 + 4.96567964553833) - 0.00431897632875524*std::sin(0.224159985780716*x_34 + 5.17888021469116) + 0.0174853416808049*std::sin(0.239119976758957*x_34 + 1.97639977931976) + 0.0697849732205988*std::sin(0.243359968066216*x_34 + 1.97447979450226) - 0.00186702877756382*std::sin(0.230159983038902*x_35 + 5.16847991943359) - 0.0214227161391778*std::sin(0.209199994802475*x_36 + 1.98423981666565) + 0.0116186109123484*std::sin(0.241999983787537*x_36 + 1.98503983020782) + 0.0137932338549688*std::sin(0.243279978632927*x_36 + 5.17535972595215) - 0.0649024671784083*std::sin(0.261199980974197*x_36 - 1.21743988990784) + 0.00651373570510372*std::sin(0.246639966964722*x_38 - 4.40207958221436) - 0.00695741478409884*std::sin(0.313199937343597*x_4 + 2.00671982765198) + 0.0131112921897889*std::sin(0.32551982998848*x_4 + 5.22919988632202) - 0.00402240908290799*std::sin(0.332879841327667*x_4 - 1.16815984249115) - 0.00255091188794186*std::sin(0.416159868240356*x_4 - 4.40927982330322) - 0.00402355067496188*std::sin(0.23047998547554*x_40 + 1.9651198387146) + 0.0158340910858581*std::sin(0.236319988965988*x_41 - 7.4236798286438) + 0.00927769310384511*std::sin(0.241679981350899*x_41 - 7.42560005187988) + 0.00910981625878455*std::sin(0.26199996471405*x_41 + 1.97463977336884) - 0.0320581018470738*std::sin(0.229359999299049*x_42 + 1.96647977828979) - 0.0125507423408892*std::sin(0.25639995932579*x_42 + 5.14743995666504) + 0.0684230568045429*std::sin(0.211759999394417*x_43 - 1.20295989513397) - 0.0141771757018611*std::sin(0.242719978094101*x_44 - 1.20631992816925) - 0.030706970571242*std::sin(0.260479986667633*x_44 + 1.94247984886169) - 0.00473030208693384*std::sin(0.267679959535599*x_44 - 7.4443998336792) - 0.0202109035280939*std::sin(0.194399997591972*x_46 - 7.60128021240234) + 0.00610959743687812*std::sin(0.249199971556664*x_46 + 1.97567975521088) - 0.0402818207733255*std::sin(0.207040011882782*x_47 - 7.58816003799438) + 0.0125369237523199*std::sin(0.253199964761734*x_48 - 1.20247983932495) + 0.0184523726533309*std::sin(0.296239942312241*x_49 + 5.06767988204956) + 0.00533005386913896*std::sin(0.309839934110641*x_5 + 1.81447994709015) - 0.00542422674491157*std::sin(0.364319831132889*x_5 - 1.16543984413147) - 0.0416987755979923*std::sin(0.388639837503433*x_5 + 2.00431990623474) + 0.00302333556390868*std::sin(0.388959854841232*x_5 + 4.98991966247559) - 0.0244699115767203*std::sin(0.408159852027893*x_5 - 1.17863988876343) + 0.013046302945035*std::sin(0.181120008230209*x_50 - 7.37967967987061) - 0.0121514284659236*std::sin(0.215199992060661*x_52 - 1.20711994171143) - 0.0117120959762782*std::sin(0.242479979991913*x_53 + 1.96927976608276) + 0.0252650434773233*std::sin(0.247439980506897*x_53 + 1.98375976085663) + 0.0146774578095046*std::sin(0.265359938144684*x_6 + 5.20975971221924) + 0.00234493406237598*std::sin(0.477919846773148*x_6 + 4.96743965148926) + 0.00595702305522726*std::sin(0.255839973688126*x_60 + 8.34751987457275) - 0.0277111506591564*std::sin(0.327759832143784*x_60 - 7.52952003479004) - 0.00698748622628657*std::sin(0.390639841556549*x_60 - 4.37255954742432) + 0.00322660329358137*std::sin(0.490879863500595*x_60 + 1.69871997833252) - 0.0589725536147901*std::sin(0.149440035223961*x_61 - 1.27567994594574) - 0.00680899425756508*std::sin(0.240959972143173*x_61 + 8.25207996368408) - 0.0142796795505441*std::sin(0.285119920969009*x_7 + 8.39744091033936) - 0.00551941365119333*std::sin(0.336559861898422*x_7 + 5.23784017562866) - 0.00549991502213943*std::sin(0.349679857492447*x_7 + 2.00879979133606) + 0.0128368137948503*std::sin(0.352479845285416*x_7 - 7.59647989273071) - 0.00545588599566468*std::sin(0.457919865846634*x_7 + 7.9870400428772) - 0.00996007201024531*std::sin(0.334079831838608*x_8 + 8.25943946838379) + 0.00366223121444518*std::sin(0.335839837789536*x_8 - 4.34151983261108) - 0.0140243626265219*std::sin(0.280479967594147*x_9 + 1.99911975860596) - 0.0336698494580107*std::sin(0.333039849996567*x_91 + 8.41728019714355) - 0.00543777018885157*std::sin(0.34775984287262*x_91 + 5.19016027450562) - 0.0311259682464731*std::sin(0.367759823799133*x_91 + 5.19528007507324) + 0.0237188256552985*std::sin(0.400319844484329*x_91 + 1.97431981563568) - 0.00179502184150965*std::sin(0.484399855136871*x_91 - 7.60904026031494) - 0.0308678590157974*std::sin(0.268319964408875*x_92 - 7.3744797706604) + 0.0327070986044563*std::sin(0.286079943180084*x_92 + 5.21439981460571) - 0.00771327748796035*std::sin(0.289279937744141*x_92 + 2.00223970413208) + 0.00537108778584688*std::sin(0.300959944725037*x_92 + 1.80455982685089) - 0.0065678902745034*std::sin(0.270399957895279*x_94 + 5.1864800453186) - 0.00341004306117323*std::sin(0.285599917173386*x_94 + 1.98791980743408) - 0.0184495836946075*std::sin(0.287359952926636*x_94 + 1.9755197763443) + 0.00606373406321063*std::sin(0.261279970407486*x_95 - 7.41343975067139) - 0.00405829331493955*std::sin(0.281039953231812*x_95 + 1.97343981266022) - 0.00782707274761283*std::sin(0.281679958105087*x_95 + 1.96399986743927) + 0.0420648561777856*std::sin(0.28263995051384*x_95 - 4.40463972091675) + 0.00445202820697228*std::sin(0.273119956254959*x_96 + 8.19167995452881) - 0.00391530199722926*std::sin(0.262239962816238*x_97 + 5.17519998550415) + 0.010779448944814*std::sin(0.273119956254959*x_97 + 1.97847986221313) + 0.0554388890196403*std::sin(0.28383994102478*x_97 + 8.18407917022705) + 0.0311521867175683*std::sin(0.248399972915649*x_99 + 1.98031985759735) - 0.0346612930297852*std::sin(-0.0403402357978256*x_10 + 0.00492054193285955*x_100 + 0.0271141752054049*x_101 - 0.0289313512665504*x_102 - 0.032696343080788*x_103 - 0.0388424423875826*x_104 - 0.0230023781805987*x_105 + 0.0455859010242175*x_106 - 0.0313486316929332*x_107 + 0.032999455743104*x_108 + 0.0126667090948013*x_11 - 0.0479246125988095*x_110 + 0.00287328396266512*x_111 + 0.000938155481276435*x_112 - 0.0265120091340628*x_113 - 0.015436358586977*x_114 + 0.0904311581351311*x_115 - 0.00432160642812729*x_116 + 0.10522493368313*x_117 + 0.0137997904955117*x_118 + 0.113215949003414*x_119 - 0.0179242397452569*x_12 + 0.0312525125815953*x_120 - 0.018838337459561*x_13 + 0.0369815682606755*x_15 + 0.052406120080632*x_16 + 0.0441885649677249*x_18 + 0.0596246439210288*x_19 - 0.000224343968264064*x_2 + 0.0125400197047983*x_21 - 0.0461576766401543*x_22 + 0.00324627887409719*x_24 - 0.0192245015789125*x_25 + 0.00388797661673088*x_29 - 0.0771248844618353*x_30 - 0.0778788134618096*x_34 + 0.0174024250587514*x_35 + 0.0199991531388546*x_36 + 0.0380231296907068*x_37 + 0.0276040894425427*x_39 + 0.0664699117143777*x_41 + 0.0110267609282434*x_42 - 0.0569443993001401*x_43 - 0.0405869524910184*x_44 + 0.0112325694906104*x_45 - 0.0125234296967815*x_46 - 0.00911382706785414*x_47 + 0.0450558674851051*x_48 - 0.0278698942062916*x_49 - 0.015436620113728*x_5 + 0.092504574927154*x_50 + 0.0364827456120267*x_51 + 0.0360276518432423*x_52 + 0.0790656315875552*x_53 + 0.0976608008413349*x_54 + 0.0284577217575715*x_55 + 0.00355086634824501*x_56 + 0.0853404297947639*x_57 + 0.0804666316952546*x_58 + 0.114147103201629*x_59 + 0.00609570813942442*x_6 + 0.0288740871455273*x_60 - 0.0159377921211911*x_61 + 0.0126360904865828*x_62 + 0.0298216478429659*x_63 - 0.0331089747044286*x_64 - 0.019610693974847*x_65 - 0.028758433698551*x_66 - 0.0138911705351629*x_67 - 0.00264601128940232*x_68 + 0.0172315376032156*x_69 - 0.0196903821768257*x_70 - 0.0127296768482913*x_71 + 0.0315403179951183*x_72 - 0.00709694346381951*x_73 + 0.00438358376919894*x_74 - 0.0235432549117274*x_75 + 0.0169719324091867*x_76 - 0.018684882159805*x_77 + 0.00938159518806886*x_78 - 0.0343227927956928*x_79 + 0.0407010345006217*x_80 - 0.0340391467230032*x_81 + 0.00662424214374026*x_82 - 0.00274896292229651*x_83 + 0.00430854144925455*x_84 + 0.025618787865088*x_85 - 0.00710151953189733*x_86 + 0.00572153423786061*x_87 + 0.0160883114658097*x_88 + 0.0198174260598836*x_89 + 0.00271289284298856*x_90 - 0.0344257230794969*x_93 - 0.0351207542002913*x_94 - 0.00178028518927854*x_95 - 0.0277494689533876*x_96 + 0.0393921658165021*x_98 - 0.0472241023441942*x_99 + 0.304721943782191*std::sin(0.408399850130081*x_1 + 8.39400005340576) + 0.41644638436232*std::sin(0.246079966425896*x_109 - 7.44191980361938) - 0.31490283742972*std::sin(0.304159939289093*x_14 - 4.2577600479126) + 0.15904246815316*std::sin(0.389599829912186*x_17 + 8.19871997833252) - 0.276904021269978*std::sin(0.269199967384338*x_20 + 2.0066397190094) + 0.326855669393847*std::sin(0.344639837741852*x_23 - 1.16903984546661) + 0.157987844386263*std::sin(0.359279841184616*x_26 - 1.14727985858917) + 0.383560799496227*std::sin(0.223039999604225*x_27 + 8.21224021911621) - 0.136739642149799*std::sin(0.284159928560257*x_28 - 1.17151987552643) + 0.480258122705443*std::sin(0.319359928369522*x_3 + 5.25487995147705) - 0.196557543600486*std::sin(0.338719844818115*x_31 + 2.12823987007141) + 0.27524907625309*std::sin(0.311599940061569*x_32 + 2.01239991188049) - 0.277113737455824*std::sin(0.254719972610474*x_33 + 1.96607983112335) - 0.144539773330747*std::sin(0.233679980039597*x_38 - 4.23104000091553) + 0.184736745988289*std::sin(0.382559835910797*x_4 + 2.01575970649719) - 0.436970403687148*std::sin(0.225519984960556*x_40 + 1.99303984642029) + 0.216971883770647*std::sin(0.39031982421875*x_7 + 1.9793598651886) - 0.266567153066655*std::sin(0.323199838399887*x_8 - 1.12079977989197) + 0.270422285371049*std::sin(0.334879845380783*x_9 + 5.06487989425659) + 0.198446524748249*std::sin(0.353039860725403*x_91 + 5.20071983337402) + 0.169481882981447*std::sin(0.316799849271774*x_92 + 8.22192001342773) + 0.265332944749808*std::sin(0.284799933433533*x_97 + 8.18175983428955) - 5.6211309454261) + 0.0386424453013181);
}

inline float score_2(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.00481726814179913*x_1 - 0.00070908924319482*x_10 - 0.00446056758067869*x_100 + 0.00583432822144535*x_101 - 0.000221677773784349*x_102 + 0.00322295728621103*x_103 + 0.00108786102967469*x_104 - 0.00742590809245045*x_105 + 0.00718261058267191*x_106 + 0.00208220800123393*x_107 - 0.006316693199955*x_108 + 0.000330308063071914*x_109 - 0.00358035601373378*x_11 + 0.00130870919417132*x_110 + 0.011916174177766*x_111 - 0.00451594659376919*x_112 - 0.00328202026716048*x_113 - 0.000262292785551305*x_114 - 0.00560358052827426*x_115 - 0.00743822688819092*x_116 - 0.000102459317102*x_117 + 0.00569529455168817*x_118 - 0.010570085446275*x_119 - 0.00427666906881767*x_12 - 0.00582374209753032*x_120 + 0.000432570218045731*x_13 - 0.0037969641335238*x_14 - 0.00141327997846232*x_15 + 0.00171595756763265*x_16 - 0.000454651611021037*x_17 + 0.000568191943536072*x_18 + 0.00541295333101589*x_19 - 0.000581930544389729*x_2 + 0.000218933717241855*x_20 + 0.00266150171396285*x_21 - 0.000674348824292314*x_22 - 0.00494756829375416*x_23 + 0.000386268808940245*x_24 - 0.000233566885204336*x_25 - 0.00205501522858461*x_26 + 0.00318715604413206*x_27 + 0.000608142957252497*x_28 + 0.000647088320960584*x_29 - 0.000974446966670865*x_3 + 0.00493706345264955*x_30 + 0.00166427209099969*x_31 + 0.000794848004390807*x_32 + 0.00235419150382403*x_33 - 0.0026318235366032*x_34 + 0.0127913675296523*x_35 + 0.00432810786562258*x_36 - 0.00620939651116482*x_37 - 0.00434312172176246*x_38 + 0.00565846924335403*x_39 - 2.43147752907344e-5*x_4 + 0.000904926728632458*x_40 + 0.000381276879293043*x_41 - 0.00817322858688075*x_42 + 0.000420891003670343*x_43 - 0.00180090325121929*x_44 + 0.00627849302241893*x_45 + 0.00365667666821354*x_46 - 0.0125111800922667*x_47 + 0.00537294381678421*x_48 + 0.00144302590755093*x_49 - 0.0007083282006007*x_5 - 0.00970032517087599*x_50 - 0.00806394164886137*x_51 - 0.012354129614802*x_52 - 0.00599008796718726*x_53 + 0.00871921714320901*x_54 + 0.00755308107807946*x_55 + 0.0147872398294194*x_56 + 0.00620199366353903*x_57 - 0.00638560822739876*x_58 + 0.00820422401301149*x_59 - 0.00905535505176747*x_6 + 0.00647751933627732*x_60 + 0.00109554606242459*x_61 - 0.00541404506468196*x_62 + 0.000707874895571458*x_63 - 0.00402156741559886*x_64 - 0.00201754472374068*x_65 - 0.00472897077046061*x_66 + 0.00208717379096432*x_67 + 0.0039946238302666*x_68 - 0.00285016876745291*x_69 + 0.0018847201928071*x_7 + 0.00232646481155059*x_70 - 0.00250863451875736*x_71 + 0.00333423868326907*x_72 + 0.00185811482842776*x_73 - 0.00097727700727524*x_74 + 0.00335477310970945*x_75 - 0.00253980583663372*x_76 + 0.000466195730397994*x_77 + 0.00125420631351531*x_78 + 0.000728265135395055*x_79 + 0.000116018623545091*x_8 + 0.00482465192366513*x_80 - 0.0023014909407625*x_81 + 0.000723670987765553*x_82 - 0.00271151932743576*x_83 - 0.000326540039501976*x_84 + 0.00188875416469768*x_85 + 0.00356522870074075*x_86 - 0.00157896920375661*x_87 + 0.00406139364251836*x_88 - 0.00140350438094262*x_89 - 0.00881482685074496*x_9 - 0.00103009792150894*x_90 - 0.000964702458954974*x_91 - 0.00133284199026904*x_92 - 0.0158554000944356*x_93 - 0.00190225006938634*x_94 - 0.00013663212652935*x_95 - 0.00430888486643465*x_96 + 0.00129740340964643*x_97 + 0.0105264284046554*x_98 + 0.000162355199459761*x_99 + 6.82598962980274e-6*std::pow(-3.34895968437195*x_1 - 4.17543983459473, 2) + 5.02414277968027e-6*std::pow(-5.60767984390259*x_22 - 9.60639953613281, 2) - 2.49489044815161e-5*std::pow(-4.01999998092651*x_27 - 6.62815999984741, 2) + 0.0015957741175918*std::exp(0.163839861750603*x_49) - 0.00392426487370887*std::sin(0.329999834299088*x_1 + 5.14520025253296) + 0.00253627242678169*std::sin(0.342239856719971*x_1 + 8.34768009185791) + 0.0153100366326034*std::sin(0.359039843082428*x_1 - 1.03663980960846) + 0.00391822077956489*std::sin(0.408399850130081*x_1 + 8.39400005340576) + 0.0339205301137622*std::sin(0.146240040659904*x_10 + 8.17375946044922) + 0.0395477152218158*std::sin(0.339839845895767*x_10 + 5.03247976303101) + 0.00168682423817999*std::sin(0.352079838514328*x_10 + 8.25903987884521) + 0.0101754028308338*std::sin(0.366479843854904*x_10 + 8.24079990386963) + 0.002842876530803*std::sin(0.242079973220825*x_100 + 1.9755197763443) - 0.0032129302374463*std::sin(0.257839977741241*x_100 + 1.95887982845306) + 0.00193265300389519*std::sin(0.229919984936714*x_101 + 1.98535978794098) + 0.0432933849674159*std::sin(0.221599996089935*x_102 + 1.97327971458435) + 0.0179154210430107*std::sin(0.239359974861145*x_102 - 1.2099198102951) + 0.00780305620143695*std::sin(0.247999966144562*x_107 + 5.15144014358521) + 0.00181514321001098*std::sin(0.246319979429245*x_108 + 1.97391986846924) - 0.0187804152240383*std::sin(0.23327998816967*x_109 + 1.95511984825134) - 0.00380606070671866*std::sin(0.23471999168396*x_109 + 1.98399984836578) + 0.00535481251048148*std::sin(0.246079966425896*x_109 - 7.44191980361938) + 0.051960669144091*std::sin(0.247759968042374*x_109 - 1.21407985687256) - 0.00547719782197274*std::sin(0.252159982919693*x_109 - 1.214399933815) + 0.00200541213154758*std::sin(0.218799993395805*x_11 + 2.00231981277466) - 0.0424750038164497*std::sin(0.248719975352287*x_11 - 7.41408014297485) - 0.00608596134653215*std::sin(0.25655996799469*x_11 + 8.37376022338867) - 0.0483510816035054*std::sin(0.216240003705025*x_110 - 7.42695951461792) + 0.00149868027144762*std::sin(0.219759985804558*x_110 - 4.41991996765137) + 0.00365870734220246*std::sin(0.213039994239807*x_111 - 7.41463994979858) - 0.00355749963870455*std::sin(0.216879993677139*x_111 + 1.98231983184814) + 0.0105205045455839*std::sin(0.267279952764511*x_112 - 1.20023989677429) + 0.00176179206992685*std::sin(0.278399974107742*x_112 + 1.96583986282349) - 0.0085200198581991*std::sin(0.293919950723648*x_113 + 1.96367979049683) - 0.00179095356255713*std::sin(0.237119987607002*x_116 + 8.16991996765137) - 0.0167105436034802*std::sin(0.250639975070953*x_116 - 4.40895986557007) + 0.00208801328415085*std::sin(0.225919991731644*x_117 - 7.40279960632324) + 0.0203910962053845*std::sin(0.232319980859756*x_117 + 5.17903995513916) + 0.00392110844871615*std::sin(0.23471999168396*x_118 - 7.41639995574951) - 0.00170407955035096*std::sin(0.265759944915771*x_119 + 8.15824031829834) + 0.0159771109229225*std::sin(0.277439951896667*x_12 - 7.43567991256714) - 0.0063618608856238*std::sin(0.285599917173386*x_12 + 5.13567972183228) - 0.0044518886745735*std::sin(0.248639971017838*x_13 + 1.98823988437653) - 0.00583212025460974*std::sin(0.289919942617416*x_13 - 7.4443998336792) + 0.0390384062490635*std::sin(0.310239940881729*x_13 + 8.31328010559082) + 0.0019859786394691*std::sin(0.389119833707809*x_13 + 4.99919986724854) - 0.0253464674360862*std::sin(0.247759968042374*x_14 + 8.37184047698975) - 0.0458166367935657*std::sin(0.265839964151382*x_14 + 1.98951983451843) + 0.00772255550405852*std::sin(0.281199961900711*x_14 + 5.17095994949341) - 0.00404913025247375*std::sin(0.304159939289093*x_14 - 4.2577600479126) + 0.00193596322303461*std::sin(0.346159845590591*x_14 - 1.13391983509064) + 0.00177824211961277*std::sin(0.357839852571487*x_14 + 8.01512050628662) + 0.00271569463755257*std::sin(0.280799955129623*x_15 - 1.3802398443222) + 0.00255667783421764*std::sin(0.300879925489426*x_15 - 7.43351984024048) + 0.00993408580812125*std::sin(0.333999842405319*x_15 + 8.27744007110596) - 0.0130931202125871*std::sin(0.274159938097*x_16 - 1.17031991481781) + 0.00418107347503665*std::sin(0.279039949178696*x_16 - 1.19951987266541) - 0.00163398654404314*std::sin(0.306239932775497*x_16 + 1.99111986160278) - 0.0243445032104089*std::sin(0.310719937086105*x_16 + 1.98639988899231) - 0.0057286887511768*std::sin(0.321919918060303*x_16 + 1.98375976085663) + 0.00308752628043029*std::sin(0.328959852457047*x_16 - 7.32767963409424) + 0.00146137586609257*std::sin(0.257359951734543*x_17 + 8.24071979522705) - 0.00191991268362055*std::sin(0.288959950208664*x_17 + 2.01887989044189) - 0.0179374000456556*std::sin(0.3503198325634*x_17 + 2.00575995445251) - 0.0040541481279717*std::sin(0.351999849081039*x_17 - 4.17120027542114) + 0.0335998552108776*std::sin(0.359679847955704*x_17 + 2.02319979667664) + 0.0020450233935119*std::sin(0.389599829912186*x_17 + 8.19871997833252) + 0.0593239945795072*std::sin(0.22095999121666*x_18 + 5.01007986068726) + 0.00458332201155689*std::sin(0.269839972257614*x_18 + 8.2186393737793) - 0.00603229543001455*std::sin(0.275279939174652*x_18 - 1.15727984905243) + 0.0134292983359092*std::sin(0.303439915180206*x_18 - 4.37415981292725) - 0.00213140764969288*std::sin(0.316159933805466*x_18 + 2.18255996704102) - 0.00261348160596285*std::sin(0.341119825839996*x_18 - 7.36839962005615) - 0.00434034371718163*std::sin(0.39743983745575*x_18 - 1.19631993770599) - 0.00125366491136198*std::sin(0.417519867420197*x_18 - 1.214479804039) - 0.0223476531517517*std::sin(0.249119967222214*x_19 - 7.57503986358643) - 0.00709564571474412*std::sin(0.270559966564178*x_19 + 5.01200008392334) + 0.0272996896335816*std::sin(0.345519840717316*x_2 - 7.40919971466064) - 0.00822213679881001*std::sin(0.391199827194214*x_2 - 4.21216011047363) + 0.00143307831934588*std::sin(0.423679858446121*x_2 + 5.21167993545532) + 0.0228157854551179*std::sin(0.262159943580627*x_20 + 8.19703960418701) - 0.00356052825280158*std::sin(0.269199967384338*x_20 + 2.0066397190094) + 0.0190575404871199*std::sin(0.273679971694946*x_20 - 7.41055965423584) + 0.00557961737881945*std::sin(0.282879948616028*x_20 + 1.99935972690582) + 0.00663570556884735*std::sin(0.289679944515228*x_20 + 1.98439979553223) + 0.0462609058070022*std::sin(0.327519834041595*x_20 + 8.24312019348145) + 0.00216952397006578*std::sin(0.341679841279984*x_20 + 8.24327945709229) - 0.0021890827307475*std::sin(0.366719841957092*x_20 + 1.7992799282074) - 0.00445090442818091*std::sin(0.311999946832657*x_21 + 1.99287974834442) - 0.0218195435753714*std::sin(0.343839854001999*x_21 + 8.24991989135742) + 0.00604760051483321*std::sin(0.436479866504669*x_21 + 1.78887987136841) + 0.00141582994109796*std::sin(0.338159829378128*x_22 + 2.02815985679626) + 0.0130840864770526*std::sin(0.353279858827591*x_22 - 7.37287998199463) - 0.0445409751652614*std::sin(0.373279839754105*x_22 + 1.98695981502533) + 0.016282406878562*std::sin(0.398239850997925*x_22 + 5.19063997268677) + 0.0179245497499117*std::sin(0.212559998035431*x_23 - 1.18399977684021) + 0.00407894733552929*std::sin(0.323359936475754*x_23 + 5.21583986282349) + 0.00420282392479413*std::sin(0.344639837741852*x_23 - 1.16903984546661) - 0.00150565121501743*std::sin(0.3503198325634*x_23 + 2.028639793396) + 0.00141987902623423*std::sin(0.294959932565689*x_24 + 8.21343994140625) - 0.0224848776942684*std::sin(0.331279844045639*x_24 + 2.03863978385925) - 0.0290188998273545*std::sin(0.410559862852097*x_24 + 1.98767983913422) - 0.00324952862492341*std::sin(0.374479830265045*x_25 - 7.5918402671814) - 0.00505500998397228*std::sin(0.439119875431061*x_25 - 1.39551985263824) - 0.01496536381419*std::sin(0.296079933643341*x_26 + 1.99919974803925) - 0.0133209396900225*std::sin(0.313919931650162*x_26 - 1.18519985675812) - 0.0049935976753894*std::sin(0.339119851589203*x_26 + 5.02279996871948) + 0.00203146267416629*std::sin(0.359279841184616*x_26 - 1.14727985858917) - 0.00220668527131577*std::sin(0.399359852075577*x_26 - 1.20367991924286) - 0.00452963978882087*std::sin(0.20040000975132*x_27 + 8.20024013519287) + 0.00493195821790525*std::sin(0.223039999604225*x_27 + 8.21224021911621) - 0.00523214199729373*std::sin(0.329599827528*x_27 + 2.0319197177887) + 0.0143437204850065*std::sin(0.112960062921047*x_28 + 5.09511995315552) + 0.0181898223156153*std::sin(0.231039986014366*x_28 - 1.15839993953705) - 0.00175824589660852*std::sin(0.284159928560257*x_28 - 1.17151987552643) - 0.0237653758854938*std::sin(0.310159921646118*x_28 + 1.99215984344482) - 0.00651406355526527*std::sin(0.326479852199554*x_28 - 1.12615978717804) + 0.00217830701788847*std::sin(0.335039854049683*x_28 + 8.22056007385254) - 0.144182453239912*std::sin(0.0978400707244873*x_29 - 7.69432020187378) - 0.0361412635712255*std::sin(0.106960065662861*x_29 - 4.49688005447388) - 0.0109586844785796*std::sin(0.314319908618927*x_29 + 1.99423980712891) - 0.00297478288076274*std::sin(0.3572798371315*x_29 + 8.236159324646) - 0.00213158050972058*std::sin(0.291919946670532*x_3 - 4.32488012313843) - 0.0349526807225833*std::sin(0.308879911899567*x_3 - 1.10775983333588) + 0.00617532604505941*std::sin(0.319359928369522*x_3 + 5.25487995147705) - 0.00242775402760013*std::sin(0.377999842166901*x_3 + 1.98583984375) - 0.00203261665746713*std::sin(0.37967985868454*x_3 - 1.19287979602814) + 0.00382464860937824*std::sin(0.383679836988449*x_3 + 8.18943977355957) + 0.00344757721457515*std::sin(0.386799842119217*x_3 - 1.1865599155426) + 0.0134101773984197*std::sin(0.396639823913574*x_3 + 2.00367975234985) + 0.037838430716692*std::sin(0.145920038223267*x_30 - 4.45616006851196) - 0.00252740528678876*std::sin(0.338719844818115*x_31 + 2.12823987007141) - 0.00144942349836817*std::sin(0.34079983830452*x_31 - 1.05159986019135) - 0.0169894292912512*std::sin(0.346719831228256*x_31 - 4.22328042984009) - 0.00344024673398826*std::sin(0.35335984826088*x_31 + 5.17592000961304) + 0.0041690715841649*std::sin(0.40871986746788*x_31 - 4.19944000244141) + 0.0203062659250556*std::sin(0.410959839820862*x_31 - 4.19831991195679) - 0.00339995420688449*std::sin(0.443759858608246*x_31 - 1.16527986526489) - 0.000147903297399297*std::sin(0.591199815273285*x_31 - 4.39583969116211) + 0.00667405662752514*std::sin(0.254879981279373*x_32 - 1.16591989994049) + 0.00353924839394493*std::sin(0.311599940061569*x_32 + 2.01239991188049) - 0.00201203325092467*std::sin(0.312719941139221*x_32 - 7.36104011535645) + 0.00938782762559574*std::sin(0.316399931907654*x_32 - 4.34007978439331) - 0.00494541187102728*std::sin(0.319839835166931*x_32 + 2.00407981872559) - 0.00066631034122722*std::sin(0.366799831390381*x_32 + 7.98663997650146) - 0.00972556655290229*std::sin(0.210879996418953*x_33 + 2.16375994682312) + 0.0234737072059505*std::sin(0.251279979944229*x_33 - 7.4314398765564) - 0.00356322485648885*std::sin(0.254719972610474*x_33 + 1.96607983112335) + 0.061299276285328*std::sin(0.264319956302643*x_33 - 1.22359991073608) - 0.00167625956396925*std::sin(0.289119929075241*x_33 + 4.96567964553833) + 0.00191268591479004*std::sin(0.224159985780716*x_34 + 5.17888021469116) - 0.00815741687394292*std::sin(0.239119976758957*x_34 + 1.97639977931976) - 0.0652996504278562*std::sin(0.243359968066216*x_34 + 1.97447979450226) + 0.0161782435093807*std::sin(0.216480001807213*x_35 - 7.40999984741211) - 0.000548156504078184*std::sin(0.230159983038902*x_35 + 5.16847991943359) - 0.00388361042591687*std::sin(0.209199994802475*x_36 + 1.98423981666565) + 0.0221305899442144*std::sin(0.231439992785454*x_36 + 1.96879982948303) + 0.00341120459228694*std::sin(0.241999983787537*x_36 + 1.98503983020782) + 0.00938104266127997*std::sin(0.243279978632927*x_36 + 5.17535972595215) + 0.0607309600199788*std::sin(0.261199980974197*x_36 - 1.21743988990784) - 0.0288531809564114*std::sin(0.2223199903965*x_37 - 1.1904798746109) - 0.00185854269734817*std::sin(0.233679980039597*x_38 - 4.23104000091553) + 0.00443011647423552*std::sin(0.246639966964722*x_38 - 4.40207958221436) - 0.00126127277313546*std::sin(0.313199937343597*x_4 + 2.00671982765198) + 0.00891724106690243*std::sin(0.32551982998848*x_4 + 5.22919988632202) - 0.00118097253098383*std::sin(0.332879841327667*x_4 - 1.16815984249115) + 0.00237540935810616*std::sin(0.382559835910797*x_4 + 2.01575970649719) + 0.00112968742279332*std::sin(0.416159868240356*x_4 - 4.40927982330322) - 0.00548698664535051*std::sin(0.443599849939346*x_4 + 5.17671966552734) - 0.00561871749218576*std::sin(0.225519984960556*x_40 + 1.99303984642029) - 0.0148099350801839*std::sin(0.23047998547554*x_40 + 1.9651198387146) + 0.0107690687724778*std::sin(0.236319988965988*x_41 - 7.4236798286438) - 0.00432831177440771*std::sin(0.241679981350899*x_41 - 7.42560005187988) + 0.0016514702043828*std::sin(0.26199996471405*x_41 + 1.97463977336884) + 0.00560822933273575*std::sin(0.222159996628761*x_42 + 4.99399995803833) - 0.00853600037298001*std::sin(0.25639995932579*x_42 + 5.14743995666504) - 0.0640252691137117*std::sin(0.211759999394417*x_43 - 1.20295989513397) + 0.00661406190433055*std::sin(0.242719978094101*x_44 - 1.20631992816925) + 0.0287333268390321*std::sin(0.260479986667633*x_44 + 1.94247984886169) + 0.00209484412177546*std::sin(0.267679959535599*x_44 - 7.4443998336792) + 0.0189118785077659*std::sin(0.194399997591972*x_46 - 7.60128021240234) + 0.00415525429360814*std::sin(0.249199971556664*x_46 + 1.97567975521088) + 0.00368081969520235*std::sin(0.253199964761734*x_48 - 1.20247983932495) + 0.00334513263181994*std::sin(0.296239942312241*x_49 + 5.06767988204956) + 0.00156489483749039*std::sin(0.309839934110641*x_5 + 1.81447994709015) - 0.00368912055240336*std::sin(0.364319831132889*x_5 - 1.16543984413147) + 0.0390186503505712*std::sin(0.388639837503433*x_5 + 2.00431990623474) - 0.00133890322812641*std::sin(0.388959854841232*x_5 + 4.98991966247559) - 0.00577763756585439*std::sin(0.181120008230209*x_50 - 7.37967967987061) - 0.00220286792643163*std::sin(0.215199992060661*x_52 - 1.20711994171143) - 0.0034386516495809*std::sin(0.242479979991913*x_53 + 1.96927976608276) - 0.0243312962255994*std::sin(0.214560002088547*x_57 - 7.41511964797974) + 0.0224173984838781*std::sin(0.222719997167587*x_59 - 1.18319988250732) - 0.00684745795578452*std::sin(0.265359938144684*x_6 + 5.20975971221924) + 0.00863126229457247*std::sin(0.477919846773148*x_6 + 4.96743965148926) - 0.00277912329517262*std::sin(0.255839973688126*x_60 + 8.34751987457275) + 0.00309445235803355*std::sin(0.390639841556549*x_60 - 4.37255954742432) + 0.00219447473060927*std::sin(0.490879863500595*x_60 + 1.69871997833252) + 0.0551821826127336*std::sin(0.149440035223961*x_61 - 1.27567994594574) - 0.00199910924425359*std::sin(0.240959972143173*x_61 + 8.25207996368408) + 0.00666188291007096*std::sin(0.285119920969009*x_7 + 8.39744091033936) - 0.0203159260211451*std::sin(0.336559861898422*x_7 + 5.23784017562866) + 0.00243567206547299*std::sin(0.349679857492447*x_7 + 2.00879979133606) + 0.0173673884972956*std::sin(0.364639848470688*x_7 + 1.99303984642029) + 0.00278989997576004*std::sin(0.39031982421875*x_7 + 1.9793598651886) - 0.00371065261551937*std::sin(0.457919865846634*x_7 + 7.9870400428772) - 0.00342761320478379*std::sin(0.323199838399887*x_8 - 1.12079977989197) - 0.00292426036444231*std::sin(0.334079831838608*x_8 + 8.25943946838379) + 0.00249075362742475*std::sin(0.335839837789536*x_8 - 4.34151983261108) - 0.0148848068077135*std::sin(0.34215983748436*x_8 - 1.14503979682922) + 0.0129104551577346*std::sin(0.259759962558746*x_9 + 5.17736005783081) - 0.00254240221264911*std::sin(0.280479967594147*x_9 + 1.99911975860596) + 0.00347718383732691*std::sin(0.334879845380783*x_9 + 5.06487989425659) + 0.0315057712011511*std::sin(0.333039849996567*x_91 + 8.41728019714355) + 0.00253687683689116*std::sin(0.34775984287262*x_91 + 5.19016027450562) + 0.00255169446364785*std::sin(0.353039860725403*x_91 + 5.20071983337402) + 0.0137258996199475*std::sin(0.356399834156036*x_91 + 5.21304035186768) + 0.00429985992471621*std::sin(0.400319844484329*x_91 + 1.97431981563568) - 0.000527015388948541*std::sin(0.484399855136871*x_91 - 7.60904026031494) + 0.0288838744240278*std::sin(0.268319964408875*x_92 - 7.3744797706604) + 0.0059292961880525*std::sin(0.286079943180084*x_92 + 5.21439981460571) + 0.0034158735971449*std::sin(0.289279937744141*x_92 + 2.00223970413208) - 0.0298570054222241*std::sin(0.299279928207397*x_92 - 7.40520000457764) + 0.00157694232631411*std::sin(0.300959944725037*x_92 + 1.80455982685089) + 0.00217925702171404*std::sin(0.316799849271774*x_92 + 8.22192001342773) - 0.0011906579436812*std::sin(0.270399957895279*x_94 + 5.1864800453186) - 0.0125517286686306*std::sin(0.285599917173386*x_94 + 1.98791980743408) + 0.00412406173430777*std::sin(0.261279970407486*x_95 - 7.41343975067139) + 0.0243059942684221*std::sin(0.278959959745407*x_95 + 1.97447979450226) - 0.014937816219046*std::sin(0.281039953231812*x_95 + 1.97343981266022) + 0.00346626854579467*std::sin(0.281679958105087*x_95 + 1.96399986743927) - 0.0393612016590508*std::sin(0.28263995051384*x_95 - 4.40463972091675) + 0.0163870804786202*std::sin(0.273119956254959*x_96 + 8.19167995452881) + 0.0109507311735039*std::sin(0.278159946203232*x_96 - 7.4423999786377) - 0.0144114920085675*std::sin(0.262239962816238*x_97 + 5.17519998550415) + 0.00316482805218923*std::sin(0.273119956254959*x_97 + 1.97847986221313) - 0.0246878916737998*std::sin(0.27567994594574*x_97 + 1.97919988632202) - 0.051875638923691*std::sin(0.28383994102478*x_97 + 8.18407917022705) + 0.00341174332480942*std::sin(0.284799933433533*x_97 + 8.18175983428955) + 0.591966688632965*std::sin(-0.00378282546374947*x_1 - 0.0194071984496439*x_10 + 0.000570148298307857*x_100 - 0.0111749714867528*x_101 - 0.0196909773676014*x_102 + 0.0273983379011751*x_103 + 0.00431231347178653*x_104 + 0.000990184723885987*x_105 + 0.0189595205938091*x_106 - 0.00197013718577075*x_107 - 0.0248816602029319*x_108 + 0.00360383610844155*x_109 + 0.00573575349721026*x_111 - 0.0179826862181466*x_113 + 0.0230396415779977*x_114 + 0.00386712635931319*x_115 + 0.0246209637894168*x_116 - 0.000702805643114153*x_117 - 0.000211171921261994*x_118 + 0.00351840891775508*x_119 - 0.0422481893075598*x_12 + 0.0121472062922709*x_120 - 0.0162802424405219*x_13 + 0.0186814015627365*x_14 + 0.0350768978230472*x_15 + 0.0301526632271987*x_17 + 0.013923802737532*x_18 - 0.010108882083039*x_19 + 0.00232070836314831*x_2 + 0.00529083400124586*x_20 + 0.0118793808484406*x_21 + 0.0147946915914791*x_22 + 0.0255265970843897*x_23 - 0.0263802591475298*x_25 - 0.00403793971440265*x_26 + 0.0181695176538436*x_27 + 0.0173951885397855*x_28 + 0.0135197996044419*x_30 + 0.0284335547603144*x_33 + 0.0294935588221068*x_34 + 0.0155601905898611*x_35 + 0.0289717459903418*x_36 - 0.0274163351340883*x_37 + 0.00230254567331609*x_38 + 0.00473168049148176*x_39 + 0.0106829027666678*x_4 - 0.001922992743982*x_40 - 0.0098020511683201*x_41 - 0.0188290857618449*x_43 + 0.0207861064775992*x_44 - 0.0216531485621858*x_45 + 0.0129246555581933*x_46 + 0.0338711665146927*x_48 + 0.0274644001074267*x_49 + 0.00529300932741977*x_50 - 0.0415840072506541*x_51 - 0.0092454920192244*x_52 + 0.00981810356567508*x_54 - 0.00638123837229798*x_55 + 0.0216501646385456*x_56 - 0.0360200060197878*x_57 - 0.046200844176823*x_58 + 0.0338081786455227*x_59 - 0.00144557510231821*x_6 - 0.00963535789105591*x_61 + 0.014023287520162*x_62 - 0.0022506352115473*x_63 - 0.00158376899202341*x_64 - 0.000198568134408968*x_65 + 0.00914341929275113*x_66 - 0.0180775812811281*x_67 - 0.00665282434760295*x_68 + 0.00478885033051087*x_69 + 0.0109739204801344*x_70 + 0.013510452214897*x_71 - 0.0107632790243756*x_72 - 0.0104722938714403*x_73 + 0.00803296889101774*x_74 - 0.0152815152291328*x_75 + 0.00825660697959927*x_76 - 0.00852616721404353*x_77 + 0.016775599855109*x_78 + 0.000281958291657607*x_79 + 0.0152812642686473*x_8 + 0.000759289260030922*x_80 - 0.0103592763899562*x_81 - 0.01069100191341*x_82 + 0.00311348549781856*x_83 + 0.0132865670810692*x_84 - 0.00235737358606654*x_85 - 0.0158264106899439*x_86 + 0.00961743547115476*x_87 - 0.0161390638234349*x_88 + 0.00422283338394563*x_89 + 0.0049530229756108*x_9 - 0.0105514336701591*x_90 + 0.00712121898307333*x_92 + 0.00461596605438462*x_93 + 0.00188534764304761*x_95 + 0.013232761526493*x_96 - 0.0193761484005259*x_97 - 0.0193370046733465*x_98 + 0.101862709979073*std::sin(0.216800004243851*x_11 + 5.18383979797363) - 0.253169881445643*std::sin(0.210319995880127*x_110 + 5.17592000961304) - 0.164072803675381*std::sin(0.290479928255081*x_112 + 1.95439982414246) - 0.0707328690134403*std::sin(0.461359858512878*x_16 - 1.4119998216629) + 0.107682561871606*std::sin(0.366319835186005*x_24 + 1.78495991230011) - 0.24674274383058*std::sin(0.271039962768555*x_29 + 5.00927972793579) - 0.0565928486363134*std::sin(0.263759940862656*x_3 + 8.26399993896484) + 0.0949688190511395*std::sin(0.382319837808609*x_31 - 4.20591974258423) - 0.0173413278453527*std::sin(0.348159849643707*x_32 - 1.19095981121063) - 0.214157358526478*std::sin(0.229359999299049*x_42 + 1.96647977828979) - 0.269094170784157*std::sin(0.207040011882782*x_47 - 7.58816003799438) - 0.163466060830586*std::sin(0.408159852027893*x_5 - 1.17863988876343) + 0.168777771059894*std::sin(0.247439980506897*x_53 + 1.98375976085663) - 0.185118471929613*std::sin(0.327759832143784*x_60 - 7.52952003479004) + 0.0857536153361593*std::sin(0.352479845285416*x_7 - 7.59647989273071) - 0.207930437461386*std::sin(0.367759823799133*x_91 + 5.19528007507324) - 0.123248535699283*std::sin(0.287359952926636*x_94 + 1.9755197763443) + 0.208105584403683*std::sin(0.248399972915649*x_99 + 1.98031985759735) - 2.17742297279932) + 0.827256709143543);
}

inline float score_3(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.00460855136764561*x_1 + 0.00137573755602332*x_10 - 0.00752315162552974*x_100 + 0.00489986550914376*x_101 - 0.00131591898203107*x_102 - 0.00588690026248774*x_103 + 0.0132767806577857*x_104 + 0.00166609745075696*x_105 + 0.0150873234814612*x_106 - 0.00165672488924324*x_107 - 0.00823792290197655*x_108 + 0.000836399752855193*x_109 + 0.000573594743117588*x_11 + 0.00182016485376973*x_110 + 0.00724543018798018*x_111 - 0.00943046732107804*x_112 - 0.00611278908752427*x_113 + 0.00631331166463825*x_114 - 0.00345009374637882*x_115 - 0.00723011524123934*x_116 - 0.00117349731031665*x_117 + 0.00625795275133786*x_118 - 0.0100821878792003*x_119 - 0.0105451955730505*x_12 - 0.0117877490614961*x_120 - 0.00261869846996439*x_13 + 0.00198095280448005*x_14 + 0.000454229309759447*x_15 + 0.00039303829945429*x_16 + 0.00545536313648614*x_17 + 0.000925577557068534*x_18 - 0.00788934388298281*x_19 + 0.00111457171885156*x_2 - 0.000819939335076751*x_20 - 0.000581083563569043*x_21 + 0.00121040740333863*x_22 - 0.00444391354678478*x_23 - 0.00339477879556364*x_24 - 0.00601553691699953*x_25 - 0.00737884699252685*x_26 + 0.00325613894899621*x_27 + 0.00049774946400827*x_28 - 0.00100646316769472*x_29 + 2.992776314549e-5*x_3 + 0.0023894660313271*x_30 + 3.47003219257355e-5*x_31 - 0.000573715040753868*x_32 + 0.00147278813066683*x_33 + 0.0061639920999331*x_34 + 0.00918997425791965*x_35 - 0.00115173124683583*x_36 - 0.00438174478715529*x_37 - 0.00703275346987114*x_38 - 0.000757351099129533*x_39 + 0.00482127644374592*x_4 - 0.000212442020595563*x_40 - 0.00397901573056469*x_41 - 0.00194031450403724*x_42 - 0.00108488854354672*x_43 + 0.00140819147701798*x_44 + 0.000342877896418968*x_45 - 0.00172121506051634*x_46 - 0.00665403919850624*x_47 + 0.00190271581637582*x_48 + 0.000158459943702446*x_49 + 0.00489052059510079*x_5 - 0.00318889676154943*x_50 - 0.0150908669247221*x_51 - 0.0122945691280389*x_52 - 0.0036069630954507*x_53 + 0.014422321171452*x_54 + 0.0139086171862796*x_55 + 0.0148286450901757*x_56 - 0.000459509773466013*x_57 - 0.0113841007869665*x_58 + 0.00585317952472767*x_59 - 0.00857410503537165*x_6 + 0.00373508579971929*x_60 - 0.000954943587268104*x_61 - 0.00405312297364275*x_62 - 0.000513674666868307*x_63 + 0.000153912250378414*x_64 - 0.00363006928683767*x_65 - 0.00321363798377781*x_66 - 0.00255644403443002*x_67 + 0.00250671152212311*x_68 - 0.00269169488747195*x_69 + 0.00137769471910327*x_7 + 0.00263642040116947*x_70 + 0.00171058188596308*x_71 + 0.00271351394491779*x_72 - 0.00333835361949773*x_73 + 0.0023576507942629*x_74 - 0.000660716550578169*x_75 - 0.00147575648616868*x_76 + 0.000592246670247121*x_77 + 0.00300145910967516*x_78 - 0.00534265301604928*x_79 + 0.00534318693986078*x_8 + 0.00715844925935691*x_80 - 0.00222071828690237*x_81 - 0.00507453193048244*x_82 - 0.00199771755720349*x_83 + 0.000835398023649203*x_84 + 0.00334450574538394*x_85 + 0.00763999864886932*x_86 - 0.00914382726368876*x_87 + 0.00584980757163452*x_88 - 0.0033958438581786*x_89 - 0.0129403736314673*x_9 - 9.18267792418741e-5*x_90 + 0.000112467804601616*x_91 + 0.00264955550618186*x_92 - 0.00639178015671262*x_93 - 0.00282482600447626*x_94 - 0.00138028801945159*x_95 + 0.00360705160412522*x_96 - 0.00288961644028673*x_97 + 0.00548209420467485*x_98 + 0.00341663900772275*x_99 - 2.8359186028254e-5*std::pow(-3.34895968437195*x_1 - 4.17543983459473, 2) - 2.08732517112803e-5*std::pow(-5.60767984390259*x_22 - 9.60639953613281, 2) + 7.66244782528494e-7*std::pow(-4.01999998092651*x_27 - 6.62815999984741, 2) - 0.00115105850934615*std::exp(0.163839861750603*x_49) + 0.00345179258043029*std::sin(0.329999834299088*x_1 + 5.14520025253296) - 0.0148867862150446*std::sin(0.342239856719971*x_1 + 8.34768009185791) - 0.000470210453478781*std::sin(0.359039843082428*x_1 - 1.03663980960846) - 0.0020579474449799*std::sin(0.408399850130081*x_1 + 8.39400005340576) + 0.000707248124393007*std::sin(0.146240040659904*x_10 + 8.17375946044922) + 0.0426730729350288*std::sin(0.339839845895767*x_10 + 5.03247976303101) - 0.00148373455340609*std::sin(0.352079838514328*x_10 + 8.25903987884521) - 0.000312512693093538*std::sin(0.366479843854904*x_10 + 8.24079990386963) - 0.0166864153483441*std::sin(0.242079973220825*x_100 + 1.9755197763443) + 0.00282610096717952*std::sin(0.257839977741241*x_100 + 1.95887982845306) - 0.00169996611189162*std::sin(0.229919984936714*x_101 + 1.98535978794098) + 0.0467147536578725*std::sin(0.221599996089935*x_102 + 1.97327971458435) - 0.000550228484428184*std::sin(0.239359974861145*x_102 - 1.2099198102951) - 0.00562847469485513*std::sin(0.247999966144562*x_107 + 5.15144014358521) + 0.00679005804331438*std::sin(0.246319979429245*x_108 + 1.97391986846924) - 0.000391574465315741*std::sin(0.23327998816967*x_109 + 1.95511984825134) + 0.00334781991810407*std::sin(0.23471999168396*x_109 + 1.98399984836578) - 0.00281248131339743*std::sin(0.246079966425896*x_109 - 7.44191980361938) + 0.0560669917769498*std::sin(0.247759968042374*x_109 - 1.21407985687256) + 0.0227555095115727*std::sin(0.252159982919693*x_109 - 1.214399933815) + 0.00895449231614801*std::sin(0.216800004243851*x_11 + 5.18383979797363) - 0.00176396521110424*std::sin(0.218799993395805*x_11 + 2.00231981277466) - 0.0458316978770781*std::sin(0.248719975352287*x_11 - 7.41408014297485) + 0.00438990551247274*std::sin(0.25655996799469*x_11 + 8.37376022338867) - 0.0222555217562035*std::sin(0.210319995880127*x_110 + 5.17592000961304) - 0.0521721474978089*std::sin(0.216240003705025*x_110 - 7.42695951461792) - 0.00622640157982271*std::sin(0.219759985804558*x_110 - 4.41991996765137) + 0.0136864326076535*std::sin(0.213039994239807*x_111 - 7.41463994979858) + 0.00312918502011258*std::sin(0.216879993677139*x_111 + 1.98231983184814) - 0.00758861554797246*std::sin(0.267279952764511*x_112 - 1.20023989677429) - 0.00154967643391688*std::sin(0.278399974107742*x_112 + 1.96583986282349) - 0.0144232237695413*std::sin(0.290479928255081*x_112 + 1.95439982414246) + 0.00614563254878337*std::sin(0.293919950723648*x_113 + 1.96367979049683) + 0.0105120974093038*std::sin(0.237119987607002*x_116 + 8.16991996765137) + 0.000513223611035427*std::sin(0.250639975070953*x_116 - 4.40895986557007) + 0.00781080595536588*std::sin(0.225919991731644*x_117 - 7.40279960632324) + 0.000425157404592696*std::sin(0.232319980859756*x_117 + 5.17903995513916) + 0.0146680183767715*std::sin(0.23471999168396*x_118 - 7.41639995574951) + 0.0100021857634963*std::sin(0.265759944915771*x_119 + 8.15824031829834) - 0.000490698014160838*std::sin(0.277439951896667*x_12 - 7.43567991256714) + 0.00458891645562263*std::sin(0.285599917173386*x_12 + 5.13567972183228) + 0.00391589171229181*std::sin(0.248639971017838*x_13 + 1.98823988437653) + 0.0242300665851444*std::sin(0.289919942617416*x_13 - 7.4443998336792) + 0.0421235145390805*std::sin(0.310239940881729*x_13 + 8.31328010559082) + 0.00742911642475643*std::sin(0.389119833707809*x_13 + 4.99919986724854) - 0.000528477635639525*std::sin(0.247759968042374*x_14 + 8.37184047698975) - 0.0494374118090908*std::sin(0.265839964151382*x_14 + 1.98951983451843) - 0.00557040819803441*std::sin(0.281199961900711*x_14 + 5.17095994949341) + 0.00212670437075128*std::sin(0.304159939289093*x_14 - 4.2577600479126) - 0.00804313281493854*std::sin(0.346159845590591*x_14 - 1.13391983509064) - 0.0015641459361755*std::sin(0.357839852571487*x_14 + 8.01512050628662) + 0.010158826099891*std::sin(0.280799955129623*x_15 - 1.3802398443222) - 0.00184417440055616*std::sin(0.300879925489426*x_15 - 7.43351984024048) + 0.000207127174362833*std::sin(0.333999842405319*x_15 + 8.27744007110596) - 0.00027299351400901*std::sin(0.274159938097*x_16 - 1.17031991481781) - 0.0173706446840572*std::sin(0.279039949178696*x_16 - 1.19951987266541) + 0.0014372583938047*std::sin(0.306239932775497*x_16 + 1.99111986160278) - 0.0262683888370815*std::sin(0.310719937086105*x_16 + 1.98639988899231) + 0.00413219882547586*std::sin(0.321919918060303*x_16 + 1.98375976085663) - 0.0181224000958055*std::sin(0.328959852457047*x_16 - 7.32767963409424) - 0.00621794700150895*std::sin(0.461359858512878*x_16 - 1.4119998216629) + 0.00546669094710569*std::sin(0.257359951734543*x_17 + 8.24071979522705) + 0.00168875969631785*std::sin(0.288959950208664*x_17 + 2.01887989044189) + 0.000550903515915612*std::sin(0.3503198325634*x_17 + 2.00575995445251) + 0.00292432472077811*std::sin(0.351999849081039*x_17 - 4.17120027542114) + 0.0362551683195406*std::sin(0.359679847955704*x_17 + 2.02319979667664) - 0.00107409737847118*std::sin(0.389599829912186*x_17 + 8.19871997833252) + 0.0640122225339605*std::sin(0.22095999121666*x_18 + 5.01007986068726) + 9.55629492018946e-5*std::sin(0.269839972257614*x_18 + 8.2186393737793) + 0.0250617123017974*std::sin(0.275279939174652*x_18 - 1.15727984905243) - 0.000412448161422586*std::sin(0.303439915180206*x_18 - 4.37415981292725) + 0.0125104108230009*std::sin(0.316159933805466*x_18 + 2.18255996704102) - 0.00977646926245276*std::sin(0.341119825839996*x_18 - 7.36839962005615) + 0.00313076237675073*std::sin(0.39743983745575*x_18 - 1.19631993770599) + 0.00110272659431757*std::sin(0.417519867420197*x_18 - 1.214479804039) - 0.000465951909452892*std::sin(0.249119967222214*x_19 - 7.57503986358643) + 0.00511820770196938*std::sin(0.270559966564178*x_19 + 5.01200008392334) + 0.0294571163037719*std::sin(0.345519840717316*x_2 - 7.40919971466064) + 0.00593076452547107*std::sin(0.391199827194214*x_2 - 4.21216011047363) - 0.00841152959131776*std::sin(0.423679858446121*x_2 + 5.21167993545532) + 0.000475712537969403*std::sin(0.262159943580627*x_20 + 8.19703960418701) + 0.00187007839345016*std::sin(0.269199967384338*x_20 + 2.0066397190094) - 0.000585305898978445*std::sin(0.273679971694946*x_20 - 7.41055965423584) - 0.0231810207448253*std::sin(0.282879948616028*x_20 + 1.99935972690582) - 0.00478644519693305*std::sin(0.289679944515228*x_20 + 1.98439979553223) + 0.0499167902992719*std::sin(0.327519834041595*x_20 + 8.24312019348145) - 0.00190831836890282*std::sin(0.341679841279984*x_20 + 8.24327945709229) - 0.00818888488875913*std::sin(0.366719841957092*x_20 + 1.7992799282074) + 0.0184916815756149*std::sin(0.311999946832657*x_21 + 1.99287974834442) - 0.0235438879130807*std::sin(0.343839854001999*x_21 + 8.24991989135742) - 0.000185737307413267*std::sin(0.436479866504669*x_21 + 1.78887987136841) + 0.00529631349553922*std::sin(0.338159829378128*x_22 + 2.02815985679626) - 0.000401845820710118*std::sin(0.353279858827591*x_22 - 7.37287998199463) - 0.0480609378105368*std::sin(0.373279839754105*x_22 + 1.98695981502533) + 0.000339490617830722*std::sin(0.398239850997925*x_22 + 5.19063997268677) - 0.000550508850407353*std::sin(0.212559998035431*x_23 - 1.18399977684021) - 0.00294221280316366*std::sin(0.323359936475754*x_23 + 5.21583986282349) - 0.00220742812728662*std::sin(0.344639837741852*x_23 - 1.16903984546661) + 0.00625536298999327*std::sin(0.3503198325634*x_23 + 2.028639793396) - 0.00124892891932439*std::sin(0.294959932565689*x_24 + 8.21343994140625) + 0.000690568206383123*std::sin(0.331279844045639*x_24 + 2.03863978385925) + 0.00946610072577609*std::sin(0.366319835186005*x_24 + 1.78495991230011) - 0.0313121914093255*std::sin(0.410559862852097*x_24 + 1.98767983913422) - 6.77531576726755e-5*std::sin(0.374479830265045*x_25 - 7.5918402671814) + 0.0036462630849421*std::sin(0.439119875431061*x_25 - 1.39551985263824) - 0.000312030073025027*std::sin(0.296079933643341*x_26 + 1.99919974803925) + 0.000409120189762986*std::sin(0.313919931650162*x_26 - 1.18519985675812) + 0.00360196536160291*std::sin(0.339119851589203*x_26 + 5.02279996871948) - 0.00106697494987426*std::sin(0.359279841184616*x_26 - 1.14727985858917) + 0.00916787184115025*std::sin(0.399359852075577*x_26 - 1.20367991924286) + 0.00398428177461337*std::sin(0.20040000975132*x_27 + 8.20024013519287) - 0.0025903876744824*std::sin(0.223039999604225*x_27 + 8.21224021911621) + 0.0037740313630233*std::sin(0.329599827528*x_27 + 2.0319197177887) - 0.010346365026189*std::sin(0.112960062921047*x_28 + 5.09511995315552) + 0.000379260514874486*std::sin(0.231039986014366*x_28 - 1.15839993953705) + 0.000923474672341893*std::sin(0.284159928560257*x_28 - 1.17151987552643) - 0.0256434945179998*std::sin(0.310159921646118*x_28 + 1.99215984344482) + 0.027063261180046*std::sin(0.326479852199554*x_28 - 1.12615978717804) - 0.00191604395835297*std::sin(0.335039854049683*x_28 + 8.22056007385254) - 0.155576834427697*std::sin(0.0978400707244873*x_29 - 7.69432020187378) - 0.000753550749007074*std::sin(0.106960065662861*x_29 - 4.49688005447388) - 0.0216905283999426*std::sin(0.271039962768555*x_29 + 5.00927972793579) + 0.00033656927947713*std::sin(0.314319908618927*x_29 + 1.99423980712891) + 0.0123590022376951*std::sin(0.3572798371315*x_29 + 8.236159324646) - 0.00497493369621625*std::sin(0.263759940862656*x_3 + 8.26399993896484) + 0.001874943212253*std::sin(0.291919946670532*x_3 - 4.32488012313843) - 0.0377149042715569*std::sin(0.308879911899567*x_3 - 1.10775983333588) - 0.00324343552120079*std::sin(0.319359928369522*x_3 + 5.25487995147705) - 0.00908170257386766*std::sin(0.377999842166901*x_3 + 1.98583984375) + 0.0119305518276867*std::sin(0.37967985868454*x_3 - 1.19287979602814) - 0.00275878288697114*std::sin(0.383679836988449*x_3 + 8.18943977355957) - 0.0143232686947009*std::sin(0.386799842119217*x_3 - 1.1865599155426) + 0.000279604203737425*std::sin(0.396639823913574*x_3 + 2.00367975234985) + 0.000788936937736644*std::sin(0.145920038223267*x_30 - 4.45616006851196) + 0.00132745640049237*std::sin(0.338719844818115*x_31 + 2.12823987007141) + 0.00127491630625842*std::sin(0.34079983830452*x_31 - 1.05159986019135) - 0.0183320616931657*std::sin(0.346719831228256*x_31 - 4.22328042984009) + 0.0142928135557519*std::sin(0.35335984826088*x_31 + 5.17592000961304) + 0.00834846786072925*std::sin(0.382319837808609*x_31 - 4.20591974258423) + 0.0155955948197834*std::sin(0.40871986746788*x_31 - 4.19944000244141) - 0.000623657456752764*std::sin(0.410959839820862*x_31 - 4.19831991195679) + 0.00245244372501015*std::sin(0.443759858608246*x_31 - 1.16527986526489) + 0.000868126288656374*std::sin(0.591199815273285*x_31 - 4.39583969116211) - 0.000204977379785539*std::sin(0.254879981279373*x_32 - 1.16591989994049) - 0.00185890167992958*std::sin(0.311599940061569*x_32 + 2.01239991188049) + 0.00176978916322661*std::sin(0.312719941139221*x_32 - 7.36104011535645) + 0.0101297243272233*std::sin(0.316399931907654*x_32 - 4.34007978439331) + 0.0205461570911955*std::sin(0.319839835166931*x_32 + 2.00407981872559) - 0.00152443212020292*std::sin(0.348159849643707*x_32 - 1.19095981121063) + 0.00391094406814556*std::sin(0.366799831390381*x_32 + 7.98663997650146) - 0.000202779516715418*std::sin(0.210879996418953*x_33 + 2.16375994682312) - 0.000720937694337914*std::sin(0.251279979944229*x_33 - 7.4314398765564) + 0.00187149471707778*std::sin(0.254719972610474*x_33 + 1.96607983112335) + 0.0661436058471796*std::sin(0.264319956302643*x_33 - 1.22359991073608) + 0.00696417067478284*std::sin(0.289119929075241*x_33 + 4.96567964553833) - 0.0112266119401601*std::sin(0.224159985780716*x_34 + 5.17888021469116) + 0.0338907199079426*std::sin(0.239119976758957*x_34 + 1.97639977931976) - 0.0704601196228563*std::sin(0.243359968066216*x_34 + 1.97447979450226) + 0.000337318796009635*std::sin(0.216480001807213*x_35 - 7.40999984741211) + 0.000482159745731794*std::sin(0.230159983038902*x_35 + 5.16847991943359) - 0.0145277463861581*std::sin(0.209199994802475*x_36 + 1.98423981666565) + 0.00046142610912222*std::sin(0.231439992785454*x_36 + 1.96879982948303) - 0.00300050355440389*std::sin(0.241999983787537*x_36 + 1.98503983020782) - 0.00676670266973693*std::sin(0.243279978632927*x_36 + 5.17535972595215) + 0.065530376958851*std::sin(0.261199980974197*x_36 - 1.21743988990784) - 0.000601593136833516*std::sin(0.2223199903965*x_37 - 1.1904798746109) + 0.00097615305787298*std::sin(0.233679980039597*x_38 - 4.23104000091553) - 0.00319551696499426*std::sin(0.246639966964722*x_38 - 4.40207958221436) - 0.00471814856855841*std::sin(0.313199937343597*x_4 + 2.00671982765198) - 0.0064321548374521*std::sin(0.32551982998848*x_4 + 5.22919988632202) + 0.00103878620616381*std::sin(0.332879841327667*x_4 - 1.16815984249115) - 0.00124762434133146*std::sin(0.382559835910797*x_4 + 2.01575970649719) - 0.00663076055054883*std::sin(0.416159868240356*x_4 - 4.40927982330322) - 0.000114404491925059*std::sin(0.443599849939346*x_4 + 5.17671966552734) + 0.00295109080310467*std::sin(0.225519984960556*x_40 + 1.99303984642029) + 0.000454851053407336*std::sin(0.23047998547554*x_40 + 1.9651198387146) - 0.00776790907412452*std::sin(0.236319988965988*x_41 - 7.4236798286438) + 0.0179823594021865*std::sin(0.241679981350899*x_41 - 7.42560005187988) + 0.00617779273983327*std::sin(0.26199996471405*x_41 + 1.97463977336884) + 0.000116932420084259*std::sin(0.222159996628761*x_42 + 4.99399995803833) - 0.0188260298765453*std::sin(0.229359999299049*x_42 + 1.96647977828979) + 0.00615715956085827*std::sin(0.25639995932579*x_42 + 5.14743995666504) - 0.0690850271185104*std::sin(0.211759999394417*x_43 - 1.20295989513397) - 0.0274787132884523*std::sin(0.242719978094101*x_44 - 1.20631992816925) + 0.0310040502969856*std::sin(0.260479986667633*x_44 + 1.94247984886169) - 0.0122957992467259*std::sin(0.267679959535599*x_44 - 7.4443998336792) + 0.0204064372966637*std::sin(0.194399997591972*x_46 - 7.60128021240234) - 0.00299725428582132*std::sin(0.249199971556664*x_46 + 1.97567975521088) - 0.0236553856175826*std::sin(0.207040011882782*x_47 - 7.58816003799438) - 0.00323765763084006*std::sin(0.253199964761734*x_48 - 1.20247983932495) + 0.0125134174578462*std::sin(0.296239942312241*x_49 + 5.06767988204956) - 0.00137648516678687*std::sin(0.309839934110641*x_5 + 1.81447994709015) + 0.00266102423709937*std::sin(0.364319831132889*x_5 - 1.16543984413147) + 0.0421021973809962*std::sin(0.388639837503433*x_5 + 2.00431990623474) + 0.00785876387302873*std::sin(0.388959854841232*x_5 + 4.98991966247559) - 0.0143698865459125*std::sin(0.408159852027893*x_5 - 1.17863988876343) + 0.0339121516926415*std::sin(0.181120008230209*x_50 - 7.37967967987061) - 0.0082404523233932*std::sin(0.215199992060661*x_52 - 1.20711994171143) + 0.00302464605032884*std::sin(0.242479979991913*x_53 + 1.96927976608276) + 0.0148368255115428*std::sin(0.247439980506897*x_53 + 1.98375976085663) - 0.000507311164120754*std::sin(0.214560002088547*x_57 - 7.41511964797974) + 0.000467406110055481*std::sin(0.222719997167587*x_59 - 1.18319988250732) + 0.0284483781136879*std::sin(0.265359938144684*x_6 + 5.20975971221924) - 0.000265088180715547*std::sin(0.477919846773148*x_6 + 4.96743965148926) + 0.0115461169438566*std::sin(0.255839973688126*x_60 + 8.34751987457275) - 0.0162732950538163*std::sin(0.327759832143784*x_60 - 7.52952003479004) - 0.0181630530775199*std::sin(0.390639841556549*x_60 - 4.37255954742432) - 0.00158291125565118*std::sin(0.490879863500595*x_60 + 1.69871997833252) + 0.0595430934540634*std::sin(0.149440035223961*x_61 - 1.27567994594574) + 0.00175842117666802*std::sin(0.240959972143173*x_61 + 8.25207996368408) - 0.0276773899450838*std::sin(0.285119920969009*x_7 + 8.39744091033936) + 0.000623954143055475*std::sin(0.336559861898422*x_7 + 5.23784017562866) - 0.0142963070314423*std::sin(0.349679857492447*x_7 + 2.00879979133606) + 0.00753838268947786*std::sin(0.352479845285416*x_7 - 7.59647989273071) + 0.000362112646798923*std::sin(0.364639848470688*x_7 + 1.99303984642029) - 0.00146532516922194*std::sin(0.39031982421875*x_7 + 1.9793598651886) + 0.00267655567366062*std::sin(0.457919865846634*x_7 + 7.9870400428772) + 0.00180026808952493*std::sin(0.323199838399887*x_8 - 1.12079977989197) + 0.00257218627031371*std::sin(0.334079831838608*x_8 + 8.25943946838379) - 0.00179662216972078*std::sin(0.335839837789536*x_8 - 4.34151983261108) - 0.000310350447395766*std::sin(0.34215983748436*x_8 - 1.14503979682922) + 0.000269184920304745*std::sin(0.259759962558746*x_9 + 5.17736005783081) - 0.00951057663005769*std::sin(0.280479967594147*x_9 + 1.99911975860596) - 0.00182630382419312*std::sin(0.334879845380783*x_9 + 5.06487989425659) + 0.0339955940513957*std::sin(0.333039849996567*x_91 + 8.41728019714355) - 0.010539682309808*std::sin(0.34775984287262*x_91 + 5.19016027450562) - 0.00134021368301165*std::sin(0.353039860725403*x_91 + 5.20071983337402) + 0.000286187059260491*std::sin(0.356399834156036*x_91 + 5.21304035186768) - 0.0182786370490612*std::sin(0.367759823799133*x_91 + 5.19528007507324) + 0.016084845705793*std::sin(0.400319844484329*x_91 + 1.97431981563568) + 0.000463563971314163*std::sin(0.484399855136871*x_91 - 7.60904026031494) + 0.0311664952837233*std::sin(0.268319964408875*x_92 - 7.3744797706604) + 0.0221802142392035*std::sin(0.286079943180084*x_92 + 5.21439981460571) - 0.0200496521751164*std::sin(0.289279937744141*x_92 + 2.00223970413208) - 0.000622523027029361*std::sin(0.299279928207397*x_92 - 7.40520000457764) - 0.00138708216619257*std::sin(0.300959944725037*x_92 + 1.80455982685089) - 0.00114460023365221*std::sin(0.316799849271774*x_92 + 8.22192001342773) - 0.0044539937690535*std::sin(0.270399957895279*x_94 + 5.1864800453186) + 0.000385495748367507*std::sin(0.285599917173386*x_94 + 1.98791980743408) - 0.010834465979969*std::sin(0.287359952926636*x_94 + 1.9755197763443) - 0.00297475457209921*std::sin(0.261279970407486*x_95 - 7.41343975067139) + 0.000506783614530664*std::sin(0.278959959745407*x_95 + 1.97447979450226) + 0.000458778610848164*std::sin(0.281039953231812*x_95 + 1.97343981266022) - 0.0203454480127186*std::sin(0.281679958105087*x_95 + 1.96399986743927) - 0.042471819668624*std::sin(0.28263995051384*x_95 - 4.40463972091675) - 0.000503289229670185*std::sin(0.273119956254959*x_96 + 8.19167995452881) + 0.000228324382231586*std::sin(0.278159946203232*x_96 - 7.4423999786377) + 0.000442613845758124*std::sin(0.262239962816238*x_97 + 5.17519998550415) - 0.00278379017228766*std::sin(0.273119956254959*x_97 + 1.97847986221313) - 0.000514746232530976*std::sin(0.27567994594574*x_97 + 1.97919988632202) - 0.0559752418294128*std::sin(0.28383994102478*x_97 + 8.18407917022705) - 0.00179193283207447*std::sin(0.284799933433533*x_97 + 8.18175983428955) + 0.0182940337722519*std::sin(0.248399972915649*x_99 + 1.98031985759735) + 0.256616672650585);
}

inline float score_4(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.0027284612090639*x_1 + 0.00539763858850956*x_10 - 0.000416646824927113*x_100 + 0.00404061793539881*x_101 + 0.00460021917641931*x_102 - 0.00963037390595692*x_103 + 0.00388168099086414*x_104 + 0.00556191269778459*x_105 - 0.00750961947442988*x_106 - 0.00123600180289058*x_107 + 0.00817375351158004*x_108 - 0.00143063424587937*x_109 - 0.000194419200888846*x_11 - 0.000325676989573602*x_110 - 0.00602952768280929*x_111 - 0.0001289738563139*x_112 + 0.00255802253693466*x_113 - 0.00384962530050051*x_114 + 0.00169152178710645*x_115 - 0.00790060959376462*x_116 + 0.00115458704953387*x_117 - 0.00411297668082591*x_118 + 0.00174845621104144*x_119 + 0.00735783626749556*x_12 - 0.00454888499490843*x_120 + 0.00451116963344251*x_13 - 0.0027330308183557*x_14 - 0.00831712106140093*x_15 + 9.3545638897027e-5*x_16 - 0.00611618405193661*x_17 - 0.00302718551993673*x_18 - 0.00194786740072879*x_19 + 0.000501492818452481*x_2 - 0.00192655367287036*x_20 - 0.00615915874250434*x_21 - 0.00391755826323912*x_22 - 0.00532143673069956*x_23 - 0.00183329370803384*x_24 + 0.00337677865157785*x_25 - 0.00125564459602455*x_26 - 0.00516309765575141*x_27 - 0.00465687384709096*x_28 + 0.00088877122325678*x_29 + 0.000178975725842531*x_3 - 0.00638325493555793*x_30 - 0.00148956896418317*x_31 - 0.0005491740682788*x_32 - 0.00977399053534266*x_33 - 0.00553530814709428*x_34 - 0.00737279644471623*x_35 - 0.00822401453712335*x_36 + 0.00658800304348195*x_37 - 0.00367785356026091*x_38 - 0.0036883726103679*x_39 - 0.00161591589210171*x_4 + 0.000494034720137151*x_40 + 0.00343046427869529*x_41 + 0.00377563435440783*x_42 + 0.00805092341630096*x_43 - 0.00753302983808857*x_44 + 6.30958040334793e-5*x_45 - 0.00603375413772493*x_46 + 0.00457156249532386*x_47 - 0.0110854123684519*x_48 - 0.00941705887826438*x_49 + 0.00113453142534348*x_5 + 0.00496495758939325*x_50 + 0.00976959411292204*x_51 + 0.00306667233078545*x_52 + 0.00361150554879585*x_53 - 0.000387477362776037*x_54 + 0.00666746166727914*x_55 - 0.0083771537340634*x_56 + 0.00965310592209123*x_57 + 0.0147199718402072*x_58 - 0.00956149540071728*x_59 + 0.00237580600865037*x_6 - 0.00298406088373845*x_60 + 0.0024353510981612*x_61 - 0.00205437829491028*x_62 + 0.000413328513036555*x_63 + 0.00192330472800584*x_64 + 3.29146865438451e-5*x_65 - 0.000780757148886925*x_66 + 0.00388786866821686*x_67 - 0.00178072743818105*x_68 - 7.0134521110252e-5*x_69 - 0.00348281311540844*x_7 - 0.0025383605245074*x_70 - 0.00337225102642116*x_71 + 0.000981059865866492*x_72 + 0.00170125493007289*x_73 - 0.000499595479194564*x_74 + 0.00155868158945254*x_75 - 0.00232980197703195*x_76 + 0.00207326250080994*x_77 - 0.00310013989460543*x_78 - 0.00276152613465064*x_79 - 0.00307378097058137*x_8 - 0.000358470076503731*x_80 + 0.00284256471254302*x_81 + 0.000601792914407709*x_82 - 0.000321984183253517*x_83 - 0.00245093506742243*x_84 + 0.00098423920740083*x_85 + 0.00199439983549472*x_86 - 0.00279839395586827*x_87 + 0.0039521339553773*x_88 - 0.000444738330186124*x_89 - 0.00140501659972425*x_9 + 0.00448245381919196*x_90 + 0.000230735965123151*x_91 - 0.00125554518095665*x_92 + 0.00396594697926944*x_93 + 0.000199667203541876*x_94 - 9.41962662492863e-5*x_95 + 0.000218941267144552*x_96 + 0.00470776610962046*x_97 + 0.00318578986750176*x_98 + 0.00258030648099407*x_99 - 9.28820270876041e-6*std::pow(-3.34895968437195*x_1 - 4.17543983459473, 2) - 6.8364089467235e-6*std::pow(-5.60767984390259*x_22 - 9.60639953613281, 2) + 4.58234100087616e-6*std::pow(-4.01999998092651*x_27 - 6.62815999984741, 2) - 0.000402378118543371*std::exp(-0.0207645256111801*x_1 - 0.0683165074556256*x_10 - 8.25459207442959e-5*x_100 - 0.131592859610978*x_101 - 0.0307477591383377*x_102 + 0.0183107929634263*x_103 + 0.0846169978745865*x_104 + 0.0947310694596184*x_105 + 0.0173587411176389*x_106 + 0.00734577093733936*x_108 + 0.0531894010137799*x_109 - 0.0355864270045206*x_110 + 0.135252158945766*x_111 + 0.0675916741522532*x_114 + 0.10896730222596*x_115 - 0.0214577952322803*x_116 - 0.0729517758191538*x_117 + 0.0564441284691869*x_118 + 0.0715656707618987*x_119 + 0.120319035459989*x_120 - 0.0754994271351693*x_13 - 0.0221288567927562*x_21 + 0.01504790789335*x_22 + 0.0476142849466647*x_24 - 0.0773496206544895*x_29 - 0.0996838223709755*x_30 - 0.0261593354230286*x_32 - 0.135274937675741*x_33 + 0.0987815080982925*x_34 + 0.0936580458221946*x_35 + 0.0304404475459254*x_37 + 0.129935982408093*x_39 - 0.0198882378447834*x_40 - 0.108775877405279*x_43 - 0.0898402637615062*x_44 + 0.132808188723386*x_45 - 0.00203764147108898*x_47 + 0.0389078364137513*x_48 - 0.0991849538795597*x_50 - 0.0374713428771036*x_51 + 0.139419237085208*x_52 + 0.0318272186194668*x_53 - 0.00989982834326344*x_54 - 0.227402226639776*x_55 - 0.10742752223828*x_56 + 0.106418158690269*x_57 - 0.0863912395102196*x_58 + 0.0160697707719816*x_59 - 0.0244618173870855*x_6 + 0.062697905205747*x_61 - 0.0335728947233981*x_62 - 0.088640594425008*x_63 + 0.0528113880300777*x_64 + 0.0340647279390578*x_65 + 0.0829284742898004*x_66 - 0.039438526717417*x_67 - 0.0425743887259521*x_68 - 0.0649317210696713*x_69 - 0.0577921623543348*x_70 + 0.0389465902878088*x_71 + 0.000750123800627559*x_72 - 0.0842139121273961*x_73 + 0.0727352913831639*x_74 - 0.0308849503769376*x_75 - 0.0840384984382172*x_76 - 0.0220713540752628*x_77 + 0.00969695260077378*x_78 - 0.0381471113740741*x_79 - 0.0359485627115049*x_80 + 0.0434489160412925*x_81 + 0.0313498803000732*x_82 + 0.0565509809675692*x_83 - 0.0108391634216443*x_84 + 0.0181591092953296*x_85 + 0.0824640650010748*x_86 - 0.0705612588784651*x_87 + 0.0498364160288984*x_88 - 0.0531170688955285*x_89 + 0.0953430415368233*x_9 - 0.101819992696148*x_90 - 0.0021234091299339*x_91 + 0.101789453878748*x_92 + 0.139902652157758*x_93 + 0.00435949265075829*x_94 + 0.0719782069612582*x_96 - 0.0983102115562947*x_97 - 0.188902678602014*x_98 - 0.0723483741398369*x_99 - 0.155389994005904*std::exp(0.163839861750603*x_49) - 0.759829880057737*std::sin(0.247999966144562*x_107 + 5.15144014358521) + 0.59262616602966*std::sin(0.25655996799469*x_11 + 8.37376022338867) - 1.02444394871151*std::sin(0.267279952764511*x_112 - 1.20023989677429) + 0.829644885263392*std::sin(0.293919950723648*x_113 + 1.96367979049683) + 0.619492141140462*std::sin(0.285599917173386*x_12 + 5.13567972183228) - 0.751991049520754*std::sin(0.281199961900711*x_14 + 5.17095994949341) - 0.248958890205369*std::sin(0.300879925489426*x_15 - 7.43351984024048) + 0.557836413621267*std::sin(0.321919918060303*x_16 + 1.98375976085663) + 0.394776457619997*std::sin(0.351999849081039*x_17 - 4.17120027542114) + 0.422645020220173*std::sin(0.39743983745575*x_18 - 1.19631993770599) + 0.690945123703372*std::sin(0.270559966564178*x_19 + 5.01200008392334) + 0.800638244346828*std::sin(0.391199827194214*x_2 - 4.21216011047363) - 0.64615802274335*std::sin(0.289679944515228*x_20 + 1.98439979553223) - 0.397191303600543*std::sin(0.323359936475754*x_23 + 5.21583986282349) + 0.492236314933244*std::sin(0.439119875431061*x_25 - 1.39551985263824) + 0.486256234070055*std::sin(0.339119851589203*x_26 + 5.02279996871948) + 0.509484710044333*std::sin(0.329599827528*x_27 + 2.0319197177887) - 1.39673316894695*std::sin(0.112960062921047*x_28 + 5.09511995315552) - 0.372428727809456*std::sin(0.383679836988449*x_3 + 8.18943977355957) + 0.331073714007481*std::sin(0.443759858608246*x_31 - 1.16527986526489) - 0.913487784289472*std::sin(0.243279978632927*x_36 + 5.17535972595215) - 0.43138672622149*std::sin(0.246639966964722*x_38 - 4.40207958221436) - 0.86832467117982*std::sin(0.32551982998848*x_4 + 5.22919988632202) - 1.04864812228553*std::sin(0.236319988965988*x_41 - 7.4236798286438) + 0.831201002804491*std::sin(0.25639995932579*x_42 + 5.14743995666504) - 0.404621764859293*std::sin(0.249199971556664*x_46 + 1.97567975521088) + 0.359231556775789*std::sin(0.364319831132889*x_5 - 1.16543984413147) - 0.213689024954288*std::sin(0.490879863500595*x_60 + 1.69871997833252) + 0.361328261517173*std::sin(0.457919865846634*x_7 + 7.9870400428772) - 0.242539459043112*std::sin(0.335839837789536*x_8 - 4.34151983261108) - 0.401584360286002*std::sin(0.261279970407486*x_95 - 7.41343975067139)) + 0.0182512229821361*std::sin(0.329999834299088*x_1 + 5.14520025253296) - 0.00796035056939771*std::sin(0.342239856719971*x_1 + 8.34768009185791) - 0.00281197952553271*std::sin(0.359039843082428*x_1 - 1.03663980960846) + 0.00161740296528457*std::sin(0.408399850130081*x_1 + 8.39400005340576) - 0.0303598006475916*std::sin(0.146240040659904*x_10 + 8.17375946044922) - 0.00818366050138501*std::sin(0.339839845895767*x_10 + 5.03247976303101) - 0.00784519044801326*std::sin(0.352079838514328*x_10 + 8.25903987884521) - 0.00186890633321017*std::sin(0.366479843854904*x_10 + 8.24079990386963) - 0.00892265892722767*std::sin(0.242079973220825*x_100 + 1.9755197763443) + 0.0149429021936174*std::sin(0.257839977741241*x_100 + 1.95887982845306) - 0.00898850665190934*std::sin(0.229919984936714*x_101 + 1.98535978794098) - 0.00895875684706191*std::sin(0.221599996089935*x_102 + 1.97327971458435) - 0.00329050794411309*std::sin(0.239359974861145*x_102 - 1.2099198102951) - 0.000273746381449696*std::sin(0.246319979429245*x_108 + 1.97391986846924) + 0.016808984422371*std::sin(0.23327998816967*x_109 + 1.95511984825134) + 0.0177014714545036*std::sin(0.23471999168396*x_109 + 1.98399984836578) + 0.00221041388942801*std::sin(0.246079966425896*x_109 - 7.44191980361938) - 0.0107522893121639*std::sin(0.247759968042374*x_109 - 1.21407985687256) + 0.0074528861609088*std::sin(0.252159982919693*x_109 - 1.214399933815) - 0.0238619160682563*std::sin(0.216800004243851*x_11 + 5.18383979797363) - 0.00932689947336903*std::sin(0.218799993395805*x_11 + 2.00231981277466) + 0.00878940816376438*std::sin(0.248719975352287*x_11 - 7.41408014297485) + 0.059306476956164*std::sin(0.210319995880127*x_110 + 5.17592000961304) + 0.0100053526353799*std::sin(0.216240003705025*x_110 - 7.42695951461792) - 0.00203927150666178*std::sin(0.219759985804558*x_110 - 4.41991996765137) - 0.000551778994730282*std::sin(0.213039994239807*x_111 - 7.41463994979858) + 0.0165454476836831*std::sin(0.216879993677139*x_111 + 1.98231983184814) - 0.00819385565225728*std::sin(0.278399974107742*x_112 + 1.96583986282349) + 0.0384349824502976*std::sin(0.290479928255081*x_112 + 1.95439982414246) + 0.00562109103932376*std::sin(0.237119987607002*x_116 + 8.16991996765137) + 0.00306920927762128*std::sin(0.250639975070953*x_116 - 4.40895986557007) - 0.00031489861395109*std::sin(0.225919991731644*x_117 - 7.40279960632324) - 0.0182505878801159*std::sin(0.232319980859756*x_117 + 5.17903995513916) - 0.000591352375497348*std::sin(0.23471999168396*x_118 - 7.41639995574951) + 0.00534842806147136*std::sin(0.265759944915771*x_119 + 8.15824031829834) - 0.00293450041110603*std::sin(0.277439951896667*x_12 - 7.43567991256714) + 0.0207051296245696*std::sin(0.248639971017838*x_13 + 1.98823988437653) + 0.00793583320287699*std::sin(0.289919942617416*x_13 - 7.4443998336792) - 0.0080782685286772*std::sin(0.310239940881729*x_13 + 8.31328010559082) - 0.000299510508698521*std::sin(0.389119833707809*x_13 + 4.99919986724854) + 0.0226857804373771*std::sin(0.247759968042374*x_14 + 8.37184047698975) + 0.0094808966518241*std::sin(0.265839964151382*x_14 + 1.98951983451843) - 0.00167144110697656*std::sin(0.304159939289093*x_14 - 4.2577600479126) - 0.00263428745536641*std::sin(0.346159845590591*x_14 - 1.13391983509064) - 0.00827036259930266*std::sin(0.357839852571487*x_14 + 8.01512050628662) - 0.000409560841289136*std::sin(0.280799955129623*x_15 - 1.3802398443222) - 0.0088912780472221*std::sin(0.333999842405319*x_15 + 8.27744007110596) + 0.011718700096253*std::sin(0.274159938097*x_16 - 1.17031991481781) - 0.0056892348337019*std::sin(0.279039949178696*x_16 - 1.19951987266541) + 0.00759944950834981*std::sin(0.306239932775497*x_16 + 1.99111986160278) + 0.00503763993018145*std::sin(0.310719937086105*x_16 + 1.98639988899231) - 0.0096905172034854*std::sin(0.328959852457047*x_16 - 7.32767963409424) + 0.0165695747149514*std::sin(0.461359858512878*x_16 - 1.4119998216629) - 0.000220393825167292*std::sin(0.257359951734543*x_17 + 8.24071979522705) + 0.00892925315254587*std::sin(0.288959950208664*x_17 + 2.01887989044189) + 0.00329454480613454*std::sin(0.3503198325634*x_17 + 2.00575995445251) - 0.00695286204017753*std::sin(0.359679847955704*x_17 + 2.02319979667664) + 0.000844165524820115*std::sin(0.389599829912186*x_17 + 8.19871997833252) - 0.0122759918873109*std::sin(0.22095999121666*x_18 + 5.01007986068726) - 0.00410219834736989*std::sin(0.269839972257614*x_18 + 8.2186393737793) + 0.00820821386960168*std::sin(0.275279939174652*x_18 - 1.15727984905243) - 0.00246654615328807*std::sin(0.303439915180206*x_18 - 4.37415981292725) + 0.00668964103330992*std::sin(0.316159933805466*x_18 + 2.18255996704102) + 0.000394145833051565*std::sin(0.341119825839996*x_18 - 7.36839962005615) + 0.00583062524536533*std::sin(0.417519867420197*x_18 - 1.214479804039) + 0.0200017597706539*std::sin(0.249119967222214*x_19 - 7.57503986358643) - 0.00564916052675453*std::sin(0.345519840717316*x_2 - 7.40919971466064) - 0.00449786296414223*std::sin(0.423679858446121*x_2 + 5.21167993545532) - 0.0204207509644599*std::sin(0.262159943580627*x_20 + 8.19703960418701) - 0.00146975101150382*std::sin(0.269199967384338*x_20 + 2.0066397190094) - 0.00350027991067446*std::sin(0.273679971694946*x_20 - 7.41055965423584) - 0.00759224963154465*std::sin(0.282879948616028*x_20 + 1.99935972690582) - 0.00957282982057626*std::sin(0.327519834041595*x_20 + 8.24312019348145) - 0.0100901613466618*std::sin(0.341679841279984*x_20 + 8.24327945709229) + 0.000330141155216354*std::sin(0.366719841957092*x_20 + 1.7992799282074) + 0.00605639691946884*std::sin(0.311999946832657*x_21 + 1.99287974834442) + 0.00451514672628964*std::sin(0.343839854001999*x_21 + 8.24991989135742) - 0.00111075689982986*std::sin(0.436479866504669*x_21 + 1.78887987136841) - 0.000213524927942935*std::sin(0.338159829378128*x_22 + 2.02815985679626) - 0.00240314142720082*std::sin(0.353279858827591*x_22 - 7.37287998199463) + 0.00921692232050983*std::sin(0.373279839754105*x_22 + 1.98695981502533) - 0.0145731987453685*std::sin(0.398239850997925*x_22 + 5.19063997268677) - 0.00329218460482373*std::sin(0.212559998035431*x_23 - 1.18399977684021) + 0.00173488434188893*std::sin(0.344639837741852*x_23 - 1.16903984546661) + 0.00204875694986624*std::sin(0.3503198325634*x_23 + 2.028639793396) - 0.00660366452047541*std::sin(0.294959932565689*x_24 + 8.21343994140625) + 0.0041297755993441*std::sin(0.331279844045639*x_24 + 2.03863978385925) - 0.0252252492980302*std::sin(0.366319835186005*x_24 + 1.78495991230011) + 0.0060049189435795*std::sin(0.410559862852097*x_24 + 1.98767983913422) + 0.00290841684727359*std::sin(0.374479830265045*x_25 - 7.5918402671814) + 0.0133944092410617*std::sin(0.296079933643341*x_26 + 1.99919974803925) + 0.00244664402627427*std::sin(0.313919931650162*x_26 - 1.18519985675812) + 0.000838567793371345*std::sin(0.359279841184616*x_26 - 1.14727985858917) + 0.00300266206454948*std::sin(0.399359852075577*x_26 - 1.20367991924286) + 0.0210667394977322*std::sin(0.20040000975132*x_27 + 8.20024013519287) + 0.00203586380019796*std::sin(0.223039999604225*x_27 + 8.21224021911621) - 0.016280387643268*std::sin(0.231039986014366*x_28 - 1.15839993953705) - 0.000725786597249848*std::sin(0.284159928560257*x_28 - 1.17151987552643) + 0.0049178003544285*std::sin(0.310159921646118*x_28 + 1.99215984344482) + 0.00886376130647604*std::sin(0.326479852199554*x_28 - 1.12615978717804) - 0.0101310101092794*std::sin(0.335039854049683*x_28 + 8.22056007385254) + 0.0298358638660714*std::sin(0.0978400707244873*x_29 - 7.69432020187378) + 0.0323474177288668*std::sin(0.106960065662861*x_29 - 4.49688005447388) + 0.0578008836103629*std::sin(0.271039962768555*x_29 + 5.00927972793579) + 0.00201277091100591*std::sin(0.314319908618927*x_29 + 1.99423980712891) + 0.00404782132841784*std::sin(0.3572798371315*x_29 + 8.236159324646) + 0.0132571949489727*std::sin(0.263759940862656*x_3 + 8.26399993896484) + 0.00991369146561126*std::sin(0.291919946670532*x_3 - 4.32488012313843) + 0.00723280399493564*std::sin(0.308879911899567*x_3 - 1.10775983333588) + 0.00254911379904103*std::sin(0.319359928369522*x_3 + 5.25487995147705) + 0.000366135782807705*std::sin(0.377999842166901*x_3 + 1.98583984375) + 0.00637957539410196*std::sin(0.37967985868454*x_3 - 1.19287979602814) - 0.00469115802392493*std::sin(0.386799842119217*x_3 - 1.1865599155426) - 0.0120024749347794*std::sin(0.396639823913574*x_3 + 2.00367975234985) - 0.0338664286649931*std::sin(0.145920038223267*x_30 - 4.45616006851196) - 0.00104328802160607*std::sin(0.338719844818115*x_31 + 2.12823987007141) + 0.00674107184800286*std::sin(0.34079983830452*x_31 - 1.05159986019135) + 0.0035156448520998*std::sin(0.346719831228256*x_31 - 4.22328042984009) + 0.0046811833545603*std::sin(0.35335984826088*x_31 + 5.17592000961304) - 0.0222469831184077*std::sin(0.382319837808609*x_31 - 4.20591974258423) - 0.000628748328988867*std::sin(0.40871986746788*x_31 - 4.19944000244141) - 0.00372963209635175*std::sin(0.410959839820862*x_31 - 4.19831991195679) + 0.000464209635067578*std::sin(0.591199815273285*x_31 - 4.39583969116211) - 0.0012258174842561*std::sin(0.254879981279373*x_32 - 1.16591989994049) + 0.00146096689525517*std::sin(0.311599940061569*x_32 + 2.01239991188049) + 0.00935769340039271*std::sin(0.312719941139221*x_32 - 7.36104011535645) - 0.00194263546458984*std::sin(0.316399931907654*x_32 - 4.34007978439331) + 0.00672927889252285*std::sin(0.319839835166931*x_32 + 2.00407981872559) + 0.00406230415078228*std::sin(0.348159849643707*x_32 - 1.19095981121063) + 0.00209128319504465*std::sin(0.366799831390381*x_32 + 7.98663997650146) + 0.0087046476202093*std::sin(0.210879996418953*x_33 + 2.16375994682312) - 0.00431139295322889*std::sin(0.251279979944229*x_33 - 7.4314398765564) - 0.00147086414295949*std::sin(0.254719972610474*x_33 + 1.96607983112335) - 0.0126847395174677*std::sin(0.264319956302643*x_33 - 1.22359991073608) + 0.00228090569529545*std::sin(0.289119929075241*x_33 + 4.96567964553833) - 0.0060031604846952*std::sin(0.224159985780716*x_34 + 5.17888021469116) + 0.0110998910948*std::sin(0.239119976758957*x_34 + 1.97639977931976) + 0.0135125421775544*std::sin(0.243359968066216*x_34 + 1.97447979450226) - 0.0144799696857837*std::sin(0.216480001807213*x_35 - 7.40999984741211) + 0.00254940145658001*std::sin(0.230159983038902*x_35 + 5.16847991943359) + 0.000585697202948865*std::sin(0.209199994802475*x_36 + 1.98423981666565) - 0.0198074822730247*std::sin(0.231439992785454*x_36 + 1.96879982948303) - 0.0158650492907922*std::sin(0.241999983787537*x_36 + 1.98503983020782) - 0.0125671370884286*std::sin(0.261199980974197*x_36 - 1.21743988990784) + 0.0258243847884363*std::sin(0.2223199903965*x_37 - 1.1904798746109) - 0.000767188129233682*std::sin(0.233679980039597*x_38 - 4.23104000091553) + 0.000190215766867654*std::sin(0.313199937343597*x_4 + 2.00671982765198) + 0.00549254285641334*std::sin(0.332879841327667*x_4 - 1.16815984249115) + 0.000980545598554115*std::sin(0.382559835910797*x_4 + 2.01575970649719) - 0.00354563958678728*std::sin(0.416159868240356*x_4 - 4.40927982330322) + 0.00491100286906344*std::sin(0.443599849939346*x_4 + 5.17671966552734) - 0.0023193512678902*std::sin(0.225519984960556*x_40 + 1.99303984642029) + 0.00272012636019827*std::sin(0.23047998547554*x_40 + 1.9651198387146) + 0.00588958368349807*std::sin(0.241679981350899*x_41 - 7.42560005187988) - 0.000249062437623887*std::sin(0.26199996471405*x_41 + 1.97463977336884) - 0.00501951838478943*std::sin(0.222159996628761*x_42 + 4.99399995803833) + 0.0501675727614956*std::sin(0.229359999299049*x_42 + 1.96647977828979) + 0.0132488327833259*std::sin(0.211759999394417*x_43 - 1.20295989513397) - 0.00899983021179704*std::sin(0.242719978094101*x_44 - 1.20631992816925) - 0.0059458249511279*std::sin(0.260479986667633*x_44 + 1.94247984886169) - 0.00657488265908987*std::sin(0.267679959535599*x_44 - 7.4443998336792) - 0.00391345978605663*std::sin(0.194399997591972*x_46 - 7.60128021240234) + 0.0630368318202779*std::sin(0.207040011882782*x_47 - 7.58816003799438) - 0.0171189925186381*std::sin(0.253199964761734*x_48 - 1.20247983932495) - 0.000504487992120724*std::sin(0.296239942312241*x_49 + 5.06767988204956) - 0.00727811336436045*std::sin(0.309839934110641*x_5 + 1.81447994709015) - 0.00807418041473044*std::sin(0.388639837503433*x_5 + 2.00431990623474) + 0.00420228480262616*std::sin(0.388959854841232*x_5 + 4.98991966247559) + 0.0382928495064511*std::sin(0.408159852027893*x_5 - 1.17863988876343) + 0.0181337067743478*std::sin(0.181120008230209*x_50 - 7.37967967987061) + 0.000332220135770228*std::sin(0.215199992060661*x_52 - 1.20711994171143) + 0.015992701826744*std::sin(0.242479979991913*x_53 + 1.96927976608276) - 0.0395371476769658*std::sin(0.247439980506897*x_53 + 1.98375976085663) + 0.0217771744848703*std::sin(0.214560002088547*x_57 - 7.41511964797974) - 0.0200641837472945*std::sin(0.222719997167587*x_59 - 1.18319988250732) + 0.00931741490718887*std::sin(0.265359938144684*x_6 + 5.20975971221924) - 0.00158529554398023*std::sin(0.477919846773148*x_6 + 4.96743965148926) + 0.00378158507676307*std::sin(0.255839973688126*x_60 + 8.34751987457275) + 0.0433650492979792*std::sin(0.327759832143784*x_60 - 7.52952003479004) - 0.0097122554068466*std::sin(0.390639841556549*x_60 - 4.37255954742432) - 0.0114189213130302*std::sin(0.149440035223961*x_61 - 1.27567994594574) + 0.00929758560054545*std::sin(0.240959972143173*x_61 + 8.25207996368408) - 0.00906490080509452*std::sin(0.285119920969009*x_7 + 8.39744091033936) + 0.00373140635679739*std::sin(0.336559861898422*x_7 + 5.23784017562866) - 0.00764460604015504*std::sin(0.349679857492447*x_7 + 2.00879979133606) - 0.02008826951611*std::sin(0.352479845285416*x_7 - 7.59647989273071) - 0.0155442869194207*std::sin(0.364639848470688*x_7 + 1.99303984642029) + 0.00115164324511156*std::sin(0.39031982421875*x_7 + 1.9793598651886) - 0.00141488498815054*std::sin(0.323199838399887*x_8 - 1.12079977989197) + 0.0136003378178745*std::sin(0.334079831838608*x_8 + 8.25943946838379) + 0.0133223085206664*std::sin(0.34215983748436*x_8 - 1.14503979682922) - 0.0115552098845138*std::sin(0.259759962558746*x_9 + 5.17736005783081) + 0.000383426168284641*std::sin(0.280479967594147*x_9 + 1.99911975860596) + 0.00143534725727136*std::sin(0.334879845380783*x_9 + 5.06487989425659) - 0.00651953049369348*std::sin(0.333039849996567*x_91 + 8.41728019714355) - 0.003451957530865*std::sin(0.34775984287262*x_91 + 5.19016027450562) + 0.00105331435470121*std::sin(0.353039860725403*x_91 + 5.20071983337402) - 0.012285054943802*std::sin(0.356399834156036*x_91 + 5.21304035186768) + 0.048708881275186*std::sin(0.367759823799133*x_91 + 5.19528007507324) - 0.000648472852521926*std::sin(0.400319844484329*x_91 + 1.97431981563568) + 0.00245107700123878*std::sin(0.484399855136871*x_91 - 7.60904026031494) - 0.00597697796004379*std::sin(0.268319964408875*x_92 - 7.3744797706604) - 0.000894212295245303*std::sin(0.286079943180084*x_92 + 5.21439981460571) - 0.0107210688595179*std::sin(0.289279937744141*x_92 + 2.00223970413208) + 0.0267228350946385*std::sin(0.299279928207397*x_92 - 7.40520000457764) - 0.00733414459873749*std::sin(0.300959944725037*x_92 + 1.80455982685089) + 0.000899575845092869*std::sin(0.316799849271774*x_92 + 8.22192001342773) + 0.000179566164162382*std::sin(0.270399957895279*x_94 + 5.1864800453186) + 0.00230536378672462*std::sin(0.285599917173386*x_94 + 1.98791980743408) + 0.0288716667266751*std::sin(0.287359952926636*x_94 + 1.9755197763443) - 0.0217545285423298*std::sin(0.278959959745407*x_95 + 1.97447979450226) + 0.00274361416449367*std::sin(0.281039953231812*x_95 + 1.97343981266022) - 0.0108792385631912*std::sin(0.281679958105087*x_95 + 1.96399986743927) + 0.00814506500558933*std::sin(0.28263995051384*x_95 - 4.40463972091675) - 0.00300979912033699*std::sin(0.273119956254959*x_96 + 8.19167995452881) - 0.00980120340861241*std::sin(0.278159946203232*x_96 - 7.4423999786377) + 0.00264694470907867*std::sin(0.262239962816238*x_97 + 5.17519998550415) - 0.0147191854626351*std::sin(0.273119956254959*x_97 + 1.97847986221313) + 0.0220963371478031*std::sin(0.27567994594574*x_97 + 1.97919988632202) + 0.0107346938973035*std::sin(0.28383994102478*x_97 + 8.18407917022705) + 0.00140833405792651*std::sin(0.284799933433533*x_97 + 8.18175983428955) - 0.0487499104372569*std::sin(0.248399972915649*x_99 + 1.98031985759735) + 0.411091956224583);
}

inline float score_5(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.00152741624310084*x_1 - 0.00150020438206106*x_10 + 0.00855785146182721*x_100 - 0.0094886071066198*x_101 - 0.00142012943538162*x_102 + 0.0176531229031653*x_103 - 0.0152479820683947*x_104 + 0.00109184878038559*x_105 - 0.000372178454675587*x_106 + 0.0033500713772668*x_107 + 0.00172293828083351*x_108 + 0.0012441464924414*x_109 - 0.00241744111290601*x_11 + 0.00478560537131007*x_110 + 0.00616993638971982*x_111 + 0.016298386513298*x_112 + 0.00118281420221154*x_113 + 0.00152382346182533*x_114 + 0.00137952816521176*x_115 + 0.0205930182036871*x_116 + 0.00346863360926051*x_117 - 0.00896039363584742*x_118 + 0.0133093303751209*x_119 - 0.00325338481356195*x_12 + 0.0239275034878059*x_120 - 0.00380514655989224*x_13 - 0.000362239877421246*x_14 + 0.00306221395994447*x_15 + 0.000419759346312006*x_16 + 0.00465408696989405*x_17 + 0.00121839550058598*x_18 - 0.00360175144468549*x_19 - 4.6706731613424e-5*x_2 + 0.000384423526891187*x_20 + 0.00337476908542037*x_21 + 0.00241323490011972*x_22 + 0.00597035388677066*x_23 - 0.000811699297072741*x_24 - 0.00815277447100398*x_25 - 0.00154644088837299*x_26 - 0.0021853233346045*x_27 + 0.0022814970089013*x_28 + 0.000568365111619029*x_29 - 0.000671855537455033*x_3 - 0.00752956290821768*x_30 + 0.00289887578111409*x_31 + 0.000840315957639333*x_32 + 0.00214570398553015*x_33 + 0.00601890787156435*x_34 - 0.00724944315268185*x_35 + 0.00510900852403696*x_36 - 0.00147021914560378*x_37 + 0.00352756558576771*x_38 - 0.0128872226907372*x_39 + 0.00127294159672886*x_4 - 0.00742245443165028*x_40 - 0.00579655360486867*x_41 + 0.0100836859738308*x_42 - 0.00391940094658266*x_43 + 0.000929201110252049*x_44 - 0.00845052250371905*x_45 + 0.00689087049855351*x_46 - 0.00266070169964711*x_47 - 0.000456060719214551*x_48 + 0.01444598397418*x_49 + 0.00142793163330575*x_5 + 0.00257351144242272*x_50 - 0.0055060334955703*x_51 + 0.00629965002753953*x_52 - 0.00244385773784187*x_53 - 0.0136859658611906*x_54 - 0.0140463096525568*x_55 - 0.00543245542466511*x_56 - 0.00985499739173581*x_57 - 0.0144143958892676*x_58 + 0.00361033092681521*x_59 + 0.0112589514379228*x_6 - 0.00768927259826953*x_60 - 0.000977277322057936*x_61 + 0.00391765166413041*x_62 - 1.07447779266252e-5*x_63 - 0.00193887528432907*x_64 + 0.000613803136993131*x_65 + 0.00555049304852652*x_66 - 0.00136117054819076*x_67 - 0.00437355078163635*x_68 - 0.00061653091885928*x_69 - 0.00265995032546613*x_7 + 0.00268173179675791*x_70 + 0.00216775346363508*x_71 - 0.000986886500169591*x_72 - 0.0028372015459782*x_73 - 0.000540808262894656*x_74 + 0.00130320234055595*x_75 + 0.00244636691365788*x_76 - 0.00168419082316585*x_77 + 0.00194759720399441*x_78 + 0.0044857313256758*x_79 - 0.00165437428933634*x_8 - 0.00576892204839466*x_80 - 0.0010467411237843*x_81 + 0.00243688292998006*x_82 - 0.00155972049975622*x_83 - 0.000178852399493752*x_84 - 0.00666886636467864*x_85 - 0.00250805766846202*x_86 + 0.00713211336693991*x_87 + 0.000788777871713722*x_88 + 0.000391275345732443*x_89 + 0.00880453177110888*x_9 - 0.00304252319220435*x_90 - 0.00064625516228814*x_91 + 0.00113588831081276*x_92 + 0.00341871714357858*x_93 + 0.00744823043384145*x_94 + 7.47366800426057e-5*x_95 + 0.00690008074436814*x_96 - 0.00239681040733389*x_97 - 0.00922547640679141*x_98 + 0.00110396800274884*x_99 - 4.75636957294501e-6*std::pow(-3.34895968437195*x_1 - 4.17543983459473, 2) - 3.50083740869867e-6*std::pow(-5.60767984390259*x_22 - 9.60639953613281, 2) - 1.72016130201624e-5*std::pow(-4.01999998092651*x_27 - 6.62815999984741, 2) - 0.000792937142749969*std::exp(-0.0153402857330456*x_1 - 0.0504704400320504*x_10 - 6.09827565544307e-5*x_100 - 0.097217345807027*x_101 - 0.0227156362570115*x_102 + 0.0135275325484133*x_103 + 0.0625128139007314*x_104 + 0.0699848241428209*x_105 + 0.0128241816691046*x_106 + 0.00542686248741533*x_108 + 0.0392949314036633*x_109 - 0.026290316893808*x_110 + 0.0999207399721298*x_111 + 0.0499349522395157*x_114 + 0.0805021787160568*x_115 - 0.0158524551067582*x_116 - 0.0538948544625724*x_117 + 0.0416994384983136*x_118 + 0.0528708364795724*x_119 + 0.0888885408529098*x_120 - 0.0557769922906962*x_13 - 0.0163482177490129*x_21 + 0.0111169988224654*x_22 + 0.0351761821933084*x_24 - 0.0571438666310625*x_29 - 0.0736437878123055*x_30 - 0.019325829421298*x_32 - 0.0999375682991039*x_33 + 0.0729771817446711*x_34 + 0.0691921024835535*x_35 + 0.022488602530118*x_37 + 0.0959932884799895*x_39 - 0.0146929073641577*x_40 - 0.0803607590900745*x_43 - 0.0663716254462201*x_44 + 0.0981151990107616*x_45 - 0.00150535596012742*x_47 + 0.0287440868632309*x_48 - 0.0732752368834361*x_50 - 0.0276828431960996*x_51 + 0.102999267771317*x_52 + 0.0235131125484442*x_53 - 0.0073137329663817*x_54 - 0.167998787851273*x_55 - 0.0793646297337526*x_56 + 0.0786189384752596*x_57 - 0.0638235769857991*x_58 + 0.0118719242578801*x_59 - 0.0180717477150276*x_6 + 0.0463195643728894*x_61 - 0.0248027721695259*x_62 - 0.0654853412733158*x_63 + 0.0390156653472468*x_64 + 0.0251661256215865*x_65 + 0.0612653770585596*x_66 - 0.0291361469105649*x_67 - 0.0314528393374042*x_68 - 0.0479698488180664*x_69 - 0.0426953305000487*x_70 + 0.0287727172067521*x_71 + 0.000554171747154639*x_72 - 0.0622150247456789*x_73 + 0.0537349214514828*x_74 - 0.022816989538064*x_75 - 0.0620854337228027*x_76 - 0.0163057362527681*x_77 + 0.00716385370035024*x_78 - 0.0281820831993163*x_79 - 0.0265578532355141*x_80 + 0.0320989171313246*x_81 + 0.0231604675447517*x_82 + 0.0417783783155369*x_83 - 0.00800768903218641*x_84 + 0.0134154726413771*x_85 + 0.0609222836828894*x_86 - 0.0521288033807164*x_87 + 0.0368178342289029*x_88 - 0.0392414943359242*x_89 + 0.0704369330279819*x_9 - 0.0752219343000327*x_90 - 0.0015687188521083*x_91 + 0.0751993730244398*x_92 + 0.103356402120517*x_93 + 0.00322067858259845*x_94 + 0.0531756073802855*x_96 - 0.0726290002473124*x_97 - 0.139556333708502*x_98 - 0.053449077162101*x_99 - 0.114798043198413*std::exp(0.163839861750603*x_49) - 0.561342343516657*std::sin(0.247999966144562*x_107 + 5.15144014358521) + 0.437816634485475*std::sin(0.25655996799469*x_11 + 8.37376022338867) - 0.756832262147256*std::sin(0.267279952764511*x_112 - 1.20023989677429) + 0.612919834298925*std::sin(0.293919950723648*x_113 + 1.96367979049683) + 0.457664510734316*std::sin(0.285599917173386*x_12 + 5.13567972183228) - 0.555551221556929*std::sin(0.281199961900711*x_14 + 5.17095994949341) - 0.183924284283962*std::sin(0.300879925489426*x_15 - 7.43351984024048) + 0.412114879842965*std::sin(0.321919918060303*x_16 + 1.98375976085663) + 0.291650470324718*std::sin(0.351999849081039*x_17 - 4.17120027542114) + 0.312239031858038*std::sin(0.39743983745575*x_18 - 1.19631993770599) + 0.510452096134447*std::sin(0.270559966564178*x_19 + 5.01200008392334) + 0.59149049041946*std::sin(0.391199827194214*x_2 - 4.21216011047363) - 0.477364563158901*std::sin(0.289679944515228*x_20 + 1.98439979553223) - 0.29343449506174*std::sin(0.323359936475754*x_23 + 5.21583986282349) + 0.363651251208539*std::sin(0.439119875431061*x_25 - 1.39551985263824) + 0.359233324651207*std::sin(0.339119851589203*x_26 + 5.02279996871948) + 0.376393912148412*std::sin(0.329599827528*x_27 + 2.0319197177887) - 1.03186975256165*std::sin(0.112960062921047*x_28 + 5.09511995315552) - 0.275140554943169*std::sin(0.383679836988449*x_3 + 8.18943977355957) + 0.244588557748743*std::sin(0.443759858608246*x_31 - 1.16527986526489) - 0.674860764317305*std::sin(0.243279978632927*x_36 + 5.17535972595215) - 0.318697174479041*std::sin(0.246639966964722*x_38 - 4.40207958221436) - 0.641495443448964*std::sin(0.32551982998848*x_4 + 5.22919988632202) - 0.774713669385271*std::sin(0.236319988965988*x_41 - 7.4236798286438) + 0.614069453036269*std::sin(0.25639995932579*x_42 + 5.14743995666504) - 0.298923924532557*std::sin(0.249199971556664*x_46 + 1.97567975521088) + 0.265390831866648*std::sin(0.364319831132889*x_5 - 1.16543984413147) - 0.157867834892877*std::sin(0.490879863500595*x_60 + 1.69871997833252) + 0.266939822218411*std::sin(0.457919865846634*x_7 + 7.9870400428772) - 0.179181777273851*std::sin(0.335839837789536*x_8 - 4.34151983261108) - 0.296679969870956*std::sin(0.261279970407486*x_95 - 7.41343975067139)) + 0.0134018524036565*std::sin(0.329999834299088*x_1 + 5.14520025253296) - 0.00338178835296363*std::sin(0.342239856719971*x_1 + 8.34768009185791) + 0.010555867319692*std::sin(0.359039843082428*x_1 - 1.03663980960846) - 0.00387225062259776*std::sin(0.408399850130081*x_1 + 8.39400005340576) + 0.0590837302152145*std::sin(0.146240040659904*x_10 + 8.17375946044922) - 0.0402396884891753*std::sin(0.339839845895767*x_10 + 5.03247976303101) - 0.00576071447736727*std::sin(0.352079838514328*x_10 + 8.25903987884521) + 0.00701567244966385*std::sin(0.366479843854904*x_10 + 8.24079990386963) - 0.00379060492053788*std::sin(0.242079973220825*x_100 + 1.9755197763443) + 0.0109725561885441*std::sin(0.257839977741241*x_100 + 1.95887982845306) - 0.00660025027342442*std::sin(0.229919984936714*x_101 + 1.98535978794098) - 0.044050896871275*std::sin(0.221599996089935*x_102 + 1.97327971458435) + 0.0123522113006389*std::sin(0.239359974861145*x_102 - 1.2099198102951) + 0.00447861995909731*std::sin(0.246319979429245*x_108 + 1.97391986846924) - 0.0327122536913594*std::sin(0.23327998816967*x_109 + 1.95511984825134) + 0.0129981704783835*std::sin(0.23471999168396*x_109 + 1.98399984836578) - 0.005291987676077*std::sin(0.246079966425896*x_109 - 7.44191980361938) - 0.0528698340301068*std::sin(0.247759968042374*x_109 - 1.21407985687256) + 0.00381652748953629*std::sin(0.252159982919693*x_109 - 1.214399933815) + 0.013021413684731*std::sin(0.216800004243851*x_11 + 5.18383979797363) - 0.00684873173968553*std::sin(0.218799993395805*x_11 + 2.00231981277466) + 0.0432181963626467*std::sin(0.248719975352287*x_11 - 7.41408014297485) - 0.0323634601857272*std::sin(0.210319995880127*x_110 + 5.17592000961304) + 0.0491970889070851*std::sin(0.216240003705025*x_110 - 7.42695951461792) - 0.0010442848040032*std::sin(0.219759985804558*x_110 - 4.41991996765137) + 0.00902736469327104*std::sin(0.213039994239807*x_111 - 7.41463994979858) + 0.012149303530299*std::sin(0.216879993677139*x_111 + 1.98231983184814) - 0.00601673894269448*std::sin(0.278399974107742*x_112 + 1.96583986282349) - 0.0209739152974597*std::sin(0.290479928255081*x_112 + 1.95439982414246) + 0.00238800289535133*std::sin(0.237119987607002*x_116 + 8.16991996765137) - 0.011521480016751*std::sin(0.250639975070953*x_116 - 4.40895986557007) + 0.00515188989920069*std::sin(0.225919991731644*x_117 - 7.40279960632324) + 0.0355177829754086*std::sin(0.232319980859756*x_117 + 5.17903995513916) + 0.00967480387406951*std::sin(0.23471999168396*x_118 - 7.41639995574951) + 0.00227216773523533*std::sin(0.265759944915771*x_119 + 8.15824031829834) + 0.0110157974864162*std::sin(0.277439951896667*x_12 - 7.43567991256714) + 0.0152037532771725*std::sin(0.248639971017838*x_13 + 1.98823988437653) + 0.00406383848045543*std::sin(0.289919942617416*x_13 - 7.4443998336792) - 0.0397214680485419*std::sin(0.310239940881729*x_13 + 8.31328010559082) + 0.00490013323687744*std::sin(0.389119833707809*x_13 + 4.99919986724854) - 0.0441491874944149*std::sin(0.247759968042374*x_14 + 8.37184047698975) + 0.0466182984744908*std::sin(0.265839964151382*x_14 + 1.98951983451843) + 0.00400162421242176*std::sin(0.304159939289093*x_14 - 4.2577600479126) - 0.00134898484582791*std::sin(0.346159845590591*x_14 - 1.13391983509064) - 0.00607291790742249*std::sin(0.357839852571487*x_14 + 8.01512050628662) + 0.00670060860183197*std::sin(0.280799955129623*x_15 - 1.3802398443222) + 0.0173034691336882*std::sin(0.333999842405319*x_15 + 8.27744007110596) - 0.0228059638136966*std::sin(0.274159938097*x_16 - 1.17031991481781) - 0.00291338424718446*std::sin(0.279039949178696*x_16 - 1.19951987266541) + 0.00558026718317066*std::sin(0.306239932775497*x_16 + 1.99111986160278) + 0.0247704632269173*std::sin(0.310719937086105*x_16 + 1.98639988899231) - 0.00411681344021763*std::sin(0.328959852457047*x_16 - 7.32767963409424) - 0.00904199337246294*std::sin(0.461359858512878*x_16 - 1.4119998216629) + 0.00360574696559932*std::sin(0.257359951734543*x_17 + 8.24071979522705) + 0.00655674049582504*std::sin(0.288959950208664*x_17 + 2.01887989044189) - 0.0123673652445064*std::sin(0.3503198325634*x_17 + 2.00575995445251) - 0.0341877577347699*std::sin(0.359679847955704*x_17 + 2.02319979667664) - 0.00202103034878826*std::sin(0.389599829912186*x_17 + 8.19871997833252) - 0.0603619968542722*std::sin(0.22095999121666*x_18 + 5.01007986068726) + 0.0079833587597858*std::sin(0.269839972257614*x_18 + 8.2186393737793) + 0.00420332112915407*std::sin(0.275279939174652*x_18 - 1.15727984905243) + 0.0092591477624906*std::sin(0.303439915180206*x_18 - 4.37415981292725) + 0.0028419539987253*std::sin(0.316159933805466*x_18 + 2.18255996704102) - 0.00644841179398075*std::sin(0.341119825839996*x_18 - 7.36839962005615) + 0.00428142152643155*std::sin(0.417519867420197*x_18 - 1.214479804039) - 0.0389257687109547*std::sin(0.249119967222214*x_19 - 7.57503986358643) - 0.0277773570620966*std::sin(0.345519840717316*x_2 - 7.40919971466064) - 0.001910822953431*std::sin(0.423679858446121*x_2 + 5.21167993545532) + 0.0397411746796809*std::sin(0.262159943580627*x_20 + 8.19703960418701) + 0.00351875468978011*std::sin(0.269199967384338*x_20 + 2.0066397190094) + 0.0131396725983855*std::sin(0.273679971694946*x_20 - 7.41055965423584) - 0.00388789373681761*std::sin(0.282879948616028*x_20 + 1.99935972690582) - 0.0470703409403023*std::sin(0.327519834041595*x_20 + 8.24312019348145) - 0.00740919407041371*std::sin(0.341679841279984*x_20 + 8.24327945709229) - 0.00540126506601188*std::sin(0.366719841957092*x_20 + 1.7992799282074) + 0.00310140324589061*std::sin(0.311999946832657*x_21 + 1.99287974834442) + 0.022201323932984*std::sin(0.343839854001999*x_21 + 8.24991989135742) + 0.00416966139069422*std::sin(0.436479866504669*x_21 + 1.78887987136841) + 0.00349336856613674*std::sin(0.338159829378128*x_22 + 2.02815985679626) + 0.00902113327129632*std::sin(0.353279858827591*x_22 - 7.37287998199463) + 0.0453203163722974*std::sin(0.373279839754105*x_22 + 1.98695981502533) + 0.0283611527308353*std::sin(0.398239850997925*x_22 + 5.19063997268677) + 0.0123585053037925*std::sin(0.212559998035431*x_23 - 1.18399977684021) - 0.00415351468817949*std::sin(0.344639837741852*x_23 - 1.16903984546661) + 0.00104914217790623*std::sin(0.3503198325634*x_23 + 2.028639793396) - 0.00484906339226132*std::sin(0.294959932565689*x_24 + 8.21343994140625) - 0.0155027314000515*std::sin(0.331279844045639*x_24 + 2.03863978385925) + 0.013765382690583*std::sin(0.366319835186005*x_24 + 1.78495991230011) + 0.0295266485763299*std::sin(0.410559862852097*x_24 + 1.98767983913422) - 0.00566012004994273*std::sin(0.374479830265045*x_25 - 7.5918402671814) - 0.0260670902018537*std::sin(0.296079933643341*x_26 + 1.99919974803925) - 0.00918443732799785*std::sin(0.313919931650162*x_26 - 1.18519985675812) - 0.00200762872930761*std::sin(0.359279841184616*x_26 - 1.14727985858917) + 0.0015376247622362*std::sin(0.399359852075577*x_26 - 1.20367991924286) + 0.0154692829982533*std::sin(0.20040000975132*x_27 + 8.20024013519287) - 0.00487409448173835*std::sin(0.223039999604225*x_27 + 8.21224021911621) + 0.0316835424079197*std::sin(0.231039986014366*x_28 - 1.15839993953705) + 0.00173761744190901*std::sin(0.284159928560257*x_28 - 1.17151987552643) + 0.0241812028102422*std::sin(0.310159921646118*x_28 + 1.99215984344482) + 0.00453901857032107*std::sin(0.326479852199554*x_28 - 1.12615978717804) - 0.00743918927062624*std::sin(0.335039854049683*x_28 + 8.22056007385254) + 0.14670523875874*std::sin(0.0978400707244873*x_29 - 7.69432020187378) - 0.0629518660032052*std::sin(0.106960065662861*x_29 - 4.49688005447388) - 0.0315418600367461*std::sin(0.271039962768555*x_29 + 5.00927972793579) - 0.00755572453092062*std::sin(0.314319908618927*x_29 + 1.99423980712891) + 0.00207283742688406*std::sin(0.3572798371315*x_29 + 8.236159324646) - 0.00723443244188371*std::sin(0.263759940862656*x_3 + 8.26399993896484) + 0.00727961243624899*std::sin(0.291919946670532*x_3 - 4.32488012313843) + 0.0355642538702842*std::sin(0.308879911899567*x_3 - 1.10775983333588) - 0.00610287461274219*std::sin(0.319359928369522*x_3 + 5.25487995147705) - 0.00599015415633405*std::sin(0.377999842166901*x_3 + 1.98583984375) + 0.00271022910065878*std::sin(0.37967985868454*x_3 - 1.19287979602814) - 0.00240228190388528*std::sin(0.386799842119217*x_3 - 1.1865599155426) + 0.0233582229077528*std::sin(0.396639823913574*x_3 + 2.00367975234985) + 0.0659080393123065*std::sin(0.145920038223267*x_30 - 4.45616006851196) + 0.00249775274184816*std::sin(0.338719844818115*x_31 + 2.12823987007141) + 0.00494996143753238*std::sin(0.34079983830452*x_31 - 1.05159986019135) + 0.0172866962972287*std::sin(0.346719831228256*x_31 - 4.22328042984009) + 0.00239717400353537*std::sin(0.35335984826088*x_31 + 5.17592000961304) + 0.0121401470692199*std::sin(0.382319837808609*x_31 - 4.20591974258423) + 0.0102866193172898*std::sin(0.40871986746788*x_31 - 4.19944000244141) + 0.0140006359231565*std::sin(0.410959839820862*x_31 - 4.19831991195679) + 0.000197209748932428*std::sin(0.591199815273285*x_31 - 4.39583969116211) + 0.00460158639295737*std::sin(0.254879981279373*x_32 - 1.16591989994049) - 0.0034977244948671*std::sin(0.311599940061569*x_32 + 2.01239991188049) + 0.00687134368548797*std::sin(0.312719941139221*x_32 - 7.36104011535645) - 0.00955208808208625*std::sin(0.316399931907654*x_32 - 4.34007978439331) + 0.00344597748088213*std::sin(0.319839835166931*x_32 + 2.00407981872559) - 0.00221679360153752*std::sin(0.348159849643707*x_32 - 1.19095981121063) + 0.000888437901081745*std::sin(0.366799831390381*x_32 + 7.98663997650146) - 0.0169402644497191*std::sin(0.210879996418953*x_33 + 2.16375994682312) + 0.0161845033237636*std::sin(0.251279979944229*x_33 - 7.4314398765564) + 0.00352141965581811*std::sin(0.254719972610474*x_33 + 1.96607983112335) - 0.0623718404084391*std::sin(0.264319956302643*x_33 - 1.22359991073608) + 0.00116802257530705*std::sin(0.289119929075241*x_33 + 4.96567964553833) - 0.00255031710364105*std::sin(0.224159985780716*x_34 + 5.17888021469116) + 0.00568411197749967*std::sin(0.239119976758957*x_34 + 1.97639977931976) + 0.0664422097947011*std::sin(0.243359968066216*x_34 + 1.97447979450226) + 0.0281797180544793*std::sin(0.216480001807213*x_35 - 7.40999984741211) + 0.00187202260759149*std::sin(0.230159983038902*x_35 + 5.16847991943359) - 0.00958228258296186*std::sin(0.209199994802475*x_36 + 1.98423981666565) + 0.0385476819313329*std::sin(0.231439992785454*x_36 + 1.96879982948303) - 0.0116496877595568*std::sin(0.241999983787537*x_36 + 1.98503983020782) - 0.0617935802143238*std::sin(0.261199980974197*x_36 - 1.21743988990784) - 0.0502572794045964*std::sin(0.2223199903965*x_37 - 1.1904798746109) + 0.00183673751986231*std::sin(0.233679980039597*x_38 - 4.23104000091553) - 0.003112019693254*std::sin(0.313199937343597*x_4 + 2.00671982765198) + 0.00403316801040991*std::sin(0.332879841327667*x_4 - 1.16815984249115) - 0.00234754009111058*std::sin(0.382559835910797*x_4 + 2.01575970649719) - 0.00150629077876293*std::sin(0.416159868240356*x_4 - 4.40927982330322) - 0.00955738715052816*std::sin(0.443599849939346*x_4 + 5.17671966552734) + 0.00555279641739161*std::sin(0.225519984960556*x_40 + 1.99303984642029) - 0.0102110604612636*std::sin(0.23047998547554*x_40 + 1.9651198387146) + 0.00301598032556744*std::sin(0.241679981350899*x_41 - 7.42560005187988) + 0.00407477899176814*std::sin(0.26199996471405*x_41 + 1.97463977336884) + 0.00976857106210065*std::sin(0.222159996628761*x_42 + 4.99399995803833) - 0.0273763731553521*std::sin(0.229359999299049*x_42 + 1.96647977828979) + 0.0651455304085476*std::sin(0.211759999394417*x_43 - 1.20295989513397) - 0.00460869771292659*std::sin(0.242719978094101*x_44 - 1.20631992816925) - 0.0292360788676486*std::sin(0.260479986667633*x_44 + 1.94247984886169) - 0.00279320130498913*std::sin(0.267679959535599*x_44 - 7.4443998336792) - 0.0192427829428142*std::sin(0.194399997591972*x_46 - 7.60128021240234) - 0.0343991095333122*std::sin(0.207040011882782*x_47 - 7.58816003799438) - 0.0125704568542418*std::sin(0.253199964761734*x_48 - 1.20247983932495) + 0.00825366157781338*std::sin(0.296239942312241*x_49 + 5.06767988204956) - 0.00534431041589426*std::sin(0.309839934110641*x_5 + 1.81447994709015) - 0.0397013664776498*std::sin(0.388639837503433*x_5 + 2.00431990623474) + 0.00178525275708208*std::sin(0.388959854841232*x_5 + 4.98991966247559) - 0.0208963535520089*std::sin(0.408159852027893*x_5 - 1.17863988876343) + 0.00770372583857029*std::sin(0.181120008230209*x_50 - 7.37967967987061) - 0.00543527816877454*std::sin(0.215199992060661*x_52 - 1.20711994171143) + 0.0117434228724012*std::sin(0.242479979991913*x_53 + 1.96927976608276) + 0.0215753652952017*std::sin(0.247439980506897*x_53 + 1.98375976085663) - 0.042380933822627*std::sin(0.214560002088547*x_57 - 7.41511964797974) + 0.0390472530855594*std::sin(0.222719997167587*x_59 - 1.18319988250732) + 0.00477132876538737*std::sin(0.265359938144684*x_6 + 5.20975971221924) + 0.00595102818950438*std::sin(0.477919846773148*x_6 + 4.96743965148926) + 0.00193650125439815*std::sin(0.255839973688126*x_60 + 8.34751987457275) - 0.0236642457693886*std::sin(0.327759832143784*x_60 - 7.52952003479004) - 0.00412604846099974*std::sin(0.390639841556549*x_60 - 4.37255954742432) - 0.0561477148814979*std::sin(0.149440035223961*x_61 - 1.27567994594574) + 0.00682720659600909*std::sin(0.240959972143173*x_61 + 8.25207996368408) - 0.00464201952983329*std::sin(0.285119920969009*x_7 + 8.39744091033936) - 0.0140072963051702*std::sin(0.336559861898422*x_7 + 5.23784017562866) - 0.00324765089730813*std::sin(0.349679857492447*x_7 + 2.00879979133606) + 0.0109621401245149*std::sin(0.352479845285416*x_7 - 7.59647989273071) + 0.0302510041286387*std::sin(0.364639848470688*x_7 + 1.99303984642029) - 0.00275716773655669*std::sin(0.39031982421875*x_7 + 1.9793598651886) + 0.00338739905506862*std::sin(0.323199838399887*x_8 - 1.12079977989197) + 0.00998671268514025*std::sin(0.334079831838608*x_8 + 8.25943946838379) - 0.0259267737497924*std::sin(0.34215983748436*x_8 - 1.14503979682922) + 0.0224877927006728*std::sin(0.259759962558746*x_9 + 5.17736005783081) - 0.00627303302065877*std::sin(0.280479967594147*x_9 + 1.99911975860596) - 0.00343638810482527*std::sin(0.334879845380783*x_9 + 5.06487989425659) - 0.0320570331720757*std::sin(0.333039849996567*x_91 + 8.41728019714355) - 0.0017677032125299*std::sin(0.34775984287262*x_91 + 5.19016027450562) - 0.00252175694822304*std::sin(0.353039860725403*x_91 + 5.20071983337402) + 0.0239081567235608*std::sin(0.356399834156036*x_91 + 5.21304035186768) - 0.0265803672844363*std::sin(0.367759823799133*x_91 + 5.19528007507324) + 0.0106093218286838*std::sin(0.400319844484329*x_91 + 1.97431981563568) + 0.00179982307118548*std::sin(0.484399855136871*x_91 - 7.60904026031494) - 0.0293892606099831*std::sin(0.268319964408875*x_92 - 7.3744797706604) + 0.0146297350560295*std::sin(0.286079943180084*x_92 + 5.21439981460571) - 0.0045546217449041*std::sin(0.289279937744141*x_92 + 2.00223970413208) - 0.0520057689984383*std::sin(0.299279928207397*x_92 - 7.40520000457764) - 0.00538545408795672*std::sin(0.300959944725037*x_92 + 1.80455982685089) - 0.00215368909356605*std::sin(0.316799849271774*x_92 + 8.22192001342773) - 0.00293778716831721*std::sin(0.270399957895279*x_94 + 5.1864800453186) - 0.00865408657329314*std::sin(0.285599917173386*x_94 + 1.98791980743408) - 0.0157552274989287*std::sin(0.287359952926636*x_94 + 1.9755197763443) + 0.0423368621643489*std::sin(0.278959959745407*x_95 + 1.97447979450226) - 0.0102992311408585*std::sin(0.281039953231812*x_95 + 1.97343981266022) - 0.00462181683348859*std::sin(0.281679958105087*x_95 + 1.96399986743927) + 0.0400499114660889*std::sin(0.28263995051384*x_95 - 4.40463972091675) + 0.0112984607052515*std::sin(0.273119956254959*x_96 + 8.19167995452881) + 0.0190742905297975*std::sin(0.278159946203232*x_96 - 7.4423999786377) - 0.00993634444984162*std::sin(0.262239962816238*x_97 + 5.17519998550415) - 0.0108082812458847*std::sin(0.273119956254959*x_97 + 1.97847986221313) - 0.0430020617704151*std::sin(0.27567994594574*x_97 + 1.97919988632202) + 0.0527833160211176*std::sin(0.28383994102478*x_97 + 8.18407917022705) - 0.00337171536696921*std::sin(0.284799933433533*x_97 + 8.18175983428955) + 0.0266027568398657*std::sin(0.248399972915649*x_99 + 1.98031985759735) - 0.158395782004244);
}

inline float score_6(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.00123643812838806*x_1 + 0.00330340760314905*x_10 - 0.00333519408169044*x_100 + 0.00509197925249714*x_101 + 0.00261032006027569*x_102 + 0.00250070382090621*x_103 + 0.00486460517538467*x_104 - 0.00623122956375796*x_105 - 0.00511125027011599*x_106 + 0.00209989723323363*x_107 - 0.00453703380358483*x_108 - 0.00255294795977347*x_109 - 0.00606264783182837*x_11 + 0.00196754877785046*x_110 + 0.00328084911638125*x_111 - 0.00351955756645704*x_112 - 0.00573006713400304*x_113 + 0.000668492753172165*x_114 - 0.00978630852835777*x_115 - 0.00938267310806711*x_116 - 0.000549292597440302*x_117 - 0.00316789802994224*x_118 - 0.00341891999437712*x_119 - 0.00313523135288317*x_12 - 0.00506253491413872*x_120 + 0.00374037529478115*x_13 - 0.00106833429303649*x_14 - 0.000655102039898732*x_15 - 0.000652358599034414*x_16 + 0.000240484258503276*x_17 - 5.85900191654751e-5*x_18 - 0.000626609786086453*x_19 - 0.00135115562345137*x_2 + 0.000517306843681023*x_20 - 0.000194212938336552*x_21 - 3.07017389354517e-5*x_22 + 0.000421971313924934*x_23 - 0.00170574874947684*x_24 + 0.00552529927765465*x_25 + 0.00329580716964131*x_26 + 0.00141527883751301*x_27 + 0.0011501850000738*x_28 + 0.00364860513441988*x_29 - 0.00123095921109219*x_3 + 0.00276953160959821*x_30 + 0.000215942304598033*x_31 + 0.00158334362159701*x_32 - 0.00147829809418642*x_33 - 0.00587429863058431*x_34 + 0.0104300955597849*x_35 + 0.00242348110228734*x_36 - 0.00850137223083637*x_37 - 0.00892644257830007*x_38 + 0.00356952785092205*x_39 + 0.00122923381937932*x_4 - 0.00413552969403492*x_40 + 0.00284750187296806*x_41 - 0.00367146905866456*x_42 + 0.0013849508706733*x_43 - 0.0051630729483001*x_44 - 0.00675387331000635*x_45 + 0.00209889569979278*x_46 - 0.00560171526966712*x_47 - 0.00386888817248131*x_48 - 0.00246323719703691*x_49 - 0.00178265605803618*x_5 + 0.00105942430355042*x_50 - 0.0073026471377379*x_51 - 0.011605483651218*x_52 - 0.00413630277234814*x_53 - 0.00243817285670767*x_54 + 0.0128691087567315*x_55 + 0.00519413506885493*x_56 + 0.00942357281541697*x_57 + 0.000170566167393663*x_58 + 0.00477708987655822*x_59 - 0.00687423834060835*x_6 + 0.00426904112558864*x_60 + 0.00192239350779273*x_61 - 0.0017033305745334*x_62 - 0.000652437682354897*x_63 + 0.000597241757240997*x_64 + 0.000689609951485679*x_65 - 0.00303276545775352*x_66 + 0.00305698084866936*x_67 + 0.000955045355177489*x_68 - 0.00175296900072832*x_69 - 0.00525097484310453*x_7 + 0.00389659581678485*x_70 - 0.00389150471035075*x_71 - 0.000711025997893998*x_72 + 0.00340424715860819*x_73 - 0.00122931460953258*x_74 + 0.00277843503536179*x_75 + 0.000151453871297188*x_76 + 0.00367182674191495*x_77 - 0.000476580868613674*x_78 + 0.00122958277141879*x_79 + 0.000141890913176273*x_8 + 2.88704820128646e-5*x_80 - 0.000929524524839227*x_81 - 0.000576554731862393*x_82 - 0.000927785419103448*x_83 - 0.00173775568715852*x_84 + 0.00197666919924545*x_85 - 0.00457161328328677*x_86 + 0.00455029159177747*x_87 - 0.0010630367564922*x_88 + 0.000317344123661043*x_89 - 0.00396327570138469*x_9 + 0.00158866990386948*x_90 - 0.00121042255994108*x_91 - 0.00221550205769513*x_92 - 0.00497107756892948*x_93 - 0.000564500685339254*x_94 + 0.00200267010672575*x_95 - 0.00287690559800997*x_96 + 0.000927295004393045*x_97 + 0.00690121641739592*x_98 + 0.00361185541055105*x_99 - 8.04261013724519e-6*std::pow(-3.34895968437195*x_1 - 4.17543983459473, 2) - 5.91961368860026e-6*std::pow(-5.60767984390259*x_22 - 9.60639953613281, 2) - 3.1516424011359e-5*std::pow(-4.01999998092651*x_27 - 6.62815999984741, 2) + 0.00396709806687576*std::exp(0.163839861750603*x_49) + 0.0193632868863767*std::sin(0.329999834299088*x_1 + 5.14520025253296) + 0.00599282330900295*std::sin(0.342239856719971*x_1 + 8.34768009185791) + 0.0193402322134044*std::sin(0.359039843082428*x_1 - 1.03663980960846) - 0.000404033589671437*std::sin(0.408399850130081*x_1 + 8.39400005340576) + 0.00440124994318262*std::sin(0.146240040659904*x_10 + 8.17375946044922) + 0.0140995361413172*std::sin(0.339839845895767*x_10 + 5.03247976303101) - 0.00832320516120086*std::sin(0.352079838514328*x_10 + 8.25903987884521) + 0.0128539636015093*std::sin(0.366479843854904*x_10 + 8.24079990386963) + 0.00671728184973881*std::sin(0.242079973220825*x_100 + 1.9755197763443) + 0.0158533870510094*std::sin(0.257839977741241*x_100 + 1.95887982845306) - 0.00953618467931598*std::sin(0.229919984936714*x_101 + 1.98535978794098) + 0.015434940870903*std::sin(0.221599996089935*x_102 + 1.97327971458435) + 0.0226314548741755*std::sin(0.239359974861145*x_102 - 1.2099198102951) + 0.0193984153716935*std::sin(0.247999966144562*x_107 + 5.15144014358521) - 0.0143985828178709*std::sin(0.246319979429245*x_108 + 1.97391986846924) - 0.00243679273762909*std::sin(0.23327998816967*x_109 + 1.95511984825134) + 0.018780038489478*std::sin(0.23471999168396*x_109 + 1.98399984836578) - 0.000552170038990913*std::sin(0.246079966425896*x_109 - 7.44191980361938) + 0.0185249976747076*std::sin(0.247759968042374*x_109 - 1.21407985687256) + 0.00645341834894763*std::sin(0.252159982919693*x_109 - 1.214399933815) - 0.00989519608850361*std::sin(0.218799993395805*x_11 + 2.00231981277466) - 0.0151431719393554*std::sin(0.248719975352287*x_11 - 7.41408014297485) - 0.0151297136773616*std::sin(0.25655996799469*x_11 + 8.37376022338867) - 0.0172381089202427*std::sin(0.216240003705025*x_110 - 7.42695951461792) - 0.00176579540803995*std::sin(0.219759985804558*x_110 - 4.41991996765137) - 0.0290226139637411*std::sin(0.213039994239807*x_111 - 7.41463994979858) + 0.0175535771206274*std::sin(0.216879993677139*x_111 + 1.98231983184814) + 0.0261539981036461*std::sin(0.267279952764511*x_112 - 1.20023989677429) - 0.00869311485896096*std::sin(0.278399974107742*x_112 + 1.96583986282349) - 0.021180788644581*std::sin(0.293919950723648*x_113 + 1.96367979049683) - 0.00423174897999949*std::sin(0.237119987607002*x_116 + 8.16991996765137) - 0.0211094069504242*std::sin(0.250639975070953*x_116 - 4.40895986557007) - 0.0165631185632338*std::sin(0.225919991731644*x_117 - 7.40279960632324) + 0.00264578149912132*std::sin(0.232319980859756*x_117 + 5.17903995513916) - 0.0311041048581237*std::sin(0.23471999168396*x_118 - 7.41639995574951) - 0.00402647899409487*std::sin(0.265759944915771*x_119 + 8.15824031829834) + 0.0201829063354825*std::sin(0.277439951896667*x_12 - 7.43567991256714) - 0.015815600555784*std::sin(0.285599917173386*x_12 + 5.13567972183228) + 0.0219667123311446*std::sin(0.248639971017838*x_13 + 1.98823988437653) + 0.00687159987418744*std::sin(0.289919942617416*x_13 - 7.4443998336792) + 0.0139179575032558*std::sin(0.310239940881729*x_13 + 8.31328010559082) - 0.0157537310319142*std::sin(0.389119833707809*x_13 + 4.99919986724854) - 0.00328874985116149*std::sin(0.247759968042374*x_14 + 8.37184047698975) - 0.0163345296364462*std::sin(0.265839964151382*x_14 + 1.98951983451843) + 0.0191982904558727*std::sin(0.281199961900711*x_14 + 5.17095994949341) + 0.000417532528918866*std::sin(0.304159939289093*x_14 - 4.2577600479126) - 0.00228101686163299*std::sin(0.346159845590591*x_14 - 1.13391983509064) - 0.00877428344508203*std::sin(0.357839852571487*x_14 + 8.01512050628662) - 0.0215421868264665*std::sin(0.280799955129623*x_15 - 1.3802398443222) + 0.00635590688051464*std::sin(0.300879925489426*x_15 - 7.43351984024048) + 0.00128896554540655*std::sin(0.333999842405319*x_15 + 8.27744007110596) - 0.00169885595533049*std::sin(0.274159938097*x_16 - 1.17031991481781) - 0.00492628113117548*std::sin(0.279039949178696*x_16 - 1.19951987266541) + 0.00806249099869851*std::sin(0.306239932775497*x_16 + 1.99111986160278) - 0.00867929287273283*std::sin(0.310719937086105*x_16 + 1.98639988899231) - 0.0142415331969557*std::sin(0.321919918060303*x_16 + 1.98375976085663) + 0.00729535173948191*std::sin(0.328959852457047*x_16 - 7.32767963409424) - 0.0115923312937079*std::sin(0.257359951734543*x_17 + 8.24071979522705) + 0.00947332080940876*std::sin(0.288959950208664*x_17 + 2.01887989044189) - 0.0226592196029723*std::sin(0.3503198325634*x_17 + 2.00575995445251) - 0.010078621418911*std::sin(0.351999849081039*x_17 - 4.17120027542114) + 0.011979007389723*std::sin(0.359679847955704*x_17 + 2.02319979667664) - 0.000210875851343535*std::sin(0.389599829912186*x_17 + 8.19871997833252) + 0.0211501676122028*std::sin(0.22095999121666*x_18 + 5.01007986068726) + 0.000594694295027191*std::sin(0.269839972257614*x_18 + 8.2186393737793) + 0.00710745298593353*std::sin(0.275279939174652*x_18 - 1.15727984905243) + 0.0169644106354698*std::sin(0.303439915180206*x_18 - 4.37415981292725) - 0.00503618984663831*std::sin(0.316159933805466*x_18 + 2.18255996704102) + 0.0207313842449989*std::sin(0.341119825839996*x_18 - 7.36839962005615) - 0.010790104301223*std::sin(0.39743983745575*x_18 - 1.19631993770599) + 0.00618589063666931*std::sin(0.417519867420197*x_18 - 1.214479804039) - 0.00289964829071189*std::sin(0.249119967222214*x_19 - 7.57503986358643) - 0.017639791301213*std::sin(0.270559966564178*x_19 + 5.01200008392334) + 0.00973287479381604*std::sin(0.345519840717316*x_2 - 7.40919971466064) - 0.02044025068496*std::sin(0.391199827194214*x_2 - 4.21216011047363) + 0.00338614458964112*std::sin(0.423679858446121*x_2 + 5.21167993545532) + 0.00296038930114666*std::sin(0.262159943580627*x_20 + 8.19703960418701) + 0.000367149553850751*std::sin(0.269199967384338*x_20 + 2.0066397190094) + 0.0240742244634708*std::sin(0.273679971694946*x_20 - 7.41055965423584) - 0.00657409250915307*std::sin(0.282879948616028*x_20 + 1.99935972690582) + 0.0164963790578691*std::sin(0.289679944515228*x_20 + 1.98439979553223) + 0.0164929202533574*std::sin(0.327519834041595*x_20 + 8.24312019348145) - 0.0107049642139857*std::sin(0.341679841279984*x_20 + 8.24327945709229) + 0.017364849682383*std::sin(0.366719841957092*x_20 + 1.7992799282074) + 0.00524420501866947*std::sin(0.311999946832657*x_21 + 1.99287974834442) - 0.00777909523982534*std::sin(0.343839854001999*x_21 + 8.24991989135742) + 0.00763956358155947*std::sin(0.436479866504669*x_21 + 1.78887987136841) - 0.0112310392648286*std::sin(0.338159829378128*x_22 + 2.02815985679626) + 0.0165283256231786*std::sin(0.353279858827591*x_22 - 7.37287998199463) - 0.0158797312459074*std::sin(0.373279839754105*x_22 + 1.98695981502533) + 0.00211267165073202*std::sin(0.398239850997925*x_22 + 5.19063997268677) + 0.0226429866108729*std::sin(0.212559998035431*x_23 - 1.18399977684021) + 0.010140272305009*std::sin(0.323359936475754*x_23 + 5.21583986282349) - 0.00043338089725514*std::sin(0.344639837741852*x_23 - 1.16903984546661) + 0.00177400880777556*std::sin(0.3503198325634*x_23 + 2.028639793396) - 0.00700603191010858*std::sin(0.294959932565689*x_24 + 8.21343994140625) - 0.0284037697840048*std::sin(0.331279844045639*x_24 + 2.03863978385925) - 0.0103458069474351*std::sin(0.410559862852097*x_24 + 1.98767983913422) - 0.000421632198195272*std::sin(0.374479830265045*x_25 - 7.5918402671814) - 0.0125667662574434*std::sin(0.439119875431061*x_25 - 1.39551985263824) - 0.00194178293841545*std::sin(0.296079933643341*x_26 + 1.99919974803925) - 0.0168275277903095*std::sin(0.313919931650162*x_26 - 1.18519985675812) - 0.012414095119357*std::sin(0.339119851589203*x_26 + 5.02279996871948) - 0.000209477516123552*std::sin(0.359279841184616*x_26 - 1.14727985858917) + 0.00259999066733225*std::sin(0.399359852075577*x_26 - 1.20367991924286) + 0.0223503554284782*std::sin(0.20040000975132*x_27 + 8.20024013519287) - 0.00050856674368183*std::sin(0.223039999604225*x_27 + 8.21224021911621) - 0.0130071168433331*std::sin(0.329599827528*x_27 + 2.0319197177887) + 0.035658521579325*std::sin(0.112960062921047*x_28 + 5.09511995315552) + 0.00236016224288378*std::sin(0.231039986014366*x_28 - 1.15839993953705) + 0.000181304332016406*std::sin(0.284159928560257*x_28 - 1.17151987552643) - 0.00847282262275082*std::sin(0.310159921646118*x_28 + 1.99215984344482) + 0.00767508836454969*std::sin(0.326479852199554*x_28 - 1.12615978717804) - 0.0107483019295072*std::sin(0.335039854049683*x_28 + 8.22056007385254) - 0.0514038724866335*std::sin(0.0978400707244873*x_29 - 7.69432020187378) - 0.00468939411341534*std::sin(0.106960065662861*x_29 - 4.49688005447388) - 0.0138434353656488*std::sin(0.314319908618927*x_29 + 1.99423980712891) + 0.00350498905660031*std::sin(0.3572798371315*x_29 + 8.236159324646) + 0.0105177418597944*std::sin(0.291919946670532*x_3 - 4.32488012313843) - 0.0124613162181397*std::sin(0.308879911899567*x_3 - 1.10775983333588) - 0.000636778601754528*std::sin(0.319359928369522*x_3 + 5.25487995147705) + 0.0192581043936521*std::sin(0.377999842166901*x_3 + 1.98583984375) - 0.00480276186205811*std::sin(0.37967985868454*x_3 - 1.19287979602814) + 0.00950808509643006*std::sin(0.383679836988449*x_3 + 8.18943977355957) - 0.00406205121288455*std::sin(0.386799842119217*x_3 - 1.1865599155426) + 0.001739994696867*std::sin(0.396639823913574*x_3 + 2.00367975234985) + 0.00490960461064237*std::sin(0.145920038223267*x_30 - 4.45616006851196) + 0.000260617430212604*std::sin(0.338719844818115*x_31 + 2.12823987007141) + 0.0071518115932459*std::sin(0.34079983830452*x_31 - 1.05159986019135) - 0.006057064762624*std::sin(0.346719831228256*x_31 - 4.22328042984009) + 0.00405341419456539*std::sin(0.35335984826088*x_31 + 5.17592000961304) - 0.0330710668707333*std::sin(0.40871986746788*x_31 - 4.19944000244141) + 0.0256516628798513*std::sin(0.410959839820862*x_31 - 4.19831991195679) - 0.00845229385093195*std::sin(0.443759858608246*x_31 - 1.16527986526489) - 0.00034947284005197*std::sin(0.591199815273285*x_31 - 4.39583969116211) + 0.00843092724591331*std::sin(0.254879981279373*x_32 - 1.16591989994049) - 0.000364955247239343*std::sin(0.311599940061569*x_32 + 2.01239991188049) + 0.0099278663179946*std::sin(0.312719941139221*x_32 - 7.36104011535645) + 0.00334694467564404*std::sin(0.316399931907654*x_32 - 4.34007978439331) + 0.00582685028894867*std::sin(0.319839835166931*x_32 + 2.00407981872559) - 0.00157438928948302*std::sin(0.366799831390381*x_32 + 7.98663997650146) - 0.00126190979606811*std::sin(0.210879996418953*x_33 + 2.16375994682312) + 0.0296528975839131*std::sin(0.251279979944229*x_33 - 7.4314398765564) + 0.000367427618444091*std::sin(0.254719972610474*x_33 + 1.96607983112335) + 0.0218543942822973*std::sin(0.264319956302643*x_33 - 1.22359991073608) + 0.00197502529200633*std::sin(0.289119929075241*x_33 + 4.96567964553833) + 0.00451938388475884*std::sin(0.224159985780716*x_34 + 5.17888021469116) + 0.00961134241365734*std::sin(0.239119976758957*x_34 + 1.97639977931976) - 0.0232806061250045*std::sin(0.243359968066216*x_34 + 1.97447979450226) + 0.00209915626576742*std::sin(0.216480001807213*x_35 - 7.40999984741211) + 0.00270473884630211*std::sin(0.230159983038902*x_35 + 5.16847991943359) + 0.0308066526329748*std::sin(0.209199994802475*x_36 + 1.98423981666565) + 0.00287148394815486*std::sin(0.231439992785454*x_36 + 1.96879982948303) - 0.0168317214240819*std::sin(0.241999983787537*x_36 + 1.98503983020782) + 0.02332129328116*std::sin(0.243279978632927*x_36 + 5.17535972595215) + 0.021651778387092*std::sin(0.261199980974197*x_36 - 1.21743988990784) - 0.00374375225325624*std::sin(0.2223199903965*x_37 - 1.1904798746109) + 0.000191646596711328*std::sin(0.233679980039597*x_38 - 4.23104000091553) + 0.0110132795783756*std::sin(0.246639966964722*x_38 - 4.40207958221436) + 0.0100050179951403*std::sin(0.313199937343597*x_4 + 2.00671982765198) + 0.0221682814681563*std::sin(0.32551982998848*x_4 + 5.22919988632202) + 0.00582720857492932*std::sin(0.332879841327667*x_4 - 1.16815984249115) - 0.000244944127421358*std::sin(0.382559835910797*x_4 + 2.01575970649719) + 0.00266927836604439*std::sin(0.416159868240356*x_4 - 4.40927982330322) - 0.000711946410628023*std::sin(0.443599849939346*x_4 + 5.17671966552734) + 0.000579383022405797*std::sin(0.225519984960556*x_40 + 1.99303984642029) - 0.0187084845313982*std::sin(0.23047998547554*x_40 + 1.9651198387146) + 0.0267719293340969*std::sin(0.236319988965988*x_41 - 7.4236798286438) + 0.00509976223843387*std::sin(0.241679981350899*x_41 - 7.42560005187988) - 0.0131002503702769*std::sin(0.26199996471405*x_41 + 1.97463977336884) + 0.000727677867924708*std::sin(0.222159996628761*x_42 + 4.99399995803833) - 0.0212205162404833*std::sin(0.25639995932579*x_42 + 5.14743995666504) - 0.022826264191575*std::sin(0.211759999394417*x_43 - 1.20295989513397) - 0.00779290977646464*std::sin(0.242719978094101*x_44 - 1.20631992816925) + 0.010243994576044*std::sin(0.260479986667633*x_44 + 1.94247984886169) + 0.00494979582995103*std::sin(0.267679959535599*x_44 - 7.4443998336792) + 0.00674245561405664*std::sin(0.194399997591972*x_46 - 7.60128021240234) + 0.0103299715754424*std::sin(0.249199971556664*x_46 + 1.97567975521088) - 0.0181620685730798*std::sin(0.253199964761734*x_48 - 1.20247983932495) - 0.026535189603982*std::sin(0.296239942312241*x_49 + 5.06767988204956) - 0.0077215755461221*std::sin(0.309839934110641*x_5 + 1.81447994709015) - 0.00917116204014949*std::sin(0.364319831132889*x_5 - 1.16543984413147) + 0.0139109141379632*std::sin(0.388639837503433*x_5 + 2.00431990623474) - 0.00316362327220374*std::sin(0.388959854841232*x_5 + 4.98991966247559) - 0.0136516727107106*std::sin(0.181120008230209*x_50 - 7.37967967987061) + 0.0174742004380831*std::sin(0.215199992060661*x_52 - 1.20711994171143) + 0.0169671519471668*std::sin(0.242479979991913*x_53 + 1.96927976608276) - 0.00315702955618112*std::sin(0.214560002088547*x_57 - 7.41511964797974) + 0.00290869787331067*std::sin(0.222719997167587*x_59 - 1.18319988250732) + 0.00806790483963044*std::sin(0.265359938144684*x_6 + 5.20975971221924) + 0.0109033453725608*std::sin(0.477919846773148*x_6 + 4.96743965148926) + 0.00327445636436683*std::sin(0.255839973688126*x_60 + 8.34751987457275) + 0.00731171700011499*std::sin(0.390639841556549*x_60 - 4.37255954742432) + 0.00545546914543618*std::sin(0.490879863500595*x_60 + 1.69871997833252) + 0.0196735304110769*std::sin(0.149440035223961*x_61 - 1.27567994594574) + 0.00986409609428463*std::sin(0.240959972143173*x_61 + 8.25207996368408) - 0.00784925409082778*std::sin(0.285119920969009*x_7 + 8.39744091033936) - 0.0256638658879863*std::sin(0.336559861898422*x_7 + 5.23784017562866) + 0.00575512006238843*std::sin(0.349679857492447*x_7 + 2.00879979133606) + 0.00225344997205514*std::sin(0.364639848470688*x_7 + 1.99303984642029) - 0.000287684989041316*std::sin(0.39031982421875*x_7 + 1.9793598651886) - 0.00922469079777358*std::sin(0.457919865846634*x_7 + 7.9870400428772) + 0.000353443806524807*std::sin(0.323199838399887*x_8 - 1.12079977989197) + 0.0144290189855716*std::sin(0.334079831838608*x_8 + 8.25943946838379) + 0.0061920191532697*std::sin(0.335839837789536*x_8 - 4.34151983261108) - 0.00193133052157561*std::sin(0.34215983748436*x_8 - 1.14503979682922) + 0.0016751548351064*std::sin(0.259759962558746*x_9 + 5.17736005783081) + 0.0201675485511388*std::sin(0.280479967594147*x_9 + 1.99911975860596) - 0.000358555361420625*std::sin(0.334879845380783*x_9 + 5.06487989425659) + 0.0112324253681704*std::sin(0.333039849996567*x_91 + 8.41728019714355) - 0.00298903345475972*std::sin(0.34775984287262*x_91 + 5.19016027450562) - 0.000263122047453094*std::sin(0.353039860725403*x_91 + 5.20071983337402) + 0.00178096022437793*std::sin(0.356399834156036*x_91 + 5.21304035186768) - 0.0341085424498798*std::sin(0.400319844484329*x_91 + 1.97431981563568) + 0.00260042339091688*std::sin(0.484399855136871*x_91 - 7.60904026031494) + 0.0102976677428434*std::sin(0.268319964408875*x_92 - 7.3744797706604) - 0.0470340090768066*std::sin(0.286079943180084*x_92 + 5.21439981460571) + 0.00807118616179307*std::sin(0.289279937744141*x_92 + 2.00223970413208) - 0.00387400028765625*std::sin(0.299279928207397*x_92 - 7.40520000457764) - 0.00778102081545569*std::sin(0.300959944725037*x_92 + 1.80455982685089) - 0.000224717566169813*std::sin(0.316799849271774*x_92 + 8.22192001342773) + 0.00944486744368007*std::sin(0.270399957895279*x_94 + 5.1864800453186) - 0.0158558305872376*std::sin(0.285599917173386*x_94 + 1.98791980743408) + 0.0102524268024465*std::sin(0.261279970407486*x_95 - 7.41343975067139) + 0.00315374658161628*std::sin(0.278959959745407*x_95 + 1.97447979450226) - 0.0188700289470425*std::sin(0.281039953231812*x_95 + 1.97343981266022) + 0.00819026170735958*std::sin(0.281679958105087*x_95 + 1.96399986743927) - 0.0140330403980284*std::sin(0.28263995051384*x_95 - 4.40463972091675) + 0.02070079578264*std::sin(0.273119956254959*x_96 + 8.19167995452881) + 0.00142087711464267*std::sin(0.278159946203232*x_96 - 7.4423999786377) - 0.0182051557860918*std::sin(0.262239962816238*x_97 + 5.17519998550415) - 0.0156160390526022*std::sin(0.273119956254959*x_97 + 1.97847986221313) - 0.0032032984585499*std::sin(0.27567994594574*x_97 + 1.97919988632202) - 0.0184946827334042*std::sin(0.28383994102478*x_97 + 8.18407917022705) - 0.000351807358520871*std::sin(0.284799933433533*x_97 + 8.18175983428955) + 0.380126625299454*std::sin(-0.00451913280690964*x_1 - 0.0231847089019702*x_10 + 0.000681124705429281*x_100 - 0.0133501216870863*x_101 - 0.0235237239134584*x_102 + 0.0327312821726836*x_103 + 0.00515168290759914*x_104 + 0.00118291904120224*x_105 + 0.0226498928750037*x_106 - 0.00235361416371148*x_107 - 0.0297247462223635*x_108 + 0.00430530410256919*x_109 + 0.00685218814613179*x_111 - 0.0214829227580167*x_113 + 0.0275241882324034*x_114 + 0.00461984243426217*x_115 + 0.0294133066050062*x_116 - 0.000839603113893162*x_117 - 0.000252275439725764*x_118 + 0.00420324895259389*x_119 - 0.050471580082651*x_12 + 0.0145115969514729*x_120 - 0.019449107134983*x_13 + 0.022317639418007*x_14 + 0.0419044339306183*x_15 + 0.0360217226281092*x_17 + 0.0166339986740362*x_18 - 0.0120765235140831*x_19 + 0.00277242220125535*x_2 + 0.00632066737946826*x_20 + 0.0141916406750501*x_21 + 0.0176744015233771*x_22 + 0.0304952167204904*x_23 - 0.031515039673603*x_25 - 0.00482390372237615*x_26 + 0.0217061199629925*x_27 + 0.0207810717057523*x_28 + 0.0161513584279192*x_30 + 0.0339679986205435*x_33 + 0.0352343269714041*x_34 + 0.0185889009287543*x_35 + 0.0346109459802129*x_36 - 0.0327527824735752*x_37 + 0.00275072423811403*x_38 + 0.00565267754110839*x_39 + 0.0127622743445379*x_4 - 0.00229729330101438*x_40 - 0.0117099695543067*x_41 - 0.0224940695799714*x_43 + 0.0248320142208541*x_44 - 0.0258678215471436*x_45 + 0.0154403726819438*x_46 + 0.0404640132809957*x_48 + 0.0328102030445106*x_49 + 0.0063232661215917*x_50 - 0.0496781184355603*x_51 - 0.0110450790554542*x_52 + 0.0117291464674928*x_54 - 0.00762331330200445*x_55 + 0.0258642568182539*x_56 - 0.0430311132429995*x_57 - 0.0551935987074208*x_58 + 0.040388765150007*x_59 - 0.00172694879326069*x_6 - 0.0115108302957829*x_61 + 0.0167528476532662*x_62 - 0.00268870967438402*x_63 - 0.00189204140635266*x_64 - 0.000237218391177099*x_65 + 0.0109231384025437*x_66 - 0.0215962886524896*x_67 - 0.00794776207783582*x_68 + 0.00572097519258558*x_69 + 0.0131099371455107*x_70 + 0.0161401916175136*x_71 - 0.0128582954236451*x_72 - 0.012510671520942*x_73 + 0.0095965445934957*x_74 - 0.0182559828554218*x_75 + 0.00986371267530872*x_76 - 0.0101857414103347*x_77 + 0.0200408832993498*x_78 + 0.000336840009728368*x_79 + 0.0182556830467803*x_8 + 0.000907080973685425*x_80 - 0.0123756557732625*x_81 - 0.0127719499481578*x_82 + 0.0037195092905722*x_83 + 0.0158727284043793*x_84 - 0.00281622411951731*x_85 - 0.0189069393896011*x_86 + 0.0114894193698677*x_87 - 0.0192804488328155*x_88 + 0.00504478598507336*x_89 + 0.00591710319097673*x_9 - 0.0126052154707355*x_90 + 0.00850732729807112*x_92 + 0.00551443988940335*x_93 + 0.0022523207765661*x_95 + 0.0158084498778627*x_96 - 0.0231476151219452*x_97 - 0.0231008522714314*x_98 + 0.121689757795719*std::sin(0.216800004243851*x_11 + 5.18383979797363) - 0.302448084884258*std::sin(0.210319995880127*x_110 + 5.17592000961304) - 0.196008723351495*std::sin(0.290479928255081*x_112 + 1.95439982414246) - 0.0845006548540699*std::sin(0.461359858512878*x_16 - 1.4119998216629) + 0.128642413653341*std::sin(0.366319835186005*x_24 + 1.78495991230011) - 0.294769938290107*std::sin(0.271039962768555*x_29 + 5.00927972793579) - 0.0676083528990894*std::sin(0.263759940862656*x_3 + 8.26399993896484) + 0.113454006778858*std::sin(0.382319837808609*x_31 - 4.20591974258423) - 0.0207167273066922*std::sin(0.348159849643707*x_32 - 1.19095981121063) - 0.255841976858971*std::sin(0.229359999299049*x_42 + 1.96647977828979) - 0.32147195449337*std::sin(0.207040011882782*x_47 - 7.58816003799438) - 0.195283881161036*std::sin(0.408159852027893*x_5 - 1.17863988876343) + 0.201629488218007*std::sin(0.247439980506897*x_53 + 1.98375976085663) - 0.221150821701643*std::sin(0.327759832143784*x_60 - 7.52952003479004) + 0.102445111488869*std::sin(0.352479845285416*x_7 - 7.59647989273071) - 0.248403017927092*std::sin(0.367759823799133*x_91 + 5.19528007507324) - 0.147238223497136*std::sin(0.287359952926636*x_94 + 1.9755197763443) + 0.248612256312672*std::sin(0.248399972915649*x_99 + 1.98031985759735) - 2.31484219500181) + 0.541966383595716);
}

inline float score_7(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.000670984420546746*x_1 + 0.00257703563413639*x_10 + 0.00143074249252067*x_100 - 0.00468965413576795*x_101 + 0.00261940441937118*x_102 + 0.00203299406585007*x_103 - 0.00681088073741*x_104 - 0.00548720954873117*x_105 + 0.0029261499512606*x_106 - 0.00153279677380766*x_107 - 0.00716888504493946*x_108 + 0.00175335804641934*x_109 + 0.00427807615277608*x_11 + 0.00010171184867213*x_110 + 0.00206210808223369*x_111 + 0.000699550026134785*x_112 - 0.00263466412796896*x_113 + 0.00308819108831323*x_114 - 0.0076869580415523*x_115 + 0.0124394955991077*x_116 - 0.000786013873882907*x_117 + 0.000462519316263981*x_118 + 0.00830277444929457*x_119 - 0.00264297454393704*x_12 + 0.00743637092725494*x_120 - 0.00252236175551438*x_13 - 0.0006075744074435*x_14 + 0.00626212791299677*x_15 - 0.00065064522575776*x_16 + 0.00561707532866218*x_17 + 0.00111393917927257*x_18 - 0.00647496416238736*x_19 - 0.000836385691869012*x_2 + 0.00209541186939597*x_20 + 0.00532108290142359*x_21 + 0.0033639700053309*x_22 + 0.00555683864230314*x_23 + 0.00109843626522022*x_24 + 0.00302532635894589*x_25 + 0.00395083177877724*x_26 - 8.634918684962e-5*x_27 + 0.00355595194115171*x_28 - 0.00083414699091254*x_29 - 0.000422485012041323*x_3 - 0.00438012536363064*x_30 + 0.00165239635059756*x_31 + 0.000542593762114875*x_32 + 0.00565359635339486*x_33 + 0.00379518753856979*x_34 + 0.0050695649080783*x_35 - 0.00108175500655695*x_36 - 0.00203890466447532*x_37 + 0.002859942097672*x_38 - 0.0033918854129211*x_39 + 0.0050136486553429*x_4 - 0.00669940133565103*x_40 - 0.00169174269921485*x_41 + 0.00448158776631945*x_42 - 0.0132102230112186*x_43 + 0.0040574047354533*x_44 - 0.00740279553229222*x_45 + 0.0021507388049104*x_46 - 0.00346587455184195*x_47 - 0.00342277943925814*x_48 + 0.00375683994153487*x_49 + 0.00394191611565102*x_5 + 0.00475800701070297*x_50 - 0.00574384614784462*x_51 - 8.68759930868846e-6*x_52 - 0.00492487432606515*x_53 - 0.00686137604997053*x_54 - 0.00854257355218653*x_55 + 3.53851384273905e-5*x_56 - 0.00894011840174563*x_57 - 0.0173597482164779*x_58 + 0.00687101434587148*x_59 + 0.00157819503129709*x_6 - 2.82656182169782e-5*x_60 - 0.00121538552418934*x_61 + 0.00547124102639571*x_62 - 0.00213861249070475*x_63 + 0.00160499215441491*x_64 - 0.0010681693750874*x_65 + 0.000724492177673322*x_66 - 0.00539514810229843*x_67 + 0.00256660852425356*x_68 - 0.000204561357098505*x_69 + 0.00212542947339443*x_7 + 0.00125585221710969*x_70 + 0.00151718832220336*x_71 + 0.00174864346840953*x_72 - 0.00235961528581485*x_73 + 0.000700708103756187*x_74 - 0.000550250352766621*x_75 + 0.00373396432306386*x_76 + 0.000672294038364967*x_77 - 0.000544349780913708*x_78 + 0.000915930819434663*x_79 + 0.00235809218450539*x_8 - 0.00254710436554673*x_80 - 0.000421547376650255*x_81 - 0.0018281480247995*x_82 + 0.00201920610324696*x_83 - 0.00239774039046481*x_84 - 0.00199955670578509*x_85 + 7.83298601295318e-5*x_86 + 0.00115651735063978*x_87 - 0.00191022844882751*x_88 + 0.000758038480424436*x_89 + 0.00631734659307896*x_9 - 0.00241645131908944*x_90 - 0.000538372811109923*x_91 + 0.00302692767923476*x_92 + 0.00180605409466651*x_93 - 0.000389788897732889*x_94 - 0.00118489953151868*x_95 + 0.00222669657482146*x_96 - 0.00774602136025804*x_97 - 0.00816053733146126*x_98 + 0.00315481462113691*x_99 - 3.34778980368203e-5*std::pow(-3.34895968437195*x_1 - 4.17543983459473, 2) - 2.46407845341868e-5*std::pow(-5.60767984390259*x_22 - 9.60639953613281, 2) - 1.08169439392913e-5*std::pow(-4.01999998092651*x_27 - 6.62815999984741, 2) - 0.000862284387143678*std::exp(0.163839861750603*x_49) - 0.0142814031045238*std::sin(0.329999834299088*x_1 + 5.14520025253296) + 0.0160562021419654*std::sin(0.342239856719971*x_1 + 8.34768009185791) + 0.00663787895320455*std::sin(0.359039843082428*x_1 - 1.03663980960846) - 0.00519291812580744*std::sin(0.408399850130081*x_1 + 8.39400005340576) + 0.0336784835084552*std::sin(0.146240040659904*x_10 + 8.17375946044922) - 0.0113867533314773*std::sin(0.339839845895767*x_10 + 5.03247976303101) + 0.00613878463539128*std::sin(0.352079838514328*x_10 + 8.25903987884521) + 0.00441168717698124*std::sin(0.366479843854904*x_10 + 8.24079990386963) + 0.0179971992603108*std::sin(0.242079973220825*x_100 + 1.9755197763443) - 0.0116926745121354*std::sin(0.257839977741241*x_100 + 1.95887982845306) + 0.00703341835937544*std::sin(0.229919984936714*x_101 + 1.98535978794098) - 0.0124652231549577*std::sin(0.221599996089935*x_102 + 1.97327971458435) + 0.00776747953861536*std::sin(0.239359974861145*x_102 - 1.2099198102951) - 0.00421641976789153*std::sin(0.247999966144562*x_107 + 5.15144014358521) - 0.00105314480213421*std::sin(0.246319979429245*x_108 + 1.97391986846924) - 0.0186464038823526*std::sin(0.23327998816967*x_109 + 1.95511984825134) - 0.0138512279222288*std::sin(0.23471999168396*x_109 + 1.98399984836578) - 0.00709686985761625*std::sin(0.246079966425896*x_109 - 7.44191980361938) - 0.0149607460042568*std::sin(0.247759968042374*x_109 - 1.21407985687256) + 0.0268627818317967*std::sin(0.252159982919693*x_109 - 1.214399933815) + 0.0136583009111463*std::sin(0.216800004243851*x_11 + 5.18383979797363) + 0.00729820742560258*std::sin(0.218799993395805*x_11 + 2.00231981277466) + 0.0122295912291962*std::sin(0.248719975352287*x_11 - 7.41408014297485) + 0.0032885791240894*std::sin(0.25655996799469*x_11 + 8.37376022338867) - 0.0339463815868851*std::sin(0.210319995880127*x_110 + 5.17592000961304) + 0.0139214575719797*std::sin(0.216240003705025*x_110 - 7.42695951461792) - 0.00735024048355717*std::sin(0.219759985804558*x_110 - 4.41991996765137) - 0.00212277940314554*std::sin(0.213039994239807*x_111 - 7.41463994979858) - 0.0129466506516723*std::sin(0.216879993677139*x_111 + 1.98231983184814) - 0.00568480633601279*std::sin(0.267279952764511*x_112 - 1.20023989677429) + 0.00641161174046822*std::sin(0.278399974107742*x_112 + 1.96583986282349) - 0.0219997654136059*std::sin(0.290479928255081*x_112 + 1.95439982414246) + 0.00460383460346263*std::sin(0.293919950723648*x_113 + 1.96367979049683) - 0.0113378642308465*std::sin(0.237119987607002*x_116 + 8.16991996765137) - 0.00724508819566989*std::sin(0.250639975070953*x_116 - 4.40895986557007) - 0.00121146382547818*std::sin(0.225919991731644*x_117 - 7.40279960632324) + 0.020245591533186*std::sin(0.232319980859756*x_117 + 5.17903995513916) - 0.00227502433890325*std::sin(0.23471999168396*x_118 - 7.41639995574951) - 0.0107878970088175*std::sin(0.265759944915771*x_119 + 8.15824031829834) + 0.00692709827371901*std::sin(0.277439951896667*x_12 - 7.43567991256714) + 0.00343766279599272*std::sin(0.285599917173386*x_12 + 5.13567972183228) - 0.0162015610016556*std::sin(0.248639971017838*x_13 + 1.98823988437653) + 0.0286034901620472*std::sin(0.289919942617416*x_13 - 7.4443998336792) - 0.0112401108362102*std::sin(0.310239940881729*x_13 + 8.31328010559082) - 0.00115226339705383*std::sin(0.389119833707809*x_13 + 4.99919986724854) - 0.0251656027391356*std::sin(0.247759968042374*x_14 + 8.37184047698975) + 0.0131917289967343*std::sin(0.265839964151382*x_14 + 1.98951983451843) - 0.00417292082042875*std::sin(0.281199961900711*x_14 + 5.17095994949341) + 0.0053664157955288*std::sin(0.304159939289093*x_14 - 4.2577600479126) - 0.00949488395071873*std::sin(0.346159845590591*x_14 - 1.13391983509064) + 0.00647147767669183*std::sin(0.357839852571487*x_14 + 8.01512050628662) - 0.00157564410121939*std::sin(0.280799955129623*x_15 - 1.3802398443222) - 0.00138151343294698*std::sin(0.300879925489426*x_15 - 7.43351984024048) + 0.00986319918758141*std::sin(0.333999842405319*x_15 + 8.27744007110596) - 0.0129996916815558*std::sin(0.274159938097*x_16 - 1.17031991481781) - 0.0205059718916942*std::sin(0.279039949178696*x_16 - 1.19951987266541) - 0.00594649475859489*std::sin(0.306239932775497*x_16 + 1.99111986160278) + 0.00700937719105876*std::sin(0.310719937086105*x_16 + 1.98639988899231) + 0.00309552512131229*std::sin(0.321919918060303*x_16 + 1.98375976085663) + 0.0195459862882806*std::sin(0.328959852457047*x_16 - 7.32767963409424) - 0.00948424413107346*std::sin(0.461359858512878*x_16 - 1.4119998216629) - 0.000847889240282293*std::sin(0.257359951734543*x_17 + 8.24071979522705) - 0.00698705307686305*std::sin(0.288959950208664*x_17 + 2.01887989044189) - 0.00777700884037801*std::sin(0.3503198325634*x_17 + 2.00575995445251) + 0.00219067886574909*std::sin(0.351999849081039*x_17 - 4.17120027542114) - 0.00967421913285558*std::sin(0.359679847955704*x_17 + 2.02319979667664) - 0.00271032176217683*std::sin(0.389599829912186*x_17 + 8.19871997833252) - 0.0170808272772762*std::sin(0.22095999121666*x_18 + 5.01007986068726) + 0.004550616817086*std::sin(0.269839972257614*x_18 + 8.2186393737793) + 0.0295852443801383*std::sin(0.275279939174652*x_18 - 1.15727984905243) + 0.00582245875169266*std::sin(0.303439915180206*x_18 - 4.37415981292725) - 0.0134931530655109*std::sin(0.316159933805466*x_18 + 2.18255996704102) + 0.00151634017283765*std::sin(0.341119825839996*x_18 - 7.36839962005615) + 0.00234532605893551*std::sin(0.39743983745575*x_18 - 1.19631993770599) - 0.00456240710893609*std::sin(0.417519867420197*x_18 - 1.214479804039) - 0.0221881870831549*std::sin(0.249119967222214*x_19 - 7.57503986358643) + 0.00383416703471807*std::sin(0.270559966564178*x_19 + 5.01200008392334) - 0.00786024755513569*std::sin(0.345519840717316*x_2 - 7.40919971466064) + 0.00444287202832484*std::sin(0.391199827194214*x_2 - 4.21216011047363) + 0.00907228850407167*std::sin(0.423679858446121*x_2 + 5.21167993545532) + 0.0226529789365198*std::sin(0.262159943580627*x_20 + 8.19703960418701) + 0.00471885907957337*std::sin(0.269199967384338*x_20 + 2.0066397190094) + 0.00826266128128693*std::sin(0.273679971694946*x_20 - 7.41055965423584) - 0.0273650960260814*std::sin(0.282879948616028*x_20 + 1.99935972690582) - 0.00358563611642878*std::sin(0.289679944515228*x_20 + 1.98439979553223) - 0.0133196448988401*std::sin(0.327519834041595*x_20 + 8.24312019348145) + 0.00789545236077634*std::sin(0.341679841279984*x_20 + 8.24327945709229) + 0.00127010424665861*std::sin(0.366719841957092*x_20 + 1.7992799282074) + 0.0218293511563067*std::sin(0.311999946832657*x_21 + 1.99287974834442) + 0.00628237962938297*std::sin(0.343839854001999*x_21 + 8.24991989135742) + 0.00262202117069489*std::sin(0.436479866504669*x_21 + 1.78887987136841) - 0.000821463526927048*std::sin(0.338159829378128*x_22 + 2.02815985679626) + 0.00567278735721531*std::sin(0.353279858827591*x_22 - 7.37287998199463) + 0.0128244348505501*std::sin(0.373279839754105*x_22 + 1.98695981502533) + 0.0161662205660849*std::sin(0.398239850997925*x_22 + 5.19063997268677) + 0.00777143741623921*std::sin(0.212559998035431*x_23 - 1.18399977684021) - 0.00220407923943275*std::sin(0.323359936475754*x_23 + 5.21583986282349) - 0.00557010994696022*std::sin(0.344639837741852*x_23 - 1.16903984546661) + 0.007384429304623*std::sin(0.3503198325634*x_23 + 2.028639793396) + 0.00516730276520425*std::sin(0.294959932565689*x_24 + 8.21343994140625) - 0.00974863091407136*std::sin(0.331279844045639*x_24 + 2.03863978385925) + 0.014438658005738*std::sin(0.366319835186005*x_24 + 1.78495991230011) + 0.0083552501688557*std::sin(0.410559862852097*x_24 + 1.98767983913422) - 0.00322634097514692*std::sin(0.374479830265045*x_25 - 7.5918402671814) + 0.0027314994885446*std::sin(0.439119875431061*x_25 - 1.39551985263824) - 0.0148585755211928*std::sin(0.296079933643341*x_26 + 1.99919974803925) - 0.00577547835627039*std::sin(0.313919931650162*x_26 - 1.18519985675812) + 0.00269831504578061*std::sin(0.339119851589203*x_26 + 5.02279996871948) - 0.00269234939429596*std::sin(0.359279841184616*x_26 - 1.14727985858917) + 0.0108226335694854*std::sin(0.399359852075577*x_26 - 1.20367991924286) - 0.0164845171832915*std::sin(0.20040000975132*x_27 + 8.20024013519287) - 0.0065364502579993*std::sin(0.223039999604225*x_27 + 8.21224021911621) + 0.00282721364248821*std::sin(0.329599827528*x_27 + 2.0319197177887) - 0.00775069985872391*std::sin(0.112960062921047*x_28 + 5.09511995315552) + 0.0180600252656321*std::sin(0.231039986014366*x_28 - 1.15839993953705) + 0.00233024821718669*std::sin(0.284159928560257*x_28 - 1.17151987552643) + 0.00684263228659739*std::sin(0.310159921646118*x_28 + 1.99215984344482) + 0.0319480642860044*std::sin(0.326479852199554*x_28 - 1.12615978717804) + 0.00792741611716864*std::sin(0.335039854049683*x_28 + 8.22056007385254) + 0.0415136505500191*std::sin(0.0978400707244873*x_29 - 7.69432020187378) - 0.0358833704861356*std::sin(0.106960065662861*x_29 - 4.49688005447388) - 0.0330845963510327*std::sin(0.271039962768555*x_29 + 5.00927972793579) - 0.00475128981078104*std::sin(0.314319908618927*x_29 + 1.99423980712891) + 0.0145897493792019*std::sin(0.3572798371315*x_29 + 8.236159324646) - 0.00758827402346277*std::sin(0.263759940862656*x_3 + 8.26399993896484) - 0.00775736640842363*std::sin(0.291919946670532*x_3 - 4.32488012313843) + 0.0100637306461231*std::sin(0.308879911899567*x_3 - 1.10775983333588) - 0.00818431741248661*std::sin(0.319359928369522*x_3 + 5.25487995147705) + 0.00140858116369342*std::sin(0.377999842166901*x_3 + 1.98583984375) - 0.0128677438530649*std::sin(0.37967985868454*x_3 - 1.19287979602814) - 0.00206666767296275*std::sin(0.383679836988449*x_3 + 8.18943977355957) - 0.016908557545955*std::sin(0.386799842119217*x_3 - 1.1865599155426) + 0.0133144864435624*std::sin(0.396639823913574*x_3 + 2.00367975234985) + 0.0375684271620777*std::sin(0.145920038223267*x_30 - 4.45616006851196) + 0.00334963481217726*std::sin(0.338719844818115*x_31 + 2.12823987007141) - 0.00527482265227459*std::sin(0.34079983830452*x_31 - 1.05159986019135) + 0.0048916717311481*std::sin(0.346719831228256*x_31 - 4.22328042984009) + 0.0168726053844431*std::sin(0.35335984826088*x_31 + 5.17592000961304) + 0.0127339308765999*std::sin(0.382319837808609*x_31 - 4.20591974258423) - 0.00241889237409655*std::sin(0.40871986746788*x_31 - 4.19944000244141) + 0.00880406353274548*std::sin(0.410959839820862*x_31 - 4.19831991195679) + 0.00183718196534247*std::sin(0.443759858608246*x_31 - 1.16527986526489) - 0.000936321041631832*std::sin(0.591199815273285*x_31 - 4.39583969116211) + 0.00289362991633882*std::sin(0.254879981279373*x_32 - 1.16591989994049) - 0.00469065633884277*std::sin(0.311599940061569*x_32 + 2.01239991188049) - 0.00732230337168941*std::sin(0.312719941139221*x_32 - 7.36104011535645) - 0.00270298491054469*std::sin(0.316399931907654*x_32 - 4.34007978439331) + 0.0242546507315916*std::sin(0.319839835166931*x_32 + 2.00407981872559) - 0.00232521865910819*std::sin(0.348159849643707*x_32 - 1.19095981121063) - 0.0042181641905091*std::sin(0.366799831390381*x_32 + 7.98663997650146) - 0.00965616786246547*std::sin(0.210879996418953*x_33 + 2.16375994682312) + 0.0101773516781958*std::sin(0.251279979944229*x_33 - 7.4314398765564) + 0.00472243295734942*std::sin(0.254719972610474*x_33 + 1.96607983112335) - 0.0176495591349375*std::sin(0.264319956302643*x_33 - 1.22359991073608) + 0.00822117375051289*std::sin(0.289119929075241*x_33 + 4.96567964553833) + 0.0121085067036461*std::sin(0.224159985780716*x_34 + 5.17888021469116) + 0.0400078501668615*std::sin(0.239119976758957*x_34 + 1.97639977931976) + 0.0188013645765186*std::sin(0.243359968066216*x_34 + 1.97447979450226) + 0.0160628004750843*std::sin(0.216480001807213*x_35 - 7.40999984741211) - 0.00199488165326321*std::sin(0.230159983038902*x_35 + 5.16847991943359) + 0.00225326801268967*std::sin(0.209199994802475*x_36 + 1.98423981666565) + 0.0219726727727706*std::sin(0.231439992785454*x_36 + 1.96879982948303) + 0.0124142455777736*std::sin(0.241999983787537*x_36 + 1.98503983020782) - 0.00506909250675019*std::sin(0.243279978632927*x_36 + 5.17535972595215) - 0.0174859269986307*std::sin(0.261199980974197*x_36 - 1.21743988990784) - 0.0286472934163468*std::sin(0.2223199903965*x_37 - 1.1904798746109) + 0.00246317413020257*std::sin(0.233679980039597*x_38 - 4.23104000091553) - 0.00239383520941305*std::sin(0.246639966964722*x_38 - 4.40207958221436) + 0.000731789567773537*std::sin(0.313199937343597*x_4 + 2.00671982765198) - 0.00481847503579657*std::sin(0.32551982998848*x_4 + 5.22919988632202) - 0.0042978609531037*std::sin(0.332879841327667*x_4 - 1.16815984249115) - 0.00314819072377333*std::sin(0.382559835910797*x_4 + 2.01575970649719) + 0.00715163301310718*std::sin(0.416159868240356*x_4 - 4.40927982330322) - 0.00544783317438712*std::sin(0.443599849939346*x_4 + 5.17671966552734) + 0.00744662987372623*std::sin(0.225519984960556*x_40 + 1.99303984642029) - 0.00642105298152782*std::sin(0.23047998547554*x_40 + 1.9651198387146) - 0.005819119237626*std::sin(0.236319988965988*x_41 - 7.4236798286438) + 0.0212280985049456*std::sin(0.241679981350899*x_41 - 7.42560005187988) - 0.000958181840437125*std::sin(0.26199996471405*x_41 + 1.97463977336884) + 0.00556821071076199*std::sin(0.222159996628761*x_42 + 4.99399995803833) - 0.0287153723447157*std::sin(0.229359999299049*x_42 + 1.96647977828979) + 0.00461246975316345*std::sin(0.25639995932579*x_42 + 5.14743995666504) + 0.0184344390640581*std::sin(0.211759999394417*x_43 - 1.20295989513397) - 0.0324385037263519*std::sin(0.242719978094101*x_44 - 1.20631992816925) - 0.00827302672919754*std::sin(0.260479986667633*x_44 + 1.94247984886169) + 0.013261682901239*std::sin(0.267679959535599*x_44 - 7.4443998336792) - 0.00544519182448258*std::sin(0.194399997591972*x_46 - 7.60128021240234) - 0.00224531207925417*std::sin(0.249199971556664*x_46 + 1.97567975521088) - 0.0360815960890937*std::sin(0.207040011882782*x_47 - 7.58816003799438) + 0.0133954438637505*std::sin(0.253199964761734*x_48 - 1.20247983932495) - 0.00194084357874406*std::sin(0.296239942312241*x_49 + 5.06767988204956) + 0.00569505237531696*std::sin(0.309839934110641*x_5 + 1.81447994709015) + 0.00199343442130072*std::sin(0.364319831132889*x_5 - 1.16543984413147) - 0.0112344226304134*std::sin(0.388639837503433*x_5 + 2.00431990623474) - 0.00847610085270148*std::sin(0.388959854841232*x_5 + 4.98991966247559) - 0.0219184100643167*std::sin(0.408159852027893*x_5 - 1.17863988876343) - 0.0365760853135497*std::sin(0.181120008230209*x_50 - 7.37967967987061) + 0.00127810240741038*std::sin(0.215199992060661*x_52 - 1.20711994171143) - 0.0125141324360421*std::sin(0.242479979991913*x_53 + 1.96927976608276) + 0.0226306327872307*std::sin(0.247439980506897*x_53 + 1.98375976085663) - 0.0241576754822214*std::sin(0.214560002088547*x_57 - 7.41511964797974) + 0.0222574347337645*std::sin(0.222719997167587*x_59 - 1.18319988250732) + 0.0335831889129009*std::sin(0.265359938144684*x_6 + 5.20975971221924) + 0.00374220360797322*std::sin(0.477919846773148*x_6 + 4.96743965148926) + 0.0136301417601523*std::sin(0.255839973688126*x_60 + 8.34751987457275) - 0.0248216819908451*std::sin(0.327759832143784*x_60 - 7.52952003479004) + 0.0195898327224707*std::sin(0.390639841556549*x_60 - 4.37255954742432) - 0.00118579520580352*std::sin(0.490879863500595*x_60 + 1.69871997833252) - 0.0158882984308817*std::sin(0.149440035223961*x_61 - 1.27567994594574) - 0.0072752696074214*std::sin(0.240959972143173*x_61 + 8.25207996368408) - 0.0326730406713255*std::sin(0.285119920969009*x_7 + 8.39744091033936) - 0.00880825180153003*std::sin(0.336559861898422*x_7 + 5.23784017562866) + 0.0154193384834439*std::sin(0.349679857492447*x_7 + 2.00879979133606) + 0.0114983067181364*std::sin(0.352479845285416*x_7 - 7.59647989273071) + 0.0172434600853657*std::sin(0.364639848470688*x_7 + 1.99303984642029) - 0.00369752573128942*std::sin(0.39031982421875*x_7 + 1.9793598651886) + 0.00200506937742843*std::sin(0.457919865846634*x_7 + 7.9870400428772) + 0.00454270336990945*std::sin(0.323199838399887*x_8 - 1.12079977989197) - 0.0106421310464989*std::sin(0.334079831838608*x_8 + 8.25943946838379) - 0.00134589096381073*std::sin(0.335839837789536*x_8 - 4.34151983261108) - 0.0147785933450591*std::sin(0.34215983748436*x_8 - 1.14503979682922) + 0.0128183300690812*std::sin(0.259759962558746*x_9 + 5.17736005783081) + 0.00147509995928626*std::sin(0.280479967594147*x_9 + 1.99911975860596) - 0.00460840059595231*std::sin(0.334879845380783*x_9 + 5.06487989425659) - 0.00907128118965444*std::sin(0.333039849996567*x_91 + 8.41728019714355) - 0.0124420499712754*std::sin(0.34775984287262*x_91 + 5.19016027450562) - 0.00338182587895695*std::sin(0.353039860725403*x_91 + 5.20071983337402) + 0.0136279557671642*std::sin(0.356399834156036*x_91 + 5.21304035186768) - 0.0278804332224946*std::sin(0.367759823799133*x_91 + 5.19528007507324) - 0.00249477567645623*std::sin(0.400319844484329*x_91 + 1.97431981563568) - 0.00191794373063002*std::sin(0.484399855136871*x_91 - 7.60904026031494) - 0.00831637305667514*std::sin(0.268319964408875*x_92 - 7.3744797706604) - 0.00344017343993695*std::sin(0.286079943180084*x_92 + 5.21439981460571) + 0.0216246316397311*std::sin(0.289279937744141*x_92 + 2.00223970413208) - 0.0296439548955123*std::sin(0.299279928207397*x_92 - 7.40520000457764) + 0.00573889626705867*std::sin(0.300959944725037*x_92 + 1.80455982685089) - 0.00288822501985421*std::sin(0.316799849271774*x_92 + 8.22192001342773) + 0.000690818893843685*std::sin(0.270399957895279*x_94 + 5.1864800453186) - 0.00544197623788896*std::sin(0.285599917173386*x_94 + 1.98791980743408) - 0.0165258276339279*std::sin(0.287359952926636*x_94 + 1.9755197763443) - 0.00222845702653508*std::sin(0.261279970407486*x_95 - 7.41343975067139) + 0.0241325540721293*std::sin(0.278959959745407*x_95 + 1.97447979450226) - 0.00647649762483827*std::sin(0.281039953231812*x_95 + 1.97343981266022) + 0.0219436634101002*std::sin(0.281679958105087*x_95 + 1.96399986743927) + 0.0113330515203798*std::sin(0.28263995051384*x_95 - 4.40463972091675) + 0.00710484626678554*std::sin(0.273119956254959*x_96 + 8.19167995452881) + 0.0108725900802696*std::sin(0.278159946203232*x_96 - 7.4423999786377) - 0.00624830245567343*std::sin(0.262239962816238*x_97 + 5.17519998550415) + 0.0115176183627743*std::sin(0.273119956254959*x_97 + 1.97847986221313) - 0.0245117263735586*std::sin(0.27567994594574*x_97 + 1.97919988632202) + 0.0149362637265832*std::sin(0.28383994102478*x_97 + 8.18407917022705) - 0.00452167061243874*std::sin(0.284799933433533*x_97 + 8.18175983428955) + 0.0279039178680735*std::sin(0.248399972915649*x_99 + 1.98031985759735) - 0.190464831047359);
}

inline float score_8(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (6.99461443554906e-6*x_1 - 0.00234465309783681*x_10 + 0.000949943124707522*x_100 + 0.00200904326708047*x_101 - 0.00295121011804351*x_102 + 0.00123049940346146*x_103 - 0.00399450262335826*x_104 + 0.00436817602988037*x_105 + 0.00565072512791526*x_106 - 0.0027070103953485*x_107 + 0.0014496610216711*x_108 + 0.0016058303755088*x_109 + 0.000505159156272775*x_11 - 2.27520125527988e-5*x_110 + 0.00202125800993431*x_111 + 0.00346168233818515*x_112 - 0.000156063779868492*x_113 + 0.000711786110224993*x_114 + 0.00490852290675868*x_115 + 0.00599142302317642*x_116 + 0.00496434957753413*x_117 - 0.00108993076362587*x_118 + 0.000374770061167764*x_119 - 0.00422157425240746*x_12 + 0.00078381330876022*x_120 - 0.00177445114852818*x_13 - 0.000900764935769264*x_14 + 0.000549869065629268*x_15 + 0.00250533736689348*x_16 + 0.00234847941816092*x_17 + 0.00155057091411264*x_18 + 0.000203740402544463*x_19 + 0.0017649054797289*x_2 - 0.000699706259366909*x_20 + 0.00028801500556054*x_21 - 0.000386653685925907*x_22 - 0.00113507944317572*x_23 - 0.000954424525300967*x_24 - 0.00999496452795522*x_25 - 0.00644178848739*x_26 + 0.000252972161857296*x_27 + 8.13846118003345e-5*x_28 - 0.000748825307770072*x_29 - 0.00316775538043335*x_30 - 0.000812998787142275*x_32 + 0.00368988817037535*x_33 + 0.00436957011323726*x_34 - 0.00405215680568287*x_35 + 0.00263542499521437*x_36 + 0.00161296921446147*x_37 + 0.00220229683615695*x_38 - 0.004214233598866*x_39 + 0.000601617695580695*x_4 + 0.0030838841586699*x_40 - 0.00090170636949003*x_41 + 0.00364118301904761*x_42 + 0.00359465574230033*x_43 + 0.00127626906388845*x_44 - 0.000229067201146252*x_45 - 0.000626039194880785*x_46 - 0.0012939759404364*x_47 + 0.00372140271999867*x_48 + 0.00454606362397201*x_49 + 0.00258491261443438*x_5 + 0.000944703111809508*x_50 - 0.00201393076372016*x_51 + 1.36149695440509e-5*x_52 + 0.00181379250531925*x_53 + 0.00691962335597944*x_54 + 9.17202967333076e-5*x_55 + 0.006174396061665*x_56 - 0.00636038848767637*x_57 - 0.00362560015285889*x_58 + 0.00461973366991209*x_59 + 0.00400861463530802*x_6 - 0.00286105731022854*x_60 - 0.000935778590030751*x_61 + 0.000909883049296783*x_62 + 0.00229980204945058*x_63 - 0.00283729528601252*x_64 - 0.00261000656836108*x_65 + 0.000333187866442654*x_66 - 0.0018103897407122*x_67 - 0.00197267354125502*x_68 + 0.000788664874750507*x_69 + 0.00250845863726043*x_7 - 0.000316172679485008*x_70 + 0.000810615128129692*x_71 + 0.00168690786643258*x_72 - 0.00239943984374405*x_73 + 0.000863665430331219*x_74 - 0.00175332741562903*x_75 - 0.00109851660886026*x_76 - 0.00241254149223389*x_77 + 0.00257938578579223*x_78 - 0.00134195013428393*x_79 + 4.03282875953426e-6*x_8 + 0.00251002451940914*x_80 - 0.0010599378733578*x_81 - 0.00121081900290269*x_82 - 0.0010725272196773*x_83 + 0.0014875522449574*x_84 - 0.00124588592560424*x_85 + 0.0023924488843734*x_86 - 0.00299755433011722*x_87 + 0.00303112021993812*x_88 + 0.0012283428398558*x_89 - 0.00259509070855733*x_9 + 0.000493791371873229*x_90 + 7.63410090457914e-5*x_91 + 0.000404114396357286*x_92 - 0.00426633838750025*x_93 + 0.000155328966523371*x_94 - 0.00156288780647152*x_95 + 0.00298884479884186*x_96 + 0.000477809598573695*x_97 + 0.000782304095622269*x_98 + 0.000808574077248696*x_99 - 0.00149105663876981*std::pow(-0.00460737201347084*x_100 + 0.1590421608333*x_101 + 0.241994568647301*x_103 - 0.194440968592668*x_104 + 0.00925483408879724*x_105 - 0.275389116289149*x_106 - 0.108438209377856*x_107 + 0.0228126623520847*x_108 + 0.0377340059577574*x_109 - 0.332806483943157*x_11 + 0.0152221947112061*x_110 + 0.374490799984774*x_111 + 0.179698502988873*x_112 - 0.132137667100478*x_113 + 0.00655748350397279*x_114 - 0.180877361242814*x_115 + 0.180968352439115*x_117 - 0.268309487525973*x_118 + 0.00381584846782158*x_119 - 0.0483317371875453*x_120 + 0.111190227243043*x_13 - 0.247474045898021*x_14 - 0.142840746158386*x_15 + 0.0682967811411442*x_16 + 0.166173038300708*x_19 + 0.00020686195578138*x_2 - 0.06704266506649*x_25 + 0.0385628148944077*x_28 - 0.0796490798855639*x_3 - 0.206988123976829*x_30 - 0.0321366238067232*x_34 + 0.306245886489922*x_35 + 0.259697219114835*x_36 - 0.1246632544975*x_37 - 0.0990326533431957*x_38 + 0.229421076579828*x_39 + 0.00608754578850177*x_4 + 0.19876155464528*x_41 + 0.065446859523423*x_42 + 0.241280602371089*x_43 - 0.309306292191985*x_44 - 0.18568265390415*x_45 + 0.0495079423396905*x_46 - 0.277188296194385*x_47 - 0.0988753267585761*x_48 + 0.164315688478287*x_49 + 0.0118085659704688*x_5 - 0.0753994886626972*x_50 - 0.218813038494837*x_51 - 0.227105834798704*x_52 - 0.100231676127606*x_53 - 0.200018326254061*x_54 + 0.0231946663100385*x_55 + 0.34382106702532*x_56 + 0.158760854715014*x_57 - 0.102896709746374*x_58 + 0.408773152731299*x_59 + 0.0279500494349833*x_60 + 0.235423074733626*x_61 + 0.00341303940476501*x_62 - 0.0214218019633006*x_63 + 0.00358214355706491*x_64 - 0.00346395350267684*x_65 + 0.00232551804168476*x_66 + 0.0502918850739611*x_67 - 0.111833734037248*x_68 - 0.144485169762403*x_69 - 0.00352243418684744*x_70 - 0.160090786833211*x_71 + 0.070117393836524*x_72 - 0.033800284791293*x_73 + 0.0186540125764249*x_74 + 0.0486818006648202*x_75 - 0.199659204646964*x_76 + 0.0817340901668874*x_77 - 0.00397978495820971*x_78 + 0.105089647487088*x_79 - 0.139053681656203*x_8 - 0.0737223295618047*x_80 + 0.0966353837107156*x_81 + 0.0315689429936647*x_82 + 0.0728798338266844*x_83 - 0.130522012293369*x_84 - 0.00252916200490921*x_85 - 0.0547963051069069*x_86 + 0.0373844118142418*x_87 + 0.0669812667736022*x_88 + 0.121865236086268*x_89 + 0.00895042098150096*x_9 - 0.0143686384350277*x_90 - 0.0792645011595011*x_91 + 0.00148694534415787*x_92 - 0.220668611666183*x_93 + 0.0225626208672833*x_98 + 0.0792780546327852*x_99 - 0.00203926673700322*std::pow(-4.01999998092651*x_27 - 6.62815999984741, 2) + 1.25140759067396*std::sin(0.359039843082428*x_1 - 1.03663980960846) + 0.831714296068633*std::sin(0.366479843854904*x_10 + 8.24079990386963) + 1.4643657896677*std::sin(0.239359974861145*x_102 - 1.2099198102951) - 1.36588184675868*std::sin(0.250639975070953*x_116 - 4.40895986557007) + 1.30593272673217*std::sin(0.277439951896667*x_12 - 7.43567991256714) - 1.46616230337993*std::sin(0.3503198325634*x_17 + 2.00575995445251) + 1.09768031770701*std::sin(0.303439915180206*x_18 - 4.37415981292725) + 1.55772003669614*std::sin(0.273679971694946*x_20 - 7.41055965423584) + 0.494317118321561*std::sin(0.436479866504669*x_21 + 1.78887987136841) + 1.06946348511995*std::sin(0.353279858827591*x_22 - 7.37287998199463) + 1.46511194941787*std::sin(0.212559998035431*x_23 - 1.18399977684021) - 1.83786278878409*std::sin(0.331279844045639*x_24 + 2.03863978385925) - 1.08882332831947*std::sin(0.313919931650162*x_26 - 1.18519985675812) - 0.895737957353504*std::sin(0.314319908618927*x_29 + 1.99423980712891) + 1.65978801531695*std::sin(0.410959839820862*x_31 - 4.19831991195679) + 0.545522216876147*std::sin(0.254879981279373*x_32 - 1.16591989994049) + 1.91868746520363*std::sin(0.251279979944229*x_33 - 7.4314398765564) - 1.21053042663943*std::sin(0.23047998547554*x_40 + 1.9651198387146) + 0.705499758865649*std::sin(0.477919846773148*x_6 + 4.96743965148926) - 1.66057760961141*std::sin(0.336559861898422*x_7 + 5.23784017562866) - 1.02594976804659*std::sin(0.285599917173386*x_94 + 1.98791980743408) - 1.2209831402231*std::sin(0.281039953231812*x_95 + 1.97343981266022) + 1.33944270624801*std::sin(0.273119956254959*x_96 + 8.19167995452881) - 1.17796259572972*std::sin(0.262239962816238*x_97 + 5.17519998550415) + 3.77529170610335, 2) - 4.69617340652568e-6*std::exp(0.163839861750603*x_49) + 0.164848569035315*std::exp(0.0566014974651534*x_10 - 0.0194114919130237*x_100 + 0.0152942241778906*x_101 + 0.0361417573544022*x_102 - 0.0819394750353084*x_103 + 0.0227931143567391*x_104 - 0.00418964769575055*x_105 + 0.037534654601537*x_106 - 0.0335867181377605*x_107 - 0.025737345068496*x_108 + 0.0367741360002955*x_11 - 0.0211875708669454*x_111 - 0.0342161747058128*x_112 - 0.0293130457380853*x_113 + 0.0201006324977662*x_114 - 0.0496998298138893*x_115 + 0.0191079763312167*x_116 + 0.0190908285807722*x_117 - 0.00231017717339985*x_118 + 0.051918171078765*x_119 - 0.0112506707589679*x_12 - 0.0289851426606744*x_120 + 0.00628817092301564*x_15 + 0.0292846310058168*x_17 - 0.0899991664321499*x_19 + 0.000260127712981679*x_2 - 0.0229415983592692*x_24 + 0.0215819178401359*x_25 - 0.0195998793377634*x_27 - 0.0617947913466877*x_30 + 0.0118672438917954*x_35 - 0.0643096128251422*x_36 + 0.0198221952853352*x_37 - 0.0235837053564623*x_38 - 0.0574065227613756*x_39 + 0.0472495277980096*x_4 - 0.0470867516035789*x_40 + 0.056354042733413*x_42 - 0.0563187535027797*x_43 - 0.0723018100726644*x_45 - 0.0353468705818653*x_46 - 0.00467713431425659*x_47 - 0.0855478025177745*x_48 - 0.0327819046429052*x_49 + 0.0509188849923557*x_5 + 0.0866517111294754*x_50 - 0.0297834802044855*x_51 - 0.0231017958217438*x_52 - 0.0107461912998741*x_53 + 0.00430772306221632*x_54 + 0.0534178313748228*x_55 + 0.00333754450378913*x_56 - 0.013832608447656*x_57 - 0.0490953210498847*x_58 + 0.0216468991515681*x_59 - 0.00854897764776254*x_61 + 0.0222369480227416*x_62 - 0.00414416788003896*x_63 + 0.0246503944259625*x_64 - 0.0230993189584649*x_65 - 0.0197216028145245*x_66 - 0.028635200994477*x_67 + 0.0193213833261817*x_68 - 0.00263844616009325*x_69 + 0.00360795315105863*x_70 - 0.00035862951757198*x_71 + 0.0279865078856186*x_72 - 0.0187085076435669*x_73 + 0.00672601053843005*x_74 - 0.00377061079395704*x_75 + 0.0240574006054761*x_76 + 0.0215184393937497*x_77 - 0.0132794357646697*x_78 - 0.033542244257492*x_79 + 0.0243090472068238*x_8 + 0.0121953384196129*x_80 - 0.00073880353314893*x_81 - 0.0347235861817592*x_82 + 0.00491678571320728*x_83 - 0.0269530532352288*x_84 + 0.00918739196062251*x_85 + 0.029405764330758*x_86 - 0.0374852125045505*x_87 + 0.0206641309689677*x_88 - 0.00235979009402891*x_89 - 0.015118711959066*x_9 + 0.0182879627546657*x_90 + 0.0189417467849214*x_92 + 0.0229815522073732*x_93 - 0.0187459864508823*x_94 - 0.0137962325670649*x_95 + 0.024623817822134*x_96 - 0.0343135421096121*x_97 - 0.00965867388156208*x_98 + 0.0440277919432371*x_99 - 0.000422938558046534*std::pow(-3.34895968437195*x_1 - 4.17543983459473, 2) - 0.000311296063706338*std::pow(-5.60767984390259*x_22 - 9.60639953613281, 2) + 0.339367370094834*std::sin(0.252159982919693*x_109 - 1.214399933815) - 0.092858282440309*std::sin(0.219759985804558*x_110 - 4.41991996765137) + 0.361358376530365*std::sin(0.289919942617416*x_13 - 7.4443998336792) - 0.119952349532801*std::sin(0.346159845590591*x_14 - 1.13391983509064) - 0.259059459876401*std::sin(0.279039949178696*x_16 - 1.19951987266541) + 0.373761237453678*std::sin(0.275279939174652*x_18 - 1.15727984905243) - 0.345713289446863*std::sin(0.282879948616028*x_20 + 1.99935972690582) + 0.275778195243488*std::sin(0.311999946832657*x_21 + 1.99287974834442) + 0.0932902023495874*std::sin(0.3503198325634*x_23 + 2.028639793396) + 0.136726297185978*std::sin(0.399359852075577*x_26 - 1.20367991924286) + 0.403611607474268*std::sin(0.326479852199554*x_28 - 1.12615978717804) + 0.184317652139132*std::sin(0.3572798371315*x_29 + 8.236159324646) - 0.213612005725921*std::sin(0.386799842119217*x_3 - 1.1865599155426) + 0.213157808890392*std::sin(0.35335984826088*x_31 + 5.17592000961304) + 0.306417893831306*std::sin(0.319839835166931*x_32 + 2.00407981872559) + 0.103861101663782*std::sin(0.289119929075241*x_33 + 4.96567964553833) + 0.505433837019993*std::sin(0.239119976758957*x_34 + 1.97639977931976) + 0.268182350094888*std::sin(0.241679981350899*x_41 - 7.42560005187988) - 0.409807508706823*std::sin(0.242719978094101*x_44 - 1.20631992816925) + 0.424268736281022*std::sin(0.265359938144684*x_6 + 5.20975971221924) + 0.172194577319891*std::sin(0.255839973688126*x_60 + 8.34751987457275) - 0.412770499907964*std::sin(0.285119920969009*x_7 + 8.39744091033936) - 0.157184978226725*std::sin(0.34775984287262*x_91 + 5.19016027450562)) - 0.0024453565955013*std::sin(0.329999834299088*x_1 + 5.14520025253296) - 0.0115576033713258*std::sin(0.342239856719971*x_1 + 8.34768009185791) + 0.00528532098830906*std::sin(0.408399850130081*x_1 + 8.39400005340576) + 0.00105112343560704*std::sin(0.352079838514328*x_10 + 8.25903987884521) - 0.0129547752953196*std::sin(0.242079973220825*x_100 + 1.9755197763443) - 0.0020020973099095*std::sin(0.257839977741241*x_100 + 1.95887982845306) + 0.00120430855764939*std::sin(0.229919984936714*x_101 + 1.98535978794098) - 2.29634662066797e-5*std::sin(0.247999966144562*x_107 + 5.15144014358521) + 0.0140293205436869*std::sin(0.246319979429245*x_108 + 1.97391986846924) - 0.0023716991466115*std::sin(0.23471999168396*x_109 + 1.98399984836578) + 0.00722315166560128*std::sin(0.246079966425896*x_109 - 7.44191980361938) + 0.0057364941141676*std::sin(0.216800004243851*x_11 + 5.18383979797363) + 0.00124964749842266*std::sin(0.218799993395805*x_11 + 2.00231981277466) + 1.79102603016641e-5*std::sin(0.25655996799469*x_11 + 8.37376022338867) - 0.0142574994823503*std::sin(0.210319995880127*x_110 + 5.17592000961304) + 0.0282783076267511*std::sin(0.213039994239807*x_111 - 7.41463994979858) - 0.0022168114245504*std::sin(0.216879993677139*x_111 + 1.98231983184814) - 3.09605934358447e-5*std::sin(0.267279952764511*x_112 - 1.20023989677429) + 0.0010978387027239*std::sin(0.278399974107742*x_112 + 1.96583986282349) - 0.00923991392701177*std::sin(0.290479928255081*x_112 + 1.95439982414246) + 2.50734049638097e-5*std::sin(0.293919950723648*x_113 + 1.96367979049683) + 0.00816124116397214*std::sin(0.237119987607002*x_116 + 8.16991996765137) + 0.0161383451736854*std::sin(0.225919991731644*x_117 - 7.40279960632324) + 0.0303064171522118*std::sin(0.23471999168396*x_118 - 7.41639995574951) + 0.00776536280100437*std::sin(0.265759944915771*x_119 + 8.15824031829834) + 1.87221998262318e-5*std::sin(0.285599917173386*x_12 + 5.13567972183228) - 0.00277413877073922*std::sin(0.248639971017838*x_13 + 1.98823988437653) + 0.0153497149824661*std::sin(0.389119833707809*x_13 + 4.99919986724854) - 2.27265622300656e-5*std::sin(0.281199961900711*x_14 + 5.17095994949341) - 0.00546190587815044*std::sin(0.304159939289093*x_14 - 4.2577600479126) + 0.00110808934552971*std::sin(0.357839852571487*x_14 + 8.01512050628662) + 0.0209897215596372*std::sin(0.280799955129623*x_15 - 1.3802398443222) - 7.52399874251992e-6*std::sin(0.300879925489426*x_15 - 7.43351984024048) - 0.00101819828707431*std::sin(0.306239932775497*x_16 + 1.99111986160278) + 1.68588495520524e-5*std::sin(0.321919918060303*x_16 + 1.98375976085663) - 0.0140696258694254*std::sin(0.328959852457047*x_16 - 7.32767963409424) - 0.00398338790374954*std::sin(0.461359858512878*x_16 - 1.4119998216629) + 0.0112950374092503*std::sin(0.257359951734543*x_17 + 8.24071979522705) - 0.00119636958634775*std::sin(0.288959950208664*x_17 + 2.01887989044189) + 1.19308756889906e-5*std::sin(0.351999849081039*x_17 - 4.17120027542114) + 0.00275854926799499*std::sin(0.389599829912186*x_17 + 8.19871997833252) + 0.00971266492417708*std::sin(0.316159933805466*x_18 + 2.18255996704102) - 0.0201997126082743*std::sin(0.341119825839996*x_18 - 7.36839962005615) + 1.27731152643141e-5*std::sin(0.39743983745575*x_18 - 1.19631993770599) - 0.000781205616391068*std::sin(0.417519867420197*x_18 - 1.214479804039) + 2.08816412926889e-5*std::sin(0.270559966564178*x_19 + 5.01200008392334) + 2.41967705540044e-5*std::sin(0.391199827194214*x_2 - 4.21216011047363) - 0.0065304305011362*std::sin(0.423679858446121*x_2 + 5.21167993545532) - 0.00480282652834314*std::sin(0.269199967384338*x_20 + 2.0066397190094) - 1.95280921544102e-5*std::sin(0.289679944515228*x_20 + 1.98439979553223) + 0.00135191173889454*std::sin(0.341679841279984*x_20 + 8.24327945709229) - 0.0169195153070706*std::sin(0.366719841957092*x_20 + 1.7992799282074) + 0.010943010980876*std::sin(0.338159829378128*x_22 + 2.02815985679626) - 1.20038568069014e-5*std::sin(0.323359936475754*x_23 + 5.21583986282349) + 0.00566922456634733*std::sin(0.344639837741852*x_23 - 1.16903984546661) + 0.000884779864090645*std::sin(0.294959932565689*x_24 + 8.21343994140625) + 0.00606424453562898*std::sin(0.366319835186005*x_24 + 1.78495991230011) + 1.48762930760385e-5*std::sin(0.439119875431061*x_25 - 1.39551985263824) + 1.46955639570355e-5*std::sin(0.339119851589203*x_26 + 5.02279996871948) + 0.00274025709953226*std::sin(0.359279841184616*x_26 - 1.14727985858917) - 0.0028225884055501*std::sin(0.20040000975132*x_27 + 8.20024013519287) + 0.00665275995127887*std::sin(0.223039999604225*x_27 + 8.21224021911621) + 1.53975715209226e-5*std::sin(0.329599827528*x_27 + 2.0319197177887) - 4.22118631639293e-5*std::sin(0.112960062921047*x_28 + 5.09511995315552) - 0.00237171268868244*std::sin(0.284159928560257*x_28 - 1.17151987552643) + 0.00135738478534095*std::sin(0.335039854049683*x_28 + 8.22056007385254) - 0.0138955491954659*std::sin(0.271039962768555*x_29 + 5.00927972793579) - 0.00318707938531072*std::sin(0.263759940862656*x_3 + 8.26399993896484) - 0.00132826774594368*std::sin(0.291919946670532*x_3 - 4.32488012313843) + 0.00832994927846524*std::sin(0.319359928369522*x_3 + 5.25487995147705) - 0.018764216105143*std::sin(0.377999842166901*x_3 + 1.98583984375) + 0.0092624817763621*std::sin(0.37967985868454*x_3 - 1.19287979602814) - 1.12554859053441e-5*std::sin(0.383679836988449*x_3 + 8.18943977355957) - 0.00340923826393246*std::sin(0.338719844818115*x_31 + 2.12823987007141) - 0.000903190132540509*std::sin(0.34079983830452*x_31 - 1.05159986019135) + 0.0053482581764046*std::sin(0.382319837808609*x_31 - 4.20591974258423) + 0.0322229349735286*std::sin(0.40871986746788*x_31 - 4.19944000244141) + 1.00056607973261e-5*std::sin(0.443759858608246*x_31 - 1.16527986526489) + 0.000673984241835331*std::sin(0.591199815273285*x_31 - 4.39583969116211) + 0.00477412194762377*std::sin(0.311599940061569*x_32 + 2.01239991188049) - 0.00125377336618628*std::sin(0.312719941139221*x_32 - 7.36104011535645) - 0.000976593153050348*std::sin(0.348159849643707*x_32 - 1.19095981121063) + 0.00303632628924204*std::sin(0.366799831390381*x_32 + 7.98663997650146) - 0.00480646399975358*std::sin(0.254719972610474*x_33 + 1.96607983112335) - 0.00871596637003044*std::sin(0.224159985780716*x_34 + 5.17888021469116) - 0.000341576872548783*std::sin(0.230159983038902*x_35 + 5.16847991943359) - 0.0300165933087244*std::sin(0.209199994802475*x_36 + 1.98423981666565) + 0.00212564949533323*std::sin(0.241999983787537*x_36 + 1.98503983020782) - 2.76072926523396e-5*std::sin(0.243279978632927*x_36 + 5.17535972595215) - 0.00250700388737504*std::sin(0.233679980039597*x_38 - 4.23104000091553) - 1.30373058096171e-5*std::sin(0.246639966964722*x_38 - 4.40207958221436) - 0.00974843193074288*std::sin(0.313199937343597*x_4 + 2.00671982765198) - 2.62423797305114e-5*std::sin(0.32551982998848*x_4 + 5.22919988632202) - 0.000735908268347281*std::sin(0.332879841327667*x_4 - 1.16815984249115) + 0.00320420967641808*std::sin(0.382559835910797*x_4 + 2.01575970649719) - 0.00514790092276796*std::sin(0.416159868240356*x_4 - 4.40927982330322) - 0.00757913531664911*std::sin(0.225519984960556*x_40 + 1.99303984642029) - 3.16920883882219e-5*std::sin(0.236319988965988*x_41 - 7.4236798286438) + 0.0127642847891293*std::sin(0.26199996471405*x_41 + 1.97463977336884) - 0.0120604726395479*std::sin(0.229359999299049*x_42 + 1.96647977828979) + 2.51204337178854e-5*std::sin(0.25639995932579*x_42 + 5.14743995666504) - 0.00954604766766172*std::sin(0.267679959535599*x_44 - 7.4443998336792) - 1.22284191076132e-5*std::sin(0.249199971556664*x_46 + 1.97567975521088) - 0.0151542907819482*std::sin(0.207040011882782*x_47 - 7.58816003799438) + 0.00229365677602879*std::sin(0.253199964761734*x_48 - 1.20247983932495) + 0.0258546750989774*std::sin(0.296239942312241*x_49 + 5.06767988204956) + 0.000975144653909759*std::sin(0.309839934110641*x_5 + 1.81447994709015) + 1.08566429550875e-5*std::sin(0.364319831132889*x_5 - 1.16543984413147) + 0.00610128166827432*std::sin(0.388959854841232*x_5 + 4.98991966247559) - 0.00920574463425789*std::sin(0.408159852027893*x_5 - 1.17863988876343) + 0.0263282613903388*std::sin(0.181120008230209*x_50 - 7.37967967987061) - 0.0170260616820032*std::sin(0.215199992060661*x_52 - 1.20711994171143) - 0.00214275278594711*std::sin(0.242479979991913*x_53 + 1.96927976608276) + 0.00950487858104611*std::sin(0.247439980506897*x_53 + 1.98375976085663) - 0.0104251204868404*std::sin(0.327759832143784*x_60 - 7.52952003479004) - 0.0141011874859979*std::sin(0.390639841556549*x_60 - 4.37255954742432) - 6.45807809361651e-6*std::sin(0.490879863500595*x_60 + 1.69871997833252) - 0.00124571993300313*std::sin(0.240959972143173*x_61 + 8.25207996368408) - 0.0110991750642005*std::sin(0.349679857492447*x_7 + 2.00879979133606) + 0.0048292953304063*std::sin(0.352479845285416*x_7 - 7.59647989273071) + 0.00376331955924264*std::sin(0.39031982421875*x_7 + 1.9793598651886) + 1.09200092555421e-5*std::sin(0.457919865846634*x_7 + 7.9870400428772) - 0.00462353630135686*std::sin(0.323199838399887*x_8 - 1.12079977989197) - 0.00182221628745301*std::sin(0.334079831838608*x_8 + 8.25943946838379) - 7.32999164378698e-6*std::sin(0.335839837789536*x_8 - 4.34151983261108) - 0.0196503368965677*std::sin(0.280479967594147*x_9 + 1.99911975860596) + 0.00469040254481877*std::sin(0.334879845380783*x_9 + 5.06487989425659) + 0.00344200213903405*std::sin(0.353039860725403*x_91 + 5.20071983337402) - 0.0117097977355853*std::sin(0.367759823799133*x_91 + 5.19528007507324) + 0.0332338037263915*std::sin(0.400319844484329*x_91 + 1.97431981563568) - 0.000328403050958686*std::sin(0.484399855136871*x_91 - 7.60904026031494) + 0.045827787230158*std::sin(0.286079943180084*x_92 + 5.21439981460571) - 0.0155658799841469*std::sin(0.289279937744141*x_92 + 2.00223970413208) + 0.00098265189595442*std::sin(0.300959944725037*x_92 + 1.80455982685089) + 0.00293961813889012*std::sin(0.316799849271774*x_92 + 8.22192001342773) - 0.00920264685324172*std::sin(0.270399957895279*x_94 + 5.1864800453186) - 0.00694085696094241*std::sin(0.287359952926636*x_94 + 1.9755197763443) - 1.21366231160296e-5*std::sin(0.261279970407486*x_95 - 7.41343975067139) - 0.0157955259883623*std::sin(0.281679958105087*x_95 + 1.96399986743927) + 0.00197212303453261*std::sin(0.273119956254959*x_97 + 1.97847986221313) + 0.00460212928668634*std::sin(0.284799933433533*x_97 + 8.18175983428955) + 0.0117196613000222*std::sin(0.248399972915649*x_99 + 1.98031985759735) + 0.0941010415554047*std::sin(-0.0135234724442533*x_1 + 0.0150288947853413*x_100 - 0.0330117396172496*x_101 + 0.000908394042966762*x_102 + 0.0481777465747345*x_103 - 0.0373198282785987*x_104 - 0.033407308029482*x_105 + 0.0451736066004048*x_106 + 0.0324389052444581*x_107 - 0.00795998682264037*x_108 - 0.00014980279687064*x_11 + 0.0221640764347409*x_110 + 0.0460867062064012*x_111 + 0.0293243273399449*x_112 + 0.0119757668316993*x_113 - 0.0044558964415081*x_114 - 0.00513946636756397*x_115 + 0.0370145013690851*x_116 + 0.0155071338490286*x_118 + 0.0168654104703028*x_119 + 0.0028300755792542*x_12 + 0.0720364436260973*x_120 - 0.0183477347795653*x_13 + 0.0018700055875971*x_17 - 0.00815651550069987*x_2 + 0.0205058312044972*x_21 - 0.00557527504346471*x_23 - 0.00163960934647994*x_24 - 0.00468707536851748*x_27 + 0.0193647643620109*x_31 + 0.00734542862150933*x_32 - 0.00554594162554555*x_34 + 0.00561392349755274*x_38 - 0.0385931856623367*x_39 - 0.0332970487150317*x_40 - 0.0338283946047606*x_41 - 0.0409195608687196*x_43 + 0.0121294921332456*x_44 + 0.0201838555018476*x_45 + 0.0327965080543134*x_46 - 0.0373901013920973*x_47 + 0.00895923052653327*x_48 + 0.0399223919784561*x_49 - 0.00234559767237398*x_5 - 0.0278380885969419*x_50 - 0.0194935232609563*x_51 + 0.00574556849593993*x_52 - 0.0256688165154725*x_53 - 0.0257038254119238*x_54 - 0.0330820554898876*x_55 - 0.00645837175964041*x_56 - 0.0463771531811987*x_58 + 0.00277688790878052*x_6 + 0.00345064785723925*x_60 - 0.0120102428773464*x_61 - 0.0159365205237562*x_62 + 0.00212418545162271*x_63 - 0.0156658071744405*x_64 - 0.00066390795540392*x_65 - 0.00253072395628727*x_66 + 0.00693560062075107*x_67 + 0.0160177730712255*x_68 - 0.0112499925524312*x_69 + 0.012011366154646*x_70 + 0.00933607640058378*x_71 + 0.0101804478669795*x_72 - 0.000668051170732877*x_73 - 0.0119776541168202*x_74 + 0.023920952383332*x_75 + 0.0149229067201211*x_76 - 0.00206392619786537*x_77 - 0.000582191826144886*x_78 + 0.0144418890390947*x_79 - 0.00038065897547926*x_80 - 0.0141411862383813*x_81 + 0.0180903011858355*x_82 - 0.0205570008216202*x_83 - 0.00288116736232507*x_84 - 0.0124530688274206*x_85 + 0.0198439213716325*x_86 + 0.0132165522912628*x_87 + 0.0190487656764116*x_88 - 0.0197073471549602*x_89 - 0.0163442188782178*x_90 - 0.0200569374340525*x_93 + 0.0203993347653895*x_94 + 0.00620812872307541*x_98 - 0.0152333452869306*x_99 + 0.394684905334763*std::sin(0.146240040659904*x_10 + 8.17375946044922) - 0.218520948227745*std::sin(0.23327998816967*x_109 + 1.95511984825134) + 0.237262149161666*std::sin(0.232319980859756*x_117 + 5.17903995513916) - 0.294920747613068*std::sin(0.247759968042374*x_14 + 8.37184047698975) + 0.115588810187108*std::sin(0.333999842405319*x_15 + 8.27744007110596) - 0.152345995015715*std::sin(0.274159938097*x_16 - 1.17031991481781) + 0.0533295914946841*std::sin(0.269839972257614*x_18 + 8.2186393737793) - 0.260027816165369*std::sin(0.249119967222214*x_19 - 7.57503986358643) + 0.265474805148695*std::sin(0.262159943580627*x_20 + 8.19703960418701) + 0.189455182331599*std::sin(0.398239850997925*x_22 + 5.19063997268677) - 0.0378101372062623*std::sin(0.374479830265045*x_25 - 7.5918402671814) - 0.174130627690499*std::sin(0.296079933643341*x_26 + 1.99919974803925) + 0.211649059570034*std::sin(0.231039986014366*x_28 - 1.15839993953705) - 0.420524418204788*std::sin(0.106960065662861*x_29 - 4.49688005447388) + 0.156035137990673*std::sin(0.396639823913574*x_3 + 2.00367975234985) + 0.440271935472332*std::sin(0.145920038223267*x_30 - 4.45616006851196) - 0.113162568550242*std::sin(0.210879996418953*x_33 + 2.16375994682312) + 0.188243181535421*std::sin(0.216480001807213*x_35 - 7.40999984741211) + 0.257502160722156*std::sin(0.231439992785454*x_36 + 1.96879982948303) - 0.335723379210036*std::sin(0.2223199903965*x_37 - 1.1904798746109) - 0.063844249999343*std::sin(0.443599849939346*x_4 + 5.17671966552734) + 0.0652549785001266*std::sin(0.222159996628761*x_42 + 4.99399995803833) - 0.283108645863308*std::sin(0.214560002088547*x_57 - 7.41511964797974) + 0.2608393432764*std::sin(0.222719997167587*x_59 - 1.18319988250732) + 0.202079568390534*std::sin(0.364639848470688*x_7 + 1.99303984642029) - 0.173193300521124*std::sin(0.34215983748436*x_8 - 1.14503979682922) + 0.150220581891549*std::sin(0.259759962558746*x_9 + 5.17736005783081) + 0.159708747887035*std::sin(0.356399834156036*x_91 + 5.21304035186768) - 0.347403455050044*std::sin(0.299279928207397*x_92 - 7.40520000457764) + 0.282814243018192*std::sin(0.278959959745407*x_95 + 1.97447979450226) + 0.127418064578162*std::sin(0.278159946203232*x_96 - 7.4423999786377) - 0.287257839294064*std::sin(0.27567994594574*x_97 + 1.97919988632202) + 5.36875703285821) + 0.295162051916122*std::sin(0.0240100052440856*x_1 + 0.0380836684139391*x_100 - 0.0302018959746237*x_101 + 0.0247842575609844*x_103 - 0.0603012976495474*x_104 + 0.0187987552426175*x_105 - 0.0427113004854287*x_106 - 0.00641807706712944*x_107 + 0.039026113326461*x_108 - 0.0292337918046239*x_111 + 0.0589858659839277*x_112 + 0.0192432605591574*x_113 - 0.010280333585582*x_114 + 0.0214808884673989*x_115 + 0.0706766505725794*x_116 + 0.0246086512693892*x_117 - 0.0459958879105163*x_118 + 0.0726080695718837*x_119 + 0.029145564236151*x_12 + 0.0662451326673352*x_120 + 0.00222148014457948*x_15 - 0.00373518986308654*x_19 + 0.0273279402542705*x_23 - 0.00643900331974704*x_25 + 0.013159175516478*x_26 - 0.0202645487213562*x_27 - 0.040567172773708*x_30 - 0.061266920031311*x_35 + 0.029743848746552*x_37 + 0.0312009890190281*x_38 - 0.0363967638277733*x_39 - 0.0040899103079985*x_4 - 0.0130027609978361*x_40 + 0.00260629691065025*x_41 + 0.0496898023972614*x_42 - 0.0387331017630845*x_45 + 0.0348624627280837*x_47 - 0.0247964079868542*x_48 + 0.0235496937973314*x_49 + 0.0435466583624107*x_50 + 0.037429956751662*x_51 + 0.0595860196799782*x_52 + 0.0196833725586543*x_53 - 0.0704055977122588*x_54 - 0.0586361221911792*x_55 - 0.0591579308965431*x_56 - 0.0324233736197713*x_57 + 0.0184714492092392*x_58 - 0.0118890962298656*x_59 + 0.0611645937573868*x_6 - 0.0342640289533872*x_60 + 0.0295393944962661*x_62 + 0.00397645420789918*x_63 + 0.00633923815819623*x_64 + 0.00826356630052083*x_65 + 0.0216470111190178*x_66 - 0.00390019203661668*x_67 - 0.0216829398281479*x_68 + 0.0088611376225399*x_69 - 0.00565132701243577*x_7 - 0.00877704737325769*x_70 + 0.00375442019290307*x_71 - 0.00766047800295538*x_72 - 0.00687101937290521*x_73 - 0.00370869560880243*x_74 - 0.00511852013763499*x_75 + 0.0121399936267929*x_76 - 0.00197374111722313*x_77 - 0.00742905358442427*x_78 + 0.0144664764527236*x_79 - 0.014712866101855*x_8 - 0.0309905351920035*x_80 + 0.00941438978031116*x_81 + 0.00908791882499056*x_82 + 0.00881244048992572*x_83 - 0.00608105792637072*x_84 - 0.0200354972699791*x_85 - 0.0229273674898299*x_86 + 0.0262011299269241*x_87 - 0.0147590566488043*x_88 + 0.0152705193415355*x_89 + 0.0539662606491821*x_9 + 0.00168857993318028*x_90 + 0.0505363298353919*x_93 + 0.0186198284641357*x_94 + 0.0149621403744464*x_96 - 0.0453859925749258*x_98 - 0.00438110338642396*x_99 - 0.243671587726638*std::sin(0.339839845895767*x_10 + 5.03247976303101) - 0.266750374677812*std::sin(0.221599996089935*x_102 + 1.97327971458435) - 0.320153482411413*std::sin(0.247759968042374*x_109 - 1.21407985687256) + 0.261707953559348*std::sin(0.248719975352287*x_11 - 7.41408014297485) + 0.297913160255771*std::sin(0.216240003705025*x_110 - 7.42695951461792) - 0.240533501864082*std::sin(0.310239940881729*x_13 + 8.31328010559082) + 0.282297284916837*std::sin(0.265839964151382*x_14 + 1.98951983451843) + 0.149997634918345*std::sin(0.310719937086105*x_16 + 1.98639988899231) - 0.207024097870091*std::sin(0.359679847955704*x_17 + 2.02319979667664) - 0.365522303081136*std::sin(0.22095999121666*x_18 + 5.01007986068726) - 0.168205892050869*std::sin(0.345519840717316*x_2 - 7.40919971466064) - 0.285034629799458*std::sin(0.327519834041595*x_20 + 8.24312019348145) + 0.134440202086527*std::sin(0.343839854001999*x_21 + 8.24991989135742) + 0.274437349326945*std::sin(0.373279839754105*x_22 + 1.98695981502533) + 0.178798733513462*std::sin(0.410559862852097*x_24 + 1.98767983913422) + 0.146429366208851*std::sin(0.310159921646118*x_28 + 1.99215984344482) + 0.888374135047641*std::sin(0.0978400707244873*x_29 - 7.69432020187378) + 0.215359475489393*std::sin(0.308879911899567*x_3 - 1.10775983333588) + 0.104679655619775*std::sin(0.346719831228256*x_31 - 4.22328042984009) - 0.0578427059566522*std::sin(0.316399931907654*x_32 - 4.34007978439331) - 0.377692918419218*std::sin(0.264319956302643*x_33 - 1.22359991073608) + 0.402341055823442*std::sin(0.243359968066216*x_34 + 1.97447979450226) - 0.374191261599556*std::sin(0.261199980974197*x_36 - 1.21743988990784) + 0.394489008835517*std::sin(0.211759999394417*x_43 - 1.20295989513397) - 0.177039187529932*std::sin(0.260479986667633*x_44 + 1.94247984886169) - 0.116524745792104*std::sin(0.194399997591972*x_46 - 7.60128021240234) - 0.240411776724574*std::sin(0.388639837503433*x_5 + 2.00431990623474) - 0.340002702458236*std::sin(0.149440035223961*x_61 - 1.27567994594574) - 0.194121487122011*std::sin(0.333039849996567*x_91 + 8.41728019714355) - 0.177966780157181*std::sin(0.268319964408875*x_92 - 7.3744797706604) + 0.242522392236669*std::sin(0.28263995051384*x_95 - 4.40463972091675) + 0.319629572276696*std::sin(0.28383994102478*x_97 + 8.18407917022705) - 1.57255059604465) + 0.374495550813069);
}

inline float score_9(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.00477452512369299*x_1 + 0.00226014944113838*x_10 - 0.00576528204767013*x_100 + 0.00282363627338898*x_101 + 0.000905804896705504*x_102 + 0.000741751324833339*x_103 + 0.00800891251735521*x_104 - 0.00968862278846642*x_105 + 0.0102386675704904*x_106 + 0.00347793995952221*x_107 - 0.0127683166037228*x_108 - 0.0014380485542977*x_109 + 0.000770138558752104*x_11 + 0.00297658562757707*x_110 + 0.00414345441735645*x_111 - 0.00959528377638565*x_112 - 0.00588736329613058*x_113 + 0.00387483780259118*x_114 - 0.0110587357612455*x_115 - 0.00570542236559027*x_116 - 0.0048303279548519*x_117 + 0.00680215648453011*x_118 - 0.00992519474181856*x_119 - 0.00925005652947706*x_12 - 0.00701721570540603*x_120 - 0.0010277393906472*x_13 + 0.00313794516023313*x_14 + 0.00487771800398514*x_15 - 0.00166849713857138*x_16 + 0.00489477712663639*x_17 + 0.00105463251203819*x_18 - 0.0050458653352925*x_19 - 0.00112908418896476*x_2 + 0.00124444411657985*x_20 + 0.00373764940738944*x_21 + 0.00263985892915412*x_22 + 0.000158155848580513*x_23 - 0.00160612519572381*x_24 + 0.0028215051244858*x_25 + 0.000660457796558789*x_26 + 0.00472311981425525*x_27 + 0.00282033307872337*x_28 + 0.0022452259413018*x_29 - 8.77702171247126e-5*x_3 + 0.0102988520769636*x_30 + 0.00149314975135865*x_31 + 0.00160236052328278*x_32 + 0.00575336523866794*x_33 + 0.000439050518039622*x_34 + 0.012299345268408*x_35 + 0.000892688460338014*x_36 - 0.0103295180665752*x_37 - 0.00616672858103313*x_38 + 0.000135872636392112*x_39 + 0.00386255812536742*x_4 - 0.00388006517536645*x_40 - 0.0044360866880751*x_41 - 0.0072597918184264*x_42 - 0.00691692990502335*x_43 + 0.00565210270063001*x_44 - 0.00218414571725313*x_45 + 0.00375896315526081*x_46 - 0.00784500279145497*x_47 + 0.00321754387945247*x_48 + 0.000568970594932924*x_49 + 0.000615604664257144*x_5 - 0.00351300695433265*x_50 - 0.0135665209311978*x_51 - 0.0147966006825091*x_52 - 0.00787004129650412*x_53 + 0.00612931656714243*x_54 + 0.0123896681963012*x_55 + 0.0115432120084042*x_56 - 0.00115230670938597*x_57 - 0.0127624372110394*x_58 + 0.00467838122742042*x_59 - 0.0107944763597134*x_6 + 0.00658643730200061*x_60 - 0.00341152610567332*x_61 - 0.00232080094700165*x_62 - 0.000401904164347308*x_63 - 0.00100219707707424*x_64 - 0.00151421380142834*x_65 - 0.0045636624493001*x_66 - 0.000851893069132271*x_67 + 0.00605419885635076*x_68 - 0.000645374885986228*x_69 - 0.000591575412786822*x_7 + 0.00589072788613503*x_70 + 0.000847946343980358*x_71 + 0.000151189630211022*x_72 + 0.00191338015179155*x_73 - 0.00095036511010394*x_74 + 0.00189055147078912*x_75 + 0.00372725706380231*x_76 + 0.00155471056701151*x_77 + 0.00166579383149377*x_78 - 0.000366020057894859*x_79 + 0.00544879071326011*x_8 + 0.00431226942215197*x_80 - 0.00430443112837536*x_81 - 0.00317379165644966*x_82 - 0.00291527715602435*x_83 + 0.001145022233649*x_84 + 0.00197175844928216*x_85 + 0.000319800634362216*x_86 + 0.000460377653879191*x_87 - 0.000904839830903703*x_88 - 0.00266703603523208*x_89 - 0.00870787639501791*x_9 - 0.000386325970239618*x_90 - 7.9048951063078e-5*x_91 - 0.000733642540596878*x_92 - 0.00862730660208241*x_93 - 0.00181159611238656*x_94 + 0.000615199153250893*x_95 - 0.00212908239981263*x_96 - 0.00241244536542335*x_97 + 0.00751929875544454*x_98 + 0.0031574504895964*x_99 - 1.64139150084027e-5*std::pow(-3.34895968437195*x_1 - 4.17543983459473, 2) - 1.20811570260377e-5*std::pow(-5.60767984390259*x_22 - 9.60639953613281, 2) - 2.24719337045873e-6*std::pow(-4.01999998092651*x_27 - 6.62815999984741, 2) + 0.00367640423968591*std::exp(0.163839861750603*x_49) + 0.00211725389694402*std::sin(0.329999834299088*x_1 + 5.14520025253296) + 0.00634425578012721*std::sin(0.342239856719971*x_1 + 8.34768009185791) + 0.00137900294771484*std::sin(0.359039843082428*x_1 - 1.03663980960846) - 0.00537282526842186*std::sin(0.408399850130081*x_1 + 8.39400005340576) + 0.0304327828239277*std::sin(0.146240040659904*x_10 + 8.17375946044922) + 0.0366526767454496*std::sin(0.339839845895767*x_10 + 5.03247976303101) - 0.000910090247901845*std::sin(0.352079838514328*x_10 + 8.25903987884521) + 0.000916517108001172*std::sin(0.366479843854904*x_10 + 8.24079990386963) + 0.00711119817898307*std::sin(0.242079973220825*x_100 + 1.9755197763443) + 0.00173346837809479*std::sin(0.257839977741241*x_100 + 1.95887982845306) - 0.00104272194554247*std::sin(0.229919984936714*x_101 + 1.98535978794098) + 0.0401241496639397*std::sin(0.221599996089935*x_102 + 1.97327971458435) + 0.00161367467764596*std::sin(0.239359974861145*x_102 - 1.2099198102951) + 0.0179769734232576*std::sin(0.247999966144562*x_107 + 5.15144014358521) - 0.00720408968573869*std::sin(0.246319979429245*x_108 + 1.97391986846924) - 0.0168493916793022*std::sin(0.23327998816967*x_109 + 1.95511984825134) + 0.00205347934521288*std::sin(0.23471999168396*x_109 + 1.98399984836578) - 0.00734273885586694*std::sin(0.246079966425896*x_109 - 7.44191980361938) + 0.0481569567023949*std::sin(0.247759968042374*x_109 - 1.21407985687256) + 0.013170582495694*std::sin(0.252159982919693*x_109 - 1.214399933815) + 0.0134152883404453*std::sin(0.216800004243851*x_11 + 5.18383979797363) - 0.00108197758997981*std::sin(0.218799993395805*x_11 + 2.00231981277466) - 0.039365677028727*std::sin(0.248719975352287*x_11 - 7.41408014297485) - 0.0140210659204831*std::sin(0.25655996799469*x_11 + 8.37376022338867) - 0.0333423974230354*std::sin(0.210319995880127*x_110 + 5.17592000961304) - 0.0448116042700879*std::sin(0.216240003705025*x_110 - 7.42695951461792) - 0.00360375739407942*std::sin(0.219759985804558*x_110 - 4.41991996765137) - 0.014520978665335*std::sin(0.213039994239807*x_111 - 7.41463994979858) + 0.00191937349180649*std::sin(0.216879993677139*x_111 + 1.98231983184814) + 0.0242375327990582*std::sin(0.267279952764511*x_112 - 1.20023989677429) - 0.000950537551796876*std::sin(0.278399974107742*x_112 + 1.96583986282349) - 0.0216083390141761*std::sin(0.290479928255081*x_112 + 1.95439982414246) - 0.0196287411755751*std::sin(0.293919950723648*x_113 + 1.96367979049683) - 0.00447990814047142*std::sin(0.237119987607002*x_116 + 8.16991996765137) - 0.00150514916718381*std::sin(0.250639975070953*x_116 - 4.40895986557007) - 0.00828707888230234*std::sin(0.225919991731644*x_117 - 7.40279960632324) + 0.0182944606195441*std::sin(0.232319980859756*x_117 + 5.17903995513916) - 0.0155624177620056*std::sin(0.23471999168396*x_118 - 7.41639995574951) - 0.00426260066661255*std::sin(0.265759944915771*x_119 + 8.15824031829834) + 0.00143908754677686*std::sin(0.277439951896667*x_12 - 7.43567991256714) - 0.014656693622463*std::sin(0.285599917173386*x_12 + 5.13567972183228) + 0.00240192213021882*std::sin(0.248639971017838*x_13 + 1.98823988437653) + 0.0140240362745342*std::sin(0.289919942617416*x_13 - 7.4443998336792) + 0.0361806510661621*std::sin(0.310239940881729*x_13 + 8.31328010559082) - 0.00788211539111018*std::sin(0.389119833707809*x_13 + 4.99919986724854) - 0.0227403149729435*std::sin(0.247759968042374*x_14 + 8.37184047698975) - 0.042462690158947*std::sin(0.265839964151382*x_14 + 1.98951983451843) + 0.0177915128985649*std::sin(0.281199961900711*x_14 + 5.17095994949341) + 0.00555233371459947*std::sin(0.304159939289093*x_14 - 4.2577600479126) - 0.00465525697014598*std::sin(0.346159845590591*x_14 - 1.13391983509064) - 0.00095941282727478*std::sin(0.357839852571487*x_14 + 8.01512050628662) - 0.0107782722708089*std::sin(0.280799955129623*x_15 - 1.3802398443222) + 0.00589017024753693*std::sin(0.300879925489426*x_15 - 7.43351984024048) + 0.00891265186419238*std::sin(0.333999842405319*x_15 + 8.27744007110596) - 0.0117468707765148*std::sin(0.274159938097*x_16 - 1.17031991481781) - 0.0100538952423111*std::sin(0.279039949178696*x_16 - 1.19951987266541) + 0.000881582790475546*std::sin(0.306239932775497*x_16 + 1.99111986160278) - 0.0225623958728079*std::sin(0.310719937086105*x_16 + 1.98639988899231) - 0.0131979679207046*std::sin(0.321919918060303*x_16 + 1.98375976085663) + 0.00772316737116843*std::sin(0.328959852457047*x_16 - 7.32767963409424) - 0.00931549762574736*std::sin(0.461359858512878*x_16 - 1.4119998216629) - 0.00580002875026112*std::sin(0.257359951734543*x_17 + 8.24071979522705) + 0.00103584817590206*std::sin(0.288959950208664*x_17 + 2.01887989044189) - 0.00161565436653649*std::sin(0.3503198325634*x_17 + 2.00575995445251) - 0.00934009845233149*std::sin(0.351999849081039*x_17 - 4.17120027542114) + 0.0311402220034916*std::sin(0.359679847955704*x_17 + 2.02319979667664) - 0.0028042200736822*std::sin(0.389599829912186*x_17 + 8.19871997833252) + 0.05498125958417*std::sin(0.22095999121666*x_18 + 5.01007986068726) + 0.00411205965596768*std::sin(0.269839972257614*x_18 + 8.2186393737793) + 0.0145053816169797*std::sin(0.275279939174652*x_18 - 1.15727984905243) + 0.00120960141607524*std::sin(0.303439915180206*x_18 - 4.37415981292725) - 0.00533152320649161*std::sin(0.316159933805466*x_18 + 2.18255996704102) + 0.0103726007829822*std::sin(0.341119825839996*x_18 - 7.36839962005615) - 0.00999944658058578*std::sin(0.39743983745575*x_18 - 1.19631993770599) + 0.000676388318440516*std::sin(0.417519867420197*x_18 - 1.214479804039) - 0.0200498421666999*std::sin(0.249119967222214*x_19 - 7.57503986358643) - 0.0163472146223062*std::sin(0.270559966564178*x_19 + 5.01200008392334) + 0.0253012517607794*std::sin(0.345519840717316*x_2 - 7.40919971466064) - 0.0189424670153442*std::sin(0.391199827194214*x_2 - 4.21216011047363) + 0.0035847156302613*std::sin(0.423679858446121*x_2 + 5.21167993545532) + 0.0204698405769084*std::sin(0.262159943580627*x_20 + 8.19703960418701) + 0.00488234258399972*std::sin(0.269199967384338*x_20 + 2.0066397190094) + 0.00171654746089685*std::sin(0.273679971694946*x_20 - 7.41055965423584) - 0.0134168626678672*std::sin(0.282879948616028*x_20 + 1.99935972690582) + 0.0152875872704549*std::sin(0.289679944515228*x_20 + 1.98439979553223) + 0.0428744370435945*std::sin(0.327519834041595*x_20 + 8.24312019348145) - 0.00117052065239265*std::sin(0.341679841279984*x_20 + 8.24327945709229) + 0.00868821161593709*std::sin(0.366719841957092*x_20 + 1.7992799282074) + 0.0107027363000544*std::sin(0.311999946832657*x_21 + 1.99287974834442) - 0.0202222725868163*std::sin(0.343839854001999*x_21 + 8.24991989135742) + 0.000544718418164794*std::sin(0.436479866504669*x_21 + 1.78887987136841) - 0.00561926233653054*std::sin(0.338159829378128*x_22 + 2.02815985679626) + 0.00117850755376953*std::sin(0.353279858827591*x_22 - 7.37287998199463) - 0.0412804116622864*std::sin(0.373279839754105*x_22 + 1.98695981502533) + 0.0146082313785851*std::sin(0.398239850997925*x_22 + 5.19063997268677) + 0.00161449691694084*std::sin(0.212559998035431*x_23 - 1.18399977684021) + 0.00939723179645614*std::sin(0.323359936475754*x_23 + 5.21583986282349) - 0.00576308479083953*std::sin(0.344639837741852*x_23 - 1.16903984546661) + 0.00362051986831227*std::sin(0.3503198325634*x_23 + 2.028639793396) - 0.000766065619480538*std::sin(0.294959932565689*x_24 + 8.21343994140625) - 0.00202525397969156*std::sin(0.331279844045639*x_24 + 2.03863978385925) + 0.0141817610884514*std::sin(0.366319835186005*x_24 + 1.78495991230011) - 0.0268946094335655*std::sin(0.410559862852097*x_24 + 1.98767983913422) - 0.00291540841463171*std::sin(0.374479830265045*x_25 - 7.5918402671814) - 0.0116459215197549*std::sin(0.439119875431061*x_25 - 1.39551985263824) - 0.0134266081724216*std::sin(0.296079933643341*x_26 + 1.99919974803925) - 0.00119984135503332*std::sin(0.313919931650162*x_26 - 1.18519985675812) - 0.011504437540817*std::sin(0.339119851589203*x_26 + 5.02279996871948) - 0.00278562505832775*std::sin(0.359279841184616*x_26 - 1.14727985858917) + 0.00530624077357671*std::sin(0.399359852075577*x_26 - 1.20367991924286) + 0.00244387109516634*std::sin(0.20040000975132*x_27 + 8.20024013519287) - 0.006762903681733*std::sin(0.223039999604225*x_27 + 8.21224021911621) - 0.0120540048929467*std::sin(0.329599827528*x_27 + 2.0319197177887) + 0.0330456010174723*std::sin(0.112960062921047*x_28 + 5.09511995315552) + 0.0163195242020219*std::sin(0.231039986014366*x_28 - 1.15839993953705) + 0.00241097899094045*std::sin(0.284159928560257*x_28 - 1.17151987552643) - 0.0220256628019967*std::sin(0.310159921646118*x_28 + 1.99215984344482) + 0.0156638511562678*std::sin(0.326479852199554*x_28 - 1.12615978717804) - 0.0011752593595972*std::sin(0.335039854049683*x_28 + 8.22056007385254) - 0.133627766391248*std::sin(0.0978400707244873*x_29 - 7.69432020187378) - 0.0324251779543738*std::sin(0.106960065662861*x_29 - 4.49688005447388) - 0.0324959453275874*std::sin(0.271039962768555*x_29 + 5.00927972793579) - 0.000987068715881211*std::sin(0.314319908618927*x_29 + 1.99423980712891) + 0.00715322407759092*std::sin(0.3572798371315*x_29 + 8.236159324646) - 0.00745326118477794*std::sin(0.263759940862656*x_3 + 8.26399993896484) + 0.00115004906297022*std::sin(0.291919946670532*x_3 - 4.32488012313843) - 0.0323940157029617*std::sin(0.308879911899567*x_3 - 1.10775983333588) - 0.00846786071593527*std::sin(0.319359928369522*x_3 + 5.25487995147705) + 0.00963546989200861*std::sin(0.377999842166901*x_3 + 1.98583984375) - 0.00508440648636546*std::sin(0.37967985868454*x_3 - 1.19287979602814) + 0.00881136885717039*std::sin(0.383679836988449*x_3 + 8.18943977355957) - 0.00829011505348235*std::sin(0.386799842119217*x_3 - 1.1865599155426) + 0.0120313277837269*std::sin(0.396639823913574*x_3 + 2.00367975234985) + 0.0339478404534759*std::sin(0.145920038223267*x_30 - 4.45616006851196) + 0.00346568193891044*std::sin(0.338719844818115*x_31 + 2.12823987007141) + 0.000782005712917614*std::sin(0.34079983830452*x_31 - 1.05159986019135) - 0.0157457404658967*std::sin(0.346719831228256*x_31 - 4.22328042984009) + 0.00827248802914604*std::sin(0.35335984826088*x_31 + 5.17592000961304) + 0.0125073649737411*std::sin(0.382319837808609*x_31 - 4.20591974258423) - 0.0165465542514449*std::sin(0.40871986746788*x_31 - 4.19944000244141) + 0.00182902244061916*std::sin(0.410959839820862*x_31 - 4.19831991195679) - 0.0078329419703782*std::sin(0.443759858608246*x_31 - 1.16527986526489) - 0.000369966703701474*std::sin(0.591199815273285*x_31 - 4.39583969116211) + 0.00060114446382013*std::sin(0.254879981279373*x_32 - 1.16591989994049) - 0.00485316276749481*std::sin(0.311599940061569*x_32 + 2.01239991188049) + 0.00108554987453613*std::sin(0.312719941139221*x_32 - 7.36104011535645) + 0.00870060405191631*std::sin(0.316399931907654*x_32 - 4.34007978439331) + 0.0118918390643575*std::sin(0.319839835166931*x_32 + 2.00407981872559) - 0.00228384767398582*std::sin(0.348159849643707*x_32 - 1.19095981121063) - 0.00166671497472112*std::sin(0.366799831390381*x_32 + 7.98663997650146) - 0.00872557279474968*std::sin(0.210879996418953*x_33 + 2.16375994682312) + 0.00211431965890054*std::sin(0.251279979944229*x_33 - 7.4314398765564) + 0.00488604027773496*std::sin(0.254719972610474*x_33 + 1.96607983112335) + 0.0568119433907711*std::sin(0.264319956302643*x_33 - 1.22359991073608) + 0.00403076821196527*std::sin(0.289119929075241*x_33 + 4.96567964553833) + 0.00478441059498971*std::sin(0.224159985780716*x_34 + 5.17888021469116) + 0.0196154923342417*std::sin(0.239119976758957*x_34 + 1.97639977931976) - 0.0605194754058206*std::sin(0.243359968066216*x_34 + 1.97447979450226) + 0.0145147782048915*std::sin(0.216480001807213*x_35 - 7.40999984741211) + 0.000295746217889177*std::sin(0.230159983038902*x_35 + 5.16847991943359) + 0.0154135925245291*std::sin(0.209199994802475*x_36 + 1.98423981666565) + 0.0198550976437844*std::sin(0.231439992785454*x_36 + 1.96879982948303) - 0.00184044310175906*std::sin(0.241999983787537*x_36 + 1.98503983020782) + 0.0216123977901402*std::sin(0.243279978632927*x_36 + 5.17535972595215) + 0.0562852299701299*std::sin(0.261199980974197*x_36 - 1.21743988990784) - 0.0258864642410084*std::sin(0.2223199903965*x_37 - 1.1904798746109) + 0.00254851008366662*std::sin(0.233679980039597*x_38 - 4.23104000091553) + 0.0102062684239801*std::sin(0.246639966964722*x_38 - 4.40207958221436) + 0.00500584313443412*std::sin(0.313199937343597*x_4 + 2.00671982765198) + 0.0205438742885084*std::sin(0.32551982998848*x_4 + 5.22919988632202) + 0.000637168686079585*std::sin(0.332879841327667*x_4 - 1.16815984249115) - 0.00325725887847896*std::sin(0.382559835910797*x_4 + 2.01575970649719) + 0.00282581077888697*std::sin(0.416159868240356*x_4 - 4.40927982330322) - 0.00492280846955264*std::sin(0.443599849939346*x_4 + 5.17671966552734) + 0.00770461620631084*std::sin(0.225519984960556*x_40 + 1.99303984642029) - 0.00133395788796138*std::sin(0.23047998547554*x_40 + 1.9651198387146) + 0.0248101843839617*std::sin(0.236319988965988*x_41 - 7.4236798286438) + 0.0104079474842463*std::sin(0.241679981350899*x_41 - 7.42560005187988) - 0.00655449079724511*std::sin(0.26199996471405*x_41 + 1.97463977336884) + 0.00503158484662604*std::sin(0.222159996628761*x_42 + 4.99399995803833) - 0.0282044598602476*std::sin(0.229359999299049*x_42 + 1.96647977828979) - 0.019665557684657*std::sin(0.25639995932579*x_42 + 5.14743995666504) - 0.0593383834996057*std::sin(0.211759999394417*x_43 - 1.20295989513397) - 0.0159043092424289*std::sin(0.242719978094101*x_44 - 1.20631992816925) + 0.0266299414402439*std::sin(0.260479986667633*x_44 + 1.94247984886169) + 0.00524006285275262*std::sin(0.267679959535599*x_44 - 7.4443998336792) + 0.0175274593160817*std::sin(0.194399997591972*x_46 - 7.60128021240234) + 0.00957303062732199*std::sin(0.249199971556664*x_46 + 1.97567975521088) - 0.0354396215508515*std::sin(0.207040011882782*x_47 - 7.58816003799438) - 0.00198590821323689*std::sin(0.253199964761734*x_48 - 1.20247983932495) - 0.0132764375600844*std::sin(0.296239942312241*x_49 + 5.06767988204956) - 0.000844305825323329*std::sin(0.309839934110641*x_5 + 1.81447994709015) - 0.00849913423839441*std::sin(0.364319831132889*x_5 - 1.16543984413147) + 0.0361623413722344*std::sin(0.388639837503433*x_5 + 2.00431990623474) - 0.00334914516846698*std::sin(0.388959854841232*x_5 + 4.98991966247559) - 0.0215284311635691*std::sin(0.408159852027893*x_5 - 1.17863988876343) - 0.0144522371238974*std::sin(0.181120008230209*x_50 - 7.37967967987061) + 0.00874292343453975*std::sin(0.215199992060661*x_52 - 1.20711994171143) + 0.00185525157949577*std::sin(0.242479979991913*x_53 + 1.96927976608276) + 0.0222279818069958*std::sin(0.247439980506897*x_53 + 1.98375976085663) - 0.0218295248150587*std::sin(0.214560002088547*x_57 - 7.41511964797974) + 0.0201124162048552*std::sin(0.222719997167587*x_59 - 1.18319988250732) + 0.0164655381864543*std::sin(0.265359938144684*x_6 + 5.20975971221924) + 0.000777433551097349*std::sin(0.477919846773148*x_6 + 4.96743965148926) + 0.00668273701525587*std::sin(0.255839973688126*x_60 + 8.34751987457275) - 0.0243800472085278*std::sin(0.327759832143784*x_60 - 7.52952003479004) + 0.00774049232703834*std::sin(0.390639841556549*x_60 - 4.37255954742432) + 0.00505571315799422*std::sin(0.490879863500595*x_60 + 1.69871997833252) + 0.0511426435147682*std::sin(0.149440035223961*x_61 - 1.27567994594574) + 0.00107857700079568*std::sin(0.240959972143173*x_61 + 8.25207996368408) - 0.0160193006160478*std::sin(0.285119920969009*x_7 + 8.39744091033936) - 0.00182989254310829*std::sin(0.336559861898422*x_7 + 5.23784017562866) + 0.00609261308710409*std::sin(0.349679857492447*x_7 + 2.00879979133606) + 0.0112937254094904*std::sin(0.352479845285416*x_7 - 7.59647989273071) + 0.0155816539595453*std::sin(0.364639848470688*x_7 + 1.99303984642029) - 0.00382562543803304*std::sin(0.39031982421875*x_7 + 1.9793598651886) - 0.0085487406126652*std::sin(0.457919865846634*x_7 + 7.9870400428772) + 0.00470008401085654*std::sin(0.323199838399887*x_8 - 1.12079977989197) + 0.00157772266947997*std::sin(0.334079831838608*x_8 + 8.25943946838379) + 0.00573829158834606*std::sin(0.335839837789536*x_8 - 4.34151983261108) - 0.0133543341285071*std::sin(0.34215983748436*x_8 - 1.14503979682922) + 0.0115829875493009*std::sin(0.259759962558746*x_9 + 5.17736005783081) + 0.0100904950398012*std::sin(0.280479967594147*x_9 + 1.99911975860596) - 0.00476805729824462*std::sin(0.334879845380783*x_9 + 5.06487989425659) + 0.0291994326593836*std::sin(0.333039849996567*x_91 + 8.41728019714355) - 0.00610022620100585*std::sin(0.34775984287262*x_91 + 5.19016027450562) - 0.00349898825586387*std::sin(0.353039860725403*x_91 + 5.20071983337402) + 0.0123145870891746*std::sin(0.356399834156036*x_91 + 5.21304035186768) - 0.0273843762243561*std::sin(0.367759823799133*x_91 + 5.19528007507324) - 0.0170656377760859*std::sin(0.400319844484329*x_91 + 1.97431981563568) + 0.0002843399775271*std::sin(0.484399855136871*x_91 - 7.60904026031494) + 0.0267694683872927*std::sin(0.268319964408875*x_92 - 7.3744797706604) - 0.0235326784555916*std::sin(0.286079943180084*x_92 + 5.21439981460571) + 0.00854449844742005*std::sin(0.289279937744141*x_92 + 2.00223970413208) - 0.0267870743393462*std::sin(0.299279928207397*x_92 - 7.40520000457764) - 0.000850805792446162*std::sin(0.300959944725037*x_92 + 1.80455982685089) - 0.00298828673813302*std::sin(0.316799849271774*x_92 + 8.22192001342773) + 0.00472558119051371*std::sin(0.270399957895279*x_94 + 5.1864800453186) - 0.00113055711415467*std::sin(0.285599917173386*x_94 + 1.98791980743408) - 0.0162317951710024*std::sin(0.287359952926636*x_94 + 1.9755197763443) + 0.00950116803975754*std::sin(0.261279970407486*x_95 - 7.41343975067139) + 0.0218068244337494*std::sin(0.278959959745407*x_95 + 1.97447979450226) - 0.00134547637558357*std::sin(0.281039953231812*x_95 + 1.97343981266022) + 0.00867055684748956*std::sin(0.281679958105087*x_95 + 1.96399986743927) - 0.0364798166627287*std::sin(0.28263995051384*x_95 - 4.40463972091675) + 0.00147601425305113*std::sin(0.273119956254959*x_96 + 8.19167995452881) + 0.00982476460269853*std::sin(0.278159946203232*x_96 - 7.4423999786377) - 0.00129806939314972*std::sin(0.262239962816238*x_97 + 5.17519998550415) - 0.00170751586406614*std::sin(0.273119956254959*x_97 + 1.97847986221313) - 0.0221494547157616*std::sin(0.27567994594574*x_97 + 1.97919988632202) - 0.0480781510074405*std::sin(0.28383994102478*x_97 + 8.18407917022705) - 0.00467832257960238*std::sin(0.284799933433533*x_97 + 8.18175983428955) + 0.0274074430241039*std::sin(0.248399972915649*x_99 + 1.98031985759735) + 0.0463507635736328);
}

inline float score_10(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.000342476717208468*x_1 + 0.00302082740031648*x_10 + 0.00444925602658611*x_100 - 0.0115270753042696*x_101 + 0.00428523810160832*x_102 - 0.000373247908372571*x_103 - 0.00161423142695206*x_104 - 0.0034417532841488*x_105 + 0.00080702680605039*x_106 + 0.00749339528742882*x_107 + 0.00714165805163121*x_108 - 0.00164951178142238*x_109 + 0.00289127587390643*x_11 + 0.00155306771479405*x_110 + 0.00102664601829252*x_111 + 0.00478531642347568*x_112 + 0.00591133605885839*x_113 - 0.00372084683341999*x_114 + 0.00532111090764173*x_115 - 0.000210649357839394*x_116 - 0.00150395478854523*x_117 + 0.00248983009848512*x_118 + 0.0154096266912129*x_119 + 0.0111557601415867*x_12 + 0.0193367677301968*x_120 - 0.00258715540972594*x_13 + 0.00158065888751396*x_14 - 0.00398761094430743*x_15 - 0.000989640610954362*x_16 - 0.00614371788548791*x_17 - 0.00202529024169795*x_18 - 0.00183267066743639*x_19 - 0.00290519442591233*x_2 - 0.000942287445412325*x_20 - 0.0010848594973596*x_21 - 0.00395598067987101*x_22 - 0.00232945608863511*x_23 + 0.000153018318231705*x_24 + 0.0109973853017855*x_25 + 0.00564708858032062*x_26 - 0.00644227401320683*x_27 - 0.0040421771572729*x_28 - 0.000573127533590444*x_29 + 0.000938236251243806*x_3 - 0.00820504855547692*x_30 + 0.00275469228155714*x_31 + 0.00112376895716251*x_32 - 0.014489474402683*x_33 - 0.00925680936415655*x_34 - 0.00592236908449581*x_35 - 0.0105677019871024*x_36 + 0.00910264726569206*x_37 - 0.000931707505259347*x_38 - 0.00726542856484387*x_39 - 0.0019147357262385*x_4 - 0.010822707612994*x_40 - 0.00295420625704517*x_41 + 0.00291184367243798*x_42 - 0.0128192244440658*x_43 - 0.00525040745553228*x_44 + 0.00708095860825431*x_45 + 0.00151936031902291*x_46 + 0.00188045462893179*x_47 - 0.00817709959479255*x_48 - 0.00409420554848061*x_49 - 0.00256902289730301*x_5 + 0.0020544755466663*x_50 + 0.00972010077769501*x_51 + 0.0145436471812102*x_52 + 0.00210696547269236*x_53 - 0.0112274709384452*x_54 - 0.0100663006205503*x_55 - 0.0231291300480184*x_56 + 0.0155074658449269*x_57 + 0.00826343077768089*x_58 - 0.0115213535908063*x_59 + 0.00226244679437109*x_6 - 0.000335442582537269*x_60 - 0.00104307776500036*x_61 - 0.00422664123427455*x_62 - 0.0020619620726243*x_63 + 0.00165180076401943*x_64 + 0.00301637934101607*x_65 + 0.00105593451906235*x_66 + 0.0036632609205393*x_67 + 0.00207860689787103*x_68 - 0.00228605398417952*x_69 - 0.00543086857006245*x_7 - 0.00192521734345788*x_70 + 0.00116269420042422*x_71 + 0.00125907717494596*x_72 + 0.000464182678115848*x_73 - 0.00190251659532642*x_74 + 0.00507926751712638*x_75 + 0.00357063779528071*x_76 + 0.00132059026696968*x_77 - 0.00465646082884464*x_78 - 0.000480045802277293*x_79 - 0.00171508184172932*x_8 - 0.00324273330670699*x_80 - 0.000234480707898228*x_81 + 0.0064046466043159*x_82 - 0.00223214678886753*x_83 - 0.00307850436323467*x_84 - 0.000318876042238097*x_85 + 0.00443341981692708*x_86 + 0.00276995846991455*x_87 + 0.00449935609859538*x_88 - 0.006436737064884*x_89 + 0.00684932995430712*x_9 - 0.00264434285953882*x_90 + 0.000857579331205264*x_91 + 0.00145820921673759*x_92 + 0.0112460781392557*x_93 + 0.00420190900239579*x_94 + 0.00130326692483619*x_95 - 0.000439135138714555*x_96 + 0.000523176785347935*x_97 - 0.00370947721337092*x_98 - 0.0067393145125044*x_99 - 8.47439881043267e-6*std::pow(-3.34895968437195*x_1 - 4.17543983459473, 2) - 6.23742371504258e-6*std::pow(-5.60767984390259*x_22 - 9.60639953613281, 2) + 2.40217963768201e-5*std::pow(-4.01999998092651*x_27 - 6.62815999984741, 2) - 0.00413572795982795*std::exp(0.163839861750603*x_49) + 0.0165058302795422*std::sin(0.329999834299088*x_1 + 5.14520025253296) + 0.0029666348088289*std::sin(0.342239856719971*x_1 + 8.34768009185791) - 0.0147411114897862*std::sin(0.359039843082428*x_1 - 1.03663980960846) + 0.00778167558674608*std::sin(0.408399850130081*x_1 + 8.39400005340576) + 0.0561450396218445*std::sin(0.146240040659904*x_10 + 8.17375946044922) - 0.0220496374394872*std::sin(0.339839845895767*x_10 + 5.03247976303101) - 0.0070949427428691*std::sin(0.352079838514328*x_10 + 8.25903987884521) - 0.00979728208248579*std::sin(0.366479843854904*x_10 + 8.24079990386963) + 0.00332526442523553*std::sin(0.242079973220825*x_100 + 1.9755197763443) + 0.0135138893285704*std::sin(0.257839977741241*x_100 + 1.95887982845306) - 0.00812892184858876*std::sin(0.229919984936714*x_101 + 1.98535978794098) - 0.0241380174987473*std::sin(0.221599996089935*x_102 + 1.97327971458435) - 0.0172496791039078*std::sin(0.239359974861145*x_102 - 1.2099198102951) - 0.0202229860408393*std::sin(0.247999966144562*x_107 + 5.15144014358521) - 0.0133882735999761*std::sin(0.246319979429245*x_108 + 1.97391986846924) - 0.0310852204647745*std::sin(0.23327998816967*x_109 + 1.95511984825134) + 0.0160086523413896*std::sin(0.23471999168396*x_109 + 1.98399984836578) + 0.0106347794391115*std::sin(0.246079966425896*x_109 - 7.44191980361938) - 0.0289704198918764*std::sin(0.247759968042374*x_109 - 1.21407985687256) + 0.00679988708221514*std::sin(0.252159982919693*x_109 - 1.214399933815) - 0.0230718382967158*std::sin(0.216800004243851*x_11 + 5.18383979797363) - 0.00843495364077584*std::sin(0.218799993395805*x_11 + 2.00231981277466) + 0.0236817330442623*std::sin(0.248719975352287*x_11 - 7.41408014297485) + 0.0157728341535388*std::sin(0.25655996799469*x_11 + 8.37376022338867) + 0.0573428153198808*std::sin(0.210319995880127*x_110 + 5.17592000961304) + 0.0269579118081705*std::sin(0.216240003705025*x_110 - 7.42695951461792) - 0.00186059677766338*std::sin(0.219759985804558*x_110 - 4.41991996765137) - 0.0269861764347241*std::sin(0.213039994239807*x_111 - 7.41463994979858) + 0.014963180913039*std::sin(0.216879993677139*x_111 + 1.98231983184814) - 0.027265729103521*std::sin(0.267279952764511*x_112 - 1.20023989677429) - 0.00741026455397549*std::sin(0.278399974107742*x_112 + 1.96583986282349) + 0.0371623845081765*std::sin(0.290479928255081*x_112 + 1.95439982414246) + 0.0220811228590542*std::sin(0.293919950723648*x_113 + 1.96367979049683) - 0.0020948479838264*std::sin(0.237119987607002*x_116 + 8.16991996765137) + 0.0160895752391121*std::sin(0.250639975070953*x_116 - 4.40895986557007) - 0.015400929785825*std::sin(0.225919991731644*x_117 - 7.40279960632324) + 0.0337512090920909*std::sin(0.232319980859756*x_117 + 5.17903995513916) - 0.0289216147998988*std::sin(0.23471999168396*x_118 - 7.41639995574951) - 0.00199323292628289*std::sin(0.265759944915771*x_119 + 8.15824031829834) - 0.0153833971172825*std::sin(0.277439951896667*x_12 - 7.43567991256714) + 0.0164878761042423*std::sin(0.285599917173386*x_12 + 5.13567972183228) + 0.018725066031661*std::sin(0.248639971017838*x_13 + 1.98823988437653) + 0.00724051978224194*std::sin(0.289919942617416*x_13 - 7.4443998336792) - 0.0217656746838418*std::sin(0.310239940881729*x_13 + 8.31328010559082) - 0.0146483347662467*std::sin(0.389119833707809*x_13 + 4.99919986724854) - 0.0419533071476226*std::sin(0.247759968042374*x_14 + 8.37184047698975) + 0.0255448443564576*std::sin(0.265839964151382*x_14 + 1.98951983451843) - 0.0200143543922473*std::sin(0.281199961900711*x_14 + 5.17095994949341) - 0.00804166477743222*std::sin(0.304159939289093*x_14 - 4.2577600479126) - 0.00240347924976264*std::sin(0.346159845590591*x_14 - 1.13391983509064) - 0.00747945502325927*std::sin(0.357839852571487*x_14 + 8.01512050628662) - 0.0200306304323622*std::sin(0.280799955129623*x_15 - 1.3802398443222) - 0.00662607814394382*std::sin(0.300879925489426*x_15 - 7.43351984024048) + 0.0164428338658977*std::sin(0.333999842405319*x_15 + 8.27744007110596) - 0.0216716469537434*std::sin(0.274159938097*x_16 - 1.17031991481781) - 0.00519076148731361*std::sin(0.279039949178696*x_16 - 1.19951987266541) + 0.00687270238961769*std::sin(0.306239932775497*x_16 + 1.99111986160278) + 0.0135731600782297*std::sin(0.310719937086105*x_16 + 1.98639988899231) + 0.0148468996834891*std::sin(0.321919918060303*x_16 + 1.98375976085663) + 0.00361142708487401*std::sin(0.328959852457047*x_16 - 7.32767963409424) + 0.0160209493393229*std::sin(0.461359858512878*x_16 - 1.4119998216629) - 0.0107789290782907*std::sin(0.257359951734543*x_17 + 8.24071979522705) + 0.00807533485308059*std::sin(0.288959950208664*x_17 + 2.01887989044189) + 0.0172708413608114*std::sin(0.3503198325634*x_17 + 2.00575995445251) + 0.010507034536592*std::sin(0.351999849081039*x_17 - 4.17120027542114) - 0.0187334368436645*std::sin(0.359679847955704*x_17 + 2.02319979667664) + 0.00406146297284029*std::sin(0.389599829912186*x_17 + 8.19871997833252) - 0.0330758063924427*std::sin(0.22095999121666*x_18 + 5.01007986068726) + 0.00758628462100979*std::sin(0.269839972257614*x_18 + 8.2186393737793) + 0.0074890352884657*std::sin(0.275279939174652*x_18 - 1.15727984905243) - 0.0129302619418733*std::sin(0.303439915180206*x_18 - 4.37415981292725) - 0.00249307135093787*std::sin(0.316159933805466*x_18 + 2.18255996704102) + 0.0192767196528387*std::sin(0.341119825839996*x_18 - 7.36839962005615) + 0.0112487605034608*std::sin(0.39743983745575*x_18 - 1.19631993770599) + 0.00527303352864688*std::sin(0.417519867420197*x_18 - 1.214479804039) - 0.0369896893548628*std::sin(0.249119967222214*x_19 - 7.57503986358643) + 0.0183896079351046*std::sin(0.270559966564178*x_19 + 5.01200008392334) - 0.0152208099824423*std::sin(0.345519840717316*x_2 - 7.40919971466064) + 0.0213091067673697*std::sin(0.391199827194214*x_2 - 4.21216011047363) + 0.001676247386147*std::sin(0.423679858446121*x_2 + 5.21167993545532) + 0.0377645388820552*std::sin(0.262159943580627*x_20 + 8.19703960418701) - 0.00707129009300557*std::sin(0.269199967384338*x_20 + 2.0066397190094) - 0.0183493570775328*std::sin(0.273679971694946*x_20 - 7.41055965423584) - 0.00692703995202281*std::sin(0.282879948616028*x_20 + 1.99935972690582) - 0.017197592536269*std::sin(0.289679944515228*x_20 + 1.98439979553223) - 0.025792544397204*std::sin(0.327519834041595*x_20 + 8.24312019348145) - 0.00912522359976688*std::sin(0.341679841279984*x_20 + 8.24327945709229) + 0.0161464056227569*std::sin(0.366719841957092*x_20 + 1.7992799282074) + 0.00552575395468565*std::sin(0.311999946832657*x_21 + 1.99287974834442) + 0.0121653810399301*std::sin(0.343839854001999*x_21 + 8.24991989135742) - 0.00582287002795273*std::sin(0.436479866504669*x_21 + 1.78887987136841) - 0.0104429879239902*std::sin(0.338159829378128*x_22 + 2.02815985679626) - 0.0125978782499777*std::sin(0.353279858827591*x_22 - 7.37287998199463) + 0.0248336053824281*std::sin(0.373279839754105*x_22 + 1.98695981502533) + 0.0269505333870049*std::sin(0.398239850997925*x_22 + 5.19063997268677) - 0.0172584685855671*std::sin(0.212559998035431*x_23 - 1.18399977684021) - 0.0105713060239829*std::sin(0.323359936475754*x_23 + 5.21583986282349) + 0.0083469039063681*std::sin(0.344639837741852*x_23 - 1.16903984546661) + 0.00186925113536086*std::sin(0.3503198325634*x_23 + 2.028639793396) - 0.00597214586138623*std::sin(0.294959932565689*x_24 + 8.21343994140625) + 0.0216493334979731*std::sin(0.331279844045639*x_24 + 2.03863978385925) - 0.0243900310073056*std::sin(0.366319835186005*x_24 + 1.78495991230011) + 0.0161793473149366*std::sin(0.410559862852097*x_24 + 1.98767983913422) - 0.0053785985297624*std::sin(0.374479830265045*x_25 - 7.5918402671814) + 0.0131009432334153*std::sin(0.439119875431061*x_25 - 1.39551985263824) - 0.0247705723196265*std::sin(0.296079933643341*x_26 + 1.99919974803925) + 0.0128259299328632*std::sin(0.313919931650162*x_26 - 1.18519985675812) + 0.0129417824857356*std::sin(0.339119851589203*x_26 + 5.02279996871948) + 0.00403453107578618*std::sin(0.359279841184616*x_26 - 1.14727985858917) + 0.00273957800295956*std::sin(0.399359852075577*x_26 - 1.20367991924286) + 0.0190520945929618*std::sin(0.20040000975132*x_27 + 8.20024013519287) + 0.00979498119638549*std::sin(0.223039999604225*x_27 + 8.21224021911621) + 0.0135600118522119*std::sin(0.329599827528*x_27 + 2.0319197177887) - 0.0371742624497014*std::sin(0.112960062921047*x_28 + 5.09511995315552) + 0.0301076749449202*std::sin(0.231039986014366*x_28 - 1.15839993953705) - 0.00349191634133856*std::sin(0.284159928560257*x_28 - 1.17151987552643) + 0.0132502704378534*std::sin(0.310159921646118*x_28 + 1.99215984344482) + 0.00808714566497488*std::sin(0.326479852199554*x_28 - 1.12615978717804) - 0.00916216593199059*std::sin(0.335039854049683*x_28 + 8.22056007385254) + 0.0803882297939208*std::sin(0.0978400707244873*x_29 - 7.69432020187378) - 0.0598207831182071*std::sin(0.106960065662861*x_29 - 4.49688005447388) + 0.0558870727837169*std::sin(0.271039962768555*x_29 + 5.00927972793579) + 0.0105514567702678*std::sin(0.314319908618927*x_29 + 1.99423980712891) + 0.00369316361044042*std::sin(0.3572798371315*x_29 + 8.236159324646) + 0.012818243818133*std::sin(0.263759940862656*x_3 + 8.26399993896484) + 0.00896562980657714*std::sin(0.291919946670532*x_3 - 4.32488012313843) + 0.0194876981678571*std::sin(0.308879911899567*x_3 - 1.10775983333588) + 0.0122643379810702*std::sin(0.319359928369522*x_3 + 5.25487995147705) + 0.0179068158235061*std::sin(0.377999842166901*x_3 + 1.98583984375) - 0.0023775172041353*std::sin(0.37967985868454*x_3 - 1.19287979602814) - 0.00991224636115374*std::sin(0.383679836988449*x_3 + 8.18943977355957) - 0.00428013311337461*std::sin(0.386799842119217*x_3 - 1.1865599155426) + 0.0221964379343461*std::sin(0.396639823913574*x_3 + 2.00367975234985) + 0.0626299230788014*std::sin(0.145920038223267*x_30 - 4.45616006851196) - 0.00501948438449175*std::sin(0.338719844818115*x_31 + 2.12823987007141) + 0.00609641271350641*std::sin(0.34079983830452*x_31 - 1.05159986019135) + 0.00947237417066371*std::sin(0.346719831228256*x_31 - 4.22328042984009) + 0.00427103239401602*std::sin(0.35335984826088*x_31 + 5.17592000961304) - 0.0215103764353814*std::sin(0.382319837808609*x_31 - 4.20591974258423) - 0.0307505604620297*std::sin(0.40871986746788*x_31 - 4.19944000244141) - 0.019551679537137*std::sin(0.410959839820862*x_31 - 4.19831991195679) + 0.00881157647597823*std::sin(0.443759858608246*x_31 - 1.16527986526489) - 0.0001729999765688*std::sin(0.591199815273285*x_31 - 4.39583969116211) - 0.00642604686039636*std::sin(0.254879981279373*x_32 - 1.16591989994049) + 0.00702902780931348*std::sin(0.311599940061569*x_32 + 2.01239991188049) + 0.00846280269689612*std::sin(0.312719941139221*x_32 - 7.36104011535645) - 0.00523413790980777*std::sin(0.316399931907654*x_32 - 4.34007978439331) + 0.00613968006836018*std::sin(0.319839835166931*x_32 + 2.00407981872559) + 0.00392779960380504*std::sin(0.348159849643707*x_32 - 1.19095981121063) - 0.000779371896683667*std::sin(0.366799831390381*x_32 + 7.98663997650146) - 0.0160976941582657*std::sin(0.210879996418953*x_33 + 2.16375994682312) - 0.0226014178349273*std::sin(0.251279979944229*x_33 - 7.4314398765564) - 0.00707664560926177*std::sin(0.254719972610474*x_33 + 1.96607983112335) - 0.0341771151585727*std::sin(0.264319956302643*x_33 - 1.22359991073608) + 0.00208105971811855*std::sin(0.289119929075241*x_33 + 4.96567964553833) + 0.00223723625003998*std::sin(0.224159985780716*x_34 + 5.17888021469116) + 0.0101273526040711*std::sin(0.239119976758957*x_34 + 1.97639977931976) + 0.0364075044230425*std::sin(0.243359968066216*x_34 + 1.97447979450226) + 0.0267781228595098*std::sin(0.216480001807213*x_35 - 7.40999984741211) + 0.00230559824938384*std::sin(0.230159983038902*x_35 + 5.16847991943359) + 0.028645033984718*std::sin(0.209199994802475*x_36 + 1.98423981666565) + 0.0366304077532266*std::sin(0.231439992785454*x_36 + 1.96879982948303) - 0.0143478500715648*std::sin(0.241999983787537*x_36 + 1.98503983020782) - 0.0243126141719506*std::sin(0.243279978632927*x_36 + 5.17535972595215) - 0.0338602531721943*std::sin(0.261199980974197*x_36 - 1.21743988990784) - 0.0477575964344*std::sin(0.2223199903965*x_37 - 1.1904798746109) - 0.00369110806882239*std::sin(0.233679980039597*x_38 - 4.23104000091553) - 0.0114814223177399*std::sin(0.246639966964722*x_38 - 4.40207958221436) + 0.00930299321717754*std::sin(0.313199937343597*x_4 + 2.00671982765198) - 0.0231105911534455*std::sin(0.32551982998848*x_4 + 5.22919988632202) + 0.00496728248182631*std::sin(0.332879841327667*x_4 - 1.16815984249115) + 0.00471761701303507*std::sin(0.382559835910797*x_4 + 2.01575970649719) + 0.001321376203978*std::sin(0.416159868240356*x_4 - 4.40927982330322) - 0.00908202441337282*std::sin(0.443599849939346*x_4 + 5.17671966552734) - 0.0111589007352007*std::sin(0.225519984960556*x_40 + 1.99303984642029) + 0.0142595938476446*std::sin(0.23047998547554*x_40 + 1.9651198387146) - 0.0279099268077233*std::sin(0.236319988965988*x_41 - 7.4236798286438) + 0.00537355638398214*std::sin(0.241679981350899*x_41 - 7.42560005187988) - 0.0121810415930496*std::sin(0.26199996471405*x_41 + 1.97463977336884) + 0.00928270451666935*std::sin(0.222159996628761*x_42 + 4.99399995803833) + 0.0485065039698017*std::sin(0.229359999299049*x_42 + 1.96647977828979) + 0.0221225391604363*std::sin(0.25639995932579*x_42 + 5.14743995666504) + 0.0356969792819835*std::sin(0.211759999394417*x_43 - 1.20295989513397) - 0.00821129262919881*std::sin(0.242719978094101*x_44 - 1.20631992816925) - 0.0160201274758207*std::sin(0.260479986667633*x_44 + 1.94247984886169) + 0.00245030361293464*std::sin(0.267679959535599*x_44 - 7.4443998336792) - 0.0105442264377851*std::sin(0.194399997591972*x_46 - 7.60128021240234) - 0.0107690688630822*std::sin(0.249199971556664*x_46 + 1.97567975521088) + 0.0609496566132628*std::sin(0.207040011882782*x_47 - 7.58816003799438) - 0.015481876767708*std::sin(0.253199964761734*x_48 - 1.20247983932495) - 0.0246732878463856*std::sin(0.296239942312241*x_49 + 5.06767988204956) - 0.00658209611843454*std::sin(0.309839934110641*x_5 + 1.81447994709015) + 0.00956100167784103*std::sin(0.364319831132889*x_5 - 1.16543984413147) - 0.0217546598781418*std::sin(0.388639837503433*x_5 + 2.00431990623474) - 0.00156609238040464*std::sin(0.388959854841232*x_5 + 4.98991966247559) + 0.0370249576440603*std::sin(0.408159852027893*x_5 - 1.17863988876343) - 0.00675800459551204*std::sin(0.181120008230209*x_50 - 7.37967967987061) + 0.0162480835346872*std::sin(0.215199992060661*x_52 - 1.20711994171143) + 0.014463294997926*std::sin(0.242479979991913*x_53 + 1.96927976608276) - 0.0382280565947437*std::sin(0.247439980506897*x_53 + 1.98375976085663) - 0.0402730023987116*std::sin(0.214560002088547*x_57 - 7.41511964797974) + 0.0371051313725007*std::sin(0.222719997167587*x_59 - 1.18319988250732) + 0.00850105152542766*std::sin(0.265359938144684*x_6 + 5.20975971221924) - 0.00831052223029493*std::sin(0.477919846773148*x_6 + 4.96743965148926) + 0.0034502541644408*std::sin(0.255839973688126*x_60 + 8.34751987457275) + 0.0419292148321263*std::sin(0.327759832143784*x_60 - 7.52952003479004) + 0.00361952840028851*std::sin(0.390639841556549*x_60 - 4.37255954742432) - 0.00568736539868998*std::sin(0.490879863500595*x_60 + 1.69871997833252) - 0.0307665591528067*std::sin(0.149440035223961*x_61 - 1.27567994594574) + 0.00840844309898169*std::sin(0.240959972143173*x_61 + 8.25207996368408) - 0.00827066193623539*std::sin(0.285119920969009*x_7 + 8.39744091033936) + 0.0195609806614174*std::sin(0.336559861898422*x_7 + 5.23784017562866) + 0.00284896427372087*std::sin(0.349679857492447*x_7 + 2.00879979133606) - 0.0194231387207457*std::sin(0.352479845285416*x_7 - 7.59647989273071) + 0.0287463878671229*std::sin(0.364639848470688*x_7 + 1.99303984642029) + 0.00554080480713653*std::sin(0.39031982421875*x_7 + 1.9793598651886) + 0.00961680578851055*std::sin(0.457919865846634*x_7 + 7.9870400428772) - 0.00680731778453701*std::sin(0.323199838399887*x_8 - 1.12079977989197) + 0.0122997164620692*std::sin(0.334079831838608*x_8 + 8.25943946838379) - 0.00645522402226255*std::sin(0.335839837789536*x_8 - 4.34151983261108) - 0.0246372348893072*std::sin(0.34215983748436*x_8 - 1.14503979682922) + 0.021369300949485*std::sin(0.259759962558746*x_9 + 5.17736005783081) + 0.0187524467691587*std::sin(0.280479967594147*x_9 + 1.99911975860596) + 0.00690576618823394*std::sin(0.334879845380783*x_9 + 5.06487989425659) - 0.0175658904273086*std::sin(0.333039849996567*x_91 + 8.41728019714355) - 0.00314950757541451*std::sin(0.34775984287262*x_91 + 5.19016027450562) + 0.00506772324218255*std::sin(0.353039860725403*x_91 + 5.20071983337402) + 0.0227190192907612*std::sin(0.356399834156036*x_91 + 5.21304035186768) + 0.0470961103534357*std::sin(0.367759823799133*x_91 + 5.19528007507324) - 0.0317152392142793*std::sin(0.400319844484329*x_91 + 1.97431981563568) + 0.00221667671389117*std::sin(0.484399855136871*x_91 - 7.60904026031494) - 0.0161040645540546*std::sin(0.268319964408875*x_92 - 7.3744797706604) - 0.0437337611617222*std::sin(0.286079943180084*x_92 + 5.21439981460571) + 0.00399548936811507*std::sin(0.289279937744141*x_92 + 2.00223970413208) - 0.0494191201257283*std::sin(0.299279928207397*x_92 - 7.40520000457764) - 0.00663276899914428*std::sin(0.300959944725037*x_92 + 1.80455982685089) + 0.0043280540115456*std::sin(0.316799849271774*x_92 + 8.22192001342773) + 0.00878214689952334*std::sin(0.270399957895279*x_94 + 5.1864800453186) + 0.0120853030031167*std::sin(0.285599917173386*x_94 + 1.98791980743408) + 0.0279157140679354*std::sin(0.287359952926636*x_94 + 1.9755197763443) - 0.0106882278855184*std::sin(0.261279970407486*x_95 - 7.41343975067139) + 0.0402311227646531*std::sin(0.278959959745407*x_95 + 1.97447979450226) + 0.0143827228884591*std::sin(0.281039953231812*x_95 + 1.97343981266022) + 0.00405443548418481*std::sin(0.281679958105087*x_95 + 1.96399986743927) + 0.0219456477042156*std::sin(0.28263995051384*x_95 - 4.40463972091675) - 0.0157781320923177*std::sin(0.273119956254959*x_96 + 8.19167995452881) + 0.0181255786263522*std::sin(0.278159946203232*x_96 - 7.4423999786377) + 0.0138759570293942*std::sin(0.262239962816238*x_97 + 5.17519998550415) - 0.0133115669748354*std::sin(0.273119956254959*x_97 + 1.97847986221313) - 0.0408632368526259*std::sin(0.27567994594574*x_97 + 1.97919988632202) + 0.0289230117035473*std::sin(0.28383994102478*x_97 + 8.18407917022705) + 0.00677579984195316*std::sin(0.284799933433533*x_97 + 8.18175983428955) - 0.0471357810232193*std::sin(0.248399972915649*x_99 + 1.98031985759735) - 0.173414610466314);
}

inline float score_11(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.00357623275219675*x_1 + 0.00734082180417602*x_10 + 3.61556189067849e-5*x_100 + 0.00797817653382972*x_101 + 0.00548710127916479*x_102 - 0.0105820633087765*x_103 - 5.79524913466513e-5*x_104 + 0.00553892436812634*x_105 - 0.00443569084755518*x_106 - 0.00318254589945416*x_107 + 0.00386933090469214*x_108 - 0.00112051854541791*x_109 + 0.00496578064211122*x_11 + 0.000600765288617397*x_110 - 0.0131727207310856*x_111 - 0.000584014068356024*x_112 + 0.00126556255035103*x_113 - 0.00312034484010015*x_114 - 0.00188212588698175*x_115 + 0.000391723876865449*x_116 + 0.00142541707355775*x_117 - 0.00559639804599604*x_118 - 0.000645054835925145*x_119 + 8.44927557262995e-5*x_12 - 0.00705702595228077*x_120 + 0.00486542978309992*x_13 - 0.00214229930573798*x_14 - 0.00338376562543547*x_15 + 0.000281227316888244*x_16 - 0.00161549275763918*x_17 - 0.00196062045143349*x_18 - 0.00754572737415994*x_19 + 0.00225613319989579*x_2 - 0.00116998093286328*x_20 - 0.00416299958914746*x_21 - 0.00188211485223495*x_22 - 0.003177104297386*x_23 - 0.00296851855577838*x_24 - 0.00298578215830171*x_25 - 0.00530499152806346*x_26 - 0.0042068345312682*x_27 - 0.00278524319338964*x_28 + 0.00313756805892208*x_29 + 0.000566201159376871*x_3 - 0.00387640007124857*x_30 - 0.00169384023813719*x_31 - 0.000453409327068339*x_32 - 0.0005826423498182*x_33 - 0.000255692609694989*x_34 - 0.0129379118610622*x_35 - 0.00836329213882455*x_36 + 0.00324136319078152*x_37 - 0.0016485692494305*x_38 - 0.0130399210661339*x_39 + 0.0010937115260102*x_4 + 0.00231213190975751*x_40 + 0.000872545215895189*x_41 + 0.00680668640131871*x_42 + 0.00987201470111667*x_43 - 1.20123120056089e-5*x_44 - 0.00722289067551374*x_45 - 0.00651890406518495*x_46 + 0.00559413534557274*x_47 - 0.0104420016211189*x_48 - 0.00810589387928075*x_49 + 0.00519137260651765*x_5 + 0.0106701678185861*x_50 + 0.00805905507210884*x_51 - 0.00178329251534285*x_52 + 0.00181197901909168*x_53 + 0.00562369228212566*x_54 + 0.0113727249743259*x_55 - 0.00309039211020329*x_56 - 0.005100124307135*x_57 + 0.00583882829794408*x_58 - 0.00896216782651257*x_59 + 0.00610184021306115*x_6 - 0.00702648176043115*x_60 - 0.00191542946644996*x_61 + 0.00276714924044395*x_62 + 0.00294170149654111*x_63 - 0.000666903851449474*x_64 - 0.00317420165016857*x_65 - 0.00150613021533961*x_66 + 0.00084991838098524*x_67 - 0.00132713056299571*x_68 + 0.00458806035080305*x_69 - 0.00217014163931231*x_7 + 0.000299707815686928*x_70 - 0.00279615807680434*x_71 + 0.000566240069393018*x_72 + 0.00279637057027063*x_73 - 0.000963133651774813*x_74 - 0.00041370945124785*x_75 + 0.00113551566179225*x_76 + 0.000186485763378392*x_77 - 0.000706743253336468*x_78 - 0.00348430062011052*x_79 - 0.000831452288019645*x_8 + 0.00126640789819201*x_80 + 0.000504595403886542*x_81 - 0.0035574439231514*x_82 - 0.00192494487138026*x_83 - 1.67527254914664e-6*x_84 - 0.00185021681157424*x_85 - 0.000223599047491504*x_86 - 0.00232853634330483*x_87 + 0.00203266870858644*x_88 + 0.00201987239745891*x_89 - 0.00318404584553877*x_9 + 0.00784425225491882*x_90 + 0.000673589705393281*x_91 - 0.00296890022785334*x_92 - 0.000990120286444394*x_93 - 2.46449100694342e-6*x_94 - 0.00145852252313664*x_95 + 0.00234241315147294*x_96 + 0.00435405077094035*x_97 + 0.00482154428765094*x_98 + 0.00988984098450893*x_99 - 2.2707143415388e-5*std::pow(-3.34895968437195*x_1 - 4.17543983459473, 2) - 1.67131708110847e-5*std::pow(-5.60767984390259*x_22 - 9.60639953613281, 2) + 1.44965289295098e-5*std::pow(-4.01999998092651*x_27 - 6.62815999984741, 2) + 0.00484343906819678*std::exp(0.163839861750603*x_49) + 0.0196269472914505*std::sin(0.329999834299088*x_1 + 5.14520025253296) - 0.00664617758649806*std::sin(0.342239856719971*x_1 + 8.34768009185791) - 0.0088958771364418*std::sin(0.359039843082428*x_1 - 1.03663980960846) - 0.00269914809294041*std::sin(0.408399850130081*x_1 + 8.39400005340576) - 0.034523176298127*std::sin(0.146240040659904*x_10 + 8.17375946044922) - 0.0116674459845544*std::sin(0.339839845895767*x_10 + 5.03247976303101) - 0.00843653817419559*std::sin(0.352079838514328*x_10 + 8.25903987884521) - 0.00591240475572311*std::sin(0.366479843854904*x_10 + 8.24079990386963) - 0.00744961861379357*std::sin(0.242079973220825*x_100 + 1.9755197763443) + 0.0160692548670568*std::sin(0.257839977741241*x_100 + 1.95887982845306) - 0.00966603424102318*std::sin(0.229919984936714*x_101 + 1.98535978794098) - 0.0127725009589732*std::sin(0.221599996089935*x_102 + 1.97327971458435) - 0.0104097324043533*std::sin(0.239359974861145*x_102 - 1.2099198102951) + 0.0236835695232416*std::sin(0.247999966144562*x_107 + 5.15144014358521) + 0.0108177414646551*std::sin(0.246319979429245*x_108 + 1.97391986846924) + 0.0191140758578077*std::sin(0.23327998816967*x_109 + 1.95511984825134) + 0.0190357570864545*std::sin(0.23471999168396*x_109 + 1.98399984836578) - 0.00368877426486533*std::sin(0.246079966425896*x_109 - 7.44191980361938) - 0.0153295404591555*std::sin(0.247759968042374*x_109 - 1.21407985687256) + 0.0182202908593607*std::sin(0.252159982919693*x_109 - 1.214399933815) - 0.0114799055682169*std::sin(0.216800004243851*x_11 + 5.18383979797363) - 0.0100299341329425*std::sin(0.218799993395805*x_11 + 2.00231981277466) + 0.0125310605162038*std::sin(0.248719975352287*x_11 - 7.41408014297485) - 0.0184719018991318*std::sin(0.25655996799469*x_11 + 8.37376022338867) + 0.0285321913417553*std::sin(0.210319995880127*x_110 + 5.17592000961304) + 0.014264632728833*std::sin(0.216240003705025*x_110 - 7.42695951461792) - 0.00498546726602003*std::sin(0.219759985804558*x_110 - 4.41991996765137) + 0.0218048636077272*std::sin(0.213039994239807*x_111 - 7.41463994979858) + 0.0177925955931252*std::sin(0.216879993677139*x_111 + 1.98231983184814) + 0.0319314758721116*std::sin(0.267279952764511*x_112 - 1.20023989677429) - 0.00881148475135145*std::sin(0.278399974107742*x_112 + 1.96583986282349) + 0.0184909697856352*std::sin(0.290479928255081*x_112 + 1.95439982414246) - 0.0258596731129398*std::sin(0.293919950723648*x_113 + 1.96367979049683) + 0.00469310603239492*std::sin(0.237119987607002*x_116 + 8.16991996765137) + 0.00970963991445627*std::sin(0.250639975070953*x_116 - 4.40895986557007) + 0.0124439701276092*std::sin(0.225919991731644*x_117 - 7.40279960632324) - 0.0207533728644454*std::sin(0.232319980859756*x_117 + 5.17903995513916) + 0.0233687001770122*std::sin(0.23471999168396*x_118 - 7.41639995574951) + 0.00446545694128114*std::sin(0.265759944915771*x_119 + 8.15824031829834) - 0.00928347979670721*std::sin(0.277439951896667*x_12 - 7.43567991256714) - 0.0193093027516726*std::sin(0.285599917173386*x_12 + 5.13567972183228) + 0.0222658223069124*std::sin(0.248639971017838*x_13 + 1.98823988437653) + 0.0194009657528647*std::sin(0.289919942617416*x_13 - 7.4443998336792) - 0.0115171886335113*std::sin(0.310239940881729*x_13 + 8.31328010559082) + 0.0118358724301286*std::sin(0.389119833707809*x_13 + 4.99919986724854) + 0.0257967832724323*std::sin(0.247759968042374*x_14 + 8.37184047698975) + 0.0135169157556792*std::sin(0.265839964151382*x_14 + 1.98951983451843) + 0.0234392365575658*std::sin(0.281199961900711*x_14 + 5.17095994949341) + 0.00278932781328507*std::sin(0.304159939289093*x_14 - 4.2577600479126) - 0.00644012032488746*std::sin(0.346159845590591*x_14 - 1.13391983509064) - 0.00889375857040232*std::sin(0.357839852571487*x_14 + 8.01512050628662) + 0.0161847739197483*std::sin(0.280799955129623*x_15 - 1.3802398443222) + 0.00775994119125703*std::sin(0.300879925489426*x_15 - 7.43351984024048) - 0.0101105788902558*std::sin(0.333999842405319*x_15 + 8.27744007110596) + 0.0133257380080957*std::sin(0.274159938097*x_16 - 1.17031991481781) - 0.0139086403843065*std::sin(0.279039949178696*x_16 - 1.19951987266541) + 0.00817227399448298*std::sin(0.306239932775497*x_16 + 1.99111986160278) + 0.00718216399190546*std::sin(0.310719937086105*x_16 + 1.98639988899231) - 0.0173875203270384*std::sin(0.321919918060303*x_16 + 1.98375976085663) - 0.00809071129190878*std::sin(0.328959852457047*x_16 - 7.32767963409424) + 0.00797157916778543*std::sin(0.461359858512878*x_16 - 1.4119998216629) + 0.00870938789561416*std::sin(0.257359951734543*x_17 + 8.24071979522705) + 0.00960231438455224*std::sin(0.288959950208664*x_17 + 2.01887989044189) + 0.0104225032756322*std::sin(0.3503198325634*x_17 + 2.00575995445251) - 0.0123050118527476*std::sin(0.351999849081039*x_17 - 4.17120027542114) - 0.00991269643677187*std::sin(0.359679847955704*x_17 + 2.02319979667664) - 0.00140875701068309*std::sin(0.389599829912186*x_17 + 8.19871997833252) - 0.0175018834454077*std::sin(0.22095999121666*x_18 + 5.01007986068726) - 0.00466475120835059*std::sin(0.269839972257614*x_18 + 8.2186393737793) + 0.0200668628114058*std::sin(0.275279939174652*x_18 - 1.15727984905243) - 0.00780307656289105*std::sin(0.303439915180206*x_18 - 4.37415981292725) + 0.00558524928138511*std::sin(0.316159933805466*x_18 + 2.18255996704102) - 0.0155756130866206*std::sin(0.341119825839996*x_18 - 7.36839962005615) - 0.0131736629247532*std::sin(0.39743983745575*x_18 - 1.19631993770599) + 0.00627012088335093*std::sin(0.417519867420197*x_18 - 1.214479804039) + 0.0227446908117247*std::sin(0.249119967222214*x_19 - 7.57503986358643) - 0.0215364613888705*std::sin(0.270559966564178*x_19 + 5.01200008392334) - 0.0080540089966868*std::sin(0.345519840717316*x_2 - 7.40919971466064) - 0.0249555486308505*std::sin(0.391199827194214*x_2 - 4.21216011047363) - 0.00375531149775526*std::sin(0.423679858446121*x_2 + 5.21167993545532) - 0.0232211401474443*std::sin(0.262159943580627*x_20 + 8.19703960418701) + 0.00245274413670918*std::sin(0.269199967384338*x_20 + 2.0066397190094) - 0.0110733594415545*std::sin(0.273679971694946*x_20 - 7.41055965423584) - 0.0185609968510172*std::sin(0.282879948616028*x_20 + 1.99935972690582) + 0.0201404667759046*std::sin(0.289679944515228*x_20 + 1.98439979553223) - 0.0136479848879364*std::sin(0.327519834041595*x_20 + 8.24312019348145) - 0.0108507284748533*std::sin(0.341679841279984*x_20 + 8.24327945709229) - 0.0130463155167929*std::sin(0.366719841957092*x_20 + 1.7992799282074) + 0.0148062523765964*std::sin(0.311999946832657*x_21 + 1.99287974834442) + 0.0064372453540083*std::sin(0.343839854001999*x_21 + 8.24991989135742) - 0.00351395051764094*std::sin(0.436479866504669*x_21 + 1.78887987136841) + 0.00843794703153087*std::sin(0.338159829378128*x_22 + 2.02815985679626) - 0.00760249165534801*std::sin(0.353279858827591*x_22 - 7.37287998199463) + 0.0131405675125675*std::sin(0.373279839754105*x_22 + 1.98695981502533) - 0.0165716868616498*std::sin(0.398239850997925*x_22 + 5.19063997268677) - 0.0104150366277823*std::sin(0.212559998035431*x_23 - 1.18399977684021) + 0.0123802815600455*std::sin(0.323359936475754*x_23 + 5.21583986282349) - 0.00289520290452651*std::sin(0.344639837741852*x_23 - 1.16903984546661) + 0.00500865660909919*std::sin(0.3503198325634*x_23 + 2.028639793396) - 0.00710142961930013*std::sin(0.294959932565689*x_24 + 8.21343994140625) + 0.0130648093271165*std::sin(0.331279844045639*x_24 + 2.03863978385925) - 0.0121358016283257*std::sin(0.366319835186005*x_24 + 1.78495991230011) + 0.00856121382405634*std::sin(0.410559862852097*x_24 + 1.98767983913422) + 0.00330726109609136*std::sin(0.374479830265045*x_25 - 7.5918402671814) - 0.0153427935549203*std::sin(0.439119875431061*x_25 - 1.39551985263824) + 0.0152312446648137*std::sin(0.296079933643341*x_26 + 1.99919974803925) + 0.00774011491076628*std::sin(0.313919931650162*x_26 - 1.18519985675812) - 0.0151563970145958*std::sin(0.339119851589203*x_26 + 5.02279996871948) - 0.00139941542637229*std::sin(0.359279841184616*x_26 - 1.14727985858917) + 0.00734069660897502*std::sin(0.399359852075577*x_26 - 1.20367991924286) + 0.0226546892846254*std::sin(0.20040000975132*x_27 + 8.20024013519287) - 0.00339748226739766*std::sin(0.223039999604225*x_27 + 8.21224021911621) - 0.015880418588496*std::sin(0.329599827528*x_27 + 2.0319197177887) + 0.0435355702379841*std::sin(0.112960062921047*x_28 + 5.09511995315552) - 0.0185129902312114*std::sin(0.231039986014366*x_28 - 1.15839993953705) + 0.00121120435160323*std::sin(0.284159928560257*x_28 - 1.17151987552643) + 0.00701130869106877*std::sin(0.310159921646118*x_28 + 1.99215984344482) + 0.0216694989867184*std::sin(0.326479852199554*x_28 - 1.12615978717804) - 0.0108946562988463*std::sin(0.335039854049683*x_28 + 8.22056007385254) + 0.0425369955169807*std::sin(0.0978400707244873*x_29 - 7.69432020187378) + 0.036783364225793*std::sin(0.106960065662861*x_29 - 4.49688005447388) + 0.0278078543109615*std::sin(0.271039962768555*x_29 + 5.00927972793579) + 0.00636752955188056*std::sin(0.314319908618927*x_29 + 1.99423980712891) + 0.00989582832183011*std::sin(0.3572798371315*x_29 + 8.236159324646) + 0.00637800190388358*std::sin(0.263759940862656*x_3 + 8.26399993896484) + 0.0106609568054536*std::sin(0.291919946670532*x_3 - 4.32488012313843) + 0.0103118097229838*std::sin(0.308879911899567*x_3 - 1.10775983333588) - 0.00425400212380537*std::sin(0.319359928369522*x_3 + 5.25487995147705) - 0.0144687291148749*std::sin(0.377999842166901*x_3 + 1.98583984375) + 0.00532637232820552*std::sin(0.37967985868454*x_3 - 1.19287979602814) + 0.0116084427567621*std::sin(0.383679836988449*x_3 + 8.18943977355957) - 0.0114686125371749*std::sin(0.386799842119217*x_3 - 1.1865599155426) - 0.013648428163184*std::sin(0.396639823913574*x_3 + 2.00367975234985) - 0.0385106839455564*std::sin(0.145920038223267*x_30 - 4.45616006851196) + 0.00174105583725707*std::sin(0.338719844818115*x_31 + 2.12823987007141) + 0.00724919431306777*std::sin(0.34079983830452*x_31 - 1.05159986019135) + 0.00501225538447118*std::sin(0.346719831228256*x_31 - 4.22328042984009) + 0.0114442271684566*std::sin(0.35335984826088*x_31 + 5.17592000961304) - 0.0107029655391668*std::sin(0.382319837808609*x_31 - 4.20591974258423) + 0.0248464905118219*std::sin(0.40871986746788*x_31 - 4.19944000244141) - 0.0117989297546502*std::sin(0.410959839820862*x_31 - 4.19831991195679) - 0.0103194248196954*std::sin(0.443759858608246*x_31 - 1.16527986526489) + 0.000387573341792661*std::sin(0.591199815273285*x_31 - 4.39583969116211) - 0.00387795203792552*std::sin(0.254879981279373*x_32 - 1.16591989994049) - 0.0024380850621745*std::sin(0.311599940061569*x_32 + 2.01239991188049) + 0.0100630492169663*std::sin(0.312719941139221*x_32 - 7.36104011535645) - 0.00276961566855636*std::sin(0.316399931907654*x_32 - 4.34007978439331) + 0.0164512668043453*std::sin(0.319839835166931*x_32 + 2.00407981872559) + 0.00195436392898871*std::sin(0.348159849643707*x_32 - 1.19095981121063) + 0.00174603359195743*std::sin(0.366799831390381*x_32 + 7.98663997650146) + 0.00989835499560162*std::sin(0.210879996418953*x_33 + 2.16375994682312) - 0.0136393674458136*std::sin(0.251279979944229*x_33 - 7.4314398765564) + 0.002454601748393*std::sin(0.254719972610474*x_33 + 1.96607983112335) - 0.0180846350020445*std::sin(0.264319956302643*x_33 - 1.22359991073608) + 0.00557619750171897*std::sin(0.289119929075241*x_33 + 4.96567964553833) - 0.00501209969507044*std::sin(0.224159985780716*x_34 + 5.17888021469116) + 0.0271362315065634*std::sin(0.239119976758957*x_34 + 1.97639977931976) + 0.0192648333766958*std::sin(0.243359968066216*x_34 + 1.97447979450226) - 0.016465672882918*std::sin(0.216480001807213*x_35 - 7.40999984741211) + 0.00274156795202261*std::sin(0.230159983038902*x_35 + 5.16847991943359) - 0.0231452225396329*std::sin(0.209199994802475*x_36 + 1.98423981666565) - 0.0225237711693573*std::sin(0.231439992785454*x_36 + 1.96879982948303) - 0.0170609107406894*std::sin(0.241999983787537*x_36 + 1.98503983020782) + 0.0284730201005094*std::sin(0.243279978632927*x_36 + 5.17535972595215) - 0.0179169692016079*std::sin(0.261199980974197*x_36 - 1.21743988990784) + 0.0293657985172765*std::sin(0.2223199903965*x_37 - 1.1904798746109) + 0.00128029589434027*std::sin(0.233679980039597*x_38 - 4.23104000091553) + 0.0134461381290953*std::sin(0.246639966964722*x_38 - 4.40207958221436) - 0.00751682991233809*std::sin(0.313199937343597*x_4 + 2.00671982765198) + 0.0270653053510748*std::sin(0.32551982998848*x_4 + 5.22919988632202) + 0.00590655482344233*std::sin(0.332879841327667*x_4 - 1.16815984249115) - 0.00163635027212454*std::sin(0.382559835910797*x_4 + 2.01575970649719) - 0.00296029052314575*std::sin(0.416159868240356*x_4 - 4.40927982330322) + 0.00558447072223231*std::sin(0.443599849939346*x_4 + 5.17671966552734) + 0.00387057071487642*std::sin(0.225519984960556*x_40 + 1.99303984642029) + 0.00860529377123979*std::sin(0.23047998547554*x_40 + 1.9651198387146) + 0.0326859095192187*std::sin(0.236319988965988*x_41 - 7.4236798286438) + 0.0143984391331149*std::sin(0.241679981350899*x_41 - 7.42560005187988) + 0.00984229652462859*std::sin(0.26199996471405*x_41 + 1.97463977336884) - 0.00570786745740777*std::sin(0.222159996628761*x_42 + 4.99399995803833) + 0.0241354883757541*std::sin(0.229359999299049*x_42 + 1.96647977828979) - 0.0259081766252894*std::sin(0.25639995932579*x_42 + 5.14743995666504) + 0.0188888628544264*std::sin(0.211759999394417*x_43 - 1.20295989513397) - 0.0220021506572708*std::sin(0.242719978094101*x_44 - 1.20631992816925) - 0.00847696351029711*std::sin(0.260479986667633*x_44 + 1.94247984886169) - 0.00548943634853058*std::sin(0.267679959535599*x_44 - 7.4443998336792) - 0.00557942019452223*std::sin(0.194399997591972*x_46 - 7.60128021240234) + 0.0126118858315148*std::sin(0.249199971556664*x_46 + 1.97567975521088) + 0.0303268553349346*std::sin(0.207040011882782*x_47 - 7.58816003799438) - 0.0184093725760135*std::sin(0.253199964761734*x_48 - 1.20247983932495) + 0.0199360467958836*std::sin(0.296239942312241*x_49 + 5.06767988204956) - 0.00782671646296358*std::sin(0.309839934110641*x_5 + 1.81447994709015) - 0.0111970926297281*std::sin(0.364319831132889*x_5 - 1.16543984413147) - 0.0115113602088541*std::sin(0.388639837503433*x_5 + 2.00431990623474) + 0.00350853028692787*std::sin(0.388959854841232*x_5 + 4.98991966247559) + 0.0184225899971545*std::sin(0.408159852027893*x_5 - 1.17863988876343) + 0.0151400160675231*std::sin(0.181120008230209*x_50 - 7.37967967987061) - 0.0131284713941519*std::sin(0.215199992060661*x_52 - 1.20711994171143) + 0.0171981853549549*std::sin(0.242479979991913*x_53 + 1.96927976608276) - 0.0190212186007987*std::sin(0.247439980506897*x_53 + 1.98375976085663) + 0.0247635761098415*std::sin(0.214560002088547*x_57 - 7.41511964797974) - 0.0228156752683029*std::sin(0.222719997167587*x_59 - 1.18319988250732) + 0.0227785593394363*std::sin(0.265359938144684*x_6 + 5.20975971221924) - 0.00501518387888161*std::sin(0.477919846773148*x_6 + 4.96743965148926) + 0.00924495269623698*std::sin(0.255839973688126*x_60 + 8.34751987457275) + 0.0208628120842372*std::sin(0.327759832143784*x_60 - 7.52952003479004) - 0.00810886073880693*std::sin(0.390639841556549*x_60 - 4.37255954742432) + 0.00666059470900779*std::sin(0.490879863500595*x_60 + 1.69871997833252) - 0.0162799578011709*std::sin(0.149440035223961*x_61 - 1.27567994594574) + 0.00999841066531625*std::sin(0.240959972143173*x_61 + 8.25207996368408) - 0.0221612306580482*std::sin(0.285119920969009*x_7 + 8.39744091033936) + 0.0118045427410852*std::sin(0.336559861898422*x_7 + 5.23784017562866) - 0.00638255927031745*std::sin(0.349679857492447*x_7 + 2.00879979133606) - 0.00966441405686683*std::sin(0.352479845285416*x_7 - 7.59647989273071) - 0.0176759447131087*std::sin(0.364639848470688*x_7 + 1.99303984642029) - 0.00192188077770938*std::sin(0.39031982421875*x_7 + 1.9793598651886) - 0.0112624460118674*std::sin(0.457919865846634*x_7 + 7.9870400428772) + 0.00236118283412731*std::sin(0.323199838399887*x_8 - 1.12079977989197) + 0.0146254918784682*std::sin(0.334079831838608*x_8 + 8.25943946838379) + 0.00755985029167379*std::sin(0.335839837789536*x_8 - 4.34151983261108) + 0.0151492564492018*std::sin(0.34215983748436*x_8 - 1.14503979682922) - 0.0131398276502377*std::sin(0.259759962558746*x_9 + 5.17736005783081) - 0.0151519999545593*std::sin(0.280479967594147*x_9 + 1.99911975860596) - 0.00239533059807987*std::sin(0.334879845380783*x_9 + 5.06487989425659) - 0.00929489558699927*std::sin(0.333039849996567*x_91 + 8.41728019714355) - 0.00843910250184897*std::sin(0.34775984287262*x_91 + 5.19016027450562) - 0.00175778794325279*std::sin(0.353039860725403*x_91 + 5.20071983337402) - 0.0139697596364388*std::sin(0.356399834156036*x_91 + 5.21304035186768) + 0.0234337157072016*std::sin(0.367759823799133*x_91 + 5.19528007507324) + 0.0256259521250281*std::sin(0.400319844484329*x_91 + 1.97431981563568) + 0.00263583208411219*std::sin(0.484399855136871*x_91 - 7.60904026031494) - 0.008521378359706*std::sin(0.268319964408875*x_92 - 7.3744797706604) + 0.0353369325769777*std::sin(0.286079943180084*x_92 + 5.21439981460571) - 0.00895112934238789*std::sin(0.289279937744141*x_92 + 2.00223970413208) + 0.0303874573442288*std::sin(0.299279928207397*x_92 - 7.40520000457764) - 0.00788697116944926*std::sin(0.300959944725037*x_92 + 1.80455982685089) - 0.00150122664472206*std::sin(0.316799849271774*x_92 + 8.22192001342773) - 0.00709598544982197*std::sin(0.270399957895279*x_94 + 5.1864800453186) + 0.0072931658339935*std::sin(0.285599917173386*x_94 + 1.98791980743408) + 0.0138900835402813*std::sin(0.287359952926636*x_94 + 1.9755197763443) + 0.0125172112414917*std::sin(0.261279970407486*x_95 - 7.41343975067139) - 0.0247378246276155*std::sin(0.278959959745407*x_95 + 1.97447979450226) + 0.00867959894285269*std::sin(0.281039953231812*x_95 + 1.97343981266022) - 0.00908318683536541*std::sin(0.281679958105087*x_95 + 1.96399986743927) + 0.0116124203805026*std::sin(0.28263995051384*x_95 - 4.40463972091675) - 0.00952169208088958*std::sin(0.273119956254959*x_96 + 8.19167995452881) - 0.0111452863981889*std::sin(0.278159946203232*x_96 - 7.4423999786377) + 0.00837377893583977*std::sin(0.262239962816238*x_97 + 5.17519998550415) - 0.0158286750170652*std::sin(0.273119956254959*x_97 + 1.97847986221313) + 0.0251265069804394*std::sin(0.27567994594574*x_97 + 1.97919988632202) + 0.0153044546735922*std::sin(0.28383994102478*x_97 + 8.18407917022705) - 0.00235025053636312*std::sin(0.284799933433533*x_97 + 8.18175983428955) - 0.0234534547300349*std::sin(0.248399972915649*x_99 + 1.98031985759735) + 0.419908391504551);
}

int predict(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120)
{
    float s0 = score_0(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s1 = score_1(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s2 = score_2(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s3 = score_3(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s4 = score_4(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s5 = score_5(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s6 = score_6(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s7 = score_7(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s8 = score_8(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s9 = score_9(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s10 = score_10(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s11 = score_11(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);

    float max_score = s0;
    int max_index = 0;

    if(s1 > max_score) {
        max_score = s1;
        max_index = 1;
    }

    if(s2 > max_score) {
        max_score = s2;
        max_index = 2;
    }

    if(s3 > max_score) {
        max_score = s3;
        max_index = 3;
    }

    if(s4 > max_score) {
        max_score = s4;
        max_index = 4;
    }

    if(s5 > max_score) {
        max_score = s5;
        max_index = 5;
    }

    if(s6 > max_score) {
        max_score = s6;
        max_index = 6;
    }

    if(s7 > max_score) {
        max_score = s7;
        max_index = 7;
    }

    if(s8 > max_score) {
        max_score = s8;
        max_index = 8;
    }

    if(s9 > max_score) {
        max_score = s9;
        max_index = 9;
    }

    if(s10 > max_score) {
        max_score = s10;
        max_index = 10;
    }

    if(s11 > max_score) {
        max_score = s11;
        max_index = 11;
    }

    return max_index;
}

#endif
