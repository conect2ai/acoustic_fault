
#ifndef KAN_MODEL_H
#define KAN_MODEL_H

#include <cmath>


inline float score_0(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.000822546827100378*x_1 - 3.87302460335463e-5*x_10 - 0.00513707733108368*x_100 - 0.00192284056278027*x_101 + 0.00161081823330307*x_102 - 9.0923776507217e-5*x_103 - 0.0011825183499752*x_104 - 0.000943478621485982*x_105 + 0.000434827587695472*x_106 + 0.00141196349431936*x_107 + 0.00195710782789144*x_108 - 0.0013125991103628*x_109 + 0.00334124113511745*x_11 + 0.000429049250853586*x_110 - 0.00162628654425954*x_111 - 0.00696205789630648*x_112 - 0.00725100553507232*x_113 - 0.0110541822969016*x_114 - 0.00088803439360652*x_115 + 0.00316518235292441*x_116 - 0.0203317292800014*x_117 - 0.00649098501027408*x_118 - 0.0193576586468935*x_119 + 0.00239031881293898*x_12 - 0.00255013512727625*x_120 + 0.000705232368333607*x_13 + 0.00203892994297736*x_14 - 0.000542182714218958*x_15 - 0.00259417475244476*x_16 - 7.7046217846429e-7*x_17 + 0.000141203275266062*x_18 - 0.0125631596220712*x_19 - 0.00422711735382032*x_2 + 0.000190210268893883*x_20 - 0.000385744343878485*x_21 - 0.00224957481833378*x_22 + 7.36492216070008e-5*x_23 - 0.000365055875202274*x_24 - 0.000855491666908422*x_25 - 0.00123076875537779*x_26 - 0.00471786452701821*x_27 - 0.00234514284505033*x_28 - 0.00200826193857673*x_29 - 0.000123220148185478*x_3 - 0.00408018707016217*x_30 + 4.41353125974757e-5*x_31 - 0.000225441968507984*x_32 + 0.0111830057834515*x_33 + 0.0219665811739619*x_34 - 0.00261285855608025*x_35 - 0.00193060452316691*x_36 - 0.00142898296284756*x_37 - 0.000237308481385236*x_38 + 0.00570438727778085*x_39 - 0.00143812061107717*x_4 - 0.00232620730248115*x_40 + 0.00134203201829972*x_41 + 0.00105488943725588*x_42 + 0.00169467997737952*x_43 + 0.00605659251565566*x_44 - 0.000604676978047144*x_45 + 0.00305802496478046*x_46 + 0.00197488277776328*x_47 + 0.00314280452886482*x_48 + 0.00151726141290905*x_49 - 0.00046813581329179*x_5 + 0.00110234476356196*x_50 + 0.00222174688312878*x_51 - 0.00200762558790682*x_52 - 0.00188722502943678*x_53 + 0.00128506018957719*x_54 + 0.00546792029592439*x_55 - 0.0020951346507994*x_56 - 0.000376187292191765*x_57 + 0.00197998851849576*x_58 - 0.0111366286351866*x_59 - 0.00407711435580756*x_6 - 0.000640185024785957*x_60 + 0.000486539373844423*x_61 - 0.00147745449481542*x_62 + 0.00409547709202769*x_63 + 0.00151651752701697*x_64 + 6.08553803369313e-5*x_65 + 0.000829203218667542*x_66 + 5.00982555219925e-5*x_67 - 0.0011083086085526*x_68 - 0.00107405984066576*x_69 - 0.00211989961522511*x_7 - 0.00216905107024516*x_70 - 0.00201135498145816*x_71 + 0.000987793014778381*x_72 - 0.00379040159770552*x_73 + 0.00209813524380807*x_74 - 0.000557406372455129*x_75 + 0.000675446498062842*x_76 + 0.000750944486633433*x_77 - 0.00172178259249966*x_78 - 0.000715338131295573*x_79 + 0.0032750550996413*x_8 - 0.000418650380619158*x_80 - 0.00111056985753021*x_81 - 0.00387503258725283*x_82 + 0.000480274558818126*x_83 + 0.000813707712977619*x_84 - 0.000246653841634392*x_85 - 0.00203812056308941*x_86 - 0.000777500358537479*x_87 + 0.00166687196189009*x_88 + 0.000920088796989436*x_89 + 0.00107999414883457*x_9 - 0.00039998553750315*x_90 + 5.07747240029748e-5*x_91 - 6.12066434374985e-5*x_92 - 0.00144262964349388*x_93 + 0.000155136050147808*x_94 - 0.00280716246459966*x_95 + 0.000232504444683282*x_96 - 0.00168622815141122*x_97 + 0.00220593869327004*x_98 - 0.000516406090309853*x_99 + 1.91361251605469e-7*std::pow(-4.55807971954346*x_27 - 8.90623950958252, 2) + 0.000605071165314147*std::exp(0.238959848880768*x_13) - 0.000101985985087412*std::exp(0.280479848384857*x_13) + 0.00154901035132637*std::sin(0.32015985250473*x_1 - 4.2707200050354) + 0.00630223272563992*std::sin(0.323999851942062*x_1 - 4.26488018035889) - 0.00256897979727938*std::sin(0.326559841632843*x_1 - 4.26743984222412) + 0.00324826853523351*std::sin(0.34759983420372*x_1 - 4.24240016937256) - 0.000696982781154931*std::sin(0.23471999168396*x_102 - 1.20815992355347) + 0.00752328975914606*std::sin(0.297919929027557*x_11 + 5.14599990844727) + 0.0259337341700771*std::sin(0.264239966869354*x_112 - 1.20367991924286) + 0.000685284270805748*std::sin(0.295519918203354*x_113 + 1.96943974494934) - 0.00236815119132938*std::sin(0.234159991145134*x_116 - 1.21535992622375) - 0.0589125840506608*std::sin(0.235279992222786*x_116 - 1.18783986568451) - 0.000628057628372404*std::sin(0.260479986667633*x_116 + 5.13952016830444) - 0.000654999702992812*std::sin(0.226159989833832*x_117 + 5.16584014892578) - 0.000695697785764111*std::sin(0.273359954357147*x_12 + 5.1637601852417) - 0.00463663696674469*std::sin(0.264079958200455*x_120 + 5.15824031829834) - 0.00873580013520632*std::sin(0.268879950046539*x_120 + 5.14952039718628) + 0.000576185639349919*std::sin(0.310319930315018*x_13 - 4.26487970352173) - 0.000462775012417066*std::sin(0.318079918622971*x_13 - 7.45847988128662) - 0.0003667296040378*std::sin(0.330799847841263*x_14 - 1.12391984462738) - 0.00032083759070739*std::sin(0.284719944000244*x_15 - 1.21959984302521) - 0.000450809298662903*std::sin(0.294959932565689*x_15 - 7.41695976257324) - 0.000268374755155585*std::sin(0.325199842453003*x_15 + 8.28919982910156) - 0.000277290676996387*std::sin(0.326799839735031*x_16 + 2.0383198261261) - 0.0243120442076857*std::sin(0.336319833993912*x_16 - 1.1515998840332) - 0.0388794560621617*std::sin(0.348319828510284*x_17 - 7.38271999359131) + 0.0219340802526764*std::sin(0.350079834461212*x_17 + 1.99031984806061) + 0.00039253842998897*std::sin(0.228959992527962*x_18 + 5.02815961837769) - 0.11901551532223*std::sin(0.254959970712662*x_18 - 1.17047989368439) + 0.00407376832930039*std::sin(0.338399857282639*x_18 + 2.00063967704773) + 0.0120938972315711*std::sin(0.340479850769043*x_18 + 1.99655985832214) + 0.0119555021165531*std::sin(0.203599989414215*x_19 + 8.19184017181396) + 0.00285146963629026*std::sin(0.342719852924347*x_2 + 5.18183994293213) + 0.00179671497032081*std::sin(0.389759838581085*x_2 + 5.18383979797363) - 0.0119967838307428*std::sin(0.395599842071533*x_2 - 7.39423990249634) + 0.000859438468306828*std::sin(0.406479865312576*x_2 - 7.39711952209473) - 0.000454237876284836*std::sin(0.372799843549728*x_22 + 2.00423979759216) + 0.00356966261610378*std::sin(0.18384000658989*x_23 - 4.41319990158081) + 0.00166812789798875*std::sin(0.227519989013672*x_23 - 4.39135980606079) - 0.000423009798819866*std::sin(0.28247994184494*x_23 + 8.24487972259521) - 0.0125695725957293*std::sin(0.332159847021103*x_23 + 5.22624015808105) + 0.00157319376951415*std::sin(0.355119854211807*x_23 + 1.99055981636047) - 0.000706545551174458*std::sin(0.359119862318039*x_23 - 1.18087983131409) + 0.00145741517863409*std::sin(0.36831983923912*x_24 + 2.01663970947266) + 0.00112879716516536*std::sin(0.313839942216873*x_25 - 1.19807994365692) - 0.0243049345060364*std::sin(0.329279839992523*x_25 - 1.16103994846344) - 0.000330433944307047*std::sin(0.338479846715927*x_26 - 1.16215980052948) + 0.000210055382168265*std::sin(0.305919945240021*x_28 - 7.56744003295898) - 0.00183739831595118*std::sin(0.32575985789299*x_29 + 8.2411994934082) + 0.00094127576234813*std::sin(0.360639840364456*x_29 - 1.14991986751556) - 0.297445857846397*std::sin(0.347679853439331*x_3 - 7.38943958282471) + 0.000725674189911214*std::sin(0.36983984708786*x_3 - 7.40488004684448) - 0.000704617824324408*std::sin(0.370719850063324*x_3 - 7.39503955841064) - 0.002639969128767*std::sin(0.370879858732224*x_3 + 1.99631977081299) + 0.00356268484370762*std::sin(0.373519837856293*x_3 + 2.00095963478088) - 0.0054156615897342*std::sin(0.417119860649109*x_3 + 1.97791981697083) + 0.109927577036976*std::sin(0.164880022406578*x_30 + 8.16287994384766) - 0.00225766391020439*std::sin(0.319759905338287*x_30 + 1.98015987873077) - 0.12098793153319*std::sin(0.364719837903976*x_31 + 5.16336011886597) - 0.0580539965473695*std::sin(0.376239836215973*x_31 + 5.17208003997803) + 0.0069644903603173*std::sin(0.37967985868454*x_31 + 5.16975975036621) - 0.00220684958298807*std::sin(0.382479846477509*x_31 - 7.40319967269897) - 0.000355171869043396*std::sin(0.383919835090637*x_31 + 1.98991990089417) + 0.000619079097050446*std::sin(0.27703994512558*x_32 - 1.15655982494354) + 0.0401730620639445*std::sin(0.297999918460846*x_32 - 1.13655984401703) - 0.00187198156651848*std::sin(0.304799944162369*x_32 - 1.14351987838745) - 0.00265552648129823*std::sin(0.307279914617538*x_32 + 2.01071977615356) + 0.00155403887101842*std::sin(0.309519916772842*x_32 - 1.13887989521027) - 0.00102096936432581*std::sin(0.313759922981262*x_32 + 2.02247977256775) + 0.000851509058577536*std::sin(0.244079977273941*x_33 - 1.21151983737946) + 0.00115485002966288*std::sin(0.250799983739853*x_33 + 1.96807980537415) - 0.000155352145153976*std::sin(0.237599983811378*x_34 - 7.59736013412476) - 0.044194245056389*std::sin(0.249999970197678*x_38 + 1.9741598367691) - 0.00361768628547912*std::sin(0.636239886283875*x_45 + 1.76487982273102) - 0.00141363429058357*std::sin(0.199120000004768*x_48 + 1.98015987873077) + 0.00111749041597797*std::sin(0.210319995880127*x_49 + 1.96399986743927) - 0.00212936575767131*std::sin(0.360239863395691*x_5 + 2.00287985801697) - 0.0401321192470607*std::sin(0.363599836826324*x_5 + 2.00503993034363) - 0.000279660002222456*std::sin(0.365839838981628*x_5 - 7.36183977127075) + 0.00042888002564684*std::sin(0.434719860553741*x_5 - 1.21343994140625) + 0.00102761611365815*std::sin(0.215199992060661*x_52 + 1.98943984508514) + 1.50258707888696e-5*std::sin(0.388159841299057*x_54 + 1.18415987491608) + 0.00624607013869878*std::sin(0.279439955949783*x_6 - 1.18223989009857) - 0.00218585512811442*std::sin(0.283759921789169*x_6 + 2.01319980621338) - 0.035452957283147*std::sin(0.414239853620529*x_6 + 1.9826397895813) - 0.000292880746731573*std::sin(0.27975994348526*x_60 + 1.9385598897934) - 0.00370816932035911*std::sin(0.330479830503464*x_7 + 2.01647973060608) - 0.00111955883649588*std::sin(0.33383983373642*x_7 + 2.02191972732544) + 0.000789172206025067*std::sin(0.357119828462601*x_7 - 7.36943960189819) + 0.000788404019925964*std::sin(0.337839841842651*x_8 - 1.117919921875) - 0.00823277032501067*std::sin(0.14688004553318*x_9 + 8.17239952087402) - 0.000429736511319343*std::sin(0.311599940061569*x_9 - 7.44295978546143) - 0.000666541342025658*std::sin(0.360399842262268*x_91 - 7.40751981735229) + 0.00238382425451078*std::sin(0.360479861497879*x_91 + 2.00023984909058) + 0.000240095665372711*std::sin(0.36151984333992*x_91 + 2.00871968269348) - 0.00336272801030466*std::sin(0.450719863176346*x_91 - 7.59360027313232) + 0.0087407291406228*std::sin(0.277359932661057*x_92 + 8.20584011077881) - 0.00499586163690658*std::sin(0.294319927692413*x_92 + 8.21280002593994) - 0.0376227898956587*std::sin(0.295199930667877*x_92 + 2.01071977615356) - 0.0031135717108952*std::sin(0.297759920358658*x_92 + 1.99575984477997) + 0.00486044980204117*std::sin(0.262639969587326*x_94 - 4.21704006195068) - 0.0658718568966144*std::sin(0.299999952316284*x_94 + 1.95367980003357) - 0.477733986365529 + 3.97577487716268e-5*std::exp(-3.91279983520508*x_25) + 2.28322608228937e-6*std::exp(-3.44471979141235*x_12));
}

inline float score_1(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.000511234087144375*x_1 + 0.00418200977200701*x_10 - 0.00141866083762288*x_100 - 0.000437735568799499*x_101 - 0.0017422035759263*x_102 - 0.000700263222707023*x_103 - 0.00372633973419082*x_104 - 0.00114439083462049*x_105 - 0.0011117161419287*x_106 - 0.00138016069941109*x_107 + 0.00895330877335086*x_108 + 0.00104433548799013*x_109 + 0.00527969940597161*x_11 - 0.00103439741666136*x_110 - 0.00103661642295916*x_111 + 9.58684390346895e-6*x_112 + 0.0283043294660723*x_113 - 0.00092929840135969*x_114 - 0.000967242075708349*x_115 + 0.0276841849943553*x_116 - 0.00586114931525738*x_117 - 0.00907533578101996*x_118 + 0.00300634170907263*x_119 + 0.0013474878021151*x_12 + 0.00158108928782539*x_120 - 0.00104291900527244*x_13 + 0.000610843648849097*x_14 + 0.000327531152851704*x_15 + 0.00401450100106401*x_16 + 0.00214827412149035*x_17 + 0.00316088290245075*x_18 + 0.00714523251065551*x_19 - 0.00196650102323303*x_2 + 0.00282551068905126*x_20 + 0.000301173834450982*x_21 - 3.77252990311438e-5*x_22 - 0.000274956371790038*x_23 - 0.000411690374787348*x_24 - 0.00531207574088158*x_25 - 0.00651404266050206*x_26 - 0.000454883567355892*x_27 - 0.00346927459950457*x_28 - 0.00219003289099238*x_29 + 0.000279423821829618*x_3 - 0.00166201309234949*x_30 + 0.00375835670301475*x_31 - 0.000672967670293859*x_32 + 0.0032571717399028*x_33 + 0.00232843560079063*x_34 - 0.00115371188644029*x_35 - 0.00141708925049847*x_36 - 0.000476004395511586*x_37 + 0.000182526757629428*x_38 + 0.000123621373515676*x_39 + 0.00237257059531634*x_4 - 7.25826694456818e-6*x_40 + 0.000237454735413874*x_41 + 0.000232610018331563*x_42 + 0.000610666717940712*x_43 - 0.00361732371366329*x_44 + 0.00129712095249079*x_45 + 0.000216105364854306*x_46 - 0.00172572843453169*x_47 + 0.00338623066236497*x_48 + 0.00147763197050189*x_49 + 0.000825131105407566*x_5 - 0.00623315431695125*x_50 - 0.00491729678697402*x_51 - 4.2823489595024e-5*x_52 + 0.00362078281613558*x_53 - 0.00032956241566566*x_54 + 0.000586658291248235*x_55 + 0.000378016933808723*x_56 - 0.00591193543484809*x_57 - 0.00619083016777773*x_58 - 0.00512710742814862*x_59 + 0.00161260069188183*x_6 - 2.83139294830077e-5*x_60 - 0.00170758923715897*x_61 - 0.00260625758987372*x_62 - 0.00304390433081811*x_63 - 0.00149612323299665*x_64 + 0.000655837522563431*x_65 - 0.00149158387323672*x_66 - 0.00410330450512731*x_67 - 0.000801116846052239*x_68 - 0.000320685840901145*x_69 + 0.00106843384731174*x_7 - 0.00222295553064378*x_70 - 0.00276267809613874*x_71 - 0.0019001741728421*x_72 - 0.00125629914686678*x_73 + 0.00100095009029352*x_74 - 0.000564794843741723*x_75 - 0.000534359525355225*x_76 - 0.000966458924034129*x_77 - 0.00083990439635853*x_78 - 0.000697543536364237*x_79 + 0.00772327787119988*x_8 - 0.00167840093672641*x_80 - 0.0014056503320993*x_81 - 0.00168587746003385*x_82 + 0.000372638585276898*x_83 - 0.00198710230517821*x_84 - 0.00157467375127651*x_85 - 0.0013012686541385*x_86 - 0.000934619494203289*x_87 - 0.000690806745629344*x_88 - 0.000407875064899761*x_89 + 0.000415212523585189*x_9 + 0.000385031171690084*x_90 - 0.000299357263361511*x_91 - 0.000705843155263425*x_92 + 0.0018410096394279*x_93 + 0.00449221963774906*x_94 - 0.00563264736656824*x_95 - 0.0076024061000556*x_96 - 0.00310809443269554*x_97 + 0.00167158413889232*x_98 + 0.00626349160960489*x_99 - 2.35292628542508e-5*std::pow(-4.55807971954346*x_27 - 8.90623950958252, 2) + 0.000678981796740601*std::exp(0.238959848880768*x_13) + 0.0011531776142819*std::exp(0.280479848384857*x_13) - 0.190462130731966*std::sin(0.32015985250473*x_1 - 4.2707200050354) - 0.0459855263564336*std::sin(0.323999851942062*x_1 - 4.26488018035889) + 0.0290480107754598*std::sin(0.326559841632843*x_1 - 4.26743984222412) + 0.00364505091761185*std::sin(0.34759983420372*x_1 - 4.24240016937256) + 0.00108355764801741*std::sin(0.23471999168396*x_102 - 1.20815992355347) + 0.00844227438174655*std::sin(0.297919929027557*x_11 + 5.14599990844727) + 0.0155172391964478*std::sin(0.264239966869354*x_112 - 1.20367991924286) + 0.00977563905695711*std::sin(0.295519918203354*x_113 + 1.96943974494934) - 0.00265742551127419*std::sin(0.234159991145134*x_116 - 1.21535992622375) - 0.00428738686039251*std::sin(0.235279992222786*x_116 - 1.18783986568451) + 0.0071015835842275*std::sin(0.260479986667633*x_116 + 5.13952016830444) - 0.00934362709265635*std::sin(0.226159989833832*x_117 + 5.16584014892578) + 0.0855411214706759*std::sin(0.273359954357147*x_12 + 5.1637601852417) - 0.00520301128030071*std::sin(0.264079958200455*x_120 + 5.15824031829834) - 0.12461694020072*std::sin(0.268879950046539*x_120 + 5.14952039718628) - 0.0708462306102585*std::sin(0.310319930315018*x_13 - 4.26487970352173) + 0.00071944876914312*std::sin(0.318079918622971*x_13 - 7.45847988128662) + 0.0450920820043073*std::sin(0.330799847841263*x_14 - 1.12391984462738) + 0.00049878710720286*std::sin(0.284719944000244*x_15 - 1.21959984302521) + 0.0554302942543919*std::sin(0.294959932565689*x_15 - 7.41695976257324) - 0.00382838896231417*std::sin(0.325199842453003*x_15 + 8.28919982910156) + 0.00202330797520905*std::sin(0.326799839735031*x_16 + 2.0383198261261) + 0.00889018153052423*std::sin(0.336319833993912*x_16 - 1.1515998840332) - 0.00282946796081423*std::sin(0.348319828510284*x_17 - 7.38271999359131) - 0.00802063181053841*std::sin(0.350079834461212*x_17 + 1.99031984806061) + 0.00559959446179165*std::sin(0.228959992527962*x_18 + 5.02815961837769) - 0.0086614017157451*std::sin(0.254959970712662*x_18 - 1.17047989368439) + 0.00457138713311061*std::sin(0.338399857282639*x_18 + 2.00063967704773) - 0.00442237357260901*std::sin(0.340479850769043*x_18 + 1.99655985832214) + 0.0134158901851135*std::sin(0.203599989414215*x_19 + 8.19184017181396) + 0.00319978225370305*std::sin(0.342719852924347*x_2 + 5.18183994293213) - 0.0203158451746412*std::sin(0.389759838581085*x_2 + 5.18383979797363) + 0.00438686213000736*std::sin(0.395599842071533*x_2 - 7.39423990249634) - 0.00133611783606922*std::sin(0.406479865312576*x_2 - 7.39711952209473) + 0.0558518629022025*std::sin(0.372799843549728*x_22 + 2.00423979759216) + 0.00400570391679716*std::sin(0.18384000658989*x_23 - 4.41319990158081) - 0.00714195107687125*std::sin(0.227519989013672*x_23 - 4.39135980606079) + 0.0047830633807465*std::sin(0.28247994184494*x_23 + 8.24487972259521) - 0.000914755671578371*std::sin(0.332159847021103*x_23 + 5.22624015808105) - 0.00244575072277355*std::sin(0.355119854211807*x_23 + 1.99055981636047) + 0.00515545370664726*std::sin(0.359119862318039*x_23 - 1.18087983131409) + 0.00163544130560614*std::sin(0.36831983923912*x_24 + 2.01663970947266) + 0.00126668195626501*std::sin(0.313839942216873*x_25 - 1.19807994365692) + 0.00888758172699681*std::sin(0.329279839992523*x_25 - 1.16103994846344) + 0.00373628815025086*std::sin(0.338479846715927*x_26 - 1.16215980052948) - 0.000899334676128869*std::sin(0.305919945240021*x_28 - 7.56744003295898) - 0.00206184012957379*std::sin(0.32575985789299*x_29 + 8.2411994934082) - 0.115736726452261*std::sin(0.360639840364456*x_29 - 1.14991986751556) - 0.021646741238038*std::sin(0.347679853439331*x_3 - 7.38943958282471) - 0.00820535518042519*std::sin(0.36983984708786*x_3 - 7.40488004684448) + 0.00514138765454633*std::sin(0.370719850063324*x_3 - 7.39503955841064) - 0.0376593866571485*std::sin(0.370879858732224*x_3 + 1.99631977081299) + 0.00399787379579589*std::sin(0.373519837856293*x_3 + 2.00095963478088) - 0.00324041712403619*std::sin(0.417119860649109*x_3 + 1.97791981697083) - 0.0401972004789484*std::sin(0.164880022406578*x_30 + 8.16287994384766) + 0.277596259086322*std::sin(0.319759905338287*x_30 + 1.98015987873077) - 0.00880494509416532*std::sin(0.364719837903976*x_31 + 5.16336011886597) - 0.0347361372962129*std::sin(0.376239836215973*x_31 + 5.17208003997803) + 0.00781521653866237*std::sin(0.37967985868454*x_31 + 5.16975975036621) - 0.0314808990886687*std::sin(0.382479846477509*x_31 - 7.40319967269897) + 0.0025915839760266*std::sin(0.383919835090637*x_31 + 1.98991990089417) - 0.00096244542688008*std::sin(0.27703994512558*x_32 - 1.15655982494354) + 0.00292361065484032*std::sin(0.297999918460846*x_32 - 1.13655984401703) + 0.0136592952709712*std::sin(0.304799944162369*x_32 - 1.14351987838745) - 0.00297990425742398*std::sin(0.307279914617538*x_32 + 2.01071977615356) - 0.017571853978234*std::sin(0.309519916772842*x_32 - 1.13887989521027) - 0.0145642157846772*std::sin(0.313759922981262*x_32 + 2.02247977256775) + 0.0121468499497239*std::sin(0.244079977273941*x_33 - 1.21151983737946) - 0.0130581393209918*std::sin(0.250799983739853*x_33 + 1.96807980537415) + 0.00113355860954521*std::sin(0.237599983811378*x_34 - 7.59736013412476) - 0.00321625385497928*std::sin(0.249999970197678*x_38 + 1.9741598367691) - 0.00216461320461362*std::sin(0.636239886283875*x_45 + 1.76487982273102) - 0.0201656147266217*std::sin(0.199120000004768*x_48 + 1.98015987873077) - 0.0017372958408135*std::sin(0.210319995880127*x_49 + 1.96399986743927) + 0.00331039821145632*std::sin(0.360239863395691*x_5 + 2.00287985801697) - 0.0240127275822677*std::sin(0.363599836826324*x_5 + 2.00503993034363) + 0.00316217619407755*std::sin(0.365839838981628*x_5 - 7.36183977127075) - 0.001836214216374*std::sin(0.434719860553741*x_5 - 1.21343994140625) - 0.00749821054475966*std::sin(0.215199992060661*x_52 + 1.98943984508514) - 0.0001699007742482*std::sin(0.388159841299057*x_54 + 1.18415987491608) - 0.00228399952348987*std::sin(0.279439955949783*x_6 - 1.18223989009857) + 0.00339821887364527*std::sin(0.283759921789169*x_6 + 2.01319980621338) - 0.021212989027195*std::sin(0.414239853620529*x_6 + 1.9826397895813) + 0.0360118258894136*std::sin(0.27975994348526*x_60 + 1.9385598897934) + 0.00576487014580276*std::sin(0.330479830503464*x_7 + 2.01647973060608) - 0.0159706030838009*std::sin(0.33383983373642*x_7 + 2.02191972732544) - 0.00337877526864286*std::sin(0.357119828462601*x_7 - 7.36943960189819) + 0.011246651146375*std::sin(0.337839841842651*x_8 - 1.117919921875) - 0.00492601125409886*std::sin(0.14688004553318*x_9 + 8.17239952087402) + 0.0528392412156054*std::sin(0.311599940061569*x_9 - 7.44295978546143) + 0.0819561238660844*std::sin(0.360399842262268*x_91 - 7.40751981735229) + 0.034005457997624*std::sin(0.360479861497879*x_91 + 2.00023984909058) - 0.000373262441346596*std::sin(0.36151984333992*x_91 + 2.00871968269348) - 0.00201206099153662*std::sin(0.450719863176346*x_91 - 7.59360027313232) + 0.000636110058175859*std::sin(0.277359932661057*x_92 + 8.20584011077881) + 0.00182683596961546*std::sin(0.294319927692413*x_92 + 8.21280002593994) - 0.0225112907466384*std::sin(0.295199930667877*x_92 + 2.01071977615356) - 0.0444153682206602*std::sin(0.297759920358658*x_92 + 1.99575984477997) + 0.00290821066052348*std::sin(0.262639969587326*x_94 - 4.21704006195068) - 0.00479385072441127*std::sin(0.299999952316284*x_94 + 1.95367980003357) + 0.163919658431332 + 2.89338606392953e-6*std::exp(-3.91279983520508*x_25) + 3.25704164195211e-5*std::exp(-3.44471979141235*x_12));
}

inline float score_2(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.00123459934697433*x_1 - 0.0017021297869493*x_10 + 0.00346175310284988*x_100 - 0.00214564619757535*x_101 - 0.00125979336936238*x_102 - 6.42532960861572e-5*x_103 + 0.000627197544821512*x_104 + 0.000649673759698317*x_105 + 0.000705473098087991*x_106 - 0.000786556530013898*x_107 - 0.0028885291530978*x_108 + 0.00108889294865255*x_109 - 0.00135596380211464*x_11 + 9.21738331069749e-5*x_110 + 0.000453839252925929*x_111 + 0.0110980994695551*x_112 + 0.0028736736446192*x_113 + 0.00744095790664357*x_114 + 0.000551288092125605*x_115 - 0.00658225580484035*x_116 + 0.0117421508201942*x_117 + 0.00515352147712295*x_118 + 0.0112874717855016*x_119 - 0.00318227823574858*x_12 + 0.00363024712347112*x_120 - 0.000296038629755228*x_13 - 0.0026687783691338*x_14 - 0.00132384395398081*x_15 + 0.000348099917259941*x_16 + 0.00148365379483852*x_17 + 0.00128556843402646*x_18 + 0.00828208685628379*x_19 + 0.00197970136489831*x_2 + 6.96897196473256e-5*x_20 + 0.000558832985090983*x_21 + 0.00108823922794704*x_22 - 0.000197218462143814*x_23 + 5.70873744162093e-5*x_24 + 0.0022699469389703*x_25 + 0.000511018937926624*x_26 + 0.00111927587247176*x_27 + 0.000185336474853159*x_28 + 0.00118014237762083*x_29 + 0.000131924151336029*x_3 - 0.00157172711559964*x_30 - 0.000297944862198788*x_31 + 0.000489351374068305*x_32 - 0.0048766438086917*x_33 - 0.0106790271443841*x_34 + 0.00123367577102355*x_35 + 0.000643760802066696*x_36 - 0.000631602620560453*x_37 + 0.000801968745346257*x_38 - 0.00190743268176193*x_39 + 0.000203269415486403*x_4 + 0.00184743240978872*x_40 - 0.00285326070488924*x_41 - 0.000944463834964981*x_42 - 0.000774097735977886*x_43 - 0.00261953841426124*x_44 + 0.000314099130872001*x_45 - 0.00106775597762353*x_46 - 0.000399656581106437*x_47 + 0.000399704896273576*x_48 - 0.000648921771534081*x_49 + 0.000814295021166419*x_5 - 0.00158213469393264*x_50 - 0.00564467747919452*x_51 - 0.000556143069982492*x_52 + 0.00237210371975842*x_53 + 0.000457832346946856*x_54 - 0.00398500278325939*x_55 + 0.00498862954774157*x_56 + 0.00127920874994291*x_57 + 0.000262864018118002*x_58 + 0.00703257846033129*x_59 + 0.00241527844206583*x_6 + 0.000439225610159545*x_60 + 0.000103687953484143*x_61 + 0.00118898729915071*x_62 - 0.00134808575171178*x_63 - 0.00115726297839991*x_64 - 0.00033644080388629*x_65 - 0.000285106098582584*x_66 + 0.00082866937070833*x_67 + 0.000330505454849713*x_68 + 0.000450154388349507*x_69 - 0.000661349296800616*x_7 + 0.00220619172223806*x_70 + 0.00149984861326018*x_71 - 7.81682209412114e-6*x_72 + 0.00239303904617086*x_73 - 0.000948572260932407*x_74 + 0.00095723939676223*x_75 - 9.17713598333214e-5*x_76 + 0.000349468788318771*x_77 + 0.00113374662091753*x_78 + 0.000454590005508389*x_79 - 0.00392745757987468*x_8 + 0.000119236495306422*x_80 + 0.0012633655317675*x_81 + 0.00172650287300204*x_82 + 0.000263732042120449*x_83 + 0.000632331864434632*x_84 + 5.66331544017503e-5*x_85 + 0.00143247201326285*x_86 + 0.000165623782558817*x_87 + 0.000117004483339474*x_88 - 0.000494334375780144*x_89 + 0.000450991881598506*x_9 + 0.000452469861152673*x_90 + 0.000802399747080133*x_91 + 0.00168603871607398*x_92 + 0.000576419691016938*x_93 - 0.000757289073770754*x_94 + 0.00263782080744947*x_95 + 0.00168307164164035*x_96 + 9.43753126269318e-5*x_97 - 0.000285582162160906*x_98 - 0.00127891221153648*x_99 + 4.60576240279139e-6*std::pow(-4.55807971954346*x_27 - 8.90623950958252, 2) - 0.00695832112282887*std::exp(0.238959848880768*x_13) + 0.00305918018031085*std::exp(0.280479848384857*x_13) + 0.0372822270852549*std::sin(0.32015985250473*x_1 - 4.2707200050354) + 0.0365097110672005*std::sin(0.323999851942062*x_1 - 4.26488018035889) + 0.0770593339145583*std::sin(0.326559841632843*x_1 - 4.26743984222412) - 0.0373551027664666*std::sin(0.34759983420372*x_1 - 4.24240016937256) + 0.0070395404545557*std::sin(0.23471999168396*x_102 - 1.20815992355347) - 0.0865178660712559*std::sin(0.297919929027557*x_11 + 5.14599990844727) - 0.0228772837972021*std::sin(0.264239966869354*x_112 - 1.20367991924286) + 0.000133645537498675*std::sin(0.295519918203354*x_113 + 1.96943974494934) + 0.027233749352647*std::sin(0.234159991145134*x_116 - 1.21535992622375) + 0.0281638826991284*std::sin(0.235279992222786*x_116 - 1.18783986568451) + 0.0188392694070966*std::sin(0.260479986667633*x_116 + 5.13952016830444) - 0.000127739379257927*std::sin(0.226159989833832*x_117 + 5.16584014892578) - 0.0167443444192334*std::sin(0.273359954357147*x_12 + 5.1637601852417) + 0.0533213459739699*std::sin(0.264079958200455*x_120 + 5.15824031829834) - 0.00170367357648224*std::sin(0.268879950046539*x_120 + 5.14952039718628) + 0.0138678762418292*std::sin(0.310319930315018*x_13 - 4.26487970352173) + 0.00467403716325568*std::sin(0.318079918622971*x_13 - 7.45847988128662) - 0.00882660103911862*std::sin(0.330799847841263*x_14 - 1.12391984462738) + 0.00324046627864227*std::sin(0.284719944000244*x_15 - 1.21959984302521) - 0.0108502661912513*std::sin(0.294959932565689*x_15 - 7.41695976257324) - 5.2338992636839e-5*std::sin(0.325199842453003*x_15 + 8.28919982910156) - 0.00160638347384078*std::sin(0.326799839735031*x_16 + 2.0383198261261) - 0.0099160741574975*std::sin(0.336319833993912*x_16 - 1.1515998840332) + 0.0185868003854494*std::sin(0.348319828510284*x_17 - 7.38271999359131) + 0.00894618175682994*std::sin(0.350079834461212*x_17 + 1.99031984806061) + 7.65536459826797e-5*std::sin(0.228959992527962*x_18 + 5.02815961837769) + 0.0568968254733006*std::sin(0.254959970712662*x_18 - 1.17047989368439) - 0.0468483541114785*std::sin(0.338399857282639*x_18 + 2.00063967704773) + 0.00493269840976602*std::sin(0.340479850769043*x_18 + 1.99655985832214) - 0.137488328118305*std::sin(0.203599989414215*x_19 + 8.19184017181396) - 0.0327919136437483*std::sin(0.342719852924347*x_2 + 5.18183994293213) - 0.0538944132584707*std::sin(0.389759838581085*x_2 + 5.18383979797363) - 0.00489308908378447*std::sin(0.395599842071533*x_2 - 7.39423990249634) - 0.00868034624301923*std::sin(0.406479865312576*x_2 - 7.39711952209473) - 0.0109327866271999*std::sin(0.372799843549728*x_22 + 2.00423979759216) - 0.0410511361421617*std::sin(0.18384000658989*x_23 - 4.41319990158081) - 0.00658825486950591*std::sin(0.227519989013672*x_23 - 4.39135980606079) + 0.0126886374781581*std::sin(0.28247994184494*x_23 + 8.24487972259521) + 0.00600903820243017*std::sin(0.332159847021103*x_23 + 5.22624015808105) - 0.0158892894957875*std::sin(0.355119854211807*x_23 + 1.99055981636047) - 0.00409311668613065*std::sin(0.359119862318039*x_23 - 1.18087983131409) - 0.016760281110001*std::sin(0.36831983923912*x_24 + 2.01663970947266) - 0.0129811724769292*std::sin(0.313839942216873*x_25 - 1.19807994365692) - 0.00991317434667988*std::sin(0.329279839992523*x_25 - 1.16103994846344) + 0.00991172436545719*std::sin(0.338479846715927*x_26 - 1.16215980052948) - 0.000829611683914977*std::sin(0.305919945240021*x_28 - 7.56744003295898) + 0.0211300888983783*std::sin(0.32575985789299*x_29 + 8.2411994934082) + 0.0226550175676104*std::sin(0.360639840364456*x_29 - 1.14991986751556) + 0.142197637138505*std::sin(0.347679853439331*x_3 - 7.38943958282471) - 0.0217673839914061*std::sin(0.36983984708786*x_3 - 7.40488004684448) - 0.00408194909626595*std::sin(0.370719850063324*x_3 - 7.39503955841064) - 0.000514852168982566*std::sin(0.370879858732224*x_3 + 1.99631977081299) - 0.0409708917282186*std::sin(0.373519837856293*x_3 + 2.00095963478088) + 0.00477739250064918*std::sin(0.417119860649109*x_3 + 1.97791981697083) + 0.0448358022279374*std::sin(0.164880022406578*x_30 + 8.16287994384766) - 0.0543383964544534*std::sin(0.319759905338287*x_30 + 1.98015987873077) + 0.0578397632122323*std::sin(0.364719837903976*x_31 + 5.16336011886597) + 0.0512119753316655*std::sin(0.376239836215973*x_31 + 5.17208003997803) - 0.0800916704711474*std::sin(0.37967985868454*x_31 + 5.16975975036621) - 0.000430384310952281*std::sin(0.382479846477509*x_31 - 7.40319967269897) - 0.00205756005569523*std::sin(0.383919835090637*x_31 + 1.98991990089417) - 0.006252711639497*std::sin(0.27703994512558*x_32 - 1.15655982494354) - 0.0192052245859863*std::sin(0.297999918460846*x_32 - 1.13655984401703) - 0.0108446496808439*std::sin(0.304799944162369*x_32 - 1.14351987838745) + 0.0305385664799533*std::sin(0.307279914617538*x_32 + 2.01071977615356) - 0.0466150805875676*std::sin(0.309519916772842*x_32 - 1.13887989521027) - 0.000199111529737244*std::sin(0.313759922981262*x_32 + 2.02247977256775) + 0.000166063034957421*std::sin(0.244079977273941*x_33 - 1.21151983737946) - 0.0346409785515925*std::sin(0.250799983739853*x_33 + 1.96807980537415) - 0.000899976592448918*std::sin(0.237599983811378*x_34 - 7.59736013412476) + 0.021127600389661*std::sin(0.249999970197678*x_38 + 1.9741598367691) + 0.00319131966493453*std::sin(0.636239886283875*x_45 + 1.76487982273102) - 0.000275689845280505*std::sin(0.199120000004768*x_48 + 1.98015987873077) - 0.0112866762329765*std::sin(0.210319995880127*x_49 + 1.96399986743927) + 0.02150663803894*std::sin(0.360239863395691*x_5 + 2.00287985801697) + 0.0354023017039136*std::sin(0.363599836826324*x_5 + 2.00503993034363) + 0.00838870493128393*std::sin(0.365839838981628*x_5 - 7.36183977127075) - 0.00169385747987812*std::sin(0.434719860553741*x_5 - 1.21343994140625) + 0.00595312312809727*std::sin(0.215199992060661*x_52 + 1.98943984508514) - 0.000450717283064172*std::sin(0.388159841299057*x_54 + 1.18415987491608) + 0.00254756425083695*std::sin(0.279439955949783*x_6 - 1.18223989009857) + 0.0220771818446675*std::sin(0.283759921789169*x_6 + 2.01319980621338) + 0.0312746078099491*std::sin(0.414239853620529*x_6 + 1.9826397895813) - 0.00704917594591649*std::sin(0.27975994348526*x_60 + 1.9385598897934) + 0.0374525865613999*std::sin(0.330479830503464*x_7 + 2.01647973060608) - 0.000218338649870012*std::sin(0.33383983373642*x_7 + 2.02191972732544) - 0.00311682793357277*std::sin(0.357119828462601*x_7 - 7.36943960189819) + 0.000153756161490812*std::sin(0.337839841842651*x_8 - 1.117919921875) + 0.00726248761274677*std::sin(0.14688004553318*x_9 + 8.17239952087402) - 0.010343077557948*std::sin(0.311599940061569*x_9 - 7.44295978546143) - 0.0160425949728694*std::sin(0.360399842262268*x_91 - 7.40751981735229) + 0.000464898272685992*std::sin(0.360479861497879*x_91 + 2.00023984909058) - 0.00242497116866215*std::sin(0.36151984333992*x_91 + 2.00871968269348) + 0.00296640979351534*std::sin(0.450719863176346*x_91 - 7.59360027313232) - 0.00417861267143981*std::sin(0.277359932661057*x_92 + 8.20584011077881) - 0.00203764578778208*std::sin(0.294319927692413*x_92 + 8.21280002593994) + 0.0331887122787968*std::sin(0.295199930667877*x_92 + 2.01071977615356) - 0.000607215111407704*std::sin(0.297759920358658*x_92 + 1.99575984477997) - 0.00428761584329218*std::sin(0.262639969587326*x_94 - 4.21704006195068) + 0.0314908483595741*std::sin(0.299999952316284*x_94 + 1.95367980003357) + 0.0493086129563167 - 1.90066789774935e-5*std::exp(-3.91279983520508*x_25) + 4.45279411768454e-7*std::exp(-3.44471979141235*x_12));
}

inline float score_3(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.00102622262282753*x_1 - 0.00159540128983746*x_10 + 0.00305177515736396*x_100 + 0.00231327927425992*x_101 + 0.00374794121284592*x_102 - 0.00115239415985761*x_103 + 0.00291858525793293*x_104 + 0.000834640945329262*x_105 + 0.00329188351103446*x_106 + 0.00237043494906739*x_107 - 0.00508174150482336*x_108 + 0.000323964320793816*x_109 + 0.00934573667497885*x_11 + 0.00209361272728718*x_110 + 0.00155271379376206*x_111 - 0.00384937605577404*x_112 - 0.0179511471549899*x_113 + 0.0017433085609359*x_114 + 0.00390883314816402*x_115 - 0.0134768518434426*x_116 + 0.00567029935333633*x_117 + 0.00514088200908646*x_118 + 0.01218670459422*x_119 + 0.00373016975845182*x_12 - 7.49601330070828e-5*x_120 - 0.000341026284862573*x_13 + 0.000798635031295015*x_14 - 0.00290586449780228*x_15 - 0.00268965216959968*x_16 - 0.000613548423819105*x_17 - 0.00270820768609746*x_18 - 0.00580926456404756*x_19 - 0.000573000008889439*x_2 - 0.000273621549482191*x_20 - 0.00028095354917692*x_21 - 0.00202811265566846*x_22 - 0.000498081581617152*x_23 - 0.00177519922985221*x_24 + 0.00288033408134429*x_25 + 0.00471683896715003*x_26 - 0.000516389980925862*x_27 + 0.00281833360244266*x_28 + 0.000514326471569251*x_29 - 0.000876831465504529*x_3 + 0.00109455463671915*x_30 - 0.00256141469757812*x_31 + 0.00102510591961796*x_32 + 0.002348439121985*x_33 - 0.000772777644141946*x_34 + 0.00204599557661073*x_35 + 0.000236503787605237*x_36 + 0.00159123636049161*x_37 - 0.00080397486686486*x_38 - 0.000148223502532108*x_39 - 0.00320498753317016*x_4 - 0.00175709487859957*x_40 + 0.00204714746736373*x_41 + 0.000858037119927677*x_42 + 0.000949100388751059*x_43 + 0.00255030527391807*x_44 + 6.84118719243716e-5*x_45 + 0.00369898766103814*x_46 + 0.000667867204275564*x_47 - 0.00617960296078284*x_48 + 0.000471699162271912*x_49 - 0.000552124466764105*x_5 + 0.00894158323980984*x_50 + 0.00684731572514723*x_51 + 0.00297599149170471*x_52 + 0.00237363034334183*x_53 + 0.00572113649633829*x_54 + 0.00611078351175213*x_55 - 0.000169353145866407*x_56 + 0.00551218841708573*x_57 + 0.00790954277923584*x_58 + 0.00762617610918513*x_59 + 0.00251670593238082*x_6 + 0.000745036501085796*x_60 + 0.000782236785334258*x_61 + 0.00231545306664944*x_62 + 0.00420487231931964*x_63 + 0.000950854587503154*x_64 - 0.00105404940634991*x_65 + 0.000688008703701408*x_66 + 0.00261210284977895*x_67 - 0.000681651314441587*x_68 - 0.00156784730240401*x_69 + 0.00162159075414335*x_7 + 1.94059660384427e-5*x_70 + 0.00233336286874658*x_71 + 0.000427588220309106*x_72 - 0.0014939403113705*x_73 - 0.00375735910825851*x_74 - 0.000343468317445385*x_75 - 8.0850723386949e-5*x_76 + 9.639593340153e-5*x_77 + 0.000637941107871769*x_78 + 0.00127074986088073*x_79 - 0.00421248895187921*x_8 + 0.000963160877215329*x_80 - 0.000161180154832087*x_81 + 0.00168530973907689*x_82 - 0.000607604679259613*x_83 + 0.00184641962956034*x_84 + 0.0016867752896794*x_85 + 0.000927472567033382*x_86 + 0.00110385152000331*x_87 + 0.00146562082191309*x_88 + 0.00112952876180693*x_89 - 0.000611182200465887*x_9 + 0.000530033552167296*x_90 + 0.0013350783686723*x_91 + 0.000699434755760306*x_92 - 0.0015782911482179*x_93 - 0.00307828226632335*x_94 + 0.00483956484199361*x_95 + 0.00454327519124946*x_96 + 0.00150848907049255*x_97 - 0.00203314234158601*x_98 - 0.00396801069521966*x_99 + 1.92005834096099e-5*std::pow(-4.55807971954346*x_27 - 8.90623950958252, 2) + 0.00382879889775177*std::exp(0.238959848880768*x_13) + 0.000575287023086863*std::exp(0.280479848384857*x_13) + 0.155422804791799*std::sin(0.32015985250473*x_1 - 4.2707200050354) + 0.103392470447542*std::sin(0.323999851942062*x_1 - 4.26488018035889) + 0.0144912140494641*std::sin(0.326559841632843*x_1 - 4.26743984222412) + 0.0205545524233445*std::sin(0.34759983420372*x_1 - 4.24240016937256) - 0.00985005206862581*std::sin(0.23471999168396*x_102 - 1.20815992355347) + 0.0476062407011747*std::sin(0.297919929027557*x_11 + 5.14599990844727) + 0.0261000116447088*std::sin(0.264239966869354*x_112 - 1.20367991924286) + 0.00268884462786689*std::sin(0.295519918203354*x_113 + 1.96943974494934) - 0.0149853028715455*std::sin(0.234159991145134*x_116 - 1.21535992622375) + 0.00298944157855277*std::sin(0.235279992222786*x_116 - 1.18783986568451) + 0.00354277504937245*std::sin(0.260479986667633*x_116 + 5.13952016830444) - 0.0025700173018357*std::sin(0.226159989833832*x_117 + 5.16584014892578) - 0.0698041178732705*std::sin(0.273359954357147*x_12 + 5.1637601852417) - 0.0293399380522952*std::sin(0.264079958200455*x_120 + 5.15824031829834) - 0.0342765918675619*std::sin(0.268879950046539*x_120 + 5.14952039718628) + 0.0578126466823409*std::sin(0.310319930315018*x_13 - 4.26487970352173) - 0.00654012995961486*std::sin(0.318079918622971*x_13 - 7.45847988128662) - 0.0367964898432957*std::sin(0.330799847841263*x_14 - 1.12391984462738) - 0.00453421097262051*std::sin(0.284719944000244*x_15 - 1.21959984302521) - 0.0452327807650973*std::sin(0.294959932565689*x_15 - 7.41695976257324) - 0.00105301996470271*std::sin(0.325199842453003*x_15 + 8.28919982910156) - 0.00454914462458491*std::sin(0.326799839735031*x_16 + 2.0383198261261) - 0.161168131669116*std::sin(0.336319833993912*x_16 - 1.1515998840332) + 0.00197288685221809*std::sin(0.348319828510284*x_17 - 7.38271999359131) + 0.145404257412743*std::sin(0.350079834461212*x_17 + 1.99031984806061) + 0.00154020002161458*std::sin(0.228959992527962*x_18 + 5.02815961837769) + 0.00603928576093697*std::sin(0.254959970712662*x_18 - 1.17047989368439) + 0.0257781903733972*std::sin(0.338399857282639*x_18 + 2.00063967704773) + 0.0801722308811214*std::sin(0.340479850769043*x_18 + 1.99655985832214) + 0.0756526107175529*std::sin(0.203599989414215*x_19 + 8.19184017181396) + 0.0180436689537708*std::sin(0.342719852924347*x_2 + 5.18183994293213) - 0.0101349887018843*std::sin(0.389759838581085*x_2 + 5.18383979797363) - 0.07952845180447*std::sin(0.395599842071533*x_2 - 7.39423990249634) + 0.0121459437614435*std::sin(0.406479865312576*x_2 - 7.39711952209473) - 0.0455767934116177*std::sin(0.372799843549728*x_22 + 2.00423979759216) + 0.0225882855990795*std::sin(0.18384000658989*x_23 - 4.41319990158081) - 0.00554826976616477*std::sin(0.227519989013672*x_23 - 4.39135980606079) + 0.00238613224837781*std::sin(0.28247994184494*x_23 + 8.24487972259521) + 0.000637826426184223*std::sin(0.332159847021103*x_23 + 5.22624015808105) + 0.0222330320959643*std::sin(0.355119854211807*x_23 + 1.99055981636047) - 0.0115913666155878*std::sin(0.359119862318039*x_23 - 1.18087983131409) + 0.00922230301062806*std::sin(0.36831983923912*x_24 + 2.01663970947266) + 0.00714285788106684*std::sin(0.313839942216873*x_25 - 1.19807994365692) - 0.16112100040686*std::sin(0.329279839992523*x_25 - 1.16103994846344) + 0.00186392630305351*std::sin(0.338479846715927*x_26 - 1.16215980052948) - 0.000698653818756666*std::sin(0.305919945240021*x_28 - 7.56744003295898) - 0.0116267788817739*std::sin(0.32575985789299*x_29 + 8.2411994934082) + 0.0944446361778127*std::sin(0.360639840364456*x_29 - 1.14991986751556) + 0.0150934987684408*std::sin(0.347679853439331*x_3 - 7.38943958282471) - 0.00409341483623635*std::sin(0.36983984708786*x_3 - 7.40488004684448) - 0.0115597409283034*std::sin(0.370719850063324*x_3 - 7.39503955841064) - 0.0103584265859091*std::sin(0.370879858732224*x_3 + 1.99631977081299) + 0.0225441313098146*std::sin(0.373519837856293*x_3 + 2.00095963478088) - 0.00545038480108106*std::sin(0.417119860649109*x_3 + 1.97791981697083) + 0.728726143248844*std::sin(0.164880022406578*x_30 + 8.16287994384766) - 0.226526864007544*std::sin(0.319759905338287*x_30 + 1.98015987873077) + 0.00613937342686224*std::sin(0.364719837903976*x_31 + 5.16336011886597) - 0.058426217218518*std::sin(0.376239836215973*x_31 + 5.17208003997803) + 0.0440702425493059*std::sin(0.37967985868454*x_31 + 5.16975975036621) - 0.00865899875208108*std::sin(0.382479846477509*x_31 - 7.40319967269897) - 0.0058268392445217*std::sin(0.383919835090637*x_31 + 1.98991990089417) + 0.00874908463368371*std::sin(0.27703994512558*x_32 - 1.15655982494354) - 0.00203852918704878*std::sin(0.297999918460846*x_32 - 1.13655984401703) - 0.0307111474965331*std::sin(0.304799944162369*x_32 - 1.14351987838745) - 0.0168037702792636*std::sin(0.307279914617538*x_32 + 2.01071977615356) - 0.00876609070455308*std::sin(0.309519916772842*x_32 - 1.13887989521027) - 0.00400596965002033*std::sin(0.313759922981262*x_32 + 2.02247977256775) + 0.00334105955043175*std::sin(0.244079977273941*x_33 - 1.21151983737946) - 0.00651432875906529*std::sin(0.250799983739853*x_33 + 1.96807980537415) - 0.00254865898738512*std::sin(0.237599983811378*x_34 - 7.59736013412476) + 0.00224257882816189*std::sin(0.249999970197678*x_38 + 1.9741598367691) - 0.00364088154674054*std::sin(0.636239886283875*x_45 + 1.76487982273102) - 0.00554666600407281*std::sin(0.199120000004768*x_48 + 1.98015987873077) + 0.0157928417762828*std::sin(0.210319995880127*x_49 + 1.96399986743927) - 0.0300930871655908*std::sin(0.360239863395691*x_5 + 2.00287985801697) - 0.0403894314951256*std::sin(0.363599836826324*x_5 + 2.00503993034363) + 0.0015775184209588*std::sin(0.365839838981628*x_5 - 7.36183977127075) - 0.00142647460214371*std::sin(0.434719860553741*x_5 - 1.21343994140625) + 0.0168587504283302*std::sin(0.215199992060661*x_52 + 1.98943984508514) - 8.47585917614827e-5*std::sin(0.388159841299057*x_54 + 1.18415987491608) + 0.0414061214239692*std::sin(0.279439955949783*x_6 - 1.18223989009857) - 0.0308914185666428*std::sin(0.283759921789169*x_6 + 2.01319980621338) - 0.0356802684820128*std::sin(0.414239853620529*x_6 + 1.9826397895813) - 0.0293867288153109*std::sin(0.27975994348526*x_60 + 1.9385598897934) - 0.0524053992041143*std::sin(0.330479830503464*x_7 + 2.01647973060608) - 0.00439280440444569*std::sin(0.33383983373642*x_7 + 2.02191972732544) - 0.00262482289053831*std::sin(0.357119828462601*x_7 - 7.36943960189819) + 0.00309345479515245*std::sin(0.337839841842651*x_8 - 1.117919921875) - 0.00828555579161135*std::sin(0.14688004553318*x_9 + 8.17239952087402) - 0.0431184038592796*std::sin(0.311599940061569*x_9 - 7.44295978546143) - 0.0668786524238599*std::sin(0.360399842262268*x_91 - 7.40751981735229) + 0.00935339291092094*std::sin(0.360479861497879*x_91 + 2.00023984909058) + 0.00339313232595751*std::sin(0.36151984333992*x_91 + 2.00871968269348) - 0.00338428857376843*std::sin(0.450719863176346*x_91 - 7.59360027313232) - 0.000443536801872003*std::sin(0.277359932661057*x_92 + 8.20584011077881) - 0.033118304623809*std::sin(0.294319927692413*x_92 + 8.21280002593994) - 0.0378640132556045*std::sin(0.295199930667877*x_92 + 2.01071977615356) - 0.0122166973984027*std::sin(0.297759920358658*x_92 + 1.99575984477997) + 0.00489161320154844*std::sin(0.262639969587326*x_94 - 4.21704006195068) + 0.00334258072424526*std::sin(0.299999952316284*x_94 + 1.95367980003357) - 1.21256465389115 - 2.0174546603719e-6*std::exp(-3.91279983520508*x_25) + 8.95867663553828e-6*std::exp(-3.44471979141235*x_12));
}

inline float score_4(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.000435335570073536*x_1 + 0.00144023223004457*x_10 + 0.000902180484927665*x_100 + 0.0013799035198486*x_101 + 0.00024991463744217*x_102 - 0.000349315535888241*x_103 + 0.000124554493650449*x_104 + 0.000505613912035211*x_105 + 0.000539238536909722*x_106 + 0.000275245459811434*x_107 + 0.00166146830312178*x_108 + 0.000923034419985716*x_109 + 0.00340152293106627*x_11 + 0.000336473664021115*x_110 + 0.000628230515643976*x_111 - 0.000532855122365456*x_112 + 0.00455106721950137*x_113 + 0.000920486641991106*x_114 + 0.000911607679795003*x_115 + 0.00450893461523118*x_116 + 0.00277522637222475*x_117 - 0.00237551354196927*x_118 + 0.00627552946335633*x_119 + 0.00205823820238438*x_12 + 0.00208953418077992*x_120 - 0.000585723038411324*x_13 + 0.00101880281020743*x_14 - 0.000167961773881032*x_15 + 0.00124737923193303*x_16 + 0.000812727355336615*x_17 + 0.000323485807323944*x_18 + 0.00414745600947169*x_19 - 0.000895129400066992*x_2 + 0.000779523738810549*x_20 - 9.42915236365575e-5*x_21 + 0.000204833858387034*x_22 - 0.000240560566988216*x_23 - 0.000312350106480289*x_24 - 0.00113547748389838*x_25 - 0.000706592519448261*x_26 + 0.000527960385762288*x_27 - 0.000224888088005961*x_28 - 0.000736601725778194*x_29 - 0.000103857909673578*x_3 - 0.000209602847613126*x_30 + 0.000446400544830487*x_31 + 2.36363292460097e-6*x_32 - 1.14248270159543e-5*x_33 - 0.00231154956638719*x_34 + 0.000712897476142916*x_35 + 0.000368758533531096*x_36 + 0.000859214334441771*x_37 + 0.000339385109414263*x_38 - 0.000617185751287441*x_39 + 0.000213622951158583*x_4 - 7.25669076327603e-5*x_40 + 0.00113074035136512*x_41 + 0.000588902459539496*x_42 + 0.000596541634807712*x_43 - 0.000764990542255444*x_44 + 0.00108067279290317*x_45 + 0.00118266385601478*x_46 - 1.56160872083163e-5*x_47 + 0.000175375154259198*x_48 + 0.000842004301015475*x_49 + 0.000511214191916973*x_5 + 0.000839593002305999*x_50 + 0.00094617270169376*x_51 + 0.00218040079298849*x_52 + 0.00358897759836915*x_53 + 0.00118812335621379*x_54 + 0.00146240636141621*x_55 + 0.000501950104174738*x_56 + 1.88202188699838e-6*x_57 - 0.000233760404804389*x_58 + 0.00305892635518037*x_59 + 0.00384117541979318*x_6 + 0.000513112995339274*x_60 - 0.000444627712320042*x_61 - 6.48000656178988e-5*x_62 - 0.000114988980160546*x_63 - 0.000397482704191858*x_64 - 0.000116879025614677*x_65 - 0.000399345374077552*x_66 - 0.000584477503373811*x_67 + 3.35867430164001e-5*x_68 - 0.000264182080169259*x_69 + 0.00141505332582395*x_7 - 0.000634082569472832*x_70 + 0.000247825189689502*x_71 - 0.000473168495693899*x_72 - 0.000180937850147208*x_73 - 0.00089290481751381*x_74 - 0.00015381665504794*x_75 - 0.000394222807660205*x_76 - 0.000412904472436408*x_77 + 0.000251838680590006*x_78 + 0.000384414515872558*x_79 + 0.00103349647627662*x_8 - 0.000365756781632669*x_80 - 0.000742855605497445*x_81 + 0.00069747899155748*x_82 - 0.000278049048201474*x_83 - 0.000433384517406624*x_84 + 4.10880723604335e-5*x_85 + 0.000394148696054706*x_86 + 4.91029564755477e-5*x_87 - 8.75179428302923e-5*x_88 - 7.73255477283434e-6*x_89 - 0.000125708135090553*x_9 + 0.000441057607896243*x_90 + 0.000186378232543603*x_91 - 7.60110254743562e-5*x_92 - 0.000597288904820106*x_93 + 0.000796302328509443*x_94 + 1.99335732079994e-5*x_95 - 0.00131918651645894*x_96 - 0.00103817281582416*x_97 - 5.08652008924958e-5*x_98 + 0.0014177795946501*x_99 - 1.87206453505695e-6*std::pow(-4.55807971954346*x_27 - 8.90623950958252, 2) + 0.00180303739131658*std::exp(0.238959848880768*x_13) + 7.66173655219022e-5*std::exp(0.280479848384857*x_13) - 0.0151537854128005*std::sin(0.32015985250473*x_1 - 4.2707200050354) + 0.0220972708771758*std::sin(0.323999851942062*x_1 - 4.26488018035889) + 0.00192995600305115*std::sin(0.326559841632843*x_1 - 4.26743984222412) + 0.00967943931524549*std::sin(0.34759983420372*x_1 - 4.24240016937256) + 0.00156696539671732*std::sin(0.23471999168396*x_102 - 1.20815992355347) + 0.0224184749151065*std::sin(0.297919929027557*x_11 + 5.14599990844727) + 0.0105337003042473*std::sin(0.264239966869354*x_112 - 1.20367991924286) + 0.00817165333639376*std::sin(0.295519918203354*x_113 + 1.96943974494934) - 0.00705679825949218*std::sin(0.234159991145134*x_116 - 1.21535992622375) + 0.00835567807136737*std::sin(0.235279992222786*x_116 - 1.18783986568451) + 0.000471830721060189*std::sin(0.260479986667633*x_116 + 5.13952016830444) - 0.00781052584499687*std::sin(0.226159989833832*x_117 + 5.16584014892578) + 0.006805929313902*std::sin(0.273359954357147*x_12 + 5.1637601852417) - 0.0138166058808321*std::sin(0.264079958200455*x_120 + 5.15824031829834) - 0.104169807132729*std::sin(0.268879950046539*x_120 + 5.14952039718628) - 0.00563675609344347*std::sin(0.310319930315018*x_13 - 4.26487970352173) + 0.00104041656484162*std::sin(0.318079918622971*x_13 - 7.45847988128662) + 0.00358767242539827*std::sin(0.330799847841263*x_14 - 1.12391984462738) + 0.000721311079983311*std::sin(0.284719944000244*x_15 - 1.21959984302521) + 0.00441021415265763*std::sin(0.294959932565689*x_15 - 7.41695976257324) - 0.00320022734622585*std::sin(0.325199842453003*x_15 + 8.28919982910156) - 0.000972253400985356*std::sin(0.326799839735031*x_16 + 2.0383198261261) - 0.0269428308045447*std::sin(0.336319833993912*x_16 - 1.1515998840332) + 0.00551434338996121*std::sin(0.348319828510284*x_17 - 7.38271999359131) + 0.0243075492974936*std::sin(0.350079834461212*x_17 + 1.99031984806061) + 0.00468081365315823*std::sin(0.228959992527962*x_18 + 5.02815961837769) + 0.0168801852364051*std::sin(0.254959970712662*x_18 - 1.17047989368439) + 0.012139326813692*std::sin(0.338399857282639*x_18 + 2.00063967704773) + 0.0134025680479292*std::sin(0.340479850769043*x_18 + 1.99655985832214) + 0.0356259206913586*std::sin(0.203599989414215*x_19 + 8.19184017181396) + 0.00849702757156825*std::sin(0.342719852924347*x_2 + 5.18183994293213) - 0.00134978906662278*std::sin(0.389759838581085*x_2 + 5.18383979797363) - 0.0132949460847154*std::sin(0.395599842071533*x_2 - 7.39423990249634) - 0.00193220030229868*std::sin(0.406479865312576*x_2 - 7.39711952209473) + 0.00444375552280367*std::sin(0.372799843549728*x_22 + 2.00423979759216) + 0.0106371540079562*std::sin(0.18384000658989*x_23 - 4.41319990158081) + 0.00459390540011713*std::sin(0.227519989013672*x_23 - 4.39135980606079) + 0.000317787746500163*std::sin(0.28247994184494*x_23 + 8.24487972259521) + 0.00178276515615542*std::sin(0.332159847021103*x_23 + 5.22624015808105) - 0.00353687388815418*std::sin(0.355119854211807*x_23 + 1.99055981636047) - 0.00247733289312641*std::sin(0.359119862318039*x_23 - 1.18087983131409) + 0.0043429173498712*std::sin(0.36831983923912*x_24 + 2.01663970947266) + 0.00336367622963593*std::sin(0.313839942216873*x_25 - 1.19807994365692) - 0.0269349517678429*std::sin(0.329279839992523*x_25 - 1.16103994846344) + 0.000248239777947114*std::sin(0.338479846715927*x_26 - 1.16215980052948) + 0.000578477558962909*std::sin(0.305919945240021*x_28 - 7.56744003295898) - 0.00547522019939931*std::sin(0.32575985789299*x_29 + 8.2411994934082) - 0.00920838966936535*std::sin(0.360639840364456*x_29 - 1.14991986751556) + 0.0421872825963456*std::sin(0.347679853439331*x_3 - 7.38943958282471) - 0.000545165540251276*std::sin(0.36983984708786*x_3 - 7.40488004684448) - 0.00247057378024734*std::sin(0.370719850063324*x_3 - 7.39503955841064) - 0.0314802388703599*std::sin(0.370879858732224*x_3 + 1.99631977081299) + 0.0106163611074519*std::sin(0.373519837856293*x_3 + 2.00095963478088) - 0.00219972009280891*std::sin(0.417119860649109*x_3 + 1.97791981697083) + 0.121822751043061*std::sin(0.164880022406578*x_30 + 8.16287994384766) + 0.0220864595257008*std::sin(0.319759905338287*x_30 + 1.98015987873077) + 0.0171599365857494*std::sin(0.364719837903976*x_31 + 5.16336011886597) - 0.0235802294063532*std::sin(0.376239836215973*x_31 + 5.17208003997803) + 0.0207533216767922*std::sin(0.37967985868454*x_31 + 5.16975975036621) - 0.0263155168241932*std::sin(0.382479846477509*x_31 - 7.40319967269897) - 0.00124532516329882*std::sin(0.383919835090637*x_31 + 1.98991990089417) - 0.00139182136078254*std::sin(0.27703994512558*x_32 - 1.15655982494354) - 0.00569781786279693*std::sin(0.297999918460846*x_32 - 1.13655984401703) - 0.00656365538266256*std::sin(0.304799944162369*x_32 - 1.14351987838745) - 0.00791314115410899*std::sin(0.307279914617538*x_32 + 2.01071977615356) - 0.00116747770896178*std::sin(0.309519916772842*x_32 - 1.13887989521027) - 0.0121745209510489*std::sin(0.313759922981262*x_32 + 2.02247977256775) + 0.0101537962214035*std::sin(0.244079977273941*x_33 - 1.21151983737946) - 0.000867585548836175*std::sin(0.250799983739853*x_33 + 1.96807980537415) - 0.000544705119957178*std::sin(0.237599983811378*x_34 - 7.59736013412476) + 0.00626814950063565*std::sin(0.249999970197678*x_38 + 1.9741598367691) - 0.00146942290979415*std::sin(0.636239886283875*x_45 + 1.76487982273102) - 0.0168568430054662*std::sin(0.199120000004768*x_48 + 1.98015987873077) - 0.00251235591516211*std::sin(0.210319995880127*x_49 + 1.96399986743927) + 0.00478726670075943*std::sin(0.360239863395691*x_5 + 2.00287985801697) - 0.016300765402717*std::sin(0.363599836826324*x_5 + 2.00503993034363) + 0.000210095657690308*std::sin(0.365839838981628*x_5 - 7.36183977127075) + 0.00118110503888634*std::sin(0.434719860553741*x_5 - 1.21343994140625) + 0.00360308998569218*std::sin(0.215199992060661*x_52 + 1.98943984508514) - 1.12882435123705e-5*std::sin(0.388159841299057*x_54 + 1.18415987491608) + 0.00692195232546837*std::sin(0.279439955949783*x_6 - 1.18223989009857) + 0.00491426680916961*std::sin(0.283759921789169*x_6 + 2.01319980621338) - 0.0144001949148861*std::sin(0.414239853620529*x_6 + 1.9826397895813) + 0.00286521777192172*std::sin(0.27975994348526*x_60 + 1.9385598897934) + 0.00833675259601555*std::sin(0.330479830503464*x_7 + 2.01647973060608) - 0.0133501483855507*std::sin(0.33383983373642*x_7 + 2.02191972732544) + 0.00217332403783427*std::sin(0.357119828462601*x_7 - 7.36943960189819) + 0.00940130193310752*std::sin(0.337839841842651*x_8 - 1.117919921875) - 0.00334396638403984*std::sin(0.14688004553318*x_9 + 8.17239952087402) + 0.00420406156163043*std::sin(0.311599940061569*x_9 - 7.44295978546143) + 0.00652069526660556*std::sin(0.360399842262268*x_91 - 7.40751981735229) + 0.0284258464007138*std::sin(0.360479861497879*x_91 + 2.00023984909058) - 0.000539786074653729*std::sin(0.36151984333992*x_91 + 2.00871968269348) - 0.00136586458521341*std::sin(0.450719863176346*x_91 - 7.59360027313232) - 0.00123971338186861*std::sin(0.277359932661057*x_92 + 8.20584011077881) - 0.00553645977509114*std::sin(0.294319927692413*x_92 + 8.21280002593994) - 0.0152815321839691*std::sin(0.295199930667877*x_92 + 2.01071977615356) - 0.037127699763957*std::sin(0.297759920358658*x_92 + 1.99575984477997) + 0.00197420553564607*std::sin(0.262639969587326*x_94 - 4.21704006195068) + 0.00934272429330175*std::sin(0.299999952316284*x_94 + 1.95367980003357) - 0.121649041840439 - 5.63891322934236e-6*std::exp(-3.91279983520508*x_25) + 2.72262662779982e-5*std::exp(-3.44471979141235*x_12));
}

inline float score_5(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.000763674904004357*x_1 - 0.00117958766512884*x_10 + 0.000760831475770435*x_100 - 0.00465007896974604*x_101 - 0.000688491493808301*x_102 + 0.00266973021021865*x_103 - 0.00239524615298709*x_104 - 0.00201298420961432*x_105 - 0.00129918731375526*x_106 - 0.000564768681440378*x_107 - 0.00265800534167165*x_108 - 0.0027442919770582*x_109 + 0.0013900410105004*x_11 + 0.000510182712650711*x_110 - 0.00155303315237951*x_111 + 0.00301625440056322*x_112 + 0.00724202599247476*x_113 + 0.00555421937270505*x_114 - 0.00236431891867934*x_115 + 0.00512584049984194*x_116 - 0.00570968541860082*x_117 + 0.0132117054497292*x_118 - 0.00332951393976507*x_119 - 0.00716884274921589*x_12 - 0.000536620531675019*x_120 + 0.00253482112068199*x_13 - 0.0039108029601842*x_14 - 0.000608614536903846*x_15 - 0.00166559205044147*x_16 - 0.00331286000432688*x_17 + 0.000427891991821025*x_18 - 0.00695308816341295*x_19 + 0.00613323818838903*x_2 + 0.000747642912961436*x_20 - 0.000533984809476159*x_21 - 0.000910361174924263*x_22 + 0.000658521249083814*x_23 + 0.00107779170974305*x_24 + 0.000318832185070721*x_25 + 1.741425110465e-5*x_26 - 0.00207115014625872*x_27 + 0.000463824512050534*x_28 + 0.0044531373183482*x_29 + 9.23046130852263e-5*x_3 - 0.000550614398164901*x_30 + 0.000827261121039209*x_31 - 1.65471321355903e-5*x_32 + 0.00290763075759842*x_33 + 0.00282110083454876*x_34 - 0.0023375234778527*x_35 - 0.000905308239666652*x_36 - 0.00108372807684664*x_37 - 0.000512291681766571*x_38 + 0.00138143608363602*x_39 + 8.45094952308799e-5*x_4 + 0.00124768965565512*x_40 - 0.00441586646954251*x_41 - 0.00211435189923051*x_42 - 0.000880018607704433*x_43 - 0.00161559021463996*x_44 - 0.00355852604333949*x_45 - 0.00342301887434883*x_46 - 0.00121623967199513*x_47 + 0.00118478818942192*x_48 - 0.00453282865850591*x_49 - 0.00268757003602841*x_5 - 0.00326784077788551*x_50 - 0.00780530199921052*x_51 - 0.00964311178353675*x_52 - 0.0123052042586969*x_53 - 0.000763187234316899*x_54 - 0.00466599884360554*x_55 + 0.0010997291170787*x_56 - 0.00328059524947037*x_57 - 0.0030372688741373*x_58 - 0.0110987788745476*x_59 - 0.0170197303015954*x_6 - 0.00165125009320854*x_60 - 0.000248418903307685*x_61 + 1.38019646359362e-5*x_62 - 0.0028694862377879*x_63 - 0.00106110287034689*x_64 - 4.30505662638723e-5*x_65 + 1.35340217786104e-5*x_66 - 0.000377406488187915*x_67 - 0.000831487391967148*x_68 - 1.60909586027647e-5*x_69 - 0.00161061773501852*x_7 + 0.00114544478656556*x_70 - 0.00241506324025871*x_71 + 0.000221096272730928*x_72 + 0.000101964810472787*x_73 + 0.00260799531796475*x_74 - 5.05432491627275e-5*x_75 + 0.00119324910186389*x_76 + 0.000920776629200465*x_77 - 0.000951909895539194*x_78 - 0.00187878201787039*x_79 + 0.00156726461201868*x_8 + 0.000296302354098923*x_80 + 0.00345608639208619*x_81 - 0.00254201647998251*x_82 + 0.000194164383234705*x_83 + 0.000500985705647433*x_84 - 0.00147882751514214*x_85 - 0.00156951226456685*x_86 - 0.000230266609169406*x_87 - 0.000478032518206744*x_88 + 0.000270442848547065*x_89 - 0.000741358728516194*x_9 - 0.000910675678028279*x_90 + 8.51875296117969e-5*x_91 - 0.000700334166542713*x_92 + 0.00933010591795226*x_93 + 0.000894073971618713*x_94 - 0.00221177207383739*x_95 + 0.000508719951977557*x_96 + 0.00674828492915693*x_97 + 0.00204561325225313*x_98 - 0.0019668747831629*x_99 - 6.35525671500624e-6*std::pow(-4.55807971954346*x_27 - 8.90623950958252, 2) - 0.00665104012622072*std::exp(0.238959848880768*x_13) - 0.00336299183645168*std::exp(0.280479848384857*x_13) - 0.0514438443221373*std::sin(0.32015985250473*x_1 - 4.2707200050354) - 0.037276881673604*std::sin(0.323999851942062*x_1 - 4.26488018035889) - 0.084712209024161*std::sin(0.326559841632843*x_1 - 4.26743984222412) - 0.0357054931833704*std::sin(0.34759983420372*x_1 - 4.24240016937256) - 0.000307119182000522*std::sin(0.23471999168396*x_102 - 1.20815992355347) - 0.0826972180095324*std::sin(0.297919929027557*x_11 + 5.14599990844727) - 0.00584243202979802*std::sin(0.264239966869354*x_112 - 1.20367991924286) - 0.0391289930575865*std::sin(0.295519918203354*x_113 + 1.96943974494934) + 0.026031100970266*std::sin(0.234159991145134*x_116 - 1.21535992622375) - 0.0120983584387328*std::sin(0.235279992222786*x_116 - 1.18783986568451) - 0.0207102247943898*std::sin(0.260479986667633*x_116 + 5.13952016830444) + 0.0373997768852803*std::sin(0.226159989833832*x_117 + 5.16584014892578) + 0.0231046671543926*std::sin(0.273359954357147*x_12 + 5.1637601852417) + 0.0509666635667992*std::sin(0.264079958200455*x_120 + 5.15824031829834) + 0.498804769648427*std::sin(0.268879950046539*x_120 + 5.14952039718628) - 0.0191355753730035*std::sin(0.310319930315018*x_13 - 4.26487970352173) - 0.000203917639153581*std::sin(0.318079918622971*x_13 - 7.45847988128662) + 0.0121793767499909*std::sin(0.330799847841263*x_14 - 1.12391984462738) - 0.000141374193276044*std::sin(0.284719944000244*x_15 - 1.21959984302521) + 0.0149717291169347*std::sin(0.294959932565689*x_15 - 7.41695976257324) + 0.0153239091843844*std::sin(0.325199842453003*x_15 + 8.28919982910156) + 0.00164013805988707*std::sin(0.326799839735031*x_16 + 2.0383198261261) + 0.000526912054195367*std::sin(0.336319833993912*x_16 - 1.1515998840332) - 0.00798433141107003*std::sin(0.348319828510284*x_17 - 7.38271999359131) - 0.000475374723083556*std::sin(0.350079834461212*x_17 + 1.99031984806061) - 0.0224135211564314*std::sin(0.228959992527962*x_18 + 5.02815961837769) - 0.0244411680007215*std::sin(0.254959970712662*x_18 - 1.17047989368439) - 0.0447795204536588*std::sin(0.338399857282639*x_18 + 2.00063967704773) - 0.000262109602100027*std::sin(0.340479850769043*x_18 + 1.99655985832214) - 0.131416813202505*std::sin(0.203599989414215*x_19 + 8.19184017181396) - 0.0313438154994875*std::sin(0.342719852924347*x_2 + 5.18183994293213) + 0.0592467462312642*std::sin(0.389759838581085*x_2 + 5.18383979797363) + 0.000260004874867582*std::sin(0.395599842071533*x_2 - 7.39423990249634) + 0.00037870381665498*std::sin(0.406479865312576*x_2 - 7.39711952209473) + 0.0150855948591991*std::sin(0.372799843549728*x_22 + 2.00423979759216) - 0.0392383089094151*std::sin(0.18384000658989*x_23 - 4.41319990158081) - 0.00561886985544571*std::sin(0.227519989013672*x_23 - 4.39135980606079) - 0.01394876461654*std::sin(0.28247994184494*x_23 + 8.24487972259521) - 0.00258130240143659*std::sin(0.332159847021103*x_23 + 5.22624015808105) + 0.000693213658479323*std::sin(0.355119854211807*x_23 + 1.99055981636047) + 0.00417912445552656*std::sin(0.359119862318039*x_23 - 1.18087983131409) - 0.0160201433968941*std::sin(0.36831983923912*x_24 + 2.01663970947266) - 0.0124079210351746*std::sin(0.313839942216873*x_25 - 1.19807994365692) + 0.000526757966473712*std::sin(0.329279839992523*x_25 - 1.16103994846344) - 0.010896072202849*std::sin(0.338479846715927*x_26 - 1.16215980052948) - 0.000707543981646996*std::sin(0.305919945240021*x_28 - 7.56744003295898) + 0.0201969795088431*std::sin(0.32575985789299*x_29 + 8.2411994934082) - 0.031260503676412*std::sin(0.360639840364456*x_29 - 1.14991986751556) - 0.061083835692006*std::sin(0.347679853439331*x_3 - 7.38943958282471) + 0.0239291347188871*std::sin(0.36983984708786*x_3 - 7.40488004684448) + 0.00416772220352847*std::sin(0.370719850063324*x_3 - 7.39503955841064) + 0.150739391100147*std::sin(0.370879858732224*x_3 + 1.99631977081299) - 0.0391616081065031*std::sin(0.373519837856293*x_3 + 2.00095963478088) + 0.00122005703177592*std::sin(0.417119860649109*x_3 + 1.97791981697083) - 0.00238244735549475*std::sin(0.164880022406578*x_30 + 8.16287994384766) + 0.0749787828266046*std::sin(0.319759905338287*x_30 + 1.98015987873077) - 0.0248462257433941*std::sin(0.364719837903976*x_31 + 5.16336011886597) + 0.0130785843126858*std::sin(0.376239836215973*x_31 + 5.17208003997803) - 0.0765548046254993*std::sin(0.37967985868454*x_31 + 5.16975975036621) + 0.126008731982636*std::sin(0.382479846477509*x_31 - 7.40319967269897) + 0.00210079511698437*std::sin(0.383919835090637*x_31 + 1.98991990089417) + 0.000272791625590376*std::sin(0.27703994512558*x_32 - 1.15655982494354) + 0.00824998788057076*std::sin(0.297999918460846*x_32 - 1.13655984401703) + 0.0110725259424931*std::sin(0.304799944162369*x_32 - 1.14351987838745) + 0.0291899766437991*std::sin(0.307279914617538*x_32 + 2.01071977615356) + 0.051244492390637*std::sin(0.309519916772842*x_32 - 1.13887989521027) + 0.0582962499952628*std::sin(0.313759922981262*x_32 + 2.02247977256775) - 0.0486202492323029*std::sin(0.244079977273941*x_33 - 1.21151983737946) + 0.0380812247756737*std::sin(0.250799983739853*x_33 + 1.96807980537415) + 0.000918887604560385*std::sin(0.237599983811378*x_34 - 7.59736013412476) - 0.0090757828100292*std::sin(0.249999970197678*x_38 + 1.9741598367691) + 0.00081500358141372*std::sin(0.636239886283875*x_45 + 1.76487982273102) + 0.0807169939522663*std::sin(0.199120000004768*x_48 + 1.98015987873077) + 0.000492412082088852*std::sin(0.210319995880127*x_49 + 1.96399986743927) - 0.000938285833392152*std::sin(0.360239863395691*x_5 + 2.00287985801697) + 0.00904108823569406*std::sin(0.363599836826324*x_5 + 2.00503993034363) - 0.00922179948205705*std::sin(0.365839838981628*x_5 - 7.36183977127075) - 0.00144462606890953*std::sin(0.434719860553741*x_5 - 1.21343994140625) - 0.00607821480772658*std::sin(0.215199992060661*x_52 + 1.98943984508514) + 0.000495478675381086*std::sin(0.388159841299057*x_54 + 1.18415987491608) - 0.000135370338228889*std::sin(0.279439955949783*x_6 - 1.18223989009857) - 0.000963177365451905*std::sin(0.283759921789169*x_6 + 2.01319980621338) + 0.00798695212281121*std::sin(0.414239853620529*x_6 + 1.9826397895813) + 0.00972679848582613*std::sin(0.27975994348526*x_60 + 1.9385598897934) - 0.00163397139668357*std::sin(0.330479830503464*x_7 + 2.01647973060608) + 0.0639256025667987*std::sin(0.33383983373642*x_7 + 2.02191972732544) - 0.00265822298430246*std::sin(0.357119828462601*x_7 - 7.36943960189819) - 0.0450170195588817*std::sin(0.337839841842651*x_8 - 1.117919921875) + 0.00185470402084676*std::sin(0.14688004553318*x_9 + 8.17239952087402) + 0.014271885380831*std::sin(0.311599940061569*x_9 - 7.44295978546143) + 0.0221363588720213*std::sin(0.360399842262268*x_91 - 7.40751981735229) - 0.136113794930073*std::sin(0.360479861497879*x_91 + 2.00023984909058) + 0.000105795991443219*std::sin(0.36151984333992*x_91 + 2.00871968269348) + 0.000757565790798127*std::sin(0.450719863176346*x_91 - 7.59360027313232) + 0.00179500654848538*std::sin(0.277359932661057*x_92 + 8.20584011077881) + 0.000108274717464774*std::sin(0.294319927692413*x_92 + 8.21280002593994) + 0.008475778740355*std::sin(0.295199930667877*x_92 + 2.01071977615356) + 0.177781587948413*std::sin(0.297759920358658*x_92 + 1.99575984477997) - 0.00109497719905819*std::sin(0.262639969587326*x_94 - 4.21704006195068) - 0.0135275230004312*std::sin(0.299999952316284*x_94 + 1.95367980003357) + 0.456532698001242 + 8.16469864812921e-6*std::exp(-3.91279983520508*x_25) - 0.000130369747751186*std::exp(-3.44471979141235*x_12));
}

inline float score_6(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.00101612842635749*x_1 - 0.000218621794972111*x_10 + 0.000678164260579912*x_100 - 0.00209091269286984*x_101 - 0.00104697307440479*x_102 + 0.0014772753251036*x_103 + 0.00100808548124161*x_104 + 0.00172294972294602*x_105 - 0.000654261685910116*x_106 + 0.00104106261730971*x_107 + 0.00175296362168833*x_108 - 0.00136939424962966*x_109 - 0.0035327701765911*x_11 - 0.00162795670379301*x_110 + 0.000446481168009635*x_111 + 0.00691528612384707*x_112 + 0.00143905411276198*x_113 + 0.00202162635993136*x_114 - 0.00210458463105865*x_115 - 0.00107471385255522*x_116 - 9.46020908994261e-5*x_117 - 0.00704275388567756*x_118 - 0.00555660650030823*x_119 - 0.0132827627394013*x_12 - 0.000257190913020982*x_120 - 0.000946697841434409*x_13 - 0.00542942412184624*x_14 + 0.00164137237333735*x_15 + 0.000424800302186992*x_16 + 0.000978438024340868*x_17 + 1.96167036193358e-5*x_18 + 0.00038839976883154*x_19 - 0.00100937873014186*x_2 - 0.0025184826601526*x_20 - 0.00623529970659845*x_21 + 0.00203083626021919*x_22 + 0.000344141495827778*x_23 + 0.000611492212138498*x_24 - 0.00466521150715049*x_25 - 0.00177870319781528*x_26 - 0.00225661718568458*x_27 - 0.003400930409803*x_28 - 0.00160230819585451*x_29 + 0.00033831267663212*x_3 - 0.00563567158387079*x_30 - 0.000785291639023706*x_31 - 0.000687984767709496*x_32 + 0.00100055133995688*x_33 - 0.0025869430630183*x_34 - 0.000415519229430752*x_35 - 0.00089928850828996*x_36 - 0.000847015548188646*x_37 - 0.000382840448026802*x_38 + 0.000327157355905145*x_39 + 0.00095062304607286*x_4 + 0.00323567065772526*x_40 - 0.00198034927977024*x_41 - 0.000364212411368315*x_42 - 0.000500657321146902*x_43 + 7.99930316296471e-5*x_44 + 8.11688605680454e-5*x_45 - 0.000993746925159674*x_46 + 0.00198836290871624*x_47 + 0.000879446190296731*x_48 + 0.00134344229062533*x_49 + 0.00157949621187424*x_5 - 0.00449172846295263*x_50 - 0.00701587449364807*x_51 + 0.000741242904441883*x_52 + 0.00652291471834497*x_53 - 0.00134799595296093*x_54 - 0.00375220468160992*x_55 + 0.00349944165075273*x_56 + 0.000806728577384604*x_57 - 0.00432499054885185*x_58 - 0.00199967076452337*x_59 + 0.00332970393945097*x_6 - 0.000399073598382409*x_60 - 0.000431855657720808*x_61 - 0.000484196649967076*x_62 - 0.000497550403870159*x_63 - 0.00087859010667155*x_64 + 0.000433732925963149*x_65 - 0.00227811452511537*x_66 - 0.00144310727790026*x_67 - 0.000419099755023591*x_68 - 0.00129101573536082*x_69 + 0.00184560681611579*x_7 - 0.00147390345664392*x_70 + 0.00150419658956472*x_71 + 0.00140822872786592*x_72 + 0.00162928203448317*x_73 - 0.00102120744082155*x_74 - 0.000386477086185498*x_75 - 0.000473233784488889*x_76 - 0.000896896711202833*x_77 - 0.000335197044504367*x_78 - 0.000389558841975344*x_79 + 0.00120015535640399*x_8 - 0.0023026132480699*x_80 - 0.00049033020538569*x_81 + 5.842495134305e-5*x_82 + 0.000299600525777968*x_83 + 8.92888796714159e-5*x_84 - 0.000723159425365574*x_85 - 0.00042770726491716*x_86 - 0.0032008422901118*x_87 + 0.000221782464192737*x_88 - 0.000593325904210955*x_89 - 0.00249833239648064*x_9 + 0.000222959949563275*x_90 - 0.000450972763978074*x_91 - 0.00193972245948032*x_92 - 0.00127880342060865*x_93 + 0.000283459036837239*x_94 + 9.64462533162337e-5*x_95 - 0.00304533274965371*x_96 - 0.00326034392311748*x_97 + 0.000332718644726797*x_98 - 0.00138852485386383*x_99 + 7.56859826924557e-7*std::pow(-4.55807971954346*x_27 - 8.90623950958252, 2) - 0.00851195858772266*std::exp(0.238959848880768*x_13) - 0.0102457245392517*std::exp(0.280479848384857*x_13) + 0.00612654702335631*std::sin(0.32015985250473*x_1 - 4.2707200050354) - 0.0547471208327367*std::sin(0.323999851942062*x_1 - 4.26488018035889) - 0.258085062641375*std::sin(0.326559841632843*x_1 - 4.26743984222412) - 0.0456956616654423*std::sin(0.34759983420372*x_1 - 4.24240016937256) + 0.00386513992339496*std::sin(0.23471999168396*x_102 - 1.20815992355347) - 0.105835370356876*std::sin(0.297919929027557*x_11 + 5.14599990844727) + 0.0168498405912774*std::sin(0.264239966869354*x_112 - 1.20367991924286) + 0.00709003739389968*std::sin(0.295519918203354*x_113 + 1.96943974494934) + 0.0333144364259965*std::sin(0.234159991145134*x_116 - 1.21535992622375) + 0.00659594132193611*std::sin(0.235279992222786*x_116 - 1.18783986568451) - 0.0630959778401314*std::sin(0.260479986667633*x_116 + 5.13952016830444) - 0.00677670944023259*std::sin(0.226159989833832*x_117 + 5.16584014892578) - 0.0027515795455331*std::sin(0.273359954357147*x_12 + 5.1637601852417) + 0.0652268098525965*std::sin(0.264079958200455*x_120 + 5.15824031829834) - 0.0903816886843497*std::sin(0.268879950046539*x_120 + 5.14952039718628) + 0.00227889272052781*std::sin(0.310319930315018*x_13 - 4.26487970352173) + 0.00256633337925345*std::sin(0.318079918622971*x_13 - 7.45847988128662) - 0.00145046555826471*std::sin(0.330799847841263*x_14 - 1.12391984462738) + 0.00177921494518719*std::sin(0.284719944000244*x_15 - 1.21959984302521) - 0.00178301220805892*std::sin(0.294959932565689*x_15 - 7.41695976257324) - 0.00277663902513697*std::sin(0.325199842453003*x_15 + 8.28919982910156) + 0.00240880761790197*std::sin(0.326799839735031*x_16 + 2.0383198261261) + 0.0617049184253318*std::sin(0.336319833993912*x_16 - 1.1515998840332) + 0.00435300224811537*std::sin(0.348319828510284*x_17 - 7.38271999359131) - 0.0556695529657773*std::sin(0.350079834461212*x_17 + 1.99031984806061) + 0.00406125204638379*std::sin(0.228959992527962*x_18 + 5.02815961837769) + 0.0133251557051097*std::sin(0.254959970712662*x_18 - 1.17047989368439) - 0.0573085436933319*std::sin(0.338399857282639*x_18 + 2.00063967704773) - 0.0306947838587151*std::sin(0.340479850769043*x_18 + 1.99655985832214) - 0.168186396485602*std::sin(0.203599989414215*x_19 + 8.19184017181396) - 0.0401136144797938*std::sin(0.342719852924347*x_2 + 5.18183994293213) + 0.180501729190327*std::sin(0.389759838581085*x_2 + 5.18383979797363) + 0.0304483062517756*std::sin(0.395599842071533*x_2 - 7.39423990249634) - 0.00476604304348765*std::sin(0.406479865312576*x_2 - 7.39711952209473) - 0.00179657269976642*std::sin(0.372799843549728*x_22 + 2.00423979759216) - 0.050216936622061*std::sin(0.18384000658989*x_23 - 4.41319990158081) - 0.00352274627241144*std::sin(0.227519989013672*x_23 - 4.39135980606079) - 0.0424964456871*std::sin(0.28247994184494*x_23 + 8.24487972259521) + 0.00140730821129746*std::sin(0.332159847021103*x_23 + 5.22624015808105) - 0.00872419550409768*std::sin(0.355119854211807*x_23 + 1.99055981636047) + 0.00613771917793672*std::sin(0.359119862318039*x_23 - 1.18087983131409) - 0.0205024769924559*std::sin(0.36831983923912*x_24 + 2.01663970947266) - 0.015879577931693*std::sin(0.313839942216873*x_25 - 1.19807994365692) + 0.0616868737246662*std::sin(0.329279839992523*x_25 - 1.16103994846344) - 0.0331960824704167*std::sin(0.338479846715927*x_26 - 1.16215980052948) - 0.00044359417250044*std::sin(0.305919945240021*x_28 - 7.56744003295898) + 0.025847965117306*std::sin(0.32575985789299*x_29 + 8.2411994934082) + 0.00372287390786863*std::sin(0.360639840364456*x_29 - 1.14991986751556) + 0.0333024846291015*std::sin(0.347679853439331*x_3 - 7.38943958282471) + 0.0729027409864434*std::sin(0.36983984708786*x_3 - 7.40488004684448) + 0.00612097312945095*std::sin(0.370719850063324*x_3 - 7.39503955841064) - 0.0273134531742441*std::sin(0.370879858732224*x_3 + 1.99631977081299) - 0.0501187754253697*std::sin(0.373519837856293*x_3 + 2.00095963478088) - 0.00351870015651718*std::sin(0.417119860649109*x_3 + 1.97791981697083) - 0.279000486993876*std::sin(0.164880022406578*x_30 + 8.16287994384766) - 0.00892936841703997*std::sin(0.319759905338287*x_30 + 1.98015987873077) + 0.0135459903841443*std::sin(0.364719837903976*x_31 + 5.16336011886597) - 0.0377192339944015*std::sin(0.376239836215973*x_31 + 5.17208003997803) - 0.0979743490186582*std::sin(0.37967985868454*x_31 + 5.16975975036621) - 0.0228323437917234*std::sin(0.382479846477509*x_31 - 7.40319967269897) + 0.00308535690086458*std::sin(0.383919835090637*x_31 + 1.98991990089417) - 0.00343312259419661*std::sin(0.27703994512558*x_32 - 1.15655982494354) - 0.00449783631742263*std::sin(0.297999918460846*x_32 - 1.13655984401703) + 0.0162617925234483*std::sin(0.304799944162369*x_32 - 1.14351987838745) + 0.0373571452965797*std::sin(0.307279914617538*x_32 + 2.01071977615356) + 0.156121982663572*std::sin(0.309519916772842*x_32 - 1.13887989521027) - 0.0105630776591221*std::sin(0.313759922981262*x_32 + 2.02247977256775) + 0.00880981998822263*std::sin(0.244079977273941*x_33 - 1.21151983737946) + 0.116018639991868*std::sin(0.250799983739853*x_33 + 1.96807980537415) + 0.00134953484465396*std::sin(0.237599983811378*x_34 - 7.59736013412476) + 0.00494805399994905*std::sin(0.249999970197678*x_38 + 1.9741598367691) - 0.00235050752120023*std::sin(0.636239886283875*x_45 + 1.76487982273102) - 0.0146256384518381*std::sin(0.199120000004768*x_48 + 1.98015987873077) - 0.0061970782314744*std::sin(0.210319995880127*x_49 + 1.96399986743927) + 0.0118084647483652*std::sin(0.360239863395691*x_5 + 2.00287985801697) - 0.0260749110586375*std::sin(0.363599836826324*x_5 + 2.00503993034363) - 0.0280952264662828*std::sin(0.365839838981628*x_5 - 7.36183977127075) - 0.000905707238324311*std::sin(0.434719860553741*x_5 - 1.21343994140625) - 0.00892684005705255*std::sin(0.215199992060661*x_52 + 1.98943984508514) + 0.00150953028431499*std::sin(0.388159841299057*x_54 + 1.18415987491608) - 0.015852770137094*std::sin(0.279439955949783*x_6 - 1.18223989009857) + 0.0121217283279695*std::sin(0.283759921789169*x_6 + 2.01319980621338) - 0.023034734403951*std::sin(0.414239853620529*x_6 + 1.9826397895813) - 0.00115838326422431*std::sin(0.27975994348526*x_60 + 1.9385598897934) + 0.020563769536858*std::sin(0.330479830503464*x_7 + 2.01647973060608) - 0.0115830967579243*std::sin(0.33383983373642*x_7 + 2.02191972732544) - 0.00166657092086129*std::sin(0.357119828462601*x_7 - 7.36943960189819) + 0.00815692730872619*std::sin(0.337839841842651*x_8 - 1.117919921875) - 0.00534905103489061*std::sin(0.14688004553318*x_9 + 8.17239952087402) - 0.00169966646252342*std::sin(0.311599940061569*x_9 - 7.44295978546143) - 0.00263626183739479*std::sin(0.360399842262268*x_91 - 7.40751981735229) + 0.0246633460375415*std::sin(0.360479861497879*x_91 + 2.00023984909058) - 0.00133145806002323*std::sin(0.36151984333992*x_91 + 2.00871968269348) - 0.0021848543119114*std::sin(0.450719863176346*x_91 - 7.59360027313232) - 0.000978625152020272*std::sin(0.277359932661057*x_92 + 8.20584011077881) + 0.0126796920956615*std::sin(0.294319927692413*x_92 + 8.21280002593994) - 0.0244445326763788*std::sin(0.295199930667877*x_92 + 2.01071977615356) - 0.0322134051506528*std::sin(0.297759920358658*x_92 + 1.99575984477997) + 0.00315796421098489*std::sin(0.262639969587326*x_94 - 4.21704006195068) + 0.00737511195372812*std::sin(0.299999952316284*x_94 + 1.95367980003357) + 1.24721395959126 - 4.45133721794345e-6*std::exp(-3.91279983520508*x_25) + 2.36225446749637e-5*std::exp(-3.44471979141235*x_12));
}

inline float score_7(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.000502543447575351*x_1 - 0.00300087427293805*x_10 - 0.00547152184441079*x_100 - 0.00297180130189062*x_101 - 0.00423945257221407*x_102 - 0.00133184161908819*x_103 + 0.000689888017975723*x_104 - 0.00103377356529718*x_105 - 0.00127821610395426*x_106 - 0.000387394088364213*x_107 - 0.000760885456853325*x_108 + 0.000191144992961357*x_109 - 0.0246170112954002*x_11 - 0.00505220298434724*x_110 - 0.00142202603002151*x_111 + 0.00404871511198951*x_112 - 0.00419426847501839*x_113 - 0.00324596769304156*x_114 - 0.00738428824675871*x_115 - 0.0112487672346381*x_116 - 0.000565350968438935*x_117 + 0.0046469938241117*x_118 - 0.0244220760307478*x_119 - 0.00362677194058957*x_12 - 0.0109493772852034*x_120 + 0.00120840268231057*x_13 - 0.000729420714070265*x_14 + 0.0047418496639719*x_15 - 0.000347739452441656*x_16 + 0.00172465873360481*x_17 - 0.00176398207132353*x_18 - 0.00353764703828996*x_19 + 0.00184801965696265*x_2 - 0.0034536752068628*x_20 + 0.00470894256044888*x_21 + 0.00237775376103605*x_22 + 0.00145872728265487*x_23 + 0.00102368365866248*x_24 + 0.00377089078021698*x_25 + 0.00119328911253192*x_26 + 0.0020578999017885*x_27 - 0.00163578129016287*x_28 - 0.00292960068072213*x_29 + 0.000722259715786749*x_3 + 0.0019510780802558*x_30 - 0.00103223774053814*x_31 - 0.00163950665661993*x_32 - 0.00588045057440109*x_33 - 0.00363607151576596*x_34 - 0.00306300224778464*x_35 - 0.00340150549693799*x_36 - 0.0057344629078843*x_37 - 0.00272565541885141*x_38 - 0.00441229622805051*x_39 + 0.00264306768074879*x_4 - 0.000315284510283367*x_40 - 0.00377521239665234*x_41 - 0.00241351686323141*x_42 - 0.00438511406970672*x_43 + 0.000332227118250617*x_44 - 0.00300404636277014*x_45 - 0.00557104982530219*x_46 - 0.000862027334647759*x_47 - 0.00366894319479802*x_48 - 0.000776421524586403*x_49 - 2.52728151677018e-5*x_5 - 0.0090757462126946*x_50 - 0.000777727349186968*x_51 - 0.000721791884437102*x_52 - 0.00522834437153353*x_53 - 0.0100957933963485*x_54 - 0.0104165042196281*x_55 - 0.00329732739153103*x_56 - 0.00278121065811527*x_57 - 0.00286612666794181*x_58 - 0.00478020186640519*x_59 - 0.0035762784286007*x_6 - 0.00264320593281226*x_60 + 0.00215626665910698*x_61 + 0.000995652558802267*x_62 - 0.00169843573674497*x_63 + 0.000574597757255052*x_64 + 0.00139035661278942*x_65 + 0.000503887863823326*x_66 + 0.000549547388785555*x_67 + 0.00155996773859592*x_68 + 0.00182709483336926*x_69 - 0.000122545567973255*x_7 + 0.00240179193199752*x_70 + 0.000238091435052936*x_71 - 0.000250756021654716*x_72 + 0.0029766148409529*x_73 + 0.000785786838338559*x_74 - 0.000220627413176313*x_75 - 0.00106249191511067*x_76 - 0.00116857410327437*x_77 - 0.000177496412312286*x_78 - 0.000763596635164073*x_79 + 0.000337461994996332*x_8 + 0.00116184263496735*x_80 - 3.58322152332587e-5*x_81 + 0.00110479304455707*x_82 + 0.00109526630979349*x_83 + 0.00115203228044943*x_84 + 0.000510281887816716*x_85 - 0.00108905532956672*x_86 - 0.00238329006658284*x_87 - 0.00112803407835356*x_88 - 0.00154547863673741*x_89 + 0.00196163530473936*x_9 - 0.00149586740413172*x_90 - 0.000635224970575777*x_91 + 0.00189846855099602*x_92 - 0.00396893897803855*x_93 - 0.0033008011458453*x_94 - 0.00178174089582192*x_95 - 0.00211636888933989*x_96 - 0.00190485150555406*x_97 - 0.00448932665626458*x_98 - 0.00635482172743883*x_99 - 6.73733790702639e-7*std::pow(-4.55807971954346*x_27 - 8.90623950958252, 2) - 0.00202078730654679*std::exp(0.238959848880768*x_13) + 0.00723204271022826*std::exp(0.280479848384857*x_13) - 0.00545366738083624*std::sin(0.32015985250473*x_1 - 4.2707200050354) + 0.117820576255177*std::sin(0.323999851942062*x_1 - 4.26488018035889) + 0.182171811153404*std::sin(0.326559841632843*x_1 - 4.26743984222412) - 0.0108484095764954*std::sin(0.34759983420372*x_1 - 4.24240016937256) - 0.0146474737412683*std::sin(0.23471999168396*x_102 - 1.20815992355347) - 0.0251259179420037*std::sin(0.297919929027557*x_11 + 5.14599990844727) - 0.0107473661224697*std::sin(0.264239966869354*x_112 - 1.20367991924286) - 0.00897084045044986*std::sin(0.295519918203354*x_113 + 1.96943974494934) + 0.00790903639398758*std::sin(0.234159991145134*x_116 - 1.21535992622375) + 0.00122720303770651*std::sin(0.235279992222786*x_116 - 1.18783986568451) + 0.0445368997414774*std::sin(0.260479986667633*x_116 + 5.13952016830444) + 0.00857439471612527*std::sin(0.226159989833832*x_117 + 5.16584014892578) + 0.00244937312258304*std::sin(0.273359954357147*x_12 + 5.1637601852417) + 0.0154852150698648*std::sin(0.264079958200455*x_120 + 5.15824031829834) + 0.114357606848047*std::sin(0.268879950046539*x_120 + 5.14952039718628) - 0.00202860156740608*std::sin(0.310319930315018*x_13 - 4.26487970352173) - 0.00972546958945217*std::sin(0.318079918622971*x_13 - 7.45847988128662) + 0.00129116069328741*std::sin(0.330799847841263*x_14 - 1.12391984462738) - 0.00674257716569564*std::sin(0.284719944000244*x_15 - 1.21959984302521) + 0.00158718369118085*std::sin(0.294959932565689*x_15 - 7.41695976257324) + 0.00351320935266549*std::sin(0.325199842453003*x_15 + 8.28919982910156) - 0.00518396396581583*std::sin(0.326799839735031*x_16 + 2.0383198261261) + 0.253851564572001*std::sin(0.336319833993912*x_16 - 1.1515998840332) + 0.000809894649041907*std::sin(0.348319828510284*x_17 - 7.38271999359131) - 0.229022312645744*std::sin(0.350079834461212*x_17 + 1.99031984806061) - 0.00513859689492175*std::sin(0.228959992527962*x_18 + 5.02815961837769) + 0.00247920209733201*std::sin(0.254959970712662*x_18 - 1.17047989368439) - 0.0136053737173022*std::sin(0.338399857282639*x_18 + 2.00063967704773) - 0.126277112191034*std::sin(0.340479850769043*x_18 + 1.99655985832214) - 0.0399284056247835*std::sin(0.203599989414215*x_19 + 8.19184017181396) - 0.00952319987522007*std::sin(0.342719852924347*x_2 + 5.18183994293213) - 0.127408872820413*std::sin(0.389759838581085*x_2 + 5.18383979797363) + 0.125263113181713*std::sin(0.395599842071533*x_2 - 7.39423990249634) + 0.018061568717523*std::sin(0.406479865312576*x_2 - 7.39711952209473) + 0.00159925483190847*std::sin(0.372799843549728*x_22 + 2.00423979759216) - 0.0119217859266718*std::sin(0.18384000658989*x_23 - 4.41319990158081) - 0.00390665144641991*std::sin(0.227519989013672*x_23 - 4.39135980606079) + 0.0299965228485881*std::sin(0.28247994184494*x_23 + 8.24487972259521) + 0.000261835699803741*std::sin(0.332159847021103*x_23 + 5.22624015808105) + 0.0330615261265157*std::sin(0.355119854211807*x_23 + 1.99055981636047) - 0.0132089066865512*std::sin(0.359119862318039*x_23 - 1.18087983131409) - 0.00486740446774274*std::sin(0.36831983923912*x_24 + 2.01663970947266) - 0.00376990197813816*std::sin(0.313839942216873*x_25 - 1.19807994365692) + 0.253777329395728*std::sin(0.329279839992523*x_25 - 1.16103994846344) + 0.0234317724743211*std::sin(0.338479846715927*x_26 - 1.16215980052948) - 0.000491936597646588*std::sin(0.305919945240021*x_28 - 7.56744003295898) + 0.00613645370460984*std::sin(0.32575985789299*x_29 + 8.2411994934082) - 0.00331399006926853*std::sin(0.360639840364456*x_29 - 1.14991986751556) + 0.00619606941682306*std::sin(0.347679853439331*x_3 - 7.38943958282471) - 0.0514590973519551*std::sin(0.36983984708786*x_3 - 7.40488004684448) - 0.0131728677304822*std::sin(0.370719850063324*x_3 - 7.39503955841064) + 0.0345590039888644*std::sin(0.370879858732224*x_3 + 1.99631977081299) - 0.0118984819011382*std::sin(0.373519837856293*x_3 + 2.00095963478088) + 0.00224433926555116*std::sin(0.417119860649109*x_3 + 1.97791981697083) - 1.14779683608932*std::sin(0.164880022406578*x_30 + 8.16287994384766) + 0.0079486544511662*std::sin(0.319759905338287*x_30 + 1.98015987873077) + 0.00252028933199872*std::sin(0.364719837903976*x_31 + 5.16336011886597) + 0.0240585313196845*std::sin(0.376239836215973*x_31 + 5.17208003997803) - 0.0232596668350403*std::sin(0.37967985868454*x_31 + 5.16975975036621) + 0.0288891724945772*std::sin(0.382479846477509*x_31 - 7.40319967269897) - 0.00663995699652178*std::sin(0.383919835090637*x_31 + 1.98991990089417) + 0.0130102852796284*std::sin(0.27703994512558*x_32 - 1.15655982494354) - 0.000836841645860413*std::sin(0.297999918460846*x_32 - 1.13655984401703) - 0.0349967950261439*std::sin(0.304799944162369*x_32 - 1.14351987838745) + 0.00886879843765189*std::sin(0.307279914617538*x_32 + 2.01071977615356) - 0.110200195437905*std::sin(0.309519916772842*x_32 - 1.13887989521027) + 0.0133651882326076*std::sin(0.313759922981262*x_32 + 2.02247977256775) - 0.0111468367683827*std::sin(0.244079977273941*x_33 - 1.21151983737946) - 0.0818928672530042*std::sin(0.250799983739853*x_33 + 1.96807980537415) - 0.00290431662259203*std::sin(0.237599983811378*x_34 - 7.59736013412476) + 0.000920606567447592*std::sin(0.249999970197678*x_38 + 1.9741598367691) + 0.00149922871775029*std::sin(0.636239886283875*x_45 + 1.76487982273102) + 0.0185054410503241*std::sin(0.199120000004768*x_48 + 1.98015987873077) + 0.0234846713100045*std::sin(0.210319995880127*x_49 + 1.96399986743927) - 0.0447497841616165*std::sin(0.360239863395691*x_5 + 2.00287985801697) + 0.0166314105014786*std::sin(0.363599836826324*x_5 + 2.00503993034363) + 0.0198312844522885*std::sin(0.365839838981628*x_5 - 7.36183977127075) - 0.0010044102580827*std::sin(0.434719860553741*x_5 - 1.21343994140625) + 0.0192113379418268*std::sin(0.215199992060661*x_52 + 1.98943984508514) - 0.0010655163963003*std::sin(0.388159841299057*x_54 + 1.18415987491608) - 0.0652176618136411*std::sin(0.279439955949783*x_6 - 1.18223989009857) - 0.0459369391281355*std::sin(0.283759921789169*x_6 + 2.01319980621338) + 0.0146922887983442*std::sin(0.414239853620529*x_6 + 1.9826397895813) + 0.00103115784446323*std::sin(0.27975994348526*x_60 + 1.9385598897934) - 0.0779292031549673*std::sin(0.330479830503464*x_7 + 2.01647973060608) + 0.0146557919464384*std::sin(0.33383983373642*x_7 + 2.02191972732544) - 0.00184819206240684*std::sin(0.357119828462601*x_7 - 7.36943960189819) - 0.0103207485923078*std::sin(0.337839841842651*x_8 - 1.117919921875) + 0.00341179547475984*std::sin(0.14688004553318*x_9 + 8.17239952087402) + 0.00151299182224952*std::sin(0.311599940061569*x_9 - 7.44295978546143) + 0.00234672077683116*std::sin(0.360399842262268*x_91 - 7.40751981735229) - 0.0312058921533172*std::sin(0.360479861497879*x_91 + 2.00023984909058) + 0.00504574151474967*std::sin(0.36151984333992*x_91 + 2.00871968269348) + 0.00139356981374197*std::sin(0.450719863176346*x_91 - 7.59360027313232) - 0.000182077386792573*std::sin(0.277359932661057*x_92 + 8.20584011077881) + 0.0521637457582879*std::sin(0.294319927692413*x_92 + 8.21280002593994) + 0.0155915031327783*std::sin(0.295199930667877*x_92 + 2.01071977615356) + 0.0407587861554647*std::sin(0.297759920358658*x_92 + 1.99575984477997) - 0.00201425036594591*std::sin(0.262639969587326*x_94 - 4.21704006195068) + 0.00137217105963946*std::sin(0.299999952316284*x_94 + 1.95367980003357) + 1.59451465793588 - 8.28190289921012e-7*std::exp(-3.91279983520508*x_25) - 2.9888993180072e-5*std::exp(-3.44471979141235*x_12));
}

inline float score_8(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.00161445818411979*x_1 - 0.00026783840562591*x_10 + 0.00226693164478221*x_100 - 0.00882538890435311*x_101 - 0.00195528692610118*x_102 - 0.00110353888064522*x_103 - 0.00250541891214381*x_104 - 0.000654997241048801*x_105 + 0.00164833283367847*x_106 + 0.000655001090686329*x_107 + 0.00511272422751018*x_108 + 0.00100944724344071*x_109 + 0.00874489259106521*x_11 - 0.00227804708372393*x_110 - 0.000903444806688601*x_111 + 0.0200749767811822*x_112 + 0.0252840778679913*x_113 + 0.00677477852257477*x_114 - 0.00162536810970796*x_115 + 0.0154690900837323*x_116 - 0.00238056090805063*x_117 - 0.00355369346538141*x_118 + 0.00736265004778105*x_119 - 0.0122720674826085*x_12 - 0.000159427180086258*x_120 - 0.000551864179296119*x_13 - 0.00883057730814852*x_14 - 0.00315250401707537*x_15 + 0.00153848915374195*x_16 + 0.00583626281237292*x_17 + 0.000220822071936093*x_18 + 0.000776267048625655*x_19 - 0.00127750161409423*x_2 + 0.00229787572341348*x_20 - 0.00110584645183285*x_21 - 0.000770713723237182*x_22 - 0.000306449748960945*x_23 - 0.00113856669253799*x_24 - 0.00170515684597816*x_25 - 0.00553362866819599*x_26 - 0.00474360167791075*x_27 - 0.00687777938271516*x_28 - 0.001218210822904*x_29 - 0.000365738142596985*x_3 - 0.0101720782871163*x_30 + 0.00164477000266086*x_31 - 0.000136656698122041*x_32 + 0.00846610808037002*x_33 + 0.0010459287622351*x_34 - 0.0018212099583765*x_35 - 0.00588627462608516*x_36 - 0.00507916835996482*x_37 - 0.00118191858303095*x_38 + 0.000825908549644718*x_39 + 0.00127248742949396*x_4 + 0.00224200646758087*x_40 - 0.0064021834649778*x_41 - 0.00203363917526364*x_42 + 0.000336077357689552*x_43 - 0.00223932037429331*x_44 - 0.000441986084323856*x_45 + 0.00129782278787718*x_46 - 6.96901637653493e-5*x_47 - 0.00116739243324351*x_48 + 0.00152147814750806*x_49 + 0.00188529278449748*x_5 - 0.00948968919888562*x_50 - 0.0173320063198831*x_51 - 0.00232451702191147*x_52 + 0.00938062974451846*x_53 + 0.00330060373169581*x_54 - 0.00312374437407513*x_55 + 0.0112963907718345*x_56 - 0.00171026930697137*x_57 - 0.00325214852514655*x_58 - 0.00343303885971422*x_59 + 0.000993074510702651*x_6 + 5.38485285619139e-5*x_60 - 0.00071392062077858*x_61 - 0.000640273753065679*x_62 - 0.000137839620104467*x_63 - 0.00207175406339118*x_64 + 0.00104900640423462*x_65 - 0.0033018920475087*x_66 - 0.00262530829523362*x_67 - 0.00175661921581095*x_68 - 0.00236222543237666*x_69 + 9.93375334183577e-5*x_7 - 0.000475262058807471*x_70 - 0.000548844966850099*x_71 - 0.000837716324733295*x_72 - 0.000259054127887344*x_73 - 0.00193616885846155*x_74 - 0.000287892660682854*x_75 - 0.000638189644710114*x_76 + 0.000249159390381695*x_77 - 0.000337623672121297*x_78 + 9.42353497953471e-6*x_79 + 0.00449484033882661*x_8 - 0.00236599877546391*x_80 + 0.000126382083066632*x_81 - 0.00128044897328175*x_82 + 0.00177370373424854*x_83 + 0.00181408581919477*x_84 - 0.00101828348077618*x_85 - 0.00153208152162449*x_86 - 0.00419481559171426*x_87 + 0.00224566409139081*x_88 - 0.000158212002748447*x_89 + 0.000983958795472015*x_9 + 0.00112973990601992*x_90 + 0.00160774676964594*x_91 + 0.00143582626568326*x_92 + 0.00295029029160502*x_93 + 0.00180295936826373*x_94 - 0.00196800673054613*x_95 - 0.00555621441242209*x_96 - 0.00485145235645112*x_97 + 0.00104658108549969*x_98 - 0.00162090150811383*x_99 - 8.98807532410225e-6*std::pow(-4.55807971954346*x_27 - 8.90623950958252, 2) - 0.0178624105413422*std::exp(0.238959848880768*x_13) + 0.00314483634890314*std::exp(0.280479848384857*x_13) - 0.0727556994884204*std::sin(0.32015985250473*x_1 - 4.2707200050354) + 0.00301954709299229*std::sin(0.323999851942062*x_1 - 4.26488018035889) + 0.0792169731866341*std::sin(0.326559841632843*x_1 - 4.26743984222412) - 0.0958926973403874*std::sin(0.34759983420372*x_1 - 4.24240016937256) - 0.0079672100783779*std::sin(0.23471999168396*x_102 - 1.20815992355347) - 0.222096338419252*std::sin(0.297919929027557*x_11 + 5.14599990844727) + 0.032639631001775*std::sin(0.264239966869354*x_112 - 1.20367991924286) + 0.0045418103171923*std::sin(0.295519918203354*x_113 + 1.96943974494934) + 0.0699106009811782*std::sin(0.234159991145134*x_116 - 1.21535992622375) - 0.00503121877345064*std::sin(0.235279992222786*x_116 - 1.18783986568451) + 0.0193667635530366*std::sin(0.260479986667633*x_116 + 5.13952016830444) - 0.00434109541915039*std::sin(0.226159989833832*x_117 + 5.16584014892578) + 0.0326763336297089*std::sin(0.273359954357147*x_12 + 5.1637601852417) + 0.136878961978228*std::sin(0.264079958200455*x_120 + 5.15824031829834) - 0.0578976475504962*std::sin(0.268879950046539*x_120 + 5.14952039718628) - 0.0270629497021699*std::sin(0.310319930315018*x_13 - 4.26487970352173) - 0.00528998110518763*std::sin(0.318079918622971*x_13 - 7.45847988128662) + 0.01722497776857*std::sin(0.330799847841263*x_14 - 1.12391984462738) - 0.00366749445656419*std::sin(0.284719944000244*x_15 - 1.21959984302521) + 0.0211741295544081*std::sin(0.294959932565689*x_15 - 7.41695976257324) - 0.00177868847099966*std::sin(0.325199842453003*x_15 + 8.28919982910156) - 0.000132856448514171*std::sin(0.326799839735031*x_16 + 2.0383198261261) - 0.071933979031605*std::sin(0.336319833993912*x_16 - 1.1515998840332) - 0.00332036104668716*std::sin(0.348319828510284*x_17 - 7.38271999359131) + 0.0648981079293521*std::sin(0.350079834461212*x_17 + 1.99031984806061) + 0.00260159931749511*std::sin(0.228959992527962*x_18 + 5.02815961837769) - 0.0101640948987432*std::sin(0.254959970712662*x_18 - 1.17047989368439) - 0.120262419562666*std::sin(0.338399857282639*x_18 + 2.00063967704773) + 0.0357831757146608*std::sin(0.340479850769043*x_18 + 1.99655985832214) - 0.3529404461422*std::sin(0.203599989414215*x_19 + 8.19184017181396) - 0.0841787284032016*std::sin(0.342719852924347*x_2 + 5.18183994293213) - 0.0554034413889357*std::sin(0.389759838581085*x_2 + 5.18383979797363) - 0.0354958385710132*std::sin(0.395599842071533*x_2 - 7.39423990249634) + 0.00982424101653344*std::sin(0.406479865312576*x_2 - 7.39711952209473) + 0.0213351669308984*std::sin(0.372799843549728*x_22 + 2.00423979759216) - 0.105380627599106*std::sin(0.18384000658989*x_23 - 4.41319990158081) - 0.0002623310625795*std::sin(0.227519989013672*x_23 - 4.39135980606079) + 0.0130439156922465*std::sin(0.28247994184494*x_23 + 8.24487972259521) - 0.001073459442273*std::sin(0.332159847021103*x_23 + 5.22624015808105) + 0.0179831777693921*std::sin(0.355119854211807*x_23 + 1.99055981636047) - 0.000338522497976912*std::sin(0.359119862318039*x_23 - 1.18087983131409) - 0.0430246056039202*std::sin(0.36831983923912*x_24 + 2.01663970947266) - 0.0333234163813086*std::sin(0.313839942216873*x_25 - 1.19807994365692) - 0.0719129429918137*std::sin(0.329279839992523*x_25 - 1.16103994846344) + 0.0101892498079768*std::sin(0.338479846715927*x_26 - 1.16215980052948) - 3.3033469238889e-5*std::sin(0.305919945240021*x_28 - 7.56744003295898) + 0.054242153533214*std::sin(0.32575985789299*x_29 + 8.2411994934082) - 0.044210922439927*std::sin(0.360639840364456*x_29 - 1.14991986751556) - 0.0254023008529895*std::sin(0.347679853439331*x_3 - 7.38943958282471) - 0.0223768645068007*std::sin(0.36983984708786*x_3 - 7.40488004684448) - 0.000337598878958136*std::sin(0.370719850063324*x_3 - 7.39503955841064) - 0.0174967375393064*std::sin(0.370879858732224*x_3 + 1.99631977081299) - 0.105174635573128*std::sin(0.373519837856293*x_3 + 2.00095963478088) - 0.00681603330859178*std::sin(0.417119860649109*x_3 + 1.97791981697083) + 0.325251466064427*std::sin(0.164880022406578*x_30 + 8.16287994384766) + 0.106040554768426*std::sin(0.319759905338287*x_30 + 1.98015987873077) - 0.0103325420587101*std::sin(0.364719837903976*x_31 + 5.16336011886597) - 0.0730654911883376*std::sin(0.376239836215973*x_31 + 5.17208003997803) - 0.205599924700789*std::sin(0.37967985868454*x_31 + 5.16975975036621) - 0.0146261816176252*std::sin(0.382479846477509*x_31 - 7.40319967269897) - 0.000170171149078556*std::sin(0.383919835090637*x_31 + 1.98991990089417) + 0.00707669307577486*std::sin(0.27703994512558*x_32 - 1.15655982494354) + 0.00343083684581389*std::sin(0.297999918460846*x_32 - 1.13655984401703) - 0.000896910149687001*std::sin(0.304799944162369*x_32 - 1.14351987838745) + 0.0783942566288503*std::sin(0.307279914617538*x_32 + 2.01071977615356) - 0.0479202894887792*std::sin(0.309519916772842*x_32 - 1.13887989521027) - 0.00676660677908172*std::sin(0.313759922981262*x_32 + 2.02247977256775) + 0.00564348664078183*std::sin(0.244079977273941*x_33 - 1.21151983737946) - 0.0356109160263821*std::sin(0.250799983739853*x_33 + 1.96807980537415) - 7.44328460580888e-5*std::sin(0.237599983811378*x_34 - 7.59736013412476) - 0.00377425161345793*std::sin(0.249999970197678*x_38 + 1.9741598367691) - 0.0045531408883825*std::sin(0.636239886283875*x_45 + 1.76487982273102) - 0.00936904446699207*std::sin(0.199120000004768*x_48 + 1.98015987873077) + 0.0127740327959283*std::sin(0.210319995880127*x_49 + 1.96399986743927) - 0.024340779691802*std::sin(0.360239863395691*x_5 + 2.00287985801697) - 0.0505094081304605*std::sin(0.363599836826324*x_5 + 2.00503993034363) + 0.00862358626599237*std::sin(0.365839838981628*x_5 - 7.36183977127075) - 6.74459991843008e-5*std::sin(0.434719860553741*x_5 - 1.21343994140625) + 0.000492354913534779*std::sin(0.215199992060661*x_52 + 1.98943984508514) - 0.000463337237859277*std::sin(0.388159841299057*x_54 + 1.18415987491608) + 0.0184807445457447*std::sin(0.279439955949783*x_6 - 1.18223989009857) - 0.0249865096777994*std::sin(0.283759921789169*x_6 + 2.01319980621338) - 0.0446203171535081*std::sin(0.414239853620529*x_6 + 1.9826397895813) + 0.0137563597150274*std::sin(0.27975994348526*x_60 + 1.9385598897934) - 0.0423880830062136*std::sin(0.330479830503464*x_7 + 2.01647973060608) - 0.00742002128302479*std::sin(0.33383983373642*x_7 + 2.02191972732544) - 0.000124105821630567*std::sin(0.357119828462601*x_7 - 7.36943960189819) + 0.00522524981874368*std::sin(0.337839841842651*x_8 - 1.117919921875) - 0.0103615847902367*std::sin(0.14688004553318*x_9 + 8.17239952087402) + 0.0201843586454928*std::sin(0.311599940061569*x_9 - 7.44295978546143) + 0.0313068802513183*std::sin(0.360399842262268*x_91 - 7.40751981735229) + 0.0157991041889524*std::sin(0.360479861497879*x_91 + 2.00023984909058) + 0.00274453351883753*std::sin(0.36151984333992*x_91 + 2.00871968269348) - 0.00423225597578301*std::sin(0.450719863176346*x_91 - 7.59360027313232) + 0.000746470745675179*std::sin(0.277359932661057*x_92 + 8.20584011077881) - 0.0147816532071141*std::sin(0.294319927692413*x_92 + 8.21280002593994) - 0.0473512210543321*std::sin(0.295199930667877*x_92 + 2.01071977615356) - 0.0206356000309694*std::sin(0.297759920358658*x_92 + 1.99575984477997) + 0.0061172558876739*std::sin(0.262639969587326*x_94 - 4.21704006195068) - 0.00562555060859841*std::sin(0.299999952316284*x_94 + 1.95367980003357) - 0.105901394375832 + 3.39536849780567e-6*std::exp(-3.91279983520508*x_25) + 1.51323767650927e-5*std::exp(-3.44471979141235*x_12));
}

inline float score_9(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.000546875224582834*x_1 - 0.00142564907735503*x_10 - 0.00250300595637848*x_100 + 0.00238502827191786*x_101 + 0.00106881104793176*x_102 - 0.000419039579214987*x_103 + 0.0031714641924355*x_104 + 0.000989700511693644*x_105 + 6.74281203122497e-5*x_106 + 0.001813132830719*x_107 - 0.00377237216656197*x_108 - 0.000420613839188026*x_109 - 0.00853194399962343*x_11 - 0.000185692743209774*x_110 + 0.000675748034502741*x_111 - 0.00702704900680206*x_112 - 0.0208873569521812*x_113 - 0.00514020317873384*x_114 - 0.000173440758027722*x_115 - 0.0168633663354402*x_116 - 0.000378226456061568*x_117 - 0.000178122192292228*x_118 - 0.0110902768764528*x_119 + 0.00491116105997871*x_12 - 0.00404848819882789*x_120 - 0.000418325255374476*x_13 + 0.00287686640634801*x_14 + 0.0018202265805025*x_15 - 0.00240239586670476*x_16 - 0.00258584126725587*x_17 - 0.000781525102028353*x_18 - 0.00443802963082841*x_19 - 0.00075369048831031*x_2 - 0.002673709662668*x_20 + 0.00114804286388415*x_21 - 1.70427636878397e-5*x_22 + 0.000523705052067002*x_23 + 0.000183742838828826*x_24 + 0.00265069149866555*x_25 + 0.00397664258143733*x_26 + 0.00124953194929163*x_27 + 0.00250755406981006*x_28 - 0.00154668133857507*x_29 + 0.000159643841760029*x_3 + 0.00247655994480363*x_30 - 0.00235504698058745*x_31 - 0.00033192187773443*x_32 - 0.00163438681500659*x_33 + 0.00131011281271349*x_34 + 0.000371554981569378*x_35 + 0.000927921861545643*x_36 - 0.000245002272284451*x_37 - 0.000523850772684803*x_38 - 0.000511761838203152*x_39 - 0.000856214294354942*x_4 - 0.00171183658021104*x_40 + 0.00251787669907102*x_41 + 0.000834902367655499*x_42 - 0.000463884266927857*x_43 + 0.0036873586363306*x_44 - 0.000160434674656056*x_45 + 0.000427661129543507*x_46 + 0.00133299855385341*x_47 - 0.00146133433231352*x_48 + 0.000746771600101486*x_49 - 0.000462683390192641*x_5 + 0.0041967519816769*x_50 + 0.00905224464690997*x_51 + 0.00220097067304176*x_52 - 0.00132684805899725*x_53 - 0.00192746987135929*x_54 + 0.00215276578706305*x_55 - 0.00534710409304789*x_56 + 0.00321413708300742*x_57 + 0.00403173742338758*x_58 + 0.00259787519169823*x_59 + 0.000672534844455362*x_6 - 0.000610494117670953*x_60 + 0.00132700543790803*x_61 + 0.000828306254110923*x_62 + 0.00271792274418347*x_63 + 0.00175390151822901*x_64 - 0.000499764656125242*x_65 + 0.00137157441158073*x_66 + 0.00223384889948892*x_67 + 0.000651269225032682*x_68 + 0.000336175781790074*x_69 + 0.000874971116399929*x_7 + 3.01596427042655e-5*x_70 + 0.00133331117966437*x_71 + 0.00122141625091485*x_72 + 0.000194845299413691*x_73 - 0.000788172928361441*x_74 - 0.000242850331831578*x_75 - 0.000273402940973556*x_76 - 0.000628085494702826*x_77 - 3.79354914932612e-5*x_78 + 0.000266132777501341*x_79 - 0.00287205926082131*x_8 + 0.00147882587539423*x_80 - 0.000830929476304771*x_81 + 0.00079290412558742*x_82 - 2.83286048117998e-5*x_83 + 0.000697879445066076*x_84 + 0.0014256651624969*x_85 + 0.000291494928469892*x_86 + 0.00034388293530457*x_87 - 0.000255651444004045*x_88 + 6.21642979152737e-5*x_89 + 0.000502011621676548*x_9 - 0.000634477191666311*x_90 - 0.00105270526936823*x_91 + 0.000251287011518357*x_92 - 0.00476651785524515*x_93 - 0.00337957821131066*x_94 + 0.00235832774434261*x_95 + 0.00335585081386037*x_96 + 4.10613395907075e-5*x_97 - 0.00257230830799012*x_98 - 0.0027679663731388*x_99 + 1.38075702273478e-5*std::pow(-4.55807971954346*x_27 - 8.90623950958252, 2) + 0.00628790475769483*std::exp(0.238959848880768*x_13) + 0.00179035059884902*std::exp(0.280479848384857*x_13) + 0.111768025289276*std::sin(0.32015985250473*x_1 - 4.2707200050354) - 0.0716149624616377*std::sin(0.323999851942062*x_1 - 4.26488018035889) + 0.0450981035732315*std::sin(0.326559841632843*x_1 - 4.26743984222412) + 0.0337560345754715*std::sin(0.34759983420372*x_1 - 4.24240016937256) - 0.00179132538040338*std::sin(0.23471999168396*x_102 - 1.20815992355347) + 0.0781820919287909*std::sin(0.297919929027557*x_11 + 5.14599990844727) + 0.00833222801282903*std::sin(0.264239966869354*x_112 - 1.20367991924286) + 0.000699128412260728*std::sin(0.295519918203354*x_113 + 1.96943974494934) - 0.0246098475625913*std::sin(0.234159991145134*x_116 - 1.21535992622375) - 0.00492461468624102*std::sin(0.235279992222786*x_116 - 1.18783986568451) + 0.0110254693338939*std::sin(0.260479986667633*x_116 + 5.13952016830444) - 0.000668232034344209*std::sin(0.226159989833832*x_117 + 5.16584014892578) - 0.0501977069723232*std::sin(0.273359954357147*x_12 + 5.1637601852417) - 0.0481839712651995*std::sin(0.264079958200455*x_120 + 5.15824031829834) - 0.00891228113432809*std::sin(0.268879950046539*x_120 + 5.14952039718628) + 0.0415743710524829*std::sin(0.310319930315018*x_13 - 4.26487970352173) - 0.00118938465565178*std::sin(0.318079918622971*x_13 - 7.45847988128662) - 0.0264611812460296*std::sin(0.330799847841263*x_14 - 1.12391984462738) - 0.000824589264987688*std::sin(0.284719944000244*x_15 - 1.21959984302521) - 0.0325279072863858*std::sin(0.294959932565689*x_15 - 7.41695976257324) - 0.000273796473166056*std::sin(0.325199842453003*x_15 + 8.28919982910156) + 0.00315097240748786*std::sin(0.326799839735031*x_16 + 2.0383198261261) + 0.0580868602101069*std::sin(0.336319833993912*x_16 - 1.1515998840332) - 0.00325000750522395*std::sin(0.348319828510284*x_17 - 7.38271999359131) - 0.0524053774577997*std::sin(0.350079834461212*x_17 + 1.99031984806061) + 0.000400468507743262*std::sin(0.228959992527962*x_18 + 5.02815961837769) - 0.00994873275533773*std::sin(0.254959970712662*x_18 - 1.17047989368439) + 0.0423346355403585*std::sin(0.338399857282639*x_18 + 2.00063967704773) - 0.0288950000207547*std::sin(0.340479850769043*x_18 + 1.99655985832214) + 0.124241680894303*std::sin(0.203599989414215*x_19 + 8.19184017181396) + 0.029632497002469*std::sin(0.342719852924347*x_2 + 5.18183994293213) - 0.0315410957723042*std::sin(0.389759838581085*x_2 + 5.18383979797363) + 0.0286629745896452*std::sin(0.395599842071533*x_2 - 7.39423990249634) + 0.00220885505754095*std::sin(0.406479865312576*x_2 - 7.39711952209473) - 0.0327752944972113*std::sin(0.372799843549728*x_22 + 2.00423979759216) + 0.0370959646300625*std::sin(0.18384000658989*x_23 - 4.41319990158081) - 0.00675599843569028*std::sin(0.227519989013672*x_23 - 4.39135980606079) + 0.00742588156585472*std::sin(0.28247994184494*x_23 + 8.24487972259521) - 0.00105071442378883*std::sin(0.332159847021103*x_23 + 5.22624015808105) + 0.0040432877308008*std::sin(0.355119854211807*x_23 + 1.99055981636047) + 0.00802877889909376*std::sin(0.359119862318039*x_23 - 1.18087983131409) + 0.0151454710801035*std::sin(0.36831983923912*x_24 + 2.01663970947266) + 0.0117304698557741*std::sin(0.313839942216873*x_25 - 1.19807994365692) + 0.058069873557635*std::sin(0.329279839992523*x_25 - 1.16103994846344) + 0.00580072457566704*std::sin(0.338479846715927*x_26 - 1.16215980052948) - 0.000850734428126382*std::sin(0.305919945240021*x_28 - 7.56744003295898) - 0.0190942591135565*std::sin(0.32575985789299*x_29 + 8.2411994934082) + 0.0679172564084061*std::sin(0.360639840364456*x_29 - 1.14991986751556) - 0.024864063654928*std::sin(0.347679853439331*x_3 - 7.38943958282471) - 0.0127391152751357*std::sin(0.36983984708786*x_3 - 7.40488004684448) + 0.00800687331546766*std::sin(0.370719850063324*x_3 - 7.39503955841064) - 0.00269330189534642*std::sin(0.370879858732224*x_3 + 1.99631977081299) + 0.0370234515592651*std::sin(0.373519837856293*x_3 + 2.00095963478088) - 0.00173999343519342*std::sin(0.417119860649109*x_3 + 1.97791981697083) - 0.262641337192204*std::sin(0.164880022406578*x_30 + 8.16287994384766) - 0.162900549240581*std::sin(0.319759905338287*x_30 + 1.98015987873077) - 0.0101136107690321*std::sin(0.364719837903976*x_31 + 5.16336011886597) - 0.0186521205591286*std::sin(0.376239836215973*x_31 + 5.17208003997803) + 0.0723750437666658*std::sin(0.37967985868454*x_31 + 5.16975975036621) - 0.00225143245041742*std::sin(0.382479846477509*x_31 - 7.40319967269897) + 0.00403596965968752*std::sin(0.383919835090637*x_31 + 1.98991990089417) + 0.00159110401147365*std::sin(0.27703994512558*x_32 - 1.15655982494354) + 0.0033581424855044*std::sin(0.297999918460846*x_32 - 1.13655984401703) + 0.021272126157716*std::sin(0.304799944162369*x_32 - 1.14351987838745) - 0.0275962540493405*std::sin(0.307279914617538*x_32 + 2.01071977615356) - 0.0272809486615027*std::sin(0.309519916772842*x_32 - 1.13887989521027) - 0.00104159503005765*std::sin(0.313759922981262*x_32 + 2.02247977256775) + 0.000868711280136312*std::sin(0.244079977273941*x_33 - 1.21151983737946) - 0.0202732408812408*std::sin(0.250799983739853*x_33 + 1.96807980537415) + 0.00176533278408998*std::sin(0.237599983811378*x_34 - 7.59736013412476) - 0.00369428080195689*std::sin(0.249999970197678*x_38 + 1.9741598367691) - 0.00116232343602398*std::sin(0.636239886283875*x_45 + 1.76487982273102) - 0.00144219258955261*std::sin(0.199120000004768*x_48 + 1.98015987873077) + 0.00287207804643584*std::sin(0.210319995880127*x_49 + 1.96399986743927) - 0.00547271328505114*std::sin(0.360239863395691*x_5 + 2.00287985801697) - 0.0128940154168149*std::sin(0.363599836826324*x_5 + 2.00503993034363) + 0.00490939467833692*std::sin(0.365839838981628*x_5 - 7.36183977127075) - 0.00173698478747485*std::sin(0.434719860553741*x_5 - 1.21343994140625) - 0.0116772408459622*std::sin(0.215199992060661*x_52 + 1.98943984508514) - 0.000263777191954593*std::sin(0.388159841299057*x_54 + 1.18415987491608) - 0.0149232454461572*std::sin(0.279439955949783*x_6 - 1.18223989009857) - 0.00561789742120739*std::sin(0.283759921789169*x_6 + 2.01319980621338) - 0.0113906513375582*std::sin(0.414239853620529*x_6 + 1.9826397895813) - 0.0211326558789015*std::sin(0.27975994348526*x_60 + 1.9385598897934) - 0.00953041882524765*std::sin(0.330479830503464*x_7 + 2.01647973060608) - 0.0011421762108614*std::sin(0.33383983373642*x_7 + 2.02191972732544) - 0.0031961854938245*std::sin(0.357119828462601*x_7 - 7.36943960189819) + 0.000804331390858755*std::sin(0.337839841842651*x_8 - 1.117919921875) - 0.00264509997192732*std::sin(0.14688004553318*x_9 + 8.17239952087402) - 0.0310074114248096*std::sin(0.311599940061569*x_9 - 7.44295978546143) - 0.0480939391451331*std::sin(0.360399842262268*x_91 - 7.40751981735229) + 0.00243198237164435*std::sin(0.360479861497879*x_91 + 2.00023984909058) + 0.000617073291816903*std::sin(0.36151984333992*x_91 + 2.00871968269348) - 0.00108040810255988*std::sin(0.450719863176346*x_91 - 7.59360027313232) + 0.000730654134222841*std::sin(0.277359932661057*x_92 + 8.20584011077881) + 0.011936220338078*std::sin(0.294319927692413*x_92 + 8.21280002593994) - 0.0120877950638936*std::sin(0.295199930667877*x_92 + 2.01071977615356) - 0.00317647221661552*std::sin(0.297759920358658*x_92 + 1.99575984477997) + 0.0015616098989032*std::sin(0.262639969587326*x_94 - 4.21704006195068) - 0.00550635350851489*std::sin(0.299999952316284*x_94 + 1.95367980003357) + 0.40784492206151 + 3.32342565935093e-6*std::exp(-3.91279983520508*x_25) + 2.32935191094694e-6*std::exp(-3.44471979141235*x_12));
}

inline float score_10(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.00151988451267603*x_1 - 0.00130737867718624*x_10 - 0.000375874227738081*x_100 + 0.000524369793998657*x_101 + 0.00013013874480465*x_102 + 0.00181124405908908*x_103 - 0.00231153114302608*x_104 - 0.00267446406614317*x_105 - 0.00134216809445976*x_106 - 0.00252561011545814*x_107 - 0.00463633720650222*x_108 - 0.0018437759212182*x_109 - 0.00142878977102099*x_11 + 0.00174962808245087*x_110 - 0.001550280072617*x_111 - 0.00727000813619488*x_112 - 0.0033831255583225*x_113 + 0.00100385618999343*x_114 - 0.000878641686611638*x_115 - 0.000833211267799405*x_116 - 0.00301721166584245*x_117 + 0.0166242714315516*x_118 - 0.00283937122434584*x_119 + 0.00284978037257559*x_12 - 0.000153139960040461*x_120 + 0.00346261550699079*x_13 + 0.00247380120985174*x_14 - 8.58551796500881e-5*x_15 - 0.00164630995942075*x_16 - 0.00356868310575355*x_17 - 0.000897507059267682*x_18 - 0.00651869727034204*x_19 + 0.00600108640214262*x_2 + 0.000929575846849307*x_20 + 0.00270793247729119*x_21 - 0.000785275893772372*x_22 + 0.000327103844732162*x_23 + 0.00105413945087034*x_24 + 0.00307087659387915*x_25 + 0.00260752027413697*x_26 + 0.00126015287691672*x_27 + 0.00390245448339568*x_28 + 0.00533792121714125*x_29 - 8.24494526614042e-6*x_3 + 0.00664748051667763*x_30 + 0.000590056312866472*x_31 + 0.000545539730264917*x_32 - 0.00304983703472375*x_33 + 0.002811982395912*x_34 - 0.00122022539606161*x_35 + 0.00176807524777686*x_36 + 0.00175291623681601*x_37 + 0.000128210579275511*x_38 + 0.000394405899218062*x_39 - 0.000829085468059598*x_4 - 0.000861160431038821*x_40 - 0.00109103918732586*x_41 - 0.00121897661068419*x_42 - 0.00118641906725838*x_43 - 0.00106055114543543*x_44 - 0.00311649811943705*x_45 - 0.00384919257907288*x_46 - 0.00235722611816335*x_47 + 0.00022060070372089*x_48 - 0.00543270899695832*x_49 - 0.00337707967850509*x_5 + 0.00185096768813205*x_50 + 0.00208849794932614*x_51 - 0.00716955738224979*x_52 - 0.0176118449091421*x_53 - 0.00204666383104293*x_54 - 0.00320335660554241*x_55 - 0.00397550063209415*x_56 - 0.00322374679574433*x_57 - 0.000119472278075402*x_58 - 0.00767678830541912*x_59 - 0.0149081744890358*x_6 - 0.000987564640456475*x_60 + 0.000364598181707344*x_61 + 0.00075500381051697*x_62 - 0.00282429905945756*x_63 + 0.000213351694758856*x_64 - 0.000194468421685948*x_65 + 0.00243122485193332*x_66 + 0.00130804932923965*x_67 + 0.00050221479428458*x_68 + 0.00197520999717351*x_69 - 0.0034491868887663*x_7 + 0.00254500260449682*x_70 - 0.00234723826015491*x_71 - 0.000515874604031861*x_72 - 0.000266053867235331*x_73 + 0.0040327986231439*x_74 + 0.000553290944321643*x_75 + 0.00162213368007188*x_76 + 0.00154468862150786*x_77 - 0.00022245572963066*x_78 - 0.00127360422933951*x_79 - 0.00157114967531046*x_8 + 0.00189553134300996*x_80 + 0.00329072489370711*x_81 - 0.00127473634719081*x_82 - 0.000918974624969587*x_83 - 0.000450778457819736*x_84 - 0.000729614434675514*x_85 - 0.000296934536784001*x_86 + 0.00316081467770117*x_87 - 0.00123166308132409*x_88 + 0.000398644128590859*x_89 - 0.000172963877431608*x_9 - 0.0012748027730909*x_90 + 0.000391433721181914*x_91 - 0.000114423775210019*x_92 + 0.0071755565222567*x_93 + 0.000291402529608343*x_94 - 0.00148202377718623*x_95 + 0.00373049578455484*x_96 + 0.00872986920440425*x_97 + 0.001545690278213*x_98 - 0.000759474780590059*x_99 - 4.45227803574073e-6*std::pow(-4.55807971954346*x_27 - 8.90623950958252, 2) + 0.00418325816000823*std::exp(0.238959848880768*x_13) - 0.000406457497865679*std::exp(0.280479848384857*x_13) - 0.0360398184401733*std::sin(0.32015985250473*x_1 - 4.2707200050354) + 0.140805462699951*std::sin(0.323999851942062*x_1 - 4.26488018035889) - 0.0102384763904049*std::sin(0.326559841632843*x_1 - 4.26743984222412) + 0.022457434157945*std::sin(0.34759983420372*x_1 - 4.24240016937256) - 0.00125254524722824*std::sin(0.23471999168396*x_102 - 1.20815992355347) + 0.0520134904440773*std::sin(0.297919929027557*x_11 + 5.14599990844727) - 0.0433251422419357*std::sin(0.264239966869354*x_112 - 1.20367991924286) - 0.034959611788508*std::sin(0.295519918203354*x_113 + 1.96943974494934) - 0.0163725993951776*std::sin(0.234159991145134*x_116 - 1.21535992622375) - 0.0102129302049721*std::sin(0.235279992222786*x_116 - 1.18783986568451) - 0.00250307659356234*std::sin(0.260479986667633*x_116 + 5.13952016830444) + 0.0334146518659956*std::sin(0.226159989833832*x_117 + 5.16584014892578) + 0.0161863488302064*std::sin(0.273359954357147*x_12 + 5.1637601852417) - 0.0320561456866982*std::sin(0.264079958200455*x_120 + 5.15824031829834) + 0.445654736872515*std::sin(0.268879950046539*x_120 + 5.14952039718628) - 0.0134057372904095*std::sin(0.310319930315018*x_13 - 4.26487970352173) - 0.000831651309058861*std::sin(0.318079918622971*x_13 - 7.45847988128662) + 0.0085324596668071*std::sin(0.330799847841263*x_14 - 1.12391984462738) - 0.000576576079407291*std::sin(0.284719944000244*x_15 - 1.21959984302521) + 0.010488687348694*std::sin(0.294959932565689*x_15 - 7.41695976257324) + 0.013691073403806*std::sin(0.325199842453003*x_15 + 8.28919982910156) - 0.00619527138660122*std::sin(0.326799839735031*x_16 + 2.0383198261261) + 0.00862186680298446*std::sin(0.336319833993912*x_16 - 1.1515998840332) - 0.00674003996885762*std::sin(0.348319828510284*x_17 - 7.38271999359131) - 0.00777856097862656*std::sin(0.350079834461212*x_17 + 1.99031984806061) - 0.0200252533278627*std::sin(0.228959992527962*x_18 + 5.02815961837769) - 0.0206322158649411*std::sin(0.254959970712662*x_18 - 1.17047989368439) + 0.0281646615843627*std::sin(0.338399857282639*x_18 + 2.00063967704773) - 0.00428890183683629*std::sin(0.340479850769043*x_18 + 1.99655985832214) + 0.0826563132620937*std::sin(0.203599989414215*x_19 + 8.19184017181396) + 0.0197141002708893*std::sin(0.342719852924347*x_2 + 5.18183994293213) + 0.00716067281782368*std::sin(0.389759838581085*x_2 + 5.18383979797363) + 0.00425446216571798*std::sin(0.395599842071533*x_2 - 7.39423990249634) + 0.00154449377785065*std::sin(0.406479865312576*x_2 - 7.39711952209473) + 0.0105684578388632*std::sin(0.372799843549728*x_22 + 2.00423979759216) + 0.0246794445402789*std::sin(0.18384000658989*x_23 - 4.41319990158081) + 0.00478766395173359*std::sin(0.227519989013672*x_23 - 4.39135980606079) - 0.00168587384093629*std::sin(0.28247994184494*x_23 + 8.24487972259521) - 0.00217902795633819*std::sin(0.332159847021103*x_23 + 5.22624015808105) + 0.00282718086049245*std::sin(0.355119854211807*x_23 + 1.99055981636047) - 0.0157857504764884*std::sin(0.359119862318039*x_23 - 1.18087983131409) + 0.0100760774732597*std::sin(0.36831983923912*x_24 + 2.01663970947266) + 0.00780412325502325*std::sin(0.313839942216873*x_25 - 1.19807994365692) + 0.00861934546417373*std::sin(0.329279839992523*x_25 - 1.16103994846344) - 0.00131691971301561*std::sin(0.338479846715927*x_26 - 1.16215980052948) + 0.000602876183706993*std::sin(0.305919945240021*x_28 - 7.56744003295898) - 0.0127031528504544*std::sin(0.32575985789299*x_29 + 8.2411994934082) - 0.0219000522159937*std::sin(0.360639840364456*x_29 - 1.14991986751556) - 0.0515644294830288*std::sin(0.347679853439331*x_3 - 7.38943958282471) + 0.00289212008144264*std::sin(0.36983984708786*x_3 - 7.40488004684448) - 0.0157426809037041*std::sin(0.370719850063324*x_3 - 7.39503955841064) + 0.134677388358592*std::sin(0.370879858732224*x_3 + 1.99631977081299) + 0.0246312025730721*std::sin(0.373519837856293*x_3 + 2.00095963478088) + 0.00904745561015844*std::sin(0.417119860649109*x_3 + 1.97791981697083) - 0.0389840080534238*std::sin(0.164880022406578*x_30 + 8.16287994384766) + 0.0525276008343178*std::sin(0.319759905338287*x_30 + 1.98015987873077) - 0.0209741487375575*std::sin(0.364719837903976*x_31 + 5.16336011886597) + 0.0969855571755537*std::sin(0.376239836215973*x_31 + 5.17208003997803) + 0.0481501396864115*std::sin(0.37967985868454*x_31 + 5.16975975036621) + 0.112581899196637*std::sin(0.382479846477509*x_31 - 7.40319967269897) - 0.00793530507929372*std::sin(0.383919835090637*x_31 + 1.98991990089417) + 0.0011125448169379*std::sin(0.27703994512558*x_32 - 1.15655982494354) + 0.00696429609378976*std::sin(0.297999918460846*x_32 - 1.13655984401703) - 0.0418241029987746*std::sin(0.304799944162369*x_32 - 1.14351987838745) - 0.018359415319752*std::sin(0.307279914617538*x_32 + 2.01071977615356) + 0.00619350541703118*std::sin(0.309519916772842*x_32 - 1.13887989521027) + 0.0520845058691093*std::sin(0.313759922981262*x_32 + 2.02247977256775) - 0.0434395292442175*std::sin(0.244079977273941*x_33 - 1.21151983737946) + 0.00460256821625597*std::sin(0.250799983739853*x_33 + 1.96807980537415) - 0.00347090176325001*std::sin(0.237599983811378*x_34 - 7.59736013412476) - 0.0076613977725744*std::sin(0.249999970197678*x_38 + 1.9741598367691) + 0.00604374101612906*std::sin(0.636239886283875*x_45 + 1.76487982273102) + 0.0721162123736141*std::sin(0.199120000004768*x_48 + 1.98015987873077) + 0.00200823800415405*std::sin(0.210319995880127*x_49 + 1.96399986743927) - 0.00382667553847199*std::sin(0.360239863395691*x_5 + 2.00287985801697) + 0.0670450989991027*std::sin(0.363599836826324*x_5 + 2.00503993034363) - 0.00111456397326577*std::sin(0.365839838981628*x_5 - 7.36183977127075) + 0.00123092086696928*std::sin(0.434719860553741*x_5 - 1.21343994140625) + 0.0229591588664902*std::sin(0.215199992060661*x_52 + 1.98943984508514) + 5.98844815673672e-5*std::sin(0.388159841299057*x_54 + 1.18415987491608) - 0.00221506609308218*std::sin(0.279439955949783*x_6 - 1.18223989009857) - 0.00392819238276216*std::sin(0.283759921789169*x_6 + 2.01319980621338) + 0.0592280466482875*std::sin(0.414239853620529*x_6 + 1.9826397895813) + 0.00681426623636829*std::sin(0.27975994348526*x_60 + 1.9385598897934) - 0.0066639377380844*std::sin(0.330479830503464*x_7 + 2.01647973060608) + 0.057114024012648*std::sin(0.33383983373642*x_7 + 2.02191972732544) + 0.00226498898978414*std::sin(0.357119828462601*x_7 - 7.36943960189819) - 0.040220240917982*std::sin(0.337839841842651*x_8 - 1.117919921875) + 0.0137537441788011*std::sin(0.14688004553318*x_9 + 8.17239952087402) + 0.00999840048312203*std::sin(0.311599940061569*x_9 - 7.44295978546143) + 0.0155079847780906*std::sin(0.360399842262268*x_91 - 7.40751981735229) - 0.121610219379089*std::sin(0.360479861497879*x_91 + 2.00023984909058) + 0.000431475056018409*std::sin(0.36151984333992*x_91 + 2.00871968269348) + 0.00561780530377656*std::sin(0.450719863176346*x_91 - 7.59360027313232) + 0.00151526975250282*std::sin(0.277359932661057*x_92 + 8.20584011077881) + 0.00177170020059159*std::sin(0.294319927692413*x_92 + 8.21280002593994) + 0.0628529895879251*std::sin(0.295199930667877*x_92 + 2.01071977615356) + 0.158838109855627*std::sin(0.297759920358658*x_92 + 1.99575984477997) - 0.00811991353239801*std::sin(0.262639969587326*x_94 - 4.21704006195068) - 0.0114193713923416*std::sin(0.299999952316284*x_94 + 1.95367980003357) - 0.195089709569888 + 6.89229847671036e-6*std::exp(-3.91279983520508*x_25) - 0.000116478227886918*std::exp(-3.44471979141235*x_12));
}

inline float score_11(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.00324904707214034*x_1 - 0.00096325619697114*x_10 + 0.0029984315031305*x_100 + 0.0041972987501538*x_101 + 0.00314170864822671*x_102 + 0.00170531922010691*x_103 - 0.00123590262533732*x_104 - 0.000960874851420538*x_105 - 0.00241173640063231*x_106 - 0.00299189548503181*x_107 - 0.0016052843064639*x_108 - 0.00370536076537322*x_109 + 0.00886135218951757*x_11 + 0.00176359425692268*x_110 + 4.9391198696255e-5*x_111 - 0.00939192438700685*x_112 - 0.0120037477790077*x_113 - 0.00112303104613857*x_114 + 0.0044352600128882*x_115 - 0.00134520339679121*x_116 - 0.00360915694060097*x_117 - 0.00168698285680359*x_118 + 0.00552340150236145*x_119 - 0.00784963699247941*x_12 - 0.00249515749829745*x_120 + 0.00042702855432324*x_13 - 0.00347026910616552*x_14 - 0.00158627520221469*x_15 - 0.000988823461309157*x_16 - 0.00346277278038289*x_17 - 0.00503282698439893*x_18 - 0.0137204049288844*x_19 + 0.000867585873435499*x_2 - 0.000830242596775064*x_20 - 0.00697782088979198*x_21 - 0.00150653002174813*x_22 - 0.00088802224475279*x_23 - 0.000121223579269098*x_24 - 0.00303831326089466*x_25 + 0.00132121098916387*x_26 - 0.000395465136588852*x_27 + 0.00324366763672096*x_28 + 0.00583484780637772*x_29 - 0.000675216390714504*x_3 + 0.00712753650593622*x_30 - 0.000706316765830405*x_31 + 0.00153435436935922*x_32 - 0.00217513132252481*x_33 + 0.0028874547258499*x_34 + 0.00206684781740656*x_35 + 0.00228756536306046*x_36 + 0.00563286301390919*x_37 - 0.00036251243402306*x_38 + 0.0027013170754963*x_39 - 0.00227142815149198*x_4 + 0.00132092494944689*x_40 + 0.00202535333738481*x_41 + 6.99372927699797e-5*x_42 + 0.000647154543056685*x_43 - 0.000612273782409397*x_44 - 0.000515540258885336*x_45 - 0.00151043491103677*x_46 - 0.00104768882762515*x_47 - 0.00561922982264116*x_48 - 0.00208069413444689*x_49 - 0.00107428798480908*x_5 + 0.00556889971446239*x_50 + 0.00205573421441332*x_51 - 0.000822216892619107*x_52 - 0.0060953561722429*x_53 + 0.0029072761510084*x_54 + 0.00298069329902609*x_55 - 0.00217980890700701*x_56 + 0.00194759395271214*x_57 + 0.000628563652022296*x_58 - 0.00392715146743101*x_59 - 0.00289316963924946*x_6 + 0.00179761072721307*x_60 - 0.00108482805398778*x_61 - 0.000853929832538744*x_62 - 0.000180247917224806*x_63 + 0.0015794799661593*x_64 + 0.000661213780948667*x_65 - 0.000163698715166917*x_66 + 2.19800360325627e-5*x_67 - 0.000671100855276818*x_68 - 0.000186733055905053*x_69 - 0.00349312695793961*x_7 - 0.000682887813828323*x_70 + 0.000145053337511518*x_71 + 0.000601240849806735*x_72 - 0.00134846618733976*x_73 + 0.00115454921046031*x_74 + 0.000241864654056094*x_75 + 0.00191030502336441*x_76 + 0.00182703140170541*x_77 - 9.30254175180676e-6*x_78 + 0.000299577742907603*x_79 - 0.00364385720741067*x_8 - 0.000502119162488331*x_80 + 0.00141221370285601*x_81 - 0.000927925979221737*x_82 - 0.00111657467129607*x_83 - 0.00163153661978352*x_84 - 0.000257664702662555*x_85 + 7.19954287895791e-5*x_86 + 0.00260525173581652*x_87 + 0.000113978336818582*x_88 + 0.00107388114616153*x_89 - 0.00469001469613602*x_9 - 5.928193491422e-5*x_90 - 0.000697561093584058*x_91 - 0.0048694029622869*x_92 + 0.00402915693567924*x_93 + 0.00131713694191683*x_94 + 0.00135446463309234*x_95 + 0.0035202791034553*x_96 + 0.00446958520963459*x_97 + 0.00222495677828851*x_98 + 0.00337200768562601*x_99 - 2.5629974555903e-7*std::pow(-4.55807971954346*x_27 - 8.90623950958252, 2) + 0.00361555165497078*std::exp(0.238959848880768*x_13) - 0.0161113503942619*std::exp(0.280479848384857*x_13) - 0.00207466744485855*std::sin(0.32015985250473*x_1 - 4.2707200050354) - 0.128045252162198*std::sin(0.323999851942062*x_1 - 4.26488018035889) - 0.405837465160264*std::sin(0.326559841632843*x_1 - 4.26743984222412) + 0.0194097543422938*std::sin(0.34759983420372*x_1 - 4.24240016937256) - 0.0126597846121173*std::sin(0.23471999168396*x_102 - 1.20815992355347) + 0.0449547826748327*std::sin(0.297919929027557*x_11 + 5.14599990844727) - 0.0505405829184012*std::sin(0.264239966869354*x_112 - 1.20367991924286) - 0.00593427719361107*std::sin(0.295519918203354*x_113 + 1.96943974494934) - 0.0141506874725828*std::sin(0.234159991145134*x_116 - 1.21535992622375) - 0.00634439572788039*std::sin(0.235279992222786*x_116 - 1.18783986568451) - 0.0992181083491425*std::sin(0.260479986667633*x_116 + 5.13952016830444) + 0.00567202541322311*std::sin(0.226159989833832*x_117 + 5.16584014892578) + 0.000931783022850097*std::sin(0.273359954357147*x_12 + 5.1637601852417) - 0.027705832668309*std::sin(0.264079958200455*x_120 + 5.15824031829834) + 0.0756484012822093*std::sin(0.268879950046539*x_120 + 5.14952039718628) - 0.000771714396311622*std::sin(0.310319930315018*x_13 - 4.26487970352173) - 0.00840570547720266*std::sin(0.318079918622971*x_13 - 7.45847988128662) + 0.000491179397162584*std::sin(0.330799847841263*x_14 - 1.12391984462738) - 0.00582759704206138*std::sin(0.284719944000244*x_15 - 1.21959984302521) + 0.000603791559542896*std::sin(0.294959932565689*x_15 - 7.41695976257324) + 0.00232401392634939*std::sin(0.325199842453003*x_15 + 8.28919982910156) + 0.00563383743570399*std::sin(0.326799839735031*x_16 + 2.0383198261261) - 0.10671830728546*std::sin(0.336319833993912*x_16 - 1.1515998840332) - 0.00418699432248594*std::sin(0.348319828510284*x_17 - 7.38271999359131) + 0.09628017687172*std::sin(0.350079834461212*x_17 + 1.99031984806061) - 0.003399219786499*std::sin(0.228959992527962*x_18 + 5.02815961837769) - 0.0128169819594489*std::sin(0.254959970712662*x_18 - 1.17047989368439) + 0.0243424586549624*std::sin(0.338399857282639*x_18 + 2.00063967704773) + 0.0530864550102112*std::sin(0.340479850769043*x_18 + 1.99655985832214) + 0.0714390933520485*std::sin(0.203599989414215*x_19 + 8.19184017181396) + 0.0170387160281147*std::sin(0.342719852924347*x_2 + 5.18183994293213) + 0.283838062853867*std::sin(0.389759838581085*x_2 + 5.18383979797363) - 0.0526601733835985*std::sin(0.395599842071533*x_2 - 7.39423990249634) + 0.0156105806202318*std::sin(0.406479865312576*x_2 - 7.39711952209473) + 0.000608383625934385*std::sin(0.372799843549728*x_22 + 2.00423979759216) + 0.0213302175334046*std::sin(0.18384000658989*x_23 - 4.41319990158081) + 0.00269615397372016*std::sin(0.227519989013672*x_23 - 4.39135980606079) - 0.0668254474686078*std::sin(0.28247994184494*x_23 + 8.24487972259521) - 0.00135363851310699*std::sin(0.332159847021103*x_23 + 5.22624015808105) + 0.0285750162180072*std::sin(0.355119854211807*x_23 + 1.99055981636047) + 0.0143551987371311*std::sin(0.359119862318039*x_23 - 1.18087983131409) + 0.00870866133300901*std::sin(0.36831983923912*x_24 + 2.01663970947266) + 0.00674503214265882*std::sin(0.313839942216873*x_25 - 1.19807994365692) - 0.106687099077757*std::sin(0.329279839992523*x_25 - 1.16103994846344) - 0.052200673007432*std::sin(0.338479846715927*x_26 - 1.16215980052948) + 0.000339507332751349*std::sin(0.305919945240021*x_28 - 7.56744003295898) - 0.010979218483546*std::sin(0.32575985789299*x_29 + 8.2411994934082) - 0.00126069795408786*std::sin(0.360639840364456*x_29 - 1.14991986751556) - 0.032032447060438*std::sin(0.347679853439331*x_3 - 7.38943958282471) + 0.114639194157029*std::sin(0.36983984708786*x_3 - 7.40488004684448) + 0.0143160322573516*std::sin(0.370719850063324*x_3 - 7.39503955841064) + 0.0228610363028748*std::sin(0.370879858732224*x_3 + 1.99631977081299) + 0.0212885224436677*std::sin(0.373519837856293*x_3 + 2.00095963478088) + 0.0105542337959867*std::sin(0.417119860649109*x_3 + 1.97791981697083) + 0.482529763649797*std::sin(0.164880022406578*x_30 + 8.16287994384766) + 0.00302380278603201*std::sin(0.319759905338287*x_30 + 1.98015987873077) - 0.013029394794229*std::sin(0.364719837903976*x_31 + 5.16336011886597) + 0.113137691895998*std::sin(0.376239836215973*x_31 + 5.17208003997803) + 0.0416157240532191*std::sin(0.37967985868454*x_31 + 5.16975975036621) + 0.0191104009065581*std::sin(0.382479846477509*x_31 - 7.40319967269897) + 0.00721618409100609*std::sin(0.383919835090637*x_31 + 1.98991990089417) + 0.011244765636155*std::sin(0.27703994512558*x_32 - 1.15655982494354) + 0.00432630493877486*std::sin(0.297999918460846*x_32 - 1.13655984401703) + 0.0380338781766435*std::sin(0.304799944162369*x_32 - 1.14351987838745) - 0.0158678742512737*std::sin(0.307279914617538*x_32 + 2.01071977615356) + 0.245501033851083*std::sin(0.309519916772842*x_32 - 1.13887989521027) + 0.00884117069690001*std::sin(0.313759922981262*x_32 + 2.02247977256775) - 0.00737371482425615*std::sin(0.244079977273941*x_33 - 1.21151983737946) + 0.182438728858431*std::sin(0.250799983739853*x_33 + 1.96807980537415) + 0.00315635830445462*std::sin(0.237599983811378*x_34 - 7.59736013412476) - 0.00475935293029314*std::sin(0.249999970197678*x_38 + 1.9741598367691) + 0.0070502756172686*std::sin(0.636239886283875*x_45 + 1.76487982273102) + 0.0122414858885541*std::sin(0.199120000004768*x_48 + 1.98015987873077) + 0.0202977582156964*std::sin(0.210319995880127*x_49 + 1.96399986743927) - 0.0386771561384446*std::sin(0.360239863395691*x_5 + 2.00287985801697) + 0.0782109004123878*std::sin(0.363599836826324*x_5 + 2.00503993034363) - 0.0441796025522938*std::sin(0.365839838981628*x_5 - 7.36183977127075) + 0.000693188206246718*std::sin(0.434719860553741*x_5 - 1.21343994140625) - 0.0208785314867811*std::sin(0.215199992060661*x_52 + 1.98943984508514) + 0.00237372879274431*std::sin(0.388159841299057*x_54 + 1.18415987491608) + 0.0274172762559172*std::sin(0.279439955949783*x_6 - 1.18223989009857) - 0.0397032119923624*std::sin(0.283759921789169*x_6 + 2.01319980621338) + 0.0690919832647494*std::sin(0.414239853620529*x_6 + 1.9826397895813) + 0.000392269909590701*std::sin(0.27975994348526*x_60 + 1.9385598897934) - 0.0673540669444061*std::sin(0.330479830503464*x_7 + 2.01647973060608) + 0.00969491458269072*std::sin(0.33383983373642*x_7 + 2.02191972732544) + 0.00127551957004578*std::sin(0.357119828462601*x_7 - 7.36943960189819) - 0.00682725139641232*std::sin(0.337839841842651*x_8 - 1.117919921875) + 0.0160443154283369*std::sin(0.14688004553318*x_9 + 8.17239952087402) + 0.000575567715953552*std::sin(0.311599940061569*x_9 - 7.44295978546143) + 0.000892732331820032*std::sin(0.360399842262268*x_91 - 7.40751981735229) - 0.0206429280661691*std::sin(0.360479861497879*x_91 + 2.00023984909058) + 0.00436102511009643*std::sin(0.36151984333992*x_91 + 2.00871968269348) + 0.00655340386857708*std::sin(0.450719863176346*x_91 - 7.59360027313232) + 0.000941303891383201*std::sin(0.277359932661057*x_92 + 8.20584011077881) - 0.0219294557367781*std::sin(0.294319927692413*x_92 + 8.21280002593994) + 0.0733206301827945*std::sin(0.295199930667877*x_92 + 2.01071977615356) + 0.0269622379817842*std::sin(0.297759920358658*x_92 + 1.99575984477997) - 0.00947221733012998*std::sin(0.262639969587326*x_94 - 4.21704006195068) - 0.00709385158055618*std::sin(0.299999952316284*x_94 + 1.95367980003357) - 0.0829951988815407 + 4.28157914852186e-6*std::exp(-3.91279983520508*x_25) - 1.97717896721264e-5*std::exp(-3.44471979141235*x_12));
}

int predict(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120)
{
    float s0 = score_0(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s1 = score_1(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s2 = score_2(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s3 = score_3(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s4 = score_4(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s5 = score_5(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s6 = score_6(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s7 = score_7(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s8 = score_8(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s9 = score_9(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s10 = score_10(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s11 = score_11(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);

    float max_score = s0;
    int max_index = 0;

    if(s1 > max_score) {
        max_score = s1;
        max_index = 1;
    }

    if(s2 > max_score) {
        max_score = s2;
        max_index = 2;
    }

    if(s3 > max_score) {
        max_score = s3;
        max_index = 3;
    }

    if(s4 > max_score) {
        max_score = s4;
        max_index = 4;
    }

    if(s5 > max_score) {
        max_score = s5;
        max_index = 5;
    }

    if(s6 > max_score) {
        max_score = s6;
        max_index = 6;
    }

    if(s7 > max_score) {
        max_score = s7;
        max_index = 7;
    }

    if(s8 > max_score) {
        max_score = s8;
        max_index = 8;
    }

    if(s9 > max_score) {
        max_score = s9;
        max_index = 9;
    }

    if(s10 > max_score) {
        max_score = s10;
        max_index = 10;
    }

    if(s11 > max_score) {
        max_score = s11;
        max_index = 11;
    }

    return max_index;
}

#endif
