
#ifndef KAN_MODEL_H
#define KAN_MODEL_H

#include <cmath>


inline float score_0(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.00149655545188214*x_10 + 9.62363162325313e-5*x_100 - 0.00182490668895558*x_101 + 0.000710842360826571*x_102 + 0.00573266816692734*x_103 + 0.00148660818707242*x_104 - 0.00233856333582527*x_105 - 0.00208335512489176*x_106 - 0.00124281965178601*x_107 - 0.0021428467261029*x_108 - 0.00143718382530422*x_109 + 9.0093546191049e-5*x_11 + 0.000948131925643266*x_110 - 0.00121880444474772*x_111 + 0.000481377616642104*x_112 + 0.000629738692444034*x_113 - 0.00592784023930446*x_114 + 0.00196444289742561*x_115 - 0.00341102526950165*x_116 - 0.00226486875601804*x_117 + 0.00135836811560495*x_118 - 0.00470607844524617*x_119 - 0.00795074455102899*x_120 + 0.00119690779211237*x_14 - 0.00067603516937302*x_15 - 0.00219414664672978*x_16 - 0.00133321856155516*x_19 - 0.000459108812364458*x_2 - 0.000571950234274628*x_21 - 0.00091010863883156*x_22 - 0.00102126620335726*x_23 + 0.000483286223892168*x_24 - 0.000870048744179656*x_26 + 0.00126365792664568*x_27 - 0.000300414340086098*x_28 - 0.000750534240219838*x_29 - 0.000154726501824414*x_31 - 0.00124573371704514*x_32 - 0.00572950316678052*x_33 + 0.00435135311205298*x_34 + 0.00249543708055345*x_35 - 0.000515930412664609*x_36 + 0.00067040764654094*x_37 - 0.00185144605978838*x_38 + 0.000648817601836351*x_39 + 0.000303728352132843*x_4 - 0.00202807675238829*x_40 + 0.00145814175016062*x_41 - 0.00205470295451122*x_42 - 0.000970487000472631*x_43 - 0.000311348733803744*x_44 - 0.00426664355770904*x_45 - 0.0110453954290129*x_46 + 0.00310764216558091*x_47 + 0.0014928077090954*x_48 - 0.000302556793601521*x_49 + 0.00141332416778778*x_50 + 0.00346143280141526*x_51 + 0.00137986362474639*x_52 - 0.00346755790321682*x_53 + 0.00947520339505417*x_54 + 0.0093055721706571*x_55 - 0.00603671292184448*x_56 + 0.0069323783514789*x_57 + 0.00881809099608882*x_58 + 0.00301253501785332*x_59 - 0.000918953214461613*x_6 - 0.00167201018056789*x_60 - 0.000346613024962493*x_61 - 0.00200439488344819*x_62 - 8.69232668279304e-5*x_63 + 0.00174016255814116*x_64 - 0.00199931792454284*x_65 + 7.64079766380503e-5*x_66 - 0.000964404415481377*x_67 + 0.00122826245468068*x_68 - 0.00142474046146954*x_69 + 8.91291763764759e-5*x_70 - 0.000462173183522037*x_71 + 0.00113545537391349*x_72 + 0.00209904641654096*x_73 + 0.00406900954501181*x_74 + 0.00115820354406634*x_75 - 0.000490770067594536*x_76 + 0.00345829971307671*x_77 + 0.000215292525228703*x_78 + 0.000552865721149233*x_79 + 0.00140553836902663*x_80 + 0.000344641399772449*x_81 + 0.00171196585627759*x_82 - 0.000899473645471115*x_83 + 0.000907117467608035*x_84 + 0.000956067792884736*x_85 + 0.000387239276688179*x_86 + 0.00125158512348575*x_87 - 0.00230524665731557*x_88 + 0.00126324180711248*x_89 + 0.0004666188101746*x_9 - 3.12560031664108e-5*x_90 + 0.000408330356572504*x_91 - 0.00665302601616568*x_93 + 8.80752691918287e-5*x_94 + 0.000981953021196084*x_95 + 0.00227113776010649*x_96 + 0.00152182676565663*x_98 - 0.000246234742973621*x_99 - 4.43357310231376e-5*std::pow(-3.08031988143921*x_22 - 8.18991947174072, 2) + 1.4931279743397e-6*std::pow(-7.29407978057861*x_24 - 1.18351984024048, 2) + 6.00618671290492e-6*std::pow(-5.27952003479004*x_55 - 8.32055950164795, 2) - 3.6968841010083e-5*std::pow(-2.59631991386414*x_56 - 9.37975978851318, 2) + 6.80579681367734e-6*std::pow(-3.85775995254517*x_59 - 9.14136028289795, 2) - 2.30116233042833e-5*std::pow(-2.80672001838684*x_59 - 8.59552001953125, 2) + 1.24251296027203e-5*std::pow(-4.6854395866394*x_61 - 8.77040004730225, 2) + 3.56473351439861e-6*std::pow(-3.75288009643555*x_65 - 9.44944000244141, 2) + 0.000386196540819479*std::exp(0.299919843673706*x_10) - 0.00593580788898472*std::exp(0.228399842977524*x_18) + 0.00110569613510943*std::exp(0.331679850816727*x_30) + 0.050575187714567*std::sin(0.31879985332489*x_1 - 4.26864004135132) + 0.0683352083087834*std::sin(0.326959848403931*x_1 - 4.2611198425293) + 0.100902564239109*std::sin(0.358239859342575*x_1 + 8.35488033294678) + 0.00835589790321363*std::sin(0.361999839544296*x_1 + 5.17400026321411) - 0.0015415705693194*std::sin(0.365919858217239*x_1 - 4.23160028457642) + 0.011560038689865*std::sin(0.263839960098267*x_10 + 1.99799978733063) - 0.00786693326265885*std::sin(0.243119969964027*x_100 - 7.42335987091064) + 0.0109230456730025*std::sin(0.250079959630966*x_100 - 1.2054398059845) + 0.0142447777722388*std::sin(0.2291199862957*x_101 - 7.40719985961914) - 0.03961187907438*std::sin(0.237119987607002*x_101 + 1.98511981964111) - 0.0101600500478358*std::sin(0.220159992575645*x_102 + 2.00143980979919) + 0.00555067784252785*std::sin(0.239199981093407*x_106 + 8.17751979827881) - 0.0154929907183077*std::sin(0.246319979429245*x_108 - 1.19671988487244) + 0.0233011728258475*std::sin(0.256719976663589*x_108 + 1.97239983081818) + 0.00985844334211332*std::sin(0.23479999601841*x_109 - 7.42360019683838) - 0.0454761169628067*std::sin(0.274879962205887*x_11 - 7.44007968902588) + 0.0732876488606124*std::sin(0.286479949951172*x_11 - 7.44456005096436) + 0.00218195367444581*std::sin(0.292959928512573*x_11 - 7.44855976104736) + 0.0318781433450068*std::sin(0.293119937181473*x_11 - 7.43735980987549) - 0.0029081261933909*std::sin(0.231119990348816*x_112 - 4.20911979675293) - 0.074924381029596*std::sin(0.281519949436188*x_112 + 5.14000034332275) - 0.0539913001300511*std::sin(0.292479932308197*x_113 - 7.43639993667603) - 0.0480034676255091*std::sin(0.251439958810806*x_116 - 7.41999959945679) - 0.0105412248107981*std::sin(0.219679996371269*x_118 - 4.21519994735718) - 0.00414714896115247*std::sin(0.23599998652935*x_119 + 5.17160034179688) + 0.0189946671167383*std::sin(0.291119933128357*x_12 - 7.45567989349365) - 0.0091781456273093*std::sin(0.292959928512573*x_12 - 4.27135992050171) + 0.0396659814711559*std::sin(0.295039921998978*x_12 - 4.26959991455078) + 0.046295787723452*std::sin(0.296319931745529*x_12 + 5.12960004806519) - 0.0213616132955695*std::sin(0.297279924154282*x_12 - 4.26855993270874) - 0.00873052674215319*std::sin(0.262639969587326*x_120 + 5.16879987716675) + 0.0458726061045507*std::sin(0.266719967126846*x_120 + 5.15808010101318) + 0.0338766973997356*std::sin(0.267679959535599*x_120 + 5.16016006469727) - 0.016164899985712*std::sin(0.192479997873306*x_13 + 8.19071960449219) + 0.0316781852612009*std::sin(0.19344000518322*x_13 + 1.97303986549377) + 0.00675902093721872*std::sin(0.216639995574951*x_13 - 1.17511987686157) - 0.0209380199862337*std::sin(0.232239991426468*x_13 + 1.98807990550995) + 0.0547142633157697*std::sin(0.295279920101166*x_13 - 7.43551969528198) + 0.0696765254315527*std::sin(0.30159991979599*x_14 - 7.4423999786377) + 0.0342482339762658*std::sin(0.310879945755005*x_14 - 7.44575977325439) + 0.00996615473890068*std::sin(0.339599847793579*x_14 - 4.33360004425049) - 0.00054969004390766*std::sin(0.654879808425903*x_14 - 4.47160005569458) + 0.00598904511750644*std::sin(0.288399934768677*x_15 + 1.96623980998993) - 0.00403990239100033*std::sin(0.291679948568344*x_15 + 5.15560007095337) + 0.0752872573054001*std::sin(0.295359939336777*x_15 - 7.43336009979248) - 0.00728034090860108*std::sin(0.423679858446121*x_15 + 8.16016006469727) - 0.0148658220547093*std::sin(0.219439998269081*x_16 + 1.98215985298157) - 0.00609531320841865*std::sin(0.299759924411774*x_16 - 7.40511989593506) + 0.0244208007506797*std::sin(0.337919861078262*x_16 - 1.15591979026794) - 0.0059688163666788*std::sin(0.342799842357635*x_16 - 1.14039981365204) + 0.00562440682411556*std::sin(0.314799934625626*x_17 + 2.02759981155396) + 0.0235179431665446*std::sin(0.346559852361679*x_17 + 2.02431988716125) - 0.010679873901185*std::sin(0.347679853439331*x_17 - 1.15719985961914) + 0.037767329675296*std::sin(0.35471984744072*x_17 - 1.15351986885071) + 0.0476213386100995*std::sin(0.361119836568832*x_17 + 2.00263977050781) - 0.0548489920212734*std::sin(0.117200054228306*x_18 - 1.28391993045807) + 0.00428517730003445*std::sin(0.395679831504822*x_18 + 2.01239991188049) - 0.00772919912776529*std::sin(0.414719849824905*x_18 - 7.41239976882935) + 0.00669583742968916*std::sin(0.46687987446785*x_18 - 7.43407964706421) - 0.0390820924120229*std::sin(0.241439983248711*x_19 - 1.16903984546661) + 0.0128842768822656*std::sin(0.287599951028824*x_19 - 1.19359982013702) + 0.0190775663888725*std::sin(0.313359916210175*x_19 - 7.41943979263306) - 0.00512934279386475*std::sin(0.331279844045639*x_19 - 1.16599988937378) - 0.015833979160781*std::sin(0.372159838676453*x_2 + 5.19632005691528) + 0.0389434755091559*std::sin(0.375199824571609*x_2 + 5.17495965957642) + 0.0227275697721766*std::sin(0.393439829349518*x_2 + 5.18728017807007) + 0.00486838211759833*std::sin(0.404799848794937*x_2 + 2.01151990890503) + 0.0643454404236439*std::sin(0.202480003237724*x_20 + 1.9812798500061) - 0.0210910598509127*std::sin(0.246639966964722*x_20 - 1.16767990589142) - 0.00154645570111501*std::sin(0.270879954099655*x_20 + 1.9923198223114) - 0.0144614663934252*std::sin(0.344479858875275*x_20 - 4.3635196685791) - 0.00815473952092297*std::sin(0.403279840946198*x_20 + 8.19911956787109) - 0.0443831341148107*std::sin(0.314639925956726*x_21 - 7.40407991409302) - 0.00991165407891998*std::sin(0.33247983455658*x_21 + 8.24967956542969) + 0.00429028583029762*std::sin(0.339919835329056*x_21 - 1.13927984237671) + 0.0329504711831989*std::sin(0.360639840364456*x_22 + 1.99255979061127) + 0.00944377253432083*std::sin(0.394959837198257*x_22 - 7.40967988967896) + 0.00779194611477075*std::sin(0.241119980812073*x_23 - 4.37519979476929) + 0.0256696784619532*std::sin(0.3643998503685*x_23 + 2.00103974342346) - 0.0119877206271418*std::sin(0.285839945077896*x_24 - 1.15983986854553) - 0.017071245968553*std::sin(0.306479930877686*x_24 + 1.9890398979187) - 0.0020580863885691*std::sin(0.363439828157425*x_24 - 1.15135991573334) + 0.0209240755002679*std::sin(0.207600012421608*x_25 + 2.0052797794342) + 0.00384986220765954*std::sin(0.275919944047928*x_25 - 1.16351985931396) - 0.0263961857012816*std::sin(0.324399828910828*x_25 - 1.1555198431015) - 0.00397956493988226*std::sin(0.363119840621948*x_25 + 2.03151988983154) + 0.00674067396870916*std::sin(0.378719836473465*x_25 + 2.0130398273468) - 0.0158188056810131*std::sin(0.299519926309586*x_26 + 1.992959856987) - 0.0151100125802293*std::sin(0.332399845123291*x_26 - 1.15983986854553) + 0.00683307329571443*std::sin(0.333199828863144*x_26 - 1.14551985263824) - 0.0184850277940646*std::sin(0.337279856204987*x_26 - 1.14231979846954) + 0.0086042797793448*std::sin(0.316079914569855*x_27 + 2.00415992736816) + 0.0154372810135636*std::sin(0.319199919700623*x_27 + 5.1755199432373) + 0.0042916118647875*std::sin(0.338799834251404*x_28 - 4.3616795539856) + 0.0218586729370485*std::sin(0.415039867162704*x_28 - 1.20719993114471) + 0.00311427900235528*std::sin(0.557119846343994*x_28 + 4.81655979156494) + 0.0205543480429418*std::sin(0.296719938516617*x_29 - 1.18191993236542) + 0.0306925345898236*std::sin(0.300719946622849*x_29 + 1.98407983779907) - 0.0230208450386079*std::sin(0.301519930362701*x_29 + 1.98215973377228) + 0.0272772607762574*std::sin(0.296959936618805*x_3 + 8.28071975708008) - 0.0196582724345009*std::sin(0.320239841938019*x_3 + 5.19632005691528) - 0.0179649873646442*std::sin(0.346719831228256*x_3 - 7.38624000549316) - 0.0119580588425006*std::sin(0.360559850931168*x_3 - 7.41143989562988) + 0.00107780261060616*std::sin(0.400479853153229*x_3 + 2.17975974082947) + 0.0166871412724084*std::sin(0.325919836759567*x_30 - 1.15055990219116) + 0.0311729588524868*std::sin(0.333119839429855*x_30 + 2.01231980323792) - 0.0234836585406424*std::sin(0.351359844207764*x_30 - 1.14287984371185) - 0.0690676393142222*std::sin(0.352639853954315*x_30 - 1.14095985889435) + 0.00366895607435443*std::sin(0.357999831438065*x_31 + 5.16495990753174) + 0.0309959834680784*std::sin(0.365359842777252*x_31 + 5.17280006408691) - 0.0363206952191873*std::sin(0.368399828672409*x_31 + 5.17471981048584) + 0.011251410624484*std::sin(0.421279847621918*x_31 - 7.38687992095947) + 0.0577323101700872*std::sin(0.303919941186905*x_32 - 1.15511989593506) + 0.022077879203833*std::sin(0.308319926261902*x_32 + 2.02879977226257) + 0.0112958859864837*std::sin(0.316719859838486*x_32 + 2.00423979759216) + 0.00331316438028306*std::sin(0.336319833993912*x_32 + 1.99399983882904) + 0.00450700220870394*std::sin(0.185760006308556*x_34 - 1.19479990005493) - 0.00829738798682156*std::sin(0.219439998269081*x_35 - 7.40215969085693) + 0.0147720010591131*std::sin(0.22919999063015*x_35 - 7.42343997955322) + 0.0148389273217178*std::sin(0.250639975070953*x_35 + 1.97823977470398) - 0.0232228019310661*std::sin(0.245919972658157*x_36 - 7.42759990692139) - 0.0307629514867661*std::sin(0.186000004410744*x_37 + 8.20440006256104) - 0.0126532275589802*std::sin(0.237679988145828*x_38 + 1.98759984970093) - 0.00866844149461475*std::sin(0.239919975399971*x_38 + 1.97351980209351) - 0.0298276702039953*std::sin(0.242159977555275*x_38 + 1.97287976741791) + 0.00577855538966397*std::sin(0.22495998442173*x_39 - 1.18631982803345) + 0.0264587532971589*std::sin(0.319279909133911*x_4 + 2.00879979133606) + 0.00257463037686754*std::sin(0.324959844350815*x_4 - 1.16639983654022) - 0.0486899667903575*std::sin(0.330719828605652*x_4 - 7.38168001174927) - 0.00407323680753905*std::sin(0.386159837245941*x_4 + 1.99143981933594) + 0.00445422853715522*std::sin(0.189759999513626*x_40 + 2.000159740448) - 0.0133136022461047*std::sin(0.213359996676445*x_40 + 1.98591983318329) - 0.0191800267635715*std::sin(0.225519984960556*x_41 - 4.39015960693359) + 0.0128457708436556*std::sin(0.250879973173141*x_42 + 5.15895986557007) - 0.0316573836877664*std::sin(0.255599975585938*x_42 - 7.43623971939087) - 0.0157039706301619*std::sin(0.256719976663589*x_43 + 5.15768003463745) - 0.00350053668323239*std::sin(0.28263995051384*x_43 + 5.11055994033813) + 0.00540059048150869*std::sin(0.225679993629456*x_44 - 7.42191982269287) - 0.00594870718031297*std::sin(0.214000001549721*x_45 - 1.21471989154816) - 0.0102599875513932*std::sin(0.153200030326843*x_47 - 1.17551982402802) + 0.0271849350471278*std::sin(0.213599994778633*x_47 + 1.9826397895813) - 0.0266620665174345*std::sin(0.0819200873374939*x_49 - 1.29207980632782) - 0.0526827770756469*std::sin(0.169840022921562*x_49 + 2.00367975234985) - 0.0218728723968991*std::sin(0.211759999394417*x_49 + 1.99351978302002) - 0.0182088300586312*std::sin(0.27295994758606*x_49 + 5.11960029602051) - 0.00929366016111437*std::sin(0.322399914264679*x_5 + 2.01399993896484) - 0.0157405011072182*std::sin(0.327759832143784*x_5 - 1.14439988136292) - 0.00344318719275789*std::sin(0.358959853649139*x_5 + 2.02503991127014) + 0.0212166131216804*std::sin(0.374239832162857*x_5 + 2.01015973091125) + 0.00117482868673325*std::sin(0.402399837970734*x_5 + 8.21047973632813) - 0.0141248868050361*std::sin(0.22775998711586*x_50 - 7.4364800453186) - 0.050447700052332*std::sin(0.217600002884865*x_51 + 1.98359978199005) - 0.0290315577510073*std::sin(0.222479999065399*x_52 - 7.41655969619751) + 0.0301961204483431*std::sin(0.223839998245239*x_52 + 1.98967981338501) - 0.0131599817508226*std::sin(0.25095996260643*x_53 + 5.15743970870972) - 0.00583120281255524*std::sin(0.256639957427979*x_53 - 7.42983961105347) - 0.0209564618774511*std::sin(0.25943997502327*x_53 - 7.4398398399353) - 0.0204558500946162*std::sin(0.224399983882904*x_54 + 1.9832798242569) + 0.00762844742076268*std::sin(0.240879982709885*x_55 - 7.44704008102417) + 0.00569341741136538*std::sin(0.0958400741219521*x_56 + 7.95592021942139) - 0.00977604524776615*std::sin(0.163920015096664*x_57 - 1.17575979232788) - 0.00270621201445643*std::sin(0.51751983165741*x_57 - 4.48799991607666) - 0.0303970939260754*std::sin(0.151040032505989*x_58 - 4.38327980041504) + 0.0449088378604863*std::sin(0.146080031991005*x_59 - 1.21031987667084) + 0.0200969706396645*std::sin(0.284239947795868*x_6 - 7.382239818573) + 0.0132708211842901*std::sin(0.344559848308563*x_6 + 2.00063967704773) + 0.0455034478808945*std::sin(0.37271985411644*x_6 + 2.00519990921021) - 0.0113447053353164*std::sin(0.40447986125946*x_60 + 8.19551944732666) - 0.00269180759507922*std::sin(0.41543984413147*x_60 - 1.21631991863251) + 0.0129610820917998*std::sin(0.257439970970154*x_7 - 7.37671947479248) + 0.0255001716708876*std::sin(0.345999836921692*x_7 + 2.00303983688354) + 0.01646481615959*std::sin(0.357119828462601*x_7 + 1.99847972393036) - 0.0362902311453673*std::sin(0.361919850111008*x_7 + 2.0079197883606) + 0.00210640181251234*std::sin(0.412159860134125*x_7 + 4.98207950592041) - 0.0212423289114246*std::sin(0.144000038504601*x_71 - 4.31903982162476) - 0.00508477675830995*std::sin(0.254399985074997*x_8 - 4.38703966140747) + 0.0193049002772514*std::sin(0.292959928512573*x_8 - 7.41423988342285) - 0.010122976240221*std::sin(0.29911994934082*x_8 - 7.41567993164063) - 0.00677796812328179*std::sin(0.334959834814072*x_8 - 1.14431989192963) + 0.0157439549722709*std::sin(0.337839841842651*x_8 - 1.15391993522644) + 0.0189950765632586*std::sin(0.271999955177307*x_9 + 2.00103974342346) + 0.00379564221902874*std::sin(0.306639939546585*x_9 - 1.19591987133026) + 0.0302788666083338*std::sin(0.314799934625626*x_9 + 5.14448022842407) - 0.0478334339017711*std::sin(0.316319912672043*x_9 - 7.42663955688477) - 0.000986931361948961*std::sin(0.259039968252182*x_91 - 4.16463994979858) + 0.0233122673186473*std::sin(0.355039834976196*x_91 - 7.40223979949951) + 0.00418874656301082*std::sin(0.359519839286804*x_91 - 7.41016006469727) + 0.00436594867959583*std::sin(0.36575984954834*x_91 - 7.38615989685059) - 0.0100796502097694*std::sin(0.262719959020615*x_92 - 7.38695955276489) + 0.0101918545936937*std::sin(0.26599994301796*x_92 - 7.39991998672485) - 0.0422262345975411*std::sin(0.285919934511185*x_92 + 1.99951982498169) + 0.00605043226089468*std::sin(0.296799927949905*x_92 + 1.99463987350464) + 0.0193667932877396*std::sin(0.300159931182861*x_92 + 1.99007987976074) - 0.0140370086854487*std::sin(0.286479949951172*x_94 + 1.97767972946167) + 0.0056952247197775*std::sin(0.28671994805336*x_94 + 1.96495985984802) + 0.00488450132996228*std::sin(0.286959946155548*x_94 + 1.97103977203369) - 0.00531779734738753*std::sin(0.249199971556664*x_95 + 5.19456005096436) - 0.00810772666149477*std::sin(0.280399948358536*x_95 - 7.44032001495361) + 0.0338758138883439*std::sin(0.28263995051384*x_95 + 1.96735978126526) - 0.00162130412018498*std::sin(0.295519918203354*x_95 - 1.22903990745544) + 0.0185497253249023*std::sin(0.282559931278229*x_96 - 7.43711996078491) - 0.00142946638511292*std::sin(0.299439936876297*x_96 + 1.93367981910706) + 0.0236279799507453*std::sin(0.260399967432022*x_97 - 7.41359996795654) + 0.00407251107722723*std::sin(0.271919965744019*x_97 - 7.42767953872681) - 0.00945013475420275*std::sin(0.276479959487915*x_97 + 1.96783983707428) + 0.017356518802661*std::sin(0.280159950256348*x_97 + 1.95407974720001) - 0.00399259989515431*std::sin(0.283359944820404*x_97 - 1.20615983009338) + 0.00900623440079625*std::sin(0.23191998898983*x_98 + 5.18480014801025) - 0.00393970948091704*std::sin(0.232239991426468*x_98 - 7.39911985397339) - 0.164822795683938);
}

inline float score_1(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (1.39969284309176e-5*x_10 - 0.000568346282936062*x_100 + 0.00281735886141977*x_101 + 0.00187302296468395*x_102 + 0.00498775858866632*x_103 - 0.00484444832640623*x_104 + 0.00048711053402151*x_105 - 0.00627585176357847*x_106 + 0.000596987205675252*x_107 - 0.00254717916476502*x_108 + 0.00171486724557411*x_109 + 4.94084731945996e-5*x_11 + 0.000854095054145187*x_110 + 0.000671294128135179*x_111 + 0.00200805625225486*x_112 + 0.00641312763451646*x_113 - 0.00632438781527241*x_114 - 0.00242449102535788*x_115 + 0.0149797479209526*x_116 - 0.00476767485124305*x_117 - 0.0032227803908273*x_118 - 0.00140131819168524*x_119 - 0.0117674850539301*x_120 + 0.00065639980956668*x_14 + 0.0016772041039859*x_15 - 0.00322356235421375*x_16 + 0.00330763804052431*x_19 + 1.40375301839993e-5*x_2 - 0.0002404633072806*x_21 - 0.00144559657105852*x_22 - 0.000909395803371268*x_23 + 0.000710026961949354*x_24 + 0.00215854054717192*x_26 - 0.00414394041480523*x_27 + 0.00112487589056998*x_28 - 0.000475391592380947*x_29 - 8.48540271871909e-5*x_31 - 0.000683176582212822*x_32 - 0.00218115281831849*x_33 + 0.0158583973948788*x_34 + 0.00361949713497848*x_35 + 0.00515898512567542*x_36 + 0.000808489697871882*x_37 + 0.00391981327496453*x_38 + 0.00179863049753352*x_39 + 0.000166568580983289*x_4 - 0.0039664069696829*x_40 - 0.00363914604764316*x_41 + 0.00526399568359167*x_42 - 0.00231499394582793*x_43 - 0.00111738486102349*x_44 + 0.000407061678098485*x_45 - 0.00790396083961131*x_46 - 0.00838012755603448*x_47 + 0.0135950315576904*x_48 - 0.000165926083038232*x_49 + 0.000464208694032385*x_50 - 0.0091358391036752*x_51 + 0.00934153841745579*x_52 + 0.0109044599129638*x_53 + 0.0141367743414493*x_54 + 0.0119510890196434*x_55 + 0.00803138668094237*x_56 + 0.00868431847941161*x_57 + 0.0144242465086771*x_58 - 0.00873274654979261*x_59 + 0.00251598784638733*x_6 + 0.00400219577505068*x_60 + 0.00160288217393754*x_61 - 0.006791346498114*x_62 - 0.00176726444929524*x_63 + 0.00209137839217202*x_64 - 0.00125021244658066*x_65 + 0.00285545476484363*x_66 + 0.00276093734070061*x_67 - 0.00232078824458352*x_68 + 0.00167995863717551*x_69 - 0.00521010139062509*x_70 + 0.000918239750359677*x_71 + 0.00532809734762838*x_72 - 0.00146241235583389*x_73 + 0.0045429887323134*x_74 - 0.00131854433405609*x_75 - 0.00186134142501584*x_76 + 0.00189341038243393*x_77 + 0.000664114470885617*x_78 + 0.00089091355071934*x_79 - 0.00222898876078454*x_80 - 0.00404893314005105*x_81 - 0.00187362880103208*x_82 - 0.00414382296294407*x_83 - 0.00331834074239356*x_84 + 0.00234808278463872*x_85 - 0.00187302734230684*x_86 - 0.000969184852845726*x_87 - 0.000271028705491899*x_88 + 0.00192667147886515*x_89 - 0.00115765424474541*x_9 + 0.00152936299902738*x_90 + 0.000599904462854212*x_91 + 0.00708401450204636*x_93 - 0.000165626830862954*x_94 - 0.00243616857773665*x_95 - 0.00351356360946048*x_96 - 0.00111150337178386*x_98 + 0.0150794729710729*x_99 - 2.43142918714116e-5*std::pow(-3.08031988143921*x_22 - 8.18991947174072, 2) + 8.1885081246363e-7*std::pow(-7.29407978057861*x_24 - 1.18351984024048, 2) - 1.49010013983923e-5*std::pow(-5.27952003479004*x_55 - 8.32055950164795, 2) - 5.43133087009628e-5*std::pow(-2.59631991386414*x_56 - 9.37975978851318, 2) + 3.73238754220418e-6*std::pow(-3.85775995254517*x_59 - 9.14136028289795, 2) + 5.70905047456572e-5*std::pow(-2.80672001838684*x_59 - 8.59552001953125, 2) - 3.08260269677487e-5*std::pow(-4.6854395866394*x_61 - 8.77040004730225, 2) - 8.61023538444108e-6*std::pow(-3.75288009643555*x_65 - 9.44944000244141, 2) + 0.00021179520888725*std::exp(0.299919843673706*x_10) - 0.00872067821049913*std::exp(0.228399842977524*x_18) - 0.00274316807702001*std::exp(0.331679850816727*x_30) + 0.0743032702107491*std::sin(0.31879985332489*x_1 - 4.26864004135132) - 0.169535694316789*std::sin(0.326959848403931*x_1 - 4.2611198425293) - 0.243719432457768*std::sin(0.358239859342575*x_1 + 8.35488033294678) + 0.0045824831524809*std::sin(0.361999839544296*x_1 + 5.17400026321411) + 4.713445443606e-5*std::sin(0.365919858217239*x_1 - 4.23160028457642) - 0.0286797865129695*std::sin(0.263839960098267*x_10 + 1.99799978733063) + 0.0190017421699499*std::sin(0.243119969964027*x_100 - 7.42335987091064) - 0.0270994437283139*std::sin(0.250079959630966*x_100 - 1.2054398059845) - 0.0344067485332693*std::sin(0.2291199862957*x_101 - 7.40719985961914) - 0.0581963663887979*std::sin(0.237119987607002*x_101 + 1.98511981964111) + 0.0245405223353214*std::sin(0.220159992575645*x_102 + 2.00143980979919) + 0.00304406396450229*std::sin(0.239199981093407*x_106 + 8.17751979827881) - 0.0227617519130527*std::sin(0.246319979429245*x_108 - 1.19671988487244) - 0.057808860339975*std::sin(0.256719976663589*x_108 + 1.97239983081818) - 0.0238120233551573*std::sin(0.23479999601841*x_109 - 7.42360019683838) + 0.112823612526106*std::sin(0.274879962205887*x_11 - 7.44007968902588) + 0.107671611762147*std::sin(0.286479949951172*x_11 - 7.44456005096436) - 6.67145559837492e-5*std::sin(0.292959928512573*x_11 - 7.44855976104736) - 0.0769982711781383*std::sin(0.293119937181473*x_11 - 7.43735980987549) + 0.00702427010367382*std::sin(0.231119990348816*x_112 - 4.20911979675293) - 0.110076240555637*std::sin(0.281519949436188*x_112 + 5.14000034332275) - 0.0793221012887581*std::sin(0.292479932308197*x_113 - 7.43639993667603) - 0.070524990360121*std::sin(0.251439958810806*x_116 - 7.41999959945679) + 0.025461209511083*std::sin(0.219679996371269*x_118 - 4.21519994735718) + 0.000126801592894509*std::sin(0.23599998652935*x_119 + 5.17160034179688) - 0.0458796020133391*std::sin(0.291119933128357*x_12 - 7.45567989349365) + 0.000280627365031318*std::sin(0.292959928512573*x_12 - 4.27135992050171) - 0.0984090028537302*std::sin(0.295039921998978*x_12 - 4.26959991455078) + 0.0680161276760687*std::sin(0.296319931745529*x_12 + 5.12960004806519) - 0.0117149867280106*std::sin(0.297279924154282*x_12 - 4.26855993270874) + 0.000266941146335261*std::sin(0.262639969587326*x_120 + 5.16879987716675) + 0.0251571341667124*std::sin(0.266719967126846*x_120 + 5.15808010101318) - 0.0840461243473772*std::sin(0.267679959535599*x_120 + 5.16016006469727) - 0.00886504151966423*std::sin(0.192479997873306*x_13 + 8.19071960449219) - 0.0785917430541186*std::sin(0.19344000518322*x_13 + 1.97303986549377) - 0.000206661161505155*std::sin(0.216639995574951*x_13 - 1.17511987686157) + 0.0505735645700904*std::sin(0.232239991426468*x_13 + 1.98807990550995) + 0.0803842531337309*std::sin(0.295279920101166*x_13 - 7.43551969528198) + 0.102366277426502*std::sin(0.30159991979599*x_14 - 7.4423999786377) - 0.082722973497448*std::sin(0.310879945755005*x_14 - 7.44575977325439) - 0.0247254527372372*std::sin(0.339599847793579*x_14 - 4.33360004425049) + 1.68071062357919e-5*std::sin(0.654879808425903*x_14 - 4.47160005569458) - 0.0144659027053436*std::sin(0.288399934768677*x_15 + 1.96623980998993) + 0.000123522464014608*std::sin(0.291679948568344*x_15 + 5.15560007095337) + 0.110609365496791*std::sin(0.295359939336777*x_15 - 7.43336009979248) - 0.00399263369950357*std::sin(0.423679858446121*x_15 + 8.16016006469727) + 0.0359068150696972*std::sin(0.219439998269081*x_16 + 1.98215985298157) + 0.0001863678954526*std::sin(0.299759924411774*x_16 - 7.40511989593506) - 0.0605865923804653*std::sin(0.337919861078262*x_16 - 1.15591979026794) - 0.00327337657273654*std::sin(0.342799842357635*x_16 - 1.14039981365204) - 0.00017196964735658*std::sin(0.314799934625626*x_17 + 2.02759981155396) + 0.0128975460913956*std::sin(0.346559852361679*x_17 + 2.02431988716125) + 0.0257961016704121*std::sin(0.347679853439331*x_17 - 1.15719985961914) - 0.0936985577048338*std::sin(0.35471984744072*x_17 - 1.15351986885071) + 0.0699635799774726*std::sin(0.361119836568832*x_17 + 2.00263977050781) - 0.0300799010207364*std::sin(0.117200054228306*x_18 - 1.28391993045807) - 0.00013102189300882*std::sin(0.395679831504822*x_18 + 2.01239991188049) + 0.0186690599884865*std::sin(0.414719849824905*x_18 - 7.41239976882935) - 0.0166119848869881*std::sin(0.46687987446785*x_18 - 7.43407964706421) - 0.0574180226335689*std::sin(0.241439983248711*x_19 - 1.16903984546661) + 0.00706590511621424*std::sin(0.287599951028824*x_19 - 1.19359982013702) - 0.0460798364048837*std::sin(0.313359916210175*x_19 - 7.41943979263306) + 0.000156832764594806*std::sin(0.331279844045639*x_19 - 1.16599988937378) - 0.00868356023271982*std::sin(0.372159838676453*x_2 + 5.19632005691528) + 0.0572143716012162*std::sin(0.375199824571609*x_2 + 5.17495965957642) - 0.0563857843828943*std::sin(0.393439829349518*x_2 + 5.18728017807007) - 0.0117590601947133*std::sin(0.404799848794937*x_2 + 2.01151990890503) + 0.0945340366033005*std::sin(0.202480003237724*x_20 + 1.9812798500061) + 0.0523256980434468*std::sin(0.246639966964722*x_20 - 1.16767990589142) + 4.72838203013774e-5*std::sin(0.270879954099655*x_20 + 1.9923198223114) - 0.00793085636943371*std::sin(0.344479858875275*x_20 - 4.3635196685791) + 0.0196969076342854*std::sin(0.403279840946198*x_20 + 8.19911956787109) - 0.0652061248995194*std::sin(0.314639925956726*x_21 - 7.40407991409302) + 0.0245902397561221*std::sin(0.33247983455658*x_21 + 8.24967956542969) - 0.000131178089417675*std::sin(0.339919835329056*x_21 - 1.13927984237671) - 0.0795883652367345*std::sin(0.360639840364456*x_22 + 1.99255979061127) - 0.0234294527403982*std::sin(0.394959837198257*x_22 - 7.40967988967896) - 0.0193313670557271*std::sin(0.241119980812073*x_23 - 4.37519979476929) - 0.062002383321947*std::sin(0.3643998503685*x_23 + 2.00103974342346) + 0.0289550666005462*std::sin(0.285839945077896*x_24 - 1.15983986854553) + 0.0423527726008163*std::sin(0.306479930877686*x_24 + 1.9890398979187) + 6.29272386474745e-5*std::sin(0.363439828157425*x_24 - 1.15135991573334) + 0.0114750353070183*std::sin(0.207600012421608*x_25 + 2.0052797794342) - 0.00955128518011168*std::sin(0.275919944047928*x_25 - 1.16351985931396) - 0.0387803388840517*std::sin(0.324399828910828*x_25 - 1.1555198431015) + 0.000121677609878759*std::sin(0.363119840621948*x_25 + 2.03151988983154) - 0.0162813824051451*std::sin(0.378719836473465*x_25 + 2.0130398273468) + 0.0382086458536395*std::sin(0.299519926309586*x_26 + 1.992959856987) - 0.00828652753835652*std::sin(0.332399845123291*x_26 - 1.15983986854553) - 0.000208925357246087*std::sin(0.333199828863144*x_26 - 1.14551985263824) - 0.0271575465579534*std::sin(0.337279856204987*x_26 - 1.14231979846954) - 0.0207827244068885*std::sin(0.316079914569855*x_27 + 2.00415992736816) + 0.0226799051927138*std::sin(0.319199919700623*x_27 + 5.1755199432373) - 0.0103659328769529*std::sin(0.338799834251404*x_28 - 4.3616795539856) + 0.0321139862269279*std::sin(0.415039867162704*x_28 - 1.20719993114471) + 0.00170791113363526*std::sin(0.557119846343994*x_28 + 4.81655979156494) + 0.0301977184001751*std::sin(0.296719938516617*x_29 - 1.18191993236542) - 0.0761464008204242*std::sin(0.300719946622849*x_29 + 1.98407983779907) + 0.0556044073787087*std::sin(0.301519930362701*x_29 + 1.98215973377228) + 0.0400747831032478*std::sin(0.296959936618805*x_3 + 8.28071975708008) - 0.0107808524327869*std::sin(0.320239841938019*x_3 + 5.19632005691528) + 0.0445700932452681*std::sin(0.346719831228256*x_3 - 7.38624000549316) + 0.000365624896370727*std::sin(0.360559850931168*x_3 - 7.41143989562988) - 0.00260331779017981*std::sin(0.400479853153229*x_3 + 2.17975974082947) - 0.000510219457757087*std::sin(0.325919836759567*x_30 - 1.15055990219116) - 0.0752949728963651*std::sin(0.333119839429855*x_30 + 2.01231980323792) - 0.0128787439563761*std::sin(0.351359844207764*x_30 - 1.14287984371185) - 0.101471723560308*std::sin(0.352639853954315*x_30 - 1.14095985889435) - 0.000112180555568672*std::sin(0.357999831438065*x_31 + 5.16495990753174) - 0.0748675076424117*std::sin(0.365359842777252*x_31 + 5.17280006408691) + 0.0901095413981775*std::sin(0.368399828672409*x_31 + 5.17471981048584) + 0.0165301730287465*std::sin(0.421279847621918*x_31 - 7.38687992095947) + 0.0848182604218633*std::sin(0.303919941186905*x_32 - 1.15511989593506) - 0.0533267735067509*std::sin(0.308319926261902*x_32 + 2.02879977226257) - 0.0280244389537574*std::sin(0.316719859838486*x_32 + 2.00423979759216) - 0.000101302008892512*std::sin(0.336319833993912*x_32 + 1.99399983882904) - 0.000137804324029854*std::sin(0.185760006308556*x_34 - 1.19479990005493) + 0.0205853390686272*std::sin(0.219439998269081*x_35 - 7.40215969085693) - 0.0356802004145418*std::sin(0.22919999063015*x_35 - 7.42343997955322) + 0.00813786085472731*std::sin(0.250639975070953*x_35 + 1.97823977470398) + 0.0576144266887164*std::sin(0.245919972658157*x_36 - 7.42759990692139) - 0.016870802939619*std::sin(0.186000004410744*x_37 + 8.20440006256104) + 0.0313919247873912*std::sin(0.237679988145828*x_38 + 1.98759984970093) - 0.00475388612539906*std::sin(0.239919975399971*x_38 + 1.97351980209351) - 0.0438217540868606*std::sin(0.242159977555275*x_38 + 1.97287976741791) + 0.00848964842145932*std::sin(0.22495998442173*x_39 - 1.18631982803345) - 0.0639083098209736*std::sin(0.319279909133911*x_4 + 2.00879979133606) - 7.87208841446266e-5*std::sin(0.324959844350815*x_4 - 1.16639983654022) - 0.0715335705602196*std::sin(0.330719828605652*x_4 - 7.38168001174927) + 0.0101054646261183*std::sin(0.386159837245941*x_4 + 1.99143981933594) - 0.0107587161862424*std::sin(0.189759999513626*x_40 + 2.000159740448) + 0.0330302761418641*std::sin(0.213359996676445*x_40 + 1.98591983318329) - 0.0281786143692863*std::sin(0.225519984960556*x_41 - 4.39015960693359) - 0.0318696135259105*std::sin(0.250879973173141*x_42 + 5.15895986557007) - 0.046509904176588*std::sin(0.255599975585938*x_42 - 7.43623971939087) + 0.0379312739787941*std::sin(0.256719976663589*x_43 + 5.15768003463745) - 0.00191973987252578*std::sin(0.28263995051384*x_43 + 5.11055994033813) - 0.0133985522201962*std::sin(0.225679993629456*x_44 - 7.42191982269287) + 0.0147583980068442*std::sin(0.214000001549721*x_45 - 1.21471989154816) + 0.000313705337517692*std::sin(0.153200030326843*x_47 - 1.17551982402802) - 0.0656623247491197*std::sin(0.213599994778633*x_47 + 1.9826397895813) + 0.000815208842493694*std::sin(0.0819200873374939*x_49 - 1.29207980632782) - 0.077399665673944*std::sin(0.169840022921562*x_49 + 2.00367975234985) + 0.0542653296929248*std::sin(0.211759999394417*x_49 + 1.99351978302002) + 0.0439814960211832*std::sin(0.27295994758606*x_49 + 5.11960029602051) + 0.022447849536853*std::sin(0.322399914264679*x_5 + 2.01399993896484) - 0.00863229565163705*std::sin(0.327759832143784*x_5 - 1.14439988136292) + 0.00854234801991309*std::sin(0.358959853649139*x_5 + 2.02503991127014) + 0.031170694741348*std::sin(0.374239832162857*x_5 + 2.01015973091125) - 3.59210991096257e-5*std::sin(0.402399837970734*x_5 + 8.21047973632813) + 0.0350430261486458*std::sin(0.22775998711586*x_50 - 7.4364800453186) - 0.0741159698636096*std::sin(0.217600002884865*x_51 + 1.98359978199005) + 0.0701226458593606*std::sin(0.222479999065399*x_52 - 7.41655969619751) + 0.0165599454214967*std::sin(0.223839998245239*x_52 + 1.98967981338501) - 0.00721710525411131*std::sin(0.25095996260643*x_53 + 5.15743970870972) + 0.00017829256003321*std::sin(0.256639957427979*x_53 - 7.42983961105347) + 0.0506181090005997*std::sin(0.25943997502327*x_53 - 7.4398398399353) + 0.0507497794249815*std::sin(0.224399983882904*x_54 + 1.9832798242569) + 0.00418353984097711*std::sin(0.240879982709885*x_55 - 7.44704008102417) - 0.000174079687886069*std::sin(0.0958400741219521*x_56 + 7.95592021942139) + 0.000298908508287837*std::sin(0.163920015096664*x_57 - 1.17575979232788) + 0.00671395528299481*std::sin(0.51751983165741*x_57 - 4.48799991607666) - 0.0166701618921227*std::sin(0.151040032505989*x_58 - 4.38327980041504) + 0.0659784701785164*std::sin(0.146080031991005*x_59 - 1.21031987667084) - 0.0485420991562971*std::sin(0.284239947795868*x_6 - 7.382239818573) - 0.000405763400579309*std::sin(0.344559848308563*x_6 + 2.00063967704773) + 0.0668520501099595*std::sin(0.37271985411644*x_6 + 2.00519990921021) - 0.00622158404412215*std::sin(0.40447986125946*x_60 + 8.19551944732666) + 8.2303648607483e-5*std::sin(0.41543984413147*x_60 - 1.21631991863251) - 0.0313061178897932*std::sin(0.257439970970154*x_7 - 7.37671947479248) + 0.0139846259995914*std::sin(0.345999836921692*x_7 + 2.00303983688354) - 0.000503421732691047*std::sin(0.357119828462601*x_7 + 1.99847972393036) - 0.053316319180524*std::sin(0.361919850111008*x_7 + 2.0079197883606) - 0.00522586090878311*std::sin(0.412159860134125*x_7 + 4.98207950592041) - 0.0312084754666482*std::sin(0.144000038504601*x_71 - 4.31903982162476) - 0.00278855774675279*std::sin(0.254399985074997*x_8 - 4.38703966140747) + 0.0283620741021793*std::sin(0.292959928512573*x_8 - 7.41423988342285) + 0.0244509744886532*std::sin(0.29911994934082*x_8 - 7.41567993164063) + 0.000207240483202102*std::sin(0.334959834814072*x_8 - 1.14431989192963) - 0.0390598405064513*std::sin(0.337839841842651*x_8 - 1.15391993522644) - 0.0458805909879434*std::sin(0.271999955177307*x_9 + 2.00103974342346) - 0.000116054061221071*std::sin(0.306639939546585*x_9 - 1.19591987133026) + 0.0166053244924813*std::sin(0.314799934625626*x_9 + 5.14448022842407) - 0.0702751828499414*std::sin(0.316319912672043*x_9 - 7.42663955688477) + 3.017602452792e-5*std::sin(0.259039968252182*x_91 - 4.16463994979858) + 0.0127847507797752*std::sin(0.355039834976196*x_91 - 7.40223979949951) - 0.0101174726603305*std::sin(0.359519839286804*x_91 - 7.41016006469727) - 0.0108316658288669*std::sin(0.36575984954834*x_91 - 7.38615989685059) + 0.0250070284275988*std::sin(0.262719959020615*x_92 - 7.38695955276489) - 0.0246173428395823*std::sin(0.26599994301796*x_92 - 7.39991998672485) - 0.0620372847055173*std::sin(0.285919934511185*x_92 + 1.99951982498169) - 0.000184995633281657*std::sin(0.296799927949905*x_92 + 1.99463987350464) + 0.0106210014754387*std::sin(0.300159931182861*x_92 + 1.99007987976074) - 0.00769807823855269*std::sin(0.286479949951172*x_94 + 1.97767972946167) - 0.0137562107255708*std::sin(0.28671994805336*x_94 + 1.96495985984802) - 0.000149346588448186*std::sin(0.286959946155548*x_94 + 1.97103977203369) - 0.00291634927029672*std::sin(0.249199971556664*x_95 + 5.19456005096436) + 0.0195833530630566*std::sin(0.280399948358536*x_95 - 7.44032001495361) + 0.0497691430659718*std::sin(0.28263995051384*x_95 + 1.96735978126526) + 4.95723560768248e-5*std::sin(0.295519918203354*x_95 - 1.22903990745544) + 0.0272525978732928*std::sin(0.282559931278229*x_96 - 7.43711996078491) + 4.37068010624586e-5*std::sin(0.299439936876297*x_96 + 1.93367981910706) + 0.0347133892754434*std::sin(0.260399967432022*x_97 - 7.41359996795654) - 0.000124519494358707*std::sin(0.271919965744019*x_97 - 7.42767953872681) - 0.00518257688179189*std::sin(0.276479959487915*x_97 + 1.96783983707428) - 0.043060517981231*std::sin(0.280159950256348*x_97 + 1.95407974720001) + 0.00964370120636436*std::sin(0.283359944820404*x_97 - 1.20615983009338) + 0.00493913615113346*std::sin(0.23191998898983*x_98 + 5.18480014801025) + 0.00012045900506623*std::sin(0.232239991426468*x_98 - 7.39911985397339) + 0.764080241162196);
}

inline float score_2(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.000134988103261354*x_10 - 0.000902899423804441*x_100 - 9.28269485129129e-5*x_101 - 2.43054707737574e-5*x_102 + 0.00340830563612122*x_103 - 1.8101339909883e-5*x_104 - 0.00209258129676403*x_105 - 0.00239616848398193*x_106 + 0.00112583449030113*x_107 + 0.00107632610933401*x_108 - 0.00139948661788354*x_109 - 5.32933205031311e-5*x_11 - 0.00104315699222112*x_110 + 0.00121890210523301*x_111 - 0.000744955661417986*x_112 - 0.00212628282730613*x_113 - 0.00901639590281989*x_114 - 0.00131935888396226*x_115 - 0.00219652984678996*x_116 - 0.00955773314098233*x_117 - 0.00339300094636737*x_118 - 0.00856556139794185*x_119 - 0.00403552755933552*x_120 - 0.000708010654197968*x_14 - 0.000263466421724085*x_15 - 0.00110417784844953*x_16 - 0.000519585873194793*x_19 + 0.00027943632473235*x_2 + 0.00034944130034349*x_21 - 0.000538439635975559*x_22 + 0.000196506120238623*x_23 + 0.000243207965920553*x_24 - 0.000339077964785683*x_26 + 0.000872083963436184*x_27 - 0.000271727691421665*x_28 + 0.000442080144160472*x_29 + 9.1525857296935e-5*x_31 + 0.000736892808095942*x_32 - 0.000249268468954222*x_33 + 0.00443358252332646*x_34 + 0.00122116813631154*x_35 - 0.00087830794864444*x_36 - 0.000218482866575061*x_37 + 0.00182807956775002*x_38 + 0.000393739606982672*x_39 - 0.000179665393365453*x_4 - 0.00217136669087428*x_40 + 0.00112797708479224*x_41 + 0.00217103861342187*x_42 - 0.000356342544781061*x_43 - 4.03799707105079e-5*x_44 + 0.000919738509209522*x_45 - 0.0034270072070525*x_46 + 0.00160065794547184*x_47 + 0.00899374637147701*x_48 + 0.000178972377639715*x_49 - 0.000480597542985977*x_50 + 0.00162485734831181*x_51 + 0.00100500665396108*x_52 - 0.00128524394342807*x_53 + 0.00523456914978568*x_54 + 0.00417805839857823*x_55 + 0.00126822345821266*x_56 + 0.00276317592156955*x_57 + 0.00625431425295346*x_58 - 0.00340191230955817*x_59 - 0.000434619566291121*x_6 + 0.00156755552119506*x_60 + 0.00101259502665518*x_61 - 0.00138424012805444*x_62 + 0.000291641171266861*x_63 + 0.000929403494082932*x_64 - 0.000135678378078089*x_65 + 0.00127948127777381*x_66 + 6.18501267402754e-5*x_67 - 9.27257861249078e-5*x_68 + 0.00104029472144241*x_69 - 0.000344957158748537*x_70 + 0.000637038042949505*x_71 + 0.000758767325626765*x_72 + 0.00113142049501509*x_73 + 0.000907542703138494*x_74 + 0.00151599888136781*x_75 - 1.03514802387997e-7*x_76 - 0.000132997020062272*x_77 + 0.00189257584367383*x_78 - 0.00166335855172945*x_79 + 0.000378585510929347*x_80 - 0.0029856532812259*x_81 + 0.00157631609702009*x_82 - 0.000455866497381781*x_83 - 8.27108609443077e-6*x_84 + 0.00170902841936655*x_85 - 0.000505388640096327*x_86 - 0.000980191627246248*x_87 - 0.000554398045041603*x_88 + 0.00100796683446455*x_89 + 0.000181852060063487*x_9 + 0.00178655324362171*x_90 + 0.000205487329321787*x_91 - 0.00351685291401694*x_93 + 3.58446576776343e-5*x_94 + 0.000382689629942811*x_95 + 0.000341016835769506*x_96 - 0.000604085979631375*x_98 - 0.00144973869267693*x_99 + 2.62260552842067e-5*std::pow(-3.08031988143921*x_22 - 8.18991947174072, 2) - 8.83234716057636e-7*std::pow(-7.29407978057861*x_24 - 1.18351984024048, 2) + 2.34074881477455e-6*std::pow(-5.27952003479004*x_55 - 8.32055950164795, 2) - 1.86041235607592e-5*std::pow(-2.59631991386414*x_56 - 9.37975978851318, 2) - 4.02585452792988e-6*std::pow(-3.85775995254517*x_59 - 9.14136028289795, 2) - 8.96815775969901e-6*std::pow(-2.80672001838684*x_59 - 8.59552001953125, 2) + 4.84235818518552e-6*std::pow(-4.6854395866394*x_61 - 8.77040004730225, 2) - 3.71270648008612e-6*std::pow(-3.75288009643555*x_65 - 9.44944000244141, 2) - 0.000228448062011548*std::exp(0.299919843673706*x_10) - 0.00298712376104736*std::exp(0.228399842977524*x_18) + 0.000430915161561206*std::exp(0.331679850816727*x_30) + 0.0254513535085876*std::sin(0.31879985332489*x_1 - 4.26864004135132) + 0.0266317990935039*std::sin(0.326959848403931*x_1 - 4.2611198425293) - 0.105091054519133*std::sin(0.358239859342575*x_1 + 8.35488033294678) - 0.00494279073112617*std::sin(0.361999839544296*x_1 + 5.17400026321411) + 0.000938276074440079*std::sin(0.365919858217239*x_1 - 4.23160028457642) + 0.00450521240105806*std::sin(0.263839960098267*x_10 + 1.99799978733063) + 0.00819349159893822*std::sin(0.243119969964027*x_100 - 7.42335987091064) + 0.00425696160225475*std::sin(0.250079959630966*x_100 - 1.2054398059845) - 0.014836082004099*std::sin(0.2291199862957*x_101 - 7.40719985961914) - 0.0199342006034925*std::sin(0.237119987607002*x_101 + 1.98511981964111) + 0.0105817962263479*std::sin(0.220159992575645*x_102 + 2.00143980979919) - 0.00328341003077149*std::sin(0.239199981093407*x_106 + 8.17751979827881) - 0.00779666080336353*std::sin(0.246319979429245*x_108 - 1.19671988487244) + 0.00908100185393335*std::sin(0.256719976663589*x_108 + 1.97239983081818) - 0.0102676697520266*std::sin(0.23479999601841*x_109 - 7.42360019683838) - 0.0177230865388389*std::sin(0.274879962205887*x_11 - 7.44007968902588) + 0.0368811257704425*std::sin(0.286479949951172*x_11 - 7.44456005096436) - 0.00132804489720699*std::sin(0.292959928512573*x_11 - 7.44855976104736) - 0.0332014129224714*std::sin(0.293119937181473*x_11 - 7.43735980987549) + 0.00302884322755108*std::sin(0.231119990348816*x_112 - 4.20911979675293) - 0.037704791502872*std::sin(0.281519949436188*x_112 + 5.14000034332275) - 0.0271704708987643*std::sin(0.292479932308197*x_113 - 7.43639993667603) - 0.0241571663771201*std::sin(0.251439958810806*x_116 - 7.41999959945679) + 0.0109787936475519*std::sin(0.219679996371269*x_118 - 4.21519994735718) + 0.00252415992159627*std::sin(0.23599998652935*x_119 + 5.17160034179688) - 0.0197831404245348*std::sin(0.291119933128357*x_12 - 7.45567989349365) + 0.00558627326002541*std::sin(0.292959928512573*x_12 - 4.27135992050171) + 0.0154587433847142*std::sin(0.295039921998978*x_12 - 4.26959991455078) + 0.0232977970533311*std::sin(0.296319931745529*x_12 + 5.12960004806519) + 0.0126361027171759*std::sin(0.297279924154282*x_12 - 4.26855993270874) + 0.00531383027313384*std::sin(0.262639969587326*x_120 + 5.16879987716675) - 0.0271351678649607*std::sin(0.266719967126846*x_120 + 5.15808010101318) + 0.0132025265076308*std::sin(0.267679959535599*x_120 + 5.16016006469727) + 0.0095620744466289*std::sin(0.192479997873306*x_13 + 8.19071960449219) + 0.0123457158674478*std::sin(0.19344000518322*x_13 + 1.97303986549377) - 0.00411387435531529*std::sin(0.216639995574951*x_13 - 1.17511987686157) + 0.0218071623500241*std::sin(0.232239991426468*x_13 + 1.98807990550995) + 0.0275342934063003*std::sin(0.295279920101166*x_13 - 7.43551969528198) + 0.0350638714386377*std::sin(0.30159991979599*x_14 - 7.4423999786377) - 0.0356698865992622*std::sin(0.310879945755005*x_14 - 7.44575977325439) + 0.00388403924287239*std::sin(0.339599847793579*x_14 - 4.33360004425049) + 0.000334568541214548*std::sin(0.654879808425903*x_14 - 4.47160005569458) - 0.00623765185461431*std::sin(0.288399934768677*x_15 + 1.96623980998993) + 0.00245888435598662*std::sin(0.291679948568344*x_15 + 5.15560007095337) + 0.0378874046140184*std::sin(0.295359939336777*x_15 - 7.43336009979248) + 0.00430656309821981*std::sin(0.423679858446121*x_15 + 8.16016006469727) + 0.0154829059876129*std::sin(0.219439998269081*x_16 + 1.98215985298157) + 0.00370990901324924*std::sin(0.299759924411774*x_16 - 7.40511989593506) + 0.00951734655370906*std::sin(0.337919861078262*x_16 - 1.15591979026794) + 0.00353075283527192*std::sin(0.342799842357635*x_16 - 1.14039981365204) - 0.00342329210288116*std::sin(0.314799934625626*x_17 + 2.02759981155396) - 0.0139116433500273*std::sin(0.346559852361679*x_17 + 2.02431988716125) + 0.011123198095811*std::sin(0.347679853439331*x_17 - 1.15719985961914) + 0.0147187952024042*std::sin(0.35471984744072*x_17 - 1.15351986885071) + 0.0239648645568684*std::sin(0.361119836568832*x_17 + 2.00263977050781) + 0.0324449978344156*std::sin(0.117200054228306*x_18 - 1.28391993045807) - 0.00260817079371927*std::sin(0.395679831504822*x_18 + 2.01239991188049) + 0.00805004008620021*std::sin(0.414719849824905*x_18 - 7.41239976882935) + 0.00260952152782601*std::sin(0.46687987446785*x_18 - 7.43407964706421) - 0.0196675918525002*std::sin(0.241439983248711*x_19 - 1.16903984546661) - 0.00762147707985193*std::sin(0.287599951028824*x_19 - 1.19359982013702) - 0.019869480865862*std::sin(0.313359916210175*x_19 - 7.41943979263306) + 0.00312197165466756*std::sin(0.331279844045639*x_19 - 1.16599988937378) + 0.00936632380377143*std::sin(0.372159838676453*x_2 + 5.19632005691528) + 0.0195978345672273*std::sin(0.375199824571609*x_2 + 5.17495965957642) + 0.0088574555786991*std::sin(0.393439829349518*x_2 + 5.18728017807007) - 0.00507046985771446*std::sin(0.404799848794937*x_2 + 2.01151990890503) + 0.0323810671772599*std::sin(0.202480003237724*x_20 + 1.9812798500061) - 0.00821967010154523*std::sin(0.246639966964722*x_20 - 1.16767990589142) + 0.00094124940720572*std::sin(0.270879954099655*x_20 + 1.9923198223114) + 0.0085544369828195*std::sin(0.344479858875275*x_20 - 4.3635196685791) + 0.00849324476583008*std::sin(0.403279840946198*x_20 + 8.19911956787109) - 0.0223352771827626*std::sin(0.314639925956726*x_21 - 7.40407991409302) - 0.00386279908479004*std::sin(0.33247983455658*x_21 + 8.24967956542969) - 0.00261128009783864*std::sin(0.339919835329056*x_21 - 1.13927984237671) - 0.0343182533531941*std::sin(0.360639840364456*x_22 + 1.99255979061127) + 0.00368045490813929*std::sin(0.394959837198257*x_22 - 7.40967988967896) + 0.0030367002400622*std::sin(0.241119980812073*x_23 - 4.37519979476929) - 0.026735233133829*std::sin(0.3643998503685*x_23 + 2.00103974342346) + 0.0124853338613055*std::sin(0.285839945077896*x_24 - 1.15983986854553) - 0.00665305636965263*std::sin(0.306479930877686*x_24 + 1.9890398979187) + 0.00125265314216379*std::sin(0.363439828157425*x_24 - 1.15135991573334) - 0.0123772846004177*std::sin(0.207600012421608*x_25 + 2.0052797794342) + 0.00150037966356625*std::sin(0.275919944047928*x_25 - 1.16351985931396) - 0.0132835622351658*std::sin(0.324399828910828*x_25 - 1.1555198431015) + 0.00242215999973365*std::sin(0.363119840621948*x_25 + 2.03151988983154) - 0.00702048100445353*std::sin(0.378719836473465*x_25 + 2.0130398273468) + 0.0164754481988336*std::sin(0.299519926309586*x_26 + 1.992959856987) + 0.00893807356119486*std::sin(0.332399845123291*x_26 - 1.15983986854553) - 0.00415894628235853*std::sin(0.333199828863144*x_26 - 1.14551985263824) - 0.00930236739125929*std::sin(0.337279856204987*x_26 - 1.14231979846954) - 0.0089614455510391*std::sin(0.316079914569855*x_27 + 2.00415992736816) + 0.00776862556605894*std::sin(0.319199919700623*x_27 + 5.1755199432373) - 0.00446975772973006*std::sin(0.338799834251404*x_28 - 4.3616795539856) + 0.0110001136385141*std::sin(0.415039867162704*x_28 - 1.20719993114471) - 0.00184219931421881*std::sin(0.557119846343994*x_28 + 4.81655979156494) + 0.0103437278598332*std::sin(0.296719938516617*x_29 - 1.18191993236542) + 0.0119615851783617*std::sin(0.300719946622849*x_29 + 1.98407983779907) + 0.0239764459830364*std::sin(0.301519930362701*x_29 + 1.98215973377228) + 0.0137269526448539*std::sin(0.296959936618805*x_3 + 8.28071975708008) + 0.0116285201069575*std::sin(0.320239841938019*x_3 + 5.19632005691528) - 0.00700136790467709*std::sin(0.346719831228256*x_3 - 7.38624000549316) + 0.00727826590100155*std::sin(0.360559850931168*x_3 - 7.41143989562988) - 0.00112254246228734*std::sin(0.400479853153229*x_3 + 2.17975974082947) - 0.0101566193065134*std::sin(0.325919836759567*x_30 - 1.15055990219116) - 0.0324669560480767*std::sin(0.333119839429855*x_30 + 2.01231980323792) + 0.0138913628567646*std::sin(0.351359844207764*x_30 - 1.14287984371185) - 0.0347574568405128*std::sin(0.352639853954315*x_30 - 1.14095985889435) - 0.0022331080855145*std::sin(0.357999831438065*x_31 + 5.16495990753174) - 0.0322826343718967*std::sin(0.365359842777252*x_31 + 5.17280006408691) - 0.0141550085520037*std::sin(0.368399828672409*x_31 + 5.17471981048584) + 0.00566213675548137*std::sin(0.421279847621918*x_31 - 7.38687992095947) + 0.029053089101696*std::sin(0.303919941186905*x_32 - 1.15511989593506) - 0.0229943374043369*std::sin(0.308319926261902*x_32 + 2.02879977226257) + 0.00440226602977212*std::sin(0.316719859838486*x_32 + 2.00423979759216) - 0.002016555667691*std::sin(0.336319833993912*x_32 + 1.99399983882904) - 0.00274318440169917*std::sin(0.185760006308556*x_34 - 1.19479990005493) - 0.00323368253839773*std::sin(0.219439998269081*x_35 - 7.40215969085693) - 0.0153851904593941*std::sin(0.22919999063015*x_35 - 7.42343997955322) - 0.00877771764030688*std::sin(0.250639975070953*x_35 + 1.97823977470398) - 0.00905045891748446*std::sin(0.245919972658157*x_36 - 7.42759990692139) + 0.0181973060504236*std::sin(0.186000004410744*x_37 + 8.20440006256104) - 0.00493125319399712*std::sin(0.237679988145828*x_38 + 1.98759984970093) + 0.00512767063087413*std::sin(0.239919975399971*x_38 + 1.97351980209351) - 0.0150104154429227*std::sin(0.242159977555275*x_38 + 1.97287976741791) + 0.00290798833652043*std::sin(0.22495998442173*x_39 - 1.18631982803345) - 0.027557062659685*std::sin(0.319279909133911*x_4 + 2.00879979133606) - 0.00156704735496344*std::sin(0.324959844350815*x_4 - 1.16639983654022) - 0.0245026388057449*std::sin(0.330719828605652*x_4 - 7.38168001174927) - 0.00158743387198693*std::sin(0.386159837245941*x_4 + 1.99143981933594) - 0.00463912466019794*std::sin(0.189759999513626*x_40 + 2.000159740448) - 0.00518861636635282*std::sin(0.213359996676445*x_40 + 1.98591983318329) - 0.00965211724410914*std::sin(0.225519984960556*x_41 - 4.39015960693359) + 0.00500629173124878*std::sin(0.250879973173141*x_42 + 5.15895986557007) - 0.0159311966955343*std::sin(0.255599975585938*x_42 - 7.43623971939087) + 0.0163558463167535*std::sin(0.256719976663589*x_43 + 5.15768003463745) + 0.00207068354260214*std::sin(0.28263995051384*x_43 + 5.11055994033813) + 0.00210473406387995*std::sin(0.225679993629456*x_44 - 7.42191982269287) - 0.00231834772166511*std::sin(0.214000001549721*x_45 - 1.21471989154816) + 0.00624473574879896*std::sin(0.153200030326843*x_47 - 1.17551982402802) - 0.0283133883928541*std::sin(0.213599994778633*x_47 + 1.9826397895813) + 0.0162278520401977*std::sin(0.0819200873374939*x_49 - 1.29207980632782) - 0.0265119724465245*std::sin(0.169840022921562*x_49 + 2.00367975234985) - 0.00852436039471605*std::sin(0.211759999394417*x_49 + 1.99351978302002) + 0.0189646830767018*std::sin(0.27295994758606*x_49 + 5.11960029602051) + 0.00967944228215574*std::sin(0.322399914264679*x_5 + 2.01399993896484) + 0.00931102843491146*std::sin(0.327759832143784*x_5 - 1.14439988136292) - 0.00134188907633823*std::sin(0.358959853649139*x_5 + 2.02503991127014) + 0.010677004776777*std::sin(0.374239832162857*x_5 + 2.01015973091125) - 0.000715058830433127*std::sin(0.402399837970734*x_5 + 8.21047973632813) - 0.00550479257940384*std::sin(0.22775998711586*x_50 - 7.4364800453186) - 0.0253871968794944*std::sin(0.217600002884865*x_51 + 1.98359978199005) + 0.0302366648597415*std::sin(0.222479999065399*x_52 - 7.41655969619751) - 0.0178620066923793*std::sin(0.223839998245239*x_52 + 1.98967981338501) + 0.00778456565329011*std::sin(0.25095996260643*x_53 + 5.15743970870972) + 0.00354915836687503*std::sin(0.256639957427979*x_53 - 7.42983961105347) + 0.0218263697686856*std::sin(0.25943997502327*x_53 - 7.4398398399353) - 0.00797211428031352*std::sin(0.224399983882904*x_54 + 1.9832798242569) - 0.00451247964503344*std::sin(0.240879982709885*x_55 - 7.44704008102417) - 0.00346529535864399*std::sin(0.0958400741219521*x_56 + 7.95592021942139) + 0.00595018453334399*std::sin(0.163920015096664*x_57 - 1.17575979232788) - 0.00105467293445224*std::sin(0.51751983165741*x_57 - 4.48799991607666) + 0.0179808891696957*std::sin(0.151040032505989*x_58 - 4.38327980041504) + 0.0225998312551565*std::sin(0.146080031991005*x_59 - 1.21031987667084) - 0.0209312008380438*std::sin(0.284239947795868*x_6 - 7.382239818573) - 0.00807727797429952*std::sin(0.344559848308563*x_6 + 2.00063967704773) + 0.0228990615796107*std::sin(0.37271985411644*x_6 + 2.00519990921021) + 0.00671076945030572*std::sin(0.40447986125946*x_60 + 8.19551944732666) + 0.00163836720402231*std::sin(0.41543984413147*x_60 - 1.21631991863251) - 0.0134990997999668*std::sin(0.257439970970154*x_7 - 7.37671947479248) - 0.0150841972504851*std::sin(0.345999836921692*x_7 + 2.00303983688354) - 0.0100213012495549*std::sin(0.357119828462601*x_7 + 1.99847972393036) - 0.0182626213273168*std::sin(0.361919850111008*x_7 + 2.0079197883606) + 0.000820913132034903*std::sin(0.412159860134125*x_7 + 4.98207950592041) - 0.0106899459379493*std::sin(0.144000038504601*x_71 - 4.31903982162476) + 0.00300781408795746*std::sin(0.254399985074997*x_8 - 4.38703966140747) + 0.00971495833445694*std::sin(0.292959928512573*x_8 - 7.41423988342285) + 0.0105431834758529*std::sin(0.29911994934082*x_8 - 7.41567993164063) + 0.0041254065496337*std::sin(0.334959834814072*x_8 - 1.14431989192963) + 0.006135780604693*std::sin(0.337839841842651*x_8 - 1.15391993522644) - 0.0197835668672809*std::sin(0.271999955177307*x_9 + 2.00103974342346) - 0.00231021553740588*std::sin(0.306639939546585*x_9 - 1.19591987133026) - 0.0179109537902706*std::sin(0.314799934625626*x_9 + 5.14448022842407) - 0.0240715989554891*std::sin(0.316319912672043*x_9 - 7.42663955688477) + 0.000600695227621076*std::sin(0.259039968252182*x_91 - 4.16463994979858) - 0.0137899792648052*std::sin(0.355039834976196*x_91 - 7.40223979949951) - 0.00436262246395502*std::sin(0.359519839286804*x_91 - 7.41016006469727) + 0.00170151040678981*std::sin(0.36575984954834*x_91 - 7.38615989685059) - 0.00392827103279453*std::sin(0.262719959020615*x_92 - 7.38695955276489) - 0.0106149209867335*std::sin(0.26599994301796*x_92 - 7.39991998672485) - 0.0212498435031814*std::sin(0.285919934511185*x_92 + 1.99951982498169) - 0.00368259224936048*std::sin(0.296799927949905*x_92 + 1.99463987350464) - 0.0114561005248114*std::sin(0.300159931182861*x_92 + 1.99007987976074) + 0.00830335617151207*std::sin(0.286479949951172*x_94 + 1.97767972946167) - 0.00593163489984799*std::sin(0.28671994805336*x_94 + 1.96495985984802) - 0.00297294903307458*std::sin(0.286959946155548*x_94 + 1.97103977203369) + 0.00314565349446952*std::sin(0.249199971556664*x_95 + 5.19456005096436) + 0.00844428039103421*std::sin(0.280399948358536*x_95 - 7.44032001495361) + 0.0170475949497075*std::sin(0.28263995051384*x_95 + 1.96735978126526) + 0.000986805856077221*std::sin(0.295519918203354*x_95 - 1.22903990745544) + 0.00933492564369283*std::sin(0.282559931278229*x_96 - 7.43711996078491) + 0.000870043924722789*std::sin(0.299439936876297*x_96 + 1.93367981910706) + 0.0118904960632905*std::sin(0.260399967432022*x_97 - 7.41359996795654) - 0.00247873161482417*std::sin(0.271919965744019*x_97 - 7.42767953872681) + 0.00559006811859229*std::sin(0.276479959487915*x_97 + 1.96783983707428) + 0.00676423374062762*std::sin(0.280159950256348*x_97 + 1.95407974720001) + 0.00415833369963178*std::sin(0.283359944820404*x_97 - 1.20615983009338) - 0.00532748633770224*std::sin(0.23191998898983*x_98 + 5.18480014801025) + 0.00239790199667681*std::sin(0.232239991426468*x_98 - 7.39911985397339) + 0.237841008649626);
}

inline float score_3(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.00265986591549982*x_10 - 0.00155995647920837*x_100 + 0.00011667769106463*x_101 - 0.000661682481608672*x_102 - 0.00249556997745717*x_103 + 0.0029970919906407*x_104 + 0.00356191650094342*x_105 + 0.00216662240161104*x_106 - 0.000595878456028631*x_107 + 0.0051707689263697*x_108 - 0.000996195501185667*x_109 - 0.000111261271537694*x_11 + 0.00223159773550199*x_110 - 0.00975138638526955*x_111 - 0.00192251128345338*x_112 - 0.00434691493377606*x_113 + 0.00334125098704404*x_114 + 0.00184032846283441*x_115 - 0.00733606993903749*x_116 + 0.0112525083966765*x_117 - 0.00563977484157025*x_118 + 0.00670770698252468*x_119 - 0.00284998981320478*x_120 - 0.00147812455490876*x_14 - 0.000149793231692001*x_15 - 0.000809563917271805*x_16 - 0.000295409360244267*x_19 + 0.000574072326044943*x_21 - 0.000362490924303318*x_22 + 0.000678559233082064*x_23 + 0.000178315833702717*x_24 - 0.000192782001624425*x_26 + 0.000518211033465355*x_27 - 0.000100887093013519*x_28 + 0.00106293262312435*x_29 + 0.000191079917057078*x_31 + 0.00153842226458604*x_32 - 0.00540514247433321*x_33 - 0.0045282921287556*x_34 + 0.000909237949590398*x_35 - 0.0160835440006282*x_36 + 0.00326104814781653*x_37 - 0.0066740371647815*x_38 - 0.00481460614001401*x_39 - 0.000375090160050844*x_4 - 0.00239186435309094*x_40 - 0.00121253951129985*x_41 - 0.00904846744224192*x_42 - 0.000345100394168612*x_43 + 0.00185046176167928*x_44 - 0.00659404464144627*x_45 - 0.00958984006572521*x_46 + 0.00126417843049959*x_47 - 0.0120612710754191*x_48 + 0.000373643340634953*x_49 + 0.000194427684288319*x_50 + 0.00146103357432834*x_51 + 0.000811445277996889*x_52 - 0.000682447150874136*x_53 + 0.00465656169217291*x_54 + 0.00572650198119196*x_55 - 0.00181990867264893*x_56 + 0.00356611560766808*x_57 - 0.00178164115448435*x_58 + 0.0149274866328962*x_59 - 0.00031714482636377*x_6 - 0.00642022064651355*x_60 - 0.000977774869840415*x_61 + 0.000650367226442631*x_62 + 0.00133413298091347*x_63 - 0.000866968469871582*x_64 + 0.000386902167862473*x_65 - 0.00278449031179634*x_66 - 0.000788699613767816*x_67 + 0.00231991619508193*x_68 - 0.00557676708421682*x_69 - 0.000334665435471853*x_70 - 0.00215895136295878*x_71 - 6.37982175359292e-5*x_72 + 0.000977190684767674*x_73 + 0.00122321570019683*x_74 + 0.00128425772512499*x_75 - 0.00294046160838593*x_76 + 0.0020320136609168*x_77 - 0.00300257562205372*x_78 + 0.005249289200464*x_79 + 0.00195791845313407*x_80 + 0.00201622911442793*x_81 + 9.17792210999336e-5*x_82 + 0.000152404468960922*x_83 + 0.00179342451938307*x_84 - 0.00235440155694209*x_85 + 0.00349564933625635*x_86 + 0.00326926182623241*x_87 - 0.00435852076696813*x_88 - 0.000613641716229524*x_89 + 0.000103391572969723*x_9 - 0.00165364070228743*x_90 + 0.000150659721628232*x_91 - 0.0151893412542746*x_93 + 2.14885750394346e-5*x_94 + 0.00021757731413752*x_95 - 0.000914920113183646*x_96 + 0.00389928696398179*x_98 - 0.00177495358129505*x_99 + 5.47525324147755e-5*std::pow(-3.08031988143921*x_22 - 8.18991947174072, 2) - 1.84394247997802e-6*std::pow(-7.29407978057861*x_24 - 1.18351984024048, 2) + 1.33082738684437e-6*std::pow(-5.27952003479004*x_55 - 8.32055950164795, 2) - 1.36402185285691e-5*std::pow(-2.59631991386414*x_56 - 9.37975978851318, 2) - 8.40483740878835e-6*std::pow(-3.85775995254517*x_59 - 9.14136028289795, 2) - 5.09882558983494e-6*std::pow(-2.80672001838684*x_59 - 8.59552001953125, 2) + 2.7531116748106e-6*std::pow(-4.6854395866394*x_61 - 8.77040004730225, 2) + 1.46866691253706e-5*std::pow(-3.75288009643555*x_65 - 9.44944000244141, 2) - 0.000476934475460834*std::exp(0.299919843673706*x_10) - 0.00219010698028843*std::exp(0.228399842977524*x_18) + 0.000244995829878206*std::exp(0.331679850816727*x_30) - 1.72492640378071e-20*std::exp(-0.00680499875325231*x_10 - 0.0684157871320231*x_100 - 0.134579124595974*x_101 - 0.121909641609164*x_102 - 0.282249699214315*x_103 + 0.0606689065290872*x_104 - 0.0839818478632825*x_105 + 0.0474658281550557*x_106 - 0.175072273455913*x_107 + 0.103039185071401*x_108 + 0.185741895308354*x_109 + 0.0805165286445579*x_110 - 0.423437783271904*x_111 - 0.218700320225475*x_112 - 0.0684294601541679*x_113 - 0.173297890953637*x_114 - 0.294278276383816*x_115 + 0.0222001182866643*x_116 - 0.23595626177513*x_117 - 0.0602599460679073*x_118 - 0.196222523048157*x_2 + 0.0309197543747376*x_22 + 0.00492403919384124*x_23 - 0.110297188073833*x_27 + 0.066204681126205*x_28 + 0.0470877518512691*x_29 - 0.0605669617144712*x_33 + 0.0133116247743918*x_35 + 0.0960403869659264*x_36 - 0.202236121564748*x_37 - 0.0989558380191559*x_38 + 0.166121172657262*x_39 + 0.0143729837134357*x_40 - 0.00607228499780299*x_41 - 0.0885526069578594*x_42 - 0.0630212174885343*x_43 - 0.25763777507042*x_44 - 0.124422516695299*x_45 - 0.0579793334779954*x_46 - 0.0974478109483093*x_48 - 0.00411244517488224*x_50 + 0.779643128388204*x_51 - 0.0401548866661217*x_52 - 0.544004605625608*x_54 - 0.148619474861918*x_55 + 0.0353219485576599*x_58 - 0.260990811432858*x_59 - 0.0156797584248698*x_61 - 0.0378971549886936*x_62 + 0.00805804534936842*x_63 + 0.0736053111636101*x_64 - 0.0496352092052574*x_65 + 0.0268857186404779*x_66 + 0.0791713162069334*x_67 - 0.0391717904415891*x_68 - 0.00812701090452622*x_69 + 0.0315886301807283*x_70 - 0.105121123844689*x_71 + 0.0409248594926991*x_72 - 0.0321429043477288*x_73 + 0.0380145046154094*x_74 + 0.0600594643116526*x_75 - 0.0499774225863618*x_76 + 0.0312664015319324*x_77 - 0.137641580854984*x_78 + 0.0109843304051493*x_79 + 0.0390399315797438*x_80 - 0.0548519998429257*x_81 - 0.0509496372057253*x_82 - 0.0382510091179546*x_83 - 0.0313619600001777*x_84 - 0.0328222513652485*x_85 - 0.00781671012173732*x_86 - 0.00621476344172637*x_87 + 0.00582681448247108*x_88 - 0.0430255790796514*x_89 - 0.0497533996923095*x_90 + 0.064118178915271*x_93 + 0.104468325892967*x_99 - 0.65886530256472*std::sin(0.365919858217239*x_1 - 4.23160028457642) + 0.93256422800718*std::sin(0.292959928512573*x_11 - 7.44855976104736) - 1.77248619651388*std::sin(0.23599998652935*x_119 + 5.17160034179688) - 3.92272777910517*std::sin(0.292959928512573*x_12 - 4.27135992050171) - 3.73141603634645*std::sin(0.262639969587326*x_120 + 5.16879987716675) + 2.8887969603675*std::sin(0.216639995574951*x_13 - 1.17511987686157) - 0.234936826314692*std::sin(0.654879808425903*x_14 - 4.47160005569458) - 1.72664914870133*std::sin(0.291679948568344*x_15 + 5.15560007095337) - 2.60512912040383*std::sin(0.299759924411774*x_16 - 7.40511989593506) + 2.40386433009942*std::sin(0.314799934625626*x_17 + 2.02759981155396) + 1.8314793331694*std::sin(0.395679831504822*x_18 + 2.01239991188049) - 2.19227459261234*std::sin(0.331279844045639*x_19 - 1.16599988937378) - 0.660953201686979*std::sin(0.270879954099655*x_20 + 1.9923198223114) + 1.83366271251283*std::sin(0.339919835329056*x_21 - 1.13927984237671) - 0.879623507412688*std::sin(0.363439828157425*x_24 - 1.15135991573334) - 1.70086099875991*std::sin(0.363119840621948*x_25 + 2.03151988983154) + 2.92044684429558*std::sin(0.333199828863144*x_26 - 1.14551985263824) - 5.11085915504299*std::sin(0.360559850931168*x_3 - 7.41143989562988) + 7.13206297668205*std::sin(0.325919836759567*x_30 - 1.15055990219116) + 1.56810716430157*std::sin(0.357999831438065*x_31 + 5.16495990753174) + 1.41604224633427*std::sin(0.336319833993912*x_32 + 1.99399983882904) + 1.92628701727784*std::sin(0.185760006308556*x_34 - 1.19479990005493) + 1.1003937516763*std::sin(0.324959844350815*x_4 - 1.16639983654022) - 4.38510564284022*std::sin(0.153200030326843*x_47 - 1.17551982402802) - 11.3953333519891*std::sin(0.0819200873374939*x_49 - 1.29207980632782) + 0.502120287939821*std::sin(0.402399837970734*x_5 + 8.21047973632813) - 2.49224867279781*std::sin(0.256639957427979*x_53 - 7.42983961105347) + 2.43335936740323*std::sin(0.0958400741219521*x_56 + 7.95592021942139) - 4.17826931718056*std::sin(0.163920015096664*x_57 - 1.17575979232788) + 5.67193211189152*std::sin(0.344559848308563*x_6 + 2.00063967704773) - 1.15047514585135*std::sin(0.41543984413147*x_60 - 1.21631991863251) + 7.03704150595593*std::sin(0.357119828462601*x_7 + 1.99847972393036) - 2.89689496361603*std::sin(0.334959834814072*x_8 - 1.14431989192963) + 1.62225266156443*std::sin(0.306639939546585*x_9 - 1.19591987133026) - 0.421813210074578*std::sin(0.259039968252182*x_91 - 4.16463994979858) + 2.58594706045906*std::sin(0.296799927949905*x_92 + 1.99463987350464) + 2.08762966204279*std::sin(0.286959946155548*x_94 + 1.97103977203369) - 0.692943320893001*std::sin(0.295519918203354*x_95 - 1.22903990745544) - 0.610952116677559*std::sin(0.299439936876297*x_96 + 1.93367981910706) + 1.7405860597612*std::sin(0.271919965744019*x_97 - 7.42767953872681) - 1.68382682623962*std::sin(0.232239991426468*x_98 - 7.39911985397339)) + 0.0186604879596291*std::sin(0.31879985332489*x_1 - 4.26864004135132) + 0.0151414484847173*std::sin(0.326959848403931*x_1 - 4.2611198425293) + 0.415717631877808*std::sin(0.358239859342575*x_1 + 8.35488033294678) - 0.0103191389933663*std::sin(0.361999839544296*x_1 + 5.17400026321411) + 0.00256142821008175*std::sin(0.263839960098267*x_10 + 1.99799978733063) - 0.0324116923167916*std::sin(0.243119969964027*x_100 - 7.42335987091064) + 0.00242028578601295*std::sin(0.250079959630966*x_100 - 1.2054398059845) + 0.0586883527366841*std::sin(0.2291199862957*x_101 - 7.40719985961914) - 0.0146154077904263*std::sin(0.237119987607002*x_101 + 1.98511981964111) - 0.0418593122731485*std::sin(0.220159992575645*x_102 + 2.00143980979919) - 0.00685482479895005*std::sin(0.239199981093407*x_106 + 8.17751979827881) - 0.00571637555532704*std::sin(0.246319979429245*x_108 - 1.19671988487244) + 0.00516298284160959*std::sin(0.256719976663589*x_108 + 1.97239983081818) + 0.040616695433756*std::sin(0.23479999601841*x_109 - 7.42360019683838) - 0.0100764203302913*std::sin(0.274879962205887*x_11 - 7.44007968902588) + 0.0270405973947395*std::sin(0.286479949951172*x_11 - 7.44456005096436) + 0.131337655885965*std::sin(0.293119937181473*x_11 - 7.43735980987549) - 0.0119814530327834*std::sin(0.231119990348816*x_112 - 4.20911979675293) - 0.0276444947268627*std::sin(0.281519949436188*x_112 + 5.14000034332275) - 0.0199209148107888*std::sin(0.292479932308197*x_113 - 7.43639993667603) - 0.0177116125540005*std::sin(0.251439958810806*x_116 - 7.41999959945679) - 0.0434297487728077*std::sin(0.219679996371269*x_118 - 4.21519994735718) + 0.0782578529259731*std::sin(0.291119933128357*x_12 - 7.45567989349365) + 0.00878903320711854*std::sin(0.295039921998978*x_12 - 4.26959991455078) + 0.0170815379721506*std::sin(0.296319931745529*x_12 + 5.12960004806519) + 0.0263805828257841*std::sin(0.297279924154282*x_12 - 4.26855993270874) - 0.05665050050441*std::sin(0.266719967126846*x_120 + 5.15808010101318) + 0.00750626626017797*std::sin(0.267679959535599*x_120 + 5.16016006469727) + 0.0199628874955825*std::sin(0.192479997873306*x_13 + 8.19071960449219) + 0.00701912852967998*std::sin(0.19344000518322*x_13 + 1.97303986549377) - 0.086264448783092*std::sin(0.232239991426468*x_13 + 1.98807990550995) + 0.0201876631202265*std::sin(0.295279920101166*x_13 - 7.43551969528198) + 0.0257082182516505*std::sin(0.30159991979599*x_14 - 7.4423999786377) + 0.1411024073766*std::sin(0.310879945755005*x_14 - 7.44575977325439) + 0.00220826163122108*std::sin(0.339599847793579*x_14 - 4.33360004425049) + 0.0246748105187808*std::sin(0.288399934768677*x_15 + 1.96623980998993) + 0.0277783834711556*std::sin(0.295359939336777*x_15 - 7.43336009979248) + 0.00899087693807891*std::sin(0.423679858446121*x_15 + 8.16016006469727) - 0.0612470494392584*std::sin(0.219439998269081*x_16 + 1.98215985298157) + 0.00541106562302578*std::sin(0.337919861078262*x_16 - 1.15591979026794) + 0.00737120611418073*std::sin(0.342799842357635*x_16 - 1.14039981365204) - 0.0290435483038068*std::sin(0.346559852361679*x_17 + 2.02431988716125) - 0.044000981743469*std::sin(0.347679853439331*x_17 - 1.15719985961914) + 0.00836833735985449*std::sin(0.35471984744072*x_17 - 1.15351986885071) + 0.0175706202173765*std::sin(0.361119836568832*x_17 + 2.00263977050781) + 0.0677359128689069*std::sin(0.117200054228306*x_18 - 1.28391993045807) - 0.0318442289543045*std::sin(0.414719849824905*x_18 - 7.41239976882935) + 0.00148363749833845*std::sin(0.46687987446785*x_18 - 7.43407964706421) - 0.0144199349097346*std::sin(0.241439983248711*x_19 - 1.16903984546661) - 0.0159114730118927*std::sin(0.287599951028824*x_19 - 1.19359982013702) + 0.0785993971608089*std::sin(0.313359916210175*x_19 - 7.41943979263306) + 0.0195542159167988*std::sin(0.372159838676453*x_2 + 5.19632005691528) + 0.0143687900862779*std::sin(0.375199824571609*x_2 + 5.17495965957642) + 0.00503588611793255*std::sin(0.393439829349518*x_2 + 5.18728017807007) + 0.0200576893190571*std::sin(0.404799848794937*x_2 + 2.01151990890503) + 0.0237412330144768*std::sin(0.202480003237724*x_20 + 1.9812798500061) - 0.00467327464310425*std::sin(0.246639966964722*x_20 - 1.16767990589142) + 0.0178592275169204*std::sin(0.344479858875275*x_20 - 4.3635196685791) - 0.0335974514402331*std::sin(0.403279840946198*x_20 + 8.19911956787109) - 0.0163758352106221*std::sin(0.314639925956726*x_21 - 7.40407991409302) - 0.00219618558790601*std::sin(0.33247983455658*x_21 + 8.24967956542969) + 0.13575563666625*std::sin(0.360639840364456*x_22 + 1.99255979061127) + 0.00209251422317576*std::sin(0.394959837198257*x_22 - 7.40967988967896) + 0.00172650897849579*std::sin(0.241119980812073*x_23 - 4.37519979476929) + 0.105758837961541*std::sin(0.3643998503685*x_23 + 2.00103974342346) - 0.0493892981641054*std::sin(0.285839945077896*x_24 - 1.15983986854553) - 0.00378257998768052*std::sin(0.306479930877686*x_24 + 1.9890398979187) - 0.0258402443275324*std::sin(0.207600012421608*x_25 + 2.0052797794342) + 0.000853037427311751*std::sin(0.275919944047928*x_25 - 1.16351985931396) - 0.00973927587256444*std::sin(0.324399828910828*x_25 - 1.1555198431015) + 0.0277715144373511*std::sin(0.378719836473465*x_25 + 2.0130398273468) - 0.0651733331698334*std::sin(0.299519926309586*x_26 + 1.992959856987) + 0.0186601514059827*std::sin(0.332399845123291*x_26 - 1.15983986854553) - 0.00682033333284495*std::sin(0.337279856204987*x_26 - 1.14231979846954) + 0.0354495531491848*std::sin(0.316079914569855*x_27 + 2.00415992736816) + 0.0056958206088881*std::sin(0.319199919700623*x_27 + 5.1755199432373) + 0.0176814012093923*std::sin(0.338799834251404*x_28 - 4.3616795539856) + 0.00806509123519831*std::sin(0.415039867162704*x_28 - 1.20719993114471) - 0.00384598738061014*std::sin(0.557119846343994*x_28 + 4.81655979156494) + 0.0075838406441123*std::sin(0.296719938516617*x_29 - 1.18191993236542) + 0.00680073190466129*std::sin(0.300719946622849*x_29 + 1.98407983779907) - 0.0948456687443304*std::sin(0.301519930362701*x_29 + 1.98215973377228) + 0.0100643619784412*std::sin(0.296959936618805*x_3 + 8.28071975708008) + 0.0242770373657939*std::sin(0.320239841938019*x_3 + 5.19632005691528) - 0.00398061171455293*std::sin(0.346719831228256*x_3 - 7.38624000549316) + 0.00444053679201986*std::sin(0.400479853153229*x_3 + 2.17975974082947) + 0.128432302295815*std::sin(0.333119839429855*x_30 + 2.01231980323792) + 0.0290012084111803*std::sin(0.351359844207764*x_30 - 1.14287984371185) - 0.0254835604189331*std::sin(0.352639853954315*x_30 - 1.14095985889435) + 0.12770316534809*std::sin(0.365359842777252*x_31 + 5.17280006408691) - 0.00804779774878885*std::sin(0.368399828672409*x_31 + 5.17471981048584) + 0.00415137979659051*std::sin(0.421279847621918*x_31 - 7.38687992095947) + 0.0213012176028007*std::sin(0.303919941186905*x_32 - 1.15511989593506) + 0.0909606582222456*std::sin(0.308319926261902*x_32 + 2.02879977226257) + 0.00250289828605965*std::sin(0.316719859838486*x_32 + 2.00423979759216) - 0.00183850281384191*std::sin(0.219439998269081*x_35 - 7.40215969085693) + 0.060860507804724*std::sin(0.22919999063015*x_35 - 7.42343997955322) - 0.0183253739237737*std::sin(0.250639975070953*x_35 + 1.97823977470398) - 0.00514561772492375*std::sin(0.245919972658157*x_36 - 7.42759990692139) + 0.0379907911651285*std::sin(0.186000004410744*x_37 + 8.20440006256104) - 0.0028036527288244*std::sin(0.237679988145828*x_38 + 1.98759984970093) + 0.0107051155572869*std::sin(0.239919975399971*x_38 + 1.97351980209351) - 0.0110053744900907*std::sin(0.242159977555275*x_38 + 1.97287976741791) + 0.00213208626889221*std::sin(0.22495998442173*x_39 - 1.18631982803345) + 0.109009818988037*std::sin(0.319279909133911*x_4 + 2.00879979133606) - 0.0179649069060106*std::sin(0.330719828605652*x_4 - 7.38168001174927) - 0.000902531898472018*std::sin(0.386159837245941*x_4 + 1.99143981933594) + 0.0183513803962478*std::sin(0.189759999513626*x_40 + 2.000159740448) - 0.00294997597204223*std::sin(0.213359996676445*x_40 + 1.98591983318329) - 0.00707676381760422*std::sin(0.225519984960556*x_41 - 4.39015960693359) + 0.00284631571761368*std::sin(0.250879973173141*x_42 + 5.15895986557007) - 0.0116804752257751*std::sin(0.255599975585938*x_42 - 7.43623971939087) - 0.0647002138219119*std::sin(0.256719976663589*x_43 + 5.15768003463745) + 0.00432299736115254*std::sin(0.28263995051384*x_43 + 5.11055994033813) + 0.00119664173983806*std::sin(0.225679993629456*x_44 - 7.42191982269287) - 0.00131809129657398*std::sin(0.214000001549721*x_45 - 1.21471989154816) + 0.112001681084768*std::sin(0.213599994778633*x_47 + 1.9826397895813) - 0.019438115244341*std::sin(0.169840022921562*x_49 + 2.00367975234985) - 0.00484650561265466*std::sin(0.211759999394417*x_49 + 1.99351978302002) - 0.0750202115111923*std::sin(0.27295994758606*x_49 + 5.11960029602051) - 0.0382897939491425*std::sin(0.322399914264679*x_5 + 2.01399993896484) + 0.0194387749386157*std::sin(0.327759832143784*x_5 - 1.14439988136292) - 0.000762927966309879*std::sin(0.358959853649139*x_5 + 2.02503991127014) + 0.00782819345991656*std::sin(0.374239832162857*x_5 + 2.01015973091125) - 0.00312973723507957*std::sin(0.22775998711586*x_50 - 7.4364800453186) - 0.0186134494394844*std::sin(0.217600002884865*x_51 + 1.98359978199005) - 0.119609749553766*std::sin(0.222479999065399*x_52 - 7.41655969619751) - 0.0372907816222891*std::sin(0.223839998245239*x_52 + 1.98967981338501) + 0.0162519554941755*std::sin(0.25095996260643*x_53 + 5.15743970870972) - 0.0863404292044229*std::sin(0.25943997502327*x_53 - 7.4398398399353) - 0.00453252734694483*std::sin(0.224399983882904*x_54 + 1.9832798242569) - 0.00942077202836118*std::sin(0.240879982709885*x_55 - 7.44704008102417) - 0.000599631885520254*std::sin(0.51751983165741*x_57 - 4.48799991607666) + 0.0375389743688642*std::sin(0.151040032505989*x_58 - 4.38327980041504) + 0.0165698016368443*std::sin(0.146080031991005*x_59 - 1.21031987667084) + 0.0827993332502543*std::sin(0.284239947795868*x_6 - 7.382239818573) + 0.0167891920855585*std::sin(0.37271985411644*x_6 + 2.00519990921021) + 0.0140101749147618*std::sin(0.40447986125946*x_60 + 8.19551944732666) + 0.0533995384003181*std::sin(0.257439970970154*x_7 - 7.37671947479248) - 0.0314915068224312*std::sin(0.345999836921692*x_7 + 2.00303983688354) - 0.013389835054339*std::sin(0.361919850111008*x_7 + 2.0079197883606) + 0.000466728284315061*std::sin(0.412159860134125*x_7 + 4.98207950592041) - 0.00783768169330886*std::sin(0.144000038504601*x_71 - 4.31903982162476) + 0.00627945897939455*std::sin(0.254399985074997*x_8 - 4.38703966140747) + 0.00712283780771282*std::sin(0.292959928512573*x_8 - 7.41423988342285) - 0.0417065685285023*std::sin(0.29911994934082*x_8 - 7.41567993164063) + 0.00348848403419161*std::sin(0.337839841842651*x_8 - 1.15391993522644) + 0.0782595398418514*std::sin(0.271999955177307*x_9 + 2.00103974342346) - 0.0373929692191222*std::sin(0.314799934625626*x_9 + 5.14448022842407) - 0.0176488760146435*std::sin(0.316319912672043*x_9 - 7.42663955688477) - 0.0287895483523217*std::sin(0.355039834976196*x_91 - 7.40223979949951) + 0.0172575971170041*std::sin(0.359519839286804*x_91 - 7.41016006469727) + 0.000967389851514113*std::sin(0.36575984954834*x_91 - 7.38615989685059) - 0.00223340951425149*std::sin(0.262719959020615*x_92 - 7.38695955276489) + 0.0419903467080681*std::sin(0.26599994301796*x_92 - 7.39991998672485) - 0.0155800141906529*std::sin(0.285919934511185*x_92 + 1.99951982498169) - 0.023917074395454*std::sin(0.300159931182861*x_92 + 1.99007987976074) + 0.017335042308323*std::sin(0.286479949951172*x_94 + 1.97767972946167) + 0.0234642731963415*std::sin(0.28671994805336*x_94 + 1.96495985984802) + 0.006567228393868*std::sin(0.249199971556664*x_95 + 5.19456005096436) - 0.0334037588939963*std::sin(0.280399948358536*x_95 - 7.44032001495361) + 0.0124989989311301*std::sin(0.28263995051384*x_95 + 1.96735978126526) + 0.00684420447499531*std::sin(0.282559931278229*x_96 - 7.43711996078491) + 0.00871790408113991*std::sin(0.260399967432022*x_97 - 7.41359996795654) + 0.0116704697884299*std::sin(0.276479959487915*x_97 + 1.96783983707428) + 0.0038457896277568*std::sin(0.280159950256348*x_97 + 1.95407974720001) - 0.0164494746587006*std::sin(0.283359944820404*x_97 - 1.20615983009338) - 0.0111222738316263*std::sin(0.23191998898983*x_98 + 5.18480014801025) - 0.293445820072147);
}

inline float score_4(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.0011533257108274*x_10 - 0.000333462818776188*x_100 - 0.00125655689823898*x_101 - 0.000534314211713202*x_102 - 0.00123965001353025*x_103 + 0.0015694914779911*x_104 + 0.000278873312375343*x_105 + 0.00095441465184716*x_106 - 0.00174892848630381*x_107 + 0.00064986443853821*x_108 + 0.000597650528606451*x_109 + 2.07973949407474e-5*x_11 + 0.00149878202094428*x_110 - 0.00497463708857065*x_111 - 0.0011204429884981*x_112 - 0.000563205387074385*x_113 + 0.00102978379177677*x_114 + 0.000136283197219267*x_115 - 0.00231686603514928*x_116 + 0.00381044258458398*x_117 + 8.77055202613995e-5*x_118 + 0.00272416107574705*x_119 - 0.00163118315631367*x_120 + 0.000276296861569115*x_14 - 0.000213831936452324*x_15 - 0.000458913511512041*x_16 - 0.00042170099966237*x_19 - 0.00117432227986857*x_2 - 0.000166689361123334*x_21 - 2.04396701321811e-5*x_22 - 0.000200870996969325*x_23 + 0.000101081018628498*x_24 - 0.000275199007691261*x_26 - 0.000168141708902639*x_27 + 0.000252193822139724*x_28 + 8.31159609349825e-5*x_29 - 3.57174104282545e-5*x_31 - 0.000287567946869951*x_32 - 0.00322126580985774*x_33 - 0.00141081804301077*x_34 + 0.000595080597458465*x_35 - 0.00311311732795765*x_36 + 2.57412455894662e-5*x_37 - 0.00323936582189028*x_38 - 0.000232412585241464*x_39 + 7.01133295454265e-5*x_4 - 0.000323138648247472*x_40 - 8.55916668953729e-5*x_41 - 0.00392553137674516*x_42 - 0.000519181634901683*x_43 - 0.000877685061054916*x_44 - 0.00375097916440685*x_45 - 0.00470447027067334*x_46 + 0.00100239533376044*x_47 - 0.00587809392527186*x_48 - 6.98428843636992e-5*x_49 + 0.000628647668272698*x_50 + 0.00488392806972293*x_51 - 0.000126642332712869*x_52 - 0.00115923276755698*x_53 - 0.000506367767024606*x_54 + 0.00195196009074286*x_55 - 0.00299681832680048*x_56 + 0.00194449545346324*x_57 + 0.000279948536795897*x_58 + 0.00435881149416785*x_59 - 0.000297328735831911*x_6 - 0.00257216609155397*x_60 - 0.000770893547010296*x_61 - 7.1850574135792e-5*x_62 + 0.000256739303062891*x_63 + 0.000376243871761904*x_64 - 0.000729816182045878*x_65 - 0.000946704708203757*x_66 - 0.000205284186078299*x_67 + 0.000818321873517186*x_68 - 0.00211377163675321*x_69 + 0.000352596494945067*x_70 - 0.00135652053520762*x_71 + 0.000169947762981661*x_72 + 0.000425471321956323*x_73 + 0.00137413682818856*x_74 + 0.000496438303952218*x_75 - 0.000998697169185899*x_76 + 0.00172362071495886*x_77 - 0.00187183019424167*x_78 + 0.00190225434570698*x_79 + 0.00101503858273179*x_80 + 0.00136106198902055*x_81 - 0.000118297833802758*x_82 - 0.000188534633494594*x_83 + 0.000633047289192238*x_84 - 0.000972334964108934*x_85 + 0.0010720905683627*x_86 + 0.00144184035159806*x_87 - 0.00150420117665984*x_88 - 0.000300104866846797*x_89 + 0.000147592918660211*x_9 - 0.00122536046732228*x_90 + 8.54037345548166e-5*x_91 - 0.00428214542956075*x_93 + 2.64239859742693e-5*x_94 + 0.000310594663621281*x_95 + 0.000524761455884481*x_96 + 0.00158193917544866*x_98 + 9.62626543038652e-5*x_99 - 1.02345589341065e-5*std::pow(-3.08031988143921*x_22 - 8.18991947174072, 2) + 3.44676988444552e-7*std::pow(-7.29407978057861*x_24 - 1.18351984024048, 2) + 1.89977473613658e-6*std::pow(-5.27952003479004*x_55 - 8.32055950164795, 2) - 7.7321635132061e-6*std::pow(-2.59631991386414*x_56 - 9.37975978851318, 2) + 1.57106530050862e-6*std::pow(-3.85775995254517*x_59 - 9.14136028289795, 2) - 7.27864495072038e-6*std::pow(-2.80672001838684*x_59 - 8.59552001953125, 2) + 3.93010547969698e-6*std::pow(-4.6854395866394*x_61 - 8.77040004730225, 2) + 5.82523261684926e-6*std::pow(-3.75288009643555*x_65 - 9.44944000244141, 2) + 8.91504699697475e-5*std::exp(0.299919843673706*x_10) - 0.00124149515988588*std::exp(0.228399842977524*x_18) + 0.000349734978902912*std::exp(0.331679850816727*x_30) + 0.010577978925914*std::sin(0.31879985332489*x_1 - 4.26864004135132) + 0.0216146298040856*std::sin(0.326959848403931*x_1 - 4.2611198425293) + 0.164887755551777*std::sin(0.358239859342575*x_1 + 8.35488033294678) + 0.00192889408980731*std::sin(0.361999839544296*x_1 + 5.17400026321411) - 0.00394307540345004*std::sin(0.365919858217239*x_1 - 4.23160028457642) + 0.00365647464881178*std::sin(0.263839960098267*x_10 + 1.99799978733063) - 0.0128555798213567*std::sin(0.243119969964027*x_100 - 7.42335987091064) + 0.00345499186141681*std::sin(0.250079959630966*x_100 - 1.2054398059845) + 0.0232777972780986*std::sin(0.2291199862957*x_101 - 7.40719985961914) - 0.00828496424826831*std::sin(0.237119987607002*x_101 + 1.98511981964111) - 0.0166028273048788*std::sin(0.220159992575645*x_102 + 2.00143980979919) + 0.00128133084066988*std::sin(0.239199981093407*x_106 + 8.17751979827881) - 0.00324041366376259*std::sin(0.246319979429245*x_108 - 1.19671988487244) + 0.00737023032630424*std::sin(0.256719976663589*x_108 + 1.97239983081818) + 0.0161099631924456*std::sin(0.23479999601841*x_109 - 7.42360019683838) - 0.0143842311658253*std::sin(0.274879962205887*x_11 - 7.44007968902588) + 0.0153283702979526*std::sin(0.286479949951172*x_11 - 7.44456005096436) + 0.00558106650217976*std::sin(0.292959928512573*x_11 - 7.44855976104736) + 0.0520929824425481*std::sin(0.293119937181473*x_11 - 7.43735980987549) - 0.00475225188284861*std::sin(0.231119990348816*x_112 - 4.20911979675293) - 0.0156706986050384*std::sin(0.281519949436188*x_112 + 5.14000034332275) - 0.0112924708887216*std::sin(0.292479932308197*x_113 - 7.43639993667603) - 0.0100400945969634*std::sin(0.251439958810806*x_116 - 7.41999959945679) - 0.0172257158470263*std::sin(0.219679996371269*x_118 - 4.21519994735718) - 0.0106077019038987*std::sin(0.23599998652935*x_119 + 5.17160034179688) + 0.0310397268092241*std::sin(0.291119933128357*x_12 - 7.45567989349365) - 0.0234761359567883*std::sin(0.292959928512573*x_12 - 4.27135992050171) + 0.0125464680145645*std::sin(0.295039921998978*x_12 - 4.26959991455078) + 0.00968292732122106*std::sin(0.296319931745529*x_12 + 5.12960004806519) - 0.00493116240909625*std::sin(0.297279924154282*x_12 - 4.26855993270874) - 0.0223312029570891*std::sin(0.262639969587326*x_120 + 5.16879987716675) + 0.0105893346022211*std::sin(0.266719967126846*x_120 + 5.15808010101318) + 0.0107153002295918*std::sin(0.267679959535599*x_120 + 5.16016006469727) - 0.00373154152981865*std::sin(0.192479997873306*x_13 + 8.19071960449219) + 0.0100199042957785*std::sin(0.19344000518322*x_13 + 1.97303986549377) + 0.0172884263227193*std::sin(0.216639995574951*x_13 - 1.17511987686157) - 0.0342154151112265*std::sin(0.232239991426468*x_13 + 1.98807990550995) + 0.0114436811894308*std::sin(0.295279920101166*x_13 - 7.43551969528198) + 0.0145730910937102*std::sin(0.30159991979599*x_14 - 7.4423999786377) + 0.0559660150814067*std::sin(0.310879945755005*x_14 - 7.44575977325439) + 0.0031523244105467*std::sin(0.339599847793579*x_14 - 4.33360004425049) - 0.00140601366865131*std::sin(0.654879808425903*x_14 - 4.47160005569458) + 0.00978686929089172*std::sin(0.288399934768677*x_15 + 1.96623980998993) - 0.0103333834125578*std::sin(0.291679948568344*x_15 + 5.15560007095337) + 0.0157465954582509*std::sin(0.295359939336777*x_15 - 7.43336009979248) - 0.00168061011671554*std::sin(0.423679858446121*x_15 + 8.16016006469727) - 0.024292663437418*std::sin(0.219439998269081*x_16 + 1.98215985298157) - 0.0155907748025125*std::sin(0.299759924411774*x_16 - 7.40511989593506) + 0.00772437197176774*std::sin(0.337919861078262*x_16 - 1.15591979026794) - 0.001377854869242*std::sin(0.342799842357635*x_16 - 1.14039981365204) + 0.0143862763395632*std::sin(0.314799934625626*x_17 + 2.02759981155396) + 0.00542893440104452*std::sin(0.346559852361679*x_17 + 2.02431988716125) - 0.0174522862765846*std::sin(0.347679853439331*x_17 - 1.15719985961914) + 0.0119459187997449*std::sin(0.35471984744072*x_17 - 1.15351986885071) + 0.00996017096534392*std::sin(0.361119836568832*x_17 + 2.00263977050781) - 0.0126614635275802*std::sin(0.117200054228306*x_18 - 1.28391993045807) + 0.010960754925834*std::sin(0.395679831504822*x_18 + 2.01239991188049) - 0.0126305045466427*std::sin(0.414719849824905*x_18 - 7.41239976882935) + 0.00211791331076499*std::sin(0.46687987446785*x_18 - 7.43407964706421) - 0.00817415749889406*std::sin(0.241439983248711*x_19 - 1.16903984546661) + 0.00297423518304178*std::sin(0.287599951028824*x_19 - 1.19359982013702) + 0.0311751948721238*std::sin(0.313359916210175*x_19 - 7.41943979263306) - 0.0131199867257982*std::sin(0.331279844045639*x_19 - 1.16599988937378) - 0.00365515102926478*std::sin(0.372159838676453*x_2 + 5.19632005691528) + 0.00814516528465696*std::sin(0.375199824571609*x_2 + 5.17495965957642) + 0.00718879797296207*std::sin(0.393439829349518*x_2 + 5.18728017807007) + 0.0079555619482271*std::sin(0.404799848794937*x_2 + 2.01151990890503) + 0.0134580758576981*std::sin(0.202480003237724*x_20 + 1.9812798500061) - 0.00667116501340487*std::sin(0.246639966964722*x_20 - 1.16767990589142) - 0.00395557073996544*std::sin(0.270879954099655*x_20 + 1.9923198223114) - 0.00333831712394389*std::sin(0.344479858875275*x_20 - 4.3635196685791) - 0.0133258922293394*std::sin(0.403279840946198*x_20 + 8.19911956787109) - 0.00928288907165557*std::sin(0.314639925956726*x_21 - 7.40407991409302) - 0.00313508568956061*std::sin(0.33247983455658*x_21 + 8.24967956542969) + 0.010973821677645*std::sin(0.339919835329056*x_21 - 1.13927984237671) + 0.0538453039200894*std::sin(0.360639840364456*x_22 + 1.99255979061127) + 0.00298709336424308*std::sin(0.394959837198257*x_22 - 7.40967988967896) + 0.00246461575068477*std::sin(0.241119980812073*x_23 - 4.37519979476929) + 0.0419475530601701*std::sin(0.3643998503685*x_23 + 2.00103974342346) - 0.0195894758799899*std::sin(0.285839945077896*x_24 - 1.15983986854553) - 0.00539968591648141*std::sin(0.306479930877686*x_24 + 1.9890398979187) - 0.00526423504603162*std::sin(0.363439828157425*x_24 - 1.15135991573334) + 0.0048301602095481*std::sin(0.207600012421608*x_25 + 2.0052797794342) + 0.00121772287631418*std::sin(0.275919944047928*x_25 - 1.16351985931396) - 0.00552085535793766*std::sin(0.324399828910828*x_25 - 1.1555198431015) - 0.0101790504717599*std::sin(0.363119840621948*x_25 + 2.03151988983154) + 0.0110151274151262*std::sin(0.378719836473465*x_25 + 2.0130398273468) - 0.0258499611374691*std::sin(0.299519926309586*x_26 + 1.992959856987) - 0.00348802897073566*std::sin(0.332399845123291*x_26 - 1.15983986854553) + 0.0174778396646468*std::sin(0.333199828863144*x_26 - 1.14551985263824) - 0.00386620877324458*std::sin(0.337279856204987*x_26 - 1.14231979846954) + 0.0140604987757666*std::sin(0.316079914569855*x_27 + 2.00415992736816) + 0.00322876178248677*std::sin(0.319199919700623*x_27 + 5.1755199432373) + 0.00701304524241133*std::sin(0.338799834251404*x_28 - 4.3616795539856) + 0.00457181855619585*std::sin(0.415039867162704*x_28 - 1.20719993114471) + 0.000718907103848627*std::sin(0.557119846343994*x_28 + 4.81655979156494) + 0.00429901440329241*std::sin(0.296719938516617*x_29 - 1.18191993236542) + 0.00970814005439795*std::sin(0.300719946622849*x_29 + 1.98407983779907) - 0.0376190188816834*std::sin(0.301519930362701*x_29 + 1.98215973377228) + 0.00570513531806042*std::sin(0.296959936618805*x_3 + 8.28071975708008) - 0.00453795940950253*std::sin(0.320239841938019*x_3 + 5.19632005691528) - 0.00568237898049911*std::sin(0.346719831228256*x_3 - 7.38624000549316) - 0.0305866812932798*std::sin(0.360559850931168*x_3 - 7.41143989562988) + 0.00176126795915275*std::sin(0.400479853153229*x_3 + 2.17975974082947) + 0.0426828700642484*std::sin(0.325919836759567*x_30 - 1.15055990219116) + 0.0509406203683198*std::sin(0.333119839429855*x_30 + 2.01231980323792) - 0.00542102006161146*std::sin(0.351359844207764*x_30 - 1.14287984371185) - 0.014445740414287*std::sin(0.352639853954315*x_30 - 1.14095985889435) + 0.0093845658064896*std::sin(0.357999831438065*x_31 + 5.16495990753174) + 0.0506514198495513*std::sin(0.365359842777252*x_31 + 5.17280006408691) - 0.0114883440150258*std::sin(0.368399828672409*x_31 + 5.17471981048584) + 0.00235327222400633*std::sin(0.421279847621918*x_31 - 7.38687992095947) + 0.0120749163358541*std::sin(0.303919941186905*x_32 - 1.15511989593506) + 0.0360780915402376*std::sin(0.308319926261902*x_32 + 2.02879977226257) + 0.00357292236241884*std::sin(0.316719859838486*x_32 + 2.00423979759216) + 0.00847451114823024*std::sin(0.336319833993912*x_32 + 1.99399983882904) + 0.0115281453253752*std::sin(0.185760006308556*x_34 - 1.19479990005493) - 0.00262448851938252*std::sin(0.219439998269081*x_35 - 7.40215969085693) + 0.0241393478749825*std::sin(0.22919999063015*x_35 - 7.42343997955322) + 0.00342545104565406*std::sin(0.250639975070953*x_35 + 1.97823977470398) - 0.00734544137899525*std::sin(0.245919972658157*x_36 - 7.42759990692139) - 0.00710138826433374*std::sin(0.186000004410744*x_37 + 8.20440006256104) - 0.00400225354224985*std::sin(0.237679988145828*x_38 + 1.98759984970093) - 0.00200104234882672*std::sin(0.239919975399971*x_38 + 1.97351980209351) - 0.00623856244701785*std::sin(0.242159977555275*x_38 + 1.97287976741791) + 0.00120860524490919*std::sin(0.22495998442173*x_39 - 1.18631982803345) + 0.0432370027339281*std::sin(0.319279909133911*x_4 + 2.00879979133606) + 0.00658546674025033*std::sin(0.324959844350815*x_4 - 1.16639983654022) - 0.0101836783190725*std::sin(0.330719828605652*x_4 - 7.38168001174927) - 0.00128837692718375*std::sin(0.386159837245941*x_4 + 1.99143981933594) + 0.0072787817806669*std::sin(0.189759999513626*x_40 + 2.000159740448) - 0.00421113202154982*std::sin(0.213359996676445*x_40 + 1.98591983318329) - 0.00401157025948298*std::sin(0.225519984960556*x_41 - 4.39015960693359) + 0.00406315555634361*std::sin(0.250879973173141*x_42 + 5.15895986557007) - 0.00662125347687667*std::sin(0.255599975585938*x_42 - 7.43623971939087) - 0.0256623059085231*std::sin(0.256719976663589*x_43 + 5.15768003463745) - 0.000808071687525504*std::sin(0.28263995051384*x_43 + 5.11055994033813) + 0.00170822284544459*std::sin(0.225679993629456*x_44 - 7.42191982269287) - 0.00188159378887624*std::sin(0.214000001549721*x_45 - 1.21471989154816) - 0.0262433036532756*std::sin(0.153200030326843*x_47 - 1.17551982402802) + 0.0444236770248935*std::sin(0.213599994778633*x_47 + 1.9826397895813) - 0.0681970328069116*std::sin(0.0819200873374939*x_49 - 1.29207980632782) - 0.011018788675782*std::sin(0.169840022921562*x_49 + 2.00367975234985) - 0.00691845464895157*std::sin(0.211759999394417*x_49 + 1.99351978302002) - 0.029755568079287*std::sin(0.27295994758606*x_49 + 5.11960029602051) - 0.0151870349022623*std::sin(0.322399914264679*x_5 + 2.01399993896484) - 0.00363357234710128*std::sin(0.327759832143784*x_5 - 1.14439988136292) - 0.00108909035853578*std::sin(0.358959853649139*x_5 + 2.02503991127014) + 0.00443752948080042*std::sin(0.374239832162857*x_5 + 2.01015973091125) + 0.00300501202482775*std::sin(0.402399837970734*x_5 + 8.21047973632813) - 0.00446774374252148*std::sin(0.22775998711586*x_50 - 7.4364800453186) - 0.010551314431616*std::sin(0.217600002884865*x_51 + 1.98359978199005) - 0.0474412958068315*std::sin(0.222479999065399*x_52 - 7.41655969619751) + 0.00697053972446433*std::sin(0.223839998245239*x_52 + 1.98967981338501) - 0.00303787950919927*std::sin(0.25095996260643*x_53 + 5.15743970870972) - 0.0149152253165202*std::sin(0.256639957427979*x_53 - 7.42983961105347) - 0.0342455515311867*std::sin(0.25943997502327*x_53 - 7.4398398399353) - 0.00647024627663523*std::sin(0.224399983882904*x_54 + 1.9832798242569) + 0.00176096779960127*std::sin(0.240879982709885*x_55 - 7.44704008102417) + 0.0145627936878948*std::sin(0.0958400741219521*x_56 + 7.95592021942139) - 0.0250054615251899*std::sin(0.163920015096664*x_57 - 1.17575979232788) - 0.000855982915856948*std::sin(0.51751983165741*x_57 - 4.48799991607666) - 0.00701693288985434*std::sin(0.151040032505989*x_58 - 4.38327980041504) + 0.00939284186460247*std::sin(0.146080031991005*x_59 - 1.21031987667084) + 0.0328410324073792*std::sin(0.284239947795868*x_6 - 7.382239818573) + 0.0339445041549157*std::sin(0.344559848308563*x_6 + 2.00063967704773) + 0.00951720664799218*std::sin(0.37271985411644*x_6 + 2.00519990921021) - 0.00261883705681485*std::sin(0.40447986125946*x_60 + 8.19551944732666) - 0.0068851861408219*std::sin(0.41543984413147*x_60 - 1.21631991863251) + 0.0211800735863843*std::sin(0.257439970970154*x_7 - 7.37671947479248) + 0.00588651644560303*std::sin(0.345999836921692*x_7 + 2.00303983688354) + 0.0421142002275438*std::sin(0.357119828462601*x_7 + 1.99847972393036) - 0.00759022986605105*std::sin(0.361919850111008*x_7 + 2.0079197883606) + 0.000666261163504157*std::sin(0.412159860134125*x_7 + 4.98207950592041) - 0.00444290802894369*std::sin(0.144000038504601*x_71 - 4.31903982162476) - 0.00117378119631183*std::sin(0.254399985074997*x_8 - 4.38703966140747) + 0.0040376879953887*std::sin(0.292959928512573*x_8 - 7.41423988342285) - 0.0165422439393969*std::sin(0.29911994934082*x_8 - 7.41567993164063) - 0.0173368900030832*std::sin(0.334959834814072*x_8 - 1.14431989192963) + 0.00497985982335971*std::sin(0.337839841842651*x_8 - 1.15391993522644) + 0.0310403958974505*std::sin(0.271999955177307*x_9 + 2.00103974342346) + 0.00970860742415212*std::sin(0.306639939546585*x_9 - 1.19591987133026) + 0.00698964103240384*std::sin(0.314799934625626*x_9 + 5.14448022842407) - 0.0100045314438111*std::sin(0.316319912672043*x_9 - 7.42663955688477) - 0.00252440261616599*std::sin(0.259039968252182*x_91 - 4.16463994979858) + 0.00538145573004823*std::sin(0.355039834976196*x_91 - 7.40223979949951) + 0.00684495012151906*std::sin(0.359519839286804*x_91 - 7.41016006469727) + 0.00138096256364189*std::sin(0.36575984954834*x_91 - 7.38615989685059) - 0.00318822336582877*std::sin(0.262719959020615*x_92 - 7.38695955276489) + 0.0166548000195704*std::sin(0.26599994301796*x_92 - 7.39991998672485) - 0.00883176592866781*std::sin(0.285919934511185*x_92 + 1.99951982498169) + 0.0154759769698427*std::sin(0.296799927949905*x_92 + 1.99463987350464) + 0.00447067371381761*std::sin(0.300159931182861*x_92 + 1.99007987976074) - 0.00324033436089768*std::sin(0.286479949951172*x_94 + 1.97767972946167) + 0.00930672900623008*std::sin(0.28671994805336*x_94 + 1.96495985984802) + 0.0124937238914703*std::sin(0.286959946155548*x_94 + 1.97103977203369) - 0.00122757218828917*std::sin(0.249199971556664*x_95 + 5.19456005096436) - 0.0132490671760651*std::sin(0.280399948358536*x_95 - 7.44032001495361) + 0.0070852459793417*std::sin(0.28263995051384*x_95 + 1.96735978126526) - 0.00414702026948791*std::sin(0.295519918203354*x_95 - 1.22903990745544) + 0.00387974049005446*std::sin(0.282559931278229*x_96 - 7.43711996078491) - 0.00365633196129703*std::sin(0.299439936876297*x_96 + 1.93367981910706) + 0.00494187535974117*std::sin(0.260399967432022*x_97 - 7.41359996795654) + 0.0104167908874792*std::sin(0.271919965744019*x_97 - 7.42767953872681) - 0.00218149016256576*std::sin(0.276479959487915*x_97 + 1.96783983707428) + 0.00548991856309228*std::sin(0.280159950256348*x_97 + 1.95407974720001) - 0.00652442126216145*std::sin(0.283359944820404*x_97 - 1.20615983009338) + 0.00207901921592819*std::sin(0.23191998898983*x_98 + 5.18480014801025) - 0.0100771069843409*std::sin(0.232239991426468*x_98 - 7.39911985397339) - 0.369646745507208);
}

inline float score_5(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.00119206172705611*x_10 + 0.00365397052586842*x_100 - 0.00204826142719099*x_101 + 0.00302012948224598*x_102 + 0.0120707296508221*x_103 - 0.00198980528716781*x_104 - 0.00630804983628947*x_105 - 0.00449708643873777*x_106 - 0.000674762765278897*x_107 - 0.0122409665738416*x_108 - 0.0014479025141243*x_109 + 0.000341089313258899*x_11 - 0.00140485041554599*x_110 + 0.0140126088026348*x_111 + 0.00578786228810092*x_112 + 0.00903601499990122*x_113 - 0.00505537628216601*x_114 + 0.00431698558803337*x_115 + 0.00549616799311701*x_116 - 0.00914436987827774*x_117 + 0.0134385009568732*x_118 - 0.00978654614042357*x_119 - 0.00507231512725611*x_120 + 0.00453142843306565*x_14 - 0.000753465890036364*x_15 - 0.0013769059541062*x_16 - 0.00148592078578812*x_19 + 0.000674168962251348*x_2 - 0.00199540949480727*x_21 - 0.000722756545396527*x_22 - 0.00275161945989881*x_23 + 0.000303279491462623*x_24 - 0.000969701105959218*x_26 + 0.00174293729276822*x_27 - 0.000734927940511251*x_28 - 0.00342037195004677*x_29 - 0.00058578620202525*x_31 - 0.00471628075499817*x_32 - 0.00100662054138301*x_33 + 0.00890068048237776*x_34 + 0.00150069626401243*x_35 + 0.0210374066185345*x_36 - 0.00157608013849443*x_37 + 0.00535454945590118*x_38 + 0.00589380548623663*x_39 + 0.00114989918175228*x_4 + 0.00186889121902663*x_40 + 0.00333772351624093*x_41 + 0.00786966053608677*x_42 - 0.000163068813492115*x_43 - 0.000808074429628095*x_44 + 0.00245801971622737*x_45 - 0.000981997151451886*x_46 + 0.00238105695588438*x_47 + 0.0118490368797684*x_48 - 0.00114546372425521*x_49 + 0.00242984740468912*x_50 - 0.0038514858692644*x_51 + 0.000178441458154484*x_52 - 0.00414848560689194*x_53 + 0.00852099393294365*x_54 + 0.00441975566504895*x_55 - 0.00870248548285339*x_56 + 0.00362635193365329*x_57 + 0.0106260392622188*x_58 - 0.0103191281509688*x_59 - 0.000815988260999732*x_6 + 0.00467360016545747*x_60 + 1.0793532049245e-5*x_61 - 0.00236477699400941*x_62 - 0.00220524851691691*x_63 + 0.00253547304440169*x_64 - 0.00318676532569761*x_65 + 0.00255400995316238*x_66 - 0.00132346771560377*x_67 - 0.000694942631837432*x_68 + 0.00452315839498015*x_69 + 0.000875487941545374*x_70 + 0.00254741086560458*x_71 + 0.000705043167533666*x_72 + 0.00146463787172889*x_73 + 0.00362385277698727*x_74 - 0.00158223293780502*x_75 + 0.00377411483444101*x_76 + 0.00255618798099904*x_77 + 0.0040645346436381*x_78 - 0.00512038736463812*x_79 - 0.000956504804465736*x_80 + 0.000883575409151448*x_81 + 0.00187196659706324*x_82 - 0.000773169875331056*x_83 - 0.000575581824084501*x_84 + 0.00355946791765775*x_85 - 0.00362780207444566*x_86 - 0.00158085033606437*x_87 + 0.00270043745450752*x_88 + 0.0023358651811156*x_89 + 0.00052006370828604*x_9 + 0.00110923880832865*x_90 + 0.000256241988221232*x_91 + 0.0121965928595114*x_93 + 9.16432911427862e-5*x_94 + 0.00109442251026021*x_95 + 0.00483427245550247*x_96 - 0.0023670175761311*x_98 + 0.00163869091612338*x_99 - 0.000167852689641555*std::pow(-3.08031988143921*x_22 - 8.18991947174072, 2) + 5.65290208796087e-6*std::pow(-7.29407978057861*x_24 - 1.18351984024048, 2) + 6.69411448158913e-6*std::pow(-5.27952003479004*x_55 - 8.32055950164795, 2) - 2.31992776686351e-5*std::pow(-2.59631991386414*x_56 - 9.37975978851318, 2) + 2.57663801626164e-5*std::pow(-3.85775995254517*x_59 - 9.14136028289795, 2) - 2.56472947261363e-5*std::pow(-2.80672001838684*x_59 - 8.59552001953125, 2) + 1.38482607992324e-5*std::pow(-4.6854395866394*x_61 - 8.77040004730225, 2) - 1.10348847602269e-5*std::pow(-3.75288009643555*x_65 - 9.44944000244141, 2) + 0.00146211930221663*std::exp(0.299919843673706*x_10) - 0.00372493298793632*std::exp(0.228399842977524*x_18) + 0.00123233873072409*std::exp(0.331679850816727*x_30) + 0.0317377497069376*std::sin(0.31879985332489*x_1 - 4.26864004135132) + 0.0761620857638959*std::sin(0.326959848403931*x_1 - 4.2611198425293) - 0.312351025369087*std::sin(0.358239859342575*x_1 + 8.35488033294678) + 0.0316349793960244*std::sin(0.361999839544296*x_1 + 5.17400026321411) + 0.00226368782947748*std::sin(0.365919858217239*x_1 - 4.23160028457642) + 0.0128840853773806*std::sin(0.263839960098267*x_10 + 1.99799978733063) + 0.0243526484151456*std::sin(0.243119969964027*x_100 - 7.42335987091064) + 0.0121741333924234*std::sin(0.250079959630966*x_100 - 1.2054398059845) - 0.0440957172581847*std::sin(0.2291199862957*x_101 - 7.40719985961914) - 0.0248578791358998*std::sin(0.237119987607002*x_101 + 1.98511981964111) + 0.0314511536369134*std::sin(0.220159992575645*x_102 + 2.00143980979919) + 0.0210145673410879*std::sin(0.239199981093407*x_106 + 8.17751979827881) - 0.00972240902801298*std::sin(0.246319979429245*x_108 - 1.19671988487244) + 0.0259700082443951*std::sin(0.256719976663589*x_108 + 1.97239983081818) - 0.0305175087439318*std::sin(0.23479999601841*x_109 - 7.42360019683838) - 0.0506847934768798*std::sin(0.274879962205887*x_11 - 7.44007968902588) + 0.0459906361450458*std::sin(0.286479949951172*x_11 - 7.44456005096436) - 0.00320404532599977*std::sin(0.292959928512573*x_11 - 7.44855976104736) - 0.0986810477589062*std::sin(0.293119937181473*x_11 - 7.43735980987549) + 0.00900231035016925*std::sin(0.231119990348816*x_112 - 4.20911979675293) - 0.0470177444616707*std::sin(0.281519949436188*x_112 + 5.14000034332275) - 0.0338814831405194*std::sin(0.292479932308197*x_113 - 7.43639993667603) - 0.0301239028347624*std::sin(0.251439958810806*x_116 - 7.41999959945679) + 0.0326311070796622*std::sin(0.219679996371269*x_118 - 4.21519994735718) + 0.00608979622291032*std::sin(0.23599998652935*x_119 + 5.17160034179688) - 0.0587993357274673*std::sin(0.291119933128357*x_12 - 7.45567989349365) + 0.0134774605634075*std::sin(0.292959928512573*x_12 - 4.27135992050171) + 0.044209185242609*std::sin(0.295039921998978*x_12 - 4.26959991455078) + 0.0290522722633262*std::sin(0.296319931745529*x_12 + 5.12960004806519) - 0.0808739173573772*std::sin(0.297279924154282*x_12 - 4.26855993270874) + 0.0128201637501845*std::sin(0.262639969587326*x_120 + 5.16879987716675) + 0.173671215920588*std::sin(0.266719967126846*x_120 + 5.15808010101318) + 0.0377568166778322*std::sin(0.267679959535599*x_120 + 5.16016006469727) - 0.0611994406717348*std::sin(0.192479997873306*x_13 + 8.19071960449219) + 0.0353064945936231*std::sin(0.19344000518322*x_13 + 1.97303986549377) - 0.00992514630161919*std::sin(0.216639995574951*x_13 - 1.17511987686157) + 0.0648151220062222*std::sin(0.232239991426468*x_13 + 1.98807990550995) + 0.0343351685477821*std::sin(0.295279920101166*x_13 - 7.43551969528198) + 0.0437245262850256*std::sin(0.30159991979599*x_14 - 7.4423999786377) - 0.10601783096629*std::sin(0.310879945755005*x_14 - 7.44575977325439) + 0.0111076434936812*std::sin(0.339599847793579*x_14 - 4.33360004425049) + 0.000807181122384863*std::sin(0.654879808425903*x_14 - 4.47160005569458) - 0.0185395128215166*std::sin(0.288399934768677*x_15 + 1.96623980998993) + 0.00593231218653968*std::sin(0.291679948568344*x_15 + 5.15560007095337) + 0.0472454623790228*std::sin(0.295359939336777*x_15 - 7.43336009979248) - 0.027562978546094*std::sin(0.423679858446121*x_15 + 8.16016006469727) + 0.0460182037667495*std::sin(0.219439998269081*x_16 + 1.98215985298157) + 0.00895053823766389*std::sin(0.299759924411774*x_16 - 7.40511989593506) + 0.0272178744636564*std::sin(0.337919861078262*x_16 - 1.15591979026794) - 0.0225976172717377*std::sin(0.342799842357635*x_16 - 1.14039981365204) - 0.00825904537176105*std::sin(0.314799934625626*x_17 + 2.02759981155396) + 0.089037666104606*std::sin(0.346559852361679*x_17 + 2.02431988716125) + 0.0330603051468809*std::sin(0.347679853439331*x_17 - 1.15719985961914) + 0.0420930684634132*std::sin(0.35471984744072*x_17 - 1.15351986885071) + 0.0298841031307005*std::sin(0.361119836568832*x_17 + 2.00263977050781) - 0.20765532951502*std::sin(0.117200054228306*x_18 - 1.28391993045807) - 0.00629248111912501*std::sin(0.395679831504822*x_18 + 2.01239991188049) + 0.0239262826573798*std::sin(0.414719849824905*x_18 - 7.41239976882935) + 0.00746275539655509*std::sin(0.46687987446785*x_18 - 7.43407964706421) - 0.0245254189464713*std::sin(0.241439983248711*x_19 - 1.16903984546661) + 0.0487791783030746*std::sin(0.287599951028824*x_19 - 1.19359982013702) - 0.0590559562885871*std::sin(0.313359916210175*x_19 - 7.41943979263306) + 0.00753207870387401*std::sin(0.331279844045639*x_19 - 1.16599988937378) - 0.0599465922526103*std::sin(0.372159838676453*x_2 + 5.19632005691528) + 0.0244384318532514*std::sin(0.375199824571609*x_2 + 5.17495965957642) + 0.0253307066888819*std::sin(0.393439829349518*x_2 + 5.18728017807007) - 0.0150704212304941*std::sin(0.404799848794937*x_2 + 2.01151990890503) + 0.0403790786595552*std::sin(0.202480003237724*x_20 + 1.9812798500061) - 0.0235067566042702*std::sin(0.246639966964722*x_20 - 1.16767990589142) + 0.00227086130152683*std::sin(0.270879954099655*x_20 + 1.9923198223114) - 0.0547503328417114*std::sin(0.344479858875275*x_20 - 4.3635196685791) + 0.0252435730467874*std::sin(0.403279840946198*x_20 + 8.19911956787109) - 0.027852013317186*std::sin(0.314639925956726*x_21 - 7.40407991409302) - 0.0110469005173683*std::sin(0.33247983455658*x_21 + 8.24967956542969) - 0.00629998263609309*std::sin(0.339919835329056*x_21 - 1.13927984237671) - 0.102000514437646*std::sin(0.360639840364456*x_22 + 1.99255979061127) + 0.0105254294454418*std::sin(0.394959837198257*x_22 - 7.40967988967896) + 0.00868440856401906*std::sin(0.241119980812073*x_23 - 4.37519979476929) - 0.079462305531559*std::sin(0.3643998503685*x_23 + 2.00103974342346) + 0.0371088372031146*std::sin(0.285839945077896*x_24 - 1.15983986854553) - 0.0190265271992502*std::sin(0.306479930877686*x_24 + 1.9890398979187) + 0.00302215493895552*std::sin(0.363439828157425*x_24 - 1.15135991573334) + 0.0792174228310354*std::sin(0.207600012421608*x_25 + 2.0052797794342) + 0.00429081205568316*std::sin(0.275919944047928*x_25 - 1.16351985931396) - 0.016564556116592*std::sin(0.324399828910828*x_25 - 1.1555198431015) + 0.00584371088830786*std::sin(0.363119840621948*x_25 + 2.03151988983154) - 0.0208662331000401*std::sin(0.378719836473465*x_25 + 2.0130398273468) + 0.0489682319952744*std::sin(0.299519926309586*x_26 + 1.992959856987) - 0.057205693772944*std::sin(0.332399845123291*x_26 - 1.15983986854553) - 0.0100338869755832*std::sin(0.333199828863144*x_26 - 1.14551985263824) - 0.0116000199300264*std::sin(0.337279856204987*x_26 - 1.14231979846954) - 0.0266351567168516*std::sin(0.316079914569855*x_27 + 2.00415992736816) + 0.00968744918415842*std::sin(0.319199919700623*x_27 + 5.1755199432373) - 0.0132849881126505*std::sin(0.338799834251404*x_28 - 4.3616795539856) + 0.0137171036223764*std::sin(0.415039867162704*x_28 - 1.20719993114471) + 0.0117904925615583*std::sin(0.557119846343994*x_28 + 4.81655979156494) + 0.0128985928289155*std::sin(0.296719938516617*x_29 - 1.18191993236542) + 0.0342079509171705*std::sin(0.300719946622849*x_29 + 1.98407983779907) + 0.0712626542932297*std::sin(0.301519930362701*x_29 + 1.98215973377228) + 0.0171174624223564*std::sin(0.296959936618805*x_3 + 8.28071975708008) - 0.0744251606027516*std::sin(0.320239841938019*x_3 + 5.19632005691528) - 0.0200226346311945*std::sin(0.346719831228256*x_3 - 7.38624000549316) + 0.0175595673689432*std::sin(0.360559850931168*x_3 - 7.41143989562988) - 0.00333641422402849*std::sin(0.400479853153229*x_3 + 2.17975974082947) - 0.0245038919131671*std::sin(0.325919836759567*x_30 - 1.15055990219116) - 0.096498099278122*std::sin(0.333119839429855*x_30 + 2.01231980323792) - 0.0889078663575794*std::sin(0.351359844207764*x_30 - 1.14287984371185) - 0.0433424283420397*std::sin(0.352639853954315*x_30 - 1.14095985889435) - 0.00538760364118158*std::sin(0.357999831438065*x_31 + 5.16495990753174) - 0.0959502594565881*std::sin(0.365359842777252*x_31 + 5.17280006408691) - 0.0404807415203636*std::sin(0.368399828672409*x_31 + 5.17471981048584) + 0.00706066493050301*std::sin(0.421279847621918*x_31 - 7.38687992095947) + 0.0362291015215305*std::sin(0.303919941186905*x_32 - 1.15511989593506) - 0.0683436368470331*std::sin(0.308319926261902*x_32 + 2.02879977226257) + 0.012589677540665*std::sin(0.316719859838486*x_32 + 2.00423979759216) - 0.00486514859194299*std::sin(0.336319833993912*x_32 + 1.99399983882904) - 0.0066182153774352*std::sin(0.185760006308556*x_34 - 1.19479990005493) - 0.00924774199286953*std::sin(0.219439998269081*x_35 - 7.40215969085693) - 0.0457277742380588*std::sin(0.22919999063015*x_35 - 7.42343997955322) + 0.056179379585419*std::sin(0.250639975070953*x_35 + 1.97823977470398) - 0.0258826610194804*std::sin(0.245919972658157*x_36 - 7.42759990692139) - 0.116466877374179*std::sin(0.186000004410744*x_37 + 8.20440006256104) - 0.0141024843032969*std::sin(0.237679988145828*x_38 + 1.98759984970093) - 0.0328182525988398*std::sin(0.239919975399971*x_38 + 1.97351980209351) - 0.0187179360879133*std::sin(0.242159977555275*x_38 + 1.97287976741791) + 0.00362625138753576*std::sin(0.22495998442173*x_39 - 1.18631982803345) - 0.0819049425024629*std::sin(0.319279909133911*x_4 + 2.00879979133606) - 0.0037806634126981*std::sin(0.324959844350815*x_4 - 1.16639983654022) - 0.0305547057571549*std::sin(0.330719828605652*x_4 - 7.38168001174927) - 0.00453977120653003*std::sin(0.386159837245941*x_4 + 1.99143981933594) - 0.0137883795253385*std::sin(0.189759999513626*x_40 + 2.000159740448) - 0.0148384960138314*std::sin(0.213359996676445*x_40 + 1.98591983318329) - 0.0120361567856181*std::sin(0.225519984960556*x_41 - 4.39015960693359) + 0.0143170808271627*std::sin(0.250879973173141*x_42 + 5.15895986557007) - 0.0198661471219696*std::sin(0.255599975585938*x_42 - 7.43623971939087) + 0.0486127519720247*std::sin(0.256719976663589*x_43 + 5.15768003463745) - 0.01325284333674*std::sin(0.28263995051384*x_43 + 5.11055994033813) + 0.00601915536087531*std::sin(0.225679993629456*x_44 - 7.42191982269287) - 0.00663005144294066*std::sin(0.214000001549721*x_45 - 1.21471989154816) + 0.0150660692497088*std::sin(0.153200030326843*x_47 - 1.17551982402802) - 0.0841528894790096*std::sin(0.213599994778633*x_47 + 1.9826397895813) + 0.0391513672389851*std::sin(0.0819200873374939*x_49 - 1.29207980632782) - 0.0330603378504452*std::sin(0.169840022921562*x_49 + 2.00367975234985) - 0.024378115244309*std::sin(0.211759999394417*x_49 + 1.99351978302002) + 0.0563667215246099*std::sin(0.27295994758606*x_49 + 5.11960029602051) + 0.0287691824548377*std::sin(0.322399914264679*x_5 + 2.01399993896484) - 0.059592689376738*std::sin(0.327759832143784*x_5 - 1.14439988136292) - 0.00383755789681653*std::sin(0.358959853649139*x_5 + 2.02503991127014) + 0.0133141879904654*std::sin(0.374239832162857*x_5 + 2.01015973091125) - 0.00172515319947577*std::sin(0.402399837970734*x_5 + 8.21047973632813) - 0.0157427022888318*std::sin(0.22775998711586*x_50 - 7.4364800453186) - 0.0316577466125828*std::sin(0.217600002884865*x_51 + 1.98359978199005) + 0.0898692406874859*std::sin(0.222479999065399*x_52 - 7.41655969619751) + 0.114320885593375*std::sin(0.223839998245239*x_52 + 1.98967981338501) - 0.0498229820854104*std::sin(0.25095996260643*x_53 + 5.15743970870972) + 0.00856271071899347*std::sin(0.256639957427979*x_53 - 7.42983961105347) + 0.0648722101850503*std::sin(0.25943997502327*x_53 - 7.4398398399353) - 0.0227987921283516*std::sin(0.224399983882904*x_54 + 1.9832798242569) + 0.0288808910514178*std::sin(0.240879982709885*x_55 - 7.44704008102417) - 0.0083603825596729*std::sin(0.0958400741219521*x_56 + 7.95592021942139) + 0.0143554340542189*std::sin(0.163920015096664*x_57 - 1.17575979232788) - 0.00301617214085266*std::sin(0.51751983165741*x_57 - 4.48799991607666) - 0.115081760355232*std::sin(0.151040032505989*x_58 - 4.38327980041504) + 0.028181911329516*std::sin(0.146080031991005*x_59 - 1.21031987667084) - 0.0622115942587574*std::sin(0.284239947795868*x_6 - 7.382239818573) - 0.0194872664281029*std::sin(0.344559848308563*x_6 + 2.00063967704773) + 0.0285550505081081*std::sin(0.37271985411644*x_6 + 2.00519990921021) - 0.0429504433507591*std::sin(0.40447986125946*x_60 + 8.19551944732666) + 0.00395272990646551*std::sin(0.41543984413147*x_60 - 1.21631991863251) - 0.040121946471777*std::sin(0.257439970970154*x_7 - 7.37671947479248) + 0.0965422764552165*std::sin(0.345999836921692*x_7 + 2.00303983688354) - 0.0241774231402867*std::sin(0.357119828462601*x_7 + 1.99847972393036) - 0.0227734255658894*std::sin(0.361919850111008*x_7 + 2.0079197883606) + 0.00234766176131155*std::sin(0.412159860134125*x_7 + 4.98207950592041) - 0.013330325573642*std::sin(0.144000038504601*x_71 - 4.31903982162476) - 0.0192506909306125*std::sin(0.254399985074997*x_8 - 4.38703966140747) + 0.0121145194077119*std::sin(0.292959928512573*x_8 - 7.41423988342285) + 0.0313363890428704*std::sin(0.29911994934082*x_8 - 7.41567993164063) + 0.00995296891016363*std::sin(0.334959834814072*x_8 - 1.14431989192963) + 0.0175472129014771*std::sin(0.337839841842651*x_8 - 1.15391993522644) - 0.0588006031981346*std::sin(0.271999955177307*x_9 + 2.00103974342346) - 0.00557363332387673*std::sin(0.306639939546585*x_9 - 1.19591987133026) + 0.114634158098224*std::sin(0.314799934625626*x_9 + 5.14448022842407) - 0.0300172005562422*std::sin(0.316319912672043*x_9 - 7.42663955688477) + 0.00144923920904889*std::sin(0.259039968252182*x_91 - 4.16463994979858) + 0.0882589884225834*std::sin(0.355039834976196*x_91 - 7.40223979949951) - 0.0129665612943913*std::sin(0.359519839286804*x_91 - 7.41016006469727) + 0.00486600927992496*std::sin(0.36575984954834*x_91 - 7.38615989685059) - 0.0112341383416527*std::sin(0.262719959020615*x_92 - 7.38695955276489) - 0.0315496068584448*std::sin(0.26599994301796*x_92 - 7.39991998672485) - 0.0264984812767622*std::sin(0.285919934511185*x_92 + 1.99951982498169) - 0.00888463372657148*std::sin(0.296799927949905*x_92 + 1.99463987350464) + 0.0733216362527692*std::sin(0.300159931182861*x_92 + 1.99007987976074) - 0.0531433588214623*std::sin(0.286479949951172*x_94 + 1.97767972946167) - 0.017629970995726*std::sin(0.28671994805336*x_94 + 1.96495985984802) - 0.00717254625494295*std::sin(0.286959946155548*x_94 + 1.97103977203369) - 0.0201328943299006*std::sin(0.249199971556664*x_95 + 5.19456005096436) + 0.0250980414147753*std::sin(0.280399948358536*x_95 - 7.44032001495361) + 0.0212582918797035*std::sin(0.28263995051384*x_95 + 1.96735978126526) + 0.00238077093438853*std::sin(0.295519918203354*x_95 - 1.22903990745544) + 0.0116406199580871*std::sin(0.282559931278229*x_96 - 7.43711996078491) + 0.00209907072892284*std::sin(0.299439936876297*x_96 + 1.93367981910706) + 0.0148274074233698*std::sin(0.260399967432022*x_97 - 7.41359996795654) - 0.00598019574608354*std::sin(0.271919965744019*x_97 - 7.42767953872681) - 0.0357777011760618*std::sin(0.276479959487915*x_97 + 1.96783983707428) + 0.0193444741931229*std::sin(0.280159950256348*x_97 + 1.95407974720001) + 0.0123593754087827*std::sin(0.283359944820404*x_97 - 1.20615983009338) + 0.0340971183474346*std::sin(0.23191998898983*x_98 + 5.18480014801025) + 0.00578518595328809*std::sin(0.232239991426468*x_98 - 7.39911985397339) + 0.520654448167142);
}

inline float score_6(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.00185395719815322*x_10 + 0.000715043512614181*x_100 - 0.000506480531335285*x_101 - 0.000868287428854621*x_102 - 0.00841157745572523*x_103 + 0.00342567982590059*x_104 + 0.00555741230310843*x_105 + 0.0072401846933118*x_106 - 0.0021060165987462*x_107 + 0.00233635964761895*x_108 + 0.000812834882803121*x_109 - 4.66664826763053e-6*x_11 + 0.0026504021199755*x_110 - 0.00775067330460222*x_111 - 0.000443565548457012*x_112 - 0.00145228474440176*x_113 + 0.0188338815044587*x_114 + 0.00437898410366122*x_115 - 0.00610306773800666*x_116 + 0.0241590862264068*x_117 + 0.00291921253005312*x_118 + 0.0183594110126176*x_119 + 0.00869436506572898*x_120 - 6.19972008064836e-5*x_14 - 0.000221186455182467*x_15 + 0.00236181764536971*x_16 - 0.000436204950531414*x_19 - 0.000189317018142464*x_2 - 9.59060542045146e-5*x_21 + 0.00108736079448855*x_22 + 0.000439550103672677*x_23 - 0.000520217704251374*x_24 - 0.000284664180621748*x_26 + 0.000438568726693162*x_27 - 8.5096281300718e-5*x_28 + 9.00133727247474e-5*x_29 + 8.01449373703497e-6*x_31 + 6.45262767240838e-5*x_32 - 0.00207977464766938*x_33 - 0.0152625960870864*x_34 - 0.00263976299991738*x_35 - 0.0106001790085237*x_36 + 0.00237348667097679*x_37 - 0.0082448906081676*x_38 - 0.00448769508227284*x_39 - 1.57324630701664e-5*x_4 + 0.00327514968704416*x_40 - 0.00136307435544424*x_41 - 0.0107434950603587*x_42 + 0.0012196605834222*x_43 + 0.00193606843385044*x_44 - 0.00549705518503719*x_45 + 0.00233316006930293*x_46 + 0.000988039724800222*x_47 - 0.026285286792187*x_48 + 1.56717789055202e-5*x_49 + 0.000699113430128051*x_50 + 0.000339689387598401*x_51 - 0.00417411683314174*x_52 - 0.001952371853287*x_53 - 0.00959300869438669*x_54 - 0.00700983174119817*x_55 - 0.00568821537513758*x_56 - 0.0051778653224035*x_57 - 0.0160791459351683*x_58 + 0.017975589833799*x_59 - 0.000330203790175084*x_6 - 0.00782857127436984*x_60 - 0.00272509979202495*x_61 + 0.00495959461150844*x_62 + 0.000963027452758471*x_63 - 0.00284849911583078*x_64 + 0.000986015602121133*x_65 - 0.00476960675726605*x_66 - 0.0015929040882279*x_67 + 0.00240573989645913*x_68 - 0.00568349652672701*x_69 + 0.00202960681734972*x_70 - 0.00253425438953618*x_71 - 0.0030952101484395*x_72 - 0.00069376083050806*x_73 - 0.00232225003279633*x_74 - 0.00124886768812458*x_75 - 0.00116222459340875*x_76 + 0.000740407974099692*x_77 - 0.00494286156668023*x_78 + 0.00562167514373295*x_79 + 0.00129895911959398*x_80 + 0.00740466803710152*x_81 - 0.00178646118600575*x_82 + 0.00226837525463197*x_83 + 0.00227018063727689*x_84 - 0.00495400987930404*x_85 + 0.00363239606207057*x_86 + 0.00391589849963991*x_87 - 0.00173854194773458*x_88 - 0.00260001606090811*x_89 + 0.000152669217845132*x_9 - 0.00431596505734151*x_90 - 0.000439533903866643*x_91 - 0.00631860814895668*x_93 + 1.00256765772612e-5*x_94 + 0.000321277231945655*x_95 + 1.15350918746598e-7*x_96 + 0.00375247023106546*x_98 - 0.0039829765963703*x_99 + 2.29649371259641e-6*std::pow(-3.08031988143921*x_22 - 8.18991947174072, 2) - 7.73407571284539e-8*std::pow(-7.29407978057861*x_24 - 1.18351984024048, 2) + 1.96511543833372e-6*std::pow(-5.27952003479004*x_55 - 8.32055950164795, 2) + 3.9793904002094e-5*std::pow(-2.59631991386414*x_56 - 9.37975978851318, 2) - 3.52525361173409e-7*std::pow(-3.85775995254517*x_59 - 9.14136028289795, 2) - 7.52898609016036e-6*std::pow(-2.80672001838684*x_59 - 8.59552001953125, 2) + 4.06527721709699e-6*std::pow(-4.6854395866394*x_61 - 8.77040004730225, 2) + 1.79333425464299e-5*std::pow(-3.75288009643555*x_65 - 9.44944000244141, 2) - 2.00041345287748e-5*std::exp(0.299919843673706*x_10) + 0.00638940693987962*std::exp(0.228399842977524*x_18) + 0.000361763736139094*std::exp(0.331679850816727*x_30) - 0.0544400124486577*std::sin(0.31879985332489*x_1 - 4.26864004135132) + 0.0223580416740646*std::sin(0.326959848403931*x_1 - 4.2611198425293) + 0.507617256943362*std::sin(0.358239859342575*x_1 + 8.35488033294678) - 0.000432817200821912*std::sin(0.361999839544296*x_1 + 5.17400026321411) - 0.000635678374232668*std::sin(0.365919858217239*x_1 - 4.23160028457642) + 0.00378223514903048*std::sin(0.263839960098267*x_10 + 1.99799978733063) - 0.0395767056413376*std::sin(0.243119969964027*x_100 - 7.42335987091064) + 0.0035738225785625*std::sin(0.250079959630966*x_100 - 1.2054398059845) + 0.0716621532172024*std::sin(0.2291199862957*x_101 - 7.40719985961914) + 0.0426389161834559*std::sin(0.237119987607002*x_101 + 1.98511981964111) - 0.0511128411312534*std::sin(0.220159992575645*x_102 + 2.00143980979919) - 0.000287512948852948*std::sin(0.239199981093407*x_106 + 8.17751979827881) + 0.0166769249049901*std::sin(0.246319979429245*x_108 - 1.19671988487244) + 0.00762372144591704*std::sin(0.256719976663589*x_108 + 1.97239983081818) + 0.0495955281690996*std::sin(0.23479999601841*x_109 - 7.42360019683838) - 0.0148789612762237*std::sin(0.274879962205887*x_11 - 7.44007968902588) - 0.0788881009957265*std::sin(0.286479949951172*x_11 - 7.44456005096436) + 0.000899745228682635*std::sin(0.292959928512573*x_11 - 7.44855976104736) + 0.160371500994696*std::sin(0.293119937181473*x_11 - 7.43735980987549) - 0.0146301043215913*std::sin(0.231119990348816*x_112 - 4.20911979675293) + 0.0806499079940013*std::sin(0.281519949436188*x_112 + 5.14000034332275) + 0.0581171753190073*std::sin(0.292479932308197*x_113 - 7.43639993667603) + 0.051671768177318*std::sin(0.251439958810806*x_116 - 7.41999959945679) - 0.0530304424236494*std::sin(0.219679996371269*x_118 - 4.21519994735718) - 0.00171010848403132*std::sin(0.23599998652935*x_119 + 5.17160034179688) + 0.0955577382107187*std::sin(0.291119933128357*x_12 - 7.45567989349365) - 0.00378467830597887*std::sin(0.292959928512573*x_12 - 4.27135992050171) + 0.0129779902443172*std::sin(0.295039921998978*x_12 - 4.26959991455078) - 0.0498335918041331*std::sin(0.296319931745529*x_12 + 5.12960004806519) + 0.00110648475827747*std::sin(0.297279924154282*x_12 - 4.26855993270874) - 0.00360009924689791*std::sin(0.262639969587326*x_120 + 5.16879987716675) - 0.00237610047400673*std::sin(0.266719967126846*x_120 + 5.15808010101318) + 0.011083841419206*std::sin(0.267679959535599*x_120 + 5.16016006469727) + 0.000837306396562272*std::sin(0.192479997873306*x_13 + 8.19071960449219) + 0.0103645280925797*std::sin(0.19344000518322*x_13 + 1.97303986549377) + 0.00278713380125872*std::sin(0.216639995574951*x_13 - 1.17511987686157) - 0.105334293051769*std::sin(0.232239991426468*x_13 + 1.98807990550995) - 0.0588953854771696*std::sin(0.295279920101166*x_13 - 7.43551969528198) - 0.0750010248756902*std::sin(0.30159991979599*x_14 - 7.4423999786377) + 0.17229487394383*std::sin(0.310879945755005*x_14 - 7.44575977325439) + 0.00326074520729714*std::sin(0.339599847793579*x_14 - 4.33360004425049) - 0.000226668879386673*std::sin(0.654879808425903*x_14 - 4.47160005569458) + 0.0301294885534764*std::sin(0.288399934768677*x_15 + 1.96623980998993) - 0.00166588454338717*std::sin(0.291679948568344*x_15 + 5.15560007095337) - 0.0810405143340823*std::sin(0.295359939336777*x_15 - 7.43336009979248) + 0.000377105705405771*std::sin(0.423679858446121*x_15 + 8.16016006469727) - 0.0747864820931365*std::sin(0.219439998269081*x_16 + 1.98215985298157) - 0.00251344886045478*std::sin(0.299759924411774*x_16 - 7.40511989593506) + 0.00799004341115829*std::sin(0.337919861078262*x_16 - 1.15591979026794) + 0.000309171608122734*std::sin(0.342799842357635*x_16 - 1.14039981365204) + 0.00231926702360138*std::sin(0.314799934625626*x_17 + 2.02759981155396) - 0.00121817792035466*std::sin(0.346559852361679*x_17 + 2.02431988716125) - 0.0537279536461899*std::sin(0.347679853439331*x_17 - 1.15719985961914) + 0.012356785787245*std::sin(0.35471984744072*x_17 - 1.15351986885071) - 0.0512604378531817*std::sin(0.361119836568832*x_17 + 2.00263977050781) + 0.00284105759423184*std::sin(0.117200054228306*x_18 - 1.28391993045807) + 0.00176702552163231*std::sin(0.395679831504822*x_18 + 2.01239991188049) - 0.0388837973463962*std::sin(0.414719849824905*x_18 - 7.41239976882935) + 0.00219075665386549*std::sin(0.46687987446785*x_18 - 7.43407964706421) + 0.0420686445977797*std::sin(0.241439983248711*x_19 - 1.16903984546661) - 0.000667377308745234*std::sin(0.287599951028824*x_19 - 1.19359982013702) + 0.0959747851058168*std::sin(0.313359916210175*x_19 - 7.41943979263306) - 0.00211512359730994*std::sin(0.331279844045639*x_19 - 1.16599988937378) + 0.000820165422988957*std::sin(0.372159838676453*x_2 + 5.19632005691528) - 0.041919434950546*std::sin(0.375199824571609*x_2 + 5.17495965957642) + 0.00743604892254672*std::sin(0.393439829349518*x_2 + 5.18728017807007) + 0.0244916944868834*std::sin(0.404799848794937*x_2 + 2.01151990890503) - 0.0692625521717755*std::sin(0.202480003237724*x_20 + 1.9812798500061) - 0.00690061253587025*std::sin(0.246639966964722*x_20 - 1.16767990589142) - 0.000637692795563451*std::sin(0.270879954099655*x_20 + 1.9923198223114) + 0.000749072269274041*std::sin(0.344479858875275*x_20 - 4.3635196685791) - 0.0410245917724072*std::sin(0.403279840946198*x_20 + 8.19911956787109) + 0.0477747781650803*std::sin(0.314639925956726*x_21 - 7.40407991409302) - 0.00324291357910328*std::sin(0.33247983455658*x_21 + 8.24967956542969) + 0.00176913206302395*std::sin(0.339919835329056*x_21 - 1.13927984237671) + 0.16576613214081*std::sin(0.360639840364456*x_22 + 1.99255979061127) + 0.00308983121743982*std::sin(0.394959837198257*x_22 - 7.40967988967896) + 0.00254938355011523*std::sin(0.241119980812073*x_23 - 4.37519979476929) + 0.129138162798288*std::sin(0.3643998503685*x_23 + 2.00103974342346) - 0.0603074253626801*std::sin(0.285839945077896*x_24 - 1.15983986854553) - 0.00558540228733093*std::sin(0.306479930877686*x_24 + 1.9890398979187) - 0.000848667609225042*std::sin(0.363439828157425*x_24 - 1.15135991573334) - 0.00108382125927237*std::sin(0.207600012421608*x_25 + 2.0052797794342) + 0.00125960514072502*std::sin(0.275919944047928*x_25 - 1.16351985931396) + 0.0284133137831331*std::sin(0.324399828910828*x_25 - 1.1555198431015) - 0.00164100393552177*std::sin(0.363119840621948*x_25 + 2.03151988983154) + 0.0339107579252129*std::sin(0.378719836473465*x_25 + 2.0130398273468) - 0.0795807203560006*std::sin(0.299519926309586*x_26 + 1.992959856987) + 0.000782665540569079*std::sin(0.332399845123291*x_26 - 1.15983986854553) + 0.00281766985571741*std::sin(0.333199828863144*x_26 - 1.14551985263824) + 0.0198976056975229*std::sin(0.337279856204987*x_26 - 1.14231979846954) + 0.0432861239206384*std::sin(0.316079914569855*x_27 + 2.00415992736816) - 0.0166169580090312*std::sin(0.319199919700623*x_27 + 5.1755199432373) + 0.0215900979236427*std::sin(0.338799834251404*x_28 - 4.3616795539856) - 0.0235290560564999*std::sin(0.415039867162704*x_28 - 1.20719993114471) - 0.000161312827896027*std::sin(0.557119846343994*x_28 + 4.81655979156494) - 0.022125058035316*std::sin(0.296719938516617*x_29 - 1.18191993236542) + 0.0100420410565097*std::sin(0.300719946622849*x_29 + 1.98407983779907) - 0.115812499901633*std::sin(0.301519930362701*x_29 + 1.98215973377228) - 0.0293617183312405*std::sin(0.296959936618805*x_3 + 8.28071975708008) + 0.00101825543426314*std::sin(0.320239841938019*x_3 + 5.19632005691528) - 0.0058778182742604*std::sin(0.346719831228256*x_3 - 7.38624000549316) - 0.00493099670898323*std::sin(0.360559850931168*x_3 - 7.41143989562988) + 0.00542217344869256*std::sin(0.400479853153229*x_3 + 2.17975974082947) + 0.00688106989439909*std::sin(0.325919836759567*x_30 - 1.15055990219116) + 0.156823882354562*std::sin(0.333119839429855*x_30 + 2.01231980323792) + 0.001216402051862*std::sin(0.351359844207764*x_30 - 1.14287984371185) + 0.074345609259749*std::sin(0.352639853954315*x_30 - 1.14095985889435) + 0.00151292200233583*std::sin(0.357999831438065*x_31 + 5.16495990753174) + 0.15593356048953*std::sin(0.365359842777252*x_31 + 5.17280006408691) - 0.0118834732115276*std::sin(0.368399828672409*x_31 + 5.17471981048584) - 0.0121112142562635*std::sin(0.421279847621918*x_31 - 7.38687992095947) - 0.0621440636481129*std::sin(0.303919941186905*x_32 - 1.15511989593506) + 0.111068658810485*std::sin(0.308319926261902*x_32 + 2.02879977226257) + 0.00369580917189978*std::sin(0.316719859838486*x_32 + 2.00423979759216) + 0.00136620858541283*std::sin(0.336319833993912*x_32 + 1.99399983882904) + 0.00185849671348931*std::sin(0.185760006308556*x_34 - 1.19479990005493) - 0.00271475497019001*std::sin(0.219439998269081*x_35 - 7.40215969085693) + 0.0743144905556825*std::sin(0.22919999063015*x_35 - 7.42343997955322) - 0.00076862391821657*std::sin(0.250639975070953*x_35 + 1.97823977470398) - 0.00759807990951257*std::sin(0.245919972658157*x_36 - 7.42759990692139) + 0.00159345347510788*std::sin(0.186000004410744*x_37 + 8.20440006256104) - 0.00413990673441379*std::sin(0.237679988145828*x_38 + 1.98759984970093) + 0.00044900627396904*std::sin(0.239919975399971*x_38 + 1.97351980209351) + 0.0321070234357678*std::sin(0.242159977555275*x_38 + 1.97287976741791) - 0.00622013761222196*std::sin(0.22495998442173*x_39 - 1.18631982803345) + 0.133107814178217*std::sin(0.319279909133911*x_4 + 2.00879979133606) + 0.00106166845993937*std::sin(0.324959844350815*x_4 - 1.16639983654022) + 0.0524107278286645*std::sin(0.330719828605652*x_4 - 7.38168001174927) - 0.00133268926143869*std::sin(0.386159837245941*x_4 + 1.99143981933594) + 0.0224081844587376*std::sin(0.189759999513626*x_40 + 2.000159740448) - 0.00435596936362991*std::sin(0.213359996676445*x_40 + 1.98591983318329) + 0.020645714686565*std::sin(0.225519984960556*x_41 - 4.39015960693359) + 0.00420290340756917*std::sin(0.250879973173141*x_42 + 5.15895986557007) + 0.0340765588806216*std::sin(0.255599975585938*x_42 - 7.43623971939087) - 0.0790030120097995*std::sin(0.256719976663589*x_43 + 5.15768003463745) + 0.000181320129345808*std::sin(0.28263995051384*x_43 + 5.11055994033813) + 0.0017669753270454*std::sin(0.225679993629456*x_44 - 7.42191982269287) - 0.00194630917700955*std::sin(0.214000001549721*x_45 - 1.21471989154816) - 0.00423078406926027*std::sin(0.153200030326843*x_47 - 1.17551982402802) + 0.136761065121256*std::sin(0.213599994778633*x_47 + 1.9826397895813) - 0.0109943063488613*std::sin(0.0819200873374939*x_49 - 1.29207980632782) + 0.0567086583249991*std::sin(0.169840022921562*x_49 + 2.00367975234985) - 0.00715640743160667*std::sin(0.211759999394417*x_49 + 1.99351978302002) - 0.0916043753318974*std::sin(0.27295994758606*x_49 + 5.11960029602051) - 0.0467542357671835*std::sin(0.322399914264679*x_5 + 2.01399993896484) + 0.000815323464656051*std::sin(0.327759832143784*x_5 - 1.14439988136292) - 0.0011265484462918*std::sin(0.358959853649139*x_5 + 2.02503991127014) - 0.0228379316945165*std::sin(0.374239832162857*x_5 + 2.01015973091125) + 0.000484449563612391*std::sin(0.402399837970734*x_5 + 8.21047973632813) - 0.00462140696786098*std::sin(0.22775998711586*x_50 - 7.4364800453186) + 0.0543027825097736*std::sin(0.217600002884865*x_51 + 1.98359978199005) - 0.146050993069284*std::sin(0.222479999065399*x_52 - 7.41655969619751) - 0.00156409286943379*std::sin(0.223839998245239*x_52 + 1.98967981338501) + 0.000681658216774991*std::sin(0.25095996260643*x_53 + 5.15743970870972) - 0.00240454092565*std::sin(0.256639957427979*x_53 - 7.42983961105347) - 0.10542706990341*std::sin(0.25943997502327*x_53 - 7.4398398399353) - 0.00669278341594024*std::sin(0.224399983882904*x_54 + 1.9832798242569) - 0.000395136859918048*std::sin(0.240879982709885*x_55 - 7.44704008102417) + 0.00234772406525804*std::sin(0.0958400741219521*x_56 + 7.95592021942139) - 0.00403122677171284*std::sin(0.163920015096664*x_57 - 1.17575979232788) - 0.000885423524644382*std::sin(0.51751983165741*x_57 - 4.48799991607666) + 0.00157450285518027*std::sin(0.151040032505989*x_58 - 4.38327980041504) - 0.0483406548281667*std::sin(0.146080031991005*x_59 - 1.21031987667084) + 0.101103170032459*std::sin(0.284239947795868*x_6 - 7.382239818573) + 0.00547232426659939*std::sin(0.344559848308563*x_6 + 2.00063967704773) - 0.0489807034048682*std::sin(0.37271985411644*x_6 + 2.00519990921021) + 0.000587630876328999*std::sin(0.40447986125946*x_60 + 8.19551944732666) - 0.00110998737900306*std::sin(0.41543984413147*x_60 - 1.21631991863251) + 0.0652041797755132*std::sin(0.257439970970154*x_7 - 7.37671947479248) - 0.00132085301315458*std::sin(0.345999836921692*x_7 + 2.00303983688354) + 0.00678939243954868*std::sin(0.357119828462601*x_7 + 1.99847972393036) + 0.0390634365307442*std::sin(0.361919850111008*x_7 + 2.0079197883606) + 0.000689176497328722*std::sin(0.412159860134125*x_7 + 4.98207950592041) + 0.0228656126182475*std::sin(0.144000038504601*x_71 - 4.31903982162476) + 0.000263380293635424*std::sin(0.254399985074997*x_8 - 4.38703966140747) - 0.0207801307104384*std::sin(0.292959928512573*x_8 - 7.41423988342285) - 0.0509263314556296*std::sin(0.29911994934082*x_8 - 7.41567993164063) - 0.00279494681784879*std::sin(0.334959834814072*x_8 - 1.14431989192963) + 0.00515113672872764*std::sin(0.337839841842651*x_8 - 1.15391993522644) + 0.0955597980406253*std::sin(0.271999955177307*x_9 + 2.00103974342346) + 0.00156516199970418*std::sin(0.306639939546585*x_9 - 1.19591987133026) - 0.00156837893919682*std::sin(0.314799934625626*x_9 + 5.14448022842407) + 0.0514887409172072*std::sin(0.316319912672043*x_9 - 7.42663955688477) - 0.000406968669569197*std::sin(0.259039968252182*x_91 - 4.16463994979858) - 0.00120752436213809*std::sin(0.355039834976196*x_91 - 7.40223979949951) + 0.0210726065921163*std::sin(0.359519839286804*x_91 - 7.41016006469727) + 0.00142845928096313*std::sin(0.36575984954834*x_91 - 7.38615989685059) - 0.00329787886841127*std::sin(0.262719959020615*x_92 - 7.38695955276489) + 0.0512728423804631*std::sin(0.26599994301796*x_92 - 7.39991998672485) + 0.0454530539782448*std::sin(0.285919934511185*x_92 + 1.99951982498169) + 0.0024949418596571*std::sin(0.296799927949905*x_92 + 1.99463987350464) - 0.00100315745318912*std::sin(0.300159931182861*x_92 + 1.99007987976074) + 0.000727086290129539*std::sin(0.286479949951172*x_94 + 1.97767972946167) + 0.0286513466900473*std::sin(0.28671994805336*x_94 + 1.96495985984802) + 0.0020141613534686*std::sin(0.286959946155548*x_94 + 1.97103977203369) + 0.000275450249523665*std::sin(0.249199971556664*x_95 + 5.19456005096436) - 0.0407880810462036*std::sin(0.280399948358536*x_95 - 7.44032001495361) - 0.0364645157660715*std::sin(0.28263995051384*x_95 + 1.96735978126526) - 0.000668557111667569*std::sin(0.295519918203354*x_95 - 1.22903990745544) - 0.0199672472459455*std::sin(0.282559931278229*x_96 - 7.43711996078491) - 0.000589451359408092*std::sin(0.299439936876297*x_96 + 1.93367981910706) - 0.0254335689254341*std::sin(0.260399967432022*x_97 - 7.41359996795654) + 0.00167933098369884*std::sin(0.271919965744019*x_97 - 7.42767953872681) + 0.000489496271864552*std::sin(0.276479959487915*x_97 + 1.96783983707428) + 0.00567873838846118*std::sin(0.280159950256348*x_97 + 1.95407974720001) - 0.0200858384733205*std::sin(0.283359944820404*x_97 - 1.20615983009338) - 0.000466503206292106*std::sin(0.23191998898983*x_98 + 5.18480014801025) - 0.00162456923323598*std::sin(0.232239991426468*x_98 - 7.39911985397339) - 0.701696211695092);
}

inline float score_7(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.000517492138008039*x_10 - 0.00106390228997*x_100 - 0.00125199400665977*x_101 - 0.00168242493247446*x_102 - 0.00189739959123709*x_103 + 0.00243401140314192*x_104 - 0.00171292962756338*x_105 + 0.00175818966519946*x_106 + 0.00100849929551897*x_107 + 0.00414873191304851*x_108 - 0.00163983564482443*x_109 - 0.000133470109481488*x_11 - 0.00169411794528618*x_110 - 0.000238730734888956*x_111 - 0.00283701340076924*x_112 - 0.00675559773735924*x_113 - 0.00486183512106831*x_114 - 0.0015450013578511*x_115 - 0.00996809492372327*x_116 - 0.00733125836014623*x_117 - 0.00330335830583393*x_118 - 0.00684731060558014*x_119 + 0.00467573139862336*x_120 - 0.00177317267225469*x_14 - 0.000974540216973931*x_15 + 0.00128651326260606*x_16 - 0.00192190460661482*x_19 + 2.79617754095135e-5*x_2 + 0.000809800805568984*x_21 + 0.00057164403226709*x_22 + 0.00119622054112034*x_23 - 0.000283369453723048*x_24 - 0.00125422097894272*x_26 + 0.00257266688743193*x_27 - 0.000665795817944206*x_28 + 0.00126839434982612*x_29 + 0.000229221337279805*x_31 + 0.00184550639450038*x_32 + 0.00260322382280553*x_33 - 0.00561276560583353*x_34 - 0.00144680651733992*x_35 - 0.0046722730611175*x_36 - 0.0011969334075456*x_37 - 4.6991914003687e-5*x_38 - 0.000759125057693803*x_39 - 0.000449961824411237*x_4 + 0.000296480267544154*x_40 + 0.0026333083353908*x_41 - 0.00046465222290814*x_42 + 0.00106157449918263*x_43 + 0.000214427771532776*x_44 + 0.00172183573002389*x_45 + 0.00382041950425455*x_46 + 0.0053473258971435*x_47 + 0.0012610741703329*x_48 + 0.000448226205689915*x_49 - 0.00136790122904291*x_50 + 0.00753944192173079*x_51 - 0.00454108108102275*x_52 - 0.00618027937787572*x_53 - 0.00634733943677143*x_54 - 0.00527877787183599*x_55 - 0.000697033897543374*x_56 - 0.00400800909001921*x_57 - 0.00416372340133345*x_58 + 0.00017383529435227*x_59 - 0.00155254889356394*x_6 - 0.000209614417858195*x_60 + 0.000323313505885491*x_61 + 0.00286853735649942*x_62 + 0.00146877826689783*x_63 - 0.000641979741673576*x_64 + 0.00122804008372952*x_65 - 0.000258425198404331*x_66 - 0.000936474284166173*x_67 + 0.000769080186795244*x_68 + 0.000400335379490794*x_69 + 0.00247685915224207*x_70 + 8.70100787485054e-7*x_71 - 0.00239845816814708*x_72 + 0.00129483804675372*x_73 - 0.00285713755058358*x_74 + 0.0022805513676385*x_75 + 0.000868984935295926*x_76 - 0.00232711892766953*x_77 + 0.00119475833461853*x_78 - 0.00221539391999841*x_79 + 0.00135837411395247*x_80 - 0.00136847335838981*x_81 + 0.0020788060835642*x_82 + 0.00202096470605784*x_83 + 0.00152065099381052*x_84 + 6.47122049955623e-5*x_85 + 0.000539421028016853*x_86 - 0.00086585165480003*x_87 + 8.76019219948127e-5*x_88 - 0.000532271725836729*x_89 + 0.000672655532009398*x_9 + 0.00100812056672142*x_90 - 0.000239419922108736*x_91 - 0.00639662848831153*x_93 + 9.98163432976737e-5*x_94 + 0.00141553687395014*x_95 + 0.00136331260470497*x_96 - 0.00039167650989531*x_98 - 0.00977122961056232*x_99 + 6.56816733692728e-5*std::pow(-3.08031988143921*x_22 - 8.18991947174072, 2) - 2.21201143289875e-6*std::pow(-7.29407978057861*x_24 - 1.18351984024048, 2) + 8.65823372445082e-6*std::pow(-5.27952003479004*x_55 - 8.32055950164795, 2) + 2.16762650452433e-5*std::pow(-2.59631991386414*x_56 - 9.37975978851318, 2) - 1.00825251556201e-5*std::pow(-3.85775995254517*x_59 - 9.14136028289795, 2) - 3.31724640726562e-5*std::pow(-2.80672001838684*x_59 - 8.59552001953125, 2) + 1.79114771650037e-5*std::pow(-4.6854395866394*x_61 - 8.77040004730225, 2) + 1.34439608075809e-7*std::pow(-3.75288009643555*x_65 - 9.44944000244141, 2) - 0.000572135261223284*std::exp(0.299919843673706*x_10) + 0.00348039434139107*std::exp(0.228399842977524*x_18) + 0.00159391907438208*std::exp(0.331679850816727*x_30) - 0.0296541937388539*std::sin(0.31879985332489*x_1 - 4.26864004135132) + 0.0985087932540012*std::sin(0.326959848403931*x_1 - 4.2611198425293) + 0.00380541803064865*std::sin(0.358239859342575*x_1 + 8.35488033294678) - 0.0123789400585151*std::sin(0.361999839544296*x_1 + 5.17400026321411) + 9.38885268074677e-5*std::sin(0.365919858217239*x_1 - 4.23160028457642) + 0.01666440316041*std::sin(0.263839960098267*x_10 + 1.99799978733063) - 0.000296691862187862*std::sin(0.243119969964027*x_100 - 7.42335987091064) + 0.0157461442576376*std::sin(0.250079959630966*x_100 - 1.2054398059845) + 0.000537224545142434*std::sin(0.2291199862957*x_101 - 7.40719985961914) + 0.0232259807528779*std::sin(0.237119987607002*x_101 + 1.98511981964111) - 0.000383173985080365*std::sin(0.220159992575645*x_102 + 2.00143980979919) - 0.00822311486960057*std::sin(0.239199981093407*x_106 + 8.17751979827881) + 0.0090841412383455*std::sin(0.246319979429245*x_108 - 1.19671988487244) + 0.0335898649215376*std::sin(0.256719976663589*x_108 + 1.97239983081818) + 0.000371799253379781*std::sin(0.23479999601841*x_109 - 7.42360019683838) - 0.0655562120135968*std::sin(0.274879962205887*x_11 - 7.44007968902588) - 0.0429713904423479*std::sin(0.286479949951172*x_11 - 7.44456005096436) - 0.000132890715568281*std::sin(0.292959928512573*x_11 - 7.44855976104736) + 0.0012022455760512*std::sin(0.293119937181473*x_11 - 7.43735980987549) - 0.000109676458028428*std::sin(0.231119990348816*x_112 - 4.20911979675293) + 0.0439310699814843*std::sin(0.281519949436188*x_112 + 5.14000034332275) + 0.0316571929165177*std::sin(0.292479932308197*x_113 - 7.43639993667603) + 0.0281462945256383*std::sin(0.251439958810806*x_116 - 7.41999959945679) - 0.000397549529713382*std::sin(0.219679996371269*x_118 - 4.21519994735718) + 0.000252579878056203*std::sin(0.23599998652935*x_119 + 5.17160034179688) + 0.000716360870283898*std::sin(0.291119933128357*x_12 - 7.45567989349365) + 0.000558990025447176*std::sin(0.292959928512573*x_12 - 4.27135992050171) + 0.0571805964255311*std::sin(0.295039921998978*x_12 - 4.26959991455078) - 0.0271450155794217*std::sin(0.296319931745529*x_12 + 5.12960004806519) + 0.031646405162195*std::sin(0.297279924154282*x_12 - 4.26855993270874) + 0.000531728037877537*std::sin(0.262639969587326*x_120 + 5.16879987716675) - 0.0679584944518906*std::sin(0.266719967126846*x_120 + 5.15808010101318) + 0.0488350392553054*std::sin(0.267679959535599*x_120 + 5.16016006469727) + 0.0239476750784691*std::sin(0.192479997873306*x_13 + 8.19071960449219) + 0.0456657684931135*std::sin(0.19344000518322*x_13 + 1.97303986549377) - 0.000411654536669357*std::sin(0.216639995574951*x_13 - 1.17511987686157) - 0.000789652070614206*std::sin(0.232239991426468*x_13 + 1.98807990550995) - 0.0320810942670446*std::sin(0.295279920101166*x_13 - 7.43551969528198) - 0.0408540487453757*std::sin(0.30159991979599*x_14 - 7.4423999786377) + 0.00129163067434357*std::sin(0.310879945755005*x_14 - 7.44575977325439) + 0.014366735699049*std::sin(0.339599847793579*x_14 - 4.33360004425049) + 3.34785766220276e-5*std::sin(0.654879808425903*x_14 - 4.47160005569458) + 0.000225869584667044*std::sin(0.288399934768677*x_15 + 1.96623980998993) + 0.000246048083354657*std::sin(0.291679948568344*x_15 + 5.15560007095337) - 0.0441438384134407*std::sin(0.295359939336777*x_15 - 7.43336009979248) + 0.0107855439064744*std::sin(0.423679858446121*x_15 + 8.16016006469727) - 0.000560646478253512*std::sin(0.219439998269081*x_16 + 1.98215985298157) + 0.000371231774242541*std::sin(0.299759924411774*x_16 - 7.40511989593506) + 0.0352038674028108*std::sin(0.337919861078262*x_16 - 1.15591979026794) + 0.00884257094560528*std::sin(0.342799842357635*x_16 - 1.14039981365204) - 0.00034255147405624*std::sin(0.314799934625626*x_17 + 2.02759981155396) - 0.034840924593664*std::sin(0.346559852361679*x_17 + 2.02431988716125) - 0.000402778512271655*std::sin(0.347679853439331*x_17 - 1.15719985961914) + 0.0544435901026036*std::sin(0.35471984744072*x_17 - 1.15351986885071) - 0.0279222374658772*std::sin(0.361119836568832*x_17 + 2.00263977050781) + 0.0812566635406338*std::sin(0.117200054228306*x_18 - 1.28391993045807) - 0.000260986419834587*std::sin(0.395679831504822*x_18 + 2.01239991188049) - 0.00029149738606813*std::sin(0.414719849824905*x_18 - 7.41239976882935) + 0.00965240146840778*std::sin(0.46687987446785*x_18 - 7.43407964706421) + 0.0229153462889098*std::sin(0.241439983248711*x_19 - 1.16903984546661) - 0.0190875586406503*std::sin(0.287599951028824*x_19 - 1.19359982013702) + 0.00071948731595241*std::sin(0.313359916210175*x_19 - 7.41943979263306) + 0.00031239986543015*std::sin(0.331279844045639*x_19 - 1.16599988937378) + 0.0234574286557167*std::sin(0.372159838676453*x_2 + 5.19632005691528) - 0.0228340698235352*std::sin(0.375199824571609*x_2 + 5.17495965957642) + 0.032762985981349*std::sin(0.393439829349518*x_2 + 5.18728017807007) + 0.000183605136599844*std::sin(0.404799848794937*x_2 + 2.01151990890503) - 0.0377282268788304*std::sin(0.202480003237724*x_20 + 1.9812798500061) - 0.0304038709441422*std::sin(0.246639966964722*x_20 - 1.16767990589142) + 9.41860531333319e-5*std::sin(0.270879954099655*x_20 + 1.9923198223114) + 0.0214241039940892*std::sin(0.344479858875275*x_20 - 4.3635196685791) - 0.000307546126723067*std::sin(0.403279840946198*x_20 + 8.19911956787109) + 0.0260235526006569*std::sin(0.314639925956726*x_21 - 7.40407991409302) - 0.0142881701341065*std::sin(0.33247983455658*x_21 + 8.24967956542969) - 0.000261297552124023*std::sin(0.339919835329056*x_21 - 1.13927984237671) + 0.00124268712202176*std::sin(0.360639840364456*x_22 + 1.99255979061127) + 0.0136136943040774*std::sin(0.394959837198257*x_22 - 7.40967988967896) + 0.0112324997298298*std::sin(0.241119980812073*x_23 - 4.37519979476929) + 0.000968100840614795*std::sin(0.3643998503685*x_23 + 2.00103974342346) - 0.000452102367912103*std::sin(0.285839945077896*x_24 - 1.15983986854553) - 0.024609098023167*std::sin(0.306479930877686*x_24 + 1.9890398979187) + 0.000125346645110489*std::sin(0.363439828157425*x_24 - 1.15135991573334) - 0.0309982098151349*std::sin(0.207600012421608*x_25 + 2.0052797794342) + 0.00554977865227318*std::sin(0.275919944047928*x_25 - 1.16351985931396) + 0.0154771072560372*std::sin(0.324399828910828*x_25 - 1.1555198431015) + 0.000242373263330496*std::sin(0.363119840621948*x_25 + 2.03151988983154) + 0.000254216356667254*std::sin(0.378719836473465*x_25 + 2.0130398273468) - 0.000596587101782716*std::sin(0.299519926309586*x_26 + 1.992959856987) + 0.0223849001245134*std::sin(0.332399845123291*x_26 - 1.15983986854553) - 0.000416164655754499*std::sin(0.333199828863144*x_26 - 1.14551985263824) + 0.0108384885997251*std::sin(0.337279856204987*x_26 - 1.14231979846954) + 0.000324499993235785*std::sin(0.316079914569855*x_27 + 2.00415992736816) - 0.00905147647816823*std::sin(0.319199919700623*x_27 + 5.1755199432373) + 0.000161852944907401*std::sin(0.338799834251404*x_28 - 4.3616795539856) - 0.0128165875687453*std::sin(0.415039867162704*x_28 - 1.20719993114471) - 0.00461368407586953*std::sin(0.557119846343994*x_28 + 4.81655979156494) - 0.0120518113048085*std::sin(0.296719938516617*x_29 - 1.18191993236542) + 0.0442449012621447*std::sin(0.300719946622849*x_29 + 1.98407983779907) - 0.000868203295439466*std::sin(0.301519930362701*x_29 + 1.98215973377228) - 0.0159937157384271*std::sin(0.296959936618805*x_3 + 8.28071975708008) + 0.0291229714555339*std::sin(0.320239841938019*x_3 + 5.19632005691528) - 0.0258974732047024*std::sin(0.346719831228256*x_3 - 7.38624000549316) + 0.000728299145393697*std::sin(0.360559850931168*x_3 - 7.41143989562988) + 4.06480203829265e-5*std::sin(0.400479853153229*x_3 + 2.17975974082947) - 0.00101632136852886*std::sin(0.325919836759567*x_30 - 1.15055990219116) + 0.00117565039680075*std::sin(0.333119839429855*x_30 + 2.01231980323792) + 0.0347901332443813*std::sin(0.351359844207764*x_30 - 1.14287984371185) + 0.0404970352036738*std::sin(0.352639853954315*x_30 - 1.14095985889435) - 0.000223455797352521*std::sin(0.357999831438065*x_31 + 5.16495990753174) + 0.00116897598447152*std::sin(0.365359842777252*x_31 + 5.17280006408691) - 0.0523581905248781*std::sin(0.368399828672409*x_31 + 5.17471981048584) - 0.00659713835125808*std::sin(0.421279847621918*x_31 - 7.38687992095947) - 0.0338506921701898*std::sin(0.303919941186905*x_32 - 1.15511989593506) + 0.000832640480787557*std::sin(0.308319926261902*x_32 + 2.02879977226257) + 0.0162836131593421*std::sin(0.316719859838486*x_32 + 2.00423979759216) - 0.00020178649549147*std::sin(0.336319833993912*x_32 + 1.99399983882904) - 0.00027449654664855*std::sin(0.185760006308556*x_34 - 1.19479990005493) - 0.0119611207453798*std::sin(0.219439998269081*x_35 - 7.40215969085693) + 0.000557108133009387*std::sin(0.22919999063015*x_35 - 7.42343997955322) - 0.0219832977827027*std::sin(0.250639975070953*x_35 + 1.97823977470398) - 0.033476889158937*std::sin(0.245919972658157*x_36 - 7.42759990692139) + 0.0455741246349153*std::sin(0.186000004410744*x_37 + 8.20440006256104) - 0.0182402923537031*std::sin(0.237679988145828*x_38 + 1.98759984970093) + 0.0128419613194785*std::sin(0.239919975399971*x_38 + 1.97351980209351) + 0.0174891196845356*std::sin(0.242159977555275*x_38 + 1.97287976741791) - 0.00338819110317287*std::sin(0.22495998442173*x_39 - 1.18631982803345) + 0.000997859842559557*std::sin(0.319279909133911*x_4 + 2.00879979133606) - 0.000156806479034281*std::sin(0.324959844350815*x_4 - 1.16639983654022) + 0.0285488156067437*std::sin(0.330719828605652*x_4 - 7.38168001174927) - 0.00587178487457509*std::sin(0.386159837245941*x_4 + 1.99143981933594) + 0.000167985835798516*std::sin(0.189759999513626*x_40 + 2.000159740448) - 0.0191922571626808*std::sin(0.213359996676445*x_40 + 1.98591983318329) + 0.0112459934459033*std::sin(0.225519984960556*x_41 - 4.39015960693359) + 0.0185178536151955*std::sin(0.250879973173141*x_42 + 5.15895986557007) + 0.0185619516518742*std::sin(0.255599975585938*x_42 - 7.43623971939087) - 0.000592256236889888*std::sin(0.256719976663589*x_43 + 5.15768003463745) + 0.00518590991372711*std::sin(0.28263995051384*x_43 + 5.11055994033813) + 0.00778523493758174*std::sin(0.225679993629456*x_44 - 7.42191982269287) - 0.00857537395812288*std::sin(0.214000001549721*x_45 - 1.21471989154816) + 0.000624879026257327*std::sin(0.153200030326843*x_47 - 1.17551982402802) + 0.0010252469079498*std::sin(0.213599994778633*x_47 + 1.9826397895813) + 0.00162383882826059*std::sin(0.0819200873374939*x_49 - 1.29207980632782) + 0.0308899551084041*std::sin(0.169840022921562*x_49 + 2.00367975234985) - 0.0315308948072723*std::sin(0.211759999394417*x_49 + 1.99351978302002) - 0.000686723977181893*std::sin(0.27295994758606*x_49 + 5.11960029602051) - 0.000350499139585969*std::sin(0.322399914264679*x_5 + 2.01399993896484) + 0.0233189445292655*std::sin(0.327759832143784*x_5 - 1.14439988136292) - 0.00496353525072396*std::sin(0.358959853649139*x_5 + 2.02503991127014) - 0.0124401230014892*std::sin(0.374239832162857*x_5 + 2.01015973091125) - 7.15523096015219e-5*std::sin(0.402399837970734*x_5 + 8.21047973632813) - 0.0203617664809932*std::sin(0.22775998711586*x_50 - 7.4364800453186) + 0.0295794427788265*std::sin(0.217600002884865*x_51 + 1.98359978199005) - 0.00109489004721131*std::sin(0.222479999065399*x_52 - 7.41655969619751) - 0.0447343863411713*std::sin(0.223839998245239*x_52 + 1.98967981338501) + 0.019496004756345*std::sin(0.25095996260643*x_53 + 5.15743970870972) + 0.000355146272562848*std::sin(0.256639957427979*x_53 - 7.42983961105347) - 0.000790347584210785*std::sin(0.25943997502327*x_53 - 7.4398398399353) - 0.029488182705172*std::sin(0.224399983882904*x_54 + 1.9832798242569) - 0.0113012502611883*std::sin(0.240879982709885*x_55 - 7.44704008102417) - 0.000346754526774004*std::sin(0.0958400741219521*x_56 + 7.95592021942139) + 0.000595404780412446*std::sin(0.163920015096664*x_57 - 1.17575979232788) - 0.00390114680896227*std::sin(0.51751983165741*x_57 - 4.48799991607666) + 0.0450321207873094*std::sin(0.151040032505989*x_58 - 4.38327980041504) - 0.0263317930922491*std::sin(0.146080031991005*x_59 - 1.21031987667084) + 0.000757932912907618*std::sin(0.284239947795868*x_6 - 7.382239818573) - 0.000808252230106098*std::sin(0.344559848308563*x_6 + 2.00063967704773) - 0.0266804360047335*std::sin(0.37271985411644*x_6 + 2.00519990921021) + 0.0168067428484721*std::sin(0.40447986125946*x_60 + 8.19551944732666) + 0.000163943094517379*std::sin(0.41543984413147*x_60 - 1.21631991863251) + 0.000488811516939975*std::sin(0.257439970970154*x_7 - 7.37671947479248) - 0.0377775195738521*std::sin(0.345999836921692*x_7 + 2.00303983688354) - 0.00100278077705011*std::sin(0.357119828462601*x_7 + 1.99847972393036) + 0.0212783697667335*std::sin(0.361919850111008*x_7 + 2.0079197883606) + 0.00303648888755872*std::sin(0.412159860134125*x_7 + 4.98207950592041) + 0.0124552011662116*std::sin(0.144000038504601*x_71 - 4.31903982162476) + 0.00753290040533426*std::sin(0.254399985074997*x_8 - 4.38703966140747) - 0.0113192116292626*std::sin(0.292959928512573*x_8 - 7.41423988342285) - 0.000381775791317641*std::sin(0.29911994934082*x_8 - 7.41567993164063) + 0.000412808504850906*std::sin(0.334959834814072*x_8 - 1.14431989192963) + 0.0226957383133401*std::sin(0.337839841842651*x_8 - 1.15391993522644) + 0.000716376312063624*std::sin(0.271999955177307*x_9 + 2.00103974342346) - 0.00023117154889002*std::sin(0.306639939546585*x_9 - 1.19591987133026) - 0.0448569715817358*std::sin(0.314799934625626*x_9 + 5.14448022842407) + 0.0280465971599198*std::sin(0.316319912672043*x_9 - 7.42663955688477) + 6.01085240453087e-5*std::sin(0.259039968252182*x_91 - 4.16463994979858) - 0.0345362237677209*std::sin(0.355039834976196*x_91 - 7.40223979949951) + 0.000157973504607138*std::sin(0.359519839286804*x_91 - 7.41016006469727) + 0.00629374441784799*std::sin(0.36575984954834*x_91 - 7.38615989685059) - 0.0145303453835993*std::sin(0.262719959020615*x_92 - 7.38695955276489) + 0.000384373455016307*std::sin(0.26599994301796*x_92 - 7.39991998672485) + 0.0247588787744057*std::sin(0.285919934511185*x_92 + 1.99951982498169) - 0.000368498324260677*std::sin(0.296799927949905*x_92 + 1.99463987350464) - 0.0286911563558452*std::sin(0.300159931182861*x_92 + 1.99007987976074) + 0.0207952862912791*std::sin(0.286479949951172*x_94 + 1.97767972946167) + 0.000214788504144249*std::sin(0.28671994805336*x_94 + 1.96495985984802) - 0.000297487927692953*std::sin(0.286959946155548*x_94 + 1.97103977203369) + 0.0078781114093464*std::sin(0.249199971556664*x_95 + 5.19456005096436) - 0.000305773093656073*std::sin(0.280399948358536*x_95 - 7.44032001495361) - 0.0198627033037579*std::sin(0.28263995051384*x_95 + 1.96735978126526) + 9.87446558598029e-5*std::sin(0.295519918203354*x_95 - 1.22903990745544) - 0.0108764232708669*std::sin(0.282559931278229*x_96 - 7.43711996078491) + 8.70608817332972e-5*std::sin(0.299439936876297*x_96 + 1.93367981910706) - 0.0138540008802646*std::sin(0.260399967432022*x_97 - 7.41359996795654) - 0.000248034097859541*std::sin(0.271919965744019*x_97 - 7.42767953872681) + 0.0140000096964056*std::sin(0.276479959487915*x_97 + 1.96783983707428) + 0.0250203338023739*std::sin(0.280159950256348*x_97 + 1.95407974720001) - 0.000150576070536543*std::sin(0.283359944820404*x_97 - 1.20615983009338) - 0.01334238846522*std::sin(0.23191998898983*x_98 + 5.18480014801025) + 0.000239945888027702*std::sin(0.232239991426468*x_98 - 7.39911985397339) - 0.158155080700148);
}

inline float score_8(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.00477512854849285*x_10 + 0.00370938539646113*x_100 + 0.000545585986583973*x_101 - 0.00207449031693056*x_102 - 0.0179272220661769*x_103 - 0.00107478620504248*x_104 + 0.00399141666486844*x_105 + 0.0115193111132802*x_106 - 0.000154202914646678*x_107 - 0.0016018884928951*x_108 + 0.00456280768810386*x_109 + 2.81852353860796e-5*x_11 - 0.00242788606765834*x_110 + 0.00869013175710328*x_111 + 0.000882362711964558*x_112 + 0.00190446812129798*x_113 + 0.0298449569644516*x_114 - 0.000180659876593859*x_115 + 0.00396080088023148*x_116 + 0.0157943085596654*x_117 + 0.0130423493532432*x_118 + 0.0192623490085407*x_119 + 0.0340882956359962*x_120 + 0.00037444555445273*x_14 + 0.000285545552567211*x_15 + 0.00939014925378368*x_16 + 0.000563128440795765*x_19 + 0.000197660797494457*x_2 - 0.000134247757156432*x_21 + 0.00417339362148854*x_22 + 0.00138098992698955*x_23 - 0.00206828918268008*x_24 + 0.000367493527958905*x_26 - 0.000623026333064464*x_27 + 0.000125627556837511*x_28 - 0.000316700052479326*x_29 - 4.84052749476416e-5*x_31 - 0.000389720457543513*x_32 + 0.017038684624672*x_33 - 0.0253560860984864*x_34 - 0.0105596796906552*x_35 + 0.0140061466192072*x_36 - 0.00456968082863654*x_37 + 0.00252358198940545*x_38 + 0.00134253312801115*x_39 + 9.50196263796393e-5*x_4 + 0.0134793726226846*x_40 - 0.000187600897990039*x_41 + 0.00333905628535331*x_42 + 0.00466999935339067*x_43 - 0.000234215920959635*x_44 + 0.0112536188990285*x_45 + 0.0411608199223463*x_46 - 0.00207142624393818*x_47 - 0.0203579705782202*x_48 - 9.46531111921492e-5*x_49 - 0.00192073907700773*x_50 - 0.00233028184974821*x_51 - 0.0132717118548344*x_52 - 0.000782909434711151*x_53 - 0.0427481424084954*x_54 - 0.039556618841548*x_55 + 0.00192397948202881*x_56 - 0.027897899395286*x_57 - 0.037662891872829*x_58 - 0.00515851446317987*x_59 + 0.00044545598294714*x_6 + 0.0024155796511853*x_60 - 0.00190323264475353*x_61 + 0.0113448795160825*x_62 - 0.000210588185193091*x_63 - 0.00565492142124319*x_64 + 0.00421935428445252*x_65 - 0.0024334627225793*x_66 - 0.000231437391115105*x_67 - 0.00204796751800776*x_68 + 0.00428109257142331*x_69 + 0.00546873438823277*x_70 + 0.000823582476569042*x_71 - 0.00798770902884526*x_72 - 0.00532012847267234*x_73 - 0.0136002271650574*x_74 - 0.00501661724379606*x_75 + 0.00536258001317002*x_76 - 0.00900353566442835*x_77 - 0.00170875825753045*x_78 - 0.0035737439685957*x_79 - 0.00300734267775779*x_80 + 0.00698220145060022*x_81 - 0.00433926202140829*x_82 + 0.00586937163702336*x_83 - 0.000296911863381578*x_84 - 0.00468082430999601*x_85 - 0.00143591529563128*x_86 - 0.00245357079629157*x_87 + 0.00939336014827411*x_88 - 0.00513283887363016*x_89 - 0.000197091707689014*x_9 - 0.00321586885712761*x_90 - 0.00174750534508769*x_91 + 0.0265871270880779*x_93 - 8.88411909575049e-5*x_94 - 0.000414759957373998*x_95 - 0.000334048210660911*x_96 - 0.00414183678940112*x_98 - 0.0082591032771196*x_99 - 1.38701723678538e-5*std::pow(-3.08031988143921*x_22 - 8.18991947174072, 2) + 4.67116294091285e-7*std::pow(-7.29407978057861*x_24 - 1.18351984024048, 2) - 2.53690929326778e-6*std::pow(-5.27952003479004*x_55 - 8.32055950164795, 2) + 0.00015821318750115*std::pow(-2.59631991386414*x_56 - 9.37975978851318, 2) + 2.12915345541571e-6*std::pow(-3.85775995254517*x_59 - 9.14136028289795, 2) + 9.71971132505448e-6*std::pow(-2.80672001838684*x_59 - 8.59552001953125, 2) - 5.2481596503603e-6*std::pow(-4.6854395866394*x_61 - 8.77040004730225, 2) - 5.33395731992862e-6*std::pow(-3.75288009643555*x_65 - 9.44944000244141, 2) + 0.000120819313574408*std::exp(0.299919843673706*x_10) + 0.0254030978751702*std::exp(0.228399842977524*x_18) - 0.000467026906549947*std::exp(0.331679850816727*x_30) - 0.216443400392462*std::sin(0.31879985332489*x_1 - 4.26864004135132) - 0.0288636090255835*std::sin(0.326959848403931*x_1 - 4.2611198425293) - 0.150981824854182*std::sin(0.358239859342575*x_1 + 8.35488033294678) + 0.00261409345309491*std::sin(0.361999839544296*x_1 + 5.17400026321411) + 0.000663694662179057*std::sin(0.365919858217239*x_1 - 4.23160028457642) - 0.00488276022452682*std::sin(0.263839960098267*x_10 + 1.99799978733063) + 0.0117713949983238*std::sin(0.243119969964027*x_100 - 7.42335987091064) - 0.00461370540131379*std::sin(0.250079959630966*x_100 - 1.2054398059845) - 0.0213146470450283*std::sin(0.2291199862957*x_101 - 7.40719985961914) + 0.169524428681939*std::sin(0.237119987607002*x_101 + 1.98511981964111) + 0.015202615596537*std::sin(0.220159992575645*x_102 + 2.00143980979919) + 0.00173649687639321*std::sin(0.239199981093407*x_106 + 8.17751979827881) + 0.0663043627686529*std::sin(0.246319979429245*x_108 - 1.19671988487244) - 0.00984201203051528*std::sin(0.256719976663589*x_108 + 1.97239983081818) - 0.014751317543196*std::sin(0.23479999601841*x_109 - 7.42360019683838) + 0.0192083245592074*std::sin(0.274879962205887*x_11 - 7.44007968902588) - 0.313644469609962*std::sin(0.286479949951172*x_11 - 7.44456005096436) - 0.000939399749627429*std::sin(0.292959928512573*x_11 - 7.44855976104736) - 0.0476996822775177*std::sin(0.293119937181473*x_11 - 7.43735980987549) + 0.00435146720893959*std::sin(0.231119990348816*x_112 - 4.20911979675293) + 0.320649087727959*std::sin(0.281519949436188*x_112 + 5.14000034332275) + 0.231063118494216*std::sin(0.292479932308197*x_113 - 7.43639993667603) + 0.205437374194896*std::sin(0.251439958810806*x_116 - 7.41999959945679) + 0.0157729723732394*std::sin(0.219679996371269*x_118 - 4.21519994735718) + 0.00178547818929464*std::sin(0.23599998652935*x_119 + 5.17160034179688) - 0.0284219685139708*std::sin(0.291119933128357*x_12 - 7.45567989349365) + 0.00395148064109487*std::sin(0.292959928512573*x_12 - 4.27135992050171) - 0.0167542239079167*std::sin(0.295039921998978*x_12 - 4.26959991455078) - 0.198129125595423*std::sin(0.296319931745529*x_12 + 5.12960004806519) - 0.00668285492598194*std::sin(0.297279924154282*x_12 - 4.26855993270874) + 0.0037587666189922*std::sin(0.262639969587326*x_120 + 5.16879987716675) + 0.0143509746867765*std::sin(0.266719967126846*x_120 + 5.15808010101318) - 0.0143089305355683*std::sin(0.267679959535599*x_120 + 5.16016006469727) - 0.00505709376922045*std::sin(0.192479997873306*x_13 + 8.19071960449219) - 0.0133803170671213*std::sin(0.19344000518322*x_13 + 1.97303986549377) - 0.0029099713025587*std::sin(0.216639995574951*x_13 - 1.17511987686157) + 0.0313298327965545*std::sin(0.232239991426468*x_13 + 1.98807990550995) - 0.234157137861156*std::sin(0.295279920101166*x_13 - 7.43551969528198) - 0.298190175329658*std::sin(0.30159991979599*x_14 - 7.4423999786377) - 0.0512460798470513*std::sin(0.310879945755005*x_14 - 7.44575977325439) - 0.00420953123567374*std::sin(0.339599847793579*x_14 - 4.33360004425049) + 0.00023665886937343*std::sin(0.654879808425903*x_14 - 4.47160005569458) - 0.00896148643787067*std::sin(0.288399934768677*x_15 + 1.96623980998993) + 0.00173930516448241*std::sin(0.291679948568344*x_15 + 5.15560007095337) - 0.322202066146943*std::sin(0.295359939336777*x_15 - 7.43336009979248) - 0.00227761178103358*std::sin(0.423679858446121*x_15 + 8.16016006469727) + 0.0222439237169318*std::sin(0.219439998269081*x_16 + 1.98215985298157) + 0.00262422423030753*std::sin(0.299759924411774*x_16 - 7.40511989593506) - 0.0103149234838682*std::sin(0.337919861078262*x_16 - 1.15591979026794) - 0.00186730905135401*std::sin(0.342799842357635*x_16 - 1.14039981365204) - 0.00242148420667956*std::sin(0.314799934625626*x_17 + 2.02759981155396) + 0.00735745002799501*std::sin(0.346559852361679*x_17 + 2.02431988716125) + 0.0159804348182113*std::sin(0.347679853439331*x_17 - 1.15719985961914) - 0.015952266257275*std::sin(0.35471984744072*x_17 - 1.15351986885071) - 0.203802001055984*std::sin(0.361119836568832*x_17 + 2.00263977050781) - 0.0171591841609892*std::sin(0.117200054228306*x_18 - 1.28391993045807) - 0.00184490373462394*std::sin(0.395679831504822*x_18 + 2.01239991188049) + 0.0115653016132076*std::sin(0.414719849824905*x_18 - 7.41239976882935) - 0.00282820581736011*std::sin(0.46687987446785*x_18 - 7.43407964706421) + 0.167257134542957*std::sin(0.241439983248711*x_19 - 1.16903984546661) + 0.00403077015012823*std::sin(0.287599951028824*x_19 - 1.19359982013702) - 0.0285460117776905*std::sin(0.313359916210175*x_19 - 7.41943979263306) + 0.00220834355593441*std::sin(0.331279844045639*x_19 - 1.16599988937378) - 0.00495356713785602*std::sin(0.372159838676453*x_2 + 5.19632005691528) - 0.166663904637856*std::sin(0.375199824571609*x_2 + 5.17495965957642) - 0.00959973203039841*std::sin(0.393439829349518*x_2 + 5.18728017807007) - 0.00728462375307571*std::sin(0.404799848794937*x_2 + 2.01151990890503) - 0.2753750713422*std::sin(0.202480003237724*x_20 + 1.9812798500061) + 0.00890849856959722*std::sin(0.246639966964722*x_20 - 1.16767990589142) + 0.000665797865211934*std::sin(0.270879954099655*x_20 + 1.9923198223114) - 0.00452418460099492*std::sin(0.344479858875275*x_20 - 4.3635196685791) + 0.0122020432618724*std::sin(0.403279840946198*x_20 + 8.19911956787109) + 0.189943664116493*std::sin(0.314639925956726*x_21 - 7.40407991409302) + 0.00418651110036939*std::sin(0.33247983455658*x_21 + 8.24967956542969) - 0.00184710311773019*std::sin(0.339919835329056*x_21 - 1.13927984237671) - 0.0493042204284859*std::sin(0.360639840364456*x_22 + 1.99255979061127) - 0.00398888603551889*std::sin(0.394959837198257*x_22 - 7.40967988967896) - 0.0032911831509885*std::sin(0.241119980812073*x_23 - 4.37519979476929) - 0.038409875178411*std::sin(0.3643998503685*x_23 + 2.00103974342346) + 0.0179373829572755*std::sin(0.285839945077896*x_24 - 1.15983986854553) + 0.00721059877346636*std::sin(0.306479930877686*x_24 + 1.9890398979187) + 0.000886070983438492*std::sin(0.363439828157425*x_24 - 1.15135991573334) + 0.00654597380327945*std::sin(0.207600012421608*x_25 + 2.0052797794342) - 0.00162611515080392*std::sin(0.275919944047928*x_25 - 1.16351985931396) + 0.112966069900136*std::sin(0.324399828910828*x_25 - 1.1555198431015) + 0.00171332799221826*std::sin(0.363119840621948*x_25 + 2.03151988983154) - 0.010086158505656*std::sin(0.378719836473465*x_25 + 2.0130398273468) + 0.0236698855647847*std::sin(0.299519926309586*x_26 + 1.992959856987) - 0.00472707845640002*std::sin(0.332399845123291*x_26 - 1.15983986854553) - 0.00294185317422486*std::sin(0.333199828863144*x_26 - 1.14551985263824) + 0.0791091927266167*std::sin(0.337279856204987*x_26 - 1.14231979846954) - 0.0128746962224167*std::sin(0.316079914569855*x_27 + 2.00415992736816) - 0.0660659455036942*std::sin(0.319199919700623*x_27 + 5.1755199432373) - 0.00642159489005664*std::sin(0.338799834251404*x_28 - 4.3616795539856) - 0.0935471663548317*std::sin(0.415039867162704*x_28 - 1.20719993114471) + 0.000974283846627293*std::sin(0.557119846343994*x_28 + 4.81655979156494) - 0.0879651304187463*std::sin(0.296719938516617*x_29 - 1.18191993236542) - 0.0129639952863215*std::sin(0.300719946622849*x_29 + 1.98407983779907) + 0.0344463911281571*std::sin(0.301519930362701*x_29 + 1.98215973377228) - 0.116736750620197*std::sin(0.296959936618805*x_3 + 8.28071975708008) - 0.00614997476817197*std::sin(0.320239841938019*x_3 + 5.19632005691528) + 0.00758809966744461*std::sin(0.346719831228256*x_3 - 7.38624000549316) + 0.00514832079811608*std::sin(0.360559850931168*x_3 - 7.41143989562988) - 0.00161273012444263*std::sin(0.400479853153229*x_3 + 2.17975974082947) - 0.00718433966627614*std::sin(0.325919836759567*x_30 - 1.15055990219116) - 0.0466445055102828*std::sin(0.333119839429855*x_30 + 2.01231980323792) - 0.00734672428467563*std::sin(0.351359844207764*x_30 - 1.14287984371185) + 0.295584364305672*std::sin(0.352639853954315*x_30 - 1.14095985889435) - 0.00157960109694721*std::sin(0.357999831438065*x_31 + 5.16495990753174) - 0.0463796949309506*std::sin(0.365359842777252*x_31 + 5.17280006408691) + 0.0153412329059843*std::sin(0.368399828672409*x_31 + 5.17471981048584) - 0.0481519433703208*std::sin(0.421279847621918*x_31 - 7.38687992095947) - 0.247073280207062*std::sin(0.303919941186905*x_32 - 1.15511989593506) - 0.0330354190326207*std::sin(0.308319926261902*x_32 + 2.02879977226257) - 0.00477118669541722*std::sin(0.316719859838486*x_32 + 2.00423979759216) - 0.00142642157153173*std::sin(0.336319833993912*x_32 + 1.99399983882904) - 0.00194040634135008*std::sin(0.185760006308556*x_34 - 1.19479990005493) + 0.00350467304794047*std::sin(0.219439998269081*x_35 - 7.40215969085693) - 0.022103538135737*std::sin(0.22919999063015*x_35 - 7.42343997955322) + 0.00464227102963227*std::sin(0.250639975070953*x_35 + 1.97823977470398) + 0.00980890952125338*std::sin(0.245919972658157*x_36 - 7.42759990692139) - 0.00962400821681936*std::sin(0.186000004410744*x_37 + 8.20440006256104) + 0.0053445042784365*std::sin(0.237679988145828*x_38 + 1.98759984970093) - 0.00271187087516875*std::sin(0.239919975399971*x_38 + 1.97351980209351) + 0.127651574941721*std::sin(0.242159977555275*x_38 + 1.97287976741791) - 0.0247301143982667*std::sin(0.22495998442173*x_39 - 1.18631982803345) - 0.0395905781611772*std::sin(0.319279909133911*x_4 + 2.00879979133606) - 0.00110845943236024*std::sin(0.324959844350815*x_4 - 1.16639983654022) + 0.208375340820843*std::sin(0.330719828605652*x_4 - 7.38168001174927) + 0.001720464714912*std::sin(0.386159837245941*x_4 + 1.99143981933594) - 0.00666492034100961*std::sin(0.189759999513626*x_40 + 2.000159740448) + 0.00562343511440359*std::sin(0.213359996676445*x_40 + 1.98591983318329) + 0.0820835354236384*std::sin(0.225519984960556*x_41 - 4.39015960693359) - 0.00542583122872924*std::sin(0.250879973173141*x_42 + 5.15895986557007) + 0.13548208286601*std::sin(0.255599975585938*x_42 - 7.43623971939087) + 0.0234980563782276*std::sin(0.256719976663589*x_43 + 5.15768003463745) - 0.00109512228750869*std::sin(0.28263995051384*x_43 + 5.11055994033813) - 0.00228111592871985*std::sin(0.225679993629456*x_44 - 7.42191982269287) + 0.00251263093374028*std::sin(0.214000001549721*x_45 - 1.21471989154816) + 0.00441724764821475*std::sin(0.153200030326843*x_47 - 1.17551982402802) - 0.0406771733989979*std::sin(0.213599994778633*x_47 + 1.9826397895813) + 0.0114788590172013*std::sin(0.0819200873374939*x_49 - 1.29207980632782) + 0.225463115959661*std::sin(0.169840022921562*x_49 + 2.00367975234985) + 0.00923872265491326*std::sin(0.211759999394417*x_49 + 1.99351978302002) + 0.0272461102593689*std::sin(0.27295994758606*x_49 + 5.11960029602051) + 0.0139062250923034*std::sin(0.322399914264679*x_5 + 2.01399993896484) - 0.00492432307926923*std::sin(0.327759832143784*x_5 - 1.14439988136292) + 0.00145434266453953*std::sin(0.358959853649139*x_5 + 2.02503991127014) - 0.0907993839743109*std::sin(0.374239832162857*x_5 + 2.01015973091125) - 0.000505800735871555*std::sin(0.402399837970734*x_5 + 8.21047973632813) + 0.00596610766779186*std::sin(0.22775998711586*x_50 - 7.4364800453186) + 0.215897799587617*std::sin(0.217600002884865*x_51 + 1.98359978199005) + 0.043440299071287*std::sin(0.222479999065399*x_52 - 7.41655969619751) + 0.00944667846438394*std::sin(0.223839998245239*x_52 + 1.98967981338501) - 0.00411702279469491*std::sin(0.25095996260643*x_53 + 5.15743970870972) + 0.00251051639010276*std::sin(0.256639957427979*x_53 - 7.42983961105347) + 0.03135742763927*std::sin(0.25943997502327*x_53 - 7.4398398399353) + 0.00864019696477691*std::sin(0.224399983882904*x_54 + 1.9832798242569) + 0.00238651485344563*std::sin(0.240879982709885*x_55 - 7.44704008102417) - 0.00245119543709814*std::sin(0.0958400741219521*x_56 + 7.95592021942139) + 0.00420889525091795*std::sin(0.163920015096664*x_57 - 1.17575979232788) + 0.00114305710714527*std::sin(0.51751983165741*x_57 - 4.48799991607666) - 0.00950955183340675*std::sin(0.151040032505989*x_58 - 4.38327980041504) - 0.192193484857747*std::sin(0.146080031991005*x_59 - 1.21031987667084) - 0.0300713596735473*std::sin(0.284239947795868*x_6 - 7.382239818573) - 0.00571350631494911*std::sin(0.344559848308563*x_6 + 2.00063967704773) - 0.194738199381615*std::sin(0.37271985411644*x_6 + 2.00519990921021) - 0.0035491242578414*std::sin(0.40447986125946*x_60 + 8.19551944732666) + 0.0011589079138011*std::sin(0.41543984413147*x_60 - 1.21631991863251) - 0.0193938364308319*std::sin(0.257439970970154*x_7 - 7.37671947479248) + 0.00797757854269935*std::sin(0.345999836921692*x_7 + 2.00303983688354) - 0.00708862170591635*std::sin(0.357119828462601*x_7 + 1.99847972393036) + 0.155308984209056*std::sin(0.361919850111008*x_7 + 2.0079197883606) - 0.000889707661274837*std::sin(0.412159860134125*x_7 + 4.98207950592041) + 0.0909094381970938*std::sin(0.144000038504601*x_71 - 4.31903982162476) - 0.00159074246577799*std::sin(0.254399985074997*x_8 - 4.38703966140747) - 0.0826179486238895*std::sin(0.292959928512573*x_8 - 7.41423988342285) + 0.0151471415739473*std::sin(0.29911994934082*x_8 - 7.41567993164063) + 0.00291812866265862*std::sin(0.334959834814072*x_8 - 1.14431989192963) - 0.0066499740336287*std::sin(0.337839841842651*x_8 - 1.15391993522644) - 0.0284225811741472*std::sin(0.271999955177307*x_9 + 2.00103974342346) - 0.00163414347059249*std::sin(0.306639939546585*x_9 - 1.19591987133026) + 0.00947256511326429*std::sin(0.314799934625626*x_9 + 5.14448022842407) + 0.20470969172825*std::sin(0.316319912672043*x_9 - 7.42663955688477) + 0.00042490502212417*std::sin(0.259039968252182*x_91 - 4.16463994979858) + 0.00729310555015722*std::sin(0.355039834976196*x_91 - 7.40223979949951) - 0.00626767619538783*std::sin(0.359519839286804*x_91 - 7.41016006469727) - 0.00184410114247679*std::sin(0.36575984954834*x_91 - 7.38615989685059) + 0.00425746975782659*std::sin(0.262719959020615*x_92 - 7.38695955276489) - 0.0152502051539333*std::sin(0.26599994301796*x_92 - 7.39991998672485) + 0.180712919023515*std::sin(0.285919934511185*x_92 + 1.99951982498169) - 0.00260490156944592*std::sin(0.296799927949905*x_92 + 1.99463987350464) + 0.00605878723356013*std::sin(0.300159931182861*x_92 + 1.99007987976074) - 0.00439139550658651*std::sin(0.286479949951172*x_94 + 1.97767972946167) - 0.00852183913888456*std::sin(0.28671994805336*x_94 + 1.96495985984802) - 0.00210293159756787*std::sin(0.286959946155548*x_94 + 1.97103977203369) - 0.00166364158486725*std::sin(0.249199971556664*x_95 + 5.19456005096436) + 0.0121316973062308*std::sin(0.280399948358536*x_95 - 7.44032001495361) - 0.144976156894094*std::sin(0.28263995051384*x_95 + 1.96735978126526) + 0.000698022466017077*std::sin(0.295519918203354*x_95 - 1.22903990745544) - 0.0793860746168146*std::sin(0.282559931278229*x_96 - 7.43711996078491) + 0.000615430281587884*std::sin(0.299439936876297*x_96 + 1.93367981910706) - 0.101119156567583*std::sin(0.260399967432022*x_97 - 7.41359996795654) - 0.00175334423049741*std::sin(0.271919965744019*x_97 - 7.42767953872681) - 0.00295641900822236*std::sin(0.276479959487915*x_97 + 1.96783983707428) - 0.00733109308018022*std::sin(0.280159950256348*x_97 + 1.95407974720001) + 0.0059741793742182*std::sin(0.283359944820404*x_97 - 1.20615983009338) + 0.00281754739668434*std::sin(0.23191998898983*x_98 + 5.18480014801025) + 0.0016961689623948*std::sin(0.232239991426468*x_98 - 7.39911985397339) - 0.0412309811510429);
}

inline float score_9(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.00296860897173194*x_10 - 0.000683933327984028*x_100 + 0.000437359604209979*x_101 - 0.00236790646444389*x_102 - 0.00859085427486282*x_103 - 0.00120237843552112*x_104 - 0.000284705609110968*x_105 + 0.00262623574182028*x_106 + 0.000941146053330407*x_107 + 0.00355586057061518*x_108 + 0.00255379455435516*x_109 - 0.000136045651797261*x_11 - 0.00226454948617529*x_110 + 0.00178405512154997*x_111 - 0.00302469626281075*x_112 - 0.003201243014257*x_113 + 0.00104870319188186*x_114 - 0.00618657973441437*x_115 + 0.00179348697040389*x_116 - 0.00796754470710832*x_117 - 0.00195684224629925*x_118 - 0.00122254177823977*x_119 + 0.012295856656034*x_120 - 0.00180738918161627*x_14 + 0.000346109650277022*x_15 + 0.00340096112474439*x_16 + 0.000682567758287853*x_19 - 0.000940373742883862*x_2 + 0.000895615780537893*x_21 + 0.00167099615562676*x_22 + 0.0015980301195316*x_23 - 0.000749101096789268*x_24 + 0.00044543875853569*x_26 - 0.0011836113075812*x_27 + 0.000550386247948673*x_28 + 0.00152537237268895*x_29 + 0.000233644569238899*x_31 + 0.00188111871123205*x_32 + 0.00954396414110461*x_33 - 0.00572708182642987*x_34 - 0.00375589523294012*x_35 + 0.00494714602816567*x_36 - 0.00418546666221092*x_37 + 0.00406698124741363*x_38 + 0.00198584329049978*x_39 - 0.00045864463529493*x_4 + 0.00330520212034767*x_40 + 9.78135432457962e-5*x_41 + 0.00510187366067591*x_42 + 0.00126547631555117*x_43 - 0.0022225441891944*x_44 + 0.00745751802008386*x_45 + 0.0176442265799315*x_46 - 0.00133758935840277*x_47 + 0.00354714674927959*x_48 + 0.000456875524734288*x_49 - 0.00249307861439814*x_50 + 0.00531061011015353*x_51 - 0.00436196363808369*x_52 + 0.00117043648011534*x_53 - 0.019685282111305*x_54 - 0.0163983349531477*x_55 + 0.00758616780601333*x_56 - 0.0111698569800955*x_57 - 0.0108333461971844*x_58 - 0.0114078792234163*x_59 + 0.000392682742017787*x_6 + 0.00442257768888385*x_60 + 0.000917147837471033*x_61 + 0.00308653184236*x_62 + 0.000421187818975421*x_63 - 0.0013726870719038*x_64 + 0.00241545844638144*x_65 + 0.00116402410937976*x_66 + 0.00159239786167068*x_67 - 0.00224728970538807*x_68 + 0.00399738477206341*x_69 + 0.00144377370525211*x_70 + 0.00059892532640483*x_71 - 0.00209286374051429*x_72 - 0.00233106041102524*x_73 - 0.0062613373351725*x_74 - 9.45652232701316e-5*x_75 + 0.00170982758570687*x_76 - 0.00574561294408615*x_77 + 0.000581380562931655*x_78 - 0.00378313661117245*x_79 - 0.00137415253026254*x_80 - 0.0025729776164321*x_81 - 0.00125940833890984*x_82 + 0.00164960294713037*x_83 - 0.00123434419547943*x_84 - 0.000292408792763542*x_85 - 0.0016061181195251*x_86 - 0.00326890777311239*x_87 + 0.00436695190629211*x_88 - 0.00174895328084087*x_89 - 0.000238894780210907*x_9 + 0.000950677547993102*x_90 - 0.000632918347014717*x_91 + 0.0104727178356683*x_93 - 5.89889197941009e-5*x_94 - 0.00050273037876098*x_95 - 0.0016314753880303*x_96 - 0.00350046713764745*x_98 - 0.00318890163569481*x_99 + 6.69491176666554e-5*std::pow(-3.08031988143921*x_22 - 8.18991947174072, 2) - 2.25469611391488e-6*std::pow(-7.29407978057861*x_24 - 1.18351984024048, 2) - 3.0749867416365e-6*std::pow(-5.27952003479004*x_55 - 8.32055950164795, 2) + 5.73022734326072e-5*std::pow(-2.59631991386414*x_56 - 9.37975978851318, 2) - 1.02770853480784e-5*std::pow(-3.85775995254517*x_59 - 9.14136028289795, 2) + 1.17812582169929e-5*std::pow(-2.80672001838684*x_59 - 8.59552001953125, 2) - 6.36129221713806e-6*std::pow(-4.6854395866394*x_61 - 8.77040004730225, 2) - 9.99325147443336e-6*std::pow(-3.75288009643555*x_65 - 9.44944000244141, 2) - 0.000583175625102141*std::exp(0.299919843673706*x_10) + 0.0092005937271677*std::exp(0.228399842977524*x_18) - 0.000566083126992198*std::exp(0.331679850816727*x_30) - 0.0783923205635559*std::sin(0.31879985332489*x_1 - 4.26864004135132) - 0.0349855689775663*std::sin(0.326959848403931*x_1 - 4.2611198425293) - 0.282866782266807*std::sin(0.358239859342575*x_1 + 8.35488033294678) - 0.0126178136465341*std::sin(0.361999839544296*x_1 + 5.17400026321411) - 0.00315753574566481*std::sin(0.365919858217239*x_1 - 4.23160028457642) - 0.00591839171895263*std::sin(0.263839960098267*x_10 + 1.99799978733063) + 0.0220538904545849*std::sin(0.243119969964027*x_100 - 7.42335987091064) - 0.00559227047514272*std::sin(0.250079959630966*x_100 - 1.2054398059845) - 0.0399333206536804*std::sin(0.2291199862957*x_101 - 7.40719985961914) + 0.0613990231741485*std::sin(0.237119987607002*x_101 + 1.98511981964111) + 0.0284823352743607*std::sin(0.220159992575645*x_102 + 2.00143980979919) - 0.00838179444509801*std::sin(0.239199981093407*x_106 + 8.17751979827881) + 0.0240143744345996*std::sin(0.246319979429245*x_108 - 1.19671988487244) - 0.0119294988532595*std::sin(0.256719976663589*x_108 + 1.97239983081818) - 0.0276368213966794*std::sin(0.23479999601841*x_109 - 7.42360019683838) + 0.0232824025302583*std::sin(0.274879962205887*x_11 - 7.44007968902588) - 0.113596985447781*std::sin(0.286479949951172*x_11 - 7.44456005096436) + 0.00446920618463093*std::sin(0.292959928512573*x_11 - 7.44855976104736) - 0.0893660919386932*std::sin(0.293119937181473*x_11 - 7.43735980987549) + 0.00815254106725135*std::sin(0.231119990348816*x_112 - 4.20911979675293) + 0.116133945539591*std::sin(0.281519949436188*x_112 + 5.14000034332275) + 0.0836873474662171*std::sin(0.292479932308197*x_113 - 7.43639993667603) + 0.074406114782987*std::sin(0.251439958810806*x_116 - 7.41999959945679) + 0.0295509075102949*std::sin(0.219679996371269*x_118 - 4.21519994735718) - 0.00849443505736937*std::sin(0.23599998652935*x_119 + 5.17160034179688) - 0.0532489972683806*std::sin(0.291119933128357*x_12 - 7.45567989349365) - 0.018799219104151*std::sin(0.292959928512573*x_12 - 4.27135992050171) - 0.020307788110505*std::sin(0.295039921998978*x_12 - 4.26959991455078) - 0.0717591846112687*std::sin(0.296319931745529*x_12 + 5.12960004806519) + 0.0322570786377317*std::sin(0.297279924154282*x_12 - 4.26855993270874) - 0.0178823797077301*std::sin(0.262639969587326*x_120 + 5.16879987716675) - 0.0692698740473449*std::sin(0.266719967126846*x_120 + 5.15808010101318) - 0.0173438489900418*std::sin(0.267679959535599*x_120 + 5.16016006469727) + 0.0244097879123357*std::sin(0.192479997873306*x_13 + 8.19071960449219) - 0.0162182769756395*std::sin(0.19344000518322*x_13 + 1.97303986549377) + 0.0138442252594296*std::sin(0.216639995574951*x_13 - 1.17511987686157) + 0.0586969259424275*std::sin(0.232239991426468*x_13 + 1.98807990550995) - 0.0848079515484077*std::sin(0.295279920101166*x_13 - 7.43551969528198) - 0.107999688468023*std::sin(0.30159991979599*x_14 - 7.4423999786377) - 0.0960103225942814*std::sin(0.310879945755005*x_14 - 7.44575977325439) - 0.00510237113031661*std::sin(0.339599847793579*x_14 - 4.33360004425049) - 0.001125907562857*std::sin(0.654879808425903*x_14 - 4.47160005569458) - 0.0167894833398412*std::sin(0.288399934768677*x_15 + 1.96623980998993) - 0.00827476630811137*std::sin(0.291679948568344*x_15 + 5.15560007095337) - 0.116696409360749*std::sin(0.295359939336777*x_15 - 7.43336009979248) + 0.010993670091713*std::sin(0.423679858446121*x_15 + 8.16016006469727) + 0.0416743348603298*std::sin(0.219439998269081*x_16 + 1.98215985298157) - 0.0124847799508146*std::sin(0.299759924411774*x_16 - 7.40511989593506) - 0.0125027146370825*std::sin(0.337919861078262*x_16 - 1.15591979026794) + 0.00901320402397097*std::sin(0.342799842357635*x_16 - 1.14039981365204) + 0.0115202417253896*std::sin(0.314799934625626*x_17 + 2.02759981155396) - 0.0355132419833795*std::sin(0.346559852361679*x_17 + 2.02431988716125) + 0.0299395916072523*std::sin(0.347679853439331*x_17 - 1.15719985961914) - 0.0193357355623034*std::sin(0.35471984744072*x_17 - 1.15351986885071) - 0.073813808918663*std::sin(0.361119836568832*x_17 + 2.00263977050781) + 0.0828246548774243*std::sin(0.117200054228306*x_18 - 1.28391993045807) + 0.00877715284052412*std::sin(0.395679831504822*x_18 + 2.01239991188049) + 0.0216677713124259*std::sin(0.414719849824905*x_18 - 7.41239976882935) - 0.00342806714220332*std::sin(0.46687987446785*x_18 - 7.43407964706421) + 0.060577845680944*std::sin(0.241439983248711*x_19 - 1.16903984546661) - 0.0194558869141101*std::sin(0.287599951028824*x_19 - 1.19359982013702) - 0.0534813942400303*std::sin(0.313359916210175*x_19 - 7.41943979263306) - 0.0105062223849711*std::sin(0.331279844045639*x_19 - 1.16599988937378) + 0.0239100813159769*std::sin(0.372159838676453*x_2 + 5.19632005691528) - 0.0603629873447495*std::sin(0.375199824571609*x_2 + 5.17495965957642) - 0.0116358313618359*std::sin(0.393439829349518*x_2 + 5.18728017807007) - 0.013647855184205*std::sin(0.404799848794937*x_2 + 2.01151990890503) - 0.0997364245282004*std::sin(0.202480003237724*x_20 + 1.9812798500061) + 0.010797987559939*std::sin(0.246639966964722*x_20 - 1.16767990589142) - 0.00316754176068216*std::sin(0.270879954099655*x_20 + 1.9923198223114) + 0.0218375200512773*std::sin(0.344479858875275*x_20 - 4.3635196685791) + 0.0228607166319504*std::sin(0.403279840946198*x_20 + 8.19911956787109) + 0.068794542034718*std::sin(0.314639925956726*x_21 - 7.40407991409302) + 0.00507446843350384*std::sin(0.33247983455658*x_21 + 8.24967956542969) + 0.00878761643345641*std::sin(0.339919835329056*x_21 - 1.13927984237671) - 0.0923722189624397*std::sin(0.360639840364456*x_22 + 1.99255979061127) - 0.00483492717129041*std::sin(0.394959837198257*x_22 - 7.40967988967896) - 0.0039892417834739*std::sin(0.241119980812073*x_23 - 4.37519979476929) - 0.0719614947658775*std::sin(0.3643998503685*x_23 + 2.00103974342346) + 0.0336059641901424*std::sin(0.285839945077896*x_24 - 1.15983986854553) + 0.00873996389484985*std::sin(0.306479930877686*x_24 + 1.9890398979187) - 0.00421549390531123*std::sin(0.363439828157425*x_24 - 1.15135991573334) - 0.0315963752126328*std::sin(0.207600012421608*x_25 + 2.0052797794342) - 0.00197101352514479*std::sin(0.275919944047928*x_25 - 1.16351985931396) + 0.0409144947286872*std::sin(0.324399828910828*x_25 - 1.1555198431015) - 0.00815117958266441*std::sin(0.363119840621948*x_25 + 2.03151988983154) - 0.0188965738404829*std::sin(0.378719836473465*x_25 + 2.0130398273468) + 0.0443458964203184*std::sin(0.299519926309586*x_26 + 1.992959856987) + 0.0228168564458876*std::sin(0.332399845123291*x_26 - 1.15983986854553) + 0.0139959036669281*std::sin(0.333199828863144*x_26 - 1.14551985263824) + 0.0286520780236506*std::sin(0.337279856204987*x_26 - 1.14231979846954) - 0.0241209423492854*std::sin(0.316079914569855*x_27 + 2.00415992736816) - 0.0239280235334927*std::sin(0.319199919700623*x_27 + 5.1755199432373) - 0.0120309572713512*std::sin(0.338799834251404*x_28 - 4.3616795539856) - 0.0338812799993123*std::sin(0.415039867162704*x_28 - 1.20719993114471) - 0.00470271328709273*std::sin(0.557119846343994*x_28 + 4.81655979156494) - 0.0318595563075507*std::sin(0.296719938516617*x_29 - 1.18191993236542) - 0.0157136535113275*std::sin(0.300719946622849*x_29 + 1.98407983779907) + 0.0645358461426481*std::sin(0.301519930362701*x_29 + 1.98215973377228) - 0.0422801746764882*std::sin(0.296959936618805*x_3 + 8.28071975708008) + 0.0296849508053387*std::sin(0.320239841938019*x_3 + 5.19632005691528) + 0.00919753257774264*std::sin(0.346719831228256*x_3 - 7.38624000549316) - 0.0244932012814884*std::sin(0.360559850931168*x_3 - 7.41143989562988) - 0.00302147481265656*std::sin(0.400479853153229*x_3 + 2.17975974082947) + 0.0341795867858651*std::sin(0.325919836759567*x_30 - 1.15055990219116) - 0.0873892019576727*std::sin(0.333119839429855*x_30 + 2.01231980323792) + 0.0354614705249933*std::sin(0.351359844207764*x_30 - 1.14287984371185) + 0.107055905600308*std::sin(0.352639853954315*x_30 - 1.14095985889435) + 0.00751497218785307*std::sin(0.357999831438065*x_31 + 5.16495990753174) - 0.0868930752446842*std::sin(0.365359842777252*x_31 + 5.17280006408691) + 0.0185951022811283*std::sin(0.368399828672409*x_31 + 5.17471981048584) - 0.0174398599060997*std::sin(0.421279847621918*x_31 - 7.38687992095947) - 0.089485970695163*std::sin(0.303919941186905*x_32 - 1.15511989593506) - 0.0618923681152888*std::sin(0.308319926261902*x_32 + 2.02879977226257) - 0.00578315348885901*std::sin(0.316719859838486*x_32 + 2.00423979759216) + 0.00678621865921183*std::sin(0.336319833993912*x_32 + 1.99399983882904) + 0.00923150769935615*std::sin(0.185760006308556*x_34 - 1.19479990005493) + 0.00424801280234428*std::sin(0.219439998269081*x_35 - 7.40215969085693) - 0.0414113203043221*std::sin(0.22919999063015*x_35 - 7.42343997955322) - 0.0224075044751191*std::sin(0.250639975070953*x_35 + 1.97823977470398) + 0.0118893753149977*std::sin(0.245919972658157*x_36 - 7.42759990692139) + 0.0464535581422192*std::sin(0.186000004410744*x_37 + 8.20440006256104) + 0.00647807150236848*std::sin(0.237679988145828*x_38 + 1.98759984970093) + 0.0130897697233551*std::sin(0.239919975399971*x_38 + 1.97351980209351) + 0.0462333486035118*std::sin(0.242159977555275*x_38 + 1.97287976741791) - 0.00895684992920604*std::sin(0.22495998442173*x_39 - 1.18631982803345) - 0.0741735600516856*std::sin(0.319279909133911*x_4 + 2.00879979133606) + 0.00527350976246442*std::sin(0.324959844350815*x_4 - 1.16639983654022) + 0.0754701990707435*std::sin(0.330719828605652*x_4 - 7.38168001174927) + 0.00208537459413587*std::sin(0.386159837245941*x_4 + 1.99143981933594) - 0.0124868312642716*std::sin(0.189759999513626*x_40 + 2.000159740448) + 0.00681616345729509*std::sin(0.213359996676445*x_40 + 1.98591983318329) + 0.0297293371396505*std::sin(0.225519984960556*x_41 - 4.39015960693359) - 0.00657664786635261*std::sin(0.250879973173141*x_42 + 5.15895986557007) + 0.0490694327080089*std::sin(0.255599975585938*x_42 - 7.43623971939087) + 0.0440239717837082*std::sin(0.256719976663589*x_43 + 5.15768003463745) + 0.00528598123666585*std::sin(0.28263995051384*x_43 + 5.11055994033813) - 0.00276493970658058*std::sin(0.225679993629456*x_44 - 7.42191982269287) + 0.00304555895174513*std::sin(0.214000001549721*x_45 - 1.21471989154816) - 0.0210151115286942*std::sin(0.153200030326843*x_47 - 1.17551982402802) - 0.0762093130229165*std::sin(0.213599994778633*x_47 + 1.9826397895813) - 0.0546108168886878*std::sin(0.0819200873374939*x_49 - 1.29207980632782) + 0.0816591165612804*std::sin(0.169840022921562*x_49 + 2.00367975234985) + 0.0111982520419252*std::sin(0.211759999394417*x_49 + 1.99351978302002) + 0.0510460086556629*std::sin(0.27295994758606*x_49 + 5.11960029602051) + 0.0260535276291493*std::sin(0.322399914264679*x_5 + 2.01399993896484) + 0.0237689248928661*std::sin(0.327759832143784*x_5 - 1.14439988136292) + 0.00176280816311524*std::sin(0.358959853649139*x_5 + 2.02503991127014) - 0.0328860773882736*std::sin(0.374239832162857*x_5 + 2.01015973091125) + 0.00240635339518088*std::sin(0.402399837970734*x_5 + 8.21047973632813) + 0.00723151672246223*std::sin(0.22775998711586*x_50 - 7.4364800453186) + 0.0781947127218959*std::sin(0.217600002884865*x_51 + 1.98359978199005) + 0.0813860716736621*std::sin(0.222479999065399*x_52 - 7.41655969619751) - 0.0455976156098025*std::sin(0.223839998245239*x_52 + 1.98967981338501) + 0.0198722147215091*std::sin(0.25095996260643*x_53 + 5.15743970870972) - 0.0119438134635596*std::sin(0.256639957427979*x_53 - 7.42983961105347) + 0.0587486253067293*std::sin(0.25943997502327*x_53 - 7.4398398399353) + 0.0104727792918422*std::sin(0.224399983882904*x_54 + 1.9832798242569) - 0.0115193279145438*std::sin(0.240879982709885*x_55 - 7.44704008102417) + 0.0116615932797118*std::sin(0.0958400741219521*x_56 + 7.95592021942139) - 0.0200238723645888*std::sin(0.163920015096664*x_57 - 1.17575979232788) + 0.00138549906326274*std::sin(0.51751983165741*x_57 - 4.48799991607666) + 0.045901095369763*std::sin(0.151040032505989*x_58 - 4.38327980041504) - 0.0696093909441288*std::sin(0.146080031991005*x_59 - 1.21031987667084) - 0.0563391570969515*std::sin(0.284239947795868*x_6 - 7.382239818573) + 0.0271820785228288*std::sin(0.344559848308563*x_6 + 2.00063967704773) - 0.0705310456415511*std::sin(0.37271985411644*x_6 + 2.00519990921021) + 0.0171310587388592*std::sin(0.40447986125946*x_60 + 8.19551944732666) - 0.00551351905068293*std::sin(0.41543984413147*x_60 - 1.21631991863251) - 0.0363346522821303*std::sin(0.257439970970154*x_7 - 7.37671947479248) - 0.0385065037683312*std::sin(0.345999836921692*x_7 + 2.00303983688354) + 0.0337242073793985*std::sin(0.357119828462601*x_7 + 1.99847972393036) + 0.0562504176816683*std::sin(0.361919850111008*x_7 + 2.0079197883606) - 0.00107841430106022*std::sin(0.412159860134125*x_7 + 4.98207950592041) + 0.0329259372587807*std::sin(0.144000038504601*x_71 - 4.31903982162476) + 0.00767826106945459*std::sin(0.254399985074997*x_8 - 4.38703966140747) - 0.0299228930107536*std::sin(0.292959928512573*x_8 - 7.41423988342285) + 0.0283784038356957*std::sin(0.29911994934082*x_8 - 7.41567993164063) - 0.0138830340032293*std::sin(0.334959834814072*x_8 - 1.14431989192963) - 0.00806043087149383*std::sin(0.337839841842651*x_8 - 1.15391993522644) - 0.0532501450966897*std::sin(0.271999955177307*x_9 + 2.00103974342346) + 0.0077744582199886*std::sin(0.306639939546585*x_9 - 1.19591987133026) - 0.0457225663498454*std::sin(0.314799934625626*x_9 + 5.14448022842407) + 0.0741425598901587*std::sin(0.316319912672043*x_9 - 7.42663955688477) - 0.00202149101435383*std::sin(0.259039968252182*x_91 - 4.16463994979858) - 0.0352026614149689*std::sin(0.355039834976196*x_91 - 7.40223979949951) - 0.0117425882180978*std::sin(0.359519839286804*x_91 - 7.41016006469727) - 0.00223523425863152*std::sin(0.36575984954834*x_91 - 7.38615989685059) + 0.00516047739388104*std::sin(0.262719959020615*x_92 - 7.38695955276489) - 0.0285714950456324*std::sin(0.26599994301796*x_92 - 7.39991998672485) + 0.0654513145347936*std::sin(0.285919934511185*x_92 + 1.99951982498169) + 0.0123928521474907*std::sin(0.296799927949905*x_92 + 1.99463987350464) - 0.0292448030679819*std::sin(0.300159931182861*x_92 + 1.99007987976074) + 0.0211965681964178*std::sin(0.286479949951172*x_94 + 1.97767972946167) - 0.0159657973305047*std::sin(0.28671994805336*x_94 + 1.96495985984802) + 0.010004723660437*std::sin(0.286959946155548*x_94 + 1.97103977203369) + 0.00803013353161761*std::sin(0.249199971556664*x_95 + 5.19456005096436) + 0.0227289223968693*std::sin(0.280399948358536*x_95 - 7.44032001495361) - 0.0525080337155433*std::sin(0.28263995051384*x_95 + 1.96735978126526) - 0.00332085070639215*std::sin(0.295519918203354*x_95 - 1.22903990745544) - 0.0287523601937481*std::sin(0.282559931278229*x_96 - 7.43711996078491) - 0.00292791734484982*std::sin(0.299439936876297*x_96 + 1.93367981910706) - 0.0366237331440413*std::sin(0.260399967432022*x_97 - 7.41359996795654) + 0.00834155734215793*std::sin(0.271919965744019*x_97 - 7.42767953872681) + 0.014270164696161*std::sin(0.276479959487915*x_97 + 1.96783983707428) - 0.00888601499591642*std::sin(0.280159950256348*x_97 + 1.95407974720001) + 0.0111927173876851*std::sin(0.283359944820404*x_97 - 1.20615983009338) - 0.0135998534977966*std::sin(0.23191998898983*x_98 + 5.18480014801025) - 0.00806954528135692*std::sin(0.232239991426468*x_98 - 7.39911985397339) + 0.161415095869303);
}

inline float score_10(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.000666887625754283*x_10 + 0.000522799325837359*x_100 + 0.00019699887636675*x_101 - 5.60187091657872e-5*x_102 - 0.00335553436316093*x_103 + 0.000761941024602856*x_104 + 0.00267639563056485*x_105 + 0.00271486389093664*x_106 - 0.000859146036216525*x_107 + 0.00024072951231333*x_108 + 0.000681453243813778*x_109 + 1.68271214648308e-5*x_11 + 0.00121942800935127*x_110 - 0.00264752936918015*x_111 + 0.00039374912715297*x_112 + 0.000657821322101403*x_113 + 0.00889635803200454*x_114 + 0.00194989997356613*x_115 - 0.000319575644687752*x_116 + 0.0110544448107955*x_117 + 0.00178908824012225*x_118 + 0.00882858533549759*x_119 + 0.00336210788504755*x_120 + 0.000223551116051844*x_14 + 0.000135514584598873*x_15 + 0.000913820654518853*x_16 + 0.000267250237463556*x_19 + 2.08182847222635e-5*x_2 - 0.000148219647364161*x_21 + 0.000405892556085686*x_22 + 3.10760002278616e-5*x_23 - 0.00020127958816942*x_24 + 0.000174405562742581*x_26 - 0.000341464139429059*x_27 + 8.42462907857493e-5*x_28 - 0.00016575340084391*x_29 - 2.88988695650483e-5*x_31 - 0.000232670523647747*x_32 - 0.000722919324804393*x_33 - 0.00542232661598261*x_34 - 0.00102774314429621*x_35 - 0.00312423678137529*x_36 + 0.00111730641597247*x_37 - 0.00300700885774833*x_38 - 0.00168597542519231*x_39 + 5.67285237370314e-5*x_4 + 0.0014706401459986*x_40 - 0.00109405340464364*x_41 - 0.00388173716298894*x_42 + 0.000410186889550706*x_43 + 0.000817740646539318*x_44 - 0.00201435337265352*x_45 + 0.00133917796718165*x_46 - 0.000797859819205539*x_47 - 0.0106641739901649*x_48 - 5.65097072008513e-5*x_49 + 0.000410273366047601*x_50 - 0.00173964620101578*x_51 - 0.00100185934064541*x_52 + 0.000569214867927482*x_53 - 0.00340156490744374*x_54 - 0.00268927111628419*x_55 - 0.00167593277308278*x_56 - 0.00199566930247079*x_57 - 0.0064155275234736*x_58 + 0.00677679891780883*x_59 + 0.000214390623329735*x_6 - 0.00286332978851892*x_60 - 0.00110462556266258*x_61 + 0.00165487989192485*x_62 + 0.000108771036279729*x_63 - 0.0011783881325759*x_64 + 0.000345666750835564*x_65 - 0.00183803231680095*x_66 - 0.00041675038955881*x_67 + 0.000708512914821779*x_68 - 0.00213722658646288*x_69 + 0.000376761430244292*x_70 - 0.000907358896252048*x_71 - 0.000930849005526659*x_72 - 0.000675864903377894*x_73 - 0.000788739203434904*x_74 - 0.00103795123904295*x_75 - 0.000505204880672368*x_76 + 0.000387675708089513*x_77 - 0.00211140551040829*x_78 + 0.00250143016191865*x_79 + 0.000126027068730144*x_80 + 0.00317925417474683*x_81 - 0.00119945571150401*x_82 + 0.000642037797907836*x_83 + 0.00055547334840454*x_84 - 0.00202466611047064*x_85 + 0.00127305498195979*x_86 + 0.00157079075920563*x_87 - 0.000452459285767363*x_88 - 0.00102614587084753*x_89 - 9.353604234152e-5*x_9 - 0.00186491833260544*x_90 - 0.000170061884541373*x_91 - 0.000632957063148669*x_93 - 2.05472143061374e-5*x_94 - 0.000196837327097064*x_95 - 0.000392434632455196*x_96 + 0.00138618778649374*x_98 + 0.000116510341498164*x_99 - 8.28075664350445e-6*std::pow(-3.08031988143921*x_22 - 8.18991947174072, 2) + 2.78877309740609e-7*std::pow(-7.29407978057861*x_24 - 1.18351984024048, 2) - 1.20396975526798e-6*std::pow(-5.27952003479004*x_55 - 8.32055950164795, 2) + 1.53968243366907e-5*std::pow(-2.59631991386414*x_56 - 9.37975978851318, 2) + 1.27114509851634e-6*std::pow(-3.85775995254517*x_59 - 9.14136028289795, 2) + 4.61279340824506e-6*std::pow(-2.80672001838684*x_59 - 8.59552001953125, 2) - 2.490678522334e-6*std::pow(-4.6854395866394*x_61 - 8.77040004730225, 2) + 6.64022909881009e-6*std::pow(-3.75288009643555*x_65 - 9.44944000244141, 2) + 7.21314275706968e-5*std::exp(0.299919843673706*x_10) + 0.00247215192215829*std::exp(0.228399842977524*x_18) - 0.000221642244708806*std::exp(0.331679850816727*x_30) - 0.021063610861481*std::sin(0.31879985332489*x_1 - 4.26864004135132) - 0.0136981296047522*std::sin(0.326959848403931*x_1 - 4.2611198425293) + 0.187956867041749*std::sin(0.358239859342575*x_1 + 8.35488033294678) + 0.00156066349821482*std::sin(0.361999839544296*x_1 + 5.17400026321411) + 6.99025027776568e-5*std::sin(0.365919858217239*x_1 - 4.23160028457642) - 0.00231726678133749*std::sin(0.263839960098267*x_10 + 1.99799978733063) - 0.0146541779232878*std::sin(0.243119969964027*x_100 - 7.42335987091064) - 0.00218957838880525*std::sin(0.250079959630966*x_100 - 1.2054398059845) + 0.0265345466883408*std::sin(0.2291199862957*x_101 - 7.40719985961914) + 0.0164975997918928*std::sin(0.237119987607002*x_101 + 1.98511981964111) - 0.0189256952028818*std::sin(0.220159992575645*x_102 + 2.00143980979919) + 0.00103672165451559*std::sin(0.239199981093407*x_106 + 8.17751979827881) + 0.00645253813812294*std::sin(0.246319979429245*x_108 - 1.19671988487244) - 0.0046708350381975*std::sin(0.256719976663589*x_108 + 1.97239983081818) + 0.0183638754719973*std::sin(0.23479999601841*x_109 - 7.42360019683838) + 0.00911591197999363*std::sin(0.274879962205887*x_11 - 7.44007968902588) - 0.0305229221345662*std::sin(0.286479949951172*x_11 - 7.44456005096436) - 9.89406685780237e-5*std::sin(0.292959928512573*x_11 - 7.44855976104736) + 0.0593812059724932*std::sin(0.293119937181473*x_11 - 7.43735980987549) - 0.00541712980630023*std::sin(0.231119990348816*x_112 - 4.20911979675293) + 0.0312045901826713*std::sin(0.281519949436188*x_112 + 5.14000034332275) + 0.0224863571888882*std::sin(0.292479932308197*x_113 - 7.43639993667603) + 0.019992537996536*std::sin(0.251439958810806*x_116 - 7.41999959945679) - 0.0196357308177549*std::sin(0.219679996371269*x_118 - 4.21519994735718) + 0.000188052430129297*std::sin(0.23599998652935*x_119 + 5.17160034179688) + 0.0353824320391186*std::sin(0.291119933128357*x_12 - 7.45567989349365) + 0.000416182926020687*std::sin(0.292959928512573*x_12 - 4.27135992050171) - 0.00795124165915151*std::sin(0.295039921998978*x_12 - 4.26959991455078) - 0.0192813215570458*std::sin(0.296319931745529*x_12 + 5.12960004806519) - 0.00398979146460776*std::sin(0.297279924154282*x_12 - 4.26855993270874) + 0.00039588565193821*std::sin(0.262639969587326*x_120 + 5.16879987716675) + 0.00856780477030779*std::sin(0.266719967126846*x_120 + 5.15808010101318) - 0.00679075110835515*std::sin(0.267679959535599*x_120 + 5.16016006469727) - 0.00301918114034059*std::sin(0.192479997873306*x_13 + 8.19071960449219) - 0.00635004850487165*std::sin(0.19344000518322*x_13 + 1.97303986549377) - 0.000306487739998024*std::sin(0.216639995574951*x_13 - 1.17511987686157) - 0.0390024244512178*std::sin(0.232239991426468*x_13 + 1.98807990550995) - 0.0227874577067369*std::sin(0.295279920101166*x_13 - 7.43551969528198) - 0.0290189574016665*std::sin(0.30159991979599*x_14 - 7.4423999786377) + 0.0637961067534169*std::sin(0.310879945755005*x_14 - 7.44575977325439) - 0.00199776488069811*std::sin(0.339599847793579*x_14 - 4.33360004425049) + 2.49256898035292e-5*std::sin(0.654879808425903*x_14 - 4.47160005569458) + 0.0111561303257929*std::sin(0.288399934768677*x_15 + 1.96623980998993) + 0.000183189335427596*std::sin(0.291679948568344*x_15 + 5.15560007095337) - 0.0313557213007116*std::sin(0.295359939336777*x_15 - 7.43336009979248) - 0.00135977754182995*std::sin(0.423679858446121*x_15 + 8.16016006469727) - 0.0276914007138811*std::sin(0.219439998269081*x_16 + 1.98215985298157) + 0.000276391919359413*std::sin(0.299759924411774*x_16 - 7.40511989593506) - 0.00489526997888209*std::sin(0.337919861078262*x_16 - 1.15591979026794) - 0.00111481901034719*std::sin(0.342799842357635*x_16 - 1.14039981365204) - 0.00025503867385*std::sin(0.314799934625626*x_17 + 2.02759981155396) + 0.00439253756786579*std::sin(0.346559852361679*x_17 + 2.02431988716125) - 0.0198940002566322*std::sin(0.347679853439331*x_17 - 1.15719985961914) - 0.00757064754057556*std::sin(0.35471984744072*x_17 - 1.15351986885071) - 0.0198333884759273*std::sin(0.361119836568832*x_17 + 2.00263977050781) - 0.010244359224226*std::sin(0.117200054228306*x_18 - 1.28391993045807) - 0.000194311323840762*std::sin(0.395679831504822*x_18 + 2.01239991188049) - 0.014397612823337*std::sin(0.414719849824905*x_18 - 7.41239976882935) - 0.00134221364351126*std::sin(0.46687987446785*x_18 - 7.43407964706421) + 0.0162769536489962*std::sin(0.241439983248711*x_19 - 1.16903984546661) + 0.00240644642430486*std::sin(0.287599951028824*x_19 - 1.19359982013702) + 0.0355368531639719*std::sin(0.313359916210175*x_19 - 7.41943979263306) + 0.000232590000115262*std::sin(0.331279844045639*x_19 - 1.16599988937378) - 0.00295737377286781*std::sin(0.372159838676453*x_2 + 5.19632005691528) - 0.0162192223259353*std::sin(0.375199824571609*x_2 + 5.17495965957642) - 0.00455585347649125*std::sin(0.393439829349518*x_2 + 5.18728017807007) + 0.00906860848667306*std::sin(0.404799848794937*x_2 + 2.01151990890503) - 0.0267986611427616*std::sin(0.202480003237724*x_20 + 1.9812798500061) + 0.00422780698983036*std::sin(0.246639966964722*x_20 - 1.16767990589142) + 7.0124019032383e-5*std::sin(0.270879954099655*x_20 + 1.9923198223114) - 0.00270102423369712*std::sin(0.344479858875275*x_20 - 4.3635196685791) - 0.0151902907864866*std::sin(0.403279840946198*x_20 + 8.19911956787109) + 0.0184847374385132*std::sin(0.314639925956726*x_21 - 7.40407991409302) + 0.00198683995455189*std::sin(0.33247983455658*x_21 + 8.24967956542969) - 0.000194542970096871*std::sin(0.339919835329056*x_21 - 1.13927984237671) + 0.0613786911942822*std::sin(0.360639840364456*x_22 + 1.99255979061127) - 0.00189305079086587*std::sin(0.394959837198257*x_22 - 7.40967988967896) - 0.00156193403656686*std::sin(0.241119980812073*x_23 - 4.37519979476929) + 0.0478163501399673*std::sin(0.3643998503685*x_23 + 2.00103974342346) - 0.0223301997232694*std::sin(0.285839945077896*x_24 - 1.15983986854553) + 0.00342201546727101*std::sin(0.306479930877686*x_24 + 1.9890398979187) + 9.33239076801554e-5*std::sin(0.363439828157425*x_24 - 1.15135991573334) + 0.00390807083157396*std::sin(0.207600012421608*x_25 + 2.0052797794342) - 0.000771723870989937*std::sin(0.275919944047928*x_25 - 1.16351985931396) + 0.0109935130043826*std::sin(0.324399828910828*x_25 - 1.1555198431015) + 0.000180453334281545*std::sin(0.363119840621948*x_25 + 2.03151988983154) + 0.0125562315533046*std::sin(0.378719836473465*x_25 + 2.0130398273468) - 0.0294665767769758*std::sin(0.299519926309586*x_26 + 1.992959856987) - 0.00282215572337968*std::sin(0.332399845123291*x_26 - 1.15983986854553) - 0.000309845643488439*std::sin(0.333199828863144*x_26 - 1.14551985263824) + 0.00769866509275831*std::sin(0.337279856204987*x_26 - 1.14231979846954) + 0.0160276746450562*std::sin(0.316079914569855*x_27 + 2.00415992736816) - 0.00642933609785448*std::sin(0.319199919700623*x_27 + 5.1755199432373) + 0.00799422617995281*std::sin(0.338799834251404*x_28 - 4.3616795539856) - 0.00910372460291946*std::sin(0.415039867162704*x_28 - 1.20719993114471) + 0.000581665982343262*std::sin(0.557119846343994*x_28 + 4.81655979156494) - 0.00856049790920041*std::sin(0.296719938516617*x_29 - 1.18191993236542) - 0.00615246996555515*std::sin(0.300719946622849*x_29 + 1.98407983779907) - 0.0428822195227546*std::sin(0.301519930362701*x_29 + 1.98215973377228) - 0.011360464139073*std::sin(0.296959936618805*x_3 + 8.28071975708008) - 0.00367165187773402*std::sin(0.320239841938019*x_3 + 5.19632005691528) + 0.00360117033896569*std::sin(0.346719831228256*x_3 - 7.38624000549316) + 0.00054223806427644*std::sin(0.360559850931168*x_3 - 7.41143989562988) + 0.00200768338749941*std::sin(0.400479853153229*x_3 + 2.17975974082947) - 0.000756678262001766*std::sin(0.325919836759567*x_30 - 1.15055990219116) + 0.0580676192574283*std::sin(0.333119839429855*x_30 + 2.01231980323792) - 0.00438613409515522*std::sin(0.351359844207764*x_30 - 1.14287984371185) + 0.0287653678291119*std::sin(0.352639853954315*x_30 - 1.14095985889435) - 0.000166368778233676*std::sin(0.357999831438065*x_31 + 5.16495990753174) + 0.0577379572805721*std::sin(0.365359842777252*x_31 + 5.17280006408691) + 0.00728066252756536*std::sin(0.368399828672409*x_31 + 5.17471981048584) - 0.0046860001068983*std::sin(0.421279847621918*x_31 - 7.38687992095947) - 0.0240444172430977*std::sin(0.303919941186905*x_32 - 1.15511989593506) + 0.041125704161939*std::sin(0.308319926261902*x_32 + 2.02879977226257) - 0.00226431606887294*std::sin(0.316719859838486*x_32 + 2.00423979759216) - 0.000150235407256004*std::sin(0.336319833993912*x_32 + 1.99399983882904) - 0.000204369972210825*std::sin(0.185760006308556*x_34 - 1.19479990005493) + 0.00166325235317658*std::sin(0.219439998269081*x_35 - 7.40215969085693) + 0.0275166350820264*std::sin(0.22919999063015*x_35 - 7.42343997955322) + 0.00277152407699487*std::sin(0.250639975070953*x_35 + 1.97823977470398) + 0.00465512520573303*std::sin(0.245919972658157*x_36 - 7.42759990692139) - 0.00574571590496391*std::sin(0.186000004410744*x_37 + 8.20440006256104) + 0.0025364018828791*std::sin(0.237679988145828*x_38 + 1.98759984970093) - 0.00161903847842049*std::sin(0.239919975399971*x_38 + 1.97351980209351) + 0.0124226615159075*std::sin(0.242159977555275*x_38 + 1.97287976741791) - 0.00240665922500051*std::sin(0.22495998442173*x_39 - 1.18631982803345) + 0.049286204102601*std::sin(0.319279909133911*x_4 + 2.00879979133606) - 0.000116746589907901*std::sin(0.324959844350815*x_4 - 1.16639983654022) + 0.0202784519381057*std::sin(0.330719828605652*x_4 - 7.38168001174927) + 0.000816500411448158*std::sin(0.386159837245941*x_4 + 1.99143981933594) + 0.00829714137836701*std::sin(0.189759999513626*x_40 + 2.000159740448) + 0.00266877724655771*std::sin(0.213359996676445*x_40 + 1.98591983318329) + 0.0079881190424983*std::sin(0.225519984960556*x_41 - 4.39015960693359) - 0.00257499813411302*std::sin(0.250879973173141*x_42 + 5.15895986557007) + 0.013184702638279*std::sin(0.255599975585938*x_42 - 7.43623971939087) - 0.0292526670855093*std::sin(0.256719976663589*x_43 + 5.15768003463745) - 0.000653808829279935*std::sin(0.28263995051384*x_43 + 5.11055994033813) - 0.00108257500326356*std::sin(0.225679993629456*x_44 - 7.42191982269287) + 0.00119244769941198*std::sin(0.214000001549721*x_45 - 1.21471989154816) + 0.000465239037760448*std::sin(0.153200030326843*x_47 - 1.17551982402802) + 0.0506389035870621*std::sin(0.213599994778633*x_47 + 1.9826397895813) + 0.00120899115219608*std::sin(0.0819200873374939*x_49 - 1.29207980632782) + 0.0219413820406633*std::sin(0.169840022921562*x_49 + 2.00367975234985) + 0.00438452517137379*std::sin(0.211759999394417*x_49 + 1.99351978302002) - 0.0339186092655258*std::sin(0.27295994758606*x_49 + 5.11960029602051) - 0.0173118221564158*std::sin(0.322399914264679*x_5 + 2.01399993896484) - 0.00293991451381874*std::sin(0.327759832143784*x_5 - 1.14439988136292) + 0.000690203858115089*std::sin(0.358959853649139*x_5 + 2.02503991127014) - 0.00883631881142673*std::sin(0.374239832162857*x_5 + 2.01015973091125) - 5.32725956061153e-5*std::sin(0.402399837970734*x_5 + 8.21047973632813) + 0.00283140323848212*std::sin(0.22775998711586*x_50 - 7.4364800453186) + 0.0210105146570316*std::sin(0.217600002884865*x_51 + 1.98359978199005) - 0.0540787112931068*std::sin(0.222479999065399*x_52 - 7.41655969619751) + 0.00563984667085303*std::sin(0.223839998245239*x_52 + 1.98967981338501) - 0.0024579408931963*std::sin(0.25095996260643*x_53 + 5.15743970870972) + 0.000264415835975438*std::sin(0.256639957427979*x_53 - 7.42983961105347) - 0.0390367771965785*std::sin(0.25943997502327*x_53 - 7.4398398399353) + 0.00410047606067545*std::sin(0.224399983882904*x_54 + 1.9832798242569) + 0.00142479474684062*std::sin(0.240879982709885*x_55 - 7.44704008102417) - 0.000258167958271308*std::sin(0.0958400741219521*x_56 + 7.95592021942139) + 0.000443294678613498*std::sin(0.163920015096664*x_57 - 1.17575979232788) + 0.000542473548107953*std::sin(0.51751983165741*x_57 - 4.48799991607666) - 0.00567738326769027*std::sin(0.151040032505989*x_58 - 4.38327980041504) - 0.0187036831236944*std::sin(0.146080031991005*x_59 - 1.21031987667084) + 0.0374357546504976*std::sin(0.284239947795868*x_6 - 7.382239818573) - 0.000601765260156846*std::sin(0.344559848308563*x_6 + 2.00063967704773) - 0.018951326971403*std::sin(0.37271985411644*x_6 + 2.00519990921021) - 0.0021188946681627*std::sin(0.40447986125946*x_60 + 8.19551944732666) + 0.000122059989751242*std::sin(0.41543984413147*x_60 - 1.21631991863251) + 0.0241433347290631*std::sin(0.257439970970154*x_7 - 7.37671947479248) + 0.00476276608282398*std::sin(0.345999836921692*x_7 + 2.00303983688354) - 0.000746596931879335*std::sin(0.357119828462601*x_7 + 1.99847972393036) + 0.0151141961396822*std::sin(0.361919850111008*x_7 + 2.0079197883606) - 0.00042223863424984*std::sin(0.412159860134125*x_7 + 4.98207950592041) + 0.00884702895236038*std::sin(0.144000038504601*x_71 - 4.31903982162476) - 0.000949703499873235*std::sin(0.254399985074997*x_8 - 4.38703966140747) - 0.00804012650342766*std::sin(0.292959928512573*x_8 - 7.41423988342285) - 0.0188566357415974*std::sin(0.29911994934082*x_8 - 7.41567993164063) + 0.000307346899969525*std::sin(0.334959834814072*x_8 - 1.14431989192963) - 0.00315595343950726*std::sin(0.337839841842651*x_8 - 1.15391993522644) + 0.0353831947381218*std::sin(0.271999955177307*x_9 + 2.00103974342346) - 0.000172113360256863*std::sin(0.306639939546585*x_9 - 1.19591987133026) + 0.00565530149246656*std::sin(0.314799934625626*x_9 + 5.14448022842407) + 0.0199217221607084*std::sin(0.316319912672043*x_9 - 7.42663955688477) + 4.47523932040634e-5*std::sin(0.259039968252182*x_91 - 4.16463994979858) + 0.00435412269109303*std::sin(0.355039834976196*x_91 - 7.40223979949951) + 0.00780261321159026*std::sin(0.359519839286804*x_91 - 7.41016006469727) - 0.000875175950156774*std::sin(0.36575984954834*x_91 - 7.38615989685059) + 0.00202051560770969*std::sin(0.262719959020615*x_92 - 7.38695955276489) + 0.0189849393146863*std::sin(0.26599994301796*x_92 - 7.39991998672485) + 0.0175864295102167*std::sin(0.285919934511185*x_92 + 1.99951982498169) - 0.000274356793221565*std::sin(0.296799927949905*x_92 + 1.99463987350464) + 0.0036172111856492*std::sin(0.300159931182861*x_92 + 1.99007987976074) - 0.00262174661936438*std::sin(0.286479949951172*x_94 + 1.97767972946167) + 0.0106088145876198*std::sin(0.28671994805336*x_94 + 1.96495985984802) - 0.000221487666267461*std::sin(0.286959946155548*x_94 + 1.97103977203369) - 0.000993225660138746*std::sin(0.249199971556664*x_95 + 5.19456005096436) - 0.0151027172958085*std::sin(0.280399948358536*x_95 - 7.44032001495361) - 0.0141086369345201*std::sin(0.28263995051384*x_95 + 1.96735978126526) + 7.35180198819524e-5*std::sin(0.295519918203354*x_95 - 1.22903990745544) - 0.00772561039291135*std::sin(0.282559931278229*x_96 - 7.43711996078491) + 6.48191396129458e-5*std::sin(0.299439936876297*x_96 + 1.93367981910706) - 0.00984060757093393*std::sin(0.260399967432022*x_97 - 7.41359996795654) - 0.000184667975993858*std::sin(0.271919965744019*x_97 - 7.42767953872681) - 0.001765038363911*std::sin(0.276479959487915*x_97 + 1.96783983707428) - 0.00347919981412583*std::sin(0.280159950256348*x_97 + 1.95407974720001) - 0.00743723980954645*std::sin(0.283359944820404*x_97 - 1.20615983009338) + 0.00168212937119344*std::sin(0.23191998898983*x_98 + 5.18480014801025) + 0.000178646088874511*std::sin(0.232239991426468*x_98 - 7.39911985397339) - 0.149549175588789);
}

inline float score_11(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.00218340242638364*x_10 - 0.00463605007630777*x_100 + 0.00255148900709871*x_101 + 0.000197969141015681*x_102 + 0.00657081414771079*x_103 - 0.00138803525258448*x_104 + 5.33859526548399e-5*x_105 - 0.00795559544771368*x_106 + 0.00214824741683979*x_107 + 0.00700390518374313*x_108 - 0.00150733087538888*x_109 - 0.000229842543951803*x_11 + 0.00090713842996911*x_110 - 0.00879866468817178*x_111 - 0.00305148379551641*x_112 - 0.00429959193506147*x_113 - 0.0214742135147775*x_114 - 0.00503463485643587*x_115 + 0.00176556102459724*x_116 - 0.0139129821752093*x_117 - 0.0176935502160005*x_118 - 0.0118585240290394*x_119 - 0.0206217942568872*x_120 - 0.00305349654270989*x_14 + 0.000991960527121769*x_15 - 0.00567299867994003*x_16 + 0.00195625944773749*x_19 + 0.00140436235984402*x_21 - 0.00254014598624032*x_22 + 0.000723232849423962*x_23 + 0.00124954369584173*x_24 + 0.00127664069858749*x_26 - 0.00209814699744402*x_27 + 0.000668094364712324*x_28 + 0.00219579674734793*x_29 + 0.000394731191074147*x_31 + 0.00317805901440516*x_32 - 0.00697835595617918*x_33 + 0.0182390239533933*x_34 + 0.00637146194109083*x_35 - 0.014636378878567*x_36 + 0.00283385710972785*x_37 + 0.000540360092727626*x_38 - 0.00234734417303956*x_39 - 0.000774857912424334*x_4 - 0.0105545053886112*x_40 - 0.00261637501300703*x_41 + 2.13040804874256e-5*x_42 - 0.00326717269529995*x_43 - 6.89454570332741e-6*x_44 - 0.00399094859586765*x_45 - 0.022421993953797*x_46 - 0.00364348844484722*x_47 + 0.0187218938744801*x_48 + 0.000771869085759033*x_49 - 0.000933096005354779*x_50 - 0.000994107192410583*x_51 + 0.0111705161010127*x_52 + 0.0074495279722226*x_53 + 0.0248346979125121*x_54 + 0.0232741106563805*x_55 + 0.0102173578353106*x_56 + 0.0160106792140013*x_57 + 0.0228337420903043*x_58 - 0.00120859651542055*x_59 + 0.00126392161746857*x_6 + 0.000649029653656781*x_60 + 0.00274660534779734*x_61 - 0.00818029510900177*x_62 + 0.000591556243430361*x_63 + 0.00281305667376658*x_64 - 0.000578402777062648*x_65 + 0.00252948748858597*x_66 + 0.00243651085158354*x_67 - 0.000318519070389853*x_68 - 0.00186346469401103*x_69 - 0.00584833418475558*x_70 - 0.000385275805000351*x_71 + 0.00635554404389779*x_72 + 0.00151678543418663*x_73 + 0.0064407550024107*x_74 + 0.00355377674103019*x_75 - 0.00503216151663123*x_76 + 0.00270078956399254*x_77 + 0.000957573566761162*x_78 + 0.00273179277227989*x_79 + 0.00070144436837706*x_80 - 0.00863446998333738*x_81 + 0.00121851817924254*x_82 - 0.00454228686109398*x_83 - 0.00149219562556034*x_84 + 0.00299416364781187*x_85 + 0.000862269718819857*x_86 + 7.95474924686138e-5*x_87 - 0.00559959862016777*x_88 + 0.0028028709748481*x_89 - 0.000684679528337274*x_9 + 0.00345310864868057*x_90 + 0.00105574418978229*x_91 - 0.0160328515774836*x_93 - 7.49765651868348e-5*x_94 - 0.00144084018205422*x_95 - 0.00420863341075339*x_96 + 0.00144822180589237*x_98 + 0.00906774852063306*x_99 + 0.000113107293886643*std::pow(-3.08031988143921*x_22 - 8.18991947174072, 2) - 3.80919995467928e-6*std::pow(-7.29407978057861*x_24 - 1.18351984024048, 2) - 8.81300323953635e-6*std::pow(-5.27952003479004*x_55 - 8.32055950164795, 2) - 9.55834864372865e-5*std::pow(-2.59631991386414*x_56 - 9.37975978851318, 2) - 1.73626382733071e-5*std::pow(-3.85775995254517*x_59 - 9.14136028289795, 2) + 3.37654356118997e-5*std::pow(-2.80672001838684*x_59 - 8.59552001953125, 2) - 1.82316522403733e-5*std::pow(-4.6854395866394*x_61 - 8.77040004730225, 2) - 1.18909884594642e-6*std::pow(-3.75288009643555*x_65 - 9.44944000244141, 2) - 0.000985246992266293*std::exp(0.299919843673706*x_10) - 0.0153471192861135*std::exp(0.228399842977524*x_18) - 0.00162241103822582*std::exp(0.331679850816727*x_30) + 0.130762897534712*std::sin(0.31879985332489*x_1 - 4.26864004135132) - 0.10026967874737*std::sin(0.326959848403931*x_1 - 4.2611198425293) - 0.0336583708726405*std::sin(0.358239859342575*x_1 + 8.35488033294678) - 0.0213171854397154*std::sin(0.361999839544296*x_1 + 5.17400026321411) - 0.0169622862712624*std::sin(0.263839960098267*x_10 + 1.99799978733063) + 0.0026241965145446*std::sin(0.243119969964027*x_100 - 7.42335987091064) - 0.0160276131101519*std::sin(0.250079959630966*x_100 - 1.2054398059845) - 0.00475167322923717*std::sin(0.2291199862957*x_101 - 7.40719985961914) - 0.102417100531465*std::sin(0.237119987607002*x_101 + 1.98511981964111) + 0.00338911835564729*std::sin(0.220159992575645*x_102 + 2.00143980979919) - 0.0141606360268929*std::sin(0.239199981093407*x_106 + 8.17751979827881) - 0.0400573571617372*std::sin(0.246319979429245*x_108 - 1.19671988487244) - 0.0341902976738914*std::sin(0.256719976663589*x_108 + 1.97239983081818) - 0.00328851050256216*std::sin(0.23479999601841*x_109 - 7.42360019683838) + 0.0667280564644501*std::sin(0.274879962205887*x_11 - 7.44007968902588) + 0.189486302504814*std::sin(0.286479949951172*x_11 - 7.44456005096436) - 0.0106336878505369*std::sin(0.293119937181473*x_11 - 7.43735980987549) + 0.000970072373281198*std::sin(0.231119990348816*x_112 - 4.20911979675293) - 0.193718097789736*std::sin(0.281519949436188*x_112 + 5.14000034332275) - 0.139595306823513*std::sin(0.292479932308197*x_113 - 7.43639993667603) - 0.124113677122692*std::sin(0.251439958810806*x_116 - 7.41999959945679) + 0.00351626796414163*std::sin(0.219679996371269*x_118 - 4.21519994735718) - 0.00633610805868627*std::sin(0.291119933128357*x_12 - 7.45567989349365) - 0.0582027232775805*std::sin(0.295039921998978*x_12 - 4.26959991455078) + 0.119698445422218*std::sin(0.296319931745529*x_12 + 5.12960004806519) + 0.0544967730802468*std::sin(0.297279924154282*x_12 - 4.26855993270874) - 0.117028099464648*std::sin(0.266719967126846*x_120 + 5.15808010101318) - 0.0497079858152236*std::sin(0.267679959535599*x_120 + 5.16016006469727) + 0.0412391552172207*std::sin(0.192479997873306*x_13 + 8.19071960449219) - 0.046482063025072*std::sin(0.19344000518322*x_13 + 1.97303986549377) + 0.00698435810179598*std::sin(0.232239991426468*x_13 + 1.98807990550995) + 0.141464538856996*std::sin(0.295279920101166*x_13 - 7.43551969528198) + 0.180149689349677*std::sin(0.30159991979599*x_14 - 7.4423999786377) - 0.0114242860882551*std::sin(0.310879945755005*x_14 - 7.44575977325439) - 0.0146235470520649*std::sin(0.339599847793579*x_14 - 4.33360004425049) - 0.00199778373580596*std::sin(0.288399934768677*x_15 + 1.96623980998993) + 0.194656319779906*std::sin(0.295359939336777*x_15 - 7.43336009979248) + 0.0185732735141854*std::sin(0.423679858446121*x_15 + 8.16016006469727) + 0.0049588368325148*std::sin(0.219439998269081*x_16 + 1.98215985298157) - 0.0358331511182275*std::sin(0.337919861078262*x_16 - 1.15591979026794) + 0.0152273719494784*std::sin(0.342799842357635*x_16 - 1.14039981365204) - 0.0599979034508198*std::sin(0.346559852361679*x_17 + 2.02431988716125) + 0.00356251755691053*std::sin(0.347679853439331*x_17 - 1.15719985961914) - 0.0554167918326401*std::sin(0.35471984744072*x_17 - 1.15351986885071) + 0.123125676888881*std::sin(0.361119836568832*x_17 + 2.00263977050781) + 0.139928245610717*std::sin(0.117200054228306*x_18 - 1.28391993045807) + 0.00257825212622278*std::sin(0.414719849824905*x_18 - 7.41239976882935) - 0.009824942143818*std::sin(0.46687987446785*x_18 - 7.43407964706421) - 0.101047329262676*std::sin(0.241439983248711*x_19 - 1.16903984546661) - 0.0328697792549932*std::sin(0.287599951028824*x_19 - 1.19359982013702) - 0.00636376101743519*std::sin(0.313359916210175*x_19 - 7.41943979263306) + 0.0403949251090232*std::sin(0.372159838676453*x_2 + 5.19632005691528) + 0.100688933205533*std::sin(0.375199824571609*x_2 + 5.17495965957642) - 0.0333486379300562*std::sin(0.393439829349518*x_2 + 5.18728017807007) - 0.00162396081902886*std::sin(0.404799848794937*x_2 + 2.01151990890503) + 0.166366090036664*std::sin(0.202480003237724*x_20 + 1.9812798500061) + 0.0309473527341358*std::sin(0.246639966964722*x_20 - 1.16767990589142) + 0.0368934331665654*std::sin(0.344479858875275*x_20 - 4.3635196685791) + 0.00272020091099547*std::sin(0.403279840946198*x_20 + 8.19911956787109) - 0.114753251164953*std::sin(0.314639925956726*x_21 - 7.40407991409302) + 0.0145435770950979*std::sin(0.33247983455658*x_21 + 8.24967956542969) - 0.0109913874625051*std::sin(0.360639840364456*x_22 + 1.99255979061127) - 0.0138570447301596*std::sin(0.394959837198257*x_22 - 7.40967988967896) - 0.0114332853163259*std::sin(0.241119980812073*x_23 - 4.37519979476929) - 0.00856271160568753*std::sin(0.3643998503685*x_23 + 2.00103974342346) + 0.00399877991038758*std::sin(0.285839945077896*x_24 - 1.15983986854553) + 0.0250489958463202*std::sin(0.306479930877686*x_24 + 1.9890398979187) - 0.0533805466223171*std::sin(0.207600012421608*x_25 + 2.0052797794342) - 0.00564898324505504*std::sin(0.275919944047928*x_25 - 1.16351985931396) - 0.0682477294131673*std::sin(0.324399828910828*x_25 - 1.1555198431015) - 0.00224850682518561*std::sin(0.378719836473465*x_25 + 2.0130398273468) + 0.00527672643791347*std::sin(0.299519926309586*x_26 + 1.992959856987) + 0.0385479746042973*std::sin(0.332399845123291*x_26 - 1.15983986854553) - 0.0477933133734146*std::sin(0.337279856204987*x_26 - 1.14231979846954) - 0.00287015540277914*std::sin(0.316079914569855*x_27 + 2.00415992736816) + 0.0399133188943113*std::sin(0.319199919700623*x_27 + 5.1755199432373) - 0.00143156583656428*std::sin(0.338799834251404*x_28 - 4.3616795539856) + 0.056515922899655*std::sin(0.415039867162704*x_28 - 1.20719993114471) - 0.00794500648203075*std::sin(0.557119846343994*x_28 + 4.81655979156494) + 0.0531435715513492*std::sin(0.296719938516617*x_29 - 1.18191993236542) - 0.0450357972036589*std::sin(0.300719946622849*x_29 + 1.98407983779907) + 0.00767913229910489*std::sin(0.301519930362701*x_29 + 1.98215973377228) + 0.0705257620800882*std::sin(0.296959936618805*x_3 + 8.28071975708008) + 0.0501512876012442*std::sin(0.320239841938019*x_3 + 5.19632005691528) + 0.0263604012680225*std::sin(0.346719831228256*x_3 - 7.38624000549316) - 0.000359525848216466*std::sin(0.400479853153229*x_3 + 2.17975974082947) - 0.0103984573451295*std::sin(0.333119839429855*x_30 + 2.01231980323792) + 0.0599104380776721*std::sin(0.351359844207764*x_30 - 1.14287984371185) - 0.178575405267527*std::sin(0.352639853954315*x_30 - 1.14095985889435) - 0.0103394231355564*std::sin(0.365359842777252*x_31 + 5.17280006408691) + 0.0532941148734443*std::sin(0.368399828672409*x_31 + 5.17471981048584) + 0.0290906889543111*std::sin(0.421279847621918*x_31 - 7.38687992095947) + 0.149267743736697*std::sin(0.303919941186905*x_32 - 1.15511989593506) - 0.00736458435846119*std::sin(0.308319926261902*x_32 + 2.02879977226257) - 0.0165746894911573*std::sin(0.316719859838486*x_32 + 2.00423979759216) + 0.0121749307344096*std::sin(0.219439998269081*x_35 - 7.40215969085693) - 0.00492754068172584*std::sin(0.22919999063015*x_35 - 7.42343997955322) - 0.037856394262771*std::sin(0.250639975070953*x_35 + 1.97823977470398) + 0.0340753024227265*std::sin(0.245919972658157*x_36 - 7.42759990692139) + 0.0784810380778051*std::sin(0.186000004410744*x_37 + 8.20440006256104) + 0.0185663451368046*std::sin(0.237679988145828*x_38 + 1.98759984970093) + 0.0221145323883096*std::sin(0.239919975399971*x_38 + 1.97351980209351) - 0.0771198834613679*std::sin(0.242159977555275*x_38 + 1.97287976741791) + 0.0149405406180954*std::sin(0.22495998442173*x_39 - 1.18631982803345) - 0.00882592566421914*std::sin(0.319279909133911*x_4 + 2.00879979133606) - 0.125888630889692*std::sin(0.330719828605652*x_4 - 7.38168001174927) + 0.00597674546199354*std::sin(0.386159837245941*x_4 + 1.99143981933594) - 0.00148581036751255*std::sin(0.189759999513626*x_40 + 2.000159740448) + 0.0195353267111589*std::sin(0.213359996676445*x_40 + 1.98591983318329) - 0.0495902435113561*std::sin(0.225519984960556*x_41 - 4.39015960693359) - 0.0188488679208449*std::sin(0.250879973173141*x_42 + 5.15895986557007) - 0.0818506347963219*std::sin(0.255599975585938*x_42 - 7.43623971939087) + 0.00523842056571019*std::sin(0.256719976663589*x_43 + 5.15768003463745) + 0.00893040945202216*std::sin(0.28263995051384*x_43 + 5.11055994033813) - 0.00792439923765299*std::sin(0.225679993629456*x_44 - 7.42191982269287) + 0.00872866232055501*std::sin(0.214000001549721*x_45 - 1.21471989154816) - 0.00906816028774641*std::sin(0.213599994778633*x_47 + 1.9826397895813) - 0.136212101069527*std::sin(0.169840022921562*x_49 + 2.00367975234985) + 0.0320945226157655*std::sin(0.211759999394417*x_49 + 1.99351978302002) + 0.00607397403516873*std::sin(0.27295994758606*x_49 + 5.11960029602051) + 0.00310011408358073*std::sin(0.322399914264679*x_5 + 2.01399993896484) + 0.040156448164304*std::sin(0.327759832143784*x_5 - 1.14439988136292) + 0.00505226049981202*std::sin(0.358959853649139*x_5 + 2.02503991127014) + 0.0548558677294801*std::sin(0.374239832162857*x_5 + 2.01015973091125) + 0.0207257414930847*std::sin(0.22775998711586*x_50 - 7.4364800453186) - 0.130433276294196*std::sin(0.217600002884865*x_51 + 1.98359978199005) + 0.00968414375950166*std::sin(0.222479999065399*x_52 - 7.41655969619751) - 0.0770349645978501*std::sin(0.223839998245239*x_52 + 1.98967981338501) + 0.0335731449348686*std::sin(0.25095996260643*x_53 + 5.15743970870972) + 0.00699050981874063*std::sin(0.25943997502327*x_53 - 7.4398398399353) + 0.030015296188508*std::sin(0.224399983882904*x_54 + 1.9832798242569) - 0.0194613469634394*std::sin(0.240879982709885*x_55 - 7.44704008102417) + 0.00397088142448731*std::sin(0.51751983165741*x_57 - 4.48799991607666) + 0.0775476789635481*std::sin(0.151040032505989*x_58 - 4.38327980041504) + 0.11611246599214*std::sin(0.146080031991005*x_59 - 1.21031987667084) - 0.00670380674968234*std::sin(0.284239947795868*x_6 - 7.382239818573) + 0.117649839014077*std::sin(0.37271985411644*x_6 + 2.00519990921021) + 0.028942094577156*std::sin(0.40447986125946*x_60 + 8.19551944732666) - 0.00432346701242156*std::sin(0.257439970970154*x_7 - 7.37671947479248) - 0.0650548743593223*std::sin(0.345999836921692*x_7 + 2.00303983688354) - 0.0938289305727256*std::sin(0.361919850111008*x_7 + 2.0079197883606) - 0.00309076738449545*std::sin(0.412159860134125*x_7 + 4.98207950592041) - 0.0549223562850606*std::sin(0.144000038504601*x_71 - 4.31903982162476) + 0.012972050440535*std::sin(0.254399985074997*x_8 - 4.38703966140747) + 0.0499131058320318*std::sin(0.292959928512573*x_8 - 7.41423988342285) + 0.003376751534489*std::sin(0.29911994934082*x_8 - 7.41567993164063) - 0.0231014340389411*std::sin(0.337839841842651*x_8 - 1.15391993522644) - 0.0063362446389896*std::sin(0.271999955177307*x_9 + 2.00103974342346) - 0.0772460628253988*std::sin(0.314799934625626*x_9 + 5.14448022842407) - 0.123674052409481*std::sin(0.316319912672043*x_9 - 7.42663955688477) - 0.0594731926129322*std::sin(0.355039834976196*x_91 - 7.40223979949951) - 0.00139725274944669*std::sin(0.359519839286804*x_91 - 7.41016006469727) - 0.00640624770692782*std::sin(0.36575984954834*x_91 - 7.38615989685059) + 0.0147900813275129*std::sin(0.262719959020615*x_92 - 7.38695955276489) - 0.00339972749336341*std::sin(0.26599994301796*x_92 - 7.39991998672485) - 0.109176555490363*std::sin(0.285919934511185*x_92 + 1.99951982498169) - 0.049407679302616*std::sin(0.300159931182861*x_92 + 1.99007987976074) + 0.0358105760305573*std::sin(0.286479949951172*x_94 + 1.97767972946167) - 0.00189977318482262*std::sin(0.28671994805336*x_94 + 1.96495985984802) + 0.013566521934344*std::sin(0.249199971556664*x_95 + 5.19456005096436) + 0.00270451869052516*std::sin(0.280399948358536*x_95 - 7.44032001495361) + 0.0875864189647013*std::sin(0.28263995051384*x_95 + 1.96735978126526) + 0.0479605897984361*std::sin(0.282559931278229*x_96 - 7.43711996078491) + 0.0610904924107998*std::sin(0.260399967432022*x_97 - 7.41359996795654) + 0.024108752562446*std::sin(0.276479959487915*x_97 + 1.96783983707428) - 0.0254675826354628*std::sin(0.280159950256348*x_97 + 1.95407974720001) + 0.00133182351737581*std::sin(0.283359944820404*x_97 - 1.20615983009338) - 0.022976294236611*std::sin(0.23191998898983*x_98 + 5.18480014801025) + 0.353469610214233*std::sin(0.000953175210146856*x_10 + 0.00958298959948551*x_100 + 0.0188504788934516*x_101 + 0.0170758662085289*x_102 + 0.0395346753346446*x_103 - 0.00849788513225001*x_104 + 0.0117633255182226*x_105 - 0.00664853181712439*x_106 + 0.0245223485107141*x_107 - 0.0144326840378705*x_108 - 0.026016840930206*x_109 - 0.0112779387467768*x_110 + 0.0593108702424697*x_111 + 0.0306333228335233*x_112 + 0.00958490477775795*x_113 + 0.0242738110052987*x_114 + 0.041219516432643*x_115 - 0.00310956741954774*x_116 + 0.0330503601188003*x_117 + 0.00844060209845952*x_118 + 0.0274848609711478*x_2 - 0.00433092560961076*x_22 - 0.0006897094714555*x_23 + 0.0154493114889459*x_27 - 0.00927328029487389*x_28 - 0.00659557472287936*x_29 + 0.0084836057365266*x_33 - 0.00186455739402787*x_35 - 0.0134523633799464*x_36 + 0.0283271848623976*x_37 + 0.0138607301954446*x_38 - 0.0232685690914714*x_39 - 0.00201322179007657*x_40 + 0.000850544098349208*x_41 + 0.0124035510962834*x_42 + 0.00882737299468792*x_43 + 0.0360872866107652*x_44 + 0.0174278442654177*x_45 + 0.0081211570164727*x_46 + 0.0136495010575297*x_48 + 0.000576029612336428*x_50 - 0.109204502408735*x_51 + 0.00562448927975354*x_52 + 0.076198647948352*x_54 + 0.0208171087637188*x_55 - 0.00494754032440535*x_58 + 0.0365569459384572*x_59 + 0.00219626153855418*x_61 + 0.0053082491239329*x_62 - 0.00112868926913268*x_63 - 0.0103098854945077*x_64 + 0.00695239671312108*x_65 - 0.00376587879650073*x_66 - 0.0110895150314437*x_67 + 0.00548678713102564*x_68 + 0.00113834926466156*x_69 - 0.00442461494888251*x_70 + 0.0147243009065427*x_71 - 0.00573233926435926*x_72 + 0.00450225205283601*x_73 - 0.0053246862695021*x_74 - 0.00841252064729725*x_75 + 0.00700033049287282*x_76 - 0.00437948042775059*x_77 + 0.0192794367072723*x_78 - 0.00153857360183156*x_79 - 0.00546831767894984*x_80 + 0.00768311183778957*x_81 + 0.00713650845670812*x_82 + 0.00535781342162781*x_83 + 0.0043928652888437*x_84 + 0.0045974080932214*x_85 + 0.00109488547802939*x_86 + 0.00087050103378041*x_87 - 0.000816161078084211*x_88 + 0.00602658675893755*x_89 + 0.00696895163787832*x_90 - 0.0089810242261379*x_93 - 0.014632863590038*x_99 + 0.0922871694767693*std::sin(0.365919858217239*x_1 - 4.23160028457642) - 0.130624139142032*std::sin(0.292959928512573*x_11 - 7.44855976104736) + 0.248271890136213*std::sin(0.23599998652935*x_119 + 5.17160034179688) + 0.549455923619455*std::sin(0.292959928512573*x_12 - 4.27135992050171) + 0.522658914946902*std::sin(0.262639969587326*x_120 + 5.16879987716675) - 0.404633380491642*std::sin(0.216639995574951*x_13 - 1.17511987686157) + 0.0329075679384536*std::sin(0.654879808425903*x_14 - 4.47160005569458) + 0.241851501350636*std::sin(0.291679948568344*x_15 + 5.15560007095337) + 0.364900066383385*std::sin(0.299759924411774*x_16 - 7.40511989593506) - 0.336708935752849*std::sin(0.314799934625626*x_17 + 2.02759981155396) - 0.256535050419963*std::sin(0.395679831504822*x_18 + 2.01239991188049) + 0.307071591234926*std::sin(0.331279844045639*x_19 - 1.16599988937378) + 0.0925796212106764*std::sin(0.270879954099655*x_20 + 1.9923198223114) - 0.256840876054907*std::sin(0.339919835329056*x_21 - 1.13927984237671) + 0.123208739917475*std::sin(0.363439828157425*x_24 - 1.15135991573334) + 0.238239358846133*std::sin(0.363119840621948*x_25 + 2.03151988983154) - 0.409066575244228*std::sin(0.333199828863144*x_26 - 1.14551985263824) + 0.71587731692248*std::sin(0.360559850931168*x_3 - 7.41143989562988) - 0.998987049531863*std::sin(0.325919836759567*x_30 - 1.15055990219116) - 0.219644548083361*std::sin(0.357999831438065*x_31 + 5.16495990753174) - 0.198344836592574*std::sin(0.336319833993912*x_32 + 1.99399983882904) - 0.269814749285509*std::sin(0.185760006308556*x_34 - 1.19479990005493) - 0.154131996717422*std::sin(0.324959844350815*x_4 - 1.16639983654022) + 0.614221125409134*std::sin(0.153200030326843*x_47 - 1.17551982402802) + 1.59614272629874*std::sin(0.0819200873374939*x_49 - 1.29207980632782) - 0.0703319175109764*std::sin(0.402399837970734*x_5 + 8.21047973632813) + 0.349088918098175*std::sin(0.256639957427979*x_53 - 7.42983961105347) - 0.340840301444416*std::sin(0.0958400741219521*x_56 + 7.95592021942139) + 0.585249590611657*std::sin(0.163920015096664*x_57 - 1.17575979232788) - 0.794466726405652*std::sin(0.344559848308563*x_6 + 2.00063967704773) + 0.161146890495974*std::sin(0.41543984413147*x_60 - 1.21631991863251) - 0.985677405605102*std::sin(0.357119828462601*x_7 + 1.99847972393036) + 0.405767666658043*std::sin(0.334959834814072*x_8 - 1.14431989192963) - 0.227228700204972*std::sin(0.306639939546585*x_9 - 1.19591987133026) + 0.0590833165051499*std::sin(0.259039968252182*x_91 - 4.16463994979858) - 0.362213237967705*std::sin(0.296799927949905*x_92 + 1.99463987350464) - 0.292413990652889*std::sin(0.286959946155548*x_94 + 1.97103977203369) + 0.0970604726703845*std::sin(0.295519918203354*x_95 - 1.22903990745544) + 0.0855759763255621*std::sin(0.299439936876297*x_96 + 1.93367981910706) - 0.243803642505981*std::sin(0.271919965744019*x_97 - 7.42767953872681) + 0.235853384717345*std::sin(0.232239991426468*x_98 - 7.39911985397339) - 0.732224332253857) + 0.4661751281282);
}

int predict(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120)
{
    float s0 = score_0(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s1 = score_1(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s2 = score_2(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s3 = score_3(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s4 = score_4(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s5 = score_5(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s6 = score_6(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s7 = score_7(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s8 = score_8(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s9 = score_9(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s10 = score_10(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s11 = score_11(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);

    float max_score = s0;
    int max_index = 0;

    if(s1 > max_score) {
        max_score = s1;
        max_index = 1;
    }

    if(s2 > max_score) {
        max_score = s2;
        max_index = 2;
    }

    if(s3 > max_score) {
        max_score = s3;
        max_index = 3;
    }

    if(s4 > max_score) {
        max_score = s4;
        max_index = 4;
    }

    if(s5 > max_score) {
        max_score = s5;
        max_index = 5;
    }

    if(s6 > max_score) {
        max_score = s6;
        max_index = 6;
    }

    if(s7 > max_score) {
        max_score = s7;
        max_index = 7;
    }

    if(s8 > max_score) {
        max_score = s8;
        max_index = 8;
    }

    if(s9 > max_score) {
        max_score = s9;
        max_index = 9;
    }

    if(s10 > max_score) {
        max_score = s10;
        max_index = 10;
    }

    if(s11 > max_score) {
        max_score = s11;
        max_index = 11;
    }

    return max_index;
}

#endif
