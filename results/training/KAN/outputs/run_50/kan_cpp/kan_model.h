
#ifndef KAN_MODEL_H
#define KAN_MODEL_H

#include <cmath>


inline float score_0(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (9.82940024488065e-7*x_1 + 2.68869637681166e-8*x_10 - 1.34412857125844e-6*x_100 - 3.58235485958976e-6*x_101 + 8.50445229906637e-7*x_102 + 1.80056676201409e-6*x_103 - 6.18384109675132e-6*x_104 - 2.15713209582854e-6*x_105 + 1.15673208988938e-6*x_106 + 1.8950305214424e-6*x_107 + 7.40352064807576e-7*x_108 + 2.5673150486922e-7*x_109 - 1.48716446325472e-6*x_11 + 1.60590168173167e-6*x_110 - 1.63834321940019e-6*x_111 - 2.25046718739365e-6*x_112 + 3.78024776787182e-6*x_113 + 5.62704127813541e-7*x_114 - 1.70048041300422e-6*x_115 - 1.36533777684082e-6*x_116 + 1.82208488294172e-6*x_117 + 1.73153559939559e-6*x_118 + 2.23058370770579e-6*x_119 + 3.18918452789691e-6*x_12 - 1.23262888101511e-6*x_120 + 4.17117160038911e-7*x_13 + 7.22301825487906e-7*x_14 + 4.46844155946388e-7*x_15 - 2.37334056779462e-6*x_16 + 5.86625965358917e-7*x_17 - 1.4181235618749e-6*x_18 - 1.89521149562641e-6*x_19 - 8.88261438687571e-7*x_2 - 1.22148730634006e-6*x_20 + 2.11220876886894e-6*x_21 + 4.2559850100279e-8*x_22 - 1.93687510135154e-6*x_23 + 2.530578650228e-6*x_24 - 7.3255759544703e-7*x_25 - 3.57687858587741e-7*x_26 + 4.20662565663533e-7*x_27 - 1.52494241592914e-6*x_28 + 6.13284457175526e-7*x_29 + 7.63452455797287e-7*x_3 + 5.78349755360761e-8*x_30 + 7.2841611476117e-5*x_31 - 7.94153097448809e-6*x_32 - 8.06277539595165e-6*x_33 - 3.69735355119733e-6*x_34 - 2.02887220756159e-6*x_35 - 1.10372919176431e-7*x_36 - 1.93298931667869e-6*x_37 + 4.19141580351342e-7*x_38 + 4.76821717177686e-7*x_39 - 8.77169683166943e-7*x_4 - 1.63249574387045e-6*x_40 - 1.22477755302914e-6*x_41 - 1.88639193377415e-7*x_42 - 1.30195899574253e-6*x_43 + 1.10359853969001e-6*x_44 - 2.92326737335006e-6*x_45 - 8.97262576686287e-7*x_46 - 2.17865226842998e-6*x_47 - 1.13876382024453e-5*x_48 - 1.11562310686595e-6*x_49 - 1.55909346534721e-6*x_5 + 3.20933164549479e-6*x_50 - 1.61583090605226e-6*x_51 - 2.20056328978495e-6*x_52 - 2.62573536978931e-6*x_53 + 2.13905235349391e-7*x_54 - 1.735925318416e-6*x_55 + 2.55746187129994e-6*x_56 - 1.45956042337055e-6*x_57 + 1.11100503307929e-6*x_58 + 2.90789235613436e-6*x_59 - 5.24374330597601e-7*x_6 - 6.01847849055133e-8*x_60 + 3.38522331386197e-6*x_61 - 8.14185528937945e-7*x_62 + 3.87460173247159e-7*x_63 - 1.48476154981559e-6*x_64 - 1.82064701474674e-6*x_65 - 7.39802283694227e-7*x_66 - 8.60585766073781e-7*x_67 + 1.85417348246592e-6*x_68 + 1.70733081477038e-8*x_69 + 8.21008749080397e-7*x_7 - 2.53474525971366e-6*x_70 + 6.27783515840447e-7*x_71 + 1.3401437364879e-6*x_72 - 8.50685502192525e-7*x_73 - 1.02903768194815e-6*x_74 + 6.98399531485119e-7*x_75 - 2.05712618015064e-6*x_76 + 5.19673739274785e-7*x_77 - 2.06502460101016e-6*x_78 - 1.69580927917917e-6*x_79 + 9.83006549203395e-7*x_8 - 1.50685417187152e-6*x_80 - 1.5412371421778e-6*x_81 - 1.02791329691967e-7*x_82 - 6.29855940657418e-7*x_83 + 2.34266067704465e-7*x_84 - 1.67956162132549e-7*x_85 - 8.5058286743743e-7*x_86 - 2.92911990977353e-7*x_87 - 2.35652461933587e-6*x_88 + 1.43257794917562e-6*x_89 + 1.31092785431207e-6*x_9 - 1.40282480108166e-6*x_90 - 1.76455673820182e-6*x_91 - 2.66916646932903e-6*x_92 - 1.24328743621135e-6*x_93 - 2.17175643171818e-6*x_94 + 5.79363059588824e-6*x_95 - 2.50619913682842e-6*x_96 - 1.10583539814333e-6*x_97 - 5.28072092054244e-7*x_98 - 8.255064357893e-7*x_99 - 9.74673384434478e-8*std::pow(-8.41960048675537*x_1 - 3.39759993553162, 2) + 8.73383237182281e-5*std::sin(0.329199850559235*x_1 + 4.60864019393921) - 6.6827437661705e-6*std::sin(0.329759836196899*x_35 + 5.16951990127563) - 2.56128152165395e-6*std::sin(0.453919857740402*x_94 - 7.36823987960815) - 8.86317129463062e-7*std::sin(0.463919848203659*x_97 - 7.37167978286743) + 0.0618006744970147);
}

inline float score_1(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (8.71991172342562e-6*x_1 - 3.76587380629019e-7*x_10 + 7.20127400659655e-7*x_100 - 7.83744903263378e-7*x_101 + 9.0006672886492e-7*x_102 + 9.67853600971798e-7*x_103 + 2.29347790948664e-7*x_104 + 1.61600668264314e-6*x_105 - 8.50789020653319e-7*x_106 - 7.68185566292434e-7*x_107 + 3.91484551071453e-7*x_108 - 1.27148348517902e-6*x_109 - 9.74741251875385e-7*x_11 - 1.854310427713e-6*x_110 - 2.01010832460385e-6*x_111 + 3.55029487422274e-7*x_112 - 1.95978008343402e-6*x_113 + 8.4477322640468e-7*x_114 - 1.63115358115165e-6*x_115 - 2.64980929432332e-7*x_116 - 2.20475593459116e-6*x_117 - 2.48132484765792e-6*x_118 + 1.73966073494057e-6*x_119 - 4.47802896949282e-6*x_12 + 1.35052599000502e-6*x_120 + 3.42924741089031e-7*x_13 - 5.68131762346126e-7*x_14 - 1.57979464625006e-6*x_15 - 4.95588869729788e-7*x_16 + 1.79164921885705e-6*x_17 + 1.23968125692862e-6*x_18 + 5.39743517969826e-7*x_19 - 4.26316311914069e-7*x_2 + 6.35684488254711e-7*x_20 + 2.24833899272722e-7*x_21 + 3.13964595933708e-7*x_22 + 2.17870049174827e-6*x_23 - 2.18693384611865e-6*x_24 + 1.34241354738414e-6*x_25 - 4.77943305346826e-7*x_26 + 1.44884157359907e-6*x_27 - 1.89264692354783e-7*x_28 - 7.26976571174831e-7*x_29 - 1.40583113545702e-6*x_3 - 1.31045499572111e-6*x_30 - 3.45500315192352e-5*x_31 - 7.24968827976088e-6*x_32 + 7.09312193487524e-7*x_33 - 2.79309023291905e-6*x_34 - 6.01092652238124e-7*x_35 - 1.09393721754139e-9*x_36 + 5.38634276865474e-6*x_37 + 1.6723291613528e-6*x_38 + 3.93367385910439e-7*x_39 - 3.74807337226844e-8*x_4 + 1.45130847719676e-6*x_40 - 4.99289524297251e-7*x_41 - 6.65320294120635e-7*x_42 + 1.21964989508697e-6*x_43 - 7.30146187103715e-7*x_44 + 1.54250081734318e-6*x_45 - 1.191375228814e-6*x_46 + 3.6333571273956e-7*x_47 - 1.8026155893241e-6*x_48 + 4.18424880137551e-7*x_49 + 4.17949784093494e-8*x_5 + 8.12451360578864e-7*x_50 - 1.09253412350874e-6*x_51 + 1.14497683136317e-6*x_52 + 5.68371506275513e-7*x_53 - 1.05181646495627e-6*x_54 + 9.56723090540086e-7*x_55 + 4.70259103768432e-7*x_56 - 8.21866975050345e-8*x_57 - 4.64886956742996e-7*x_58 + 1.96319733520218e-7*x_59 - 1.74748753134103e-7*x_6 - 8.34681009035496e-7*x_60 + 3.77848390310309e-6*x_61 + 4.23470056658356e-6*x_62 + 4.05005056075452e-6*x_63 + 3.52310146056761e-6*x_64 + 1.19280727845829e-7*x_65 + 2.19432053151288e-6*x_66 + 1.46318228383859e-6*x_67 - 1.51005423231556e-6*x_68 - 4.51513445959318e-6*x_69 + 1.60832831369781e-7*x_7 + 1.27089238158268e-6*x_70 - 1.83949794333203e-6*x_71 - 4.72405532239768e-7*x_72 + 1.07633724812448e-6*x_73 + 2.30076141639278e-6*x_74 - 3.44458400617137e-8*x_75 + 1.13297517841667e-6*x_76 + 2.35664006394561e-7*x_77 + 1.76629419862993e-6*x_78 + 1.89163894122746e-7*x_79 + 2.61668944255837e-7*x_8 + 1.93639442484264e-6*x_80 + 9.44582681360153e-7*x_81 + 1.28148654327363e-6*x_82 - 5.20153195113554e-7*x_83 - 1.27334054600055e-7*x_84 - 6.50225553796673e-7*x_85 + 4.46770807220561e-7*x_86 + 2.48771899821235e-7*x_87 + 1.07283507310515e-6*x_88 - 4.04064028784861e-8*x_89 - 8.43846420499323e-7*x_9 - 5.63318428645211e-8*x_90 - 4.5729747433713e-8*x_91 + 1.09552247426611e-6*x_92 + 3.77604415785955e-6*x_93 - 7.50477870105899e-7*x_94 + 3.73245927384016e-8*x_95 - 5.74166954467011e-7*x_96 - 2.43030189848568e-7*x_97 - 4.1800949045046e-7*x_98 + 2.62508511449876e-6*x_99 - 1.68073679958302e-9*std::pow(-8.41960048675537*x_1 - 3.39759993553162, 2) - 7.06045679788053e-5*std::sin(0.329199850559235*x_1 + 4.60864019393921) + 1.47211529738131e-7*std::sin(0.329759836196899*x_35 + 5.16951990127563) + 5.64214616160202e-8*std::sin(0.453919857740402*x_94 - 7.36823987960815) + 6.11231354836396e-7*std::sin(0.463919848203659*x_97 - 7.37167978286743) + 0.0653418270262638);
}

inline float score_2(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-1.08403041098088e-5*x_1 - 2.81323672966413e-6*x_10 - 3.38183795872619e-6*x_100 - 2.45353669446081e-6*x_101 + 1.78169024139404e-6*x_102 + 3.31824244102135e-6*x_103 - 5.62430704523839e-6*x_104 - 2.57127153458263e-6*x_105 + 1.03198193795543e-6*x_106 - 2.60043319673246e-6*x_107 + 4.60970292450097e-6*x_108 + 4.16117338569623e-6*x_109 - 7.10260166553641e-7*x_11 - 1.13766740708849e-6*x_110 - 3.47501244990886e-6*x_111 - 6.97106427759239e-7*x_112 + 9.63324369905313e-8*x_113 - 1.20550727133695e-6*x_114 - 2.20086299424809e-6*x_115 - 1.97028942034232e-6*x_116 - 4.27866609862641e-7*x_117 - 7.12431180365696e-7*x_118 + 7.46620569994253e-7*x_119 + 6.18318539737356e-6*x_12 - 2.72827476622862e-6*x_120 + 1.35168023099007e-6*x_13 - 1.88743785019671e-6*x_14 - 2.66698508927314e-7*x_15 - 3.62795121674151e-7*x_16 - 1.88541807091941e-6*x_17 - 4.31557865177609e-6*x_18 - 2.5617171954672e-7*x_19 + 8.88251958712303e-7*x_2 + 5.9446293231227e-8*x_20 - 1.0878917342823e-6*x_21 + 3.21832967109318e-7*x_22 - 1.42715137218152e-6*x_23 - 1.50436619206009e-6*x_24 - 1.95349899992003e-6*x_25 - 1.04990238391821e-6*x_26 - 1.67800332800324e-7*x_27 + 1.14931464999068e-6*x_28 - 1.74048433308754e-6*x_29 + 2.41714430503688e-6*x_3 - 2.43074115676536e-6*x_30 + 4.83339441238203e-5*x_31 - 1.74815913787366e-5*x_32 + 1.01155255732063e-5*x_33 - 1.16167479636808e-5*x_34 - 5.87666397855116e-6*x_35 - 1.38979138044858e-7*x_36 + 2.33196493733034e-6*x_37 + 1.21682090973816e-6*x_38 - 4.44620598008832e-7*x_39 - 5.42719783312478e-7*x_4 + 1.35710056366866e-6*x_40 - 6.59333529344343e-7*x_41 + 7.15946451757962e-7*x_42 - 1.69050014568244e-6*x_43 - 2.10548010157104e-7*x_44 - 6.71782838098746e-6*x_45 - 7.27089171464208e-7*x_46 - 1.68098622997227e-6*x_47 - 1.74070094730432e-5*x_48 - 3.81131146121683e-7*x_49 - 3.44291960037924e-7*x_5 + 5.92099582177188e-6*x_50 - 8.01523476887156e-6*x_51 - 5.29508569718019e-6*x_52 - 4.47536664740577e-6*x_53 - 6.73829915494995e-6*x_54 - 2.01469533371896e-6*x_55 - 1.09170736735789e-6*x_56 - 1.49598673281746e-6*x_57 - 3.20777003768033e-6*x_58 + 6.16546680048293e-6*x_59 - 1.66611129255228e-7*x_6 - 1.80172897538654e-8*x_60 + 5.2170578034204e-6*x_61 + 8.33035353912718e-6*x_62 + 7.84723843246632e-6*x_63 + 4.8071694935439e-6*x_64 - 2.07811279460004e-6*x_65 - 1.81050764426148e-6*x_66 + 1.62506440588874e-8*x_67 + 4.6352608747785e-7*x_68 - 1.46746387754359e-6*x_69 - 3.46231117070329e-6*x_7 - 1.83620795378786e-6*x_70 + 1.29922923235664e-6*x_71 - 6.29914866366776e-7*x_72 - 1.23384065670037e-6*x_73 + 1.28270231355984e-7*x_74 + 7.58753252843343e-7*x_75 + 1.01613292638223e-6*x_76 + 6.33796047374475e-7*x_77 - 1.08308461735063e-6*x_78 - 2.20903053285291e-6*x_79 + 3.41596564413653e-6*x_8 - 1.54329517949251e-7*x_80 - 1.05089721323116e-6*x_81 - 1.60279172146827e-7*x_82 - 2.15415786610217e-6*x_83 - 6.55874612684167e-7*x_84 + 8.66915645146974e-7*x_85 + 1.5106076046953e-6*x_86 - 3.13071738386521e-7*x_87 - 1.00771971665102e-6*x_88 + 9.65691839910007e-8*x_89 - 1.40856850043843e-7*x_9 - 1.03877998863459e-6*x_90 - 1.31180601720001e-5*x_91 - 2.63151349609697e-6*x_92 - 2.03981411298259e-6*x_93 - 4.49379870746708e-6*x_94 - 1.1486606321041e-5*x_95 - 4.6740565352647e-6*x_96 - 8.23165922823309e-7*x_97 + 2.12726602223881e-6*x_98 - 1.19404199211129e-7*x_99 - 1.32615591172737e-7*std::pow(-8.41960048675537*x_1 - 3.39759993553162, 2) + 2.06843828179312e-5*std::sin(0.329199850559235*x_1 + 4.60864019393921) - 1.22342154115124e-5*std::sin(0.329759836196899*x_35 + 5.16951990127563) - 4.68898269361555e-6*std::sin(0.453919857740402*x_94 - 7.36823987960815) + 1.20483383223001e-6*std::sin(0.463919848203659*x_97 - 7.37167978286743) + 0.0479928806494967);
}

inline float score_3(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-2.00702972963493e-5*x_1 + 1.93087124247694e-6*x_10 - 4.07389103333607e-6*x_100 + 7.84943421774803e-8*x_101 - 2.3015995895603e-6*x_102 - 1.53028116079799e-6*x_103 + 2.13439131643555e-6*x_104 + 1.17589172482554e-6*x_105 - 1.14723929812259e-7*x_106 + 3.60932508808373e-6*x_107 - 1.41323691760739e-6*x_108 - 4.82944197055843e-8*x_109 + 2.51351976766971e-6*x_11 - 1.58757947253015e-6*x_110 + 4.86734545920259e-7*x_111 + 8.42484370553382e-7*x_112 + 3.74031593695947e-7*x_113 + 3.53953545265217e-6*x_114 - 3.74514249460267e-7*x_115 + 5.41141079630026e-6*x_116 + 2.14125044298055e-6*x_117 - 1.25869888764857e-6*x_118 + 5.82693155128373e-6*x_119 - 2.66801967687049e-6*x_12 - 2.0237573170596e-6*x_120 - 1.45365115166361e-6*x_13 - 4.15972358815944e-7*x_14 + 4.25633749878104e-7*x_15 - 8.21688151762934e-7*x_16 + 1.23037146574998e-6*x_17 + 3.77004155660605e-6*x_18 - 2.20956172456291e-6*x_19 + 1.46548242991536e-6*x_2 + 1.02343515545607e-6*x_20 + 4.76722133455352e-6*x_21 - 4.0140259217968e-7*x_22 + 1.03625939633084e-6*x_23 + 4.28838462721876e-6*x_24 + 1.79598059674545e-6*x_25 + 5.02994322487166e-7*x_26 - 9.90109443685816e-7*x_27 - 9.13922401008738e-7*x_28 + 1.50613525474591e-6*x_29 + 1.16398714393105e-6*x_3 + 2.98386739689203e-6*x_30 - 7.98291288179677e-5*x_31 + 5.11354321575056e-6*x_32 + 9.65854830494562e-6*x_33 - 2.53950447189454e-6*x_34 + 3.57596916061911e-6*x_35 + 8.00399850328845e-7*x_36 + 2.04900171878503e-6*x_37 + 2.1393038836138e-6*x_38 - 2.55397080392111e-6*x_39 - 1.22637477418697e-6*x_4 - 2.29870223201387e-6*x_40 + 6.77893348022848e-7*x_41 - 2.40718621558587e-6*x_42 + 3.36211380893172e-6*x_43 + 5.03577388805891e-7*x_44 + 3.48275201930196e-6*x_45 + 1.30384276245126e-6*x_46 + 4.28473615960206e-7*x_47 + 4.65649853051215e-7*x_48 - 7.73233512605923e-7*x_49 - 8.90993485297891e-7*x_5 - 1.25147327299804e-6*x_50 + 7.16062335691696e-6*x_51 + 2.52400584058387e-7*x_52 + 1.89284600381716e-6*x_53 + 1.98306741480483e-6*x_54 + 5.97907774237231e-7*x_55 + 4.12808844414538e-6*x_56 + 6.00581127022966e-7*x_57 - 1.70482209373852e-6*x_58 - 1.99890316855027e-6*x_59 - 9.26012571732124e-7*x_6 + 1.91190237563699e-6*x_60 + 2.05663279441057e-6*x_61 + 3.33934054699153e-6*x_62 + 2.85497846191659e-6*x_63 + 5.78886794027152e-6*x_64 + 2.0045530168365e-6*x_65 + 2.67315660022372e-7*x_66 + 2.63380100565435e-6*x_67 + 1.89861836124109e-6*x_68 - 5.71420416594214e-6*x_69 + 9.01581264514447e-7*x_7 - 2.4521867304762e-6*x_70 + 1.09712027761714e-6*x_71 + 1.30275376564291e-6*x_72 - 1.75513895117168e-7*x_73 + 1.9254674577369e-6*x_74 - 1.13163853229988e-6*x_75 - 5.51100546625746e-8*x_76 + 7.07314366777578e-7*x_77 + 1.98944045106046e-6*x_78 + 4.73970442939164e-7*x_79 - 8.60625177924675e-7*x_8 + 1.13262113750412e-6*x_80 - 7.64575545229219e-7*x_81 + 1.11805159810512e-6*x_82 - 1.35017203058975e-6*x_83 + 1.9734363767183e-7*x_84 - 1.88592068129165e-6*x_85 - 6.43894762965382e-7*x_86 - 5.34096795227943e-8*x_87 + 2.68780686005323e-6*x_88 + 3.23532349864388e-6*x_89 - 2.25789786415172e-8*x_9 + 5.98900804375074e-7*x_90 + 3.90852800496201e-5*x_91 + 3.97009027664022e-7*x_92 + 3.3642866168616e-6*x_93 - 2.07694875335637e-7*x_94 - 1.98156094255527e-6*x_95 + 5.04672431223345e-6*x_96 - 9.44050865130736e-7*x_97 + 1.78985103034703e-6*x_98 + 3.40909738978096e-6*x_99 + 6.59866208963572e-10*std::pow(-8.41960048675537*x_1 - 3.39759993553162, 2) + 9.2051616936462e-6*std::sin(0.329199850559235*x_1 + 4.60864019393921) - 7.01904530851586e-6*std::sin(0.329759836196899*x_35 + 5.16951990127563) - 2.69017512527726e-6*std::sin(0.453919857740402*x_94 - 7.36823987960815) - 2.01531607278679e-6*std::sin(0.463919848203659*x_97 - 7.37167978286743) + 0.0673215682748211);
}

inline float score_4(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (2.5603766423243e-5*x_1 + 5.12553790739804e-6*x_10 - 8.65752152438869e-6*x_100 + 1.52942597744381e-6*x_101 - 3.07482439400202e-7*x_102 - 1.68252498038115e-6*x_103 + 5.76864978223952e-6*x_104 + 8.78082074641069e-7*x_105 + 1.93947037529687e-6*x_106 + 8.83542501997103e-7*x_107 + 5.29618128578238e-6*x_108 - 2.81368117217988e-6*x_109 - 6.16020383807332e-7*x_11 - 3.14112106284502e-7*x_110 - 5.69091212768145e-7*x_111 + 4.07508535053014e-6*x_112 - 1.44984608976452e-7*x_113 - 2.62754772271658e-6*x_114 + 7.68751531233439e-6*x_115 - 2.08232268994724e-6*x_116 + 2.84023610894185e-7*x_117 - 4.18671553973446e-7*x_118 + 2.57500861073994e-8*x_119 - 9.84470910042314e-7*x_12 - 8.43288698132958e-6*x_120 + 4.10979685831568e-6*x_13 - 2.03601679924146e-6*x_14 + 2.61929255415448e-6*x_15 + 3.41811148685134e-6*x_16 + 2.61987575480022e-6*x_17 + 3.42133205474385e-7*x_18 - 9.17570916461844e-7*x_19 + 6.29615933861263e-6*x_2 - 1.1720795450571e-6*x_20 + 1.38952572700291e-6*x_21 - 2.99504246791255e-6*x_22 + 3.92526833740714e-7*x_23 + 2.49636077076055e-6*x_24 - 1.37092871174849e-6*x_25 + 6.14615649255113e-7*x_26 - 2.32710624164495e-6*x_27 - 3.93617551942081e-7*x_28 + 2.68118543586265e-6*x_29 - 3.05503246463363e-6*x_3 + 1.539968741149e-6*x_30 - 0.000121929457986222*x_31 + 1.88862140008514e-5*x_32 + 1.65543579080091e-5*x_33 - 1.09216321408254e-5*x_34 + 4.39420980928304e-6*x_35 + 2.39603210849828e-6*x_36 - 2.85559104057595e-6*x_37 + 3.41285929253487e-6*x_38 + 7.66346568827953e-6*x_39 + 1.19879998661557e-6*x_4 + 3.73882438294699e-7*x_40 + 1.32369913659522e-6*x_41 + 1.79909483776375e-6*x_42 + 2.22734014902385e-6*x_43 + 8.82785028479583e-7*x_44 + 7.83837959458592e-6*x_45 + 4.42828655305783e-7*x_46 - 2.57401920717328e-6*x_47 + 9.92580778056452e-6*x_48 - 2.30992265056723e-7*x_49 + 1.09361130286012e-6*x_5 + 8.94470110979164e-7*x_50 - 7.26230608674921e-7*x_51 - 2.69733622218045e-6*x_52 + 1.58161549281851e-6*x_53 + 1.19468977039898e-5*x_54 + 8.56730565912938e-7*x_55 + 4.46456882207861e-7*x_56 + 6.15826573128268e-7*x_57 - 1.78204214486283e-6*x_58 - 4.22224431416322e-6*x_59 - 4.7394443254504e-7*x_6 + 6.22737640397963e-6*x_60 - 3.67406628066799e-6*x_61 + 6.87257979043746e-6*x_62 + 1.44347581661833e-7*x_63 + 4.5916201397789e-6*x_64 - 9.28834235434989e-7*x_65 + 3.67824668152836e-6*x_66 - 2.11273241584827e-6*x_67 - 1.12766678272958e-6*x_68 - 2.14767459802211e-6*x_69 + 5.9452559569767e-7*x_7 - 3.32543778371418e-6*x_70 + 7.83433308556515e-6*x_71 - 1.25032543118272e-6*x_72 - 2.33109187848659e-6*x_73 + 1.56232386655759e-6*x_74 - 2.43383621151045e-6*x_75 + 5.75961074017822e-7*x_76 + 1.38745309754867e-6*x_77 + 1.46392759474016e-6*x_78 + 2.28643653084116e-6*x_79 + 4.94176025183497e-6*x_8 + 1.18876521199306e-6*x_80 - 6.95328250638575e-7*x_81 + 2.72767152937631e-7*x_82 + 1.70522489791558e-6*x_83 + 3.57572100217616e-6*x_84 - 1.09278383019382e-6*x_85 + 5.19526813224493e-7*x_86 - 3.60371587155823e-7*x_87 + 3.20648680424428e-7*x_88 - 1.28128641631596e-7*x_89 - 1.41259578400897e-6*x_9 - 3.58156135041641e-6*x_90 + 7.395747975213e-6*x_91 + 1.8248198713378e-6*x_92 - 1.27255099460071e-6*x_93 + 1.99791800466606e-6*x_94 - 6.19129114553042e-6*x_95 - 4.89586697244074e-6*x_96 - 2.82371311001745e-6*x_97 + 1.44409401421417e-6*x_98 + 9.83924657415655e-6*x_99 + 2.4573155162262e-8*std::pow(-8.41960048675537*x_1 - 3.39759993553162, 2) + 5.9701439518789e-5*std::sin(0.329199850559235*x_1 + 4.60864019393921) - 1.06430739387899e-5*std::sin(0.329759836196899*x_35 + 5.16951990127563) - 4.07914915891506e-6*std::sin(0.453919857740402*x_94 - 7.36823987960815) - 4.88323167950295e-7*std::sin(0.463919848203659*x_97 - 7.37167978286743) + 0.0577040679359181);
}

inline float score_5(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-2.74628126243779e-5*x_1 + 1.03041461240571e-6*x_10 + 5.0591518867479e-6*x_100 + 1.58828556390607e-6*x_101 + 2.11625172122893e-6*x_102 - 7.36661860152405e-7*x_103 + 4.66441541306059e-6*x_104 - 1.5738807207053e-6*x_105 - 3.60113865181217e-6*x_106 - 4.11750307209942e-6*x_107 - 1.68945709019908e-6*x_108 + 4.43105055663889e-6*x_109 + 1.60362812302162e-6*x_11 + 6.42301858605745e-6*x_110 + 7.6168270929254e-7*x_111 + 1.31455944391571e-6*x_112 - 3.69535332371072e-6*x_113 + 6.04701887953921e-8*x_114 + 1.04505451859742e-6*x_115 + 4.76466278196102e-7*x_116 + 6.24729479386423e-7*x_117 + 1.30699178780567e-6*x_118 - 2.10845176633185e-6*x_119 - 1.91060390918679e-6*x_12 - 8.3503178096973e-6*x_120 - 2.65501726836194e-6*x_13 - 5.75233839382439e-7*x_14 - 7.99541761556793e-7*x_15 + 1.25085102261335e-6*x_16 - 3.38869630303096e-6*x_17 + 1.60471654605554e-6*x_18 + 4.82023003820418e-7*x_19 - 1.20479259587371e-6*x_2 + 5.3575652719841e-8*x_20 - 3.04209347553811e-6*x_21 + 1.563193009535e-6*x_22 + 1.5376632044524e-6*x_23 - 4.08642103155604e-6*x_24 - 1.80866152424514e-6*x_25 - 7.3153997948978e-7*x_26 - 8.65241629756092e-7*x_27 + 7.92470678326368e-6*x_28 - 1.11759975479734e-6*x_29 + 1.4193258996762e-6*x_3 + 1.11632366874832e-6*x_30 + 2.20941150646052e-7*x_31 - 1.27874306335114e-5*x_32 + 5.7893125596961e-6*x_33 - 2.91823697751094e-5*x_34 + 3.43176217706869e-6*x_35 - 1.31179371620108e-6*x_36 + 1.33238567503849e-6*x_37 - 2.9217660919874e-6*x_38 + 3.57801142745648e-6*x_39 + 1.01954746266536e-7*x_4 - 1.32269626160593e-7*x_40 + 2.42806282317693e-6*x_41 + 2.43266032706545e-6*x_42 + 5.29943780396779e-6*x_43 + 1.61151035226159e-6*x_44 - 4.23675182458493e-6*x_45 - 3.27630023184766e-6*x_46 + 4.26501125481772e-6*x_47 + 1.17741783100348e-5*x_48 - 4.27863220432018e-6*x_49 + 1.68089739585416e-6*x_5 - 2.82868332429842e-6*x_50 - 1.0210141698757e-6*x_51 + 4.09161424278896e-8*x_52 + 3.6748057113005e-6*x_53 - 2.03448824296976e-6*x_54 + 2.75273378778382e-6*x_55 - 3.14067981584071e-7*x_56 - 9.58522497772771e-7*x_57 - 3.35460943927358e-6*x_58 + 3.49719589924381e-8*x_59 - 7.10715112969506e-7*x_6 + 1.31037799601615e-6*x_60 + 2.02965480789755e-6*x_61 + 7.35917118008395e-6*x_62 + 3.96670140436584e-6*x_63 + 2.43401150902477e-6*x_64 + 2.53265719754032e-6*x_65 - 2.25185694158208e-6*x_66 - 6.0524159939936e-7*x_67 - 4.21255497657299e-6*x_68 + 3.73835602069308e-6*x_69 - 4.92743137097286e-7*x_7 - 9.36174812758997e-6*x_70 - 1.2939502113404e-6*x_71 - 4.34461620019973e-7*x_72 - 7.58953143222124e-7*x_73 + 1.05038980456307e-6*x_74 - 1.68867943592765e-6*x_75 - 1.53167868681779e-6*x_76 - 1.92513815312626e-6*x_77 + 2.69264727732867e-6*x_78 + 1.43643490302236e-6*x_79 + 9.71501967215154e-7*x_8 + 3.82105638427333e-6*x_80 + 6.2074364339089e-7*x_81 - 1.3080161144614e-6*x_82 - 2.17593423567039e-7*x_83 - 9.31960340801358e-7*x_84 + 2.62768530017423e-6*x_85 + 4.31838030935624e-6*x_86 + 2.76813941163429e-6*x_87 + 2.9566762230294e-6*x_88 + 1.12597902682187e-7*x_89 - 1.26117572959844e-6*x_9 + 1.43424322018738e-6*x_90 + 1.74877817473604e-5*x_91 + 2.19935435333196e-6*x_92 + 7.71885370197776e-7*x_93 - 2.84618148046604e-7*x_94 - 4.01441043916109e-6*x_95 + 5.7754172672378e-6*x_96 + 4.32121313977878e-6*x_97 + 1.40021805788444e-6*x_98 - 4.45789536317841e-6*x_99 + 1.08765910847569e-7*std::pow(-8.41960048675537*x_1 - 3.39759993553162, 2) + 4.84555275295817e-6*std::sin(0.329199850559235*x_1 + 4.60864019393921) - 3.38212391817757e-5*std::sin(0.329759836196899*x_35 + 5.16951990127563) - 1.29625970988501e-5*std::sin(0.453919857740402*x_94 - 7.36823987960815) + 2.01919913365623e-6*std::sin(0.463919848203659*x_97 - 7.37167978286743) + 0.062526327497053);
}

inline float score_6(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (1.67669201680724e-5*x_1 + 2.91336885046071e-6*x_10 - 4.99826151604691e-7*x_100 - 1.54797132065109e-6*x_101 + 1.02785264007617e-6*x_102 - 1.17814528700146e-6*x_103 - 3.57441202200878e-6*x_104 + 2.58999057363475e-6*x_105 + 2.07636374348553e-7*x_106 - 4.52145715681325e-6*x_107 + 4.93944887868627e-7*x_108 + 3.10581839213499e-6*x_109 - 2.19089851648195e-6*x_11 + 1.12646401592752e-6*x_110 + 2.69897574818235e-6*x_111 + 1.83516612129943e-6*x_112 + 5.36702005661077e-6*x_113 - 3.06262625166062e-6*x_114 - 1.6388211763104e-6*x_115 - 1.04786781562815e-6*x_116 + 2.41163716658908e-7*x_117 - 8.05106194759045e-7*x_118 + 3.95278964402173e-6*x_119 - 1.30504410954892e-6*x_12 + 8.78601744687722e-7*x_120 + 3.98380740969347e-7*x_13 - 1.28943212254791e-6*x_14 - 4.14396846063273e-7*x_15 - 2.10923170259147e-6*x_16 - 7.36571113147029e-7*x_17 + 8.34941244635331e-7*x_18 - 8.43222326435905e-8*x_19 + 1.73183779354545e-6*x_2 + 1.27343629482958e-6*x_20 - 1.12227952820718e-6*x_21 + 5.60700207470321e-8*x_22 + 1.4960330023553e-6*x_23 - 4.09764985077209e-6*x_24 - 2.18645763148873e-6*x_25 + 9.47711703330177e-7*x_26 + 1.02292413371241e-6*x_27 - 5.34430717096013e-7*x_28 + 2.52874148022067e-7*x_29 - 1.2101083400921e-6*x_3 - 1.74455900026387e-6*x_30 - 4.52837097081441e-5*x_31 - 7.53440000909466e-6*x_32 + 3.79198141385608e-6*x_33 + 8.46839899146981e-6*x_34 + 1.32677352237174e-6*x_35 + 8.27781899977902e-7*x_36 + 4.68248787820193e-6*x_37 + 2.56634255735397e-6*x_38 + 4.43669078791238e-6*x_39 - 8.46178478406506e-7*x_4 + 3.19349451196807e-6*x_40 - 1.51227785368131e-6*x_41 - 4.21998696241346e-6*x_42 + 6.09815820143261e-7*x_43 + 1.85648732933018e-6*x_44 - 3.2503466223237e-6*x_45 + 1.24937822042676e-7*x_46 + 7.83878739268237e-7*x_47 + 4.2642833846238e-6*x_48 - 2.57770591709805e-6*x_49 + 1.88650509461618e-6*x_5 + 2.60996234343372e-6*x_50 - 6.38798025316975e-6*x_51 + 6.11242700381534e-7*x_52 + 1.93247451537193e-6*x_53 + 3.59953290805796e-7*x_54 - 1.79457013399452e-6*x_55 - 4.36334150564061e-7*x_56 - 1.47827939344054e-6*x_57 + 1.56603783295038e-6*x_58 + 2.35789681427092e-6*x_59 - 5.77555636693489e-7*x_6 + 1.36874675112659e-6*x_60 + 2.98844416141716e-6*x_61 + 7.87454909384912e-6*x_62 + 7.4199110863331e-6*x_63 + 3.75025558979337e-6*x_64 + 4.16579011006358e-7*x_65 + 8.2759843324769e-7*x_66 + 7.51263099347661e-7*x_67 - 4.54339616000793e-6*x_68 - 9.91146301366839e-7*x_69 - 1.29856443103536e-6*x_7 + 2.00482892474657e-6*x_70 + 2.64578013532948e-6*x_71 - 1.31811314294007e-6*x_72 - 2.63976358895108e-6*x_73 + 2.85553131277424e-7*x_74 + 6.47859106850078e-7*x_75 + 9.76705924888874e-7*x_76 - 2.84435231543509e-7*x_77 + 9.51169139441088e-7*x_78 - 7.05558717898352e-7*x_79 + 2.12164290551602e-6*x_8 - 3.33993106928638e-7*x_80 + 1.49951877732319e-7*x_81 + 2.72186530969689e-6*x_82 - 2.99036297032683e-6*x_83 + 5.32204852455562e-7*x_84 + 1.12488760080924e-6*x_85 + 3.48153184306063e-7*x_86 + 2.51668368643402e-8*x_87 - 4.96183447172923e-7*x_88 - 7.00652984177875e-7*x_89 - 2.12144092118264e-6*x_9 - 1.16533699251596e-6*x_90 - 1.62750782134802e-5*x_91 + 1.84563908767055e-6*x_92 - 5.05631838497277e-7*x_93 - 3.63156832455035e-7*x_94 + 3.5991937846377e-6*x_95 - 9.39261351884465e-7*x_96 - 1.74228737987924e-6*x_97 + 5.28894711395478e-6*x_98 - 3.09969324351677e-6*x_99 + 4.03137452250966e-8*std::pow(-8.41960048675537*x_1 - 3.39759993553162, 2) + 4.87278189517074e-5*std::sin(0.329199850559235*x_1 + 4.60864019393921) + 8.81051875516514e-7*std::sin(0.329759836196899*x_35 + 5.16951990127563) + 3.37678948548426e-7*std::sin(0.453919857740402*x_94 - 7.36823987960815) + 2.48854975930211e-6*std::sin(0.463919848203659*x_97 - 7.37167978286743) + 0.0620729927367003);
}

inline float score_7(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (1.29291527538375e-6*x_1 + 9.09437280755102e-6*x_10 + 2.72640755901094e-6*x_100 + 3.67435899721855e-6*x_101 + 6.51861822652226e-8*x_102 - 2.2447400291684e-6*x_103 - 1.17811906159155e-7*x_104 + 2.78360837677911e-6*x_105 - 7.42545091967716e-7*x_106 - 3.12837782413206e-6*x_107 - 3.48110820826599e-6*x_108 + 2.69247054350467e-6*x_109 + 1.40574056730986e-6*x_11 - 1.65774033547345e-7*x_110 + 2.94616868030647e-6*x_111 - 9.65410405263992e-8*x_112 + 5.37512222250366e-6*x_113 + 2.90577050265308e-6*x_114 - 5.95807578313744e-7*x_115 + 6.99460101095247e-6*x_116 - 3.16014772124853e-7*x_117 - 3.43709164151476e-6*x_118 + 6.57633171846669e-6*x_119 - 8.52373861405619e-6*x_12 - 3.99232216391135e-6*x_120 - 3.32277833205136e-6*x_13 - 2.24408843776926e-6*x_14 + 2.08644887454255e-7*x_15 - 3.63377490430661e-6*x_16 + 2.30127891692671e-6*x_17 + 6.66666210740308e-6*x_18 - 2.21025378617651e-6*x_19 - 2.03282144643588e-7*x_2 + 3.10556411725845e-6*x_20 + 1.12209502645561e-6*x_21 + 7.03696523695863e-7*x_22 + 1.88380909304333e-6*x_23 - 1.829427532329e-6*x_24 - 2.53369194381737e-6*x_25 + 1.0013944085308e-6*x_26 - 2.68652452150254e-6*x_27 - 5.89789765933837e-7*x_28 + 2.13345686016152e-7*x_29 - 2.03597925803025e-6*x_3 + 1.0840920857548e-6*x_30 - 6.12520307855871e-5*x_31 - 4.15134931875789e-6*x_32 + 1.51777978773661e-5*x_33 + 1.38001485579139e-6*x_34 + 2.41717907488168e-6*x_35 - 2.15692417442093e-6*x_36 - 5.92755543517259e-6*x_37 + 3.31261073274751e-6*x_38 + 3.07345501490824e-6*x_39 - 1.27188240051187e-6*x_4 + 1.38970711701395e-6*x_40 + 3.24965141072917e-7*x_41 - 3.68648382968988e-6*x_42 + 6.80351461225123e-6*x_43 + 1.16946706189794e-6*x_44 + 1.2397840746553e-6*x_45 + 3.66295734086588e-7*x_46 - 4.93313744620582e-7*x_47 + 7.32514706868581e-6*x_48 - 2.09617402873853e-6*x_49 + 2.0465811177487e-6*x_5 - 1.0981696142308e-6*x_50 - 3.00942917933519e-6*x_51 + 2.82275545704832e-6*x_52 + 3.76094345394463e-6*x_53 + 5.15658790950475e-6*x_54 - 5.95103255772778e-7*x_55 + 5.87889263496918e-7*x_56 + 3.8934020537767e-8*x_57 - 5.79914843990721e-7*x_58 - 2.82389420113578e-6*x_59 - 2.11317314821659e-6*x_6 + 3.30609111340844e-6*x_60 + 5.29852974952297e-7*x_61 + 2.51117195652037e-6*x_62 - 1.80455244921255e-6*x_63 + 9.0131227552521e-7*x_64 + 2.47861827596449e-6*x_65 + 9.71468067545503e-7*x_66 + 2.9338114138167e-6*x_67 - 5.14593864265035e-6*x_68 - 6.84594043043806e-6*x_69 + 1.34780133753731e-7*x_7 - 3.60370470616866e-6*x_70 + 2.0902231176475e-6*x_71 - 4.3099633367611e-7*x_72 - 2.84010834571396e-6*x_73 + 5.58357724244325e-6*x_74 - 1.25052146020066e-6*x_75 - 1.62445773233929e-7*x_76 + 8.29977623440782e-7*x_77 + 4.78491192073866e-6*x_78 + 1.17384381089251e-6*x_79 - 3.23025800601973e-6*x_8 + 4.59979321765063e-7*x_80 - 4.08985861368833e-7*x_81 + 3.68520534955957e-6*x_82 - 3.56005954167947e-7*x_83 - 2.72530017307431e-7*x_84 + 1.40544091322783e-7*x_85 + 4.51464967827432e-7*x_86 + 6.4318357728001e-7*x_87 + 1.96295882857783e-6*x_88 + 1.84054216114988e-6*x_89 - 2.6887514826396e-6*x_9 - 4.70881793724381e-7*x_90 + 3.37831543492401e-5*x_91 + 2.90272852453782e-7*x_92 + 3.26117227442199e-7*x_93 + 5.59847483804487e-7*x_94 - 9.56576456206629e-6*x_95 + 4.53297927135085e-6*x_96 - 3.36965677004418e-6*x_97 + 6.41980906430669e-6*x_98 - 2.72035122391399e-6*x_99 + 4.54410369067579e-8*std::pow(-8.41960048675537*x_1 - 3.39759993553162, 2) + 0.000114497522701516*std::sin(0.329199850559235*x_1 + 4.60864019393921) - 1.24629800122617e-5*std::sin(0.329759836196899*x_35 + 5.16951990127563) - 4.77666083379414e-6*std::sin(0.453919857740402*x_94 - 7.36823987960815) + 1.66984211321645e-6*std::sin(0.463919848203659*x_97 - 7.37167978286743) + 0.0571823225766812);
}

inline float score_8(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (9.40148941497225e-6*x_1 + 4.80618662627475e-7*x_10 - 3.10439516005468e-7*x_100 - 2.48535337592812e-6*x_101 + 3.2633737157137e-6*x_102 + 1.50355614666374e-6*x_103 + 4.8194735491412e-6*x_104 + 4.25837385793707e-6*x_105 - 5.80047140178366e-7*x_106 - 1.00814161658577e-6*x_107 + 4.91659747592282e-6*x_108 - 1.55685048764375e-6*x_109 - 3.33450791254514e-6*x_11 - 1.45344131242551e-6*x_110 - 3.90634470543092e-6*x_111 + 2.94629603113502e-6*x_112 - 6.09417962178729e-6*x_113 - 6.34110216797257e-7*x_114 + 2.11522433376845e-6*x_115 - 6.06700903427495e-7*x_116 - 2.58600596846698e-6*x_117 - 2.38267808995123e-7*x_118 - 3.27222761041524e-7*x_119 - 7.43179251499682e-6*x_12 + 1.74096710844156e-6*x_120 + 2.78784054396603e-6*x_13 + 3.16352349601218e-6*x_14 - 1.37518348828697e-6*x_15 + 3.70401703659629e-6*x_16 + 1.86242346072164e-6*x_17 + 2.71788638504378e-6*x_18 + 3.33440281837942e-6*x_19 + 3.41981611981351e-6*x_2 + 1.0765216223642e-7*x_20 + 8.01984728799861e-8*x_21 - 2.00710360518156e-6*x_22 + 3.20381036665618e-6*x_23 - 2.47500826717231e-6*x_24 + 4.36489935880663e-6*x_25 - 7.90936018039723e-7*x_26 + 6.2675362614376e-6*x_27 + 5.1069107508064e-8*x_28 + 1.0034668075319e-6*x_29 - 1.9802669551455e-6*x_3 - 2.77840263679836e-6*x_30 - 9.0787189632668e-5*x_31 + 6.93324228073703e-7*x_32 - 7.14746389881272e-6*x_33 - 4.56409188041735e-6*x_34 - 1.98595171132546e-6*x_35 + 2.97887032602133e-6*x_36 + 1.79458418555973e-5*x_37 + 2.26944135772229e-6*x_38 + 2.53758842959227e-6*x_39 + 2.36662943736333e-7*x_4 + 1.56400544039453e-6*x_40 + 1.15344103108833e-6*x_41 + 1.23807919034117e-6*x_42 + 2.2519021582838e-6*x_43 - 1.60470737277775e-7*x_44 + 9.28819336011256e-6*x_45 - 8.37957129140427e-7*x_46 + 8.2611311233871e-7*x_47 + 5.32567802469366e-7*x_48 + 5.23126867259442e-7*x_49 + 5.45392329871055e-7*x_5 + 2.35745891955827e-6*x_50 - 6.42413865538404e-7*x_51 - 4.66432805958997e-7*x_52 + 3.7256855891498e-6*x_53 + 2.20332064970726e-6*x_54 + 5.87398813469303e-6*x_55 + 1.97659092437098e-6*x_56 + 9.91268511326847e-7*x_57 + 4.63758774618381e-8*x_58 - 2.45184259964958e-8*x_59 + 8.08049768151583e-7*x_6 + 4.06584890325865e-7*x_60 + 5.34686897771194e-6*x_61 + 1.68470038891762e-5*x_62 + 1.49329498568625e-5*x_63 + 1.13577549712976e-5*x_64 + 3.25094381843951e-8*x_65 + 6.11882573429489e-6*x_66 + 1.14631515814722e-6*x_67 - 3.18797219648572e-6*x_68 - 2.75221898926742e-6*x_69 + 2.93164200719105e-6*x_7 + 3.65989779319969e-6*x_70 - 1.08488440958723e-6*x_71 - 1.15767723686929e-6*x_72 + 2.13036192862194e-6*x_73 + 9.87993678331495e-7*x_74 - 7.68215639343144e-7*x_75 + 2.5145632967402e-6*x_76 - 4.07755693679239e-7*x_77 + 1.35668636644521e-6*x_78 + 1.74876308514621e-6*x_79 + 3.09189428208373e-6*x_8 + 5.83009790025586e-6*x_80 + 1.91475654308816e-6*x_81 + 2.34175617212261e-6*x_82 + 1.49318805565412e-7*x_83 + 2.9799754836447e-6*x_84 - 7.01860379822706e-7*x_85 + 3.41900125293693e-7*x_86 + 9.55865199485907e-7*x_87 + 3.42218499079905e-6*x_88 + 1.20901633527717e-6*x_89 - 1.05957392171889e-6*x_9 - 8.42239803601197e-7*x_90 - 2.10061587500654e-5*x_91 + 3.71663093039549e-6*x_92 + 9.24235184925505e-6*x_93 - 3.15057753333186e-7*x_94 + 2.56581244563256e-5*x_95 - 8.40307716606474e-7*x_96 + 1.361708231715e-6*x_97 - 7.53110777207854e-6*x_98 + 7.8531220659811e-6*x_99 - 1.78066619102581e-9*std::pow(-8.41960048675537*x_1 - 3.39759993553162, 2) - 0.00017900467893096*std::sin(0.329199850559235*x_1 + 4.60864019393921) + 4.04987852868291e-6*std::sin(0.329759836196899*x_35 + 5.16951990127563) + 1.55218865235689e-6*std::sin(0.453919857740402*x_94 - 7.36823987960815) + 9.53673487204173e-7*std::sin(0.463919848203659*x_97 - 7.37167978286743) + 0.0515247719759769);
}

inline float score_9(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-2.57313094130994e-5*x_1 + 6.37503455119885e-6*x_10 + 4.75722411314267e-6*x_100 - 4.2993664546161e-7*x_101 + 5.14948570282239e-6*x_102 + 2.35802343740468e-6*x_103 + 2.8755006283091e-6*x_104 - 1.46678762613801e-6*x_105 - 1.60516842376774e-6*x_106 + 5.2304622884287e-7*x_107 - 1.08099272635284e-6*x_108 - 3.78252051722705e-6*x_109 + 1.82943115996927e-7*x_11 - 2.46620000663265e-7*x_110 - 4.3063196932118e-6*x_111 - 1.98489470694666e-6*x_112 + 1.75709673725845e-8*x_113 + 2.5148776214253e-6*x_114 + 2.30362520924974e-6*x_115 + 5.45276489171797e-6*x_116 - 1.81743766892921e-6*x_117 - 1.28601590499615e-6*x_118 + 6.58592116062649e-6*x_119 + 6.35289031257177e-7*x_12 - 1.5271100942702e-5*x_120 + 1.22114652039468e-6*x_13 + 3.80645804280917e-7*x_14 + 8.64841486777173e-7*x_15 + 3.92524927844245e-6*x_16 + 4.54233037419422e-6*x_17 + 1.3775254910913e-6*x_18 - 1.51072136126429e-6*x_19 - 8.42776415566621e-7*x_2 + 3.87821397323541e-8*x_20 + 2.22084384711412e-6*x_21 + 1.14190810026693e-6*x_22 - 3.57340303122999e-7*x_23 + 3.15582705645631e-7*x_24 - 1.42768106830373e-6*x_25 - 2.58590900478955e-6*x_26 - 1.67726152782301e-6*x_27 + 2.6207382527559e-6*x_28 + 6.41089600136321e-7*x_29 - 2.06613061303263e-7*x_3 + 4.34291043934522e-6*x_30 - 1.17388034339355e-5*x_31 - 6.67373067939024e-6*x_32 - 4.93297555566052e-6*x_33 - 4.40624898442173e-5*x_34 + 3.25338588041162e-6*x_35 - 1.26959245125661e-6*x_36 - 9.20485954398483e-6*x_37 + 3.06409043516796e-6*x_38 + 2.54592284817559e-6*x_39 + 1.14381117039621e-6*x_4 - 2.90996613039879e-6*x_40 + 2.06237988637347e-6*x_41 + 1.85498145953605e-6*x_42 + 2.17500865580412e-6*x_43 + 3.15425989066334e-6*x_44 + 4.39381036217319e-6*x_45 - 2.1456142354879e-6*x_46 + 2.35579006951929e-6*x_47 + 1.22406041380328e-5*x_48 - 2.18584432551578e-6*x_49 + 8.83453347216216e-7*x_5 - 4.08146355278365e-6*x_50 + 5.08941471221821e-6*x_51 + 1.63930573417019e-6*x_52 + 7.58699656762114e-7*x_53 + 4.62639964461305e-6*x_54 + 4.17918099592993e-7*x_55 + 4.51602773181775e-7*x_56 + 4.81048474069624e-7*x_57 - 8.08495299927696e-7*x_58 - 3.06610315363484e-6*x_59 - 1.73275484297744e-6*x_6 + 2.55897197687752e-6*x_60 - 3.2754801721357e-6*x_61 - 3.95566722436939e-6*x_62 - 1.03661890852208e-5*x_63 - 1.30477563974193e-6*x_64 - 4.40703977703566e-6*x_65 + 9.3685733627516e-7*x_66 - 8.32233110761638e-7*x_67 - 4.04428020567535e-6*x_68 - 3.8880454008096e-7*x_69 + 2.26186096000498e-6*x_7 - 1.49799989434121e-5*x_70 + 1.43565623886154e-6*x_71 + 8.70280151010119e-7*x_72 - 8.09453792766828e-8*x_73 + 5.05910801412324e-6*x_74 - 2.17981162746443e-6*x_75 - 2.04812724136386e-6*x_76 - 4.89533874897449e-7*x_77 + 4.43854625265637e-6*x_78 + 2.75109563146307e-6*x_79 + 1.01773309059148e-5*x_8 + 2.94769062065268e-6*x_80 - 1.16578536022954e-7*x_81 + 1.22530716532194e-6*x_82 + 4.57086678998703e-6*x_83 - 5.80071424446855e-7*x_84 + 1.18197667235662e-6*x_85 + 7.97178988674241e-7*x_86 - 2.04633725176788e-7*x_87 - 2.04505862489797e-6*x_88 - 5.68946299803577e-7*x_89 + 1.79763654538683e-7*x_9 - 4.22528321635021e-7*x_90 + 6.20629666122481e-5*x_91 + 3.32877245470588e-6*x_92 - 5.25113966632528e-6*x_93 + 2.39269705904962e-6*x_94 - 9.05706768667029e-6*x_95 + 1.45530875802678e-6*x_96 + 1.29841281274699e-6*x_97 - 3.72354164559692e-6*x_98 - 1.49470439641149e-6*x_99 + 7.51866122864407e-8*std::pow(-8.41960048675537*x_1 - 3.39759993553162, 2) + 6.40801723379844e-5*std::sin(0.329199850559235*x_1 + 4.60864019393921) - 4.670402208848e-5*std::sin(0.329759836196899*x_35 + 5.16951990127563) - 1.79001549285332e-5*std::sin(0.453919857740402*x_94 - 7.36823987960815) + 5.04055196413037e-7*std::sin(0.463919848203659*x_97 - 7.37167978286743) + 0.0738051625645807);
}

inline float score_10(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (1.13203769733849e-6*x_1 + 1.57300281704817e-6*x_10 - 3.44667284935582e-6*x_100 - 2.35834875584442e-6*x_101 + 7.07298623253118e-7*x_102 - 1.70768837342643e-6*x_103 + 1.86248464285755e-6*x_104 + 3.80833898532345e-7*x_105 + 1.95742327201485e-6*x_106 - 1.07825794573055e-6*x_107 + 3.7478308709755e-6*x_108 - 1.80723895172042e-9*x_109 + 6.93057153058501e-7*x_11 + 1.09915668473112e-6*x_110 + 7.96918094997047e-7*x_111 + 3.17842709394297e-6*x_112 - 2.02613356455046e-6*x_113 - 4.90718875577366e-6*x_114 + 3.98473983290177e-6*x_115 - 1.63263041994715e-6*x_116 + 1.47633889540924e-7*x_117 + 2.61948356007983e-6*x_118 - 3.82399158782462e-6*x_119 - 9.59076966247703e-7*x_12 - 1.45409259678994e-6*x_120 + 2.18964981996516e-6*x_13 + 1.11665394974837e-6*x_14 + 3.26882575493472e-7*x_15 + 1.3418885059215e-6*x_16 + 2.91103710464997e-8*x_17 - 4.94652265900089e-7*x_18 + 1.1672487983023e-6*x_19 + 4.91088582988177e-6*x_2 + 1.14874258435583e-7*x_20 - 1.10502948789014e-6*x_21 - 1.75211791413421e-6*x_22 + 1.4386509982488e-6*x_23 - 3.88364149888962e-7*x_24 + 6.58766703328466e-7*x_25 + 3.27741216787617e-7*x_26 + 1.54205605116368e-6*x_27 + 2.10686232977209e-6*x_28 + 2.21804057030972e-6*x_29 - 2.29271642134678e-6*x_3 + 2.12160754321513e-7*x_30 - 7.96997498610036e-6*x_31 + 6.24960316413392e-6*x_32 - 5.52165202380988e-6*x_33 + 3.335623771066e-6*x_34 - 3.45494716561565e-8*x_35 + 3.34406221399496e-6*x_36 + 5.60361466624387e-6*x_37 - 7.67914319603291e-8*x_38 + 1.14769912184021e-6*x_39 - 7.45095010302812e-7*x_4 - 3.39657486806319e-7*x_40 + 5.40862036851311e-7*x_41 + 1.88678889342663e-6*x_42 - 7.22879267216884e-7*x_43 - 2.21595883918437e-7*x_44 + 6.08372082591451e-6*x_45 + 1.6059010011985e-6*x_46 - 1.21939531646477e-6*x_47 + 3.30973507677622e-6*x_48 - 2.12999588381538e-6*x_49 + 8.17824501689087e-7*x_5 - 1.20528454959041e-6*x_50 - 1.92481723162257e-6*x_51 - 1.9626030479044e-6*x_52 + 6.29440185371007e-7*x_53 + 6.1312924456735e-6*x_54 + 2.31074160784252e-6*x_55 - 1.86779878507861e-8*x_56 - 8.2581256138555e-7*x_57 + 1.4594277172934e-6*x_58 - 2.50732950357726e-6*x_59 + 3.07048031819723e-7*x_6 + 2.51463816491031e-6*x_60 - 1.11481006882221e-6*x_61 + 7.85591791950219e-6*x_62 + 6.07142683044512e-6*x_63 + 3.53508853519907e-6*x_64 + 3.50132790898059e-6*x_65 + 6.15903954092723e-7*x_66 - 2.16689190243964e-6*x_67 - 2.43057455496975e-6*x_68 + 1.1964324527988e-6*x_69 + 2.76737730064976e-6*x_7 - 1.38813912234217e-7*x_70 + 1.40095664430208e-6*x_71 - 1.03898001082091e-6*x_72 - 3.76048177885077e-7*x_73 - 4.10512736119753e-7*x_74 + 2.61199100821996e-7*x_75 + 1.02343139812958e-6*x_76 + 1.91679703572267e-7*x_77 - 1.7650367955481e-6*x_78 + 2.66219303075702e-6*x_79 + 1.17912572766009e-6*x_8 + 1.86613252244447e-6*x_80 + 5.8128731437497e-7*x_81 - 2.41137588704988e-6*x_82 + 2.03753088910199e-6*x_83 + 2.73468075533974e-6*x_84 - 1.87010881873075e-6*x_85 + 1.27430661978296e-6*x_86 - 1.01964576659251e-7*x_87 + 2.85890543097824e-7*x_88 + 3.55424176326658e-6*x_89 + 3.88045822522908e-7*x_9 - 6.00707849354064e-7*x_90 - 2.47691524327207e-5*x_91 + 2.21586220156972e-7*x_92 + 1.63662999387416e-6*x_93 + 1.21508220667312e-6*x_94 + 1.62435124297628e-5*x_95 - 4.19392294824905e-6*x_96 + 2.31044544988063e-6*x_97 - 8.015195542844e-7*x_98 + 3.05994323355274e-6*x_99 - 4.00169952953836e-9*std::pow(-8.41960048675537*x_1 - 3.39759993553162, 2) - 1.140240769351e-5*std::sin(0.329199850559235*x_1 + 4.60864019393921) + 1.42023884510168e-6*std::sin(0.329759836196899*x_35 + 5.16951990127563) + 5.44332034501842e-7*std::sin(0.453919857740402*x_94 - 7.36823987960815) + 4.27343407981008e-7*std::sin(0.463919848203659*x_97 - 7.37167978286743) + 0.0699597653700747);
}

inline float score_11(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-1.92801432326168e-6*x_1 - 3.28192876602115e-6*x_10 + 3.64482336060786e-6*x_100 + 6.64231102226851e-8*x_101 + 1.71672988829899e-6*x_102 + 1.74871693725403e-6*x_103 + 1.54810264992791e-6*x_104 - 3.18772247205649e-7*x_105 - 3.3074929480597e-6*x_106 - 1.45542982167713e-6*x_107 - 2.91781887513991e-6*x_108 - 1.11932080641523e-6*x_109 - 1.28834548621465e-6*x_11 - 1.36214906648413e-6*x_110 - 2.34017875374023e-6*x_111 + 1.44571200116991e-6*x_112 - 3.40434107377226e-6*x_113 + 1.08675350998227e-6*x_114 - 4.34027253896831e-6*x_115 - 1.22512822387483e-6*x_116 - 2.27741524015984e-6*x_117 - 3.28870527177459e-6*x_118 + 1.0026654921231e-6*x_119 - 1.71242376364912e-6*x_12 + 4.4302724232736e-6*x_120 - 1.20373098802992e-6*x_13 - 2.42966001954028e-6*x_14 - 3.05107030017549e-6*x_15 - 3.78216265887325e-7*x_16 - 3.67509001605694e-7*x_17 - 4.85360601340713e-7*x_18 + 9.55858431681856e-7*x_19 - 3.61091825821392e-6*x_2 + 1.03085136845087e-7*x_20 - 2.1758961938355e-6*x_21 + 2.14340010481415e-6*x_22 + 1.46812919804541e-6*x_23 - 4.05255810902596e-6*x_24 + 2.6415134005774e-7*x_25 - 6.44392373710929e-7*x_26 + 5.69329662388701e-7*x_27 + 1.2267208581457e-6*x_28 - 1.77483752005251e-6*x_29 + 3.88202574992244e-7*x_3 - 1.21473167542918e-6*x_30 - 2.14819909950055e-5*x_31 - 1.28750537978381e-5*x_32 + 6.11920769424699e-6*x_33 - 6.93784296527983e-6*x_34 + 2.50702784580076e-6*x_35 - 5.76494274177325e-7*x_36 + 1.15721079035573e-5*x_37 - 8.2076948482408e-7*x_38 + 8.76030160560265e-7*x_39 + 9.05581059461422e-7*x_4 + 2.44562012530789e-6*x_40 - 8.31659081099079e-7*x_41 - 5.06914874296022e-7*x_42 - 5.9237427683212e-7*x_43 - 7.5580401202212e-7*x_44 - 4.82659968379952e-6*x_45 - 2.83539997815263e-6*x_46 + 3.53251095723861e-6*x_47 + 1.9718587228627e-6*x_48 + 1.30625186269554e-6*x_49 - 1.47014089715379e-7*x_5 - 2.56212345190298e-7*x_50 + 6.40364059064825e-7*x_51 + 3.1161858831061e-6*x_52 - 6.370553062814e-7*x_53 - 7.80533704803105e-6*x_54 - 1.17597089154866e-6*x_55 - 2.11983702939249e-6*x_56 + 1.51814394277914e-7*x_57 - 2.76592145860554e-6*x_58 + 2.50927079985337e-6*x_59 + 1.15074123967833e-7*x_6 - 2.85796290563919e-6*x_60 + 9.62516269463484e-6*x_61 + 6.13611887453873e-6*x_62 + 7.98175754584603e-6*x_63 + 6.90386770586878e-6*x_64 - 1.77887933935431e-6*x_65 - 3.54405548727966e-8*x_66 + 2.21682477983301e-6*x_67 - 1.4398457769154e-6*x_68 - 5.17376896725214e-7*x_69 - 1.81293092328446e-6*x_7 + 1.35844335885452e-6*x_70 - 3.39112654774258e-6*x_71 - 6.6940940591043e-7*x_72 + 2.15730207717047e-6*x_73 + 4.24809219068365e-7*x_74 + 2.47654198604066e-7*x_75 + 3.84419465736413e-7*x_76 - 1.04153687121832e-6*x_77 + 2.66541296000613e-6*x_78 - 7.77700122990342e-7*x_79 + 1.144151623793e-6*x_8 + 2.82325202589187e-6*x_80 + 1.96150815285861e-6*x_81 + 6.11239709929074e-7*x_82 - 1.92595874763908e-6*x_83 - 3.15466376948295e-6*x_84 + 1.13483566746064e-6*x_85 + 1.97267319616062e-6*x_86 + 2.29082353802771e-7*x_87 - 7.51206606364173e-8*x_88 - 3.11521496133014e-6*x_89 - 8.00763018334635e-7*x_9 + 1.10361407836878e-6*x_90 - 8.01769907602088e-6*x_91 + 2.84699657411692e-6*x_92 + 2.64927600601396e-6*x_93 - 3.18481299231859e-6*x_94 - 1.7232320333782e-5*x_95 + 2.47498991061882e-6*x_96 + 1.10106300752468e-6*x_97 + 1.21378860573651e-6*x_98 - 1.93541698457885e-6*x_99 + 7.29200847553656e-8*std::pow(-8.41960048675537*x_1 - 3.39759993553162, 2) - 9.61685183184018e-5*std::sin(0.329199850559235*x_1 + 4.60864019393921) - 2.84935124974233e-6*std::sin(0.329759836196899*x_35 + 5.16951990127563) - 1.09206502000131e-6*std::sin(0.453919857740402*x_94 - 7.36823987960815) + 1.1273768333348e-6*std::sin(0.463919848203659*x_97 - 7.37167978286743) + 0.0566359679784394);
}

int predict(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120)
{
    float s0 = score_0(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s1 = score_1(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s2 = score_2(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s3 = score_3(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s4 = score_4(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s5 = score_5(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s6 = score_6(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s7 = score_7(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s8 = score_8(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s9 = score_9(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s10 = score_10(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s11 = score_11(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);

    float max_score = s0;
    int max_index = 0;

    if(s1 > max_score) {
        max_score = s1;
        max_index = 1;
    }

    if(s2 > max_score) {
        max_score = s2;
        max_index = 2;
    }

    if(s3 > max_score) {
        max_score = s3;
        max_index = 3;
    }

    if(s4 > max_score) {
        max_score = s4;
        max_index = 4;
    }

    if(s5 > max_score) {
        max_score = s5;
        max_index = 5;
    }

    if(s6 > max_score) {
        max_score = s6;
        max_index = 6;
    }

    if(s7 > max_score) {
        max_score = s7;
        max_index = 7;
    }

    if(s8 > max_score) {
        max_score = s8;
        max_index = 8;
    }

    if(s9 > max_score) {
        max_score = s9;
        max_index = 9;
    }

    if(s10 > max_score) {
        max_score = s10;
        max_index = 10;
    }

    if(s11 > max_score) {
        max_score = s11;
        max_index = 11;
    }

    return max_index;
}

#endif
