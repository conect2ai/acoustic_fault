
#ifndef KAN_MODEL_H
#define KAN_MODEL_H

#include <cmath>


inline float score_0(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.000431871025819879*x_1 + 9.92420962524464e-5*x_10 - 0.000269076525467124*x_100 - 0.000192107585019905*x_101 + 1.02071156802845e-5*x_102 - 0.000258913330250537*x_103 - 5.97231699079789e-5*x_104 + 0.000370180746271725*x_105 + 9.30158257427168e-5*x_106 - 0.000102403232272912*x_107 + 0.000246153960393708*x_108 - 0.000244645823612705*x_109 - 0.00070581248602325*x_11 - 0.000118744235667604*x_110 - 1.26331743988391e-5*x_111 + 0.000616369246192041*x_112 - 0.000424987167744894*x_113 - 0.000951653950621633*x_114 - 2.96840765830542e-5*x_115 - 0.000157328759695751*x_116 - 0.00175593787736751*x_117 - 0.000430217505327217*x_118 + 0.000288382788674146*x_119 + 0.000556483178852597*x_12 + 0.00162714174498223*x_120 + 0.000705849108434317*x_13 + 0.000101030047823509*x_14 - 9.43338891644305e-5*x_15 - 4.50828363487319e-5*x_16 - 0.000101022410764116*x_17 - 0.000459371215199879*x_18 - 6.23959936451236e-5*x_19 - 5.66702150853284e-5*x_2 + 0.000240522785144105*x_20 + 0.00131263795804664*x_21 - 0.000844518684565127*x_22 - 7.20099120100839e-5*x_23 - 7.91511421581127e-6*x_24 + 0.0002129847303686*x_25 + 0.000549129804917941*x_26 - 0.000467872078203471*x_27 + 1.18909181735816e-5*x_28 + 0.000159106046578536*x_29 - 3.68126697987708e-6*x_3 - 0.00132585251063707*x_30 - 0.000261599181435333*x_31 + 5.98016610556142e-5*x_32 + 0.000334305460803572*x_33 + 0.000497040077567569*x_34 + 0.00032445401441937*x_35 + 0.000148630401707757*x_36 - 4.31028989859579e-6*x_37 - 0.000104775769810718*x_38 + 0.000148380470821221*x_39 + 0.000114257454768906*x_4 - 0.00023700131881887*x_40 - 0.00027067296839853*x_41 + 0.000179060579124966*x_42 - 3.91626097656765e-6*x_43 - 4.08078455256637e-5*x_44 + 0.000445278777534138*x_45 + 0.000197606159426813*x_46 - 0.000357299313774587*x_47 - 0.000922718126375721*x_48 + 0.000501187599828415*x_49 + 2.09561034917823e-5*x_5 + 8.88240672387865e-5*x_50 + 0.000837051568198263*x_51 + 1.68771680691942e-5*x_52 - 0.000597653477417524*x_53 - 0.00089724466693265*x_54 + 0.000470220817131142*x_55 + 0.00030986590698823*x_56 - 0.000128520915845404*x_57 - 0.000180529496584658*x_58 - 0.00073913749529276*x_59 - 0.00125101275510765*x_6 - 0.000398007091615714*x_60 - 0.000110837095227954*x_61 - 0.000105177288186633*x_62 - 1.07400407221095e-5*x_63 + 0.000106689080966424*x_64 + 8.47439148615026e-5*x_65 - 5.81651842163228e-5*x_66 - 0.000172084255097847*x_67 + 0.000226586934735963*x_68 - 0.000312590649878241*x_69 - 0.000104732789865456*x_7 + 4.5237124075302e-5*x_70 - 9.89757173547733e-5*x_71 - 0.000164839639041025*x_72 - 3.66367150636262e-5*x_73 - 7.18009900575221e-5*x_74 + 0.000232161222224053*x_75 + 5.65161842793101e-5*x_76 + 3.94597111540658e-5*x_77 + 0.000210724151392521*x_78 + 0.000258111327526204*x_79 + 1.49875247345314e-5*x_8 + 0.000216838341691669*x_80 - 0.000162912032949573*x_81 + 7.5045157839401e-5*x_82 + 0.000193720125000333*x_83 - 9.30930816741439e-5*x_84 - 1.25037807795834e-5*x_85 - 0.000166177436578225*x_86 + 2.86038672715759e-5*x_87 + 0.000108387263334269*x_88 + 0.000202689005813874*x_89 - 4.42126480819336e-5*x_9 + 0.000197988930099774*x_90 - 0.000270475983839282*x_91 - 0.00017700999275894*x_92 + 0.000810197624972797*x_93 + 0.00041171510353817*x_94 + 0.000440045397043747*x_95 + 3.49941966227648e-5*x_96 - 0.000572748267313873*x_97 + 0.000241729075179953*x_98 + 0.000203880794807618*x_99 + 6.44432030196734e-6*std::pow(-3.11615991592407*x_28 - 7.80615997314453, 2) - 2.63519966231152e-7*std::pow(-4.07271957397461*x_64 - 9.9672794342041, 2) - 1.71284737194145e-7*std::pow(-4.70783948898315*x_8 - 6.14423990249634, 2) + 7.12999917806471e-5*std::exp(0.183999866247177*x_10) - 0.000125416837708966*std::sin(0.212719991803169*x_1 + 5.01215982437134) + 0.000886174470107325*std::sin(0.246879979968071*x_1 - 7.55592012405396) - 0.00619861827227472*std::sin(0.270639955997467*x_1 + 5.06863975524902) - 0.000657904971873714*std::sin(0.309119910001755*x_1 + 5.12335968017578) - 0.00339265321753202*std::sin(0.326159834861755*x_1 + 8.32335948944092) - 0.00125437548083982*std::sin(0.333519846200943*x_1 - 4.24272012710571) + 0.0154937985562112*std::sin(0.334079831838608*x_1 - 4.24832010269165) + 0.00684568782180669*std::sin(0.345999836921692*x_1 - 4.23943996429443) + 0.00102935399900037*std::sin(0.352639853954315*x_1 - 4.22119998931885) + 0.000795756710809259*std::sin(0.366159856319427*x_1 + 8.36544036865234) + 0.000381104166628067*std::sin(0.669359803199768*x_1 + 2.20183968544006) + 0.000711857123129932*std::sin(0.329439848661423*x_10 + 5.07223987579346) - 0.000302681719638835*std::sin(0.22503998875618*x_100 - 4.40079975128174) - 0.000125380354964917*std::sin(0.246639966964722*x_100 + 1.96799981594086) + 0.00138242779904018*std::sin(0.257359951734543*x_107 - 7.44687986373901) + 0.000178953224685647*std::sin(0.244079977273941*x_11 + 1.96719980239868) + 0.00405830599166162*std::sin(0.256879955530167*x_11 + 5.17695999145508) + 0.00804706956587985*std::sin(0.26895996928215*x_11 - 7.42095994949341) - 0.0144940863996364*std::sin(0.280799955129623*x_113 - 7.41103982925415) + 0.00222640716962225*std::sin(0.288559943437576*x_113 - 7.43031978607178) + 0.000518272992931219*std::sin(0.236719980835915*x_116 + 1.98751986026764) + 0.00205454193196653*std::sin(0.247999966144562*x_116 - 7.43703985214233) - 0.00255722523964434*std::sin(0.257119953632355*x_116 - 4.40911960601807) - 0.0127739742027612*std::sin(0.236159980297089*x_119 + 5.174880027771) + 0.0025144588049681*std::sin(0.282719939947128*x_12 - 4.24959993362427) + 0.00373345663047929*std::sin(0.305519938468933*x_12 - 7.46560001373291) - 0.00200347477416873*std::sin(0.243599981069565*x_120 - 4.21704006195068) + 0.0175234071228117*std::sin(0.259839981794357*x_120 - 4.24631977081299) + 0.00287890542292248*std::sin(0.262159943580627*x_120 + 5.16527986526489) - 0.000421571201922575*std::sin(0.264319956302643*x_120 + 5.15952014923096) - 0.0099572758986202*std::sin(0.268479973077774*x_120 + 5.15248012542725) - 0.00241705504335076*std::sin(0.208000004291534*x_13 + 5.20496034622192) + 0.00276014965874073*std::sin(0.265359938144684*x_13 - 4.39911985397339) + 0.000779143870469647*std::sin(0.288719952106476*x_14 - 4.24064016342163) - 8.68976444769647e-5*std::sin(0.290559947490692*x_14 + 4.80288028717041) + 0.00403859043844146*std::sin(0.294959932565689*x_14 - 4.25464010238647) + 0.00115041283446115*std::sin(0.297279924154282*x_14 + 4.98759984970093) + 0.00156716025964532*std::sin(0.318319916725159*x_14 + 5.12160015106201) + 0.00210089271539887*std::sin(0.33247983455658*x_14 + 1.86767983436584) - 0.000476694972628056*std::sin(0.460639864206314*x_14 + 7.76711988449097) - 0.000258687449819154*std::sin(0.198239997029305*x_15 + 8.19207954406738) + 0.0072252796870832*std::sin(0.269839942455292*x_15 + 1.99335980415344) - 0.00462981699844758*std::sin(0.321759909391403*x_15 - 7.44143962860107) - 0.00801106204753161*std::sin(0.253999978303909*x_16 - 7.39783954620361) + 0.000657366425086516*std::sin(0.350239843130112*x_16 - 1.15351986885071) - 0.00451809921147456*std::sin(0.356159836053848*x_16 - 1.14495992660522) - 6.00364483436543e-5*std::sin(0.689119875431061*x_16 - 7.84295988082886) + 0.00154037297870353*std::sin(0.332639843225479*x_17 - 1.1490398645401) + 0.0110473548017946*std::sin(0.352479845285416*x_17 + 2.00735974311829) + 0.000180284905814116*std::sin(0.398319840431213*x_17 + 1.99095976352692) - 0.00268469783981413*std::sin(0.272399961948395*x_18 - 1.17335987091064) + 0.00641219726459921*std::sin(0.276239961385727*x_18 - 1.16479980945587) + 0.00319341201778749*std::sin(0.280479967594147*x_18 + 2.00055980682373) - 0.00186534391568263*std::sin(0.344239860773087*x_18 - 1.15015983581543) + 0.00042830719938022*std::sin(0.367839843034744*x_18 + 1.99519979953766) - 0.000822466014915173*std::sin(0.384639829397202*x_18 + 2.00191974639893) - 0.000477224746735418*std::sin(0.393519848585129*x_18 + 5.18936014175415) - 0.00695181669780618*std::sin(0.292719930410385*x_19 + 1.98071980476379) + 0.000291705094627583*std::sin(0.373119831085205*x_2 - 7.39439964294434) - 0.0138290873914881*std::sin(0.378239840269089*x_2 + 5.18455982208252) - 0.00768157508997946*std::sin(0.387199848890305*x_2 + 5.19736003875732) - 0.00309463674961653*std::sin(0.392479836940765*x_2 + 5.19144010543823) - 0.0148729763448212*std::sin(0.393279850482941*x_2 + 5.18304014205933) + 0.00113463448642945*std::sin(0.264879941940308*x_20 - 1.16751992702484) - 0.000123838967931569*std::sin(0.311919927597046*x_20 + 8.18335914611816) + 8.57784017395575e-5*std::sin(0.396639823913574*x_20 - 4.40351963043213) - 2.90652315629354e-5*std::sin(0.779839873313904*x_20 - 1.36743986606598) - 0.00558927966176795*std::sin(0.262959957122803*x_21 - 7.38935995101929) + 0.000476859490306374*std::sin(0.459439843893051*x_21 - 7.62784004211426) - 0.00611896404802579*std::sin(0.298159927129745*x_23 - 4.34663963317871) + 0.00105055875604311*std::sin(0.310159921646118*x_23 + 8.23967933654785) + 0.00619561502779703*std::sin(0.341519832611084*x_23 + 1.9962397813797) - 0.00510088859604654*std::sin(0.346639841794968*x_23 - 1.15591979026794) + 0.000192655762980341*std::sin(0.368399828672409*x_23 + 2.02231979370117) - 0.000586934711038859*std::sin(0.238879978656769*x_24 - 1.17855989933014) - 0.00205453064697851*std::sin(0.247199967503548*x_25 - 4.38279962539673) - 0.0042255913771718*std::sin(0.333119839429855*x_25 - 1.13919985294342) + 0.00150596800991337*std::sin(0.348159849643707*x_25 + 8.23272037506104) - 0.00244644747332128*std::sin(0.384799838066101*x_25 + 8.20487976074219) - 0.00020505221426124*std::sin(0.141840040683746*x_26 - 1.25295984745026) + 0.00606080785755742*std::sin(0.283519923686981*x_26 - 1.17279982566833) + 0.000953571799079897*std::sin(0.353679865598679*x_26 + 5.01056003570557) + 0.00223062919068838*std::sin(0.1891999989748*x_27 + 8.18383979797363) + 0.00100921978442515*std::sin(0.226879984140396*x_27 + 5.00183963775635) + 0.000383616947473437*std::sin(0.698799848556519*x_27 + 5.2292799949646) + 0.00079560220559316*std::sin(0.308639913797379*x_28 + 1.9936797618866) + 0.00022652805755597*std::sin(0.410879880189896*x_28 + 8.20399951934814) + 0.00448177095698307*std::sin(0.29079994559288*x_29 - 1.16375982761383) - 0.000905562418843594*std::sin(0.267839968204498*x_3 - 4.3551197052002) - 0.00662101633733036*std::sin(0.324559837579727*x_3 - 7.40367984771729) - 0.00197377438985785*std::sin(0.357199847698212*x_3 - 7.38823986053467) - 0.00170009833594984*std::sin(0.36287984251976*x_3 - 7.39383983612061) - 0.00696058273379488*std::sin(0.365039855241776*x_3 - 7.41415977478027) - 0.00832590607234024*std::sin(0.370799839496613*x_3 - 7.40367984771729) - 3.68852179731781e-5*std::sin(0.385759830474854*x_3 + 1.99527978897095) + 8.54995741508129e-5*std::sin(0.39183983206749*x_3 + 1.99183976650238) - 4.90902937906807e-5*std::sin(0.449039846658707*x_3 + 8.18967914581299) - 0.0356190047440357*std::sin(0.191760003566742*x_30 + 8.18335914611816) + 0.00777773752199549*std::sin(0.304079920053482*x_30 + 1.99335980415344) + 0.00191841173578329*std::sin(0.389519840478897*x_30 + 2.00319981575012) + 0.00260002915654303*std::sin(0.390079855918884*x_30 + 1.99391984939575) - 0.00026531075123215*std::sin(0.342559844255447*x_31 - 7.44663953781128) - 0.00364701019334658*std::sin(0.367919832468033*x_31 + 5.17503976821899) + 0.00117309903482015*std::sin(0.369759827852249*x_31 + 5.17216014862061) + 0.00320281674265156*std::sin(0.370159834623337*x_31 + 5.17727994918823) - 0.000945465816085195*std::sin(0.377839833498001*x_31 - 7.40151977539063) - 0.0351379734120535*std::sin(0.380639851093292*x_31 - 7.39687967300415) - 0.00162090986965826*std::sin(0.380719840526581*x_31 - 7.39687967300415) + 0.00191757256382767*std::sin(0.423199862241745*x_31 + 5.21799993515015) - 0.000652893918701138*std::sin(0.263039946556091*x_32 + 5.23415994644165) - 0.000217196970082941*std::sin(0.294079929590225*x_32 - 4.36799955368042) - 0.0155266989900164*std::sin(0.30991992354393*x_32 - 1.14351987838745) + 0.000543302953239632*std::sin(0.310159921646118*x_32 - 1.14815986156464) + 0.00143315222151453*std::sin(0.32847985625267*x_32 + 1.99999976158142) - 0.00722928628022907*std::sin(0.241039976477623*x_33 + 1.99663984775543) - 2.7405915646998e-5*std::sin(0.245679974555969*x_36 + 1.78207981586456) - 0.00899714918500748*std::sin(0.317439913749695*x_4 - 1.14063990116119) + 0.000553253526399171*std::sin(0.530719876289368*x_44 + 5.1005597114563) - 0.000194257851628468*std::sin(0.635519862174988*x_45 - 1.40887975692749) + 0.00499588458441722*std::sin(0.338719844818115*x_5 + 2.01407980918884) + 0.00145982308404552*std::sin(0.339759826660156*x_5 + 2.00815987586975) - 0.00853529793642926*std::sin(0.351199835538864*x_5 + 2.00807976722717) + 0.00296418799305744*std::sin(0.210960000753403*x_56 - 1.01687979698181) + 0.00123112275336276*std::sin(0.217439994215965*x_56 - 7.39751958847046) - 4.53144853415318e-5*std::sin(0.247839972376823*x_56 - 7.42392015457153) - 6.13158868952727e-5*std::sin(0.274239957332611*x_57 - 7.45928001403809) + 0.00016181461935157*std::sin(0.299679934978485*x_6 + 5.21031999588013) - 0.00341184261736235*std::sin(0.314479917287827*x_6 + 2.01639986038208) - 0.00917848057806396*std::sin(0.352959841489792*x_6 + 2.014399766922) - 0.000623936541480956*std::sin(0.573599874973297*x_6 - 7.57480001449585) - 0.000934589843599162*std::sin(0.444079846143723*x_60 + 5.10624027252197) - 0.00680338344929304*std::sin(0.334399849176407*x_7 - 1.14743983745575) + 0.00145979843626974*std::sin(0.339119851589203*x_7 - 1.15287983417511) + 0.00543849817646915*std::sin(0.340719848871231*x_7 - 1.14399981498718) + 0.0101632871388296*std::sin(0.344799846410751*x_7 + 2.02967977523804) - 0.0104718931567631*std::sin(0.345839858055115*x_7 - 1.14471983909607) + 0.000144921544589549*std::sin(0.346959829330444*x_7 - 7.36223983764648) - 0.00254554483027611*std::sin(0.348799854516983*x_7 + 2.01079988479614) + 0.000517963009726728*std::sin(0.349759846925735*x_7 - 1.15015983581543) - 2.24943457468214e-5*std::sin(0.97055983543396*x_72 + 8.38920021057129) + 0.00023255413266443*std::sin(0.266479969024658*x_8 - 7.40127992630005) - 0.00912237778944733*std::sin(0.313199937343597*x_8 - 7.42335987091064) - 8.78246435730232e-5*std::sin(0.326239854097366*x_8 + 8.24759960174561) + 0.000432011252816882*std::sin(0.334319829940796*x_8 - 7.55656003952026) - 0.0034156908583607*std::sin(0.363439828157425*x_8 + 5.01847982406616) + 0.000410184600762529*std::sin(0.405199855566025*x_8 + 4.79080009460449) + 7.89602387455143e-5*std::sin(0.206080004572868*x_9 - 7.41024017333984) - 0.00189637313375126*std::sin(0.404639840126038*x_9 - 4.38887977600098) - 0.00213693691759259*std::sin(0.339599847793579*x_91 + 2.00343990325928) + 0.00620433249245189*std::sin(0.358399868011475*x_91 + 1.99927973747253) - 0.00200195682615548*std::sin(0.377519845962524*x_91 + 1.9975198507309) + 0.00275033408819289*std::sin(0.379759848117828*x_91 + 1.99135982990265) + 8.41524250161074e-5*std::sin(0.424319863319397*x_91 + 5.00743961334229) - 0.000228059758439283*std::sin(0.215199992060661*x_92 + 1.98735988140106) + 0.00318346549682885*std::sin(0.255759954452515*x_92 + 1.99335980415344) - 0.0155147820124761*std::sin(0.292079925537109*x_92 + 2.01063990592957) - 0.00242678992469923*std::sin(0.293359935283661*x_92 + 1.99031984806061) + 0.000951732608089384*std::sin(0.293599933385849*x_92 - 7.38927984237671) + 0.000248266963833985*std::sin(0.309599906206131*x_92 - 4.39079999923706) - 0.000125588314838185*std::sin(0.225439995527267*x_93 - 1.1833598613739) - 0.000348805410171239*std::sin(0.281519949436188*x_94 - 7.42119979858398) - 3.3073871210929e-5*std::sin(0.310239940881729*x_97 - 1.41639983654022) - 0.0779897886064487);
}

inline float score_1(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.00416804734534364*x_1 + 0.000875460327500766*x_10 - 0.000684700263457871*x_100 - 0.000140511642780398*x_101 + 0.00140849096172808*x_102 + 0.00120106732983966*x_103 - 0.00176371672709819*x_104 - 0.000123329758609272*x_105 + 0.000181185003981395*x_106 + 0.00252248935212062*x_107 + 0.00435388573893236*x_108 + 0.00103762469953854*x_109 - 0.0011074471252827*x_11 - 0.00112764602351582*x_110 - 2.27462677925363e-5*x_111 - 0.00699469855690712*x_112 + 0.00139411357459136*x_113 - 0.00545009844899385*x_114 + 0.00143866988000349*x_115 - 0.00313591948531446*x_116 - 0.010300782896809*x_117 - 0.00861944176522478*x_118 + 0.00381614104893529*x_119 + 0.000960382737099756*x_12 + 0.00110515204916275*x_120 - 0.000178080268058624*x_13 + 0.000311773775107439*x_14 + 7.45165164523533e-5*x_15 - 0.00049417548939808*x_16 + 0.000193680492514611*x_17 - 0.000121200316682569*x_18 - 0.00235301555550649*x_19 - 0.000404504478516415*x_2 - 0.000536703515145259*x_20 - 0.000346562243217631*x_21 - 0.000401276897465962*x_22 - 0.000170757252517659*x_23 + 0.00103589850813652*x_24 - 0.00120843228279893*x_25 - 0.00128102401555167*x_26 - 0.00157024909829072*x_27 - 0.000422852218468307*x_28 - 0.00152742976661575*x_29 - 0.000247792260191582*x_3 + 0.00235359668246846*x_30 - 5.74656863670033e-5*x_31 + 0.00141320976999773*x_32 + 0.00515588566657875*x_33 + 0.0116486639187964*x_34 + 0.00401204711616443*x_35 + 0.00508799903348561*x_36 + 3.54576244783788e-5*x_37 + 0.00140132828116857*x_38 + 0.00250850619712743*x_39 + 0.000889476550687983*x_4 + 0.000998035307396607*x_40 + 0.000606592123868791*x_41 + 0.00262307267331589*x_42 + 0.00132511711362228*x_43 - 0.00099648256652054*x_44 + 0.00136775407194087*x_45 + 0.00108081752423196*x_46 + 0.00064247180562768*x_47 + 0.00865002071273319*x_48 + 0.00529253678412098*x_49 + 0.000161912324953535*x_5 + 0.000652384820795519*x_50 + 0.000385117182738433*x_51 + 0.00121837246574284*x_52 - 0.000949268329097608*x_53 - 0.00339567397558962*x_54 + 0.00309968909555632*x_55 - 0.000484078181104986*x_56 - 0.000120863366994563*x_57 - 0.00132576649984609*x_58 - 0.00114258416365744*x_59 + 0.00167547235459978*x_6 + 0.000188462372382431*x_60 + 0.00200590129685517*x_61 + 0.000130713953742129*x_62 + 0.000117587089802116*x_63 + 0.00099474889011383*x_64 - 2.13403348857147e-5*x_65 - 0.00135075857409508*x_66 - 0.000615656868876494*x_67 + 0.000676948051408046*x_68 + 1.28201961883764e-5*x_69 - 0.00146864667026477*x_7 - 0.000212686482625008*x_70 + 0.00134807176069846*x_71 - 8.89079430662869e-5*x_72 + 0.000297247619575469*x_73 + 0.00113968287034144*x_74 - 4.50869221493542e-5*x_75 - 0.000123578580949867*x_76 + 8.24076884208743e-5*x_77 + 0.000814962961201109*x_78 + 9.19297678950477e-5*x_79 + 0.000654665563944695*x_8 + 1.53093416503041e-5*x_80 - 2.48321116064205e-5*x_81 + 4.63305394306283e-6*x_82 + 0.000861755561432826*x_83 + 0.000496979853186061*x_84 + 0.00123656746670261*x_85 - 0.000598344215467554*x_86 - 0.000518436311285027*x_87 + 0.000760181986569721*x_88 + 0.000485365917804296*x_89 + 0.00201231778075676*x_9 + 0.000288762199926512*x_90 + 0.00165377520808557*x_91 - 0.00198816952449927*x_92 + 0.00197154548260151*x_93 + 0.00388609247211924*x_94 - 0.000190244138699175*x_95 + 0.00337976738593961*x_96 + 0.00140548737202927*x_97 + 0.00264787690110377*x_98 + 0.00456455491905444*x_99 - 1.56497848648254e-6*std::pow(-3.11615991592407*x_28 - 7.80615997314453, 2) - 3.42385740713232e-6*std::pow(-4.07271957397461*x_64 - 9.9672794342041, 2) + 2.04678646076072e-6*std::pow(-4.70783948898315*x_8 - 6.14423990249634, 2) - 0.0030840210812835*std::exp(0.183999866247177*x_10) + 0.00542479966382478*std::sin(0.212719991803169*x_1 + 5.01215982437134) + 0.0113362448301286*std::sin(0.246879979968071*x_1 - 7.55592012405396) - 0.00194475863444126*std::sin(0.270639955997467*x_1 + 5.06863975524902) - 0.008548015709607*std::sin(0.309119910001755*x_1 + 5.12335968017578) - 0.0182679770265826*std::sin(0.326159834861755*x_1 + 8.32335948944092) - 0.00278090993269538*std::sin(0.333519846200943*x_1 - 4.24272012710571) + 0.00625289706217724*std::sin(0.334079831838608*x_1 - 4.24832010269165) - 0.0818033257241525*std::sin(0.345999836921692*x_1 - 4.23943996429443) - 0.0200117646514276*std::sin(0.352639853954315*x_1 - 4.22119998931885) - 0.000193246467359857*std::sin(0.366159856319427*x_1 + 8.36544036865234) - 4.42012511726924e-5*std::sin(0.669359803199768*x_1 + 2.20183968544006) + 0.000287287155422883*std::sin(0.329439848661423*x_10 + 5.07223987579346) - 0.00393267752197541*std::sin(0.22503998875618*x_100 - 4.40079975128174) + 0.00542322163346401*std::sin(0.246639966964722*x_100 + 1.96799981594086) + 0.00274733512300525*std::sin(0.257359951734543*x_107 - 7.44687986373901) - 0.00347904590597691*std::sin(0.244079977273941*x_11 + 1.96719980239868) - 0.000985544055992177*std::sin(0.256879955530167*x_11 + 5.17695999145508) + 0.0032475895091236*std::sin(0.26895996928215*x_11 - 7.42095994949341) + 0.00351983333133292*std::sin(0.280799955129623*x_113 - 7.41103982925415) + 0.0119882441318493*std::sin(0.288559943437576*x_113 - 7.43031978607178) - 0.0100757923608424*std::sin(0.236719980835915*x_116 + 1.98751986026764) + 0.0110628238156973*std::sin(0.247999966144562*x_116 - 7.43703985214233) - 0.0185441607350089*std::sin(0.257119953632355*x_116 - 4.40911960601807) + 0.00310211067691673*std::sin(0.236159980297089*x_119 + 5.174880027771) - 0.0300468116567553*std::sin(0.282719939947128*x_12 - 4.24959993362427) + 0.00150672670177007*std::sin(0.305519938468933*x_12 - 7.46560001373291) + 0.000232367156976298*std::sin(0.243599981069565*x_120 - 4.21704006195068) - 0.00425549225861774*std::sin(0.259839981794357*x_120 - 4.24631977081299) + 0.0155016663229464*std::sin(0.262159943580627*x_120 + 5.16527986526489) + 0.0182347072071352*std::sin(0.264319956302643*x_120 + 5.15952014923096) - 0.0722069068786937*std::sin(0.268479973077774*x_120 + 5.15248012542725) + 0.0288828743219327*std::sin(0.208000004291534*x_13 + 5.20496034622192) - 0.000320127878473935*std::sin(0.265359938144684*x_13 - 4.39911985397339) + 0.00172733679945427*std::sin(0.288719952106476*x_14 - 4.24064016342163) + 0.00168938500430872*std::sin(0.290559947490692*x_14 + 4.80288028717041) - 0.0482595960700827*std::sin(0.294959932565689*x_14 - 4.25464010238647) + 0.000464276917425738*std::sin(0.297279924154282*x_14 + 4.98759984970093) + 0.000491681905970961*std::sin(0.318319916725159*x_14 + 5.12160015106201) - 0.000243665891721548*std::sin(0.33247983455658*x_14 + 1.86767983436584) - 0.00345683597085677*std::sin(0.460639864206314*x_14 + 7.76711988449097) - 0.00336106957610401*std::sin(0.198239997029305*x_15 + 8.19207954406738) - 0.00175463148001079*std::sin(0.269839942455292*x_15 + 1.99335980415344) + 0.0553245251354847*std::sin(0.321759909391403*x_15 - 7.44143962860107) - 0.00469925877653484*std::sin(0.253999978303909*x_16 - 7.39783954620361) - 0.0127799204174238*std::sin(0.350239843130112*x_16 - 1.15351986885071) + 0.00109720307719541*std::sin(0.356159836053848*x_16 - 1.14495992660522) - 0.000323270428416293*std::sin(0.689119875431061*x_16 - 7.84295988082886) - 0.029946531081794*std::sin(0.332639843225479*x_17 - 1.1490398645401) + 0.00648033665222001*std::sin(0.352479845285416*x_17 + 2.00735974311829) + 0.000399685814137456*std::sin(0.398319840431213*x_17 + 1.99095976352692) + 0.000651968580880845*std::sin(0.272399961948395*x_18 - 1.17335987091064) + 0.0464991565451038*std::sin(0.276239961385727*x_18 - 1.16479980945587) + 0.00187324344295943*std::sin(0.280479967594147*x_18 + 2.00055980682373) - 0.00370704702234512*std::sin(0.344239860773087*x_18 - 1.15015983581543) + 0.000949543229435537*std::sin(0.367839843034744*x_18 + 1.99519979953766) - 0.000258041036531486*std::sin(0.384639829397202*x_18 + 2.00191974639893) + 0.00461937569128588*std::sin(0.393519848585129*x_18 + 5.18936014175415) - 0.0504123001157172*std::sin(0.292719930410385*x_19 + 1.98071980476379) - 0.00567106525741246*std::sin(0.373119831085205*x_2 - 7.39439964294434) - 0.00811209049565926*std::sin(0.378239840269089*x_2 + 5.18455982208252) - 0.00241002249633035*std::sin(0.387199848890305*x_2 + 5.19736003875732) + 0.0369797140355142*std::sin(0.392479836940765*x_2 + 5.19144010543823) - 0.107853958138122*std::sin(0.393279850482941*x_2 + 5.18304014205933) + 0.00610951824505651*std::sin(0.264879941940308*x_20 - 1.16751992702484) - 0.00158419014239112*std::sin(0.311919927597046*x_20 + 8.18335914611816) - 0.00166762570452404*std::sin(0.396639823913574*x_20 - 4.40351963043213) + 0.000281341705479194*std::sin(0.779839873313904*x_20 - 1.36743986606598) - 0.00327865036486189*std::sin(0.262959957122803*x_21 - 7.38935995101929) + 0.000192448178230168*std::sin(0.459439843893051*x_21 - 7.62784004211426) - 0.04437272520199*std::sin(0.298159927129745*x_23 - 4.34663963317871) + 0.00208780304567215*std::sin(0.310159921646118*x_23 + 8.23967933654785) - 0.0740352068883235*std::sin(0.341519832611084*x_23 + 1.9962397813797) - 0.00205858693728314*std::sin(0.346639841794968*x_23 - 1.15591979026794) - 0.00374543819837281*std::sin(0.368399828672409*x_23 + 2.02231979370117) - 0.00130121530012598*std::sin(0.238879978656769*x_24 - 1.17855989933014) + 0.000498934893313551*std::sin(0.247199967503548*x_25 - 4.38279962539673) - 0.00247871596143023*std::sin(0.333119839429855*x_25 - 1.13919985294342) + 0.00299284983319194*std::sin(0.348159849643707*x_25 + 8.23272037506104) - 0.000767550063330905*std::sin(0.384799838066101*x_25 + 8.20487976074219) - 0.000454594137138656*std::sin(0.141840040683746*x_26 - 1.25295984745026) + 0.00190152190293674*std::sin(0.283519923686981*x_26 - 1.17279982566833) + 0.000384836957793765*std::sin(0.353679865598679*x_26 + 5.01056003570557) + 0.00443298805639891*std::sin(0.1891999989748*x_27 + 8.18383979797363) + 0.000407295047901171*std::sin(0.226879984140396*x_27 + 5.00183963775635) - 4.44926887034621e-5*std::sin(0.698799848556519*x_27 + 5.2292799949646) - 0.00950713910203036*std::sin(0.308639913797379*x_28 + 1.9936797618866) + 0.000450185166488816*std::sin(0.410879880189896*x_28 + 8.20399951934814) - 0.00108838089982578*std::sin(0.29079994559288*x_29 - 1.16375982761383) + 0.0108211211846735*std::sin(0.267839968204498*x_3 - 4.3551197052002) - 0.00388386320667272*std::sin(0.324559837579727*x_3 - 7.40367984771729) - 0.000796564382773337*std::sin(0.357199847698212*x_3 - 7.38823986053467) - 0.00337865013576886*std::sin(0.36287984251976*x_3 - 7.39383983612061) + 0.00169035083939656*std::sin(0.365039855241776*x_3 - 7.41415977478027) - 0.00261217532883964*std::sin(0.370799839496613*x_3 - 7.40367984771729) + 0.00159543903128324*std::sin(0.385759830474854*x_3 + 1.99527978897095) - 0.00166220499202892*std::sin(0.39183983206749*x_3 + 1.99183976650238) - 0.000108831596030592*std::sin(0.449039846658707*x_3 + 8.18967914581299) + 0.0086499387867667*std::sin(0.191760003566742*x_30 + 8.18335914611816) + 0.00313889405010851*std::sin(0.304079920053482*x_30 + 1.99335980415344) + 0.0249255049832908*std::sin(0.389519840478897*x_30 + 2.00319981575012) + 0.00516710632379344*std::sin(0.390079855918884*x_30 + 1.99391984939575) + 0.00256811920015134*std::sin(0.342559844255447*x_31 - 7.44663953781128) + 0.0435803633661604*std::sin(0.367919832468033*x_31 + 5.17503976821899) + 0.000473432482154564*std::sin(0.369759827852249*x_31 + 5.17216014862061) - 0.00077779177066441*std::sin(0.370159834623337*x_31 + 5.17727994918823) + 0.0183808868628682*std::sin(0.377839833498001*x_31 - 7.40151977539063) - 0.254809086330705*std::sin(0.380639851093292*x_31 - 7.39687967300415) - 0.00322127681404399*std::sin(0.380719840526581*x_31 - 7.39687967300415) + 0.00112484083218231*std::sin(0.423199862241745*x_31 + 5.21799993515015) - 0.000263491128489155*std::sin(0.263039946556091*x_32 + 5.23415994644165) - 0.00116951217979327*std::sin(0.294079929590225*x_32 - 4.36799955368042) - 0.00487135690550016*std::sin(0.30991992354393*x_32 - 1.14351987838745) + 0.00120448510211255*std::sin(0.310159921646118*x_32 - 1.14815986156464) - 0.0171256155758948*std::sin(0.32847985625267*x_32 + 1.99999976158142) - 0.00226812110324772*std::sin(0.241039976477623*x_33 + 1.99663984775543) - 6.07580299531389e-5*std::sin(0.245679974555969*x_36 + 1.78207981586456) - 0.00527769377151025*std::sin(0.317439913749695*x_4 - 1.14063990116119) + 0.00032453643151862*std::sin(0.530719876289368*x_44 + 5.1005597114563) - 0.000386053737539835*std::sin(0.635519862174988*x_45 - 1.40887975692749) + 0.00293056705098315*std::sin(0.338719844818115*x_5 + 2.01407980918884) + 0.000458005868848634*std::sin(0.339759826660156*x_5 + 2.00815987586975) + 0.10199351408083*std::sin(0.351199835538864*x_5 + 2.00807976722717) + 0.0214953214679227*std::sin(0.210960000753403*x_56 - 1.01687979698181) + 0.000386253274438324*std::sin(0.217439994215965*x_56 - 7.39751958847046) + 0.00196003989047764*std::sin(0.247839972376823*x_56 - 7.42392015457153) + 0.00265216703508713*std::sin(0.274239957332611*x_57 - 7.45928001403809) - 0.00699915504724591*std::sin(0.299679934978485*x_6 + 5.21031999588013) - 0.0183713036835609*std::sin(0.314479917287827*x_6 + 2.01639986038208) + 0.109679298256697*std::sin(0.352959841489792*x_6 + 2.014399766922) + 0.000151520597765745*std::sin(0.573599874973297*x_6 - 7.57480001449585) - 0.000293218841387629*std::sin(0.444079846143723*x_60 + 5.10624027252197) + 0.00165217559564576*std::sin(0.334399849176407*x_7 - 1.14743983745575) + 0.018966842476589*std::sin(0.339119851589203*x_7 - 1.15287983417511) + 0.00219483744718416*std::sin(0.340719848871231*x_7 - 1.14399981498718) + 0.00318863649112747*std::sin(0.344799846410751*x_7 + 2.02967977523804) - 0.00614277302208851*std::sin(0.345839858055115*x_7 - 1.14471983909607) - 0.00626845932915869*std::sin(0.346959829330444*x_7 - 7.36223983764648) - 0.0137066630445206*std::sin(0.348799854516983*x_7 + 2.01079988479614) - 0.0100697659491899*std::sin(0.349759846925735*x_7 - 1.15015983581543) - 0.000287755311489221*std::sin(0.97055983543396*x_72 + 8.38920021057129) + 0.00302152508999606*std::sin(0.266479969024658*x_8 - 7.40127992630005) + 0.00221533448324921*std::sin(0.313199937343597*x_8 - 7.42335987091064) + 0.00379878097417861*std::sin(0.326239854097366*x_8 + 8.24759960174561) + 0.000174348587518151*std::sin(0.334319829940796*x_8 - 7.55656003952026) - 0.00200363137232561*std::sin(0.363439828157425*x_8 + 5.01847982406616) + 0.000128691590449404*std::sin(0.405199855566025*x_8 + 4.79080009460449) - 0.0034153586107487*std::sin(0.206080004572868*x_9 - 7.41024017333984) - 0.000594969372848929*std::sin(0.404639840126038*x_9 - 4.38887977600098) - 0.000670444014972294*std::sin(0.339599847793579*x_91 + 2.00343990325928) + 0.044991789229121*std::sin(0.358399868011475*x_91 + 1.99927973747253) - 0.00117434032213666*std::sin(0.377519845962524*x_91 + 1.9975198507309) - 0.000667908092238593*std::sin(0.379759848117828*x_91 + 1.99135982990265) + 0.00107650640501536*std::sin(0.424319863319397*x_91 + 5.00743961334229) - 0.00122800361862139*std::sin(0.215199992060661*x_92 + 1.98735988140106) - 0.000773092394782995*std::sin(0.255759954452515*x_92 + 1.99335980415344) - 0.112508122846464*std::sin(0.292079925537109*x_92 + 2.01063990592957) - 0.000979389756206035*std::sin(0.293359935283661*x_92 + 1.99031984806061) + 0.0123656540580984*std::sin(0.293599933385849*x_92 - 7.38927984237671) + 0.000550399841380683*std::sin(0.309599906206131*x_92 - 4.39079999923706) + 0.00121565281901592*std::sin(0.225439995527267*x_93 - 1.1833598613739) + 0.015087284182911*std::sin(0.281519949436188*x_94 - 7.42119979858398) - 7.33237043995645e-5*std::sin(0.310239940881729*x_97 - 1.41639983654022) + 0.183180596035294);
}

inline float score_2(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.00305457762682294*x_1 + 0.000462723542837184*x_10 - 0.00157562164217043*x_100 - 0.000301151728323972*x_101 + 0.000470393714393704*x_102 + 0.000635785088152057*x_103 - 0.00146720804125089*x_104 - 0.000237418450701144*x_105 - 0.000765557494976629*x_106 + 0.00142893722559944*x_107 + 0.00137493023695705*x_108 + 0.000315207397214244*x_109 - 0.00121253687093191*x_11 + 0.000265854538644723*x_110 + 0.000157230640430815*x_111 - 0.0137730311534595*x_112 - 0.00189855762920205*x_113 - 0.00554938209976412*x_114 + 0.000288355572658894*x_115 + 3.09120478273184e-5*x_116 - 0.00918708924567214*x_117 - 0.00772647755928971*x_118 - 0.00629484645452052*x_119 + 0.000215478788524973*x_12 - 5.85362335067291e-5*x_120 + 0.00135182839826837*x_13 + 0.000763224079990853*x_14 + 0.00327809414685813*x_15 - 0.000238789634912632*x_16 + 8.98762043246682e-5*x_17 + 0.00123063286864191*x_18 + 0.00135524889982945*x_19 + 0.00102893119204458*x_2 - 0.000277781202953566*x_20 - 0.000651605545194087*x_21 + 0.000585418085588156*x_22 + 0.000236152977610832*x_23 + 0.00125890543069845*x_24 + 0.000199190429589947*x_25 - 0.000850416967493878*x_26 + 0.00145009943008573*x_27 - 0.000420571521965073*x_28 - 0.00158670193435388*x_29 + 0.000317886460783257*x_3 + 0.0040037592814207*x_30 + 2.02970931485158e-5*x_31 + 0.000808117977756105*x_32 + 0.0025620600696371*x_33 + 0.00717434364049813*x_34 + 0.00215411379828107*x_35 + 0.0034583441669445*x_36 - 2.85159245666522e-5*x_37 + 0.00495496128306738*x_38 + 0.00329596196532641*x_39 + 0.000492652420499648*x_4 + 4.92560977185153e-5*x_40 - 0.000225021465876092*x_41 + 0.00247775194434011*x_42 + 0.00183308321094153*x_43 - 0.0015584705439085*x_44 + 0.00167814020557951*x_45 + 0.00113871172299891*x_46 + 0.00145848108248025*x_47 + 0.00793172674336506*x_48 + 0.00571498671035688*x_49 - 0.000911635539037764*x_5 + 0.000675616464499973*x_50 + 7.42387333930887e-5*x_51 + 0.000906975804322702*x_52 - 0.00119806314620852*x_53 - 0.00349381580675272*x_54 + 0.00307181243230756*x_55 - 0.000633414446392326*x_56 + 0.000412850834562833*x_57 + 0.000518177248509775*x_58 + 0.00197764378747878*x_59 - 0.000123725462551599*x_6 + 0.000890546215109432*x_60 - 4.31447676767364e-5*x_61 - 0.000482554428294027*x_62 - 9.17033207904765e-5*x_63 + 0.00110074412759434*x_64 - 0.000469146685122942*x_65 - 0.000264948606391358*x_66 - 0.00070131496548437*x_67 + 0.000182823008516064*x_68 + 9.05668202833126e-5*x_69 - 0.00098470296149865*x_7 + 0.000511246055569452*x_70 + 0.000622742773016681*x_71 + 6.05008619096426e-5*x_72 - 0.000152785523586134*x_73 + 0.0010195183514898*x_74 + 0.000126939538754213*x_75 - 0.000557207626325217*x_76 - 0.000122002524363826*x_77 + 9.16268908494178e-5*x_78 - 0.000859644490027088*x_79 + 0.000166025385855472*x_8 - 0.000133375299031489*x_80 - 0.000417592734332659*x_81 - 0.00075158447291011*x_82 - 4.49721848583489e-5*x_83 - 0.000814400592908754*x_84 + 0.00119717723942898*x_85 - 0.000131361386028321*x_86 - 0.000324721586065439*x_87 - 0.000740477158711274*x_88 - 0.000689227490998659*x_89 + 0.00126192382453014*x_9 + 0.000185285259119436*x_90 + 0.00160283823125716*x_91 - 0.00130318575476647*x_92 - 0.00060724490055254*x_93 + 0.00221448964637726*x_94 - 0.000646022953121351*x_95 + 0.00415790600384021*x_96 + 0.00090498447934943*x_97 + 0.00262209047431537*x_98 + 0.0052173576246141*x_99 - 2.29410678502757e-6*std::pow(-3.11615991592407*x_28 - 7.80615997314453, 2) - 1.57252608399728e-6*std::pow(-4.07271957397461*x_64 - 9.9672794342041, 2) + 1.33346875616361e-6*std::pow(-4.70783948898315*x_8 - 6.14423990249634, 2) + 4.46545447611194e-5*std::exp(0.183999866247177*x_10) + 0.00389313598711906*std::exp(-0.0295366405409967*x_10 + 0.00527450891369757*x_100 - 0.0154702918731162*x_101 - 0.00308568101897767*x_102 + 0.00631560682706002*x_103 + 0.0114994787664063*x_104 + 0.0292935581870444*x_105 - 0.00617829540277929*x_106 - 0.00764480968545296*x_107 - 0.00842374605942231*x_108 - 0.0134969112335635*x_109 - 0.0236519646318391*x_11 - 0.00247285524373758*x_110 - 0.00902051055353742*x_111 + 0.00742347317890925*x_112 - 0.00935573171780301*x_113 - 0.00593821009938551*x_114 - 0.00859119723166034*x_115 - 0.00302355544356312*x_116 - 0.0073775562620002*x_117 - 0.00797737241331935*x_118 - 0.0123053183868843*x_119 - 0.00686517936176271*x_12 - 0.0218558690987482*x_120 - 0.00131774343154639*x_13 - 0.00293110351330606*x_14 - 0.0100466699684173*x_15 - 0.0060793988352158*x_16 - 0.0188222111441126*x_17 + 0.00288200482085843*x_18 - 0.0186768361273899*x_19 + 0.0110172931736757*x_2 - 0.00646850958654712*x_21 - 0.0114753306011086*x_22 - 0.00202391228697511*x_23 - 0.00180875554773524*x_24 - 0.00979533485490126*x_25 - 0.0140264657479487*x_26 + 0.0284576813516569*x_27 + 0.000204276126728811*x_28 + 0.000917227266920822*x_29 + 0.0319179711733631*x_3 + 0.0120630378870469*x_30 - 0.000998730288541172*x_31 - 0.00351357157862806*x_32 - 0.017832124611195*x_33 + 0.00260592605292415*x_34 - 0.00995171354953402*x_35 + 0.012773460956856*x_36 - 0.0110526532700344*x_37 - 0.0124486964545694*x_38 + 0.00473870050680156*x_39 - 0.0016702378859869*x_4 + 0.017039601200401*x_40 + 0.0092769776465249*x_41 - 0.00458364276774406*x_42 + 0.00199638934758237*x_43 - 0.00257499281121259*x_44 + 0.0434383831252629*x_45 - 0.00817608768003654*x_46 + 0.015297465104245*x_47 + 0.0193959800312686*x_48 - 0.00948868990797828*x_49 - 0.0088887932593895*x_5 - 0.00958936017491888*x_50 - 0.00522489808190703*x_51 + 0.0166783798634338*x_52 - 0.0010387506147651*x_53 + 0.00236330677639289*x_54 + 0.00668514731413659*x_55 - 0.0001353890805245*x_56 + 0.00180875005499119*x_57 - 0.0428407290173676*x_58 + 0.0290940776397814*x_59 - 0.0141545634923304*x_6 - 0.0231869695402633*x_60 - 0.0140520858717189*x_61 - 0.0036113282619608*x_62 - 0.0178251960475618*x_63 - 0.0118289178187596*x_64 - 0.00308023994611338*x_65 - 0.011091777381979*x_66 - 0.00929536485557051*x_67 - 0.00627283281995037*x_68 - 0.0107583153957432*x_69 - 0.0115817145226361*x_7 - 0.00494239324347423*x_70 - 0.00749998798046502*x_71 - 0.0184803040649932*x_73 + 0.00386206103166952*x_74 - 0.0173788290591122*x_75 - 0.0146907633111715*x_76 - 0.0203077936516593*x_77 - 0.0221050456723136*x_78 - 0.0265049053717073*x_79 - 0.0118254416085813*x_8 - 0.00405162765746117*x_80 - 0.0148819500956505*x_81 - 0.0369178654107075*x_82 - 0.00856589551291929*x_83 + 0.000549201519518458*x_84 - 0.00542222874707576*x_85 - 0.0223177922802395*x_86 - 0.0114459152939912*x_87 - 0.00959474878840731*x_88 - 0.0117092707687256*x_89 + 0.00586369210981666*x_9 - 0.012832730963947*x_90 - 0.027476551798531*x_92 - 0.0301618846965814*x_93 - 0.0139697488919786*x_94 + 0.00373118899286109*x_95 + 0.0188875589347095*x_96 - 0.00232204946153868*x_97 - 0.00975521417776892*x_98 - 0.0126797121937287*x_99 - 1.43840125172906*std::sin(0.246879979968071*x_1 - 7.55592012405396) + 0.201010221456763*std::sin(0.311919927597046*x_20 + 8.18335914611816) + 0.0365118790604919*std::sin(0.97055983543396*x_72 + 8.38920021057129) - 0.136592688643518*std::sin(0.424319863319397*x_91 + 5.00743961334229)) - 7.85474395355149e-5*std::sin(0.212719991803169*x_1 + 5.01215982437134) - 0.000506551663278826*std::sin(0.270639955997467*x_1 + 5.06863975524902) - 0.00392597473299391*std::sin(0.309119910001755*x_1 + 5.12335968017578) + 0.0766668822515047*std::sin(0.326159834861755*x_1 + 8.32335948944092) + 0.071693825451462*std::sin(0.333519846200943*x_1 - 4.24272012710571) - 0.0275586960093921*std::sin(0.334079831838608*x_1 - 4.24832010269165) - 0.0532943622085962*std::sin(0.345999836921692*x_1 - 4.23943996429443) - 0.00376594372334568*std::sin(0.352639853954315*x_1 - 4.22119998931885) - 0.000283280591894452*std::sin(0.366159856319427*x_1 + 8.36544036865234) + 0.000415679622630754*std::sin(0.669359803199768*x_1 + 2.20183968544006) - 0.00126617459154932*std::sin(0.329439848661423*x_10 + 5.07223987579346) - 0.00180621949102599*std::sin(0.22503998875618*x_100 - 4.40079975128174) - 7.85245907204381e-5*std::sin(0.246639966964722*x_100 + 1.96799981594086) - 0.0030430225751576*std::sin(0.257359951734543*x_107 - 7.44687986373901) - 0.000654709433228846*std::sin(0.244079977273941*x_11 + 1.96719980239868) - 0.00144471206813645*std::sin(0.256879955530167*x_11 + 5.17695999145508) - 0.0143132585032616*std::sin(0.26895996928215*x_11 - 7.42095994949341) + 0.00515973452499415*std::sin(0.280799955129623*x_113 - 7.41103982925415) - 0.0503121555233706*std::sin(0.288559943437576*x_113 - 7.43031978607178) - 0.00189612798571174*std::sin(0.236719980835915*x_116 + 1.98751986026764) - 0.0464283598349734*std::sin(0.247999966144562*x_116 - 7.43703985214233) - 0.0129293597170117*std::sin(0.257119953632355*x_116 - 4.40911960601807) + 0.00454739359888354*std::sin(0.236159980297089*x_119 + 5.174880027771) - 0.019575312488497*std::sin(0.282719939947128*x_12 - 4.24959993362427) - 0.00664066955371517*std::sin(0.305519938468933*x_12 - 7.46560001373291) - 0.00218523886906084*std::sin(0.243599981069565*x_120 - 4.21704006195068) - 0.00623813921306335*std::sin(0.259839981794357*x_120 - 4.24631977081299) - 0.065057254284591*std::sin(0.262159943580627*x_120 + 5.16527986526489) - 0.000264026259135702*std::sin(0.264319956302643*x_120 + 5.15952014923096) - 0.0503440994946134*std::sin(0.268479973077774*x_120 + 5.15248012542725) + 0.0188170144931402*std::sin(0.208000004291534*x_13 + 5.20496034622192) + 0.0030105626466936*std::sin(0.265359938144684*x_13 - 4.39911985397339) - 0.044531964714129*std::sin(0.288719952106476*x_14 - 4.24064016342163) + 0.000317919432099502*std::sin(0.290559947490692*x_14 + 4.80288028717041) - 0.0314408292111791*std::sin(0.294959932565689*x_14 - 4.25464010238647) - 0.002046230140091*std::sin(0.297279924154282*x_14 + 4.98759984970093) + 0.00012806848256789*std::sin(0.318319916725159*x_14 + 5.12160015106201) + 0.00229149499689671*std::sin(0.33247983455658*x_14 + 1.86767983436584) - 0.00241017516988702*std::sin(0.460639864206314*x_14 + 7.76711988449097) - 0.00154368857988745*std::sin(0.198239997029305*x_15 + 8.19207954406738) - 0.00257211969256079*std::sin(0.269839942455292*x_15 + 1.99335980415344) + 0.03604358692618*std::sin(0.321759909391403*x_15 - 7.44143962860107) - 0.00547774657709876*std::sin(0.253999978303909*x_16 - 7.39783954620361) - 0.00240500834979693*std::sin(0.350239843130112*x_16 - 1.15351986885071) + 0.00160839337133929*std::sin(0.356159836053848*x_16 - 1.14495992660522) + 0.00135669843654395*std::sin(0.689119875431061*x_16 - 7.84295988082886) - 0.00563553253437913*std::sin(0.332639843225479*x_17 - 1.1490398645401) + 0.00755388107001019*std::sin(0.352479845285416*x_17 + 2.00735974311829) - 0.0103041830507695*std::sin(0.398319840431213*x_17 + 1.99095976352692) + 0.000955722751425971*std::sin(0.272399961948395*x_18 - 1.17335987091064) + 0.0324201418495197*std::sin(0.276239961385727*x_18 - 1.16479980945587) + 0.00218356837656642*std::sin(0.280479967594147*x_18 + 2.00055980682373) + 0.00410602539228172*std::sin(0.344239860773087*x_18 - 1.15015983581543) - 0.0244798962200787*std::sin(0.367839843034744*x_18 + 1.99519979953766) - 6.72119994401108e-5*std::sin(0.384639829397202*x_18 + 2.00191974639893) + 0.00613535690464626*std::sin(0.393519848585129*x_18 + 5.18936014175415) - 0.0351484638033548*std::sin(0.292719930410385*x_19 + 1.98071980476379) - 0.00106721785823684*std::sin(0.373119831085205*x_2 - 7.39439964294434) - 0.00945595423848508*std::sin(0.378239840269089*x_2 + 5.18455982208252) - 0.000627739032718716*std::sin(0.387199848890305*x_2 + 5.19736003875732) + 0.0240920556313901*std::sin(0.392479836940765*x_2 + 5.19144010543823) - 0.075197936514792*std::sin(0.393279850482941*x_2 + 5.18304014205933) - 0.0256403714119839*std::sin(0.264879941940308*x_20 - 1.16751992702484) - 0.00031382462587547*std::sin(0.396639823913574*x_20 - 4.40351963043213) + 0.000373672091346229*std::sin(0.779839873313904*x_20 - 1.36743986606598) - 0.00382179757865323*std::sin(0.262959957122803*x_21 - 7.38935995101929) - 0.000848186174931177*std::sin(0.459439843893051*x_21 - 7.62784004211426) - 0.0309375513919887*std::sin(0.298159927129745*x_23 - 4.34663963317871) - 0.00231250703536797*std::sin(0.310159921646118*x_23 + 8.23967933654785) - 0.0482334806949017*std::sin(0.341519832611084*x_23 + 1.9962397813797) + 0.00907290989270462*std::sin(0.346639841794968*x_23 - 1.15591979026794) - 0.000704840863363592*std::sin(0.368399828672409*x_23 + 2.02231979370117) + 0.0335462509969116*std::sin(0.238879978656769*x_24 - 1.17855989933014) + 0.00073139019732486*std::sin(0.247199967503548*x_25 - 4.38279962539673) - 0.002889344579431*std::sin(0.333119839429855*x_25 - 1.13919985294342) - 0.00331496129838629*std::sin(0.348159849643707*x_25 + 8.23272037506104) - 0.000199923915669742*std::sin(0.384799838066101*x_25 + 8.20487976074219) + 0.0117197584632622*std::sin(0.141840040683746*x_26 - 1.25295984745026) + 0.000495289783336254*std::sin(0.283519923686981*x_26 - 1.17279982566833) - 0.00169611055924288*std::sin(0.353679865598679*x_26 + 5.01056003570557) - 0.00491009728593644*std::sin(0.1891999989748*x_27 + 8.18383979797363) - 0.00179509118727293*std::sin(0.226879984140396*x_27 + 5.00183963775635) + 0.000418420374070967*std::sin(0.698799848556519*x_27 + 5.2292799949646) - 0.00619384249217043*std::sin(0.308639913797379*x_28 + 1.9936797618866) - 0.000498637247838925*std::sin(0.410879880189896*x_28 + 8.20399951934814) - 0.00159546091435206*std::sin(0.29079994559288*x_29 - 1.16375982761383) + 0.00704989371537045*std::sin(0.267839968204498*x_3 - 4.3551197052002) - 0.00452727108634758*std::sin(0.324559837579727*x_3 - 7.40367984771729) + 0.00351073677664473*std::sin(0.357199847698212*x_3 - 7.38823986053467) + 0.00374228413221662*std::sin(0.36287984251976*x_3 - 7.39383983612061) + 0.00247789050343599*std::sin(0.365039855241776*x_3 - 7.41415977478027) - 0.000680393820686029*std::sin(0.370799839496613*x_3 - 7.40367984771729) - 2.31008808819245e-5*std::sin(0.385759830474854*x_3 + 1.99527978897095) - 0.000312804521024517*std::sin(0.39183983206749*x_3 + 1.99183976650238) + 0.00280575553982746*std::sin(0.449039846658707*x_3 + 8.18967914581299) + 0.0126799719179501*std::sin(0.191760003566742*x_30 + 8.18335914611816) - 0.0138341997433282*std::sin(0.304079920053482*x_30 + 1.99335980415344) + 0.0114479086253355*std::sin(0.389519840478897*x_30 + 2.00319981575012) - 0.0057232265040689*std::sin(0.390079855918884*x_30 + 1.99391984939575) + 0.00341092150099988*std::sin(0.342559844255447*x_31 - 7.44663953781128) + 0.0283923379625218*std::sin(0.367919832468033*x_31 + 5.17503976821899) - 0.00208658190386499*std::sin(0.369759827852249*x_31 + 5.17216014862061) - 0.00114016735299047*std::sin(0.370159834623337*x_31 + 5.17727994918823) + 0.00345903455874431*std::sin(0.377839833498001*x_31 - 7.40151977539063) - 0.177657990750325*std::sin(0.380639851093292*x_31 - 7.39687967300415) + 0.00356797319114275*std::sin(0.380719840526581*x_31 - 7.39687967300415) + 0.00131118402098533*std::sin(0.423199862241745*x_31 + 5.21799993515015) + 0.00116129720975702*std::sin(0.263039946556091*x_32 + 5.23415994644165) + 0.0049081982339609*std::sin(0.294079929590225*x_32 - 4.36799955368042) - 0.00126884328944751*std::sin(0.30991992354393*x_32 - 1.14351987838745) - 0.0310524780592391*std::sin(0.310159921646118*x_32 - 1.14815986156464) - 0.0111572329299252*std::sin(0.32847985625267*x_32 + 1.99999976158142) - 0.000590777949006526*std::sin(0.241039976477623*x_33 + 1.99663984775543) + 0.00156638499615593*std::sin(0.245679974555969*x_36 + 1.78207981586456) - 0.00615200617089305*std::sin(0.317439913749695*x_4 - 1.14063990116119) + 0.000378299730113147*std::sin(0.530719876289368*x_44 + 5.1005597114563) + 0.000427603545239371*std::sin(0.635519862174988*x_45 - 1.40887975692749) + 0.00341605014659748*std::sin(0.338719844818115*x_5 + 2.01407980918884) + 0.000119296878567862*std::sin(0.339759826660156*x_5 + 2.00815987586975) + 0.0664481454052478*std::sin(0.351199835538864*x_5 + 2.00807976722717) + 0.0149869679983359*std::sin(0.210960000753403*x_56 - 1.01687979698181) + 0.000100607466216413*std::sin(0.217439994215965*x_56 - 7.39751958847046) - 2.83800553615177e-5*std::sin(0.247839972376823*x_56 - 7.42392015457153) - 3.84015895030702e-5*std::sin(0.274239957332611*x_57 - 7.45928001403809) + 0.000101343043419529*std::sin(0.299679934978485*x_6 + 5.21031999588013) + 0.0771005226394072*std::sin(0.314479917287827*x_6 + 2.01639986038208) + 0.0714553863957542*std::sin(0.352959841489792*x_6 + 2.014399766922) + 0.000222114511099196*std::sin(0.573599874973297*x_6 - 7.57480001449585) - 7.63747691765704e-5*std::sin(0.444079846143723*x_60 + 5.10624027252197) + 0.00242192929600391*std::sin(0.334399849176407*x_7 - 1.14743983745575) + 0.00871118477754735*std::sin(0.339119851589203*x_7 - 1.15287983417511) - 0.00967341336272006*std::sin(0.340719848871231*x_7 - 1.14399981498718) + 0.000830544772789369*std::sin(0.344799846410751*x_7 + 2.02967977523804) - 0.00716039603174436*std::sin(0.345839858055115*x_7 - 1.14471983909607) + 9.07630623525696e-5*std::sin(0.346959829330444*x_7 - 7.36223983764648) + 0.0575240006140897*std::sin(0.348799854516983*x_7 + 2.01079988479614) - 0.00189499389646312*std::sin(0.349759846925735*x_7 - 1.15015983581543) + 0.00138774091688901*std::sin(0.266479969024658*x_8 - 7.40127992630005) + 0.00324746564443221*std::sin(0.313199937343597*x_8 - 7.42335987091064) - 5.50037858296837e-5*std::sin(0.326239854097366*x_8 + 8.24759960174561) - 0.00076841497234029*std::sin(0.334319829940796*x_8 - 7.55656003952026) - 0.00233555660869933*std::sin(0.363439828157425*x_8 + 5.01847982406616) + 3.35203238271633e-5*std::sin(0.405199855566025*x_8 + 4.79080009460449) + 4.94520886658403e-5*std::sin(0.206080004572868*x_9 - 7.41024017333984) - 0.000154971789341444*std::sin(0.404639840126038*x_9 - 4.38887977600098) - 0.000174630684191369*std::sin(0.339599847793579*x_91 + 2.00343990325928) + 0.0313691752119617*std::sin(0.358399868011475*x_91 + 1.99927973747253) - 0.00136888368694531*std::sin(0.377519845962524*x_91 + 1.9975198507309) - 0.000979088530234867*std::sin(0.379759848117828*x_91 + 1.99135982990265) + 0.00515367458018309*std::sin(0.215199992060661*x_92 + 1.98735988140106) - 0.00113327852340715*std::sin(0.255759954452515*x_92 + 1.99335980415344) - 0.0784429132250489*std::sin(0.292079925537109*x_92 + 2.01063990592957) + 0.00431651189802198*std::sin(0.293359935283661*x_92 + 1.99031984806061) + 0.00567935846613808*std::sin(0.293599933385849*x_92 - 7.38927984237671) - 0.0141896972974642*std::sin(0.309599906206131*x_92 - 4.39079999923706) + 0.00161460431349455*std::sin(0.225439995527267*x_93 - 1.1833598613739) - 0.000218453697012065*std::sin(0.281519949436188*x_94 - 7.42119979858398) + 0.00189033697311505*std::sin(0.310239940881729*x_97 - 1.41639983654022) - 0.254929603932499);
}

inline float score_3(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.000668781731966151*x_1 + 0.000926460863852575*x_10 + 0.00116427967954814*x_100 + 0.00134077909619262*x_101 + 0.0024213184674191*x_102 + 0.000154705817901402*x_103 + 0.00213744125465962*x_104 + 0.000789988168094699*x_105 + 0.00174530632623664*x_106 - 0.000524811518027169*x_107 - 0.00121438981150706*x_108 + 0.000289256587178095*x_109 + 0.00211124145896682*x_11 + 0.00375619555686777*x_110 - 1.6718292013047e-6*x_111 + 0.00266927691786708*x_112 - 0.0014438955393693*x_113 + 0.00221715162624961*x_114 - 0.0012032154968925*x_115 + 0.00550296157536093*x_116 - 0.00209288479401984*x_117 - 0.00369342177687777*x_118 - 0.00715647212123363*x_119 + 0.00141272911685181*x_12 - 0.00244151054192713*x_120 + 0.00307365373324671*x_13 + 0.00124344398879003*x_14 + 0.00147238869157503*x_15 + 0.000782819148789757*x_16 - 0.0010127968582968*x_17 - 0.00537701405608682*x_18 + 0.00231227803825085*x_19 + 0.0011968060213755*x_2 + 0.000656510592460419*x_20 - 0.000664351188821465*x_21 - 0.00425090993100467*x_22 + 0.000179817079792978*x_23 - 0.00147073505843186*x_24 - 0.00138829268092433*x_25 - 0.000824580467539321*x_26 - 0.000117372209413735*x_27 + 0.00113098680974405*x_28 + 0.00113317283778904*x_29 + 0.000226472858530195*x_3 - 0.00886320786852281*x_30 + 0.00096040459749844*x_31 + 0.000189766300742349*x_32 + 0.00124892630438246*x_33 - 0.00503127474782625*x_34 + 0.000308931817951743*x_35 - 0.00246192054802915*x_36 - 0.000339985708029947*x_37 + 8.31792856789514e-5*x_38 + 0.0014260096495023*x_39 - 0.000278919434881743*x_4 + 0.000722434966751657*x_40 + 0.00158869495047152*x_41 + 0.000485249374072131*x_42 + 0.000606451756385416*x_43 + 0.00108714280347302*x_44 - 0.00120715324887997*x_45 + 0.000890858951239851*x_46 - 0.00182847539969656*x_47 - 0.00544845376028348*x_48 - 0.000277541552925778*x_49 + 0.00187902701888731*x_5 - 0.000161967500408806*x_50 + 0.00229418511911933*x_51 - 0.000629240583594644*x_52 + 0.000784887536686432*x_53 + 0.003301301733085*x_54 - 7.87001870231148e-5*x_55 - 0.0021649469222006*x_56 - 0.00117405124824284*x_57 - 7.45871350888855e-5*x_58 - 0.00211476272724956*x_59 + 0.00881253753142495*x_6 - 0.00369209127575881*x_60 - 0.002180552666659*x_61 - 0.000867335578395676*x_62 + 0.000154585981510213*x_63 - 0.000528998876489583*x_64 - 0.000844445492025622*x_65 + 0.00161839102439505*x_66 + 0.000694642227641694*x_67 - 3.89911360495476e-5*x_68 - 8.58098984303405e-6*x_69 + 0.000973389915670154*x_7 + 0.000382181380890626*x_70 + 0.000769083245317397*x_71 - 0.000434212599709268*x_72 + 0.000539466523263021*x_73 - 0.000984951898537564*x_74 - 0.000710037147900205*x_75 - 0.00214353169376117*x_76 - 0.00093220819886096*x_77 + 0.000263473324945654*x_78 - 1.85831423444533e-5*x_79 + 0.000357114592609704*x_8 - 0.00101323993045408*x_80 - 0.000351096959902586*x_81 + 0.000548420940240496*x_82 + 2.8511662345303e-6*x_83 - 0.00125521436444204*x_84 - 0.00067874348181344*x_85 - 0.000752519495966144*x_86 + 0.0010492748678442*x_87 + 0.000196472275675331*x_88 - 0.000691173551765805*x_89 + 0.000921980214209124*x_9 - 0.000435994137314882*x_90 - 0.000857368097216667*x_91 + 0.0031881412899686*x_92 - 0.00209990249531382*x_93 - 0.00251929850122316*x_94 + 0.001332851709473*x_95 - 0.00169018675132986*x_96 + 0.000282110878289962*x_97 + 0.000256749604631473*x_98 + 0.00280222426021294*x_99 + 2.74532666805849e-6*std::pow(-3.11615991592407*x_28 - 7.80615997314453, 2) - 7.32212522969786e-6*std::pow(-4.07271957397461*x_64 - 9.9672794342041, 2) - 1.77389930361456e-6*std::pow(-4.70783948898315*x_8 - 6.14423990249634, 2) + 0.00260509132675332*std::exp(0.183999866247177*x_10) - 0.00458236120348529*std::sin(0.212719991803169*x_1 + 5.01215982437134) + 0.00306938206955026*std::sin(0.246879979968071*x_1 - 7.55592012405396) + 0.0154512080992525*std::sin(0.270639955997467*x_1 + 5.06863975524902) - 0.0182804463061998*std::sin(0.309119910001755*x_1 + 5.12335968017578) + 0.0342511918072925*std::sin(0.326159834861755*x_1 + 8.32335948944092) + 0.00636963375166681*std::sin(0.333519846200943*x_1 - 4.24272012710571) + 0.176276487435361*std::sin(0.334079831838608*x_1 - 4.24832010269165) + 0.0708969232098086*std::sin(0.345999836921692*x_1 - 4.23943996429443) + 0.0106568258789259*std::sin(0.352639853954315*x_1 - 4.22119998931885) + 0.000338998066065128*std::sin(0.366159856319427*x_1 + 8.36544036865234) - 0.00151050865927136*std::sin(0.669359803199768*x_1 + 2.20183968544006) + 0.00809896119185577*std::sin(0.329439848661423*x_10 + 5.07223987579346) - 0.00841026768344297*std::sin(0.22503998875618*x_100 - 4.40079975128174) - 0.00458102823166122*std::sin(0.246639966964722*x_100 + 1.96799981594086) + 0.0117624647302099*std::sin(0.257359951734543*x_107 - 7.44687986373901) + 0.0018526895099249*std::sin(0.244079977273941*x_11 + 1.96719980239868) + 0.00172886745909401*std::sin(0.256879955530167*x_11 + 5.17695999145508) + 0.0915533496885846*std::sin(0.26895996928215*x_11 - 7.42095994949341) - 0.00617458475953129*std::sin(0.280799955129623*x_113 - 7.41103982925415) - 0.0224771275218444*std::sin(0.288559943437576*x_113 - 7.43031978607178) + 0.00536564199369839*std::sin(0.236719980835915*x_116 + 1.98751986026764) - 0.0207420285174627*std::sin(0.247999966144562*x_116 - 7.43703985214233) - 0.000878117861436496*std::sin(0.257119953632355*x_116 - 4.40911960601807) - 0.0054418046268162*std::sin(0.236159980297089*x_119 + 5.174880027771) + 0.0260408300013604*std::sin(0.282719939947128*x_12 - 4.24959993362427) + 0.0424763894035086*std::sin(0.305519938468933*x_12 - 7.46560001373291) + 0.00794078433145824*std::sin(0.243599981069565*x_120 - 4.21704006195068) + 0.00746509711424719*std::sin(0.259839981794357*x_120 - 4.24631977081299) - 0.029064550814098*std::sin(0.262159943580627*x_120 + 5.16527986526489) - 0.0154029678589047*std::sin(0.264319956302643*x_120 + 5.15952014923096) - 0.00341919893573615*std::sin(0.268479973077774*x_120 + 5.15248012542725) - 0.0250320742433584*std::sin(0.208000004291534*x_13 + 5.20496034622192) - 0.0109398697928214*std::sin(0.265359938144684*x_13 - 4.39911985397339) - 0.00395643981451637*std::sin(0.288719952106476*x_14 - 4.24064016342163) - 0.000899644891241619*std::sin(0.290559947490692*x_14 + 4.80288028717041) + 0.0418254006964762*std::sin(0.294959932565689*x_14 - 4.25464010238647) + 0.0130885097559289*std::sin(0.297279924154282*x_14 + 4.98759984970093) - 0.00390643821462044*std::sin(0.318319916725159*x_14 + 5.12160015106201) - 0.00832690092813175*std::sin(0.33247983455658*x_14 + 1.86767983436584) - 0.000163690848749755*std::sin(0.460639864206314*x_14 + 7.76711988449097) - 0.00718784967233009*std::sin(0.198239997029305*x_15 + 8.19207954406738) + 0.00307802096725008*std::sin(0.269839942455292*x_15 + 1.99335980415344) - 0.047948400330031*std::sin(0.321759909391403*x_15 - 7.44143962860107) - 0.00183305621763785*std::sin(0.253999978303909*x_16 - 7.39783954620361) + 0.0068056660173294*std::sin(0.350239843130112*x_16 - 1.15351986885071) - 0.00192474266842518*std::sin(0.356159836053848*x_16 - 1.14495992660522) + 0.000606109665739129*std::sin(0.689119875431061*x_16 - 7.84295988082886) + 0.0159473676097701*std::sin(0.332639843225479*x_17 - 1.1490398645401) + 0.00252780746020069*std::sin(0.352479845285416*x_17 + 2.00735974311829) - 0.000915474543731379*std::sin(0.398319840431213*x_17 + 1.99095976352692) - 0.00114370053472834*std::sin(0.272399961948395*x_18 - 1.17335987091064) + 0.00220186507696206*std::sin(0.276239961385727*x_18 - 1.16479980945587) + 0.000730702585993383*std::sin(0.280479967594147*x_18 + 2.00055980682373) - 0.0158713836868458*std::sin(0.344239860773087*x_18 - 1.15015983581543) - 0.00217491495563003*std::sin(0.367839843034744*x_18 + 1.99519979953766) + 0.00205014940311105*std::sin(0.384639829397202*x_18 + 2.00191974639893) + 0.00808740126791841*std::sin(0.393519848585129*x_18 + 5.18936014175415) - 0.0023871633664249*std::sin(0.292719930410385*x_19 + 1.98071980476379) + 0.00302000128669108*std::sin(0.373119831085205*x_2 - 7.39439964294434) - 0.00316431135807208*std::sin(0.378239840269089*x_2 + 5.18455982208252) + 0.0191477535850504*std::sin(0.387199848890305*x_2 + 5.19736003875732) - 0.0320494053644871*std::sin(0.392479836940765*x_2 + 5.19144010543823) - 0.00510718648425605*std::sin(0.393279850482941*x_2 + 5.18304014205933) - 0.0114549236052291*std::sin(0.264879941940308*x_20 - 1.16751992702484) - 0.000428932586643723*std::sin(0.311919927597046*x_20 + 8.18335914611816) + 0.000888057453897048*std::sin(0.396639823913574*x_20 - 4.40351963043213) + 0.000492560773938131*std::sin(0.779839873313904*x_20 - 1.36743986606598) - 0.00127891455281855*std::sin(0.262959957122803*x_21 - 7.38935995101929) + 0.00542533941218218*std::sin(0.459439843893051*x_21 - 7.62784004211426) - 0.00210117260723053*std::sin(0.298159927129745*x_23 - 4.34663963317871) + 0.00893873830051002*std::sin(0.310159921646118*x_23 + 8.23967933654785) + 0.0641644863594346*std::sin(0.341519832611084*x_23 + 1.9962397813797) - 0.0580339754159068*std::sin(0.346639841794968*x_23 - 1.15591979026794) + 0.00199455087622617*std::sin(0.368399828672409*x_23 + 2.02231979370117) + 0.00298041471837038*std::sin(0.238879978656769*x_24 - 1.17855989933014) - 0.000875244790947414*std::sin(0.247199967503548*x_25 - 4.38279962539673) - 0.000966881357448517*std::sin(0.333119839429855*x_25 - 1.13919985294342) + 0.0128136135671816*std::sin(0.348159849643707*x_25 + 8.23272037506104) + 0.00609822501625121*std::sin(0.384799838066101*x_25 + 8.20487976074219) + 0.00104124125890754*std::sin(0.141840040683746*x_26 - 1.25295984745026) - 0.0151076900275614*std::sin(0.283519923686981*x_26 - 1.17279982566833) + 0.0108490043064253*std::sin(0.353679865598679*x_26 + 5.01056003570557) + 0.0189794340072339*std::sin(0.1891999989748*x_27 + 8.18383979797363) + 0.0114821241545973*std::sin(0.226879984140396*x_27 + 5.00183963775635) - 0.00152046808128284*std::sin(0.698799848556519*x_27 + 5.2292799949646) + 0.00823960278992189*std::sin(0.308639913797379*x_28 + 1.9936797618866) + 0.00192742672655674*std::sin(0.410879880189896*x_28 + 8.20399951934814) + 0.00190926657146131*std::sin(0.29079994559288*x_29 - 1.16375982761383) - 0.00937839862722501*std::sin(0.267839968204498*x_3 - 4.3551197052002) - 0.00151499203129562*std::sin(0.324559837579727*x_3 - 7.40367984771729) - 0.0224560823591278*std::sin(0.357199847698212*x_3 - 7.38823986053467) - 0.0144653823717829*std::sin(0.36287984251976*x_3 - 7.39383983612061) - 0.00296525816671168*std::sin(0.365039855241776*x_3 - 7.41415977478027) + 0.0207538683119053*std::sin(0.370799839496613*x_3 - 7.40367984771729) - 0.00134767703372181*std::sin(0.385759830474854*x_3 + 1.99527978897095) + 0.000885170772477072*std::sin(0.39183983206749*x_3 + 1.99183976650238) + 0.00024927718771975*std::sin(0.449039846658707*x_3 + 8.18967914581299) - 0.0151739514846354*std::sin(0.191760003566742*x_30 + 8.18335914611816) + 0.0884890974668021*std::sin(0.304079920053482*x_30 + 1.99335980415344) + 0.0533046932740034*std::sin(0.389519840478897*x_30 + 2.00319981575012) + 0.0221224944062816*std::sin(0.390079855918884*x_30 + 1.99391984939575) + 0.00449615096573539*std::sin(0.342559844255447*x_31 - 7.44663953781128) - 0.0377700252119944*std::sin(0.367919832468033*x_31 + 5.17503976821899) + 0.0133466158425694*std::sin(0.369759827852249*x_31 + 5.17216014862061) + 0.00136442290334658*std::sin(0.370159834623337*x_31 + 5.17727994918823) - 0.00978833772082408*std::sin(0.377839833498001*x_31 - 7.40151977539063) - 0.012065922699909*std::sin(0.380639851093292*x_31 - 7.39687967300415) - 0.0137916028496691*std::sin(0.380719840526581*x_31 - 7.39687967300415) + 0.000438770576240776*std::sin(0.423199862241745*x_31 + 5.21799993515015) - 0.00742812333844414*std::sin(0.263039946556091*x_32 + 5.23415994644165) + 0.00219275434454372*std::sin(0.294079929590225*x_32 - 4.36799955368042) + 0.0387031829758342*std::sin(0.30991992354393*x_32 - 1.14351987838745) - 0.00275885560679046*std::sin(0.310159921646118*x_32 - 1.14815986156464) + 0.0148423482988839*std::sin(0.32847985625267*x_32 + 1.99999976158142) + 0.0180203396657783*std::sin(0.241039976477623*x_33 + 1.99663984775543) + 0.000139165383863832*std::sin(0.245679974555969*x_36 + 1.78207981586456) - 0.00205868836825136*std::sin(0.317439913749695*x_4 - 1.14063990116119) + 0.000126593054763388*std::sin(0.530719876289368*x_44 + 5.1005597114563) - 0.0016528538632778*std::sin(0.635519862174988*x_45 - 1.40887975692749) + 0.0011431364837436*std::sin(0.338719844818115*x_5 + 2.01407980918884) - 0.00363888035508961*std::sin(0.339759826660156*x_5 + 2.00815987586975) - 0.0883952610933055*std::sin(0.351199835538864*x_5 + 2.00807976722717) + 0.00101786357377004*std::sin(0.210960000753403*x_56 - 1.01687979698181) - 0.00306880227534194*std::sin(0.217439994215965*x_56 - 7.39751958847046) - 0.00165565759253786*std::sin(0.247839972376823*x_56 - 7.42392015457153) - 0.00224030159266328*std::sin(0.274239957332611*x_57 - 7.45928001403809) + 0.00591222875188444*std::sin(0.299679934978485*x_6 + 5.21031999588013) + 0.0344449221334157*std::sin(0.314479917287827*x_6 + 2.01639986038208) - 0.0950563405262006*std::sin(0.352959841489792*x_6 + 2.014399766922) - 0.000265801441616881*std::sin(0.573599874973297*x_6 - 7.57480001449585) + 0.00232963888508644*std::sin(0.444079846143723*x_60 + 5.10624027252197) - 0.00289829014406221*std::sin(0.334399849176407*x_7 - 1.14743983745575) + 0.0405617347078293*std::sin(0.339119851589203*x_7 - 1.15287983417511) + 0.0618750367763932*std::sin(0.340719848871231*x_7 - 1.14399981498718) - 0.0253338821099699*std::sin(0.344799846410751*x_7 + 2.02967977523804) - 0.00239613284075842*std::sin(0.345839858055115*x_7 - 1.14471983909607) + 0.00529500564363883*std::sin(0.346959829330444*x_7 - 7.36223983764648) + 0.025699043976936*std::sin(0.348799854516983*x_7 + 2.01079988479614) + 0.00536243276049109*std::sin(0.349759846925735*x_7 - 1.15015983581543) - 7.79121311102493e-5*std::sin(0.97055983543396*x_72 + 8.38920021057129) + 0.00646171334341734*std::sin(0.266479969024658*x_8 - 7.40127992630005) - 0.00388619836506711*std::sin(0.313199937343597*x_8 - 7.42335987091064) - 0.00320885334673188*std::sin(0.326239854097366*x_8 + 8.24759960174561) + 0.00491509076375469*std::sin(0.334319829940796*x_8 - 7.55656003952026) - 0.000781563459164075*std::sin(0.363439828157425*x_8 + 5.01847982406616) - 0.00102246135301454*std::sin(0.405199855566025*x_8 + 4.79080009460449) + 0.00288497414904533*std::sin(0.206080004572868*x_9 - 7.41024017333984) + 0.00472706248979414*std::sin(0.404639840126038*x_9 - 4.38887977600098) + 0.00532671243144346*std::sin(0.339599847793579*x_91 + 2.00343990325928) + 0.00213048701985694*std::sin(0.358399868011475*x_91 + 1.99927973747253) - 0.000458079014474437*std::sin(0.377519845962524*x_91 + 1.9975198507309) + 0.00117166204728856*std::sin(0.379759848117828*x_91 + 1.99135982990265) + 0.000291473014814261*std::sin(0.424319863319397*x_91 + 5.00743961334229) + 0.00230242174162174*std::sin(0.215199992060661*x_92 + 1.98735988140106) + 0.0013561791338367*std::sin(0.255759954452515*x_92 + 1.99335980415344) - 0.00532757419653177*std::sin(0.292079925537109*x_92 + 2.01063990592957) - 0.0276101436402122*std::sin(0.293359935283661*x_92 + 1.99031984806061) + 0.0264446957901651*std::sin(0.293599933385849*x_92 - 7.38927984237671) - 0.0012606828309511*std::sin(0.309599906206131*x_92 - 4.39079999923706) + 0.00212831187738298*std::sin(0.225439995527267*x_93 - 1.1833598613739) - 0.0127443205261122*std::sin(0.281519949436188*x_94 - 7.42119979858398) + 0.000167946878411853*std::sin(0.310239940881729*x_97 - 1.41639983654022) - 0.285188352180155);
}

inline float score_4(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.000703420101725922*x_1 + 0.000681145366109829*x_10 + 0.000406582377542805*x_100 + 0.00047677866165267*x_101 + 1.24864182895105e-5*x_102 + 0.000919966300900576*x_103 - 0.000423747875191601*x_104 - 0.000111127328565321*x_105 + 5.72803623091776e-5*x_106 + 0.0007631474098789*x_107 - 0.000786905343480872*x_108 + 0.00026149362167142*x_109 + 0.000626643496042979*x_11 + 0.00110002510883039*x_110 - 8.16114192855583e-5*x_111 - 0.00772210086866001*x_112 + 0.000254325943274236*x_113 - 0.0004464329122414*x_114 - 0.000147152070189864*x_115 - 0.00380449690461332*x_116 + 0.000491869835776104*x_117 + 0.000364297506724838*x_118 - 0.00109995965479393*x_119 + 0.000813606351611282*x_12 + 0.00143163359233467*x_120 + 0.000455929813707737*x_13 - 0.000146066132720424*x_14 - 0.00060272966240988*x_15 + 0.000277834395549388*x_16 - 1.07718679009576e-5*x_17 - 0.000819057686384841*x_18 - 0.00206484492747106*x_19 + 0.000648201508164897*x_2 + 0.000104513454621856*x_20 + 0.00117856811720986*x_21 + 2.16424713201459e-5*x_22 + 5.81991068747842e-5*x_23 - 8.90259583382936e-5*x_24 - 0.000953570234094588*x_25 + 0.000560082434605393*x_26 - 0.000485382265419302*x_27 + 0.000377445393201716*x_28 - 0.000197220475494768*x_29 - 0.000297360237286202*x_3 - 0.000973350293177003*x_30 + 0.000317872007022967*x_31 + 0.000419258056114352*x_32 - 0.000796525228041619*x_33 + 0.00148661598191918*x_34 - 5.81486814519311e-5*x_35 + 0.000689858699700129*x_36 - 9.3781999045314e-5*x_37 + 0.000380681532336313*x_38 - 0.000187806874806935*x_39 + 4.72727168543525e-5*x_4 - 0.000330656784136787*x_40 + 0.000875555440970879*x_41 + 7.4897343800141e-5*x_42 + 0.00107698813441876*x_43 + 0.000137652119315011*x_44 - 0.000964350419340702*x_45 - 0.000739628810812444*x_46 - 0.00148169585882077*x_47 - 0.00195950128471932*x_48 - 0.00148000502304741*x_49 + 0.000193623207749323*x_5 + 0.000640482076316002*x_50 + 0.00132559473410684*x_51 - 0.00149641590383684*x_52 - 0.00128818459968734*x_53 - 0.000242645579891746*x_54 - 0.00156503206187619*x_55 - 0.00154557691636296*x_56 - 0.000991157189523526*x_57 - 0.000985657362055722*x_58 - 0.00284442878540729*x_59 - 0.00128461841211095*x_6 - 0.000487828648141002*x_60 + 0.000626864650650629*x_61 + 0.000108138322742624*x_62 - 6.54693580641979e-5*x_63 - 6.87833156918255e-5*x_64 - 0.000683570537003433*x_65 - 0.000152828047614986*x_66 + 0.000880268797919768*x_67 + 0.000221372143115942*x_68 + 0.000530274989611772*x_69 - 1.20815461864006e-5*x_7 - 5.07212797955033e-5*x_70 + 0.00018593286349092*x_71 + 0.000422424126063248*x_72 + 0.000680433870923488*x_73 + 0.000630190174031395*x_74 - 5.24529779645978e-5*x_75 + 0.00064062200309227*x_76 + 0.000461897860322571*x_77 + 0.000178309032434974*x_78 + 0.000245242843296118*x_79 + 3.90917476746062e-5*x_8 + 0.000502759391771801*x_80 + 0.000361856436954719*x_81 - 0.000114547066805195*x_82 + 0.000566335064893449*x_83 + 1.89121723857532e-5*x_84 + 8.9094676789271e-5*x_85 + 3.34760812955674e-5*x_86 + 0.000502388634370265*x_87 + 0.000667674276039816*x_88 + 0.00050621966347038*x_89 + 9.87224192515801e-5*x_9 + 9.87620897605505e-5*x_90 + 0.000954286523831956*x_91 + 0.000482641456699878*x_92 + 0.00135666923754534*x_93 + 0.000636595546919751*x_94 - 0.000182133209911486*x_95 + 0.00183476815089279*x_96 + 0.00194759196555107*x_97 + 0.000622986124557529*x_98 + 0.0019669898923694*x_99 + 3.34632907683012e-6*std::pow(-3.11615991592407*x_28 - 7.80615997314453, 2) + 1.68551611926213e-6*std::pow(-4.07271957397461*x_64 - 9.9672794342041, 2) + 7.95893428973994e-7*std::pow(-4.70783948898315*x_8 - 6.14423990249634, 2) - 0.000797199191564725*std::exp(0.183999866247177*x_10) + 0.00140227507932659*std::sin(0.212719991803169*x_1 + 5.01215982437134) + 0.00742228374836122*std::sin(0.246879979968071*x_1 - 7.55592012405396) - 0.00442464113696842*std::sin(0.270639955997467*x_1 + 5.06863975524902) + 0.00420806609417648*std::sin(0.309119910001755*x_1 + 5.12335968017578) + 0.011579887301345*std::sin(0.326159834861755*x_1 + 8.32335948944092) - 0.0444733488928268*std::sin(0.333519846200943*x_1 - 4.24272012710571) + 0.0271546517383257*std::sin(0.334079831838608*x_1 - 4.24832010269165) - 0.0318092437390241*std::sin(0.345999836921692*x_1 - 4.23943996429443) + 0.00219303884007619*std::sin(0.352639853954315*x_1 - 4.22119998931885) + 0.000413210966352929*std::sin(0.366159856319427*x_1 + 8.36544036865234) - 0.00113207875840529*std::sin(0.669359803199768*x_1 + 2.20183968544006) + 0.00124761091967925*std::sin(0.329439848661423*x_10 + 5.07223987579346) + 0.00193600099739587*std::sin(0.22503998875618*x_100 - 4.40079975128174) + 0.00140186716884391*std::sin(0.246639966964722*x_100 + 1.96799981594086) + 0.00132578719283937*std::sin(0.257359951734543*x_107 - 7.44687986373901) + 0.00038125987043682*std::sin(0.244079977273941*x_11 + 1.96719980239868) + 0.00210734828596669*std::sin(0.256879955530167*x_11 + 5.17695999145508) + 0.0141034085852334*std::sin(0.26895996928215*x_11 - 7.42095994949341) - 0.00752631472187756*std::sin(0.280799955129623*x_113 - 7.41103982925415) - 0.00759922764221885*std::sin(0.288559943437576*x_113 - 7.43031978607178) + 0.00110418068455018*std::sin(0.236719980835915*x_116 + 1.98751986026764) - 0.0070126129912467*std::sin(0.247999966144562*x_116 - 7.43703985214233) + 0.00282098561875902*std::sin(0.257119953632355*x_116 - 4.40911960601807) - 0.00663311556508574*std::sin(0.236159980297089*x_119 + 5.174880027771) - 0.0116837102539474*std::sin(0.282719939947128*x_12 - 4.24959993362427) + 0.00654330919645047*std::sin(0.305519938468933*x_12 - 7.46560001373291) + 0.00595136824376619*std::sin(0.243599981069565*x_120 - 4.21704006195068) + 0.00909934392340729*std::sin(0.259839981794357*x_120 - 4.24631977081299) - 0.00982635070876016*std::sin(0.262159943580627*x_120 + 5.16527986526489) + 0.00471355203509108*std::sin(0.264319956302643*x_120 + 5.15952014923096) + 0.0109843011388117*std::sin(0.268479973077774*x_120 + 5.15248012542725) + 0.011231112929174*std::sin(0.208000004291534*x_13 + 5.20496034622192) - 0.00819908852303236*std::sin(0.265359938144684*x_13 - 4.39911985397339) + 0.027624214374714*std::sin(0.288719952106476*x_14 - 4.24064016342163) - 0.000185135443816396*std::sin(0.290559947490692*x_14 + 4.80288028717041) - 0.0187657560441564*std::sin(0.294959932565689*x_14 - 4.25464010238647) + 0.00201622989751402*std::sin(0.297279924154282*x_14 + 4.98759984970093) + 0.0011186560372759*std::sin(0.318319916725159*x_14 + 5.12160015106201) - 0.00624075049568434*std::sin(0.33247983455658*x_14 + 1.86767983436584) + 0.000525862814691091*std::sin(0.460639864206314*x_14 + 7.76711988449097) + 0.00165460656646613*std::sin(0.198239997029305*x_15 + 8.19207954406738) + 0.00375185626601077*std::sin(0.269839942455292*x_15 + 1.99335980415344) + 0.0215129554844102*std::sin(0.321759909391403*x_15 - 7.44143962860107) - 0.00180402510557581*std::sin(0.253999978303909*x_16 - 7.39783954620361) + 0.00140051926137827*std::sin(0.350239843130112*x_16 - 1.15351986885071) - 0.00234610417467068*std::sin(0.356159836053848*x_16 - 1.14495992660522) + 0.000204917880259589*std::sin(0.689119875431061*x_16 - 7.84295988082886) + 0.00328176484842071*std::sin(0.332639843225479*x_17 - 1.1490398645401) + 0.00248777319341595*std::sin(0.352479845285416*x_17 + 2.00735974311829) + 0.00639192461814826*std::sin(0.398319840431213*x_17 + 1.99095976352692) - 0.00139407757884574*std::sin(0.272399961948395*x_18 - 1.17335987091064) - 0.00707357177132981*std::sin(0.276239961385727*x_18 - 1.16479980945587) + 0.000719130050217405*std::sin(0.280479967594147*x_18 + 2.00055980682373) - 0.00178891734915191*std::sin(0.344239860773087*x_18 - 1.15015983581543) + 0.0151854494944313*std::sin(0.367839843034744*x_18 + 1.99519979953766) - 0.000587085186327614*std::sin(0.384639829397202*x_18 + 2.00191974639893) - 0.00144572799204199*std::sin(0.393519848585129*x_18 + 5.18936014175415) + 0.00766884927644762*std::sin(0.292719930410385*x_19 + 1.98071980476379) + 0.000621477745253466*std::sin(0.373119831085205*x_2 - 7.39439964294434) - 0.00311419643156222*std::sin(0.378239840269089*x_2 + 5.18455982208252) - 0.00548319184161703*std::sin(0.387199848890305*x_2 + 5.19736003875732) + 0.0143795710839636*std::sin(0.392479836940765*x_2 + 5.19144010543823) + 0.0164070226300125*std::sin(0.393279850482941*x_2 + 5.18304014205933) - 0.00387276230095522*std::sin(0.264879941940308*x_20 - 1.16751992702484) - 0.00103723136932729*std::sin(0.311919927597046*x_20 + 8.18335914611816) + 0.000182750897006464*std::sin(0.396639823913574*x_20 - 4.40351963043213) - 8.80516342733063e-5*std::sin(0.779839873313904*x_20 - 1.36743986606598) - 0.00125865968483174*std::sin(0.262959957122803*x_21 - 7.38935995101929) + 0.000835750725711741*std::sin(0.459439843893051*x_21 - 7.62784004211426) + 0.00675009354419831*std::sin(0.298159927129745*x_23 - 4.34663963317871) + 0.00100751543411833*std::sin(0.310159921646118*x_23 + 8.23967933654785) - 0.0287886087800516*std::sin(0.341519832611084*x_23 + 1.9962397813797) - 0.00893988991009007*std::sin(0.346639841794968*x_23 - 1.15591979026794) + 0.000410453130206616*std::sin(0.368399828672409*x_23 + 2.02231979370117) - 0.0208095204187708*std::sin(0.238879978656769*x_24 - 1.17855989933014) - 0.00106685194420332*std::sin(0.247199967503548*x_25 - 4.38279962539673) - 0.000951568329528973*std::sin(0.333119839429855*x_25 - 1.13919985294342) + 0.00144426573435167*std::sin(0.348159849643707*x_25 + 8.23272037506104) - 0.0017463008132484*std::sin(0.384799838066101*x_25 + 8.20487976074219) - 0.00727003899979078*std::sin(0.141840040683746*x_26 - 1.25295984745026) + 0.00432627056416057*std::sin(0.283519923686981*x_26 - 1.17279982566833) + 0.00167124349897545*std::sin(0.353679865598679*x_26 + 5.01056003570557) + 0.00213923621547656*std::sin(0.1891999989748*x_27 + 8.18383979797363) + 0.00176877294964615*std::sin(0.226879984140396*x_27 + 5.00183963775635) - 0.00113954303213586*std::sin(0.698799848556519*x_27 + 5.2292799949646) - 0.00369685342594821*std::sin(0.308639913797379*x_28 + 1.9936797618866) + 0.000217246786946127*std::sin(0.410879880189896*x_28 + 8.20399951934814) + 0.00232724007595755*std::sin(0.29079994559288*x_29 - 1.16375982761383) + 0.00420779568857025*std::sin(0.267839968204498*x_3 - 4.3551197052002) - 0.00149099827539745*std::sin(0.324559837579727*x_3 - 7.40367984771729) - 0.00345926507125845*std::sin(0.357199847698212*x_3 - 7.38823986053467) - 0.00163044218434753*std::sin(0.36287984251976*x_3 - 7.39383983612061) - 0.00361440761823535*std::sin(0.365039855241776*x_3 - 7.41415977478027) - 0.00594312230436684*std::sin(0.370799839496613*x_3 - 7.40367984771729) + 0.000412410509658538*std::sin(0.385759830474854*x_3 + 1.99527978897095) + 0.000182156854789311*std::sin(0.39183983206749*x_3 + 1.99183976650238) - 0.00174047547672299*std::sin(0.449039846658707*x_3 + 8.18967914581299) - 0.018495808041436*std::sin(0.191760003566742*x_30 + 8.18335914611816) + 0.0136313734140572*std::sin(0.304079920053482*x_30 + 1.99335980415344) - 0.0122704702428811*std::sin(0.389519840478897*x_30 + 2.00319981575012) + 0.00249350118620806*std::sin(0.390079855918884*x_30 + 1.99391984939575) - 0.000803745367921304*std::sin(0.342559844255447*x_31 - 7.44663953781128) + 0.0169462352328316*std::sin(0.367919832468033*x_31 + 5.17503976821899) + 0.00205599005495892*std::sin(0.369759827852249*x_31 + 5.17216014862061) + 0.00166312012617085*std::sin(0.370159834623337*x_31 + 5.17727994918823) - 0.00201431505454171*std::sin(0.377839833498001*x_31 - 7.40151977539063) + 0.0387622162221134*std::sin(0.380639851093292*x_31 - 7.39687967300415) - 0.00155449821497505*std::sin(0.380719840526581*x_31 - 7.39687967300415) + 0.000431821527081343*std::sin(0.423199862241745*x_31 + 5.21799993515015) - 0.00114427116888601*std::sin(0.263039946556091*x_32 + 5.23415994644165) + 0.000741342033649895*std::sin(0.294079929590225*x_32 - 4.36799955368042) - 0.0110831266025584*std::sin(0.30991992354393*x_32 - 1.14351987838745) + 0.0192625750128281*std::sin(0.310159921646118*x_32 - 1.14815986156464) - 0.00665929991491319*std::sin(0.32847985625267*x_32 + 1.99999976158142) - 0.00516034317026665*std::sin(0.241039976477623*x_33 + 1.99663984775543) - 0.00097166507709502*std::sin(0.245679974555969*x_36 + 1.78207981586456) - 0.00202608379663788*std::sin(0.317439913749695*x_4 - 1.14063990116119) + 0.00012458813144257*std::sin(0.530719876289368*x_44 + 5.1005597114563) - 0.000186298750630106*std::sin(0.635519862174988*x_45 - 1.40887975692749) + 0.00112503200716375*std::sin(0.338719844818115*x_5 + 2.01407980918884) + 0.00104203759396747*std::sin(0.339759826660156*x_5 + 2.00815987586975) + 0.0396602035488983*std::sin(0.351199835538864*x_5 + 2.00807976722717) - 0.00326992381041734*std::sin(0.210960000753403*x_56 - 1.01687979698181) + 0.000878788810653396*std::sin(0.217439994215965*x_56 - 7.39751958847046) + 0.000506657436813984*std::sin(0.247839972376823*x_56 - 7.42392015457153) + 0.000685567757333925*std::sin(0.274239957332611*x_57 - 7.45928001403809) - 0.00180923560450451*std::sin(0.299679934978485*x_6 + 5.21031999588013) + 0.0116453850322263*std::sin(0.314479917287827*x_6 + 2.01639986038208) + 0.0426488226546798*std::sin(0.352959841489792*x_6 + 2.014399766922) - 0.000323990257004629*std::sin(0.573599874973297*x_6 - 7.57480001449585) - 0.000667120394665668*std::sin(0.444079846143723*x_60 + 5.10624027252197) - 0.00353277906596976*std::sin(0.334399849176407*x_7 - 1.14743983745575) - 0.0093371057624074*std::sin(0.339119851589203*x_7 - 1.15287983417511) + 0.0095315892630046*std::sin(0.340719848871231*x_7 - 1.14399981498718) + 0.00725466489240434*std::sin(0.344799846410751*x_7 + 2.02967977523804) - 0.00235818397680856*std::sin(0.345839858055115*x_7 - 1.14471983909607) - 0.00162035556108519*std::sin(0.346959829330444*x_7 - 7.36223983764648) + 0.00868851614506057*std::sin(0.348799854516983*x_7 + 2.01079988479614) + 0.00110352026528928*std::sin(0.349759846925735*x_7 - 1.15015983581543) - 0.000188404679325088*std::sin(0.97055983543396*x_72 + 8.38920021057129) - 0.00148745366361763*std::sin(0.266479969024658*x_8 - 7.40127992630005) - 0.00473695853344498*std::sin(0.313199937343597*x_8 - 7.42335987091064) + 0.000981959928849221*std::sin(0.326239854097366*x_8 + 8.24759960174561) + 0.000757149066752089*std::sin(0.334319829940796*x_8 - 7.55656003952026) - 0.00076918541197258*std::sin(0.363439828157425*x_8 + 5.01847982406616) + 0.000292794229062734*std::sin(0.405199855566025*x_8 + 4.79080009460449) - 0.000882847766481334*std::sin(0.206080004572868*x_9 - 7.41024017333984) - 0.00135365176722818*std::sin(0.404639840126038*x_9 - 4.38887977600098) - 0.00152536881243001*std::sin(0.339599847793579*x_91 + 2.00343990325928) - 0.00684426716265335*std::sin(0.358399868011475*x_91 + 1.99927973747253) - 0.0004508241670374*std::sin(0.377519845962524*x_91 + 1.9975198507309) + 0.00142816037984755*std::sin(0.379759848117828*x_91 + 1.99135982990265) + 0.00070483093076084*std::sin(0.424319863319397*x_91 + 5.00743961334229) + 0.00077841916970812*std::sin(0.215199992060661*x_92 + 1.98735988140106) + 0.00165307164416885*std::sin(0.255759954452515*x_92 + 1.99335980415344) + 0.0171150261841868*std::sin(0.292079925537109*x_92 + 2.01063990592957) - 0.00425322654145825*std::sin(0.293359935283661*x_92 + 1.99031984806061) - 0.00608743494887563*std::sin(0.293599933385849*x_92 - 7.38927984237671) + 0.00880219955651508*std::sin(0.309599906206131*x_92 - 4.39079999923706) - 0.000380463384342495*std::sin(0.225439995527267*x_93 - 1.1833598613739) + 0.00389996385774325*std::sin(0.281519949436188*x_94 - 7.42119979858398) - 0.00117262002970217*std::sin(0.310239940881729*x_97 - 1.41639983654022) + 0.032964629659569);
}

inline float score_5(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.000352532939518448*x_1 - 0.00013369490213357*x_10 - 0.000313070496636911*x_100 - 0.00026365493489252*x_101 + 0.00010224973390408*x_102 + 0.000210923828168895*x_103 - 0.00108565869005196*x_104 - 0.000170939753121778*x_105 + 7.19282509241062e-5*x_106 + 0.00137103402211604*x_107 - 0.00035846709124263*x_108 - 0.000583008102039804*x_109 - 0.00243757420149194*x_11 - 0.00106804044166347*x_110 + 0.000701095664778794*x_111 - 0.000911120001651236*x_112 - 0.00149992602826572*x_113 - 0.000530805793272617*x_114 + 2.56074932698463e-5*x_115 - 0.00227522911512711*x_116 - 0.000859607947566786*x_117 + 0.00163668564207388*x_118 - 0.000288694760549525*x_119 - 0.000256011564407129*x_12 + 0.00645057373097789*x_120 + 0.000696790385057159*x_13 - 0.000121783988473455*x_14 - 0.000295254024993009*x_15 + 0.000538549110226612*x_16 + 0.00130365540924556*x_17 + 0.00256417201170311*x_18 + 0.00103705151143949*x_19 - 0.000385702734219514*x_2 + 0.000507867719138091*x_20 + 0.0004685426400262*x_21 + 0.000564958511734135*x_22 - 0.000525854782114884*x_23 - 0.000121004263851503*x_24 - 0.000265246111809554*x_25 - 0.00159234069870403*x_26 - 0.00014200601742327*x_27 - 0.000832791723657643*x_28 - 0.00116420490340157*x_29 - 5.77865702608772e-5*x_3 + 0.00534990614097841*x_30 - 0.0006101506574832*x_31 - 0.000100430468670649*x_32 - 0.000184495449951157*x_33 + 0.00190642642673435*x_34 - 0.00137288338411591*x_35 + 0.00135953803066118*x_36 - 0.000442148809995517*x_37 + 0.000523539775975813*x_38 + 0.000956851313805818*x_39 + 0.000598577464764485*x_4 - 2.84722157567449e-5*x_40 + 9.20839465651126e-5*x_41 + 0.000490399986010607*x_42 + 5.68436433986589e-5*x_43 - 0.000578502582288723*x_44 + 0.000881336198640129*x_45 - 6.69383248659075e-5*x_46 + 0.00252228534969567*x_47 + 0.004620971413452*x_48 + 0.000368533070110547*x_49 - 0.000686833270852196*x_5 + 9.33103953978647e-5*x_50 - 0.00269548699115082*x_51 - 0.00255617596308434*x_52 - 0.00302540038824434*x_53 - 8.74592377642465e-5*x_54 - 0.000468078751020985*x_55 - 0.000129579330831114*x_56 - 0.00102418934721691*x_57 - 0.00126189434482299*x_58 - 0.000596078182187911*x_59 - 0.00511975967511205*x_6 + 0.00132393483763127*x_60 + 0.000508840729327271*x_61 + 0.000182117904024995*x_62 - 5.32544092507345e-5*x_63 + 5.89071095381005e-5*x_64 - 2.54094349558234e-5*x_65 - 0.000430361115100908*x_66 - 0.000462861801581153*x_67 + 0.000274411839877616*x_68 + 0.000216409956106305*x_69 - 0.00040164599440133*x_7 - 0.000236657193953019*x_70 - 0.000300973122133898*x_71 + 0.000118661636499517*x_72 - 8.45809636037613e-5*x_73 + 0.000196861157728237*x_74 - 4.61943250798294e-5*x_75 + 0.00040714841703959*x_76 + 0.00036679213733524*x_77 - 0.000112533772695158*x_78 - 0.000383636129107614*x_79 - 0.000146902022274416*x_8 - 0.000612663363511238*x_80 + 0.000826933920163468*x_81 + 0.000256899470528586*x_82 - 6.21617610453465e-6*x_83 - 0.000234505013813631*x_84 - 0.000122716739288683*x_85 - 7.49319263266799e-5*x_86 - 0.000311066341705087*x_87 - 0.000389434497675964*x_88 + 0.000178665447817673*x_89 - 5.16076337181531e-5*x_9 + 0.000563766075019253*x_90 + 0.000312405975000853*x_91 - 0.00046901053461437*x_92 + 0.00272416600601498*x_93 + 0.00149287661093343*x_94 - 0.0012785655977683*x_95 + 0.000403383643072116*x_96 + 9.8675746884127e-5*x_97 + 0.000643734165557431*x_98 - 0.000721476975605197*x_99 - 1.2491472562747e-5*std::pow(-3.11615991592407*x_28 - 7.80615997314453, 2) + 3.9708287462633e-7*std::pow(-4.07271957397461*x_64 - 9.9672794342041, 2) + 9.15148022673505e-7*std::pow(-4.70783948898315*x_8 - 6.14423990249634, 2) + 0.000748962342117427*std::exp(0.183999866247177*x_10) + 4.74438175704236e-6*std::exp(0.00124494341707049*x_1 + 0.0063221390613565*x_10 + 0.020574800862845*x_100 - 0.0212438681341918*x_101 + 0.0184267129559864*x_102 + 0.0111903358423254*x_103 + 0.00177557984613463*x_104 - 0.0141291090597652*x_105 + 0.0204052115489091*x_106 - 0.012874811378311*x_108 - 0.00493922774786183*x_109 + 0.00065624060979477*x_11 + 0.00177232380214917*x_110 + 0.0672859141103669*x_111 + 0.0108960499539126*x_112 - 0.0183715787727306*x_113 - 0.00886630267085846*x_114 - 0.0413155271684302*x_115 - 0.0276052504264613*x_116 - 0.0406581502268458*x_117 - 0.038411659314153*x_118 - 0.0357654158512219*x_119 + 0.00118357319716592*x_12 + 0.161245840117839*x_120 - 0.00279257830127382*x_13 + 0.00564157706733571*x_14 - 0.0897176226107745*x_15 - 0.0148329877240564*x_16 - 0.00958849883199819*x_17 - 0.254133436721956*x_19 - 0.00941098534653719*x_2 + 0.00299688559967216*x_20 + 0.000995402064219753*x_21 - 0.00318838784516569*x_22 - 0.0692381761927058*x_24 - 0.0320272124937308*x_26 - 0.0205294376318937*x_29 - 0.0352643014343169*x_32 + 0.000837260749512609*x_33 + 0.0173574654558627*x_34 - 0.00961467559996238*x_35 - 0.00557698422250514*x_36 + 0.0137445004716547*x_37 - 0.0110612806337091*x_38 + 0.0490280652732008*x_39 - 0.00143027046122905*x_4 + 0.0225613511717491*x_40 - 0.00456932415964729*x_41 + 0.00324585380211806*x_42 + 0.014737381113427*x_43 - 0.00801640018142934*x_44 + 0.00455512573124611*x_46 + 0.014251304947447*x_47 - 0.171064282310102*x_48 + 0.00563304336313156*x_49 - 0.00364616893540272*x_5 - 0.000979166703131001*x_50 - 0.0165922991061582*x_51 - 0.0115921413866966*x_52 - 0.0272117034011422*x_53 - 0.0126117908540457*x_54 - 0.0273812379420217*x_55 - 0.048750720189517*x_56 - 0.035911180583927*x_57 - 0.0631340728842761*x_58 - 0.0493835521754587*x_59 - 0.00546154329690461*x_6 - 0.0622185826101375*x_60 + 0.0367718835509763*x_61 + 0.00522729104377057*x_62 + 0.00754043904186149*x_63 - 0.0298785433833049*x_64 - 6.06921335420662e-5*x_65 - 0.00331770124312269*x_66 - 0.00318047437927352*x_67 - 0.000313972582265302*x_68 - 0.00924622052864186*x_69 + 0.00404037890434459*x_7 + 0.00384999415855085*x_70 + 0.0344049634368891*x_71 - 0.00012707578381896*x_72 + 0.00609158605482844*x_73 - 0.00822919662325162*x_74 - 0.00124336400529277*x_75 - 0.00488663594699259*x_76 - 0.0100437008790156*x_77 + 0.00453166416005914*x_78 - 0.0089583941499115*x_79 + 0.000348468937359636*x_8 - 0.012358199591168*x_80 + 0.00430783133016021*x_81 + 0.00840928480434908*x_82 - 0.0117169695949507*x_83 - 0.0125784659236825*x_84 - 0.0158172361942817*x_85 - 0.0390013006237637*x_86 - 0.00510981253153399*x_87 - 0.0046438102464956*x_88 - 0.000897455744936381*x_89 + 0.0113209510359089*x_9 - 0.0108123997490848*x_90 + 0.00683469185681479*x_91 + 0.00944257438688951*x_92 - 0.0182928195315584*x_93 - 0.0127563045080682*x_94 + 0.0100091441254268*x_95 - 0.0183366504068808*x_96 + 0.00999263220673346*x_97 - 0.0047671505282268*x_98 - 0.0201155946472575*x_99 + 1.22502395210114*std::sin(0.257359951734543*x_107 - 7.44687986373901) - 1.65295502391075*std::sin(0.344239860773087*x_18 - 1.15015983581543) + 0.930941666635988*std::sin(0.310159921646118*x_23 + 8.23967933654785) + 1.33449781936014*std::sin(0.348159849643707*x_25 + 8.23272037506104) + 1.97664875427597*std::sin(0.1891999989748*x_27 + 8.18383979797363) + 0.200735471698181*std::sin(0.410879880189896*x_28 + 8.20399951934814) - 1.50652437972661*std::sin(0.36287984251976*x_3 - 7.39383983612061) + 2.30398867495137*std::sin(0.390079855918884*x_30 + 1.99391984939575) - 1.4363523475925*std::sin(0.380719840526581*x_31 - 7.39687967300415) - 0.172139565837583*std::sin(0.635519862174988*x_45 - 1.40887975692749)) - 0.00131742635820282*std::sin(0.212719991803169*x_1 + 5.01215982437134) - 0.0289234766211606*std::sin(0.270639955997467*x_1 + 5.06863975524902) + 0.000991358648070764*std::sin(0.309119910001755*x_1 + 5.12335968017578) - 0.00247920542811092*std::sin(0.326159834861755*x_1 + 8.32335948944092) - 0.000985837652591501*std::sin(0.333519846200943*x_1 - 4.24272012710571) - 0.0840973979562688*std::sin(0.334079831838608*x_1 - 4.24832010269165) - 0.036575457782123*std::sin(0.345999836921692*x_1 - 4.23943996429443) + 0.00166096751431656*std::sin(0.352639853954315*x_1 - 4.22119998931885) - 0.0015424703698637*std::sin(0.366159856319427*x_1 + 8.36544036865234) + 0.000269973578060839*std::sin(0.669359803199768*x_1 + 2.20183968544006) - 0.0038638253592024*std::sin(0.329439848661423*x_10 + 5.07223987579346) + 0.000456093437814128*std::sin(0.22503998875618*x_100 - 4.40079975128174) - 0.00131704312952708*std::sin(0.246639966964722*x_100 + 1.96799981594086) + 0.000288759253933733*std::sin(0.244079977273941*x_11 + 1.96719980239868) - 0.00786649570018998*std::sin(0.256879955530167*x_11 + 5.17695999145508) - 0.043677966330102*std::sin(0.26895996928215*x_11 - 7.42095994949341) + 0.0280948919512692*std::sin(0.280799955129623*x_113 - 7.41103982925415) + 0.00162696284771712*std::sin(0.288559943437576*x_113 - 7.43031978607178) + 0.000836286258801487*std::sin(0.236719980835915*x_116 + 1.98751986026764) + 0.00150137110497791*std::sin(0.247999966144562*x_116 - 7.43703985214233) - 0.00011482552448981*std::sin(0.257119953632355*x_116 - 4.40911960601807) + 0.0247606792949626*std::sin(0.236159980297089*x_119 + 5.174880027771) - 0.0134343668978067*std::sin(0.282719939947128*x_12 - 4.24959993362427) - 0.020264494008154*std::sin(0.305519938468933*x_12 - 7.46560001373291) - 0.00141925830442266*std::sin(0.243599981069565*x_120 - 4.21704006195068) - 0.0339668342080427*std::sin(0.259839981794357*x_120 - 4.24631977081299) + 0.00210378057935419*std::sin(0.262159943580627*x_120 + 5.16527986526489) - 0.00442834489704517*std::sin(0.264319956302643*x_120 + 5.15952014923096) - 0.000447105483640474*std::sin(0.268479973077774*x_120 + 5.15248012542725) + 0.0129139535714049*std::sin(0.208000004291534*x_13 + 5.20496034622192) + 0.00195528557440537*std::sin(0.265359938144684*x_13 - 4.39911985397339) + 0.000612344051703398*std::sin(0.288719952106476*x_14 - 4.24064016342163) - 0.00014021819965438*std::sin(0.290559947490692*x_14 + 4.80288028717041) - 0.0215775679413785*std::sin(0.294959932565689*x_14 - 4.25464010238647) - 0.00624422252572104*std::sin(0.297279924154282*x_14 + 4.98759984970093) + 0.00731255275618536*std::sin(0.318319916725159*x_14 + 5.12160015106201) + 0.00148826901714701*std::sin(0.33247983455658*x_14 + 1.86767983436584) - 2.14047434715938e-5*std::sin(0.460639864206314*x_14 + 7.76711988449097) + 0.000389801037367471*std::sin(0.198239997029305*x_15 + 8.19207954406738) - 0.0140052602509252*std::sin(0.269839942455292*x_15 + 1.99335980415344) + 0.0247364005741331*std::sin(0.321759909391403*x_15 - 7.44143962860107) - 0.0028745520831831*std::sin(0.253999978303909*x_16 - 7.39783954620361) + 0.0010607276778751*std::sin(0.350239843130112*x_16 - 1.15351986885071) + 0.00875774475683247*std::sin(0.356159836053848*x_16 - 1.14495992660522) - 4.38720609135419e-5*std::sin(0.689119875431061*x_16 - 7.84295988082886) + 0.00248554868397289*std::sin(0.332639843225479*x_17 - 1.1490398645401) + 0.00396404329048311*std::sin(0.352479845285416*x_17 + 2.00735974311829) + 0.00014168935144242*std::sin(0.398319840431213*x_17 + 1.99095976352692) + 0.00520393584332961*std::sin(0.272399961948395*x_18 - 1.17335987091064) + 0.000287922980981578*std::sin(0.276239961385727*x_18 - 1.16479980945587) + 0.00114586918859547*std::sin(0.280479967594147*x_18 + 2.00055980682373) + 0.000336614809899138*std::sin(0.367839843034744*x_18 + 1.99519979953766) - 0.00383772245832592*std::sin(0.384639829397202*x_18 + 2.00191974639893) - 0.00573302586576973*std::sin(0.393519848585129*x_18 + 5.18936014175415) - 0.000312153183109375*std::sin(0.292719930410385*x_19 + 1.98071980476379) + 0.000470695879558999*std::sin(0.373119831085205*x_2 - 7.39439964294434) - 0.00496219249506023*std::sin(0.378239840269089*x_2 + 5.18455982208252) - 0.0358431262854935*std::sin(0.387199848890305*x_2 + 5.19736003875732) + 0.0165341684769864*std::sin(0.392479836940765*x_2 + 5.19144010543823) - 0.000667832181163734*std::sin(0.393279850482941*x_2 + 5.18304014205933) + 0.000829142207385416*std::sin(0.264879941940308*x_20 - 1.16751992702484) + 0.000138412187505718*std::sin(0.396639823913574*x_20 - 4.40351963043213) - 0.000349168238832508*std::sin(0.779839873313904*x_20 - 1.36743986606598) - 0.00200556123518959*std::sin(0.262959957122803*x_21 - 7.38935995101929) - 0.00258830280902562*std::sin(0.459439843893051*x_21 - 7.62784004211426) - 0.000274756108791798*std::sin(0.298159927129745*x_23 - 4.34663963317871) - 0.0331022187663346*std::sin(0.341519832611084*x_23 + 1.9962397813797) + 0.0276866551889144*std::sin(0.346639841794968*x_23 - 1.15591979026794) + 0.000310869695038803*std::sin(0.368399828672409*x_23 + 2.02231979370117) - 0.000461283201555905*std::sin(0.238879978656769*x_24 - 1.17855989933014) + 0.00398243910971033*std::sin(0.247199967503548*x_25 - 4.38279962539673) - 0.00151623872388711*std::sin(0.333119839429855*x_25 - 1.13919985294342) - 0.0114154095624828*std::sin(0.384799838066101*x_25 + 8.20487976074219) - 0.000161154452278236*std::sin(0.141840040683746*x_26 - 1.25295984745026) + 0.0282804371350776*std::sin(0.283519923686981*x_26 - 1.17279982566833) - 0.00517580674462488*std::sin(0.353679865598679*x_26 + 5.01056003570557) - 0.00547785344750834*std::sin(0.226879984140396*x_27 + 5.00183963775635) + 0.000271753627966116*std::sin(0.698799848556519*x_27 + 5.2292799949646) - 0.00425078029257209*std::sin(0.308639913797379*x_28 + 1.9936797618866) - 0.00868732718399794*std::sin(0.29079994559288*x_29 - 1.16375982761383) + 0.00483828080999899*std::sin(0.267839968204498*x_3 - 4.3551197052002) - 0.00237577192541239*std::sin(0.324559837579727*x_3 - 7.40367984771729) + 0.0107132727805619*std::sin(0.357199847698212*x_3 - 7.38823986053467) + 0.0134921798057409*std::sin(0.365039855241776*x_3 - 7.41415977478027) - 0.0388496498825277*std::sin(0.370799839496613*x_3 - 7.40367984771729) - 0.000387456415530775*std::sin(0.385759830474854*x_3 + 1.99527978897095) + 0.000137962270793441*std::sin(0.39183983206749*x_3 + 1.99183976650238) - 3.85809996566823e-5*std::sin(0.449039846658707*x_3 + 8.18967914581299) + 0.0690427849057485*std::sin(0.191760003566742*x_30 + 8.18335914611816) - 0.0422160831131011*std::sin(0.304079920053482*x_30 + 1.99335980415344) - 0.00289074280653753*std::sin(0.389519840478897*x_30 + 2.00319981575012) - 0.00318724753836792*std::sin(0.342559844255447*x_31 - 7.44663953781128) + 0.0194854148815854*std::sin(0.367919832468033*x_31 + 5.17503976821899) - 0.00636735891559891*std::sin(0.369759827852249*x_31 + 5.17216014862061) - 0.00620824161271518*std::sin(0.370159834623337*x_31 + 5.17727994918823) - 0.00152560538739767*std::sin(0.377839833498001*x_31 - 7.40151977539063) - 0.00157777897855771*std::sin(0.380639851093292*x_31 - 7.39687967300415) + 0.000688068844717536*std::sin(0.423199862241745*x_31 + 5.21799993515015) + 0.0035437842763372*std::sin(0.263039946556091*x_32 + 5.23415994644165) - 0.000158718228086567*std::sin(0.294079929590225*x_32 - 4.36799955368042) - 0.0724493904149925*std::sin(0.30991992354393*x_32 - 1.14351987838745) + 0.000426992169608731*std::sin(0.310159921646118*x_32 - 1.14815986156464) - 0.00765711202990945*std::sin(0.32847985625267*x_32 + 1.99999976158142) - 0.033732693889077*std::sin(0.241039976477623*x_33 + 1.99663984775543) - 2.15388326392258e-5*std::sin(0.245679974555969*x_36 + 1.78207981586456) - 0.00322838267623221*std::sin(0.317439913749695*x_4 - 1.14063990116119) + 0.000198520004888635*std::sin(0.530719876289368*x_44 + 5.1005597114563) + 0.00179263752474665*std::sin(0.338719844818115*x_5 + 2.01407980918884) + 0.00681170496193928*std::sin(0.339759826660156*x_5 + 2.00815987586975) + 0.0456027849147992*std::sin(0.351199835538864*x_5 + 2.00807976722717) + 0.000133099124673334*std::sin(0.210960000753403*x_56 - 1.01687979698181) + 0.00574456251547806*std::sin(0.217439994215965*x_56 - 7.39751958847046) - 0.00047600065898537*std::sin(0.247839972376823*x_56 - 7.42392015457153) - 0.000644085491613698*std::sin(0.274239957332611*x_57 - 7.45928001403809) + 0.00169976255637223*std::sin(0.299679934978485*x_6 + 5.21031999588013) - 0.0024932282182905*std::sin(0.314479917287827*x_6 + 2.01639986038208) + 0.0490392109055327*std::sin(0.352959841489792*x_6 + 2.014399766922) + 0.00120941943038202*std::sin(0.573599874973297*x_6 - 7.57480001449585) - 0.00436090533476174*std::sin(0.444079846143723*x_60 + 5.10624027252197) + 0.0131874695403869*std::sin(0.334399849176407*x_7 - 1.14743983745575) - 0.00219968516139132*std::sin(0.339119851589203*x_7 - 1.15287983417511) - 0.0295191359156802*std::sin(0.340719848871231*x_7 - 1.14399981498718) + 0.0474230844749544*std::sin(0.344799846410751*x_7 + 2.02967977523804) - 0.00375755450526306*std::sin(0.345839858055115*x_7 - 1.14471983909607) + 0.0015223112478468*std::sin(0.346959829330444*x_7 - 7.36223983764648) - 0.00186017495926421*std::sin(0.348799854516983*x_7 + 2.01079988479614) + 0.000835786069330088*std::sin(0.349759846925735*x_7 - 1.15015983581543) - 0.000350422265247346*std::sin(0.266479969024658*x_8 - 7.40127992630005) + 0.0176825369510431*std::sin(0.313199937343597*x_8 - 7.42335987091064) - 0.000922543595074209*std::sin(0.326239854097366*x_8 + 8.24759960174561) - 0.00234487508779201*std::sin(0.334319829940796*x_8 - 7.55656003952026) - 0.00122562791477012*std::sin(0.363439828157425*x_8 + 5.01847982406616) + 0.00191396924110981*std::sin(0.405199855566025*x_8 + 4.79080009460449) + 0.000829428501575838*std::sin(0.206080004572868*x_9 - 7.41024017333984) - 0.00884869846629921*std::sin(0.404639840126038*x_9 - 4.38887977600098) - 0.00997119717039818*std::sin(0.339599847793579*x_91 + 2.00343990325928) + 0.000278589355959134*std::sin(0.358399868011475*x_91 + 1.99927973747253) - 0.000718347845881563*std::sin(0.377519845962524*x_91 + 1.9975198507309) - 0.00533116313144168*std::sin(0.379759848117828*x_91 + 1.99135982990265) - 0.000166656287808761*std::sin(0.215199992060661*x_92 + 1.98735988140106) - 0.00617073175210575*std::sin(0.255759954452515*x_92 + 1.99335980415344) - 0.000696650789421823*std::sin(0.292079925537109*x_92 + 2.01063990592957) + 0.0131721551247276*std::sin(0.293359935283661*x_92 + 1.99031984806061) - 0.00143411038374317*std::sin(0.293599933385849*x_92 - 7.38927984237671) + 0.000195117749494156*std::sin(0.309599906206131*x_92 - 4.39079999923706) - 0.00150872531722444*std::sin(0.225439995527267*x_93 - 1.1833598613739) - 0.00366398523226745*std::sin(0.281519949436188*x_94 - 7.42119979858398) - 2.59933871912628e-5*std::sin(0.310239940881729*x_97 - 1.41639983654022) - 0.0394949428737164*std::sin(0.0194319882204698*x_10 - 0.00347006948665921*x_100 + 0.0101778172445972*x_101 + 0.00203005203417348*x_102 - 0.0041550018966513*x_103 - 0.0075654418321607*x_104 - 0.0192720657190584*x_105 + 0.00406466548972461*x_106 + 0.00502947691526609*x_107 + 0.00554193473600094*x_108 + 0.00887954131883419*x_109 + 0.0155604933295964*x_11 + 0.00162687743382796*x_110 + 0.00593454271062635*x_111 - 0.00488386088347847*x_112 + 0.00615508281254551*x_113 + 0.00390671473087034*x_114 + 0.00565209991209525*x_115 + 0.00198917997060993*x_116 + 0.00485365240437746*x_117 + 0.00524826804696224*x_118 + 0.00809559914612404*x_119 + 0.00451656254894734*x_12 + 0.0143788522694556*x_120 + 0.000866935926713446*x_13 + 0.00192835637026779*x_14 + 0.00660964716722808*x_15 + 0.00399960199906556*x_16 + 0.012383025914133*x_17 - 0.0018960546190934*x_18 + 0.0122873845154917*x_19 - 0.00724821466663335*x_2 + 0.00425559575454474*x_21 + 0.00754955489122845*x_22 + 0.00133152040988468*x_23 + 0.00118997001194214*x_24 + 0.00644429522212602*x_25 + 0.00922793222914595*x_26 - 0.0187221470918378*x_27 - 0.000134392104708314*x_28 - 0.000603438614542508*x_29 - 0.020998652131789*x_3 - 0.00793620417998511*x_30 + 0.000657058990016865*x_31 + 0.00231155880550842*x_32 + 0.011731653601896*x_33 - 0.00171442396414554*x_34 + 0.00654717587802927*x_35 - 0.00840358748665874*x_36 + 0.00727147787339385*x_37 + 0.00818992676332422*x_38 - 0.00311756417594927*x_39 + 0.00109884002822971*x_4 - 0.0112102569467273*x_40 - 0.00610327095590372*x_41 + 0.00301555256922386*x_42 - 0.00131341322422387*x_43 + 0.0016940731599393*x_44 - 0.0285778657879106*x_45 + 0.00537900169342133*x_46 - 0.0100641154939791*x_47 - 0.0127605052094175*x_48 + 0.00624255525145456*x_49 + 0.00584788665017283*x_5 + 0.0063087856488698*x_50 + 0.00343743080191701*x_51 - 0.0109726114787132*x_52 + 0.000683388135563503*x_53 - 0.00155480611874194*x_54 - 0.00439812048631933*x_55 + 8.90717078768889e-5*x_56 - 0.001189966398297*x_57 + 0.0281846725414269*x_58 - 0.0191408285988705*x_59 + 0.00931220700834567*x_6 + 0.0152545756972395*x_60 + 0.00924478756320529*x_61 + 0.00237587237279978*x_62 + 0.0117270953391945*x_63 + 0.00778217791546058*x_64 + 0.00202647238320882*x_65 + 0.00729721740465126*x_66 + 0.00611536779640546*x_67 + 0.00412686112007438*x_68 + 0.00707783465597633*x_69 + 0.00761954426957709*x_7 + 0.00325157247164982*x_70 + 0.00493419953727559*x_71 + 0.0121580871867675*x_73 - 0.00254082803932871*x_74 + 0.0114334330301882*x_75 + 0.00966496982675344*x_76 + 0.0133603822166249*x_77 + 0.0145427841233717*x_78 + 0.0174374268547165*x_79 + 0.00777989093650834*x_8 + 0.00266554284683245*x_80 + 0.00979075052746477*x_81 + 0.0242880541810443*x_82 + 0.00563545405489794*x_83 - 0.00036131656351148*x_84 + 0.00356725352687363*x_85 + 0.0146827489095979*x_86 + 0.00753020272757891*x_87 + 0.00631233078710875*x_88 + 0.0077034628001228*x_89 - 0.00385768976834947*x_9 + 0.00844258088802474*x_90 + 0.0180766675257837*x_92 + 0.0198433328027819*x_93 + 0.00919061853141573*x_94 - 0.00245472806756705*x_95 - 0.0124260178547821*x_96 + 0.00152766316539414*x_97 + 0.00641790005628612*x_98 + 0.00834191070732952*x_99 + 0.946316021996893*std::sin(0.246879979968071*x_1 - 7.55592012405396) - 0.132243484160641*std::sin(0.311919927597046*x_20 + 8.18335914611816) - 0.0240209580648116*std::sin(0.97055983543396*x_72 + 8.38920021057129) + 0.0898635548290958*std::sin(0.424319863319397*x_91 + 5.00743961334229) - 7.80629125203945) - 0.00343019908327366);
}

inline float score_6(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.000973823617791838*x_1 - 0.00087749076693814*x_10 - 0.00211963994453417*x_100 - 0.00269321378418133*x_101 - 0.00242409666375479*x_102 - 0.00160491817198715*x_103 - 0.00326991532284378*x_104 - 0.0006608059189421*x_105 - 0.00139579732900736*x_106 - 0.00157820015901486*x_107 + 0.00284326869911974*x_108 - 0.000258881120899456*x_109 - 0.00109730327914235*x_11 - 0.00584987505947592*x_110 - 8.7006674296756e-5*x_111 + 0.00669785085746911*x_112 + 0.00585697839415997*x_113 - 8.75527117726402e-5*x_114 + 0.000567935644649284*x_115 + 0.0107939465198991*x_116 + 0.0013515605808135*x_117 + 0.00235726860280226*x_118 + 0.00197633194532193*x_119 - 0.000264833068949533*x_12 + 0.00198213449225784*x_120 - 0.00502565601503594*x_13 + 0.000196940216317578*x_14 - 0.00144033991996491*x_15 - 0.000806967508466827*x_16 + 0.000896710386125919*x_17 + 0.00991370025211096*x_18 + 0.00440672261373994*x_19 - 0.00067709031511113*x_2 - 0.00150949317358019*x_20 + 0.000151913784989476*x_21 + 0.00462465015314023*x_22 + 0.000372869142708399*x_23 + 0.00103964444426339*x_24 - 0.00126622531819118*x_25 + 0.00104294616092285*x_26 + 0.000983865801523447*x_27 - 0.0027748402609929*x_28 - 0.00571209718880371*x_29 + 0.000480817471918259*x_3 + 0.00208300134169503*x_30 - 0.000444476985528718*x_31 - 0.00021380653630532*x_32 + 0.000188187942912019*x_33 + 9.78579781966456e-5*x_34 - 0.0025059330098438*x_35 + 0.00188280778175747*x_36 + 0.000231024778065712*x_37 + 0.000804535329497747*x_38 + 0.000422169538159438*x_39 + 0.000839492781695764*x_4 + 0.000660333689624021*x_40 - 0.00073518226380858*x_41 - 0.00145965895816048*x_42 - 0.00112867863491631*x_43 - 0.00159403315930934*x_44 + 0.0016808461536108*x_45 - 0.000943957445294008*x_46 + 0.00124012444936694*x_47 + 0.00820280208560419*x_48 - 0.00024330329892927*x_49 - 0.00259357776575998*x_5 - 0.00051161095899265*x_50 - 0.00425489125051998*x_51 + 0.00167691610063961*x_52 + 0.0034469724314536*x_53 - 0.00384729875290105*x_54 - 0.00160268203396261*x_55 + 0.00463620535552131*x_56 + 0.00121105641437491*x_57 - 0.00123843790522454*x_58 + 0.00255597730468994*x_59 - 0.0090241048003262*x_6 + 0.00347879437237437*x_60 - 0.000322450255531848*x_61 + 0.000719686200967424*x_62 - 0.000845922151622333*x_63 - 0.000536905606989072*x_64 + 0.00175263650580157*x_65 - 0.000946249464784222*x_66 - 0.000915221343088924*x_67 - 0.000453523059723415*x_68 - 0.000551498760624517*x_69 - 0.000342617286635035*x_7 - 0.00165985953908647*x_70 - 0.000693377195663093*x_71 - 0.000393392421365332*x_72 - 0.00144347595501778*x_73 - 0.000245079414194297*x_74 - 0.000357265206994264*x_75 + 0.000426382345560195*x_76 + 0.000515881533964437*x_77 - 0.00103883554245938*x_78 - 0.000883344263179394*x_79 + 0.000117382268392779*x_8 + 0.000714808446705213*x_80 + 0.000179055291257885*x_81 - 0.000431875230505203*x_82 - 0.000720209787714269*x_83 + 0.000300019541762626*x_84 + 0.000414753008508236*x_85 + 0.000871763361278588*x_86 - 0.00225443739444554*x_87 - 0.00159449010611042*x_88 - 0.00131750194863823*x_89 + 0.000367870679566524*x_9 + 0.000421132329247157*x_90 + 0.000535775033173944*x_91 - 0.00115406730843238*x_92 + 0.000617237504209978*x_93 + 0.000999538609800433*x_94 - 0.00187348909574291*x_95 - 0.000521565865443025*x_96 - 0.00117751589502881*x_97 - 0.000898131624146042*x_98 - 0.00152961820413955*x_99 - 3.95967222627764e-6*std::pow(-3.11615991592407*x_28 - 7.80615997314453, 2) + 5.22558275642645e-6*std::pow(-4.07271957397461*x_64 - 9.9672794342041, 2) + 1.68678507655412e-7*std::pow(-4.70783948898315*x_8 - 6.14423990249634, 2) - 3.58558971182007e-5*std::exp(0.183999866247177*x_10) + 6.30705995537487e-5*std::sin(0.212719991803169*x_1 + 5.01215982437134) - 0.0191384214606456*std::sin(0.246879979968071*x_1 - 7.55592012405396) - 0.00896387039556127*std::sin(0.270639955997467*x_1 + 5.06863975524902) + 0.0130462102191332*std::sin(0.309119910001755*x_1 + 5.12335968017578) - 0.00578375820681534*std::sin(0.326159834861755*x_1 + 8.32335948944092) - 0.0136087773954772*std::sin(0.333519846200943*x_1 - 4.24272012710571) - 0.330670765380678*std::sin(0.334079831838608*x_1 - 4.24832010269165) - 0.00674152539550764*std::sin(0.345999836921692*x_1 - 4.23943996429443) - 0.0012581725486208*std::sin(0.352639853954315*x_1 - 4.22119998931885) - 0.000488947724355592*std::sin(0.366159856319427*x_1 + 8.36544036865234) + 0.000603000762732375*std::sin(0.669359803199768*x_1 + 2.20183968544006) - 0.0151925519680064*std::sin(0.329439848661423*x_10 + 5.07223987579346) + 0.00600215762566843*std::sin(0.22503998875618*x_100 - 4.40079975128174) + 6.30522528262868e-5*std::sin(0.246639966964722*x_100 + 1.96799981594086) - 0.00828678871092199*std::sin(0.257359951734543*x_107 - 7.44687986373901) - 0.000218733336641527*std::sin(0.244079977273941*x_11 + 1.96719980239868) - 0.00249360068524417*std::sin(0.256879955530167*x_11 + 5.17695999145508) - 0.171741657978012*std::sin(0.26895996928215*x_11 - 7.42095994949341) + 0.00890580056121479*std::sin(0.280799955129623*x_113 - 7.41103982925415) + 0.0037955546627847*std::sin(0.288559943437576*x_113 - 7.43031978607178) - 0.000633481633170753*std::sin(0.236719980835915*x_116 + 1.98751986026764) + 0.00350256067989817*std::sin(0.247999966144562*x_116 - 7.43703985214233) + 0.000526171793810471*std::sin(0.257119953632355*x_116 - 4.40911960601807) + 0.00784888840091002*std::sin(0.236159980297089*x_119 + 5.174880027771) - 0.00247619937264047*std::sin(0.282719939947128*x_12 - 4.24959993362427) - 0.0796799414318732*std::sin(0.305519938468933*x_12 - 7.46560001373291) - 0.0031699911014561*std::sin(0.243599981069565*x_120 - 4.21704006195068) - 0.010767147696363*std::sin(0.259839981794357*x_120 - 4.24631977081299) + 0.00490792656921941*std::sin(0.262159943580627*x_120 + 5.16527986526489) + 0.000212003020850767*std::sin(0.264319956302643*x_120 + 5.15952014923096) + 0.00204879790791188*std::sin(0.268479973077774*x_120 + 5.15248012542725) + 0.00238027768446919*std::sin(0.208000004291534*x_13 + 5.20496034622192) + 0.00436723734668712*std::sin(0.265359938144684*x_13 - 4.39911985397339) + 0.0084529677550561*std::sin(0.288719952106476*x_14 - 4.24064016342163) + 0.00010621441304634*std::sin(0.290559947490692*x_14 + 4.80288028717041) - 0.00397714016640946*std::sin(0.294959932565689*x_14 - 4.25464010238647) - 0.0245522678699422*std::sin(0.297279924154282*x_14 + 4.98759984970093) + 0.00226628271648347*std::sin(0.318319916725159*x_14 + 5.12160015106201) + 0.00332413030540483*std::sin(0.33247983455658*x_14 + 1.86767983436584) + 9.80842222889302e-5*std::sin(0.460639864206314*x_14 + 7.76711988449097) + 0.00512975428925621*std::sin(0.198239997029305*x_15 + 8.19207954406738) - 0.00443952782658821*std::sin(0.269839942455292*x_15 + 1.99335980415344) + 0.00455937075777288*std::sin(0.321759909391403*x_15 - 7.44143962860107) + 0.000429713080709991*std::sin(0.253999978303909*x_16 - 7.39783954620361) - 0.000803494610437266*std::sin(0.350239843130112*x_16 - 1.15351986885071) + 0.00277611774786879*std::sin(0.356159836053848*x_16 - 1.14495992660522) - 0.000102349482411366*std::sin(0.689119875431061*x_16 - 7.84295988082886) - 0.00188278764965612*std::sin(0.332639843225479*x_17 - 1.1490398645401) - 0.000592579715075132*std::sin(0.352479845285416*x_17 + 2.00735974311829) + 0.00195591925102543*std::sin(0.398319840431213*x_17 + 1.99095976352692) + 0.00164959576404269*std::sin(0.272399961948395*x_18 - 1.17335987091064) - 0.00131936650893138*std::sin(0.276239961385727*x_18 - 1.16479980945587) - 0.000171294506021532*std::sin(0.280479967594147*x_18 + 2.00055980682373) + 0.0111815683344896*std::sin(0.344239860773087*x_18 - 1.15015983581543) + 0.0046467245432311*std::sin(0.367839843034744*x_18 + 1.99519979953766) - 0.00118937454100523*std::sin(0.384639829397202*x_18 + 2.00191974639893) + 0.0179969196813377*std::sin(0.393519848585129*x_18 + 5.18936014175415) + 0.00143039799757139*std::sin(0.292719930410385*x_19 + 1.98071980476379) - 0.000356549197564369*std::sin(0.373119831085205*x_2 - 7.39439964294434) + 0.000741791751349008*std::sin(0.378239840269089*x_2 + 5.18455982208252) - 0.0111083858556561*std::sin(0.387199848890305*x_2 + 5.19736003875732) + 0.00304754946186037*std::sin(0.392479836940765*x_2 + 5.19144010543823) + 0.00306024691190038*std::sin(0.393279850482941*x_2 + 5.18304014205933) + 0.0019343124987575*std::sin(0.264879941940308*x_20 - 1.16751992702484) + 0.00267450986399855*std::sin(0.311919927597046*x_20 + 8.18335914611816) - 0.00010484637009045*std::sin(0.396639823913574*x_20 - 4.40351963043213) + 0.0010960970518313*std::sin(0.779839873313904*x_20 - 1.36743986606598) + 0.00029980876045618*std::sin(0.262959957122803*x_21 - 7.38935995101929) - 0.0101772003854688*std::sin(0.459439843893051*x_21 - 7.62784004211426) + 0.00125903117155973*std::sin(0.298159927129745*x_23 - 4.34663963317871) - 0.00629744167889469*std::sin(0.310159921646118*x_23 + 8.23967933654785) - 0.00610134396103082*std::sin(0.341519832611084*x_23 + 1.9962397813797) + 0.108863861244672*std::sin(0.346639841794968*x_23 - 1.15591979026794) - 0.000235481858088524*std::sin(0.368399828672409*x_23 + 2.02231979370117) - 0.00636768172705264*std::sin(0.238879978656769*x_24 - 1.17855989933014) + 0.001262393481341*std::sin(0.247199967503548*x_25 - 4.38279962539673) + 0.000226660569813656*std::sin(0.333119839429855*x_25 - 1.13919985294342) - 0.00902733489027371*std::sin(0.348159849643707*x_25 + 8.23272037506104) - 0.00353782683771438*std::sin(0.384799838066101*x_25 + 8.20487976074219) - 0.00222462092168976*std::sin(0.141840040683746*x_26 - 1.25295984745026) + 0.00876458167629785*std::sin(0.283519923686981*x_26 - 1.17279982566833) - 0.0203512596025571*std::sin(0.353679865598679*x_26 + 5.01056003570557) - 0.0133712247456854*std::sin(0.1891999989748*x_27 + 8.18383979797363) - 0.0215389065078171*std::sin(0.226879984140396*x_27 + 5.00183963775635) + 0.000606976601621106*std::sin(0.698799848556519*x_27 + 5.2292799949646) - 0.000783496503688456*std::sin(0.308639913797379*x_28 + 1.9936797618866) - 0.00135789380925733*std::sin(0.410879880189896*x_28 + 8.20399951934814) - 0.00275379607954713*std::sin(0.29079994559288*x_29 - 1.16375982761383) + 0.000891783587385414*std::sin(0.267839968204498*x_3 - 4.3551197052002) + 0.000355151078703985*std::sin(0.324559837579727*x_3 - 7.40367984771729) + 0.0421245626639072*std::sin(0.357199847698212*x_3 - 7.38823986053467) + 0.0101910245928127*std::sin(0.36287984251976*x_3 - 7.39383983612061) + 0.00427688644236091*std::sin(0.365039855241776*x_3 - 7.41415977478027) - 0.0120401579319525*std::sin(0.370799839496613*x_3 - 7.40367984771729) + 1.85491266941164e-5*std::sin(0.385759830474854*x_3 + 1.99527978897095) - 0.000104505560982702*std::sin(0.39183983206749*x_3 + 1.99183976650238) - 0.000532582859502865*std::sin(0.449039846658707*x_3 + 8.18967914581299) + 0.0218858742588497*std::sin(0.191760003566742*x_30 + 8.18335914611816) - 0.165993536704221*std::sin(0.304079920053482*x_30 + 1.99335980415344) - 0.0380419724152584*std::sin(0.389519840478897*x_30 + 2.00319981575012) - 0.0155855461511032*std::sin(0.390079855918884*x_30 + 1.99391984939575) + 0.0100052989983933*std::sin(0.342559844255447*x_31 - 7.44663953781128) + 0.00359151811711338*std::sin(0.367919832468033*x_31 + 5.17503976821899) - 0.0250364398571457*std::sin(0.369759827852249*x_31 + 5.17216014862061) - 0.00196795067710442*std::sin(0.370159834623337*x_31 + 5.17727994918823) + 0.00115563658043099*std::sin(0.377839833498001*x_31 - 7.40151977539063) + 0.00722994995296396*std::sin(0.380639851093292*x_31 - 7.39687967300415) + 0.00971633934056594*std::sin(0.380719840526581*x_31 - 7.39687967300415) - 0.000102858523501417*std::sin(0.423199862241745*x_31 + 5.21799993515015) + 0.0139341512041763*std::sin(0.263039946556091*x_32 + 5.23415994644165) - 0.000370275025965214*std::sin(0.294079929590225*x_32 - 4.36799955368042) - 0.0224532809255125*std::sin(0.30991992354393*x_32 - 1.14351987838745) + 0.00589431877606008*std::sin(0.310159921646118*x_32 - 1.14815986156464) - 0.00141134570381542*std::sin(0.32847985625267*x_32 + 1.99999976158142) - 0.0104543274681443*std::sin(0.241039976477623*x_33 + 1.99663984775543) - 0.000297328041767463*std::sin(0.245679974555969*x_36 + 1.78207981586456) + 0.000482606759373211*std::sin(0.317439913749695*x_4 - 1.14063990116119) - 2.96764992996038e-5*std::sin(0.530719876289368*x_44 + 5.1005597114563) + 0.00116445413858171*std::sin(0.635519862174988*x_45 - 1.40887975692749) - 0.000267979069804228*std::sin(0.338719844818115*x_5 + 2.01407980918884) + 0.00211106158679949*std::sin(0.339759826660156*x_5 + 2.00815987586975) + 0.00840542678755629*std::sin(0.351199835538864*x_5 + 2.00807976722717) - 0.000609907992975784*std::sin(0.210960000753403*x_56 - 1.01687979698181) + 0.00178033624872993*std::sin(0.217439994215965*x_56 - 7.39751958847046) + 2.27881025480173e-5*std::sin(0.247839972376823*x_56 - 7.42392015457153) + 3.08350124217668e-5*std::sin(0.274239957332611*x_57 - 7.45928001403809) - 8.13746004563431e-5*std::sin(0.299679934978485*x_6 + 5.21031999588013) - 0.00581647208637692*std::sin(0.314479917287827*x_6 + 2.01639986038208) + 0.00903882290864696*std::sin(0.352959841489792*x_6 + 2.014399766922) + 0.000383373898021121*std::sin(0.573599874973297*x_6 - 7.57480001449585) - 0.00135151768717586*std::sin(0.444079846143723*x_60 + 5.10624027252197) + 0.00418029632708643*std::sin(0.334399849176407*x_7 - 1.14743983745575) - 0.028947702314663*std::sin(0.339119851589203*x_7 - 1.15287983417511) - 0.116069171030595*std::sin(0.340719848871231*x_7 - 1.14399981498718) + 0.0146972090720326*std::sin(0.344799846410751*x_7 + 2.02967977523804) + 0.000561711973089147*std::sin(0.345839858055115*x_7 - 1.14471983909607) - 7.28792789906607e-5*std::sin(0.346959829330444*x_7 - 7.36223983764648) - 0.00433961706632543*std::sin(0.348799854516983*x_7 + 2.01079988479614) - 0.000633102742761037*std::sin(0.349759846925735*x_7 - 1.15015983581543) + 0.000485803060126534*std::sin(0.97055983543396*x_72 + 8.38920021057129) - 0.0046115324123903*std::sin(0.266479969024658*x_8 - 7.40127992630005) + 0.00560518786744031*std::sin(0.313199937343597*x_8 - 7.42335987091064) + 4.41659431614647e-5*std::sin(0.326239854097366*x_8 + 8.24759960174561) - 0.00922004317429026*std::sin(0.334319829940796*x_8 - 7.55656003952026) + 0.00018321753505222*std::sin(0.363439828157425*x_8 + 5.01847982406616) + 0.000593171161375783*std::sin(0.405199855566025*x_8 + 4.79080009460449) - 3.97081419812476e-5*std::sin(0.206080004572868*x_9 - 7.41024017333984) - 0.00274236003023502*std::sin(0.404639840126038*x_9 - 4.38887977600098) - 0.00309024120076372*std::sin(0.339599847793579*x_91 + 2.00343990325928) - 0.00127659648682493*std::sin(0.358399868011475*x_91 + 1.99927973747253) + 0.000107384892304103*std::sin(0.377519845962524*x_91 + 1.9975198507309) - 0.00168992554555014*std::sin(0.379759848117828*x_91 + 1.99135982990265) - 0.0018174125200183*std::sin(0.424319863319397*x_91 + 5.00743961334229) - 0.000388793789091437*std::sin(0.215199992060661*x_92 + 1.98735988140106) - 0.00195606042537304*std::sin(0.255759954452515*x_92 + 1.99335980415344) + 0.00319230412539584*std::sin(0.292079925537109*x_92 + 2.01063990592957) + 0.0517928820945405*std::sin(0.293359935283661*x_92 + 1.99031984806061) - 0.0188727919811517*std::sin(0.293599933385849*x_92 - 7.38927984237671) + 0.00269345973121675*std::sin(0.309599906206131*x_92 - 4.39079999923706) + 0.00473613916821977*std::sin(0.225439995527267*x_93 - 1.1833598613739) + 0.000175409990787214*std::sin(0.281519949436188*x_94 - 7.42119979858398) - 0.000358819952869991*std::sin(0.310239940881729*x_97 - 1.41639983654022) + 0.222553758102602);
}

inline float score_7(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.000790994726170622*x_1 - 0.00221900220070477*x_10 - 8.59085134249769e-5*x_100 + 9.24211194962287e-6*x_101 - 0.000315230562205172*x_102 - 0.00138040838936706*x_103 + 0.000742732867250549*x_104 + 7.27499367216648e-5*x_105 + 0.00134726317695015*x_106 + 0.00142098614946356*x_107 - 0.000328070476919888*x_108 - 0.00143908788806426*x_109 - 0.0022034865621295*x_11 - 0.00296022036153954*x_110 - 0.00090464976467491*x_111 + 0.00775368361237756*x_112 - 0.0133099977236551*x_113 + 0.00241834582402941*x_114 - 0.00142598354797685*x_115 - 0.00362178524545414*x_116 - 0.00909941762246468*x_117 + 0.000689921619238431*x_118 - 0.00224947265699937*x_119 - 0.00242471697581594*x_12 + 0.001235202917784*x_120 + 0.000597886468590109*x_13 - 0.000902734127669434*x_14 + 7.4013334067737e-5*x_15 + 0.00041061859791832*x_16 + 0.000423205847101005*x_17 - 0.000517680792879387*x_18 - 0.00216673044874342*x_19 - 0.00145508713764745*x_2 + 0.000333917704209712*x_20 + 0.00122206646581779*x_21 + 0.00107769859738849*x_22 - 0.00017659819127183*x_23 - 0.00107746656778544*x_24 + 0.00120860343223514*x_25 + 0.000646978232668352*x_26 - 0.000452479680992359*x_27 - 0.00206251955762936*x_28 - 6.79443192312224e-5*x_29 - 0.000455166473940556*x_3 + 0.00454081285397432*x_30 - 0.000351303669786498*x_31 - 0.000174513039129555*x_32 + 2.44579149721472e-5*x_33 - 0.000802589825299792*x_34 - 0.0038443796352837*x_35 - 0.00437315801930325*x_36 - 0.00603744687095135*x_37 - 0.00207287283490634*x_38 - 0.00111711372854632*x_39 + 6.31315473405749e-6*x_4 - 7.36142364476268e-5*x_40 - 0.000738561222445272*x_41 - 0.000432047962546441*x_42 - 0.00302037670202468*x_43 + 0.00020737686529705*x_44 - 0.00058542051621495*x_45 + 5.02907703440087e-5*x_46 + 0.000423754885971077*x_47 - 0.00163304642233716*x_48 - 0.00164416725368928*x_49 + 0.00110811748154801*x_5 - 0.00164216468241785*x_50 - 0.000138051245618517*x_51 - 0.00156203279332776*x_52 - 0.00238988389198624*x_53 - 0.000754264185030261*x_54 - 0.00185258538482168*x_55 - 0.00609721128512306*x_56 - 0.00026827641836478*x_57 - 0.000573718673718156*x_58 - 0.00129348966088455*x_59 - 0.000940213785641424*x_6 - 0.000843359637235523*x_60 + 0.00088846227682817*x_61 + 0.000713247996488497*x_62 + 0.00052953916891048*x_63 - 0.000656096673080833*x_64 + 0.000422026490694858*x_65 + 0.000519970893845579*x_66 - 0.000626575187546142*x_67 + 0.000560169909729542*x_68 - 0.000230809205746165*x_69 + 0.000335446981545596*x_7 + 0.0010801631253655*x_70 + 0.000460833876249033*x_71 - 0.000683136635269194*x_72 + 0.000193274411464455*x_73 + 0.000129212843640524*x_74 + 0.000790883667579599*x_75 + 0.000149226686390263*x_76 - 0.000269209667746777*x_77 + 0.000239880133208678*x_78 + 0.000574227624962927*x_79 + 0.000289300888401974*x_8 - 0.000305107764363249*x_80 + 4.34707741797829e-5*x_81 + 0.000646823568467055*x_82 + 0.000449078263360825*x_83 + 0.00113947968488006*x_84 + 0.000390178398263775*x_85 + 4.33777029114329e-6*x_86 - 0.000180903004406098*x_87 + 0.000431745258734204*x_88 + 0.000778278386517599*x_89 - 0.000882427685894222*x_9 - 6.75493721095414e-5*x_90 - 0.00422146659061343*x_91 + 0.00123813691258891*x_92 - 0.000448911030640615*x_93 - 0.000186569114841357*x_94 + 0.000743687314272657*x_95 - 0.00374300687842258*x_96 - 0.0037651388797687*x_97 - 0.000437924784884861*x_98 - 0.00423995707939681*x_99 - 9.09429665343633e-8*std::pow(-3.11615991592407*x_28 - 7.80615997314453, 2) - 2.87996278558666e-7*std::pow(-4.07271957397461*x_64 - 9.9672794342041, 2) - 6.18117310172561e-7*std::pow(-4.70783948898315*x_8 - 6.14423990249634, 2) - 0.00117475552299319*std::exp(0.183999866247177*x_10) - 0.0269234479079269*std::exp(-0.0263854326250904*x_100 - 0.0200183289364312*x_101 - 0.0158850674079369*x_102 - 0.0195925037990868*x_103 - 0.0357896906563964*x_104 - 0.01442801640781*x_105 - 0.00853706436817386*x_106 - 0.00817634404631421*x_107 + 0.0224205802909309*x_108 - 0.00835331241140549*x_109 - 0.0671569907416528*x_110 + 0.00137413424080567*x_111 + 0.0570149467042031*x_112 + 0.0386434541278927*x_113 - 0.00196938939842295*x_114 + 0.000537197734390036*x_115 + 0.0153871146208654*x_116 + 0.00176303385455612*x_117 + 0.00324117619158*x_118 + 0.000681431155724415*x_119 + 0.00186168386041154*x_120 - 0.0735325901676382*x_13 - 0.0203076908853053*x_15 - 0.00502694013159617*x_16 + 0.00527831739407555*x_17 + 0.11834816605365*x_18 - 0.0191027954630028*x_19 - 0.0116084170499988*x_2 - 0.0191574617394756*x_20 + 0.04194418135219*x_22 - 0.00399941596541785*x_24 - 0.0260699252934971*x_25 - 0.0384805234012802*x_28 - 0.0732935201719127*x_29 + 0.0048109072967035*x_33 - 0.0038189862557037*x_34 - 0.0378842023503919*x_35 + 0.000815587204215502*x_36 + 0.00913569869496768*x_37 + 0.0137128843016762*x_38 + 0.0110355164811425*x_39 + 0.0063792113840327*x_4 + 0.00648172193556197*x_40 - 0.00462869844150135*x_41 - 0.0108021405593409*x_42 - 0.0117321361099144*x_43 - 0.0139000767106303*x_44 + 0.00326971479371785*x_45 - 0.0126343663687622*x_46 + 0.0187378329811673*x_47 + 0.0624899352170658*x_48 - 0.00535886237387614*x_49 - 0.0373557605503064*x_5 - 0.00435894308450639*x_50 - 0.0430616541297593*x_51 + 0.0217286889611122*x_52 + 0.0399901564317975*x_53 - 0.0137628279126928*x_54 - 0.0215475112220993*x_55 + 0.0269247783656813*x_56 + 0.00386953820536557*x_57 - 0.0296799750042069*x_58 - 0.00636262587480722*x_59 - 0.0609401510313198*x_6 + 0.0187904929974227*x_60 - 0.00114139010864803*x_61 + 0.00586911332011195*x_62 - 0.0112645791993271*x_63 - 0.00956946516293227*x_64 + 0.0115557441327903*x_65 - 0.00849614171203185*x_66 - 0.0106961751549767*x_67 - 0.00596742251176397*x_68 - 0.00458131991272791*x_69 - 0.0168126347314665*x_70 - 0.00328701178848784*x_71 - 0.00900969053647474*x_72 - 0.0102644949569884*x_73 - 0.00640983158385417*x_74 - 0.00708724664739802*x_75 + 0.00664497673215373*x_76 + 0.00527780767996961*x_77 - 0.00768786473700486*x_78 - 0.00898331708076967*x_79 - 0.000452791797564322*x_80 + 0.00118731143253393*x_81 - 0.000538498063634662*x_82 - 0.0124771767772563*x_83 - 0.0041405581484901*x_84 - 0.00264316518657732*x_85 + 0.00651058891101942*x_86 - 0.0267348319584601*x_87 - 0.0137453761254106*x_88 - 0.0113937578353835*x_89 - 0.00333570570104636*x_9 + 0.00238921182680279*x_90 - 0.000183254836063572*x_91 + 0.00283053607933086*x_93 + 0.0160521612891728*x_94 - 0.0163883944379699*x_95 - 0.0201900979111381*x_96 - 0.0100004139051402*x_97 - 0.0103290236986411*x_98 - 0.019645032271206*x_99 - 3.9834387415201*std::sin(0.334079831838608*x_1 - 4.24832010269165) - 0.183017691395378*std::sin(0.329439848661423*x_10 + 5.07223987579346) - 2.06889282496724*std::sin(0.26895996928215*x_11 - 7.42095994949341) - 0.959867635278783*std::sin(0.305519938468933*x_12 - 7.46560001373291) - 0.295769887346147*std::sin(0.297279924154282*x_14 + 4.98759984970093) - 0.122600055825977*std::sin(0.459439843893051*x_21 - 7.62784004211426) + 1.31143290497502*std::sin(0.346639841794968*x_23 - 1.15591979026794) - 0.245162271440087*std::sin(0.353679865598679*x_26 + 5.01056003570557) - 0.259469307891322*std::sin(0.226879984140396*x_27 + 5.00183963775635) + 0.507455246888313*std::sin(0.357199847698212*x_3 - 7.38823986053467) - 1.99964784969217*std::sin(0.304079920053482*x_30 + 1.99335980415344) - 0.301602484761176*std::sin(0.369759827852249*x_31 + 5.17216014862061) + 0.167858315726868*std::sin(0.263039946556091*x_32 + 5.23415994644165) - 1.39823196056392*std::sin(0.340719848871231*x_7 - 1.14399981498718) - 0.111069622791341*std::sin(0.334319829940796*x_8 - 7.55656003952026) + 0.623925047721897*std::sin(0.293359935283661*x_92 + 1.99031984806061)) + 0.00206639747208133*std::sin(0.212719991803169*x_1 + 5.01215982437134) + 0.00895961901933098*std::sin(0.246879979968071*x_1 - 7.55592012405396) - 0.0128470797826392*std::sin(0.270639955997467*x_1 + 5.06863975524902) - 0.000719012628358762*std::sin(0.309119910001755*x_1 + 5.12335968017578) - 0.0490522799385818*std::sin(0.326159834861755*x_1 + 8.32335948944092) + 0.0438866551704988*std::sin(0.333519846200943*x_1 - 4.24272012710571) + 0.0247041167357488*std::sin(0.345999836921692*x_1 - 4.23943996429443) + 0.113983322252579*std::sin(0.352639853954315*x_1 - 4.22119998931885) - 1.12298074163894e-5*std::sin(0.366159856319427*x_1 + 8.36544036865234) + 0.000290217970054485*std::sin(0.669359803199768*x_1 + 2.20183968544006) - 0.000330795461499329*std::sin(0.22503998875618*x_100 - 4.40079975128174) + 0.00206579637376426*std::sin(0.246639966964722*x_100 + 1.96799981594086) - 0.00345724461527424*std::sin(0.257359951734543*x_107 - 7.44687986373901) + 0.0198160041125704*std::sin(0.244079977273941*x_11 + 1.96719980239868) - 5.72712665869846e-5*std::sin(0.256879955530167*x_11 + 5.17695999145508) + 0.000204542163117792*std::sin(0.280799955129623*x_113 - 7.41103982925415) + 0.0321902477910846*std::sin(0.288559943437576*x_113 - 7.43031978607178) + 0.0573898557983511*std::sin(0.236719980835915*x_116 + 1.98751986026764) + 0.0297053543437867*std::sin(0.247999966144562*x_116 - 7.43703985214233) + 0.000199230929709132*std::sin(0.257119953632355*x_116 - 4.40911960601807) + 0.000180267748031997*std::sin(0.236159980297089*x_119 + 5.174880027771) + 0.00907395801007613*std::sin(0.282719939947128*x_12 - 4.24959993362427) - 0.00152568361337825*std::sin(0.243599981069565*x_120 - 4.21704006195068) - 0.000247292274881398*std::sin(0.259839981794357*x_120 - 4.24631977081299) + 0.041624317508237*std::sin(0.262159943580627*x_120 + 5.16527986526489) + 0.00694590680062106*std::sin(0.264319956302643*x_120 + 5.15952014923096) + 0.000775761674762895*std::sin(0.268479973077774*x_120 + 5.15248012542725) - 0.00872245587323742*std::sin(0.208000004291534*x_13 + 5.20496034622192) + 0.00210190572854083*std::sin(0.265359938144684*x_13 - 4.39911985397339) - 0.0272597949288804*std::sin(0.288719952106476*x_14 - 4.24064016342163) - 0.00962242554361931*std::sin(0.290559947490692*x_14 + 4.80288028717041) + 0.0145741103357538*std::sin(0.294959932565689*x_14 - 4.25464010238647) + 0.00324805174370846*std::sin(0.318319916725159*x_14 + 5.12160015106201) + 0.00159986920258565*std::sin(0.33247983455658*x_14 + 1.86767983436584) + 3.71388413941847e-5*std::sin(0.460639864206314*x_14 + 7.76711988449097) - 0.00028271490742526*std::sin(0.198239997029305*x_15 + 8.19207954406738) - 0.000101963952440915*std::sin(0.269839942455292*x_15 + 1.99335980415344) - 0.0167076767991763*std::sin(0.321759909391403*x_15 - 7.44143962860107) + 0.00809585367788256*std::sin(0.253999978303909*x_16 - 7.39783954620361) + 0.0727920706981532*std::sin(0.350239843130112*x_16 - 1.15351986885071) + 6.37599197641723e-5*std::sin(0.356159836053848*x_16 - 1.14495992660522) - 0.000868029970010734*std::sin(0.689119875431061*x_16 - 7.84295988082886) + 0.170569920349302*std::sin(0.332639843225479*x_17 - 1.1490398645401) - 0.0111642835210021*std::sin(0.352479845285416*x_17 + 2.00735974311829) - 0.00630760216120671*std::sin(0.398319840431213*x_17 + 1.99095976352692) + 3.78867552139763e-5*std::sin(0.272399961948395*x_18 - 1.17335987091064) - 0.00049956804848451*std::sin(0.276239961385727*x_18 - 1.16479980945587) - 0.00322721210693472*std::sin(0.280479967594147*x_18 + 2.00055980682373) + 0.00466494540445861*std::sin(0.344239860773087*x_18 - 1.15015983581543) - 0.0149851225995401*std::sin(0.367839843034744*x_18 + 1.99519979953766) - 0.00170461965038008*std::sin(0.384639829397202*x_18 + 2.00191974639893) - 0.0136997202393436*std::sin(0.393519848585129*x_18 + 5.18936014175415) + 0.000541609273363822*std::sin(0.292719930410385*x_19 + 1.98071980476379) + 0.0323013422359499*std::sin(0.373119831085205*x_2 - 7.39439964294434) + 0.0139754588537527*std::sin(0.378239840269089*x_2 + 5.18455982208252) - 0.0159206138694979*std::sin(0.387199848890305*x_2 + 5.19736003875732) - 0.0111676532011488*std::sin(0.392479836940765*x_2 + 5.19144010543823) + 0.00115873911252838*std::sin(0.393279850482941*x_2 + 5.18304014205933) + 0.0164049800812809*std::sin(0.264879941940308*x_20 - 1.16751992702484) - 0.00125206718297766*std::sin(0.311919927597046*x_20 + 8.18335914611816) + 0.0094984885834087*std::sin(0.396639823913574*x_20 - 4.40351963043213) - 0.000834377395195549*std::sin(0.779839873313904*x_20 - 1.36743986606598) + 0.00564843837657964*std::sin(0.262959957122803*x_21 - 7.38935995101929) + 0.000476722533958129*std::sin(0.298159927129745*x_23 - 4.34663963317871) - 0.00262728990612093*std::sin(0.310159921646118*x_23 + 8.23967933654785) + 0.0223581911534001*std::sin(0.341519832611084*x_23 + 1.9962397813797) + 0.0213333255001972*std::sin(0.368399828672409*x_23 + 2.02231979370117) + 0.0205350006153764*std::sin(0.238879978656769*x_24 - 1.17855989933014) + 2.89937655356687e-5*std::sin(0.247199967503548*x_25 - 4.38279962539673) + 0.00427031638116521*std::sin(0.333119839429855*x_25 - 1.13919985294342) - 0.00376620015646612*std::sin(0.348159849643707*x_25 + 8.23272037506104) - 0.00507043739318063*std::sin(0.384799838066101*x_25 + 8.20487976074219) + 0.00717413243218473*std::sin(0.141840040683746*x_26 - 1.25295984745026) + 0.0125614578399765*std::sin(0.283519923686981*x_26 - 1.17279982566833) - 0.0055784690987372*std::sin(0.1891999989748*x_27 + 8.18383979797363) + 0.000292131499792528*std::sin(0.698799848556519*x_27 + 5.2292799949646) + 0.00287109933637106*std::sin(0.308639913797379*x_28 + 1.9936797618866) - 0.00056651270159473*std::sin(0.410879880189896*x_28 + 8.20399951934814) - 6.32472513868009e-5*std::sin(0.29079994559288*x_29 - 1.16375982761383) - 0.00326791409262876*std::sin(0.267839968204498*x_3 - 4.3551197052002) + 0.00669109528148177*std::sin(0.324559837579727*x_3 - 7.40367984771729) + 0.00425169098992375*std::sin(0.36287984251976*x_3 - 7.39383983612061) + 9.82285195268655e-5*std::sin(0.365039855241776*x_3 - 7.41415977478027) - 0.0172560359221576*std::sin(0.370799839496613*x_3 - 7.40367984771729) + 0.000607729572593863*std::sin(0.385759830474854*x_3 + 1.99527978897095) + 0.00946761320435383*std::sin(0.39183983206749*x_3 + 1.99183976650238) + 0.00171751507321211*std::sin(0.449039846658707*x_3 + 8.18967914581299) + 0.000502659365865981*std::sin(0.191760003566742*x_30 + 8.18335914611816) + 0.00209659802462264*std::sin(0.389519840478897*x_30 + 2.00319981575012) - 0.0065022830177861*std::sin(0.390079855918884*x_30 + 1.99391984939575) - 0.00761629209975916*std::sin(0.342559844255447*x_31 - 7.44663953781128) - 0.0131610099522654*std::sin(0.367919832468033*x_31 + 5.17503976821899) - 4.51985069323353e-5*std::sin(0.370159834623337*x_31 + 5.17727994918823) - 0.104694143023966*std::sin(0.377839833498001*x_31 - 7.40151977539063) + 0.00273756531198317*std::sin(0.380639851093292*x_31 - 7.39687967300415) + 0.00405365251090267*std::sin(0.380719840526581*x_31 - 7.39687967300415) - 0.00193786876213926*std::sin(0.423199862241745*x_31 + 5.21799993515015) - 0.00314031700123787*std::sin(0.294079929590225*x_32 - 4.36799955368042) - 0.0321801943471772*std::sin(0.30991992354393*x_32 - 1.14351987838745) - 0.0190084625585775*std::sin(0.310159921646118*x_32 - 1.14815986156464) + 0.00517183381743061*std::sin(0.32847985625267*x_32 + 1.99999976158142) - 0.014983212957161*std::sin(0.241039976477623*x_33 + 1.99663984775543) + 0.000958846842913672*std::sin(0.245679974555969*x_36 + 1.78207981586456) + 0.0090923778754584*std::sin(0.317439913749695*x_4 - 1.14063990116119) - 0.000559109337803759*std::sin(0.530719876289368*x_44 + 5.1005597114563) + 0.000485809755839364*std::sin(0.635519862174988*x_45 - 1.40887975692749) - 0.00504876261687341*std::sin(0.338719844818115*x_5 + 2.01407980918884) + 0.00302558776899628*std::sin(0.339759826660156*x_5 + 2.00815987586975) - 0.0308014332649332*std::sin(0.351199835538864*x_5 + 2.00807976722717) - 0.00023093700176822*std::sin(0.210960000753403*x_56 - 1.01687979698181) + 0.0025515899737555*std::sin(0.217439994215965*x_56 - 7.39751958847046) + 0.000746612174799822*std::sin(0.247839972376823*x_56 - 7.42392015457153) + 0.00101025505022567*std::sin(0.274239957332611*x_57 - 7.45928001403809) - 0.00266609592844153*std::sin(0.299679934978485*x_6 + 5.21031999588013) - 0.0493297276327542*std::sin(0.314479917287827*x_6 + 2.01639986038208) - 0.0331224942707734*std::sin(0.352959841489792*x_6 + 2.014399766922) + 8.80506203177803e-6*std::sin(0.573599874973297*x_6 - 7.57480001449585) - 0.00193700430601876*std::sin(0.444079846143723*x_60 + 5.10624027252197) + 9.60101056989072e-5*std::sin(0.334399849176407*x_7 - 1.14743983745575) + 0.00159538771617277*std::sin(0.339119851589203*x_7 - 1.15287983417511) + 0.0210641396180861*std::sin(0.344799846410751*x_7 + 2.02967977523804) + 0.0105827310067704*std::sin(0.345839858055115*x_7 - 1.14471983909607) - 0.00238776163440577*std::sin(0.346959829330444*x_7 - 7.36223983764648) - 0.0368044623498968*std::sin(0.348799854516983*x_7 + 2.01079988479614) + 0.0573555304685572*std::sin(0.349759846925735*x_7 - 1.15015983581543) - 0.00022742786525572*std::sin(0.97055983543396*x_72 + 8.38920021057129) + 0.000254154270466344*std::sin(0.266479969024658*x_8 - 7.40127992630005) + 0.000128736012355913*std::sin(0.313199937343597*x_8 - 7.42335987091064) + 0.00144701959306987*std::sin(0.326239854097366*x_8 + 8.24759960174561) + 0.0034518436175001*std::sin(0.363439828157425*x_8 + 5.01847982406616) + 0.000850136927317575*std::sin(0.405199855566025*x_8 + 4.79080009460449) - 0.00130096756320148*std::sin(0.206080004572868*x_9 - 7.41024017333984) - 0.00393036897528059*std::sin(0.404639840126038*x_9 - 4.38887977600098) - 0.00442895462583541*std::sin(0.339599847793579*x_91 + 2.00343990325928) - 0.00048337350638213*std::sin(0.358399868011475*x_91 + 1.99927973747253) + 0.00202314617435611*std::sin(0.377519845962524*x_91 + 1.9975198507309) - 3.88130212684317e-5*std::sin(0.379759848117828*x_91 + 1.99135982990265) + 0.000850818538708101*std::sin(0.424319863319397*x_91 + 5.00743961334229) - 0.00329737535680906*std::sin(0.215199992060661*x_92 + 1.98735988140106) - 4.49254199939477e-5*std::sin(0.255759954452515*x_92 + 1.99335980415344) + 0.00120874156748509*std::sin(0.292079925537109*x_92 + 2.01063990592957) + 0.00104013161975077*std::sin(0.293599933385849*x_92 - 7.38927984237671) - 0.00868608068192951*std::sin(0.309599906206131*x_92 - 4.39079999923706) - 0.0036052715002385*std::sin(0.225439995527267*x_93 - 1.1833598613739) + 0.00574700041073201*std::sin(0.281519949436188*x_94 - 7.42119979858398) + 0.00115715079189505*std::sin(0.310239940881729*x_97 - 1.41639983654022) + 0.319648761960649);
}

inline float score_8(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.000991112467004146*x_1 - 0.000977371449067046*x_10 - 0.00213332052004572*x_100 - 0.0042260239995212*x_101 - 0.0015500069369174*x_102 - 0.00404920627568294*x_103 - 0.00246672396152155*x_104 + 0.000764110119349768*x_105 + 0.00275880901998185*x_106 - 0.00559276776507618*x_107 + 0.00200916760197662*x_108 - 0.00180363639453458*x_109 - 0.00532238134181264*x_11 - 0.00639528085958743*x_110 - 0.000898777664002697*x_111 + 0.0462254051427624*x_112 + 0.0120994737599603*x_113 + 0.0103678890642013*x_114 + 0.00114867753381861*x_115 + 0.027001317337642*x_116 + 0.00499230496734835*x_117 + 0.00986563304597704*x_118 + 0.0017049540422164*x_119 + 0.000611414228554778*x_12 + 0.0106314192384992*x_120 + 2.26687790680687e-5*x_13 + 0.000549027711267961*x_14 - 0.0012157266891824*x_15 + 0.000145468323875516*x_16 + 0.00164603271232466*x_17 + 0.00626174149753839*x_18 + 0.017962601191389*x_19 - 0.000760157848114066*x_2 - 2.94065470755493e-5*x_20 + 0.00240862609754488*x_21 + 0.00193772494984418*x_22 - 0.000112851164817511*x_23 - 0.00106445871330981*x_24 - 0.000575698594222509*x_25 + 0.000684544426943449*x_26 + 0.000465272345530007*x_27 - 0.00171157162980777*x_28 - 0.00345158918383125*x_29 + 0.000276137803248587*x_3 - 0.00491456413318153*x_30 - 0.00140782526608043*x_31 - 0.000916946807679275*x_32 + 0.00323458782242144*x_33 - 0.0166090590418701*x_34 - 0.00643826575706092*x_35 - 0.00561449993742135*x_36 + 0.000587539325048204*x_37 - 0.00201679766332299*x_38 + 0.000574181973940108*x_39 + 0.000766830801488039*x_4 + 5.54600268212857e-5*x_40 - 0.00178057776106604*x_41 - 0.00344938499686252*x_42 - 0.00474789463332254*x_43 - 0.000873312706895945*x_44 + 0.00160473369073099*x_45 + 9.43963730370692e-5*x_46 + 0.00124507498965683*x_47 + 0.000757035003079556*x_48 - 0.0017798108597897*x_49 - 0.00188292052718156*x_5 - 0.0024100216068782*x_50 - 0.00501213868542862*x_51 - 0.00198107652541821*x_52 + 0.00346138990967139*x_53 + 0.00113984162470865*x_54 - 0.00153626193165356*x_55 + 0.00801299229831875*x_56 - 0.000507515877334013*x_57 + 7.30823215220894e-5*x_58 + 0.00228486498710069*x_59 - 0.00754428011013459*x_6 + 0.00189958089394535*x_60 - 0.00134503508812354*x_61 + 0.00104786353541623*x_62 - 0.000269176032826892*x_63 - 0.00206011654107888*x_64 + 0.00298641454360041*x_65 + 0.00154299333986808*x_66 - 0.00114710195908875*x_67 - 0.000435751461265777*x_68 - 0.000225607466167606*x_69 + 0.00181053543762094*x_7 - 0.000105065479669107*x_70 - 0.000875056730589856*x_71 - 0.00104966969047831*x_72 - 0.00093948723894385*x_73 - 0.00212408336027804*x_74 + 0.00110135482573235*x_75 + 0.000679283234207786*x_76 + 0.000853598980278689*x_77 + 0.000101609692707758*x_78 + 0.00102162558326089*x_79 + 0.000120904704083362*x_8 - 0.000464464707553716*x_80 - 7.47759927643766e-5*x_81 + 0.0016466867131325*x_82 + 0.00118619924828223*x_83 + 0.0013844613096497*x_84 - 0.00126351078918839*x_85 + 0.00098507805025858*x_86 - 0.00175897071760555*x_87 + 0.000523702021198134*x_88 + 0.000186533592513651*x_89 - 0.00102721171139515*x_9 + 0.000965495548680377*x_90 - 0.00354077970092166*x_91 + 0.00217799413709661*x_92 + 0.00400502123745861*x_93 - 0.00400277128284178*x_94 + 0.000397671393448568*x_95 - 0.00647438378104865*x_96 - 0.00733599242732319*x_97 - 0.00274510643742354*x_98 - 0.00683621459717262*x_99 - 4.80213988764212e-6*std::pow(-3.11615991592407*x_28 - 7.80615997314453, 2) - 9.45305825135242e-9*std::pow(-4.07271957397461*x_64 - 9.9672794342041, 2) - 5.54155080152261e-6*std::pow(-4.70783948898315*x_8 - 6.14423990249634, 2) - 0.000230663514264798*std::exp(0.183999866247177*x_10) - 0.0306273638506298*std::exp(-0.0178124626477994*x_10 - 0.000898277726238003*x_100 - 0.00109833809840236*x_101 - 0.00213397654768035*x_102 - 0.0052339720681495*x_103 + 0.00496553834461544*x_104 + 9.68026900082098e-5*x_105 + 0.00535791892911556*x_106 + 0.0131858414624937*x_107 - 0.00347722561112004*x_108 - 0.0116899314412819*x_109 - 0.0152216500871212*x_110 - 0.00279529072780798*x_111 - 0.0217632086465618*x_112 - 0.12964704294365*x_113 + 0.00409549695217129*x_114 - 0.0179332824496113*x_115 - 0.104865793578025*x_117 - 0.0221485319416875*x_118 - 0.069425656827015*x_119 - 0.0206425293946871*x_12 - 0.00643376551440392*x_120 + 0.00311525637349272*x_13 - 0.00624595842533378*x_15 - 0.00291564612194295*x_18 - 0.0335048615400506*x_19 + 0.00380082987972281*x_21 - 0.00246015173263201*x_22 - 0.00691535080572404*x_24 + 0.00046854808227583*x_25 + 0.00732908058609589*x_26 - 0.0022118196483133*x_27 - 0.0189777995096604*x_28 - 0.00858252141439618*x_29 + 0.00192911785656685*x_30 - 0.00206205472928183*x_32 - 0.00394489383531187*x_33 + 0.00656632983002662*x_34 - 0.0274405706425842*x_35 - 0.0257695944247298*x_36 - 0.0564813786773625*x_37 + 0.00028144606130804*x_38 + 9.58643546132624e-5*x_39 - 0.00051474627513569*x_4 + 0.00267950757889354*x_40 - 0.00153608770371421*x_41 - 0.000520244196138059*x_42 - 0.0149961602335071*x_43 - 0.0018019595033193*x_44 - 0.00303815100380305*x_45 + 0.00155238878732077*x_46 - 0.00203211147592929*x_47 - 0.00452122359602834*x_48 - 0.00981373059085977*x_49 + 0.00879888541682156*x_5 - 0.00733947458521175*x_50 + 0.00132037212375871*x_51 - 0.00588806651107913*x_52 - 0.0102655049932661*x_53 - 0.0230576069907754*x_54 - 0.0158663320204379*x_55 - 0.0576629070633498*x_56 + 0.000884156286009366*x_57 - 0.00593869272927801*x_58 - 0.00944252310552341*x_59 - 0.00504513359950425*x_6 - 0.00842426466602226*x_60 - 0.00132726110568578*x_61 + 0.00161068509440189*x_62 + 0.00238594922170227*x_63 - 0.00286644407802276*x_64 + 0.00123326174322168*x_65 + 0.00566330758908*x_66 - 0.00349146827471403*x_67 + 0.00237060495508892*x_68 - 0.00323246087688453*x_69 + 0.00603440935866911*x_70 + 0.00492346953497488*x_71 - 0.00540501929297864*x_72 - 0.00129995679281538*x_73 + 0.00172203664131096*x_74 + 0.00279844023268982*x_75 - 0.00570682802370258*x_76 - 0.00400495112274579*x_77 - 0.00125931510318772*x_78 - 0.000480582943134102*x_79 + 0.00308345265407781*x_8 - 0.00112138028810059*x_80 - 0.00239117132160462*x_81 - 0.00230977736315019*x_82 - 0.0015247059876031*x_83 + 0.000247617548342007*x_84 + 0.00720024254828787*x_85 - 0.000433393064356866*x_86 - 0.00167257116181182*x_87 - 0.00435448815406371*x_88 - 0.0017111964286412*x_89 + 0.000755786195316447*x_9 - 0.00207329348141547*x_90 - 0.028801476204132*x_91 + 0.0106715609486763*x_92 - 0.0172992314051777*x_93 - 0.000526443340851161*x_94 + 0.00282068426110504*x_95 - 0.0140732708098238*x_96 - 0.0236861333527545*x_97 - 0.00255415954510696*x_98 - 0.00815538606303119*x_99 + 1.13227532119754*std::sin(0.352639853954315*x_1 - 4.22119998931885) + 0.19684609974513*std::sin(0.244079977273941*x_11 + 1.96719980239868) + 0.570093204193199*std::sin(0.236719980835915*x_116 + 1.98751986026764) - 0.0955862204907305*std::sin(0.290559947490692*x_14 + 4.80288028717041) + 0.723094077287442*std::sin(0.350239843130112*x_16 - 1.15351986885071) + 1.69438921004758*std::sin(0.332639843225479*x_17 - 1.1490398645401) + 0.320871614658472*std::sin(0.373119831085205*x_2 - 7.39439964294434) + 0.0943550687866264*std::sin(0.396639823913574*x_20 - 4.40351963043213) + 0.211918704469952*std::sin(0.368399828672409*x_23 + 2.02231979370117) + 0.0940483622523232*std::sin(0.39183983206749*x_3 + 1.99183976650238) - 1.03999946726663*std::sin(0.377839833498001*x_31 - 7.40151977539063) + 0.569752226907667*std::sin(0.349759846925735*x_7 - 1.15015983581543)) + 0.000405737613868564*std::sin(0.212719991803169*x_1 + 5.01215982437134) + 0.000942723604816852*std::sin(0.246879979968071*x_1 - 7.55592012405396) - 0.0448517018203306*std::sin(0.270639955997467*x_1 + 5.06863975524902) - 2.36005419700201e-5*std::sin(0.309119910001755*x_1 + 5.12335968017578) - 0.00648507899793224*std::sin(0.326159834861755*x_1 + 8.32335948944092) - 0.00628696074209599*std::sin(0.333519846200943*x_1 - 4.24272012710571) - 0.219064362822673*std::sin(0.334079831838608*x_1 - 4.24832010269165) + 0.22147756687105*std::sin(0.345999836921692*x_1 - 4.23943996429443) - 0.000592977205163041*std::sin(0.366159856319427*x_1 + 8.36544036865234) + 0.00154496903408386*std::sin(0.669359803199768*x_1 + 2.20183968544006) - 0.0100648350714954*std::sin(0.329439848661423*x_10 + 5.07223987579346) - 1.08578790756811e-5*std::sin(0.22503998875618*x_100 - 4.40079975128174) + 0.000405619588077223*std::sin(0.246639966964722*x_100 + 1.96799981594086) + 0.000411703231074482*std::sin(0.257359951734543*x_107 - 7.44687986373901) - 0.00302414407813742*std::sin(0.256879955530167*x_11 + 5.17695999145508) - 0.113776241548752*std::sin(0.26895996928215*x_11 - 7.42095994949341) + 0.0108006162284293*std::sin(0.280799955129623*x_113 - 7.41103982925415) + 0.00425579198662285*std::sin(0.288559943437576*x_113 - 7.43031978607178) + 0.00392727045149039*std::sin(0.247999966144562*x_116 - 7.43703985214233) - 0.000129588762634986*std::sin(0.257119953632355*x_116 - 4.40911960601807) + 0.00951883335532904*std::sin(0.236159980297089*x_119 + 5.174880027771) + 0.0813499289797952*std::sin(0.282719939947128*x_12 - 4.24959993362427) - 0.0527867517390793*std::sin(0.305519938468933*x_12 - 7.46560001373291) - 0.00812194344146246*std::sin(0.243599981069565*x_120 - 4.21704006195068) - 0.0130579872459406*std::sin(0.259839981794357*x_120 - 4.24631977081299) + 0.00550304670066139*std::sin(0.262159943580627*x_120 + 5.16527986526489) + 0.00136383038089901*std::sin(0.264319956302643*x_120 + 5.15952014923096) - 0.000504590304722951*std::sin(0.268479973077774*x_120 + 5.15248012542725) - 0.0781986388992897*std::sin(0.208000004291534*x_13 + 5.20496034622192) + 0.0111894493044294*std::sin(0.265359938144684*x_13 - 4.39911985397339) + 0.00390508822988777*std::sin(0.288719952106476*x_14 - 4.24064016342163) + 0.130659943482296*std::sin(0.294959932565689*x_14 - 4.25464010238647) - 0.0162655047856697*std::sin(0.297279924154282*x_14 + 4.98759984970093) + 0.0113395924031453*std::sin(0.318319916725159*x_14 + 5.12160015106201) + 0.00851686880765942*std::sin(0.33247983455658*x_14 + 1.86767983436584) - 2.4156773795092e-5*std::sin(0.460639864206314*x_14 + 7.76711988449097) - 9.2797049385216e-6*std::sin(0.198239997029305*x_15 + 8.19207954406738) - 0.00538409051054155*std::sin(0.269839942455292*x_15 + 1.99335980415344) - 0.149787812498259*std::sin(0.321759909391403*x_15 - 7.44143962860107) + 0.00218070904978194*std::sin(0.253999978303909*x_16 - 7.39783954620361) + 0.00336677002741822*std::sin(0.356159836053848*x_16 - 1.14495992660522) - 0.000114760066915151*std::sin(0.689119875431061*x_16 - 7.84295988082886) - 0.00300722506572628*std::sin(0.352479845285416*x_17 + 2.00735974311829) + 0.000903592379282608*std::sin(0.398319840431213*x_17 + 1.99095976352692) + 0.00200056700764894*std::sin(0.272399961948395*x_18 - 1.17335987091064) + 0.000324941540701523*std::sin(0.276239961385727*x_18 - 1.16479980945587) - 0.000869285800753139*std::sin(0.280479967594147*x_18 + 2.00055980682373) - 0.000555521321030193*std::sin(0.344239860773087*x_18 - 1.15015983581543) + 0.00214668621094036*std::sin(0.367839843034744*x_18 + 1.99519979953766) - 0.00595116505614302*std::sin(0.384639829397202*x_18 + 2.00191974639893) + 0.0155376830558541*std::sin(0.393519848585129*x_18 + 5.18936014175415) - 0.000352287045336387*std::sin(0.292719930410385*x_19 + 1.98071980476379) + 0.00376444669207568*std::sin(0.378239840269089*x_2 + 5.18455982208252) - 0.0555820184939061*std::sin(0.387199848890305*x_2 + 5.19736003875732) - 0.100120343710607*std::sin(0.392479836940765*x_2 + 5.19144010543823) - 0.000753696065307433*std::sin(0.393279850482941*x_2 + 5.18304014205933) + 0.00216886130307947*std::sin(0.264879941940308*x_20 - 1.16751992702484) - 0.000131741459727572*std::sin(0.311919927597046*x_20 + 8.18335914611816) + 0.000946317975040544*std::sin(0.779839873313904*x_20 - 1.36743986606598) + 0.00152147027046621*std::sin(0.262959957122803*x_21 - 7.38935995101929) - 0.00674224077594145*std::sin(0.459439843893051*x_21 - 7.62784004211426) - 0.000310081789941159*std::sin(0.298159927129745*x_23 - 4.34663963317871) + 0.000312868733250904*std::sin(0.310159921646118*x_23 + 8.23967933654785) + 0.200445853995144*std::sin(0.341519832611084*x_23 + 1.9962397813797) + 0.0721206556331801*std::sin(0.346639841794968*x_23 - 1.15591979026794) - 0.00294173119838426*std::sin(0.238879978656769*x_24 - 1.17855989933014) + 0.00153098280469186*std::sin(0.247199967503548*x_25 - 4.38279962539673) + 0.00115025764401842*std::sin(0.333119839429855*x_25 - 1.13919985294342) + 0.000448494956486417*std::sin(0.348159849643707*x_25 + 8.23272037506104) - 0.0177019019034124*std::sin(0.384799838066101*x_25 + 8.20487976074219) - 0.00102772673799169*std::sin(0.141840040683746*x_26 - 1.25295984745026) + 0.0438545390080498*std::sin(0.283519923686981*x_26 - 1.17279982566833) - 0.0134824005755106*std::sin(0.353679865598679*x_26 + 5.01056003570557) + 0.000664307565120636*std::sin(0.1891999989748*x_27 + 8.18383979797363) - 0.0142691986229872*std::sin(0.226879984140396*x_27 + 5.00183963775635) + 0.00155515566791126*std::sin(0.698799848556519*x_27 + 5.2292799949646) + 0.0257400052819688*std::sin(0.308639913797379*x_28 + 1.9936797618866) + 6.74627154413207e-5*std::sin(0.410879880189896*x_28 + 8.20399951934814) - 0.00333969915698233*std::sin(0.29079994559288*x_29 - 1.16375982761383) - 0.0292975324607206*std::sin(0.267839968204498*x_3 - 4.3551197052002) + 0.00180232160978197*std::sin(0.324559837579727*x_3 - 7.40367984771729) + 0.0279068833573148*std::sin(0.357199847698212*x_3 - 7.38823986053467) - 0.000506309247065823*std::sin(0.36287984251976*x_3 - 7.39383983612061) + 0.00518684522508683*std::sin(0.365039855241776*x_3 - 7.41415977478027) - 0.0602442415612157*std::sin(0.370799839496613*x_3 - 7.40367984771729) + 0.000119327839872566*std::sin(0.385759830474854*x_3 + 1.99527978897095) - 0.000246041759101778*std::sin(0.449039846658707*x_3 + 8.18967914581299) + 0.0265423559699896*std::sin(0.191760003566742*x_30 + 8.18335914611816) - 0.109968198455433*std::sin(0.304079920053482*x_30 + 1.99335980415344) + 6.88177755477176e-5*std::sin(0.389519840478897*x_30 + 2.00319981575012) + 0.000774319212460737*std::sin(0.390079855918884*x_30 + 1.99391984939575) + 0.00863809848955964*std::sin(0.342559844255447*x_31 - 7.44663953781128) - 0.117991203367954*std::sin(0.367919832468033*x_31 + 5.17503976821899) - 0.0165862613779593*std::sin(0.369759827852249*x_31 + 5.17216014862061) - 0.00238665573900784*std::sin(0.370159834623337*x_31 + 5.17727994918823) - 0.00178063567705219*std::sin(0.380639851093292*x_31 - 7.39687967300415) - 0.000482725991970179*std::sin(0.380719840526581*x_31 - 7.39687967300415) - 0.000521986700232963*std::sin(0.423199862241745*x_31 + 5.21799993515015) + 0.00923116366668688*std::sin(0.263039946556091*x_32 + 5.23415994644165) - 0.000415173440604117*std::sin(0.294079929590225*x_32 - 4.36799955368042) - 0.112347436600365*std::sin(0.30991992354393*x_32 - 1.14351987838745) + 0.00272304775584063*std::sin(0.310159921646118*x_32 - 1.14815986156464) + 0.0463665704950461*std::sin(0.32847985625267*x_32 + 1.99999976158142) - 0.0523093661154991*std::sin(0.241039976477623*x_33 + 1.99663984775543) - 0.00013735912285093*std::sin(0.245679974555969*x_36 + 1.78207981586456) + 0.00244913402662128*std::sin(0.317439913749695*x_4 - 1.14063990116119) - 0.000150602375151269*std::sin(0.530719876289368*x_44 + 5.1005597114563) - 5.78522691981129e-5*std::sin(0.635519862174988*x_45 - 1.40887975692749) - 0.00135994087428915*std::sin(0.338719844818115*x_5 + 2.01407980918884) + 0.010562926574928*std::sin(0.339759826660156*x_5 + 2.00815987586975) - 0.27614128319701*std::sin(0.351199835538864*x_5 + 2.00807976722717) + 0.000150211818764631*std::sin(0.210960000753403*x_56 - 1.01687979698181) + 0.00890810632508712*std::sin(0.217439994215965*x_56 - 7.39751958847046) + 0.000146597470419562*std::sin(0.247839972376823*x_56 - 7.42392015457153) + 0.000198363809003487*std::sin(0.274239957332611*x_57 - 7.45928001403809) - 0.000523488542241106*std::sin(0.299679934978485*x_6 + 5.21031999588013) - 0.00652175966225111*std::sin(0.314479917287827*x_6 + 2.01639986038208) - 0.296950079950665*std::sin(0.352959841489792*x_6 + 2.014399766922) + 0.000464941283611939*std::sin(0.573599874973297*x_6 - 7.57480001449585) - 0.00676246594775972*std::sin(0.444079846143723*x_60 + 5.10624027252197) + 0.0050697044066541*std::sin(0.334399849176407*x_7 - 1.14743983745575) + 5.23662774045228e-5*std::sin(0.339119851589203*x_7 - 1.15287983417511) - 0.0768940639971645*std::sin(0.340719848871231*x_7 - 1.14399981498718) + 0.0735390863322037*std::sin(0.344799846410751*x_7 + 2.02967977523804) + 0.00285057736911915*std::sin(0.345839858055115*x_7 - 1.14471983909607) - 0.000468837540269974*std::sin(0.346959829330444*x_7 - 7.36223983764648) - 0.00486582572949421*std::sin(0.348799854516983*x_7 + 2.01079988479614) - 2.39297693916547e-5*std::sin(0.97055983543396*x_72 + 8.38920021057129) + 8.34224364138414e-6*std::sin(0.266479969024658*x_8 - 7.40127992630005) + 0.00679775867743136*std::sin(0.313199937343597*x_8 - 7.42335987091064) + 0.000284122626380238*std::sin(0.326239854097366*x_8 + 8.24759960174561) - 0.00610813865219744*std::sin(0.334319829940796*x_8 - 7.55656003952026) + 0.000929792819215489*std::sin(0.363439828157425*x_8 + 5.01847982406616) + 0.00296799651092902*std::sin(0.405199855566025*x_8 + 4.79080009460449) - 0.000255445277080262*std::sin(0.206080004572868*x_9 - 7.41024017333984) - 0.0137216970942597*std::sin(0.404639840126038*x_9 - 4.38887977600098) - 0.0154623584203301*std::sin(0.339599847793579*x_91 + 2.00343990325928) + 0.000314407881718194*std::sin(0.358399868011475*x_91 + 1.99927973747253) + 0.000544957128301754*std::sin(0.377519845962524*x_91 + 1.9975198507309) - 0.00204947743289868*std::sin(0.379759848117828*x_91 + 1.99135982990265) + 8.95224136344806e-5*std::sin(0.424319863319397*x_91 + 5.00743961334229) - 0.000435937732181181*std::sin(0.215199992060661*x_92 + 1.98735988140106) - 0.00237223569390046*std::sin(0.255759954452515*x_92 + 1.99335980415344) - 0.00078621991226238*std::sin(0.292079925537109*x_92 + 2.01063990592957) + 0.0343119982249671*std::sin(0.293359935283661*x_92 + 1.99031984806061) + 3.41408050124323e-5*std::sin(0.293599933385849*x_92 - 7.38927984237671) + 0.00124432012505428*std::sin(0.309599906206131*x_92 - 4.39079999923706) + 0.00408895692191839*std::sin(0.225439995527267*x_93 - 1.1833598613739) + 0.00112842483842348*std::sin(0.281519949436188*x_94 - 7.42119979858398) - 0.000165767055453791*std::sin(0.310239940881729*x_97 - 1.41639983654022) - 0.362239181879894);
}

inline float score_9(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.000931066789975414*x_1 - 0.000691196171037693*x_10 - 0.00154539287234709*x_100 - 0.00118717544300219*x_101 - 0.00356725562801813*x_102 - 0.00157038500391574*x_103 - 0.00161012004476598*x_104 - 0.000619068848266399*x_105 - 0.00235213506847891*x_106 - 0.00126615793472946*x_107 - 0.0014264503417151*x_108 - 0.000719686384403431*x_109 + 3.04341865793822e-5*x_11 - 0.00168216025210368*x_110 - 0.0006001655992147*x_111 - 0.00553563150844721*x_112 - 0.000858787956154247*x_113 - 0.00378921291042568*x_114 - 0.000576930333281783*x_115 - 0.00753696806759034*x_116 + 0.00122944216409335*x_117 + 0.00117350912881465*x_118 - 0.00082206788856644*x_119 + 0.000196762586560117*x_12 - 0.000369275874860411*x_120 - 0.00268609927360869*x_13 - 0.00164717779366274*x_14 - 0.000351854027561424*x_15 - 0.00149038808795075*x_16 - 0.000719246191927726*x_17 + 0.00262159865190793*x_18 - 0.00490736294693769*x_19 + 0.000178586731130668*x_2 - 0.000922688146251736*x_20 + 0.00320286655096506*x_21 + 0.00640768009731497*x_22 + 0.00092491565185008*x_23 + 0.000641489423006081*x_24 + 0.00149241491051143*x_25 + 0.00473038406057101*x_26 + 0.000948063735202792*x_27 - 0.000310597054620487*x_28 - 0.00150780771228001*x_29 - 0.000619352442568501*x_3 - 0.0012642681443895*x_30 + 6.95099041753608e-5*x_31 + 0.000472008293963474*x_32 - 0.00214662287899637*x_33 - 0.000910521607929621*x_34 - 0.000672017452516608*x_35 - 0.00109391537719709*x_36 + 0.00049062844615965*x_37 + 0.00089454452860025*x_38 - 0.00160589360698084*x_39 - 0.000131013251592936*x_4 - 0.00161262855951692*x_40 - 0.00172396562911842*x_41 - 0.00109314796826207*x_42 - 0.000195399018007905*x_43 + 0.00018362942574221*x_44 - 0.00101367291273797*x_45 - 0.00170448299711598*x_46 - 0.00338137546102661*x_47 - 0.00588808916177883*x_48 - 0.00121250297904565*x_49 - 0.00123193323134488*x_5 - 0.000544550899711123*x_50 + 0.00294638099845565*x_51 + 0.00115169872237369*x_52 + 0.00114058167559239*x_53 - 0.0057748541966564*x_54 - 0.00182021579427335*x_55 + 0.00124137576348216*x_56 + 0.00104708712542418*x_57 - 0.00120934192046255*x_58 - 0.000442861084538745*x_59 - 0.0105935408496463*x_6 + 0.00100361634409939*x_60 - 0.000957321417677596*x_61 + 0.000679451772664001*x_62 + 0.00023736550670371*x_63 - 0.000383231510697741*x_64 + 4.21789107890769e-5*x_65 - 0.000669615616406999*x_66 + 0.000992649960780792*x_67 + 0.000281896145546557*x_68 - 0.00043782364382122*x_69 + 0.000118464852754445*x_7 - 0.000277406422694333*x_70 - 0.00093883382589228*x_71 + 0.000161436975947939*x_72 + 2.76922582133364e-5*x_73 + 0.000230861069521295*x_74 + 0.000658894422456348*x_75 + 0.000775477824738299*x_76 + 0.000467043478742686*x_77 - 0.000109860926150759*x_78 + 0.000781582647533146*x_79 - 0.000380279754494296*x_8 + 0.00262486950161562*x_80 - 0.000336382363489637*x_81 - 0.000152227397542032*x_82 - 0.000319322965508885*x_83 - 4.62518193620648e-5*x_84 + 0.000460323637367427*x_85 + 0.00046667603489926*x_86 - 0.000312745090802307*x_87 - 0.000162590136214448*x_88 - 8.09159532409791e-5*x_89 - 0.00195721835056347*x_9 + 0.000275768324476003*x_90 + 0.000606189512284296*x_91 + 0.000430066218454413*x_92 - 0.0012461374599448*x_93 + 0.00117835133986464*x_94 + 0.00133210802208476*x_95 + 0.00028213230168193*x_96 + 0.000262686122994191*x_97 - 0.000475937827506695*x_98 - 0.000387777748293153*x_99 + 2.52227702567039e-5*std::pow(-3.11615991592407*x_28 - 7.80615997314453, 2) + 1.50898678577658e-5*std::pow(-4.07271957397461*x_64 - 9.9672794342041, 2) - 2.82044053870681e-7*std::pow(-4.70783948898315*x_8 - 6.14423990249634, 2) + 0.00110069718803544*std::exp(0.183999866247177*x_10) - 0.00193612870283704*std::sin(0.212719991803169*x_1 + 5.01215982437134) + 0.00051599480295582*std::sin(0.246879979968071*x_1 - 7.55592012405396) + 0.00410397243633244*std::sin(0.270639955997467*x_1 + 5.06863975524902) + 0.0376734227410805*std::sin(0.309119910001755*x_1 + 5.12335968017578) + 0.0183971717394762*std::sin(0.326159834861755*x_1 + 8.32335948944092) - 0.00118641439160929*std::sin(0.333519846200943*x_1 - 4.24272012710571) - 0.0844237057841091*std::sin(0.334079831838608*x_1 - 4.24832010269165) + 0.0112723735717738*std::sin(0.345999836921692*x_1 - 4.23943996429443) - 0.00806094383330774*std::sin(0.352639853954315*x_1 - 4.22119998931885) + 0.00311455479499443*std::sin(0.366159856319427*x_1 + 8.36544036865234) - 8.51460169027508e-6*std::sin(0.669359803199768*x_1 + 2.20183968544006) - 0.00387881745754023*std::sin(0.329439848661423*x_10 + 5.07223987579346) + 0.0173323760534521*std::sin(0.22503998875618*x_100 - 4.40079975128174) - 0.00193556549865168*std::sin(0.246639966964722*x_100 + 1.96799981594086) - 0.0028180368847955*std::sin(0.257359951734543*x_107 - 7.44687986373901) - 0.00140139533569712*std::sin(0.244079977273941*x_11 + 1.96719980239868) + 0.0158840211011605*std::sin(0.256879955530167*x_11 + 5.17695999145508) - 0.0438474419936067*std::sin(0.26895996928215*x_11 - 7.42095994949341) - 0.0567291807682557*std::sin(0.280799955129623*x_113 - 7.41103982925415) - 0.0120730273432831*std::sin(0.288559943437576*x_113 - 7.43031978607178) - 0.00405863239507106*std::sin(0.236719980835915*x_116 + 1.98751986026764) - 0.0111410622733317*std::sin(0.247999966144562*x_116 - 7.43703985214233) + 0.000662311616680024*std::sin(0.257119953632355*x_116 - 4.40911960601807) - 0.0499967415466527*std::sin(0.236159980297089*x_119 + 5.174880027771) + 0.00414040483852448*std::sin(0.282719939947128*x_12 - 4.24959993362427) - 0.0203431226361826*std::sin(0.305519938468933*x_12 - 7.46560001373291) + 4.47614883077592e-5*std::sin(0.243599981069565*x_120 - 4.21704006195068) + 0.0685858013355476*std::sin(0.259839981794357*x_120 - 4.24631977081299) - 0.015611297144523*std::sin(0.262159943580627*x_120 + 5.16527986526489) - 0.00650802650777931*std::sin(0.264319956302643*x_120 + 5.15952014923096) + 0.00257889660867785*std::sin(0.268479973077774*x_120 + 5.15248012542725) - 0.0039800160482631*std::sin(0.208000004291534*x_13 + 5.20496034622192) - 6.16670637785549e-5*std::sin(0.265359938144684*x_13 - 4.39911985397339) + 0.000736930460758419*std::sin(0.288719952106476*x_14 - 4.24064016342163) + 0.000680501588429058*std::sin(0.290559947490692*x_14 + 4.80288028717041) + 0.00665009876443525*std::sin(0.294959932565689*x_14 - 4.25464010238647) - 0.00626845084595966*std::sin(0.297279924154282*x_14 + 4.98759984970093) - 0.00103758325265282*std::sin(0.318319916725159*x_14 + 5.12160015106201) - 4.6937992895469e-5*std::sin(0.33247983455658*x_14 + 1.86767983436584) + 0.000123462185923223*std::sin(0.460639864206314*x_14 + 7.76711988449097) + 0.0148131448636016*std::sin(0.198239997029305*x_15 + 8.19207954406738) + 0.028279409006423*std::sin(0.269839942455292*x_15 + 1.99335980415344) - 0.00762363521883128*std::sin(0.321759909391403*x_15 - 7.44143962860107) + 2.51438300363158e-5*std::sin(0.253999978303909*x_16 - 7.39783954620361) - 0.0051478828815652*std::sin(0.350239843130112*x_16 - 1.15351986885071) - 0.0176836304013673*std::sin(0.356159836053848*x_16 - 1.14495992660522) + 0.000325556660226496*std::sin(0.689119875431061*x_16 - 7.84295988082886) - 0.0120627695386936*std::sin(0.332639843225479*x_17 - 1.1490398645401) - 3.46736562317339e-5*std::sin(0.352479845285416*x_17 + 2.00735974311829) + 0.000170517209651282*std::sin(0.398319840431213*x_17 + 1.99095976352692) - 0.0105077826131064*std::sin(0.272399961948395*x_18 - 1.17335987091064) - 0.00166073471782978*std::sin(0.276239961385727*x_18 - 1.16479980945587) - 1.00229668094903e-5*std::sin(0.280479967594147*x_18 + 2.00055980682373) + 0.00380244665281772*std::sin(0.344239860773087*x_18 - 1.15015983581543) + 0.000405101848000368*std::sin(0.367839843034744*x_18 + 1.99519979953766) + 0.000544537138240873*std::sin(0.384639829397202*x_18 + 2.00191974639893) - 0.0130166500057082*std::sin(0.393519848585129*x_18 + 5.18936014175415) + 0.00180049409985785*std::sin(0.292719930410385*x_19 + 1.98071980476379) - 0.00228436318891866*std::sin(0.373119831085205*x_2 - 7.39439964294434) + 4.3404510021998e-5*std::sin(0.378239840269089*x_2 + 5.18455982208252) + 0.00508580639299874*std::sin(0.387199848890305*x_2 + 5.19736003875732) - 0.00509574821678197*std::sin(0.392479836940765*x_2 + 5.19144010543823) + 0.00385204433894619*std::sin(0.393279850482941*x_2 + 5.18304014205933) - 0.00615272595516253*std::sin(0.264879941940308*x_20 - 1.16751992702484) - 7.21079945446441e-5*std::sin(0.311919927597046*x_20 + 8.18335914611816) - 0.000671736719539601*std::sin(0.396639823913574*x_20 - 4.40351963043213) - 0.000792775205346483*std::sin(0.779839873313904*x_20 - 1.36743986606598) + 1.75427299160955e-5*std::sin(0.262959957122803*x_21 - 7.38935995101929) - 0.0025983457293529*std::sin(0.459439843893051*x_21 - 7.62784004211426) + 0.00158478842935969*std::sin(0.298159927129745*x_23 - 4.34663963317871) - 0.002141531967333*std::sin(0.310159921646118*x_23 + 8.23967933654785) + 0.0102019386390588*std::sin(0.341519832611084*x_23 + 1.9962397813797) + 0.0277940826781638*std::sin(0.346639841794968*x_23 - 1.15591979026794) - 0.0015087008804121*std::sin(0.368399828672409*x_23 + 2.02231979370117) - 0.000555135044289392*std::sin(0.238879978656769*x_24 - 1.17855989933014) - 0.00804133749811851*std::sin(0.247199967503548*x_25 - 4.38279962539673) + 1.32626049779837e-5*std::sin(0.333119839429855*x_25 - 1.13919985294342) - 0.00306986983494143*std::sin(0.348159849643707*x_25 + 8.23272037506104) + 0.00161974048996587*std::sin(0.384799838066101*x_25 + 8.20487976074219) - 0.000193942644564456*std::sin(0.141840040683746*x_26 - 1.25295984745026) - 0.00401273111147638*std::sin(0.283519923686981*x_26 - 1.17279982566833) - 0.00519588948555627*std::sin(0.353679865598679*x_26 + 5.01056003570557) - 0.00454706953956347*std::sin(0.1891999989748*x_27 + 8.18383979797363) - 0.00549910816528942*std::sin(0.226879984140396*x_27 + 5.00183963775635) - 8.57074205794037e-6*std::sin(0.698799848556519*x_27 + 5.2292799949646) + 0.00131006927417944*std::sin(0.308639913797379*x_28 + 1.9936797618866) - 0.000461770533026764*std::sin(0.410879880189896*x_28 + 8.20399951934814) + 0.01754144330111*std::sin(0.29079994559288*x_29 - 1.16375982761383) - 0.00149113400194023*std::sin(0.267839968204498*x_3 - 4.3551197052002) + 2.07809786599768e-5*std::sin(0.324559837579727*x_3 - 7.40367984771729) + 0.010754841543152*std::sin(0.357199847698212*x_3 - 7.38823986053467) + 0.0034655985808535*std::sin(0.36287984251976*x_3 - 7.39383983612061) - 0.0272433974291581*std::sin(0.365039855241776*x_3 - 7.41415977478027) + 0.00551240414032433*std::sin(0.370799839496613*x_3 - 7.40367984771729) - 0.00056941739668154*std::sin(0.385759830474854*x_3 + 1.99527978897095) - 0.000669553201008338*std::sin(0.39183983206749*x_3 + 1.99183976650238) - 4.64306198034087e-5*std::sin(0.449039846658707*x_3 + 8.18967914581299) - 0.139411129697726*std::sin(0.191760003566742*x_30 + 8.18335914611816) - 0.0423798864972167*std::sin(0.304079920053482*x_30 + 1.99335980415344) - 0.109853458179196*std::sin(0.389519840478897*x_30 + 2.00319981575012) - 0.00530008009804857*std::sin(0.390079855918884*x_30 + 1.99391984939575) - 0.0072365425623141*std::sin(0.342559844255447*x_31 - 7.44663953781128) - 0.00600530763154492*std::sin(0.367919832468033*x_31 + 5.17503976821899) - 0.00639206501956076*std::sin(0.369759827852249*x_31 + 5.17216014862061) + 0.0125356759268411*std::sin(0.370159834623337*x_31 + 5.17727994918823) + 0.00740400955082165*std::sin(0.377839833498001*x_31 - 7.40151977539063) + 0.00910060154913597*std::sin(0.380639851093292*x_31 - 7.39687967300415) + 0.00330417530868335*std::sin(0.380719840526581*x_31 - 7.39687967300415) - 6.01856761826496e-6*std::sin(0.423199862241745*x_31 + 5.21799993515015) + 0.00355753457750761*std::sin(0.263039946556091*x_32 + 5.23415994644165) + 0.00117778319907877*std::sin(0.294079929590225*x_32 - 4.36799955368042) + 0.0102798949513106*std::sin(0.30991992354393*x_32 - 1.14351987838745) + 0.000513867221237274*std::sin(0.310159921646118*x_32 - 1.14815986156464) + 0.00235988371755255*std::sin(0.32847985625267*x_32 + 1.99999976158142) + 0.00478635565624672*std::sin(0.241039976477623*x_33 + 1.99663984775543) - 2.59210844244656e-5*std::sin(0.245679974555969*x_36 + 1.78207981586456) + 2.82388013695275e-5*std::sin(0.317439913749695*x_4 - 1.14063990116119) - 1.73646297485105e-6*std::sin(0.530719876289368*x_44 + 5.1005597114563) + 0.000395988702940022*std::sin(0.635519862174988*x_45 - 1.40887975692749) - 1.56802771126135e-5*std::sin(0.338719844818115*x_5 + 2.01407980918884) - 0.000966517606938568*std::sin(0.339759826660156*x_5 + 2.00815987586975) - 0.0140545507464331*std::sin(0.351199835538864*x_5 + 2.00807976722717) - 0.000767713422888958*std::sin(0.210960000753403*x_56 - 1.01687979698181) - 0.000815100014811585*std::sin(0.217439994215965*x_56 - 7.39751958847046) - 0.000699544633134661*std::sin(0.247839972376823*x_56 - 7.42392015457153) - 0.000946567069673133*std::sin(0.274239957332611*x_57 - 7.45928001403809) + 0.00249802127679406*std::sin(0.299679934978485*x_6 + 5.21031999588013) + 0.0185012291428181*std::sin(0.314479917287827*x_6 + 2.01639986038208) - 0.0151136400885283*std::sin(0.352959841489792*x_6 + 2.014399766922) - 0.00244205863506385*std::sin(0.573599874973297*x_6 - 7.57480001449585) + 0.000618771924472722*std::sin(0.444079846143723*x_60 + 5.10624027252197) - 0.0266281267331473*std::sin(0.334399849176407*x_7 - 1.14743983745575) - 0.083592017019921*std::sin(0.339119851589203*x_7 - 1.15287983417511) - 0.0296336736463883*std::sin(0.340719848871231*x_7 - 1.14399981498718) - 0.00672889480335467*std::sin(0.344799846410751*x_7 + 2.02967977523804) + 3.28674899944434e-5*std::sin(0.345839858055115*x_7 - 1.14471983909607) + 0.00223723359052007*std::sin(0.346959829330444*x_7 - 7.36223983764648) + 0.0138035992512056*std::sin(0.348799854516983*x_7 + 2.01079988479614) - 0.00405620489471346*std::sin(0.349759846925735*x_7 - 1.15015983581543) - 1.30978333192621e-5*std::sin(0.97055983543396*x_72 + 8.38920021057129) - 0.0133166802571817*std::sin(0.266479969024658*x_8 - 7.40127992630005) - 0.0357045628392875*std::sin(0.313199937343597*x_8 - 7.42335987091064) - 0.00135579732629478*std::sin(0.326239854097366*x_8 + 8.24759960174561) - 0.00235397347983563*std::sin(0.334319829940796*x_8 - 7.55656003952026) + 1.0720619799179e-5*std::sin(0.363439828157425*x_8 + 5.01847982406616) - 0.000271574441495603*std::sin(0.405199855566025*x_8 + 4.79080009460449) + 0.00121895263355956*std::sin(0.206080004572868*x_9 - 7.41024017333984) + 0.00125554804765555*std::sin(0.404639840126038*x_9 - 4.38887977600098) + 0.00141482017810445*std::sin(0.339599847793579*x_91 + 2.00343990325928) - 0.00160689853196808*std::sin(0.358399868011475*x_91 + 1.99927973747253) + 6.28341933669152e-6*std::sin(0.377519845962524*x_91 + 1.9975198507309) + 0.0107646798397796*std::sin(0.379759848117828*x_91 + 1.99135982990265) + 4.89996218906892e-5*std::sin(0.424319863319397*x_91 + 5.00743961334229) + 0.00123668830082288*std::sin(0.215199992060661*x_92 + 1.98735988140106) + 0.0124599360497561*std::sin(0.255759954452515*x_92 + 1.99335980415344) + 0.00401826956727142*std::sin(0.292079925537109*x_92 + 2.01063990592957) + 0.0132232646409692*std::sin(0.293359935283661*x_92 + 1.99031984806061) - 0.0544987899679604*std::sin(0.293599933385849*x_92 - 7.38927984237671) + 0.000234816052571897*std::sin(0.309599906206131*x_92 - 4.39079999923706) - 0.003425512088881*std::sin(0.225439995527267*x_93 - 1.1833598613739) - 0.00538470095940797*std::sin(0.281519949436188*x_94 - 7.42119979858398) - 3.12819545584605e-5*std::sin(0.310239940881729*x_97 - 1.41639983654022) - 0.137228949491005);
}

inline float score_10(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.00864635400974731*x_1 + 0.000642477698276158*x_10 + 0.00346064371022546*x_100 + 0.00235848570628225*x_101 - 0.000831248314359459*x_102 + 0.00140773722299932*x_103 + 0.00417953006596441*x_104 + 0.00044961150811383*x_105 - 0.000128667878004819*x_106 - 0.00213089544135081*x_107 - 0.00674090189491896*x_108 + 0.000741479884636549*x_109 + 0.00206116113182099*x_11 + 0.0055480793308572*x_110 + 0.00088657475903891*x_111 - 0.00436580122604984*x_112 + 0.00344609965364583*x_113 + 0.00842623694683951*x_114 - 0.00100907836544063*x_115 - 0.00121616411722753*x_116 + 0.0247123219154746*x_117 + 0.0181121804084902*x_118 + 0.00439114242654244*x_119 - 0.00024965725548353*x_12 + 0.000846171953850447*x_120 + 0.00311758465234676*x_13 - 0.000128244046420031*x_14 + 0.00018329540679259*x_15 + 0.00211355790091755*x_16 + 9.60744670920862e-5*x_17 - 0.00380958737846414*x_18 + 0.00115063544419658*x_19 - 8.14897528943392e-5*x_2 + 0.00205847685449149*x_20 + 0.00121380819450991*x_21 - 0.00381669099652121*x_22 - 0.000110023673312195*x_23 - 0.00100348393688778*x_24 + 0.00329208922644645*x_25 + 0.000923500373931634*x_26 + 0.00164735640214977*x_27 + 0.00311043162916636*x_28 + 0.00649851849559105*x_29 + 0.000133031297735951*x_3 + 0.00340558214840731*x_30 - 0.000107269150038307*x_31 - 0.00281520841680357*x_32 - 0.0108436533106425*x_33 - 0.0101675657990035*x_34 - 0.00264080220284968*x_35 - 0.00309665540494929*x_36 + 0.00237489253727091*x_37 - 0.003870056206188*x_38 - 0.00589367224663688*x_39 - 0.00165981589092241*x_4 - 0.00214356412930647*x_40 + 0.000107729204771442*x_41 - 0.00339736962430387*x_42 + 0.000811029194307221*x_43 + 0.00147293147335504*x_44 - 0.00215224463148265*x_45 - 0.00171925438484753*x_46 - 0.000756781294221163*x_47 - 0.015446319004251*x_48 - 0.00945081956151218*x_49 + 0.000881073840583289*x_5 + 0.00142804156469483*x_50 + 0.000768423629193738*x_51 - 0.00337012171861078*x_52 - 0.00314428088195819*x_53 + 0.00868010345117796*x_54 - 0.00465149074045374*x_55 - 0.000239940662697622*x_56 - 0.000845258688642742*x_57 + 0.00498704515858342*x_58 + 1.24087676204738e-5*x_59 + 0.000932017262406718*x_6 - 0.000309624635227573*x_60 + 0.00132764142626227*x_61 - 0.000444825518132649*x_62 - 0.000379192026388153*x_63 - 0.000330437675238395*x_64 - 0.000769880094073068*x_65 + 0.00122514307938803*x_66 + 0.00136262301651331*x_67 - 0.000713728244348999*x_68 + 0.000812937627948917*x_69 + 0.0017130056206796*x_7 + 0.000752324738580519*x_70 - 0.00158125741437296*x_71 + 0.001522459370491*x_72 + 0.000572084189198937*x_73 + 4.35527364033798e-5*x_74 + 0.000503968232399956*x_75 + 0.00284145938262705*x_76 + 0.000840950398497903*x_77 - 0.000750692011522395*x_78 - 0.000110553195401781*x_79 - 0.000940403641652082*x_8 - 1.03059379765971e-5*x_80 + 0.000935745435554531*x_81 - 0.000287445512911124*x_82 + 3.17682740929346e-5*x_83 + 0.000642285758025281*x_84 - 0.00191949026517721*x_85 + 0.000971632529058653*x_86 + 0.00239947270329387*x_87 + 0.000230631339868978*x_88 + 0.00115934040823083*x_89 - 0.00226156255858532*x_9 - 0.000456912044931376*x_90 + 3.68298678112451e-5*x_91 - 0.000124721820761675*x_92 + 0.00112781964939461*x_93 - 0.00500091522966025*x_94 - 0.00139788389361133*x_95 - 0.000547462376532217*x_96 + 0.0019850930725986*x_97 - 0.00233657142342733*x_98 - 0.00586378555310135*x_99 - 7.32868521006545e-7*std::pow(-3.11615991592407*x_28 - 7.80615997314453, 2) + 3.70890701238985e-7*std::pow(-4.07271957397461*x_64 - 9.9672794342041, 2) + 7.34881531149178e-8*std::pow(-4.70783948898315*x_8 - 6.14423990249634, 2) + 5.04625471524032e-5*std::exp(0.183999866247177*x_10) - 8.87637281370885e-5*std::sin(0.212719991803169*x_1 + 5.01215982437134) - 0.00474342633519338*std::sin(0.270639955997467*x_1 + 5.06863975524902) + 0.000925967166194976*std::sin(0.309119910001755*x_1 + 5.12335968017578) - 0.0211986712023676*std::sin(0.326159834861755*x_1 + 8.32335948944092) + 0.00269793607500649*std::sin(0.333519846200943*x_1 - 4.24272012710571) + 0.126525984565697*std::sin(0.334079831838608*x_1 - 4.24832010269165) - 0.00293707987685814*std::sin(0.345999836921692*x_1 - 4.23943996429443) - 0.00966986204104817*std::sin(0.352639853954315*x_1 - 4.22119998931885) - 9.04959741919995e-5*std::sin(0.366159856319427*x_1 + 8.36544036865234) + 0.00581319184235888*std::sin(0.329439848661423*x_10 + 5.07223987579346) + 0.000426008840448151*std::sin(0.22503998875618*x_100 - 4.40079975128174) - 8.87379074862599e-5*std::sin(0.246639966964722*x_100 + 1.96799981594086) - 0.00175327899765405*std::sin(0.257359951734543*x_107 - 7.44687986373901) - 0.00168110581606656*std::sin(0.244079977273941*x_11 + 1.96719980239868) - 0.000461523414500841*std::sin(0.256879955530167*x_11 + 5.17695999145508) + 0.065714253092792*std::sin(0.26895996928215*x_11 - 7.42095994949341) + 0.00164831342411702*std::sin(0.280799955129623*x_113 - 7.41103982925415) + 0.0139114936084594*std::sin(0.288559943437576*x_113 - 7.43031978607178) - 0.00486871216910112*std::sin(0.236719980835915*x_116 + 1.98751986026764) + 0.012837610004514*std::sin(0.247999966144562*x_116 - 7.43703985214233) + 0.0400445467588083*std::sin(0.257119953632355*x_116 - 4.40911960601807) + 0.00145269681559673*std::sin(0.236159980297089*x_119 + 5.174880027771) - 0.00107880559988952*std::sin(0.282719939947128*x_12 - 4.24959993362427) + 0.0304882804749872*std::sin(0.305519938468933*x_12 - 7.46560001373291) - 0.00199281737395486*std::sin(0.259839981794357*x_120 - 4.24631977081299) + 0.0179885669327684*std::sin(0.262159943580627*x_120 + 5.16527986526489) - 0.000298366887903169*std::sin(0.264319956302643*x_120 + 5.15952014923096) + 0.155924708598648*std::sin(0.268479973077774*x_120 + 5.15248012542725) + 0.00103701540500724*std::sin(0.208000004291534*x_13 + 5.20496034622192) - 0.00167579834576556*std::sin(0.288719952106476*x_14 - 4.24064016342163) + 0.00081632580686559*std::sin(0.290559947490692*x_14 + 4.80288028717041) - 0.0017327203659263*std::sin(0.294959932565689*x_14 - 4.25464010238647) + 0.0093945404033189*std::sin(0.297279924154282*x_14 + 4.98759984970093) + 0.00119925262704428*std::sin(0.318319916725159*x_14 + 5.12160015106201) + 0.00746474492162761*std::sin(0.460639864206314*x_14 + 7.76711988449097) + 0.000364089184729899*std::sin(0.198239997029305*x_15 + 8.19207954406738) - 0.000821681696441249*std::sin(0.269839942455292*x_15 + 1.99335980415344) + 0.00198638072515661*std::sin(0.321759909391403*x_15 - 7.44143962860107) - 0.00378126050932032*std::sin(0.253999978303909*x_16 - 7.39783954620361) - 0.00617537081235096*std::sin(0.350239843130112*x_16 - 1.15351986885071) + 0.000513812556129986*std::sin(0.356159836053848*x_16 - 1.14495992660522) - 0.000375132041794969*std::sin(0.689119875431061*x_16 - 7.84295988082886) - 0.0144704292306501*std::sin(0.332639843225479*x_17 - 1.1490398645401) + 0.00521440555529681*std::sin(0.352479845285416*x_17 + 2.00735974311829) - 0.000387760410343322*std::sin(0.398319840431213*x_17 + 1.99095976352692) + 0.000305312343741418*std::sin(0.272399961948395*x_18 - 1.17335987091064) - 0.100410995953042*std::sin(0.276239961385727*x_18 - 1.16479980945587) + 0.00150730610763019*std::sin(0.280479967594147*x_18 + 2.00055980682373) + 0.00236574258202765*std::sin(0.344239860773087*x_18 - 1.15015983581543) - 0.000921211759990113*std::sin(0.367839843034744*x_18 + 1.99519979953766) - 0.000629383321183047*std::sin(0.384639829397202*x_18 + 2.00191974639893) - 0.00180436441265521*std::sin(0.393519848585129*x_18 + 5.18936014175415) + 0.108861098544719*std::sin(0.292719930410385*x_19 + 1.98071980476379) - 0.00274030899424194*std::sin(0.373119831085205*x_2 - 7.39439964294434) - 0.00652739695724684*std::sin(0.378239840269089*x_2 + 5.18455982208252) - 0.0058782431788952*std::sin(0.387199848890305*x_2 + 5.19736003875732) + 0.00132772565154536*std::sin(0.392479836940765*x_2 + 5.19144010543823) + 0.232901500990064*std::sin(0.393279850482941*x_2 + 5.18304014205933) + 0.00708965575626449*std::sin(0.264879941940308*x_20 - 1.16751992702484) - 0.000805811520359992*std::sin(0.396639823913574*x_20 - 4.40351963043213) - 0.000109894279029959*std::sin(0.779839873313904*x_20 - 1.36743986606598) - 0.00263816736597395*std::sin(0.262959957122803*x_21 - 7.38935995101929) + 0.00389414618317228*std::sin(0.459439843893051*x_21 - 7.62784004211426) + 0.0958191473077728*std::sin(0.298159927129745*x_23 - 4.34663963317871) - 0.00133238249697438*std::sin(0.310159921646118*x_23 + 8.23967933654785) - 0.00265817207803964*std::sin(0.341519832611084*x_23 + 1.9962397813797) - 0.0416550498854907*std::sin(0.346639841794968*x_23 - 1.15591979026794) - 0.00180982893274999*std::sin(0.368399828672409*x_23 + 2.02231979370117) + 0.00126239101032577*std::sin(0.238879978656769*x_24 - 1.17855989933014) + 0.000233647734137935*std::sin(0.247199967503548*x_25 - 4.38279962539673) - 0.00199449981890322*std::sin(0.333119839429855*x_25 - 1.13919985294342) - 0.00190996020533816*std::sin(0.348159849643707*x_25 + 8.23272037506104) - 0.00187211776284474*std::sin(0.384799838066101*x_25 + 8.20487976074219) + 0.0004410304367118*std::sin(0.141840040683746*x_26 - 1.25295984745026) + 0.00463796838928989*std::sin(0.283519923686981*x_26 - 1.17279982566833) + 0.00778709044750677*std::sin(0.353679865598679*x_26 + 5.01056003570557) - 0.00282901958012081*std::sin(0.1891999989748*x_27 + 8.18383979797363) + 0.00824152491748912*std::sin(0.226879984140396*x_27 + 5.00183963775635) - 0.000341345864558416*std::sin(0.308639913797379*x_28 + 1.9936797618866) - 0.000287296657350209*std::sin(0.410879880189896*x_28 + 8.20399951934814) - 0.000509681191937583*std::sin(0.29079994559288*x_29 - 1.16375982761383) + 0.000388523290406567*std::sin(0.267839968204498*x_3 - 4.3551197052002) - 0.00312515212831563*std::sin(0.324559837579727*x_3 - 7.40367984771729) - 0.0161183035316544*std::sin(0.357199847698212*x_3 - 7.38823986053467) + 0.00215616808952842*std::sin(0.36287984251976*x_3 - 7.39383983612061) + 0.000791579520326239*std::sin(0.365039855241776*x_3 - 7.41415977478027) - 0.0063713105716691*std::sin(0.370799839496613*x_3 - 7.40367984771729) - 2.61055016236816e-5*std::sin(0.385759830474854*x_3 + 1.99527978897095) - 0.000803192184039332*std::sin(0.39183983206749*x_3 + 1.99183976650238) + 0.000105584393647325*std::sin(0.449039846658707*x_3 + 8.18967914581299) + 0.00405070606414729*std::sin(0.191760003566742*x_30 + 8.18335914611816) + 0.0635148245986156*std::sin(0.304079920053482*x_30 + 1.99335980415344) - 0.00270006513785614*std::sin(0.389519840478897*x_30 + 2.00319981575012) - 0.00329751507935538*std::sin(0.390079855918884*x_30 + 1.99391984939575) - 0.00100312752239464*std::sin(0.342559844255447*x_31 - 7.44663953781128) + 0.00156471643586397*std::sin(0.367919832468033*x_31 + 5.17503976821899) + 0.00957980122403138*std::sin(0.369759827852249*x_31 + 5.17216014862061) - 0.000364234466825847*std::sin(0.370159834623337*x_31 + 5.17727994918823) + 0.00888180743937397*std::sin(0.377839833498001*x_31 - 7.40151977539063) + 0.550238671781777*std::sin(0.380639851093292*x_31 - 7.39687967300415) + 0.00205573646127134*std::sin(0.380719840526581*x_31 - 7.39687967300415) + 0.000905103638735618*std::sin(0.423199862241745*x_31 + 5.21799993515015) - 0.00533168451757759*std::sin(0.263039946556091*x_32 + 5.23415994644165) - 0.00135713462582778*std::sin(0.294079929590225*x_32 - 4.36799955368042) - 0.0118816403354416*std::sin(0.30991992354393*x_32 - 1.14351987838745) - 0.00116854694594429*std::sin(0.310159921646118*x_32 - 1.14815986156464) - 0.000614880879738096*std::sin(0.32847985625267*x_32 + 1.99999976158142) - 0.00553213400471371*std::sin(0.241039976477623*x_33 + 1.99663984775543) + 5.89451959337706e-5*std::sin(0.245679974555969*x_36 + 1.78207981586456) - 0.00424669846618087*std::sin(0.317439913749695*x_4 - 1.14063990116119) + 0.000261138373239786*std::sin(0.530719876289368*x_44 + 5.1005597114563) + 0.000246369619900626*std::sin(0.635519862174988*x_45 - 1.40887975692749) + 0.00235808198414837*std::sin(0.338719844818115*x_5 + 2.01407980918884) + 0.00111711400144723*std::sin(0.339759826660156*x_5 + 2.00815987586975) + 0.00366199167484957*std::sin(0.351199835538864*x_5 + 2.00807976722717) - 0.0464173287709281*std::sin(0.210960000753403*x_56 - 1.01687979698181) + 0.000942103519469299*std::sin(0.217439994215965*x_56 - 7.39751958847046) - 3.20713129991497e-5*std::sin(0.247839972376823*x_56 - 7.42392015457153) - 4.33963000046791e-5*std::sin(0.274239957332611*x_57 - 7.45928001403809) + 0.000114524246848415*std::sin(0.299679934978485*x_6 + 5.21031999588013) - 0.0213185743435056*std::sin(0.314479917287827*x_6 + 2.01639986038208) + 0.00393794331668053*std::sin(0.352959841489792*x_6 + 2.014399766922) + 7.09560401920886e-5*std::sin(0.573599874973297*x_6 - 7.57480001449585) - 0.000715184881856853*std::sin(0.444079846143723*x_60 + 5.10624027252197) + 0.000773702319669254*std::sin(0.334399849176407*x_7 - 1.14743983745575) - 0.00205459067652101*std::sin(0.339119851589203*x_7 - 1.15287983417511) + 0.044412048720012*std::sin(0.340719848871231*x_7 - 1.14399981498718) + 0.00777734678098918*std::sin(0.344799846410751*x_7 + 2.02967977523804) - 0.00494278484132961*std::sin(0.345839858055115*x_7 - 1.14471983909607) + 0.000102568178405235*std::sin(0.346959829330444*x_7 - 7.36223983764648) - 0.0159055949511883*std::sin(0.348799854516983*x_7 + 2.01079988479614) - 0.00486580015357937*std::sin(0.349759846925735*x_7 - 1.15015983581543) - 0.00032730789462942*std::sin(0.266479969024658*x_8 - 7.40127992630005) + 0.00103742570284321*std::sin(0.313199937343597*x_8 - 7.42335987091064) - 6.21578643526523e-5*std::sin(0.326239854097366*x_8 + 8.24759960174561) + 0.0035279049813258*std::sin(0.334319829940796*x_8 - 7.55656003952026) - 0.00161222280867807*std::sin(0.363439828157425*x_8 + 5.01847982406616) + 0.000313889378581422*std::sin(0.405199855566025*x_8 + 4.79080009460449) + 5.58840845749164e-5*std::sin(0.206080004572868*x_9 - 7.41024017333984) - 0.00145117925783933*std::sin(0.404639840126038*x_9 - 4.38887977600098) - 0.00163526812046064*std::sin(0.339599847793579*x_91 + 2.00343990325928) - 0.0971559637178217*std::sin(0.358399868011475*x_91 + 1.99927973747253) - 0.00094493342370734*std::sin(0.377519845962524*x_91 + 1.9975198507309) - 0.000312776705849408*std::sin(0.379759848117828*x_91 + 1.99135982990265) - 0.00142500972650622*std::sin(0.215199992060661*x_92 + 1.98735988140106) - 0.000362033781844159*std::sin(0.255759954452515*x_92 + 1.99335980415344) + 0.242951776057758*std::sin(0.292079925537109*x_92 + 2.01063990592957) - 0.0198177343950035*std::sin(0.293359935283661*x_92 + 1.99031984806061) - 0.00133951434289669*std::sin(0.293599933385849*x_92 - 7.38927984237671) - 0.000533977591392009*std::sin(0.309599906206131*x_92 - 4.39079999923706) - 0.000474843535440115*std::sin(0.225439995527267*x_93 - 1.1833598613739) - 0.000246866921274416*std::sin(0.281519949436188*x_94 - 7.42119979858398) + 7.11359490384352e-5*std::sin(0.310239940881729*x_97 - 1.41639983654022) - 0.147717759013176*std::sin(0.00745118306304307*x_10 + 0.0045391448536523*x_100 + 0.00856371601573206*x_101 + 0.00795979224621995*x_102 + 0.00399115808560789*x_103 - 0.0063905937045417*x_104 + 0.00321339926535998*x_105 + 0.00826451723142736*x_106 + 0.0096421975782907*x_107 + 0.00141674594660608*x_108 + 0.00764112158526008*x_109 + 0.00509067248413379*x_11 + 0.00484097598642396*x_110 - 0.0095089502066934*x_111 - 0.010196182277284*x_112 + 0.0169329911531586*x_113 + 0.0126900578530235*x_114 - 0.00208713551518943*x_115 - 0.014703654949681*x_116 - 0.00557411636693717*x_117 - 0.0186145522668787*x_118 - 0.0223321894502343*x_119 + 0.0171680221953121*x_12 + 0.0151969961709659*x_15 + 0.00748195819459427*x_16 - 0.00172048286672084*x_17 - 0.00224181538901958*x_18 + 0.0100761444085068*x_19 + 0.00246152430479739*x_2 - 0.00333071886880179*x_20 + 0.00396652175000972*x_21 + 0.00319866573401746*x_22 + 0.00344097185585092*x_23 - 0.00711741918667885*x_24 - 0.0239851249206708*x_25 - 0.00128550437805883*x_26 - 0.00274255904193251*x_28 - 0.0262768592584608*x_29 - 0.00281662640184989*x_3 - 0.0407241907495276*x_30 + 0.0114146946615218*x_31 + 0.0142467214104455*x_32 + 0.0131164577616978*x_33 - 0.000291408229541094*x_34 - 0.00887890063782167*x_35 + 4.87117015073837e-5*x_36 - 0.00489603177571171*x_37 + 0.00152333418869957*x_38 + 0.00749380721197657*x_39 + 0.00461730624376778*x_4 + 0.00722560304155871*x_40 + 0.0221597238989544*x_41 + 0.00336084530990886*x_42 + 0.00942222722861805*x_43 + 0.00554024584080849*x_44 - 0.0143842676752344*x_45 - 0.00848343965206342*x_46 - 0.0189809966422255*x_47 + 0.00112200579201936*x_48 - 0.0156979820365529*x_49 + 0.00719975138841673*x_5 - 0.00355368291231745*x_50 + 0.00916233961412768*x_51 - 0.018499688900673*x_52 - 0.00176117194966587*x_53 + 0.011705579765001*x_54 - 0.0272798005911769*x_55 - 0.0215214350980024*x_56 - 0.0170054094105941*x_57 - 0.0234573289556875*x_58 - 0.0415861056923554*x_59 - 0.000750038447340957*x_6 - 0.0151226861665772*x_60 - 0.00368425072240753*x_61 + 0.00226037821235798*x_62 - 0.00266570862107626*x_63 - 0.00836051985523297*x_64 - 0.00842235123417157*x_65 + 0.00134400620901367*x_66 + 0.0126194556801235*x_67 + 0.0050220810790774*x_68 + 0.0056650856089729*x_69 + 0.00507696634814239*x_7 - 0.00581696407913258*x_70 + 0.00633481734982771*x_71 + 0.000106986067530088*x_72 + 0.00917146847395599*x_73 + 0.00334063433178715*x_74 - 0.00967209641976673*x_75 - 0.00556358889797628*x_76 + 0.000243480461423424*x_77 + 0.000990323532267256*x_78 - 0.00149108215255548*x_79 + 0.00444120673962885*x_8 - 9.84000748971618e-5*x_80 + 0.00450676607963972*x_81 + 0.00523729493354022*x_82 + 0.00716818756207931*x_83 + 0.000600565940633046*x_84 - 0.000563799147706606*x_85 - 0.00282158977483275*x_86 + 0.00170936653577555*x_87 + 0.0100279537498917*x_88 - 0.000286653405252941*x_89 + 0.00722086628243552*x_9 + 0.000895968529987018*x_90 + 0.00658951170442487*x_91 + 0.0253442341949188*x_92 + 0.00939426126513774*x_93 + 0.00750590335298511*x_94 + 0.000951609874299394*x_95 + 0.00046267899275708*x_96 + 0.0249145908951653*x_97 + 0.0151289903434578*x_98 + 0.032004945387777*x_99 - 0.0291656263965447*std::sin(0.669359803199768*x_1 + 2.20183968544006) + 0.153324476285071*std::sin(0.243599981069565*x_120 - 4.21704006195068) - 0.211232258250136*std::sin(0.265359938144684*x_13 - 4.39911985397339) - 0.160779800910299*std::sin(0.33247983455658*x_14 + 1.86767983436584) - 0.0293579276983145*std::sin(0.698799848556519*x_27 + 5.2292799949646) + 4.90192539505181) - 0.0578618384897709*std::sin(0.0099891425583097*x_10 - 0.00178381225823126*x_100 + 0.00523197452752706*x_101 + 0.00104356172616367*x_102 - 0.00213590631101636*x_103 - 0.00388906560258432*x_104 - 0.00990693333469575*x_105 + 0.00208946828127087*x_106 + 0.00258543600018228*x_107 + 0.00284886834526001*x_108 + 0.0045645871683269*x_109 + 0.0079989749058837*x_11 + 0.000836307146084286*x_110 + 0.00305069108123363*x_111 - 0.00251058111226249*x_112 + 0.0031640611848432*x_113 + 0.00200827264500929*x_114 + 0.00290549948544401*x_115 + 0.0010225511705295*x_116 + 0.00249505224301936*x_117 + 0.00269790703403688*x_118 + 0.00416159648966729*x_119 + 0.00232176896481603*x_12 + 0.00739154447372315*x_120 + 0.000445654168920218*x_13 + 0.000991284394951321*x_14 + 0.00339773300932831*x_15 + 0.00205602196192564*x_16 + 0.00636557668500515*x_17 - 0.000974679465301141*x_18 + 0.00631641158904767*x_19 - 0.00372599287199862*x_2 + 0.00218761725153295*x_21 + 0.00388089881512093*x_22 + 0.000684476906980931*x_23 + 0.000611711985131913*x_24 + 0.00331273274413782*x_25 + 0.00474367982882252*x_26 - 0.00962424401333285*x_27 - 6.90851536863566e-5*x_28 - 0.000310201626177616*x_29 - 0.0107944965433765*x_3 - 0.00407965844906259*x_30 + 0.000337765536188595*x_31 + 0.00118827215095859*x_32 + 0.00603073442328451*x_33 - 0.00088131102123621*x_34 + 0.00336561922835396*x_35 - 0.00431991994092677*x_36 + 0.0037379514778838*x_37 + 0.00421008622755245*x_38 - 0.00160260456289447*x_39 + 0.000564866011970971*x_4 - 0.00576270701101904*x_40 - 0.00313742695594529*x_41 + 0.00155016481917803*x_42 - 0.000675168787974092*x_43 + 0.000870849555220174*x_44 - 0.0146906416435023*x_45 + 0.00276511153297085*x_46 - 0.00517352538772896*x_47 - 0.0065596224229207*x_48 + 0.00320902697281466*x_49 + 0.00300614495802737*x_5 + 0.00324307314832528*x_50 + 0.00176703412564356*x_51 - 0.00564054378040177*x_52 + 0.000351300208262284*x_53 - 0.000799258408065768*x_54 - 0.00226088303615717*x_55 + 4.57879028023025e-5*x_56 - 0.000611710127513636*x_57 + 0.0144885180446442*x_58 - 0.00983947002174878*x_59 + 0.00478700183859038*x_6 + 0.00784171591591094*x_60 + 0.00475234442520228*x_61 + 0.00122133296721774*x_62 + 0.00602839121807942*x_63 + 0.00400048022516687*x_64 + 0.00104172158281913*x_65 + 0.00375118305481752*x_66 + 0.003143645417119*x_67 + 0.0021214403579837*x_68 + 0.00363840789632709*x_69 + 0.00391687731973713*x_7 + 0.00167149241701219*x_70 + 0.00253645803145716*x_71 + 0.00624994543878137*x_73 - 0.00130612952277672*x_74 + 0.00587743215844103*x_75 + 0.00496834190746888*x_76 + 0.00686799318120138*x_77 + 0.00747581473161117*x_78 + 0.00896382504587835*x_79 + 0.00399930458845268*x_8 + 0.00137023999758519*x_80 + 0.00503300031175744*x_81 + 0.0124854355059163*x_82 + 0.00289694257203594*x_83 - 0.000185737178339411*x_84 + 0.00183377035933136*x_85 + 0.00754776455923016*x_86 + 0.00387095070691328*x_87 + 0.00324489555017402*x_88 + 0.00396001619751917*x_89 - 0.00198307103753709*x_9 + 0.0043399647577854*x_90 + 0.00929243095691087*x_92 + 0.0102005969718614*x_93 + 0.00472449847476981*x_94 - 0.00126186926065451*x_95 - 0.00638767697752951*x_96 + 0.000785305392688827*x_97 + 0.00329916413389406*x_98 + 0.00428821458302582*x_99 + 0.486460033923947*std::sin(0.246879979968071*x_1 - 7.55592012405396) - 0.0679806410286243*std::sin(0.311919927597046*x_20 + 8.18335914611816) - 0.0123481329740525*std::sin(0.97055983543396*x_72 + 8.38920021057129) + 0.0461949569853441*std::sin(0.424319863319397*x_91 + 5.00743961334229) + 7.76826825742976) + 0.339773584644916);
}

inline float score_11(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.00124478055658326*x_1 - 0.00131998016531801*x_10 + 0.00129135862394395*x_100 + 0.00227030675630474*x_101 - 0.00063723924306582*x_102 + 0.000878684280374944*x_103 + 0.00338899058931159*x_104 - 0.00268660229747908*x_105 - 0.00448579048135939*x_106 - 0.000222320904940303*x_107 + 0.00124996662315863*x_108 + 0.00089584670476142*x_109 + 0.0166956949947715*x_11 + 0.000978866251390043*x_110 + 0.000572143027145096*x_111 - 0.0132021735273496*x_112 - 0.00782210473863219*x_113 - 0.00267796923310225*x_114 - 9.73759266496926e-5*x_115 - 0.0167308274241611*x_116 + 0.00211722643674464*x_117 - 0.013398283819919*x_118 + 0.000587227086947234*x_119 - 0.00604469696306083*x_12 - 0.0397116979652502*x_120 - 0.0153124624568092*x_13 - 0.00074302672648403*x_14 - 0.00500646826551544*x_15 - 0.00430252342861904*x_16 - 0.00428944135244711*x_17 - 0.000164418160781471*x_18 - 0.028902303913448*x_19 + 0.000100086346931127*x_2 - 0.00493834049772939*x_20 - 0.013812569406784*x_21 - 0.00228323332288701*x_22 + 9.05740872888772e-5*x_23 - 0.000106307593926178*x_24 - 0.000801852162093787*x_25 - 0.000588211004464061*x_26 - 0.00159814073429763*x_27 - 0.000682761883829047*x_28 + 0.000599436958542635*x_29 - 0.000194394715130875*x_3 - 0.0219748044222407*x_30 + 0.00289870257154037*x_31 - 6.8260964215438e-5*x_32 - 0.00110678980690069*x_33 + 0.000702201730871462*x_34 + 0.0056441605991374*x_35 - 0.00313854503520608*x_36 + 0.00187227571765112*x_37 + 0.000598959613143722*x_38 - 0.00305934829587104*x_39 - 0.00321309863834201*x_4 + 0.00218400805251025*x_40 - 0.00064026990399301*x_41 - 0.000165557991763198*x_42 - 0.00011760688841478*x_43 + 0.00217440044521047*x_44 - 0.00413547901185442*x_45 + 0.000180748134757885*x_46 - 0.00067609807594247*x_47 - 0.00116403970780983*x_48 + 0.00105651292783205*x_49 - 0.000405604827826903*x_5 + 0.000154229999967215*x_50 + 0.00013211058996512*x_51 + 0.0153118190202752*x_52 + 0.0172095469466368*x_53 + 0.00184531801249411*x_54 + 0.00384330752539345*x_55 - 0.00109320054127407*x_56 + 0.0073557537710178*x_57 + 0.0034557867079545*x_58 + 0.00645997447717958*x_59 + 0.0191072882644557*x_6 - 0.000448527951627298*x_60 - 0.00273515066439566*x_61 - 0.00120502434230215*x_62 + 7.16856482620866e-5*x_63 + 0.00135035055695447*x_64 - 0.000346979701027301*x_65 - 0.000267639964982602*x_66 + 0.00055867670270342*x_67 - 0.00236730385457811*x_68 - 0.00115041160036964*x_69 - 0.000235725778933707*x_7 - 0.00158226624999534*x_70 + 0.000171998483962931*x_71 - 0.000807477296672563*x_72 - 0.00135619654224243*x_73 - 0.00169479689550545*x_74 - 0.00224216584753024*x_75 - 0.00292873740659777*x_76 - 0.0020675682734316*x_77 - 0.000886856289451357*x_78 - 0.000970679053150614*x_79 - 0.000455796800581765*x_8 - 0.000321412130072535*x_80 - 0.00308761696747083*x_81 - 0.00226927124358788*x_82 - 0.00534860771526828*x_83 - 0.00181252776576943*x_84 + 0.000754635741989886*x_85 + 0.000450618620113177*x_86 - 0.0013095025197822*x_87 - 0.00178049296632003*x_88 - 0.00259032797701734*x_89 - 0.000943684392445967*x_9 - 0.0027426276363707*x_90 - 0.000294358057207664*x_91 - 0.000668901755328384*x_92 - 0.0163942725328902*x_93 - 4.11674862365351e-5*x_94 + 0.00209668171247072*x_95 - 0.00271627762568791*x_96 + 0.00106297178137462*x_97 - 0.00495468083089304*x_98 - 0.000264378626417394*x_99 - 3.09930278350876e-7*std::pow(-3.11615991592407*x_28 - 7.80615997314453, 2) - 1.33779852616357e-7*std::pow(-4.07271957397461*x_64 - 9.9672794342041, 2) + 3.11219887350351e-7*std::pow(-4.70783948898315*x_8 - 6.14423990249634, 2) + 0.000659566940595574*std::exp(0.183999866247177*x_10) - 0.00116017965614026*std::sin(0.212719991803169*x_1 + 5.01215982437134) + 0.172672842541338*std::sin(0.270639955997467*x_1 + 5.06863975524902) - 0.00033399529998281*std::sin(0.309119910001755*x_1 + 5.12335968017578) - 0.00917092911476105*std::sin(0.326159834861755*x_1 + 8.32335948944092) - 0.0633896021339691*std::sin(0.333519846200943*x_1 - 4.24272012710571) + 0.00517503741434667*std::sin(0.334079831838608*x_1 - 4.24832010269165) - 0.0124384357160994*std::sin(0.345999836921692*x_1 - 4.23943996429443) + 0.00153559085515021*std::sin(0.352639853954315*x_1 - 4.22119998931885) - 3.82707698134432e-5*std::sin(0.366159856319427*x_1 + 8.36544036865234) + 0.000105492184814607*std::sin(0.669359803199768*x_1 + 2.20183968544006) + 0.000237765273151158*std::sin(0.329439848661423*x_10 + 5.07223987579346) - 0.000153660902519355*std::sin(0.22503998875618*x_100 - 4.40079975128174) - 0.00115984216925876*std::sin(0.246639966964722*x_100 + 1.96799981594086) + 7.30437316077896e-5*std::sin(0.257359951734543*x_107 - 7.44687986373901) + 0.000266962517844961*std::sin(0.244079977273941*x_11 + 1.96719980239868) - 0.00019517836586191*std::sin(0.256879955530167*x_11 + 5.17695999145508) + 0.00268777768913126*std::sin(0.26895996928215*x_11 - 7.42095994949341) + 0.000697072153739715*std::sin(0.280799955129623*x_113 - 7.41103982925415) + 0.00601836410149064*std::sin(0.288559943437576*x_113 - 7.43031978607178) + 0.000773159932529896*std::sin(0.236719980835915*x_116 + 1.98751986026764) + 0.00555378260412831*std::sin(0.247999966144562*x_116 - 7.43703985214233) + 0.00114461575931929*std::sin(0.257119953632355*x_116 - 4.40911960601807) + 0.000614345841732921*std::sin(0.236159980297089*x_119 + 5.174880027771) - 0.00456870588032768*std::sin(0.282719939947128*x_12 - 4.24959993362427) + 0.00124700070660371*std::sin(0.305519938468933*x_12 - 7.46560001373291) - 0.000554575230751219*std::sin(0.243599981069565*x_120 - 4.21704006195068) - 0.00084276295912398*std::sin(0.259839981794357*x_120 - 4.24631977081299) + 0.00778217986597803*std::sin(0.262159943580627*x_120 + 5.16527986526489) - 0.00389978204696994*std::sin(0.264319956302643*x_120 + 5.15952014923096) + 0.00445688347540163*std::sin(0.268479973077774*x_120 + 5.15248012542725) + 0.00439172579316621*std::sin(0.208000004291534*x_13 + 5.20496034622192) + 0.000764027904738235*std::sin(0.265359938144684*x_13 - 4.39911985397339) + 0.0393738722644075*std::sin(0.288719952106476*x_14 - 4.24064016342163) - 0.000129633953258555*std::sin(0.290559947490692*x_14 + 4.80288028717041) - 0.00733801319309215*std::sin(0.294959932565689*x_14 - 4.25464010238647) + 0.000384245957418518*std::sin(0.297279924154282*x_14 + 4.98759984970093) - 0.0436558608490461*std::sin(0.318319916725159*x_14 + 5.12160015106201) + 0.000581541169096728*std::sin(0.33247983455658*x_14 + 1.86767983436584) + 0.000213368994486476*std::sin(0.460639864206314*x_14 + 7.76711988449097) - 0.000131326553374522*std::sin(0.198239997029305*x_15 + 8.19207954406738) - 0.00034748939215467*std::sin(0.269839942455292*x_15 + 1.99335980415344) + 0.00841225638847436*std::sin(0.321759909391403*x_15 - 7.44143962860107) + 0.0051010525687344*std::sin(0.253999978303909*x_16 - 7.39783954620361) + 0.000980659590214767*std::sin(0.350239843130112*x_16 - 1.15351986885071) + 0.000217291456757929*std::sin(0.356159836053848*x_16 - 1.14495992660522) - 0.000162288915712462*std::sin(0.689119875431061*x_16 - 7.84295988082886) + 0.00229792924680402*std::sin(0.332639843225479*x_17 - 1.1490398645401) - 0.00703441531909973*std::sin(0.352479845285416*x_17 + 2.00735974311829) + 0.00911065994582865*std::sin(0.398319840431213*x_17 + 1.99095976352692) + 0.000129116665496526*std::sin(0.272399961948395*x_18 - 1.17335987091064) - 0.00287010386380555*std::sin(0.276239961385727*x_18 - 1.16479980945587) - 0.00203340861420259*std::sin(0.280479967594147*x_18 + 2.00055980682373) - 9.85597080932144e-5*std::sin(0.344239860773087*x_18 - 1.15015983581543) + 0.0216444145907965*std::sin(0.367839843034744*x_18 + 1.99519979953766) + 0.0229111615606768*std::sin(0.384639829397202*x_18 + 2.00191974639893) - 0.0174280983456844*std::sin(0.393519848585129*x_18 + 5.18936014175415) + 0.00311163788971308*std::sin(0.292719930410385*x_19 + 1.98071980476379) + 0.000435165818703619*std::sin(0.373119831085205*x_2 - 7.39439964294434) + 0.00880568660472911*std::sin(0.378239840269089*x_2 + 5.18455982208252) + 0.213983076182353*std::sin(0.387199848890305*x_2 + 5.19736003875732) + 0.00562287403059305*std::sin(0.392479836940765*x_2 + 5.19144010543823) + 0.00665715434383599*std::sin(0.393279850482941*x_2 + 5.18304014205933) + 0.00306711348876894*std::sin(0.264879941940308*x_20 - 1.16751992702484) + 0.000127964266334596*std::sin(0.396639823913574*x_20 - 4.40351963043213) - 0.00106145315720555*std::sin(0.779839873313904*x_20 - 1.36743986606598) + 0.00355897997130372*std::sin(0.262959957122803*x_21 - 7.38935995101929) + 0.0001592744151648*std::sin(0.459439843893051*x_21 - 7.62784004211426) + 0.00273885247630849*std::sin(0.298159927129745*x_23 - 4.34663963317871) + 5.55086724007608e-5*std::sin(0.310159921646118*x_23 + 8.23967933654785) - 0.0112572704527175*std::sin(0.341519832611084*x_23 + 1.9962397813797) - 0.00170373257630698*std::sin(0.346639841794968*x_23 - 1.15591979026794) + 0.00028740397192015*std::sin(0.368399828672409*x_23 + 2.02231979370117) - 0.0296606226601782*std::sin(0.238879978656769*x_24 - 1.17855989933014) + 9.88096844137408e-5*std::sin(0.247199967503548*x_25 - 4.38279962539673) + 0.00269064995640444*std::sin(0.333119839429855*x_25 - 1.13919985294342) + 7.95712609384755e-5*std::sin(0.348159849643707*x_25 + 8.23272037506104) + 0.0681498715989552*std::sin(0.384799838066101*x_25 + 8.20487976074219) - 0.0103622706894804*std::sin(0.141840040683746*x_26 - 1.25295984745026) - 0.168833903765664*std::sin(0.283519923686981*x_26 - 1.17279982566833) + 0.000318499670665078*std::sin(0.353679865598679*x_26 + 5.01056003570557) + 0.000117860390274463*std::sin(0.1891999989748*x_27 + 8.18383979797363) + 0.000337086488168216*std::sin(0.226879984140396*x_27 + 5.00183963775635) + 0.000106187739375671*std::sin(0.698799848556519*x_27 + 5.2292799949646) - 0.00144558839775514*std::sin(0.308639913797379*x_28 + 1.9936797618866) + 1.19691275372503e-5*std::sin(0.410879880189896*x_28 + 8.20399951934814) - 0.00021554430182165*std::sin(0.29079994559288*x_29 - 1.16375982761383) + 0.00164538322910682*std::sin(0.267839968204498*x_3 - 4.3551197052002) + 0.00421593943409514*std::sin(0.324559837579727*x_3 - 7.40367984771729) - 0.000659254493204886*std::sin(0.357199847698212*x_3 - 7.38823986053467) - 8.98285803021239e-5*std::sin(0.36287984251976*x_3 - 7.39383983612061) + 0.000334759174448663*std::sin(0.365039855241776*x_3 - 7.41415977478027) + 0.231931989532822*std::sin(0.370799839496613*x_3 - 7.40367984771729) - 0.000341210002472586*std::sin(0.385759830474854*x_3 + 1.99527978897095) + 0.000127548311186167*std::sin(0.39183983206749*x_3 + 1.99183976650238) - 0.00248076771234998*std::sin(0.449039846658707*x_3 + 8.18967914581299) + 0.00171304459393957*std::sin(0.191760003566742*x_30 + 8.18335914611816) + 0.00259781889697791*std::sin(0.304079920053482*x_30 + 1.99335980415344) + 0.000973910413473021*std::sin(0.389519840478897*x_30 + 2.00319981575012) + 0.000137378481548776*std::sin(0.390079855918884*x_30 + 1.99391984939575) - 0.00968906557397131*std::sin(0.342559844255447*x_31 - 7.44663953781128) + 0.00662652212994552*std::sin(0.367919832468033*x_31 + 5.17503976821899) + 0.000391823307493213*std::sin(0.369759827852249*x_31 + 5.17216014862061) - 0.00015403484588651*std::sin(0.370159834623337*x_31 + 5.17727994918823) - 0.00141044641828513*std::sin(0.377839833498001*x_31 - 7.40151977539063) + 0.0157277808362209*std::sin(0.380639851093292*x_31 - 7.39687967300415) - 8.56444767400787e-5*std::sin(0.380719840526581*x_31 - 7.39687967300415) - 0.00122101643882058*std::sin(0.423199862241745*x_31 + 5.21799993515015) - 0.000218071149216234*std::sin(0.263039946556091*x_32 + 5.23415994644165) - 0.000587121019701662*std::sin(0.294079929590225*x_32 - 4.36799955368042) + 0.432522077037984*std::sin(0.30991992354393*x_32 - 1.14351987838745) + 0.0274557009205991*std::sin(0.310159921646118*x_32 - 1.14815986156464) - 0.00260400010089693*std::sin(0.32847985625267*x_32 + 1.99999976158142) + 0.201383817605881*std::sin(0.241039976477623*x_33 + 1.99663984775543) - 0.00138495220571213*std::sin(0.245679974555969*x_36 + 1.78207981586456) + 0.00572894463794726*std::sin(0.317439913749695*x_4 - 1.14063990116119) - 0.000352284791361644*std::sin(0.530719876289368*x_44 + 5.1005597114563) - 1.02640574696973e-5*std::sin(0.635519862174988*x_45 - 1.40887975692749) - 0.00318113500322899*std::sin(0.338719844818115*x_5 + 2.01407980918884) - 0.0406658049354441*std::sin(0.339759826660156*x_5 + 2.00815987586975) + 0.0155084131008493*std::sin(0.351199835538864*x_5 + 2.00807976722717) - 0.00132677256498158*std::sin(0.210960000753403*x_56 - 1.01687979698181) - 0.0342949760741527*std::sin(0.217439994215965*x_56 - 7.39751958847046) - 0.000419185692942669*std::sin(0.247839972376823*x_56 - 7.42392015457153) - 0.000567208086837345*std::sin(0.274239957332611*x_57 - 7.45928001403809) + 0.00149688058531195*std::sin(0.299679934978485*x_6 + 5.21031999588013) - 0.00922280138531595*std::sin(0.314479917287827*x_6 + 2.01639986038208) + 0.016677059137585*std::sin(0.352959841489792*x_6 + 2.014399766922) + 3.00073269038848e-5*std::sin(0.573599874973297*x_6 - 7.57480001449585) + 0.0260345576733362*std::sin(0.444079846143723*x_60 + 5.10624027252197) + 0.000327198901880067*std::sin(0.334399849176407*x_7 - 1.14743983745575) + 0.000741088511989446*std::sin(0.339119851589203*x_7 - 1.15287983417511) + 0.0018164965446644*std::sin(0.340719848871231*x_7 - 1.14399981498718) - 0.283115301304322*std::sin(0.344799846410751*x_7 + 2.02967977523804) + 0.00666798948377612*std::sin(0.345839858055115*x_7 - 1.14471983909607) + 0.00134060968878342*std::sin(0.346959829330444*x_7 - 7.36223983764648) - 0.00688104845973351*std::sin(0.348799854516983*x_7 + 2.01079988479614) + 0.000772697499416965*std::sin(0.349759846925735*x_7 - 1.15015983581543) + 0.000118059584016045*std::sin(0.266479969024658*x_8 - 7.40127992630005) + 0.000438727585691564*std::sin(0.313199937343597*x_8 - 7.42335987091064) - 0.000812429707545612*std::sin(0.326239854097366*x_8 + 8.24759960174561) + 0.000144294789210996*std::sin(0.334319829940796*x_8 - 7.55656003952026) + 0.00217494491038327*std::sin(0.363439828157425*x_8 + 5.01847982406616) - 0.0114263756645814*std::sin(0.405199855566025*x_8 + 4.79080009460449) + 0.000730428739154651*std::sin(0.206080004572868*x_9 - 7.41024017333984) + 0.0528266341207828*std::sin(0.404639840126038*x_9 - 4.38887977600098) + 0.0595279392413413*std::sin(0.339599847793579*x_91 + 2.00343990325928) - 0.00277706345018902*std::sin(0.358399868011475*x_91 + 1.99927973747253) + 0.00127474821065733*std::sin(0.377519845962524*x_91 + 1.9975198507309) - 0.000132273346073642*std::sin(0.379759848117828*x_91 + 1.99135982990265) - 0.000616485017616292*std::sin(0.215199992060661*x_92 + 1.98735988140106) - 0.000153104175664789*std::sin(0.255759954452515*x_92 + 1.99335980415344) + 0.00694442699789458*std::sin(0.292079925537109*x_92 + 2.01063990592957) - 0.000810564859967373*std::sin(0.293359935283661*x_92 + 1.99031984806061) + 0.000483161294612093*std::sin(0.293599933385849*x_92 - 7.38927984237671) + 0.012546119005697*std::sin(0.309599906206131*x_92 - 4.39079999923706) - 0.0045864459398669*std::sin(0.225439995527267*x_93 - 1.1833598613739) - 0.00322665559285904*std::sin(0.281519949436188*x_94 - 7.42119979858398) - 0.00167138115270499*std::sin(0.310239940881729*x_97 - 1.41639983654022) + 0.0881378427147865*std::sin(0.00626532534295091*x_10 - 0.00111883117928532*x_100 + 0.0032815652003805*x_101 + 0.000654536031666484*x_102 - 0.00133966933222385*x_103 - 0.00243927455615303*x_104 - 0.00621376260579643*x_105 + 0.00131054277176655*x_106 + 0.00162162043438298*x_107 + 0.0017868487648562*x_108 + 0.00286297082045712*x_109 + 0.00501706526890752*x_11 + 0.000524543155357617*x_110 + 0.00191343471506144*x_111 - 0.00157467043606331*x_112 + 0.00198454197768501*x_113 + 0.00125961577031101*x_114 + 0.00182236858207013*x_115 + 0.000641357926947705*x_116 + 0.00156493051920374*x_117 + 0.00169216378829387*x_118 + 0.00261020961525451*x_119 + 0.00145624490298598*x_12 + 0.00463607668470424*x_120 + 0.000279520323434051*x_13 + 0.000621746982336712*x_14 + 0.00213110410705038*x_15 + 0.0012895647878206*x_16 + 0.00399257580860963*x_17 - 0.000611332145833188*x_18 + 0.00396173879533317*x_19 - 0.00233699313352653*x_2 + 0.00137210313364727*x_21 + 0.00243415223657793*x_22 + 0.000429313175474187*x_23 + 0.00038367403214659*x_24 + 0.00207779079086265*x_25 + 0.00297530015983633*x_26 - 0.00603645603929406*x_27 - 4.3331142957082e-5*x_28 - 0.000194562656261067*x_29 - 0.0067704542569925*x_3 - 0.00255881696775192*x_30 + 0.000211851113496963*x_31 + 0.000745300367700773*x_32 + 0.00378255821240423*x_33 - 0.000552770194652976*x_34 + 0.00211096190919685*x_35 - 0.00270951222564066*x_36 + 0.00234449373291046*x_37 + 0.00264062303481195*x_38 - 0.00100517526144212*x_39 + 0.000354291604060579*x_4 - 0.00361444779363005*x_40 - 0.0019678366290197*x_41 + 0.000972284344792702*x_42 - 0.000423474997315418*x_43 + 0.000546208621647877*x_44 - 0.00921416916977306*x_45 + 0.00173431535914927*x_46 - 0.00324490510921521*x_47 - 0.00411428392042775*x_48 + 0.00201274512818555*x_49 + 0.00188549478397874*x_5 + 0.00203409935003312*x_50 + 0.00110830770755634*x_51 - 0.00353782536279624*x_52 + 0.00022034024291491*x_53 - 0.000501305685687243*x_54 - 0.001418056424883*x_55 + 2.8718792043787e-5*x_56 - 0.000383672867023277*x_57 + 0.00908739451429666*x_58 - 0.00617144870329091*x_59 + 0.00300247231041099*x_6 + 0.00491843030304014*x_60 + 0.002980734711898*x_61 + 0.000766036558896158*x_62 + 0.00378108852240136*x_63 + 0.00250915531462324*x_64 + 0.000653381868867835*x_65 + 0.00235279275695643*x_66 + 0.00197173693198949*x_67 + 0.00133059609079033*x_68 + 0.00228205865195983*x_69 + 0.00245671844138054*x_7 + 0.00104838265544073*x_70 + 0.00159090078983806*x_71 + 0.00392005032675031*x_73 - 0.000819222105647282*x_74 + 0.00368640495806343*x_75 + 0.00311621125473028*x_76 + 0.00430769823157638*x_77 + 0.00468893213043653*x_78 + 0.00562223232894006*x_79 + 0.00250841793937241*x_8 + 0.000859433062716065*x_80 + 0.00315676588058121*x_81 + 0.0078310340488557*x_82 + 0.00181700157022501*x_83 - 0.000116496870856053*x_84 + 0.00115016557611478*x_85 + 0.00473406003563668*x_86 + 0.00242791264853482*x_87 + 0.00203524238512561*x_88 + 0.00248377572909634*x_89 - 0.00124380898118402*x_9 + 0.00272208460593517*x_90 + 0.00582833840163023*x_92 + 0.00639795241162784*x_93 + 0.00296326935509439*x_94 - 0.000791461470503552*x_95 - 0.00400643741104761*x_96 + 0.000492554165690262*x_97 + 0.00206928037496532*x_98 + 0.0026896261962638*x_99 + 0.305114313974933*std::sin(0.246879979968071*x_1 - 7.55592012405396) - 0.0426383776766082*std::sin(0.311919927597046*x_20 + 8.18335914611816) - 0.00774491604347971*std::sin(0.97055983543396*x_72 + 8.38920021057129) + 0.028974101933908*std::sin(0.424319863319397*x_91 + 5.00743961334229) + 8.24744286773383) + 0.648879107507235);
}

int predict(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120)
{
    float s0 = score_0(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s1 = score_1(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s2 = score_2(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s3 = score_3(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s4 = score_4(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s5 = score_5(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s6 = score_6(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s7 = score_7(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s8 = score_8(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s9 = score_9(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s10 = score_10(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s11 = score_11(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);

    float max_score = s0;
    int max_index = 0;

    if(s1 > max_score) {
        max_score = s1;
        max_index = 1;
    }

    if(s2 > max_score) {
        max_score = s2;
        max_index = 2;
    }

    if(s3 > max_score) {
        max_score = s3;
        max_index = 3;
    }

    if(s4 > max_score) {
        max_score = s4;
        max_index = 4;
    }

    if(s5 > max_score) {
        max_score = s5;
        max_index = 5;
    }

    if(s6 > max_score) {
        max_score = s6;
        max_index = 6;
    }

    if(s7 > max_score) {
        max_score = s7;
        max_index = 7;
    }

    if(s8 > max_score) {
        max_score = s8;
        max_index = 8;
    }

    if(s9 > max_score) {
        max_score = s9;
        max_index = 9;
    }

    if(s10 > max_score) {
        max_score = s10;
        max_index = 10;
    }

    if(s11 > max_score) {
        max_score = s11;
        max_index = 11;
    }

    return max_index;
}

#endif
