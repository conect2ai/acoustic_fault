
#ifndef KAN_MODEL_H
#define KAN_MODEL_H

#include <cmath>


inline float score_0(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-1137.65944138889*x_1 - 90.1775338755276*x_10 - 118.129946386189*x_100 + 1097.38829728489*x_101 - 140.637205905428*x_102 + 31.0979608247939*x_103 - 502.797177385575*x_104 - 546.690460003779*x_105 - 422.735061662391*x_106 + 83.9142976186611*x_107 + 199.05763671913*x_108 + 206.595257775392*x_109 - 681.701344203463*x_11 - 372.900496567095*x_110 - 408.311648130406*x_111 + 276.909424351954*x_112 + 1318.93186581673*x_113 + 145.207377536765*x_114 - 523.133336255923*x_115 - 150.654607443026*x_116 - 269.695946809027*x_117 + 33.9695477285484*x_118 - 460.750399012042*x_119 - 2368.000628052*x_12 + 246.05615580408*x_120 + 849.677056800987*x_13 + 131.741193078588*x_14 + 391.887613743757*x_15 - 602.596752240631*x_16 + 125.071432627333*x_17 - 277.541049453004*x_18 + 201.797906368663*x_19 + 98.9122279206733*x_2 + 2144.67886233302*x_20 + 1079.8634887764*x_21 + 1576.36885804496*x_22 + 25.4305163895927*x_23 - 746.85648198948*x_24 + 1308.36227500872*x_25 + 53.2814349366576*x_26 + 37.0419953094124*x_27 - 376.84504527577*x_28 + 232.137802273687*x_29 + 232.183400895689*x_3 + 445.86225797288*x_30 - 35817.601609822*x_31 - 468.386449639808*x_32 - 389.918024341255*x_33 + 420.060036639751*x_34 + 12.0874193798832*x_35 - 14.4180279648175*x_36 + 6226.26411809686*x_37 - 350.136712008451*x_38 + 268.023441260067*x_39 - 316.405902177411*x_4 + 259.383100763472*x_40 + 8.20083033202965*x_41 + 404255.954741684*x_42 - 198.780803038778*x_43 + 892.257232408369*x_44 + 47.6424826980776*x_45 + 308.481377706444*x_46 + 248.425931527174*x_47 - 590.03161171289*x_48 + 161.581708871701*x_49 - 24.3227797275699*x_5 - 1840.81824359089*x_50 + 877.215704680999*x_51 + 1031.56131089741*x_52 - 319.446825482636*x_53 - 598.459847442764*x_54 - 12.8715602964856*x_55 - 152.56146548672*x_56 + 2298.3745569438*x_57 - 461.425081568395*x_58 - 113.338482010835*x_59 + 35.5395280936154*x_6 + 17.2344467584631*x_60 + 260.944625556865*x_61 - 574.321248220355*x_62 - 274.418094954264*x_63 - 351.81219367457*x_64 - 19.3102869000303*x_65 - 705.326049772286*x_66 - 307.332661036837*x_67 + 13.9140433080277*x_68 - 54.6066697961177*x_69 - 18.3785675763792*x_7 - 18521.0028017863*x_70 + 808.566882709581*x_72 - 115.376509499836*x_73 + 186.499250370113*x_74 - 594.182482667954*x_75 + 1469.61084147369*x_76 - 223.259206535895*x_77 + 76.5397191004331*x_78 + 258.043896159779*x_79 + 1311.12855030739*x_8 - 37.4429485727993*x_80 - 279.505108918468*x_81 - 206.248975820482*x_82 + 378.20735281116*x_83 - 5.80312381770895*x_84 - 273.755439818729*x_85 + 172.450989315583*x_86 + 237.892917216097*x_87 + 541.443265333258*x_88 + 314.380627552879*x_89 - 566.350863018567*x_9 - 1262.4537948621*x_90 - 179.756803848637*x_91 + 342.834657442428*x_92 + 62.9711945204277*x_93 + 304.81304412202*x_94 - 25.1951607282419*x_95 + 127.096802219751*x_96 + 136.73238832938*x_97 + 366.235289558504*x_98 - 156.565818896412*x_99 - 0.00171495248449893*std::pow(-6.10439968109131*x_115 - 9.13776016235352, 2) - 0.00104214318891888*std::pow(-3.79663991928101*x_15 - 5.39775991439819, 2) + 0.203497830170071*std::pow(-5.44127988815308*x_23 - 7.45175981521606, 2) + 0.000225094571765872*std::pow(-5.54735994338989*x_77 - 8.12199974060059, 2) + 4.25844914765886*std::pow(-4.89847993850708*x_85 - 6.53056001663208, 2) - 179.064342238907*std::exp(0.736559867858887*x_108) + 4.94869195192578*std::exp(2.52023983001709*x_71) - 4.90464553971973e-5*std::exp(2.53288006782532*x_71) + 0.00232880057607054*std::exp(2.54391980171204*x_71) - 0.00295817060482209*std::exp(2.55216002464294*x_71) + 0.0450594931801742*std::exp(2.5849597454071*x_71) + 0.0228030703610773*std::exp(2.58639979362488*x_71) - 2.67315555399748*std::exp(2.59751987457275*x_71) + 2.1141214591424*std::exp(2.60303997993469*x_71) - 0.041449688736905*std::exp(2.60527992248535*x_71) - 18.6932564615974*std::exp(2.61863994598389*x_71) + 0.282840946035479*std::exp(2.62951993942261*x_71) - 1.04521609587315*std::exp(2.63624000549316*x_71) - 5.2045480614588*std::exp(2.65231990814209*x_71) + 16.3121667579033*std::exp(2.67671990394592*x_71) + 1.91452210599829*std::exp(2.68367981910706*x_71) - 0.0832532106439142*std::exp(1.35743987560272*x_76) - 347.984533680845*std::sin(0.317119836807251*x_103 + 1.93383991718292) - 13.2345269728788*std::sin(0.500719845294952*x_103 + 5.25192022323608) + 20.2605008578355*std::sin(0.511439859867096*x_103 - 1.02791976928711) + 2.12920548120625*std::sin(0.364719837903976*x_105 + 5.15799999237061) + 8.71436333535445*std::sin(0.409359842538834*x_105 + 5.19928026199341) + 13.4781542089801*std::sin(0.178240016102791*x_106 - 7.61064004898071) + 0.0993453605859539*std::sin(0.413999855518341*x_106 + 2.01239991188049) + 12.3672150833002*std::sin(0.521679878234863*x_106 - 7.24088001251221) + 5.91476012212447*std::sin(0.608319878578186*x_106 - 0.998319804668427) - 292.215329095581*std::sin(0.318959832191467*x_112 + 1.93887984752655) - 228.863460987122*std::sin(0.291759938001633*x_115 - 7.5033597946167) + 18.5149567763974*std::sin(0.424159854650497*x_115 - 4.19056034088135) - 101.48420571627*std::sin(0.3713598549366*x_119 - 7.40855979919434) - 1161.25225611363*std::sin(0.335279852151871*x_16 - 4.25288009643555) + 0.129151479835015*std::sin(0.425439864397049*x_16 + 2.00127983093262) + 1.72160574832381*std::sin(0.413759857416153*x_21 - 1.167839884758) + 786.899875311044*std::sin(0.429599851369858*x_21 - 1.1561598777771) + 29.1715082030469*std::sin(0.298399925231934*x_28 + 5.13191986083984) - 0.344117484098885*std::sin(0.314399927854538*x_28 + 5.14447975158691) + 2790.71039592784*std::sin(0.328799843788147*x_28 - 4.27672004699707) + 30.1556347077273*std::sin(0.332959830760956*x_28 + 5.14264011383057) + 0.737786748173822*std::sin(0.340399831533432*x_28 + 5.14807987213135) + 221.159704624757*std::sin(0.343279838562012*x_28 + 5.15431976318359) + 0.0566661249049399*std::sin(0.359119862318039*x_28 + 5.16559982299805) - 2.28133096079427*std::sin(0.360319852828979*x_28 + 5.16567993164063) + 317.796906065048*std::sin(0.282959938049316*x_32 + 1.94863975048065) + 22.3381769841055*std::sin(0.314079910516739*x_34 - 1.11303985118866) + 154.473692360307*std::sin(0.349199831485748*x_34 + 2.00455975532532) + 0.00202958168782423*std::sin(0.354799836874008*x_34 + 1.97967982292175) + 0.0382515693109094*std::sin(0.31551992893219*x_36 - 7.47928047180176) - 11.6342574511773*std::sin(0.389759838581085*x_36 - 7.39135980606079) - 11.434571750884*std::sin(0.410719871520996*x_36 + 2.01095986366272) + 727.429664866187*std::sin(0.412559866905212*x_36 + 5.19296026229858) - 1.52156480357929*std::sin(0.422959864139557*x_45 + 5.2304801940918) + 0.00258678099948364*std::sin(0.519839882850647*x_47 + 2.12175989151001) - 25.2707787896973*std::sin(0.319039851427078*x_53 - 4.28480005264282) + 0.180216883296909*std::sin(0.344319850206375*x_53 + 5.14800024032593) + 185.0904561255*std::sin(0.510559856891632*x_53 + 2.09687995910645) + 88.7462195414471*std::sin(0.533279836177826*x_53 - 1.02551984786987) - 0.0865665774842534*std::sin(0.48295983672142*x_55 - 4.12296009063721) - 4.98977941005895*std::sin(0.32415983080864*x_56 + 8.32760047912598) - 0.00413491196510405*std::sin(0.431999862194061*x_59 + 2.02600002288818) + 0.0100900298429523*std::sin(0.198319986462593*x_6 + 4.98751974105835) + 0.791670241744776*std::sin(0.181840002536774*x_64 - 4.4115195274353) - 590.659560827002*std::sin(0.19463999569416*x_64 - 4.41431999206543) - 16.1438710029238*std::sin(0.197919994592667*x_64 - 4.38776016235352) + 3.79131920758983*std::sin(0.220159992575645*x_64 - 4.36287975311279) - 419.094280066563*std::sin(0.311039924621582*x_65 + 1.91295993328094) + 2.31092502663661*std::sin(0.168160021305084*x_67 + 4.94855976104736) + 18.8942964850099*std::sin(0.567279815673828*x_75 - 7.22448015213013) + 202.121886634891*std::sin(0.415999859571457*x_78 - 4.19112014770508) - 13.3161523523586*std::sin(0.141520038247108*x_80 + 4.9081597328186) + 18.6986053508853*std::sin(0.145120039582253*x_80 - 7.66784000396729) + 165.722052943825*std::sin(0.277919948101044*x_80 - 4.30703973770142) + 1538.38315672831*std::sin(0.31047984957695*x_80 - 4.29623985290527) - 1278.44535342511*std::sin(0.32983985543251*x_80 + 5.12744045257568) - 310.962848784169*std::sin(0.37271985411644*x_80 - 7.41304016113281) + 0.177767778315293*std::sin(0.482399851083755*x_80 - 7.30615949630737) + 0.22717669566061*std::sin(0.496399849653244*x_80 - 7.31647968292236) - 111.610481272273*std::sin(0.517439842224121*x_80 + 2.10879969596863) - 0.00132180613767732*std::sin(0.568239867687225*x_80 - 1.00951981544495) - 8.98283221992241*std::sin(0.710559844970703*x_80 - 7.24224042892456) + 1.52038420738519*std::sin(0.362319827079773*x_81 + 1.95999991893768) - 15.9259163048882*std::sin(0.535439848899841*x_81 + 2.15199971199036) - 1138.26578894824*std::sin(0.310879945755005*x_85 - 4.24671983718872) - 180.53486422581*std::sin(0.420799851417542*x_85 - 4.18016004562378) + 0.211850154186631*std::sin(0.708079874515533*x_87 + 5.34943962097168) + 0.14040235093319*std::sin(0.36167985200882*x_92 - 1.17719984054565) + 202.414852141188*std::sin(0.40871986746788*x_92 + 8.21111965179443) - 0.138381745835537*std::sin(0.410719871520996*x_93 - 4.38527965545654) - 23.8224975819796*std::sin(0.357999861240387*x_95 + 5.17431974411011) + 0.122646697743866*std::sin(0.368399828672409*x_95 + 5.18304014205933) - 0.00129671241590158*std::sin(0.395359843969345*x_95 + 1.99887979030609) + 167.77612957169*std::sin(0.408159852027893*x_95 + 1.98855984210968) - 14.1734921396619*std::sin(0.361279845237732*x_96 - 7.42191982269287) - 0.116817005037978*std::sin(0.368799835443497*x_96 + 5.18600034713745) - 264.298306349571*std::sin(0.373759835958481*x_96 + 5.1735200881958) - 3.08596196856877*std::sin(0.379359841346741*x_96 + 5.17080020904541) + 0.534773785442952*std::sin(0.443919867277145*x_96 - 7.36175966262817) - 29.5230689734774*std::sin(0.474479854106903*x_96 + 2.04111981391907) + 258.837823300012*std::sin(0.426079869270325*x_97 + 2.02439975738525) - 0.671632935132416*std::sin(0.44735985994339*x_99 + 2.00959992408752) + 8106.93850908001 + 0.00159466793280394*std::exp(-3.23736000061035*x_74) + 2.31440510441206*std::exp(-3.12712001800537*x_74) + 0.216167322170266*std::exp(-2.99327993392944*x_74) - 0.00214274557130325*std::exp(-2.77376008033752*x_74) - 0.271697719078008*std::exp(-3.92463994026184*x_45) - 0.216829467257905*std::exp(-3.88455986976624*x_45) + 0.0403825249683011*std::exp(-4.77167987823486*x_111) + 0.0397547987170922*std::exp(-4.69159984588623*x_111) - 2.61191316934137e-5*std::exp(-4.68919992446899*x_111) - 0.012841286572319*std::exp(-4.61607980728149*x_111));
}

inline float score_1(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (16601.9386693372*x_1 - 156.862008851546*x_10 + 341.809812507373*x_100 + 1507.31765484873*x_101 - 871.776236446373*x_102 + 87.7714297331545*x_103 - 1552.09660018339*x_104 - 56.6477184729048*x_105 - 1851.12960451034*x_106 - 298.543434521154*x_107 + 456.042415403353*x_108 + 1287.00172841217*x_109 - 27.1659585569876*x_11 - 952.202262920357*x_110 - 734.276850837098*x_111 + 437.399885240948*x_112 - 41.4863708300841*x_113 + 1127.84552264178*x_114 - 1740.71437506335*x_115 - 1963.15338577155*x_116 - 1405.94858639085*x_117 + 725.606748261312*x_118 - 1053.47635781955*x_119 + 1631.40391092057*x_12 + 1739.56965738346*x_120 + 2613.40562775831*x_13 - 44.1741874025103*x_14 + 1084.13971487056*x_15 - 1069.57183512475*x_16 - 489.245563395408*x_17 - 405.881923032293*x_18 + 341.617677828039*x_19 + 20.8016343541678*x_2 + 3596.48767244466*x_20 + 5505.46765569135*x_21 + 323.985916074268*x_22 + 337.470098041985*x_23 - 2315.71838010956*x_24 + 1969.95786713654*x_25 + 166.603912295089*x_26 - 1024.24820324434*x_27 - 182.112815419662*x_28 - 713.98302547523*x_29 - 1190.09788928994*x_3 - 2032.94100935791*x_30 - 7801.95712043768*x_31 - 1499.67101831499*x_32 + 10.5536901115737*x_33 + 847.202829660281*x_34 - 858.84082213637*x_35 - 20.8697344609524*x_36 + 4999.95529639976*x_37 - 1009.43088810217*x_38 + 1636.00835875534*x_39 - 1137.08515589362*x_4 + 751.873289253046*x_40 + 587.141483406512*x_41 + 852758.052561713*x_42 + 183.331793451665*x_43 + 3186.94032017866*x_44 - 1297.48269689115*x_45 + 65.1138186120637*x_46 + 3471.57833830741*x_47 + 288.1265346187*x_48 - 2479.65666061023*x_49 - 340.847828335045*x_5 + 332.893403836133*x_50 + 3106.23919648164*x_51 + 3362.13469007297*x_52 - 223.440434819462*x_53 - 2207.97909699114*x_54 - 1050.54355949969*x_55 + 308.844698503927*x_56 + 1580.53375892036*x_57 - 1663.15136711687*x_58 + 184.288637757459*x_59 - 255.446354044928*x_6 - 651.262420804267*x_60 + 748.286156121964*x_61 - 3040.85576322691*x_62 - 908.455242256485*x_63 - 536.968334349194*x_64 + 344.511510087961*x_65 - 82.8420549115366*x_66 - 1682.77543431671*x_67 - 1750.82565751515*x_68 - 1281.29012151764*x_69 + 180.320708026638*x_7 - 36875.2650662034*x_70 + 412.937777433656*x_72 - 369.3974097833*x_73 + 455.498592813326*x_74 - 510.752154920921*x_75 + 5124.63588536328*x_76 + 568.00443340507*x_77 - 515.616442522957*x_78 - 285.991102374318*x_79 + 10023.0544026158*x_8 - 645.921722361458*x_80 - 2144.41972232052*x_81 - 420.528890398549*x_82 - 47.4728954925122*x_83 - 4702.26062641136*x_84 + 172.763393778007*x_85 - 592.321419210919*x_86 + 28.8755758483211*x_87 - 588.395420892363*x_88 + 2584.00283580057*x_89 - 7178.4297416989*x_9 - 1110.3552171852*x_90 + 1408.46253831852*x_91 + 1272.83219433798*x_92 - 171.582041166002*x_93 + 1698.65361541423*x_94 - 44.0027985292181*x_95 + 361.691310997498*x_96 - 534.149534469056*x_97 + 1305.42453473141*x_98 - 957.549960484417*x_99 - 0.00121305127097404*std::pow(-6.10439968109131*x_115 - 9.13776016235352, 2) + 0.00227651242892207*std::pow(-3.79663991928101*x_15 - 5.39775991439819, 2) + 5.08447083655088*std::pow(-5.44127988815308*x_23 - 7.45175981521606, 2) - 0.00015432453286952*std::pow(-5.54735994338989*x_77 - 8.12199974060059, 2) + 3.64664761176033*std::pow(-4.89847993850708*x_85 - 6.53056001663208, 2) + 4.88261654816441*std::exp(0.736559867858887*x_108) - 0.134937893910801*std::exp(2.52023983001709*x_71) + 0.000177694625281855*std::exp(2.53288006782532*x_71) - 0.00159662251394568*std::exp(2.54391980171204*x_71) + 0.00646198355500031*std::exp(2.55216002464294*x_71) + 0.0318722973176873*std::exp(2.5849597454071*x_71) - 0.0139342370061764*std::exp(2.58639979362488*x_71) - 66.789810213235*std::exp(2.59751987457275*x_71) + 0.832833640814971*std::exp(2.60303997993469*x_71) + 0.0656326487756072*std::exp(2.60527992248535*x_71) - 35.1858252423735*std::exp(2.61863994598389*x_71) - 0.00141035499928831*std::exp(2.62951993942261*x_71) + 0.600145982822565*std::exp(2.63624000549316*x_71) - 1.76533705512694*std::exp(2.65231990814209*x_71) + 13.9686355026799*std::exp(2.67671990394592*x_71) + 1.0488932841936*std::exp(2.68367981910706*x_71) - 0.058888169728957*std::exp(1.35743987560272*x_76) - 8694.52618532752*std::sin(0.317119836807251*x_103 + 1.93383991718292) + 0.0659925005238608*std::sin(0.500719845294952*x_103 + 5.25192022323608) - 11.6332481367362*std::sin(0.511439859867096*x_103 - 1.02791976928711) + 1.50606820800448*std::sin(0.364719837903976*x_105 + 5.15799999237061) - 0.0434532060081931*std::sin(0.409359842538834*x_105 + 5.19928026199341) - 21.3417033588926*std::sin(0.178240016102791*x_106 - 7.61064004898071) - 0.0681110443708434*std::sin(0.413999855518341*x_106 + 2.01239991188049) - 7.10105257683094*std::sin(0.521679878234863*x_106 - 7.24088001251221) - 0.029493295170859*std::sin(0.608319878578186*x_106 - 0.998319804668427) - 7301.11135601737*std::sin(0.318959832191467*x_112 + 1.93887984752655) - 77.6284786833003*std::sin(0.291759938001633*x_115 - 7.5033597946167) - 10.6309852817621*std::sin(0.424159854650497*x_115 - 4.19056034088135) - 39.9785263833337*std::sin(0.3713598549366*x_119 - 7.40855979919434) - 994.417831368521*std::sin(0.335279852151871*x_16 - 4.25288009643555) - 0.0885460792705255*std::sin(0.425439864397049*x_16 + 2.00127983093262) + 1.21775737811802*std::sin(0.413759857416153*x_21 - 1.167839884758) - 21.4567026852061*std::sin(0.429599851369858*x_21 - 1.1561598777771) - 16.7498027728983*std::sin(0.298399925231934*x_28 + 5.13191986083984) + 0.751708342855639*std::sin(0.314399927854538*x_28 + 5.14447975158691) + 2389.7754904552*std::sin(0.328799843788147*x_28 - 4.27672004699707) - 0.150367727031362*std::sin(0.332959830760956*x_28 + 5.14264011383057) - 0.450838209341233*std::sin(0.340399831533432*x_28 + 5.14807987213135) + 121.16492579969*std::sin(0.343279838562012*x_28 + 5.15431976318359) - 0.038850218318799*std::sin(0.359119862318039*x_28 + 5.16559982299805) + 3.61232612966321*std::sin(0.360319852828979*x_28 + 5.16567993164063) + 174.108744665198*std::sin(0.282959938049316*x_32 + 1.94863975048065) - 12.8262157782704*std::sin(0.314079910516739*x_34 - 1.11303985118866) + 60.8531203645953*std::sin(0.349199831485748*x_34 + 2.00455975532532) - 0.00735314620753309*std::sin(0.354799836874008*x_34 + 1.97967982292175) - 0.0262252239986142*std::sin(0.31551992893219*x_36 - 7.47928047180176) + 6.68020029543718*std::sin(0.389759838581085*x_36 - 7.39135980606079) + 0.057017223494781*std::sin(0.410719871520996*x_36 + 2.01095986366272) - 19.8351054983499*std::sin(0.412559866905212*x_36 + 5.19296026229858) - 1.07626079179127*std::sin(0.422959864139557*x_45 + 5.2304801940918) - 0.00937187155864753*std::sin(0.519839882850647*x_47 + 2.12175989151001) + 0.126009934917584*std::sin(0.319039851427078*x_53 - 4.28480005264282) - 0.123556450570137*std::sin(0.344319850206375*x_53 + 5.14800024032593) + 4624.55558129295*std::sin(0.510559856891632*x_53 + 2.09687995910645) + 48.6206523199467*std::sin(0.533279836177826*x_53 - 1.02551984786987) + 0.0593499280216581*std::sin(0.48295983672142*x_55 - 4.12296009063721) + 7.90096257578336*std::sin(0.32415983080864*x_56 + 8.32760047912598) + 0.0149807285004047*std::sin(0.431999862194061*x_59 + 2.02600002288818) - 0.0365560376892922*std::sin(0.198319986462593*x_6 + 4.98751974105835) - 1.72936614095168*std::sin(0.181840002536774*x_64 - 4.4115195274353) - 14757.8542181259*std::sin(0.19463999569416*x_64 - 4.41431999206543) + 0.0804996217696965*std::sin(0.197919994592667*x_64 - 4.38776016235352) + 2.68174461100529*std::sin(0.220159992575645*x_64 - 4.36287975311279) - 788.850146511087*std::sin(0.311039924621582*x_65 + 1.91295993328094) - 1.41213338882746*std::sin(0.168160021305084*x_67 + 4.94855976104736) + 7.44318906759105*std::sin(0.567279815673828*x_75 - 7.22448015213013) + 5050.09236297444*std::sin(0.415999859571457*x_78 - 4.19112014770508) - 9.41902220703923*std::sin(0.141520038247108*x_80 + 4.9081597328186) - 29.6079182977233*std::sin(0.145120039582253*x_80 - 7.66784000396729) + 65.2842816195266*std::sin(0.277919948101044*x_80 - 4.30703973770142) + 1317.36720809258*std::sin(0.31047984957695*x_80 - 4.29623985290527) + 34.8598629995752*std::sin(0.32983985543251*x_80 + 5.12744045257568) - 105.475870958267*std::sin(0.37271985411644*x_80 - 7.41304016113281) - 0.388325290708326*std::sin(0.482399851083755*x_80 - 7.30615949630737) - 0.138820512741925*std::sin(0.496399849653244*x_80 - 7.31647968292236) - 61.1471050061656*std::sin(0.517439842224121*x_80 + 2.10879969596863) + 0.00478888524007892*std::sin(0.568239867687225*x_80 - 1.00951981544495) + 5.1577953041873*std::sin(0.710559844970703*x_80 - 7.24224042892456) + 1.07542571109562*std::sin(0.362319827079773*x_81 + 1.95999991893768) + 9.14440059896186*std::sin(0.535439848899841*x_81 + 2.15199971199036) + 31.0375326982356*std::sin(0.310879945755005*x_85 - 4.24671983718872) - 61.2358425355387*std::sin(0.420799851417542*x_85 - 4.18016004562378) - 0.335449726801195*std::sin(0.708079874515533*x_87 + 5.34943962097168) - 0.306702284626421*std::sin(0.36167985200882*x_92 - 1.17719984054565) + 110.895339555887*std::sin(0.40871986746788*x_92 + 8.21111965179443) + 0.0948743371117386*std::sin(0.410719871520996*x_93 - 4.38527965545654) + 0.118788241346301*std::sin(0.357999861240387*x_95 + 5.17431974411011) - 0.0840864094981297*std::sin(0.368399828672409*x_95 + 5.18304014205933) + 0.00469797103533656*std::sin(0.395359843969345*x_95 + 1.99887979030609) + 4191.95053413448*std::sin(0.408159852027893*x_95 + 1.98855984210968) + 8.13818731243264*std::sin(0.361279845237732*x_96 - 7.42191982269287) + 0.0800895800919331*std::sin(0.368799835443497*x_96 + 5.18600034713745) - 6603.59390397974*std::sin(0.373759835958481*x_96 + 5.1735200881958) + 4.88640238780908*std::sin(0.379359841346741*x_96 + 5.17080020904541) - 0.326783391580966*std::sin(0.443919867277145*x_96 - 7.36175966262817) - 11.6302707750702*std::sin(0.474479854106903*x_96 + 2.04111981391907) - 7.05783085305356*std::sin(0.426079869270325*x_97 + 2.02439975738525) + 0.410413700922636*std::sin(0.44735985994339*x_99 + 2.00959992408752) + 1287292.27774424 + 0.00112796942198346*std::exp(-3.23736000061035*x_74) + 4.35634388856724*std::exp(-3.12712001800537*x_74) + 0.11842979079538*std::exp(-2.99327993392944*x_74) + 0.00130936422866275*std::exp(-2.77376008033752*x_74) - 0.232663536428806*std::exp(-3.92463994026184*x_45) + 0.00591237279139929*std::exp(-3.88455986976624*x_45) + 0.0345808610426792*std::exp(-4.77167987823486*x_111) - 0.0010840094440804*std::exp(-4.69159984588623*x_111) + 1.59605774857753e-5*std::exp(-4.68919992446899*x_111) - 0.320844438617267*std::exp(-4.61607980728149*x_111));
}

inline float score_2(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-693.655703646192*x_1 + 111.071187382833*x_10 - 86.247168503812*x_100 - 485.887515957611*x_101 + 141.0086603168*x_102 - 63.8705614610398*x_103 + 9.03714105506246*x_104 + 247.311111909212*x_105 + 119.673909534476*x_106 - 13.9937026842133*x_107 - 13.3036629488189*x_108 + 140.316131761506*x_109 + 232.446401146995*x_11 - 39.0400018930369*x_110 + 105.192801429259*x_111 - 109.602072892716*x_112 - 527.856469138118*x_113 - 148.916187774304*x_114 + 90.9874949153411*x_115 + 91.197182422359*x_116 + 17.8619715035452*x_117 - 109.174843565912*x_118 + 43.9142796580587*x_119 + 1019.96330629788*x_12 - 10.06093989825*x_120 - 90.5118585867552*x_13 - 7.74446349748708*x_14 - 115.296396798814*x_15 + 234.279992002984*x_16 - 85.1343646980916*x_17 + 142.102550480998*x_18 - 142.281350645945*x_19 - 41.9313684318464*x_2 - 601.372371805464*x_20 + 342.20773345798*x_21 - 649.221235287645*x_22 + 64.6858052657608*x_23 + 224.437341677549*x_24 - 479.470648116281*x_25 + 23.7262459233745*x_26 + 69.9957430995218*x_27 + 102.002353100257*x_28 - 56.8586788853516*x_29 - 151.911955962512*x_3 - 777.516255520768*x_30 + 15801.0876945752*x_31 + 49.3769910036029*x_32 + 58.3374339290139*x_33 - 77.5869198524175*x_34 + 24.8280434144011*x_35 + 17.3240170781724*x_36 - 1261.80006112765*x_37 + 93.3682917885753*x_38 - 42.670749761131*x_39 + 139.154357545821*x_4 - 145.203407499368*x_40 + 246.962758662034*x_41 - 38704.8425221537*x_42 + 123.905878173*x_43 - 455.09863863053*x_44 + 25.6840085173642*x_45 - 134.47780130349*x_46 - 59.7450906992202*x_47 + 477.352821180662*x_48 - 228.4970109976*x_49 + 45.695556905646*x_5 + 487.48892544729*x_50 - 414.150707027492*x_51 - 250.989195716608*x_52 + 76.9212758700512*x_53 + 359.989812643048*x_54 - 56.7664051534072*x_55 + 35.3210443227758*x_56 + 605.765273332301*x_57 + 200.691658495313*x_58 + 103.11603453062*x_59 - 80.3452052061429*x_6 - 225.013249562106*x_60 - 44.5183142762681*x_61 + 115.133182873117*x_62 + 86.7799725198379*x_63 + 141.199850668952*x_64 + 96.4497519685344*x_65 + 209.170357459875*x_66 + 74.6776434089357*x_67 + 88.6093330210742*x_68 - 78.7797855879373*x_69 + 62.3005386171302*x_7 + 5087.9880630937*x_70 - 189.639306694543*x_72 + 184.560651697857*x_73 - 27.6739933129297*x_74 + 142.450101458093*x_75 - 612.686764507886*x_76 + 86.3392059066485*x_77 - 113.654062846275*x_78 - 84.4304023081591*x_79 - 501.942856937024*x_8 + 12.8923954167035*x_80 - 42.6747277179469*x_81 + 94.4911888548096*x_82 - 47.7380540996968*x_83 + 246.606872413117*x_84 + 134.674196894202*x_85 + 15.4520372017759*x_86 - 108.33681175641*x_87 + 18.9126962925467*x_88 + 39.0419579192826*x_89 + 226.801994929231*x_9 + 635.68011022794*x_90 + 28.3248145277933*x_91 - 199.425864102952*x_92 + 15.4550186914389*x_93 - 143.081949532106*x_94 + 15.1287633050654*x_95 - 141.16135023825*x_96 - 326.869916880098*x_97 - 287.570406812251*x_98 - 34.3792463502583*x_99 - 0.000825967192886051*std::pow(-6.10439968109131*x_115 - 9.13776016235352, 2) - 0.0132349229104661*std::pow(-3.79663991928101*x_15 - 5.39775991439819, 2) - 0.0769112096051426*std::pow(-5.44127988815308*x_23 - 7.45175981521606, 2) + 0.000121887118359676*std::pow(-5.54735994338989*x_77 - 8.12199974060059, 2) - 2.29919842750336*std::pow(-4.89847993850708*x_85 - 6.53056001663208, 2) + 39.3083971234952*std::exp(0.736559867858887*x_108) - 1.08634218323941*std::exp(2.52023983001709*x_71) + 0.000265762343262086*std::exp(2.53288006782532*x_71) + 0.00126102903870483*std::exp(2.54391980171204*x_71) - 0.0375679276390441*std::exp(2.55216002464294*x_71) + 0.0217018625479707*std::exp(2.5849597454071*x_71) - 0.00584170683729234*std::exp(2.58639979362488*x_71) + 1.01030869444076*std::exp(2.59751987457275*x_71) + 3.29174464041629*std::exp(2.60303997993469*x_71) - 0.216005873900843*std::exp(2.60527992248535*x_71) + 5.19785903178093*std::exp(2.61863994598389*x_71) - 0.0768348504528484*std::exp(2.62951993942261*x_71) + 1.51869947357228*std::exp(2.63624000549316*x_71) - 4.12568526471251*std::exp(2.65231990814209*x_71) - 8.80717530220192*std::exp(2.67671990394592*x_71) - 2.03274285193823*std::exp(2.68367981910706*x_71) - 0.0400969830452161*std::exp(1.35743987560272*x_76) + 131.51939451594*std::sin(0.317119836807251*x_103 + 1.93383991718292) + 3.59521107190675*std::sin(0.500719845294952*x_103 + 5.25192022323608) - 29.4385171722802*std::sin(0.511439859867096*x_103 - 1.02791976928711) + 1.02548256601019*std::sin(0.364719837903976*x_105 + 5.15799999237061) - 2.36729092109512*std::sin(0.409359842538834*x_105 + 5.19928026199341) + 70.2384159495246*std::sin(0.178240016102791*x_106 - 7.61064004898071) + 0.0537948100179855*std::sin(0.413999855518341*x_106 + 2.01239991188049) - 17.9695692696667*std::sin(0.521679878234863*x_106 - 7.24088001251221) - 1.60676774638881*std::sin(0.608319878578186*x_106 - 0.998319804668427) + 110.441641599436*std::sin(0.318959832191467*x_112 + 1.93887984752655) - 181.421825195139*std::sin(0.291759938001633*x_115 - 7.5033597946167) - 26.9022408098668*std::sin(0.424159854650497*x_115 - 4.19056034088135) - 158.01366984324*std::sin(0.3713598549366*x_119 - 7.40855979919434) + 626.976927189332*std::sin(0.335279852151871*x_16 - 4.25288009643555) + 0.0699346127517972*std::sin(0.425439864397049*x_16 + 2.00127983093262) + 0.829171583500155*std::sin(0.413759857416153*x_21 - 1.167839884758) - 172.74110751702*std::sin(0.429599851369858*x_21 - 1.1561598777771) - 42.3862149905635*std::sin(0.298399925231934*x_28 + 5.13191986083984) - 4.37019444412143*std::sin(0.314399927854538*x_28 + 5.14447975158691) - 1506.74499834337*std::sin(0.328799843788147*x_28 - 4.27672004699707) - 8.19189624259108*std::sin(0.332959830760956*x_28 + 5.14264011383057) - 0.189006735629223*std::sin(0.340399831533432*x_28 + 5.14807987213135) - 234.816201549332*std::sin(0.343279838562012*x_28 + 5.15431976318359) + 0.0306843057968393*std::sin(0.359119862318039*x_28 + 5.16559982299805) - 11.888651105953*std::sin(0.360319852828979*x_28 + 5.16567993164063) - 337.420700000207*std::sin(0.282959938049316*x_32 + 1.94863975048065) - 32.4573815503533*std::sin(0.314079910516739*x_34 - 1.11303985118866) + 240.519742474316*std::sin(0.349199831485748*x_34 + 2.00455975532532) - 0.0109974590585564*std::sin(0.354799836874008*x_34 + 1.97967982292175) + 0.0207129542017195*std::sin(0.31551992893219*x_36 - 7.47928047180176) + 16.9045814891963*std::sin(0.389759838581085*x_36 - 7.39135980606079) + 3.10624618813619*std::sin(0.410719871520996*x_36 + 2.01095986366272) - 159.686142916277*std::sin(0.412559866905212*x_36 + 5.19296026229858) - 0.732826489926803*std::sin(0.422959864139557*x_45 + 5.2304801940918) - 0.0140166903879439*std::sin(0.519839882850647*x_47 + 2.12175989151001) + 6.86490600582931*std::sin(0.319039851427078*x_53 - 4.28480005264282) + 0.0975861675050521*std::sin(0.344319850206375*x_53 + 5.14800024032593) - 69.9542145244627*std::sin(0.510559856891632*x_53 + 2.09687995910645) - 94.2262525171277*std::sin(0.533279836177826*x_53 - 1.02551984786987) - 0.0468751893616968*std::sin(0.48295983672142*x_55 - 4.12296009063721) - 26.0031304187471*std::sin(0.32415983080864*x_56 + 8.32760047912598) + 0.0224053682193573*std::sin(0.431999862194061*x_59 + 2.02600002288818) - 0.0546736752519858*std::sin(0.198319986462593*x_6 + 4.98751974105835) + 10.0539875243744*std::sin(0.181840002536774*x_64 - 4.4115195274353) + 223.237472606371*std::sin(0.19463999569416*x_64 - 4.41431999206543) + 4.38554576919048*std::sin(0.197919994592667*x_64 - 4.38776016235352) + 1.8260011933467*std::sin(0.220159992575645*x_64 - 4.36287975311279) + 116.533627690119*std::sin(0.311039924621582*x_65 + 1.91295993328094) - 0.592014422391815*std::sin(0.168160021305084*x_67 + 4.94855976104736) + 29.4189337703415*std::sin(0.567279815673828*x_75 - 7.22448015213013) - 76.3911771234663*std::sin(0.415999859571457*x_78 - 4.19112014770508) - 6.41341674357477*std::sin(0.141520038247108*x_80 + 4.9081597328186) + 97.4436410169903*std::sin(0.145120039582253*x_80 - 7.66784000396729) + 258.033745988232*std::sin(0.277919948101044*x_80 - 4.30703973770142) - 830.595367515876*std::sin(0.31047984957695*x_80 - 4.29623985290527) + 280.645699890787*std::sin(0.32983985543251*x_80 + 5.12744045257568) - 246.502641142346*std::sin(0.37271985411644*x_80 - 7.41304016113281) + 2.25760036335166*std::sin(0.482399851083755*x_80 - 7.30615949630737) - 0.0581982880068336*std::sin(0.496399849653244*x_80 - 7.31647968292236) + 118.502370537685*std::sin(0.517439842224121*x_80 + 2.10879969596863) + 0.00716231771781423*std::sin(0.568239867687225*x_80 - 1.00951981544495) + 13.0520593946536*std::sin(0.710559844970703*x_80 - 7.24224042892456) + 0.732257883080147*std::sin(0.362319827079773*x_81 + 1.95999991893768) + 23.1403638002579*std::sin(0.535439848899841*x_81 + 2.15199971199036) + 249.873331030752*std::sin(0.310879945755005*x_85 - 4.24671983718872) - 143.111374956643*std::sin(0.420799851417542*x_85 - 4.18016004562378) + 1.10401016474625*std::sin(0.708079874515533*x_87 + 5.34943962097168) + 1.78307003376061*std::sin(0.36167985200882*x_92 - 1.17719984054565) - 214.913864158068*std::sin(0.40871986746788*x_92 + 8.21111965179443) - 0.074932736498944*std::sin(0.410719871520996*x_93 - 4.38527965545654) + 6.47147474501498*std::sin(0.357999861240387*x_95 + 5.17431974411011) + 0.0664123192623189*std::sin(0.368399828672409*x_95 + 5.18304014205933) + 0.00702634527604897*std::sin(0.395359843969345*x_95 + 1.99887979030609) - 63.410332471081*std::sin(0.408159852027893*x_95 + 1.98855984210968) + 20.5940906728992*std::sin(0.361279845237732*x_96 - 7.42191982269287) - 0.0632555818995795*std::sin(0.368799835443497*x_96 + 5.18600034713745) + 99.8905119575359*std::sin(0.373759835958481*x_96 + 5.1735200881958) - 16.0818074190257*std::sin(0.379359841346741*x_96 + 5.17080020904541) - 0.136998729967486*std::sin(0.443919867277145*x_96 - 7.36175966262817) - 45.9682217603086*std::sin(0.474479854106903*x_96 + 2.04111981391907) - 56.8203575409961*std::sin(0.426079869270325*x_97 + 2.02439975738525) + 0.172059404597145*std::sin(0.44735985994339*x_99 + 2.00959992408752) - 266367.762316268 + 0.000768034921053985*std::exp(-3.23736000061035*x_74) - 0.643544986390248*std::exp(-3.12712001800537*x_74) - 0.229515542070544*std::exp(-2.99327993392944*x_74) + 0.000548930089512241*std::exp(-2.77376008033752*x_74) + 0.14669353720094*std::exp(-3.92463994026184*x_45) + 0.0475986380117937*std::exp(-3.88455986976624*x_45) - 0.0218031106363633*std::exp(-4.77167987823486*x_111) - 0.00872701619985925*std::exp(-4.69159984588623*x_111) + 6.69121779574009e-6*std::exp(-4.68919992446899*x_111) + 0.00485331407385485*std::exp(-4.61607980728149*x_111));
}

inline float score_3(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (632.900034521952*x_1 - 741.336027487562*x_10 - 449.795724738044*x_100 - 966.226062481572*x_101 - 1151.22142073109*x_102 - 46.1411281867014*x_103 - 467.162070468955*x_104 + 1121.29847827793*x_105 - 225.554224685281*x_106 - 558.336081530342*x_107 - 108.6931788313*x_108 + 1180.16781515841*x_109 + 1625.42374079403*x_11 - 123.511931262924*x_110 + 656.9609380699*x_111 - 384.905541722463*x_112 - 4200.4247480962*x_113 - 111.211006275162*x_114 - 615.932985213648*x_115 + 1009.02609238934*x_116 - 446.496006930381*x_117 + 826.236036488305*x_118 + 475.552173907635*x_119 + 2810.49697581139*x_12 - 294.310663202709*x_120 + 292.826996452758*x_13 - 569.459506022309*x_14 - 95.5184990063958*x_15 + 559.796635824813*x_16 - 555.359206392193*x_17 - 92.3148501507585*x_18 - 6.00109689957189*x_19 + 95.0715630638142*x_2 + 643.045947127446*x_20 + 2465.86633308956*x_21 - 3936.59188045255*x_22 - 169.82333070184*x_23 - 951.966534490221*x_24 - 676.816125418819*x_25 - 248.721299788848*x_26 - 831.997358716072*x_27 + 753.214164535085*x_28 - 1163.72670942225*x_29 + 181.571864837206*x_3 - 1126.46938342288*x_30 + 53476.2328875371*x_31 - 924.114113435823*x_32 + 1008.68935260965*x_33 - 433.541523642512*x_34 - 1119.76295732516*x_35 + 278.818738122784*x_36 - 4937.46473940845*x_37 - 270.445094534006*x_38 + 716.207359129106*x_39 + 223.733019738325*x_4 + 105.534538660657*x_40 - 379.954202662879*x_41 + 747842.680393599*x_42 - 1265.22592587135*x_43 - 484.753000455337*x_44 - 1872.95827140886*x_45 - 888.904115780292*x_46 + 2369.9511687631*x_47 + 4400.48007204685*x_48 - 658.312668236526*x_49 - 768.405075017924*x_5 + 2412.15074494295*x_50 + 512.384872908836*x_51 + 2790.61380751827*x_52 + 262.559806881667*x_53 - 20.1511216583004*x_54 - 1887.30181702413*x_55 - 89.9599075184187*x_56 + 3754.74746552204*x_57 + 124.830841543721*x_58 + 934.551735098176*x_59 + 280.301587439789*x_6 - 991.41078905965*x_60 + 103.295089422319*x_61 - 1441.54659172723*x_62 + 448.373089506283*x_63 + 557.411947603414*x_64 + 600.955500907118*x_65 + 1550.44606954081*x_66 - 1131.90317018931*x_67 - 2815.36565975781*x_68 - 586.16052652195*x_69 - 227.702401595385*x_7 + 31505.1296364082*x_70 - 1492.42273156535*x_72 + 679.915784118594*x_73 + 426.524625169692*x_74 + 1314.40335104058*x_75 + 2088.75166512956*x_76 + 1315.63251790089*x_77 + 288.506082618738*x_78 - 910.399429538943*x_79 + 3845.66923985698*x_8 - 611.931169180277*x_80 - 742.710577027667*x_81 + 322.905185024911*x_82 - 447.855657436676*x_83 + 248.692907298501*x_84 + 1336.90898631599*x_85 - 1156.28137557944*x_86 - 1199.39731511312*x_87 - 2093.11232954467*x_88 + 1573.15177251544*x_89 - 5268.25867255128*x_9 + 13.1438241052469*x_90 - 475.496779986506*x_91 + 740.192537431296*x_92 + 184.561051784845*x_93 + 650.964282018567*x_94 + 7.09237524520343*x_95 - 395.614038282496*x_96 - 2101.45160665952*x_97 - 72.576115919952*x_98 - 444.865247688783*x_99 + 0.00224742270457989*std::pow(-6.10439968109131*x_115 - 9.13776016235352, 2) - 0.00423995430103391*std::pow(-3.79663991928101*x_15 - 5.39775991439819, 2) + 5.18626250980485*std::pow(-5.44127988815308*x_23 - 7.45175981521606, 2) + 3.59407357932813e-5*std::pow(-5.54735994338989*x_77 - 8.12199974060059, 2) - 5.3819910528742*std::pow(-4.89847993850708*x_85 - 6.53056001663208, 2) + 56.7480031070451*std::exp(0.736559867858887*x_108) - 1.56830993123697*std::exp(2.52023983001709*x_71) + 0.000480911850834611*std::exp(2.53288006782532*x_71) + 0.00037183840357932*std::exp(2.54391980171204*x_71) - 0.0120353021662206*std::exp(2.55216002464294*x_71) - 0.0590498739442186*std::exp(2.5849597454071*x_71) - 0.0252134215937302*std::exp(2.58639979362488*x_71) - 68.1269496632338*std::exp(2.59751987457275*x_71) - 2.10991246281807*std::exp(2.60303997993469*x_71) - 0.061107454260928*std::exp(2.60527992248535*x_71) + 31.8794389594733*std::exp(2.61863994598389*x_71) + 0.0141730607937612*std::exp(2.62951993942261*x_71) + 2.9444275694512*std::exp(2.63624000549316*x_71) + 1.35854012292929*std::exp(2.65231990814209*x_71) - 20.6159408037765*std::exp(2.67671990394592*x_71) - 0.221389087652711*std::exp(2.68367981910706*x_71) + 0.109102238995836*std::exp(1.35743987560272*x_76) - 8868.59156931846*std::sin(0.317119836807251*x_103 + 1.93383991718292) - 0.663177513696178*std::sin(0.500719845294952*x_103 + 5.25192022323608) - 57.0748743080399*std::sin(0.511439859867096*x_103 - 1.02791976928711) - 2.79029581544179*std::sin(0.364719837903976*x_105 + 5.15799999237061) + 0.436673696160701*std::sin(0.409359842538834*x_105 + 5.19928026199341) + 19.8702503431267*std::sin(0.178240016102791*x_106 - 7.61064004898071) + 0.0158624231988227*std::sin(0.413999855518341*x_106 + 2.01239991188049) - 34.8390817864146*std::sin(0.521679878234863*x_106 - 7.24088001251221) + 0.29638655918252*std::sin(0.608319878578186*x_106 - 0.998319804668427) - 7447.28041970832*std::sin(0.318959832191467*x_112 + 1.93887984752655) + 59.7400947694041*std::sin(0.291759938001633*x_115 - 7.5033597946167) - 52.1575867372004*std::sin(0.424159854650497*x_115 - 4.19056034088135) + 101.28216119939*std::sin(0.3713598549366*x_119 - 7.40855979919434) + 1467.63505582061*std::sin(0.335279852151871*x_16 - 4.25288009643555) + 0.0206215511002622*std::sin(0.425439864397049*x_16 + 2.00127983093262) - 2.25614171943*std::sin(0.413759857416153*x_21 - 1.167839884758) - 249.379614113826*std::sin(0.429599851369858*x_21 - 1.1561598777771) - 82.1776409057013*std::sin(0.298399925231934*x_28 + 5.13191986083984) - 1.40004024617735*std::sin(0.314399927854538*x_28 + 5.14447975158691) - 3527.00663111214*std::sin(0.328799843788147*x_28 - 4.27672004699707) + 1.51108829884009*std::sin(0.332959830760956*x_28 + 5.14264011383057) - 0.815772965368994*std::sin(0.340399831533432*x_28 + 5.14807987213135) - 25.5741864139446*std::sin(0.343279838562012*x_28 + 5.15431976318359) + 0.00904785134381594*std::sin(0.359119862318039*x_28 + 5.16559982299805) - 3.36326596384434*std::sin(0.360319852828979*x_28 + 5.16567993164063) - 36.7489969805855*std::sin(0.282959938049316*x_32 + 1.94863975048065) - 62.9277949535737*std::sin(0.314079910516739*x_34 - 1.11303985118866) - 154.166151277207*std::sin(0.349199831485748*x_34 + 2.00455975532532) - 0.0199005183556519*std::sin(0.354799836874008*x_34 + 1.97967982292175) + 0.0061076086175536*std::sin(0.31551992893219*x_36 - 7.47928047180176) + 32.7743023902846*std::sin(0.389759838581085*x_36 - 7.39135980606079) - 0.572982387619277*std::sin(0.410719871520996*x_36 + 2.01095986366272) - 230.532669798141*std::sin(0.412559866905212*x_36 + 5.19296026229858) + 1.99399068893321*std::sin(0.422959864139557*x_45 + 5.2304801940918) - 0.0253639866141391*std::sin(0.519839882850647*x_47 + 2.12175989151001) - 1.26630987879366*std::sin(0.319039851427078*x_53 - 4.28480005264282) + 0.0287751380997311*std::sin(0.344319850206375*x_53 + 5.14800024032593) + 4717.13969983913*std::sin(0.510559856891632*x_53 + 2.09687995910645) - 10.2623231747243*std::sin(0.533279836177826*x_53 - 1.02551984786987) - 0.01382204140012*std::sin(0.48295983672142*x_55 - 4.12296009063721) - 7.35621246778667*std::sin(0.32415983080864*x_56 + 8.32760047912598) + 0.0405437691688928*std::sin(0.431999862194061*x_59 + 2.02600002288818) - 0.0989350787422634*std::sin(0.198319986462593*x_6 + 4.98751974105835) + 3.2209063804068*std::sin(0.181840002536774*x_64 - 4.4115195274353) - 15053.3081056184*std::sin(0.19463999569416*x_64 - 4.41431999206543) - 0.808963724588789*std::sin(0.197919994592667*x_64 - 4.38776016235352) - 4.96847402156263*std::sin(0.220159992575645*x_64 - 4.36287975311279) + 714.722474764822*std::sin(0.311039924621582*x_65 + 1.91295993328094) - 2.55519656105374*std::sin(0.168160021305084*x_67 + 4.94855976104736) - 18.8566799024279*std::sin(0.567279815673828*x_75 - 7.22448015213013) + 5151.19577535294*std::sin(0.415999859571457*x_78 - 4.19112014770508) + 17.4506427465712*std::sin(0.141520038247108*x_80 + 4.9081597328186) + 27.566532006428*std::sin(0.145120039582253*x_80 - 7.66784000396729) - 165.392117542675*std::sin(0.277919948101044*x_80 - 4.30703973770142) - 1944.26752517543*std::sin(0.31047984957695*x_80 - 4.29623985290527) + 405.157274649135*std::sin(0.32983985543251*x_80 + 5.12744045257568) + 81.170449734549*std::sin(0.37271985411644*x_80 - 7.41304016113281) + 0.723247308304231*std::sin(0.482399851083755*x_80 - 7.30615949630737) - 0.251189936848965*std::sin(0.496399849653244*x_80 - 7.31647968292236) + 12.9062717760912*std::sin(0.517439842224121*x_80 + 2.10879969596863) + 0.0129606152160646*std::sin(0.568239867687225*x_80 - 1.00951981544495) + 25.3051009686173*std::sin(0.710559844970703*x_80 - 7.24224042892456) - 1.99244353312828*std::sin(0.362319827079773*x_81 + 1.95999991893768) + 44.8641263964769*std::sin(0.535439848899841*x_81 + 2.15199971199036) + 360.732403337436*std::sin(0.310879945755005*x_85 - 4.24671983718872) + 47.1249095487474*std::sin(0.420799851417542*x_85 - 4.18016004562378) + 0.312321370838277*std::sin(0.708079874515533*x_87 + 5.34943962097168) + 0.571226255704857*std::sin(0.36167985200882*x_92 - 1.17719984054565) - 23.4065928528569*std::sin(0.40871986746788*x_92 + 8.21111965179443) - 0.0220953429781557*std::sin(0.410719871520996*x_93 - 4.38527965545654) - 1.19373701446421*std::sin(0.357999861240387*x_95 + 5.17431974411011) + 0.0195829358520277*std::sin(0.368399828672409*x_95 + 5.18304014205933) + 0.0127145654641351*std::sin(0.395359843969345*x_95 + 1.99887979030609) + 4275.87385138511*std::sin(0.408159852027893*x_95 + 1.98855984210968) + 39.9274572752897*std::sin(0.361279845237732*x_96 - 7.42191982269287) - 0.0186521117825948*std::sin(0.368799835443497*x_96 + 5.18600034713745) - 6735.79859048195*std::sin(0.373759835958481*x_96 + 5.1735200881958) - 4.54949809254853*std::sin(0.379359841346741*x_96 + 5.17080020904541) - 0.59130093869566*std::sin(0.443919867277145*x_96 - 7.36175966262817) + 29.464291608414*std::sin(0.474479854106903*x_96 + 2.04111981391907) - 82.0293388242118*std::sin(0.426079869270325*x_97 + 2.02439975738525) + 0.742626500799344*std::sin(0.44735985994339*x_99 + 2.00959992408752) + 2187275.74518958 - 0.00208979137955311*std::exp(-3.23736000061035*x_74) - 3.94698143713868*std::exp(-3.12712001800537*x_74) - 0.0249968836012216*std::exp(-2.99327993392944*x_74) + 0.0023692400453925*std::exp(-2.77376008033752*x_74) + 0.343381978382452*std::exp(-3.92463994026184*x_45) + 0.0687163012345237*std::exp(-3.88455986976624*x_45) - 0.0510369809608623*std::exp(-4.77167987823486*x_111) - 0.0125988536461802*std::exp(-4.69159984588623*x_111) + 2.88800003078659e-5*std::exp(-4.68919992446899*x_111) - 0.327267780064385*std::exp(-4.61607980728149*x_111));
}

inline float score_4(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (3644.99397188197*x_1 - 287.898392182817*x_10 + 64.2084297809179*x_100 - 37.5886670384792*x_101 - 580.733874864329*x_102 + 0.728685649545368*x_103 - 24.7052392087012*x_104 + 431.50069741657*x_105 - 328.598411896345*x_106 - 283.44572591226*x_107 + 45.3418740278155*x_108 + 115.978064412014*x_109 + 499.47908065472*x_11 + 166.485386754938*x_110 + 161.625011490913*x_111 - 154.050362204567*x_112 - 1266.86361989766*x_113 + 294.113785730959*x_114 - 143.544332483918*x_115 - 531.905584408061*x_116 - 173.179238989503*x_117 + 522.529800474267*x_118 + 175.402902643091*x_119 + 1348.99100758499*x_12 + 131.786073861242*x_120 + 121.166789990294*x_13 - 119.925402378505*x_14 + 201.051556449064*x_15 + 162.367002613288*x_16 - 90.8645929194407*x_17 - 89.53258724732*x_18 + 33.995312885861*x_19 - 1.76539454138581*x_2 + 205.177292281115*x_20 + 566.301080418844*x_21 - 1015.7249270737*x_22 - 115.328375391528*x_23 - 470.562636629451*x_24 - 44.4680173636887*x_25 - 41.995389588797*x_26 - 442.081401463747*x_27 + 302.696170558972*x_28 - 435.730572671512*x_29 - 117.2923117107*x_3 - 496.191118638395*x_30 + 6341.31902663067*x_31 - 285.687868336358*x_32 + 408.476572565278*x_33 - 123.655173355751*x_34 - 431.254817565106*x_35 + 93.6461050772598*x_36 - 3184.31889316488*x_37 + 31.8238773404407*x_38 + 201.187989447488*x_39 - 213.311651199515*x_4 + 122.683888932372*x_40 - 253.677159415107*x_41 + 64563.4315695317*x_42 - 263.514937270993*x_43 + 636.333172509119*x_44 - 717.261809019791*x_45 - 179.220195868644*x_46 + 1074.38723753094*x_47 + 1023.53310741819*x_48 - 561.252683066554*x_49 - 272.354263922519*x_5 + 1303.81648292655*x_50 + 831.112129193357*x_51 + 758.58785963171*x_52 + 188.593755080841*x_53 - 535.409274635925*x_54 - 594.541547188553*x_55 + 180.55022374647*x_56 - 814.97509234072*x_57 - 376.150691740551*x_58 + 258.271978782288*x_59 + 90.882049166252*x_6 - 71.3595075301471*x_60 + 65.4306795510992*x_61 - 676.823661009441*x_62 + 119.337316288842*x_63 + 67.9182926767245*x_64 + 85.1328400727936*x_65 + 579.705081539789*x_66 - 454.264196026493*x_67 - 1215.04511595839*x_68 - 231.53316016072*x_69 - 22.547217347817*x_7 + 6447.39867985356*x_70 - 500.431003931239*x_72 - 105.148179326694*x_73 + 62.3617146071364*x_74 + 361.221449666301*x_75 + 1232.2862819061*x_76 + 470.739117955787*x_77 - 8.28456812132525*x_78 - 354.12461233159*x_79 + 2697.52789024689*x_8 - 255.570118432342*x_80 - 560.300142336201*x_81 - 1.24948156865978*x_82 - 233.475885270814*x_83 - 1019.80037284929*x_84 + 430.031196770455*x_85 - 560.376024767976*x_86 - 240.989063526472*x_87 - 1039.37272340049*x_88 + 439.160219166437*x_89 - 2814.4223881116*x_9 + 218.34907380713*x_90 + 375.338632048811*x_91 + 506.747264573004*x_92 - 120.284573632873*x_93 + 407.712363495374*x_94 + 48.8335533516051*x_95 + 150.618506075936*x_96 - 467.784068967046*x_97 + 315.067090012002*x_98 - 54.7184978565154*x_99 + 0.00270348208968041*std::pow(-6.10439968109131*x_115 - 9.13776016235352, 2) + 0.00253625889697441*std::pow(-3.79663991928101*x_15 - 5.39775991439819, 2) + 2.1291856176527*std::pow(-5.44127988815308*x_23 - 7.45175981521606, 2) + 3.72053202719927e-5*std::pow(-5.54735994338989*x_77 - 8.12199974060059, 2) + 0.284314209563977*std::pow(-4.89847993850708*x_85 - 6.53056001663208, 2) + 123.970881046644*std::exp(0.736559867858887*x_108) - 3.42610758589869*std::exp(2.52023983001709*x_71) + 0.000913549899933242*std::exp(2.53288006782532*x_71) + 0.000384921638058987*std::exp(2.54391980171204*x_71) + 0.00719928565961409*std::exp(2.55216002464294*x_71) - 0.071032599377393*std::exp(2.5849597454071*x_71) + 0.000526419601909169*std::exp(2.58639979362488*x_71) - 27.9690665721749*std::exp(2.59751987457275*x_71) - 2.71867027596974*std::exp(2.60303997993469*x_71) + 0.101653760490524*std::exp(2.60527992248535*x_71) + 6.78356073218116*std::exp(2.61863994598389*x_71) + 0.0195903623706577*std::exp(2.62951993942261*x_71) - 2.45730831687834*std::exp(2.63624000549316*x_71) + 6.47440934032103*std::exp(2.65231990814209*x_71) + 1.08907741697438*std::exp(2.67671990394592*x_71) - 0.478198323195627*std::exp(2.68367981910706*x_71) + 0.131241865835119*std::exp(1.35743987560272*x_76) - 3640.94134890587*std::sin(0.317119836807251*x_103 + 1.93383991718292) - 0.916660698661422*std::sin(0.500719845294952*x_103 + 5.25192022323608) + 47.632539776848*std::sin(0.511439859867096*x_103 - 1.02791976928711) - 3.35651800018955*std::sin(0.364719837903976*x_105 + 5.15799999237061) + 0.603581404892319*std::sin(0.409359842538834*x_105 + 5.19928026199341) - 33.0546525574781*std::sin(0.178240016102791*x_106 - 7.61064004898071) + 0.0164205468356719*std::sin(0.413999855518341*x_106 + 2.01239991188049) + 29.0753850814261*std::sin(0.521679878234863*x_106 - 7.24088001251221) + 0.409672983180445*std::sin(0.608319878578186*x_106 - 0.998319804668427) - 3057.43149913678*std::sin(0.318959832191467*x_112 + 1.93887984752655) + 284.70401502218*std::sin(0.291759938001633*x_115 - 7.5033597946167) + 43.5287568311671*std::sin(0.424159854650497*x_115 - 4.19056034088135) + 130.50437209655*std::sin(0.3713598549366*x_119 - 7.40855979919434) - 77.5306938871964*std::sin(0.335279852151871*x_16 - 4.25288009643555) + 0.0213471259354113*std::sin(0.425439864397049*x_16 + 2.00127983093262) - 2.71397041501364*std::sin(0.413759857416153*x_21 - 1.167839884758) - 544.791160641299*std::sin(0.429599851369858*x_21 - 1.1561598777771) + 68.5823630216379*std::sin(0.298399925231934*x_28 + 5.13191986083984) + 0.837477076020292*std::sin(0.314399927854538*x_28 + 5.14447975158691) + 186.321027404167*std::sin(0.328799843788147*x_28 - 4.27672004699707) + 2.0886643879612*std::sin(0.332959830760956*x_28 + 5.14264011383057) + 0.0170321540089821*std::sin(0.340399831533432*x_28 + 5.14807987213135) - 55.2399993599727*std::sin(0.343279838562012*x_28 + 5.15431976318359) + 0.0093662024326998*std::sin(0.359119862318039*x_28 + 5.16559982299805) + 5.59487605709616*std::sin(0.360319852828979*x_28 + 5.16567993164063) - 79.377483874924*std::sin(0.282959938049316*x_32 + 1.94863975048065) + 52.5171668362868*std::sin(0.314079910516739*x_34 - 1.11303985118866) - 198.646598104926*std::sin(0.349199831485748*x_34 + 2.00455975532532) - 0.0378034280520937*std::sin(0.354799836874008*x_34 + 1.97967982292175) + 0.00632250647340792*std::sin(0.31551992893219*x_36 - 7.47928047180176) - 27.3521979888752*std::sin(0.389759838581085*x_36 - 7.39135980606079) - 0.791990718787248*std::sin(0.410719871520996*x_36 + 2.01095986366272) - 503.618393954776*std::sin(0.412559866905212*x_36 + 5.19296026229858) + 2.3986222545207*std::sin(0.422959864139557*x_45 + 5.2304801940918) - 0.0481819431004698*std::sin(0.519839882850647*x_47 + 2.12175989151001) - 1.75032547733312*std::sin(0.319039851427078*x_53 - 4.28480005264282) + 0.0297875990917095*std::sin(0.344319850206375*x_53 + 5.14800024032593) + 1936.59036471217*std::sin(0.510559856891632*x_53 + 2.09687995910645) - 22.1665204291504*std::sin(0.533279836177826*x_53 - 1.02551984786987) - 0.0143083736532834*std::sin(0.48295983672142*x_55 - 4.12296009063721) + 12.2372412557845*std::sin(0.32415983080864*x_56 + 8.32760047912598) + 0.0770177657358175*std::sin(0.431999862194061*x_59 + 2.02600002288818) - 0.187939080993796*std::sin(0.198319986462593*x_6 + 4.98751974105835) - 1.92668408280636*std::sin(0.181840002536774*x_64 - 4.4115195274353) - 6180.03563375033*std::sin(0.19463999569416*x_64 - 4.41431999206543) - 1.11817007913967*std::sin(0.197919994592667*x_64 - 4.38776016235352) - 5.97670411665963*std::sin(0.220159992575645*x_64 - 4.36287975311279) + 152.084336251509*std::sin(0.311039924621582*x_65 + 1.91295993328094) + 0.0533487908996879*std::sin(0.168160021305084*x_67 + 4.94855976104736) - 24.2972616436113*std::sin(0.567279815673828*x_75 - 7.22448015213013) + 2114.78920279481*std::sin(0.415999859571457*x_78 - 4.19112014770508) + 20.9918232216069*std::sin(0.141520038247108*x_80 + 4.9081597328186) - 45.8576073251271*std::sin(0.145120039582253*x_80 - 7.66784000396729) - 213.111511385833*std::sin(0.277919948101044*x_80 - 4.30703973770142) + 102.709736818673*std::sin(0.31047984957695*x_80 - 4.29623985290527) + 885.100823829251*std::sin(0.32983985543251*x_80 + 5.12744045257568) + 386.834889194346*std::sin(0.37271985411644*x_80 - 7.41304016113281) - 0.432632592278671*std::sin(0.482399851083755*x_80 - 7.30615949630737) + 0.00524448084398443*std::sin(0.496399849653244*x_80 - 7.31647968292236) + 27.8774242555054*std::sin(0.517439842224121*x_80 + 2.10879969596863) + 0.0246202473762306*std::sin(0.568239867687225*x_80 - 1.00951981544495) - 21.1186838877545*std::sin(0.710559844970703*x_80 - 7.24224042892456) - 2.39676114134424*std::sin(0.362319827079773*x_81 + 1.95999991893768) - 37.4419096150807*std::sin(0.535439848899841*x_81 + 2.15199971199036) + 788.050881358036*std::sin(0.310879945755005*x_85 - 4.24671983718872) + 224.583690532691*std::sin(0.420799851417542*x_85 - 4.18016004562378) - 0.519554319702146*std::sin(0.708079874515533*x_87 + 5.34943962097168) - 0.341696530281833*std::sin(0.36167985200882*x_92 - 1.17719984054565) - 50.5580178889266*std::sin(0.40871986746788*x_92 + 8.21111965179443) - 0.022872773577871*std::sin(0.410719871520996*x_93 - 4.38527965545654) - 1.65001343244891*std::sin(0.357999861240387*x_95 + 5.17431974411011) + 0.0202719667296511*std::sin(0.368399828672409*x_95 + 5.18304014205933) + 0.0241528462800345*std::sin(0.395359843969345*x_95 + 1.99887979030609) + 1755.43160224819*std::sin(0.408159852027893*x_95 + 1.98855984210968) - 33.3219515576879*std::sin(0.361279845237732*x_96 - 7.42191982269287) - 0.0193083913643798*std::sin(0.368799835443497*x_96 + 5.18600034713745) - 2765.33736098891*std::sin(0.373759835958481*x_96 + 5.1735200881958) + 7.56820252202406*std::sin(0.379359841346741*x_96 + 5.17080020904541) + 0.012345504302125*std::sin(0.443919867277145*x_96 - 7.36175966262817) + 37.965410987388*std::sin(0.474479854106903*x_96 + 2.04111981391907) - 179.200127738922*std::sin(0.426079869270325*x_97 + 2.02439975738525) - 0.0155049621275997*std::sin(0.44735985994339*x_99 + 2.00959992408752) + 810239.279114925 - 0.00251386334857129*std::exp(-3.23736000061035*x_74) - 0.839870121982356*std::exp(-3.12712001800537*x_74) - 0.0539930307765288*std::exp(-2.99327993392944*x_74) - 4.94662890907645e-5*std::exp(-2.77376008033752*x_74) - 0.0181398249835782*std::exp(-3.92463994026184*x_45) + 0.150116655034385*std::exp(-3.88455986976624*x_45) + 0.00269612839520982*std::exp(-4.77167987823486*x_111) - 0.0275232766120149*std::exp(-4.69159984588623*x_111) - 6.02972437068358e-7*std::exp(-4.68919992446899*x_111) - 0.134357612850653*std::exp(-4.61607980728149*x_111));
}

inline float score_5(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (7631.00446131224*x_1 + 700.200492067195*x_10 + 470.359193400623*x_100 + 378.480510647339*x_101 + 832.16901408966*x_102 + 76.8787628222622*x_103 - 223.442096853508*x_104 - 580.876198349477*x_105 - 268.67783447507*x_106 + 326.457395440984*x_107 + 27.5384775528042*x_108 + 1.30029696988869*x_109 - 661.085519843684*x_11 - 431.187633791952*x_110 - 573.073430876576*x_111 + 398.873400411343*x_112 + 2150.07570947656*x_113 + 300.476663828632*x_114 - 180.300765172826*x_115 - 798.233471186519*x_116 - 224.863477476885*x_117 - 619.899753835007*x_118 - 654.826564309816*x_119 + 596.963847610095*x_12 + 867.676784111758*x_120 + 539.868770562055*x_13 + 204.521008257668*x_14 + 26.3005108487376*x_15 - 599.963416989723*x_16 - 151.756840077966*x_17 + 175.424911876623*x_18 + 7.22076288996186*x_19 - 125.060347100579*x_2 - 455.427053347297*x_20 + 685.940661490241*x_21 + 1607.57316123973*x_22 + 446.903702958103*x_23 + 281.475814144057*x_24 + 294.769429772986*x_25 + 212.456543473483*x_26 + 176.647111174708*x_27 - 461.31232494008*x_28 + 353.34977561866*x_29 - 998.813668039076*x_3 - 384.369147827099*x_30 + 3423.70211276905*x_31 + 312.397976320257*x_32 - 536.032245257059*x_33 + 471.390005367246*x_34 + 466.845392742269*x_35 - 263.989574417182*x_36 + 3367.98469963409*x_37 - 241.077409111738*x_38 + 276.530955480634*x_39 - 228.575408126904*x_4 + 38.6026481294617*x_40 + 837.097532275142*x_41 - 258499.166474806*x_42 + 1269.90706077155*x_43 + 607.59181892284*x_44 + 817.464136090041*x_45 + 330.095467584298*x_46 - 388.831251478348*x_47 - 2552.5135701939*x_48 - 788.585138621308*x_49 + 476.833585791749*x_5 - 381.968132951483*x_50 - 198.65423002122*x_51 - 1025.49716696635*x_52 - 188.710185148084*x_53 - 149.0846120533*x_54 + 927.065429599841*x_55 + 161.318840995748*x_56 - 2611.23778013941*x_57 - 162.671732560801*x_58 - 522.960340847248*x_59 - 439.541798450683*x_6 + 100.795845583098*x_60 + 92.4045022612247*x_61 + 107.805521068224*x_62 - 712.76640942729*x_63 - 307.652292681027*x_64 - 114.539253215678*x_65 - 741.688163768963*x_66 + 306.005521398246*x_67 + 1671.50321682097*x_68 - 241.370377883282*x_69 + 259.411446635217*x_7 - 27776.6765403607*x_70 + 702.809401629005*x_72 - 304.64015914018*x_73 - 181.388819324942*x_74 - 737.172560271726*x_75 - 659.543009778327*x_76 - 587.947832008994*x_77 - 534.709107657182*x_78 + 429.849345319377*x_79 + 134.477048886594*x_8 + 210.353236143175*x_80 - 17.6979308359797*x_81 - 207.163309000579*x_82 + 29.2701465112025*x_83 - 1991.16379038071*x_84 - 782.721544681998*x_85 + 687.664135089808*x_86 + 597.443883211591*x_87 + 1288.37762157954*x_88 + 177.000825006934*x_89 + 1843.4017794245*x_9 + 194.096413203034*x_90 + 868.151317356053*x_91 - 496.135175437479*x_92 - 107.657072835358*x_93 + 22.4146863728965*x_94 - 95.3812316799081*x_95 + 71.5755416007783*x_96 + 1111.90553188038*x_97 + 145.941383140856*x_98 - 235.304523817984*x_99 - 0.000151423023085177*std::pow(-6.10439968109131*x_115 - 9.13776016235352, 2) + 0.0122207040342471*std::pow(-3.79663991928101*x_15 - 5.39775991439819, 2) - 1.87356331028438*std::pow(-5.44127988815308*x_23 - 7.45175981521606, 2) - 0.000112209574662877*std::pow(-5.54735994338989*x_77 - 8.12199974060059, 2) - 0.251049617532185*std::pow(-4.89847993850708*x_85 - 6.53056001663208, 2) + 2.13671163647234*std::exp(0.736559867858887*x_108) - 0.0590509955627523*std::exp(2.52023983001709*x_71) - 0.000450655742981152*std::exp(2.53288006782532*x_71) - 0.00116090636955625*std::exp(2.54391980171204*x_71) + 0.0346890214595593*std::exp(2.55216002464294*x_71) + 0.00397856193550543*std::exp(2.5849597454071*x_71) - 0.0212039330194264*std::exp(2.58639979362488*x_71) + 24.6112018219897*std::exp(2.59751987457275*x_71) + 0.636600021130907*std::exp(2.60303997993469*x_71) + 0.0382452651044978*std::exp(2.60527992248535*x_71) - 27.0194111889993*std::exp(2.61863994598389*x_71) + 0.00755824053792433*std::exp(2.62951993942261*x_71) + 2.23178369519312*std::exp(2.63624000549316*x_71) - 4.23713212376901*std::exp(2.65231990814209*x_71) - 0.961656012246672*std::exp(2.67671990394592*x_71) + 0.490764265221704*std::exp(2.68367981910706*x_71) - 0.00735090502576335*std::exp(1.35743987560272*x_76) + 3203.82312826616*std::sin(0.317119836807251*x_103 + 1.93383991718292) - 0.353660739962729*std::sin(0.500719845294952*x_103 + 5.25192022323608) - 43.2609635935524*std::sin(0.511439859867096*x_103 - 1.02791976928711) + 0.18799980387094*std::sin(0.364719837903976*x_105 + 5.15799999237061) + 0.232870293876105*std::sin(0.409359842538834*x_105 + 5.19928026199341) - 12.4361749520881*std::sin(0.178240016102791*x_106 - 7.61064004898071) - 0.0495236316390379*std::sin(0.413999855518341*x_106 + 2.01239991188049) - 26.4069306690102*std::sin(0.521679878234863*x_106 - 7.24088001251221) + 0.158057665814524*std::sin(0.608319878578186*x_106 - 0.998319804668427) + 2690.36735594971*std::sin(0.318959832191467*x_112 + 1.93887984752655) - 186.322560778444*std::sin(0.291759938001633*x_115 - 7.5033597946167) - 39.5338139298842*std::sin(0.424159854650497*x_115 - 4.19056034088135) - 30.558720845508*std::sin(0.3713598549366*x_119 - 7.40855979919434) + 68.459649193178*std::sin(0.335279852151871*x_16 - 4.25288009643555) - 0.0643819729000033*std::sin(0.425439864397049*x_16 + 2.00127983093262) + 0.152010478032677*std::sin(0.413759857416153*x_21 - 1.167839884758) - 9.38979865724721*std::sin(0.429599851369858*x_21 - 1.1561598777771) - 62.2880728959359*std::sin(0.298399925231934*x_28 + 5.13191986083984) + 4.03529761639076*std::sin(0.314399927854538*x_28 + 5.14447975158691) - 164.521578924089*std::sin(0.328799843788147*x_28 - 4.27672004699707) + 0.805836438781363*std::sin(0.332959830760956*x_28 + 5.14264011383057) - 0.686047121864825*std::sin(0.340399831533432*x_28 + 5.14807987213135) + 56.6915783300519*std::sin(0.343279838562012*x_28 + 5.15431976318359) - 0.0282480458035675*std::sin(0.359119862318039*x_28 + 5.16559982299805) + 2.1049641154239*std::sin(0.360319852828979*x_28 + 5.16567993164063) + 81.4633399144903*std::sin(0.282959938049316*x_32 + 1.94863975048065) - 47.6972937656667*std::sin(0.314079910516739*x_34 - 1.11303985118866) + 46.5148089744247*std::sin(0.349199831485748*x_34 + 2.00455975532532) + 0.0186484963298619*std::sin(0.354799836874008*x_34 + 1.97967982292175) - 0.0190683955143492*std::sin(0.31551992893219*x_36 - 7.47928047180176) + 24.8418926839486*std::sin(0.389759838581085*x_36 - 7.39135980606079) - 0.305561287899579*std::sin(0.410719871520996*x_36 + 2.01095986366272) - 8.68016161230475*std::sin(0.412559866905212*x_36 + 5.19296026229858) - 0.134347711939843*std::sin(0.422959864139557*x_45 + 5.2304801940918) + 0.0237682357228702*std::sin(0.519839882850647*x_47 + 2.12175989151001) - 0.675300473112014*std::sin(0.319039851427078*x_53 - 4.28480005264282) - 0.0898380607900626*std::sin(0.344319850206375*x_53 + 5.14800024032593) - 1704.09034529126*std::sin(0.510559856891632*x_53 + 2.09687995910645) + 22.7490051371082*std::sin(0.533279836177826*x_53 - 1.02551984786987) + 0.0431534122005949*std::sin(0.48295983672142*x_55 - 4.12296009063721) + 4.60402580009624*std::sin(0.32415983080864*x_56 + 8.32760047912598) - 0.0379929968170972*std::sin(0.431999862194061*x_59 + 2.02600002288818) + 0.0927106731516725*std::sin(0.198319986462593*x_6 + 4.98751974105835) - 9.28353015205175*std::sin(0.181840002536774*x_64 - 4.4115195274353) + 5438.0829569991*std::sin(0.19463999569416*x_64 - 4.41431999206543) - 0.431405926064235*std::sin(0.197919994592667*x_64 - 4.38776016235352) + 0.334757388955815*std::sin(0.220159992575645*x_64 - 4.36287975311279) - 605.762869799542*std::sin(0.311039924621582*x_65 + 1.91295993328094) - 2.14886410916657*std::sin(0.168160021305084*x_67 + 4.94855976104736) + 5.6894127296216*std::sin(0.567279815673828*x_75 - 7.22448015213013) - 1860.89527681011*std::sin(0.415999859571457*x_78 - 4.19112014770508) - 1.17575971537548*std::sin(0.141520038247108*x_80 + 4.9081597328186) - 17.2530395407352*std::sin(0.145120039582253*x_80 - 7.66784000396729) + 49.9018927931851*std::sin(0.277919948101044*x_80 - 4.30703973770142) - 90.6927592001239*std::sin(0.31047984957695*x_80 - 4.29623985290527) + 15.255237469964*std::sin(0.32983985543251*x_80 + 5.12744045257568) - 253.161400437297*std::sin(0.37271985411644*x_80 - 7.41304016113281) - 2.08459588731808*std::sin(0.482399851083755*x_80 - 7.30615949630737) - 0.211245212249331*std::sin(0.496399849653244*x_80 - 7.31647968292236) - 28.6099782609022*std::sin(0.517439842224121*x_80 + 2.10879969596863) - 0.0121452105402516*std::sin(0.568239867687225*x_80 - 1.00951981544495) + 19.1804724058816*std::sin(0.710559844970703*x_80 - 7.24224042892456) + 0.134243470308445*std::sin(0.362319827079773*x_81 + 1.95999991893768) + 34.0055998760407*std::sin(0.535439848899841*x_81 + 2.15199971199036) + 13.5825241711112*std::sin(0.310879945755005*x_85 - 4.24671983718872) - 146.977232919826*std::sin(0.420799851417542*x_85 - 4.18016004562378) - 0.195472283536897*std::sin(0.708079874515533*x_87 + 5.34943962097168) - 1.64642977540064*std::sin(0.36167985200882*x_92 - 1.17719984054565) + 51.8865652529158*std::sin(0.40871986746788*x_92 + 8.21111965179443) + 0.0689832576569765*std::sin(0.410719871520996*x_93 - 4.38527965545654) - 0.636598658937228*std::sin(0.357999861240387*x_95 + 5.17431974411011) - 0.061139341032*std::sin(0.368399828672409*x_95 + 5.18304014205933) - 0.0119146407724788*std::sin(0.395359843969345*x_95 + 1.99887979030609) - 1544.68084718314*std::sin(0.408159852027893*x_95 + 1.98855984210968) + 30.2637596054435*std::sin(0.361279845237732*x_96 - 7.42191982269287) + 0.0582332410145219*std::sin(0.368799835443497*x_96 + 5.18600034713745) + 2433.34098124299*std::sin(0.373759835958481*x_96 + 5.1735200881958) + 2.84739010561562*std::sin(0.379359841346741*x_96 + 5.17080020904541) - 0.497271084442762*std::sin(0.443919867277145*x_96 - 7.36175966262817) - 8.88992742166714*std::sin(0.474479854106903*x_96 + 2.04111981391907) - 3.0886204483214*std::sin(0.426079869270325*x_97 + 2.02439975738525) + 0.624532553936116*std::sin(0.44735985994339*x_99 + 2.00959992408752) - 807472.746476853 + 0.00014080240787121*std::exp(-3.23736000061035*x_74) + 3.34526321310013*std::exp(-3.12712001800537*x_74) + 0.0554118423064731*std::exp(-2.99327993392944*x_74) + 0.00199247876940026*std::exp(-2.77376008033752*x_74) + 0.0160174763379293*std::exp(-3.92463994026184*x_45) + 0.00258734955283241*std::exp(-3.88455986976624*x_45) - 0.00238068298968638*std::exp(-4.77167987823486*x_111) - 0.000474379990802938*std::exp(-4.69159984588623*x_111) + 2.42874450757322e-5*std::exp(-4.68919992446899*x_111) + 0.118227124872228*std::exp(-4.61607980728149*x_111));
}

inline float score_6(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (17357.7481750736*x_1 + 501.48001650463*x_10 + 703.651369551865*x_100 + 6.14517340010439*x_101 + 391.203898819325*x_102 + 196.56405001398*x_103 - 1141.67524852782*x_104 - 206.34125370093*x_105 - 745.203275325983*x_106 + 88.5175541020741*x_107 - 52.3567048481872*x_108 + 1186.9988552667*x_109 + 309.323804174833*x_11 - 922.983998546116*x_110 - 510.543137540808*x_111 + 648.78271645423*x_112 + 410.647737322578*x_113 + 584.713593745665*x_114 - 1148.86644987582*x_115 + 173.978728899196*x_116 - 975.104803519944*x_117 - 310.121138757723*x_118 - 816.808439828677*x_119 + 4026.68259966533*x_12 + 1346.14351754759*x_120 + 1370.50434567796*x_13 - 217.86409873162*x_14 - 1.6248653168958*x_15 - 719.481598450981*x_16 - 763.404748087253*x_17 + 180.899798309218*x_18 + 153.372433171862*x_19 - 164.374674410844*x_2 + 157.200241678169*x_20 + 3773.6239437952*x_21 - 397.755444400875*x_22 + 810.551233823733*x_23 - 598.236335787908*x_24 + 271.510344192357*x_25 + 109.399997394754*x_26 - 656.1595252057*x_27 - 232.722949661065*x_28 - 442.608987078878*x_29 - 1907.69212272186*x_3 - 454.437274555541*x_30 + 54492.0497656263*x_31 - 258.984516024154*x_32 - 150.140447567795*x_33 + 544.633504466277*x_34 - 136.243761793363*x_35 - 273.74149831228*x_36 + 1884.01529802076*x_37 - 1018.62101151543*x_38 + 1539.4762732506*x_39 - 316.141649659846*x_4 + 299.95258523632*x_40 + 1018.94642901672*x_41 + 216422.622737266*x_42 + 1026.69903003684*x_43 + 904.394367592365*x_44 - 350.201800461891*x_45 - 185.126078854733*x_46 + 1569.51387767502*x_47 - 1215.22848756316*x_48 - 1735.6777691671*x_49 + 144.109857591538*x_5 - 83.4681657336355*x_50 + 281.487998117255*x_51 + 789.553609532407*x_52 - 170.806641790914*x_53 - 428.269609498081*x_54 + 33.3883915581261*x_55 + 268.176908692593*x_56 - 1953.11437873572*x_57 - 211.290026491284*x_58 - 262.60012965538*x_59 - 548.595189527405*x_6 - 527.088847495068*x_60 + 255.080584034006*x_61 - 1224.57813541815*x_62 - 1210.84564705161*x_63 - 204.974491359236*x_64 + 298.437290036411*x_65 - 65.787866753596*x_66 - 660.73747461977*x_67 + 596.233248540734*x_68 - 1025.35958177444*x_69 + 213.652482398447*x_7 - 26180.2569899207*x_70 - 1.62501996772255*x_72 + 153.623256244988*x_73 + 202.152199029481*x_74 - 180.209910394804*x_75 + 1221.9089462109*x_76 + 88.9236782169422*x_77 - 633.877802394131*x_78 - 60.371161823211*x_79 + 4729.77356076437*x_8 - 209.155367557732*x_80 - 509.286604631906*x_81 - 109.242671834352*x_82 - 392.900964537012*x_83 - 4357.76107620664*x_84 - 194.106020670757*x_85 + 174.952314384769*x_86 + 1.75182274647974*x_87 + 434.382305488904*x_88 + 1975.97155480091*x_89 - 1372.03357595097*x_9 + 123.251101853975*x_90 + 1386.1776514327*x_91 - 230.949139161789*x_92 + 25.4577654292542*x_93 + 831.49603139279*x_94 - 266.134684276601*x_95 - 202.281861923693*x_96 + 245.757107438158*x_97 + 361.830882275006*x_98 - 856.384989865613*x_99 - 0.00130117433472132*std::pow(-6.10439968109131*x_115 - 9.13776016235352, 2) - 0.00549085398039341*std::pow(-3.79663991928101*x_15 - 5.39775991439819, 2) + 1.5725001228568*std::pow(-5.44127988815308*x_23 - 7.45175981521606, 2) + 0.000180315617663812*std::pow(-5.54735994338989*x_77 - 8.12199974060059, 2) - 4.9940431666309*std::pow(-4.89847993850708*x_85 - 6.53056001663208, 2) + 1.43547637552302*std::exp(0.736559867858887*x_108) - 0.0396713845867348*std::exp(2.52023983001709*x_71) - 0.000480779667235474*std::exp(2.53288006782532*x_71) + 0.00186552305991089*std::exp(2.54391980171204*x_71) - 0.0155860375166108*std::exp(2.55216002464294*x_71) + 0.0341876854265869*std::exp(2.5849597454071*x_71) + 0.00116309018673421*std::exp(2.58639979362488*x_71) - 20.6564238722512*std::exp(2.59751987457275*x_71) + 1.91996974966532*std::exp(2.60303997993469*x_71) + 0.234228160470846*std::exp(2.60527992248535*x_71) - 24.3994244823469*std::exp(2.61863994598389*x_71) - 0.018148015897538*std::exp(2.62951993942261*x_71) + 2.46253862086975*std::exp(2.63624000549316*x_71) + 3.37923478923808*std::exp(2.65231990814209*x_71) - 19.1298902735604*std::exp(2.67671990394592*x_71) + 3.17903567610217*std::exp(2.68367981910706*x_71) - 0.0631661471394408*std::exp(1.35743987560272*x_76) - 2689.00027832275*std::sin(0.317119836807251*x_103 + 1.93383991718292) + 0.849171271934839*std::sin(0.500719845294952*x_103 + 5.25192022323608) - 47.7339241498243*std::sin(0.511439859867096*x_103 - 1.02791976928711) + 1.61547771762493*std::sin(0.364719837903976*x_105 + 5.15799999237061) - 0.5591425377537*std::sin(0.409359842538834*x_105 + 5.19928026199341) - 76.1637388147853*std::sin(0.178240016102791*x_106 - 7.61064004898071) + 0.0795821947884324*std::sin(0.413999855518341*x_106 + 2.01239991188049) - 29.1372711303191*std::sin(0.521679878234863*x_106 - 7.24088001251221) - 0.379510683410648*std::sin(0.608319878578186*x_106 - 0.998319804668427) - 2258.05179602855*std::sin(0.318959832191467*x_112 + 1.93887984752655) + 148.597603523012*std::sin(0.291759938001633*x_115 - 7.5033597946167) - 43.6214064303369*std::sin(0.424159854650497*x_115 - 4.19056034088135) - 92.1643381469153*std::sin(0.3713598549366*x_119 - 7.40855979919434) + 1361.84411115188*std::sin(0.335279852151871*x_16 - 4.25288009643555) + 0.103458864760492*std::sin(0.425439864397049*x_16 + 2.00127983093262) + 1.30622232072053*std::sin(0.413759857416153*x_21 - 1.167839884758) - 6.30821394582255*std::sin(0.429599851369858*x_21 - 1.1561598777771) - 68.728338438963*std::sin(0.298399925231934*x_28 + 5.13191986083984) - 1.81308948461055*std::sin(0.314399927854538*x_28 + 5.14447975158691) - 3272.77083735783*std::sin(0.328799843788147*x_28 - 4.27672004699707) - 1.93488582804958*std::sin(0.332959830760956*x_28 + 5.14264011383057) + 0.0376314466918558*std::sin(0.340399831533432*x_28 + 5.14807987213135) + 367.23242260591*std::sin(0.343279838562012*x_28 + 5.15431976318359) + 0.0453933083889593*std::sin(0.359119862318039*x_28 + 5.16559982299805) + 12.8915794220733*std::sin(0.360319852828979*x_28 + 5.16567993164063) + 527.697068093599*std::sin(0.282959938049316*x_32 + 1.94863975048065) - 52.6289479853738*std::sin(0.314079910516739*x_34 - 1.11303985118866) + 140.287501064961*std::sin(0.349199831485748*x_34 + 2.00455975532532) + 0.0198950484922322*std::sin(0.354799836874008*x_34 + 1.97967982292175) + 0.0306420332253987*std::sin(0.31551992893219*x_36 - 7.47928047180176) + 27.4104162878704*std::sin(0.389759838581085*x_36 - 7.39135980606079) + 0.733680157789292*std::sin(0.410719871520996*x_36 + 2.01095986366272) - 5.83146865374717*std::sin(0.412559866905212*x_36 + 5.19296026229858) - 1.15444660358104*std::sin(0.422959864139557*x_45 + 5.2304801940918) + 0.0253570150599274*std::sin(0.519839882850647*x_47 + 2.12175989151001) + 1.62145722409324*std::sin(0.319039851427078*x_53 - 4.28480005264282) + 0.144365625391133*std::sin(0.344319850206375*x_53 + 5.14800024032593) + 1430.2597956633*std::sin(0.510559856891632*x_53 + 2.09687995910645) + 147.361786608542*std::sin(0.533279836177826*x_53 - 1.02551984786987) - 0.0693455455885055*std::sin(0.48295983672142*x_55 - 4.12296009063721) + 28.1967582384475*std::sin(0.32415983080864*x_56 + 8.32760047912598) - 0.0405326252943511*std::sin(0.431999862194061*x_59 + 2.02600002288818) + 0.0989078854119963*std::sin(0.198319986462593*x_6 + 4.98751974105835) + 4.17115972571181*std::sin(0.181840002536774*x_64 - 4.4115195274353) - 4564.23653849656*std::sin(0.19463999569416*x_64 - 4.41431999206543) + 1.03584446211021*std::sin(0.197919994592667*x_64 - 4.38776016235352) + 2.87656205769061*std::sin(0.220159992575645*x_64 - 4.36287975311279) - 547.023963346076*std::sin(0.311039924621582*x_65 + 1.91295993328094) + 0.117870715574662*std::sin(0.168160021305084*x_67 + 4.94855976104736) + 17.1591265655771*std::sin(0.567279815673828*x_75 - 7.22448015213013) + 1561.86771770385*std::sin(0.415999859571457*x_78 - 4.19112014770508) - 10.1032744841268*std::sin(0.141520038247108*x_80 + 4.9081597328186) - 105.664000579301*std::sin(0.145120039582253*x_80 - 7.66784000396729) + 150.502861190222*std::sin(0.277919948101044*x_80 - 4.30703973770142) - 1804.11967482171*std::sin(0.31047984957695*x_80 - 4.29623985290527) + 10.248707695195*std::sin(0.32983985543251*x_80 + 5.12744045257568) + 201.903501392109*std::sin(0.37271985411644*x_80 - 7.41304016113281) + 0.936624567072037*std::sin(0.482399851083755*x_80 - 7.30615949630737) + 0.0115873424584336*std::sin(0.496399849653244*x_80 - 7.31647968292236) - 185.327555466631*std::sin(0.517439842224121*x_80 + 2.10879969596863) - 0.0129570528568436*std::sin(0.568239867687225*x_80 - 1.00951981544495) + 21.1636343467071*std::sin(0.710559844970703*x_80 - 7.24224042892456) + 1.15355085779139*std::sin(0.362319827079773*x_81 + 1.95999991893768) + 37.5216035500912*std::sin(0.535439848899841*x_81 + 2.15199971199036) + 9.12495267718495*std::sin(0.310879945755005*x_85 - 4.24671983718872) + 117.218572421298*std::sin(0.420799851417542*x_85 - 4.18016004562378) - 1.19714462092978*std::sin(0.708079874515533*x_87 + 5.34943962097168) + 0.739753246651125*std::sin(0.36167985200882*x_92 - 1.17719984054565) + 336.106871951865*std::sin(0.40871986746788*x_92 + 8.21111965179443) - 0.110852917411466*std::sin(0.410719871520996*x_93 - 4.38527965545654) + 1.52853068445966*std::sin(0.357999861240387*x_95 + 5.17431974411011) + 0.098248104717135*std::sin(0.368399828672409*x_95 + 5.18304014205933) - 0.0127110707342348*std::sin(0.395359843969345*x_95 + 1.99887979030609) + 1296.4658352545*std::sin(0.408159852027893*x_95 + 1.98855984210968) + 33.3928762906719*std::sin(0.361279845237732*x_96 - 7.42191982269287) - 0.0935781358555764*std::sin(0.368799835443497*x_96 + 5.18600034713745) - 2042.32703050546*std::sin(0.373759835958481*x_96 + 5.1735200881958) + 17.4384710044224*std::sin(0.379359841346741*x_96 + 5.17080020904541) + 0.0272765961829896*std::sin(0.443919867277145*x_96 - 7.36175966262817) - 26.81179886862*std::sin(0.474479854106903*x_96 + 2.04111981391907) - 2.07498363880421*std::sin(0.426079869270325*x_97 + 2.02439975738525) - 0.0342572146456818*std::sin(0.44735985994339*x_99 + 2.00959992408752) + 421842.889586717 + 0.00120991164788676*std::exp(-3.23736000061035*x_74) + 3.02088363697733*std::exp(-3.12712001800537*x_74) + 0.358942645286626*std::exp(-2.99327993392944*x_74) - 0.000109292578025149*std::exp(-2.77376008033752*x_74) + 0.318630113992716*std::exp(-3.92463994026184*x_45) + 0.00173822199257679*std::exp(-3.88455986976624*x_45) - 0.0473581028859104*std::exp(-4.77167987823486*x_111) - 0.000318695914879134*std::exp(-4.69159984588623*x_111) - 1.33222874277851e-6*std::exp(-4.68919992446899*x_111) - 0.0992291893025836*std::exp(-4.61607980728149*x_111));
}

inline float score_7(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (10557.08787768*x_1 + 18.0501739753512*x_10 + 472.213183772398*x_100 + 1068.00464840958*x_101 - 230.301768300525*x_102 + 108.592942023064*x_103 - 766.262436637587*x_104 - 363.842206821954*x_105 - 892.123797938983*x_106 + 7.72481142103791*x_107 + 231.609604822096*x_108 + 254.699455829601*x_109 - 385.391305103652*x_11 - 383.438180938771*x_110 - 533.789664529087*x_111 + 395.37170167361*x_112 + 986.867269203352*x_113 + 664.90239055581*x_114 - 777.470429016212*x_115 - 1206.61076409664*x_116 - 659.105037341304*x_117 + 256.746922310952*x_118 - 610.113697098202*x_119 - 109.82819894109*x_12 + 938.749681961873*x_120 + 1235.11656246323*x_13 + 57.3232875183511*x_14 + 600.63508176211*x_15 - 765.598131518833*x_16 - 106.219495450114*x_17 - 241.781728343537*x_18 + 254.324153305909*x_19 - 1.9658058549397*x_2 + 1801.24192021906*x_20 + 1801.4381759932*x_21 + 1194.14917858126*x_22 + 151.101087379031*x_23 - 1000.84075776452*x_24 + 1291.86058004832*x_25 + 87.8604823006624*x_26 - 410.735794465226*x_27 - 283.307305920505*x_28 - 175.558807805317*x_29 - 605.710064209041*x_3 - 267.320169668298*x_30 - 18741.3230709908*x_31 - 542.808239551815*x_32 - 207.340618825938*x_33 + 539.796718666722*x_34 - 257.403573315828*x_35 - 99.2728976608771*x_36 + 3331.18223542217*x_37 - 600.093111607524*x_38 + 725.41733240957*x_39 - 670.951313969157*x_4 + 463.098846578779*x_40 + 244.293016484213*x_41 + 225745.853498585*x_42 + 300.1536566079*x_43 + 1817.09494842858*x_44 - 276.353672368664*x_45 + 245.836588342502*x_46 + 1370.09975958539*x_47 - 1119.77070878077*x_48 - 962.534245607574*x_49 - 15.0423652339114*x_5 - 701.187957799096*x_50 + 1620.460652202*x_51 + 1214.77321772335*x_52 - 187.049319035767*x_53 - 1307.76537325422*x_54 - 60.9825291280811*x_55 + 149.653578221402*x_56 - 396.834672965657*x_57 - 922.942645633631*x_58 - 203.478919961165*x_59 - 167.155890965773*x_6 + 22.7333214654283*x_60 + 342.685711148963*x_61 - 1303.36066711684*x_62 - 619.145588922401*x_63 - 462.983526244761*x_64 - 38.1006083749524*x_65 - 450.000082630564*x_66 - 678.240253589779*x_67 - 306.911142293981*x_68 - 484.981676724629*x_69 + 74.7360492156895*x_7 - 26804.232455574*x_70 + 508.834417591107*x_72 - 456.393651425249*x_73 + 180.354002842176*x_74 - 557.065441220329*x_75 + 2480.47041760213*x_76 - 24.5912503761581*x_77 - 233.074697074865*x_78 + 33.6011544527825*x_79 + 4530.97579222561*x_8 - 207.09023501951*x_80 - 827.609227486404*x_81 - 311.202890488377*x_82 + 29.9118803862397*x_83 - 2885.56554310174*x_84 - 280.862988465005*x_85 - 114.570963248149*x_86 + 317.231873413441*x_87 + 107.913904116893*x_88 + 979.753506351392*x_89 - 2569.89233883825*x_9 - 978.126231606747*x_90 + 789.279282981922*x_91 + 542.337666047513*x_92 - 110.965793405036*x_93 + 820.628518540339*x_94 - 35.82039277536*x_95 + 334.690303539492*x_96 + 534.666906699316*x_97 + 842.356762160122*x_98 - 361.081946815987*x_99 - 0.00122437068127118*std::pow(-6.10439968109131*x_115 - 9.13776016235352, 2) - 0.00918270416986449*std::pow(-3.79663991928101*x_15 - 5.39775991439819, 2) + 1.54651252601464*std::pow(-5.44127988815308*x_23 - 7.45175981521606, 2) + 0.000198003057403828*std::pow(-5.54735994338989*x_77 - 8.12199974060059, 2) + 3.7564835165425*std::pow(-4.89847993850708*x_85 - 6.53056001663208, 2) - 23.3718447412452*std::exp(0.736559867858887*x_108) + 0.645913410378187*std::exp(2.52023983001709*x_71) - 6.66613604638989e-5*std::exp(2.53288006782532*x_71) + 0.00204851512201448*std::exp(2.54391980171204*x_71) - 0.026065521357243*std::exp(2.55216002464294*x_71) + 0.0321697089927615*std::exp(2.5849597454071*x_71) + 0.0108080005679569*std::exp(2.58639979362488*x_71) - 20.3150497712319*std::exp(2.59751987457275*x_71) - 2.07225433918809*std::exp(2.60303997993469*x_71) + 0.190239141973516*std::exp(2.60527992248535*x_71) - 26.0351621347417*std::exp(2.61863994598389*x_71) - 0.00256924476541185*std::exp(2.62951993942261*x_71) + 2.81300870395306*std::exp(2.63624000549316*x_71) + 4.97653253938227*std::exp(2.65231990814209*x_71) + 14.3893665088954*std::exp(2.67671990394592*x_71) + 1.47307956801212*std::exp(2.68367981910706*x_71) - 0.059437676061261*std::exp(1.35743987560272*x_76) - 2644.56107343762*std::sin(0.317119836807251*x_103 + 1.93383991718292) + 0.120218587953336*std::sin(0.500719845294952*x_103 + 5.25192022323608) - 54.5274469887767*std::sin(0.511439859867096*x_103 - 1.02791976928711) + 1.52012186294042*std::sin(0.364719837903976*x_105 + 5.15799999237061) - 0.0791587381427014*std::sin(0.409359842538834*x_105 + 5.19928026199341) - 61.8598732641425*std::sin(0.178240016102791*x_106 - 7.61064004898071) + 0.0873885362076376*std::sin(0.413999855518341*x_106 + 2.01239991188049) - 33.2841063301085*std::sin(0.521679878234863*x_106 - 7.24088001251221) - 0.05372795804653*std::sin(0.608319878578186*x_106 - 0.998319804668427) - 2220.73457177466*std::sin(0.318959832191467*x_112 + 1.93887984752655) + 218.836764927255*std::sin(0.291759938001633*x_115 - 7.5033597946167) - 49.8296330978445*std::sin(0.424159854650497*x_115 - 4.19056034088135) + 99.4744576973858*std::sin(0.3713598549366*x_119 - 7.40855979919434) - 1024.36939068225*std::sin(0.335279852151871*x_16 - 4.25288009643555) + 0.113607305920111*std::sin(0.425439864397049*x_16 + 2.00127983093262) + 1.22912070276482*std::sin(0.413759857416153*x_21 - 1.167839884758) + 102.707783597347*std::sin(0.429599851369858*x_21 - 1.1561598777771) - 78.5097998457991*std::sin(0.298399925231934*x_28 + 5.13191986083984) - 3.03214480481921*std::sin(0.314399927854538*x_28 + 5.14447975158691) + 2461.75479341113*std::sin(0.328799843788147*x_28 - 4.27672004699707) - 0.273925001689047*std::sin(0.332959830760956*x_28 + 5.14264011383057) + 0.349689733313484*std::sin(0.340399831533432*x_28 + 5.14807987213135) + 170.165620511574*std::sin(0.343279838562012*x_28 + 5.15431976318359) + 0.049846008699293*std::sin(0.359119862318039*x_28 + 5.16559982299805) + 10.4704874213616*std::sin(0.360319852828979*x_28 + 5.16567993164063) + 244.520618296955*std::sin(0.282959938049316*x_32 + 1.94863975048065) - 60.1191337703611*std::sin(0.314079910516739*x_34 - 1.11303985118866) - 151.41456414425*std::sin(0.349199831485748*x_34 + 2.00455975532532) + 0.00275850059677729*std::sin(0.354799836874008*x_34 + 1.97967982292175) + 0.0336477579829529*std::sin(0.31551992893219*x_36 - 7.47928047180176) + 31.3114843939068*std::sin(0.389759838581085*x_36 - 7.39135980606079) + 0.103868319023371*std::sin(0.410719871520996*x_36 + 2.01095986366272) + 94.9456099123599*std::sin(0.412559866905212*x_36 + 5.19296026229858) - 1.08630376176337*std::sin(0.422959864139557*x_45 + 5.2304801940918) + 0.00351581657127453*std::sin(0.519839882850647*x_47 + 2.12175989151001) + 0.229552393433044*std::sin(0.319039851427078*x_53 - 4.28480005264282) + 0.158526674404625*std::sin(0.344319850206375*x_53 + 5.14800024032593) + 1406.62290406056*std::sin(0.510559856891632*x_53 + 2.09687995910645) + 68.2834856464908*std::sin(0.533279836177826*x_53 - 1.02551984786987) - 0.0761477581462775*std::sin(0.48295983672142*x_55 - 4.12296009063721) + 22.9012902758317*std::sin(0.32415983080864*x_56 + 8.32760047912598) - 0.00561995468908116*std::sin(0.431999862194061*x_59 + 2.02600002288818) + 0.0137138374425927*std::sin(0.198319986462593*x_6 + 4.98751974105835) + 6.9756955736274*std::sin(0.181840002536774*x_64 - 4.4115195274353) - 4488.80663084146*std::sin(0.19463999569416*x_64 - 4.41431999206543) + 0.146646221663194*std::sin(0.197919994592667*x_64 - 4.38776016235352) + 2.70676891813102*std::sin(0.220159992575645*x_64 - 4.36287975311279) - 583.696455119592*std::sin(0.311039924621582*x_65 + 1.91295993328094) + 1.09531210512014*std::sin(0.168160021305084*x_67 + 4.94855976104736) - 18.5201222510891*std::sin(0.567279815673828*x_75 - 7.22448015213013) + 1536.05583509824*std::sin(0.415999859571457*x_78 - 4.19112014770508) - 9.50691443345249*std::sin(0.141520038247108*x_80 + 4.9081597328186) - 85.8198637059158*std::sin(0.145120039582253*x_80 - 7.66784000396729) - 162.440167203689*std::sin(0.277919948101044*x_80 - 4.30703973770142) + 1357.04590333163*std::sin(0.31047984957695*x_80 - 4.29623985290527) - 166.865306273835*std::sin(0.32983985543251*x_80 + 5.12744045257568) + 297.339311163872*std::sin(0.37271985411644*x_80 - 7.41304016113281) + 1.56637680556817*std::sin(0.482399851083755*x_80 - 7.30615949630737) + 0.107675230433769*std::sin(0.496399849653244*x_80 - 7.31647968292236) - 85.8758010801111*std::sin(0.517439842224121*x_80 + 2.10879969596863) - 0.00179652932497415*std::sin(0.568239867687225*x_80 - 1.00951981544495) + 24.1756564222087*std::sin(0.710559844970703*x_80 - 7.24224042892456) + 1.0854608886345*std::sin(0.362319827079773*x_81 + 1.95999991893768) + 42.8617023417092*std::sin(0.535439848899841*x_81 + 2.15199971199036) - 148.56878237698*std::sin(0.310879945755005*x_85 - 4.24671983718872) + 172.625483654556*std::sin(0.420799851417542*x_85 - 4.18016004562378) - 0.972315903630378*std::sin(0.708079874515533*x_87 + 5.34943962097168) + 1.23713638114401*std::sin(0.36167985200882*x_92 - 1.17719984054565) + 155.742878088055*std::sin(0.40871986746788*x_92 + 8.21111965179443) - 0.12172665271029*std::sin(0.410719871520996*x_93 - 4.38527965545654) + 0.216396628810102*std::sin(0.357999861240387*x_95 + 5.17431974411011) + 0.107885414309447*std::sin(0.368399828672409*x_95 + 5.18304014205933) - 0.00176242325922227*std::sin(0.395359843969345*x_95 + 1.99887979030609) + 1275.04006176393*std::sin(0.408159852027893*x_95 + 1.98855984210968) + 38.1453719586785*std::sin(0.361279845237732*x_96 - 7.42191982269287) - 0.102757360929771*std::sin(0.368799835443497*x_96 + 5.18600034713745) - 2008.57493680628*std::sin(0.373759835958481*x_96 + 5.1735200881958) + 14.1634539354387*std::sin(0.379359841346741*x_96 + 5.17080020904541) + 0.253467418434209*std::sin(0.443919867277145*x_96 - 7.36175966262817) + 28.9384072622087*std::sin(0.474479854106903*x_96 + 2.04111981391907) + 33.7840428959246*std::sin(0.426079869270325*x_97 + 2.02439975738525) - 0.318334725518374*std::sin(0.44735985994339*x_99 + 2.00959992408752) + 519916.941343801 + 0.00113849490346604*std::exp(-3.23736000061035*x_74) + 3.22340370510771*std::exp(-3.12712001800537*x_74) + 0.166324360822604*std::exp(-2.99327993392944*x_74) - 0.00101559987251377*std::exp(-2.77376008033752*x_74) - 0.239671290605838*std::exp(-3.92463994026184*x_45) - 0.0283010262161373*std::exp(-3.88455986976624*x_45) + 0.0356224259442399*std::exp(-4.77167987823486*x_111) + 0.00518887776157955*std::exp(-4.69159984588623*x_111) - 1.2379718419797e-5*std::exp(-4.68919992446899*x_111) - 0.0975892987047467*std::exp(-4.61607980728149*x_111));
}

inline float score_8(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (3813.61396250165*x_1 + 301.896442490467*x_10 + 205.081477632246*x_100 - 675.090181218669*x_101 + 464.240359234891*x_102 + 30.5229024086625*x_103 - 160.302488101673*x_104 + 47.3667449285095*x_105 + 281.746520147679*x_106 + 127.441971743106*x_107 - 161.266692479965*x_108 + 178.526506409691*x_109 + 239.169491980361*x_11 - 83.1838118483829*x_110 + 53.1620658459895*x_111 + 103.708862188064*x_112 - 268.393944092099*x_113 - 73.7374331202999*x_114 + 76.4108683841168*x_115 + 489.885759373363*x_116 - 28.8878729790659*x_117 - 350.024719611256*x_118 - 19.676035535892*x_119 + 1288.32757433876*x_12 + 67.3155080714891*x_120 - 171.454489634395*x_13 - 123.42163503407*x_14 - 377.803642953763*x_15 + 78.2064515175195*x_16 - 272.539418572647*x_17 + 220.380440503859*x_18 - 69.0927540251842*x_19 - 70.4677185430171*x_2 - 1133.90280101898*x_20 - 331.268356984449*x_21 - 641.068738274925*x_22 + 156.922056875434*x_23 + 528.515429993743*x_24 - 575.914781289563*x_25 - 17.0050850141167*x_26 + 41.4818723485347*x_27 - 5.88383460936746*x_28 - 125.358821839996*x_29 - 355.460169483632*x_3 + 265.156586616733*x_30 + 33467.8543115488*x_31 + 356.640756779048*x_32 - 23.0488704131387*x_33 - 9.24710577345244*x_34 + 145.284851504161*x_35 - 118.44408552481*x_36 - 617.403186565372*x_37 - 164.092181095952*x_38 + 99.3053877247456*x_39 + 216.995160858671*x_4 - 100.231607641898*x_40 + 356.533708717593*x_41 - 179073.989309573*x_42 + 411.20703019115*x_43 - 588.584038044314*x_44 + 219.362986084383*x_45 - 153.355729154509*x_46 - 69.0005416852268*x_47 - 460.064080630602*x_48 - 36.1665174797573*x_49 + 140.970019108992*x_5 + 193.948073945107*x_50 - 798.429838844377*x_51 - 297.907782501892*x_52 + 5.07129816308556*x_53 + 227.237680468813*x_54 + 228.175983176599*x_55 - 8.69041637562153*x_56 - 1374.68225834259*x_57 + 436.786867287023*x_58 - 104.58084302573*x_59 - 176.488970229362*x_6 - 161.753146756152*x_60 - 81.1730424292378*x_61 + 414.068787096314*x_62 - 134.547154962783*x_63 + 139.949166448439*x_64 + 25.2537090241188*x_65 + 124.617984686438*x_66 + 172.343340562838*x_67 + 779.063325975412*x_68 - 32.8883774994319*x_69 + 40.6188263098526*x_7 + 1829.83476613328*x_70 - 285.629983641189*x_72 + 46.6568823348838*x_73 - 71.786352277109*x_74 + 94.6902507601712*x_75 - 956.681956208405*x_76 - 30.4809851033446*x_77 - 82.8656490450074*x_78 - 21.5973290085107*x_79 - 1057.70838757763*x_8 + 77.6375708416317*x_80 + 300.321737610595*x_81 + 95.7574201728779*x_82 - 201.622653575146*x_83 - 842.560507657596*x_84 - 116.588219519822*x_85 + 209.241233324011*x_86 - 47.0753959194961*x_87 + 225.063042473771*x_88 + 139.131820495504*x_89 + 1260.74409480797*x_9 + 290.862476396768*x_90 + 108.19332841259*x_91 - 449.64732556489*x_92 + 13.1532261266601*x_93 - 133.316673616668*x_94 - 76.9157109925147*x_95 - 225.957247825135*x_96 + 406.179954990642*x_97 - 248.880229417067*x_98 - 47.6938779280051*x_99 + 0.000542125029491802*std::pow(-6.10439968109131*x_115 - 9.13776016235352, 2) - 0.00452344991568138*std::pow(-3.79663991928101*x_15 - 5.39775991439819, 2) - 0.622737878208563*std::pow(-5.44127988815308*x_23 - 7.45175981521606, 2) - 8.88250063908568e-5*std::pow(-5.54735994338989*x_77 - 8.12199974060059, 2) - 3.81320880012257*std::pow(-4.89847993850708*x_85 - 6.53056001663208, 2) + 8.179422478174*std::exp(0.736559867858887*x_108) - 0.226049707513156*std::exp(2.52023983001709*x_71) + 0.000263560533293891*std::exp(2.53288006782532*x_71) - 0.000918972520881818*std::exp(2.54391980171204*x_71) - 0.0128400172982325*std::exp(2.55216002464294*x_71) - 0.0142440559082457*std::exp(2.5849597454071*x_71) + 0.0133255213988034*std::exp(2.58639979362488*x_71) + 8.18030942357759*std::exp(2.59751987457275*x_71) - 3.55838114406706*std::exp(2.60303997993469*x_71) + 0.0757228280730935*std::exp(2.60527992248535*x_71) + 2.15157863699727*std::exp(2.61863994598389*x_71) + 0.012080612087347*std::exp(2.62951993942261*x_71) + 1.55761821248653*std::exp(2.63624000549316*x_71) + 2.65775693132872*std::exp(2.65231990814209*x_71) - 14.6066550693696*std::exp(2.67671990394592*x_71) - 1.32388670518761*std::exp(2.68367981910706*x_71) + 0.0263177258166463*std::exp(1.35743987560272*x_76) + 1064.89169920239*std::sin(0.317119836807251*x_103 + 1.93383991718292) - 0.565268886135122*std::sin(0.500719845294952*x_103 + 5.25192022323608) - 30.1929192009816*std::sin(0.511439859867096*x_103 - 1.02791976928711) - 0.673077297899773*std::sin(0.364719837903976*x_105 + 5.15799999237061) + 0.372205101553474*std::sin(0.409359842538834*x_105 + 5.19928026199341) - 24.6227169614554*std::sin(0.178240016102791*x_106 - 7.61064004898071) - 0.0392028657986822*std::sin(0.413999855518341*x_106 + 2.01239991188049) - 18.4300639145767*std::sin(0.521679878234863*x_106 - 7.24088001251221) + 0.25262934390034*std::sin(0.608319878578186*x_106 - 0.998319804668427) + 894.22847343835*std::sin(0.318959832191467*x_112 + 1.93887984752655) + 116.871521327812*std::sin(0.291759938001633*x_115 - 7.5033597946167) - 27.5916473083261*std::sin(0.424159854650497*x_115 - 4.19056034088135) + 170.813026129485*std::sin(0.3713598549366*x_119 - 7.40855979919434) + 1039.83801816891*std::sin(0.335279852151871*x_16 - 4.25288009643555) - 0.0509647164377918*std::sin(0.425439864397049*x_16 + 2.00127983093262) - 0.544228236944999*std::sin(0.413759857416153*x_21 - 1.167839884758) - 35.9445462324603*std::sin(0.429599851369858*x_21 - 1.1561598777771) - 43.4724193802316*std::sin(0.298399925231934*x_28 + 5.13191986083984) - 1.49365098863852*std::sin(0.314399927854538*x_28 + 5.14447975158691) - 2498.92885211414*std::sin(0.328799843788147*x_28 - 4.27672004699707) + 1.28799783149535*std::sin(0.332959830760956*x_28 + 5.14264011383057) + 0.43114339187082*std::sin(0.340399831533432*x_28 + 5.14807987213135) - 152.931319914566*std::sin(0.343279838562012*x_28 + 5.15431976318359) - 0.0223611296680301*std::sin(0.359119862318039*x_28 + 5.16559982299805) + 4.16767501484858*std::sin(0.360319852828979*x_28 + 5.16567993164063) - 219.755675618012*std::sin(0.282959938049316*x_32 + 1.94863975048065) - 33.2891460833501*std::sin(0.314079910516739*x_34 - 1.11303985118866) - 260.002220672936*std::sin(0.349199831485748*x_34 + 2.00455975532532) - 0.0109063463949535*std::sin(0.354799836874008*x_34 + 1.97967982292175) - 0.0150945261000602*std::sin(0.31551992893219*x_36 - 7.47928047180176) + 17.3377843742182*std::sin(0.389759838581085*x_36 - 7.39135980606079) - 0.48838977398286*std::sin(0.410719871520996*x_36 + 2.01095986366272) - 33.2280256230952*std::sin(0.412559866905212*x_36 + 5.19296026229858) + 0.480991964191428*std::sin(0.422959864139557*x_45 + 5.2304801940918) - 0.0139005637454765*std::sin(0.519839882850647*x_47 + 2.12175989151001) - 1.07935742678924*std::sin(0.319039851427078*x_53 - 4.28480005264282) - 0.0711157345332984*std::sin(0.344319850206375*x_53 + 5.14800024032593) - 566.408191320368*std::sin(0.510559856891632*x_53 + 2.09687995910645) - 61.367763693342*std::sin(0.533279836177826*x_53 - 1.02551984786987) + 0.0341602053659084*std::sin(0.48295983672142*x_55 - 4.12296009063721) + 9.11563439689098*std::sin(0.32415983080864*x_56 + 8.32760047912598) + 0.0222197423610023*std::sin(0.431999862194061*x_59 + 2.02600002288818) - 0.0542207102393731*std::sin(0.198319986462593*x_6 + 4.98751974105835) + 3.43626550203996*std::sin(0.181840002536774*x_64 - 4.4115195274353) + 1807.51844550678*std::sin(0.19463999569416*x_64 - 4.41431999206543) - 0.689531858481437*std::sin(0.197919994592667*x_64 - 4.38776016235352) - 1.19849911633441*std::sin(0.220159992575645*x_64 - 4.36287975311279) + 48.2374112681442*std::sin(0.311039924621582*x_65 + 1.91295993328094) + 1.35044449742344*std::sin(0.168160021305084*x_67 + 4.94855976104736) - 31.801913769867*std::sin(0.567279815673828*x_75 - 7.22448015213013) - 618.527257599406*std::sin(0.415999859571457*x_78 - 4.19112014770508) + 4.20945743511311*std::sin(0.141520038247108*x_80 + 4.9081597328186) - 34.1597565950127*std::sin(0.145120039582253*x_80 - 7.66784000396729) - 278.934886073482*std::sin(0.277919948101044*x_80 - 4.30703973770142) - 1377.53815715323*std::sin(0.31047984957695*x_80 - 4.29623985290527) + 58.3976939806969*std::sin(0.32983985543251*x_80 + 5.12744045257568) + 158.796432847274*std::sin(0.37271985411644*x_80 - 7.41304016113281) + 0.771605716355902*std::sin(0.482399851083755*x_80 - 7.30615949630737) + 0.132756153947677*std::sin(0.496399849653244*x_80 - 7.31647968292236) + 77.1783370131974*std::sin(0.517439842224121*x_80 + 2.10879969596863) + 0.00710297875220724*std::sin(0.568239867687225*x_80 - 1.00951981544495) + 13.3865361629104*std::sin(0.710559844970703*x_80 - 7.24224042892456) - 0.480618758080862*std::sin(0.362319827079773*x_81 + 1.95999991893768) + 23.7333670854994*std::sin(0.535439848899841*x_81 + 2.15199971199036) + 51.9944767553883*std::sin(0.310879945755005*x_85 - 4.24671983718872) + 92.192017650068*std::sin(0.420799851417542*x_85 - 4.18016004562378) - 0.387020826731796*std::sin(0.708079874515533*x_87 + 5.34943962097168) + 0.609420096243264*std::sin(0.36167985200882*x_92 - 1.17719984054565) - 139.969306618428*std::sin(0.40871986746788*x_92 + 8.21111965179443) + 0.0546070896414353*std::sin(0.410719871520996*x_93 - 4.38527965545654) - 1.0174989027351*std::sin(0.357999861240387*x_95 + 5.17431974411011) - 0.048397851736059*std::sin(0.368399828672409*x_95 + 5.18304014205933) + 0.00696813282623802*std::sin(0.395359843969345*x_95 + 1.99887979030609) - 513.423415159761*std::sin(0.408159852027893*x_95 + 1.98855984210968) + 21.1218422472049*std::sin(0.361279845237732*x_96 - 7.42191982269287) + 0.0460973853685454*std::sin(0.368799835443497*x_96 + 5.18600034713745) + 808.797648469745*std::sin(0.373759835958481*x_96 + 5.1735200881958) + 5.63762418263908*std::sin(0.379359841346741*x_96 + 5.17080020904541) + 0.312507895147436*std::sin(0.443919867277145*x_96 - 7.36175966262817) + 49.6917201686364*std::sin(0.474479854106903*x_96 + 2.04111981391907) - 11.823369653781*std::sin(0.426079869270325*x_97 + 2.02439975738525) - 0.39248482364571*std::sin(0.44735985994339*x_99 + 2.00959992408752) - 17930.746119214 - 0.0005041010803011*std::exp(-3.23736000061035*x_74) - 0.266386147873183*std::exp(-3.12712001800537*x_74) - 0.149479101348897*std::exp(-2.99327993392944*x_74) - 0.00125216479669028*std::exp(-2.77376008033752*x_74) + 0.243290479101075*std::exp(-3.92463994026184*x_45) + 0.00990448347361955*std::exp(-3.88455986976624*x_45) - 0.0361603471688634*std::exp(-4.77167987823486*x_111) - 0.00181594666015652*std::exp(-4.69159984588623*x_111) - 1.52633414179539e-5*std::exp(-4.68919992446899*x_111) + 0.0392965150873149*std::exp(-4.61607980728149*x_111));
}

inline float score_9(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (5084.75604451029*x_1 - 302.797988410666*x_10 - 75.7079066095769*x_100 - 357.283642319168*x_101 - 573.877442814893*x_102 - 3.69325381730006*x_103 - 770.622859462271*x_104 + 515.909301291682*x_105 - 378.392998586286*x_106 - 267.774035721986*x_107 + 24.1648906596078*x_108 + 925.291454128986*x_109 + 803.623940762267*x_11 - 289.819291712908*x_110 + 166.18900327979*x_111 - 17.5915442929231*x_112 - 2119.8056318113*x_113 + 155.354037055815*x_114 - 664.561481620146*x_115 + 319.307220338108*x_116 - 552.844503424617*x_117 + 433.033268011046*x_118 - 31.3900061482468*x_119 + 1772.37923519384*x_12 + 218.212815507259*x_120 + 707.894369939629*x_13 - 322.319639042106*x_14 + 79.1851802847376*x_15 + 56.8563421644259*x_16 - 443.259861187743*x_17 - 85.2801342664276*x_18 + 60.6966808842466*x_19 + 39.3709550560594*x_2 + 929.16966839219*x_20 + 2105.16400960831*x_21 - 1952.5524605038*x_22 + 4.41372882533164*x_23 - 801.111276465905*x_24 + 48.3688709323877*x_25 - 100.060297928692*x_26 - 569.166252250693*x_27 + 281.164699431586*x_28 - 763.829355338063*x_29 - 167.726778966605*x_3 - 677.557970734254*x_30 + 32459.3540480418*x_31 - 661.462137584735*x_32 + 414.770412475632*x_33 + 22.1147466191608*x_34 - 650.052374004674*x_35 + 87.9208963581153*x_36 - 685.428781376876*x_37 - 476.667255492285*x_38 + 711.715566182244*x_39 - 83.983897900597*x_4 + 200.55024944657*x_40 + 67.3021990059966*x_41 + 503289.96432433*x_42 - 507.206582434836*x_43 + 278.732241348704*x_44 - 1072.51043612021*x_45 - 436.871083113817*x_46 + 1910.3330395272*x_47 + 1953.18783727689*x_48 - 687.307199577184*x_49 - 400.259177791155*x_5 + 765.645664288456*x_50 + 705.856607725585*x_51 + 2199.42674477207*x_52 + 36.1781806756864*x_53 - 558.228765303565*x_54 - 1068.87888862335*x_55 - 18.0454135163514*x_56 + 2115.03785301238*x_57 - 150.087706581524*x_58 + 443.883413031151*x_59 + 29.3415583101902*x_6 - 681.556624577296*x_60 + 210.633215790244*x_61 - 1169.97564176433*x_62 - 2.92349395413326*x_63 + 170.945939249362*x_64 + 346.680783778059*x_65 + 705.556366869031*x_66 - 888.137350577854*x_67 - 1387.71514772725*x_68 - 512.095067466066*x_69 - 69.8424369018255*x_7 + 7089.76851992687*x_70 - 669.791370984791*x_72 + 222.767201008315*x_73 + 311.0811033381*x_74 + 475.119165843926*x_75 + 1918.34554607337*x_76 + 737.54608459442*x_77 + 68.865255373866*x_78 - 508.217814135638*x_79 + 3537.90931188154*x_8 - 405.423928313306*x_80 - 724.376261649646*x_81 + 88.5990335933477*x_82 - 241.746654031662*x_83 - 1280.70644924117*x_84 + 627.343650535014*x_85 - 596.049494715925*x_86 - 568.393987044867*x_87 - 1017.94716421118*x_88 + 1347.7426415582*x_89 - 3609.28053749515*x_9 - 332.515696070789*x_90 + 22.8310257364401*x_91 + 498.366579615549*x_92 + 57.2584623185402*x_93 + 638.559549048799*x_94 - 30.6469613881423*x_95 - 191.232743575617*x_96 - 901.780600280675*x_97 + 166.467673687587*x_98 - 388.897184171447*x_99 + 0.000379421570387423*std::pow(-6.10439968109131*x_115 - 9.13776016235352, 2) + 0.0106526878825394*std::pow(-3.79663991928101*x_15 - 5.39775991439819, 2) + 3.35947971082501*std::pow(-5.44127988815308*x_23 - 7.45175981521606, 2) + 7.89189865853776e-5*std::pow(-5.54735994338989*x_77 - 8.12199974060059, 2) - 2.69983164603831*std::pow(-4.89847993850708*x_85 - 6.53056001663208, 2) - 2.97263076383734*std::exp(0.736559867858887*x_108) + 0.0821527823636823*std::exp(2.52023983001709*x_71) - 0.000393074035705818*std::exp(2.53288006782532*x_71) + 0.000816486066194847*std::exp(2.54391980171204*x_71) + 0.0302381366510331*std::exp(2.55216002464294*x_71) - 0.00996910632674366*std::exp(2.5849597454071*x_71) + 0.0264431870691916*std::exp(2.58639979362488*x_71) - 44.130258489874*std::exp(2.59751987457275*x_71) - 2.42173334155971*std::exp(2.60303997993469*x_71) + 0.0304041545908838*std::exp(2.60527992248535*x_71) + 7.6533760856763*std::exp(2.61863994598389*x_71) - 0.0192863738505914*std::exp(2.62951993942261*x_71) + 1.32613636614934*std::exp(2.63624000549316*x_71) + 2.23284909640975*std::exp(2.65231990814209*x_71) - 10.3418175259069*std::exp(2.67671990394592*x_71) - 1.29927824259316*std::exp(2.68367981910706*x_71) + 0.0184192064840432*std::exp(1.35743987560272*x_76) - 5744.76386114134*std::sin(0.317119836807251*x_103 + 1.93383991718292) + 0.902436646858971*std::sin(0.500719845294952*x_103 + 5.25192022323608) - 25.7058679923315*std::sin(0.511439859867096*x_103 - 1.02791976928711) - 0.47107222774911*std::sin(0.364719837903976*x_105 + 5.15799999237061) - 0.594215482274799*std::sin(0.409359842538834*x_105 + 5.19928026199341) - 9.88648881709791*std::sin(0.178240016102791*x_106 - 7.61064004898071) + 0.0348308496197646*std::sin(0.413999855518341*x_106 + 2.01239991188049) - 15.6911223762338*std::sin(0.521679878234863*x_106 - 7.24088001251221) - 0.403315985718535*std::sin(0.608319878578186*x_106 - 0.998319804668427) - 4824.08814122598*std::sin(0.318959832191467*x_112 + 1.93887984752655) + 98.1867332248385*std::sin(0.291759938001633*x_115 - 7.5033597946167) - 23.491178136089*std::sin(0.424159854650497*x_115 - 4.19056034088135) + 116.250503755111*std::sin(0.3713598549366*x_119 - 7.40855979919434) + 736.227082061686*std::sin(0.335279852151871*x_16 - 4.25288009643555) + 0.0452809848972404*std::sin(0.425439864397049*x_16 + 2.00127983093262) - 0.380893559746576*std::sin(0.413759857416153*x_21 - 1.167839884758) + 13.063252840638*std::sin(0.429599851369858*x_21 - 1.1561598777771) - 37.01186581055*std::sin(0.298399925231934*x_28 + 5.13191986083984) + 3.51753597011272*std::sin(0.314399927854538*x_28 + 5.14447975158691) - 1769.29393321422*std::sin(0.328799843788147*x_28 - 4.27672004699707) - 2.05625406373143*std::sin(0.332959830760956*x_28 + 5.14264011383057) + 0.855561671748893*std::sin(0.340399831533432*x_28 + 5.14807987213135) - 150.088626011161*std::sin(0.343279838562012*x_28 + 5.15431976318359) + 0.0198673522694709*std::sin(0.359119862318039*x_28 + 5.16559982299805) + 1.67340072552105*std::sin(0.360319852828979*x_28 + 5.16567993164063) - 215.670847737973*std::sin(0.282959938049316*x_32 + 1.94863975048065) - 28.341956241456*std::sin(0.314079910516739*x_34 - 1.11303985118866) - 176.950141424015*std::sin(0.349199831485748*x_34 + 2.00455975532532) + 0.0162657190691355*std::sin(0.354799836874008*x_34 + 1.97967982292175) + 0.0134111412000518*std::sin(0.31551992893219*x_36 - 7.47928047180176) + 14.7611694462678*std::sin(0.389759838581085*x_36 - 7.39135980606079) + 0.779701202036349*std::sin(0.410719871520996*x_36 + 2.01095986366272) + 12.075993317665*std::sin(0.412559866905212*x_36 + 5.19296026229858) + 0.336635861598791*std::sin(0.422959864139557*x_45 + 5.2304801940918) + 0.0207312931937639*std::sin(0.519839882850647*x_47 + 2.12175989151001) + 1.72316524203876*std::sin(0.319039851427078*x_53 - 4.28480005264282) + 0.0631847035838813*std::sin(0.344319850206375*x_53 + 5.14800024032593) + 3055.59833980194*std::sin(0.510559856891632*x_53 + 2.09687995910645) - 60.2270570819419*std::sin(0.533279836177826*x_53 - 1.02551984786987) - 0.0303505611602565*std::sin(0.48295983672142*x_55 - 4.12296009063721) + 3.66010045384889*std::sin(0.32415983080864*x_56 + 8.32760047912598) - 0.0331385116467478*std::sin(0.431999862194061*x_59 + 2.02600002288818) + 0.0808647376990268*std::sin(0.198319986462593*x_6 + 4.98751974105835) - 8.09237740156459*std::sin(0.181840002536774*x_64 - 4.4115195274353) - 9751.00721685711*std::sin(0.19463999569416*x_64 - 4.41431999206543) + 1.100819156216*std::sin(0.197919994592667*x_64 - 4.38776016235352) - 0.838803582365157*std::sin(0.220159992575645*x_64 - 4.36287975311279) + 171.585199576889*std::sin(0.311039924621582*x_65 + 1.91295993328094) + 2.67982433131174*std::sin(0.168160021305084*x_67 + 4.94855976104736) - 21.643481061691*std::sin(0.567279815673828*x_75 - 7.22448015213013) + 3336.76470503937*std::sin(0.415999859571457*x_78 - 4.19112014770508) + 2.94610811828193*std::sin(0.141520038247108*x_80 + 4.9081597328186) - 13.7157914823149*std::sin(0.145120039582253*x_80 - 7.66784000396729) - 189.835176834441*std::sin(0.277919948101044*x_80 - 4.30703973770142) - 975.325848977385*std::sin(0.31047984957695*x_80 - 4.29623985290527) - 21.2233543538555*std::sin(0.32983985543251*x_80 + 5.12744045257568) + 133.408916149026*std::sin(0.37271985411644*x_80 - 7.41304016113281) - 1.81712520707428*std::sin(0.482399851083755*x_80 - 7.30615949630737) + 0.263441535108718*std::sin(0.496399849653244*x_80 - 7.31647968292236) + 75.7437427899543*std::sin(0.517439842224121*x_80 + 2.10879969596863) - 0.0105933786396974*std::sin(0.568239867687225*x_80 - 1.00951981544495) + 11.3971268954729*std::sin(0.710559844970703*x_80 - 7.24224042892456) - 0.336374662722432*std::sin(0.362319827079773*x_81 + 1.95999991893768) + 20.2062873501003*std::sin(0.535439848899841*x_81 + 2.15199971199036) - 18.8962462282786*std::sin(0.310879945755005*x_85 - 4.24671983718872) + 77.4528554058679*std::sin(0.420799851417542*x_85 - 4.18016004562378) - 0.155396217300372*std::sin(0.708079874515533*x_87 + 5.34943962097168) - 1.43517938645038*std::sin(0.36167985200882*x_92 - 1.17719984054565) - 137.367551171537*std::sin(0.40871986746788*x_92 + 8.21111965179443) - 0.0485171501808363*std::sin(0.410719871520996*x_93 - 4.38527965545654) + 1.62440976407721*std::sin(0.357999861240387*x_95 + 5.17431974411011) + 0.0430003843187148*std::sin(0.368399828672409*x_95 + 5.18304014205933) - 0.0103922694992022*std::sin(0.395359843969345*x_95 + 1.99887979030609) + 2769.76173547297*std::sin(0.408159852027893*x_95 + 1.98855984210968) + 17.9828682661413*std::sin(0.361279845237732*x_96 - 7.42191982269287) - 0.0409564725671181*std::sin(0.368799835443497*x_96 + 5.18600034713745) - 4363.21506251316*std::sin(0.373759835958481*x_96 + 5.1735200881958) + 2.26361325291243*std::sin(0.379359841346741*x_96 + 5.17080020904541) + 0.620141192578404*std::sin(0.443919867277145*x_96 - 7.36175966262817) + 33.8187761961606*std::sin(0.474479854106903*x_96 + 2.04111981391907) + 4.29694302486947*std::sin(0.426079869270325*x_97 + 2.02439975738525) - 0.778847543962833*std::sin(0.44735985994339*x_99 + 2.00959992408752) + 1161774.71931196 - 0.000352809431619744*std::exp(-3.23736000061035*x_74) - 0.947561636200907*std::exp(-3.12712001800537*x_74) - 0.14670057743157*std::exp(-2.99327993392944*x_74) - 0.0024847979279303*std::exp(-2.77376008033752*x_74) + 0.172254751598127*std::exp(-3.92463994026184*x_45) - 0.00359956614934173*std::exp(-3.88455986976624*x_45) - 0.0256022826799024*std::exp(-4.77167987823486*x_111) + 0.000659965776541481*std::exp(-4.69159984588623*x_111) - 3.02886003734262e-5*std::exp(-4.68919992446899*x_111) - 0.211992637290243*std::exp(-4.61607980728149*x_111));
}

inline float score_10(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (11090.1435238659*x_1 - 55.9778840241092*x_10 + 83.06284215388*x_100 - 300.873073648918*x_101 - 394.466366536841*x_102 + 59.2661769376574*x_103 - 1244.69697109468*x_104 + 410.094547648456*x_105 - 708.289203013795*x_106 - 247.021851833219*x_107 + 18.0514391835821*x_108 + 1542.2967578438*x_109 + 873.63627643543*x_11 - 739.345140946881*x_110 - 68.0796737098778*x_111 + 237.677531290105*x_112 - 1881.86290619591*x_113 + 400.327225893936*x_114 - 1165.16818348121*x_115 + 408.598096516709*x_116 - 944.663774861957*x_117 + 256.514583799829*x_118 - 429.211326392873*x_119 + 3359.23247142362*x_12 + 792.322752417709*x_120 + 1358.26570974938*x_13 - 393.371172781732*x_14 + 57.6595505583538*x_15 - 249.732502538488*x_16 - 784.591268381621*x_17 - 4.40736834368727*x_18 + 113.929532027363*x_19 - 18.8066457898382*x_2 + 1107.9502444434*x_20 + 3891.23615174572*x_21 - 2088.5600042459*x_22 + 369.936183775143*x_23 - 1082.66050426577*x_24 + 210.464820833701*x_25 - 26.8708927365324*x_26 - 806.045296955983*x_27 + 157.210234079108*x_28 - 896.065453955206*x_29 - 927.762333163054*x_3 - 893.234319973549*x_30 + 55196.3275411518*x_31 - 778.795816299652*x_32 + 310.238523742887*x_33 + 281.314995468804*x_34 - 648.8273602611*x_35 - 22.8897204344228*x_36 + 1141.29340252194*x_37 - 852.822806630117*x_38 + 1344.39140385802*x_39 - 217.742879556897*x_4 + 291.490541241472*x_40 + 551.68093356336*x_41 + 650676.558836675*x_42 - 52.7972495508596*x_43 + 735.1204988825*x_44 - 1194.7543740459*x_45 - 490.843089577922*x_46 + 2548.99565024473*x_47 + 1473.84516471814*x_48 - 1409.91059557662*x_49 - 350.565021550656*x_5 + 780.378400687564*x_50 + 804.668861448092*x_51 + 2628.89785070765*x_52 - 65.3410459232572*x_53 - 768.791501260521*x_54 - 1089.49360360403*x_55 + 85.8342775711134*x_56 + 1281.25190754535*x_57 - 231.869616208911*x_58 + 374.242146499218*x_59 - 201.013911152081*x_6 - 969.595645377131*x_60 + 356.772237152018*x_61 - 1619.71251542833*x_62 - 499.530199863146*x_63 + 103.872309781572*x_64 + 506.638383998962*x_65 + 667.549992395948*x_66 - 1140.18405501278*x_67 - 1065.40936020512*x_68 - 934.286789805586*x_69 + 51.1849960326671*x_7 - 4787.43758356784*x_70 - 599.185416915494*x_72 + 303.391182499036*x_73 + 369.723270782023*x_74 + 346.690003143667*x_75 + 2362.28995305645*x_76 + 774.392580156293*x_77 - 215.977142320129*x_78 - 489.563604205916*x_79 + 5374.04453028026*x_8 - 486.709196959723*x_80 - 992.470554314154*x_81 + 36.1767372897743*x_82 - 360.744742930957*x_83 - 2965.54841320892*x_84 + 547.989999934692*x_85 - 449.661565461409*x_86 - 572.614419753565*x_87 - 795.157884550619*x_88 + 2185.56068998922*x_89 - 4126.5391789457*x_9 - 226.644216106615*x_90 + 595.341836157635*x_91 + 407.523331184884*x_92 + 42.8552033665404*x_93 + 958.552236220541*x_94 - 145.753893612894*x_95 - 304.322461145988*x_96 - 909.591428276392*x_97 + 273.697818641655*x_98 - 758.40280273787*x_99 + 0.000516451030693199*std::pow(-6.10439968109131*x_115 - 9.13776016235352, 2) - 0.00159261078988092*std::pow(-3.79663991928101*x_15 - 5.39775991439819, 2) + 3.9611591948995*std::pow(-5.44127988815308*x_23 - 7.45175981521606, 2) - 0.000189000408198392*std::pow(-5.54735994338989*x_77 - 8.12199974060059, 2) - 4.83462407701868*std::pow(-4.89847993850708*x_85 - 6.53056001663208, 2) - 16.1121296953275*std::exp(0.736559867858887*x_108) + 0.445281095916187*std::exp(2.52023983001709*x_71) - 0.000664644447389179*std::exp(2.53288006782532*x_71) - 0.00195537482773147*std::exp(2.54391980171204*x_71) - 0.00452069780203201*std::exp(2.55216002464294*x_71) - 0.01356948481416*std::exp(2.5849597454071*x_71) - 0.0392955284077916*std::exp(2.58639979362488*x_71) - 52.0339440143628*std::exp(2.59751987457275*x_71) - 1.41790556775231*std::exp(2.60303997993469*x_71) + 0.0863782174241803*std::exp(2.60527992248535*x_71) - 3.49862854202236*std::exp(2.61863994598389*x_71) - 0.0347662033009888*std::exp(2.62951993942261*x_71) - 1.59865813989486*std::exp(2.63624000549316*x_71) + 0.31553994801869*std::exp(2.65231990814209*x_71) - 18.5192288134894*std::exp(2.67671990394592*x_71) - 0.348152293834978*std::exp(2.68367981910706*x_71) + 0.0250713689354081*std::exp(1.35743987560272*x_76) - 6773.64537066905*std::sin(0.317119836807251*x_103 + 1.93383991718292) + 1.62675970993892*std::sin(0.500719845294952*x_103 + 5.25192022323608) + 30.9884384125062*std::sin(0.511439859867096*x_103 - 1.02791976928711) - 0.641201651512731*std::sin(0.364719837903976*x_105 + 5.15799999237061) - 1.07115087685222*std::sin(0.409359842538834*x_105 + 5.19928026199341) - 28.0875193570112*std::sin(0.178240016102791*x_106 - 7.61064004898071) - 0.083415222126687*std::sin(0.413999855518341*x_106 + 2.01239991188049) + 18.9156569046442*std::sin(0.521679878234863*x_106 - 7.24088001251221) - 0.727029646042005*std::sin(0.608319878578186*x_106 - 0.998319804668427) - 5688.07754249846*std::sin(0.318959832191467*x_112 + 1.93887984752655) + 13.8754727078094*std::sin(0.291759938001633*x_115 - 7.5033597946167) + 28.3186285374439*std::sin(0.424159854650497*x_115 - 4.19056034088135) + 68.0637433113191*std::sin(0.3713598549366*x_119 - 7.40855979919434) + 1318.37152968838*std::sin(0.335279852151871*x_16 - 4.25288009643555) - 0.108441897184591*std::sin(0.425439864397049*x_16 + 2.00127983093262) - 0.518454634286236*std::sin(0.413759857416153*x_21 - 1.167839884758) + 70.8049000137213*std::sin(0.429599851369858*x_21 - 1.1561598777771) + 44.6178251807845*std::sin(0.298399925231934*x_28 + 5.13191986083984) - 0.525882838356504*std::sin(0.314399927854538*x_28 + 5.14447975158691) - 3168.29794235221*std::sin(0.328799843788147*x_28 - 4.27672004699707) - 3.70666603126016*std::sin(0.332959830760956*x_28 + 5.14264011383057) - 1.27139545958876*std::sin(0.340399831533432*x_28 + 5.14807987213135) - 40.2174820691489*std::sin(0.343279838562012*x_28 + 5.15431976318359) - 0.0475796490960893*std::sin(0.359119862318039*x_28 + 5.16559982299805) + 4.75413224448535*std::sin(0.360319852828979*x_28 + 5.16567993164063) - 57.7907779040838*std::sin(0.282959938049316*x_32 + 1.94863975048065) + 34.1662442886702*std::sin(0.314079910516739*x_34 - 1.11303985118866) - 103.602897327283*std::sin(0.349199831485748*x_34 + 2.00455975532532) + 0.0275035206603782*std::sin(0.354799836874008*x_34 + 1.97967982292175) - 0.0321178878605328*std::sin(0.31551992893219*x_36 - 7.47928047180176) - 17.7945981212809*std::sin(0.389759838581085*x_36 - 7.39135980606079) + 1.40551306917603*std::sin(0.410719871520996*x_36 + 2.01095986366272) + 65.453796987204*std::sin(0.412559866905212*x_36 + 5.19296026229858) + 0.458213109796226*std::sin(0.422959864139557*x_45 + 5.2304801940918) + 0.0350543095111595*std::sin(0.519839882850647*x_47 + 2.12175989151001) + 3.10623000414772*std::sin(0.319039851427078*x_53 - 4.28480005264282) - 0.151318906716177*std::sin(0.344319850206375*x_53 + 5.14800024032593) + 3602.85297173404*std::sin(0.510559856891632*x_53 + 2.09687995910645) - 16.1383354131744*std::sin(0.533279836177826*x_53 - 1.02551984786987) + 0.0726855310303943*std::sin(0.48295983672142*x_55 - 4.12296009063721) + 10.3983471025928*std::sin(0.32415983080864*x_56 + 8.32760047912598) - 0.056033535059631*std::sin(0.431999862194061*x_59 + 2.02600002288818) + 0.136733271646223*std::sin(0.198319986462593*x_6 + 4.98751974105835) + 1.20983621294723*std::sin(0.181840002536774*x_64 - 4.4115195274353) - 11497.4029377601*std::sin(0.19463999569416*x_64 - 4.41431999206543) + 1.98437004691034*std::sin(0.197919994592667*x_64 - 4.38776016235352) - 1.14174050310133*std::sin(0.220159992575645*x_64 - 4.36287975311279) - 78.4376554749249*std::sin(0.311039924621582*x_65 + 1.91295993328094) - 3.98231547745773*std::sin(0.168160021305084*x_67 + 4.94855976104736) - 12.6720856405885*std::sin(0.567279815673828*x_75 - 7.22448015213013) + 3934.37595410777*std::sin(0.415999859571457*x_78 - 4.19112014770508) + 4.0101056264848*std::sin(0.141520038247108*x_80 + 4.9081597328186) - 38.9665700213003*std::sin(0.145120039582253*x_80 - 7.66784000396729) - 111.146982852968*std::sin(0.277919948101044*x_80 - 4.30703973770142) - 1746.52883979783*std::sin(0.31047984957695*x_80 - 4.29623985290527) - 115.033943024188*std::sin(0.32983985543251*x_80 + 5.12744045257568) + 18.852972435343*std::sin(0.37271985411644*x_80 - 7.41304016113281) + 0.271666009861656*std::sin(0.482399851083755*x_80 - 7.30615949630737) - 0.391483609731668*std::sin(0.496399849653244*x_80 - 7.31647968292236) + 20.2961589992748*std::sin(0.517439842224121*x_80 + 2.10879969596863) - 0.0179122242946504*std::sin(0.568239867687225*x_80 - 1.00951981544495) - 13.7392429224813*std::sin(0.710559844970703*x_80 - 7.24224042892456) - 0.457857578009317*std::sin(0.362319827079773*x_81 + 1.95999991893768) - 24.3586908359127*std::sin(0.535439848899841*x_81 + 2.15199971199036) - 102.420648298696*std::sin(0.310879945755005*x_85 - 4.24671983718872) + 10.9454194678733*std::sin(0.420799851417542*x_85 - 4.18016004562378) - 0.441480726087722*std::sin(0.708079874515533*x_87 + 5.34943962097168) + 0.214563892369545*std::sin(0.36167985200882*x_92 - 1.17719984054565) - 36.8087654137986*std::sin(0.40871986746788*x_92 + 8.21111965179443) + 0.116192079822015*std::sin(0.410719871520996*x_93 - 4.38527965545654) + 2.92821038000816*std::sin(0.357999861240387*x_95 + 5.17431974411011) - 0.10298016409692*std::sin(0.368399828672409*x_95 + 5.18304014205933) - 0.0175721711204198*std::sin(0.395359843969345*x_95 + 1.99887979030609) + 3265.82331507971*std::sin(0.408159852027893*x_95 + 1.98855984210968) - 21.678357871898*std::sin(0.361279845237732*x_96 - 7.42191982269287) + 0.0980852690648438*std::sin(0.368799835443497*x_96 + 5.18600034713745) - 5144.66255250984*std::sin(0.373759835958481*x_96 + 5.1735200881958) + 6.43092631106905*std::sin(0.379359841346741*x_96 + 5.17080020904541) - 0.921552148235491*std::sin(0.443919867277145*x_96 - 7.36175966262817) + 19.8006238920682*std::sin(0.474479854106903*x_96 + 2.04111981391907) + 23.2901119615534*std::sin(0.426079869270325*x_97 + 2.02439975738525) + 1.15739550263167*std::sin(0.44735985994339*x_99 + 2.00959992408752) + 1281850.77180169 - 0.000480227822609683*std::exp(-3.23736000061035*x_74) + 0.433163893767407*std::exp(-3.12712001800537*x_74) - 0.039309626579893*std::exp(-2.99327993392944*x_74) + 0.00369249921762899*std::exp(-2.77376008033752*x_74) + 0.308458851750699*std::exp(-3.92463994026184*x_45) - 0.0195102188104375*std::exp(-3.88455986976624*x_45) - 0.0458463446980197*std::exp(-4.77167987823486*x_111) + 0.00357711906755188*std::exp(-4.69159984588623*x_111) + 4.50099510808552e-5*std::exp(-4.68919992446899*x_111) - 0.249960308361863*std::exp(-4.61607980728149*x_111));
}

inline float score_11(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (26049.0776743952*x_1 + 1340.22584647482*x_10 + 1154.73386946021*x_100 + 513.245913377395*x_101 + 1338.00005798391*x_102 + 240.848015714623*x_103 - 1498.49464489717*x_104 - 844.0770257104*x_105 - 1088.65080910312*x_106 + 445.605418465681*x_107 + 54.5245319340291*x_108 + 1206.24780978789*x_109 - 556.000917178762*x_11 - 1386.61797307332*x_110 - 1188.0030250445*x_111 + 1067.96622356609*x_112 + 2809.46660167801*x_113 + 1009.77476329808*x_114 - 1303.95191820297*x_115 - 1104.77742628386*x_116 - 1230.97976841875*x_117 - 999.385707394701*x_118 - 1626.34057898443*x_119 + 4242.02732193833*x_12 + 2369.56461328259*x_120 + 2114.61199879138*x_13 + 60.6079699176319*x_14 + 83.5279946817699*x_15 - 1394.02775711728*x_16 - 927.63024878872*x_17 + 354.955513787549*x_18 + 146.099660411369*x_19 - 288.69416698087*x_2 - 129.43306021779*x_20 + 4316.64550682795*x_21 + 1537.27863973206*x_22 + 1227.44378973204*x_23 - 299.242729727491*x_24 + 775.691182409885*x_25 + 377.980450340905*x_26 - 385.839045186151*x_27 - 792.618057518065*x_28 - 46.2957239465459*x_29 - 2855.70560266387*x_3 - 909.360587417044*x_30 + 53508.1173103549*x_31 + 95.792525269379*x_32 - 824.170412426599*x_33 + 1158.51660070843*x_34 + 437.608312354458*x_35 - 574.884631926978*x_36 + 7055.20941320626*x_37 - 1247.70633380434*x_38 + 1728.24830471229*x_39 - 673.481711261382*x_4 + 344.802082929958*x_40 + 2042.88506636646*x_41 - 81027.8384773465*x_42 + 2511.35320618102*x_43 + 1919.82908600504*x_44 + 645.310889544544*x_45 + 262.048974076527*x_46 + 1310.21927243923*x_47 - 4244.78229775335*x_48 - 2585.17668647671*x_49 + 671.00744946846*x_5 - 549.842230400367*x_50 + 283.187391222073*x_51 - 19.1499850775714*x_52 - 416.236463419263*x_53 - 1031.59008878585*x_54 + 1040.1994666346*x_55 + 448.650986924381*x_56 - 5109.64119156156*x_57 - 516.538163596253*x_58 - 817.350196919014*x_59 - 1048.99087524673*x_6 - 458.265316859786*x_60 + 443.083404794622*x_61 - 1030.2564538567*x_62 - 1921.32423158232*x_63 - 566.636790283438*x_64 + 132.304368610172*x_65 - 931.794688883852*x_66 - 333.199772473421*x_67 + 2569.90094348858*x_68 - 1223.86919947155*x_69 + 546.69230635043*x_7 - 59815.070193113*x_70 + 864.925252609325*x_72 - 397.483113371465*x_73 - 53.7259061470778*x_74 - 1179.94209965135*x_75 + 650.037653092211*x_76 - 559.821166635146*x_77 - 1223.73293637724*x_78 + 439.581910983974*x_79 + 4875.86975542448*x_8 + 25.438373364978*x_80 - 741.096728325662*x_81 - 387.31078308222*x_82 - 298.748884796192*x_83 - 6973.32047601766*x_84 - 1121.50297520174*x_85 + 987.537303496322*x_86 + 749.578816147421*x_87 + 1849.87589681185*x_88 + 2111.88628650566*x_89 + 470.688813456816*x_9 + 223.536919629704*x_90 + 2389.16894677112*x_91 - 682.130008859291*x_92 - 197.571264459043*x_93 + 872.496243221602*x_94 - 339.473705058908*x_95 - 65.5740722125235*x_96 + 1661.22004347073*x_97 + 581.777641404537*x_98 - 1038.42990675332*x_99 + 0.00134910974516372*std::pow(-6.10439968109131*x_115 - 9.13776016235352, 2) - 0.00949412265002953*std::pow(-3.79663991928101*x_15 - 5.39775991439819, 2) - 0.531966897291256*std::pow(-5.44127988815308*x_23 - 7.45175981521606, 2) - 0.000405450531418651*std::pow(-5.54735994338989*x_77 - 8.12199974060059, 2) - 4.39754791669374*std::pow(-4.89847993850708*x_85 - 6.53056001663208, 2) - 0.560473980702114*std::exp(0.736559867858887*x_108) + 0.0154894773738024*std::exp(2.52023983001709*x_71) - 0.000149839038901058*std::exp(2.53288006782532*x_71) - 0.00419474100920553*std::exp(2.54391980171204*x_71) - 0.0269494968066995*std::exp(2.55216002464294*x_71) - 0.0354471636450457*std::exp(2.5849597454071*x_71) - 0.0206436816129852*std::exp(2.58639979362488*x_71) + 6.98793822444436*std::exp(2.59751987457275*x_71) - 0.279328979292179*std::exp(2.60303997993469*x_71) + 0.00287557440675103*std::exp(2.60527992248535*x_71) - 57.2052825481921*std::exp(2.61863994598389*x_71) - 0.00935756055761593*std::exp(2.62951993942261*x_71) + 0.735848306193039*std::exp(2.63624000549316*x_71) - 2.51654458377974*std::exp(2.65231990814209*x_71) - 16.8449903839794*std::exp(2.67671990394592*x_71) + 1.16210060638506*std::exp(2.68367981910706*x_71) + 0.0654931951824248*std::exp(1.35743987560272*x_76) + 909.671874795103*std::sin(0.317119836807251*x_103 + 1.93383991718292) + 0.43785346264745*std::sin(0.500719845294952*x_103 + 5.25192022323608) - 14.2637061347648*std::sin(0.511439859867096*x_103 - 1.02791976928711) - 1.67499210043166*std::sin(0.364719837903976*x_105 + 5.15799999237061) - 0.28830755862844*std::sin(0.409359842538834*x_105 + 5.19928026199341) - 0.935047680082548*std::sin(0.178240016102791*x_106 - 7.61064004898071) - 0.178945360288157*std::sin(0.413999855518341*x_106 + 2.01239991188049) - 8.70671080105128*std::sin(0.521679878234863*x_106 - 7.24088001251221) - 0.195684984095651*std::sin(0.608319878578186*x_106 - 0.998319804668427) + 763.884714790349*std::sin(0.318959832191467*x_112 + 1.93887984752655) - 110.661885791251*std::sin(0.291759938001633*x_115 - 7.5033597946167) - 13.0348160891724*std::sin(0.424159854650497*x_115 - 4.19056034088135) + 13.4086333944609*std::sin(0.3713598549366*x_119 - 7.40855979919434) + 1199.18361416523*std::sin(0.335279852151871*x_16 - 4.25288009643555) - 0.23263349143345*std::sin(0.425439864397049*x_16 + 2.00127983093262) - 1.35434369954113*std::sin(0.413759857416153*x_21 - 1.167839884758) + 2.46300798927991*std::sin(0.429599851369858*x_21 - 1.1561598777771) - 20.5371932034554*std::sin(0.298399925231934*x_28 + 5.13191986083984) - 3.13497572578648*std::sin(0.314399927854538*x_28 + 5.14447975158691) - 2881.86667544331*std::sin(0.328799843788147*x_28 - 4.27672004699707) - 0.997674424040096*std::sin(0.332959830760956*x_28 + 5.14264011383057) - 0.667920349602455*std::sin(0.340399831533432*x_28 + 5.14807987213135) + 134.242287434105*std::sin(0.343279838562012*x_28 + 5.15431976318359) - 0.1020695891327*std::sin(0.359119862318039*x_28 + 5.16559982299805) + 0.158267459276428*std::sin(0.360319852828979*x_28 + 5.16567993164063) + 192.900346299694*std::sin(0.282959938049316*x_32 + 1.94863975048065) - 15.7264222796558*std::sin(0.314079910516739*x_34 - 1.11303985118866) - 20.4098863988648*std::sin(0.349199831485748*x_34 + 2.00455975532532) + 0.00620045968688186*std::sin(0.354799836874008*x_34 + 1.97967982292175) - 0.0689004580742936*std::sin(0.31551992893219*x_36 - 7.47928047180176) + 8.19069728553195*std::sin(0.389759838581085*x_36 - 7.39135980606079) + 0.378303421442665*std::sin(0.410719871520996*x_36 + 2.01095986366272) + 2.27686537057388*std::sin(0.412559866905212*x_36 + 5.19296026229858) + 1.19697654772442*std::sin(0.422959864139557*x_45 + 5.2304801940918) + 0.00790272764201216*std::sin(0.519839882850647*x_47 + 2.12175989151001) + 0.836062975242085*std::sin(0.319039851427078*x_53 - 4.28480005264282) - 0.324614807590057*std::sin(0.344319850206375*x_53 + 5.14800024032593) - 483.847889586918*std::sin(0.510559856891632*x_53 + 2.09687995910645) + 53.8682918418022*std::sin(0.533279836177826*x_53 - 1.02551984786987) + 0.155927637742377*std::sin(0.48295983672142*x_55 - 4.12296009063721) + 0.346166217507045*std::sin(0.32415983080864*x_56 + 8.32760047912598) - 0.0126323345851224*std::sin(0.431999862194061*x_59 + 2.02600002288818) + 0.0308254768241082*std::sin(0.198319986462593*x_6 + 4.98751974105835) + 7.21226646532206*std::sin(0.181840002536774*x_64 - 4.4115195274353) + 1544.05250250559*std::sin(0.19463999569416*x_64 - 4.41431999206543) + 0.534106722034687*std::sin(0.197919994592667*x_64 - 4.38776016235352) - 2.98253493097816*std::sin(0.220159992575645*x_64 - 4.36287975311279) - 1282.51633174727*std::sin(0.311039924621582*x_65 + 1.91295993328094) - 2.09208671139284*std::sin(0.168160021305084*x_67 + 4.94855976104736) - 2.49641501380085*std::sin(0.567279815673828*x_75 - 7.22448015213013) - 528.370021527785*std::sin(0.415999859571457*x_78 - 4.19112014770508) + 10.4754802649245*std::sin(0.141520038247108*x_80 + 4.9081597328186) - 1.29721676151141*std::sin(0.145120039582253*x_80 - 7.66784000396729) - 21.8960796669559*std::sin(0.277919948101044*x_80 - 4.30703973770142) - 1588.63318813295*std::sin(0.31047984957695*x_80 - 4.29623985290527) - 4.00155244413929*std::sin(0.32983985543251*x_80 + 5.12744045257568) - 150.359236503078*std::sin(0.37271985411644*x_80 - 7.41304016113281) + 1.61949826904259*std::sin(0.482399851083755*x_80 - 7.30615949630737) - 0.205663680410015*std::sin(0.496399849653244*x_80 - 7.31647968292236) - 67.746727791271*std::sin(0.517439842224121*x_80 + 2.10879969596863) - 0.00403817482179165*std::sin(0.568239867687225*x_80 - 1.00951981544495) + 6.32405289197569*std::sin(0.710559844970703*x_80 - 7.24224042892456) - 1.19604780255803*std::sin(0.362319827079773*x_81 + 1.95999991893768) + 11.21209153188*std::sin(0.535439848899841*x_81 + 2.15199971199036) - 3.56278838015489*std::sin(0.310879945755005*x_85 - 4.24671983718872) - 87.2936572755043*std::sin(0.420799851417542*x_85 - 4.18016004562378) - 0.0146971159497017*std::sin(0.708079874515533*x_87 + 5.34943962097168) + 1.27909211928454*std::sin(0.36167985200882*x_92 - 1.17719984054565) + 122.864302103194*std::sin(0.40871986746788*x_92 + 8.21111965179443) + 0.249259464355354*std::sin(0.410719871520996*x_93 - 4.38527965545654) + 0.788147780162886*std::sin(0.357999861240387*x_95 + 5.17431974411011) - 0.220916783496298*std::sin(0.368399828672409*x_95 + 5.18304014205933) - 0.00396151241830341*std::sin(0.395359843969345*x_95 + 1.99887979030609) - 438.586234620766*std::sin(0.408159852027893*x_95 + 1.98855984210968) + 9.97835780083152*std::sin(0.361279845237732*x_96 - 7.42191982269287) + 0.210416077117344*std::sin(0.368799835443497*x_96 + 5.18600034713745) + 690.906383967889*std::sin(0.373759835958481*x_96 + 5.1735200881958) + 0.214088779130504*std::sin(0.379359841346741*x_96 + 5.17080020904541) - 0.484132162329286*std::sin(0.443919867277145*x_96 - 7.36175966262817) + 3.90074500510455*std::sin(0.474479854106903*x_96 + 2.04111981391907) + 0.81016613004768*std::sin(0.426079869270325*x_97 + 2.02439975738525) + 0.608031122744532*std::sin(0.44735985994339*x_99 + 2.00959992408752) - 470061.005622633 - 0.00125448493056906*std::exp(-3.23736000061035*x_74) + 7.08256467784833*std::exp(-3.12712001800537*x_74) + 0.131211948604643*std::exp(-2.99327993392944*x_74) + 0.00193983339309964*std::exp(-2.77376008033752*x_74) + 0.280572503527204*std::exp(-3.92463994026184*x_45) - 0.00067867936814252*std::exp(-3.88455986976624*x_45) - 0.0417015872181578*std::exp(-4.77167987823486*x_111) + 0.000124433094888608*std::exp(-4.69159984588623*x_111) + 2.36457209554911e-5*std::exp(-4.68919992446899*x_111) + 0.0335686103846678*std::exp(-4.61607980728149*x_111));
}

int predict(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120)
{
    float s0 = score_0(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s1 = score_1(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s2 = score_2(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s3 = score_3(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s4 = score_4(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s5 = score_5(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s6 = score_6(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s7 = score_7(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s8 = score_8(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s9 = score_9(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s10 = score_10(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s11 = score_11(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);

    float max_score = s0;
    int max_index = 0;

    if(s1 > max_score) {
        max_score = s1;
        max_index = 1;
    }

    if(s2 > max_score) {
        max_score = s2;
        max_index = 2;
    }

    if(s3 > max_score) {
        max_score = s3;
        max_index = 3;
    }

    if(s4 > max_score) {
        max_score = s4;
        max_index = 4;
    }

    if(s5 > max_score) {
        max_score = s5;
        max_index = 5;
    }

    if(s6 > max_score) {
        max_score = s6;
        max_index = 6;
    }

    if(s7 > max_score) {
        max_score = s7;
        max_index = 7;
    }

    if(s8 > max_score) {
        max_score = s8;
        max_index = 8;
    }

    if(s9 > max_score) {
        max_score = s9;
        max_index = 9;
    }

    if(s10 > max_score) {
        max_score = s10;
        max_index = 10;
    }

    if(s11 > max_score) {
        max_score = s11;
        max_index = 11;
    }

    return max_index;
}

#endif
