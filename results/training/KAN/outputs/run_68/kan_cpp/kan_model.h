
#ifndef KAN_MODEL_H
#define KAN_MODEL_H

#include <cmath>


inline float score_0(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.000274725397936914*x_1 - 0.000108532353759511*x_10 - 3.08488445715876e-5*x_100 + 8.56729365905196e-5*x_101 + 4.71133713565316e-5*x_102 - 1.65463214500273e-5*x_103 - 7.06009487511332e-5*x_104 - 5.32084588332433e-5*x_105 + 3.10727763198038e-5*x_106 + 2.50416176243182e-5*x_107 - 3.75272056948546e-5*x_108 - 6.8330491254391e-5*x_109 + 1.81095907990481e-5*x_11 - 1.7400460091316e-5*x_110 - 6.9040959392209e-5*x_111 + 9.57357570599895e-6*x_112 - 8.58015487485581e-5*x_113 - 3.59550717379094e-5*x_114 - 1.01070501592079e-5*x_115 - 0.00023284096869259*x_116 - 2.78126638048386e-5*x_117 - 3.62294308223558e-5*x_118 - 9.97358678869168e-5*x_119 - 2.91996187713649e-5*x_12 - 1.20646483912125e-5*x_120 - 8.58717766525644e-5*x_13 + 2.37847195110103e-6*x_14 - 9.18862835082529e-5*x_15 - 6.29660261750599e-5*x_16 + 9.25392688550931e-6*x_17 + 3.38872677463966e-5*x_18 + 1.40671858272634e-5*x_19 - 4.97705117106823e-5*x_2 + 4.20578367967967e-5*x_20 + 2.30048612059738e-5*x_21 - 2.49563000884246e-5*x_22 + 1.22782521405758e-5*x_23 + 6.27025403207713e-6*x_24 + 3.15281190012559e-5*x_25 - 5.03324831752091e-7*x_26 + 3.7368136050505e-5*x_27 - 3.64774058410513e-5*x_28 + 2.72335517213869e-5*x_29 + 4.54972427106843e-6*x_3 - 1.01356682762878e-5*x_30 - 7.76821405766488e-5*x_31 + 3.90736015127061e-5*x_32 + 2.27142135036028e-5*x_33 - 1.95706639223907e-5*x_34 - 5.60943631068961e-5*x_35 - 4.65355617275314e-5*x_36 + 4.5700551171288e-5*x_37 + 8.05021061815518e-6*x_38 + 2.68756540221508e-5*x_39 + 5.49861948443863e-5*x_4 + 4.35193012133572e-5*x_40 - 5.18189622636053e-5*x_41 - 7.61810297477996e-5*x_42 - 6.08297705857825e-5*x_43 + 1.01958710592958e-5*x_44 - 1.60186671799464e-5*x_45 + 1.58914059098155e-5*x_46 + 5.53536095760155e-8*x_47 + 0.000109209702618576*x_48 - 5.74772603560645e-5*x_49 - 2.29369454435698e-5*x_5 - 6.20675888185728e-5*x_50 - 7.3319377781286e-5*x_51 - 0.000262326438528913*x_52 - 0.00010804889132506*x_53 - 8.9381077042678e-6*x_54 - 6.19174898768603e-5*x_55 - 1.1610305420596e-5*x_56 - 1.92813449554481e-5*x_57 + 4.57820589520005e-5*x_58 + 5.81514389522519e-5*x_59 - 0.000199289834227599*x_6 - 3.49085842747212e-5*x_60 - 3.02976445114918e-5*x_61 - 3.10816801807684e-5*x_62 + 1.83441658892868e-5*x_63 + 2.69049644906643e-5*x_64 - 1.30666413686461e-5*x_65 - 7.51452014945825e-5*x_66 + 1.6430167848995e-7*x_67 - 2.32858861863863e-5*x_68 - 2.32632880232343e-5*x_69 - 2.57259357400567e-6*x_7 + 2.31144112673308e-5*x_70 + 3.11808795739879e-5*x_71 - 3.05253848233903e-5*x_72 + 4.38555678813579e-5*x_73 - 6.50430724217863e-6*x_74 - 4.81606394208789e-5*x_75 - 1.69470196169014e-5*x_76 - 6.47111596905747e-5*x_77 + 2.61296845060349e-5*x_78 + 7.80522380679315e-5*x_79 - 9.23225475067549e-7*x_8 - 1.04329079358023e-5*x_80 - 4.66156603758041e-5*x_81 - 7.81328675801821e-5*x_82 - 3.21007603209111e-5*x_83 + 2.32275908883864e-5*x_84 + 8.66789013443025e-5*x_85 - 6.53505315945613e-5*x_86 + 3.64737970324372e-5*x_87 - 5.65539646960501e-5*x_88 - 9.29429061359388e-5*x_89 - 5.7740388898546e-5*x_9 - 4.55188882234534e-7*x_90 + 0.000311176540133586*x_91 + 0.000130655715711401*x_92 + 4.09329730218838e-5*x_93 - 0.000115582855134822*x_94 - 7.25725737078167e-5*x_95 - 8.64514554538472e-5*x_96 + 9.2017312057457e-5*x_97 + 3.18476902688926e-5*x_98 + 4.15884818553721e-5*x_99 + 1.21801922318912e-5*std::sin(2.76207995414734*x_25 - 5.79063987731934) + 0.00772041803573519);
}

inline float score_1(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.000194453204671429*x_1 + 3.62921090601662e-5*x_10 + 4.73297420757346e-5*x_100 - 8.10148363820297e-5*x_101 - 3.4291054199266e-5*x_102 - 4.3855946765534e-6*x_103 + 9.36339495218116e-6*x_104 + 3.10678023805145e-5*x_105 + 2.25334872677329e-5*x_106 - 2.51643493313808e-5*x_107 + 7.59671110248179e-5*x_108 + 3.46224071924977e-5*x_109 - 5.71466034230323e-6*x_11 + 2.13774837563983e-5*x_110 + 7.55480565086434e-5*x_111 + 1.50975670645157e-5*x_112 + 4.90184274927032e-5*x_113 - 2.05944316694603e-5*x_114 + 3.39169514358376e-5*x_115 + 0.000161068936478773*x_116 + 1.29729115235771e-5*x_117 - 5.50648605928748e-6*x_118 + 9.3319841281429e-5*x_119 + 4.51196918326157e-5*x_12 + 2.98720459259752e-5*x_120 + 5.77949807515539e-5*x_13 + 2.25575889089276e-5*x_14 + 0.000104098014909667*x_15 + 3.08268890624697e-5*x_16 - 1.10070996451327e-6*x_17 - 6.99004342732815e-6*x_18 + 8.985354768378e-6*x_19 + 2.09992624664558e-5*x_2 - 2.47346747118124e-5*x_20 - 3.09780657905329e-5*x_21 - 1.09496287652354e-5*x_22 - 1.54804522720135e-5*x_23 - 1.48774196339021e-5*x_24 - 1.87857806235248e-5*x_25 + 2.07572859789207e-5*x_26 - 4.40857746477516e-5*x_27 + 4.5454931286494e-5*x_28 - 9.19622489712687e-6*x_29 + 1.91268078984126e-5*x_3 + 2.42025703036448e-5*x_30 + 8.85966688951138e-5*x_31 - 3.68488240354648e-5*x_32 - 2.96191134931401e-5*x_33 - 8.05774060561371e-7*x_34 + 1.14008591018885e-6*x_35 + 5.87884617693806e-5*x_36 - 3.60517030605795e-5*x_37 + 2.40770716700675e-5*x_38 + 3.20315126712429e-5*x_39 - 3.60374715216193e-5*x_4 - 3.28479619555855e-5*x_40 + 5.93177819648033e-5*x_41 + 8.27421435844296e-5*x_42 + 2.01705665830149e-5*x_43 - 2.75658387851387e-5*x_44 - 1.15458908071778e-5*x_45 - 2.11525830708267e-6*x_46 - 1.71146114358574e-6*x_47 - 0.00011611427465066*x_48 + 1.02830264439091e-5*x_49 + 3.42047220897309e-6*x_5 + 6.5264173019567e-5*x_50 + 6.41792227636124e-5*x_51 + 0.000180734145489591*x_52 - 2.63240470108979e-6*x_53 - 3.78790277254617e-5*x_54 + 9.74969825725211e-5*x_55 - 8.45575016428998e-6*x_56 + 1.95532616845338e-5*x_57 - 2.45032041991361e-5*x_58 + 2.97172273696505e-6*x_59 + 0.000234655100864463*x_6 + 7.43796288973115e-5*x_60 + 2.2894117227945e-5*x_61 + 3.7294506692777e-6*x_62 + 1.34670234242316e-5*x_63 - 2.58268179481373e-5*x_64 + 9.71550035487342e-6*x_65 + 1.26777276854905e-5*x_66 + 2.11632516351537e-5*x_67 + 1.29683133232452e-5*x_68 + 2.61375178656674e-5*x_69 + 1.85840066998388e-6*x_7 - 1.09859850661251e-5*x_70 + 2.04930190176322e-5*x_71 + 1.77639152610032e-5*x_72 - 3.33847193113524e-5*x_73 + 8.9628744503364e-6*x_74 + 3.7475519320676e-5*x_75 + 5.14967920956984e-5*x_76 + 3.76399672447057e-5*x_77 - 2.49898433384813e-5*x_78 - 6.47058102008437e-5*x_79 - 1.09090906470603e-5*x_8 - 4.14392041709068e-6*x_80 + 3.62278727007406e-5*x_81 + 4.11493815933601e-5*x_82 - 2.22930108006996e-5*x_83 - 4.43478595393795e-5*x_84 - 3.30573774965467e-5*x_85 + 2.93905529280537e-5*x_86 - 1.39340069416867e-5*x_87 + 5.79620963034023e-5*x_88 + 5.63395805459908e-5*x_89 + 9.88953694405344e-6*x_9 - 2.88318524514772e-6*x_90 - 0.00022263874907466*x_91 - 0.000102012630162073*x_92 - 1.63144334140283e-5*x_93 + 3.40274694877688e-5*x_94 + 2.13418159394746e-5*x_95 + 7.54022002173044e-5*x_96 - 3.51473183112265e-5*x_97 + 1.79729914697635e-5*x_98 + 7.18823117016597e-6*x_99 + 8.10046737051545e-6*std::sin(2.76207995414734*x_25 - 5.79063987731934) + 0.0613788522860603);
}

inline float score_2(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (2.61074051052476e-5*x_1 - 8.33121939228427e-5*x_10 + 5.6985017204706e-5*x_100 - 1.06484684002579e-5*x_101 + 3.41356746833656e-5*x_102 - 3.2937295298173e-5*x_103 - 3.90212051499407e-5*x_104 + 1.34038371802588e-5*x_105 + 5.9773964358956e-5*x_106 + 1.69692679591422e-6*x_107 + 8.38676113106272e-5*x_108 - 8.65754369408224e-6*x_109 + 1.54964481701986e-5*x_11 + 3.1858789081236e-5*x_110 + 5.73037442456104e-5*x_111 + 5.40120404102052e-5*x_112 - 1.70989503528232e-5*x_113 - 3.03105622908955e-5*x_114 + 4.27878356760184e-5*x_115 + 1.3115456003236e-5*x_116 + 2.41023060997943e-6*x_117 - 1.25926832071959e-5*x_118 + 6.1792982356775e-5*x_119 + 7.31817545256587e-5*x_12 + 6.57919113561677e-5*x_120 + 2.7308584423062e-6*x_13 + 1.82530797602797e-5*x_14 + 5.61613716558727e-5*x_15 - 3.81980658413846e-5*x_16 + 1.21030017332132e-5*x_17 + 3.38348793760685e-5*x_18 + 2.29134566129237e-5*x_19 - 3.02117355056253e-6*x_2 + 1.52304442627449e-5*x_20 + 2.13012275176293e-5*x_21 - 1.95411883961887e-5*x_22 + 1.08429597127663e-5*x_23 + 1.99876832517215e-5*x_24 + 3.30186702996909e-5*x_25 + 5.70251824693861e-5*x_26 + 2.16510918205556e-5*x_27 + 3.95898832257506e-5*x_28 + 1.41334111637565e-5*x_29 + 3.01495929152786e-5*x_3 + 5.81901853296744e-5*x_30 + 4.43046621929115e-5*x_31 - 3.51353498718032e-5*x_32 - 6.52988647541128e-5*x_33 - 4.67292963178689e-5*x_34 - 1.79937856198004e-5*x_35 + 3.78277693811192e-5*x_36 - 3.83401207051969e-6*x_37 + 4.46421104625602e-5*x_38 + 0.00012162386501765*x_39 + 3.7444320798e-5*x_4 - 1.91760794576498e-5*x_40 + 2.17472687523991e-5*x_41 + 5.08527957301511e-5*x_42 - 3.28185579631213e-5*x_43 - 4.91565071011005e-5*x_44 - 2.16735937073838e-5*x_45 + 2.76380519240316e-5*x_46 - 2.552946353588e-5*x_47 - 4.88165126753288e-5*x_48 - 5.13836599521708e-5*x_49 - 2.0076663236244e-5*x_5 + 4.17826865124413e-5*x_50 + 2.63604983974192e-5*x_51 + 2.02328916007974e-5*x_52 - 0.000102321785897751*x_53 - 3.72849711223541e-5*x_54 + 9.67912399796954e-5*x_55 - 4.17843639175838e-5*x_56 + 5.26389328476645e-6*x_57 + 2.40768993844443e-5*x_58 + 4.69912708318031e-5*x_59 + 0.000192324534842414*x_6 + 0.000101087261625615*x_60 + 4.59672909093654e-5*x_61 - 4.08229094738041e-5*x_62 + 4.29338069022122e-5*x_63 + 9.48799916709496e-7*x_64 - 7.6863414642869e-6*x_65 - 4.49764793403844e-5*x_66 + 4.07308837884331e-5*x_67 - 1.4385541574619e-5*x_68 + 2.52830513660656e-5*x_69 + 9.72080353289033e-6*x_7 + 4.42133338221449e-5*x_70 + 6.6678776045062e-5*x_71 + 1.83664798933275e-5*x_72 + 2.32245811772418e-5*x_73 + 5.91102516993809e-6*x_74 - 2.65213411321115e-7*x_75 + 9.40011509320899e-5*x_76 - 1.19965946001206e-5*x_77 + 5.86739537200046e-6*x_78 + 3.42103500854608e-7*x_79 + 2.84857081704714e-5*x_8 - 2.04790189985977e-5*x_80 + 2.24404044902157e-5*x_81 - 6.51196580156166e-7*x_82 - 3.19143290875504e-6*x_83 + 2.35113976254799e-5*x_84 + 9.51619156756015e-5*x_85 + 3.22079450487042e-6*x_86 + 2.87340070103363e-5*x_87 + 2.64450778699087e-5*x_88 - 1.73485441676768e-5*x_89 - 3.45015766868936e-5*x_9 + 1.0659984427022e-5*x_90 + 1.58603952489524e-5*x_91 + 5.14457450770961e-6*x_92 + 2.1187308068913e-5*x_93 - 7.56453510319423e-5*x_94 - 3.93546324048813e-5*x_95 + 2.69506213131356e-5*x_96 + 2.65514918053297e-5*x_97 + 9.45211070832244e-5*x_98 + 8.65623525713855e-5*x_99 + 9.81387291032016e-6*std::sin(2.76207995414734*x_25 - 5.79063987731934) + 0.0265490268813164);
}

inline float score_3(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.000319296333202045*x_1 - 0.00012224940398302*x_10 - 6.81629113996928e-6*x_100 + 0.000166181106830597*x_101 + 8.17068119511584e-5*x_102 + 1.68212253183522e-5*x_103 - 2.996806737563e-6*x_104 - 6.08323626942676e-5*x_105 + 3.9653571416493e-5*x_106 + 2.38859237509076e-5*x_107 + 3.80324543981691e-5*x_108 - 5.93485249097419e-5*x_109 - 6.78883409104352e-6*x_11 - 1.17836278511383e-5*x_110 - 4.7927423954751e-5*x_111 + 3.96074310944544e-5*x_112 + 3.67101414632779e-6*x_113 + 1.52165604966552e-5*x_114 + 1.67327551035497e-5*x_115 - 0.000195221525880319*x_116 - 3.61148248025475e-5*x_117 - 4.41356319929544e-5*x_118 + 1.00301880153675e-5*x_119 + 3.52186756415026e-5*x_12 + 6.24590237387028e-5*x_120 - 1.72801528148961e-5*x_13 - 3.12059714259585e-5*x_14 - 4.23371571068806e-5*x_15 - 7.95509305170373e-7*x_16 - 2.0794982392567e-5*x_17 + 1.95646128835419e-6*x_18 + 3.50015900665181e-5*x_19 - 1.8900881806871e-5*x_2 + 7.54876578597392e-5*x_20 - 9.95340237029671e-7*x_21 - 2.97120945609225e-5*x_22 + 4.05121375729772e-5*x_23 + 1.80056348463791e-5*x_24 + 5.06487064404254e-5*x_25 + 4.46613950050735e-5*x_26 + 0.000101289808373074*x_27 + 1.24656719314148e-6*x_28 + 8.79941217842708e-6*x_29 - 9.88967119064068e-6*x_3 + 7.78164049875708e-5*x_30 - 0.000181624122186269*x_31 - 2.24173787419413e-5*x_32 - 0.000142405766045898*x_33 - 7.28408574105198e-5*x_34 - 7.92473082194927e-5*x_35 - 4.40846865656853e-5*x_36 + 1.75250752786084e-5*x_37 + 9.77037078399555e-6*x_38 - 5.45493059065884e-5*x_39 + 9.77191393459394e-5*x_4 - 6.68465623392941e-5*x_40 - 6.4040196022371e-5*x_41 - 0.00012000106656155*x_42 - 1.28399060251639e-5*x_43 - 2.44676886600246e-5*x_44 - 8.77504329524573e-6*x_45 + 4.05578939207638e-5*x_46 - 5.03276202664264e-5*x_47 + 4.28283287400343e-5*x_48 - 4.63881231543975e-5*x_49 - 2.54710803732708e-6*x_5 - 2.33542318184467e-5*x_50 - 5.91864336302274e-5*x_51 - 7.9203180141558e-5*x_52 - 0.000131558385351819*x_53 - 5.26529173901336e-5*x_54 + 1.26347803270578e-5*x_55 - 3.7902901209988e-5*x_56 - 4.42984546046938e-5*x_57 + 4.11916555574714e-5*x_58 + 6.70234571651365e-5*x_59 - 5.63704322579955e-5*x_6 + 8.54202732456538e-6*x_60 - 1.80258406934491e-5*x_61 - 5.00326832353707e-5*x_62 + 2.49518382667695e-6*x_63 + 2.41587109828337e-5*x_64 + 7.18550283425985e-6*x_65 - 4.43349005597487e-5*x_66 + 4.0707174120792e-5*x_67 - 2.31273058015528e-5*x_68 + 8.17818416845251e-6*x_69 - 7.00346093293644e-6*x_7 + 4.72659313437381e-5*x_70 + 3.00039763980776e-5*x_71 + 5.26109235631637e-6*x_72 + 5.93433174767418e-5*x_73 - 1.95405944607249e-5*x_74 - 1.78112955608013e-5*x_75 + 3.58232352733405e-6*x_76 - 9.39639013825494e-5*x_77 + 1.37051598901385e-5*x_78 + 3.45043686849031e-5*x_79 - 2.59265434942826e-6*x_8 - 4.25114210668735e-5*x_80 - 2.97050694008996e-5*x_81 - 2.85493959571978e-5*x_82 - 7.36500626488568e-5*x_83 + 3.74139330009991e-5*x_84 + 5.5515671327198e-5*x_85 - 0.000120572993382943*x_86 + 2.72411201319173e-5*x_87 - 1.79289470900805e-5*x_88 - 9.07287308491572e-5*x_89 - 2.40412696715788e-5*x_9 - 7.42823502817804e-7*x_90 + 7.28216670227085e-5*x_91 + 9.11855061566461e-5*x_92 + 3.03687320038781e-5*x_93 - 0.000142833520147944*x_94 - 9.28299451806262e-5*x_95 - 5.36550106729165e-5*x_96 + 4.3546117758056e-5*x_97 + 6.41781747962693e-5*x_98 + 3.90452880824351e-5*x_99 + 4.6029603265604e-5*std::sin(2.76207995414734*x_25 - 5.79063987731934) + 0.0381246636778875);
}

inline float score_4(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-6.22864791082453e-5*x_1 - 4.06571017600688e-5*x_10 - 2.96860530349367e-5*x_100 - 2.89504831678501e-5*x_101 + 2.1481442813107e-6*x_102 - 5.73101065537797e-6*x_103 - 5.90692612739161e-5*x_104 - 3.42083376609651e-5*x_105 + 3.84347386547077e-5*x_106 + 2.1490828741441e-5*x_107 + 7.81374668723984e-6*x_108 - 1.41785344683347e-5*x_109 + 7.5854791246937e-6*x_11 - 2.60461150759683e-5*x_110 + 1.23407179344683e-5*x_111 + 1.28702628790054e-6*x_112 - 6.98021544216896e-5*x_113 - 5.42562855374075e-5*x_114 + 3.35446327960167e-6*x_115 - 0.000156414444287528*x_116 - 1.55760819230001e-5*x_117 - 2.67955983460905e-5*x_118 - 1.81132902624761e-6*x_119 - 3.1839608093663e-5*x_12 - 1.35044127312565e-5*x_120 - 4.19283604345015e-5*x_13 + 2.29789445862311e-5*x_14 - 3.15451865507404e-5*x_15 + 1.74323822719292e-5*x_16 + 2.72171597313393e-6*x_17 + 2.06916363210263e-5*x_18 - 2.22242106268551e-5*x_19 - 2.65597694084976e-5*x_2 - 7.46985672016384e-6*x_20 - 6.14988984315823e-6*x_21 - 1.4292239167416e-5*x_22 + 4.64965973258017e-6*x_23 - 1.3980899031038e-5*x_24 + 4.65445587055537e-6*x_25 - 2.42920852874765e-6*x_26 + 1.91038728065247e-5*x_27 + 5.50945819584578e-6*x_28 + 1.4503525693819e-5*x_29 - 6.80853667532185e-6*x_3 + 5.75628287618836e-6*x_30 - 0.000104470177898437*x_31 + 1.8157561668087e-5*x_32 + 1.95001099496037e-5*x_33 - 3.37111701807132e-5*x_34 - 1.18762554758978e-5*x_35 - 3.06657085239644e-5*x_36 + 5.83007200952321e-6*x_37 + 6.92399044133598e-6*x_38 + 3.11961756300167e-5*x_39 - 3.28247641823428e-5*x_4 + 1.35798309509354e-5*x_40 - 2.92349802340782e-6*x_41 + 4.50847670022619e-5*x_42 - 1.23649759709873e-5*x_43 + 1.48670711143529e-5*x_44 - 1.11096417010327e-5*x_45 + 5.23381932826961e-6*x_46 + 5.05909890733065e-5*x_47 - 3.21723680029287e-5*x_48 - 3.76615433434165e-5*x_49 - 1.67522184365178e-5*x_5 - 2.97634697298626e-5*x_50 - 2.87584585537044e-5*x_51 - 9.90422484969521e-5*x_52 - 8.34129529019445e-5*x_53 - 3.53906441470033e-5*x_54 - 1.14441636693498e-5*x_55 + 1.31004847013319e-6*x_56 - 1.04040153600886e-5*x_57 + 1.81047061161727e-5*x_58 + 3.21120132706062e-5*x_59 - 0.000115808350528868*x_6 - 1.01330271785443e-5*x_60 - 3.4984674255453e-5*x_61 - 1.63873550746067e-5*x_62 + 2.84540780232678e-5*x_63 + 2.06900190594731e-5*x_64 - 7.34593282941758e-6*x_65 - 4.09433933609672e-5*x_66 - 7.54123574918684e-7*x_67 - 1.15488835857016e-5*x_68 - 1.56759069280735e-5*x_69 - 1.91813469187381e-5*x_7 - 5.48025906451727e-6*x_70 + 1.17562920974875e-5*x_71 - 1.02403899227773e-5*x_72 + 2.89367467303207e-5*x_73 + 7.70639050593803e-6*x_74 - 1.48083215448907e-5*x_75 - 8.86902053756181e-6*x_76 - 3.39804331464954e-5*x_77 - 1.56861031481048e-6*x_78 + 1.43045670710378e-6*x_79 - 1.10694065143246e-5*x_8 + 4.84841885501722e-6*x_80 - 2.79425104918896e-5*x_81 - 6.9124358804984e-5*x_82 - 4.58297266089443e-5*x_83 - 1.10368138061903e-5*x_84 + 4.19709164454117e-5*x_85 + 1.56045951921065e-5*x_86 + 1.4646226495162e-5*x_87 - 1.37322862746859e-5*x_88 - 2.65061330404435e-5*x_89 - 4.30599382576413e-5*x_9 - 6.54958755378685e-6*x_90 + 3.6649946009287e-5*x_91 + 5.93192665237374e-5*x_92 + 1.83270385487755e-5*x_93 - 4.43151896031979e-5*x_94 - 3.50434092548657e-5*x_95 - 2.18810175540031e-5*x_96 + 0.000105380350577254*x_97 + 2.43469942089841e-6*x_98 + 2.24016999791481e-5*x_99 + 7.74778922620514e-6*std::sin(2.76207995414734*x_25 - 5.79063987731934) + 0.0171654175953864);
}

inline float score_5(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-2.67841774754797e-5*x_1 - 7.308421046234e-6*x_10 + 3.5130138396265e-5*x_100 - 2.41630187013221e-5*x_101 - 5.42362400009566e-5*x_102 - 1.75295399776166e-5*x_103 - 6.17273409208462e-5*x_104 - 1.7303134709768e-5*x_105 + 4.2738631576498e-5*x_106 - 5.1130365144614e-5*x_107 + 2.89329388882824e-5*x_108 - 4.35127144015183e-5*x_109 + 5.24509323755918e-6*x_11 + 1.24096700966419e-5*x_110 - 2.11297226180938e-5*x_111 - 2.87004440760732e-6*x_112 + 2.23258560756711e-5*x_113 - 8.95493307028055e-5*x_114 + 2.66658958339223e-5*x_115 + 8.53645322483042e-5*x_116 - 1.66503883069057e-5*x_117 - 7.83684235497905e-5*x_118 - 5.44123013760028e-5*x_119 + 7.27047327027629e-8*x_12 - 2.08580315476033e-5*x_120 - 3.03804998796218e-6*x_13 + 4.75371904851225e-5*x_14 + 7.02244213353003e-5*x_15 - 4.69847063339152e-5*x_16 + 8.69544943921021e-6*x_17 + 5.7517833887824e-6*x_18 + 6.52383860055339e-5*x_19 - 3.91002393130081e-5*x_2 + 8.98629332318077e-6*x_20 - 7.16707443929718e-5*x_21 - 7.06268145903448e-5*x_22 - 5.21603978101236e-5*x_23 - 5.58340522985207e-5*x_24 - 3.85834765904129e-5*x_25 - 1.48400932764019e-5*x_26 - 0.000130438267768257*x_27 - 8.45132652929165e-6*x_28 + 1.15964336149584e-5*x_29 + 5.42231800006145e-5*x_3 - 5.19948389332373e-5*x_30 + 0.000193854441059815*x_31 + 1.99619922770444e-5*x_32 + 6.66343763374032e-5*x_33 + 6.20210359873533e-5*x_34 - 0.000119139576417506*x_35 + 6.7925031198496e-5*x_36 + 2.60455636701589e-6*x_37 + 4.17498892478207e-5*x_38 + 1.15584267532677e-6*x_39 - 1.56107830484523e-6*x_4 + 4.12363136946912e-5*x_40 + 4.82584411845186e-5*x_41 - 2.98307145337739e-5*x_42 - 5.12955734204697e-5*x_43 - 1.19817404877256e-5*x_44 - 4.90168545004441e-5*x_45 - 1.43275298954433e-5*x_46 - 1.73920350615229e-5*x_47 + 5.16500698544444e-6*x_48 - 1.23852565431884e-5*x_49 - 9.78573848868074e-6*x_5 + 3.073139599558e-5*x_50 + 2.02133294696424e-5*x_51 - 4.04767239287317e-5*x_52 - 7.55723916303102e-5*x_53 - 6.60572947172482e-5*x_54 + 4.30255636396099e-5*x_55 - 2.20215829557857e-8*x_56 + 2.83187706972393e-5*x_57 - 1.4880495609361e-5*x_58 + 7.55927754799927e-5*x_59 + 0.000128303176076737*x_6 + 3.31839061713722e-5*x_60 - 3.32797413925692e-5*x_61 + 6.93738452742743e-6*x_62 + 1.18129941254365e-5*x_63 - 4.55764360630501e-5*x_64 + 1.45959661429996e-5*x_65 - 6.71151357669368e-5*x_66 + 1.2871710705777e-5*x_67 + 1.61807196342488e-5*x_68 + 4.98683315806616e-6*x_69 + 8.80322096455482e-6*x_7 - 3.95911711349339e-5*x_70 + 5.90102954491039e-5*x_71 - 4.70181750620653e-5*x_72 - 7.20472082163764e-5*x_73 - 8.87825770250956e-8*x_74 + 1.22232250611958e-5*x_75 + 1.24277953433904e-5*x_76 + 1.71714584461197e-5*x_77 - 2.30067503928099e-5*x_78 - 9.15162226894868e-6*x_79 - 7.5745363732261e-5*x_8 - 1.52559444893442e-5*x_80 - 3.94568938757238e-6*x_81 - 2.42633987237358e-6*x_82 - 0.00011560794086485*x_83 - 0.000129636983870111*x_84 - 5.63053864975766e-5*x_85 - 9.50294861492242e-5*x_86 - 3.59292009142508e-6*x_87 + 2.29623084724853e-5*x_88 - 3.21893575223149e-6*x_89 - 3.92419786605724e-5*x_9 - 2.11146190306195e-5*x_90 + 5.71499036535993e-5*x_91 - 7.42158800129537e-5*x_92 + 8.07484401806525e-6*x_93 - 4.20162374782276e-5*x_94 - 2.95286392558628e-5*x_95 + 1.08859319689584e-5*x_96 - 1.5792466345472e-5*x_97 + 1.20700499993652e-5*x_98 - 4.83211954991306e-6*x_99 + 3.68613265866408e-5*std::sin(2.76207995414734*x_25 - 5.79063987731934) + 0.0331012555697253);
}

inline float score_6(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.000231076980655188*x_1 - 4.30134877405251e-5*x_10 - 3.88296357951468e-5*x_100 + 4.78049995972815e-5*x_101 - 1.31929631533149e-5*x_102 + 1.30894876640284e-6*x_103 - 6.80742843564596e-5*x_104 - 6.41916891927028e-5*x_105 + 2.5580962938188e-5*x_106 - 5.62978938370817e-6*x_107 - 3.92360872465784e-5*x_108 - 6.57771339897252e-5*x_109 + 4.57185845600465e-6*x_11 - 3.05484460985733e-5*x_110 - 7.86041576515278e-5*x_111 - 2.03604804500801e-5*x_112 - 4.39724171936484e-5*x_113 - 6.73655417406714e-5*x_114 - 9.87161709051219e-6*x_115 - 0.000158293856532748*x_116 - 3.50118701277234e-5*x_117 - 7.01254058030722e-5*x_118 - 0.000110080441469922*x_119 - 6.06093755414933e-5*x_12 - 4.89152823963785e-5*x_120 - 6.18120248598692e-5*x_13 + 2.09466378474657e-5*x_14 - 5.38577344604965e-5*x_15 - 2.78448768692077e-5*x_16 + 1.99670052790378e-7*x_17 + 8.35373883909251e-6*x_18 + 2.70099859758724e-5*x_19 - 5.60953561973628e-5*x_2 + 2.5202682251719e-5*x_20 - 4.29992518226305e-5*x_21 - 4.97948802742656e-5*x_22 - 2.09550962613141e-5*x_23 - 4.13469392070223e-5*x_24 - 1.51524681427775e-5*x_25 - 3.39540402542206e-5*x_26 - 4.34578105641858e-5*x_27 - 4.14279923407649e-5*x_28 + 1.81253641926387e-5*x_29 + 1.12350796601027e-5*x_3 - 5.13632478807795e-5*x_30 - 2.14909265619128e-5*x_31 + 5.20796020190415e-5*x_32 + 6.86449282078738e-5*x_33 + 2.69358982688953e-5*x_34 - 9.88145020731666e-5*x_35 - 2.36634609989396e-5*x_36 + 2.98887262914382e-5*x_37 + 6.17554422725516e-6*x_38 - 5.09862788783963e-5*x_39 + 7.1146021112898e-6*x_4 + 4.84065896108403e-5*x_40 - 2.08027450439745e-5*x_41 - 8.21603938321402e-5*x_42 - 4.52339789876414e-5*x_43 + 2.71523747041185e-5*x_44 - 2.80526730570602e-5*x_45 - 7.48045167878502e-6*x_46 + 1.56657368083057e-5*x_47 + 7.57006437097608e-5*x_48 - 2.66252120373909e-5*x_49 - 1.16874648195131e-5*x_5 - 5.00685162578985e-5*x_50 - 5.78094378032298e-5*x_51 - 0.000205865701022413*x_52 - 8.73520991018118e-5*x_53 - 4.14160321761888e-5*x_54 - 6.12238275514964e-5*x_55 + 1.22751028493346e-5*x_56 - 7.14053968291402e-6*x_57 + 1.3108987005279e-5*x_58 + 6.53689316125603e-5*x_59 - 0.000181323737350151*x_6 - 5.65237822372727e-5*x_60 - 7.39203323245912e-5*x_61 - 2.05985517782068e-6*x_62 + 2.36202784943622e-6*x_63 - 1.53705167755568e-6*x_64 + 4.55574855411144e-6*x_65 - 6.95389635305272e-5*x_66 - 9.32341391053266e-6*x_67 - 1.94908956153221e-6*x_68 - 2.6749282828489e-5*x_69 - 1.00093280451972e-5*x_7 - 3.0173664149218e-5*x_70 + 1.92867436350729e-5*x_71 - 5.34156964256747e-5*x_72 - 1.19566095793559e-5*x_73 - 6.5350957833471e-6*x_74 - 2.39996373185497e-5*x_75 - 5.59277680006817e-5*x_76 - 4.15827149841007e-5*x_77 - 2.14304940956637e-6*x_78 + 3.72525137583137e-5*x_79 - 6.25280914836341e-5*x_8 - 6.7714149771458e-6*x_80 - 5.15426128664717e-5*x_81 - 6.79130076249492e-5*x_82 - 0.00010566245681245*x_83 - 7.19190114075693e-5*x_84 - 1.87860434453414e-5*x_85 - 9.77710237265081e-5*x_86 + 8.92062462240089e-6*x_87 - 3.64244988364419e-5*x_88 - 5.978579416922e-5*x_89 - 4.94448378491022e-5*x_9 - 2.03292262213601e-5*x_90 + 0.000193600384148324*x_91 + 5.38732212292221e-5*x_92 + 2.34902442061414e-5*x_93 - 7.42827837396915e-5*x_94 - 5.60801880973614e-5*x_95 - 6.59950068603261e-5*x_96 + 6.59337979953171e-5*x_97 - 1.98668398349899e-5*x_98 - 1.66602759968042e-5*x_99 + 3.06758095129831e-5*std::sin(2.76207995414734*x_25 - 5.79063987731934) - 0.00557866981267788);
}

inline float score_7(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (0.000208323729918663*x_1 + 9.83249845458944e-5*x_10 + 5.51487029083984e-5*x_100 - 7.53183833467951e-5*x_101 - 8.25723740959371e-5*x_102 + 4.12272616054949e-6*x_103 + 2.82285770384908e-5*x_104 + 3.67022315152578e-5*x_105 - 7.64468915266863e-6*x_106 - 6.59865248798879e-5*x_107 + 4.21795595274009e-5*x_108 + 2.41491718932966e-5*x_109 - 1.38232233468703e-5*x_11 + 2.80606356527872e-5*x_110 + 2.82808232852211e-5*x_111 - 1.48660180284771e-5*x_112 + 0.000107054537841178*x_113 - 2.27828181926696e-5*x_114 + 2.39153670096065e-5*x_115 + 0.000293212574412543*x_116 + 1.29498665027892e-5*x_117 - 2.40284341384642e-5*x_118 + 3.04850741361355e-5*x_119 + 2.58677409423587e-5*x_12 - 8.51422838008197e-6*x_120 + 7.70129417001037e-5*x_13 + 2.65657308394791e-5*x_14 + 0.000130798605475212*x_15 + 1.0939398584111e-5*x_16 - 2.51805257398372e-6*x_17 - 3.13285192704192e-5*x_18 + 4.47026219685658e-5*x_19 + 1.64864470476719e-5*x_2 - 2.46165099993792e-5*x_20 - 7.4197472162861e-5*x_21 - 2.97924981538571e-5*x_22 - 5.25175585714089e-5*x_23 - 4.61304604007269e-5*x_24 - 5.89718071790145e-5*x_25 - 1.5468734489044e-5*x_26 - 0.000138271793449344*x_27 + 1.66750432054204e-5*x_28 - 1.78371743725257e-5*x_29 + 3.79962498395783e-5*x_3 - 3.92955990077352e-5*x_30 + 0.000238210956943995*x_31 - 1.73056965841871e-5*x_32 + 3.36037782793232e-5*x_33 + 7.76987884360663e-5*x_34 - 4.45088566878963e-5*x_35 + 9.48958595110365e-5*x_36 - 3.50325372294246e-5*x_37 + 2.02028837728835e-5*x_38 - 4.10478497170785e-5*x_39 - 3.73534331531929e-5*x_4 - 4.5620450797525e-6*x_40 + 7.67608150935093e-5*x_41 + 1.74521394062158e-5*x_42 + 1.41886331614954e-5*x_43 - 1.73906612442222e-5*x_44 - 2.0514164454715e-5*x_45 - 2.75003527456354e-5*x_46 - 2.66645274744239e-5*x_47 - 6.714569761514e-5*x_48 + 5.10083528906287e-5*x_49 + 1.71467825082946e-5*x_5 + 7.74890396311682e-5*x_50 + 7.89752760534216e-5*x_51 + 0.000200959105329792*x_52 + 5.90061117389096e-5*x_53 - 3.09972012045727e-5*x_54 + 7.66744490712555e-5*x_55 + 1.23073984650213e-5*x_56 + 3.95635237103841e-5*x_57 - 5.48468643546003e-5*x_58 + 6.85565393223618e-8*x_59 + 0.000272732605332895*x_6 + 4.70070436423071e-5*x_60 + 3.76147024839559e-6*x_61 + 3.81015263916374e-5*x_62 - 1.75624602793068e-5*x_63 - 6.27951906256843e-5*x_64 + 2.45916536451521e-5*x_65 + 2.24624774062897e-5*x_66 + 6.65506472846471e-6*x_67 + 3.5509307670535e-5*x_68 + 2.4503128601614e-5*x_69 + 1.36613764564495e-5*x_7 - 5.12094917990639e-5*x_70 + 1.22298028047681e-5*x_71 - 1.14590359404987e-5*x_72 - 0.000101053930085198*x_73 + 2.05767938100416e-6*x_74 + 5.16011656447629e-5*x_75 + 1.69568057230721e-5*x_76 + 7.47299616726513e-5*x_77 - 3.84422496350492e-5*x_78 - 6.8533612550219e-5*x_79 - 5.78480469028613e-5*x_8 - 3.57879997228159e-6*x_80 + 3.94815453043939e-5*x_81 + 7.97626590397327e-5*x_82 - 5.17718092295057e-5*x_83 - 0.000118185504810743*x_84 - 0.000132857822185101*x_85 - 2.88224683935823e-5*x_86 - 3.82233237950254e-5*x_87 + 6.37791321797174e-5*x_88 + 7.9198799195394e-5*x_89 + 3.04101678551298e-5*x_9 - 1.51913399481524e-5*x_90 - 0.000211005276343007*x_91 - 0.000177912332778121*x_92 - 3.29723771001909e-5*x_93 + 7.69608097390389e-5*x_94 + 4.72367058142494e-5*x_95 + 7.99059947178139e-5*x_96 - 0.00011797278517826*x_97 - 2.45662051143111e-5*x_98 - 5.07814501658166e-5*x_99 + 1.63603546047242e-5*std::sin(2.76207995414734*x_25 - 5.79063987731934) + 0.0382023610327945);
}

inline float score_8(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (7.7012554860771e-5*x_1 + 8.1813007131452e-5*x_10 - 2.03625152464876e-5*x_100 - 7.73114232088796e-5*x_101 - 7.98834703676579e-5*x_102 + 1.41798833804349e-5*x_103 - 1.59818028439232e-5*x_104 - 1.23289169726739e-5*x_105 - 5.12571561468028e-6*x_106 - 3.04291647310205e-5*x_107 - 1.5734618823083e-5*x_108 + 6.96605647099611e-6*x_109 - 1.02659273127381e-5*x_11 - 2.13874747295277e-5*x_110 - 5.05893811825624e-6*x_111 - 4.24724501576292e-5*x_112 + 1.92850288541419e-5*x_113 - 5.25928210668275e-5*x_114 - 5.6667290210933e-6*x_115 + 6.1863492753412e-5*x_116 - 6.1959340411548e-6*x_117 - 3.57921573119648e-5*x_118 - 2.52768918184241e-5*x_119 - 5.6006675991703e-5*x_12 - 6.12410143684764e-5*x_120 + 1.12420961865681e-5*x_13 + 3.20492879923841e-5*x_14 + 3.11604304869013e-5*x_15 + 3.90462658992379e-5*x_16 - 4.20087844790873e-6*x_17 - 2.12279657182501e-5*x_18 + 1.72888297401399e-7*x_19 - 1.3513411130915e-5*x_2 - 3.40462081933764e-5*x_20 - 7.11039488011951e-5*x_21 - 2.4735124170681e-5*x_22 - 4.28266342220198e-5*x_23 - 5.90655500892322e-5*x_24 - 5.90048800335195e-5*x_25 - 4.93235868658863e-5*x_26 - 0.000101851030391787*x_27 - 9.22131360652856e-6*x_28 - 6.35042785862517e-6*x_29 + 6.34656912443292e-6*x_3 - 6.37070516091404e-5*x_30 + 6.41423919754801e-5*x_31 + 2.87335831176144e-5*x_32 + 9.11392563641697e-5*x_33 + 5.7823704365834e-5*x_34 - 3.48608168803602e-5*x_35 + 2.03180205818962e-5*x_36 - 1.52543789545161e-5*x_37 - 4.02432398132237e-6*x_38 - 6.69891068504709e-5*x_39 - 7.88720864449749e-5*x_4 + 2.82633458052234e-5*x_40 + 4.11479913928782e-5*x_41 + 2.31367440919444e-5*x_42 + 1.29290167393294e-5*x_43 + 3.08802538424134e-5*x_44 - 1.40193894105572e-5*x_45 - 3.27297095828438e-5*x_46 + 4.2498863059114e-5*x_47 - 4.21376676203695e-5*x_48 + 3.12813335320374e-5*x_49 + 7.32560879135688e-6*x_5 + 2.83735354139549e-6*x_50 + 1.46874638001362e-5*x_51 + 2.90241492748609e-5*x_52 + 2.58015285960036e-5*x_53 - 3.10834231676543e-5*x_54 - 1.52903376951471e-5*x_55 + 3.55054783857679e-5*x_56 + 1.81993303140377e-5*x_57 - 3.67530164555548e-5*x_58 + 3.62510062848668e-6*x_59 - 2.53584524217231e-5*x_6 - 3.58474904349382e-5*x_60 - 5.67125613250378e-5*x_61 + 3.73674791598919e-5*x_62 - 1.08725868919495e-5*x_63 - 2.81249720933995e-5*x_64 + 1.46133602106892e-5*x_65 + 1.19260725914305e-6*x_66 - 2.14989152119814e-5*x_67 + 2.37140281033262e-5*x_68 - 1.29188255233734e-5*x_69 - 1.21527773307669e-5*x_7 - 6.92607121963776e-5*x_70 - 1.71861358990703e-5*x_71 - 3.18093692160204e-5*x_72 - 6.27705263970341e-5*x_73 + 5.48487957809621e-6*x_74 + 2.1886599031238e-5*x_75 - 5.10990885067631e-5*x_76 + 3.19054359359126e-5*x_77 - 3.17946663423331e-5*x_78 - 4.44066125208605e-5*x_79 - 6.97070779199691e-5*x_8 + 1.48385101818566e-5*x_80 - 1.1055357588737e-5*x_81 - 7.36606565023749e-6*x_82 - 7.67565361667764e-5*x_83 - 0.000112149408531045*x_84 - 0.000111744023052046*x_85 - 9.33311337374963e-6*x_86 - 3.01106230467444e-5*x_87 + 1.57923011667858e-5*x_88 + 4.17991691962651e-5*x_89 - 1.03847318055837e-7*x_9 - 2.33817480132639e-5*x_90 - 0.000107122483046725*x_91 - 7.6101899754702e-5*x_92 - 1.82725700366725e-5*x_93 + 5.85683483948041e-5*x_94 + 2.50665150835948e-5*x_95 + 1.94282472145035e-5*x_96 - 3.58466562700566e-6*x_97 - 7.11684484389686e-5*x_98 - 6.60884937201927e-5*x_99 + 1.20623015592331e-5*std::sin(2.76207995414734*x_25 - 5.79063987731934) + 0.023362939015993);
}

inline float score_9(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.000205163787102217*x_1 + 4.4695525313767e-6*x_10 - 2.47772012952081e-5*x_100 + 9.64218040948281e-5*x_101 - 1.31437738736229e-5*x_102 + 3.08091639642944e-5*x_103 + 1.04157120510013e-5*x_104 - 5.01287908150841e-5*x_105 - 8.65196973334448e-6*x_106 - 2.13610531469359e-5*x_107 - 2.68333402226035e-5*x_108 - 4.70141948071294e-5*x_109 - 1.72420300761562e-5*x_11 - 2.18375921648445e-5*x_110 - 8.58839787050414e-5*x_111 - 2.30332017637977e-5*x_112 + 4.80441841649676e-5*x_113 - 5.63501343583358e-6*x_114 - 9.31554746850032e-6*x_115 - 4.10996381918997e-5*x_116 - 2.98224120126439e-5*x_117 - 5.57580179362864e-5*x_118 - 6.68845111734617e-5*x_119 - 3.17974903847126e-5*x_12 - 2.45723750885884e-5*x_120 - 6.17022872008519e-7*x_13 - 1.11168891512528e-5*x_14 - 1.9932620219487e-5*x_15 + 8.421901359778e-6*x_16 - 1.97615983942944e-5*x_17 - 3.0221738092082e-5*x_18 + 4.25717607012158e-5*x_19 - 2.35374296940419e-5*x_2 + 3.73788898423457e-5*x_20 - 6.17274238602844e-5*x_21 - 3.90455586753824e-5*x_22 - 1.54312347735014e-5*x_23 - 3.64950981317403e-5*x_24 - 2.17204824341374e-5*x_25 - 2.77599857397939e-5*x_26 - 3.56993279968209e-5*x_27 - 3.45291899059134e-5*x_28 - 4.31639483909222e-6*x_29 + 2.29513959444187e-7*x_3 - 2.92721840047781e-5*x_30 - 1.86057073574239e-5*x_31 + 2.04157082984772e-5*x_32 - 2.26646172772425e-6*x_33 + 3.54751294468486e-5*x_34 - 9.73581897600549e-5*x_35 - 1.16688383435011e-5*x_36 + 1.04945326151683e-5*x_37 - 8.9061119637105e-6*x_38 - 0.000143750873959515*x_39 + 2.88978531299209e-5*x_4 - 8.90754450137041e-6*x_40 - 2.55610491637356e-5*x_41 - 0.00013533912218743*x_42 - 2.44744158509161e-6*x_43 + 1.57615079533843e-5*x_44 - 1.26567765307782e-5*x_45 - 8.03173367878284e-6*x_46 - 2.76989973363376e-5*x_47 + 6.48244909442524e-5*x_48 + 1.74888964721924e-5*x_49 + 1.42464550607442e-5*x_5 - 2.18984630276005e-5*x_50 - 3.69054460712253e-5*x_51 - 5.09010280368089e-5*x_52 - 1.92949684140226e-5*x_53 - 3.48351410116032e-5*x_54 - 4.06525169731945e-5*x_55 + 1.19855886357972e-5*x_56 - 1.29152200333715e-5*x_57 - 9.75527230576289e-6*x_58 + 3.68158874983324e-5*x_59 - 8.74600983236991e-5*x_6 - 5.55382590668377e-5*x_60 - 6.17237969194988e-5*x_61 + 1.18741131707361e-5*x_62 - 3.35089240016065e-5*x_63 - 1.74095801605242e-5*x_64 + 2.18906922715669e-5*x_65 - 1.61434168902577e-5*x_66 - 7.50848336853576e-7*x_67 + 1.06980748527021e-5*x_68 - 8.67023081203305e-6*x_69 - 4.66526152701375e-6*x_7 - 3.16589055232049e-5*x_70 - 7.54102247681904e-6*x_71 - 3.49200796344439e-5*x_72 - 3.19309261046804e-5*x_73 - 1.79212688202039e-5*x_74 + 2.87393730320784e-6*x_75 - 6.67949860094756e-5*x_76 - 2.87285815230239e-5*x_77 - 1.19958516475601e-5*x_78 + 8.30774357070218e-6*x_79 - 6.80605995157471e-5*x_8 - 1.83765672488665e-5*x_80 - 3.16196132710518e-5*x_81 - 1.67232929647383e-6*x_82 - 0.000101993740607471*x_83 - 7.20619023712143e-5*x_84 - 9.20287335564507e-5*x_85 - 0.000130482560722063*x_86 - 1.46202272394411e-5*x_87 - 1.27735738392854e-5*x_88 - 3.21433973604813e-5*x_89 + 2.70841765142826e-6*x_9 - 2.07825363456236e-5*x_90 + 2.96620236703443e-5*x_91 - 1.06002226714544e-5*x_92 - 4.39798366079957e-7*x_93 - 3.40949644598011e-5*x_94 - 3.11215976570271e-5*x_95 - 3.88911295143879e-5*x_96 - 2.7546335552587e-5*x_97 - 3.5223741180707e-5*x_98 - 5.8130437840914e-5*x_99 + 4.02617600013468e-5*std::sin(2.76207995414734*x_25 - 5.79063987731934) + 0.0301723949202873);
}

inline float score_10(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (7.37893762853803e-5*x_1 + 7.66530009048925e-5*x_10 - 1.30668081199395e-5*x_100 - 7.89311643193481e-6*x_101 - 2.55792051114384e-5*x_102 + 2.36357823362759e-5*x_103 + 5.50772539413929e-5*x_104 + 1.51161918342541e-5*x_105 - 4.55083165290779e-5*x_106 - 9.77834931407878e-6*x_107 - 2.83056210911172e-5*x_108 + 2.77837550231485e-5*x_109 - 1.52313584145407e-5*x_11 - 5.55521710708002e-6*x_110 - 8.6498535473752e-6*x_111 - 2.68398586060307e-5*x_112 + 4.86129579132867e-5*x_113 + 4.08190070209136e-5*x_114 - 1.78723143311872e-5*x_115 + 8.60659411875791e-5*x_116 + 9.72872568979967e-6*x_117 + 2.38146428426705e-5*x_118 + 6.16717688788175e-6*x_119 - 1.73293791546251e-5*x_12 - 2.0683642011273e-5*x_120 + 3.38756391953604e-5*x_13 - 1.73166734597858e-5*x_14 + 4.29462962443212e-6*x_15 + 3.70773582587782e-5*x_16 - 1.06609221803663e-5*x_17 - 3.11348133986143e-5*x_18 - 1.20519723811264e-5*x_19 + 2.33125213434558e-5*x_2 - 1.60106425872011e-5*x_20 - 1.35366912864061e-5*x_21 + 2.14651897637932e-5*x_22 - 5.86429285513088e-6*x_23 - 5.66446394303435e-6*x_24 - 2.26651714506945e-5*x_25 - 2.35442437552175e-5*x_26 - 1.56721604461871e-5*x_27 - 7.56222558067416e-6*x_28 - 1.83454558946906e-5*x_29 - 1.71547838045808e-5*x_3 - 1.93608599568343e-5*x_30 + 7.24008201872498e-6*x_31 - 1.45420754963848e-6*x_32 + 9.96459290093632e-6*x_33 + 2.87741005888673e-5*x_34 + 2.98532494755697e-5*x_35 - 1.91066849643171e-6*x_36 - 1.33656268343909e-5*x_37 - 2.62929901752681e-5*x_38 - 7.51273549071231e-5*x_39 - 2.43362699997938e-5*x_4 - 1.26828238800008e-5*x_40 + 1.90651999110111e-6*x_41 - 1.28183036204208e-5*x_42 + 3.91062801534818e-5*x_43 + 1.63893729971862e-5*x_44 + 1.91426990560863e-5*x_45 - 1.66378526162907e-5*x_46 + 5.65701427157966e-7*x_47 - 4.23273480799864e-6*x_48 + 4.8392387588582e-5*x_49 + 2.04381645555402e-5*x_5 + 3.63703222857176e-6*x_50 + 1.30289984977685e-5*x_51 + 9.22246747188307e-5*x_52 + 9.59836612591833e-5*x_53 + 2.73692935506356e-5*x_54 - 2.46708477073179e-5*x_55 + 2.14128969214079e-5*x_56 + 2.3826155060275e-6*x_57 - 2.70681519329785e-5*x_58 - 4.69880265738558e-5*x_59 - 1.22727586078405e-5*x_6 - 3.55375138208555e-5*x_60 - 4.80506213051539e-6*x_61 + 2.97766378635893e-5*x_62 - 3.21023317956974e-5*x_63 - 1.00869036030936e-5*x_64 + 9.06322223627856e-6*x_65 + 5.40423752453571e-5*x_66 - 1.76815918452266e-5*x_67 + 1.47710477074026e-5*x_68 - 1.21442401748001e-6*x_69 - 8.08164658726436e-7*x_7 - 2.3426730957585e-5*x_70 - 4.48532999381148e-5*x_71 + 5.34019452151059e-6*x_72 - 2.48833630971705e-5*x_73 - 3.14387328953193e-6*x_74 + 1.72109491059398e-5*x_75 - 3.76647309463707e-5*x_76 + 2.77809338557725e-5*x_77 - 9.34530051050687e-6*x_78 - 2.36791549807238e-5*x_79 - 8.14316912012727e-6*x_8 + 1.06420988058345e-5*x_80 + 8.51973251451953e-6*x_81 + 3.75784019442633e-5*x_82 + 2.16840855976103e-5*x_83 - 9.43991859889362e-6*x_84 - 7.62059581338692e-5*x_85 + 1.44894190065496e-5*x_86 - 2.67491302813623e-5*x_87 + 6.63324404193919e-6*x_88 + 3.90443805463069e-5*x_89 + 4.37239717092241e-5*x_9 - 2.8322847602142e-6*x_90 - 0.000114247646696913*x_91 - 4.86329845404263e-5*x_92 - 2.56408782506189e-5*x_93 + 7.6379112265451e-5*x_94 + 4.54498233861074e-5*x_95 + 1.63543038619597e-5*x_96 - 5.98086216117309e-5*x_97 - 5.2857764848586e-5*x_98 - 5.66532701639844e-5*x_99 - 9.26461338482015e-6*std::sin(2.76207995414734*x_25 - 5.79063987731934) + 0.0468560151358578);
}

inline float score_11(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120){
    return (-0.0001322556518126*x_1 - 8.9879341622872e-5*x_10 + 4.17355595146917e-5*x_100 + 9.88478940181307e-5*x_101 + 5.8321365661238e-5*x_102 - 1.40481052571888e-6*x_103 + 7.1741460352346e-6*x_104 - 1.40004234020863e-5*x_105 + 4.01087361097792e-5*x_106 + 1.19374246817779e-6*x_107 + 7.24561480458908e-5*x_108 - 3.01175695040327e-5*x_109 - 2.30330240603227e-6*x_11 + 2.08210109979192e-5*x_110 + 2.43417710724356e-6*x_111 + 5.06130807093693e-5*x_112 + 3.48660226521514e-5*x_113 + 1.38750489200291e-5*x_114 + 3.47022749372242e-5*x_115 - 2.23980583783871e-5*x_116 - 1.38069480741572e-5*x_117 - 2.56288869408701e-5*x_118 + 5.1068929708451e-5*x_119 + 7.56060804251342e-5*x_12 + 7.9224340437541e-5*x_120 + 1.91346714460787e-5*x_13 - 1.67683832433831e-5*x_14 + 3.14718904330516e-5*x_15 - 1.78675305863538e-5*x_16 - 9.81384899120711e-6*x_17 + 5.2694949023807e-6*x_18 + 4.4599985808589e-5*x_19 + 9.91416655470486e-7*x_2 + 5.36942996579196e-5*x_20 + 2.76908883991468e-6*x_21 - 2.51974448824448e-5*x_22 + 2.47684322383086e-5*x_23 + 2.15525109232164e-5*x_24 + 4.00643092510728e-5*x_25 + 5.76356629819606e-5*x_26 + 5.54766255505926e-5*x_27 + 2.41017277112428e-5*x_28 + 3.86903328801865e-6*x_29 + 1.37589803648801e-5*x_3 + 7.64054961247808e-5*x_30 - 3.51732571907405e-5*x_31 - 4.38658967860817e-5*x_32 - 0.000132818943470553*x_33 - 5.18329849053908e-5*x_34 - 5.63635128710175e-5*x_35 + 1.29461306129591e-5*x_36 + 4.83120256172371e-9*x_37 + 2.76776459932735e-5*x_38 + 8.05897218975068e-6*x_39 + 8.52447102072965e-5*x_4 - 6.32257323349581e-5*x_40 - 1.84213970678869e-5*x_41 - 5.95158030015201e-5*x_42 - 1.35401905994247e-5*x_43 - 4.82835027429857e-5*x_44 - 1.34031166815583e-5*x_45 + 3.49712785868617e-5*x_46 - 6.49556091326828e-5*x_47 - 2.873735288787e-6*x_48 - 3.39508347301404e-5*x_49 - 2.46136391789755e-6*x_5 + 2.83765434413532e-5*x_50 - 2.22064442451385e-6*x_51 + 3.43382205112218e-5*x_52 - 9.55607414810939e-5*x_53 - 4.42936215259305e-5*x_54 + 7.38715097597628e-5*x_55 - 4.42251849096916e-5*x_56 - 1.78742265453646e-5*x_57 + 2.39285576736323e-5*x_58 + 5.19248304794444e-5*x_59 + 0.000141315371429914*x_6 + 6.74017516197228e-5*x_60 + 2.56464160482781e-5*x_61 - 4.17761208581527e-5*x_62 + 1.05361117526937e-5*x_63 + 1.36552399903132e-6*x_64 + 6.88817071931935e-6*x_65 - 2.9189546616869e-5*x_66 + 4.82982277493906e-5*x_67 - 1.32318644443924e-5*x_68 + 2.77409058093325e-5*x_69 + 7.88722962062538e-6*x_7 + 4.82372739121173e-5*x_70 + 4.75377061688232e-5*x_71 + 1.79941990592857e-5*x_72 + 2.80086972068895e-5*x_73 - 1.16626378989549e-5*x_74 + 2.41850235586041e-6*x_75 + 5.55522411964237e-5*x_76 - 4.41320861273465e-5*x_77 + 6.35226848368776e-6*x_78 + 8.42660457614305e-6*x_79 + 1.08116809018831e-5*x_8 - 3.93552443177881e-5*x_80 + 8.80523712768064e-6*x_81 + 1.8146516352063e-5*x_82 - 3.74354949490794e-5*x_83 + 2.68861826911925e-5*x_84 + 5.00098985492173e-5*x_85 - 7.96587836423254e-5*x_86 + 2.05717445674646e-5*x_87 + 1.73381875679625e-5*x_88 - 4.37927676232458e-5*x_89 - 1.07919169807644e-5*x_9 + 5.57925279684856e-6*x_90 - 6.36509953258704e-6*x_91 + 1.4502212766644e-5*x_92 + 1.77310346844616e-5*x_93 - 9.98278916937925e-5*x_94 - 5.84835860372086e-5*x_95 + 9.5873598657011e-7*x_96 - 1.17877635427131e-5*x_97 + 8.37102731018384e-5*x_98 + 5.31926714108178e-5*x_99 + 3.33253956793893e-5*std::sin(2.76207995414734*x_25 - 5.79063987731934) + 0.0307060891049122);
}

int predict(float x_1, float x_2, float x_3, float x_4, float x_5, float x_6, float x_7, float x_8, float x_9, float x_10, float x_11, float x_12, float x_13, float x_14, float x_15, float x_16, float x_17, float x_18, float x_19, float x_20, float x_21, float x_22, float x_23, float x_24, float x_25, float x_26, float x_27, float x_28, float x_29, float x_30, float x_31, float x_32, float x_33, float x_34, float x_35, float x_36, float x_37, float x_38, float x_39, float x_40, float x_41, float x_42, float x_43, float x_44, float x_45, float x_46, float x_47, float x_48, float x_49, float x_50, float x_51, float x_52, float x_53, float x_54, float x_55, float x_56, float x_57, float x_58, float x_59, float x_60, float x_61, float x_62, float x_63, float x_64, float x_65, float x_66, float x_67, float x_68, float x_69, float x_70, float x_71, float x_72, float x_73, float x_74, float x_75, float x_76, float x_77, float x_78, float x_79, float x_80, float x_81, float x_82, float x_83, float x_84, float x_85, float x_86, float x_87, float x_88, float x_89, float x_90, float x_91, float x_92, float x_93, float x_94, float x_95, float x_96, float x_97, float x_98, float x_99, float x_100, float x_101, float x_102, float x_103, float x_104, float x_105, float x_106, float x_107, float x_108, float x_109, float x_110, float x_111, float x_112, float x_113, float x_114, float x_115, float x_116, float x_117, float x_118, float x_119, float x_120)
{
    float s0 = score_0(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s1 = score_1(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s2 = score_2(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s3 = score_3(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s4 = score_4(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s5 = score_5(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s6 = score_6(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s7 = score_7(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s8 = score_8(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s9 = score_9(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s10 = score_10(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);
    float s11 = score_11(x_1, x_2, x_3, x_4, x_5, x_6, x_7, x_8, x_9, x_10, x_11, x_12, x_13, x_14, x_15, x_16, x_17, x_18, x_19, x_20, x_21, x_22, x_23, x_24, x_25, x_26, x_27, x_28, x_29, x_30, x_31, x_32, x_33, x_34, x_35, x_36, x_37, x_38, x_39, x_40, x_41, x_42, x_43, x_44, x_45, x_46, x_47, x_48, x_49, x_50, x_51, x_52, x_53, x_54, x_55, x_56, x_57, x_58, x_59, x_60, x_61, x_62, x_63, x_64, x_65, x_66, x_67, x_68, x_69, x_70, x_71, x_72, x_73, x_74, x_75, x_76, x_77, x_78, x_79, x_80, x_81, x_82, x_83, x_84, x_85, x_86, x_87, x_88, x_89, x_90, x_91, x_92, x_93, x_94, x_95, x_96, x_97, x_98, x_99, x_100, x_101, x_102, x_103, x_104, x_105, x_106, x_107, x_108, x_109, x_110, x_111, x_112, x_113, x_114, x_115, x_116, x_117, x_118, x_119, x_120);

    float max_score = s0;
    int max_index = 0;

    if(s1 > max_score) {
        max_score = s1;
        max_index = 1;
    }

    if(s2 > max_score) {
        max_score = s2;
        max_index = 2;
    }

    if(s3 > max_score) {
        max_score = s3;
        max_index = 3;
    }

    if(s4 > max_score) {
        max_score = s4;
        max_index = 4;
    }

    if(s5 > max_score) {
        max_score = s5;
        max_index = 5;
    }

    if(s6 > max_score) {
        max_score = s6;
        max_index = 6;
    }

    if(s7 > max_score) {
        max_score = s7;
        max_index = 7;
    }

    if(s8 > max_score) {
        max_score = s8;
        max_index = 8;
    }

    if(s9 > max_score) {
        max_score = s9;
        max_index = 9;
    }

    if(s10 > max_score) {
        max_score = s10;
        max_index = 10;
    }

    if(s11 > max_score) {
        max_score = s11;
        max_index = 11;
    }

    return max_index;
}

#endif
