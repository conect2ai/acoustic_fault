#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.48328841f, -0.28811425f, -0.33068743f, -0.01558638f, 0.36127102f, 0.56706846f, -0.30291244f, 0.41111699f, 
    0.08463819f, 0.03845396f, 0.45205843f, -0.34072322f, -0.11722749f, -0.39317846f, 0.40012208f, 0.04399397f, 
    -0.10294782f, 0.30389237f, -0.37410107f, 0.44206053f, -0.15762548f, -0.63750374f, -0.49805713f, -0.14508192f, 
    0.09097302f, 0.34276763f, -0.06411019f, 0.59776723f, 0.31984055f, -0.21244687f, -0.41997859f, 0.30069876f, 
    -0.11003488f, -0.26341987f, 0.38997784f, -0.05936794f, 0.51635832f, -0.87209404f, 0.47570530f, -0.41522020f, 
    -0.00534949f, 0.35734534f, 0.08454536f, -0.22120368f, 0.35128036f, -0.22776660f, 0.32511604f, -0.18767396f, 
    0.27049738f, 0.23413745f, -0.25280741f, -0.30087128f, 0.45559230f, 0.23183624f, 0.34536064f, -0.04718390f, 
    -0.10275078f, -0.50914317f, -0.32791647f, -0.50706327f, -0.30550489f, -0.35859996f, -0.23519523f, -0.10954209f, 
    0.02518148f, 0.52768821f, -0.50962782f, 0.12866269f, 0.32839641f, 0.04826040f, -0.13111694f, 0.31192470f, 
    0.37739503f, 0.31377175f, -0.16021286f, 0.35102770f, -0.15572390f, 0.38445625f, -0.05676049f, -0.19154504f, 
    -0.20309447f, 0.25418401f, 0.02225768f, 0.45208263f, -0.03868548f, 0.54934323f, -0.63681650f, 0.26830634f, 
    0.00960243f, 0.19159208f, 0.45305327f, 0.41803643f, 0.45372289f, 0.02678541f, 0.22922644f, -0.23572940f, 
    0.32971585f, -0.42737579f, -0.44497028f, 0.38895872f, -0.28508344f, 0.08420236f, 0.62355310f, 0.26564825f, 
    0.26067653f, 0.38222551f, 0.04726038f, -0.07121037f, 0.60436404f, -0.68362308f, 0.11903972f, -0.16746934f, 
    0.29011708f, -0.38737196f, -0.07691587f, -0.27006152f, -0.22550713f, -0.05585563f, 0.16205761f, 0.29653630f, 
    0.01334429f, -0.29745504f, -0.04087299f, -0.31540406f, -0.20514652f, 0.68710178f, -0.30682918f, 0.31106621f, 
    -0.34767121f, 0.34228608f, 0.06123033f, 0.18910971f, 0.33794862f, 0.21098085f, 0.38290125f, -0.15551779f, 
    -0.41902390f, 0.24541038f, -0.42345008f, 0.35097700f, -0.60217512f, -0.08361295f, 0.22205830f, -0.10741381f, 
    -0.27470684f, 0.60771143f, -0.28624392f, -0.12679522f, 0.24022506f, -0.01910579f, -0.27480197f, -0.10865596f, 
    0.45720214f, -0.10883898f, -0.50911117f, -0.63589054f, 0.60013062f, 0.38362303f, 0.13862740f, 0.01877844f, 
    0.06862602f, -0.32391825f, -0.49008235f, -0.00467567f, 0.63615495f, -0.46179798f, -0.60501337f, 0.92337829f, 
    0.25836939f, -0.22946058f, -0.42646712f, -0.86833644f, 0.28574789f, -0.12445683f, -0.01713013f, 0.08839525f, 
    -0.30448633f, -0.16167895f, -0.34949735f, -0.17731497f, -0.75473171f, -0.73438251f, 0.44864100f, 0.68368757f, 
    0.59100956f, 0.00162036f, -0.15676916f, 0.10410525f, -0.34519562f, 0.04980693f, -0.02716859f, -0.35536793f, 
    -0.57244253f, -0.31305930f, -0.32103166f, 0.02887743f, -0.10393327f, 0.64154524f, -0.41547856f, -0.26063016f, 
    -0.36017284f, 0.26447004f, -0.57165408f, -0.40318125f, -0.29449013f, -0.23869970f, -0.16126037f, 0.56599665f, 
    0.14879321f, 0.55520540f, 0.35891005f, -0.73171192f, -0.10897001f, -0.13476653f, 0.06495085f, 0.00997811f, 
    0.43205079f, 0.37141564f, 0.31316185f, 0.12621135f, 0.34835154f, 0.11897983f, 0.30178210f, 0.04097330f, 
    0.17180729f, -0.33912751f, 0.35972005f, 0.51508409f, 0.25325269f, -0.39855203f, -0.57432091f, -0.25034091f, 
    -0.32874426f, -0.02564946f, 0.13524084f, 0.42273927f, 0.38002720f, -0.75332063f, -0.41992569f, -0.12772779f, 
    0.33399555f, 0.07405369f, 0.02448784f, 0.08510172f, 0.00136961f, -0.53062028f, -0.27744794f, 0.32017654f, 
    -0.50700372f, 0.29340094f, 0.50520211f, 0.11447051f, 0.84971225f, -0.62733513f, -0.49386215f, 0.04752585f, 
    0.01589858f, 0.48401240f, 0.13791154f, -0.03556236f, -0.23288025f, -0.54892224f, -0.57705009f, -0.05986622f, 
    0.59719777f, -0.05652532f, -0.42928883f, -0.04387501f, 0.22632350f, 0.37646028f, -0.42684054f, -0.30638808f, 
    0.06456814f, 0.30530325f, 0.11998373f, -0.35606530f, -0.22814180f, -0.22035153f, -0.13213430f, -0.66657901f, 
    0.82100636f, -0.87037426f, -0.44499627f, 0.43660522f, -0.07639411f, -0.19867897f, 0.01481373f, -0.15545177f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.22732367f, 0.09090830f, 0.11663064f, 0.18167613f, 0.06493434f, 0.21304189f, -0.29931873f, 0.22949934f, 
    0.22925328f, 0.18516017f, -0.23643941f, -0.48458233f, -0.02432978f, -0.19986995f, -0.05527378f, -0.23476915f, 
    0.08654548f, -0.03111368f, -0.18153337f, -0.29896566f, -0.22238174f, -0.22463813f, -0.14599591f, -0.24113005f, 
    0.01640828f, -0.09129287f, -0.16336080f, 0.28086281f, 0.01291143f, -0.05212067f, 0.16820554f, -0.07092230f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.01347935f, 0.24459559f, 0.06294120f, -0.04378677f, -0.05898217f, 0.07233326f, 0.05791596f, -0.14197290f, 
    -0.15497358f, 0.07160196f, 0.14224082f, 0.08154658f, 0.15544419f, 0.13164447f, 0.14795327f, 0.00146044f, 
    -0.00999353f, 0.09057029f, 0.02029338f, -0.00144962f, 0.00365634f, 0.01362105f, 0.21366090f, 0.05064367f, 
    0.05753557f, 0.11101014f, 0.25602147f, -0.16891725f, 0.07984500f, 0.05115122f, -0.03188381f, -0.02815338f, 
    0.01557752f, 0.01081102f, 0.09905516f, 0.11627237f, 0.10364147f, 0.13860682f, -0.18377802f, 0.00322402f, 
    -0.02269091f, 0.11553624f, 0.19234338f, 0.08949428f, 0.15588850f, 0.07573251f, 0.19745962f, -0.06813551f, 
    -0.06705863f, -0.07179087f, 0.01096476f, -0.03632545f, 0.22542511f, -0.03275285f, -0.17938583f, -0.34292555f, 
    0.07624060f, -0.14589401f, 0.05367876f, 0.28463787f, -0.04721444f, 0.00857742f, -0.02923308f, -0.09293597f, 
    0.15136647f, -0.21030907f, 0.09178026f, 0.06663524f, -0.13234125f, 0.17957257f, -0.02912920f, 0.07635604f, 
    -0.37342718f, -0.10692370f, 0.08291773f, -0.13546179f, 0.00135272f, 0.02131106f, -0.01383178f, 0.10543150f, 
    -0.01276422f, -0.04299150f, 0.24449168f, -0.10736534f, 0.07901955f, 0.10934900f, -0.02577866f, -0.07863753f, 
    0.05689497f, 0.19590004f, -0.54257005f, -0.10174533f, -0.08365504f, -0.24860787f, -0.09046653f, 0.01145392f, 
    -0.02664213f, 0.15522826f, -0.07486358f, -0.27227923f, -0.14446463f, 0.08032145f, -0.11195024f, -0.04667413f, 
    0.01873282f, -0.12071569f, -0.03146594f, -0.15706426f, 0.13951118f, 0.02132318f, 0.25552309f, -0.01237471f, 
    0.00100057f, 0.00925769f, -0.03455575f, 0.10612820f, 0.13766000f, 0.00996260f, 0.17156997f, -0.09319091f, 
    0.03715559f, 0.20743169f, -0.07782123f, 0.00931103f, 0.08184820f, 0.05802428f, -0.04454266f, -0.03457649f, 
    -0.01241130f, -0.12336770f, 0.05348407f, -0.12118696f, -0.15547210f, 0.09832852f, 0.01644106f, 0.05117613f, 
    0.03493502f, 0.02026024f, -0.03231609f, 0.07248131f, 0.02009109f, 0.08057966f, 0.05502198f, -0.05548711f, 
    -0.09999421f, 0.16306704f, -0.12522127f, 0.08866071f, 0.14778432f, -0.01753778f, 0.06251343f, 0.17022169f, 
    0.03172440f, -0.01473272f, 0.05543881f, 0.37769386f, -0.09199954f, 0.02716043f, 0.03190354f, 0.00079842f, 
    -0.02017405f, -0.24234141f, 0.05317779f, 0.41195431f, -0.32058990f, -0.01730920f, -0.04185172f, -0.09714200f, 
    0.14411370f, -0.08990747f, 0.14930418f, -0.03013522f, 0.00726783f, 0.13520382f, 0.04112577f, 0.11108075f, 
    -0.07306624f, 0.08607159f, 0.01663183f, -0.05486573f, -0.03106669f, -0.04632411f, 0.10671148f, 0.11894283f, 
    -0.06200853f, 0.03395879f, 0.02238718f, -0.04621684f, -0.09204644f, -0.24581128f, -0.13971831f, 0.18568280f, 
    0.00743844f, 0.00287419f, 0.04826213f, 0.18643485f, 0.12072156f, 0.19331630f, -0.01543851f, -0.31402913f, 
    0.24721760f, -0.05736281f, 0.14386320f, -0.04266466f, 0.03827098f, -0.04715669f, -0.15274708f, -0.25755191f, 
    -0.32862091f, 0.06354380f, -0.15377201f, 0.05648085f, 0.02069023f, -0.01281736f, 0.12901953f, -0.02715164f, 
    -0.34938809f, -0.12392416f, -0.21035181f, -0.02929373f, 0.01624905f, -0.10755164f, -0.07802972f, -0.03751663f, 
    -0.15702231f, -0.14977951f, -0.18310833f, 0.02854003f, 0.08514363f, 0.14507984f, 0.10747430f, 0.02718758f, 
    0.05118556f, 0.03513524f, -0.23469938f, -0.22855954f, 0.07768293f, -0.10300665f, 0.12515067f, 0.04661650f, 
    -0.02909836f, 0.04407151f, 0.15183888f, -0.12580945f, 0.11805509f, 0.09693517f, 0.02179763f, -0.04382489f, 
    0.05338683f, -0.04893237f, 0.11509693f, 0.19690721f, 0.02836949f, 0.06729645f, 0.17773621f, -0.07663850f, 
    0.18462406f, 0.20116585f, -0.04740416f, 0.06009782f, -0.03202836f, -0.07278672f, 0.09237269f, 0.21656460f, 
    -0.13461752f, -0.07882091f, 0.10089707f, 0.07281863f, 0.02496916f, -0.14722036f, 0.03952300f, -0.03551277f, 
    0.16832234f, 0.00078412f, 0.01003382f, -0.01070338f, 0.04346216f, -0.04185971f, -0.11005787f, -0.05909358f, 
    0.28680539f, 0.14029044f, 0.14812298f, 0.05478289f, 0.01802725f, 0.11794783f, -0.04910431f, 0.00534132f, 
    -0.19188119f, -0.21039528f, 0.07767741f, 0.03047989f, 0.06566162f, 0.06976698f, -0.01531262f, -0.01965688f, 
    0.07823877f, -0.06819046f, 0.27117756f, -0.15810223f, -0.15674357f, 0.03486326f, -0.10705900f, 0.01674916f, 
    0.01315189f, 0.05610338f, -0.01120598f, 0.04015053f, -0.05124774f, -0.02789861f, -0.02013865f, -0.04219650f, 
    -0.03919316f, -0.02306903f, -0.04904925f, -0.19568594f, 0.08392093f, -0.17743315f, 0.07263803f, -0.13446972f, 
    0.02517409f, 0.08632204f, -0.01034115f, -0.13420489f, -0.18511377f, 0.19362795f, -0.10307834f, 0.02314589f, 
    -0.02567968f, -0.02660029f, 0.08307720f, 0.01622429f, -0.04967247f, 0.04729229f, -0.16978028f, -0.08982825f, 
    -0.01451933f, 0.03756800f, 0.05039028f, -0.13506253f, -0.13237213f, -0.11782484f, 0.05709529f, 0.20093624f, 
    0.22935662f, 0.17733340f, 0.12068556f, 0.10136964f, -0.11033474f, -0.04363631f, -0.14237259f, -0.01927448f, 
    0.08079141f, -0.04375048f, -0.05975913f, -0.03996943f, -0.01017459f, 0.02134664f, -0.03239846f, 0.02410886f, 
    -0.09502375f, 0.17756809f, -0.19420291f, 0.07151790f, -0.06518381f, 0.05619220f, -0.05224988f, 0.07911883f, 
    0.15695167f, 0.15693866f, -0.20378888f, 0.02431159f, -0.11189140f, 0.04014562f, 0.18332449f, 0.00025479f, 
    -0.04978521f, -0.16078271f, 0.20555636f, -0.00729532f, -0.08610737f, -0.00739866f, -0.00601772f, -0.08590320f, 
    -0.07253295f, -0.01724823f, -0.05545405f, -0.20380098f, -0.21816339f, -0.01148048f, 0.11907961f, 0.07432320f, 
    0.12524678f, -0.16978791f, -0.08389632f, -0.02799130f, 0.00470200f, 0.10396045f, 0.13477227f, 0.01166901f, 
    0.03173019f, 0.00015659f, 0.10172644f, 0.03328368f, 0.05543219f, 0.00736646f, 0.06391361f, 0.07995341f, 
    0.12443503f, 0.02246276f, 0.12823847f, 0.10593586f, -0.00463350f, -0.07457225f, -0.05930656f, -0.12206239f, 
    -0.09134847f, 0.00929413f, 0.06082878f, 0.04987942f, -0.23173691f, -0.29289061f, -0.18866627f, 0.06608111f, 
    -0.05429990f, 0.22129449f, -0.06782136f, 0.09226603f, 0.06281207f, 0.12414024f, 0.06309655f, 0.02802537f, 
    -0.21789470f, 0.01717394f, -0.10029050f, 0.13418144f, -0.06006587f, -0.00432772f, -0.01963661f, -0.02077393f, 
    -0.09740657f, -0.21296759f, -0.27166134f, 0.31992260f, 0.08140723f, 0.13433141f, 0.05214591f, 0.10364796f, 
    0.20739605f, 0.17682266f, 0.23285982f, 0.03163394f, -0.03265322f, 0.00718480f, 0.06236166f, 0.02293184f, 
    0.06537427f, 0.00257593f, 0.06527242f, 0.07096236f, 0.06914972f, -0.00596370f, -0.03698094f, 0.01450208f, 
    0.02486829f, 0.11707575f, 0.14057265f, 0.00688833f, -0.02145259f, -0.35140201f, 0.03865137f, -0.01574216f, 
    0.01710763f, 0.16874297f, 0.05352692f, 0.11137203f, 0.14835869f, -0.08729247f, 0.17253719f, 0.10359401f, 
    0.20224541f, 0.01603079f, -0.05164198f, 0.07746269f, -0.03666380f, -0.24313216f, 0.10903010f, 0.03367047f, 
    0.10623354f, -0.04047202f, 0.01647274f, 0.05812735f, 0.02144034f, -0.01413524f, -0.04610467f, 0.35352156f, 
    0.02008780f, -0.23516208f, -0.14750069f, -0.02813667f, 0.00369449f, -0.03782141f, 0.01791318f, -0.00675183f, 
    0.04141153f, -0.00637083f, 0.05177753f, 0.02321742f, -0.04360632f, 0.04943081f, -0.20964380f, -0.00671935f, 
    0.05039112f, 0.26852646f, 0.23391104f, -0.00970504f, 0.05783713f, -0.12528795f, 0.10079946f, 0.05172332f, 
    0.10492213f, -0.02925047f, -0.04982525f, 0.28037962f, 0.00656366f, 0.04815290f, -0.03410324f, -0.05467704f, 
    -0.04417982f, 0.00147883f, -0.07596196f, 0.02408966f, 0.06026084f, -0.03344987f, 0.04375450f, 0.08496403f, 
    -0.04662318f, 0.00038054f, -0.03635885f, -0.14484894f, -0.27993271f, 0.16163507f, -0.10243160f, 0.06947086f, 
    0.05484219f, 0.02684908f, 0.03073512f, 0.00524280f, 0.08790344f, 0.09672857f, -0.24175993f, 0.12754782f, 
    0.07470386f, -0.05667975f, 0.07375565f, -0.07015727f, 0.06954455f, -0.01115604f, 0.01617334f, -0.01882957f, 
    0.09792323f, 0.01085534f, -0.01171460f, 0.06666617f, 0.03755530f, 0.00713865f, 0.12365340f, -0.14761916f, 
    0.09568719f, -0.05217009f, -0.07110918f, -0.06401496f, 0.05140700f, 0.05780411f, 0.07932281f, 0.03530605f, 
    -0.19281518f, -0.31381357f, -0.21339539f, 0.11915842f, 0.11258142f, 0.12885150f, 0.01696988f, 0.07451067f, 
    0.10045002f, 0.02070830f, -0.17900488f, 0.03950600f, 0.00658342f, -0.03373643f, -0.12890859f, 0.05756067f, 
    0.10797615f, 0.01398780f, 0.05369552f, 0.10266181f, 0.11816020f, -0.04332352f, -0.02466754f, -0.01368257f, 
    -0.01507379f, 0.05965587f, 0.02088633f, 0.02773732f, -0.31246224f, -0.11259938f, -0.02693403f, 0.04945382f, 
    0.04745643f, 0.11915438f, 0.03602481f, 0.08721974f, -0.30145329f, -0.10887723f, -0.08133729f, -0.09597526f, 
    0.04507760f, -0.04782717f, 0.02891400f, 0.00314740f, -0.01194403f, -0.03293012f, -0.24432507f, -0.12030141f, 
    -0.01018870f, 0.05020797f, -0.06014778f, -0.03288497f, 0.18349810f, -0.02730567f, 0.03903432f, 0.22957884f, 
    0.12999254f, 0.00363389f, 0.00678960f, 0.00421535f, 0.01454085f, -0.00075085f, 0.06509273f, -0.06742309f, 
    -0.06084494f, 0.03623988f, -0.00639549f, 0.04200854f, 0.01609314f, -0.05257726f, 0.07676822f, -0.05481612f, 
    0.21128564f, -0.09890197f, -0.13551381f, -0.05797824f, -0.12352569f, -0.02601514f, 0.07453987f, -0.01637544f, 
    0.06043699f, -0.11507771f, -0.03468286f, 0.09482890f, -0.10417054f, -0.02049836f, -0.05662456f, 0.09333979f, 
    0.06146173f, -0.04381757f, -0.05737325f, -0.22647895f, 0.17891566f, 0.00676384f, 0.02550753f, -0.00668645f, 
    0.03693370f, -0.05767531f, -0.01929900f, -0.03219978f, -0.26348141f, -0.26383311f, -0.14571975f, -0.03076124f, 
    -0.09274720f, 0.08828831f, 0.01583015f, 0.05996144f, 0.28137228f, -0.02650040f, 0.07390380f, -0.09989364f, 
    0.03442907f, 0.03557029f, 0.03099028f, -0.04095347f, -0.06993726f, -0.09215886f, -0.17665748f, 0.08267970f, 
    -0.11984073f, 0.03714617f, -0.06746358f, 0.23531850f, 0.15339860f, -0.02094232f, -0.05873477f, -0.12026642f, 
    -0.19675551f, 0.03785338f, -0.02803370f, 0.05567010f, 0.04346611f, -0.02425447f, -0.05170255f, 0.11970086f, 
    0.11268630f, 0.15912029f, -0.06076861f, 0.03203239f, 0.05901701f, 0.01868667f, -0.04833777f, -0.03280425f, 
    -0.20357561f, -0.22243711f, -0.11270459f, 0.09519231f, 0.13147506f, 0.03315174f, 0.03520013f, 0.16325845f, 
    -0.13534170f, 0.04383232f, -0.29213008f, -0.35764951f, 0.05689519f, 0.04341746f, 0.00297367f, 0.07056260f, 
    -0.02498469f, 0.04342481f, -0.74562985f, 0.07208999f, 0.10851428f, 0.03252347f, -0.11722040f, -0.13800097f, 
    0.04200069f, -0.00345967f, -0.03368102f, -0.08562724f, 0.04453387f, 0.05667427f, -0.11146117f, -0.07666725f, 
    0.05263547f, 0.17655140f, -0.03242217f, 0.04067776f, 0.06361631f, -0.28475833f, -0.16206823f, -0.13451570f, 
    -0.10301547f, 0.02261850f, 0.13322023f, 0.01382737f, 0.17378984f, 0.09735381f, 0.15563063f, 0.29559818f, 
    -0.07109190f, 0.07762704f, -0.10823014f, 0.04261137f, -0.05154131f, 0.04057262f, 0.10657265f, 0.22864555f, 
    0.19740093f, 0.01301671f, 0.15929419f, 0.01256755f, 0.10908287f, -0.08707475f, -0.00730928f, -0.22278233f, 
    -0.49544150f, 0.03409582f, -0.19211733f, 0.08373028f, -0.01398458f, 0.06620432f, 0.01029981f, 0.05673372f, 
    -0.02651706f, -0.24363725f, -0.13608538f, 0.12718420f, 0.04293618f, 0.07242225f, 0.10748885f, 0.01064454f, 
    0.09529721f, -0.19684184f, -0.09499566f, -0.11316496f, -0.00082789f, 0.02362536f, -0.02115519f, -0.03737082f, 
    0.06875212f, -0.02343778f, -0.22261830f, -0.01065715f, 0.14413090f, -0.08562800f, -0.09179801f, -0.04758204f, 
    -0.02493985f, 0.04585838f, 0.11535404f, 0.04997366f, 0.06436801f, 0.16825631f, 0.02421061f, 0.09102855f, 
    -0.01128561f, 0.03255938f, 0.09445996f, 0.00434248f, 0.34709230f, -0.32429048f, -0.26786497f, 0.01951588f, 
    -0.09919132f, -0.12345897f, 0.09115200f, 0.01538005f, -0.12993209f, 0.03948454f, 0.04135051f, 0.14877468f, 
    -0.09834296f, 0.09662744f, 0.12730958f, -0.03731104f, -0.03402136f, 0.09256941f, 0.06699799f, 0.05606508f, 
    0.05594122f, -0.01280066f, 0.03078536f, 0.10418002f, 0.05795809f, -0.02686957f, -0.02217359f, -0.22760554f, 
    -0.03029687f, 0.12571117f, 0.04905752f, 0.12124360f, 0.06251988f, 0.05202306f, 0.08698516f, -0.16518132f, 
    0.37764227f, -0.40837786f, 0.03727004f, -0.00053283f, 0.17012836f, 0.00056839f, 0.05426367f, -0.05596547f, 
    -0.06112846f, 0.02773828f, -0.15257707f, 0.02612999f, 0.11522617f, 0.27279243f, -0.03667737f, 0.04737144f, 
    0.18274842f, 0.00564687f, 0.13337609f, -0.12338752f, 0.21867076f, -0.04110721f, -0.00768152f, -0.08316288f, 
    0.05034147f, 0.13061862f, 0.08408178f, -0.23326048f, 0.22431214f, 0.09183303f, 0.00206894f, 0.09613644f, 
    -0.06997404f, 0.08684258f, 0.14361146f, 0.13514367f, 0.18864582f, -0.15831614f, -0.11421280f, -0.05324857f, 
    0.14179397f, -0.11775522f, 0.25017753f, 0.02505492f, -0.08320774f, 0.03242316f, 0.03860047f, 0.05008126f, 
    -0.03444435f, 0.13015394f, 0.01003817f, 0.10020303f, 0.06801531f, -0.11358468f, -0.05318800f, 0.22961600f, 
    -0.04753748f, -0.00679983f, 0.01094308f, -0.01903524f, 0.01656225f, -0.05363853f, 0.04019246f, 0.22391480f, 
    0.03498603f, 0.15168867f, 0.00461356f, 0.08689968f, -0.03862843f, 0.08385338f, 0.07931160f, 0.08847576f, 
    -0.29424265f, 0.15986919f, 0.22522449f, -0.04008368f, 0.08075224f, -0.02196334f, 0.06632427f, 0.11807735f, 
    0.11619560f, 0.08701086f, 0.19942886f, -0.14000115f, 0.01637155f, -0.00077999f, -0.01983682f, -0.02070552f, 
    0.08080085f, 0.10420865f, -0.21909265f, 0.20920929f, 0.04300773f, 0.08208165f, -0.13983896f, -0.13179983f, 
    -0.09193832f, -0.02115916f, 0.17594710f, 0.04260033f, 0.19233106f, -0.31082597f, -0.22023545f, -0.08996454f, 
    -0.14584257f, 0.11067239f, -0.15762511f, 0.05413496f, 0.14051495f, 0.22393155f, -0.19691510f, 0.01143348f, 
    0.27565658f, -0.09658584f, 0.03537470f, 0.07102358f, -0.06569675f, 0.05834280f, -0.10042293f, 0.00544454f, 
    -0.05352750f, -0.10665317f, -0.03938050f, 0.07863315f, 0.17248179f, 0.03532985f, 0.17274140f, -0.03125240f, 
    -0.10307823f, -0.08121131f, 0.05365813f, -0.04455486f, 0.22036180f, 0.05785567f, -0.09166119f, 0.10630519f, 
    0.09866470f, -0.17475718f, -0.19718203f, 0.10280658f, 0.02583355f, -0.07068353f, 0.10407733f, 0.04217768f, 
    -0.00276577f, -0.04908480f, -0.01687510f, 0.09456231f, 0.17785686f, 0.09355473f, -0.03064385f, 0.03764538f, 
    0.10748865f, -0.21388459f, -0.41730958f, -0.31969258f, -0.16493590f, 0.02049089f, 0.06716544f, -0.09831747f, 
    -0.05184817f, -0.06071302f, 0.06969724f, 0.20588337f, 0.12768097f, 0.05092923f, -0.11696585f, -0.23532815f, 
    -0.01200469f, -0.13757735f, 0.13463502f, 0.14783919f, -0.07702188f, -0.42478833f, -0.24159975f, 0.04811588f, 
    0.28988868f, 0.02793771f, 0.17988458f, -0.03943273f, -0.01087504f, -0.31689227f, -1.01710820f, -0.10139979f, 
    -0.08890510f, 0.00165122f, -0.04535354f, -0.00102371f, -0.15044391f, -0.03914794f, -0.15984857f, 0.08385582f, 
    0.06438357f, -0.05855562f, -0.07685354f, -0.04359471f, 0.00656785f, 0.04740611f, 0.12000703f, 0.23324010f, 
    -0.39360636f, -0.11607626f, -0.19564915f, 0.21899639f, 0.08421218f, 0.03914641f, 0.16188945f, 0.06090565f, 
    0.06748688f, -0.09377392f, -0.01383255f, -0.32846418f, -0.01598281f, -0.04696120f, -0.01053807f, -0.04479707f, 
    0.09609318f, 0.30221149f, 0.10418080f, -0.12933215f, -0.13168746f, -0.06650871f, 0.09385591f, 0.01404971f, 
    0.05862668f, -0.03002282f, 0.09953239f, 0.01804615f, 0.03374673f, -0.16860645f, -0.00998448f, 0.00401335f, 
    -0.02169050f, 0.09611988f, 0.01096518f, 0.08732871f, 0.39970645f, -0.09323034f, -0.28791684f, -0.06511548f, 
    -0.02669633f, 0.07489128f, 0.02792222f, -0.26372612f, 0.08595916f, -0.17084959f, 0.01692704f, 0.24214944f, 
    0.07015451f, 0.10954661f, 0.09938674f, 0.15710947f, -0.37710080f, -0.11737958f, -0.21569936f, -0.15465057f, 
    0.30999622f, -0.14630012f, 0.05215291f, 0.08879907f, 0.04924265f, -0.06351392f, -0.19692093f, -0.73402834f, 
    -0.12909946f, -0.11488023f, 0.18047997f, 0.26549509f, -0.11251551f, -0.12409294f, -0.14736433f, -0.05017392f, 
    -0.38407120f, 0.00829332f, -0.11105929f, 0.14139214f, 0.05947316f, 0.06974399f, -0.00798706f, -0.07478210f, 
    -0.42042077f, -0.38759029f, -0.05445928f, 0.22683336f, -0.02746251f, 0.08562955f, -0.11028938f, -0.04156001f, 
    -0.02213603f, -0.04576801f, -0.04294851f, -0.00204609f, 0.02094840f, 0.02867996f, -0.04676329f, 0.00565522f, 
    -0.01867642f, -0.06084401f, 0.04232829f, -0.04403674f, -0.01070522f, 0.00634683f, -0.06054106f, 0.00772298f, 
    -0.02491079f, 0.04073906f, -0.01019199f, 0.00658545f, -0.03881430f, -0.02979973f, -0.05336537f, -0.01030731f, 
    -0.02685728f, 0.01959017f, -0.05488556f, -0.06068631f, 0.05133943f, -0.04604754f, -0.06021208f, -0.05180552f, 
    -0.02939673f, -0.04878687f, -0.02005089f, -0.04643737f, 0.02909483f, 0.00353789f, 0.02361621f, 0.01530552f, 
    -0.01930087f, 0.00345038f, 0.03150870f, -0.05430330f, -0.01537654f, -0.01809598f, -0.02883678f, 0.01022885f, 
    0.02940242f, -0.05216795f, -0.01841821f, -0.03024796f, -0.04501568f, 0.04091374f, -0.05209852f, 0.03557932f, 
    0.01923957f, -0.04740987f, 0.00667425f, -0.01367587f, -0.04270941f, -0.05570357f, -0.01940951f, -0.02446220f, 
    -0.05632665f, 0.00745200f, 0.01109272f, 0.03124110f, -0.03153437f, -0.02926959f, -0.02050581f, 0.02185584f, 
    0.00335155f, -0.02864512f, -0.04108584f, -0.05203474f, -0.01405225f, -0.03422504f, -0.05175683f, 0.01246697f, 
    -0.00462403f, -0.04165950f, 0.03066067f, -0.01170828f, -0.04862083f, -0.01137021f, 0.04030591f, -0.05518904f, 
    0.00985412f, -0.03549695f, 0.03569283f, 0.00576258f, 0.05077277f, -0.03633029f, 0.02796486f, 0.00021439f, 
    0.00879358f, 0.02325597f, -0.02112742f, 0.00926888f, 0.04244149f, 0.04670587f, -0.04224560f, -0.00300622f, 
    -0.00832908f, -0.00132296f, -0.04766965f, -0.04021322f, -0.00333147f, 0.03345768f, -0.05312862f, -0.01316162f, 
    -0.02942334f, -0.00914116f, 0.04416468f, 0.02917788f, -0.00375273f, -0.01587429f, 0.01902459f, 0.00725615f, 
    -0.05731678f, -0.00205845f, 0.00556260f, -0.04913751f, -0.05873124f, -0.04604845f, 0.02695398f, 0.01051117f, 
    -0.02055174f, -0.02714754f, -0.04399854f, -0.02663578f, -0.03584254f, -0.03043754f, -0.05781110f, -0.00083189f, 
    0.04186432f, 0.04906652f, 0.00500306f, -0.00469509f, -0.06234084f, 0.03661196f, -0.00307469f, -0.03048534f, 
    0.01587393f, -0.01089149f, 0.03062967f, 0.00704870f, -0.00674887f, 0.03979934f, 0.03306614f, 0.03564883f, 
    -0.05281634f, 0.01958874f, -0.05167435f, 0.00829036f, -0.03093678f, 0.00266688f, -0.03964262f, 0.01304882f, 
    -0.05825372f, -0.04734264f, -0.05844098f, 0.03318827f, -0.04728415f, 0.01434194f, -0.04654866f, 0.04648879f, 
    0.02842299f, -0.05656428f, -0.04759370f, 0.02949618f, 0.04745186f, 0.04970857f, 0.00382420f, -0.05753943f, 
    -0.02010874f, 0.01545958f, -0.03614178f, -0.02416435f, -0.00575485f, -0.05317884f, 0.05020779f, -0.02964376f, 
    0.00197119f, -0.00824484f, -0.03545775f, -0.01608109f, 0.03476766f, -0.04192767f, -0.03530559f, 0.04353318f, 
    -0.04903444f, -0.01686177f, -0.04958524f, -0.05728544f, -0.04762551f, 0.00597135f, 0.04107122f, 0.05531476f, 
    -0.02671036f, 0.01929658f, -0.02799439f, 0.03066312f, 0.04732215f, 0.00102528f, 0.04184629f, -0.01997555f, 
    -0.03268529f, 0.04809527f, 0.04978343f, -0.04130195f, 0.04203061f, -0.04638606f, -0.01559294f, -0.02261898f, 
    0.03671610f, 0.01942944f, -0.01207417f, -0.04617213f, 0.04561597f, 0.01520680f, -0.06222715f, -0.05294808f, 
    -0.02980688f, -0.02574805f, -0.05015680f, -0.01674558f, -0.02459334f, -0.06003989f, 0.03238416f, -0.05394178f, 
    -0.04341510f, 0.00005525f, -0.01178419f, -0.01247350f, 0.01386980f, -0.06199459f, 0.04184846f, 0.02144998f, 
    -0.02237233f, 0.00501392f, -0.03682456f, -0.04488006f, -0.00561275f, 0.02457752f, -0.03489593f, 0.02695811f, 
    -0.01653444f, 0.01947291f, 0.00085577f, -0.00906848f, 0.01494024f, -0.03404585f, 0.01424933f, 0.03268206f, 
    0.01094310f, -0.04981907f, 0.00045232f, 0.04209711f, -0.01531324f, 0.01062889f, -0.00958447f, -0.04898683f, 
    -0.02389700f, 0.04629627f, -0.05334480f, -0.05335338f, -0.05194002f, -0.03605022f, 0.04825654f, -0.04902013f, 
    0.03707132f, 0.02792007f, 0.00710780f, 0.00389270f, -0.02065263f, -0.02371828f, 0.04158369f, 0.03973010f, 
    -0.01677290f, 0.03280279f, -0.01694549f, 0.01201446f, -0.01162615f, -0.03862026f, -0.05496755f, -0.04866803f, 
    -0.02707943f, -0.01313071f, -0.28402027f, 0.00545208f, -0.00712744f, -0.11799855f, -0.06076688f, 0.00431049f, 
    0.03569052f, -0.33236331f, 0.26274681f, -0.24980775f, 0.24448131f, -0.05327306f, 0.25440386f, 0.03689590f, 
    0.04894807f, -0.03990459f, -0.24978238f, -0.09380002f, 0.04899802f, -0.12801249f, -0.09765040f, -0.02758198f, 
    0.10568699f, -0.02423819f, 0.09091340f, 0.29704461f, 0.02771827f, 0.30073896f, -0.02086617f, -0.03280205f, 
    0.12015900f, -0.03470379f, 0.11242069f, 0.04249101f, -0.10739791f, 0.20383969f, -0.00417048f, 0.13234331f, 
    0.14253686f, 0.01584945f, 0.00267657f, 0.08628345f, 0.02648651f, 0.00237875f, 0.02802705f, 0.10534446f, 
    -0.11009028f, -0.00099084f, 0.02613365f, -0.01829766f, 0.08640699f, -0.06998805f, 0.06623801f, -0.30755445f, 
    -0.09163523f, -0.00033149f, 0.03505106f, 0.11029159f, 0.00908141f, 0.04609884f, -0.07645538f, 0.01842237f, 
    0.17850067f, -0.00192384f, 0.18193655f, -0.05073063f, -0.07359198f, 0.01469880f, 0.11534069f, 0.12639929f, 
    0.11091989f, -0.07077245f, 0.06392149f, -0.09157833f, -0.07661077f, -0.01600987f, 0.09384869f, 0.04633179f, 
    0.07748986f, 0.15473220f, 0.15987088f, -0.00854201f, -0.04449058f, 0.10543589f, -0.08241290f, 0.02256830f, 
    0.02920211f, 0.07018536f, 0.08133607f, 0.09362060f, 0.10412969f, -0.03340504f, -0.10365959f, -0.16004953f, 
    0.07600015f, 0.05460808f, 0.08496885f, 0.00641361f, -0.18614350f, 0.01710352f, -0.14345004f, 0.06230229f, 
    -0.04829832f, 0.17439301f, 0.01583719f, 0.12983619f, 0.09451772f, -0.26350787f, -0.06446594f, 0.07217113f, 
    0.09831773f, 0.12846801f, -0.16967748f, -0.08667019f, -0.02549656f, 0.01991812f, 0.34178710f, -0.12732068f, 
    0.08320090f, -0.10136439f, 0.05564583f, 0.12132084f, 0.25790301f, 0.16056606f, 0.01425106f, -0.06048587f, 
    -0.03731569f, -0.02145587f, 0.09081534f, 0.08450120f, -0.00276484f, -0.04817348f, 0.04116971f, -0.14502569f, 
    -0.19861101f, 0.04485980f, -0.01295083f, 0.11686926f, -0.09861310f, 0.04170273f, 0.06712815f, -0.07661741f, 
    -0.01503812f, 0.34132159f, -0.05286311f, -0.06428882f, -0.04096657f, 0.13137160f, 0.06187823f, 0.10567508f, 
    -0.13597822f, 0.13123089f, -0.38257849f, -0.42486084f, -0.10870402f, -0.17185658f, 0.01268305f, -0.07061142f, 
    -0.00815016f, 0.00079255f, -0.90697646f, 0.51565605f, 0.20996447f, -0.00588361f, -0.16323681f, -0.20231397f, 
    -0.13668042f, -0.26341882f, 0.02614154f, -0.28705925f, -0.12172750f, 0.15492636f, 0.15079375f, 0.04576424f, 
    -0.10680992f, 0.06138584f, 0.06355440f, -0.05731789f, -0.27793521f, -0.39153612f, -0.27256954f, -0.14287877f, 
    0.01244558f, -0.19173245f, -0.20334470f, -0.12448805f, 0.13110919f, -0.00754008f, 0.51816231f, -0.08098754f, 
    0.03865834f, -0.15857571f, -0.18199445f, 0.01543022f, 0.08528100f, -0.05080751f, 0.12325936f, 0.15636232f, 
    0.34954756f, -0.11528419f, -0.00592687f, 0.01612882f, 0.01778050f, -0.02084781f, -0.07414646f, 0.20158412f, 
    0.12280679f, 0.10186308f, -0.09065391f, -0.06480837f, -0.16308916f, 0.13398330f, 0.07817795f, 0.02164682f, 
    0.13561811f, 0.10450573f, -0.03603353f, 0.01503356f, -0.05073727f, -0.09494612f, -0.00375325f, 0.06435877f, 
    0.01213171f, -0.08025005f, 0.00833251f, 0.16065380f, 0.03134418f, 0.01203141f, -0.00641992f, -0.04396596f, 
    0.13005191f, 0.00470685f, -0.04192109f, 0.20366806f, 0.12009695f, -0.10038962f, -0.15894681f, -0.07541768f, 
    -0.07319172f, -0.04996795f, -0.00049517f, -0.17135070f, -0.17360510f, 0.09229016f, 0.12648231f, 0.05476338f, 
    0.10121306f, 0.19263990f, 0.08301131f, -0.02950293f, 0.13391744f, -0.18800285f, 0.13312358f, -0.02450721f, 
    0.01886598f, 0.06594118f, -0.14931217f, 0.04715645f, 0.10246021f, 0.03468859f, -0.22699110f, 0.40977323f, 
    -0.24791478f, -0.09338999f, -0.13455848f, -0.10244201f, -0.05914045f, -0.08879270f, 0.02769109f, -0.03019264f, 
    0.15452780f, 0.00082654f, 0.19464344f, -0.10510234f, -0.09076949f, 0.00736083f, 0.02115483f, -0.19910601f, 
    -0.25411758f, -0.05843392f, 0.10492174f, -0.00823045f, 0.04348259f, 0.06950485f, 0.03063931f, -0.09097937f, 
    -0.03470789f, -0.06478313f, 0.01123210f, -0.03188196f, -0.01289570f, -0.00411923f, -0.06352128f, 0.02626718f, 
    -0.05554721f, -0.02365987f, 0.02104885f, -0.06160661f, 0.03704689f, 0.04239435f, 0.00711113f, 0.00476861f, 
    -0.04648937f, -0.02080104f, -0.02546480f, 0.02970458f, -0.06425484f, 0.00446033f, 0.02229083f, -0.06175699f, 
    -0.01174975f, 0.03369102f, -0.04670922f, -0.02418446f, 0.01497892f, 0.05230786f, 0.01636692f, -0.04522950f, 
    0.03996314f, 0.02902529f, -0.00397587f, -0.01554863f, -0.00925265f, 0.03296382f, 0.04186843f, 0.00879217f, 
    0.02979530f, -0.01150260f, -0.01649848f, 0.00073789f, -0.00114753f, 0.03314215f, -0.01349136f, 0.03804415f, 
    -0.00883744f, 0.02771668f, -0.03416181f, 0.02004922f, 0.00539662f, 0.00670890f, 0.02177050f, 0.02842646f, 
    0.04253927f, 0.01774728f, -0.05884531f, 0.00919778f, -0.04586484f, 0.01496738f, -0.01873118f, -0.05563711f, 
    -0.00530654f, -0.03172845f, -0.02057781f, 0.03986776f, -0.02499107f, -0.03034690f, -0.04742163f, -0.00233005f, 
    -0.06071161f, -0.00965595f, -0.02698946f, 0.02124088f, 0.03862902f, 0.01233470f, 0.01979707f, -0.05192784f, 
    0.01399726f, -0.01958437f, 0.03887416f, -0.04420400f, 0.01486316f, 0.01464040f, -0.03533799f, 0.00859051f, 
    -0.04437615f, 0.03326877f, 0.03781741f, 0.02314958f, -0.04809933f, -0.05092653f, -0.00593306f, 0.02662838f, 
    0.03551937f, 0.04018023f, -0.03421159f, -0.03243141f, 0.00819354f, -0.01757399f, -0.05144868f, -0.03713538f, 
    0.03607377f, -0.00778651f, -0.04553203f, -0.02877993f, 0.03485858f, 0.04128648f, -0.02495544f, -0.04218422f, 
    0.04059088f, -0.04094771f, -0.06210045f, -0.04558894f, -0.00833444f, -0.04906747f, -0.01847607f, -0.01658761f, 
    0.04898423f, 0.00132838f, 0.00525956f, -0.01774749f, 0.03054091f, -0.00801990f, 0.02717008f, -0.06128439f, 
    0.00960969f, -0.05557404f, 0.03674566f, 0.00725538f, -0.01161639f, -0.04563955f, 0.01116002f, -0.06496965f, 
    -0.03643568f, 0.01677885f, -0.05591821f, -0.00165795f, 0.04952900f, -0.05195329f, 0.02553905f, 0.03933733f, 
    -0.04250158f, -0.00701025f, 0.01315072f, 0.00420589f, -0.02605895f, -0.01004982f, -0.04560786f, -0.01594932f, 
    -0.00845844f, 0.02260772f, 0.02743809f, -0.02895454f, 0.03260504f, -0.03130301f, -0.06138980f, 0.01917234f, 
    0.04612928f, 0.04760273f, -0.02472140f, 0.04294252f, -0.01773938f, -0.02749252f, -0.04682882f, 0.04681982f, 
    -0.01133654f, 0.01141277f, 0.01461422f, 0.03236705f, 0.01652706f, -0.06062820f, -0.02657431f, 0.03984576f, 
    -0.04225019f, 0.00885339f, -0.01474945f, -0.00677173f, -0.00047701f, 0.00610814f, -0.02213575f, -0.03690675f, 
    -0.03302577f, 0.04433822f, 0.01136758f, -0.05286299f, -0.00860942f, -0.05057345f, 0.02642918f, 0.01607381f, 
    0.00804222f, -0.00714557f, 0.00214677f, -0.06569920f, -0.01247768f, -0.04928735f, 0.03561715f, -0.03787968f, 
    0.04697664f, 0.00538618f, -0.02762107f, -0.06184984f, 0.03478882f, 0.04686971f, 0.04742143f, 0.04853992f, 
    0.02972733f, -0.02917353f, -0.00646507f, -0.04607007f, 0.00650253f, -0.05573415f, -0.00104508f, -0.05911680f, 
    -0.05110031f, -0.00994913f, 0.05231847f, -0.04262075f, -0.05394007f, 0.00595367f, -0.03661427f, -0.04801216f, 
    -0.03364187f, 0.01779301f, -0.05545763f, -0.00828062f, 0.05258803f, 0.02738890f, -0.01892020f, -0.06680588f, 
    0.00384960f, 0.04305249f, -0.03925740f, -0.04242821f, -0.04015931f, -0.04494239f, 0.01167375f, 0.03720582f, 
    -0.03267082f, 0.01197139f, -0.01206600f, 0.00052987f, 0.02042212f, -0.00404523f, -0.02600390f, 0.01616448f, 
    -0.03960311f, 0.01741814f, -0.02671545f, -0.04915815f, -0.00288562f, -0.05437625f, 0.03699135f, -0.00472459f, 
    -0.01908827f, -0.02485870f, -0.04443488f, 0.01844879f, -0.04151514f, 0.01716854f, -0.06399894f, 0.04573932f, 
    0.04501617f, -0.00993463f, 0.00028811f, 0.05019669f, -0.02541560f, 0.04475060f, 0.03764799f, -0.00674483f, 
    -0.02167432f, 0.01489899f, -0.03981316f, -0.02330440f, -0.05729387f, 0.01017865f, -0.06273257f, 0.03609904f, 
    -0.06069398f, -0.04084797f, -0.03477761f, -0.03413877f, -0.03485319f, -0.05961901f, -0.00683891f, -0.02366009f, 
    -0.04609696f, 0.04148028f, -0.03647079f, -0.01926405f, 0.03944578f, 0.01747911f, 0.00279767f, -0.03180529f, 
    -0.02846092f, -0.02771022f, -0.03229043f, -0.01040152f, -0.00237119f, -0.04970841f, 0.01196372f, -0.05801380f, 
    0.04434396f, -0.00389261f, 0.01569873f, 0.01247977f, -0.02471534f, -0.05188167f, 0.02229672f, -0.02077532f, 
    0.02762826f, -0.02099001f, -0.03265076f, -0.01948016f, -0.00917235f, 0.04830196f, 0.01831609f, -0.04189271f, 
    -0.02262991f, 0.04097785f, 0.01032690f, -0.00334300f, 0.01237153f, -0.03381713f, -0.05441208f, 0.04964310f, 
    -0.01752037f, -0.01946609f, -0.01973737f, -0.00375310f, -0.04816240f, 0.02136185f, -0.03342005f, -0.02908023f, 
    0.02590669f, -0.05942396f, -0.03627143f, -0.00380198f, 0.00934115f, -0.04030887f, -0.05006938f, -0.05371960f, 
    0.05309104f, 0.02322332f, -0.00449427f, 0.05824986f, -0.06307839f, -0.06104729f, -0.04047878f, 0.03973722f, 
    0.03259302f, -0.05077037f, -0.04226867f, -0.05450139f, 0.00705965f, 0.00423628f, -0.04743476f, -0.04153467f, 
    0.03408041f, 0.04390301f, -0.06266675f, 0.00971751f, 0.02311373f, -0.02493010f, -0.05326983f, 0.02715461f, 
    -0.05106368f, -0.04460173f, 0.02191768f, -0.05662788f, -0.05795531f, -0.01208464f, -0.03212938f, -0.00338381f, 
    0.00219390f, -0.04472925f, 0.04307262f, -0.06228589f, 0.03010991f, -0.01624511f, 0.00811561f, -0.01567853f, 
    0.05138096f, 0.04485362f, 0.02132288f, 0.02113250f, 0.00424881f, -0.06094064f, -0.03926321f, -0.06488468f, 
    0.02808181f, 0.00434041f, -0.02652163f, 0.03870305f, -0.00394261f, -0.01172169f, 0.04847620f, -0.02340262f, 
    0.00261636f, 0.01481484f, 0.01840144f, 0.01431836f, -0.03205927f, -0.00289014f, -0.02782299f, 0.00124922f, 
    0.05278442f, -0.02204254f, 0.04548438f, -0.05056299f, -0.02199220f, -0.01816030f, -0.00793024f, -0.03149650f, 
    0.03885792f, 0.01771195f, 0.03900310f, 0.00498088f, -0.01064248f, 0.02452207f, -0.03821389f, 0.05662667f, 
    -0.01138525f, 0.03670492f, -0.02408962f, 0.02812421f, -0.00762702f, -0.05896007f, -0.05210307f, -0.03433162f, 
    0.00438160f, -0.01930890f, -0.00231617f, -0.04199908f, -0.06353148f, 0.04652554f, -0.03695807f, -0.05378806f, 
    -0.03763513f, -0.04046999f, -0.03851373f, -0.00089454f, 0.00273357f, 0.00215930f, 0.03778493f, -0.03777200f, 
    0.04653129f, 0.05128264f, 0.01786320f, 0.03692841f, -0.00910189f, -0.05878341f, 0.05170033f, -0.01382885f, 
    0.05028047f, -0.01307602f, 0.04601071f, -0.02001569f, 0.01927214f, -0.01988639f, -0.05582380f, -0.00638657f, 
    -0.01127380f, -0.02948324f, 0.04232311f, -0.05645624f, -0.04059038f, -0.02255658f, 0.01810738f, -0.01649287f, 
    0.00739955f, -0.02059606f, -0.06029052f, -0.03465048f, -0.04071948f, 0.01549929f, -0.02250876f, -0.02913006f, 
    0.04944098f, 0.04607514f, -0.05873307f, -0.03869366f, -0.02927217f, 0.03695447f, -0.05668429f, -0.04265110f, 
    -0.03224539f, -0.00843458f, 0.04707440f, 0.02523087f, -0.04380188f, 0.00384209f, 0.03082738f, 0.02482806f, 
    -0.03529963f, -0.05161148f, -0.00213343f, -0.01970752f, -0.06027097f, -0.03667476f, 0.03431945f, -0.01662217f, 
    -0.01864673f, -0.01131540f, 0.04874720f, -0.01477373f, 0.02325559f, -0.01708543f, -0.03650139f, 0.01754515f, 
    0.02288690f, 0.02206309f, 0.04103582f, -0.05854053f, -0.06128591f, -0.02201466f, -0.00005083f, -0.03604741f, 
    -0.05614954f, 0.00946498f, -0.03569268f, -0.02609996f, 0.03328932f, -0.03655154f, -0.05275646f, 0.00293546f, 
    0.01923912f, 0.01547361f, 0.03776348f, 0.03430804f, 0.01578185f, -0.03893221f, -0.05125488f, 0.03321937f, 
    -0.05669993f, -0.01117490f, 0.01591937f, -0.03550463f, -0.06305803f, 0.02062940f, 0.02048777f, -0.04070724f, 
    0.05259759f, 0.04983008f, -0.00625184f, -0.00748799f, -0.00988032f, -0.05661770f, 0.04330295f, 0.03303793f, 
    0.04730815f, -0.02782048f, 0.03775494f, 0.00440863f, 0.00431316f, -0.00809902f, -0.03581375f, 0.01052186f, 
    -0.02623502f, -0.01233920f, -0.04399036f, -0.01832236f, -0.04689419f, -0.02692328f, -0.04843653f, 0.00977527f, 
    -0.05589751f, 0.05082563f, 0.01969520f, 0.05632869f, 0.02731225f, 0.02796436f, 0.04936519f, 0.04062407f, 
    0.16003115f, -0.11102997f, -0.05212444f, 0.04166135f, 0.04609833f, 0.10460567f, -0.19643806f, -0.02504896f, 
    -0.02395848f, -0.16064584f, 0.02719882f, -0.14227201f, 0.11461052f, -0.02452179f, -0.11583614f, 0.03154556f, 
    -0.06338583f, -0.00790071f, -0.13731577f, 0.03194420f, 0.05348906f, 0.12516090f, -0.00308832f, 0.17399541f, 
    0.01651279f, -0.19072780f, -0.07593995f, -0.24057595f, -0.05896202f, -0.00446953f, -0.05225256f, 0.09827643f, 
    0.12053332f, 0.02119370f, 0.03885496f, 0.03858137f, 0.01242680f, 0.00037715f, -0.11241814f, 0.19689304f, 
    0.04771495f, -0.11867225f, 0.02505926f, 0.12084037f, -0.17352450f, -0.04571623f, 0.06064688f, 0.00686960f, 
    0.04497024f, 0.02770476f, 0.05599284f, -0.02886976f, 0.00445548f, -0.15507904f, 0.06823907f, 0.00675541f, 
    0.18388611f, -0.01453789f, 0.09551234f, 0.00719385f, 0.07935457f, 0.05180401f, 0.10096785f, -0.03606628f, 
    -0.16405681f, -0.11024533f, 0.04276402f, 0.04407240f, 0.08948249f, 0.04249912f, 0.01905924f, -0.14585286f, 
    -0.21229172f, 0.06602813f, -0.19392820f, 0.02483501f, 0.09878505f, -0.03037319f, 0.04654266f, 0.00210249f, 
    0.08506139f, -0.09228967f, -0.03265237f, 0.00266032f, 0.08274847f, 0.02097575f, -0.02222773f, -0.02809596f, 
    -0.10775653f, 0.01620074f, -0.04448637f, 0.01925702f, -0.22385897f, -0.01827696f, 0.02415222f, 0.09492517f, 
    0.02908066f, 0.06763002f, 0.07769482f, -0.03461809f, -0.02620550f, 0.01882296f, 0.06471855f, 0.00421575f, 
    0.09265844f, -0.12066541f, -0.20388500f, -0.12308767f, -0.16066551f, 0.29461581f, 0.01762955f, 0.01649282f, 
    0.06436998f, -0.09982820f, 0.03678400f, 0.02550152f, 0.06178007f, -0.02102088f, -0.25899473f, 0.14503534f, 
    0.11314482f, 0.01394923f, -0.03187072f, 0.09435511f, 0.00646336f, -0.11615475f, -0.07322923f, -0.05471729f, 
    -0.07094674f, 0.11845057f, 0.06286212f, 0.11272181f, -0.07131222f, -0.05104164f, -0.19099262f, -0.07834253f, 
    0.02909961f, 0.09802515f, -0.06033105f, -0.05491250f, 0.10398382f, 0.06284108f, 0.06685729f, 0.14686225f, 
    0.00747719f, -0.14819153f, -0.05644921f, -0.01258357f, -0.05473169f, -0.11860055f, 0.05667124f, 0.00657145f, 
    0.06905805f, -0.14770143f, -0.06374248f, -0.10842865f, 0.06715322f, 0.16002026f, 0.05869336f, -0.07539723f, 
    -0.06308871f, 0.17464207f, 0.19745882f, -0.03221587f, -0.10106591f, 0.10393339f, -0.11706778f, -0.05665620f, 
    0.11110072f, 0.15783493f, -0.15431124f, 0.05814201f, 0.07411763f, 0.00002676f, -0.19161938f, -0.12356111f, 
    -0.02897364f, -0.06202251f, 0.09324684f, 0.26330173f, -0.21745004f, 0.19474214f, -0.31606156f, -0.00684830f, 
    -0.02056573f, 0.09838899f, -0.07151919f, -0.07543806f, 0.08088071f, -0.13522768f, -0.13600515f, -0.02050780f, 
    0.25432399f, 0.08531869f, 0.00708095f, -0.07169180f, -0.21746927f, -0.13009959f, -0.02595348f, -0.11412323f, 
    0.10256963f, -0.21846598f, -0.13433737f, -0.05233853f, 0.10849840f, 0.02289397f, 0.21410061f, 0.01406767f, 
    -0.08352111f, -0.28477108f, 0.07388044f, 0.01789030f, -0.03373197f, -0.00129683f, 0.04286224f, 0.06819499f, 
    -0.03373909f, -0.07705685f, -0.13737713f, -0.06748956f, 0.02970660f, -0.02897876f, -0.02815067f, 0.03817927f, 
    0.03877582f, 0.13162172f, 0.08182295f, 0.18170223f, 0.01703452f, 0.10443648f, -0.19285317f, 0.03723523f, 
    0.09191923f, 0.04771677f, -0.08271259f, 0.05655456f, 0.07926321f, 0.13729261f, 0.04102585f, -0.03485753f, 
    -0.01423544f, 0.03507636f, -0.04657358f, -0.08072578f, 0.07780930f, 0.06883886f, -0.02867818f, 0.19205716f, 
    -0.00163326f, -0.13250944f, -0.07808311f, -0.05605024f, -0.46067604f, -0.01639132f, -0.21444023f, 0.06087082f, 
    0.14179212f, 0.03568298f, -0.03336984f, 0.15945952f, 0.01737403f, 0.13558605f, 0.04246301f, -0.16520783f, 
    0.05594983f, 0.02685800f, 0.01481549f, -0.08533480f, -0.14812854f, -0.12971607f, -0.11465606f, -0.04615772f, 
    0.00436785f, -0.06943422f, -0.06314294f, -0.03733625f, -0.02867018f, -0.01025253f, 0.16306068f, 0.15354842f, 
    0.04669990f, 0.14628235f, -0.10022888f, -0.02170966f, 0.09222413f, -0.02764818f, 0.00205408f, 0.30326375f, 
    0.03576015f, 0.04640465f, -0.01433825f, 0.06238816f, -0.03514670f, 0.05614673f, -0.16605493f, -0.05151722f, 
    -0.00696553f, 0.03380702f, 0.06325109f, -0.09653640f, 0.06965372f, -0.07962493f, -0.11273136f, 0.02743542f, 
    0.07659512f, -0.04212176f, -0.04174009f, -0.09349976f, -0.18303232f, 0.23055623f, -0.03835621f, -0.05433248f, 
    -0.06845011f, -0.10733403f, 0.06075229f, 0.02313201f, 0.01380931f, 0.04395773f, 0.03464467f, 0.04732757f, 
    -0.02851758f, -0.07831952f, 0.03963646f, -0.08146608f, -0.04489294f, 0.02662752f, 0.13242009f, -0.00048086f, 
    0.09921373f, 0.06344558f, 0.04060321f, -0.05575109f, -0.13346843f, 0.00615306f, 0.03133177f, -0.01747788f, 
    -0.02809042f, 0.06128669f, 0.07831016f, -0.12413857f, -0.03957555f, -0.21881442f, 0.16841801f, 0.06883654f, 
    0.21450441f, 0.24992864f, -0.01148052f, -0.05048790f, 0.15225740f, -0.14256436f, -0.01061340f, 0.03106976f, 
    0.02268397f, -0.04171234f, -0.05114011f, 0.07494602f, 0.03121048f, -0.05430716f, -0.14981422f, -0.09255341f, 
    0.15993312f, 0.20270361f, 0.02045569f, -0.00560280f, 0.02244982f, -0.04298146f, 0.10317409f, -0.04271739f, 
    0.00720316f, 0.14002720f, 0.12243272f, 0.02042035f, 0.00068075f, -0.10163963f, 0.02749112f, -0.08023617f, 
    -0.09671108f, -0.12382188f, 0.18169847f, 0.15585034f, 0.17374849f, 0.12481462f, 0.09134339f, -0.19680019f, 
    0.09673355f, -0.06342314f, 0.03094040f, 0.11075160f, 0.06378806f, 0.04565129f, 0.13172489f, 0.03902768f, 
    0.07398803f, 0.00778865f, -0.07334793f, -0.27307382f, 0.16967741f, -0.05700367f, 0.19542910f, 0.01288800f, 
    -0.14508037f, 0.09281301f, 0.06815043f, 0.03088149f, 0.13732114f, 0.16027334f, -0.06338421f, -0.01902124f, 
    0.02101566f, 0.03908691f, 0.08348534f, -0.01261474f, 0.03763095f, -0.26456258f, 0.15901311f, 0.10593440f, 
    -0.11219561f, 0.07589839f, 0.01160552f, 0.05712103f, 0.00640320f, -0.29299718f, -0.21978840f, 0.15506917f, 
    -0.15673307f, -0.10071150f, 0.19101483f, 0.00983829f, 0.06325732f, -0.02290970f, 0.08585881f, -0.00481676f, 
    0.01485623f, -0.09740967f, -0.04826926f, 0.01949706f, 0.06758114f, 0.03326818f, -0.09569287f, 0.08435862f, 
    0.03847371f, 0.04926239f, -0.13795376f, -0.00615196f, -0.01347397f, 0.00817463f, 0.04555800f, 0.06104961f, 
    0.13483274f, 0.14690404f, 0.15773411f, -0.15043475f, 0.10319735f, 0.02741543f, 0.14944233f, 0.00438600f, 
    0.07769866f, -0.14176066f, 0.00424549f, 0.21692772f, 0.01825336f, -0.03820742f, -0.00868989f, -0.05204234f, 
    0.06961959f, 0.15050937f, 0.01827855f, 0.06162778f, 0.05121737f, 0.05999190f, -0.01784349f, -0.04676868f, 
    0.01912504f, 0.05502790f, 0.08334854f, 0.04540773f, 0.15900722f, -0.09841449f, -0.17709640f, -0.11964642f, 
    0.15672953f, 0.04238772f, -0.03408388f, -0.11840596f, -0.13002300f, -0.07816574f, 0.09701943f, -0.07892617f, 
    0.00216006f, 0.01293230f, -0.01398569f, 0.12252139f, 0.02831532f, 0.01798483f, -0.00275774f, 0.30698833f, 
    0.24886958f, 0.17025067f, 0.03958412f, -0.05165078f, 0.02004746f, 0.03937021f, 0.02243829f, 0.02975601f, 
    0.12131798f, -0.00089040f, -0.00044032f, 0.08255294f, 0.04418081f, 0.02322374f, 0.02800186f, -0.04450718f, 
    -0.10292581f, 0.26731369f, 0.19730844f, 0.11669847f, 0.13152006f, -0.05086114f, 0.04300665f, 0.00898987f, 
    0.01305725f, -0.06049861f, 0.10543979f, 0.10670080f, -0.14948280f, 0.19243845f, 0.03604423f, -0.11413986f, 
    -0.08288671f, -0.08935383f, 0.10925344f, 0.10625897f, -0.06858955f, -0.09640805f, -0.02888590f, 0.16301967f, 
    -0.10297563f, -0.04063880f, -0.11323972f, -0.06867433f, 0.00943083f, 0.00144203f, 0.04710134f, -0.00233000f, 
    -0.01207065f, 0.05298265f, -0.14177942f, 0.09250198f, 0.02665404f, 0.17097415f, 0.06037049f, -0.15603858f, 
    0.03292002f, -0.10871310f, 0.00229837f, 0.18488534f, 0.05788420f, 0.07405368f, 0.03212859f, -0.10016587f, 
    -0.12753445f, -0.07408012f, -0.04010633f, 0.07141596f, 0.01517829f, 0.04202896f, 0.07740337f, 0.01668364f, 
    0.09721414f, -0.01200449f, -0.06431462f, 0.01858645f, -0.06349817f, 0.05595825f, 0.13467683f, 0.06477537f, 
    0.16458580f, -0.01751653f, -0.01192608f, -0.00904426f, -0.04993223f, 0.04023981f, -0.07066528f, 0.00247955f, 
    0.00723027f, 0.11922082f, -0.09655522f, -0.01341226f, -0.02556291f, 0.02448169f, -0.11300512f, 0.00675917f, 
    0.15246785f, 0.03811272f, 0.04886980f, -0.16734366f, 0.12552512f, -0.09830815f, -0.01541965f, -0.12169585f, 
    -0.09635227f, -0.02011968f, -0.08262414f, 0.10035191f, 0.02383047f, 0.13983202f, -0.02009001f, 0.03914450f, 
    0.06795584f, 0.02478768f, 0.00874027f, -0.01794437f, -0.09467844f, -0.07653701f, -0.02545131f, 0.14958471f, 
    0.13833712f, -0.22407348f, 0.07574409f, 0.03623611f, -0.19647124f, 0.04378696f, 0.07651255f, 0.03769024f, 
    0.06009356f, 0.02544751f, -0.05408309f, 0.03745424f, -0.06560223f, -0.21020246f, 0.10743403f, 0.04393835f, 
    0.07497936f, 0.03479509f, 0.18922278f, 0.08458317f, -0.05268813f, 0.01183413f, -0.05387817f, 0.00575942f, 
    -0.00645194f, 0.04081672f, 0.06110172f, 0.07001195f, 0.03830094f, -0.06158660f, -0.15782556f, -0.06056361f, 
    0.05388260f, -0.05274113f, 0.11137183f, -0.02082281f, 0.05497131f, 0.00748573f, 0.11794274f, 0.14881624f, 
    0.02655176f, -0.02779016f, 0.13915810f, 0.05864078f, 0.00172616f, -0.07647082f, -0.01061966f, -0.01313781f, 
    -0.07161397f, -0.15154277f, -0.03591704f, 0.17537260f, 0.06185279f, -0.03258587f, -0.01717979f, -0.04380303f, 
    0.09680090f, 0.09135137f, -0.10777825f, 0.13167498f, 0.13839030f, -0.18320274f, 0.04907810f, -0.02132778f, 
    0.14327253f, 0.01483636f, -0.06383887f, -0.31390923f, -0.22064072f, 0.11936356f, -0.09825738f, 0.01219145f, 
    0.01195940f, -0.10291906f, 0.05230604f, 0.18258633f, -0.02651219f, 0.08357441f, 0.06387413f, -0.04299823f, 
    0.08662573f, -0.11550324f, 0.13856508f, 0.08813938f, -0.00516457f, -0.05175406f, 0.06905740f, -0.23530148f, 
    -0.07777008f, 0.03398939f, 0.00896399f, 0.05341526f, -0.08629594f, -0.11119591f, -0.21105304f, 0.01295201f, 
    0.01942312f, -0.14726898f, 0.04453385f, 0.07517597f, 0.16266754f, 0.00234086f, 0.08371495f, 0.09421945f, 
    -0.01817786f, -0.12997857f, 0.01442810f, -0.00116196f, -0.00170109f, -0.01939885f, 0.11125588f, -0.05738546f, 
    0.03501981f, -0.15528433f, -0.07119523f, -0.10504480f, 0.00059868f, -0.03083890f, 0.07005183f, 0.01611613f, 
    -0.02629367f, 0.11920253f, 0.14947429f, 0.30582181f, -0.03416295f, -0.08175652f, 0.10455805f, -0.08464850f, 
    0.08870205f, 0.02848666f, -0.12589206f, 0.33764043f, -0.01424417f, -0.16591363f, 0.04981398f, -0.00976646f, 
    0.00383237f, -0.20166591f, -0.06081787f, 0.25103748f, 0.03206660f, 0.09171583f, -0.41347566f, -0.07667216f, 
    -0.00718328f, 0.09151503f, -0.08179031f, -0.02451970f, 0.17691094f, -0.02912748f, -0.07256140f, 0.02531442f, 
    0.00286349f, -0.04291512f, -0.10415463f, -0.08202241f, -0.11778837f, -0.10065585f, 0.00907669f, 0.11637800f, 
    -0.08513939f, 0.04704074f, -0.11383969f, 0.10651262f, -0.08018903f, 0.00388670f, 0.01946377f, 0.28257874f, 
    0.26801020f, -0.01722929f, -0.02904516f, -0.15998991f, 0.02102445f, 0.11483060f, 0.05374577f, -0.04357800f, 
    0.04511018f, 0.01745926f, 0.05658041f, 0.05827266f, -0.00427993f, 0.05681515f, 0.03060292f, -0.02620734f, 
    -0.05110030f, 0.36307710f, 0.12637289f, 0.19648683f, -0.03363493f, -0.07290773f, -0.05948449f, -0.05188753f, 
    0.04890240f, -0.05660287f, -0.09527217f, 0.08577947f, 0.27636030f, -0.07937823f, 0.01130392f, 0.05711272f, 
    -0.07435638f, -0.00944488f, -0.06863555f, -0.03538074f, 0.05629098f, -0.14711054f, -0.03047361f, 0.05594317f, 
    -0.04199117f, 0.06282438f, 0.03376820f, -0.01397388f, -0.10492344f, -0.06610283f, 0.01488873f, -0.05327608f, 
    0.19835062f, 0.07394613f, 0.04461287f, 0.21393262f, -0.02302708f, 0.01981189f, 0.13541161f, -0.15790488f, 
    0.05472058f, -0.15351760f, -0.02499860f, -0.06732018f, 0.02475316f, -0.04044128f, -0.03489289f, 0.04468499f, 
    -0.11889296f, 0.03078003f, -0.12369093f, -0.01926598f, -0.11225951f, 0.11083242f, 0.16766079f, 0.10500621f, 
    -0.09423986f, -0.11351678f, -0.16639155f, 0.14982997f, -0.00033171f, 0.12817797f, 0.07796019f, 0.16490711f, 
    0.03443079f, 0.03198989f, 0.08180256f, 0.12165195f, -0.00299199f, -0.06667042f, -0.00055006f, 0.01340050f, 
    -0.08766056f, 0.15744661f, 0.10915242f, 0.09292964f, 0.04806059f, -0.00629068f, 0.07167732f, -0.04584791f, 
    0.02405852f, -0.07615019f, 0.10265110f, 0.10569086f, -0.10283181f, -0.03305913f, -0.04492513f, 0.05174290f, 
    0.02367230f, 0.10910346f, 0.11865366f, 0.03089503f, -0.15505062f, 0.05361027f, -0.11587529f, 0.12415183f, 
    0.03418900f, -0.06281243f, -0.09584341f, -0.04219797f, 0.06553815f, 0.07478897f, 0.13336259f, -0.06641006f, 
    0.09510262f, 0.17604035f, -0.03174881f, 0.07962070f, 0.13850391f, 0.09007736f, 0.08485074f, 0.08874671f, 
    -0.06035207f, 0.01147859f, -0.02843063f, -0.09532718f, 0.12831075f, 0.19736324f, -0.10556554f, -0.12666792f, 
    -0.23228543f, 0.03540340f, 0.13853678f, -0.01565624f, -0.08397329f, -0.04478882f, -0.10204794f, 0.07642016f, 
    -0.00943372f, 0.05928997f, 0.08140723f, -0.02768968f, 0.06018199f, -0.03895348f, 0.11581839f, 0.04770719f, 
    -0.15013437f, -0.08053482f, 0.01177261f, 0.00860578f, 0.07496554f, 0.03646303f, -0.10320099f, -0.02939027f, 
    -0.01786507f, -0.09624265f, 0.00065993f, -0.12789686f, -0.04181267f, 0.07367477f, 0.05020855f, -0.10602895f, 
    0.06462295f, 0.13926576f, 0.08615672f, -0.04038016f, 0.08629511f, 0.08544696f, 0.10061486f, -0.00111992f, 
    -0.06908683f, -0.07001747f, -0.18792400f, -0.02319932f, -0.04682851f, -0.00333914f, 0.12274448f, 0.15319055f, 
    0.10453999f, -0.11210955f, 0.05025949f, -0.06998428f, 0.04567600f, -0.06337573f, -0.01365945f, 0.15570268f, 
    0.01956618f, -0.04123484f, -0.14320675f, 0.01840192f, -0.24663784f, -0.01129066f, -0.10595793f, 0.01668257f, 
    0.05990503f, 0.22989078f, 0.07324155f, 0.10921534f, -0.08547561f, 0.06437513f, 0.10371134f, 0.17873295f, 
    0.07490575f, 0.15595801f, 0.08045372f, 0.01088092f, -0.12144011f, 0.12124696f, 0.02858660f, 0.07248515f, 
    0.02194454f, 0.07945088f, 0.01393020f, -0.05282871f, 0.04782614f, 0.01706331f, 0.07323302f, -0.09342080f, 
    0.10224776f, 0.07985993f, 0.10558821f, -0.07480742f, 0.03693381f, 0.08093881f, 0.03440134f, 0.09334888f, 
    -0.18209541f, -0.09760287f, 0.05358029f, -0.04419924f, 0.08805702f, -0.05972070f, -0.14536458f, -0.04551253f, 
    -0.10789395f, -0.08763908f, 0.18642256f, 0.12699525f, -0.02386829f, 0.10967598f, -0.05668220f, 0.09197860f, 
    -0.14771673f, -0.01499995f, -0.03685270f, 0.00257195f, 0.01486356f, 0.05830154f, 0.04960220f, -0.01861028f, 
    -0.01489378f, 0.01248173f, 0.03949115f, -0.16885039f, -0.07792988f, 0.00388521f, -0.04098268f, 0.24640150f, 
    0.14832538f, 0.10227250f, -0.14594835f, -0.17450751f, -0.06534242f, 0.08635581f, 0.00105341f, -0.15941986f, 
    -0.09130161f, 0.03680920f, 0.02917066f, 0.19158921f, 0.04567381f, 0.06033447f, 0.14471869f, -0.00130071f, 
    -0.05263470f, 0.09378862f, 0.09911226f, -0.06841163f, -0.03928839f, -0.09259154f, -0.07859062f, -0.20123582f, 
    0.16891986f, 0.14120293f, 0.10663945f, 0.15606587f, -0.06134466f, 0.01599425f, 0.00270404f, 0.12197175f, 
    -0.04623806f, -0.05369687f, -0.01113642f, 0.02616121f, 0.06138609f, 0.08406535f, -0.02211942f, 0.01033663f, 
    0.01502342f, 0.05329249f, 0.00745814f, -0.17498046f, 0.03251984f, 0.00883280f, 0.01890787f, -0.05555274f, 
    -0.05898029f, -0.08771905f, -0.04457160f, 0.02250720f, -0.38584653f, 0.11076727f, -0.00619177f, 0.10723102f, 
    0.02620133f, 0.12370239f, -0.02143102f, -0.05715726f, 0.13442902f, 0.02536067f, -0.06840233f, -0.16215174f, 
    -0.07780755f, 0.11763145f, 0.10430935f, 0.07811775f, -0.03475605f, -0.13813965f, 0.22873722f, 0.09346058f, 
    -0.01154530f, 0.07426269f, -0.08073278f, -0.03963336f, -0.14581825f, 0.11364064f, 0.29384217f, 0.14811920f, 
    0.00270051f, 0.06116360f, -0.09834979f, -0.10976376f, -0.05273915f, -0.04250995f, -0.01230089f, 0.03830589f, 
    -0.03198338f, 0.03799756f, 0.01978713f, -0.01484213f, -0.15611488f, -0.21883172f, -0.20099038f, 0.06809784f, 
    0.41492337f, 0.09937363f, 0.03314265f, -0.05990794f, -0.01869120f, -0.01764986f, 0.09369510f, 0.02127254f, 
    -0.19235836f, 0.11742851f, 0.20632656f, 0.10197075f, 0.18538728f, 0.01666235f, -0.03820626f, 0.04765283f, 
    0.04201163f, 0.25832224f, -0.01330737f, 0.08935610f, -0.01872034f, -0.01615263f, 0.02647103f, 0.13759653f, 
    0.04454973f, -0.00421640f, -0.42434809f, -0.41864464f, -0.42663386f, -0.05029473f, 0.13557942f, -0.10204480f, 
    0.06531303f, -0.03807149f, 0.02797972f, 0.19267523f, 0.10194916f, -0.02584594f, -0.00605293f, -0.01162400f, 
    0.03815193f, 0.20283782f, 0.13642906f, 0.08412769f, 0.27302644f, 0.12197033f, -0.19898245f, -0.02542321f, 
    -0.05279876f, 0.04107383f, 0.05546552f, 0.16162136f, -0.09299830f, -0.07477769f, 0.02443351f, -0.02761804f, 
    0.08915585f, -0.01085647f, 0.13651423f, 0.05776250f, 0.02000473f, -0.03738224f, -0.36258391f, 0.07688142f, 
    -0.27634192f, 0.04351518f, 0.01418667f, -0.01216488f, 0.15843762f, -0.10635103f, 0.09380582f, 0.30082718f, 
    -0.10095007f, -0.01734999f, -0.13364933f, -0.00447772f, 0.10969162f, -0.06307632f, 0.06770181f, 0.07418229f, 
    0.07070452f, 0.12132809f, 0.09604561f, 0.09219626f, 0.00648280f, 0.01488095f, 0.08402162f, -0.01412132f, 
    0.18839785f, 0.18666895f, -0.10023446f, -0.06236765f, -0.03125571f, 0.04567426f, 0.01235594f, -0.00761571f, 
    0.10817482f, -0.05788039f, 0.07631396f, -0.02547895f, -0.06680669f, 0.03468500f, 0.00369841f, -0.16143945f, 
    0.04809118f, -0.02587956f, 0.29506010f, 0.09343776f, 0.13902040f, -0.02722676f, -0.20186614f, -0.15279832f, 
    -0.02474254f, 0.14390616f, 0.00932610f, -0.11193836f, -0.25935107f, -0.02764484f, -0.26086095f, 0.04477113f, 
    0.04888116f, -0.01873934f, 0.05804256f, -0.22695507f, 0.04350116f, 0.00153011f, -0.34780976f, -0.05514642f, 
    0.22778450f, 0.11262423f, -0.06104865f, -0.03614218f, -0.00511990f, -0.00676916f, 0.05328161f, 0.09144206f, 
    -0.00728568f, -0.08714627f, -0.11017068f, 0.05909999f, 0.03245247f, -0.16779727f, 0.00751723f, -0.06506709f, 
    -0.21327426f, -0.32380983f, -0.10594833f, -0.01650791f, 0.03833550f, 0.12214225f, -0.01387250f, -0.03791804f, 
    -0.07735979f, -0.13922019f, 0.07111806f, 0.04727566f, 0.04599188f, 0.15011227f, -0.06818794f, 0.10865328f, 
    -0.02895425f, -0.29083726f, -0.21555826f, 0.02202812f, -0.08922411f, 0.05977852f, 0.10260940f, 0.05572454f, 
    -0.08771574f, 0.06584743f, -0.01719490f, -0.04923432f, -0.13701543f, -0.07692910f, 0.11893652f, 0.09454688f, 
    -0.13782197f, 0.02108986f, 0.09341418f, 0.01617392f, -0.19315700f, -0.60438633f, -0.08941869f, -0.04999537f, 
    -0.10835598f, -0.14821889f, 0.08193815f, 0.09778715f, 0.03720777f, -0.29838276f, -0.22195032f, -0.08799215f, 
    -0.17647719f, 0.13543668f, 0.09806272f, -0.03668891f, 0.10191958f, -0.07998446f, -0.40536109f, -0.31202284f, 
    0.08675230f, 0.02145008f, -0.09142552f, 0.07618051f, -0.13496199f, -0.16146332f, 0.19358879f, -0.01878569f, 
    -0.00858115f, -0.00709810f, -0.10229103f, -0.07140440f, 0.03100638f, -0.00294691f, 0.14112930f, 0.30707452f, 
    -0.20974177f, -0.07751682f, 0.02923653f, 0.09516304f, 0.06727716f, 0.15755931f, -0.12551904f, 0.13495329f, 
    0.25403506f, 0.02025376f, -0.03553432f, -0.13826118f, -0.09469568f, 0.00038469f, -0.03459793f, -0.01348680f, 
    0.08299986f, 0.14467026f, 0.00003317f, -0.24640156f, -0.05555312f, 0.04900917f, -0.07761430f, 0.06811151f, 
    -0.16562009f, 0.07129187f, 0.16152483f, -0.78113180f, -0.30163836f, -0.05799223f, 0.10304236f, -0.09265386f, 
    0.06453452f, -0.13245212f, -0.02616307f, -0.28771523f, 0.14666532f, 0.06289815f, 0.12032975f, 0.14518960f, 
    0.05091938f, 0.15153417f, -0.04974828f, 0.01296199f, 0.22852920f, 0.24280491f, -0.14933075f, 0.03369676f, 
    0.19261169f, 0.03499621f, 0.06831417f, 0.13137749f, -0.04182751f, -0.51499015f, -0.30320853f, 0.34828681f, 
    0.12587273f, 0.08742457f, -0.01873571f, 0.11563768f, -0.01688697f, -0.01683348f, 0.09439987f, -0.26911271f, 
    -0.11406294f, 0.01929612f, -0.02715391f, 0.04209526f, -0.03204741f, 0.09502334f, -0.03340397f, -0.54537982f, 
    -0.22385804f, -0.43546128f, -0.03566875f, 0.12975574f, -0.02341770f, 0.05911980f, -0.03901886f, -0.13931702f, 
    -0.13936751f, -0.26594877f, -0.21276364f, 0.11811422f, 0.08331370f, 0.12380450f, 0.04549849f, 0.13773444f, 
    0.04037721f, -0.11947571f, -0.12300805f, 0.06829470f, -0.04880716f, -0.14774768f, 0.06682885f, -0.00273071f, 
    0.03547731f, 0.03495693f, -0.00700622f, -0.04832385f, -0.10279053f, -0.08600570f, -0.10414639f, -0.22610050f, 
    -0.03275245f, -0.05713056f, 0.09430715f, -0.04785413f, -0.05344132f, -0.13545427f, -0.21466888f, 0.06541879f, 
    -0.05361778f, 0.04874666f, 0.14945088f, -0.10001137f, -0.19954631f, 0.08287414f, -0.34352243f, -0.01635037f, 
    0.17777327f, -0.14821586f, 0.04251648f, -0.05398210f, 0.09105644f, -0.03708250f, -0.26216850f, -0.05408063f, 
    0.05364893f, 0.03086095f, -0.03390719f, -0.04104381f, 0.03957996f, -0.19719686f, -0.11133257f, 0.10256562f, 
    -0.02800221f, -0.05623112f, -0.13459092f, -0.19859406f, 0.03440893f, 0.01671487f, 0.17666233f, 0.38729131f, 
    -0.10149393f, -0.18659419f, 0.02542225f, -0.00164350f, -0.06621853f, 0.09342848f, 0.01337224f, 0.06908733f, 
    0.25494677f, 0.07074384f, -0.18881747f, 0.00984263f, -0.08481789f, 0.17313753f, 0.06017337f, 0.01941546f, 
    0.09350869f, 0.06986301f, -0.21395400f, 0.05691988f, -0.17087212f, 0.03949661f, -0.03556933f, -0.02214294f, 
    -0.00732601f, 0.09094032f, -0.06915682f, -0.18188737f, -0.21473843f, 0.10428926f, 0.07182131f, 0.02863881f, 
    -0.04567907f, -0.08034068f, -0.11782737f, -0.10887719f, -0.11326098f, -0.37670437f, -0.10982625f, -0.04581277f, 
    0.08181006f, -0.15435779f, 0.07487711f, 0.05353542f, 0.09717589f, 0.04781181f, -0.04941466f, -0.01921726f, 
    0.08146127f, -0.11812524f, 0.02376540f, 0.02634448f, 0.08663140f, 0.07092645f, -0.00789884f, -0.20514046f, 
    0.03636824f, 0.10744867f, 0.07219322f, 0.12099438f, -0.18000230f, 0.11428886f, -0.06584513f, -0.06713714f, 
    -0.22389007f, 0.09168502f, -0.06061463f, -0.01913724f, -0.05532296f, 0.12755258f, -0.00420255f, 0.35757905f, 
    0.02637906f, -0.05903734f, -0.06338940f, 0.09913849f, 0.08069980f, 0.17187108f, -0.02207495f, -0.06670474f, 
    -0.04543455f, -0.34527749f, -0.21993765f, 0.07307313f, -0.01166615f, 0.01308127f, 0.19381854f, 0.01069630f, 
    -0.07196821f, 0.28583729f, 0.09199882f, -0.05349779f, 0.19533584f, 0.07146313f, 0.11746086f, 0.02051597f, 
    0.00331219f, 0.04651071f, -0.19270031f, -0.09136244f, 0.08034181f, 0.05124000f, -0.01527442f, -0.16611220f, 
    0.07569713f, 0.07294120f, -0.02014359f, 0.06103401f, 0.19445772f, 0.10885457f, 0.13146406f, 0.05654879f, 
    0.05320259f, 0.10923094f, 0.08061760f, -0.05376566f, 0.41717601f, -0.07020924f, -0.06402779f, 0.17417021f, 
    -0.08018361f, -0.00807818f, -0.13853812f, 0.15859486f, -0.01477674f, 0.16882791f, 0.13735653f, 0.04018001f, 
    0.08673113f, -0.30937561f, 0.02256003f, 0.04822375f, 0.03325504f, 0.09775423f, 0.21773349f, 0.25483489f, 
    0.01411305f, 0.11625750f, 0.23763599f, 0.04407614f, 0.05638034f, -0.06922934f, 0.00510275f, -0.27470043f, 
    -0.18720879f, -0.15089296f, 0.09978063f, 0.02373726f, -0.01258497f, 0.08971982f, -0.07326903f, -0.05053546f, 
    -0.12935592f, -0.37623069f, -0.40976328f, 0.03435650f, -0.04804284f, 0.14456372f, 0.03234027f, 0.00971686f, 
    0.07500505f, -0.08157516f, 0.20251878f, -0.05882430f, 0.04050215f, -0.24899052f, -0.05666798f, 0.14413039f, 
    -0.08727724f, 0.03401692f, -0.00779474f, 0.08920567f, 0.29880348f, -0.19542763f, -0.11677074f, -0.28300837f, 
    -0.05057456f, -0.03934330f, 0.07616569f, -0.00710009f, 0.00685109f, -0.07660457f, 0.07168888f, 0.03602113f, 
    0.02074919f, 0.06691096f, -0.00770440f, -0.06138387f, 0.62003797f, 0.17367584f, -0.23109643f, -0.01721617f, 
    0.01650678f, -0.00171439f, 0.04140587f, -0.15982389f, -0.04663710f, 0.09758834f, 0.17481455f, 0.10843368f, 
    0.09893730f, 0.08485749f, 0.22599313f, -0.04639424f, -0.01581789f, 0.08171609f, 0.31768763f, 0.14895880f, 
    0.06770033f, 0.09745900f, -0.00422551f, 0.08224241f, 0.03876874f, 0.01160976f, -0.05672845f, -0.34661230f, 
    -0.01373781f, -0.06639313f, 0.09332376f, 0.10270502f, -0.11660000f, 0.09500337f, 0.00215212f, -0.06138666f, 
    -0.00946850f, 0.04023370f, -0.06487354f, -0.00757766f, -0.00773991f, 0.02502736f, -0.02530340f, -0.06342718f, 
    0.00348828f, 0.00108099f, 0.03080995f, 0.02435879f, -0.04318410f, -0.02998177f, -0.05697563f, -0.02393520f, 
    0.00325943f, -0.05872002f, -0.01595538f, 0.00660019f, -0.06530877f, 0.00197786f, -0.04204485f, -0.05101997f, 
    0.05020972f, 0.01740740f, 0.01770606f, -0.00224141f, -0.06450070f, -0.00985165f, -0.04657412f, -0.05210605f, 
    -0.05679734f, -0.04859192f, -0.02739071f, 0.01004614f, -0.03206285f, -0.02550405f, -0.03102470f, -0.03446690f, 
    0.03240250f, 0.02342279f, -0.01707171f, -0.05715453f, -0.01456975f, -0.03551983f, -0.02472176f, -0.03686178f, 
    -0.04653666f, 0.00063060f, -0.02897621f, 0.01098573f, -0.02574553f, -0.01245333f, -0.03883521f, -0.05737308f, 
    -0.00534870f, -0.01421180f, -0.01332190f, -0.06066877f, 0.00801098f, 0.00622202f, 0.02622354f, -0.01541196f, 
    -0.01864523f, 0.00375198f, 0.02577859f, -0.01359820f, 0.01678241f, -0.00943372f, 0.01093972f, -0.05821238f, 
    -0.04598591f, -0.01537665f, 0.01384111f, -0.05740176f, 0.03827837f, 0.00208388f, -0.06086063f, -0.01825714f, 
    -0.00536476f, -0.00958381f, 0.01302803f, 0.01284801f, -0.05046018f, 0.03825820f, -0.04265101f, 0.01216500f, 
    -0.05312719f, 0.04435241f, 0.01389023f, -0.05552776f, -0.00880449f, 0.00364704f, -0.02188582f, -0.05412613f, 
    0.01188987f, -0.04392213f, 0.03287610f, -0.03409985f, -0.05158624f, 0.01231285f, -0.05261415f, 0.00913780f, 
    -0.02219084f, -0.06170188f, -0.02805701f, -0.03062648f, 0.00316332f, -0.02341560f, -0.03037459f, 0.02183701f, 
    0.01816327f, -0.00187333f, 0.04506107f, 0.03427470f, -0.02598104f, -0.05461051f, -0.03847425f, 0.02024990f, 
    0.04977865f, 0.03218646f, 0.04120093f, -0.00960443f, 0.02390612f, -0.00637164f, 0.02657259f, -0.03621126f, 
    0.00930554f, -0.01445486f, -0.05321775f, -0.00329822f, -0.03190200f, -0.03169859f, -0.02479579f, 0.01130158f, 
    -0.01049709f, 0.02190462f, -0.03007136f, 0.04041371f, -0.03992330f, -0.01792573f, 0.00752127f, 0.04150410f, 
    0.04854434f, 0.00916567f, -0.04429355f, -0.05001608f, -0.00598454f, 0.01131815f, -0.01871327f, -0.04243168f, 
    0.00030381f, 0.00913502f, -0.02806465f, -0.05313213f, 0.03207970f, -0.00644392f, -0.02674715f, -0.04775013f, 
    -0.03976703f, 0.04926736f, 0.00314559f, 0.02333552f, -0.03649290f, 0.02585334f, -0.05664236f, -0.00264265f, 
    0.03146287f, 0.02368432f, -0.03065164f, -0.02360353f, -0.03869938f, 0.00498990f, 0.04114762f, 0.01385316f, 
    -0.02852519f, 0.02191103f, -0.06048077f, 0.02289565f, -0.02658401f, -0.04922650f, 0.03252775f, -0.05285642f, 
    -0.03380090f, 0.02172114f, -0.03453301f, 0.04676165f, -0.02087916f, 0.00802009f, -0.00351303f, -0.01686096f, 
    -0.03672366f, -0.06583598f, -0.03983778f, -0.06311853f, -0.00698618f, -0.05276079f, -0.02639746f, -0.02695572f, 
    -0.02903079f, 0.02294833f, -0.04910387f, 0.03577062f, 0.04258042f, 0.04528090f, -0.01553764f, -0.05510055f, 
    0.00643332f, 0.03239464f, 0.03135222f, 0.00311831f, 0.03746753f, -0.06159111f, 0.03648829f, -0.05553489f, 
    -0.05595912f, 0.04681344f, -0.05347768f, 0.02185750f, 0.04086325f, -0.06245602f, 0.03189756f, 0.02179092f, 
    -0.01862063f, 0.01533792f, 0.02798011f, 0.01277254f, -0.05765501f, -0.02139626f, -0.03935612f, -0.01111177f, 
    -0.04666782f, 0.03309652f, 0.01746417f, 0.03141555f, 0.01071020f, -0.03476334f, 0.03713746f, -0.05596699f, 
    -0.04866261f, -0.06152502f, 0.03202495f, -0.03215088f, -0.05686954f, 0.04349281f, 0.00777039f, 0.00023682f, 
    0.01041047f, 0.02369232f, 0.01730662f, -0.04842652f, 0.01553124f, -0.04342655f, -0.02951411f, -0.04100202f, 
    -0.00545965f, 0.01451936f, 0.03249909f, 0.01789202f, -0.06180346f, -0.00709426f, 0.02330979f, -0.03719198f, 
    -0.03563453f, 0.03413846f, 0.02911712f, -0.03763449f, 0.02895417f, -0.04186160f, 0.03709409f, 0.04153245f, 
    -0.05288802f, -0.03110829f, 0.02341126f, 0.01673778f, 0.04839651f, 0.00913621f, -0.00033016f, -0.01328233f, 
    -0.03644490f, -0.06101244f, -0.05069992f, 0.02762597f, -0.04961701f, -0.00700027f, -0.00529825f, 0.01213405f, 
    0.01079785f, -0.03780417f, 0.16896652f, 0.06822003f, 0.01664704f, 0.09975888f, 0.08389392f, -0.06826986f, 
    -0.02801547f, 0.04440152f, 0.19927010f, 0.05476501f, -0.07064085f, 0.11509121f, -0.01400225f, 0.03471079f, 
    0.11651687f, 0.02916644f, -0.01057594f, 0.28488201f, -0.05948968f, 0.05222261f, -0.00331486f, 0.05159967f, 
    -0.01644084f, 0.09302745f, -0.07401118f, 0.10692206f, -0.15510449f, 0.04151891f, 0.02393809f, 0.02204420f, 
    0.01904967f, 0.05727704f, -0.07538851f, 0.03337448f, -0.02911072f, 0.03973705f, 0.35281703f, 0.21076407f, 
    0.02668246f, 0.17170164f, 0.05781337f, -0.07436398f, 0.15162942f, 0.08975212f, 0.02750643f, 0.07553519f, 
    -0.02474429f, -0.05355171f, -0.04012148f, 0.19545482f, 0.13163367f, 0.11747948f, -0.12656137f, -0.19744715f, 
    0.11187423f, 0.06686493f, -0.12807222f, 0.03528262f, -0.14370745f, -0.03487594f, -0.14468403f, 0.05959931f, 
    -0.06322563f, 0.16646583f, 0.07028585f, 0.05630043f, 0.01162915f, 0.01401701f, 0.06402147f, 0.12307073f, 
    -0.04466673f, 0.03005021f, 0.00889191f, -0.09153148f, -0.00916860f, -0.03151093f, -0.11597916f, -0.00367480f, 
    -0.08603279f, 0.08518936f, -0.00511800f, -0.13811357f, 0.09164581f, 0.03422550f, -0.11438036f, 0.06421677f, 
    0.10988501f, 0.06378575f, -0.11337620f, -0.06912220f, 0.10687128f, -0.01455263f, -0.06405922f, 0.01698063f, 
    -0.05947214f, -0.09125215f, -0.25033677f, 0.00718586f, -0.07551565f, -0.03736416f, 0.15180874f, 0.10375784f, 
    0.10868258f, 0.05533713f, 0.14273770f, 0.03160870f, -0.15066215f, 0.06478991f, 0.05688620f, 0.15157785f, 
    -0.05074232f, -0.00687007f, -0.08852585f, -0.02995589f, -0.04798023f, 0.00836617f, -0.08742915f, 0.07446063f, 
    -0.15688764f, 0.12458906f, -0.03953517f, -0.09779947f, -0.09150871f, -0.06632181f, -0.07094341f, 0.10138595f, 
    -0.03594043f, 0.01364968f, 0.01853028f, -0.13473570f, 0.04249248f, 0.27441758f, 0.08653764f, -0.15209337f, 
    -0.02271177f, -0.10332158f, 0.07012615f, -0.03611708f, 0.00902541f, 0.03283241f, 0.11352517f, 0.02495689f, 
    0.10620882f, 0.19284470f, 0.12964089f, -0.13437741f, 0.10437918f, -0.05510623f, 0.08698972f, 0.13061664f, 
    0.11814916f, -0.03119233f, -0.00122709f, -0.06591258f, 0.10578824f, -0.01651504f, 0.10245050f, -0.01269987f, 
    -0.22621551f, -0.18872075f, -0.06219264f, -0.06268761f, 0.00664891f, 0.21161398f, -0.05942481f, 0.07701990f, 
    -0.21891931f, -0.03731651f, -0.11877687f, -0.20567930f, 0.00988823f, 0.15847248f, 0.02685072f, -0.02331277f, 
    -0.23372240f, -0.07104028f, 0.07578123f, -0.11323542f, -0.09312327f, 0.02468962f, -0.08685593f, 0.17001517f, 
    0.01814815f, 0.20549895f, -0.14985095f, -0.06852028f, -0.21945558f, -0.07565302f, 0.04480572f, -0.04007147f, 
    -0.14439173f, 0.01060150f, 0.04431961f, 0.03764041f, -0.05350695f, 0.01148252f, -0.07010906f, -0.02144138f, 
    -0.07602120f, 0.01324629f, -0.10525472f, -0.02880407f, 0.03722604f, -0.12527388f, 0.02527544f, -0.11910005f, 
    0.14545430f, 0.18322834f, 0.06178018f, -0.08204139f, -0.03204181f, -0.06109103f, -0.13184246f, -0.16778305f, 
    -0.03763263f, 0.03258079f, -0.04486595f, 0.11917984f, -0.02131188f, -0.01772770f, 0.01517274f, 0.05601754f, 
    0.03778430f, -0.03123945f, -0.05990650f, -0.19389334f, -0.02500713f, -0.11441625f, 0.01742462f, -0.09324413f, 
    -0.23931926f, -0.27986079f, 0.04924626f, 0.26955900f, -0.05166522f, 0.19943532f, -0.09233581f, -0.01935552f, 
    0.06141686f, 0.01804630f, -0.08911031f, -0.14622408f, -0.08244377f, 0.04160473f, -0.13237466f, -0.22647065f, 
    -0.06173356f, 0.11655392f, 0.20103741f, 0.23984393f, -0.30744672f, -0.11168452f, 0.06793533f, 0.24902323f, 
    0.11448537f, 0.04937338f, 0.04412072f, -0.06205321f, 0.04477778f, -0.06893718f, -0.03919435f, 0.02037539f, 
    -0.03499060f, 0.11349862f, -0.02929757f, 0.09018215f, 0.05664954f, 0.12551613f, -0.06027115f, 0.03516354f, 
    0.00732905f, -0.02613738f, -0.04241650f, 0.02163252f, -0.05014815f, -0.13018472f, -0.09166157f, 0.03899014f, 
    0.50763559f, 0.28172821f, 0.02839294f, -0.17483313f, -0.15107542f, 0.07426047f, 0.12284376f, -0.00638849f, 
    -0.00978327f, 0.02846875f, 0.10494246f, 0.02678290f, 0.11634738f, 0.03827766f, 0.04764263f, -0.03369965f, 
    -0.11500856f, 0.06298886f, 0.13225172f, -0.06732516f, 0.15416555f, 0.04616670f, 0.06296969f, 0.15681343f, 
    -0.03877843f, 0.06502584f, 0.05779968f, 0.12168617f, 0.13365173f, 0.13586077f, 0.10278675f, 0.00285754f, 
    0.01463782f, -0.08192545f, 0.07404897f, 0.13960129f, 0.15973975f, 0.09740874f, -0.05852134f, 0.03806606f, 
    -0.15030414f, 0.05301539f, -0.04061099f, 0.14045005f, 0.02827611f, -0.13681357f, 0.16866843f, -0.12084880f, 
    0.04258228f, 0.02328986f, 0.16840363f, 0.02408709f, 0.09842558f, 0.07615850f, 0.08689397f, -0.10265549f, 
    0.03512995f, 0.02032341f, -0.18503486f, 0.15932474f, -0.07758170f, -0.06852006f, 0.13995112f, 0.01533908f, 
    0.15311754f, 0.01861928f, 0.00240750f, 0.14978822f, -0.08306772f, 0.06126461f, 0.10487250f, 0.04327221f, 
    -0.03916825f, -0.07145280f, -0.10913110f, 0.14679457f, -0.07363027f, 0.12920114f, -0.14921443f, -0.14261903f, 
    0.07409050f, -0.07395966f, -0.00300495f, 0.08413102f, 0.07808502f, -0.02878492f, 0.06255893f, 0.06619006f, 
    -0.00460366f, 0.10276135f, 0.00218329f, -0.02349566f, 0.18053254f, -0.13995107f, 0.04157018f, 0.05981987f, 
    0.10062461f, -0.02230669f, 0.03859825f, 0.08997703f, 0.01826222f, -0.07192333f, 0.00802346f, 0.04540158f, 
    -0.07897025f, -0.05340353f, -0.19150491f, 0.10122255f, -0.07767641f, 0.02279081f, -0.00650425f, -0.03784994f, 
    0.10177503f, 0.04236643f, 0.01197547f, -0.12651962f, 0.05782271f, 0.06438005f, 0.20773491f, -0.04546280f, 
    0.12627165f, 0.26271012f, 0.10628127f, 0.09832948f, 0.16734749f, -0.11443846f, 0.12302517f, 0.09255699f, 
    -0.11462485f, -0.10599235f, 0.01398397f, -0.12998840f, -0.23212191f, -0.23221198f, -0.03100990f, -0.07203344f, 
    -0.02540264f, -0.08300451f, 0.01910606f, -0.00378657f, -0.02201384f, -0.07237350f, -0.13625589f, -0.04157287f, 
    0.06266377f, 0.22129634f, -0.00349895f, 0.08321868f, 0.06591585f, 0.04386612f, 0.01670678f, 0.05873402f, 
    0.10756636f, 0.14668937f, -0.05949583f, 0.17620754f, -0.03023007f, 0.08837052f, 0.15820311f, -0.06341308f, 
    0.02599414f, -0.13651450f, -0.26580355f, 0.15673852f, -0.07928928f, 0.04691546f, 0.28480801f, -0.02403940f, 
    -0.14852937f, 0.08594376f, -0.06784739f, 0.06192098f, 0.07355653f, -0.35407969f, -0.01343807f, 0.11117461f, 
    0.19391562f, -0.11068467f, 0.07032824f, 0.04948382f, -0.11758189f, 0.01602162f, -0.10026594f, 0.00963637f, 
    0.06917569f, -0.07846405f, 0.03770535f, 0.23898083f, -0.24336909f, -0.20932405f, 0.11501756f, -0.16449001f, 
    0.06360602f, 0.10820039f, 0.07992993f, -0.20595591f, -0.01230770f, -0.09484056f, -0.04983424f, 0.12346310f, 
    0.09026480f, -0.08193545f, 0.02279230f, -0.18755810f, 0.06313938f, -0.06972789f, -0.06749032f, -0.03117290f, 
    0.22414087f, -0.01130144f, -0.05786949f, 0.08775221f, -0.03873790f, 0.02580136f, 0.22726472f, 0.14339039f, 
    0.23921138f, 0.04747513f, -0.12144721f, -0.21701169f, -0.02534656f, -0.25998905f, 0.06340409f, -0.20466195f, 
    0.15422210f, 0.12371725f, -0.03155619f, -0.07270193f, -0.04372697f, -0.10622738f, 0.11652108f, 0.14211401f, 
    -0.13374625f, 0.22012292f, 0.11562143f, 0.33494428f, 0.02203625f, 0.11706748f, 0.03456290f, -0.11908703f, 
    0.09418429f, -0.12579714f, 0.01328928f, 0.08183740f, 0.03549295f, -0.14866540f, -0.15263900f, -0.16486867f, 
    -0.20787644f, -0.26966742f, -0.18363854f, 0.09559814f, 0.09780736f, 0.18131050f, 0.07475975f, 0.06672860f, 
    -0.00451113f, 0.06156276f, -0.02830194f, -0.00846381f, -0.11310305f, -0.06698858f, 0.19056107f, -0.07551604f, 
    0.01093891f, 0.21532300f, 0.07015742f, -0.00515922f, 0.08253265f, -0.07369579f, -0.09622936f, 0.09546968f, 
    -0.04545671f, 0.01586989f, -0.03175001f, 0.04856789f, -0.08264782f, -0.08074584f, -0.01985912f, 0.10904070f, 
    0.18790597f, -0.04060692f, -0.00560632f, 0.09410894f, 0.07660542f, 0.17430140f, 0.13818265f, 0.18777183f, 
    0.05868931f, 0.06274339f, 0.01175607f, 0.05215199f, 0.00936625f, -0.05804893f, -0.03119095f, 0.35118994f, 
    0.01857182f, -0.23157400f, -0.16278648f, 0.22365703f, 0.03714516f, -0.00120375f, -0.11648082f, 0.11274198f, 
    -0.08200805f, 0.14470686f, -0.14664695f, 0.04555287f, -0.07563348f, 0.31213978f, 0.13107313f, -0.05148540f, 
    0.13865308f, -0.06074829f, 0.18132327f, 0.04095255f, 0.13070729f, -0.03762200f, -0.04710777f, 0.05670526f, 
    -0.01005396f, 0.03138869f, 0.02957266f, -0.30374733f, -0.01252110f, 0.40728724f, -0.17423275f, -0.05294074f, 
    -0.04069343f, 0.04279752f, 0.00412821f, 0.02738478f, 0.14145014f, 0.15060048f, -0.34596589f, -0.03256296f, 
    -0.30520773f, 0.18931451f, -0.08771127f, 0.09349666f, 0.05684864f, -0.28658393f, -0.05809274f, -0.04349481f, 
    -0.00256827f, -0.01687495f, 0.00171674f, 0.08032964f, -0.08664276f, -0.00757242f, 0.05911532f, -0.01320391f, 
    0.18227202f, -0.05305473f, -0.02988143f, -0.17406923f, 0.01073979f, 0.00122134f, 0.02796572f, 0.02762138f, 
    -0.11407184f, -0.17834665f, -0.02540078f, -0.01964647f, 0.01322795f, 0.01163448f, 0.19048740f, 0.11317372f, 
    -0.07838625f, -0.22391319f, 0.03730482f, -0.10077403f, 0.01233191f, -0.03570205f, 0.05060176f, -0.04892058f, 
    -0.02109436f, -0.25791520f, -0.15895544f, 0.00828409f, 0.07548218f, 0.09931863f, 0.07241361f, 0.09682238f, 
    -0.08157735f, 0.12390777f, -0.49211654f, -0.15479624f, -0.19236198f, -0.09188934f, -0.26712021f, 0.02705572f, 
    -0.04237790f, -0.13783503f, 0.16099206f, -0.36025763f, -0.08800066f, -0.25717372f, -0.04517920f, -0.15207750f, 
    0.08135682f, 0.09607657f, -0.02560958f, -0.09397901f, 0.00999827f, 0.32810742f, -0.11419357f, -0.02137655f, 
    -0.01462880f, -0.01441149f, -0.03369615f, 0.14021917f, 0.00998592f, 0.14822641f, -0.18266080f, 0.09540547f, 
    0.09558312f, -0.04579318f, -0.05794091f, 0.10155375f, 0.00267636f, 0.21578290f, -0.25853041f, 0.18934083f, 
    -0.25627777f, 0.07531764f, -0.06100481f, -0.02836055f, 0.12185535f, 0.20772195f, -0.07404533f, 0.01100877f, 
    0.16982707f, 0.03814924f, 0.21761888f, -0.06181217f, -0.07335305f, -0.08542059f, 0.23602173f, -0.04027597f, 
    0.14700061f, -0.08117947f, -0.07164111f, -0.09616637f, -0.04630096f, 0.04237621f, 0.05429420f, 0.09830100f, 
    0.06370904f, -0.11822183f, 0.07960969f, -0.19829091f, 0.12163489f, 0.02939533f, -0.02803199f, -0.11239259f, 
    -0.03802335f, 0.12985100f, 0.56474984f, -0.18137789f, -0.29438907f, -0.04737766f, -0.02272820f, 0.07738506f, 
    -0.03227735f, 0.04053602f, -0.15764213f, 0.48267674f, 0.34403706f, 0.07933106f, 0.03291041f, 0.22094189f, 
    0.02899783f, -0.04114861f, 0.14670454f, -0.08538833f, -0.05789793f, 0.24327098f, -0.68434095f, 0.17668515f, 
    0.03483648f, 0.01974296f, -0.11473073f, -0.13429245f, 0.08256120f, 0.08062906f, 0.03246203f, -0.09087410f, 
    -0.10478034f, -0.09316009f, -0.01574934f, 0.02488357f, -0.03108064f, 0.16674365f, 0.11691737f, 0.09288776f, 
    -0.03904646f, 0.04013890f, 0.08243193f, -0.01698419f, 0.12685868f, 0.08522597f, -0.05350097f, -0.69439471f, 
    -0.14477330f, -0.34485620f, -0.00731452f, -0.09437812f, -0.03218663f, 0.08309333f, -0.07084833f, -0.06539193f, 
    -0.19080447f, 0.33302966f, 0.27733600f, -0.21704160f, -0.13882916f, -0.03873270f, 0.07373762f, 0.09940749f, 
    0.14163527f, 0.02421054f, 0.16821244f, 0.33434305f, -0.38028172f, -0.17008422f, -0.08027942f, -0.03209992f, 
    0.02414951f, 0.05541247f, 0.03232623f, -0.12074511f, 0.15728988f, -0.19718963f, -0.04043923f, -0.30182776f, 
    0.07600892f, 0.15987581f, 0.04528940f, -0.16020848f, 0.03992043f, 0.00453696f, 0.01954321f, 0.07078411f, 
    0.02634205f, 0.02795268f, -0.01427711f, 0.03808758f, -0.30549645f, -0.03092766f, 0.02643014f, -0.11668108f, 
    -0.01153228f, 0.10363430f, 0.05858419f, 0.02859747f, 0.02647659f, -0.31687859f, -0.02443342f, -0.43352908f, 
    0.15427896f, -0.03533413f, 0.01629405f, -0.17516251f, -0.06143658f, -0.09527405f, 0.12235857f, 0.22562569f, 
    -0.03574960f, 0.04047179f, 0.00850626f, 0.04297049f, -0.05608885f, -0.00094760f, -0.09818767f, 0.43184939f, 
    -0.11003473f, -0.24169122f, 0.05030483f, -0.04825953f, 0.29149258f, -0.09239142f, -0.18583311f, -0.03098241f, 
    -0.06286896f, -0.00107151f, -0.05595664f, -0.05233901f, -0.05641621f, -0.04758756f, 0.04649447f, 0.04540180f, 
    0.04842525f, -0.04262426f, -0.06116213f, 0.01100710f, 0.00275086f, -0.05906909f, -0.02181354f, -0.03832563f, 
    -0.01375567f, 0.00172429f, -0.01541659f, -0.01173461f, 0.00921232f, -0.01621152f, -0.04401324f, -0.05808415f, 
    0.01972542f, -0.05405145f, -0.02496608f, 0.03433597f, 0.00096253f, 0.01796110f, 0.03008857f, 0.00868223f, 
    -0.04768749f, -0.02609736f, -0.00076095f, -0.05028484f, 0.04187690f, 0.04336906f, 0.03154708f, -0.01796624f, 
    0.02337851f, -0.03540852f, -0.03004872f, -0.01706878f, -0.04325794f, -0.04770171f, -0.02740054f, -0.04972870f, 
    -0.01581200f, 0.04993267f, -0.04091242f, -0.03869883f, 0.00246404f, 0.02224998f, -0.03848681f, -0.04910758f, 
    -0.00706477f, -0.02360478f, 0.00964466f, -0.05589058f, 0.00537617f, -0.00467530f, 0.04618302f, -0.00358046f, 
    -0.02492217f, -0.01767624f, -0.02225123f, 0.01429364f, 0.00465570f, -0.04203231f, -0.01446048f, -0.02607483f, 
    0.02627292f, 0.01816660f, 0.02396271f, 0.04439905f, -0.03606394f, 0.02998030f, 0.01960370f, 0.01635646f, 
    -0.00674811f, -0.05154027f, 0.04706847f, 0.02218287f, -0.02108028f, -0.01064145f, 0.03433273f, -0.05447246f, 
    0.01738504f, 0.02904401f, 0.02428048f, 0.00026275f, -0.04400752f, -0.04604178f, 0.01398171f, -0.02968406f, 
    -0.02445101f, 0.00666188f, -0.02937909f, -0.01635988f, -0.03068073f, 0.01616009f, 0.01913560f, -0.01276313f, 
    0.04595819f, -0.03922556f, -0.03507682f, 0.01886161f, -0.04580452f, -0.03250087f, 0.00369217f, -0.04918518f, 
    0.04126073f, 0.05582105f, -0.05662708f, -0.05403299f, 0.04073753f, 0.02781978f, -0.04652309f, -0.01442975f, 
    0.00845503f, 0.01351826f, -0.06135802f, -0.07668846f, 0.01617148f, 0.03671198f, -0.02877068f, 0.03312298f, 
    -0.05154954f, -0.01715840f, -0.04928079f, 0.00640756f, -0.05557781f, -0.04671449f, -0.02255687f, 0.03520662f, 
    0.03485971f, -0.03567018f, -0.00019474f, 0.02526953f, -0.02890418f, 0.00437167f, -0.03257652f, 0.02240855f, 
    -0.02648708f, 0.03963549f, -0.01561845f, -0.02987153f, -0.00703883f, -0.04448590f, 0.03673421f, 0.00612505f, 
    0.04707200f, 0.01070637f, 0.00146388f, -0.05670947f, 0.01874651f, 0.00375276f, 0.04152101f, -0.03567810f, 
    0.01812765f, -0.06067688f, 0.03966561f, -0.05888563f, -0.01094616f, -0.05157287f, 0.02613767f, -0.04036799f, 
    -0.01530003f, 0.04359740f, 0.03694767f, 0.03832451f, -0.02579555f, -0.00295885f, -0.02230613f, 0.03155480f, 
    0.02480393f, -0.05177742f, -0.02148008f, 0.00974891f, 0.03693758f, -0.01620003f, 0.02937903f, -0.00917760f, 
    0.03552431f, -0.00942249f, 0.00465897f, 0.01611621f, -0.04173643f, 0.00260590f, -0.04633361f, -0.04572068f, 
    -0.02491698f, -0.03874188f, 0.02036224f, -0.04633337f, -0.01372746f, 0.01404316f, 0.01677403f, 0.03187654f, 
    0.02384722f, -0.05514036f, 0.04600247f, -0.05564283f, 0.02215533f, 0.00282963f, -0.04897705f, 0.03096393f, 
    -0.01761152f, 0.03174723f, 0.05508237f, 0.00161766f, 0.03057766f, -0.03679217f, 0.03397585f, 0.03732783f, 
    -0.00769154f, -0.02348890f, 0.04000861f, 0.03487626f, -0.04434065f, -0.04040251f, -0.05099412f, -0.02452436f, 
    -0.01630863f, -0.01924380f, -0.03567988f, -0.05615878f, 0.05131930f, 0.00057546f, -0.00825467f, 0.00911591f, 
    0.00225745f, 0.05150248f, 0.04543743f, -0.01373967f, 0.02489649f, 0.03132170f, 0.02502491f, 0.04567430f, 
    0.00507171f, 0.00655581f, -0.02167602f, -0.02121327f, -0.06020959f, -0.05875346f, -0.03400527f, -0.01040521f, 
    -0.05727304f, 0.05165462f, -0.00197791f, -0.03525503f, -0.02536914f, 0.02702420f, -0.03173102f, -0.02342851f, 
    -0.05334832f, -0.01957864f, 0.02175407f, -0.06035277f, -0.01029782f, -0.05949840f, 0.03585622f, -0.04258432f, 
    -0.03757068f, 0.01806313f, -0.03199364f, 0.03298894f, -0.05110278f, -0.02039064f, 0.02028279f, 0.00228553f, 
    -0.01463139f, -0.06897195f, 0.02614902f, 0.02521243f, 0.00418523f, -0.00803046f, 0.00632139f, 0.00652267f, 
    -0.05842665f, -0.04422526f, 0.01347007f, 0.03975780f, 0.02570263f, -0.06279578f, -0.04356164f, 0.02704302f, 
    -0.01429340f, 0.13280869f, 0.18083020f, -0.00530062f, 0.01408145f, 0.16234368f, 0.12661532f, 0.04179079f, 
    0.09329487f, -0.00475554f, -0.10148699f, 0.18594347f, 0.15930857f, 0.15407231f, -0.05768058f, -0.05829869f, 
    0.11298755f, 0.14960803f, 0.04658068f, -0.09768686f, -0.14892037f, -0.05384578f, 0.02045374f, 0.13741939f, 
    0.15978067f, 0.02671374f, 0.17758918f, 0.14595038f, -0.03530061f, -0.06265250f, 0.01041694f, 0.06588542f, 
    -0.11446157f, -0.06156496f, 0.02187905f, 0.03958436f, 0.36828041f, -0.22714341f, 0.00997760f, 0.05834029f, 
    -0.06346922f, -0.05264121f, 0.04692817f, 0.10834517f, 0.09243119f, 0.02535745f, 0.07864435f, 0.02054422f, 
    0.07291272f, -0.04830071f, 0.03275951f, 0.09302475f, 0.07514082f, 0.11181445f, -0.10300317f, -0.01473410f, 
    -0.05757174f, 0.08144001f, 0.07501149f, 0.07934897f, 0.17752831f, -0.02565817f, -0.03022078f, -0.05770779f, 
    -0.17510524f, -0.04961019f, 0.02992078f, -0.12582967f, 0.01294338f, 0.04929525f, 0.16753303f, 0.06005317f, 
    0.14248504f, 0.12749441f, -0.03366812f, -0.04601191f, -0.23014429f, -0.15047085f, -0.00036439f, 0.01217126f, 
    -0.01897505f, -0.16038865f, -0.17385508f, -0.00060307f, 0.01276204f, -0.04137999f, -0.13504614f, -0.00530757f, 
    0.18648282f, 0.26174173f, -0.08448230f, 0.00825234f, -0.10409740f, -0.00226220f, -0.22661211f, -0.10579678f, 
    -0.03725400f, 0.03984230f, -0.01920203f, -0.12398537f, -0.13351221f, -0.07597594f, -0.28657719f, -0.19960096f, 
    -0.26953939f, 0.07227218f, -0.01688888f, -0.04779846f, 0.14494075f, 0.09928124f, -0.00306898f, 0.04484056f, 
    0.09571192f, -0.10600770f, 0.16058792f, -0.02014739f, 0.07412390f, -0.18953525f, 0.13569348f, 0.02154963f, 
    -0.03185234f, -0.07605061f, -0.06288377f, 0.02440668f, -0.06383263f, 0.20123322f, -0.08654644f, -0.11192606f, 
    -0.08070927f, -0.06444707f, 0.13127576f, 0.00221930f, 0.04459427f, 0.06811325f, 0.09024638f, -0.00842900f, 
    -0.20467786f, 0.08889692f, -0.02102911f, 0.03763550f, -0.04045842f, 0.11716226f, -0.06110850f, 0.04592418f, 
    -0.01895325f, 0.16783530f, -0.11036322f, 0.03278499f, -0.10762712f, 0.10097581f, 0.12425615f, 0.11279404f, 
    0.06737193f, -0.21464089f, 0.20270994f, 0.11631197f, -0.03448008f, -0.03377276f, -0.12666535f, -0.04274054f, 
    0.05116747f, -0.00743398f, -0.01817509f, -0.15241773f, -0.15850750f, -0.02590024f, -0.03207240f, 0.04995565f, 
    -0.08919263f, -0.10384418f, 0.02276336f, -0.51485920f, 0.06511857f, -0.00398042f, 0.01493416f, -0.01113662f, 
    0.12607802f, -0.04202826f, -0.05845025f, -0.17730507f, -0.24096027f, 0.29648218f, 0.05255913f, -0.06746959f, 
    -0.20178626f, -0.04393594f, 0.02507258f, 0.06231818f, -0.11348505f, -0.29018790f, -0.22355594f, -0.15462527f, 
    -0.01193118f, 0.07117666f, 0.02597737f, 0.03288608f, -0.01729189f, 0.13188639f, -0.27157986f, -0.12154951f, 
    -0.04113077f, 0.13619663f, -0.01141662f, 0.03654221f, 0.13947707f, 0.07826409f, 0.02275749f, -0.31313324f, 
    -0.00883667f, -0.04775390f, -0.08476339f, -0.09810102f, -0.15890844f, -0.11811612f, 0.03057336f, -0.00288555f, 
    -0.13632753f, 0.00266403f, -0.02505504f, -0.08304281f, -0.28807822f, -0.19664849f, -0.02604469f, 0.13175559f, 
    -0.11846750f, -0.11830181f, 0.05270327f, -0.12162637f, -0.04782041f, -0.01399746f, -0.07875004f, 0.09843256f, 
    0.05084568f, -0.04650798f, -0.31167787f, -0.23422767f, -0.47750765f, 0.03105680f, -0.09776206f, -0.01071849f, 
    0.02239946f, 0.06317025f, 0.10566282f, -0.02182847f, -0.08079317f, 0.00798059f, -0.07595589f, 0.10199694f, 
    -0.07666025f, 0.02342531f, 0.15902805f, 0.06613512f, 0.49271739f, 0.10285807f, -0.04700356f, -0.03829026f, 
    -0.05884332f, -0.10888748f, 0.06793713f, -0.02258925f, 0.08954111f, -0.05334779f, 0.20635907f, 0.14575469f, 
    0.11800365f, 0.05942484f, -0.03371770f, 0.07804936f, 0.01714540f, 0.03466630f, -0.08333840f, 0.18434455f, 
    0.14871666f, 0.08686125f, 0.03125818f, 0.02163517f, 0.06229122f, -0.00033848f, 0.00509625f, 0.02891740f, 
    0.22384796f, -0.12427342f, -0.07366679f, -0.05486015f, 0.17925729f, 0.04226926f, 0.00808736f, -0.06406028f, 
    -0.02127207f, 0.06735975f, 0.01700454f, -0.03840450f, 0.15045084f, 0.17449977f, 0.03747620f, -0.12147819f, 
    0.11745661f, -0.09602965f, -0.17754993f, 0.04855381f, -0.07843149f, 0.13938722f, 0.10177428f, 0.04551626f, 
    0.08395717f, 0.02727229f, -0.05961129f, -0.18085016f, -0.06614224f, 0.01920931f, 0.08100622f, -0.00197384f, 
    0.10238512f, 0.07509366f, 0.09011050f, 0.02030634f, -0.19689763f, 0.02820405f, 0.10566486f, 0.07544546f, 
    -0.13630380f, -0.01282738f, 0.03579071f, 0.08405243f, 0.39355847f, 0.01178144f, -0.33467421f, 0.07144989f, 
    -0.02929461f, -0.07813435f, 0.04632384f, -0.03146762f, 0.07278810f, 0.04587576f, 0.03031722f, 0.01971424f, 
    0.03235616f, -0.00551975f, -0.07739610f, 0.03344246f, 0.09295970f, 0.15151727f, -0.19496445f, -0.13788155f, 
    -0.03330844f, 0.13066150f, 0.15943307f, 0.00572291f, 0.01130693f, -0.12783691f, 0.05998404f, 0.15187094f, 
    0.02959929f, 0.00374567f, -0.05162183f, -0.04383867f, 0.03527169f, 0.15199232f, 0.00034013f, 0.19645821f, 
    0.05336843f, 0.02935798f, -0.02748987f, 0.01096489f, -0.06553993f, -0.06182824f, 0.06954820f, -0.02289956f, 
    -0.18860222f, -0.00707999f, -0.14753228f, 0.15538622f, 0.02321254f, -0.03368648f, -0.16479704f, -0.02893900f, 
    0.09546517f, 0.28745911f, 0.08975723f, -0.05739780f, 0.06651762f, -0.11872867f, -0.16205753f, 0.04146739f, 
    0.00252244f, 0.09974494f, -0.11700658f, -0.00756627f, 0.06606833f, -0.07239990f, 0.05486854f, 0.10194112f, 
    -0.16778612f, 0.01637196f, -0.05144405f, 0.00817637f, 0.01208654f, -0.07014301f, -0.01510668f, 0.06297313f, 
    -0.01555976f, -0.02683437f, -0.02827926f, -0.06089827f, 0.02163763f, -0.24239600f, -0.04897591f, 0.06845777f, 
    -0.01349486f, -0.12562989f, 0.04539012f, -0.02975387f, 0.05015836f, 0.15583472f, 0.03779218f, -0.00425715f, 
    0.00805284f, 0.03841690f, -0.06330472f, -0.04403277f, -0.07387528f, 0.01962608f, 0.11361026f, 0.15952705f, 
    -0.25178975f, 0.00131351f, -0.02245252f, 0.01837044f, -0.03432553f, 0.07983004f, -0.06224209f, 0.03081775f, 
    0.10323043f, -0.11708431f, -0.00029526f, -0.07013512f, -0.12877105f, 0.15488005f, 0.11353689f, 0.04344175f, 
    0.00586989f, -0.10414263f, 0.07339926f, 0.04992659f, -0.06736737f, 0.02310923f, 0.08220101f, -0.01145556f, 
    -0.10883603f, 0.01173180f, 0.10790026f, -0.15535390f, -0.17644434f, 0.01673566f, 0.00554766f, 0.15498930f, 
    -0.15539862f, 0.03262931f, -0.01412980f, -0.27779061f, -0.11401947f, 0.09189485f, -0.22069278f, -0.12531504f, 
    -0.04402165f, -0.08621138f, -0.05596611f, -0.05637057f, -0.05243935f, -0.07164054f, -0.02815798f, -0.09355444f, 
    0.03043468f, -0.06514619f, -0.10772341f, -0.13520963f, -0.17868116f, -0.32426226f, -0.25305024f, -0.17744415f, 
    0.02111990f, 0.00568479f, 0.09279709f, 0.07371210f, 0.25895193f, 0.16980712f, 0.04029622f, -0.02963113f, 
    0.10774683f, -0.01099946f, -0.12586300f, -0.01742009f, -0.01456197f, -0.11490445f, -0.03402821f, -0.22434208f, 
    0.03423015f, 0.06207177f, 0.11456179f, -0.07435368f, -0.11594890f, 0.04778783f, 0.06162601f, 0.00765948f, 
    0.01050627f, 0.03106626f, 0.12305542f, -0.01369079f, -0.08957505f, -0.15418056f, -0.13236873f, -0.06200981f, 
    -0.11610224f, -0.07025293f, 0.05162299f, -0.07828077f, 0.14838940f, -0.03359428f, 0.04656206f, -0.06371529f, 
    0.06094433f, 0.07324836f, -0.32960126f, -0.24082685f, -0.00650538f, 0.00582707f, 0.03777208f, -0.06742662f, 
    0.11048623f, 0.14215568f, 0.20882712f, -0.08985580f, -0.09084837f, -0.08506888f, -0.01313323f, 0.00530818f, 
    -0.09867817f, 0.01059879f, 0.16237587f, 0.14282128f, 0.41841447f, 0.15028562f, -0.25211796f, 0.03600852f, 
    0.01745708f, -0.00636417f, 0.00207431f, -0.00159477f, 0.06621177f, 0.06559397f, 0.09085616f, 0.10015036f, 
    0.08139874f, 0.04390888f, -0.04564006f, -0.01016075f, -0.06638326f, -0.04330609f, -0.00326378f, 0.01009377f, 
    0.16351856f, -0.04401642f, -0.05357399f, 0.00278696f, -0.02015686f, 0.01701372f, -0.14671415f, 0.20258573f, 
    -0.04883216f, -0.11092141f, -0.14837712f, -0.18780296f, 0.06609047f, -0.04512445f, -0.14434792f, 0.03614829f, 
    -0.00184251f, -0.22379421f, -0.15557574f, -0.13490677f, -0.16699286f, -0.08587502f, 0.09600546f, 0.03325244f, 
    -0.02441859f, -0.11538026f, 0.10328794f, 0.07769083f, 0.11086167f, 0.17323327f, 0.00257204f, -0.14865081f, 
    -0.02360037f, 0.04939156f, -0.41537264f, -0.28451434f, 0.07337653f, -0.02242239f, 0.08373024f, 0.03999539f, 
    0.09702472f, 0.04506541f, -0.07410322f, 0.15002240f, 0.07622432f, 0.16939530f, -0.04429044f, 0.14079367f, 
    0.04599587f, 0.19679274f, -0.06670694f, 0.04190885f, -0.03902067f, 0.18508410f, 0.05705217f, 0.02217955f, 
    0.14372396f, -0.15227109f, 0.01169792f, 0.22895448f, -0.14729156f, 0.14291652f, 0.13629863f, 0.07103765f, 
    -0.11603259f, -0.09670303f, 0.01687093f, 0.05512270f, 0.06175268f, 0.12620777f, -0.20373638f, -0.12809412f, 
    0.12256456f, -0.03335758f, 0.00861528f, 0.12475867f, 0.04948156f, 0.04874195f, -0.01303566f, 0.00064464f, 
    0.10062353f, 0.21084085f, -0.11041649f, -0.00945143f, -0.05066546f, 0.01909585f, 0.09078760f, 0.10536868f, 
    0.17367887f, 0.01186000f, 0.08766837f, 0.01326801f, 0.08602452f, 0.12442698f, 0.04550759f, -0.09296452f, 
    -0.10049316f, 0.11224697f, -0.02179458f, 0.21709891f, 0.04573827f, 0.06321286f, 0.08526962f, 0.08199631f, 
    -0.12693013f, 0.14073874f, 0.22743447f, -0.00560439f, 0.19606087f, 0.18043628f, 0.04469068f, 0.04131289f, 
    -0.01200816f, -0.18069771f, -0.06119603f, 0.15901524f, 0.00608599f, 0.09250412f, -0.18767312f, -0.02427235f, 
    -0.30401537f, -0.00862419f, -0.12937199f, -0.00663383f, -0.12213675f, -0.05630603f, 0.09202299f, 0.07274116f, 
    0.07915349f, 0.20635784f, -0.03739003f, -0.07447976f, -0.12964286f, 0.01391612f, -0.06831942f, 0.19838162f, 
    -0.00583066f, -0.06654209f, 0.05617733f, -0.14017422f, 0.14709179f, 0.10132269f, 0.15622711f, 0.12033204f, 
    0.07364248f, -0.15395194f, 0.02457514f, -0.16139807f, -0.01433886f, -0.04761948f, -0.02036669f, -0.19204152f, 
    0.03132854f, -0.05314016f, -0.00468694f, -0.00106847f, 0.05373162f, 0.10439783f, 0.07314803f, -0.24499980f, 
    0.09805881f, -0.01648469f, 0.14130256f, 0.10181429f, 0.08508808f, 0.02895080f, -0.10868044f, -0.07660963f, 
    0.01499000f, 0.26024777f, -0.41147175f, -0.43396726f, -0.27095705f, -0.20099649f, -0.00711404f, 0.01901116f, 
    0.00366241f, -0.08719536f, -0.34831965f, 0.01278748f, 0.17364599f, -0.00836227f, -0.09523349f, -0.09313685f, 
    0.00633066f, -0.05709206f, -0.11796316f, 0.01046859f, -0.07887680f, 0.01472680f, -0.14756294f, 0.06113823f, 
    0.06008019f, 0.17967224f, 0.02018358f, 0.04049120f, 0.23679796f, -0.20660955f, -0.08052887f, -0.18287095f, 
    -0.06329203f, -0.13548808f, -0.06878656f, -0.20382658f, -0.05126709f, 0.04669674f, -0.11682716f, 0.05576498f, 
    0.03086171f, 0.02642967f, 0.05341219f, 0.01681899f, -0.09543360f, 0.08278321f, -0.05010827f, -0.15352570f, 
    -0.21262202f, -0.12106172f, -0.02182307f, 0.02686090f, 0.03162930f, 0.00960129f, 0.03057436f, 0.09839798f, 
    -0.17289798f, -0.00773379f, 0.04028649f, 0.06751537f, 0.09412599f, 0.07802430f, 0.04554407f, 0.08631063f, 
    0.17733793f, 0.01751799f, 0.17433283f, -0.07047366f, -0.06638870f, -0.16160652f, 0.03184582f, -0.00626110f, 
    0.00935394f, -0.18910392f, -0.02164962f, 0.05611685f, 0.05530526f, -0.02611810f, 0.07688114f, -0.06757992f, 
    0.02225002f, 0.19570044f, -0.20909929f, -0.00215269f, 0.27267647f, 0.03085217f, -0.02222939f, 0.15807647f, 
    0.09686229f, 0.04371860f, 0.10200653f, -0.05394531f, 0.01422033f, -0.18874137f, -0.07541902f, -0.01821256f, 
    0.14479306f, 0.09497507f, -0.00369497f, -0.01517681f, 0.31596106f, 0.07766566f, 0.03061749f, 0.07738588f, 
    -0.00382109f, 0.00934196f, -0.13717625f, -0.08257188f, -0.10744156f, 0.38137433f, 0.04193456f, -0.38676369f, 
    -0.13612172f, -0.13062304f, 0.01535362f, 0.01099948f, 0.09906313f, 0.06842814f, -0.15758111f, -0.15626021f, 
    -0.23980467f, -0.02026277f, 0.04124164f, -0.04660245f, -0.08125195f, -0.00688189f, -0.11799061f, -0.12553205f, 
    -0.27084818f, -0.21968827f, 0.12119253f, 0.01536368f, 0.03674359f, 0.01916447f, 0.07254989f, -0.07313310f, 
    -0.00636555f, 0.05648877f, -0.11257444f, 0.08453855f, -0.12052444f, -0.02001813f, 0.00444972f, 0.09914334f, 
    0.03328741f, -0.00222211f, -0.11118113f, 0.07369016f, 0.06433886f, 0.18392184f, -0.04859695f, -0.14670743f, 
    -0.12441255f, 0.18740200f, -0.15092257f, 0.06620705f, 0.12982953f, -0.09050564f, 0.16387458f, 0.14866284f, 
    0.06578396f, 0.16598347f, -0.03210025f, 0.02921017f, -0.17763008f, -0.09863026f, 0.01122948f, 0.06814511f, 
    0.17576142f, -0.22911543f, -0.03537039f, 0.03504330f, 0.00422039f, -0.29206392f, 0.04639835f, -0.01532060f, 
    0.06029196f, 0.00701017f, -0.18283366f, -0.06029463f, 0.00801390f, 0.18556575f, 0.03363940f, 0.18791348f, 
    0.03450271f, 0.01263596f, 0.08261833f, 0.03988208f, 0.13435750f, 0.24296296f, 0.20690122f, 0.13566515f, 
    -0.15522832f, 0.01205914f, 0.05634372f, 0.10181392f, 0.01678174f, -0.02661598f, -0.18117909f, -0.01503299f, 
    -0.25622824f, 0.10096963f, 0.00233886f, 0.19519366f, -0.08381993f, -0.15298933f, 0.06115984f, 0.09600310f, 
    -0.03263826f, -0.13847505f, -0.06346314f, -0.04948751f, 0.03189571f, 0.12299652f, 0.04224227f, -0.05482503f, 
    -0.13041832f, -0.19323790f, -0.03303182f, 0.17740417f, -0.03525270f, 0.06644712f, 0.00630797f, -0.01652065f, 
    0.15005510f, 0.14030156f, -0.08435905f, -0.22611985f, -0.03463249f, -0.05820167f, 0.01697268f, 0.15409790f, 
    -0.03513839f, -0.10919821f, -0.24436285f, -0.06588562f, -0.06086424f, -0.09056584f, -0.04499484f, -0.02137468f, 
    -0.27376059f, -0.17195295f, -0.24407098f, -0.07875296f, 0.11862897f, 0.02780813f, -0.06499504f, 0.10916546f, 
    0.08032465f, 0.01234815f, -0.07948559f, 0.03496712f, -0.01352355f, 0.20215937f, -0.07156508f, 0.19801365f, 
    0.03792064f, -0.04720015f, -0.12226590f, 0.08209825f, -0.13718525f, 0.17550054f, 0.01643196f, -0.00007985f, 
    -0.04417210f, -0.13798971f, -0.07551042f, -0.05582188f, -0.07637291f, -0.06445971f, 0.09574448f, 0.00161808f, 
    0.06750757f, 0.03754607f, 0.04082922f, -0.00815736f, 0.13780995f, 0.03378494f, 0.01549901f, -0.03715700f, 
    0.02312196f, -0.11910795f, 0.08508368f, -0.10763460f, 0.05892514f, 0.15693465f, 0.08046344f, -0.12444305f, 
    0.07928803f, 0.03691223f, 0.02892278f, -0.30114901f, 0.02320275f, 0.03522373f, -0.11124505f, 0.02901774f, 
    0.01679555f, -0.04575165f, -0.41343391f, -0.03408522f, 0.33643574f, 0.04882806f, 0.06228190f, -0.03182168f, 
    -0.18003102f, -0.18170519f, -0.17947589f, -0.20897262f, -0.01057011f, 0.15963103f, 0.12480127f, -0.05072369f, 
    0.09226850f, 0.07038494f, -0.19314742f, -0.12801844f, 0.08393589f, 0.00392834f, -0.06869411f, 0.17312536f, 
    -0.10391497f, 0.00409155f, -0.03177899f, -0.02766684f, -0.07558136f, -0.01431493f, 0.03766730f, 0.17567822f, 
    0.08235358f, 0.18129782f, 0.10394958f, 0.10337654f, -0.18153186f, -0.05311662f, 0.01504477f, 0.13876651f, 
    0.00208800f, 0.05020868f, 0.06018404f, -0.00060286f, 0.08792245f, -0.05797876f, -0.08076169f, -0.28680611f, 
    -0.26753733f, -0.14183557f, 0.00301039f, -0.00091567f, 0.12814897f, -0.03528295f, -0.02886500f, -0.07139929f, 
    -0.10667907f, -0.13350260f, -0.07974666f, -0.16227713f, -0.08008973f, 0.08076873f, -0.04669655f, -0.03186224f, 
    0.04873988f, -0.06181379f, -0.35440886f, -0.16890655f, 0.08030792f, 0.04127616f, 0.12716992f, 0.01882135f, 
    -0.16567555f, -0.17136578f, -0.38162315f, -0.22527252f, -0.10193412f, 0.04990749f, 0.01897712f, -0.02675829f, 
    0.00261538f, 0.13818178f, 0.07292830f, 0.03548485f, 0.05794130f, 0.05256825f, -0.05220793f, -0.02768332f, 
    -0.01842580f, 0.01868085f, 0.07331223f, 0.11176828f, 0.00058246f, -0.04834820f, -0.22097316f, 0.02755747f, 
    -0.05722504f, -0.11805192f, -0.14515734f, -0.16167103f, -0.06620020f, 0.13386579f, 0.17183600f, 0.09364657f, 
    -0.02071570f, 0.07732004f, 0.08410595f, 0.00792251f, 0.07293273f, 0.03553980f, -0.03123154f, 0.05225812f, 
    0.08694176f, 0.04443975f, -0.00437564f, 0.00581395f, 0.06029812f, -0.07009485f, -0.07197199f, -0.15176460f, 
    0.13473429f, 0.14130735f, 0.13219289f, 0.02906564f, 0.13782591f, 0.04751341f, 0.05757159f, 0.12890020f, 
    -0.01099156f, -0.07201289f, 0.01307027f, -0.00212171f, -0.00470274f, 0.03376510f, -0.06615204f, 0.00958883f, 
    0.02690669f, -0.05125265f, 0.04106234f, 0.01927652f, -0.06005832f, 0.02693811f, 0.04711563f, -0.03846142f, 
    -0.00362538f, 0.04671581f, -0.03634284f, -0.06839513f, -0.02478959f, -0.02562542f, -0.05458221f, -0.01472167f, 
    -0.02698884f, -0.00910226f, 0.02113966f, -0.02729593f, 0.04666844f, 0.05720342f, 0.03633031f, -0.00712955f, 
    -0.06470776f, -0.04409939f, 0.01579602f, -0.04304791f, -0.00095710f, 0.02300618f, -0.03816888f, -0.03788127f, 
    0.01641071f, -0.00733480f, -0.04855774f, -0.00596544f, 0.00456521f, -0.07070914f, -0.05205078f, 0.04748799f, 
    -0.06199213f, -0.01438276f, -0.00186414f, -0.03022003f, 0.03570468f, 0.02672182f, -0.04285138f, 0.01993019f, 
    -0.05077152f, 0.05252705f, 0.04389918f, -0.02414005f, -0.03164695f, 0.01406380f, 0.03048594f, -0.00010313f, 
    -0.00641860f, 0.00960177f, -0.05342903f, 0.02937987f, -0.04163395f, -0.05551260f, 0.01869343f, -0.05982280f, 
    0.01740653f, 0.00110216f, 0.04799971f, 0.01275785f, -0.00894852f, -0.00823510f, -0.03745468f, 0.02595330f, 
    0.03405136f, -0.01057623f, 0.01413915f, 0.03614784f, 0.04154964f, -0.01396367f, 0.01164429f, -0.06182085f, 
    -0.03319389f, 0.00344040f, 0.00095130f, -0.03549470f, -0.01621403f, -0.01909750f, 0.01809841f, 0.01385645f, 
    0.01624281f, -0.04239007f, -0.02199778f, -0.06514558f, 0.03138438f, -0.03243654f, 0.03864986f, -0.03692301f, 
    0.02225635f, 0.02024614f, -0.04520968f, 0.00649723f, 0.04691982f, -0.00706588f, -0.03699663f, 0.01599364f, 
    0.01306263f, -0.02908335f, -0.05022149f, -0.05513912f, -0.02077014f, -0.01437764f, -0.01362107f, 0.01753360f, 
    0.03765236f, -0.02323568f, -0.04550778f, 0.03685496f, -0.01882113f, -0.04727644f, 0.02803652f, -0.04199322f, 
    -0.02537811f, 0.05020883f, -0.03956482f, -0.04430025f, -0.03210593f, -0.03040100f, -0.06481934f, 0.04010228f, 
    0.02628396f, -0.06933672f, 0.03500679f, -0.02603785f, -0.03361382f, -0.05451979f, 0.00793482f, 0.05527100f, 
    -0.03636426f, -0.05372706f, -0.03105011f, 0.00283253f, 0.03007296f, 0.01236743f, 0.00256964f, -0.05868075f, 
    0.00287967f, -0.02217932f, 0.03135204f, -0.03168292f, -0.02924535f, -0.01292223f, -0.05688073f, 0.02264443f, 
    0.01240299f, -0.04282299f, -0.03354400f, 0.00475126f, 0.01561753f, 0.00066790f, 0.04185394f, -0.02346846f, 
    0.00766653f, 0.04094274f, 0.03952360f, -0.01153737f, -0.03257129f, 0.02455248f, -0.05115054f, 0.02377935f, 
    -0.04209360f, -0.05423862f, 0.00459250f, -0.02912336f, -0.00733008f, -0.00847638f, 0.02372399f, -0.05826417f, 
    -0.00230787f, -0.01826767f, -0.01079652f, 0.03722723f, -0.01931219f, 0.00762634f, 0.02829134f, -0.06046637f, 
    0.02252244f, 0.00016051f, -0.03306533f, 0.00285611f, -0.01975392f, -0.03565995f, 0.00526393f, -0.06413018f, 
    -0.04775112f, -0.04439250f, -0.04806445f, 0.03680849f, -0.03571736f, -0.05109459f, -0.00194007f, 0.02949788f, 
    -0.00306524f, -0.02321997f, 0.01754716f, -0.06339809f, 0.02854618f, -0.02992131f, 0.02965943f, -0.05994606f, 
    0.01314242f, 0.03505313f, -0.05237042f, -0.00809951f, 0.04489966f, -0.04999868f, 0.00697251f, 0.02217787f, 
    -0.04323282f, -0.03134154f, 0.01392492f, -0.06699279f, -0.01467408f, 0.01129773f, 0.02122805f, -0.01548671f, 
    0.02972932f, 0.03135866f, -0.00274732f, -0.06797961f, -0.07375917f, -0.00536699f, -0.05934334f, 0.04118763f, 
    0.00187375f, -0.03491085f, 0.02359364f, -0.00988596f, -0.04487971f, 0.00897477f, -0.02950304f, 0.01511085f, 
    -0.00163672f, 0.02138316f, -0.00843225f, 0.01836561f, 0.04601762f, -0.00822216f, -0.01230418f, -0.05151209f, 
    0.02786682f, 0.03647994f, -0.01514987f, 0.03347824f, 0.02401401f, 0.03187266f, 0.02218177f, -0.05459566f, 
    -0.03549640f, 0.01461465f, -0.03010161f, -0.06269400f, 0.01375189f, -0.05144131f, -0.00122204f, 0.03152973f, 
    -0.06315517f, 0.02366711f, 0.04871474f, 0.04518936f, 0.01669866f, 0.04626473f, 0.02878638f, -0.02333389f, 
    0.02561902f, 0.00537764f, -0.05800816f, 0.05285770f, -0.02131586f, 0.03531892f, 0.01406993f, -0.04996317f, 
    0.02911349f, 0.19177499f, -0.04889907f, 0.15541576f, -0.20327285f, -0.06336696f, 0.07845352f, -0.03218684f, 
    0.01622183f, -0.38573554f, 0.16014831f, -0.21056169f, 0.09295107f, 0.07088108f, -0.05457976f, -0.05101607f, 
    0.16313204f, -0.01114334f, 0.22687861f, 0.32160074f, 0.16647859f, -0.00179595f, -0.02126487f, 0.15981767f, 
    0.11391006f, 0.02766661f, -0.05461304f, -0.36329690f, 0.04439868f, -0.15896973f, 0.17013656f, -0.10889615f, 
    0.05723440f, 0.08352828f, 0.13607001f, -0.06676469f, -0.55127692f, 0.08186210f, -0.34310973f, 0.19977871f, 
    -0.09140653f, 0.21775277f, -0.04500081f, 0.11929058f, 0.09396820f, -0.03659401f, -0.04458900f, 0.07606906f, 
    -0.12936878f, 0.03820285f, 0.09640935f, 0.10751813f, 0.11396720f, -0.07099538f, 0.25987291f, 0.02238019f, 
    0.17856248f, 0.02710829f, -0.17735440f, -0.05820066f, -0.02398842f, 0.11860058f, 0.17473044f, -0.26200306f, 
    0.07068200f, -0.21541379f, 0.13693787f, 0.09688605f, 0.00261289f, -0.05426126f, 0.14017025f, 0.12240054f, 
    -0.08329952f, -0.03599170f, 0.06056431f, 0.03782186f, -0.08665804f, 0.00787856f, -0.06152205f, 0.04828975f, 
    0.09097299f, -0.01688187f, 0.19147517f, -0.09902640f, -0.05087904f, 0.21418236f, -0.04174995f, 0.14084770f, 
    0.12020802f, -0.14283521f, -0.19324568f, -0.13167319f, 0.01473823f, -0.09530997f, 0.11111448f, -0.08154604f, 
    -0.00085236f, -0.04815663f, -0.05367306f, 0.21185535f, 0.04459131f, 0.26352420f, -0.22535945f, -0.20709702f, 
    -0.23749554f, 0.10908946f, 0.08135341f, 0.02075722f, 0.26152650f, -0.07376720f, 0.04660551f, 0.02134702f, 
    -0.17228684f, 0.19943441f, 0.09876965f, -0.01678976f, 0.07330075f, -0.45926923f, 0.17990722f, -0.07590479f, 
    -0.09273965f, 0.06863685f, -0.21036878f, -0.13174979f, -0.10937131f, 0.08432878f, -0.05979674f, 0.11886225f, 
    0.12765102f, -0.03980575f, -0.01296267f, -0.14776582f, 0.09401807f, 0.06324381f, -0.02182345f, -0.15893579f, 
    0.25316653f, 0.28805774f, -0.08587041f, -0.05828903f, -0.14205448f, 0.08769051f, 0.11653152f, -0.01603995f, 
    -0.26275879f, 0.20404392f, -0.20670015f, 0.01021906f, 0.15514594f, -0.02558314f, -0.05462214f, -0.06578679f, 
    0.08859386f, 0.20989053f, 0.08891310f, 0.31592441f, -0.00008910f, -0.04137826f, -0.12094956f, -0.08860905f, 
    -0.14522345f, 0.01252378f, -0.33223665f, 0.06147921f, -0.11951672f, -0.09201554f, -0.29753354f, -0.04123281f, 
    0.17008960f, 0.03142459f, 0.06783281f, -0.17402381f, -0.17510571f, -0.10752566f, -0.18668602f, 0.10988832f, 
    -0.19743149f, 0.07488173f, -0.10986419f, 0.06571307f, -0.06748302f, 0.13442747f, 0.10078463f, -0.26538834f, 
    0.06737041f, -0.26192319f, 0.11773267f, -0.00670185f, -0.13533841f, -0.03299332f, 0.62099516f, 0.31319144f, 
    0.00685649f, 0.03716850f, -0.23034853f, 0.04914181f, 0.06112623f, -0.06300381f, -0.07717738f, -0.01724481f, 
    0.23596944f, -0.10359934f, -0.00377247f, -0.11467226f, 0.05605751f, -0.02009326f, -0.04584244f, -0.30371955f, 
    -0.39821360f, -0.17359017f, 0.02221468f, 0.13534994f, 0.01788727f, 0.01630265f, -0.05519280f, -0.08464530f, 
    -0.15987194f, 0.01691448f, 0.13650079f, -0.05816269f, 0.05315514f, -0.00101293f, 0.11802077f, 0.10296669f, 
    0.02141743f, -0.29943797f, -0.17534561f, 0.08321515f, -0.00106997f, 0.00932050f, -0.13061747f, -0.00250507f, 
    0.00948464f, 0.12948631f, -0.06882546f, -0.02162673f, 0.11473308f, 0.04571785f, 0.00936181f, 0.05529751f, 
    -0.00751016f, 0.05080756f, 0.02161683f, 0.12869117f, 0.24236579f, 0.32552284f, -0.10178812f, 0.07137305f, 
    0.11379559f, 0.02806817f, 0.22775003f, 0.03089378f, -0.17007001f, -0.09168660f, 0.12665892f, 0.05121473f, 
    -0.19518067f, 0.07691525f, -0.21650444f, -0.05968841f, 0.10169608f, 0.13134302f, -0.49177095f, 0.17225358f, 
    -0.12837410f, 0.12681019f, -0.25256309f, 0.00509758f, 0.03364745f, 0.01503190f, -0.14173599f, -0.22909695f, 
    -0.05916068f, -0.02800956f, 0.18040273f, -0.12313709f, 0.06334224f, -0.07443944f, -0.04808942f, -0.23975082f, 
    -0.00853508f, -0.09943516f, 0.00195451f, 0.25901359f, 0.13273038f, -0.11702015f, 0.05706162f, -0.02141233f, 
    -0.04775503f, 0.05281720f, -0.00591725f, 0.13601318f, 0.22202192f, 0.00722235f, 0.09828499f, -0.00254824f, 
    0.08831475f, 0.64223212f, 0.43956479f, -0.46536338f, -0.08528018f, 0.25871131f, -0.12109885f, -0.07596996f, 
    0.08798305f, -0.12391103f, 0.17335750f, 0.13127521f, 0.09707265f, -0.06961135f, -0.01941027f, 0.07805637f, 
    -0.05208701f, -0.07611264f, -0.07286412f, 0.06348123f, -0.02720642f, -0.29323122f, -0.01280713f, 0.05142522f, 
    0.05326242f, -0.10428164f, 0.09688482f, 0.02380711f, 0.52429914f, -0.07465550f, -0.55891007f, 0.28748667f, 
    -0.00215562f, 0.01602482f, 0.14066307f, 0.24098249f, -0.05199412f, -0.09588745f, -0.07170228f, 0.00235831f, 
    -0.08700849f, 0.08619140f, -0.14017648f, -0.00041473f, -0.08832922f, 0.18234424f, 0.14114268f, 0.18632150f, 
    0.38841051f, 0.11012382f, -0.14374410f, -0.08924262f, 0.08772350f, -0.11403169f, -0.05208690f, -0.12626520f, 
    -0.41327438f, -0.46781445f, 0.24684612f, -0.02207367f, 0.01004575f, -0.02648255f, 0.08874716f, -0.02092314f, 
    0.24435967f, -0.26463082f, -0.37051690f, 0.08410212f, 0.02224195f, -0.11144276f, 0.11026652f, -0.03067367f, 
    0.16523348f, -0.16631499f, -0.45403817f, -0.19291689f, -0.00686289f, -0.13145356f, 0.08470045f, 0.04157647f, 
    -0.11569735f, -0.09859610f, 0.10434010f, -0.02209451f, 0.13205388f, 0.19956546f, -0.10529814f, -0.11964478f, 
    -0.00298568f, -0.18960930f, 0.11083703f, -0.06929898f, -0.32915312f, -0.39809105f, 0.23290309f, -0.03736484f, 
    -0.05364209f, 0.11326595f, 0.05850952f, 0.02866060f, 0.26091662f, 0.26382515f, 0.08158848f, 0.03575132f, 
    0.09493475f, -0.10211754f, 0.10537080f, -0.04239933f, 0.13205649f, 0.11211289f, -0.38683352f, -0.07576843f, 
    -0.16487305f, 0.04553122f, 0.01083754f, -0.04471204f, -0.02596512f, -0.20852864f, -0.12357827f, -0.09419987f, 
    -0.24252985f, -0.10288535f, -0.10158826f, 0.02762793f, 0.12461218f, 0.07608657f, 0.05901363f, -0.11531734f, 
    -0.02080016f, 0.30126312f, -0.05416069f, 0.01072232f, 0.06717343f, 0.10402737f, 0.04449758f, -0.09148370f, 
    0.18218133f, -0.09142175f, -0.27406472f, -0.03146421f, 0.12156782f, -0.06359898f, -0.05975810f, 0.07678619f, 
    -0.15877037f, -0.37930992f, 0.05679922f, 0.03761933f, 0.07859515f, 0.10140435f, 0.08853358f, 0.12037894f, 
    0.08485041f, 0.24195929f, 0.13587014f, -0.40782937f, -0.38878936f, 0.23984195f, -0.20103486f, -0.27213061f, 
    0.03141120f, 0.05885174f, -0.06487776f, -0.40736184f, 0.13068639f, 0.39442223f, -0.10418264f, -0.23349896f, 
    0.00707861f, 0.28739926f, 0.06733493f, 0.01289391f, -0.61834967f, -0.04302964f, -0.13640307f, 0.13789321f, 
    0.07824042f, -0.04411211f, 0.00196295f, 0.04541580f, 0.06826372f, 0.17529057f, -0.10330352f, 0.12308674f, 
    -0.09633786f, 0.05124200f, -0.14372455f, -0.05142739f, -0.19060139f, -0.13876341f, -0.10214854f, 0.09575416f, 
    0.24890073f, 0.09889507f, -0.02419796f, 0.01128816f, 0.25330317f, 0.02992313f, -0.09166849f, -0.03589318f, 
    -0.51741123f, -0.37226835f, 0.06189691f, 0.13808714f, 0.10278384f, 0.04463132f, 0.08724769f, 0.08410402f, 
    -0.19469337f, -0.24569689f, -0.08736990f, 0.26542631f, 0.21903543f, 0.03322214f, -0.00514944f, -0.09613690f, 
    -0.04164155f, -0.03163235f, -0.07001188f, 0.34550384f, -0.11603095f, 0.07852828f, 0.14756928f, 0.05442469f, 
    0.14236334f, -0.17590030f, 0.01093789f, -0.19147523f, -0.20008354f, 0.03741108f, -0.08422446f, 0.11296245f, 
    -0.18114923f, 0.00556659f, 0.03255131f, 0.02861975f, 0.11428660f, 0.35491627f, -0.07269121f, 0.11914133f, 
    0.21216942f, -0.06120592f, 0.08080795f, -0.15255615f, 0.05271057f, -0.02640517f, -0.36139041f, -0.02743488f, 
    0.04193214f, -0.09029695f, 0.12504248f, 0.16548185f, 0.05107512f, -0.20796312f, -0.18692429f, 0.32427090f, 
    0.09985381f, -0.05215542f, -0.03770218f, 0.04522483f, -0.00168379f, 0.05224412f, -0.24445254f, 0.02702574f, 
    0.08360603f, 0.10236652f, 0.02967822f, 0.07069086f, 0.08753257f, 0.01202085f, -0.08161038f, 0.15221788f, 
    0.25841892f, -0.15523915f, -0.26663971f, -0.23866734f, 0.16117348f, 0.01666361f, -0.02742637f, -0.16689715f, 
    0.10205024f, 0.06469946f, 0.14001526f, 0.00156992f, 0.08504625f, -0.07138633f, -0.06528856f, 0.02829251f, 
    0.05963500f, 0.09463974f, 0.02254080f, -0.18236254f, -0.01572182f, 0.02817609f, -0.02414658f, -0.01466200f, 
    0.13819298f, 0.00297659f, 0.11324220f, 0.04362231f, -0.09336694f, 0.00379430f, 0.02720818f, 0.01006128f, 
    0.05630346f, -0.02654461f, -0.02236604f, -0.10771515f, 0.16863477f, -0.02097568f, -0.07607833f, -0.10369792f, 
    0.02800059f, -0.00697762f, -0.07950607f, 0.07270316f, 0.18800132f, 0.01277438f, -0.01323545f, 0.00508793f, 
    -0.08273265f, 0.11699016f, 0.15384962f, 0.18843214f, -0.11853985f, -0.06575146f, 0.03230942f, 0.04586312f, 
    -0.06096766f, -0.01714906f, 0.03003326f, 0.02762080f, -0.02591282f, 0.07630979f, 0.00392591f, 0.20548525f, 
    0.35883519f, 0.01941769f, 0.03641020f, 0.04143241f, 0.01928702f, -0.07845671f, 0.01769955f, 0.05115968f, 
    -0.05478374f, -0.14225765f, -0.06325306f, 0.01727090f, 0.02892371f, 0.03071550f, 0.01753275f, -0.14543730f, 
    -0.10766092f, 0.00791759f, -0.15193637f, 0.00025630f, 0.02389784f, 0.10276684f, 0.00300627f, 0.06440814f, 
    -0.05090550f, 0.01859673f, -0.08377008f, -0.01902097f, -0.04012950f, 0.01280642f, 0.05578616f, -0.13438231f, 
    -0.06024900f, -0.04203658f, -0.06230393f, 0.01934008f, -0.17427376f, -0.17039409f, -0.07903548f, 0.04716492f, 
    -0.05758377f, -0.01148519f, -0.05681172f, 0.10948735f, -0.10312251f, -0.11033349f, -0.03907957f, 0.07818200f, 
    0.15751918f, -0.00297406f, -0.08125295f, -0.05837513f, 0.11953921f, 0.04733164f, 0.12689462f, -0.04110811f, 
    -0.01992236f, 0.09694801f, 0.11791845f, 0.02734291f, 0.04732066f, 0.10025944f, 0.19350639f, -0.13370559f, 
    0.09919486f, -0.09000647f, 0.05221475f, 0.01062703f, 0.04495551f, -0.07466853f, 0.01049511f, -0.18279542f, 
    0.00993732f, -0.13903657f, -0.08555056f, 0.09495682f, 0.07358216f, -0.09632315f, -0.17080885f, 0.18838562f, 
    0.08678716f, 0.15667990f, -0.07040755f, -0.05176665f, -0.07071999f, 0.01412657f, 0.03024611f, 0.01371777f, 
    -0.03847098f, -0.05927574f, -0.09542038f, 0.09223545f, 0.01118109f, -0.00183472f, 0.05288633f, 0.07199728f, 
    0.19824789f, 0.12074816f, -0.00133205f, 0.15144174f, 0.02575383f, 0.03626229f, 0.17436717f, 0.08148362f, 
    0.09797593f, 0.15621650f, -0.01247985f, -0.05579465f, -0.12024409f, -0.02652666f, 0.16118249f, 0.11402082f, 
    0.00980349f, -0.10259128f, -0.12708305f, 0.29022068f, -0.05522198f, -0.05275634f, -0.15479249f, 0.01480960f, 
    -0.06750238f, -0.02336324f, -0.03904035f, 0.11237054f, 0.41318572f, -0.43495196f, -0.01876003f, -0.09534662f, 
    0.24776913f, 0.04965273f, 0.09177221f, 0.06677293f, 0.02464676f, 0.00922743f, -0.10538805f, 0.23928906f, 
    0.06890793f, 0.00946845f, -0.00615127f, -0.01201257f, -0.05234506f, -0.16937488f, 0.13355152f, -0.07949737f, 
    0.03768899f, -0.11571161f, -0.20334937f, -0.02758430f, -0.05221371f, -0.05383872f, 0.02134346f, 0.10853716f, 
    0.06496317f, -0.23645686f, 0.01044794f, -0.19133444f, -0.12134174f, 0.10945346f, -0.05683169f, 0.05779303f, 
    0.09418666f, 0.09435810f, -0.01794796f, -0.20281087f, -0.06766225f, -0.04101788f, -0.09051819f, -0.01773092f, 
    -0.13445376f, 0.41832328f, 0.38046542f, 0.13395214f, -0.03598381f, 0.04335091f, -0.05399934f, -0.00404632f, 
    -0.00303692f, -0.07667496f, 0.16846551f, 0.15536235f, -0.01483533f, 0.06900686f, -0.01328604f, -0.03381104f, 
    -0.06239212f, 0.06323310f, -0.08571587f, 0.06059378f, -0.05620337f, 0.06832334f, 0.07387445f, -0.00047267f, 
    -0.05588401f, -0.10211103f, 0.06014704f, 0.04771742f, -0.35875627f, 0.25577706f, 0.00176254f, -0.12724577f, 
    0.04944137f, 0.00794626f, 0.11389858f, 0.09664195f, 0.15980957f, 0.11326822f, -0.22814201f, 0.12207712f, 
    -0.18187851f, 0.01771133f, -0.18520786f, 0.14005296f, -0.04524590f, -0.12761986f, 0.14678630f, -0.06739572f, 
    0.07159100f, -0.06587891f, -0.00087253f, 0.01015491f, 0.14003800f, 0.16724379f, 0.05995575f, 0.13260382f, 
    -0.10119535f, 0.01284914f, -0.06196950f, 0.00208030f, 0.03165200f, -0.08257408f, 0.03035421f, 0.26073611f, 
    -0.19954874f, -0.01977847f, 0.01102828f, -0.01432533f, 0.03214987f, 0.06575305f, -0.02140358f, -0.01367511f, 
    0.02317313f, -0.11111968f, 0.05386055f, -0.14477834f, 0.05717637f, -0.17393762f, 0.14633296f, -0.02028157f, 
    0.03100122f, -0.15724422f, -0.49162889f, -0.33652511f, -0.23672006f, -0.13922508f, -0.00506743f, -0.05202028f, 
    -0.05864102f, 0.06863510f, 0.02220026f, 0.32004139f, -0.05727079f, 0.26892281f, 0.16060969f, -0.01374474f, 
    0.03986796f, -0.06465855f, 0.08263550f, -0.05527061f, 0.14775191f, 0.20631367f, 0.10411983f, 0.08263823f, 
    -0.08639889f, 0.18270192f, -0.00359607f, 0.10344808f, -0.19000453f, -0.17621531f, -0.02929755f, 0.02484462f, 
    0.04096983f, -0.17561375f, 0.09555282f, 0.12494900f, -0.03013583f, -0.07915203f, -0.15415533f, 0.06524990f, 
    -0.08290355f, -0.29174969f, 0.00364624f, 0.03702508f, 0.05960769f, 0.07489643f, -0.01613233f, 0.12962061f, 
    0.15590836f, 0.01156831f, -0.00842234f, -0.05656831f, -0.07117455f, 0.00590377f, -0.04100438f, -0.04842659f, 
    -0.05880506f, 0.03349713f, 0.16346018f, 0.05027393f, 0.00752635f, -0.03987362f, 0.11006590f, 0.12361676f, 
    0.07702416f, 0.16361624f, -0.08485405f, 0.05544003f, -0.01782923f, -0.07184967f, -0.21315245f, 0.09998911f, 
    -0.06298869f, -0.01091734f, -0.02340613f, 0.08040863f, 0.01025938f, 0.10331437f, -0.03391480f, -0.12875502f, 
    -0.03423186f, 0.19474995f, 0.15328516f, -0.10832044f, -0.10476228f, -0.03753663f, -0.04675202f, -0.04101754f, 
    0.09618182f, 0.08521748f, 0.08405529f, -0.12085146f, -0.18105890f, -0.29911530f, -0.13383916f, 0.12165575f, 
    0.16655180f, 0.05310373f, 0.02773894f, -0.04534516f, 0.06829066f, -0.28674081f, 0.31582028f, -0.13329954f, 
    0.26988280f, -0.12069965f, -0.05766216f, 0.04499997f, -0.08890969f, 0.02223904f, -0.16788588f, -0.05653049f, 
    -0.06703889f, -0.08152004f, -0.11548605f, 0.16229479f, 0.07871181f, -0.03731523f, 0.03232254f, -0.18842828f, 
    -0.13992546f, 0.09598889f, 0.05659793f, 0.02145056f, -0.29311532f, -0.01426227f, -0.01580236f, -0.00571610f, 
    -0.16807896f, 0.14721727f, -0.03671882f, 0.14741188f, -0.09420351f, 0.27191854f, 0.08663915f, -0.08685885f, 
    -0.14604704f, -0.21392481f, -0.26252827f, -0.17598671f, 0.17080963f, 0.12176408f, 0.11822359f, -0.00980180f, 
    0.04392470f, 0.04585184f, -0.18757078f, 0.57578427f, 0.18281709f, -0.00301253f, -0.16260998f, -0.06681678f, 
    0.04834609f, 0.06696744f, 0.07749815f, -0.11943251f, -0.09613064f, -0.16197987f, 0.00380195f, -0.00028416f, 
    -0.06904531f, 0.01357269f, 0.05634627f, 0.05286174f, -0.15175277f, -0.42978373f, -0.15532072f, 0.01033460f, 
    0.09935649f, -0.07251662f, -0.21939106f, -0.01500043f, 0.11359696f, -0.38581073f, 0.06668100f, -0.30608386f, 
    -0.16183630f, -0.01419483f, -0.04785243f, -0.00707961f, 0.02266757f, -0.03361113f, 0.19702549f, 0.08923208f, 
    -0.06435485f, -0.31138206f, -0.04520371f, 0.02013224f, 0.09762461f, 0.10749856f, 0.07970164f, 0.19494861f, 
    0.02062467f, 0.03536529f, -0.11528230f, 0.01414690f, -0.06435724f, 0.01324212f, -0.05930416f, -0.00561117f, 
    0.23341399f, 0.10905603f, -0.09209317f, -0.08189154f, -0.18675968f, -0.01292955f, -0.09804232f, -0.03476472f, 
    -0.03778992f, -0.17156076f, 0.12070914f, -0.05166865f, -0.17852595f, 0.13963290f, 0.00446059f, 0.10147265f, 
    -0.13368872f, 0.05152029f, 0.22337119f, -0.16261491f, -0.07801744f, -0.06425700f, -0.02998055f, -0.31990960f, 
    -0.15558726f, 0.03511821f, -0.06757168f, -0.14732851f, -0.12349415f, 0.27596074f, 0.12007177f, 0.03446850f, 
    -0.07046964f, 0.14104791f, -0.11858943f, -0.01508003f, -0.16251718f, 0.04295350f, -0.04253599f, 0.03880747f, 
    0.13617735f, 0.05669310f, 0.04956868f, -0.03468663f, 0.20057333f, -0.38024554f, 0.00750689f, 0.27897474f, 
    -0.12467417f, -0.04863192f, -0.25260130f, 0.00109284f, -0.03766833f, -0.00642989f, 0.03540308f, 0.00388407f, 
    0.02696893f, -0.06513757f, 0.03285191f, -0.07403731f, 0.03652829f, -0.01484806f, 0.08636132f, -0.38470685f, 
    -0.15761578f, -0.10547785f, 0.05272596f, 0.00285923f, 0.16436921f, -0.02896844f, -0.05897155f, 0.03084285f, 
    0.15230788f, 0.23073973f, 0.36166772f, 0.06818494f, -0.03772498f, 0.13088268f, 0.02626510f, 0.11633605f, 
    0.17923994f, -0.25838926f, -0.21787263f, -0.20535123f, 0.18829225f, 0.17977892f, 0.09703966f, -0.02379481f, 
    0.15615869f, -0.03879350f, 0.02250374f, -0.04117687f, 0.11740675f, 0.14474107f, -0.02773006f, 0.01317201f, 
    -0.03309299f, -0.04388205f, -0.04180923f, -0.24452968f, -0.11822693f, -0.18927327f, 0.10770889f, 0.03565481f, 
    -0.06073510f, -0.00040158f, 0.02442636f, 0.04603504f, -0.25739434f, -0.11302579f, -0.06170459f, 0.11597855f, 
    0.13755631f, -0.07274378f, -0.11257025f, 0.04285260f, 0.06911406f, -0.01882235f, 0.02729534f, 0.02522630f, 
    0.00066204f, 0.20452064f, -0.06816243f, -0.00413540f, 0.11976172f, 0.09054983f, 0.09590608f, 0.09731908f, 
    0.06591634f, -0.08061381f, -0.07638525f, -0.05584608f, -0.13832629f, -0.11132701f, 0.05217282f, 0.00708976f, 
    -0.03826296f, -0.06879421f, 0.19284140f, -0.01902032f, 0.07942071f, 0.03775039f, 0.13836813f, 0.09265961f, 
    -0.05437929f, -0.01664734f, -0.03872441f, 0.10028458f, -0.04387380f, -0.01707011f, 0.03948569f, 0.17266804f, 
    0.22420098f, -0.05376665f, 0.01698830f, -0.12636390f, 0.09221873f, -0.10841737f, 0.16169250f, 0.21541229f, 
    -0.06914503f, 0.13798158f, -0.11257831f, -0.05485890f, -0.11672446f, 0.04602896f, -0.16198614f, 0.02416595f, 
    -0.02252513f, -0.25468442f, 0.17359994f, -0.06217776f, -0.02108650f, 0.02768449f, -0.39405414f, -0.45783395f, 
    -0.26443514f, 0.07864700f, -0.03869062f, -0.01405386f, -0.11487398f, 0.01906055f, -0.18735495f, 0.08330351f, 
    0.09195352f, 0.11825371f, 0.04823841f, -0.10792365f, -0.16197588f, 0.03993328f, -0.31072226f, -0.29664505f, 
    -0.19830184f, 0.02890118f, 0.03624145f, -0.13487077f, -0.08261263f, -0.17828029f, 0.04424337f, -0.13944136f, 
    -0.02977362f, -0.13451512f, -0.19818316f, 0.00049965f, 0.07920850f, 0.03548138f, -0.04640928f, -0.19495675f, 
    0.09348754f, 0.00161837f, 0.01100966f, -0.01926257f, -0.01955674f, -0.09194423f, -0.02072632f, -0.09602313f, 
    0.07407178f, -0.01899380f, -0.08878764f, -0.01438560f, 0.09371470f, 0.11028025f, -0.03398296f, 0.11202186f, 
    0.08445015f, -0.00302552f, 0.33048242f, 0.25899094f, 0.00890036f, -0.05935937f, -0.00788471f, 0.08488794f, 
    -0.08649232f, 0.10828345f, -0.43875927f, -0.14710945f, 0.08126545f, -0.11267153f, -0.06696936f, -0.20944586f, 
    -0.01608106f, 0.08705015f, -0.13614358f, -0.22229254f, -0.17288297f, 0.05193571f, -0.16925113f, -0.19015585f, 
    -0.08176342f, 0.07155166f, -0.02395486f, -0.16349766f, -0.29865962f, 0.17416412f, 0.33542758f, -0.16647695f, 
    -0.13701931f, -0.10495402f, 0.06469870f, -0.03108857f, 0.03958267f, -0.11348116f, 0.07426487f, -0.04294183f, 
    -0.07202534f, 0.01139284f, 0.13988811f, -0.10227635f, -0.08177017f, -0.29167882f, -0.13374735f, 0.18329516f, 
    0.09647603f, -0.06347533f, 0.04040116f, 0.03113713f, 0.05496721f, -0.03000939f, -0.18164422f, -0.30633542f, 
    -0.14041494f, -0.06466862f, -0.03640816f, -0.02408657f, -0.12963803f, -0.01612967f, -0.30922163f, 0.18405187f, 
    -0.08991480f, 0.02189829f, 0.08732906f, 0.06510457f, 0.06272215f, 0.10589375f, 0.28546402f, 0.07140189f, 
    0.08584855f, -0.09721711f, -0.14695711f, -0.03633853f, 0.09943195f, -0.03704080f, 0.09757996f, -0.15168920f, 
    0.04609958f, -0.03915213f, -0.46646407f, -0.28397530f, 0.15867542f, 0.12112817f, -0.12874542f, 0.12556179f, 
    -0.22056846f, -0.09754636f, -0.01291669f, 0.23790613f, 0.23507482f, -0.12730320f, 0.08110398f, 0.14660089f, 
    0.02684033f, -0.00448919f, 0.00151274f, 0.04450274f, 0.06966026f, 0.08309991f, -0.12394556f, -0.06301500f, 
    -0.14024936f, -0.00889281f, 0.02235884f, 0.06586915f, 0.03377600f, 0.04439731f, 0.18610981f, 0.21439297f, 
    -0.05905438f, 0.05893414f, -0.11172422f, -0.00072903f, 0.02234231f, 0.12163819f, -0.09336024f, -0.06505422f, 
    0.02082180f, -0.05935003f, 0.06295361f, 0.03683296f, 0.18856049f, 0.12120534f, -0.14253262f, -0.11348699f, 
    -0.14990810f, -0.09767516f, 0.14238571f, 0.08019460f, -0.18813638f, -0.09594217f, 0.12387758f, -0.04538219f, 
    -0.08076444f, 0.26361433f, 0.33155820f, -0.04240708f, 0.07114421f, -0.06709658f, 0.01747428f, 0.13114806f, 
    0.15714645f, 0.09940876f, 0.11308590f, -0.13876176f, -0.02490519f, -0.08343682f, 0.08757894f, 0.08549982f, 
    0.05250744f, 0.04242777f, -0.30041426f, -0.08263975f, -0.22197187f, 0.12620921f, -0.01051025f, -0.04931476f, 
    0.11937532f, 0.04004239f, -0.08423029f, 0.12000144f, -0.00207722f, 0.03036814f, 0.13646494f, 0.10985888f, 
    0.05583300f, 0.00523470f, 0.02186267f, 0.01700978f, -0.14738537f, 0.06290815f, -0.00196653f, 0.03586407f, 
    -0.01117100f, 0.13982642f, 0.00481443f, -0.06838771f, -0.07740049f, -0.16722924f, -0.06841049f, 0.04188941f, 
    0.23701517f, -0.01875322f, 0.01650707f, 0.16093592f, -0.01198152f, -0.04248337f, -0.14704351f, -0.09132036f, 
    0.06950702f, 0.14789207f, -0.09903114f, -0.21279460f, 0.08069882f, -0.02037250f, -0.05663356f, 0.09645294f, 
    -0.02149416f, -0.05963243f, 0.02870250f, 0.12297612f, 0.07891611f, -0.00075423f, 0.01147866f, -0.00292229f, 
    0.08356588f, -0.07364303f, -0.05131324f, 0.06507792f, 0.00041773f, 0.08603709f, 0.18388435f, 0.10339326f, 
    0.19754331f, 0.19377939f, -0.23483300f, 0.07465231f, 0.16693258f, 0.09155544f, 0.06496260f, -0.01590612f, 
    0.07167190f, -0.13551281f, 0.10108086f, -0.14834557f, -0.24371441f, -0.09797493f, 0.09923546f, 0.02959747f, 
    0.06230149f, 0.07766593f, 0.06674428f, -0.11725125f, -0.12782441f, -0.06838872f, 0.06290741f, 0.09775204f, 
    0.02254828f, -0.15063371f, -0.12335059f, 0.05806104f, -0.17008837f, -0.28148460f, -0.10506466f, 0.00160464f, 
    0.02239449f, 0.08469523f, 0.16827267f, 0.08377579f, 0.05483867f, -0.20501140f, -0.24308658f, -0.27931571f, 
    -0.16837934f, -0.15076269f, -0.08390583f, 0.15942794f, -0.20772837f, -0.07392397f, -0.13636751f, 0.02885538f, 
    0.13697501f, 0.04694454f, 0.01550891f, 0.01600524f, -0.05030227f, 0.00536701f, -0.04954897f, -0.33416077f, 
    -0.37344024f, -0.18559034f, 0.01080289f, 0.21231690f, -0.02646950f, -0.01385516f, -0.05521561f, 0.10919886f, 
    -0.08177926f, -0.08065201f, -0.03514074f, 0.09301376f, 0.00829035f, 0.07777511f, 0.15108247f, 0.08339442f, 
    0.11401138f, -0.07065909f, -0.03740053f, 0.31000090f, -0.10401823f, -0.18282357f, -0.04094755f, -0.01970261f, 
    0.09098130f, 0.21597338f, -0.27154934f, -0.36960381f, -0.19758946f, -0.21479338f, 0.15802453f, -0.06247638f, 
    0.07924864f, 0.09086460f, 0.13831706f, -0.34100854f, -0.30286255f, -0.08417534f, 0.03551858f, -0.01693814f, 
    -0.04701017f, -0.15062155f, 0.08951753f, 0.14944282f, -0.18994769f, 0.05416577f, 0.14134459f, -0.26315787f, 
    -0.05684930f, -0.28275892f, -0.15260489f, 0.06475569f, 0.19642781f, -0.40708977f, -0.13299182f, -0.25887445f, 
    -0.11290283f, -0.23538809f, -0.10449860f, -0.05347179f, -0.15913297f, -0.06738409f, -0.13033204f, -0.14946055f, 
    0.02628008f, -0.04553179f, 0.08058722f, 0.01628703f, 0.02754489f, 0.05987868f, 0.07612060f, 0.07964998f, 
    -0.11523987f, 0.00366933f, -0.00066809f, 0.02296508f, 0.07462989f, 0.02476751f, -0.09639169f, -0.03646037f, 
    0.15302400f, -0.13652076f, -0.08523181f, 0.15559340f, 0.09346278f, 0.10720595f, -0.06670044f, 0.09993754f, 
    -0.00277803f, -0.16126318f, -0.20576183f, -0.10759422f, -0.26484132f, 0.10347234f, -0.03497003f, 0.17330080f, 
    -0.00774846f, -0.09407816f, 0.05234168f, -0.12687337f, -0.52292007f, -0.05745876f, 0.00049028f, -0.03781126f, 
    0.02181168f, 0.02370317f, -0.16590127f, 0.08704475f, 0.14426130f, 0.20947407f, 0.05597163f, 0.05686865f, 
    -0.07898736f, -0.03002298f, -0.06428144f, -0.12603642f, -0.10794682f, 0.13410044f, 0.00901975f, 0.09435959f, 
    0.04536691f, -0.03825422f, 0.01012430f, 0.08862737f, 0.04276016f, -0.50189602f, -0.14197145f, 0.12846680f, 
    -0.16888753f, 0.03571423f, -0.16488422f, -0.01671696f, 0.01037205f, 0.02930032f, -0.04677082f, 0.08667104f, 
    0.07621367f, -0.12249990f, 0.10490859f, 0.03015473f, 0.09451024f, 0.17538418f, 0.10434308f, -0.25350910f, 
    -0.14374030f, 0.08062107f, 0.02193246f, 0.10052373f, 0.00876393f, -0.02169365f, 0.18744071f, 0.13828102f, 
    -0.16503389f, 0.12598395f, 0.32515267f, -0.09227926f, 0.19814855f, 0.22606155f, 0.12077775f, -0.07293517f, 
    0.02367832f, 0.05662403f, 0.12384434f, 0.08652973f, 0.15334609f, 0.07851215f, 0.07720723f, 0.11705901f, 
    0.09092775f, 0.00909742f, 0.02170610f, -0.28273997f, 0.06717056f, -0.01558099f, -0.07427429f, -0.03945727f, 
    0.05399680f, 0.10432474f, 0.17601751f, 0.11576314f, -0.26742411f, 0.19696239f, 0.11115944f, 0.11210949f, 
    -0.06267100f, -0.02481734f, -0.07708029f, 0.08382050f, 0.20883413f, 0.46659842f, -0.10182358f, 0.06440385f, 
    0.03075800f, 0.04488157f, 0.01078397f, 0.20405155f, 0.01846525f, -0.02374332f, -0.01161092f, 0.04083829f, 
    0.07985045f, 0.04375202f, 0.08575317f, 0.10598311f, -0.01378079f, 0.08522357f, -0.41336274f, -0.22469333f, 
    -0.19787477f, -0.08565660f, 0.07134075f, 0.01693161f, 0.02602374f, -0.15096428f, -0.13398691f, 0.27308959f, 
    0.09478631f, 0.04139488f, 0.00352248f, -0.03678218f, 0.05407737f, 0.02925041f, 0.14587218f, -0.01209225f, 
    -0.00368879f, 0.11527144f, 0.03398653f, 0.17627777f, -0.02889380f, -0.08767591f, 0.11461914f, 0.02796229f, 
    0.04532514f, 0.02825790f, -0.05976206f, 0.13808429f, 0.12024637f, 0.04258105f, 0.01176946f, -0.04072855f, 
    0.19252019f, 0.18814965f, -0.10473131f, 0.11546586f, 0.15907197f, -0.02852165f, -0.23121153f, -0.09756136f, 
    -0.00634679f, 0.12572734f, 0.05031902f, -0.18984546f, -0.00871646f, -0.03495427f, -0.06548893f, -0.04282032f, 
    -0.01726964f, 0.03503351f, 0.11711098f, 0.00585235f, -0.01127752f, -0.00385857f, -0.05967750f, -0.01556431f, 
    0.12075654f, -0.00775015f, -0.08867460f, -0.00403658f, -0.00813225f, -0.02007934f, 0.16117559f, 0.07081036f, 
    0.06743249f, 0.05096577f, -0.14221750f, 0.07016899f, 0.06190353f, -0.11615427f, -0.00723456f, -0.12923679f, 
    0.05136109f, -0.14443085f, -0.02395830f, -0.03156622f, -0.03745655f, 0.13001095f, -0.01503107f, -0.04057712f, 
    -0.16089354f, 0.03130523f, 0.08907154f, -0.10512354f, -0.03208403f, -0.03761571f, -0.02969843f, -0.08765868f, 
    0.09986395f, -0.07798812f, -0.02849240f, 0.04561518f, 0.06813689f, 0.22618970f, 0.04284184f, 0.10805874f, 
    -0.05619154f, -0.37672505f, 0.23367400f, -0.00320614f, -0.22522248f, 0.10332716f, -0.21622582f, -0.00964253f, 
    0.02299841f, -0.09094434f, -0.03872289f, 0.19904734f, -0.24899048f, -0.05909169f, -0.00342425f, 0.00567897f, 
    -0.25098664f, -0.03851238f, 0.02330870f, -0.44963595f, -0.26210341f, 0.17029586f, -0.06885036f, -0.11826351f, 
    0.11364847f, -0.11254179f, -0.08887920f, -0.09555485f, -0.19946511f, -0.18208413f, -0.00361042f, -0.12805040f, 
    0.03945211f, -0.10343456f, -0.07280677f, -0.05656793f, -0.11274064f, -0.37074053f, -0.26303023f, -0.54795969f, 
    -0.10004394f, -0.15656331f, -0.08625019f, 0.10910381f, 0.06853760f, 0.02767970f, -0.05204729f, 0.07717174f, 
    -0.11840552f, -0.15855969f, -0.12851927f, 0.01091579f, 0.11672065f, -0.08656811f, -0.00915899f, -0.21014982f, 
    0.09174217f, 0.25947613f, -0.00149391f, -0.07650114f, -0.09511463f, -0.06583629f, 0.02447188f, -0.11898206f, 
    0.00153526f, 0.06611224f, 0.18806210f, 0.01983480f, -0.02121606f, -0.09500270f, -0.18897364f, -0.06892762f, 
    -0.00893566f, -0.25466129f, 0.25780392f, -0.09303138f, -0.00984867f, -0.05259150f, 0.02754442f, 0.09558388f, 
    -0.06550090f, 0.05788640f, -0.07938036f, -0.15484242f, -0.15388726f, 0.06089292f, -0.12175982f, -0.11632317f, 
    -0.08262790f, 0.02018090f, 0.04702596f, -0.08103319f, -0.15609030f, 0.01818375f, -0.09080472f, 0.06272137f, 
    -0.11175379f, 0.09606689f, 0.01373902f, 0.02668790f, 0.17063570f, 0.35951859f, -0.09822287f, -0.08135895f, 
    -0.02818991f, 0.04431462f, -0.08069526f, 0.06738507f, 0.08835448f, -0.26600754f, 0.43841574f, 0.25506255f, 
    -0.21660663f, -0.10226176f, -0.06229596f, 0.08619219f, -0.06925301f, -0.03028291f, 0.07790694f, 0.27962452f, 
    0.18095449f, -0.01976770f, 0.08274237f, 0.05520201f, 0.00208913f, -0.04753569f, 0.01763911f, 0.13858087f, 
    -0.09887915f, 0.08133064f, 0.03321770f, -0.12106742f, 0.15199360f, -0.05341719f, -0.13370222f, 0.04362795f, 
    -0.09151354f, -0.14749022f, -0.07818577f, 0.04644448f, -0.01634314f, 0.12703152f, 0.01714492f, -0.06342046f, 
    0.07038821f, -0.30312771f, -0.21644208f, 0.08118006f, -0.18185651f, -0.19809295f, -0.11827232f, 0.02562442f, 
    -0.01297225f, -0.11217923f, 0.12636290f, 0.03686989f, 0.02349903f, -0.23936439f, 0.01869216f, -0.10483073f, 
    -0.04923014f, 0.07049834f, 0.08771254f, -0.46396610f, -0.39858380f, -0.31039333f, 0.06439546f, 0.13436621f, 
    0.04976493f, -0.02741494f, -0.01168207f, -0.14273156f, -0.28828949f, -0.26263034f, -0.08995213f, -0.15089519f, 
    -0.00524044f, 0.01881098f, 0.01136661f, 0.02278129f, -0.02331834f, -0.15823892f, -0.15127575f, -0.20620994f, 
    -0.04246145f, 0.10740247f, 0.07505485f, 0.02588896f, 0.15555207f, 0.03422598f, 0.17927156f, 0.24571741f, 
    0.10484195f, -0.02081420f, -0.11108639f, 0.01038536f, -0.03720147f, -0.06488659f, -0.00047231f, -0.21236128f, 
    -0.05923743f, 0.13937069f, -0.03218377f, -0.01505584f, -0.04350545f, 0.12067453f, -0.08611821f, -0.01975658f, 
    0.16680789f, -0.18454994f, -0.23579051f, -0.11962965f, -0.17854534f, 0.05755705f, -0.06121670f, 0.03668943f, 
    -0.05412687f, -0.23830959f, -0.35946137f, 0.14737609f, -0.00617060f, -0.01595616f, -0.09465647f, 0.12032589f, 
    0.03647700f, -0.00251563f, -0.11593232f, -0.28648505f, 0.19184242f, -0.12173200f, 0.09909540f, -0.00981355f, 
    -0.01868283f, -0.09841900f, -0.08962581f, 0.33621988f, 0.38338044f, -0.11637561f, -0.50999683f, -0.11158919f, 
    0.16623263f, 0.15387207f, 0.07933662f, -0.01099468f, 0.22764663f, -0.11974566f, -0.05760232f, -0.10742945f, 
    -0.06167392f, -0.04868397f, 0.00564063f, 0.03821092f, 0.01720831f, -0.01848713f, 0.01010946f, 0.01118562f, 
    0.08330777f, 0.11731886f, -0.00441655f, 0.10373968f, 0.11073994f, 0.09853751f, 0.28024593f, -0.17320698f, 
    -0.31356239f, -0.08301042f, -0.07167430f, 0.05274471f, 0.10121258f, 0.06336012f, 0.00759869f, 0.38057086f, 
    0.13359770f, 0.19099449f, -0.06323742f, 0.05490040f, -0.04639343f, 0.07326674f, -0.11558482f, -0.07325991f, 
    -0.36447912f, -0.12888175f, -0.15559441f, -0.05798739f, -0.08381202f, -0.08731500f, 0.12173748f, 0.16457938f, 
    -0.11871172f, 0.14903894f, -0.15703905f, -0.15150593f, 0.02183419f, 0.02386268f, 0.10671029f, 0.03982214f, 
    -0.08964777f, 0.05611022f, -0.29646212f, -0.00252945f, 0.31787121f, -0.13896489f, 0.04784663f, -0.11093146f, 
    -0.03809584f, 0.16430736f, -0.05806137f, -0.02890546f, 0.07276347f, 0.01031496f, -0.09276138f, 0.04914755f, 
    -0.01297036f, 0.10377540f, 0.11680929f, -0.09544155f, 0.27304044f, -0.17258659f, -0.15160207f, -0.12255065f, 
    -0.13030750f, 0.25027499f, 0.03835679f, 0.15337040f, 0.01725721f, 0.19146952f, 0.25401500f, 0.28154907f, 
    -0.15103669f, -0.00428475f, -0.09139308f, -0.05807632f, 0.00663825f, 0.06439108f, 0.20275924f, 0.24267714f, 
    0.19323054f, 0.04795548f, 0.07414636f, 0.03389764f, 0.07762964f, -0.03798980f, 0.07834505f, -0.03914730f, 
    -0.53894663f, 0.19922306f, 0.04140283f, 0.06594227f, -0.04760547f, -0.06119731f, 0.00442640f, -0.02059614f, 
    0.09691342f, -0.32776546f, -0.28401512f, 0.11842611f, 0.02577249f, -0.02034477f, 0.07518934f, -0.10537095f, 
    -0.02266672f, -0.04317136f, -0.05097550f, -0.14306793f, 0.01605528f, 0.01247780f, -0.08369788f, 0.03247804f, 
    0.00393642f, 0.00650549f, -0.14412229f, 0.06773394f, 0.22974800f, -0.30159000f, 0.04181971f, -0.10424123f, 
    -0.03105680f, 0.03316244f, 0.09646508f, 0.23138557f, 0.09558162f, -0.01450301f, 0.01976997f, -0.09941188f, 
    0.03936651f, 0.18294980f, 0.10433161f, 0.03479344f, 0.22631823f, -0.25116992f, -0.44125611f, 0.00892120f, 
    -0.01560189f, 0.04920018f, 0.05937696f, 0.06447195f, -0.10845129f, 0.26091436f, 0.23674828f, 0.10867157f, 
    -0.04527032f, 0.04981637f, 0.09378213f, -0.04757869f, -0.07551120f, -0.00012553f, 0.16859156f, 0.04272972f, 
    -0.09316035f, -0.05888980f, -0.00260879f, -0.00078769f, 0.06316146f, -0.00147368f, 0.00058306f, -0.12447578f, 
    0.08990064f, -0.00123932f, 0.01132478f, 0.06845475f, 0.08391093f, 0.07277589f, 0.00261416f, 0.06269467f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.05911254f, 0.02623090f, 0.00796734f, 0.20786780f, -0.01721471f, 0.17218165f, -0.01738681f, -0.05290155f, 
    -0.08275357f, 0.01949974f, -0.03757169f, -0.09079789f, 0.12012087f, 0.01637734f, -0.00597255f, -0.03532668f, 
    0.19088034f, 0.04834786f, -0.06677225f, 0.07948875f, 0.03325998f, 0.12673812f, 0.00464997f, 0.04480826f, 
    0.14113979f, 0.11729367f, 0.08014712f, 0.04646358f, 0.18147202f, 0.18390171f, 0.22602443f, -0.02694078f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.20506841f, 0.02942160f, 0.22298668f, 0.14052042f, 0.07895181f, 0.08834014f, 0.17842381f, 0.01199762f, 
    -0.10162552f, -0.15844567f, -0.23516423f, 0.10330372f, -0.50767010f, -0.28188136f, 0.01353029f, 0.25422311f, 
    0.10880905f, -0.34451592f, 0.01136813f, 0.25298500f, -0.09468205f, -0.51055890f, 0.25993297f, -0.14390230f, 
    0.15810022f, 0.44330302f, -0.08349107f, -0.04282183f, 0.20538421f, -0.01554712f, 0.02489428f, -0.03671900f, 
    0.11045827f, 0.19997536f, 0.27804115f, -0.29662141f, -0.04791336f, -0.24122110f, 0.08344696f, 0.09743176f, 
    0.07647462f, 0.03184015f, -0.19164133f, -0.09731227f, -0.46742541f, -0.14813420f, 0.06269569f, 0.04184122f, 
    0.02357437f, -0.54854810f, -0.08949178f, 0.30285642f, 0.20942199f, -0.15813582f, 0.03769559f, -0.02731087f, 
    0.26170069f, 0.31712449f, -0.18200922f, -0.36333781f, 0.13823165f, 0.07640882f, 0.08749392f, -0.16787824f, 
    -0.15563805f, -0.04458554f, 0.27905643f, -0.32214391f, 0.06442101f, -0.00091395f, -0.15143824f, 0.00036815f, 
    0.10598849f, 0.13399872f, 0.00507581f, 0.07732206f, 0.01636337f, -0.02761446f, 0.12183743f, -0.12293783f, 
    0.23737767f, 0.04897945f, 0.15240875f, -0.02330619f, 0.12374736f, 0.23019093f, -0.13239604f, 0.04653253f, 
    -0.59647578f, -0.29158673f, -0.03968848f, 0.48401284f, -0.06569812f, 0.29580364f, 0.06525084f, 0.41867879f, 
    -0.02237462f, 0.11436203f, -0.28197485f, -0.03985449f, -0.06948627f, -0.40442273f, 0.04595591f, -0.12855858f, 
    0.18492682f, 0.04314836f, 0.21112107f, -0.15516843f, 0.06363236f, -0.08971498f, -0.08616915f, -0.08479103f, 
    0.27069137f, 0.05084191f, -0.08627950f, 0.08427972f, -0.01203172f, -0.13738750f, -0.07876021f, -0.14823563f, 
    -0.05876004f, 0.11929884f, 0.09063416f, -0.22669470f, 0.11802178f, 0.18101230f, -0.09289176f, -0.15982351f, 
    0.13248228f, -0.23034695f, -0.17821799f, 0.19505054f, 0.07697654f, -0.16622636f, 0.10990263f, 0.01685197f, 
    0.22016738f, -0.17914428f, -0.23953220f, 0.24028233f, -0.18045209f, -0.22299273f, 0.01873659f, 0.29198608f, 
    0.10478239f, 0.13480313f, -0.11960088f, 0.15097812f, -0.06469337f, -0.13765055f, 0.37029752f, 0.10599408f, 
    0.06618645f, -0.08986218f, 0.11169578f, 0.26681679f, 0.12005867f, 0.03963428f, 0.18218358f, -0.27639347f, 
    0.04022504f, -0.25086766f, 0.16605821f, -0.00586327f, -0.08405840f, 0.19689256f, 0.09434041f, 0.07482522f, 
    0.04513709f, -0.05705569f, -0.02275479f, 0.14347474f, -0.04688803f, 0.16204120f, -0.12566808f, 0.10228306f, 
    0.17059462f, 0.02369208f, -0.08187737f, -0.42807499f, 0.06764354f, -0.27811787f, -0.68221843f, -0.13377927f, 
    -0.08530750f, 0.24499060f, 0.06964408f, 0.26163903f, -0.14238577f, -0.09552568f, 0.25035718f, -0.21712014f, 
    0.25809449f, 0.15180351f, -0.31326976f, 0.25770202f, -0.04449120f, -0.39986363f, 0.15134768f, -0.14227924f, 
    0.18344249f, -0.00834354f, -0.05469306f, -0.00816347f, 0.29704511f, -0.36210513f, 0.15831880f, 0.23110016f, 
    -0.23932287f, 0.31806821f, 0.16603459f, 0.10136958f, 0.07048893f, 0.14976062f, -0.07204153f, -0.02112145f, 
    0.16128618f, -0.06514049f, -0.09015218f, -0.28124976f, 0.33338907f, 0.18186280f, -0.04515693f, -0.22407758f, 
    -0.15654048f, 0.28669310f, -0.00326751f, 0.17717370f, -0.05428373f, 0.06375470f, -0.16411474f, -0.07848388f, 
    0.29902601f, 0.07811589f, 0.11517913f, -0.28009498f, -0.17642587f, -0.19541265f, 0.12020434f, -0.01378749f, 
    0.21814330f, 0.08076701f, -0.06432384f, -0.12893888f, -0.09158553f, -0.40790376f, -0.23475443f, -0.07399192f, 
    0.13279815f, 0.30383348f, 0.19128609f, -0.04020401f, 0.11080772f, 0.38205627f, -0.00816483f, -0.20154086f, 
    -0.02057468f, -0.01910651f, 0.11483880f, -0.61096150f, 0.04562569f, 0.14709766f, 0.03103762f, -0.12125724f, 
    -0.16443540f, 0.15869002f, 0.12084693f, 0.17929994f, 0.14344749f, 0.04241782f, 0.11341923f, -0.18694749f, 
    0.15866721f, -0.05069355f, 0.09860066f, 0.30494857f, -0.14676671f, 0.03629163f, -0.28184411f, 0.17417394f, 
    -0.33596048f, -0.15698627f, -0.12133891f, 0.37186486f, 0.02246788f, 0.30363396f, 0.41284904f, 0.03626142f, 
    -0.10299721f, 0.07362325f, 0.33306524f, 0.16568135f, 0.08738113f, 0.14691325f, -0.05001073f, -0.17632724f, 
    -0.16112185f, 0.14365357f, -0.19529331f, 0.08060027f, -0.30483022f, 0.01421249f, -0.08347918f, 0.20937304f, 
    0.04100004f, -0.32312801f, -0.01701345f, -0.21580505f, -0.29407471f, 0.01226769f, 0.19175895f, 0.15400985f, 
    0.38286659f, -0.02848913f, -0.03733851f, -0.22742048f, 0.11611672f, -0.18178727f, 0.03635874f, 0.51405472f, 
    -0.02712844f, 0.05079551f, 0.12314411f, 0.08500000f, 0.16832134f, 0.36793187f, 0.00332503f, -0.15554561f, 
    0.16297308f, 0.27691394f, -0.00833202f, -0.04211977f, 0.06151335f, -0.24812964f, -0.02214596f, -0.07421399f, 
    0.16896592f, -0.09633501f, 0.15481561f, -0.23850799f, -0.19722967f, -0.46704611f, 0.02448205f, -0.02828090f, 
    -0.04048083f, -0.05947115f, 0.24286354f, 0.36858290f, -0.02885299f, 0.24035171f, -0.00776354f, -0.09033685f, 
    0.09357087f, -0.07607004f, 0.18805817f, 0.30707619f, 0.11889193f, 0.42458218f, -0.00298908f, 0.06388637f, 
    -0.22790006f, -0.04640321f, 0.24825087f, -0.13512243f, 0.23535207f, 0.05347869f, 0.02798966f, 0.03310403f, 
    0.07432758f, -0.23089661f, -0.07313937f, -0.26743054f, -0.08656388f, 0.23672543f, -0.17006530f, -0.15556273f, 
    -0.00034365f, 0.25985658f, -0.06137083f, 0.08185606f, 0.04657270f, -0.07390629f, -0.26299521f, 0.08706292f, 
    0.09963618f, 0.22782074f, -0.04020318f, 0.16887660f, -0.13977683f, 0.17100440f, -0.07850071f, -0.10146865f, 
    0.15052319f, 0.17661370f, 0.27603993f, -0.11198210f, -0.14107944f, 0.16636790f, -0.06281691f, -0.30694661f, 
    0.04049509f, 0.23977576f, -0.11778929f, -0.48202866f, -0.11983363f, -0.00362483f, -0.21807924f, -0.03734948f, 
    0.26293898f, 0.25083491f, 0.25974146f, -0.06385660f, 0.00737435f, -0.32566726f, -0.34537736f, 0.00868777f, 
    0.11508112f, -0.09260772f, 0.18641736f, 0.27531022f, 0.00613218f, 0.27336773f, 0.11808788f, -0.15223666f, 
    -0.13049300f, -0.00771156f, 0.01512899f, 0.08269740f, -0.20214216f, 0.09856779f, -0.05994148f, 0.15779491f, 
    0.04653426f, -0.00025809f, -0.10563000f, 0.16301416f, -0.08851629f, 0.09041442f, 0.20281982f, -0.04517418f, 
    -0.23304915f, 0.37909690f, -0.22203425f, 0.09570955f, -0.29989159f, -0.29651192f, 0.26787072f, 0.18505369f, 
    0.29311562f, -0.22596590f, -0.15578581f, 0.33418590f, 0.14589038f, -0.00310780f, -0.00643543f, 0.03760033f, 
    -0.04913428f, -0.27570501f, -0.09284686f, 0.08859491f, 0.19832976f, -0.06902195f, 0.13965783f, -0.02466098f, 
    0.21306366f, -0.02391968f, -0.02650649f, 0.11616161f, 0.20103709f, -0.08328378f, -0.09738339f, -0.07011906f, 
    0.04716494f, 0.25306281f, 0.16816495f, 0.04046629f, -0.13528858f, -0.03345305f, 0.26676315f, -0.20143574f, 
    0.26113430f, -0.05459721f, 0.12785292f, 0.13432565f, -0.14002143f, 0.20589328f, 0.13151024f, -0.02793252f, 
    -0.20047984f, -0.14362419f, -0.10267479f, 0.03822029f, 0.00632145f, -0.13277359f, -0.10827430f, 0.18609804f, 
    0.24838674f, -0.34360889f, -0.00592994f, 0.12806508f, -0.19297901f, -0.19867317f, 0.02595957f, -0.08972260f, 
    0.24357259f, -0.15897420f, 0.06468865f, 0.25941476f, -0.10791416f, 0.01960544f, -0.03003543f, -0.54240233f, 
    -0.05111166f, -0.07263894f, -0.07938794f, -0.11260425f, -0.11077755f, -0.43173915f, 0.14251645f, 0.16851433f, 
    0.27852950f, 0.16722648f, -0.10860496f, 0.10436705f, -0.00264191f, -0.28497347f, 0.07712962f, 0.29507282f, 
    0.13830209f, 0.24290441f, -0.04587582f, 0.32679865f, 0.25536734f, -0.13178203f, -0.04102245f, 0.03606576f, 
    -0.03334661f, 0.19297484f, 0.20919324f, -0.12267176f, 0.06328709f, 0.01732972f, -0.01848382f, -0.36154693f, 
    0.04671771f, -0.12854941f, 0.02510514f, 0.12294003f, -0.12232442f, 0.16273755f, -0.08791260f, -0.01934629f, 
    -0.12238184f, -0.11934067f, 0.04465900f, -0.18549047f, -0.18544917f, 0.07160269f, 0.04570437f, -0.04593327f, 
    -0.05698046f, 0.13403754f, 0.03550556f, 0.05358082f, -0.02868402f, -0.11800522f, -0.05897102f, 0.03872262f, 
    -0.01390913f, -0.17791925f, -0.04090117f, -0.06837885f, -0.17946887f, 0.00423184f, -0.09113136f, -0.01117673f, 
    -0.15553069f, -0.07072946f, 0.19526343f, -0.03413160f, 0.07493348f, 0.40617913f, 0.08844021f, 0.10576829f, 
    0.13576968f, 0.06827198f, 0.21865268f, -0.22498433f, -0.07010213f, -0.07723698f, -0.14571112f, -0.00739444f, 
    -0.00574422f, -0.14622509f, -0.11116900f, -0.28468096f, -0.04725363f, 0.00855710f, 0.09138232f, -0.10889418f, 
    0.29173005f, 0.42053324f, -0.02435560f, -0.05886906f, -0.02615623f, 0.02376303f, -0.14434093f, 0.35670313f, 
    0.29189518f, -0.07250354f, 0.24205922f, 0.08504225f, -0.05324120f, -0.26144975f, -0.07915399f, 0.09132785f, 
    -0.08867815f, -0.21821542f, -0.30657801f, 0.02591725f, -0.33247873f, -0.12609936f, -0.13883749f, -0.04627127f, 
    -0.04413756f, -0.14069909f, -0.14215675f, 0.21515371f, 0.05835551f, -0.04601844f, 0.33540973f, 0.12601116f, 
    -0.00660201f, 0.31617951f, -0.07451264f, -0.06723457f, 0.22316968f, -0.18172263f, 0.37235180f, -0.11853469f, 
    -0.23231123f, -0.02488220f, -0.17649619f, 0.11246333f, -0.16655962f, 0.03361306f, 0.00339729f, -0.10270780f, 
    0.02021197f, -0.08993118f, 0.06269104f, 0.03401024f, -0.08797114f, -0.18151543f, -0.08474696f, -0.09235808f, 
    -0.08010229f, -0.01078162f, -0.14549753f, -0.16171156f, -0.14119604f, 0.05532725f, -0.14208181f, -0.13837680f, 
    0.06960166f, -0.02272923f, -0.26394197f, 0.07055543f, -0.10463238f, -0.07370182f, 0.05092121f, 0.12313876f, 
    0.11061874f, 0.18110254f, 0.14251433f, -0.42102268f, 0.10302839f, -0.07386421f, 0.05301812f, -0.03969030f, 
    0.01500729f, 0.11176315f, 0.11878847f, -0.16118783f, -0.17234229f, 0.19139424f, -0.04236142f, -0.34383208f, 
    0.02106865f, -0.22813675f, 0.00045020f, 0.02384276f, 0.05661942f, -0.16564122f, 0.08005660f, -0.07270370f, 
    0.23336650f, -0.04365846f, 0.13363074f, -0.34270653f, 0.13493803f, 0.00299028f, -0.12802590f, -0.16850436f, 
    0.26386395f, -0.01078559f, 0.06521595f, -0.05298597f, -0.02516684f, 0.18857516f, -0.06543837f, -0.05498213f, 
    -0.25499558f, -0.26000425f, -0.08340739f, 0.12858465f, 0.08335216f, 0.30841866f, -0.11603478f, -0.03673175f, 
    0.01261743f, -0.38208571f, -0.05897272f, 0.25134456f, 0.07195809f, -0.06545310f, 0.14187653f, -0.01680535f, 
    -0.11868756f, -0.13150360f, -0.16726114f, 0.03091954f, 0.04890513f, 0.12373198f, 0.43256047f, 0.06716651f, 
    -0.11457729f, 0.29036537f, -0.13104938f, -0.11884359f, 0.09954605f, -0.11457098f, -0.04239170f, -0.14682828f, 
    -0.01436726f, 0.35314786f, 0.08477317f, -0.25539589f, -0.14102530f, -0.21066590f, 0.13578685f, 0.17663899f, 
    0.10911471f, -0.12937956f, 0.05291210f, -0.08455770f, -0.20876548f, -0.22489540f, -0.10062459f, 0.08820779f, 
    0.03749881f, 0.10772674f, -0.01635131f, -0.26193923f, 0.26760453f, 0.37548953f, 0.07240018f, 0.22469385f, 
    0.01920049f, 0.00715953f, -0.16250567f, -0.15907004f, -0.02249101f, -0.12788254f, 0.07307516f, 0.14648083f, 
    -0.01085300f, 0.04754236f, -0.08371539f, 0.13398781f, -0.17490476f, -0.25542882f, 0.10508509f, 0.26287246f, 
    0.15439884f, 0.36630377f, -0.12145527f, -0.09420282f, 0.23854406f, -0.16689210f, -0.19705352f, 0.06821898f, 
    0.02770568f, 0.27171192f, 0.27020958f, 0.07272791f, -0.01422968f, 0.26457590f, 0.08485296f, -0.34896076f, 
    0.20631611f, -0.16147044f, 0.28073111f, -0.05426782f, 0.07186438f, 0.34426558f, -0.03301950f, 0.16143672f, 
    0.09443635f, -0.25519052f, -0.21784309f, 0.10527798f, -0.18377921f, 0.01917878f, -0.03263396f, 0.31544217f, 
    0.07023013f, -0.10845634f, -0.10143389f, 0.09584975f, -0.16317059f, -0.34028390f, 0.39891931f, 0.03315210f, 
    0.38711336f, -0.10826909f, 0.17730479f, -0.06812965f, -0.00657454f, 0.02108944f, -0.02415594f, 0.35711122f, 
    0.00139559f, -0.03491198f, 0.01239045f, 0.02492690f, -0.08342671f, -0.06564775f, 0.13302758f, 0.01115393f, 
    -0.09242076f, -0.14926487f, 0.15457222f, -0.13363832f, 0.00926627f, 0.14585055f, -0.05073676f, -0.05554772f, 
    -0.16271751f, 0.01462144f, 0.10355455f, 0.12732528f, 0.09156195f, -0.03739884f, -0.12028812f, -0.16780435f, 
    0.02571364f, -0.05571650f, -0.17324054f, -0.04670575f, 0.02542326f, 0.01280311f, 0.04749833f, -0.14811800f, 
    0.05836804f, 0.06883693f, -0.12805110f, 0.04015842f, -0.05131030f, -0.30825791f, 0.11667106f, -0.09813508f, 
    0.10788441f, -0.33827630f, -0.03599170f, 0.06065912f, 0.06880701f, 0.11838643f, 0.07208149f, -0.21266362f, 
    -0.08459148f, 0.30913505f, 0.15136033f, 0.35789314f, 0.36938313f, -0.21829301f, -0.22310744f, -0.15335745f, 
    -0.12406912f, 0.38313720f, 0.20854719f, 0.13843343f, 0.13139392f, -0.00349239f, 0.36648041f, -0.24253747f, 
    0.06445969f, -0.13114527f, 0.23871823f, -0.41300592f, 0.05317925f, -0.01171572f, -0.02414251f, 0.00781242f, 
    -0.08373170f, -0.12185041f, -0.04240630f, 0.27340004f, -0.23320407f, 0.49160793f, 0.05487427f, -0.01640899f, 
    -0.07859930f, -0.22937790f, -0.10898131f, -0.26315770f, -0.14044021f, -0.06673642f, -0.02057107f, 0.09902448f, 
    0.06197318f, -0.18438242f, -0.10112714f, -0.07941278f, 0.31365752f, -0.11186863f, -0.01681278f, 0.29752970f, 
    -0.10624439f, -0.16616338f, 0.11691453f, 0.03673396f, -0.06066741f, -0.31880686f, -0.13292933f, 0.04826481f, 
    0.12137239f, -0.16293433f, -0.01876139f, 0.19978581f, -0.30107650f, -0.42425591f, 0.12390216f, 0.30021787f, 
    0.06121543f, 0.05111348f, 0.08923661f, 0.26151133f, 0.12952033f, 0.07724999f, 0.33975190f, 0.15253268f, 
    0.28698131f, 0.29669252f, -0.09261114f, -0.30681899f, -0.11050468f, 0.00243746f, -0.00053027f, -0.13953352f, 
    0.18692376f, 0.12642789f, 0.19155414f, -0.29941440f, -0.15496866f, -0.13496184f, 0.08122001f, 0.00251370f, 
    -0.32545161f, -0.07330455f, -0.28289735f, 0.17476919f, -0.32133922f, 0.44520831f, 0.07631654f, -0.07743903f, 
    0.04461136f, -0.23757328f, 0.05466355f, 0.06800433f, 0.05028848f, 0.14974941f, 0.04356897f, -0.15076873f, 
    0.08332834f, 0.12317071f, 0.08913133f, -0.28183439f, -0.02289011f, -0.25310966f, 0.39498505f, 0.06885354f, 
    0.02333085f, 0.15648466f, -0.23798262f, 0.02703363f, -0.11840259f, 0.07190762f, -0.07923326f, 0.05183796f, 
    -0.02435313f, 0.22125921f, 0.08276220f, -0.03109471f, 0.26338273f, -0.25205609f, -0.10039572f, -0.15351537f, 
    0.11983454f, 0.31810427f, 0.05494012f, -0.05786315f, 0.01017724f, -0.18727583f, 0.05528076f, 0.17758386f, 
    -0.27116871f, 0.18748561f, 0.25033966f, 0.39433134f, -0.11287454f, 0.04158730f, 0.21136937f, -0.42400172f, 
    0.20520011f, -0.08873198f, 0.29106817f, -0.00813067f, -0.14677200f, -0.16120280f, -0.02712908f, 0.01251833f, 
    -0.03552731f, -0.20940265f, -0.10333194f, 0.13048865f, -0.51978773f, -0.03297178f, -0.05574669f, 0.20545456f, 
    0.00625866f, 0.44503078f, 0.02263776f, 0.22685067f, -0.04157167f, -0.18678749f, 0.16345108f, -0.07581361f, 
    0.30176535f, 0.34036422f, 0.14335515f, -0.11335305f, 0.21742697f, -0.16634478f, 0.08864551f, 0.18658891f, 
    0.24571566f, -0.15889387f, -0.02605485f, 0.36582360f, -0.09859741f, 0.17423408f, -0.02324920f, 0.10850107f, 
    -0.07894484f, -0.10196622f, -0.04253611f, 0.21800350f, -0.14585368f, 0.35864034f, 0.06522723f, 0.11632760f, 
    -0.08934017f, 0.46005031f, -0.02487620f, 0.03046405f, 0.18416496f, 0.22900486f, 0.14383699f, 0.00243535f, 
    -0.26150325f, 0.08131935f, 0.04606790f, -0.11774078f, -0.14430925f, -0.32332650f, 0.02427239f, 0.11077362f, 
    0.02142730f, 0.19750586f, 0.06738099f, 0.06495098f, -0.00560045f, 0.03763650f, 0.10991229f, -0.08536430f, 
    0.22203779f, 0.17367092f, 0.04574487f, -0.12983944f, -0.17348307f, -0.13509661f, 0.13748358f, -0.00357127f, 
    0.21911134f, 0.00322035f, -0.00067993f, 0.06056165f, -0.05809791f, -0.32807633f, -0.27019617f, -0.04209978f, 
    -0.02860227f, 0.27000362f, 0.13650344f, 0.21881467f, 0.17073315f, 0.12251041f, 0.32975739f, 0.26755992f, 
    -0.09321655f, 0.09197797f, -0.18767284f, 0.04941384f, -0.01581042f, -0.18096340f, -0.00724427f, -0.12320735f, 
    -0.07732507f, -0.18632148f, 0.00594927f, 0.14341633f, -0.15345702f, -0.16801493f, 0.07256109f, -0.12835112f, 
    -0.12610950f, -0.16394001f, 0.16209890f, -0.04527970f, -0.06507081f, 0.03387860f, 0.04244172f, -0.03598197f, 
    0.06759345f, 0.10979541f, 0.03867640f, -0.08979284f, -0.13903609f, -0.12268206f, -0.13188827f, 0.03951832f, 
    -0.25246096f, 0.22004688f, 0.03953953f, 0.07434874f, -0.08034338f, -0.14573546f, 0.12655146f, 0.01823154f, 
    -0.20086288f, 0.10205232f, 0.19830970f, -0.05143705f, 0.12529710f, 0.16546868f, -0.09032454f, -0.20749436f, 
    0.06904206f, -0.10747018f, -0.14162406f, -0.18472958f, 0.02672064f, -0.22217962f, -0.03218859f, 0.18456386f, 
    0.15697506f, -0.07472736f, -0.14435451f, -0.01949324f, 0.17583200f, 0.23142627f, -0.11394129f, 0.15718167f, 
    0.20464748f, -0.11964622f, 0.18235166f, -0.15760584f, 0.11281990f, 0.50683326f, -0.02508239f, 0.12610638f, 
    -0.18478937f, 0.08855928f, -0.23859118f, 0.14624617f, -0.08793319f, -0.11368930f, -0.14461574f, -0.02492129f, 
    0.19880977f, -0.27369368f, -0.17238234f, -0.25758150f, -0.24624477f, 0.03600669f, 0.09428815f, -0.01690193f, 
    0.49775890f, -0.12888694f, -0.03348932f, -0.09018434f, 0.00226504f, 0.16383760f, -0.26672685f, 0.09876926f, 
    -0.10428593f, 0.02023958f, -0.11167564f, -0.41203412f, -0.11894175f, 0.16742578f, -0.10033631f, -0.08161396f, 
    -0.01809173f, 0.07428899f, 0.03511903f, -0.09894288f, 0.04620827f, -0.03305780f, -0.11027981f, -0.14651051f, 
    0.34441569f, -0.22874439f, -0.11343776f, 0.23139019f, -0.03307411f, -0.33082870f, -0.12099638f, 0.19743912f, 
    -0.32497048f, -0.02771849f, 0.18676667f, 0.10893176f, 0.17934033f, 0.31258765f, 0.42200121f, -0.13897857f, 
    -0.15418562f, 0.19030489f, 0.14480060f, -0.26934126f, 0.05642333f, -0.05569508f, -0.10593852f, -0.13759039f, 
    0.30169001f, 0.05138858f, 0.14826404f, -0.22132543f, -0.29628748f, -0.00989623f, -0.15890597f, -0.08401642f, 
    0.03279935f, 0.45694479f, -0.07877634f, 0.04287476f, -0.25127330f, 0.14066851f, 0.13199511f, -0.02123371f, 
    0.04098077f, 0.17925997f, 0.20686299f, -0.12139985f, -0.22440590f, -0.08375750f, -0.09205661f, 0.41518214f, 
    -0.21640660f, 0.16800041f, -0.14745326f, 0.08254008f, 0.09544463f, -0.03990471f, 0.16407266f, 0.17623821f, 
    -0.13614708f, -0.04321533f, -0.10366185f, -0.08151571f, -0.17676073f, -0.28180504f, 0.13408372f, 0.07304917f, 
    0.14232166f, 0.03887873f, -0.11380854f, 0.08487894f, 0.19270183f, 0.09832739f, 0.15743382f, -0.11039264f, 
    0.05395915f, 0.52996588f, -0.20893902f, -0.18624254f, 0.07791752f, -0.01837267f, 0.05155688f, 0.09418520f, 
    0.17284378f, -0.17468707f, 0.09128128f, -0.17772730f, 0.04065715f, 0.34185612f, -0.05297246f, -0.07033425f, 
    -0.24252726f, -0.05665136f, -0.04333716f, 0.26058444f, -0.14453541f, 0.31067640f, -0.16542821f, 0.11650973f, 
    0.00056365f, -0.38258201f, -0.14233765f, -0.08496340f, 0.11957426f, -0.04693931f, -0.00070203f, -0.09918968f, 
    -0.13985139f, -0.02921413f, 0.09720068f, 0.30095458f, 0.10298976f, -0.20630197f, 0.50909007f, -0.25319144f, 
    -0.16411646f, 0.26104617f, -0.09874154f, -0.05157736f, -0.12818757f, -0.15902776f, -0.11216190f, -0.02355389f, 
    0.05534539f, -0.00340611f, 0.16542861f, 0.02984495f, 0.18865666f, 0.06489735f, -0.09260206f, 0.13595665f, 
    -0.12690265f, 0.08761432f, -0.09084839f, -0.19727360f, -0.08936753f, 0.28701487f, -0.28012705f, -0.07251654f, 
    0.38157016f, 0.17297070f, 0.18678109f, -0.44567877f, 0.32440647f, -0.03565209f, -0.14475313f, -0.00217205f, 
    -0.31316799f, 0.31297231f, 0.36047205f, -0.03544092f, 0.03873685f, 0.15282783f, -0.15517470f, -0.11405639f, 
    -0.00421858f, 0.08547042f, 0.16586685f, -0.09140511f, -0.26972216f, 0.02908051f, -0.09892845f, 0.02468772f, 
    0.02949313f, 0.09821103f, -0.11623217f, -0.06949579f, -0.14192343f, 0.07362545f, 0.05240729f, -0.18286370f, 
    0.01855587f, 0.22494626f, 0.01230474f, -0.31275809f, 0.19148067f, -0.05673314f, 0.17396376f, 0.58319533f, 
    0.28470546f, 0.05320369f, 0.01274275f, -0.21921623f, -0.00169142f, 0.34577271f, -0.12200250f, -0.00104050f, 
    -0.06443915f, 0.07012670f, -0.20447193f, -0.03744411f, -0.06730259f, -0.12193814f, 0.02165771f, 0.00119926f, 
    0.18578990f, -0.07956287f, 0.03189456f, -0.07402737f, -0.27051702f, 0.22310878f, -0.01964400f, -0.13643409f, 
    0.57711190f, -0.16738181f, -0.01535113f, -0.23003611f, 0.19825961f, -0.06096745f, -0.37686068f, -0.17536187f, 
    0.17152882f, 0.20932446f, -0.34235540f, 0.19585378f, 0.16464838f, -0.09554030f, -0.16183244f, 0.06188487f, 
    0.18363610f, -0.06838154f, 0.34329084f, -0.21032387f, 0.17187169f, 0.00151542f, 0.02886449f, -0.04384327f, 
    0.09849473f, 0.30771264f, -0.16782190f, -0.00812581f, -0.31074366f, -0.26811063f, -0.30035886f, -0.14150620f, 
    0.34898180f, -0.23877358f, 0.33602902f, 0.03512448f, 0.06934822f, -0.04483288f, -0.28605515f, -0.06445963f, 
    -0.14810894f, 0.04912899f, -0.16238923f, -0.10021380f, -0.05616254f, 0.05872124f, -0.08705762f, -0.03614153f, 
    0.10545573f, 0.03291954f, -0.08308908f, -0.22703454f, 0.08594873f, 0.15991551f, 0.01421878f, -0.26433042f, 
    0.14538568f, -0.24719390f, -0.14126518f, 0.19640566f, 0.19039200f, 0.08627480f, 0.03780709f, 0.05771497f, 
    0.22565340f, 0.37717095f, 0.02017126f, 0.13371606f, 0.03864470f, 0.15992932f, -0.07370605f, -0.13405034f, 
    -0.08133987f, 0.29721841f, -0.14724089f, 0.31593797f, -0.05287642f, -0.01746134f, 0.14190358f, -0.15693150f, 
    0.02318012f, -0.01390606f, 0.21638364f, -0.27863193f, 0.07208214f, 0.14387785f, 0.06325120f, -0.24574536f, 
    0.17601962f, -0.01022315f, -0.18221757f, 0.00103334f, 0.22511584f, -0.24673705f, -0.11433852f, 0.00385911f, 
    0.22199564f, 0.39253655f, 0.03788609f, -0.07035924f, 0.16473033f, 0.24921486f, 0.11342862f, -0.37644532f, 
    0.03672415f, 0.02560089f, -0.19491890f, -0.26636371f, -0.00080888f, 0.32549012f, 0.14533389f, -0.00496526f, 
    0.20694773f, 0.16518292f, 0.16474560f, -0.18948051f, -0.27798700f, -0.22926186f, -0.12978210f, -0.10119987f, 
    0.14363548f, 0.15913565f, -0.09965155f, 0.08712544f, -0.26600134f, -0.12466768f, -0.27616629f, -0.09336273f, 
    0.20947653f, 0.09403370f, 0.27935618f, 0.14455883f, 0.28268299f, 0.26571986f, 0.00152631f, -0.18790564f, 
    0.09280752f, 0.12192237f, 0.08493926f, 0.05819681f, 0.08829949f, 0.35415810f, 0.07219250f, 0.04851291f, 
    0.07135104f, -0.09047501f, 0.01078094f, 0.06513704f, -0.48707962f, -0.32528743f, 0.09881946f, -0.02459766f, 
    0.17216003f, -0.05629987f, -0.14444295f, -0.15852070f, -0.00895245f, -0.32720971f, 0.09684366f, 0.04674700f, 
    0.42379004f, 0.28571984f, 0.05739113f, -0.12699513f, 0.06733429f, 0.07358961f, -0.15584125f, -0.23249008f, 
    -0.08565273f, -0.12203939f, 0.23739889f, 0.53378040f, -0.04922870f, -0.08411373f, 0.12836474f, -0.00887385f, 
    -0.14847778f, -0.15970866f, -0.05005892f, -0.02791996f, -0.00485193f, 0.29147559f, 0.13732322f, 0.21612459f, 
    0.00405037f, 0.19649127f, -0.03478945f, 0.09347047f, 0.02650573f, 0.16934212f, 0.09635603f, -0.03194630f, 
    -0.24637209f, 0.16104643f, -0.05805756f, 0.11768621f, -0.13868700f, -0.24240789f, 0.19971520f, 0.26863670f, 
    -0.09046958f, -0.06057181f, -0.01874600f, 0.13605154f, -0.13780317f, 0.11166246f, -0.14891613f, -0.01478198f, 
    0.18202497f, -0.10229786f, 0.01288619f, 0.08103681f, -0.15957701f, -0.12604322f, -0.16705494f, -0.09241562f, 
    -0.20553070f, -0.10041314f, 0.08328976f, 0.13999951f, -0.07804719f, -0.17688909f, 0.02989556f, 0.04358480f, 
    -0.10502119f, -0.10106368f, -0.10107149f, -0.04488869f, 0.05788549f, -0.17895094f, -0.06426499f, 0.15529780f, 
    -0.05631519f, -0.19518337f, 0.20388511f, 0.31731352f, 0.07133401f, 0.43416581f, 0.06790791f, -0.01187245f, 
    0.01232376f, 0.06271192f, 0.03150831f, -0.00218214f, -0.16268702f, 0.06445288f, 0.05179526f, 0.08463627f, 
    0.14207493f, -0.11333454f, 0.07718301f, -0.12913792f, -0.20479028f, 0.13778117f, 0.30913681f, 0.02292389f, 
    0.24733472f, -0.08704745f, -0.07458069f, 0.11753121f, 0.01904523f, -0.21498130f, -0.12416381f, 0.38764006f, 
    -0.09970730f, -0.03127731f, -0.06818763f, 0.15096262f, -0.11483490f, -0.19174592f, -0.11799983f, 0.07955966f, 
    0.31514010f, 0.03182789f, 0.09687255f, 0.00604586f, -0.05075610f, 0.27210003f, -0.15347326f, -0.00909913f, 
    -0.14552377f, 0.53635746f, 0.00725420f, -0.25089327f, 0.09704039f, 0.09274640f, -0.10881922f, -0.04106066f, 
    0.09428230f, 0.01089114f, 0.14594251f, -0.40441531f, 0.17460763f, -0.07312290f, -0.20595750f, -0.15955742f, 
    -0.06794700f, -0.12378597f, -0.18717584f, -0.14408217f, -0.14531995f, 0.13540220f, -0.11626587f, -0.16143720f, 
    -0.05001261f, 0.13148353f, -0.15035287f, -0.09126840f, -0.17954056f, 0.03066756f, 0.02115287f, -0.04238361f, 
    -0.04577909f, 0.13649578f, 0.06787206f, -0.10501764f, -0.14510876f, -0.02539291f, -0.05214444f, 0.04183502f, 
    0.06719971f, 0.04355503f, -0.09808027f, 0.05996338f, -0.14872316f, -0.07960089f, -0.01756716f, 0.10369968f, 
    0.22376095f, -0.15181097f, -0.08708678f, 0.28612548f, -0.02926962f, 0.06380747f, -0.01857413f, -0.11050612f, 
    0.09767452f, 0.02264530f, -0.13350618f, -0.18434137f, 0.09570780f, -0.07799800f, 0.07957476f, -0.15749192f, 
    0.17975514f, -0.24777074f, -0.10435016f, 0.06035089f, 0.09834958f, -0.18276918f, -0.15569025f, -0.02407239f, 
    0.33381706f, 0.19516824f, 0.00776119f, 0.09559349f, 0.06689813f, 0.16555405f, 0.03442067f, -0.24746156f, 
    -0.08645157f, 0.16424076f, -0.05924638f, 0.20275544f, -0.07209381f, -0.10437004f, -0.07187734f, -0.17780852f, 
    0.20346983f, 0.15519820f, 0.28794682f, -0.12521645f, -0.10341199f, -0.22673383f, -0.17166816f, 0.15866522f, 
    0.22745106f, 0.07186282f, -0.03381383f, -0.21038702f, -0.30618408f, -0.20608534f, -0.08065844f, -0.08424246f, 
    0.08755071f, 0.08772408f, 0.29912505f, -0.11850977f, 0.01030374f, 0.07115495f, -0.07305428f, 0.17065342f, 
    -0.10470025f, 0.13531616f, 0.30488637f, -0.31103173f, 0.08170740f, -0.26815626f, 0.06551155f, -0.16353765f, 
    0.12943047f, 0.11690801f, -0.04682503f, 0.00925946f, -0.12123037f, 0.48707706f, -0.09279444f, -0.23528172f, 
    -0.10560002f, 0.21360533f, -0.05487848f, -0.14689147f, -0.20022696f, -0.17287801f, 0.04187614f, -0.08320897f, 
    0.22321051f, -0.10085244f, 0.09849820f, -0.06374518f, 0.26937443f, -0.19533287f, -0.03084744f, 0.50232536f, 
    0.30217382f, 0.00466426f, -0.22891569f, 0.55128503f, -0.06933794f, 0.19532947f, -0.02745982f, 0.12587880f, 
    0.07329980f, -0.16539676f, 0.34896138f, -0.09557402f, 0.09918314f, 0.15550107f, 0.08725710f, -0.09696925f, 
    0.07783192f, 0.42963892f, -0.00865209f, -0.15144740f, 0.18968707f, -0.02424362f, -0.19880468f, -0.07309316f, 
    -0.08156022f, 0.33720461f, -0.10276503f, -0.03537284f, -0.22433181f, -0.18285824f, -0.13391575f, -0.40692714f, 
    0.14298345f, 0.11946543f, 0.20722234f, -0.00218138f, -0.10442887f, 0.27146357f, 0.09800385f, -0.09061096f, 
    -0.17656611f, -0.08263752f, -0.21596853f, 0.11679213f, -0.02141185f, 0.42419282f, -0.06566919f, -0.21463072f, 
    0.08760055f, -0.19248320f, -0.07357620f, 0.08649933f, -0.01443561f, 0.05212571f, 0.00872612f, -0.10442810f, 
    -0.29695991f, 0.12181187f, -0.09331601f, -0.10932132f, 0.17769736f, -0.22975515f, 0.17311566f, 0.27795556f, 
    0.12127904f, -0.06191535f, -0.16998254f, -0.25451121f, -0.13017179f, -0.06339730f, -0.00083088f, 0.09445217f, 
    0.09590790f, -0.16408765f, -0.18462330f, 0.11825942f, 0.07945268f, -0.15918110f, 0.11433190f, 0.14246516f, 
    0.17604393f, 0.41189301f, 0.07706062f, 0.37024534f, 0.22712491f, -0.13129842f, 0.01849538f, 0.00161180f, 
    -0.27815339f, 0.04418310f, 0.21891958f, 0.06175909f, -0.08259888f, 0.11883324f, 0.42510310f, -0.31752267f, 
    0.22413875f, -0.11720740f, -0.16163546f, 0.61194372f, -0.00189195f, 0.19361120f, 0.06788534f, -0.10992645f, 
    0.19220090f, 0.13884982f, 0.27532995f, 0.19069588f, -0.05475226f, 0.15162632f, 0.05540914f, -0.17698838f, 
    -0.00268295f, 0.58903992f, 0.07359537f, -0.24946754f, 0.00842290f, 0.01306000f, -0.19009882f, 0.02999368f, 
    -0.22843201f, -0.02846236f, 0.05067034f, 0.23385847f, -0.27080968f, -0.24108493f, -0.22661799f, -0.27445933f, 
    -0.03316396f, -0.02295562f, 0.12338056f, -0.02370936f, -0.04160560f, 0.10637648f, 0.14473791f, -0.01543319f, 
    -0.21246980f, 0.01423156f, -0.13379399f, -0.01897791f, 0.04690221f, -0.02477225f, 0.14347443f, 0.15586571f, 
    0.10406934f, -0.09023385f, -0.03714674f, 0.41698003f, 0.12539595f, -0.06142672f, 0.20533426f, 0.08039086f, 
    -0.04609882f, 0.31904009f, -0.19173726f, 0.23376606f, -0.04530206f, -0.03499910f, 0.49346057f, -0.23576325f, 
    0.29250008f, -0.08940034f, -0.29108053f, 0.36882883f, 0.16889495f, 0.04282569f, -0.04237134f, -0.05069152f, 
    0.15650363f, -0.05349157f, 0.08973715f, 0.16849115f, -0.09455197f, -0.25502533f, 0.06295855f, 0.35377154f, 
    0.04453850f, 0.30354035f, -0.09147138f, -0.00888138f, -0.09660267f, -0.24883997f, 0.23163047f, -0.11183611f, 
    0.10833217f, 0.03217904f, 0.00910169f, 0.37334299f, -0.44331861f, -0.31199104f, 0.14242718f, -0.19166963f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.11411644f, 0.11176383f, -0.03516287f, 0.26994136f, -0.04206922f, -0.11041844f, -0.15425706f, -0.03312227f, 
    0.12264993f, 0.06918991f, -0.03025492f, -0.08384066f, -0.13432802f, -0.10048705f, 0.40663779f, 0.33064583f, 
    0.19596685f, 0.11451235f, 0.09321547f, 0.01055720f, 0.01876904f, 0.15494710f, 0.15596926f, 0.26088753f, 
    0.11359807f, 0.13341738f, -0.01218072f, 0.16230460f, -0.00581690f, 0.03162907f, -0.00042451f, 0.07373359f, 
    0.16357784f, -0.15220796f, 0.04010015f, 0.14350809f, 0.05181745f, -0.10547781f, 0.17002805f, -0.17804509f, 
    -0.04956602f, 0.08902597f, -0.19463870f, 0.13892245f, -0.00727453f, -0.11199784f, -0.16488551f, 0.20821674f, 
    0.13028766f, 0.20614173f, -0.00815449f, 0.12117012f, -0.13192458f, -0.11054180f, -0.04242688f, 0.22379521f, 
    0.04193847f, 0.13953033f, 0.17121576f, 0.21284659f, 0.18597850f, -0.15301350f, 0.02025550f, 0.16592132f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.00587533f, -0.02528914f, 0.00293162f, -0.15977554f, -0.12598434f, -0.11670186f, -0.09800313f, -0.13177191f, 
    0.10329408f, -0.13260052f, 0.07754172f, 0.10160457f, 0.02376703f, 0.25887394f, -0.17258570f, -0.04472891f, 
    -0.26588440f, -0.06579708f, 0.02167732f, 0.02191172f, 0.05774627f, -0.03243333f, 0.15235683f, -0.24368346f, 
    -0.16635874f, -0.22966178f, -0.04358681f, -0.25163063f, -0.05790146f, -0.10393637f, -0.10914744f, 0.03556538f, 
    -0.08305352f, -0.10948264f, -0.36995947f, 0.06305879f, -0.01407557f, -0.04603169f, -0.42016667f, 0.08356854f, 
    -0.14278458f, 0.23034258f, -0.04041687f, 0.14436558f, -0.21929535f, -0.23523729f, -0.01746129f, -0.08577020f, 
    -0.17219067f, 0.05158315f, 0.07326631f, -0.00424136f, 0.01550100f, -0.15958321f, -0.00063546f, -0.07218023f, 
    -0.12126109f, 0.00109194f, 0.10234693f, -0.45448840f, -0.25916466f, 0.02003884f, 0.12549199f, 0.06492655f, 
    0.26820004f, 0.05016299f, -0.33783931f, 0.22324570f, 0.30005357f, -0.06858887f, -0.03683589f, 0.17943931f, 
    -0.60594761f, -0.10175362f, 0.00440007f, -0.18686002f, 0.12325840f, 0.13085030f, 0.18892153f, 0.03127095f, 
    0.34227505f, 0.03454163f, -0.03139365f, 0.09013882f, 0.02963692f, -0.01982161f, -0.25712466f, -0.00393233f, 
    0.38834265f, 0.07230455f, 0.05059595f, 0.11784313f, -0.27418587f, 0.27369255f, -0.17834172f, 0.13790835f, 
    0.20668730f, 0.06681824f, 0.04618653f, -0.03873100f, -0.16705382f, -0.25386474f, -0.35189569f, -0.05496679f, 
    0.17156056f, -0.27552536f, -0.16185386f, -0.02729741f, -0.11552276f, 0.25134012f, -0.09148825f, 0.19170251f, 
    0.12675752f, 0.20980996f, 0.11527093f, -0.00956491f, -0.02607463f, 0.02558016f, 0.05886267f, 0.12979265f, 
    0.31360480f, -0.18184420f, 0.18966235f, -0.13552882f, 0.02945797f, 0.20262846f, -0.01826657f, 0.41906461f, 
    -0.00773733f, 0.02478766f, -0.04981127f, -0.17751911f, -0.05296954f, -0.05771752f, 0.07448472f, 0.07535627f, 
    -0.03104850f, -0.04276206f, -0.09300535f, -0.09810494f, -0.06474692f, -0.03124476f, -0.06988168f, -0.10488947f, 
    -0.02597873f, 0.06110790f, -0.01709015f, 0.04479472f, 0.07591644f, 0.05324732f, -0.01583741f, 0.01019538f, 
    -0.07166441f, -0.09648983f, 0.10544457f, -0.07272986f, -0.15113963f, -0.00924326f, -0.01363547f, 0.00977302f, 
    -0.05214116f, 0.00798050f, -0.12604250f, -0.00645107f, 0.04753649f, -0.16160627f, 0.05116964f, 0.03354247f, 
    -0.11402060f, 0.02944306f, -0.00714459f, -0.05407174f, 0.02104632f, 0.03072634f, -0.04382274f, -0.07908697f, 
    -0.08443915f, 0.02449188f, -0.08787773f, 0.02221338f, -0.12451672f, -0.15796898f, 0.02808063f, -0.14947829f, 
    -0.13988751f, 0.00053882f, -0.11509490f, -0.03857402f, -0.09901839f, -0.01491473f, -0.04476729f, 0.01101284f, 
    0.00482361f, 0.10539363f, 0.07004856f, -0.06571349f, 0.01504980f, -0.04930720f, 0.00111525f, -0.30099946f, 
    0.03635429f, 0.03515419f, -0.35379148f, 0.05374386f, -0.24337633f, -0.10602829f, 0.17928812f, 0.07274384f, 
    -0.07842346f, -0.10719636f, -0.14246741f, -0.00921565f, -0.14028598f, 0.03023080f, 0.34295729f, -0.15671940f, 
    0.24502940f, 0.04365553f, 0.07622737f, -0.08451109f, 0.10411073f, -0.16914164f, 0.23420058f, -0.06750523f, 
    0.06985370f, 0.02630605f, -0.18735576f, 0.09837535f, 0.12037327f, 0.08545776f, -0.10277625f, -0.07808870f, 
    -0.06236687f, 0.28901270f, 0.02604857f, -0.26507092f, 0.04543832f, -0.11178956f, -0.22305296f, -0.22470446f, 
    0.02295206f, -0.07063318f, 0.05909535f, 0.11192375f, 0.04727474f, 0.02771202f, -0.01675775f, 0.10327230f, 
    -0.46117058f, -0.12264591f, -0.12216442f, 0.05378437f, 0.25064722f, 0.02532725f, 0.05605413f, -0.15854517f, 
    -0.08519505f, -0.08649777f, 0.02608279f, -0.10804595f, 0.18429783f, -0.09537882f, 0.05260492f, -0.02994694f, 
    -0.12552126f, 0.07205649f, 0.01199040f, -0.03224478f, 0.00100236f, -0.05327759f, 0.00655736f, 0.03514040f, 
    -0.11458123f, -0.07125595f, 0.03302491f, -0.11140902f, -0.27131820f, -0.16096953f, 0.14610560f, -0.19346775f, 
    -0.12075338f, -0.14015761f, 0.04007941f, -0.10042108f, -0.13143376f, -0.08738904f, 0.03060986f, -0.01827906f, 
    -0.07128130f, 0.10166613f, -0.23361561f, -0.11917129f, -0.07358138f, 0.00543119f, -0.00136026f, 0.08050436f, 
    -0.09868147f, 0.09882954f, -0.03542633f, -0.30050054f, 0.00418489f, -0.05925127f, 0.11589218f, -0.08700306f, 
    -0.14317548f, -0.02764506f, 0.01614941f, -0.03412306f, -0.04607095f, -0.17182806f, 0.07223472f, 0.01145432f, 
    -0.23426588f, -0.07984179f, -0.06152003f, 0.01999241f, 0.02846213f, -0.09769112f, 0.15841457f, -0.00649368f, 
    -0.29696131f, -0.02124556f, -0.45504835f, 0.24799421f, -0.19961315f, -0.32408166f, -0.01497363f, 0.17948079f, 
    -0.43752709f, 0.15423948f, 0.06377620f, 0.05110446f, 0.25195044f, -0.05540395f, 0.13844319f, 0.18102525f, 
    0.02861334f, -0.10832393f, 0.08817731f, -0.34036991f, -0.08147521f, -0.13778146f, -0.17412281f, 0.07895719f, 
    -0.07329524f, -0.35168928f, -0.06706980f, -0.01259497f, -0.54217350f, -0.05275937f, -0.26523945f, 0.04143879f, 
    -0.24892743f, -0.06442093f, -0.00149497f, 0.06939830f, 0.10063361f, -0.15988685f, -0.20906873f, -0.13594033f, 
    0.18261486f, -0.13043535f, 0.22791176f, 0.11601705f, 0.18134488f, 0.15187392f, 0.06499089f, 0.08314478f, 
    0.03682222f, -0.04830947f, -0.00981359f, -0.00399336f, -0.04137809f, 0.06834738f, -0.04306269f, 0.18546367f, 
    0.33844811f, -0.23200208f, 0.10934123f, -0.16367804f, -0.27059144f, 0.05241182f, -0.15479513f, 0.00887629f, 
    0.05482030f, -0.02912359f, -0.47284114f, -0.01868877f, 0.06130479f, 0.18955877f, -0.00941440f, -0.09396063f, 
    -0.01955516f, -0.00162687f, -0.38255969f, -0.04627013f, 0.01271083f, -0.06768183f, 0.16716775f, -0.07187011f, 
    -0.04178368f, 0.04501913f, -0.14877813f, 0.02626899f, -0.02403968f, 0.05718484f, 0.16814891f, -0.17752756f, 
    0.20105585f, 0.08941659f, 0.05628541f, 0.28469080f, 0.20465170f, -0.14854234f, 0.24148045f, -0.20994845f, 
    0.11420690f, 0.13460645f, -0.10591356f, -0.01157458f, -0.01011795f, -0.02795163f, -0.00176008f, -0.12261047f, 
    -0.17572831f, 0.22793312f, 0.08476549f, -0.09742837f, 0.08788659f, -0.05108942f, -0.09059792f, 0.16609481f, 
    0.07668779f, -0.04105866f, -0.08311290f, 0.13767499f, -0.06704411f, 0.10203227f, -0.00270153f, -0.07039398f, 
    -0.31176841f, 0.20957339f, 0.17343612f, 0.08943017f, 0.14108901f, -0.06275111f, -0.12655671f, -0.22798796f, 
    0.16239412f, 0.18560362f, 0.25121930f, 0.17810348f, -0.03261260f, 0.21981663f, -0.22797333f, 0.42648253f, 
    0.13228102f, -0.10496003f, 0.33847201f, -0.09127123f, 0.08082509f, -0.01201305f, -0.00284392f, -0.03107981f, 
    0.17527901f, 0.09284235f, 0.11591596f, -0.03437117f, -0.01295467f, -0.03036485f, -0.13380590f, 0.44173211f, 
    0.36988062f, 0.06167531f, -0.00677609f, 0.10781045f, -0.29359126f, -0.02290843f, -0.05171797f, 0.35106909f, 
    -0.07042425f, -0.10391162f, 0.20741861f, -0.10845821f, 0.04247491f, -0.16941129f, 0.38885996f, 0.21661551f, 
    0.21631630f, -0.00708059f, -0.01956098f, 0.18569927f, -0.20997408f, 0.00099225f, 0.17845953f, 0.05102918f, 
    0.33353597f, 0.21335480f, -0.35022095f, -0.05515912f, -0.10638600f, -0.02480379f, 0.09335478f, 0.00814438f, 
    0.20047103f, -0.05346818f, -0.01678821f, -0.11406347f, 0.17250703f, 0.11038943f, 0.07794921f, -0.12131699f, 
    -0.08423108f, -0.07256027f, 0.05154433f, 0.00633506f, -0.10243971f, 0.04285719f, -0.13939621f, 0.09237895f, 
    -0.11501241f, -0.13989697f, -0.00378045f, -0.06665146f, 0.01067091f, 0.00825403f, -0.06481040f, -0.06148885f, 
    0.06924789f, 0.00497897f, -0.05433766f, -0.05721821f, 0.02063537f, 0.07170538f, 0.02371612f, -0.13084149f, 
    -0.05812304f, -0.04597775f, -0.05689594f, -0.11911982f, -0.11740874f, -0.08089752f, -0.12381709f, -0.00269039f, 
    -0.15076165f, -0.13066620f, -0.12779978f, 0.00309494f, -0.06145287f, -0.10833544f, 0.08737756f, -0.05069299f, 
    -0.01933729f, -0.13299634f, -0.05477879f, -0.07389160f, -0.11813952f, 0.05211567f, -0.05385052f, 0.01701916f, 
    -0.13646075f, -0.01787279f, 0.04710027f, 0.09581603f, 0.04113027f, -0.13245572f, 0.08466236f, -0.11544555f, 
    0.05614116f, 0.04434710f, -0.01036813f, 0.08538067f, -0.01059704f, -0.05628862f, -0.03080081f, -0.08802025f, 
    -0.11006785f, 0.04703790f, 0.00780078f, -0.16663845f, -0.00719881f, 0.02510751f, 0.02578233f, 0.01529075f, 
    -0.02211647f, 0.03381000f, -0.06613625f, 0.03143549f, 0.05084473f, -0.10441158f, 0.07246962f, -0.11874157f, 
    -0.09907572f, 0.11310443f, -0.11351080f, -0.06815195f, -0.00142650f, -0.05703557f, -0.15290618f, 0.09240879f, 
    -0.05505859f, -0.11512575f, 0.10447980f, -0.02576745f, -0.07176682f, -0.09545188f, -0.06702766f, -0.07674226f, 
    -0.11983845f, -0.06317572f, 0.00737897f, -0.10569207f, 0.07376727f, -0.07760090f, -0.06076092f, 0.13021444f, 
    0.08654744f, -0.16305175f, -0.15407425f, 0.10154252f, -0.10988869f, -0.04879132f, 0.05569853f, -0.02408926f, 
    0.04293206f, -0.12187995f, 0.01054515f, 0.02008268f, 0.07005797f, -0.15637414f, 0.02218734f, 0.01116329f, 
    0.02533802f, -0.09270146f, 0.00874131f, -0.11700619f, 0.03996471f, -0.09617522f, 0.03284280f, 0.00360257f, 
    -0.05400543f, 0.06973916f, -0.10735375f, 0.19834466f, -0.10957147f, 0.21977003f, -0.25012088f, 0.32492533f, 
    0.00737772f, -0.01323816f, 0.30970034f, -0.08256558f, 0.27034634f, -0.30738634f, 0.08961967f, 0.07538563f, 
    -0.08929250f, 0.03673378f, 0.00725569f, -0.13827464f, -0.05316459f, 0.22333749f, -0.25626677f, 0.35030180f, 
    -0.02276437f, -0.04728404f, 0.01852510f, 0.01022212f, -0.14527678f, -0.11195900f, -0.14160469f, 0.02646540f, 
    -0.00058630f, -0.33071482f, 0.13006851f, 0.09603103f, -0.00848247f, 0.21246648f, 0.23441914f, 0.19515218f, 
    -0.14349978f, 0.02354043f, 0.05138088f, -0.08074751f, 0.32927060f, 0.40364984f, -0.06786510f, 0.20066704f, 
    0.43933731f, 0.06419454f, -0.40363738f, -0.00253807f, 0.05856355f, -0.15363277f, -0.00808806f, 0.20733340f, 
    0.28021052f, 0.13136794f, 0.00102225f, -0.17231226f, 0.01365176f, -0.09697384f, -0.12825660f, 0.01425341f, 
    0.29477304f, 0.38374147f, 0.02079847f, -0.02293647f, 0.23516105f, -0.01734122f, -0.05545364f, 0.05664501f, 
    -0.20107189f, 0.45446867f, -0.14001137f, 0.01482077f, -0.06111293f, 0.33080292f, 0.01085038f, 0.20137565f, 
    0.23613769f, 0.05089440f, 0.47424918f, 0.34238249f, -0.02506310f, -0.07053538f, -0.13614364f, 0.12412082f, 
    -0.00959694f, 0.30704716f, -0.02134053f, -0.10501087f, -0.07961484f, 0.31943244f, 0.11944033f, -0.17712393f, 
    0.31680635f, -0.10522719f, 0.13573124f, -0.07718430f, 0.14214554f, 0.17859901f, -0.24443091f, 0.17518711f, 
    0.14781275f, 0.04059954f, 0.00545165f, 0.36359286f, 0.28499722f, -0.24287729f, -0.01004007f, 0.01203209f, 
    0.06634221f, 0.39566514f, 0.14492536f, -0.03767986f, 0.30046591f, 0.07763068f, -0.09950898f, 0.00945714f, 
    0.03269529f, 0.04037579f, -0.14524996f, 0.00046500f, -0.09417835f, -0.17748557f, 0.13227950f, 0.06755520f, 
    0.01514527f, 0.11038591f, -0.06399075f, 0.22186156f, -0.29464966f, -0.29166180f, 0.11687368f, 0.39107531f, 
    -0.06599733f, 0.09888244f, -0.02745322f, 0.08734138f, 0.15344721f, -0.16470048f, -0.03648806f, 0.05117633f, 
    0.06273714f, -0.09693833f, 0.19549486f, -0.00384110f, 0.10906462f, 0.25985792f, -0.26074854f, 0.58748114f, 
    0.16451640f, -0.03963744f, -0.09388876f, 0.14015256f, -0.24348646f, -0.08959865f, 0.00348811f, -0.01525032f, 
    -0.02350287f, -0.20172989f, 0.14567174f, -0.08721162f, 0.16910209f, -0.12133058f, 0.28592688f, 0.32564500f, 
    0.10726351f, -0.13421534f, 0.30528665f, 0.21112137f, -0.04564160f, 0.36040834f, -0.14295444f, 0.18596649f, 
    0.23440130f, -0.01995183f, -0.18456386f, 0.10586274f, -0.25936627f, 0.10407625f, -0.04332861f, 0.04964581f, 
    0.34407738f, 0.09047835f, -0.08126831f, -0.15670764f, -0.04803789f, -0.01447538f, -0.10226291f, -0.01703534f, 
    -0.03091332f, 0.03792805f, -0.05634566f, 0.00672368f, -0.18670076f, -0.12582566f, -0.03725946f, 0.06624059f, 
    0.04875790f, -0.15188104f, -0.15692736f, 0.02890081f, -0.07990430f, -0.09460130f, -0.17134348f, -0.05072760f, 
    -0.09639633f, 0.07454961f, -0.07491674f, -0.07117873f, 0.04156749f, -0.10682298f, -0.14070897f, -0.06515986f, 
    0.03637091f, 0.03094243f, -0.02805148f, -0.15607516f, -0.06765885f, -0.07036787f, -0.05195149f, -0.04247036f, 
    0.03585523f, 0.12467720f, -0.08103836f, 0.10447161f, -0.20830269f, -0.04600541f, -0.07207073f, -0.14251450f, 
    -0.16282050f, 0.03602466f, -0.05341249f, -0.04061663f, 0.04641541f, -0.02863907f, -0.02568049f, -0.03905851f, 
    -0.00681230f, -0.05922896f, -0.01420400f, -0.09137569f, 0.08592124f, -0.08872790f, -0.05242051f, -0.07274109f, 
    -0.01679949f, -0.11146987f, -0.07806973f, -0.07100828f, 0.05172860f, 0.01493709f, -0.09363377f, 0.05061917f, 
    -0.02325184f, -0.07448656f, 0.01841873f, -0.07427057f, -0.17721018f, 0.07275292f, -0.30499464f, 0.17459959f, 
    0.06486776f, -0.21807894f, 0.14329238f, 0.16865087f, 0.45714685f, 0.22098598f, -0.01470613f, 0.02798312f, 
    -0.29298192f, -0.04974002f, 0.28569162f, -0.10338426f, 0.30638424f, -0.03075473f, 0.02337907f, -0.32956365f, 
    -0.12358116f, 0.06959729f, -0.05943599f, -0.29179001f, -0.31018728f, -0.32008553f, -0.28917706f, 0.04119948f, 
    -0.36106709f, 0.07255317f, 0.09239625f, -0.07712944f, -0.21200749f, 0.00423617f, 0.04689422f, -0.18987004f, 
    -0.19026145f, 0.10966585f, -0.34314933f, -0.07718477f, 0.33427379f, 0.10536947f, 0.15365154f, 0.05001805f, 
    0.08207313f, 0.28954026f, -0.12393265f, -0.05275503f, 0.11420184f, -0.11965553f, -0.10382423f, 0.11092560f, 
    -0.06476380f, -0.37129179f, 0.23914994f, 0.41473562f, -0.16516730f, 0.14119036f, 0.03060987f, 0.05790190f, 
    0.01267529f, -0.06885210f, -0.14737459f, -0.08532567f, -0.11135089f, -0.00134552f, -0.06269030f, -0.04600644f, 
    0.03573619f, -0.03831946f, -0.06590648f, -0.06123723f, -0.01021353f, 0.05341423f, -0.02671741f, 0.07432090f, 
    0.03994225f, -0.05172674f, -0.02342167f, -0.14604554f, -0.04549420f, -0.07424019f, -0.04777118f, -0.08327764f, 
    -0.07191984f, -0.05562000f, -0.07059328f, -0.14659156f, -0.13709080f, -0.05146494f, 0.04972252f, -0.00301403f, 
    0.06448475f, 0.00251083f, 0.03827913f, 0.04775126f, -0.06382605f, 0.04648968f, 0.04182057f, -0.14243871f, 
    -0.02420171f, -0.16088730f, 0.00715850f, -0.01372103f, -0.01922315f, -0.00711556f, -0.06305445f, -0.06699806f, 
    -0.10263272f, -0.10496899f, 0.06183219f, 0.08073527f, 0.04094948f, 0.06017319f, -0.05125242f, -0.07412388f, 
    -0.03379550f, -0.11649612f, -0.00181245f, -0.00131895f, 0.02143107f, -0.00491247f, 0.04649587f, -0.13018431f, 
    0.21786384f, 0.31496826f, -0.12717171f, 0.08125930f, 0.15470159f, 0.17406686f, -0.26582280f, 0.21348068f, 
    -0.06253031f, 0.15095915f, -0.12498175f, -0.06556384f, -0.24080846f, 0.09579305f, 0.13999651f, 0.16683497f, 
    0.35661662f, -0.08651713f, 0.10173361f, 0.30198649f, 0.12073335f, -0.03243318f, -0.21057443f, 0.14604972f, 
    0.34662753f, 0.09160074f, 0.07656361f, 0.07462038f, -0.28187531f, 0.34251788f, -0.09126160f, 0.08297436f, 
    0.17621005f, -0.07300387f, -0.05284991f, 0.01433510f, -0.16315411f, 0.09640677f, -0.06479782f, -0.05764496f, 
    0.29449019f, -0.11843504f, -0.10664402f, 0.00967436f, 0.13464367f, -0.12447529f, 0.03132401f, 0.01447307f, 
    0.03499399f, 0.20163468f, 0.11038429f, -0.02776790f, 0.08773609f, -0.05329378f, -0.09507466f, 0.16677131f, 
    -0.13127171f, -0.17347619f, -0.15484527f, -0.04822552f, 0.22965574f, -0.20070745f, 0.30860531f, 0.18708570f, 
    0.21441962f, 0.26058993f, -0.09244283f, -0.05013547f, -0.13607897f, 0.15883622f, -0.38375905f, -0.10902110f, 
    -0.12206687f, 0.17836659f, -0.28541189f, 0.06684221f, 0.08201176f, 0.27336109f, -0.02680211f, -0.00124522f, 
    -0.20990238f, -0.10033797f, 0.24156943f, 0.16864923f, -0.03445322f, 0.09105535f, 0.04144932f, -0.08988425f, 
    0.06358848f, -0.02090283f, 0.05291045f, 0.23158655f, 0.40738463f, 0.01771353f, 0.11870448f, -0.08807776f, 
    0.20300028f, 0.20121272f, 0.14417693f, 0.05364421f, -0.07503908f, -0.02784956f, -0.04626558f, 0.11361272f, 
    0.07970633f, 0.16564438f, -0.05248557f, 0.27931783f, -0.01430765f, -0.31640074f, -0.02801747f, 0.01697047f, 
    -0.06322657f, 0.05097679f, 0.30123076f, 0.06436758f, 0.06616245f, -0.09204856f, -0.06124644f, -0.12948069f, 
    0.06279720f, 0.23396420f, -0.09533103f, 0.37915188f, -0.07640880f, -0.32940865f, 0.08868511f, -0.23829925f, 
    -0.02710220f, -0.02162742f, 0.03193474f, 0.02545332f, 0.00458069f, -0.00842406f, -0.01896567f, -0.01616198f, 
    0.02995818f, 0.04278469f, -0.13309635f, -0.01853290f, -0.08989506f, -0.09348331f, 0.07689761f, 0.03412700f, 
    -0.00834559f, 0.06784096f, -0.02823091f, 0.03126610f, 0.03640650f, 0.04709310f, 0.00780240f, 0.03974850f, 
    0.04860441f, -0.00093108f, -0.10195576f, -0.02872069f, 0.00731194f, -0.15219556f, -0.11199504f, -0.07979936f, 
    -0.08405059f, -0.09606283f, 0.06265000f, 0.06138393f, 0.02327026f, -0.20391779f, -0.01899001f, 0.06905375f, 
    -0.08310626f, -0.04774872f, -0.16390647f, -0.04112247f, 0.01247382f, -0.11621182f, -0.13931297f, -0.13169292f, 
    0.01730661f, 0.03292274f, 0.00158765f, 0.10495396f, 0.01388638f, -0.05020975f, 0.02955028f, -0.00718271f, 
    -0.11291331f, -0.08177806f, -0.06636377f, 0.03190709f, -0.08061025f, 0.05944081f, -0.13709874f, -0.11564413f, 
    0.01063640f, 0.05972135f, -0.02397525f, -0.00915411f, -0.05236385f, -0.06899485f, -0.07708804f, 0.01624118f, 
    0.00206797f, -0.00488423f, -0.17500775f, -0.10891196f, 0.03569373f, -0.16303878f, 0.04469091f, -0.12511297f, 
    0.03890568f, 0.05842099f, -0.06890811f, -0.10280780f, 0.09440462f, -0.05402266f, -0.11844362f, 0.00182095f, 
    -0.05429491f, 0.05585999f, -0.11607380f, -0.11091076f, -0.09753864f, -0.11768906f, -0.03247542f, -0.00327777f, 
    -0.00944053f, -0.05058024f, -0.10697073f, -0.02113380f, -0.08683352f, 0.01257691f, -0.06447157f, 0.05441836f, 
    -0.15484123f, -0.06745900f, -0.01942161f, 0.03850010f, -0.04077756f, -0.13598007f, 0.07772011f, -0.11241551f, 
    -0.06018697f, -0.07992709f, -0.13387115f, 0.03647870f, -0.05499634f, -0.03999810f, 0.10765173f, 0.07374173f, 
    -0.09617419f, -0.00684874f, -0.10603096f, -0.12317067f, -0.12889265f, -0.07664600f, 0.01166322f, -0.09224272f, 
    -0.02969495f, -0.13568898f, 0.08878437f, 0.12695494f, 0.29379669f, 0.00110905f, 0.22690281f, 0.21583994f, 
    0.15880860f, -0.24497454f, 0.18731374f, -0.14197400f, -0.15157871f, 0.06627076f, 0.15605353f, 0.13046187f, 
    0.22448367f, -0.04800416f, -0.07391952f, 0.17015845f, 0.04753476f, -0.18387519f, 0.01365861f, 0.04255669f, 
    0.24176639f, 0.08684415f, 0.02300049f, 0.17875418f, -0.34383643f, 0.15114537f, -0.17172627f, 0.06252281f, 
    0.09127200f, 0.16093002f, 0.14024229f, -0.07734212f, 0.12124391f, -0.19802772f, 0.24019364f, -0.12433352f, 
    -0.02340122f, -0.05976764f, -0.04782408f, -0.17390479f, -0.31911543f, 0.20921640f, -0.01802795f, -0.01374155f, 
    0.09384311f, -0.00438653f, 0.06954943f, -0.12433556f, -0.14875817f, 0.12038346f, 0.00663656f, 0.09056385f, 
    0.21576126f, -0.05652304f, 0.12383635f, -0.13211633f, 0.15082853f, 0.08035340f, 0.01670155f, 0.23619491f, 
    0.10170476f, 0.06179027f, -0.09689588f, -0.11018139f, -0.25627542f, 0.07499196f, -0.26036698f, 0.01462308f, 
    0.13968819f, 0.14636157f, -0.11979017f, -0.01863371f, 0.17769426f, 0.10813849f, -0.15957551f, 0.02896809f, 
    -0.24099928f, 0.04487276f, -0.01734884f, 0.15414527f, 0.08061945f, 0.06721993f, 0.46960369f, 0.11184084f, 
    -0.34701261f, 0.08698431f, -0.07884483f, -0.12632479f, 0.34182885f, -0.02305211f, 0.15461645f, -0.55615920f, 
    0.16735174f, 0.03068634f, 0.08844250f, -0.07348529f, 0.23400205f, 0.08549269f, 0.01431755f, -0.00594020f, 
    -0.27831888f, 0.24401897f, -0.00347063f, 0.06455052f, -0.08726976f, 0.02048663f, -0.26606604f, -0.02439177f, 
    -0.20019968f, 0.09752738f, 0.04249926f, 0.04557411f, 0.17690848f, 0.02153420f, 0.09467611f, -0.15287164f, 
    -0.03075610f, 0.28023914f, -0.35055730f, 0.15559021f, -0.35296834f, -0.27740648f, -0.07237475f, -0.30997592f, 
    0.03036976f, 0.09067077f, -0.01035680f, -0.31439242f, 0.03576865f, 0.29251146f, -0.28543267f, -0.29487592f, 
    -0.14653111f, -0.00271300f, -0.00056386f, 0.04242631f, 0.05679923f, 0.14667004f, 0.20922305f, 0.22825214f, 
    -0.21384043f, 0.09130241f, 0.13994014f, 0.25356048f, 0.05278734f, 0.02260329f, 0.08072116f, -0.44952589f, 
    -0.19568236f, 0.24777257f, 0.05007380f, -0.12462945f, 0.27593073f, 0.05283453f, 0.24582684f, 0.03653353f, 
    0.13522397f, 0.09301769f, -0.03042997f, 0.09740596f, -0.21067718f, 0.14373280f, -0.07968245f, -0.34415689f, 
    -0.02169213f, 0.29156965f, -0.24689409f, -0.06860732f, 0.08742416f, -0.20664255f, -0.07690154f, -0.04371242f, 
    -0.10112412f, -0.01101557f, 0.23914573f, -0.07563066f, 0.06155970f, -0.17524885f, 0.02379109f, 0.02838186f, 
    -0.21699210f, -0.02086068f, 0.25058699f, 0.17399593f, -0.09355012f, 0.02014445f, 0.14236630f, 0.17284413f, 
    -0.17300956f, -0.15458432f, 0.06959528f, 0.05844463f, -0.01097720f, -0.01891632f, -0.07316103f, 0.06573209f, 
    -0.12712649f, -0.07037827f, -0.11745891f, -0.05987452f, -0.14244203f, -0.00821972f, -0.06184368f, 0.11283991f, 
    0.12628378f, -0.00648714f, 0.05416859f, -0.04533168f, 0.11228047f, 0.05346869f, 0.03315635f, -0.03808926f, 
    0.01528470f, -0.16007794f, -0.03809071f, -0.10110329f, -0.18071769f, -0.12011807f, -0.00372153f, 0.10728098f, 
    -0.10706802f, -0.06674986f, -0.04561431f, 0.05720262f, -0.02567929f, 0.09805149f, -0.08059404f, 0.07458086f, 
    0.02428810f, 0.10623235f, -0.09431496f, 0.01769949f, 0.10753471f, 0.04150958f, -0.09960227f, -0.04275771f, 
    0.02872289f, 0.01571134f, -0.07205108f, 0.07227679f, -0.13605249f, -0.14795329f, 0.02049886f, -0.08896449f, 
    -0.05144318f, -0.05485054f, 0.07092880f, -0.06958785f, 0.10800799f, 0.02845655f, -0.10182782f, -0.09624629f, 
    0.13005376f, 0.12252113f, 0.15634260f, -0.07533551f, -0.29932252f, -0.19219103f, 0.12694404f, 0.18480612f, 
    0.00200749f, 0.19515890f, 0.07455476f, 0.27427664f, 0.05380613f, 0.06979193f, -0.13573697f, -0.09599069f, 
    -0.30106771f, 0.11138044f, 0.15619358f, -0.02572912f, -0.06563640f, -0.04373697f, -0.31172362f, 0.22936130f, 
    -0.24332207f, 0.13512255f, 0.04815282f, -0.12375148f, 0.04824362f, 0.00921781f, -0.04879858f, -0.11967514f, 
    0.09995452f, -0.15860467f, 0.16451527f, -0.03655317f, 0.00878895f, 0.03558032f, 0.01744910f, 0.32166368f, 
    0.08366098f, -0.70075095f, 0.06034514f, 0.26293781f, -0.07452080f, 0.12248711f, 0.02342418f, -0.05702471f, 
    0.01393264f, 0.09696240f, 0.17820776f, -0.08687314f, 0.14595120f, 0.00745073f, 0.08726614f, -0.13674940f, 
    0.17138442f, 0.13834058f, -0.26594931f, 0.10240787f, -0.30460173f, 0.01448891f, -0.22763494f, -0.22930968f, 
    0.26802766f, -0.18949863f, -0.00353517f, -0.02349880f, 0.14503878f, -0.06146644f, -0.03306649f, -0.25340959f, 
    -0.26187801f, 0.04512770f, -0.09695703f, 0.09245674f, -0.28053311f, 0.26493979f, 0.05337910f, -0.03006787f, 
    0.04917469f, -0.03768446f, 0.03899176f, 0.24059157f, 0.21230942f, -0.19448790f, 0.12118945f, -0.21262120f, 
    0.01806848f, 0.15478395f, 0.03840358f, 0.10202590f, -0.01793828f, 0.15108660f, 0.04286649f, -0.01384338f, 
    0.08780290f, 0.20379968f, -0.00452703f, 0.00028920f, 0.00243612f, -0.12796590f, -0.26747456f, 0.04907427f, 
    0.15884592f, -0.14545803f, -0.10248559f, 0.17475599f, -0.42219591f, -0.42251056f, -0.14381094f, -0.02216472f, 
    -0.34169421f, -0.10353861f, 0.43718937f, -0.11266866f, 0.18646672f, -0.03349373f, 0.12205897f, -0.01033361f, 
    -0.19957711f, -0.13546625f, 0.02471784f, 0.10386612f, -0.00288124f, 0.13696842f, 0.17108206f, 0.16573872f, 
    0.07989714f, -0.13383807f, 0.06539670f, -0.16242541f, 0.24076882f, 0.31642637f, -0.22179647f, -0.20174411f, 
    0.23169969f, 0.16578960f, 0.25991327f, 0.05211617f, -0.20056815f, 0.03156705f, -0.06141160f, 0.24365410f, 
    -0.14172420f, -0.04424212f, 0.08765605f, 0.05103362f, 0.05322707f, 0.13965353f, 0.25499830f, -0.08721869f, 
    0.08921120f, 0.16036268f, 0.10928346f, -0.20077008f, 0.29395744f, -0.04912889f, 0.01864399f, -0.15764844f, 
    -0.09125845f, -0.15580471f, 0.08031654f, 0.08032496f, -0.01094361f, 0.36376673f, 0.03505569f, -0.10142024f, 
    -0.40540835f, 0.39979821f, -0.30735826f, -0.25182873f, 0.29870093f, 0.08327033f, -0.20406713f, -0.17374541f, 
    0.02666095f, 0.08682118f, -0.31092507f, -0.09550048f, 0.13218427f, -0.16690582f, -0.02748293f, 0.12210263f, 
    -0.12864327f, -0.02118966f, -0.05166265f, -0.00972544f, 0.06298684f, 0.04378219f, 0.09509361f, 0.09692246f, 
    -0.04604971f, 0.01967669f, 0.12882814f, 0.20511267f, 0.12065158f, 0.19309276f, -0.26224139f, 0.11732441f, 
    0.07549148f, -0.18893087f, 0.40859291f, -0.14361727f, 0.05117485f, -0.19574980f, 0.11673338f, 0.11112643f, 
    -0.08284962f, 0.10264709f, -0.18612492f, -0.17705588f, 0.03869048f, 0.13897853f, 0.16811848f, 0.26292330f, 
    0.08952980f, -0.06169471f, 0.07997539f, -0.02335716f, -0.15151943f, -0.04172625f, -0.21681519f, 0.30817550f, 
    -0.18470101f, -0.14013870f, 0.07710247f, -0.09821448f, 0.09774093f, 0.01208737f, 0.60098284f, 0.01200559f, 
    -0.30406898f, 0.23814256f, -0.39666852f, -0.07208952f, -0.19200654f, 0.25636914f, -0.01124964f, 0.04461441f, 
    0.26577643f, 0.11870389f, -0.25616872f, 0.04444019f, -0.03312555f, 0.01529238f, -0.02866085f, 0.04003003f, 
    0.23008487f, -0.03090599f, 0.12400010f, -0.07597346f, 0.15453473f, 0.11256145f, 0.11676034f, 0.10497721f, 
    -0.07410429f, -0.01954331f, -0.11775555f, -0.08430573f, -0.02952672f, 0.04450137f, -0.08945184f, 0.06216935f, 
    -0.12101775f, 0.02421994f, 0.05491652f, -0.12571201f, -0.04129327f, -0.14310624f, -0.08519624f, 0.05416140f, 
    -0.05427964f, 0.02804079f, 0.01174411f, -0.01345595f, -0.06082873f, -0.14124547f, -0.06090569f, 0.03833656f, 
    -0.02105204f, -0.16067636f, -0.01368253f, -0.11306500f, -0.06540320f, -0.13594581f, 0.07934146f, -0.02217532f, 
    0.02171593f, 0.10219211f, -0.12349631f, 0.04843473f, 0.05215605f, -0.00879957f, -0.15246619f, 0.08824895f, 
    -0.12043876f, 0.02868253f, -0.12253026f, -0.05584316f, -0.16318464f, -0.08727407f, -0.05024042f, 0.06686514f, 
    -0.03473285f, -0.00871385f, -0.11518657f, -0.03393470f, 0.09488120f, 0.01514585f, 0.03437881f, -0.05423459f, 
    -0.12435574f, -0.13863982f, -0.15010953f, 0.01062036f, -0.08248507f, -0.12189501f, -0.02831222f, 0.03397335f, 
    -0.06946094f, 0.03515135f, 0.08492348f, -0.00656918f, 0.00942973f, 0.09962483f, 0.01465299f, 0.05883244f, 
    -0.08239650f, 0.03878740f, -0.10700104f, -0.01945635f, 0.02470687f, 0.01268806f, -0.04696504f, 0.09524080f, 
    -0.02724099f, 0.02989651f, -0.09708466f, 0.02790045f, 0.04205480f, -0.09366462f, -0.07196632f, -0.10671742f, 
    -0.14308763f, -0.04460007f, 0.07129852f, 0.04471856f, -0.09672988f, 0.01272118f, 0.00044092f, -0.02045124f, 
    -0.10431207f, -0.10076669f, 0.06783044f, 0.10663927f, 0.04656978f, -0.10478745f, -0.01644950f, -0.10473154f, 
    -0.11478701f, -0.01600107f, -0.05677688f, -0.11783307f, 0.08683489f, 0.00285531f, -0.07002964f, -0.08502937f, 
    -0.01528926f, 0.00797119f, -0.15067311f, -0.01440910f, -0.09638896f, -0.00843798f, -0.04174088f, -0.03193408f, 
    0.00103878f, -0.01848846f, 0.03593871f, -0.10445581f, -0.02898967f, -0.08459410f, 0.08135563f, 0.08435319f, 
    0.09451722f, -0.16328609f, 0.07793462f, -0.25527725f, -0.08536655f, 0.19230799f, -0.26466924f, -0.27845466f, 
    0.11531433f, 0.07968099f, 0.06410523f, 0.11703067f, 0.05475700f, 0.22669283f, 0.15301001f, 0.12615575f, 
    -0.28284502f, 0.08853592f, -0.16331685f, 0.14316243f, -0.00569909f, -0.09026932f, 0.25233877f, -0.40931726f, 
    -0.00700910f, 0.08847374f, 0.02161253f, -0.08426141f, 0.24234487f, -0.06964217f, 0.15694310f, 0.10342097f, 
    0.13189188f, 0.17247042f, -0.13223363f, 0.03953014f, -0.00727742f, 0.14011595f, 0.04028868f, -0.00386312f, 
    -0.26436326f, 0.28995121f, -0.30994865f, -0.11827349f, -0.02807541f, -0.07458384f, -0.28752565f, -0.06728737f, 
    -0.16065931f, -0.03797902f, 0.19685303f, 0.03935986f, 0.12220953f, -0.10476243f, -0.01327902f, -0.01966239f, 
    -0.17664231f, 0.04900178f, 0.11026944f, 0.21536367f, 0.05874576f, 0.13813247f, -0.06924798f, 0.22763492f, 
    -0.14048027f, -0.33718354f, -0.10137819f, -0.05810218f, -0.04145638f, 0.39961243f, -0.11047795f, 0.24522187f, 
    0.02058656f, 0.03801515f, 0.24884334f, 0.25755563f, 0.15188684f, 0.00646135f, 0.26148093f, 0.12438507f, 
    -0.20524308f, 0.04358167f, 0.17733832f, -0.32916710f, -0.01885449f, -0.28416908f, 0.04538433f, -0.10251060f, 
    0.05129315f, -0.00697531f, -0.11982895f, -0.01521048f, -0.07524200f, -0.06906065f, -0.19991590f, 0.06122740f, 
    -0.27331039f, 0.04544872f, 0.07828906f, -0.00614378f, 0.11664414f, 0.09248337f, -0.10455199f, -0.24898839f, 
    -0.01668220f, 0.18631423f, -0.03525985f, 0.04828631f, -0.07247411f, -0.04198595f, 0.12729879f, -0.00888234f, 
    -0.01109680f, -0.06783547f, 0.10114080f, -0.00872650f, 0.13816287f, -0.01579853f, 0.08135182f, 0.29722059f, 
    0.02493306f, -0.29394567f, 0.23759750f, -0.01288653f, -0.10043611f, 0.16481879f, 0.03998792f, 0.06954109f, 
    -0.31538349f, -0.12924664f, -0.02596597f, 0.23543140f, -0.20454191f, -0.24338561f, -0.09266983f, 0.00628431f, 
    0.16116655f, -0.08438598f, 0.06824785f, 0.17295228f, 0.05812067f, -0.16292585f, 0.12847708f, 0.17559984f, 
    0.00830002f, 0.04470295f, 0.10847352f, -0.10470733f, -0.11899834f, -0.03441093f, 0.21037385f, 0.04088393f, 
    0.10535959f, -0.09655157f, 0.09556907f, 0.00070411f, 0.06513507f, -0.10669130f, -0.17483592f, 0.20005412f, 
    -0.34035027f, -0.21704234f, 0.14927125f, 0.11433516f, 0.19745138f, 0.14055714f, 0.21571295f, -0.19505940f, 
    0.01841360f, -0.12283497f, 0.01797172f, -0.02639529f, -0.12634675f, 0.22215179f, 0.22021630f, 0.30485329f, 
    0.00598016f, -0.08896288f, -0.19759965f, -0.13019681f, -0.02730016f, -0.04284221f, -0.11396398f, 0.13303694f, 
    -0.10006703f, 0.07083806f, 0.21883768f, 0.04441072f, -0.00354262f, -0.00310627f, 0.20112313f, -0.06982926f, 
    -0.13918820f, -0.16337356f, -0.10884923f, -0.08342512f, 0.06224472f, -0.05586302f, -0.02608153f, -0.05209731f, 
    -0.09703557f, 0.10690900f, -0.02169567f, 0.06106848f, -0.08588719f, -0.06432044f, -0.14700238f, 0.04849927f, 
    0.08239630f, 0.02401570f, 0.13850121f, -0.09801102f, 0.08736321f, -0.02061838f, 0.04937207f, -0.04336540f, 
    -0.12367281f, -0.15223728f, -0.00191613f, -0.05042742f, -0.06865524f, -0.13491002f, -0.01778930f, -0.15480745f, 
    -0.04549775f, -0.12561281f, -0.12453206f, 0.06957953f, -0.08523253f, -0.08178034f, -0.17441854f, 0.07349619f, 
    0.02605314f, -0.11801291f, 0.10466494f, -0.08051800f, -0.09779795f, -0.18134308f, 0.08963671f, -0.15812060f, 
    -0.11431780f, -0.14165744f, 0.01724063f, 0.07354915f, -0.08835377f, 0.00362784f, -0.11450052f, 0.05953655f, 
    -0.06568464f, -0.04660246f, -0.05533784f, -0.14152940f, -0.01797420f, -0.11070634f, -0.01018455f, -0.03841593f, 
    -0.06093120f, -0.03755043f, -0.19830225f, 0.02828632f, 0.13919824f, -0.34279475f, -0.00555262f, -0.22922775f, 
    -0.02509502f, 0.12779553f, -0.25687018f, -0.08443699f, -0.06190816f, -0.15616532f, 0.19008352f, 0.01537255f, 
    0.10659755f, 0.03749387f, -0.28417701f, 0.01976419f, 0.05502916f, -0.08179500f, 0.23976977f, 0.10918511f, 
    -0.12174222f, -0.26497492f, 0.03631251f, -0.17516935f, 0.12649083f, -0.26883373f, 0.20150812f, 0.19956642f, 
    -0.18198903f, -0.09623823f, -0.25818259f, -0.11128801f, -0.03292825f, -0.05112836f, -0.28340074f, 0.04556262f, 
    0.02363239f, 0.16330463f, -0.05918014f, 0.00573537f, 0.13918795f, -0.19669126f, 0.14648600f, -0.35587478f, 
    -0.28129914f, -0.16706330f, -0.06717046f, 0.11460471f, -0.06223951f, -0.25317076f, -0.07074855f, 0.26201573f, 
    0.08965450f, 0.09246092f, -0.36898926f, 0.09173480f, 0.14162908f, -0.27119926f, 0.25466591f, -0.14490752f, 
    -0.26338983f, -0.19281651f, -0.20719767f, 0.00111915f, -0.02783991f, -0.25521004f, 0.21233439f, -0.00802038f, 
    -0.18317378f, 0.02193058f, 0.01117085f, 0.21416098f, 0.24263090f, -0.12187342f, 0.27876368f, 0.01208524f, 
    0.01795799f, -0.02976981f, 0.03485660f, -0.15075508f, 0.01107347f, -0.16865498f, 0.06212068f, -0.08182651f, 
    -0.19270419f, -0.42778584f, -0.04408733f, 0.20235492f, -0.73979449f, 0.09066693f, -0.26744607f, -0.04440960f, 
    -0.25896168f, -0.02090714f, 0.04223021f, 0.04423308f, 0.10310631f, 0.04039826f, -0.26999354f, -0.31173414f, 
    0.18387213f, -0.24819350f, 0.21789239f, -0.05683591f, 0.38599372f, 0.32968602f, 0.09902640f, 0.23084277f, 
    -0.12478267f, -0.06986285f, -0.02468402f, 0.10076170f, -0.02765748f, 0.06429811f, -0.02262351f, 0.17685138f, 
    0.20607434f, -0.30554509f, 0.28103748f, -0.18066353f, -0.02995631f, -0.03936489f, -0.04031003f, -0.05137790f, 
    -0.11663019f, -0.16993310f, -0.30091712f, 0.07685098f, 0.27843967f, -0.09871076f, 0.17206717f, -0.00540738f, 
    -0.31974679f, -0.19732985f, -0.32193512f, -0.44951501f, 0.02275932f, -0.07843232f, 0.22599985f, 0.06153884f, 
    0.37355539f, -0.00200135f, -0.25909820f, 0.18096814f, 0.11845052f, 0.05184462f, -0.08591675f, -0.21467830f, 
    0.21415445f, -0.01648662f, 0.08127686f, 0.36983997f, 0.07300764f, 0.11617050f, 0.21226071f, 0.00709785f, 
    0.16840145f, 0.32487977f, 0.01798347f, -0.01838883f, -0.13454095f, -0.37725639f, -0.02431449f, 0.17402057f, 
    -0.04788331f, 0.04779356f, -0.11080770f, -0.14324723f, 0.11264012f, 0.29367945f, -0.19115818f, -0.06648744f, 
    0.07325892f, 0.00974706f, 0.09847663f, 0.06140411f, -0.05898578f, 0.10216823f, 0.04799334f, -0.01043330f, 
    -0.05961071f, 0.00433280f, 0.26767316f, -0.01004755f, 0.37649971f, 0.14430635f, 0.04398363f, 0.14523993f, 
    -0.11752319f, -0.32799175f, 0.36355764f, -0.18485732f, -0.24779791f, -0.14216119f, 0.14802679f, -0.14149195f, 
    0.25306106f, 0.23694795f, -0.10650908f, -0.19629404f, -0.03489069f, 0.08108874f, -0.32152086f, -0.09511464f, 
    -0.33133310f, -0.00983274f, 0.11316740f, -0.08677839f, -0.08832165f, -0.07705246f, -0.02458074f, 0.11155169f, 
    -0.39212248f, 0.11743008f, -0.11320637f, -0.22468407f, 0.02098376f, -0.02221834f, 0.09201869f, -0.51566559f, 
    0.12578151f, 0.12653866f, 0.06604672f, -0.10165325f, 0.01594714f, -0.12501115f, -0.04984715f, 0.08861089f, 
    -0.22914773f, -0.36426058f, -0.16864552f, 0.25267783f, -0.12488997f, 0.08405139f, -0.69991744f, -0.19660680f, 
    -0.16820869f, -0.00333634f, 0.13321500f, -0.05217272f, 0.19032884f, -0.06075051f, 0.08502652f, -0.69169885f, 
    0.08740817f, 0.28153148f, -0.40512753f, 0.16208556f, -0.21823251f, 0.07045642f, -0.23340817f, -0.00627418f, 
    -0.72773182f, -0.55153745f, -0.12039492f, 0.17493747f, -0.27484724f, -0.12194718f, 0.05201026f, 0.09394220f, 
    0.00697990f, -0.37170637f, 0.02495435f, 0.02718033f, 0.23085652f, 0.03839090f, 0.04183571f, 0.17151971f, 
    -0.00165954f, 0.04457347f, 0.12504593f, -0.31115556f, 0.06110899f, -0.12122689f, -0.02632988f, 0.00190083f, 
    0.08393721f, -0.40745488f, 0.07878755f, 0.12610911f, -0.01310730f, -0.09725285f, -0.09552159f, 0.20765094f, 
    -0.76408917f, 0.04434539f, 0.20332479f, 0.03439364f, 0.07329410f, -0.34181124f, 0.22383861f, -0.48855379f, 
    0.00681121f, -0.13978511f, -0.04733218f, -0.12661092f, -0.18982363f, 0.21384980f, 0.08099223f, 0.12100120f, 
    -0.02503748f, -0.32457849f, 0.19260234f, -0.14434233f, -0.22163899f, 0.02151375f, 0.12137022f, 0.05220803f, 
    -0.07607263f, -0.22835186f, 0.18906841f, 0.17930315f, 0.17060038f, -0.07326716f, 0.16244124f, 0.05868275f, 
    0.27700707f, 0.17800549f, 0.14893207f, -0.15294081f, -0.15626256f, -0.18230300f, -0.19458222f, -0.10313486f, 
    0.10538986f, 0.03023139f, 0.05476003f, 0.04564211f, -0.13432033f, 0.30037698f, 0.16045710f, 0.05003547f, 
    -0.08398034f, -0.04969459f, 0.01237690f, 0.31785125f, 0.22847305f, -0.05232441f, 0.20358779f, -0.05919762f, 
    -0.06962376f, 0.11355490f, 0.12903853f, 0.10348205f, 0.08239488f, -0.05547312f, 0.27368414f, 0.01464853f, 
    0.14466305f, 0.14913796f, 0.09393709f, -0.04545967f, 0.09148511f, -0.22650293f, 0.14690442f, -0.02259478f, 
    0.11741269f, 0.16198501f, -0.21791767f, -0.05314894f, -0.27237868f, -0.38812712f, -0.02958509f, 0.09965402f, 
    -0.22234465f, 0.07127280f, 0.26094049f, -0.02503556f, -0.04198774f, -0.20916727f, 0.08551596f, -0.02997022f, 
    -0.30566046f, 0.04955330f, 0.04280767f, 0.18196677f, 0.17363824f, 0.13489130f, 0.25712180f, -0.05244917f, 
    0.07726493f, -0.09958987f, -0.09100492f, -0.09320732f, -0.03304109f, -0.11106239f, -0.01327205f, -0.08482470f, 
    -0.12865140f, -0.10219690f, -0.13698861f, 0.07273051f, -0.08810169f, -0.02395924f, -0.01990315f, 0.05505576f, 
    -0.00607369f, -0.08699793f, 0.06991081f, -0.08573599f, -0.08083278f, -0.04894167f, -0.07016549f, -0.09816462f, 
    -0.06714617f, -0.08822563f, 0.03347653f, 0.07217333f, -0.10735571f, -0.04220150f, -0.07213527f, 0.03556621f, 
    0.03622734f, -0.06799072f, -0.11375335f, -0.04160371f, -0.04041136f, -0.06568282f, -0.13343495f, 0.11466107f, 
    0.05310093f, -0.13561937f, -0.09605233f, 0.04552994f, -0.12127906f, 0.04182683f, -0.00619330f, -0.05551684f, 
    0.07382714f, -0.05515186f, 0.08004273f, 0.03747005f, -0.05912507f, 0.05885447f, 0.10267046f, -0.08233232f, 
    -0.04223775f, -0.12336333f, -0.13861223f, -0.12948255f, 0.08527061f, -0.05518831f, 0.07915559f, 0.05449872f, 
    -0.10800363f, -0.46433440f, -0.50201350f, -0.04649851f, 0.08038747f, 0.39791092f, 0.20062983f, -0.04412845f, 
    -0.47888285f, -0.01752972f, -0.07222711f, 0.09747173f, 0.32512072f, 0.32323256f, 0.07623225f, 0.13625857f, 
    -0.00445861f, -0.04242360f, 0.02461918f, 0.05470503f, -0.11668684f, -0.13588648f, -0.01459645f, -0.35626340f, 
    0.09769746f, 0.03171884f, 0.10931171f, 0.25568363f, -0.03613767f, -0.10852730f, -0.02886092f, 0.18037291f, 
    0.14900436f, 0.48338625f, 0.00318649f, -0.02467923f, -0.09494567f, -0.27344364f, -0.36200759f, 0.13013779f, 
    -0.14079852f, 0.25870493f, -0.06435271f, -0.05841230f, -0.33108807f, 0.17370322f, -0.25388035f, 0.11833725f, 
    -0.23677875f, 0.04303352f, 0.58478159f, -0.07488718f, -0.05834972f, 0.12440673f, 0.11674245f, 0.07272199f, 
    0.05406358f, 0.08360624f, 0.43237734f, 0.20916711f, 0.08175571f, 0.44058272f, 0.08556571f, 0.23968996f, 
    0.28287697f, 0.58970463f, -0.56654572f, -0.00484268f, -0.17248881f, -0.07878454f, -0.30036041f, 0.18476874f, 
    -0.03071948f, 0.21743748f, -0.17071107f, -0.28408068f, -0.02851053f, 0.15549004f, -0.03128891f, -0.07663245f, 
    -0.01277013f, -0.09086361f, 0.09275442f, 0.24767494f, -0.09598095f, 0.33336979f, 0.17940800f, 0.28536004f, 
    0.05779987f, 0.15239164f, -0.09106778f, 0.29894975f, 0.15113023f, 0.04672618f, 0.30566400f, -0.09557214f, 
    0.12140267f, -0.03109769f, 0.24672791f, 0.00084362f, -0.08502042f, -0.08234081f, 0.11022060f, 0.02234378f, 
    0.06766441f, 0.15068081f, -0.09374932f, 0.47410756f, -0.27207085f, -0.28803566f, -0.05531912f, 0.09056113f, 
    0.17132875f, 0.10086659f, -0.00476938f, -0.07387608f, -0.08900777f, 0.05456387f, -0.04464279f, -0.05949664f, 
    0.01862343f, 0.17640540f, -0.03380352f, 0.36394498f, -0.03189215f, -0.37868425f, 0.10646179f, -0.24569570f, 
    -0.01787639f, 0.09758087f, 0.05257740f, -0.02823326f, -0.21725346f, 0.01607511f, -0.28879359f, 0.04490009f, 
    0.23938234f, 0.03233415f, 0.14861123f, 0.03822333f, -0.04110070f, 0.00730891f, -0.03711468f, 0.13541570f, 
    -0.18601190f, 0.03406124f, 0.19278114f, 0.10055164f, 0.11128146f, 0.32040709f, 0.23901680f, 0.31454155f, 
    -0.07599743f, 0.08301388f, -0.02561047f, -0.06075037f, 0.29333249f, -0.16700025f, 0.04081082f, 0.09142657f, 
    -0.08222209f, -0.17013024f, 0.17911534f, 0.10867674f, 0.07566651f, 0.13016358f, 0.65025884f, -0.09523313f, 
    -0.12393330f, 0.10040464f, -0.05202062f, 0.21952477f, 0.00621213f, -0.01177069f, 0.02353684f, 0.20962197f, 
    0.31548753f, 0.04645333f, -0.10452538f, -0.00934018f, -0.05630462f, -0.01862847f, -0.04303334f, 0.12068871f, 
    -0.02578692f, 0.20134331f, -0.08127119f, 0.29977724f, 0.04613737f, -0.01132889f, 0.06402296f, -0.28419366f, 
    0.00070689f, 0.00033825f, -0.00796315f, 0.05365925f, -0.10474309f, 0.07569107f, -0.07076314f, -0.16252038f, 
    -0.12943639f, 0.10451896f, -0.04467631f, 0.17021166f, 0.22313638f, 0.37424690f, 0.01299278f, 0.01643741f, 
    -0.01877182f, 0.06481312f, 0.20641106f, 0.22664848f, -0.00310542f, 0.11261168f, -0.15604474f, -0.06646687f, 
    -0.03723182f, -0.03840971f, 0.08678477f, 0.23356475f, 0.04414313f, 0.17354695f, 0.33003780f, 0.14764492f, 
    0.25636411f, 0.25431240f, -0.02651123f, 0.05945756f, 0.15042651f, -0.09906723f, -0.18648422f, 0.07333545f, 
    0.14215289f, -0.00905438f, 0.06901606f, 0.23644429f, -0.04161944f, -0.32512730f, 0.07113897f, 0.02310534f, 
    0.01613746f, 0.13477911f, 0.31549728f, -0.06948220f, 0.24176587f, 0.08585788f, -0.03866114f, 0.07465179f, 
    -0.17295618f, 0.00129431f, 0.27912807f, 0.19999719f, -0.04294032f, 0.22396506f, 0.02869205f, 0.17609045f, 
    0.12550648f, 0.20561945f, -0.07745577f, 0.16498964f, 0.36260396f, -0.04371293f, -0.21395077f, 0.31727216f, 
    -0.01310374f, -0.11399825f, 0.41071251f, -0.33899859f, -0.19525847f, -0.01946905f, 0.11007844f, 0.24102186f, 
    0.21619233f, -0.10283482f, -0.04319365f, 0.15052477f, -0.08054905f, 0.04260525f, 0.13338211f, 0.39328983f, 
    0.23959973f, 0.00098597f, 0.10331367f, 0.04752091f, -0.41465357f, 0.06792955f, -0.03302335f, 0.28386381f, 
    -0.13836870f, -0.20969915f, 0.22434321f, -0.06596763f, 0.07218944f, -0.14418815f, 0.48152795f, -0.24270703f, 
    0.06921969f, 0.16766022f, -0.43054387f, -0.18787274f, -0.23486656f, -0.03414425f, -0.12259538f, 0.09176445f, 
    0.21211809f, 0.19595772f, -0.12003542f, -0.12591968f, 0.01945458f, -0.20196849f, 0.00478437f, 0.05354779f, 
    0.24597141f, -0.31617209f, -0.02226813f, -0.19156040f, 0.27494189f, 0.07292841f, 0.10148664f, 0.34559381f, 
    -0.02263180f, 0.10195757f, -0.27320737f, 0.21257448f, -0.08764477f, -0.01601913f, 0.21763045f, 0.11380998f, 
    0.05313896f, -0.01116608f, -0.15185785f, -0.15756944f, 0.05256878f, -0.03023817f, 0.20385620f, 0.16042727f, 
    -0.00868258f, -0.07161662f, -0.12545177f, 0.13214532f, 0.12008226f, 0.07757538f, 0.31930450f, -0.13872622f, 
    -0.25093096f, -0.03195066f, -0.04781730f, 0.19719568f, 0.13845523f, -0.01578337f, 0.12349402f, -0.00365903f, 
    -0.00844393f, -0.07823464f, 0.02017008f, -0.11285588f, 0.04870718f, -0.05074777f, 0.07012509f, -0.24837522f, 
    0.00197991f, -0.10839920f, -0.01925305f, -0.19352640f, -0.03604358f, 0.15042497f, 0.06062158f, 0.30825317f, 
    -0.18459342f, 0.05335753f, 0.01440554f, 0.03794811f, 0.01830516f, 0.01938589f, -0.06137964f, 0.21941786f, 
    -0.17582197f, -0.01087380f, 0.10399525f, 0.25751555f, -0.08347062f, -0.09433170f, 0.19039616f, -0.19070727f, 
    -0.01407961f, -0.05425926f, -0.11152047f, 0.02541206f, 0.14316864f, -0.08555312f, 0.22557993f, -0.15610267f, 
    0.06063939f, 0.05694621f, -0.21375649f, -0.43302307f, 0.09201503f, -0.27344832f, -0.01804119f, 0.07536379f, 
    0.09532309f, -0.01731910f, -0.15418366f, -0.05807170f, 0.10484178f, 0.22704761f, 0.14208485f, -0.17103593f, 
    0.00004503f, 0.23738298f, -0.04983616f, 0.08658954f, 0.39185968f, 0.05406198f, 0.23301762f, -0.22343065f, 
    0.05218885f, 0.12251005f, 0.03122478f, -0.10431033f, 0.03164323f, 0.26280129f, 0.23071511f, 0.00884875f, 
    -0.32915741f, 0.09681530f, 0.16982491f, 0.02245796f, 0.45609146f, 0.29886827f, -0.08119194f, -0.07249670f, 
    0.20680906f, 0.06038584f, -0.13869271f, 0.01211692f, -0.12629382f, 0.17325334f, 0.01041516f, -0.16159548f, 
    0.07330390f, 0.20642717f, -0.26429400f, -0.04849713f, -0.00404608f, -0.09322106f, -0.35480615f, 0.10918336f, 
    0.01367469f, -0.09568879f, -0.01189283f, -0.08060604f, 0.03192852f, 0.02225727f, -0.00729660f, -0.00190397f, 
    0.03490277f, -0.11975906f, -0.06988058f, 0.02414916f, 0.07565291f, -0.08068213f, 0.01749805f, -0.10882206f, 
    0.01685588f, -0.11451771f, 0.08563931f, 0.07451308f, -0.00750415f, -0.08169438f, 0.02359734f, 0.04838067f, 
    -0.05668336f, -0.11118287f, 0.02294154f, 0.06985058f, 0.04257683f, 0.06092286f, -0.05228014f, -0.11740521f, 
    0.00682686f, -0.00718311f, 0.01653817f, -0.11070414f, -0.10856845f, -0.11989052f, 0.06354533f, -0.01616532f, 
    -0.15611677f, -0.12430458f, -0.15693836f, 0.01111909f, 0.00150456f, 0.09166542f, 0.06003211f, -0.11087659f, 
    -0.00231337f, -0.07286806f, -0.01564828f, 0.10341842f, -0.15934508f, -0.12297402f, -0.10725947f, -0.06760713f, 
    -0.08184969f, -0.02942448f, 0.04134861f, -0.05581592f, -0.00311166f, 0.06119146f, -0.13811044f, 0.04891205f, 
    0.08674706f, -0.12460933f, 0.11507247f, -0.11904683f, -0.03752666f, 0.26154748f, -0.08152265f, 0.15409730f, 
    0.14473972f, 0.08422191f, 0.03693800f, 0.18572704f, 0.13985559f, 0.24937642f, -0.09677059f, -0.08084398f, 
    -0.01200822f, 0.06794977f, 0.21216206f, -0.22064389f, -0.17019774f, -0.28988752f, -0.02425631f, -0.23878641f, 
    -0.00549198f, -0.16542670f, -0.07893287f, 0.02225414f, 0.04560471f, -0.09116883f, -0.13979778f, 0.13861988f, 
    -0.11209215f, 0.18235505f, -0.03889962f, 0.00017798f, 0.02632165f, -0.20452414f, 0.16733494f, -0.14659066f, 
    -0.05478212f, 0.23054953f, 0.01848456f, 0.18062575f, -0.25313035f, -0.27973500f, 0.16476004f, -0.07689776f, 
    0.15008169f, 0.14526977f, 0.13687798f, 0.02843111f, 0.15608042f, 0.01736645f, 0.01977035f, -0.14256164f, 
    -0.19406421f, -0.31615156f, 0.13122025f, 0.29439616f, 0.09917063f, 0.21204990f, 0.04592353f, -0.07724795f, 
    0.13214745f, 0.26028356f, -0.22659729f, -0.11360336f, 0.07016086f, 0.16668004f, -0.30336508f, -0.10651399f, 
    -0.10380489f, 0.10166774f, -0.18562667f, -0.14027430f, -0.03940760f, 0.20125614f, 0.22676001f, 0.29795668f, 
    0.14176269f, 0.01213050f, -0.13067403f, 0.32825348f, 0.15709120f, -0.08333359f, 0.27389219f, -0.27421603f, 
    0.09375793f, 0.15025955f, 0.03725894f, 0.20003274f, -0.00750587f, 0.17769097f, 0.24126607f, -0.09891193f, 
    0.20402597f, -0.05418075f, 0.00376400f, -0.03321535f, -0.17292473f, 0.18616001f, 0.13090016f, -0.22329819f, 
    -0.13110548f, 0.36025602f, -0.44691691f, -0.19914874f, -0.00537265f, -0.10050384f, -0.10488676f, 0.09113511f, 
    -0.10096045f, 0.07331837f, -0.03600274f, 0.08594040f, -0.06032499f, -0.13947436f, -0.11457454f, 0.11930534f, 
    -0.20430323f, -0.22862533f, -0.07027137f, 0.25286913f, 0.28616664f, -0.05335351f, 0.19456752f, 0.12330423f, 
    0.18168567f, 0.35518309f, 0.05375541f, -0.06408660f, 0.13604087f, -0.01219492f, -0.18507251f, -0.05248018f, 
    0.11251251f, 0.27724421f, 0.07414889f, 0.02059071f, -0.15865350f, 0.03367636f, 0.05377863f, 0.19043083f, 
    -0.02874697f, 0.09675481f, 0.10244203f, 0.05127233f, 0.03276635f, 0.02310165f, 0.42386261f, 0.24755305f, 
    -0.08798025f, 0.22430170f, 0.04197849f, -0.36335346f, 0.17587869f, 0.05893583f, 0.28636801f, -0.05248223f, 
    -0.04712194f, -0.14336374f, -0.06983633f, -0.05861055f, 0.11536799f, 0.20358469f, 0.09285244f, -0.00952694f, 
    0.02555243f, 0.18968788f, -0.25343150f, 0.05901258f, 0.38296813f, -0.17654078f, 0.12812354f, -0.03803526f, 
    -0.08925477f, 0.08250701f, -0.19507071f, -0.02755477f, 0.11392415f, -0.29622045f, 0.10071504f, 0.20312420f, 
    0.02336626f, 0.08769292f, -0.56709760f, 0.17402481f, -0.14502969f, -0.62679315f, 0.12124453f, -0.02126054f, 
    -0.24294020f, -0.03630086f, 0.26010513f, 0.26353744f, 0.00839067f, 0.09117191f, 0.04815696f, 0.07908917f, 
    0.22308730f, -0.38380641f, 0.21600944f, -0.10682562f, -0.25900745f, -0.27720991f, 0.15291965f, 0.07959281f, 
    0.28173047f, -0.00010704f, -0.11162572f, 0.05857716f, 0.03809393f, 0.14619654f, 0.14144936f, 0.03754668f, 
    0.13532805f, -0.08151895f, 0.04333476f, 0.33969665f, -0.35866818f, 0.09200393f, -0.11607130f, 0.18478687f, 
    -0.22939029f, -0.30328870f, 0.16441496f, -0.01349564f, 0.11867777f, -0.16550788f, 0.53059483f, -0.12636772f, 
    -0.02922087f, -0.15672646f, -0.05497741f, -0.01504898f, -0.26953733f, 0.08655955f, 0.13917199f, 0.30226597f, 
    0.08000571f, -0.25980917f, -0.07990126f, -0.05328435f, -0.31556380f, 0.02202710f, -0.10417868f, 0.04751963f, 
    -0.06706250f, -0.24688302f, 0.00956824f, -0.00368098f, 0.25365147f, -0.04372567f, 0.16129720f, -0.13025562f, 
    0.15446664f, 0.13121431f, 0.11051081f, 0.01079437f, 0.13093376f, 0.31430727f, -0.46917659f, -0.05099842f, 
    0.11003536f, -0.23843102f, 0.11191225f, 0.04048590f, -0.13049647f, 0.32881099f, 0.20189820f, -0.05522531f, 
    0.00964339f, 0.11868108f, -0.06550755f, 0.09673827f, 0.21123931f, 0.00547164f, 0.15498595f, -0.04314397f, 
    0.07544815f, -0.05923701f, 0.05667636f, 0.21178192f, -0.05012272f, -0.03252650f, 0.02029817f, 0.21879867f, 
    0.08433340f, 0.26468155f, 0.21129039f, 0.06102552f, -0.28690940f, -0.25792331f, 0.29387975f, -0.18984339f, 
    -0.01083352f, 0.41214013f, -0.43417859f, -0.02296249f, -0.36455464f, -0.11968705f, -0.08746118f, 0.03210093f, 
    0.15694161f, 0.01246264f, 0.21414873f, 0.15481456f, -0.11517175f, -0.03291339f, -0.11642279f, -0.05270508f, 
    -0.08066055f, -0.09396576f, 0.13209225f, 0.13424431f, 0.13754620f, 0.24607678f, 0.23640579f, 0.20678590f, 
    -0.18677476f, -0.42915797f, -0.27770874f, -0.03760058f, 0.17092977f, 0.38315657f, 0.01796015f, 0.14341371f, 
    -0.21332754f, -0.09327282f, 0.26401100f, 0.23168819f, 0.02356873f, 0.08316520f, 0.30988577f, 0.24927431f, 
    -0.13918668f, 0.01754581f, -0.15263300f, -0.19942032f, -0.00538985f, -0.19241387f, 0.09307227f, -0.31536102f, 
    0.00644601f, -0.03617824f, 0.05610643f, 0.00681563f, -0.05105718f, -0.20412841f, -0.28785416f, 0.16466641f, 
    -0.21006159f, 0.05062125f, 0.16013317f, 0.03171952f, -0.06189510f, -0.10641234f, 0.12322760f, -0.43340272f, 
    -0.26397002f, 0.07676037f, -0.24043036f, -0.44211838f, 0.03266543f, 0.23547032f, -0.04181989f, 0.05488973f, 
    -0.00846035f, -0.20238005f, 0.17105831f, -0.06507406f, 0.01496193f, -0.12749662f, -0.11561824f, 0.25429109f, 
    0.01091718f, -0.38995272f, 0.19734417f, 0.00941171f, 0.06541314f, 0.21420464f, -0.09924617f, 0.20559335f, 
    0.34632283f, 0.38653800f, -0.28978273f, 0.02169322f, -0.03016503f, -0.08595501f, -0.18049639f, -0.06521889f, 
    -0.10458981f, 0.15459415f, -0.02486153f, 0.05864988f, -0.12014052f, 0.17365777f, 0.15430948f, 0.15847589f, 
    -0.04813582f, -0.03774786f, 0.18725733f, 0.16968325f, -0.06855465f, 0.13017981f, -0.00834359f, 0.09658995f, 
    0.16883296f, 0.12165926f, -0.08436024f, -0.05780586f, 0.02978144f, 0.28671655f, 0.14199542f, -0.09078535f, 
    0.18239860f, -0.10350592f, -0.05803500f, -0.00430704f, -0.04710832f, 0.27493811f, -0.09213337f, -0.22837573f, 
    0.14859983f, 0.00660631f, -0.04274704f, -0.12981232f, 0.30385676f, -0.16186585f, 0.10141423f, 0.08564561f, 
    0.13272689f, 0.22977126f, -0.15676172f, -0.05210868f, -0.06147065f, -0.04397880f, -0.03999239f, 0.13298902f, 
    -0.16133893f, -0.16986896f, 0.01757659f, -0.11415410f, -0.03579523f, -0.20452869f, 0.08558967f, 0.13896663f, 
    -0.51825631f, -0.23584040f, -0.02960050f, 0.22393705f, 0.16025044f, -0.23160288f, 0.12304083f, 0.21710397f, 
    -0.03593939f, -0.03933239f, 0.18394630f, 0.00322102f, -0.02039618f, -0.37694308f, 0.20434812f, 0.05624387f, 
    0.01205101f, -0.08202185f, -0.10879622f, -0.54453260f, -0.07148335f, -0.16929249f, 0.06264095f, 0.07484263f, 
    0.00100371f, -0.26657921f, 0.11361693f, -0.08720806f, -0.15152575f, -0.15034361f, -0.18134376f, 0.12740186f, 
    -0.40760040f, -0.05684596f, 0.15491080f, 0.04439588f, 0.17994271f, -0.11900120f, -0.03836380f, -0.16108958f, 
    0.02851571f, -0.17148454f, -0.09759481f, -0.11813308f, 0.03539052f, 0.24801366f, 0.24553166f, 0.14051756f, 
    0.04164451f, 0.03465695f, -0.07750446f, -0.07131618f, 0.08001199f, -0.04499133f, 0.09713092f, 0.16872962f, 
    0.07600012f, 0.23571989f, 0.02281312f, -0.09936646f, 0.07945511f, 0.10384741f, -0.00562320f, 0.05778386f, 
    -0.05713417f, -0.29745129f, -0.03240724f, -0.17167956f, -0.06918419f, 0.18691783f, 0.04498267f, -0.07697116f, 
    0.20294382f, 0.01491055f, -0.06561697f, 0.18530774f, 0.02080028f, -0.00121341f, 0.17447309f, 0.00483292f, 
    -0.14057332f, -0.05211057f, 0.02095898f, -0.05271158f, 0.03225456f, -0.34001750f, 0.20061737f, -0.20387699f, 
    -0.13301192f, -0.22114126f, 0.10725199f, 0.03741650f, 0.07875044f, -0.03063952f, -0.03710594f, 0.17988743f, 
    -0.10782889f, 0.11426972f, -0.18040758f, 0.01937851f, 0.04337297f, 0.08042008f, -0.06996827f, -0.18554534f, 
    -0.12042441f, 0.29257965f, -0.12367765f, -0.13100486f, 0.10398258f, -0.07244811f, -0.05541441f, -0.05064267f, 
    -0.19266616f, -0.41501677f, 0.00711949f, -0.07834220f, 0.13757315f, -0.15979715f, -0.11229660f, 0.16408515f, 
    -0.33722395f, 0.16267991f, 0.20076320f, 0.03963773f, -0.08661895f, 0.04610292f, 0.21755655f, -0.07892792f, 
    0.08159292f, 0.18532534f, -0.10410323f, 0.17645334f, -0.20447490f, -0.11531488f, -0.09991504f, 0.11657445f, 
    0.02819521f, -0.16889758f, 0.12767646f, -0.30442351f, 0.11145693f, -0.36029825f, 0.00826147f, 0.02004803f, 
    0.13774228f, 0.06170195f, 0.19477277f, 0.07912385f, 0.11899661f, 0.31212932f, -0.11120021f, 0.34320918f, 
    0.20572814f, -0.05896071f, 0.11221205f, 0.11936679f, -0.09547488f, -0.18973148f, 0.08909044f, 0.05448610f, 
    0.01886174f, -0.43340319f, 0.19892521f, 0.00375605f, 0.07087630f, -0.17875513f, 0.44411030f, 0.16898572f, 
    0.03665520f, -0.05778421f, 0.15777044f, 0.30233783f, -0.16672707f, -0.00161107f, -0.00443090f, 0.18735491f, 
    0.34524041f, 0.08333191f, -0.12985246f, 0.14321108f, -0.15924464f, 0.00743279f, -0.06149505f, 0.05832230f, 
    0.14513224f, 0.13398568f, -0.09672574f, 0.05995058f, -0.06976464f, -0.31934872f, 0.02000807f, -0.28549480f, 
    -0.02093155f, -0.09439936f, 0.01369052f, -0.06267010f, -0.07594454f, -0.05231062f, 0.04246221f, -0.04844094f, 
    0.00104499f, -0.02384447f, 0.02731481f, -0.02657051f, 0.01334929f, 0.07145144f, 0.04438316f, -0.04298511f, 
    -0.05663748f, -0.09623623f, 0.04649481f, 0.04658901f, 0.07490283f, -0.14002386f, -0.03387013f, 0.08494861f, 
    -0.03355260f, 0.01726070f, 0.03405616f, -0.04242805f, -0.00034638f, -0.08365197f, -0.00278296f, -0.04410605f, 
    -0.14079252f, -0.09581194f, 0.09321111f, -0.06168380f, -0.11351283f, -0.03056886f, 0.02823660f, 0.07467963f, 
    0.07855511f, -0.07991068f, -0.06435946f, 0.00489133f, 0.04603007f, -0.12163164f, 0.06829335f, 0.03628099f, 
    -0.05258534f, -0.01150405f, -0.06564851f, -0.01270937f, -0.07912464f, 0.04649168f, -0.05408286f, -0.10507349f, 
    0.03566620f, 0.07469799f, -0.01004406f, 0.01084629f, 0.05302832f, -0.11236539f, -0.12968308f, -0.13873756f, 
    0.07736930f, -0.02590281f, -0.42501199f, 0.09704843f, -0.10725296f, 0.29645586f, -0.08125140f, 0.15925324f, 
    -0.43458828f, 0.09389923f, 0.20005204f, -0.01871384f, 0.29382443f, -0.18059190f, 0.04633985f, -0.00515342f, 
    0.05702822f, 0.08166000f, 0.19760443f, -0.05701076f, -0.04601496f, 0.01566781f, -0.67536819f, 0.24684781f, 
    0.20781510f, 0.15251814f, 0.00885795f, -0.08382329f, -0.16505526f, 0.10154140f, -0.18932012f, -0.12973459f, 
    0.21544985f, -0.03116200f, 0.15325138f, 0.08863286f, -0.09962399f, 0.24261992f, -0.16181332f, 0.10412336f, 
    0.03079414f, -0.45160675f, 0.03503429f, -0.00426894f, 0.24511530f, 0.39222795f, -0.04017611f, 0.05832954f, 
    0.28951824f, 0.29469109f, -0.06300580f, -0.08388264f, 0.08706611f, -0.06094482f, -0.10823580f, -0.00577326f, 
    0.32925442f, 0.03304035f, 0.12553774f, -0.24148670f, -0.11807375f, 0.17331770f, -0.20872384f, 0.12033840f, 
    -0.00033404f, 0.23938876f, -0.01090993f, 0.07880956f, -0.34293717f, -0.13741466f, 0.03670451f, 0.11068668f, 
    0.08831796f, 0.02902726f, -0.06572843f, 0.34512299f, 0.46244836f, 0.09022907f, -0.01920778f, -0.22339168f, 
    0.03801045f, 0.09247676f, 0.20190425f, 0.02406680f, 0.02058966f, 0.24968418f, -0.11137453f, -0.00479762f, 
    0.03364740f, -0.15888961f, -0.07201384f, 0.14991461f, 0.42486325f, -0.05003320f, 0.36399725f, -0.12825592f, 
    0.20606142f, -0.02433497f, 0.15411866f, 0.01435653f, 0.18023126f, -0.05255724f, -0.00390499f, 0.38983274f, 
    0.18254820f, 0.01768026f, 0.33484089f, 0.31628028f, -0.00700567f, -0.09738725f, 0.21396963f, 0.15319715f, 
    0.02702296f, 0.10288838f, 0.04690045f, 0.16566119f, 0.07127329f, 0.19189252f, -0.08834972f, -0.07495455f, 
    -0.11094189f, 0.49455222f, 0.12699994f, 0.42125741f, -0.19506033f, 0.15340480f, -0.03222188f, -0.32118329f, 
    -0.04485726f, -0.04351231f, -0.01625962f, -0.08128851f, 0.03044475f, -0.07521357f, 0.03806424f, 0.08855931f, 
    -0.12505230f, 0.04042118f, -0.05679672f, -0.13760622f, -0.09150060f, -0.06021772f, -0.12793125f, -0.04140868f, 
    -0.06505789f, 0.11853917f, 0.07811625f, -0.05472252f, 0.12007555f, -0.08366066f, -0.16371225f, 0.01103988f, 
    0.02265293f, -0.04928565f, -0.11033578f, -0.13639343f, -0.07941590f, -0.16336563f, -0.04132280f, -0.00073033f, 
    -0.06533135f, -0.08190741f, -0.01719153f, -0.11288044f, -0.14301108f, 0.05552309f, 0.03471474f, 0.11198491f, 
    -0.01865184f, 0.00025470f, -0.14549497f, 0.01304046f, 0.05350328f, -0.09929777f, -0.02584228f, -0.09211820f, 
    -0.01576703f, 0.04491095f, -0.15899310f, -0.11629567f, -0.00667994f, -0.11040466f, 0.03595544f, -0.20811634f, 
    -0.05494780f, 0.08486384f, 0.07148311f, -0.02087995f, -0.15589362f, 0.01789469f, -0.08391859f, -0.14822575f, 
    -0.01690459f, -0.21743017f, -0.21234523f, -0.14208379f, 0.08028363f, 0.30689681f, 0.00540791f, 0.10170431f, 
    -0.19433731f, 0.20336744f, 0.26430795f, 0.10613181f, 0.36889976f, -0.03788343f, -0.12767579f, 0.18687735f, 
    -0.16311403f, -0.11568420f, 0.15591662f, -0.23141524f, 0.05536870f, 0.02727200f, -0.11483203f, -0.00861754f, 
    0.03318104f, 0.22321545f, -0.11349521f, -0.28997368f, -0.06296904f, -0.17081654f, -0.17593479f, 0.03532062f, 
    0.14314245f, 0.11012054f, 0.01690341f, 0.12271498f, 0.07415266f, 0.22835414f, -0.18475899f, 0.25725845f, 
    -0.23931985f, 0.03539628f, 0.00780763f, 0.12089925f, 0.20457917f, 0.32801056f, -0.16100736f, 0.13716537f, 
    0.19698815f, 0.04335998f, 0.07110320f, -0.04079698f, 0.24574381f, 0.19486031f, 0.04381602f, -0.00178441f, 
    0.11388154f, 0.15374316f, 0.18778245f, -0.12410992f, -0.15873882f, 0.32642901f, -0.25824898f, 0.19869092f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.01757834f, 0.03252414f, 0.04128499f, 0.08885657f, 0.03230578f, -0.09752818f, 0.06388174f, 0.18384351f, 
    -0.05588467f, 0.08645679f, 0.03078908f, 0.08654937f, 0.07137786f, -0.06235291f, -0.10976502f, -0.14365086f, 
    0.19081564f, -0.05807169f, -0.19393001f, -0.06385001f, 0.08416538f, 0.03219033f, 0.04896627f, 0.06149617f, 
    -0.11959278f, 0.14752376f, 0.13066365f, 0.17261630f, -0.13297299f, -0.04022823f, 0.14574130f, 0.07760920f, 
    0.18297316f, 0.05672755f, 0.25293890f, 0.30623543f, 0.13217404f, -0.13534704f, 0.11756514f, 0.20662355f, 
    -0.09154469f, -0.11216696f, 0.14762944f, 0.24577352f, 0.21017767f, 0.21649209f, 0.06874359f, 0.08231428f, 
    -0.01142556f, -0.05908085f, 0.23695356f, 0.13322167f, 0.19494779f, 0.08491808f, 0.16444738f, 0.12451965f, 
    0.14550918f, 0.24447042f, 0.12099592f, -0.11175395f, 0.04424487f, 0.14430442f, -0.01908343f, -0.01629176f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.07661194f, -0.58433849f, 0.07138968f, -0.14918615f, -0.00930809f, -0.43327701f, -0.20255479f, -0.27739915f, 
    0.10943802f, -0.09426699f, -0.14188771f, 0.02899018f, 0.05212073f, -0.13709784f, -0.41554284f, 0.03547643f, 
    -0.25708529f, 0.10215354f, 0.04188626f, -0.06274433f, 0.04425913f, 0.28792208f, -0.02838954f, -0.06376719f, 
    0.25523552f, 0.07018934f, 0.20548800f, 0.20291831f, 0.03342216f, -0.02596659f, 0.08728506f, -0.15457667f, 
    -0.29994130f, -0.05327970f, -0.27450815f, 0.11132482f, -0.31993440f, 0.50353825f, -0.16351053f, 0.06440882f, 
    0.02582634f, -0.05225776f, 0.06183324f, 0.16517414f, -0.04609053f, 0.25644833f, -0.22178270f, 0.18876678f, 
    0.02435951f, -0.17869739f, -0.30406040f, 0.07643608f, -0.03812650f, -0.18935718f, -0.19601597f, -0.27302271f, 
    -0.15281606f, -0.81722444f, -0.05554868f, -0.00433162f, -0.05583344f, 0.17517263f, 0.00706201f, 0.16915755f, 
    0.25055805f, -0.36235300f, -0.07476040f, -0.05939040f, -0.12589848f, 0.06157940f, 0.22868408f, -0.29513130f, 
    -0.04652853f, -0.05471390f, -0.45678267f, -0.01514183f, -0.35860297f, -0.08582430f, 0.15628241f, -0.02133492f, 
    -0.07944364f, 0.21138552f, 0.04026821f, -0.04315842f, -0.22827274f, 0.20856002f, 0.24301751f, -0.04667106f, 
    -0.43651628f, 0.15399794f, -0.03277395f, -0.14399226f, 0.02516549f, -0.03896722f, 0.25129661f, 0.14157687f, 
    0.17351557f, 0.14569724f, -0.40833360f, 0.16329846f, -0.04863530f, -0.38151723f, 0.29051727f, 0.22410786f, 
    -0.04805266f, 0.02123964f, 0.10499566f, 0.12376464f, 0.14263767f, -0.41667432f, 0.14438613f, 0.13366339f, 
    -0.06729887f, 0.03630673f, 0.12883602f, 0.00274861f, 0.15853320f, 0.01147654f, 0.15532231f, 0.07476765f, 
    0.06080031f, 0.01979249f, -0.25419521f, 0.04722317f, -0.58465266f, 0.12198595f, -0.05520016f, -0.21336453f, 
    0.04283331f, 0.05704038f, -0.14774567f, 0.10353493f, -0.00101294f, -0.57652545f, -0.13611430f, 0.07484144f, 
    -0.10778627f, 0.11499067f, -0.07821821f, -0.16215058f, 0.16167024f, -0.02776018f, -0.38356444f, -0.04642025f, 
    0.00680213f, -0.15988113f, -0.04232189f, 0.07775473f, 0.13853331f, -0.29047352f, -0.24480030f, -0.12793013f, 
    -0.14359197f, -0.30766255f, -0.30267197f, 0.06365723f, 0.06968091f, 0.03789560f, -0.25843012f, -0.37719116f, 
    -0.05441578f, 0.05057224f, -0.13027146f, -0.02908220f, 0.15725075f, 0.00348516f, -0.44361049f, 0.11421473f, 
    -0.00340280f, -0.32698610f, 0.15872921f, 0.14891057f, -0.20400003f, 0.23505865f, 0.13607100f, 0.04048014f, 
    0.04164506f, -0.10929554f, 0.16224125f, -0.17225420f, 0.23810309f, 0.20319496f, -0.34723535f, -0.00941073f, 
    -0.42048144f, 0.05247613f, 0.27251098f, -0.11229140f, -0.49624392f, -0.03520152f, -0.17829366f, -0.65629584f, 
    -0.17337678f, 0.08464725f, -0.02301855f, -0.15955029f, -0.23247989f, -0.19330232f, 0.14203744f, 0.04563722f, 
    -0.02587231f, 0.10865442f, 0.09261900f, -0.02437037f, 0.20456356f, -0.12805162f, -0.27552143f, -0.07405497f, 
    -0.04536625f, -0.03377052f, -0.02542830f, -0.04498981f, -0.04149835f, -0.26372945f, -0.18434678f, 0.05875344f, 
    -0.09570727f, -0.14140031f, -0.19315347f, 0.01594948f, 0.06052478f, -0.01783145f, -0.11289690f, -0.34546494f, 
    -0.45750839f, 0.02372227f, -0.41680461f, -0.28805462f, 0.36573198f, -0.23796813f, -0.70289934f, -0.14382148f, 
    0.08029109f, 0.16043366f, -0.05112376f, -0.02958660f, 0.10137964f, 0.01807357f, -0.17038715f, 0.15985137f, 
    0.02373706f, -0.12050342f, -0.25377804f, -0.67784822f, -0.74046135f, -0.05837004f, -0.08833404f, -0.17091849f, 
    -0.89756900f, -0.88503963f, 0.02100949f, -0.07138499f, 0.24952976f, 0.18656637f, -0.04082567f, 0.23309655f, 
    0.00082700f, -0.07605905f, -0.13968283f, 0.03778501f, -0.07464578f, -0.54433227f, -0.02970155f, -0.01975548f, 
    0.08036397f, 0.00398590f, 0.20219836f, 0.14423743f, 0.15899034f, -0.07775319f, -0.23193839f, 0.00207885f, 
    0.11239205f, 0.09268840f, 0.00472513f, -0.02567851f, -0.39782339f, 0.02064015f, -0.08318862f, -0.04917356f, 
    0.17530519f, -0.11221165f, 0.02668072f, -0.42871407f, -0.02809004f, -0.04276107f, -0.23468065f, 0.13741051f, 
    0.05108969f, -0.17253472f, 0.08651801f, -0.23696628f, -0.20832925f, -0.37259504f, 0.07429229f, -0.04740588f, 
    0.08060300f, -0.34463885f, 0.05437878f, 0.08357093f, 0.01576990f, -0.67475539f, -0.05374485f, -0.03964552f, 
    -0.14717634f, 0.13008238f, -0.26239270f, 0.17131478f, 0.04570602f, -0.48298627f, -0.16382335f, 0.08924019f, 
    0.01527633f, -0.03773038f, 0.03444979f, 0.06628000f, 0.17471568f, 0.18522617f, -0.02040326f, -0.03206678f, 
    -0.17932551f, 0.14328913f, 0.03999022f, -0.29037660f, 0.01586955f, 0.01434872f, -0.09312898f, 0.03812007f, 
    0.02064365f, -0.07494087f, -0.37748656f, 0.20118678f, -0.04537008f, -0.14722832f, -0.04785028f, 0.07115711f, 
    0.15494518f, 0.13710748f, -0.03403197f, -0.00131194f, -0.02486171f, -0.22141664f, 0.04590967f, -0.12597501f, 
    0.05572711f, 0.32455617f, -0.29596755f, -0.17017801f, 0.06244671f, 0.01368552f, -0.01472657f, 0.02734458f, 
    -0.26695997f, -0.12584992f, -0.05088602f, -0.14329386f, -0.02152294f, 0.09850919f, -0.12560189f, 0.14947306f, 
    -0.11209478f, 0.02665729f, 0.07451675f, -0.18094017f, 0.19086124f, 0.11543673f, -0.18040672f, -0.17926301f, 
    -0.12080703f, 0.20974691f, 0.03900099f, -0.14082240f, -0.30479169f, 0.07166179f, -0.38790891f, 0.06935119f, 
    0.12126805f, -0.41165027f, -0.16988948f, 0.08697969f, -0.09884663f, 0.03613836f, -0.04647048f, -0.12147049f, 
    -0.01975875f, 0.03543312f, -0.04030952f, -0.13295014f, -0.09781380f, -0.08614092f, -0.43394679f, 0.20585358f, 
    0.04770267f, -0.02848259f, 0.08380079f, -0.75838280f, 0.15176381f, 0.00685804f, -0.46968257f, 0.08754857f, 
    0.00728737f, -0.16910204f, -0.14311057f, 0.06233208f, 0.17513126f, -0.05075988f, -0.40331650f, -0.01470450f, 
    -0.22970738f, -0.01893724f, -0.04103657f, 0.16718960f, -0.01956709f, -0.04767355f, -0.23289657f, -0.04310224f, 
    0.16561124f, -0.05378222f, -0.21895520f, -0.05382350f, -0.09932626f, 0.04972009f, 0.30631638f, -0.25556973f, 
    -0.04171325f, -0.41958299f, -0.70034730f, 0.15130402f, -0.58202249f, 0.27244937f, 0.10770394f, -0.70191497f, 
    0.11140678f, -0.04930304f, -0.05175039f, 0.06560188f, 0.36644259f, -0.10114610f, 0.02061417f, -0.23492371f, 
    0.26395997f, -0.23098727f, 0.09276374f, -0.15577970f, -0.52121347f, -0.38927314f, 0.04999153f, -0.58501202f, 
    -0.21565263f, 0.22037940f, -0.02959067f, 0.10187637f, 0.08311285f, 0.43292698f, 0.18324645f, -0.26829082f, 
    0.06171153f, 0.01106451f, -0.10353029f, -0.35773292f, -0.02453159f, -0.15236828f, 0.11833231f, 0.06225561f, 
    -0.36106318f, -0.23637512f, 0.06175249f, -0.02748251f, -0.12800537f, -0.19700059f, -0.08716920f, 0.03468939f, 
    0.06110885f, -0.00099310f, -0.16784635f, -0.04422642f, -0.00694275f, 0.00628730f, -0.12488663f, 0.15938595f, 
    0.01536654f, -0.12132162f, 0.32620588f, 0.27157825f, -0.14038277f, 0.06869067f, 0.14939679f, -0.34965518f, 
    0.09179742f, 0.30483165f, -0.44228774f, -0.29585546f, -0.01409470f, -0.10948903f, 0.15947610f, -0.44053528f, 
    -0.13303843f, 0.02128039f, -0.46063989f, 0.52019179f, -0.58942914f, -0.13629155f, 0.17145574f, -0.32030210f, 
    0.17549169f, 0.01382596f, -0.28309390f, 0.06135380f, 0.11220021f, 0.01113653f, -0.04429905f, 0.21174155f, 
    -0.07752259f, 0.29239830f, 0.09279422f, -0.21405759f, -0.03448782f, -0.32250622f, -0.34412804f, -0.16084366f, 
    -0.05802580f, -0.01864413f, -0.27766785f, -0.08172344f, -0.28847459f, -0.00485015f, -0.38979030f, 0.06204230f, 
    0.11633988f, -0.40499172f, -0.02211117f, 0.02351821f, 0.29205853f, -0.49024084f, 0.07031108f, -0.09185535f, 
    -0.39612696f, 0.27267256f, -0.03846410f, 0.04907793f, 0.09152957f, 0.03034993f, 0.10260475f, -0.01932438f, 
    -0.23521420f, -0.09945671f, -0.16345578f, -0.01067402f, 0.19833471f, -0.26165783f, -0.18591468f, 0.07499018f, 
    -0.08959104f, 0.38952047f, -0.62648141f, -0.58946240f, -0.02958989f, 0.10581805f, 0.17306410f, -0.22920254f, 
    -0.11221939f, -0.18405978f, 0.01395730f, -0.37078476f, 0.00166784f, 0.09937802f, 0.31643242f, 0.01860262f, 
    -0.03987794f, -0.00488389f, -0.46837404f, -0.01788965f, -0.28556567f, -0.61806738f, -0.13801990f, -0.03247238f, 
    -0.38049164f, -0.00808478f, -0.09874601f, -0.20649539f, -0.21427272f, 0.17262758f, -0.21391614f, 0.17389204f, 
    -0.04847841f, -0.01112039f, 0.18458936f, -0.04016871f, 0.26939562f, -0.10155978f, -0.23083837f, 0.03764579f, 
    0.02726043f, -0.31550461f, -0.15332167f, 0.01720367f, -0.07423997f, -0.71611661f, -0.34656668f, -0.12961639f, 
    -0.12232041f, -0.19366880f, 0.01951352f, 0.08836192f, -0.12327706f, -0.09214886f, -0.39641276f, -0.06514429f, 
    0.06920171f, -0.08358525f, 0.19830987f, 0.17664647f, -0.34746444f, -0.30139321f, -0.21657394f, -0.19737536f, 
    -0.01879075f, -0.63836217f, -0.00732560f, 0.21164468f, -0.26854295f, 0.04491729f, 0.12189164f, -0.19734956f, 
    -0.17118703f, -0.34998700f, -0.23825726f, 0.23482512f, -0.04156770f, -0.48676470f, -0.16989397f, 0.11656484f, 
    0.15906304f, 0.13222815f, 0.19640844f, -0.11616589f, 0.26354724f, -0.11897719f, -0.20047815f, 0.21035042f, 
    -0.20256765f, 0.04623052f, -0.11534047f, 0.07403049f, -0.22776726f, -0.51346356f, -0.03850633f, -0.37807354f, 
    0.01844301f, 0.00733543f, -0.15904160f, 0.19635735f, -0.35583615f, -0.09760587f, -0.13310458f, -0.06389260f, 
    0.12420300f, -0.21271847f, 0.07779987f, -0.07230533f, -0.09618632f, -0.29804748f, 0.27286923f, 0.08570992f, 
    -0.29672000f, 0.13544567f, 0.35852423f, -0.20000289f, 0.04104576f, -0.09644082f, 0.26196548f, -0.62437165f, 
    -0.08546007f, -0.06987292f, 0.07165778f, -0.47176722f, 0.12514307f, -0.28553793f, -0.19736195f, 0.07435426f, 
    0.01878297f, -0.33990383f, -0.21440862f, -0.44413120f, -0.11317645f, 0.06264716f, -0.07190582f, 0.18064176f, 
    0.02651917f, -0.82982564f, 0.31445312f, 0.39464337f, -0.02917879f, -0.12963872f, -0.35133806f, 0.25879630f, 
    -0.27791467f, -0.52966338f, -0.71840823f, -0.01118978f, 0.09324134f, -0.56943738f, 0.00274331f, -0.02695297f, 
    -0.02781790f, 0.05133648f, -0.15011293f, -0.36522222f, 0.01458692f, -0.39811018f, -0.29579824f, 0.19029450f, 
    0.10470478f, 0.02080525f, 0.14052980f, -0.21156381f, -0.25404325f, -0.10666160f, 0.29323381f, 0.06547952f, 
    -0.02370230f, -0.50632590f, -0.11973619f, -0.01348408f, -0.00722286f, -0.37353840f, 0.09377486f, -0.06493859f, 
    -0.08874119f, -0.58411813f, 0.37858957f, 0.22205299f, -0.09834616f, 0.02749641f, 0.16672409f, 0.08800259f, 
    -0.07807977f, 0.09157992f, -0.12875350f, -0.41174713f, -0.31806821f, -0.31193674f, -0.14732818f, -0.11150411f, 
    0.11058275f, -0.05339353f, -0.33231908f, 0.20784646f, -0.13688280f, 0.14548494f, -0.08119678f, -0.28941220f, 
    -0.11419144f, 0.10151196f, 0.12968582f, -0.15502062f, -0.08994073f, 0.26645920f, 0.24135454f, 0.01611516f, 
    -0.14738312f, -0.00621612f, -0.05180734f, 0.06281390f, 0.04727840f, -0.26691604f, -0.12787491f, 0.16754639f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.24794303f, 0.05043584f, 0.01529610f, 0.07146487f, -0.05768314f, 0.05217451f, -0.06302564f, -0.07874977f, 
    -0.00906265f, 0.03292584f, 0.11892175f, 0.04983922f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
