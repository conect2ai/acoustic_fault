#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.88090354f, 0.32713822f, -0.52898318f, -0.69566429f, -0.08590247f, 0.18647803f, 0.12947699f, 0.21265171f, 
    0.48759407f, 0.25067395f, 0.06881066f, 0.26403651f, 0.23159872f, 0.01697641f, -0.12731203f, -0.55489206f, 
    -0.19664429f, -0.20999877f, -0.28158623f, 0.03547455f, 0.28788313f, 0.63274020f, 0.18767697f, 0.49430919f, 
    0.31832978f, 0.27466056f, 0.19933352f, -0.57393193f, -0.72455186f, -0.80290711f, -0.52977890f, -0.70148772f, 
    -0.89276010f, -0.91858590f, -1.23135436f, 0.14799710f, 0.18524501f, -0.12941168f, -0.16206914f, 0.31056294f, 
    0.28788048f, 0.66866863f, 0.24801128f, -0.29699299f, 0.05147146f, -0.30824146f, -0.00722567f, -0.08592073f, 
    0.21475598f, 0.16709208f, 0.10045938f, 0.95704627f, -0.99068642f, -1.22016597f, -1.04918921f, -0.85163146f, 
    -0.18101126f, 0.58039910f, 0.81778920f, 0.39413428f, 0.32249644f, 0.11494455f, 0.05745250f, 0.06779861f, 
    -0.13668467f, 0.09983160f, -0.33049569f, -0.06666996f, -0.22014685f, -0.42145684f, -0.23428032f, 0.10167063f, 
    -0.24833417f, -0.52703989f, -0.19877614f, 0.56674641f, 0.48276159f, -0.91833407f, 0.48107803f, -0.19863814f, 
    -0.27021426f, 1.25010788f, -0.78754508f, -0.39515188f, 0.44021359f, -0.41956487f, 0.26026598f, -0.16239674f, 
    -0.25613087f, 0.11731409f, 0.21627675f, 0.02695038f, 0.06378478f, 0.00277083f, -0.37211269f, -0.12374699f, 
    0.17605031f, 0.13947564f, -0.21056896f, 0.15537068f, 1.75695789f, -0.31344071f, -0.93126529f, -0.78854650f, 
    -1.13262093f, 0.59233522f, 0.58777988f, 0.58225703f, 0.22946680f, 0.05324623f, -0.04873484f, 0.45872000f, 
    -0.14780924f, -0.25725403f, -0.22424668f, 0.03139106f, -0.00518042f, 0.01787823f, -0.10251120f, -0.19452643f, 
    0.20281528f, -0.04550729f, -0.11959140f, -0.01128790f, 0.14345150f, 0.12313527f, 0.66244143f, 0.21539290f, 
    0.51594943f, 0.49040192f, 0.10441659f, -0.29811180f, -0.08007781f, 0.52682793f, 0.38631982f, 0.53201514f, 
    -0.27386850f, -0.23796847f, 0.22870089f, -0.17819719f, 0.10693833f, 0.10552501f, -0.27516624f, 0.08120865f, 
    -0.18442836f, -0.21488549f, 0.06862581f, 0.03693260f, -0.30384189f, -0.44685513f, -0.70694292f, -0.58023453f, 
    -0.62669820f, -0.80495399f, -0.29074597f, -1.12776601f, -0.80602545f, -0.33411977f, -0.52046645f, -1.33468950f, 
    0.61499494f, 0.63617027f, -0.06205336f, 0.01204006f, -0.03693949f, -0.37829712f, -0.56137925f, -0.14898610f, 
    -0.41803014f, -0.57282132f, -0.28978711f, -0.20000468f, 0.22092262f, 0.02316350f, -0.21877328f, 0.48033270f, 
    -0.71878213f, 0.38761202f, -0.62030363f, 0.47539762f, -1.11307812f, -0.40469006f, 0.75009185f, 0.90402472f, 
    -0.07846471f, -0.21554969f, -0.49827439f, 0.21747206f, -0.35688436f, 0.23883036f, 0.11117937f, -0.08448496f, 
    -0.08845433f, 0.06201728f, 0.18269558f, -0.14891611f, -0.25000542f, 0.13349210f, 0.11589683f, 0.18099698f, 
    -0.91644359f, 0.01938273f, 0.30570942f, 0.30184224f, 1.11351585f, 0.18362994f, 0.53915942f, -1.52215314f, 
    -1.40048409f, -0.74120110f, -0.12244159f, 0.07908256f, -0.46468720f, -0.36128756f, -0.54033780f, -0.21529832f, 
    0.14410137f, -0.03726337f, 0.18856072f, 0.32093310f, 0.03778421f, -0.12720720f, 0.23050670f, -0.12711427f, 
    -0.44964495f, -0.28457657f, 0.48046300f, 0.59778589f, 0.17945902f, 0.09760682f, -0.35768229f, -0.39077255f, 
    -0.33621448f, 0.16649416f, -0.05790893f, -0.46899918f, -0.11525758f, -0.20164585f, -0.17325546f, -0.22443810f, 
    0.37984306f, 0.51429212f, -0.01831514f, -0.26874936f, -0.40992016f, -0.03208677f, 0.11571455f, 0.09000193f, 
    0.40065339f, 0.38826144f, -2.17912459f, 0.20294766f, -0.51928812f, -0.67204595f, 0.37085932f, 0.15704976f, 
    0.50108027f, 0.43139499f, 0.82952935f, 0.75876975f, 0.23933311f, -0.33552977f, -0.07194957f, -0.54263663f, 
    0.23401533f, 0.12862979f, 0.09839188f, -0.24638699f, 0.18310201f, 0.17981409f, 0.02183215f, -0.14496648f, 
    0.10578825f, 0.01418927f, -0.35769168f, 0.89208627f, 0.88575679f, 0.78732115f, -0.47646743f, -0.66497189f, 
    0.35431463f, 0.04635495f, -0.00993701f, -0.42430916f, -0.32965860f, -0.03018592f, -0.23851547f, 0.55011821f, 
    -0.33711809f, -0.66531849f, -0.10786346f, -0.00357215f, -0.28615767f, 0.00683802f, -0.15883231f, -0.39608362f, 
    -0.01527451f, 0.19432022f, 0.20931159f, 0.07084994f, -0.09787700f, 0.83796507f, 0.40249059f, 0.79265618f, 
    -0.80943239f, -1.35457671f, -0.56489283f, 0.10521484f, -0.08156151f, -0.07386068f, 0.27000937f, -0.28058785f, 
    0.70800340f, -0.32302001f, -0.19879869f, -0.11102467f, 0.30531949f, -0.08206958f, -0.73330307f, -0.78514200f, 
    -0.00217966f, -0.07134466f, -0.14817910f, 0.19674867f, -0.02715866f, 0.12746660f, 0.38374215f, 0.15799208f, 
    -0.03618840f, -0.26474050f, 0.12060937f, 0.34781837f, 0.22972430f, 0.32700312f, -0.11072540f, 0.04880049f, 
    -0.22507624f, 0.15397064f, -0.29163498f, -0.47354728f, -0.36231053f, -0.29755777f, 0.04389236f, 0.19322978f, 
    -0.12379684f, 0.07067008f, 0.15435053f, -0.48973003f, -0.45127639f, 0.73136759f, -1.79437768f, -0.76309478f, 
    -0.68477243f, -1.07399154f, -0.21694633f, 1.06538868f, -0.10118859f, -0.88515657f, -0.26393348f, 0.14507742f, 
    -0.46060011f, -0.74398589f, -0.56464261f, -0.53345358f, -0.60801899f, 0.07994449f, 0.10604747f, -0.04717809f, 
    0.09632436f, -0.31895754f, -0.14766082f, 0.07056987f, -0.13607202f, -0.21684782f, 0.00338300f, -1.89739108f, 
    0.36922470f, 1.36766219f, -1.73134136f, -0.70782816f, -0.01365636f, -0.07973403f, -0.24445103f, 0.43241772f, 
    0.21568088f, -0.38867542f, -0.56189084f, -0.33229426f, -0.50266427f, 0.18578780f, 0.06243218f, -0.52678531f, 
    -0.64153230f, -0.16105476f, 0.05645366f, -0.30305389f, -0.12675439f, -0.05056798f, -0.46862552f, -0.19947554f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.36278173f, 0.11306310f, 0.24076395f, 0.33987176f, 0.64884096f, 0.44214201f, -0.18235274f, 0.60107398f, 
    0.04802689f, 0.44738522f, 0.46669745f, 0.86954296f, 0.25419235f, 0.46319115f, -0.62030083f, 0.23671596f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.08593072f, 0.10678418f, 0.10635885f, -0.03433252f, -0.03776744f, 0.15899882f, -0.20743988f, -0.13802959f, 
    -0.20962368f, -0.37990355f, -0.13358606f, -0.14444366f, 0.58027315f, 0.11988910f, -0.44310811f, -0.35382792f, 
    0.01981777f, 0.11643092f, -0.12841050f, 0.21126612f, 0.07120170f, 0.02978592f, 0.07811113f, 0.09216655f, 
    -0.13289654f, -0.45649868f, 0.06183764f, -0.02052918f, -0.01509293f, -0.04700978f, -0.03414327f, -0.08258790f, 
    -0.04602684f, 0.01366760f, -0.09316922f, 0.14419173f, -0.54024816f, 0.14312011f, -0.45109147f, 0.17095277f, 
    -0.10353256f, -0.01049405f, 0.14512120f, -0.04990673f, -0.16891387f, 0.06151863f, -0.01708192f, -0.08415157f, 
    -0.46485820f, -1.03269386f, -1.04234266f, 0.16024739f, 0.08260036f, 0.01750796f, -0.17336948f, -0.08830600f, 
    -0.19504826f, 0.00194417f, -0.38393083f, -0.15559393f, -0.40392226f, -0.06873816f, 0.05501975f, 0.09598503f, 
    0.13993733f, 0.08021107f, 0.04116305f, 0.07372259f, -0.00977377f, 0.06241732f, -0.17498699f, -0.00255954f, 
    0.45867461f, 0.34331366f, -0.29598692f, -0.23092057f, 0.05485481f, 0.11881674f, -0.07702717f, 0.23486231f, 
    -0.05536360f, -0.01049208f, -0.07690058f, 0.02433406f, -0.64109403f, 0.16968840f, 0.12000592f, -0.28525528f, 
    -0.42174801f, 0.04600929f, -0.09780987f, -0.08064447f, 0.05135022f, -0.11564316f, -0.00982227f, 0.01804906f, 
    0.67525691f, 0.47759944f, -0.41278705f, -0.07886939f, 0.05508723f, -0.07814407f, -0.06932659f, -0.11459361f, 
    -0.04645558f, -0.02716555f, 0.12684003f, -0.02392804f, 0.00010524f, 0.23274772f, -0.02389304f, -0.17612502f, 
    -0.27862445f, -0.30738491f, -0.04087381f, 0.06478460f, 0.05162856f, -0.06691733f, 0.04951455f, -0.03321548f, 
    -0.12111678f, 0.25608933f, 0.13567950f, -0.00905167f, 0.00785081f, 0.19108371f, 0.06245016f, 0.07835509f, 
    0.21314701f, 0.11564803f, 0.03399043f, 0.04519589f, -0.60785645f, -0.93659323f, -0.84056294f, 0.12111518f, 
    0.06492373f, 0.03791529f, -0.08898804f, 0.00849431f, -0.12206726f, -0.06556787f, -0.06101030f, 0.01347171f, 
    -0.18715514f, -0.25195906f, 0.61270106f, -0.26873675f, -0.28117657f, -0.21668439f, -0.25985917f, 0.02950279f, 
    -0.08581459f, -0.04707519f, -0.11801504f, 0.13477603f, -0.06631045f, -0.58177489f, -0.27546075f, -0.05254016f, 
    0.09447010f, 0.03952323f, -0.00556358f, 0.01942632f, 0.11261348f, -0.13332483f, -0.06325282f, -0.17754278f, 
    0.73856342f, 0.59735888f, 0.04325408f, -0.30299169f, 0.08565492f, 0.22094607f, 0.07845873f, 0.42585725f, 
    0.01731621f, 0.09625215f, -0.09918673f, -0.09512685f, -0.18358870f, 0.36115333f, 0.16401611f, -0.27302599f, 
    -0.33534351f, 0.10310104f, -0.12424306f, 0.15841064f, -0.08726265f, -0.10614228f, -0.12347150f, -0.12042831f, 
    -0.26562932f, -0.00069902f, -0.08795709f, -0.09771903f, 0.03011751f, 0.09778330f, 0.13643937f, 0.18237413f, 
    -0.22350338f, 0.10100705f, 0.04166704f, -0.03981965f, 0.04870460f, -0.01070707f, 0.11017276f, -0.06611551f, 
    -0.02709465f, -0.06651797f, -0.06867244f, -0.36521381f, -0.07130834f, 0.10322253f, -0.05952001f, 0.07874753f, 
    -0.99537253f, -0.43119603f, 0.29693097f, -0.43339679f, 0.01960470f, 0.15329053f, -0.23336869f, -0.11593417f, 
    -0.03860384f, -0.02104836f, -0.23890042f, 0.07865445f, 0.24099554f, -0.49325061f, 0.04094848f, 0.02335290f, 
    -0.19704999f, 0.16441025f, -0.14894474f, 0.03756455f, -0.08394032f, 0.07403651f, -0.00219796f, -0.02569145f, 
    1.53598213f, -0.39241812f, -0.20323928f, -0.21833935f, -0.02407113f, -0.03039631f, 0.07273912f, -0.05480291f, 
    0.07228165f, 0.08825184f, -0.08202614f, -0.02725053f, 0.09767416f, 0.15465863f, 0.25134942f, 0.25870526f, 
    0.05314357f, -0.07815662f, -0.08016349f, -0.06277180f, -0.01709631f, 0.16252132f, 0.00524119f, -0.05097098f, 
    -0.30310071f, 0.08266369f, 0.10783118f, 0.14814897f, -0.10250778f, 0.34396020f, -0.07891466f, 0.19694857f, 
    -0.00151493f, 0.02486963f, -0.01419035f, 0.17087455f, -0.46127605f, 0.54908609f, 0.15910934f, 0.29395282f, 
    0.00139184f, 0.18218988f, 0.06512270f, -0.56770188f, 0.08011061f, 0.15053785f, -0.02274502f, -0.04311758f, 
    -0.03323908f, -0.31931382f, -0.39267340f, -0.59952658f, -0.28630707f, -0.24639516f, 0.14777042f, 0.04970289f, 
    -0.02739712f, 0.03409272f, -0.12156707f, 0.04957475f, -0.05143489f, 0.12937208f, -0.03130434f, -0.09571482f, 
    0.07951062f, -0.12166376f, 0.09367178f, 0.07374828f, 0.01306336f, -0.02470268f, -0.01669517f, 0.04284244f, 
    -0.21670298f, -0.11134689f, -0.10281496f, -0.07589370f, -0.02702114f, 0.06775760f, -0.07301449f, -0.14615102f, 
    -0.01065518f, 0.00123089f, -0.22839670f, 0.14363600f, 0.77198225f, 0.23304638f, 0.31671616f, 0.01249686f, 
    -0.17517383f, -0.15359834f, 0.08251212f, 0.05804285f, -0.01091815f, 0.01531784f, -0.03012056f, 0.02997317f, 
    -0.61364418f, -0.24621201f, -0.01643953f, -0.68828583f, 0.05460885f, -0.07657115f, -0.11822416f, -0.16471758f, 
    -0.09510515f, -0.10222145f, -0.06788084f, 0.07798956f, 0.39817730f, 0.61909842f, 0.29413670f, 0.01947788f, 
    -0.07700064f, 0.04976259f, -0.04055517f, -0.07037409f, 0.12012832f, -0.08439046f, 0.03955040f, -0.10634681f, 
    0.52774018f, 0.50827986f, 0.20265308f, 0.20667955f, 0.18719323f, -0.21975076f, -0.12882391f, 0.12259616f, 
    0.01580961f, -0.03218496f, -0.07968812f, -0.13310333f, -0.24881186f, 0.21579105f, 0.04229975f, -0.21842910f, 
    0.28124616f, -0.09937505f, -0.17965001f, 0.13232113f, -0.05607740f, 0.04152903f, 0.09289604f, -0.34400287f, 
    0.02257683f, -0.16979012f, 0.00047276f, 0.23211458f, 0.14698401f, 0.03302925f, -0.05172678f, 0.09478515f, 
    -0.14989966f, -0.32315445f, -0.29111516f, -0.16749279f, -0.63238937f, -0.64234710f, -0.08715244f, -0.70643258f, 
    0.13351867f, 0.11464493f, -0.11561897f, -0.14603096f, 0.04467794f, 0.08044183f, -0.00419327f, 0.07131281f, 
    0.07224233f, 0.74707836f, 0.01962982f, 0.27183509f, 0.01047619f, 0.14994729f, 0.02394906f, -0.21656916f, 
    0.01395865f, 0.19734123f, 0.01005385f, 0.20330042f, -0.00815674f, -0.78941470f, 0.16524597f, -0.32710561f, 
    0.14880587f, -0.09188296f, -0.19554015f, 0.14388049f, -0.03561651f, -0.18567881f, 0.09713243f, -0.02719707f, 
    -0.62529290f, 1.00083601f, 0.37691918f, -0.13195911f, -0.06633868f, 0.14407389f, -0.19316962f, -0.03722673f, 
    0.10739272f, 0.17425260f, -0.21890159f, 0.20143706f, -0.12833597f, -0.14030810f, -0.04721402f, -0.02606553f, 
    0.00647192f, -0.10582402f, 0.07399815f, 0.00884381f, -0.07141551f, -0.21183348f, -0.00895795f, 0.24763177f, 
    -1.47241926f, 0.03935379f, -0.30559430f, -0.31994075f, 0.02608580f, 0.03630047f, 0.13160419f, -0.24691924f, 
    -0.05408625f, 0.02772324f, -0.03501495f, -0.04637580f, 0.04712959f, 0.49713254f, -0.17590861f, 0.14212692f, 
    0.04294083f, 0.02132452f, 0.09983532f, -0.24644487f, -0.02087470f, 0.12817904f, 0.08423990f, 0.00211587f, 
    -0.14405231f, 0.18022142f, -0.32905200f, -0.40249705f, -0.11213558f, -0.34582397f, 0.34646618f, 0.16593485f, 
    -0.06098165f, -0.00493091f, -0.06256661f, -0.10187863f, -0.14886609f, -0.17835310f, 0.08064231f, -0.13743956f, 
    0.15703851f, 0.02500217f, 0.10701867f, 0.09590001f, -0.03508572f, -0.11168514f, -0.08105978f, -0.07740112f, 
    0.24042612f, 0.12780876f, 0.06002843f, 0.37954482f, 0.04001416f, -0.00556316f, 0.16357435f, 0.03679710f, 
    0.01436353f, 0.13442719f, -0.05192668f, 0.22411625f, -0.29261032f, -0.21795440f, 0.33096376f, -0.87541568f, 
    0.06127282f, -0.12906390f, -0.01078329f, 0.07908926f, 0.05551584f, -0.11906906f, 0.14041404f, -0.08460570f, 
    -0.75370580f, -0.48600179f, -0.14395225f, -0.46132705f, 0.19902639f, -0.02222821f, -0.03890649f, -0.10009787f, 
    0.11921422f, -0.12996647f, 0.03440929f, 0.16580114f, -0.33835533f, -0.11101981f, 0.01546601f, -0.43035081f, 
    0.08474451f, 0.04258791f, -0.12106911f, 0.07040998f, 0.03340565f, -0.19956514f, 0.08090436f, -0.52703846f, 
    -0.79120493f, -0.12038867f, 0.71295172f, 0.73193473f, -0.19231692f, -0.23774336f, -0.42108837f, 0.02494804f, 
    -0.07400136f, -0.08628548f, 0.02262057f, 0.03784035f, 0.91098487f, 0.62573069f, 0.30986822f, 0.69273192f, 
    0.07928953f, 0.12131334f, -0.12606888f, -0.00056808f, -0.20382431f, 0.05647400f, -0.32105452f, -0.02297922f, 
    0.46792904f, 0.04599714f, -0.10195433f, 0.29979470f, 0.23483615f, -0.19643930f, -0.01011672f, 0.02759080f, 
    -0.01106027f, 0.20766225f, -0.12576146f, -0.01361092f, -0.03820385f, -0.70560068f, 0.15284581f, 0.36418974f, 
    -0.14878003f, 0.08927329f, -0.05500855f, -0.00855444f, 0.08088108f, 0.01706177f, -0.03613739f, 0.03148092f, 
    0.33203849f, 0.10042685f, 0.02662064f, 0.50293303f, 0.00941133f, 0.03858969f, -0.33717823f, -0.11167406f, 
    -0.14039655f, -0.07832694f, 0.00383655f, 0.10365113f, 0.02362892f, -0.29110873f, -0.78160155f, -0.00681481f, 
    -0.01368336f, -0.11888324f, -0.18579093f, -0.35441184f, -0.11251640f, -0.13299581f, -0.05316124f, -0.18836384f, 
    -0.60801625f, 0.33651805f, -0.09482265f, 0.68786567f, 0.11725199f, 0.12042795f, 0.10289792f, -0.03987183f, 
    0.00260550f, -0.03126547f, 0.11100149f, -0.05565575f, -0.34459344f, 0.14259680f, -0.06198339f, -0.37729067f, 
    -0.46975589f, 0.24048446f, -0.27532676f, 0.19136198f, 0.13896850f, -0.13433754f, 0.17102817f, -0.05856721f, 
    0.11917786f, -0.26803449f, -0.12793915f, 0.10540732f, 0.17461519f, 0.04367870f, 0.09459762f, 0.00881782f, 
    -0.05632833f, -0.08919281f, 0.17879535f, -0.11414192f, -0.15675232f, -0.43986493f, -0.40508845f, -0.66565603f, 
    -0.26069272f, -0.25473347f, -0.07110560f, -0.02145856f, -0.14914384f, -0.01478350f, -0.30095103f, -0.33545372f, 
    -0.37310439f, 0.34281981f, -0.02477684f, 0.29650128f, 0.25014189f, 0.04445759f, -0.07355817f, -0.00790712f, 
    -0.09364914f, 0.01401494f, 0.10466405f, 0.25960559f, 0.31347868f, 0.23795642f, 0.50583470f, 0.01824161f, 
    -0.47433621f, -0.30441526f, -0.00420714f, -0.14745276f, -0.32117093f, 0.05307185f, -0.21614730f, 0.03292263f, 
    1.09972823f, -0.41766638f, -0.14809051f, -0.43419930f, 0.44077176f, 0.02200180f, 0.09011405f, -0.08352945f, 
    -0.49868682f, 0.02494173f, -0.02345821f, -0.03052109f, -0.37669596f, -0.29132342f, 0.48003772f, 0.00586880f, 
    -0.02861884f, -0.18550782f, -0.36429614f, -0.17313910f, 0.11111722f, -0.14239672f, 0.06988443f, -0.09062865f, 
    0.35051456f, 0.05868763f, 0.09704180f, 0.10117634f, 0.07066121f, -0.35865852f, -0.21449162f, 0.02696882f, 
    0.04396780f, 0.14247851f, -0.09063140f, 0.09197595f, 0.19557442f, -0.56637841f, -0.29251549f, 0.20642968f, 
    0.22691645f, 0.35820955f, -0.16353413f, 0.07741981f, -0.13420630f, 0.09809303f, 0.21549591f, -0.28482494f, 
    0.08807476f, -0.33535454f, -0.14972755f, 0.17645666f, 0.09751926f, 0.09283527f, 0.14494501f, -0.11550741f, 
    -0.10683279f, 0.22335139f, 0.10402093f, 0.02569788f, 0.76547176f, -0.29730287f, 0.22092845f, 0.25403830f, 
    -0.09645405f, 0.04703886f, -0.23947681f, -0.13356365f, -0.01551474f, -0.07918133f, 0.09029608f, 0.01514093f, 
    0.30157310f, 0.26495647f, 0.07283180f, 0.16740872f, -0.24141577f, -0.19036020f, -0.12568837f, -0.11328509f, 
    0.19065723f, -0.47897214f, -0.17938602f, -0.01078614f, 0.19137663f, 0.71258742f, 0.30868095f, 0.21297617f, 
    0.08445734f, 0.02053560f, 0.09506273f, 0.09874621f, 0.03202931f, -0.08137527f, 0.11069651f, -0.11761655f, 
    -0.14253126f, -0.07513098f, 0.05337437f, -0.06310698f, -0.09979217f, -0.02673740f, 0.07392234f, -0.18104272f, 
    0.27453935f, -0.09672543f, 0.21397558f, 0.02281357f, -0.46308115f, -0.00809340f, -0.13684809f, 0.18149789f, 
    0.27461791f, -0.08213093f, 0.17637858f, -0.04341493f, 0.01202414f, -0.25111115f, -0.01549385f, -0.11479150f, 
    -0.36510679f, -0.27380300f, 0.12553395f, -0.25697890f, 0.19573188f, -0.08797767f, -0.21955954f, 0.11864804f, 
    -0.08595608f, -0.28420806f, -0.17302144f, -0.07296087f, 0.13950844f, -0.16826732f, -0.12386342f, 0.02958034f, 
    0.11368779f, 0.03630179f, 0.06938589f, 0.05574097f, 0.06961034f, 0.16826284f, 0.00608045f, 0.25210249f, 
    0.20407441f, 0.20887651f, 0.40676311f, 0.29754695f, -0.02906338f, -0.06837492f, 0.03242236f, 0.11743311f, 
    0.09138119f, -0.02378814f, 0.12145863f, 0.01392640f, -0.48286134f, -0.17491835f, -0.02084871f, -0.45453641f, 
    -0.40232575f, -0.06913366f, -0.01737495f, 0.27748606f, -0.07503082f, -0.22224417f, -0.16232368f, -0.23340574f, 
    0.31112573f, -0.19479679f, 0.26231000f, 0.41676891f, 0.15800604f, 0.01525231f, 0.14512804f, 0.13752593f, 
    -0.08346825f, 0.03229404f, -0.00983162f, -0.03633817f, 0.02057613f, -0.18417856f, -0.04421087f, 0.37944347f, 
    0.14835405f, 0.14157417f, 0.08790920f, 0.12927502f, 0.02732022f, -0.05625864f, -0.01400011f, -0.18998760f, 
    -0.31797257f, -0.12675539f, -0.16463548f, 0.14195818f, -0.28114116f, -0.07558896f, 0.00668969f, 0.19181105f, 
    0.10193919f, -0.09893470f, -0.07454390f, -0.04919817f, -0.13440123f, -0.16159990f, -0.98373181f, -0.14892769f, 
    0.17574085f, 0.12415248f, 0.03682711f, -0.04855214f, 0.00033947f, -0.11171928f, -0.01215157f, -0.23182675f, 
    -0.15374091f, 0.22030199f, -0.03520685f, 0.45095897f, -0.23702717f, -0.13656686f, -0.15643162f, 0.10423876f, 
    0.12335606f, -0.01133655f, 0.05219045f, -0.23306605f, -0.14503685f, -0.07497673f, -0.11382913f, -0.27942482f, 
    0.14939594f, 0.05416523f, 0.11548796f, 0.10054450f, -0.03949708f, -0.20132492f, -0.07055459f, -0.43127203f, 
    -0.37969106f, -0.38505542f, -0.02352643f, 0.13133462f, -0.16761321f, 0.08340327f, -0.03452212f, -0.13587436f, 
    -0.02100841f, -0.01736042f, 0.05690327f, 0.04497954f, -0.24872160f, 0.02494884f, -0.39477488f, 0.16184953f, 
    0.00306065f, -0.03335931f, 0.12759224f, -0.35295287f, -0.10744531f, -0.23670383f, 0.21687892f, 0.14198831f, 
    -0.26931393f, -0.24335814f, -0.10127030f, -0.06959506f, -0.11430150f, 0.08289784f, -0.18249434f, -0.13160993f, 
    0.21457422f, 0.21557733f, 0.19432318f, 0.08350591f, -0.04431429f, 0.17439193f, 0.03380767f, -0.25607744f, 
    0.10571913f, 0.08836195f, 0.05589958f, -0.00706728f, -0.06637274f, -0.07193712f, 0.18167834f, 0.00337259f, 
    0.25879240f, -0.15379347f, -0.50198293f, -0.00138577f, -0.07457103f, -0.22109716f, 0.01491037f, 0.15996467f, 
    -0.14025675f, -0.23130661f, -0.14521836f, -0.16686480f, 0.62017035f, 0.53137952f, -0.08450784f, -0.54420996f, 
    -0.01358593f, -0.15431032f, 0.01831808f, 0.13641869f, 0.26773989f, -0.03225369f, -0.04671020f, -0.04901527f, 
    -0.16485372f, -0.36334801f, -0.65627575f, -0.36746818f, 0.01810155f, -0.11803645f, -0.14359374f, -0.00717176f, 
    0.22981459f, -0.09006237f, 0.07648334f, 0.03256945f, -0.14103511f, -0.17978133f, -0.01830869f, 0.01555102f, 
    0.12331490f, -0.07254355f, -0.07879779f, -0.11233472f, 0.02205451f, -0.08353467f, 0.14693651f, -0.10858466f, 
    0.10615306f, 0.23579016f, 0.01409284f, 0.09835024f, 0.19997241f, -0.03594459f, 0.04705380f, -0.54822111f, 
    0.12726000f, 0.02995404f, -0.08294421f, -0.03721686f, 0.78379619f, -0.28698522f, 0.20246701f, 0.26931763f, 
    0.31896487f, -0.09359889f, -0.26433095f, 0.20472853f, 0.07706609f, -0.04192334f, -0.07948999f, 0.21853432f, 
    -0.11172518f, 0.25517744f, 0.28952652f, -0.30378321f, 0.06436076f, 0.11585572f, 0.18245596f, 0.33341888f, 
    0.13319255f, -0.02364398f, -0.07967818f, -0.01939734f, -0.08942305f, 0.01841044f, 0.00336753f, 0.05485987f, 
    0.25760442f, 0.20274213f, -0.19058654f, -0.06156849f, 0.08889621f, -0.02040521f, 0.06587093f, 0.09768116f, 
    -1.11708677f, 0.11667816f, -0.22040135f, 0.15949817f, -0.06429842f, -0.13854402f, -0.01835157f, 0.14605516f, 
    0.00645740f, -0.32165131f, 0.00831308f, -0.00743477f, -0.04359935f, -0.19639768f, -0.92538011f, 0.26888305f, 
    0.16208357f, 0.13677479f, 0.01110453f, -0.08638968f, 0.23467498f, 0.01036528f, 0.00527826f, 0.00677637f, 
    0.44284055f, 0.09510320f, -0.21772102f, 0.33954442f, 0.27487427f, 0.17840271f, 0.02295407f, -0.13523676f, 
    0.07590435f, -0.06494986f, 0.09613381f, -0.10105209f, -0.50300902f, -0.38751757f, -0.45906487f, 0.53409040f, 
    0.02935440f, 0.00732210f, 0.05092880f, -0.06584354f, -0.13014321f, 0.08856483f, 0.10376947f, 0.69374859f, 
    -0.54951334f, 0.11601403f, 0.25300598f, -0.46725377f, -0.02543922f, -0.06214954f, 0.12696762f, -0.05724836f, 
    0.01285578f, -0.02062608f, 0.05654751f, 0.13466330f, -0.43788287f, 0.07804678f, 0.21676841f, 0.03253902f, 
    0.08042248f, -0.11913849f, 0.08502895f, 0.20125170f, 0.05088358f, 0.06810161f, -0.50102800f, -0.26959270f, 
    -0.28311095f, 0.08996977f, 0.07880113f, 0.08391234f, -0.10639088f, -0.30638057f, -0.17290829f, -0.01817553f, 
    0.00128306f, -0.14314878f, -0.12310605f, 0.02180401f, -0.69087607f, -0.57696652f, -0.50085926f, -0.07264037f, 
    -0.10303410f, -0.06879023f, -0.12553014f, -0.22258689f, 0.06210630f, -0.08850955f, -0.06686042f, -0.13320762f, 
    0.91155195f, 0.66249436f, -0.17972144f, 0.17322221f, -0.12031210f, -0.00235389f, -0.00635577f, 0.27356824f, 
    0.12539545f, 0.33952969f, 0.17560986f, 0.02299494f, 0.14294653f, -0.21797369f, 0.09093957f, 0.18277961f, 
    0.06661018f, 0.10577504f, 0.11082559f, 0.09163310f, 0.03992927f, 0.10951655f, -0.12642884f, -0.19208801f, 
    0.54833722f, 0.69921845f, -0.14681588f, 0.12495007f, -0.00597397f, 0.07133467f, 0.23818038f, -0.18009187f, 
    0.14843462f, 0.14679027f, 0.24574035f, -0.00214251f, 0.09363109f, 0.06866539f, -0.14703602f, -0.04832046f, 
    0.07752752f, -0.02362691f, 0.01394472f, 0.09498905f, -0.22658455f, -0.26796690f, -0.10149329f, -0.22449809f, 
    -0.96960676f, -0.86102176f, -0.09260976f, -0.52791357f, -0.25798693f, -0.08251839f, -0.27805293f, -0.38099569f, 
    -0.02429216f, -0.01905080f, 0.04029393f, -0.01504956f, 0.37028781f, 0.35036927f, -0.94768298f, 0.50042051f, 
    -0.30320689f, -0.13349035f, 0.19664469f, 0.56525660f, -0.10566735f, -0.04287235f, 0.03319930f, 0.04513173f, 
    -1.10897946f, -1.29619956f, -0.23718150f, 0.61846429f, 0.23457585f, 0.01403018f, -0.02188092f, -0.38063496f, 
    -0.04361412f, 0.03970745f, 0.00520529f, 0.10835957f, -0.40064451f, -0.30970809f, -0.23486950f, -0.18860967f, 
    -0.39820090f, 0.19011821f, -0.09669909f, -0.10227595f, -0.07905994f, 0.04920996f, -0.11864776f, -0.13393092f, 
    -0.37382701f, 0.00808133f, 0.28445545f, 0.39428151f, 0.02268899f, 0.02344288f, 0.04099982f, 0.04780217f, 
    0.04097406f, 0.10764785f, 0.32755670f, -0.01890468f, 0.21845092f, 0.03927113f, 0.18558735f, -0.52149516f, 
    -0.00097415f, 0.03130116f, 0.00910006f, -0.01885677f, -0.03719244f, 0.02926419f, -0.12348922f, 0.11408530f, 
    0.39268708f, -0.75100225f, -1.17915082f, -1.09852087f, -0.34065080f, 0.30739921f, 0.34890547f, 0.14150508f, 
    0.01955993f, 0.41165963f, -0.18601644f, -0.13908279f, -0.11325245f, 0.23277915f, 0.01504539f, -0.24201684f, 
    0.07346271f, -0.14411874f, 0.20237021f, -0.19241880f, -0.15085182f, -0.09501292f, 0.02396256f, 0.30591598f, 
    -0.30172071f, -1.15992534f, -0.28645942f, -0.03136815f, -0.15613633f, -0.12660880f, -0.01179624f, -0.16716836f, 
    -0.10360060f, 0.07100364f, -0.00841658f, -0.04805283f, -0.75225705f, -0.93846250f, -0.15221050f, 0.28158394f, 
    -0.22059840f, -0.02113222f, 0.02009458f, -0.14267202f, -0.00352293f, -0.12453472f, 0.35565248f, 0.27946723f, 
    0.37287757f, 0.05028140f, -0.04457599f, -0.02062528f, -0.14193061f, -0.11519617f, 0.21014872f, -0.10608085f, 
    -0.04775539f, -0.11056636f, 0.02284777f, 0.15893565f, -0.85160136f, -0.30188581f, -0.24216834f, 0.08286458f, 
    0.10377226f, 0.16340138f, 0.09124238f, 0.19690658f, 0.06631362f, 0.07467225f, -0.07000588f, -0.10595629f, 
    -0.30155945f, -0.73717982f, -0.46679911f, 0.40272310f, -0.06498341f, -0.04337395f, 0.10113265f, -0.06286029f, 
    0.07943244f, 0.04587220f, 0.20308159f, -0.33141324f, -0.09757232f, 0.27363253f, 0.23936738f, -0.02793363f, 
    0.04863392f, -0.08451342f, -0.03660346f, -0.15268454f, -0.06243659f, -0.35897830f, 0.07676480f, 0.07599280f, 
    -0.69837093f, -0.22327551f, 0.07233215f, 0.27576557f, 0.09227081f, -0.06165464f, 0.26945075f, -0.12854294f, 
    -0.28293872f, 0.04746334f, -0.01058785f, -0.13723463f, 0.19240056f, 0.09886317f, 0.22149973f, -0.17189653f, 
    -0.12883565f, 0.01083710f, -0.10198181f, -0.01968217f, 0.17187552f, -0.06223674f, -0.20310436f, -0.09646188f, 
    -0.72263855f, -0.63892585f, -0.75689280f, 0.90328133f, 0.12679985f, -0.19507609f, 0.12880644f, -0.02424155f, 
    -0.03844848f, -0.07376562f, 0.09129475f, 0.00382814f, -0.04665678f, -0.17140526f, -0.13885634f, 0.04323768f, 
    0.20758407f, 0.13893290f, -0.09113795f, -0.54989147f, -0.13718326f, 0.11865403f, -0.04461597f, -0.08512779f, 
    -0.26414365f, -0.63178897f, 0.14678928f, 0.02325521f, 0.06917215f, -0.06376515f, -0.17815761f, 0.13307011f, 
    -0.06044324f, -0.02037483f, 0.14510013f, 0.00015671f, 0.21963371f, 0.10449674f, 0.10003972f, 0.00345870f, 
    0.07520346f, 0.10727557f, -0.12996717f, 0.06617454f, -0.07107347f, -0.09071445f, -0.03230721f, 0.03569718f, 
    1.27964962f, -0.25912926f, -0.19614150f, -0.40253693f, 0.09045610f, -0.15789759f, -0.17017299f, -0.27791229f, 
    -0.06447132f, -0.06374899f, -0.01086833f, -0.13999936f, -0.08678115f, 0.39893469f, -0.24515715f, -0.08246833f, 
    0.01891700f, 0.13306871f, -0.00947863f, -0.00491681f, 0.07682458f, -0.09239439f, 0.02872900f, -0.21278788f, 
    -0.35923085f, -0.32179558f, -0.54047167f, 0.58994466f, -0.23589624f, -0.15295197f, -0.06330109f, 0.02430460f, 
    0.07775847f, -0.02508598f, -0.00422838f, 0.00112184f, 0.09715728f, -0.05714147f, 0.07552416f, -0.07937081f, 
    -0.05963922f, 0.05644551f, -0.10732739f, -0.00481735f, 0.00054909f, 0.11058065f, -0.20995881f, -0.03713238f, 
    0.14848004f, -0.74094355f, -0.37928438f, -1.29910767f, -0.01328484f, 0.07015831f, -0.23909460f, 0.45398766f, 
    0.06806128f, -0.07066336f, -0.11357610f, -0.08382012f, 0.17278072f, -0.08971985f, -0.31278831f, 0.46115863f, 
    -0.13097952f, 0.42789283f, -0.21818255f, -0.04400617f, -0.00305036f, 0.06392552f, 0.15299839f, 0.16468178f, 
    -0.37972161f, -0.40130800f, -0.26830921f, -0.12724519f, 0.07678131f, 0.26498461f, 0.28319508f, -0.08462546f, 
    0.05646255f, 0.17056845f, 0.10826004f, 0.25036019f, -0.81987357f, -0.43300802f, -0.07685439f, 0.09463625f, 
    0.08036292f, -0.00294809f, 0.13184097f, -0.06853502f, 0.00489927f, -0.07698704f, -0.02050431f, 0.13158202f, 
    -0.65606713f, -0.03106385f, -0.31097120f, 0.00795335f, 0.20468405f, 0.20932750f, 0.03140200f, 0.09597228f, 
    -0.33321008f, -0.13844614f, -0.53294224f, -0.12379168f, -1.09985805f, -0.15286268f, 0.47840562f, -0.04301257f, 
    -0.09666785f, 0.03722026f, -0.16520035f, -0.27381182f, -0.07082880f, 0.17032127f, -0.04539541f, 0.12169194f, 
    -0.96039498f, -0.01329052f, 0.55121607f, 0.30741230f, -0.09074961f, 0.07981925f, -0.10993529f, -0.15905209f, 
    0.12706380f, 0.16509657f, -0.11571467f, 0.35367876f, -0.02782281f, 0.13759497f, -0.15884769f, -0.46368158f, 
    0.05928258f, -0.19292530f, 0.03929393f, -0.18525463f, -0.30303875f, -0.04967004f, -0.25768477f, -0.03657880f, 
    -0.52339542f, -0.76379734f, -1.12173021f, -0.54837072f, -0.00866196f, -0.10529797f, 0.12789716f, -0.15071122f, 
    0.10837022f, -0.04782284f, 0.00527624f, 0.01234038f, 0.86939758f, 0.27526221f, -0.11178517f, 0.00110229f, 
    0.36611873f, -0.12986498f, -0.05520479f, 0.14849782f, 0.13825148f, 0.10040631f, 0.16433273f, 0.47970530f, 
    0.64368039f, 0.98910773f, -0.07909963f, -0.31521297f, -0.48751748f, -0.13961190f, -0.00079458f, -0.53869581f, 
    -0.08070683f, 0.00795177f, -0.13332759f, -0.00813152f, -0.03449682f, 0.37174776f, 0.12339803f, 0.03222405f, 
    0.22366412f, -0.36210790f, -0.18453176f, 0.10070866f, 0.12749045f, 0.21332838f, 0.16743429f, 0.16657361f, 
    -0.08377641f, -0.28013659f, -0.61612791f, -0.40397596f, -0.19973199f, 0.01324066f, 0.07805307f, 0.05132909f, 
    0.19471611f, 0.14010906f, -0.01524025f, -0.18767892f, -0.95852184f, 0.12264378f, 0.07884991f, 0.53490746f, 
    -0.06875332f, -0.18208227f, -0.19839083f, 0.19875655f, 0.01278167f, 0.06545430f, -0.01507309f, 0.12198120f, 
    0.50441754f, 0.32054314f, -0.37139896f, 0.07140852f, 0.12736987f, 0.05754052f, -0.03623905f, 0.02962910f, 
    -0.13749765f, -0.06224613f, -0.05514135f, -0.04716665f, -0.30393347f, 0.32010362f, 0.14947389f, 0.32981774f, 
    -0.23482221f, -0.26158121f, 0.05436711f, -0.07361663f, -0.03027631f, 0.21186724f, 0.23701480f, 0.15275359f, 
    0.28884351f, -0.02368762f, -1.49012649f, -0.11697857f, 0.15346061f, -0.30313477f, 0.15325153f, -0.12424013f, 
    -0.09294219f, 0.00522279f, -0.02656681f, 0.14088520f, -0.21692668f, 0.02234108f, -0.31948775f, 0.13411571f, 
    0.15634242f, 0.05259151f, 0.01046768f, 0.14215118f, 0.16969238f, 0.10335295f, -0.03916089f, -0.22961901f, 
    0.04533395f, 0.41680726f, 0.18411356f, 0.04656630f, 0.19885446f, -0.34182611f, -0.09315240f, -0.10086749f, 
    -0.25455573f, -0.18707606f, -0.02310731f, 0.08089971f, -0.03590313f, 0.30911088f, 0.06202156f, -0.46049660f, 
    0.03667805f, 0.05131197f, 0.14194886f, 0.33590007f, -0.03778364f, 0.05778581f, 0.00768713f, -0.08928097f, 
    -0.39409250f, 0.72935939f, 0.41035941f, -0.41607782f, 0.01902060f, -0.53574079f, 0.06885897f, -0.13557337f, 
    -0.02197935f, 0.14779511f, 0.10023581f, 0.19152629f, 0.05244865f, -0.49236187f, -0.20554809f, -0.93114257f, 
    -0.03764285f, -0.17705540f, -0.24339247f, -0.04801336f, -0.05200487f, 0.14265694f, -0.03646629f, 0.11689620f, 
    0.08468514f, 0.09762891f, 0.70798838f, -1.02002978f, 0.17336985f, -0.24672586f, 0.18908517f, -0.00056740f, 
    -0.07602381f, 0.07741401f, 0.00517757f, -0.18353567f, -0.11895183f, -0.39832455f, -0.23177981f, 0.31114221f, 
    0.11623192f, 0.38937005f, 0.18092953f, -0.14450036f, 0.16099951f, 0.18043715f, 0.16333273f, -0.06728118f, 
    -0.68544221f, -0.04048963f, 0.10086150f, -0.22532482f, 0.14680807f, -0.25042695f, 0.16703407f, 0.47543094f, 
    0.05770782f, 0.00755633f, 0.00869207f, -0.05188834f, -1.14247239f, -0.03580509f, -0.09972320f, -0.34072345f, 
    0.47580841f, -0.47701934f, 0.16342874f, -0.45556018f, -0.08866164f, -0.09668770f, 0.16982193f, -0.22620350f, 
    -0.37259215f, -1.38833809f, 0.32866940f, -0.49687189f, 0.02667052f, 0.31826013f, -0.31294614f, 0.30028766f, 
    0.07174776f, -0.10358651f, 0.05356900f, -0.06344233f, -0.47998756f, -0.12456486f, -0.76060849f, 0.06907980f, 
    0.15588908f, 0.07077125f, 0.09021606f, 0.08133134f, -0.09762114f, -0.26679802f, -0.04016516f, -0.17284681f, 
    0.04988850f, 0.43502143f, 0.75327516f, 0.28927407f, 0.15199804f, 0.00648951f, -0.27702597f, -0.29356825f, 
    0.05580657f, -0.10087211f, 0.14772804f, 0.05474359f, -0.15005881f, -0.04244678f, -0.29661617f, -0.03165041f, 
    -0.03225528f, 0.01411200f, 0.21078484f, 0.24551651f, -0.12305139f, 0.12172151f, -0.08502303f, 0.09006350f, 
    -0.46805039f, 0.36544937f, -1.41555357f, 0.45506009f, -0.03467919f, 0.14793333f, 0.05663621f, -0.05465690f, 
    0.21268032f, -0.03897968f, -0.12575381f, 0.00129988f, 0.05495461f, -0.31385279f, -0.18427990f, 0.21290015f, 
    0.01603609f, -0.02477575f, 0.09235622f, -0.05522171f, 0.06819312f, 0.31700706f, -0.21293144f, -0.01164152f, 
    0.07969622f, -0.46620327f, -0.06235112f, 0.07902633f, -0.03346317f, -0.03879128f, -0.17478612f, 0.03018251f, 
    0.19312666f, 0.03565038f, 0.08398303f, 0.02924635f, -1.16773522f, 0.22307879f, -0.38600856f, -0.07821662f, 
    -0.11935919f, 0.02333320f, -0.19250965f, 0.07514172f, 0.09084290f, -0.03693552f, 0.26652074f, 0.31553042f, 
    0.34629175f, 0.01648067f, 0.21887602f, -0.25923425f, -0.22585489f, 0.22353536f, 0.28320238f, -0.09998596f, 
    0.06822351f, 0.26547980f, 0.39824164f, 0.09463435f, 0.00983992f, -0.02665243f, -0.02778295f, 0.12570594f, 
    -0.00895923f, -0.14390305f, -0.04496719f, -0.11617520f, 0.03003380f, 0.05114890f, -0.02682651f, 0.05513727f, 
    0.26629928f, -0.05252749f, 0.04836984f, -0.19416904f, 0.19224587f, -0.17952709f, 0.26567525f, -0.05921062f, 
    -0.19719422f, -0.35860443f, -0.27811098f, -0.19871053f, -0.08230262f, 0.43482539f, 0.85630226f, 0.33901513f, 
    0.14471494f, 0.26825878f, 0.33207834f, -0.18061021f, -0.11416859f, -0.04184746f, 0.01849084f, 0.37405688f, 
    0.03769287f, -0.10745641f, 0.11056601f, 0.06055405f, -0.12719642f, 0.13230589f, -0.11191402f, 0.00285645f, 
    -0.08583563f, 0.03020471f, -0.06383809f, -0.20686309f, -0.40266132f, -0.05499312f, -0.68434125f, -0.22552729f, 
    -0.67564982f, -0.26856449f, 0.08831295f, -0.34960306f, -0.38578132f, 0.01199693f, -0.23381814f, -0.03397971f, 
    -0.25343943f, -0.43072090f, 0.26450685f, -0.04305707f, -0.20338461f, -0.17815167f, -0.14513743f, -0.18218610f, 
    0.11651743f, 0.24172203f, 0.05851743f, -0.02595377f, -0.61662066f, 0.53504288f, 0.09794252f, 0.18308353f, 
    -0.50928581f, 0.21418101f, 0.23565887f, 0.75033957f, 0.14405906f, 0.00426019f, 0.34193829f, 0.03392205f, 
    -0.28386247f, -0.72474062f, 0.05599143f, 0.11886734f, -0.20823550f, 0.00575420f, -0.27709574f, -0.07974766f, 
    0.20028397f, -0.09553034f, -0.00026213f, 0.04575328f, -0.05355320f, 0.10918423f, -0.37146509f, 0.07789606f, 
    -0.38814014f, 0.29574984f, 0.15157081f, -0.04297580f, 0.13137498f, 0.04422754f, 0.11388754f, 0.13158201f, 
    -0.07082933f, -0.12056934f, 0.18112595f, -0.21511263f, 0.03495982f, -0.00667418f, -0.26883230f, -0.10933653f, 
    -0.27161300f, 0.04378018f, -0.19114490f, -0.27914318f, 0.29101798f, -0.53523254f, -0.01547303f, 0.32783994f, 
    -0.20457648f, -0.11807663f, -0.17328548f, 0.17105211f, -0.04212904f, -0.00411023f, -0.09928063f, 0.22694686f, 
    -0.70339245f, -0.66007203f, 0.79951555f, 0.00370933f, -0.23738608f, 0.25644562f, -0.03382839f, -0.11658869f, 
    -0.29527298f, -0.13816410f, -0.13602810f, -0.04134617f, 0.17276545f, 0.09935115f, 0.44475293f, -0.20378534f, 
    -0.17283674f, -0.08391287f, 0.15222180f, -0.09250218f, 0.25187409f, -0.07283701f, 0.03979889f, 0.45112625f, 
    -0.00202290f, -0.11485076f, -0.69161248f, 0.14091352f, -0.02103519f, -0.00843256f, 0.16655493f, -0.07360931f, 
    -0.09780499f, 0.07626734f, 0.01230180f, -0.21961096f, 0.71499813f, -0.56286639f, 0.40634724f, -0.27204138f, 
    0.05634721f, 0.06916076f, 0.25834620f, 0.11772498f, 0.02582482f, -0.03115411f, -0.24515742f, -0.15842830f, 
    -0.16388176f, -0.38360134f, 0.24486086f, -0.13066161f, 0.10065432f, -0.03942172f, -0.17984539f, 0.38430080f, 
    -0.04175976f, -0.10650859f, -0.52071023f, -0.45146841f, -0.02310254f, -0.25752711f, 0.09135617f, -0.02636439f, 
    -0.52437449f, -0.40331471f, -0.35853833f, -0.03212538f, 0.05895567f, -0.02420233f, -0.13986580f, -0.07223927f, 
    0.24504532f, -0.69992054f, 0.21680214f, -0.59211904f, 0.07532207f, 0.04665056f, -0.11646036f, 0.21622439f, 
    0.06615236f, 0.14493623f, 0.24372999f, 0.00214265f, 0.19218245f, 0.50283861f, -0.88568586f, 0.74294037f, 
    0.13220309f, -0.12783925f, 0.28651953f, 0.20183797f, 0.07554185f, -0.04882669f, 0.04864537f, -0.23367839f, 
    -0.58000511f, -0.13506670f, 0.03891350f, 0.18496378f, -0.07425465f, 0.16544491f, 0.21551220f, 0.37048396f, 
    -0.39923814f, 0.10952471f, 0.20855476f, 0.01443983f, 0.13472749f, -0.02972257f, -0.14528030f, 0.04115071f, 
    -0.15447399f, 0.18087681f, -0.00883029f, 0.14918859f, 0.01624260f, 0.03013291f, 0.14537019f, 0.04676401f, 
    -0.46410176f, -0.61860436f, 0.07123955f, 0.08365282f, -0.49087894f, -0.33210221f, -0.47181675f, 0.18578441f, 
    -0.05030736f, 0.10736398f, -0.11433205f, -0.07673588f, 0.99550331f, -1.51855516f, 0.44086429f, 0.05496284f, 
    0.17530486f, 0.13459021f, 0.17794862f, -0.00067174f, -0.15185805f, 0.03350088f, 0.17252243f, -0.25166994f, 
    -0.33619186f, 0.47362801f, -0.15935001f, 0.03348403f, -0.37176520f, 0.31485257f, -0.12332990f, -0.48160067f, 
    -0.02256419f, 0.09585113f, 0.03895522f, -0.02490775f, 0.30155683f, -0.26858455f, 0.06346471f, -0.23617335f, 
    -0.08851646f, -0.04495133f, -0.26750600f, -0.06764945f, -0.20953141f, -0.00286620f, -0.17574733f, -0.22228469f, 
    -0.87346834f, -0.29758367f, -0.17370667f, -0.18807858f, 0.31400460f, 0.20977597f, 0.00171627f, 0.05529775f, 
    -0.10698196f, 0.01648789f, 0.22416247f, 0.09653140f, 0.27393135f, 0.14659192f, 0.88490450f, -0.36869401f, 
    -0.12185323f, 0.03821645f, -0.06095931f, -0.09974724f, -0.14440805f, 0.20787837f, 0.21914206f, -0.03733483f, 
    0.73631197f, 0.37593135f, 0.61230075f, -0.26167929f, 0.28778213f, -0.04375676f, 0.12098116f, 0.22175044f, 
    -0.10662910f, -0.07931943f, 0.32477680f, -0.12094416f, 0.20619006f, -0.33318144f, 0.25318027f, -0.10534270f, 
    -0.09443420f, 0.09552916f, -0.16892077f, 0.05710950f, -0.13672249f, 0.04720094f, 0.03870914f, -0.13546178f, 
    -0.28711092f, -0.03043937f, 0.01061108f, 0.20264646f, -0.22418736f, 0.14727451f, 0.10920809f, -0.35118690f, 
    -0.04879051f, 0.03237123f, 0.24993350f, 0.07376269f, -0.04963424f, -0.17702542f, 0.13453449f, -0.66147488f, 
    0.09747832f, -0.13348006f, 0.36180067f, -0.30418816f, 0.19209962f, 0.02218724f, 0.09390096f, 0.20307887f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.25183660f, 0.10008742f, 0.09878527f, -0.31013936f, -0.11454047f, 0.08035816f, 0.00170439f, -0.32909736f, 
    0.18081222f, 0.15512352f, 0.00857665f, 0.09206043f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
