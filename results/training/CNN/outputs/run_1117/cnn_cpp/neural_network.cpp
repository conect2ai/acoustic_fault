#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.34174168f, -0.66816783f, 0.64440554f, -0.54516405f, -0.29808387f, -0.62507755f, 0.49724323f, 0.22927918f, 
    0.93223482f, -1.35433781f, -1.09852231f, 0.52038562f, -0.64821392f, 0.63092995f, -0.55755919f, 0.13702184f, 
    -0.25002581f, -0.19321021f, -0.00516522f, 0.31467372f, -1.22758770f, -0.28250352f, 0.86023772f, -0.33104655f, 
    0.31897482f, 0.13530277f, 0.47875687f, 1.38783395f, -1.02213180f, -0.74464142f, 0.30977848f, -0.55461133f, 
    -0.29376206f, -0.09833011f, -0.15046634f, 0.09471804f, 0.75538760f, -0.12285411f, 0.03906034f, 0.34304953f, 
    0.66836333f, -0.53208858f, -0.16704179f, -0.06392031f, 0.32295367f, 0.18500334f, 0.50705552f, 0.44157448f, 
    -0.32315639f, 0.72891366f, -0.78914279f, -0.35166809f, -0.36034796f, -0.56930864f, 0.90723908f, -1.17820668f, 
    -0.83957052f, -0.91785008f, -0.52364326f, -1.25437856f, -0.15798351f, 0.33377120f, 0.18794620f, -0.33655894f, 
    1.34766603f, -0.62620705f, -0.06325230f, 0.39256379f, 0.44369155f, -0.10001794f, -0.69489920f, -0.21150810f, 
    -1.00520086f, -0.85658330f, -0.61843127f, 1.14853418f, 0.95646238f, -0.45118251f, -0.11757903f, -0.36131284f, 
    -0.40144712f, -0.65534395f, -0.80433393f, -0.43605593f, 0.09865822f, 0.83584243f, -0.45591378f, -0.66486812f, 
    -0.35073620f, -0.74809647f, -0.24761057f, -0.01148558f, 0.33827779f, 0.63107514f, 0.22729419f, -0.53341877f, 
    -0.37520969f, 0.29667130f, 0.65801471f, 0.67444438f, -0.91380537f, -0.52967709f, 1.08061540f, -0.18124740f, 
    -0.25652072f, -0.76335835f, -0.44758913f, -0.25392535f, 0.74525309f, 0.93970215f, 0.59631628f, -0.13250582f, 
    -0.23629732f, 0.33329651f, 0.26790121f, -0.11682447f, -0.37335208f, -1.06955457f, -0.40882367f, -0.76593626f, 
    0.40139288f, 1.26494956f, 0.52830261f, 0.36527959f, 0.01079792f, -0.24714257f, 0.62830019f, 0.90180522f, 
    -0.99078387f, -0.70387012f, 0.09725253f, 0.47549343f, 0.04086499f, 0.01337703f, 0.02234092f, 0.71670538f, 
    0.86269814f, 0.69003761f, -0.66531998f, -0.53759146f, -0.54045963f, 0.06365699f, 0.58083320f, -0.11174316f, 
    0.79754591f, 0.37577286f, 0.40385121f, 0.43993032f, 0.47743723f, 0.56999701f, 0.62872720f, -0.15047501f, 
    0.14177783f, 0.17570667f, 0.30952761f, 0.26367772f, -0.67369545f, -0.02887607f, 0.63874143f, -0.18382841f, 
    0.31683969f, 0.44370541f, 1.23534346f, -0.75553858f, -0.88753772f, 0.53622615f, 0.21446478f, 0.54260015f, 
    -0.17203294f, 0.63548982f, -0.59145921f, -0.18482994f, 0.62363547f, 0.87632430f, 0.24424146f, -0.84032696f, 
    -0.96889323f, 0.11811138f, -0.13672280f, 0.08881427f, 0.46147376f, 0.35918212f, 0.13551666f, 0.73822093f, 
    -0.20877106f, -0.55604148f, 0.24097000f, 0.20488237f, 0.41257715f, 0.91860127f, -0.98720580f, -0.62731987f, 
    0.43162596f, -0.19045049f, -0.52701169f, 1.08952987f, 0.17007355f, -0.09791267f, -0.80503160f, -0.31527725f, 
    -0.57004136f, -0.08114129f, 0.03639114f, -0.68700612f, 0.21002844f, 0.77108741f, 0.53250128f, 0.64885652f, 
    -0.94445449f, 1.02508533f, -0.70154798f, -0.09547430f, 0.64871925f, -0.09483386f, 0.12185023f, -0.03886578f, 
    -0.90003181f, -0.56830925f, -0.10222556f, 0.07380177f, 0.37992701f, 0.48102254f, 0.64360273f, -0.10626762f, 
    0.69410086f, -0.63782454f, 0.11791233f, 0.00703741f, -0.15392865f, -0.09752673f, 0.21464917f, -0.79031181f, 
    -0.45976022f, 0.86091483f, 1.09110940f, -0.44761708f, 0.14703825f, 0.79192328f, 0.04207692f, 0.27340013f, 
    -0.00254538f, 0.54234564f, -0.24477503f, -0.89132345f, -0.79971164f, -0.27968869f, 0.47272161f, 0.70868623f, 
    0.01171916f, 0.19861729f, 0.91214818f, -0.17071334f, -0.23736760f, -1.06919706f, -1.66097772f, 0.61241639f, 
    0.46698639f, 0.27786738f, -0.14916420f, 0.08663114f, 0.35361528f, -1.01320088f, -0.46436426f, -0.30695656f, 
    -0.85848987f, -0.57792968f, -0.66270232f, 0.38852182f, 0.34220546f, -0.23619349f, -0.25734276f, 0.12617357f, 
    -0.06605336f, -0.74736887f, -1.21520472f, -1.15586686f, -0.46464688f, -0.61923200f, -0.19283131f, 0.56633264f, 
    0.60861576f, -0.47159982f, 0.35946590f, -0.49601972f, -0.50893879f, 0.04639614f, -0.21627997f, 0.45527822f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.12317120f, 0.26222822f, -0.16284494f, 0.51599008f, 0.33969235f, 0.38535535f, 0.08343823f, -0.01494025f, 
    0.07715059f, -0.21674140f, 0.46956193f, -0.29603702f, -0.14608593f, 0.03483034f, 0.18713918f, 0.22200717f, 
    -0.10121008f, 0.64085615f, 0.27782458f, -0.03281188f, 0.43093672f, 0.33275270f, 0.12833461f, 0.30572122f, 
    0.37574556f, 0.58840150f, -0.17385939f, -0.12318282f, 0.50151545f, -0.16768618f, -0.32077435f, 0.68673444f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.11975499f, 0.50755244f, -0.14229023f, -0.08015239f, 0.29150811f, 0.00591949f, -0.06206616f, 0.03488494f, 
    0.20427349f, 0.16172455f, 0.04532126f, 0.34269696f, -0.23180953f, -0.09783505f, 0.04810467f, 0.01765713f, 
    0.13684055f, 0.08892052f, -0.64366096f, -0.32040954f, -0.04643901f, 0.02455358f, -0.02469219f, 0.19137536f, 
    0.19199279f, 0.15879771f, 0.15308550f, 0.21710140f, 0.22368611f, -0.17589821f, -0.13054512f, -0.06176953f, 
    0.11164944f, -0.03698441f, 0.05098432f, 0.18287498f, 0.24764635f, -0.75179583f, 0.04304087f, -0.23622768f, 
    -0.16631763f, -0.09251091f, -0.01503090f, 0.11258727f, 0.06412072f, 0.16955933f, -0.57966882f, -0.01180972f, 
    0.10939824f, -0.08048558f, -0.39452374f, 0.00376491f, 0.04998360f, -0.33802196f, 0.10578967f, 0.45721820f, 
    -0.04333274f, -0.18471800f, -0.20211931f, 0.09237771f, 0.09265586f, -0.03530896f, -0.22844014f, -0.63966846f, 
    -0.77067423f, 0.24696168f, -0.08412203f, -0.04455059f, 0.14859016f, -0.04437869f, -0.01642105f, 0.26148230f, 
    0.08547318f, 0.24963713f, 0.48914072f, -0.11727978f, -0.06073474f, -0.00417096f, 0.25577861f, -0.11525722f, 
    0.01777560f, 0.15206040f, 0.14727940f, 0.39978078f, 0.03564529f, -0.02316802f, 0.01666927f, 0.25690195f, 
    0.05317758f, -0.03277501f, -0.22858289f, -0.53504837f, -0.07544912f, 0.04492461f, 0.00918081f, 0.11720517f, 
    -0.02406492f, 0.04212596f, -0.00384220f, 0.14325124f, -0.08812361f, 0.56715548f, -0.00521756f, 0.00849345f, 
    0.03067045f, 0.26437280f, 0.02549757f, 0.11760922f, 0.12046537f, -0.40989050f, -0.60998857f, 0.20375380f, 
    0.07899414f, 0.00064961f, -0.01969155f, -0.04477622f, 0.22357114f, -0.26910162f, 0.24009207f, 0.27574760f, 
    -0.29482323f, -0.16027904f, 0.06754562f, 0.10753024f, -0.02080277f, 0.08332829f, -0.53238326f, -0.62452638f, 
    -0.50815362f, -0.30707002f, -0.02874474f, -0.08759993f, -0.16971138f, -0.09849719f, 0.03530763f, 0.34752306f, 
    -0.67317724f, 0.09316833f, -0.17067437f, 0.18657282f, -0.09791546f, 0.05989269f, 0.11792870f, -0.04742896f, 
    -0.34019142f, 0.04984213f, -0.08325353f, -0.04246578f, 0.02244625f, -0.00594908f, -0.08646967f, -0.06640872f, 
    0.04659267f, -0.13246723f, -0.27681819f, -0.08827820f, 0.00112871f, -0.09230579f, -0.07900074f, 0.07169188f, 
    -0.00210210f, 0.16662888f, 0.65098959f, -0.48646727f, -0.07950098f, 0.01230254f, -0.23338534f, 0.01366219f, 
    0.01245695f, 0.11171677f, -0.20194748f, -0.16238348f, -0.77092582f, -0.02238152f, -0.15406230f, -0.20338330f, 
    -0.19736724f, 0.01786903f, 0.00776056f, 0.04981820f, 0.09821650f, -0.57088602f, -0.19727419f, 0.20164114f, 
    -0.17003565f, 0.12810425f, -0.12334877f, 0.18398997f, 0.01850450f, -0.02865252f, 0.08308162f, -0.11290862f, 
    -0.04947826f, -0.05406094f, 0.17983675f, 0.05299006f, -0.13168514f, -0.06927566f, 0.16161931f, 0.22735663f, 
    0.31392148f, -0.09591009f, 0.04260104f, -0.05805565f, -0.11676855f, 0.11332663f, 0.06398547f, -0.81276727f, 
    -0.09261099f, -0.79983354f, -0.37212607f, 0.16632107f, 0.24280915f, -0.13864964f, 0.04944183f, -0.05145161f, 
    0.28794858f, -0.13098282f, -0.09659678f, -0.19028504f, 0.05812117f, -0.18384801f, -0.01963378f, 0.05695484f, 
    0.16496567f, -0.48200345f, 0.14735079f, 0.04946731f, 0.04362326f, 0.01495595f, 0.20905916f, 0.07079286f, 
    0.02981141f, 0.02007246f, 0.16208282f, -0.04830306f, 0.14445768f, -0.05741279f, 0.08324511f, 0.11004374f, 
    -0.04429033f, 0.12176076f, -0.28919083f, 0.38330176f, 0.02997997f, 0.16931476f, -0.36698985f, 0.01824376f, 
    -0.35074461f, -0.06838079f, 0.03770531f, 0.06486983f, 0.06618332f, 0.15919217f, 0.12996376f, -0.09643456f, 
    -0.12755448f, 0.24725249f, 0.15212120f, -0.11999496f, 0.00892731f, 0.11295617f, 0.53422272f, 0.24020149f, 
    -0.34269792f, -0.02994511f, 0.00894273f, -0.05621544f, 0.20564534f, 0.03935489f, 0.31100243f, 0.32725134f, 
    0.02076831f, 0.09306320f, 0.18194364f, -0.28634232f, -0.14771073f, 0.00709000f, 0.14160404f, -0.29658017f, 
    -0.11910622f, -0.09598561f, 0.16722862f, -0.18682100f, -0.32346591f, -0.03216244f, 0.03988291f, 0.07047324f, 
    -0.03774270f, -0.04202536f, -0.04729876f, 0.00823632f, 0.00539899f, -0.00046785f, 0.03357469f, 0.02928828f, 
    -0.00502869f, 0.01347886f, 0.00172168f, -0.05604866f, -0.02279859f, -0.02286223f, -0.03809432f, -0.02581496f, 
    0.03802917f, 0.04387937f, 0.04817745f, -0.06117817f, -0.02781959f, 0.03435513f, 0.02782760f, -0.01412845f, 
    -0.02083775f, 0.04800038f, 0.02327077f, -0.05458951f, 0.00430240f, 0.04093544f, 0.05254903f, -0.01260201f, 
    0.01634159f, -0.05014648f, 0.01453742f, -0.04534347f, -0.01179658f, -0.01321377f, -0.05263156f, -0.06051285f, 
    -0.01312834f, 0.01792363f, 0.02885679f, -0.05030942f, -0.04674974f, 0.01398389f, -0.02594467f, -0.00191748f, 
    0.02613756f, -0.04956811f, -0.00820520f, -0.00811460f, -0.05310312f, -0.00653804f, 0.03729322f, -0.00434176f, 
    -0.02655037f, -0.05584282f, 0.03707559f, -0.05410232f, -0.01269954f, -0.00042595f, -0.02731751f, -0.02927779f, 
    -0.06458832f, 0.00713159f, 0.01753861f, -0.05797037f, -0.05879014f, 0.00356768f, -0.00580770f, 0.02421562f, 
    -0.06029832f, -0.04724274f, 0.01107142f, 0.04152184f, 0.03515855f, 0.04046556f, -0.03165478f, -0.02596856f, 
    0.00199114f, 0.00629859f, 0.05208199f, -0.02379358f, 0.01612050f, -0.01679909f, 0.01630146f, 0.00143610f, 
    -0.05890229f, -0.03168146f, -0.02723853f, -0.02091959f, 0.02802031f, -0.02435222f, 0.01462451f, -0.04972535f, 
    -0.00235107f, -0.01601222f, -0.04853847f, 0.03021779f, -0.02457719f, -0.02599300f, -0.03227743f, -0.02462756f, 
    -0.04425242f, -0.04922649f, 0.00312578f, 0.00856724f, 0.03855881f, 0.01478922f, -0.02601900f, -0.04865139f, 
    -0.01022986f, 0.02683616f, -0.01141815f, 0.00701069f, 0.04910082f, -0.05901017f, 0.00144553f, 0.00361581f, 
    0.02485579f, 0.02057161f, 0.02758092f, 0.02459650f, 0.04995082f, -0.02272594f, -0.06186133f, -0.02798843f, 
    -0.04503962f, 0.02706328f, -0.00604906f, -0.04446747f, -0.00903678f, -0.04955960f, 0.00414899f, -0.00396393f, 
    0.01148741f, 0.00857495f, -0.05496754f, -0.05300092f, 0.01771478f, 0.02614851f, -0.03202164f, -0.02242576f, 
    -0.03701647f, -0.00499727f, -0.01304571f, -0.01185970f, -0.04657007f, -0.00650589f, 0.02057500f, -0.02061926f, 
    -0.05870784f, 0.02711870f, -0.05502339f, -0.00251861f, -0.02159196f, -0.05935046f, 0.00180099f, -0.00646600f, 
    -0.00714729f, -0.00123202f, -0.00834686f, -0.01995498f, -0.06480294f, -0.01266693f, 0.03131515f, -0.05159920f, 
    0.00573847f, 0.00877317f, -0.05028355f, 0.03185840f, 0.03772267f, 0.04501102f, 0.04284241f, 0.01898016f, 
    0.01405668f, -0.03105458f, 0.03203337f, -0.04892504f, -0.00608168f, 0.02843582f, -0.03721701f, -0.02446315f, 
    0.02373890f, 0.02494236f, 0.04833073f, 0.02970887f, 0.01325822f, 0.03224117f, -0.03439949f, 0.02584113f, 
    -0.03378891f, 0.02416410f, -0.03726609f, -0.06062099f, -0.05670949f, -0.00563667f, 0.01475310f, 0.01414316f, 
    0.01559226f, 0.05100489f, 0.02590824f, 0.03328485f, -0.04669379f, -0.03997310f, -0.02987883f, -0.03437679f, 
    0.02952289f, -0.06099015f, 0.00706485f, -0.02725645f, -0.00454609f, -0.05992946f, 0.03588560f, 0.04762896f, 
    -0.00079335f, -0.05820554f, -0.02635250f, -0.00516741f, -0.02883875f, 0.03150564f, -0.00118515f, -0.04782929f, 
    0.02643956f, -0.00168327f, -0.03608415f, -0.04188693f, -0.05940900f, -0.01836866f, -0.01830186f, -0.05686843f, 
    0.01983200f, -0.04626147f, 0.05327995f, 0.05289372f, -0.00321682f, -0.04193281f, 0.02420311f, 0.02447155f, 
    0.02734894f, -0.03194772f, -0.06163107f, -0.05018258f, 0.01661709f, -0.04816083f, -0.01906193f, 0.02655985f, 
    0.04438522f, -0.04147978f, 0.01855905f, 0.02194604f, -0.03860090f, -0.01686409f, -0.00340404f, -0.03284512f, 
    -0.03598331f, 0.03567152f, -0.03965212f, -0.00210437f, -0.01336978f, 0.01051574f, -0.05506202f, -0.00095876f, 
    0.04806387f, -0.02837955f, 0.03660731f, -0.04797130f, 0.00039692f, -0.03072359f, 0.00420499f, 0.01231551f, 
    -0.04506309f, 0.04144897f, -0.04996581f, -0.00523097f, -0.02782074f, 0.05013489f, 0.04968352f, -0.03288764f, 
    0.03401305f, -0.00757124f, -0.03050700f, 0.05271212f, -0.02354858f, 0.02564779f, -0.02085342f, -0.02436139f, 
    -0.02334863f, -0.10305282f, -0.41089839f, 0.03778115f, -0.20787705f, -0.17813824f, -0.09548145f, -0.21127406f, 
    -0.17363147f, -0.36561915f, -0.07918767f, 0.10822684f, 0.22395445f, -0.00567048f, -0.00761861f, 0.04267262f, 
    -0.00843701f, 0.22548747f, -0.30880207f, -0.09826124f, -0.12324057f, 0.01022847f, -0.17560792f, -0.01702796f, 
    -0.28813231f, -0.22168021f, -0.34222612f, 0.04095734f, -0.11267214f, -0.07982978f, 0.04005360f, -0.17938361f, 
    -0.00483227f, 0.00873152f, 0.24430013f, 0.06128426f, 0.23847304f, -0.05281569f, -0.00195896f, 0.11883968f, 
    -0.04064668f, 0.01958180f, 0.14691743f, -0.07702437f, -0.31909317f, -0.07160678f, -0.51864731f, -0.17020299f, 
    0.10373541f, 0.19297069f, 0.09463273f, -0.03085245f, 0.16928020f, -0.10511789f, 0.02404549f, -0.01952000f, 
    -0.33368957f, 0.04647367f, -0.17834200f, -0.05618294f, 0.06643997f, 0.12776411f, 0.05005970f, -0.09439663f, 
    -0.61184639f, -0.06612953f, -0.06483723f, -0.14698666f, -0.04607042f, -0.10457660f, -0.11338080f, 0.23272631f, 
    -0.27532133f, 0.24637568f, 0.44189733f, -0.17067303f, -0.05091384f, 0.02140236f, -0.06328169f, -0.08752353f, 
    0.37577951f, -0.24427862f, 0.00438512f, 0.04220335f, -0.26315054f, -0.04934434f, 0.09021754f, -0.06798150f, 
    -0.09885754f, 0.30320314f, -0.15097938f, -0.09509116f, 0.17368661f, 0.03788441f, -0.09258348f, -0.13842465f, 
    0.02592851f, 0.08304445f, -0.27284068f, -0.19788302f, -0.12263066f, 0.07657446f, -0.10277190f, 0.08279505f, 
    0.22308211f, -0.09941521f, -0.04102030f, 0.17679580f, 0.48754478f, 0.00506873f, 0.21256362f, -0.02199185f, 
    0.04984231f, -0.00153030f, -0.03032288f, -0.07434356f, -0.03622218f, -0.24559510f, 0.35840875f, 0.12208035f, 
    -0.04061877f, -0.06622604f, 0.05511247f, -0.03962195f, 0.03215853f, 0.20001271f, 0.18962610f, -0.26979160f, 
    -0.14764550f, -0.02997545f, -0.06288265f, -0.06197937f, -0.06266730f, 0.17663041f, -0.16046911f, 0.62810123f, 
    -0.25305718f, 0.02794411f, 0.05681810f, -0.05134748f, -0.07443207f, 0.05544798f, 0.07574686f, -0.01535159f, 
    0.22549619f, 0.12509102f, -0.06400654f, 0.07403400f, 0.06698442f, -0.13647763f, 0.06067401f, -0.11837684f, 
    -0.21545503f, 0.25430867f, 0.12999977f, 0.02096097f, 0.10705880f, 0.37503362f, -0.05722848f, 0.03105190f, 
    -0.07469278f, -0.12820366f, 0.05165756f, -0.18955673f, -0.20483463f, 0.17588732f, -0.01246666f, 0.22988261f, 
    -0.01863624f, -0.00675973f, 0.27789834f, -0.02934227f, -0.33247137f, 0.10421649f, -0.02256275f, 0.07140324f, 
    0.00675536f, 0.21092430f, -0.05315549f, -0.01932858f, 0.18282047f, 0.03179499f, 0.19096524f, 0.17308623f, 
    0.03850631f, -0.02383091f, 0.14672725f, 0.17328036f, -0.19613656f, 0.15008876f, -0.08588166f, 0.13355313f, 
    -0.14639097f, 0.11343317f, 0.07991555f, -0.10445516f, 0.21468210f, -0.01191762f, -0.20817678f, 0.03172274f, 
    0.12172449f, -0.06423382f, -0.05022457f, -0.23859581f, -0.18124683f, 0.01988286f, -0.18368699f, 0.26551560f, 
    0.00993827f, -0.23197816f, 0.17790838f, 0.12979753f, 0.02274520f, -0.00883790f, -0.15832345f, -0.08781689f, 
    -0.16491768f, 0.21169984f, 0.06692588f, -0.06956769f, -0.04615341f, 0.05442995f, 0.01406781f, -0.04739346f, 
    -0.23166157f, -0.01697972f, -0.05385156f, -0.17427869f, 0.18386832f, -0.15276608f, 0.06203798f, 0.13825983f, 
    0.01373714f, 0.01129375f, 0.23249632f, 0.04122002f, -0.09335136f, 0.15337048f, 0.03007598f, -0.00942112f, 
    0.22576666f, -0.11507428f, -0.18610261f, -0.48319721f, 0.02782195f, 0.07137764f, -0.17460614f, 0.00711006f, 
    -0.03312982f, -0.03529274f, -0.15320706f, -0.02370770f, -0.03564633f, 0.54904521f, 0.19308597f, -0.01769532f, 
    -0.20452665f, 0.23996779f, 0.00843941f, 0.11197469f, 0.00647874f, -0.02504460f, 0.31268656f, 0.23515771f, 
    0.14066717f, -0.08603031f, -0.02134344f, -0.03864551f, -0.00441129f, 0.14799091f, -0.09334543f, 0.17448978f, 
    -0.21009302f, 0.05359767f, -0.31329435f, -0.07515228f, 0.13291880f, 0.06218063f, 0.00835529f, 0.49810144f, 
    0.06026785f, -0.07872847f, 0.16981618f, 0.11961734f, -0.04225209f, 0.07838297f, 0.17090741f, 0.00109208f, 
    0.31257981f, -0.11548473f, 0.02726619f, -0.01545317f, 0.06278207f, -0.29940614f, 0.11527245f, -0.00967366f, 
    0.03577397f, 0.51478618f, 0.02456189f, 0.09947091f, 0.02133070f, -0.11994447f, 0.05491127f, 0.10300513f, 
    0.02808846f, 0.07299675f, 0.25711372f, 0.20184076f, -0.47162700f, -0.12348748f, -0.15325297f, -0.03436173f, 
    0.22854863f, 0.00226306f, -0.13742952f, -0.13971514f, 0.05521205f, -0.15581982f, -0.01261897f, -0.16902286f, 
    0.02318111f, 0.05815620f, -0.18201002f, -0.00569320f, -0.03636465f, 0.10257033f, -0.05604791f, 0.02595735f, 
    0.09425212f, 0.05824914f, 0.09354156f, -0.19306934f, -0.21315859f, -0.23276225f, -0.07949310f, 0.03240117f, 
    0.04965504f, 0.06255987f, -0.01939702f, -0.11775410f, -0.37325779f, -0.05113861f, 0.44447258f, 0.18731001f, 
    0.22919981f, 0.06226080f, -0.01088625f, 0.03985544f, 0.07805294f, -0.11780643f, -0.05899998f, 0.04698814f, 
    -0.08627582f, -0.16471137f, 0.11606044f, 0.14053677f, 0.08985762f, -0.19091779f, -0.21491989f, -0.39355129f, 
    0.35024932f, 0.11729839f, -0.56508929f, -0.15666500f, -0.02571106f, 0.24868938f, -0.01252735f, -0.11830303f, 
    0.06979130f, 0.48284540f, 0.05371327f, -0.24569175f, -0.01909251f, -0.01896125f, 0.08943421f, -0.07174584f, 
    -0.22836758f, -0.09529817f, -0.02918354f, -0.04305832f, -0.15034878f, -0.10136109f, -0.33534563f, -0.28118861f, 
    0.01685648f, -0.04162754f, 0.00100351f, -0.07540642f, 0.12257035f, -0.38212284f, 0.10747128f, -0.05970694f, 
    0.06461783f, 0.00821100f, 0.02442562f, -0.10279553f, -0.00970973f, 0.05319475f, 0.06986886f, 0.13729928f, 
    0.03273081f, -0.03663030f, -0.24083301f, 0.09762788f, -0.02714473f, 0.24821544f, -0.15268280f, -0.22632210f, 
    -0.12845945f, 0.14820644f, 0.10399801f, 0.07773551f, -0.05652871f, 0.00013124f, -0.13262627f, -0.04525368f, 
    -0.48787951f, -0.15649322f, -0.23850261f, -0.25364846f, -0.15368077f, 0.14625098f, -0.36570340f, 0.01352851f, 
    0.09636603f, 0.07539533f, -0.00499417f, -0.02586930f, -0.09095078f, -0.01009210f, 0.15578958f, 0.13272476f, 
    0.14735660f, 0.20615613f, 0.02638064f, 0.20152460f, 0.04905855f, -0.09205113f, 0.03671497f, -0.03657572f, 
    -0.18463604f, -0.05495094f, 0.02579146f, -0.00570637f, -0.04028547f, -0.05336807f, -0.12636612f, -0.00795844f, 
    0.14389218f, -0.18313916f, -0.24574581f, -0.20700966f, -0.28360313f, 0.04881958f, 0.23558748f, -0.07176784f, 
    0.14265192f, -0.06847689f, -0.00569852f, -0.28602958f, 0.39144132f, 0.24767858f, -0.04129681f, -0.08042549f, 
    -0.04434768f, 0.06615435f, -0.01743471f, 0.05155955f, -0.02425529f, 0.13887976f, 0.02247019f, -0.06135688f, 
    0.05330430f, -0.02400997f, 0.12108681f, 0.00512905f, 0.04649220f, 0.14638828f, 0.22337629f, -0.24884121f, 
    -0.07176255f, 0.11702745f, -0.15197231f, 0.09778363f, 0.10513192f, 0.10393415f, 0.13958800f, 0.22020058f, 
    -0.09873307f, 0.02768044f, -0.09193618f, -0.14060238f, 0.28229663f, 0.09065095f, 0.13809103f, 0.36148149f, 
    -0.14318743f, -0.32711294f, 0.33325177f, -0.10345744f, -0.09301077f, 0.23761657f, -0.09020279f, -0.04674917f, 
    0.06078838f, -0.14119926f, -0.12857278f, -0.05133273f, -0.18258859f, -0.12676808f, 0.18146174f, 0.07359289f, 
    0.04456868f, 0.13629314f, -0.05170350f, -0.06617842f, 0.18162838f, -0.07951944f, -0.19202480f, 0.17725557f, 
    0.02810967f, 0.01544928f, 0.02892190f, 0.13914657f, -0.03836366f, 0.19133298f, 0.14299250f, -0.39666292f, 
    0.12718993f, 0.18652771f, -0.14214489f, 0.02763460f, 0.18444100f, -0.28369781f, -0.01522368f, -0.21651393f, 
    0.04759675f, 0.23876706f, 0.12460726f, 0.07707357f, 0.38453317f, 0.13860013f, -0.51362026f, 0.06064354f, 
    -0.03077626f, 0.04903332f, 0.00976093f, -0.02796053f, 0.00749063f, 0.38653153f, 0.34428594f, 0.32520616f, 
    0.03758027f, -0.08509707f, -0.01967556f, 0.10166416f, 0.00744900f, 0.01887646f, 0.17314133f, 0.37357280f, 
    0.59770095f, -0.08528741f, -0.02890044f, -0.04241773f, -0.02045967f, -0.09315150f, 0.13914032f, -0.10843641f, 
    0.19208106f, -0.05331298f, 0.04068554f, 0.00423514f, 0.00047667f, 0.03437911f, 0.02167131f, -0.14652523f, 
    0.06319377f, 0.01912974f, -0.00596722f, 0.00330572f, -0.01471065f, -0.07234181f, -0.14314087f, -0.12192230f, 
    -0.37065390f, -0.12951362f, 0.11683244f, 0.25504762f, 0.07398313f, -0.16898581f, 0.15436281f, -0.05288162f, 
    0.03092270f, 0.06854684f, -0.38556829f, 0.23166698f, 0.32682374f, -0.20398262f, -0.00310713f, 0.06984367f, 
    -0.37193325f, -0.12249726f, -0.45262089f, 0.14249109f, 0.22931674f, 0.07626119f, -0.23619871f, 0.08434443f, 
    0.07355403f, -0.05119099f, -0.08995273f, -0.01299307f, -0.09575868f, -0.00382709f, 0.06092945f, -0.15442802f, 
    0.05982308f, -0.05198549f, -0.09909219f, 0.07441156f, -0.09734880f, 0.00817730f, 0.19914924f, 0.32916614f, 
    -0.13535249f, -0.14842716f, 0.06656333f, -0.00116960f, 0.01053022f, 0.07971641f, 0.25292957f, 0.18944187f, 
    0.10947298f, 0.03734439f, -0.03660578f, 0.07300437f, 0.00871792f, 0.07742288f, 0.05203688f, 0.36653659f, 
    -0.21204029f, 0.05371118f, -0.03563264f, 0.19860104f, 0.06730659f, 0.09520318f, 0.11613705f, 0.21910936f, 
    -0.62481827f, -0.02498732f, -0.27547586f, 0.20836893f, -0.06603547f, 0.00994747f, 0.03438963f, 0.10762221f, 
    0.10440577f, -0.07287360f, 0.04606501f, 0.00079121f, 0.16690877f, 0.04656590f, 0.08162223f, -0.15737067f, 
    0.08153883f, 0.14987047f, 0.09655263f, -0.01879736f, -0.19786778f, -0.09653372f, 0.12562056f, -0.08187272f, 
    -0.09873946f, -0.17478463f, -0.15114954f, 0.28989640f, 0.13342141f, -0.01469085f, 0.06399880f, 0.12375611f, 
    0.13349491f, -0.10561438f, 0.14844406f, 0.06865477f, -0.09924568f, -0.42305058f, 0.14575239f, 0.08189597f, 
    -0.16046424f, -0.26291502f, 0.15227558f, -0.04217483f, 0.13397859f, -0.71428651f, 0.04573463f, 0.29525718f, 
    0.07748791f, -0.02161270f, -0.00199785f, 0.12240350f, 0.15506949f, 0.15493900f, 0.46977803f, 0.18286775f, 
    -0.33346522f, 0.22922161f, 0.13807954f, 0.03520182f, -0.05162035f, -0.14256279f, -0.00076861f, -0.08211872f, 
    -0.29523790f, -0.04521681f, 0.04732370f, -0.12658048f, -0.16121496f, -0.11293777f, -0.11234856f, 0.00678236f, 
    -0.01907903f, -0.24053353f, 0.19833608f, 0.11473534f, 0.03167852f, 0.10048656f, -0.08338824f, 0.03361631f, 
    0.01439980f, -0.36726916f, -0.06637193f, -0.32766163f, -0.04193578f, -0.11467725f, 0.00841632f, -0.07422131f, 
    0.05700454f, -0.34068227f, -0.47570214f, 0.24816862f, -0.45352206f, -0.20109850f, -0.06303580f, 0.34370002f, 
    0.18822828f, 0.13652651f, 0.26970175f, 0.09381305f, -0.45715860f, -0.08742654f, -0.12764150f, 0.18298206f, 
    -0.01139976f, -0.00519918f, 0.05210314f, -0.11805083f, -0.06034846f, -0.21701516f, 0.06095603f, -0.08335107f, 
    -0.01177750f, 0.00434540f, -0.04124011f, -0.29356819f, -0.22110246f, 0.22634552f, 0.17152439f, -0.16667007f, 
    0.29900035f, -0.21041955f, 0.05273322f, -0.13234133f, -0.20017740f, 0.02145431f, 0.09428780f, 0.07764801f, 
    -0.08952476f, 0.13627887f, 0.02156368f, 0.05833095f, 0.11123306f, -0.15718229f, -0.05323445f, -0.26404142f, 
    0.20970426f, -0.06130560f, -0.07794266f, -0.07477541f, 0.21854813f, 0.10914840f, 0.14190687f, 0.14575265f, 
    -0.40085721f, 0.04406898f, 0.31136346f, 0.13993160f, -0.07789239f, 0.10323230f, 0.09958979f, -0.17898586f, 
    -0.19533244f, 0.07624041f, 0.32900020f, -0.10915681f, -0.00306806f, -0.07237687f, -0.05311627f, 0.02160067f, 
    0.00753968f, -0.06123420f, -0.30661610f, 0.50263470f, 0.19049482f, -0.08427351f, -0.04100585f, 0.26692894f, 
    -0.06630041f, -0.09429342f, 0.10583480f, -0.41328153f, 0.12194915f, 0.19207324f, 0.02647608f, -0.14241733f, 
    -0.02335282f, -0.02089021f, -0.04172791f, 0.06441306f, -0.03732140f, -0.02055364f, -0.33191150f, 0.07109717f, 
    -0.02860272f, -0.10218994f, 0.11546940f, 0.18239111f, 0.00188103f, 0.23772472f, 0.13554065f, 0.15199538f, 
    0.13219699f, -0.13525750f, 0.03720327f, 0.03278828f, -0.11376004f, -0.11556989f, 0.23455589f, 0.23992945f, 
    0.45824888f, 0.01500167f, 0.06206891f, 0.02020827f, 0.04035144f, -0.06611452f, -0.00565146f, 0.23031588f, 
    0.10157016f, 0.13427475f, -0.28895700f, 0.15739566f, 0.07596194f, 0.09922404f, -0.08488464f, -0.23357038f, 
    -0.04385205f, -0.02957391f, -0.01577701f, 0.03097184f, 0.01393826f, -0.01340138f, -0.04466633f, -0.02344670f, 
    0.05384463f, -0.05475143f, 0.00283170f, -0.02778564f, 0.04402013f, 0.05201178f, -0.03091335f, -0.01761117f, 
    -0.02676919f, -0.06005815f, -0.03787218f, 0.02895819f, -0.03540227f, -0.04105269f, 0.04676631f, -0.06180722f, 
    -0.04964026f, -0.03086015f, 0.01216487f, 0.01863764f, 0.04850618f, -0.01750201f, -0.04570943f, -0.05850829f, 
    -0.04346102f, -0.01348460f, -0.01763160f, 0.01651703f, -0.03721954f, -0.04781737f, 0.05125053f, 0.04803794f, 
    -0.03489770f, 0.04682604f, -0.05150704f, -0.03010996f, -0.03525046f, 0.00011713f, -0.05762279f, -0.05376304f, 
    0.02761831f, -0.06370910f, 0.01230172f, -0.00900728f, 0.00930153f, -0.02182142f, 0.01940775f, 0.04032090f, 
    -0.02276591f, -0.01490129f, -0.02793832f, -0.02432982f, -0.05469882f, 0.01301869f, -0.04922984f, 0.04253382f, 
    0.04201460f, 0.01127323f, 0.00620425f, 0.03376713f, -0.02544536f, -0.04987837f, 0.05806864f, 0.03982449f, 
    -0.01155190f, -0.05980257f, -0.04175562f, 0.02717387f, 0.01095325f, 0.02598829f, -0.01005553f, 0.05276938f, 
    -0.04579422f, -0.00747027f, 0.00540056f, -0.03481154f, 0.04179033f, -0.00240902f, -0.03051996f, -0.03948967f, 
    -0.05059611f, 0.02058538f, 0.03757240f, 0.02974291f, 0.00302581f, 0.00247678f, -0.04384476f, 0.04443160f, 
    -0.05496125f, -0.03780112f, -0.00709170f, -0.03964902f, 0.01712476f, -0.00724257f, 0.03891390f, 0.04839525f, 
    0.00688485f, -0.01280565f, -0.02501741f, 0.00725965f, 0.01373492f, 0.01186310f, -0.03901996f, -0.06202899f, 
    0.02142772f, -0.01453166f, 0.02634671f, -0.05161690f, -0.03564104f, -0.00524467f, -0.04812301f, -0.03249967f, 
    0.01543410f, -0.04887746f, -0.00935351f, 0.00686060f, 0.01138908f, -0.02403819f, -0.02953378f, 0.01156546f, 
    -0.03178860f, -0.01200061f, -0.02525825f, -0.04945131f, -0.03979928f, 0.04246252f, 0.02423360f, 0.04576518f, 
    -0.02804242f, 0.02912208f, -0.03302594f, -0.00190521f, -0.03014321f, -0.03031685f, -0.03884886f, -0.02645573f, 
    0.00539167f, 0.03723739f, 0.01493610f, -0.00784173f, -0.02002617f, -0.03534802f, 0.01237259f, 0.01733506f, 
    0.00090221f, -0.06282498f, -0.03206434f, 0.04879009f, -0.04925636f, 0.03653377f, -0.02841678f, -0.04217082f, 
    0.01983535f, -0.01601376f, -0.02220304f, -0.03542645f, -0.01907992f, 0.00041504f, -0.01726277f, -0.05993796f, 
    -0.00832898f, -0.04877367f, -0.05238898f, -0.00316993f, 0.03031776f, 0.00624025f, 0.03086437f, -0.02440027f, 
    0.03099535f, 0.00544966f, -0.01571630f, 0.01067278f, -0.03163023f, 0.01209306f, 0.02439343f, 0.00853661f, 
    -0.00993700f, -0.05766634f, -0.01492511f, -0.02706804f, -0.03286271f, 0.00251671f, -0.05005107f, 0.04458492f, 
    -0.05693067f, 0.04907557f, -0.00733726f, 0.00786368f, -0.01460059f, -0.03434741f, 0.04083549f, -0.01310593f, 
    -0.00466552f, 0.03376850f, -0.03571324f, -0.06442422f, -0.01054384f, 0.03025478f, 0.00515837f, -0.02356301f, 
    -0.03274573f, 0.04894608f, 0.00018801f, -0.00204823f, 0.02290398f, 0.02109482f, -0.03337693f, -0.01149108f, 
    -0.01477590f, -0.04302488f, 0.00901724f, -0.04552582f, -0.03595284f, 0.04138370f, -0.05083414f, -0.05861912f, 
    -0.01513589f, 0.04480257f, -0.01213779f, 0.00301020f, 0.04149648f, -0.03956031f, 0.01848075f, 0.02782045f, 
    -0.06385907f, 0.00690281f, 0.01597168f, -0.04951571f, -0.00937379f, -0.01571045f, 0.04558497f, -0.03853578f, 
    -0.01246574f, -0.05134970f, -0.05009249f, 0.01528939f, -0.04831068f, -0.05942176f, 0.00614186f, 0.00862375f, 
    0.01256821f, 0.00298055f, -0.00568049f, -0.01503109f, 0.04304262f, 0.04590308f, 0.05223745f, 0.02304333f, 
    0.01574830f, 0.00818996f, -0.04538112f, -0.01872543f, 0.02682619f, 0.03271873f, 0.01400797f, -0.03649290f, 
    -0.03851679f, 0.04992164f, 0.01851275f, -0.03845304f, 0.05154509f, -0.00483214f, 0.01230420f, 0.03744292f, 
    0.04807190f, -0.06352585f, -0.04154262f, -0.06417635f, 0.01695533f, -0.03725191f, -0.05580453f, -0.01230460f, 
    -0.04674876f, -0.00655162f, 0.01050481f, -0.04572763f, -0.03029573f, -0.04497642f, -0.05164628f, -0.03058665f, 
    -0.12787181f, 0.09515021f, -0.00444193f, -0.03762316f, 0.14432715f, 0.11867671f, 0.24504507f, 0.34303048f, 
    0.29278228f, -0.00023570f, 0.06147544f, 0.41835865f, 0.00285958f, -0.06562488f, 0.03515267f, 0.01296639f, 
    0.12161425f, 0.24378164f, 0.01870933f, 0.18435051f, 0.10889792f, -0.08956817f, -0.04284273f, 0.20022941f, 
    0.12711585f, 0.29543284f, 0.10434951f, 0.03158804f, -0.06939743f, 0.25582358f, 0.24019109f, -0.00147510f, 
    0.13140658f, -0.04371805f, 0.04107073f, 0.26668420f, -0.28938478f, 0.06567802f, 0.02600994f, 0.16487800f, 
    -0.01110788f, 0.10553589f, 0.18485171f, 0.05682800f, 0.21842578f, -0.11472551f, -0.10459884f, -0.09950712f, 
    -0.04662171f, -0.06028438f, -0.00687798f, -0.25388885f, 0.03976668f, -0.39374101f, 0.12921859f, -0.11344056f, 
    0.11732250f, 0.11499638f, 0.02164169f, 0.19900160f, 0.13178942f, 0.12170373f, 0.30970192f, 0.06667706f, 
    0.19730873f, 0.00248741f, -0.04037043f, -0.01447991f, 0.11485736f, -0.05381242f, 0.12364894f, -0.78335762f, 
    -0.32948297f, -0.06809811f, 0.21254410f, 0.22275248f, -0.02992576f, -0.05788460f, -0.09753558f, -0.30407906f, 
    -0.21651119f, -0.24653009f, -0.23583342f, 0.16814099f, 0.11790016f, -0.05040633f, -0.05705851f, -0.15690196f, 
    -0.26788849f, -0.40155128f, -0.12368496f, 0.15369634f, 0.05112838f, 0.19946176f, -0.01272188f, 0.01814277f, 
    0.29965124f, 0.26611766f, 0.25079206f, -0.10259635f, -0.13106993f, 0.25909635f, 0.21212195f, 0.04042637f, 
    0.01038084f, -0.25037715f, -0.76673871f, -0.28806421f, -0.13689519f, -0.12098416f, -0.01110263f, -0.12501083f, 
    -0.09075081f, -0.05843806f, -0.03741492f, -0.06368213f, -0.23318827f, -0.10917636f, -0.12856154f, 0.05473271f, 
    0.21598978f, -0.00320959f, 0.10522700f, -0.12599887f, -0.08691292f, -0.18097737f, 0.09860696f, 0.15606084f, 
    0.41597876f, 0.11963511f, 0.24767855f, 0.31828555f, 0.03268218f, 0.14643186f, 0.08640110f, -0.51741844f, 
    -0.07521795f, -0.06851827f, -0.02240870f, 0.21037802f, -0.05822758f, -0.06408647f, 0.19683413f, 0.06388342f, 
    -0.26952615f, -0.20934089f, -0.12197661f, 0.06331067f, -0.05002536f, 0.10510702f, -0.05311849f, -0.08397631f, 
    -0.16098346f, 0.08236809f, 0.00542610f, 0.23496029f, 0.08530105f, 0.13920505f, 0.05051378f, 0.04487522f, 
    0.15726891f, 0.08368963f, -0.06559087f, 0.12143979f, 0.16086133f, 0.35213116f, 0.41885111f, 0.04306897f, 
    -0.26533464f, -0.46419698f, -0.22835259f, -0.76257110f, -0.06629606f, -0.31791911f, 0.10182086f, 0.13421924f, 
    -0.00158333f, 0.05306663f, 0.01837371f, -0.22306919f, -0.22338474f, -0.01560604f, -0.07189336f, 0.12816624f, 
    0.03421164f, -0.06107257f, 0.00575745f, 0.43316656f, 0.17306475f, -0.12609741f, -0.08337931f, 0.11979467f, 
    -0.11095564f, -0.31047574f, 0.02248868f, 0.00767077f, 0.23410212f, 0.13502306f, -0.06725331f, 0.03391620f, 
    -0.06188427f, -0.32099909f, -0.20092092f, -0.14491647f, 0.22630580f, 0.25961408f, 0.11241319f, 0.29620263f, 
    0.07628524f, 0.59820312f, 0.19919474f, 0.17864038f, 0.10985328f, -0.16743267f, 0.09294718f, 0.15923978f, 
    -0.01335038f, -0.13453378f, -0.03372554f, -0.01626945f, -0.06247266f, 0.00806671f, 0.05846017f, 0.07871168f, 
    0.12240817f, 0.06583934f, 0.19186895f, 0.27712420f, -0.02920336f, 0.21892846f, 0.04588817f, 0.25090042f, 
    -0.17063396f, 0.14918512f, -0.17459001f, -0.15122920f, 0.02315624f, 0.24411604f, 0.14286819f, -0.13114752f, 
    -0.09533226f, -0.14223087f, 0.26900032f, -0.11037177f, 0.06821965f, -0.10936946f, 0.22329330f, 0.02568654f, 
    -0.14648324f, 0.01661776f, 0.01642952f, 0.05369657f, -0.14581871f, 0.03884342f, 0.07031244f, 0.19537155f, 
    0.06049176f, -0.14055872f, -0.02835697f, -0.10444605f, 0.10726088f, -0.21579005f, 0.13341810f, -0.24805900f, 
    -0.18574333f, -0.01591638f, 0.03172482f, 0.14602520f, 0.19010277f, 0.21961853f, -0.03473226f, -0.18008824f, 
    -0.40307611f, 0.27735177f, 0.11691405f, 0.23673376f, 0.08786688f, 0.12275607f, -0.03806502f, 0.08385816f, 
    0.20375437f, -0.13744834f, 0.04900706f, 0.11294989f, 0.17949258f, 0.17481889f, 0.28169435f, 0.08365213f, 
    0.00932743f, -0.05421777f, -0.04755982f, -0.00429383f, 0.05244600f, 0.00815814f, -0.02749483f, 0.00760959f, 
    -0.06264915f, -0.04408375f, -0.03700303f, 0.03721626f, 0.05222333f, 0.01306676f, 0.04493586f, -0.04416236f, 
    -0.04129514f, -0.06123278f, -0.04812853f, -0.02693779f, 0.02253128f, -0.02476618f, -0.03448701f, 0.02891329f, 
    0.01182434f, -0.03973515f, -0.06158629f, -0.02432889f, -0.05577009f, -0.01592710f, -0.04891422f, -0.04776720f, 
    0.01608860f, -0.04916808f, -0.05657696f, 0.02935882f, -0.05210511f, 0.01640640f, -0.05969124f, 0.01894743f, 
    0.01967591f, -0.03974677f, -0.03858639f, -0.03728760f, -0.04043605f, 0.01318663f, -0.01377632f, -0.05967375f, 
    0.04466781f, 0.00653636f, -0.05401356f, -0.00609120f, -0.04510920f, -0.00484994f, 0.02021784f, -0.04923075f, 
    -0.00090770f, -0.03045610f, -0.05854073f, 0.01577756f, 0.04053596f, 0.05177207f, 0.02971223f, -0.05336889f, 
    -0.01136552f, 0.00637722f, 0.03419415f, -0.00134255f, 0.04784273f, -0.03715445f, -0.03520805f, -0.04971214f, 
    -0.03679748f, -0.05235111f, -0.01619154f, -0.04286534f, -0.01795805f, 0.00475882f, -0.00730786f, -0.03496183f, 
    -0.00915502f, 0.02301622f, -0.02113857f, -0.03086623f, 0.02929994f, 0.00671788f, 0.00458865f, 0.00320466f, 
    0.00237658f, -0.01429686f, -0.04625594f, -0.01457042f, -0.02364435f, 0.00388683f, -0.05802079f, -0.04459891f, 
    -0.00144047f, -0.06268772f, -0.05361318f, -0.00368261f, -0.01240531f, 0.04200264f, 0.05018982f, -0.06188862f, 
    0.01156310f, 0.01737431f, 0.03980440f, -0.01942825f, -0.04280742f, 0.02885535f, 0.03260889f, 0.01923949f, 
    0.01682103f, -0.01289510f, 0.05026644f, -0.02594972f, -0.02743182f, 0.04393102f, -0.01366926f, -0.02728280f, 
    0.04583422f, 0.01762967f, 0.02720359f, -0.00840279f, -0.03831447f, -0.03744890f, -0.02685743f, -0.06107075f, 
    -0.01869102f, -0.01069084f, -0.04093269f, 0.02642803f, -0.06071415f, -0.05786422f, -0.05166712f, 0.01724496f, 
    -0.01303430f, 0.01634117f, -0.02846240f, 0.00998403f, 0.03653631f, -0.05644193f, -0.05678865f, -0.03483123f, 
    0.01691375f, -0.06204825f, 0.03508918f, 0.02011782f, -0.00902841f, 0.03288122f, -0.01692754f, 0.02580816f, 
    -0.02297132f, 0.02672382f, -0.00933495f, -0.02790385f, 0.03019134f, -0.03742892f, 0.00142085f, -0.01105039f, 
    0.00893445f, -0.01390200f, -0.06274305f, -0.04371893f, -0.00072002f, 0.00184122f, -0.03887937f, 0.02437894f, 
    0.05123825f, 0.03901025f, -0.02271813f, 0.02239637f, 0.02694317f, -0.00263647f, 0.04711567f, -0.03492187f, 
    0.01129210f, 0.03777014f, -0.03103402f, 0.04920880f, -0.02775045f, 0.01798259f, -0.05657659f, 0.00274148f, 
    -0.01263713f, 0.01592677f, -0.01513934f, -0.04110426f, -0.05481772f, 0.01393593f, -0.05652849f, 0.01170863f, 
    0.05035007f, -0.03017097f, -0.04033699f, -0.05215282f, -0.01355925f, -0.00610833f, 0.03235480f, 0.04700685f, 
    -0.06335541f, -0.02646470f, 0.01901563f, -0.01763139f, 0.00477185f, -0.02258071f, -0.05694863f, -0.00948964f, 
    0.05209573f, 0.01647520f, 0.02878310f, 0.00696456f, 0.03773385f, -0.02539829f, -0.05787848f, -0.03557323f, 
    0.02987379f, -0.04376846f, -0.06470151f, -0.01308596f, 0.02013710f, -0.01376855f, -0.00961236f, 0.01269325f, 
    -0.04626891f, 0.02264696f, -0.02695120f, 0.01529772f, -0.04578564f, 0.03846468f, -0.03825239f, 0.03275772f, 
    -0.02761518f, 0.02464344f, -0.05892339f, -0.04441931f, 0.01678143f, 0.02109735f, -0.04335926f, -0.01778142f, 
    -0.03207630f, 0.01806583f, 0.00686868f, -0.05605537f, -0.02861029f, 0.00324838f, -0.02576979f, 0.03568263f, 
    -0.01057495f, 0.04669561f, -0.04206078f, -0.00100303f, 0.01288564f, 0.03345815f, -0.05131040f, 0.01657699f, 
    0.01619559f, 0.03493103f, 0.01147746f, -0.02903122f, 0.04684160f, 0.04267583f, -0.05792725f, -0.03719404f, 
    0.02694385f, -0.03898734f, 0.00432718f, -0.04633192f, -0.02241179f, 0.00024598f, 0.03493903f, -0.06041035f, 
    -0.03496400f, 0.01549267f, 0.04680768f, 0.04373840f, 0.03351257f, -0.03071693f, 0.03441123f, -0.06397589f, 
    0.00013980f, -0.06137808f, 0.05285095f, -0.02740899f, -0.03176618f, 0.03833966f, -0.00600552f, 0.04769876f, 
    -0.17128181f, 0.00212482f, -0.05924152f, 0.19998719f, 0.03251085f, -0.04665575f, -0.19112760f, -0.24585384f, 
    -0.06074965f, -0.12228695f, 0.19278146f, -0.34661299f, 0.03364471f, -0.07955731f, 0.03843887f, 0.06456789f, 
    -0.00478388f, -0.02634345f, -0.13501757f, -0.28511801f, -0.02144558f, 0.06073553f, -0.06491644f, -0.04365214f, 
    -0.01371994f, -0.07424255f, -0.12654100f, 0.86970270f, 0.23747864f, -0.64638376f, -0.10219609f, -0.01613161f, 
    0.18880010f, 0.01474577f, 0.07298857f, 0.16099805f, 0.10298835f, -0.08769217f, 0.07439310f, 0.07711212f, 
    0.03619255f, -0.00018784f, 0.13752049f, -0.12353126f, 0.07678857f, 0.17289613f, -0.06944937f, 0.26669654f, 
    -0.01882651f, 0.02505414f, 0.07592344f, -0.03937377f, -0.00599681f, 0.00643063f, -0.49644735f, 0.19741417f, 
    -0.48032191f, -0.10436780f, -0.07798358f, 0.03380158f, 0.00408363f, 0.01643484f, 0.00765083f, -0.00325748f, 
    0.04715132f, 0.16078591f, -0.10635369f, -0.15707469f, 0.02736143f, -0.10841408f, -0.10790988f, -0.24399278f, 
    0.00660765f, -0.55437297f, -0.56845903f, -0.15752041f, -0.26467952f, -0.20783766f, 0.10668688f, -0.21622491f, 
    -0.12925257f, -0.76507980f, -0.33696276f, -0.36713028f, -0.10196517f, -0.23942550f, -0.02432165f, 0.09271508f, 
    0.07246818f, -0.07483200f, 0.07678693f, -0.03978073f, 0.04504545f, 0.05506778f, -0.10155948f, -0.04662807f, 
    0.14537896f, 0.00457601f, 0.10254845f, 0.12376043f, -0.76929963f, -1.19307947f, -0.24899085f, -0.22097370f, 
    -0.32764545f, 0.09189583f, -0.02080685f, -0.14580718f, 0.14006607f, 0.05243541f, 0.13306965f, -0.02422732f, 
    -0.01971955f, 0.03095382f, -0.08131669f, -0.02842630f, -0.10390949f, -0.06186963f, -0.28740922f, 0.10828523f, 
    -0.23642650f, -0.21542363f, -0.35787198f, -0.12630384f, -0.07004596f, -0.17418958f, 0.02382646f, 0.20348996f, 
    0.17352024f, -0.03186860f, -0.02277265f, 0.01185315f, 0.11635855f, -0.18788038f, -0.14496227f, 0.25914082f, 
    0.00158762f, -0.02705361f, -0.01558563f, -0.02051248f, 0.11354206f, 0.01470485f, -0.16447918f, -0.15075067f, 
    0.07635306f, 0.06952485f, 0.11084793f, 0.00719678f, 0.04223036f, -0.00407065f, 0.02507025f, -0.09491163f, 
    -0.18848744f, -0.01759155f, 0.17984737f, 0.09220755f, 0.08329842f, 0.06847474f, 0.12515040f, 0.08865004f, 
    -0.01972911f, -0.10992365f, 1.03551161f, 0.07841454f, 0.04472374f, -0.17651685f, -0.19179668f, -0.08700395f, 
    0.17240107f, 0.10872054f, -0.15742347f, 0.04720515f, -0.40793142f, 0.02381638f, -0.02935391f, 0.05765251f, 
    0.01094800f, -0.12215219f, -0.06456071f, -0.06319502f, 0.11653463f, 0.07069653f, -0.09075417f, -0.01047027f, 
    0.05401313f, 0.04721272f, 0.13082987f, -0.07655783f, -0.15776019f, 0.52280879f, -0.11669206f, -0.32346880f, 
    0.13606261f, 0.22639933f, 0.16761295f, 0.06601991f, -0.05366517f, 0.07978199f, -0.35149175f, -0.22252910f, 
    -0.07095111f, 0.19390814f, 0.05970852f, -0.03480574f, -0.14914255f, -0.12382776f, -0.04517286f, -0.00789564f, 
    -0.00336094f, 0.23557541f, 0.08930113f, 0.04214619f, 0.19267187f, 0.02727856f, -0.02434541f, 0.04378001f, 
    -0.14178407f, -0.08042131f, 0.14260921f, -0.14081387f, -0.12154814f, -0.03191454f, 0.02997870f, 0.02566065f, 
    -0.02941274f, -0.13141413f, 0.23225652f, 0.01647602f, 0.44582254f, -0.06975681f, 0.02432201f, 0.05027197f, 
    0.13097909f, 0.16854443f, 0.28700098f, 0.04647207f, 0.13990802f, 0.00651583f, -0.10427129f, -0.04392379f, 
    -0.17918286f, -0.03567764f, 0.01617454f, -0.08443914f, -0.29032576f, -0.05093869f, -0.26066610f, -0.21801785f, 
    -0.29564223f, -0.05382573f, -0.15507737f, -0.19778343f, 0.45216566f, -0.59621310f, 0.13376237f, -0.01637649f, 
    -0.21041210f, -0.22643203f, 0.04307676f, -0.05782783f, 0.00121202f, -0.62776035f, 0.25478396f, -0.27031681f, 
    -0.14571793f, 0.05755325f, 0.00590547f, -0.00580562f, -0.07525071f, -0.03593269f, 0.10415403f, -0.26708430f, 
    -0.77559853f, 0.05218619f, 0.05821710f, 0.05088615f, -0.04709899f, 0.00269550f, 0.18404292f, 0.30003852f, 
    0.14142080f, 0.03317068f, 0.05285804f, 0.24689864f, 0.25610721f, 0.03990717f, 0.00625457f, -0.02306262f, 
    -0.29657522f, 0.25446260f, 0.21306394f, -0.14317743f, -0.07335070f, 0.02716339f, 0.15806057f, 0.19084294f, 
    0.12187966f, -0.52676475f, -0.58705717f, -0.90231502f, -0.13552508f, 0.05261910f, 0.03975119f, -0.01759674f, 
    0.00573767f, -0.12212580f, -0.21567705f, -0.04021374f, -0.14464352f, -0.09178418f, 0.20754553f, 0.07197067f, 
    0.35492510f, 0.05524341f, -0.05568489f, -0.25246435f, 0.14075364f, -0.41871607f, -0.11836767f, 0.13447060f, 
    0.08251172f, 0.01487190f, 0.00833282f, -0.01377639f, 0.28228858f, 0.31325170f, 0.04179514f, -0.11297762f, 
    0.01987408f, 0.03773845f, -0.00276150f, -0.05952493f, -0.21208069f, 0.26811916f, 0.22558422f, 0.13847226f, 
    0.10232991f, 0.08400773f, -0.06967115f, -0.07099761f, -0.01571999f, 0.03747417f, 0.14886798f, 0.00006429f, 
    0.04807452f, -0.18948106f, -0.01369108f, -0.04385534f, 0.00570022f, -0.06134294f, 0.09978150f, 0.18586373f, 
    0.24080962f, 0.09923212f, 0.00615490f, 0.32729059f, 0.04220239f, -0.06767497f, 0.04424197f, -0.12360869f, 
    -0.37674856f, -0.51529711f, -0.63328022f, -0.08295307f, 0.12160534f, 0.24003139f, -0.08771195f, -0.16449347f, 
    -0.20897703f, -0.72749060f, -0.30225819f, -0.59530014f, -0.15311672f, 0.03603026f, -0.24260794f, -0.10812307f, 
    -0.10835769f, -0.26681897f, 0.25229108f, 0.14232789f, -0.07156347f, 0.02272152f, -0.07465763f, 0.01861941f, 
    -0.00467323f, -0.00567055f, 0.04660272f, -0.41733992f, -0.09090412f, -0.21980974f, -0.09363464f, -0.08329436f, 
    -0.04425626f, 0.01367276f, 0.04417179f, -0.20613731f, 0.20517641f, 0.30278185f, 0.09855851f, 0.08637980f, 
    0.00268795f, -0.01508129f, -0.03642072f, 0.03548924f, 0.06036440f, 0.35559428f, -0.41181156f, -0.55846649f, 
    -0.11968788f, 0.15222485f, -0.03421060f, 0.01815513f, 0.14367318f, -0.03403642f, 0.04612440f, -0.11501275f, 
    0.24091905f, -0.10160609f, 0.24121141f, -0.22478262f, 0.12693347f, 0.06082649f, -0.07004182f, 0.24268925f, 
    0.35788104f, 0.17921196f, -0.02008999f, 0.03398193f, -0.18453340f, 0.00956931f, 0.26602963f, 0.13366143f, 
    0.24834365f, 0.23194452f, 0.11248469f, -0.03934114f, -0.03029413f, -0.04152632f, -0.16905367f, -0.20159012f, 
    0.01305390f, 0.07771392f, -0.03904576f, 0.14330944f, -0.15824796f, -0.02564170f, -0.08266242f, 0.06311139f, 
    -0.03715265f, 0.14497754f, -0.03080639f, 0.16670839f, -0.03051121f, -0.27247328f, 0.12645750f, -0.28873128f, 
    -0.05571341f, 0.10747490f, -0.13722493f, 0.36458987f, 0.46895063f, 0.00593467f, 0.06321092f, -0.18091032f, 
    -0.33443156f, 0.16571304f, 0.26273242f, 0.27294230f, 0.12777744f, 0.24830820f, 0.01171025f, -0.12762645f, 
    -0.18949169f, 0.01714201f, 0.13283898f, 0.04133617f, -0.04839439f, -0.71915799f, 0.13477568f, -0.07015816f, 
    0.15440656f, 0.21584417f, 0.14883710f, 0.35388130f, -0.06247645f, -0.02334369f, -0.31764388f, -0.18644293f, 
    -0.32094941f, 0.09792412f, 0.20622917f, 0.01792612f, 0.04326560f, 0.03731349f, 0.01647887f, -0.08113745f, 
    -0.19539984f, -0.01595632f, 0.05180839f, 0.15953106f, -0.11539256f, 0.19334176f, -0.12185340f, 0.18178734f, 
    0.25232691f, -0.26726586f, -0.31407413f, 0.03955229f, 0.04666375f, 0.18481492f, 0.02856885f, -0.01914823f, 
    0.00876806f, -0.18909809f, 0.10251821f, -0.09513694f, 0.02142476f, 0.12973927f, 0.05817133f, -0.04441312f, 
    0.02609101f, 0.07014848f, 0.08076612f, 0.28828987f, 0.13550144f, -0.09560173f, 0.00605649f, -0.12290659f, 
    -0.02897768f, 0.00049989f, -0.09237891f, 0.29049593f, -0.29154581f, -0.23208617f, -0.06340094f, -0.01069569f, 
    0.01357058f, -0.01970892f, 0.06519748f, 0.00531209f, -0.47724548f, -0.91382903f, -0.82825655f, -0.03578146f, 
    0.14315251f, 0.19626063f, -0.08558831f, -0.08804847f, -0.08910696f, -0.26947081f, -0.04702871f, -0.14204459f, 
    -0.16663514f, -0.15901005f, 0.01309219f, 0.04746915f, 0.00639125f, -0.06979588f, -0.35165673f, 0.60539812f, 
    0.53884035f, -0.15099117f, -0.21520346f, -0.17735888f, 0.07950623f, 0.18186684f, 0.08834089f, 0.02740373f, 
    0.29537919f, -0.15248758f, -0.06282482f, -0.06200948f, -0.09245276f, 0.09405445f, 0.11106762f, -0.05835935f, 
    0.43277389f, -0.00175466f, -0.10852271f, -0.16608645f, 0.04483208f, -0.28474987f, -0.15881631f, -0.32088363f, 
    -0.23854029f, -0.38292280f, 0.02431911f, 0.29873970f, -0.08168118f, -0.13994972f, -0.19255772f, 0.01850681f, 
    0.06020163f, 0.00611298f, -0.13544242f, 0.16286288f, 0.16885321f, -0.27076274f, 0.01374000f, 0.07022702f, 
    0.05679215f, 0.20768636f, -0.33421075f, 0.26618379f, 0.33131617f, 0.00121916f, 0.04581492f, -0.05870388f, 
    -0.14414722f, -0.00737144f, -0.06440179f, -0.09981740f, -0.40481716f, -0.35054898f, -0.25172332f, 0.18760496f, 
    -0.09271818f, -0.04007652f, 0.11615042f, -0.15040620f, 0.03828613f, -0.00360714f, 0.02186273f, 0.15322834f, 
    0.16194399f, -0.11812166f, 0.08857696f, 0.11952030f, -0.08520916f, 0.06409682f, -0.04405892f, 0.27970815f, 
    0.37320140f, 0.10208052f, 0.18620847f, -0.24365890f, 0.06425049f, -0.17236824f, 0.01405586f, 0.77059478f, 
    0.18033102f, -0.81884587f, -0.02232444f, 0.00229572f, 0.00244211f, -0.05947965f, 0.17883494f, 0.04374274f, 
    -0.52755731f, 0.12965299f, 0.29584283f, -0.09252896f, 0.01623592f, -0.08192611f, 0.26695859f, -0.09611142f, 
    0.21939062f, -0.46087465f, 0.23086073f, 0.19806500f, -0.04902005f, -0.11955039f, -0.25316435f, 0.15431733f, 
    0.10990243f, 0.16058035f, -0.09654695f, -0.25095078f, -0.20220710f, -0.07626393f, -0.00455933f, -0.01625226f, 
    -0.03942519f, 0.21443230f, -0.09569983f, 0.13918665f, 0.22844677f, 0.11319427f, -0.10476486f, -0.09951430f, 
    -0.15178837f, 0.21210741f, -0.03220580f, 0.07308280f, -0.50118899f, 0.06338399f, -0.00886872f, 0.24445300f, 
    0.00960104f, -0.06525160f, 0.05204223f, -0.11603326f, 0.17514576f, -0.10092042f, 0.31764612f, -0.07725320f, 
    -0.04555922f, 0.05940059f, 0.05238444f, -0.02263319f, 0.01450334f, 0.20816895f, 0.09604866f, 0.32071099f, 
    -0.97654974f, 0.02450283f, -0.10146657f, -0.00444339f, -0.03203179f, 0.14610870f, -0.25554463f, 0.07570620f, 
    -0.07627751f, -0.05707153f, 0.01691144f, 0.09111360f, -0.16942239f, -0.07683157f, -0.07198247f, -0.03648698f, 
    -0.24886566f, -0.13394664f, 0.25407857f, 0.02232346f, -0.06421362f, 0.04200437f, 0.20678869f, -0.12896417f, 
    0.21048424f, -0.38572988f, -0.19637533f, -0.53675115f, 0.03718003f, -0.05889934f, -0.19471575f, 0.07005394f, 
    0.17312229f, -0.20461465f, -0.31727061f, 0.08675388f, -0.18220462f, 0.10387311f, 0.08540963f, -0.27007997f, 
    0.15164517f, 0.01221954f, 0.16566914f, 0.15868928f, -0.46920797f, 0.13241303f, -0.07034966f, -0.09350780f, 
    -0.07111302f, -0.13247813f, 0.02388549f, -0.10581893f, 0.02414484f, -0.42550778f, -0.15992974f, 0.06374382f, 
    0.12074298f, -0.11218648f, 0.10001016f, -0.11824824f, -0.07925738f, 0.15446098f, 0.13781987f, 0.21227616f, 
    0.07519409f, 0.06358305f, 0.07152195f, 0.09502339f, -0.15655354f, 0.12148065f, 0.15019022f, -0.00148621f, 
    0.33080509f, -0.08913054f, 0.10348543f, 0.14273536f, -0.01404137f, -0.01373790f, 0.02458522f, -0.01611855f, 
    -0.55309963f, -0.84430182f, 0.19999237f, -0.24015413f, -0.32668820f, 0.12878184f, 0.22115926f, -0.18033546f, 
    0.08926904f, 0.03093421f, 0.10994235f, -0.08524435f, 0.00254904f, 0.07122680f, 0.09635346f, -0.07110967f, 
    0.00885278f, -0.04351164f, 0.01998042f, -0.15774448f, -0.06448549f, 0.11726321f, -0.11277422f, -0.03690747f, 
    0.30313626f, -0.04134531f, -0.46784660f, -0.17091827f, -0.13152735f, 0.01629283f, -0.12145498f, -0.11318193f, 
    0.28315204f, 0.07895674f, 0.05599015f, -0.11344355f, 0.08178280f, 0.61251044f, 0.01699239f, -0.00949151f, 
    -0.14358863f, 0.19341551f, -0.03155547f, 0.20130503f, -0.06231907f, 0.18636574f, 0.36251968f, 0.02701787f, 
    0.18450066f, -0.08857137f, 0.13075905f, 0.07695971f, 0.15792468f, -0.11536732f, 0.12251277f, 0.49141955f, 
    -0.04217451f, -0.11526696f, 0.03896647f, 0.09305672f, -0.18019874f, 0.03429962f, -0.16169833f, 0.04530131f, 
    0.52236056f, -0.06657644f, -0.17902625f, 0.03664995f, 0.02902618f, -0.00401506f, 0.09781677f, 0.49758795f, 
    0.12828748f, -0.06427171f, 0.13243291f, 0.21350975f, -0.09687892f, -0.11591331f, 0.03326968f, -0.16966733f, 
    0.05867931f, -0.01448291f, -0.01693271f, 0.25683895f, -0.04731716f, -0.42293817f, 0.13433847f, -0.35700199f, 
    -0.65797079f, 0.14531361f, -0.32942125f, 0.05416142f, -0.07534715f, 0.05059251f, 0.01850257f, 0.08231176f, 
    0.01387064f, 0.12182865f, -0.07520770f, 0.09683141f, 0.00661286f, 0.09193034f, -0.07744370f, -0.09328692f, 
    -0.28071162f, -0.20122430f, -0.23437044f, -0.12264375f, 0.40391186f, 0.33901697f, 0.05903677f, 0.05551120f, 
    -0.11789193f, 0.00872774f, 0.07164422f, -0.02916133f, 0.01324852f, 0.12806599f, 0.07512914f, 0.09256378f, 
    -0.05517501f, 0.09516676f, -0.03940753f, -0.03454859f, 0.03066898f, 0.27779138f, 0.22493830f, 0.06722586f, 
    0.25925270f, 0.07574444f, 0.11689455f, 0.21497500f, 0.07592197f, 0.06000080f, -0.20940465f, 0.24599032f, 
    0.27312198f, 0.15297154f, 0.09122965f, -0.02216293f, -0.04244292f, 0.04100408f, -0.12527050f, -0.47684231f, 
    0.10622415f, -0.14116266f, 0.06709687f, 0.19336686f, 0.09287876f, 0.18838327f, 0.22291370f, 0.01569476f, 
    -0.03527033f, -0.68382519f, -0.15155162f, -0.04397475f, 0.19762063f, 0.16285175f, 0.10895260f, 0.23174666f, 
    0.26275805f, -0.14921351f, -0.34369659f, 0.04789927f, 0.19160058f, 0.31967407f, 0.13510025f, 0.07675985f, 
    0.23177429f, 0.12322492f, 0.11916020f, -0.02728266f, -0.06300300f, 0.00596640f, -0.01003942f, 0.06587748f, 
    -0.20764881f, -0.16999289f, -0.36550522f, -0.36202312f, 0.15949698f, 0.20200427f, 0.13789783f, 0.25503987f, 
    0.22071467f, -0.21361282f, 0.35371765f, 0.14836079f, 0.10966177f, 0.32657447f, -0.12591316f, -0.05697045f, 
    -0.00509112f, 0.06651210f, 0.19776563f, 0.01273639f, 0.00719486f, 0.08440138f, -0.66760963f, 0.24727476f, 
    -0.08165755f, 0.09245456f, 0.16498812f, 0.17808352f, -0.13183208f, -0.03788267f, -0.16264506f, 0.26845685f, 
    -0.15411589f, -0.16176718f, 0.01665859f, -0.22943535f, 0.38014013f, -0.01427330f, -0.03827593f, 0.27784276f, 
    0.26484153f, -0.02840716f, -0.08354026f, -0.15390295f, 0.08156344f, 0.14283659f, -0.06579978f, -0.05881381f, 
    -0.01222260f, -0.05051481f, -0.04309560f, 0.17752494f, 0.11300386f, 0.17695805f, 0.05640223f, -0.04859929f, 
    -0.06984133f, 0.02048755f, 0.03724932f, -0.07614961f, -0.10718516f, 0.08741014f, -0.09252331f, 0.05610605f, 
    -0.12391530f, -0.26625949f, -0.90871489f, 0.09033225f, 0.08584493f, 0.13736801f, 0.28363815f, 0.10111456f, 
    -0.00005319f, 0.05083583f, 0.30262482f, 0.55057818f, 0.32297015f, -0.04521417f, 0.00799127f, -0.27884039f, 
    0.03964128f, -0.02115077f, 0.10850041f, -0.03284856f, 0.13146263f, 0.04579408f, 0.14599261f, 0.03616948f, 
    0.02842472f, 0.12361184f, -0.19502969f, -0.09542482f, -0.32033941f, -0.03780540f, -0.05774511f, 0.16767040f, 
    0.24154131f, -0.08061694f, -0.07801816f, -0.11116081f, -0.03900522f, -0.38466972f, -0.11064474f, -0.22010973f, 
    -0.09001429f, 0.04558181f, 0.09133651f, -0.07001620f, 0.19198796f, 0.13106889f, -0.19825086f, 0.06535618f, 
    0.10772571f, -0.07036556f, -0.08956220f, 0.07861850f, -0.19411719f, 0.20984758f, -0.07998214f, -0.23008141f, 
    0.19546407f, -0.10484387f, 0.05740802f, -0.02001672f, 0.04712820f, -0.04274142f, -0.07766213f, -0.13317823f, 
    -0.22830762f, 0.13162608f, -0.04243598f, 0.12821715f, -0.09630955f, -0.04328017f, -0.04346044f, -0.28107443f, 
    0.11866673f, -0.04710143f, 0.04477705f, -0.00823370f, -0.07964566f, 0.15095851f, 0.11937212f, 0.13793240f, 
    0.05063584f, -0.35761228f, -0.11896317f, 0.08499457f, -0.24237925f, 0.20280498f, 0.08019762f, 0.08486614f, 
    0.06997877f, -0.00126015f, -0.15104139f, 0.17313237f, -0.01607072f, -0.24328962f, 0.33397716f, 0.00705353f, 
    -0.02221348f, -0.01653930f, -0.03861176f, 0.28446186f, 0.04260736f, 0.06289778f, -0.23134999f, 0.03534426f, 
    0.07646926f, 0.16397302f, -0.01166595f, 0.00520973f, -0.03469532f, 0.03961766f, 0.02809023f, 0.39106882f, 
    0.40699396f, 0.33496714f, 0.22759216f, -0.04463946f, -0.11134138f, -0.15184249f, -0.00019421f, 0.09692761f, 
    0.01232457f, 0.34612387f, 0.02173078f, -0.04147436f, -0.03332108f, 0.09116038f, -0.05039434f, -0.09440134f, 
    0.19163223f, 0.28347510f, 0.42656174f, 0.04156067f, -0.20308782f, 0.32565039f, 0.19905718f, -0.01469482f, 
    0.17388430f, 0.05011977f, 0.11021800f, -0.23855606f, 0.06582538f, 0.07656938f, 0.05591986f, -0.13902088f, 
    0.04206349f, -0.28379017f, 0.28759789f, 0.09542058f, 0.22780156f, 0.00971104f, -0.10666645f, -0.09007646f, 
    0.12501338f, 0.19829391f, -0.00982109f, -0.12271926f, 0.21651836f, 0.59035444f, -0.10241154f, -0.13473788f, 
    -0.12905286f, 0.02095570f, -0.13995105f, -0.01148614f, 0.09783165f, -0.07904440f, 0.14276928f, 0.00306085f, 
    0.04966446f, -0.08878981f, 0.03605547f, 0.07265513f, 0.18014520f, -0.24896736f, 0.02326519f, -0.05254190f, 
    0.02867717f, 0.14694779f, -0.09284757f, -0.05210182f, 0.15123154f, 0.14087604f, -0.22223073f, -0.12656023f, 
    0.73724127f, 0.00868988f, -0.02050772f, 0.01006216f, -0.13610420f, -0.16103491f, 0.03003046f, -0.15365390f, 
    0.32049996f, 0.14154111f, 0.26789963f, -0.17602925f, 0.13141881f, -0.13905464f, 0.15229402f, -0.14957643f, 
    0.32204717f, -0.25002426f, -0.29020351f, -0.18310814f, -0.06686530f, -0.24807301f, -0.03092276f, -0.00076346f, 
    -0.09117877f, 0.32515779f, 0.02396136f, 0.01548573f, 0.03131409f, 0.03364546f, 0.13173801f, -0.14772339f, 
    0.10889819f, -0.03262481f, 0.06419264f, 0.06006389f, -0.08557498f, -0.15389672f, 0.15214024f, -0.19692978f, 
    0.22860539f, -0.21637747f, 0.04843295f, 0.22501561f, -0.04774974f, 0.17796932f, 0.01232572f, -0.20352502f, 
    -0.18428847f, 0.11493064f, -0.13350450f, -0.02124276f, -0.31234819f, -0.13212128f, -0.01147107f, 0.04551854f, 
    -0.04581584f, -0.12868242f, 0.04658990f, 0.11520835f, -0.13469556f, 0.00874066f, -0.18246076f, -0.14746709f, 
    -0.15310156f, -0.23364536f, -0.26016849f, -0.04584130f, -0.04128610f, 0.03341192f, -0.01060269f, 0.18679500f, 
    0.31815344f, -0.12144659f, 0.14031360f, 0.18492225f, -0.06060627f, 0.14158501f, -0.14925703f, -0.39501750f, 
    0.45111558f, -0.14834958f, 0.02812684f, 0.22252394f, -0.02704476f, 0.03894902f, -0.13825004f, 0.04905380f, 
    0.06551822f, -0.11508902f, 0.08562841f, 0.03746048f, -0.05441687f, -0.38507789f, -0.05488047f, 0.02763530f, 
    0.10810383f, 0.07982617f, -0.08518513f, -0.15133438f, 0.00943026f, 0.02569981f, 0.14292374f, 0.25642827f, 
    0.10815705f, -0.04849123f, 0.08880664f, -0.35735446f, 0.58627647f, 0.02209341f, -0.04532439f, 0.13072926f, 
    0.04850351f, 0.24917868f, 0.20901620f, -0.37504834f, 0.72433650f, -0.28525725f, 0.20157112f, 0.14592043f, 
    -0.02437359f, -0.23091999f, -0.09628740f, 0.06171098f, 0.06800039f, 0.16229504f, -0.12345703f, 0.11569323f, 
    0.14192726f, -0.08000838f, 0.07948055f, 0.03858596f, 0.12358975f, 0.00034321f, 0.06832623f, 0.55261022f, 
    -0.00229466f, 0.17875367f, 0.11897570f, -0.00876792f, -0.07854747f, -0.14129800f, 0.25295421f, 0.28063986f, 
    0.30273417f, -0.01285237f, 0.19577947f, -0.03215790f, 0.18920393f, -0.18816288f, 0.16799049f, -0.27770433f, 
    0.33822873f, 0.44724581f, -0.18602356f, -0.13228326f, 0.11270279f, 0.21794014f, 0.07143077f, 0.01623013f, 
    -0.11998231f, -0.09248429f, 0.00644004f, 0.03176921f, -0.00704454f, 0.23793265f, 0.03598805f, -0.11100619f, 
    -0.05268261f, -0.06567754f, 0.02106697f, 0.13646956f, 0.09194525f, 0.16256957f, -0.37568790f, 0.19655743f, 
    -0.15300229f, -0.02361613f, 0.04023513f, -0.04326936f, 0.29197225f, 0.14333941f, 0.11899699f, -0.12835351f, 
    0.02451584f, -0.17964540f, 0.07339305f, -0.08058876f, -0.08460845f, -0.14778434f, -0.20601696f, 0.08176853f, 
    -0.11246885f, 0.07629932f, -0.12506227f, 0.10067911f, 0.16655831f, -0.10854330f, 0.05203358f, -0.09600039f, 
    -0.05572645f, -0.06477360f, 0.12954506f, -0.14149466f, -0.01950532f, -0.12830667f, -0.08856502f, 0.37926954f, 
    0.13239442f, 0.04704823f, -0.02882394f, -0.03851268f, -0.10796948f, 0.07678574f, 0.16242065f, 0.02820701f, 
    -0.12135796f, 0.18038337f, 0.09361789f, 0.01255940f, -0.18870564f, -0.04100454f, -0.09448189f, -0.12415028f, 
    0.16800112f, 0.11082762f, -0.21588059f, 0.28542092f, -0.05863073f, -0.03181822f, 0.16032486f, 0.31916684f, 
    -0.02349904f, -0.05251520f, -0.01737298f, -0.06398384f, 0.03885899f, -0.02668517f, 0.00814755f, -0.07464741f, 
    0.03786282f, 0.04598808f, -0.06784631f, 0.00114379f, -0.02704139f, 0.02225268f, -0.02633335f, -0.07123729f, 
    -0.03615941f, 0.01469957f, -0.02830571f, -0.02072942f, 0.05756675f, 0.02971145f, 0.01068678f, -0.04290293f, 
    -0.04000589f, 0.04480456f, -0.01198883f, -0.05303389f, -0.07332593f, -0.02095122f, 0.01922987f, 0.00760834f, 
    -0.00667022f, -0.07319096f, -0.07627569f, -0.05698437f, 0.02711858f, -0.03225046f, -0.04286226f, -0.01724287f, 
    -0.00437533f, -0.01012365f, -0.03670894f, -0.02486197f, -0.02893022f, -0.03557243f, -0.04251353f, -0.04406257f, 
    0.02505891f, 0.02705613f, -0.05250449f, -0.05975249f, 0.00033692f, -0.06541434f, 0.00850648f, -0.00739530f, 
    0.04303380f, 0.02694090f, -0.03068350f, -0.06282707f, -0.00446535f, 0.02992381f, -0.04193418f, 0.02017259f, 
    0.04520763f, 0.03406445f, -0.00954227f, -0.00690696f, -0.02397145f, -0.05765357f, 0.00178506f, -0.03086436f, 
    0.03681977f, -0.05255984f, -0.04853889f, -0.03786107f, 0.01343826f, -0.06709986f, -0.06709536f, -0.05042946f, 
    -0.04904886f, 0.00896459f, -0.03400224f, 0.00498421f, -0.02881997f, 0.02253093f, 0.03733175f, -0.00069070f, 
    -0.04745319f, -0.00953309f, -0.02659458f, -0.02148108f, -0.01532329f, -0.03923435f, -0.04184552f, 0.00312459f, 
    -0.01825987f, -0.01214365f, -0.04706575f, -0.00103533f, -0.03269267f, -0.01825026f, -0.01404220f, -0.01474428f, 
    0.03972311f, 0.04059416f, -0.05204298f, -0.05199312f, -0.02376832f, -0.03831317f, 0.02746202f, -0.05100628f, 
    -0.02683220f, 0.00282692f, -0.02587945f, 0.01819079f, -0.03657654f, -0.02202241f, -0.07605074f, 0.01956096f, 
    -0.03140559f, 0.00456780f, -0.03447289f, 0.02125015f, 0.04224350f, 0.00217797f, -0.07208077f, -0.04894608f, 
    0.05910336f, -0.05831315f, -0.00046072f, -0.05433509f, -0.00130080f, -0.04300642f, -0.01923672f, 0.01590662f, 
    0.00189926f, 0.03419207f, 0.04626464f, 0.03398878f, -0.03804025f, -0.06811284f, -0.04999959f, 0.01852876f, 
    0.04625630f, 0.04267631f, 0.01527715f, 0.01784004f, -0.00777744f, -0.00269549f, -0.04409204f, 0.00554261f, 
    -0.00917379f, 0.01676662f, 0.00746988f, -0.02750473f, 0.03588779f, -0.05107411f, 0.03861335f, -0.04808934f, 
    -0.05360625f, 0.03027619f, 0.00718011f, 0.05006010f, 0.05723030f, -0.07443894f, -0.03988628f, 0.02179014f, 
    -0.02352727f, 0.00839644f, -0.00410375f, -0.00801641f, -0.01612577f, 0.00873987f, 0.03417636f, -0.04305657f, 
    0.03439655f, 0.02180550f, -0.06453921f, -0.03613216f, -0.03991895f, -0.03419999f, 0.05807007f, 0.02926192f, 
    0.04708586f, -0.02169960f, -0.06647807f, -0.06523739f, 0.03655420f, -0.02487593f, -0.03438264f, -0.06492549f, 
    -0.00426332f, 0.01087576f, -0.04523624f, -0.03794168f, 0.02408052f, -0.03141033f, 0.02482848f, -0.04276755f, 
    -0.00345217f, -0.01904256f, 0.02719339f, -0.06938831f, -0.03587224f, -0.05441871f, -0.00862078f, -0.02567088f, 
    0.04951587f, 0.03441017f, 0.05050854f, 0.00475482f, 0.04210218f, 0.02109879f, -0.02919821f, 0.01329171f, 
    -0.03396436f, 0.03414221f, -0.05545408f, -0.07588541f, -0.03091775f, -0.02653914f, -0.00277681f, 0.00048951f, 
    0.03638424f, -0.02938584f, 0.03224079f, -0.04644224f, -0.00907193f, 0.02621456f, -0.02095493f, 0.02377805f, 
    0.02358914f, -0.07092726f, -0.01519020f, 0.04872229f, 0.00301005f, -0.04705541f, 0.04807646f, 0.01228759f, 
    -0.01213475f, 0.03898104f, 0.00181052f, 0.03550820f, -0.04594678f, -0.00060196f, 0.02878805f, -0.00155511f, 
    0.01633517f, 0.02260840f, 0.02561425f, 0.00103487f, -0.01990880f, -0.03305500f, -0.06043998f, 0.01086239f, 
    -0.08129105f, -0.06370035f, -0.05601079f, -0.05901368f, 0.00361548f, -0.02887849f, -0.04133289f, -0.00455789f, 
    -0.01144243f, 0.02361440f, -0.04445854f, 0.00883272f, 0.03431375f, -0.01329073f, 0.03192273f, -0.03685676f, 
    -0.02123225f, -0.03846664f, -0.05897607f, -0.04571699f, -0.06240606f, 0.01615594f, -0.08156469f, 0.03024062f, 
    -0.07023386f, -0.02178135f, -0.05927559f, -0.07328204f, -0.07678941f, -0.01126997f, -0.05366100f, 0.01642554f, 
    0.03912666f, 0.06401061f, -0.04339666f, -0.46017194f, -0.02266375f, -0.14662872f, -0.33694881f, -0.03270352f, 
    -0.01223230f, 0.57225925f, 0.17878821f, 0.01807200f, -0.06632292f, 0.16781744f, 0.09410150f, 0.04391254f, 
    0.10097460f, 0.01647483f, -0.06630827f, -0.12853064f, 0.05340618f, 0.13301963f, 0.16136166f, -0.17303607f, 
    -0.04803504f, 0.01711250f, -0.24889164f, 0.43949601f, -0.25740844f, -0.09421727f, -0.19494952f, 0.22495675f, 
    0.07204042f, -0.01145484f, 0.16001667f, -0.12327217f, 0.10321740f, -0.00029915f, -0.02859019f, 0.03976216f, 
    0.06932037f, 0.02103754f, -0.03650701f, -0.03868466f, 0.05581573f, -0.09800044f, 0.36822063f, 0.32245755f, 
    0.08159400f, 0.13647866f, -0.11020362f, 0.00582868f, 0.05093202f, -0.00105902f, 0.30633897f, -0.42079172f, 
    -0.48241946f, -0.19232444f, -0.06392583f, 0.02379625f, 0.01276738f, -0.07484274f, -0.00476853f, -0.72868276f, 
    -0.10029027f, -0.28757820f, 0.05169761f, 0.14267607f, -0.19039550f, -0.13443471f, -0.04848386f, -0.01113821f, 
    0.13781388f, 0.04486922f, 0.38991836f, 0.01322439f, 0.07958783f, -0.12873927f, 0.01505092f, 0.12951569f, 
    0.09755907f, 0.19127993f, 0.20024908f, 0.25589311f, -0.09620222f, 0.04472410f, -0.11327749f, 0.08959334f, 
    0.08790462f, -0.20552059f, 0.15149477f, -0.02278780f, -0.06175452f, -0.06603111f, -0.00565983f, 0.11086700f, 
    -0.16973630f, 0.19980808f, -0.10545064f, 0.31280452f, -0.38781136f, 0.00677037f, -0.21313325f, -0.02160566f, 
    -0.01061293f, 0.18420474f, 0.17390782f, -0.14681296f, -0.13292025f, -0.10108621f, 0.11918844f, 0.12784536f, 
    0.01266091f, -0.14388728f, 0.05710866f, 0.01456452f, 0.04239072f, -0.58505404f, 0.09938519f, 0.25039899f, 
    0.01630070f, 0.13781850f, 0.02443045f, 0.11942007f, 0.18615647f, -0.09930677f, -0.38427189f, 0.31986874f, 
    0.17656429f, 0.00289145f, 0.12825675f, -0.26663554f, 0.03645151f, 0.01858150f, -0.06821680f, -0.51152080f, 
    0.08068038f, -0.02547471f, -0.01822675f, -0.23614441f, -0.26680136f, -0.09046304f, -0.03818547f, -0.06645548f, 
    0.04449092f, 0.10728180f, 0.13166851f, 0.03343873f, -0.02786141f, -0.00134837f, 0.02850863f, 0.02734208f, 
    0.01049846f, -0.00001645f, 0.21546608f, 0.15415406f, -0.05080746f, -0.06934669f, -0.06798698f, -0.02406789f, 
    0.03548209f, -0.17815571f, 0.52520609f, 0.16826382f, -0.18758491f, -0.05705766f, 0.07787205f, -0.16431341f, 
    0.48590413f, -0.35476351f, -0.01980093f, -0.74289000f, 0.24500734f, -0.28076473f, -0.10400138f, -0.39148226f, 
    -0.38082150f, 0.02698240f, 0.04610258f, 0.12613647f, 0.05681667f, -0.04651956f, -0.04608658f, -0.11549000f, 
    -0.04929348f, 0.02616821f, -0.11373811f, -0.00647878f, -0.14660831f, 0.36748743f, -0.31938639f, -0.09243216f, 
    -0.08324587f, -0.00556711f, -0.01246488f, 0.11662749f, -0.14443904f, 0.09296195f, 0.26372018f, 0.05118184f, 
    0.06034558f, 0.07505525f, -0.05054453f, -0.17292053f, -0.20924528f, 0.06738254f, -0.04412872f, -0.25310063f, 
    -0.16249442f, 0.01514294f, -0.10281917f, 0.16759904f, 0.05189217f, 0.09506831f, -0.01823584f, -0.00288138f, 
    -0.17388427f, 0.20600601f, 0.09480445f, -0.00469852f, 0.21064639f, 0.16120407f, 0.00374777f, 0.26642790f, 
    -0.07015623f, -0.35322013f, 0.20392033f, -0.10599402f, -0.00294089f, 0.03296015f, 0.04419669f, 0.04804013f, 
    0.04449493f, -0.06669615f, 0.10223578f, -0.01055658f, 0.03960050f, -0.13146099f, 0.07989286f, 0.05557711f, 
    -0.02662475f, -0.10883720f, 0.06600375f, -0.20324168f, -0.14286155f, 0.13845354f, -0.00116883f, 0.08839002f, 
    -0.11517938f, 0.00122183f, -0.17373838f, -0.12801659f, 0.24233697f, 0.17942925f, 0.40994340f, 0.17964908f, 
    0.21617988f, -0.02063427f, 0.16143477f, 0.16448240f, -0.01273812f, 0.50515217f, -0.00230757f, -0.20117292f, 
    0.02977333f, 0.00450222f, -0.02466098f, 0.02767128f, -0.06467716f, 0.16136183f, -0.24517585f, 0.09203804f, 
    -0.54270989f, -0.15795559f, -0.21964063f, -0.26639912f, 0.00935274f, 0.00063906f, 0.07091661f, -0.00178600f, 
    -0.15710400f, 0.12790428f, -0.30583000f, 0.21726340f, -0.24541320f, 0.01117312f, 0.19794838f, 0.00757554f, 
    -0.00231386f, 0.00478665f, -0.00318187f, 0.13286602f, -0.10550941f, -0.08425149f, -0.21823753f, 0.36111113f, 
    -0.17256638f, -0.05523418f, 0.10042664f, 0.06695089f, -0.18424031f, -0.06755129f, 0.00852801f, -0.08656389f, 
    -0.22109272f, -0.27261475f, 0.15521814f, -0.18389241f, -0.11995891f, 0.08863073f, -0.02168415f, 0.04216677f, 
    0.05354885f, -0.41778356f, -0.30732396f, -0.18655682f, -0.17746043f, 0.16212878f, 0.06582311f, -0.04813989f, 
    0.12759872f, 0.01772764f, -0.01078217f, 0.28200278f, 0.08748677f, 0.11256365f, -0.01608277f, 0.16401340f, 
    0.09704710f, -0.02035804f, -0.09748971f, -0.08013484f, 0.07169059f, -0.03124660f, 0.26071653f, 0.01780464f, 
    0.04692994f, -0.04770229f, 0.11132842f, -0.10069810f, 0.02188249f, -0.11002912f, -0.43206704f, -0.03449610f, 
    -0.15029897f, -0.20485923f, 0.05167925f, -0.01938630f, -0.29650724f, -0.03153897f, -0.08691399f, -0.03532074f, 
    -0.05009327f, 0.03449292f, 0.02020095f, -0.30482867f, -0.30829021f, -0.00138458f, 0.05991676f, 0.01704637f, 
    -0.38593215f, 0.21592709f, 0.04246495f, -0.04141841f, -0.15671438f, -0.04098414f, 0.02343038f, -0.04775151f, 
    -0.08724397f, 0.01022539f, 0.09669857f, -0.32287833f, -0.01015969f, -0.38918141f, -0.22227776f, -0.09921003f, 
    0.01957635f, -0.01992277f, -0.08207782f, 0.03969906f, 0.18016779f, 0.14048433f, -0.00148383f, 0.02772898f, 
    0.29846621f, -0.13818201f, 0.04187531f, -0.16847247f, -0.11440175f, -0.22148003f, 0.15788677f, -0.28830150f, 
    -0.35514399f, 0.00215783f, -0.22308663f, 0.03517994f, 0.05164582f, 0.03258368f, 0.17305797f, -0.02911659f, 
    0.04896971f, -0.03434990f, -0.04825481f, -0.06375471f, -0.18073651f, -0.35107300f, 0.07492999f, 0.01032209f, 
    0.08055545f, -0.01945397f, -0.06812605f, 0.03929758f, -0.10866350f, -0.01501425f, 0.22002944f, -0.19534491f, 
    -0.13675289f, 0.32676831f, 0.06835202f, 0.01524209f, -0.17977187f, -0.15161517f, -0.08051708f, 0.20306224f, 
    0.17421551f, 0.28942245f, 0.19965492f, -0.03010888f, -0.05537783f, -0.04351944f, -0.04046636f, -0.00790285f, 
    0.08773036f, 0.09680745f, 0.06983128f, -0.01824843f, 0.10528208f, 0.01754301f, -0.06192916f, -0.04995728f, 
    -0.10754206f, 0.23875873f, 0.21036303f, 0.12964979f, 0.11751291f, 0.14614041f, 0.00657721f, 0.08235411f, 
    -0.00846372f, -0.05754615f, 0.05976734f, 0.00861963f, -0.21708308f, 0.19215098f, -0.02233418f, -0.07361558f, 
    0.12070850f, 0.03602587f, 0.29311767f, 0.12808858f, 0.21874321f, 0.38256979f, 0.04867607f, 0.10594313f, 
    -0.30596331f, -0.02952902f, -0.08781353f, 0.14346924f, 0.17742178f, -0.07392239f, 0.01843719f, 0.10615785f, 
    0.01715608f, -0.01991825f, 0.20010825f, -0.01323966f, 0.03936753f, 0.33663839f, -0.17840202f, -0.03239103f, 
    -0.00265233f, 0.03359357f, -0.04279913f, 0.15725861f, 0.18508360f, 0.07905630f, 0.18382746f, 0.04503086f, 
    0.09677858f, -0.41370133f, -0.15336832f, 0.04600700f, -0.06747369f, -0.17794934f, -0.30342928f, 0.00280546f, 
    0.21468005f, 0.15035848f, 0.18215550f, -0.08774160f, 0.36212525f, -0.05113833f, -0.02508702f, -0.14713092f, 
    -0.10326771f, -0.06955224f, 0.09939662f, 0.03682915f, 0.09804875f, 0.07664041f, 0.09975252f, -0.08313872f, 
    -0.29394525f, -0.15434733f, -0.01548923f, 0.51001030f, 0.13662480f, -0.11618540f, 0.10857183f, -0.00049757f, 
    -0.07962716f, 0.01074979f, 0.06639364f, 0.01397400f, -0.06566935f, 0.05108664f, -0.02470859f, -0.04585353f, 
    0.01844919f, 0.05687370f, -0.16856205f, -0.23335522f, 0.07602889f, -0.20635870f, -0.06384096f, 0.04708099f, 
    -0.00528202f, 0.02679049f, -0.08451466f, -0.26050571f, -0.13018602f, 0.24350584f, -0.09783646f, -0.03033542f, 
    0.11460252f, -0.06086608f, 0.04780449f, -0.08148162f, 0.11929558f, -0.10433071f, 0.13053566f, -0.19034135f, 
    -0.32381079f, 0.05563702f, -0.18610218f, -0.07507126f, -0.29534432f, -0.22440714f, -0.46145049f, 0.12382775f, 
    -0.14868373f, 0.04398398f, 0.16213609f, -0.21965744f, 0.18836710f, 0.13975115f, -0.18101172f, 0.16448262f, 
    -0.09230137f, 0.19086899f, 0.21107408f, 0.15706627f, 0.13117127f, -0.00858628f, -0.01891633f, 0.05859770f, 
    0.28619611f, 0.43398660f, 0.06203773f, -0.10631306f, -0.00446765f, -0.19864649f, -0.10971615f, 0.05024388f, 
    0.24390423f, 0.62891424f, 0.09964553f, 0.17144072f, 0.16001315f, -0.00497061f, 0.34139436f, 0.06665849f, 
    0.00383283f, -0.04921152f, -0.08715736f, 0.01587450f, -0.79660934f, 0.02039261f, -0.00027678f, 0.34933171f, 
    0.33178160f, 0.34274974f, 0.11802471f, 0.21050367f, 0.32785177f, 0.01648987f, 0.03852702f, -0.05609625f, 
    0.05673843f, 0.12699427f, 0.07778312f, -0.08670329f, -0.11391281f, -0.38450733f, -0.25417760f, -0.07758892f, 
    -0.10104429f, 0.07638449f, -0.07635920f, -0.03959910f, -0.00598287f, -0.25687271f, -0.12489432f, -0.24021712f, 
    -0.01492386f, -0.08004115f, -0.05206164f, -0.00927302f, -0.02315969f, -0.17223002f, 0.14519352f, 0.44270289f, 
    0.25265244f, 0.13743012f, 0.06526563f, -0.00995828f, 0.12565836f, -0.16706996f, -0.07438841f, -0.95147550f, 
    0.23485887f, -0.08967051f, 0.01247968f, -0.23231721f, -0.02124306f, -0.08364861f, -0.09949954f, 0.04037456f, 
    0.54285866f, -0.23641504f, -0.09667152f, 0.05405621f, -0.04587438f, 0.03567756f, -0.02176168f, 0.00638468f, 
    0.01619937f, 0.64015985f, -0.10244664f, 0.33168814f, 0.02924229f, -0.02991596f, 0.13516563f, 0.11436764f, 
    0.07609880f, -0.08163776f, -0.21728300f, -0.27985650f, 0.10610319f, 0.08447121f, -0.00666421f, 0.07218578f, 
    -0.06171628f, -0.05845390f, -0.07483318f, 0.66743374f, -0.13069589f, 0.03250176f, -0.08639251f, 0.04278836f, 
    0.16985476f, 0.10328729f, 0.05570657f, 0.03605952f, 0.07394999f, 0.12003998f, -0.34938461f, 0.22163007f, 
    -0.03077182f, 0.01150561f, -0.09534757f, 0.06770719f, 0.05127105f, 0.02413898f, -0.74687743f, -0.31110233f, 
    0.09684887f, -0.04281959f, -0.04869219f, -0.00399660f, 0.09670778f, -0.00022866f, -0.08472335f, -0.02126111f, 
    -0.54576051f, -0.21017270f, -0.14557463f, 0.06912338f, 0.16916157f, 0.19764052f, -0.20348194f, 0.01817483f, 
    -0.34296596f, -0.40868825f, 0.00556673f, -0.25992483f, -0.36158970f, -0.03470522f, 0.04752517f, 0.11817738f, 
    0.13415459f, 0.15298802f, -0.14142303f, 0.03424349f, -0.04350478f, 0.06616732f, 0.10693991f, -0.00600504f, 
    0.07596784f, 0.01456116f, -0.22380961f, 0.00736939f, -0.17204961f, -0.07063595f, 0.04240398f, 0.13186976f, 
    0.10196413f, 0.16090646f, 0.51742923f, -0.38419992f, -0.27337098f, 0.03842701f, 0.03738068f, -0.15508701f, 
    0.13389137f, 0.19131482f, -0.15082888f, -0.34578380f, -0.05363790f, -0.32831290f, -0.28367588f, -0.14272265f, 
    0.03446211f, 0.08778584f, -0.01327071f, 0.02188094f, -0.05120263f, -0.10748594f, -0.02205294f, -0.00865653f, 
    -0.04483260f, -0.08386817f, 0.01631796f, -0.08379370f, 0.01088916f, 0.07469407f, 0.35625693f, -0.18880475f, 
    -0.17556757f, 0.04280801f, 0.06936524f, -0.10069887f, 0.10141592f, 0.14197029f, 0.19358397f, 0.38204697f, 
    0.21743461f, -0.01688127f, -0.06030375f, 0.29433000f, -0.01570376f, -0.10072175f, 0.09027585f, -0.19796745f, 
    -0.38333499f, -0.26907483f, -0.03818067f, 0.21414305f, -0.05790382f, -0.02792318f, -0.06305952f, -0.02555418f, 
    -0.08590578f, -0.14215112f, 0.01777669f, 0.07409839f, -0.05444790f, -0.02586433f, -0.18115789f, -0.04835977f, 
    0.25941348f, -0.14560746f, 0.07329392f, 0.26566935f, 0.11192840f, 0.09078890f, -0.06826597f, 0.01145531f, 
    0.03406859f, 0.11599553f, 0.02216699f, -0.11051216f, -0.32795200f, 0.04124692f, 0.03095982f, 0.05821951f, 
    0.01735729f, 0.02345569f, -0.00645093f, -0.06207902f, -0.37145379f, -0.54950392f, 0.17869358f, 0.07942574f, 
    0.19717595f, 0.07478325f, 0.03674593f, 0.03088930f, 0.28673941f, -0.17867357f, -0.23578191f, 0.16870715f, 
    0.21001352f, 0.15340477f, 0.02769424f, -0.11162855f, 0.06433048f, 0.23391266f, 0.27031663f, 0.36410683f, 
    0.00166320f, 0.02171770f, -0.02535379f, 0.03290021f, -0.00487512f, -0.03058241f, 0.24331383f, 0.35515380f, 
    0.23811750f, -0.06550146f, -0.16326867f, -0.05964372f, -0.00173156f, -0.05622633f, 0.10759211f, 0.01141241f, 
    0.01015524f, -0.31987798f, -0.11763570f, -0.30803180f, -0.09061712f, 0.00162711f, 0.05332343f, -0.03762779f, 
    0.18031886f, -0.42007399f, -0.58328944f, 0.05504438f, 0.06951064f, 0.14220275f, -0.28592294f, 0.09906914f, 
    -0.15806174f, 0.00445973f, 0.11200944f, 0.13652295f, 0.10072977f, 0.09274555f, -0.05719982f, 0.28860810f, 
    0.14733200f, -0.05421424f, -0.25111428f, -0.39542189f, 0.00692528f, -0.23368445f, 0.00477800f, -0.01817513f, 
    -0.17775594f, 0.23348188f, 0.25493285f, 0.11467367f, -0.01456218f, 0.19674677f, -0.15551764f, 0.09286507f, 
    -0.02824586f, 0.32798529f, 0.10577565f, 0.03553186f, -0.41492468f, -0.07828609f, -0.12203167f, 0.09406888f, 
    0.04893163f, -0.13267112f, 0.22366376f, 0.11677409f, 0.04139871f, -0.27591470f, -0.45306605f, 0.03405917f, 
    0.00045667f, 0.12760320f, -0.04879804f, -0.02857013f, 0.00410612f, -0.03009969f, -0.00419688f, -0.12065034f, 
    0.10176415f, -0.06953860f, 0.04685267f, 0.21227171f, 0.15858983f, -0.11404046f, -0.30744299f, -0.35176903f, 
    -0.28693670f, -0.29583392f, 0.07809631f, -0.23379451f, -0.25355500f, -0.19595763f, -0.26270083f, -0.11392923f, 
    0.18486288f, 0.17655943f, 0.21112537f, 0.02811620f, -0.05960642f, 0.08464764f, 0.14067954f, -0.10865604f, 
    -0.04524180f, -0.06146955f, -0.11268991f, 0.12648493f, 0.11224765f, 0.02552523f, -0.00462671f, 0.26489538f, 
    0.17864348f, -0.21355638f, -0.20030113f, -0.06514680f, 0.04318689f, -0.07005472f, 0.04431502f, -0.09385186f, 
    0.16570804f, 0.19177395f, 0.11189198f, 0.09268280f, -0.01401628f, 0.01244406f, -0.00500022f, -0.05939277f, 
    -0.17491923f, 0.11943564f, 0.08836501f, -0.21031637f, -0.91911286f, -0.49620900f, 0.03897699f, -0.06449944f, 
    -0.09111874f, -0.14440459f, 0.04555052f, -0.13367271f, 0.14576304f, 0.06279542f, 0.03848878f, -0.02815879f, 
    0.28960159f, -0.08340830f, 0.12012616f, -0.15385620f, 0.08277071f, -0.05389398f, 0.26112384f, -0.14518629f, 
    0.32747206f, -0.07654003f, -0.12360888f, 0.16605620f, -0.05323684f, -0.00224837f, 0.03087201f, -0.63875920f, 
    0.04942315f, 0.13356976f, -0.21710750f, -0.12725157f, -0.00031319f, -0.20205072f, 0.01827213f, 0.12938339f, 
    -0.72166169f, -0.28726470f, -0.20537335f, 0.25503990f, -0.22525668f, -0.13007444f, 0.10239860f, 0.06920157f, 
    -0.05214744f, 0.22415251f, -0.01831250f, -0.11908682f, -0.04831038f, 0.23375919f, 0.03129354f, 0.16502431f, 
    0.09526546f, 0.15815561f, 0.56898260f, -0.02032411f, 0.00797232f, -0.13801101f, 0.02226973f, -0.11479925f, 
    0.03292038f, 0.06302065f, 0.03220084f, -0.42254427f, -0.02238399f, 0.34661728f, -0.13776733f, 0.03576418f, 
    -0.01184409f, -0.22950655f, 0.11808892f, -0.05012646f, -0.52598882f, -0.24275085f, 0.04109430f, 0.02057043f, 
    -0.04523672f, 0.07814879f, 0.26438332f, 0.29783726f, 0.07003728f, -0.24514352f, -0.15485899f, 0.35603735f, 
    -0.04034375f, 0.12488400f, 0.25561735f, 0.04241017f, 0.00089458f, 0.08694465f, -0.08154142f, -0.26418507f, 
    0.26945397f, -0.14556472f, 0.09987634f, 0.14358623f, 0.14831799f, -0.03140485f, 0.21207888f, 0.46708047f, 
    -0.30624816f, -0.57586402f, -0.07127442f, 0.00809528f, -0.42122069f, 0.10614251f, 0.05725478f, 0.11272430f, 
    -0.12526631f, -0.52296460f, -0.17072020f, 0.13081093f, 0.13516119f, 0.04364995f, -0.03327503f, 0.15306136f, 
    0.18902375f, 0.19664946f, -0.11739857f, -0.02088402f, 0.17425975f, 0.07498354f, -0.19191979f, 0.16591729f, 
    0.21151470f, -0.12939642f, -0.21157092f, -0.46634784f, -0.52760810f, 0.31621814f, -0.04339912f, -0.29785088f, 
    0.25562218f, -0.01252136f, 0.11473223f, -0.37961450f, -0.52068019f, -0.11684764f, -0.07341521f, -0.03722093f, 
    0.25687763f, 0.10498238f, 0.11755095f, -0.01069909f, -0.17551219f, -0.20225273f, 0.37384403f, -0.17115530f, 
    -0.06175740f, 0.12662449f, 0.08144704f, 0.13781783f, 0.16307534f, 0.01305669f, -0.19063397f, 0.12921517f, 
    0.12713383f, 0.03108723f, 0.03496433f, 0.09798025f, -0.00537195f, 0.03547627f, -0.24277151f, -0.32613447f, 
    0.21200567f, 0.06701058f, -0.00565660f, 0.00587940f, 0.03174407f, 0.11067329f, -0.23285893f, -0.07055489f, 
    0.00841502f, 0.22302169f, -0.04189193f, 0.06620815f, 0.16603975f, 0.17546082f, 0.10008515f, 0.07274674f, 
    -0.29703346f, 0.09801012f, 0.20398064f, 0.18278900f, -0.10031845f, 0.07892230f, -0.05890467f, -0.06029094f, 
    -0.04106234f, -1.05933881f, 0.00092076f, -0.75170171f, 0.00305966f, 0.02472079f, -0.05843256f, -0.09051315f, 
    -0.05957988f, -0.20714182f, -0.06336817f, 0.02971696f, -0.54145211f, -0.51532412f, -0.15010203f, 0.06804141f, 
    0.13365522f, 0.03360277f, -0.10978978f, 0.31529912f, 0.37399429f, -0.01106306f, -0.05384050f, 0.16388562f, 
    -0.09119028f, 0.05658586f, -0.02332085f, -0.02137562f, 0.21690983f, 0.14993206f, 0.06185968f, 0.01762957f, 
    -0.10066155f, -0.03905653f, 0.23369424f, 0.03671333f, 0.01125285f, 0.05333631f, 0.17019592f, 0.09852705f, 
    0.08418676f, 0.05752329f, -0.11886430f, 0.00022135f, 0.00827666f, 0.07516535f, -0.78210092f, -0.42975965f, 
    -0.56036049f, -0.05398126f, -0.11288925f, -0.16700761f, 0.08425226f, -0.27628428f, -0.12400949f, -0.03468506f, 
    0.15382871f, -0.10634251f, -0.43240920f, 0.15760648f, -0.07092177f, 0.23532319f, 0.27499154f, -0.16211174f, 
    -0.22859921f, 0.02532602f, -0.05896872f, -0.08408668f, -0.09747652f, 0.14679815f, 0.20630538f, -0.03414923f, 
    -0.04069757f, -0.16983166f, -0.12337571f, -0.45336482f, -0.02621836f, -0.18342687f, -0.10325234f, -0.14919840f, 
    0.02015614f, 0.03505537f, 0.11579686f, 0.08556252f, -0.11241278f, -0.05045209f, -0.02746251f, 0.06130717f, 
    0.09543845f, 0.13122343f, 0.19613118f, -0.03736908f, -0.05645212f, -0.20641266f, -0.01881097f, 0.04818810f, 
    0.06309045f, -0.10161591f, 0.27971014f, 0.21801180f, 0.00040088f, 0.09410559f, -0.15655021f, 0.04035459f, 
    -0.04437415f, 0.01659514f, 0.09818015f, -0.17429715f, -0.10325501f, 0.06353795f, 0.00254170f, -0.39663088f, 
    -0.34043905f, -0.17072935f, 0.24178883f, 0.24047881f, 0.10941752f, 0.11426547f, 0.15947311f, -0.10674930f, 
    -0.38965765f, -0.16140498f, 0.21556996f, 0.20668463f, 0.41217721f, -0.00294243f, -0.32319367f, -0.31802243f, 
    -0.40687287f, 0.02482432f, 0.14251487f, 0.08877996f, -0.03142647f, 0.12417527f, -0.21003696f, 0.19085604f, 
    0.18767592f, 0.04335634f, -0.07563102f, -0.05953000f, -0.34790400f, -0.37852237f, -0.08493169f, -0.13194859f, 
    -0.04102634f, 0.05820942f, -0.10849641f, -0.14807053f, -0.04788239f, -0.09254766f, 0.10031221f, 0.19141625f, 
    0.04090399f, 0.01319259f, 0.28391257f, 0.26128808f, 0.03000724f, -0.19188412f, 0.47984916f, 0.04825167f, 
    -0.01971765f, -0.05794970f, 0.15156397f, -0.47242522f, -0.10437331f, 0.23992214f, 0.12922609f, -0.00341237f, 
    -0.07354301f, -0.11242100f, 0.29427227f, 0.22791888f, 0.06685586f, 0.22601615f, -0.08766926f, 0.00456190f, 
    -0.04833523f, 0.08509325f, -0.03108812f, -0.00603041f, 0.06709159f, 0.21808960f, 0.25051078f, -0.16709059f, 
    0.17002390f, 0.10194595f, 0.05176932f, -0.03414277f, 0.09632955f, -0.03969449f, -0.17631182f, 0.49606025f, 
    0.11645617f, 0.05979911f, -0.11552090f, -0.00807062f, 0.04724367f, 0.02854077f, 0.02440260f, -0.20323867f, 
    -0.38614735f, -0.46606380f, -0.04015361f, 0.36052638f, 0.08658414f, 0.14900793f, 0.10237492f, -0.12119589f, 
    0.22579268f, 0.28325009f, -0.31206667f, -0.23527730f, -0.00913906f, -0.01529870f, 0.17814685f, 0.08764207f, 
    0.01285953f, -0.39431581f, 0.06512968f, -0.03815709f, -0.05737633f, 0.17830692f, 0.06323008f, -0.01641213f, 
    0.17706592f, 0.24911323f, 0.19097579f, 0.22978750f, -0.16907215f, -0.24363692f, -0.01389623f, -0.38276470f, 
    -0.03727255f, 0.01077346f, -0.07672656f, 0.03158419f, 0.14526975f, 0.04380456f, -0.30373093f, -0.09425481f, 
    -0.03313795f, 0.25573185f, 0.07553171f, 0.04115218f, 0.18597813f, 0.10645720f, -0.32601625f, 0.08726627f, 
    0.06703237f, 0.13327044f, 0.07106661f, 0.05757808f, 0.01632058f, -1.01606143f, -0.42435628f, -0.18401822f, 
    -0.01839660f, -0.03205904f, -0.17288598f, -0.03959640f, -0.04028533f, -0.22236584f, -0.10033493f, -0.14945200f, 
    0.42719373f, 0.01533000f, -0.15393357f, -0.19728583f, 0.01832930f, -0.09994546f, -0.03859622f, 0.17454734f, 
    0.53176510f, 0.05200603f, 0.01906006f, 0.15689526f, 0.24936213f, 0.00212001f, 0.10384954f, 0.13344364f, 
    -0.09778720f, 0.00743430f, 0.18249767f, -0.16224046f, -0.16245976f, -0.17431675f, -0.06575064f, 0.20233938f, 
    0.12586513f, -0.19455470f, -0.34521729f, 0.10987109f, 0.16336517f, 0.09754189f, 0.28079441f, -0.03406574f, 
    -0.03503793f, 0.06325727f, -0.04997370f, -0.17566799f, 0.09602676f, -0.20850497f, -0.04125432f, 0.24750119f, 
    -0.01481071f, 0.17795444f, 0.00225436f, 0.08853383f, 0.20487049f, -0.34317836f, 0.12607327f, 0.13018629f, 
    0.05729986f, -0.13064158f, -0.03287380f, -0.12459063f, 0.18087454f, 0.10515630f, -0.02407154f, -0.21918814f, 
    -0.02656838f, -0.00813011f, 0.12742341f, -0.05298465f, -0.03703918f, 0.07704098f, -0.06413318f, 0.06891891f, 
    0.11888902f, 0.13965186f, -0.04523034f, 0.00395569f, -0.04842527f, -0.00753851f, -0.03057001f, 0.02406394f, 
    -0.20661233f, 0.08558790f, 0.05786636f, 0.03986922f, 0.14469966f, 0.04273050f, -0.16681670f, 0.01282657f, 
    -0.00540945f, -0.13024910f, -0.12803911f, 0.06359997f, -0.39930412f, 0.03996411f, -0.04057679f, 0.04203746f, 
    -0.67138982f, -0.09571712f, -0.50957954f, -0.00748383f, -0.14519906f, 0.21768740f, -0.02425996f, -0.15772499f, 
    0.05738891f, -0.16023540f, -0.21368009f, -0.04617653f, -0.07931189f, -0.02328911f, -0.07626411f, 0.07576333f, 
    0.06813160f, 0.12676899f, 0.09600111f, 0.00072511f, 0.05777270f, -0.02646101f, -0.00030788f, -0.08328548f, 
    0.27211541f, 0.20262223f, -0.22867389f, -0.13193864f, -0.12327202f, -0.32443097f, -0.19936571f, -0.01283132f, 
    0.01347291f, 0.06675521f, -0.14118928f, -0.03542314f, 0.13474555f, 0.02232733f, 0.22412179f, -0.01844101f, 
    -0.00651577f, -0.12016796f, -0.10033508f, -0.06034764f, 0.07232459f, 0.05596141f, -0.15135847f, -0.54325056f, 
    -0.17108412f, -0.04749215f, 0.04068443f, -0.04139459f, -0.07994369f, 0.07188534f, 0.72161263f, -0.82255495f, 
    -0.38758323f, -0.18096922f, 0.09085195f, -0.34483972f, 0.03091168f, -0.00502434f, -0.09384149f, 0.45136866f, 
    -0.02231434f, 0.07944352f, 0.06917779f, -0.01697015f, -0.09511794f, 0.03922883f, 0.03468478f, 0.12998751f, 
    0.06712047f, 0.05590153f, -0.02784372f, -0.15710875f, -0.06625456f, -0.07099509f, -0.08458133f, -0.10515200f, 
    0.04720677f, 0.20293890f, -0.12050872f, 0.17850529f, -0.02863285f, 0.19965304f, -0.11044385f, -0.00221943f, 
    0.29732206f, 0.04292433f, -0.25334904f, -0.37410185f, -0.19926941f, -0.32183337f, 0.33902201f, -0.13820162f, 
    -0.34724927f, 0.18341549f, 0.15486661f, 0.14524841f, 0.19065794f, 0.38916582f, 0.00851526f, -0.05352599f, 
    0.04414754f, 0.08083989f, -0.12104709f, 0.13498925f, 0.14777380f, 0.19783823f, 0.00849322f, -0.13016899f, 
    -0.10268658f, -0.00845376f, 0.11918329f, 0.21015267f, 0.11523156f, -0.29702276f, 0.16212313f, -0.02888340f, 
    -0.30356330f, 0.08559784f, 0.18373194f, -0.04114021f, -0.06246854f, 0.05377426f, -0.00968943f, -0.04131741f, 
    0.18054055f, 0.07162778f, 0.04884908f, 0.11173686f, 0.00115254f, 0.08269580f, -0.10653443f, 0.14493710f, 
    -0.29770336f, 0.30876109f, 0.15651041f, 0.21370015f, -0.10622817f, 0.06352451f, 0.04890455f, -0.11485318f, 
    0.13261375f, -0.10407917f, 0.01352338f, 0.13836041f, 0.04115406f, 0.18787770f, -0.06316459f, -0.01297198f, 
    0.04232413f, 0.08655974f, 0.30135188f, 0.36310494f, 0.13404931f, 0.12916535f, -0.24764623f, -0.01356791f, 
    0.22238445f, 0.09887430f, -0.09514832f, 0.04459194f, -0.18981986f, -0.25260046f, 0.02972995f, -0.15511747f, 
    -0.11883654f, 0.00867860f, -0.03790651f, 0.02785132f, -0.09321925f, -0.36440375f, 0.04788328f, 0.06109725f, 
    0.10568826f, -0.01481950f, -0.03511589f, 0.08492737f, -0.46876949f, -0.31239846f, -0.41756707f, -0.21067934f, 
    0.08261875f, 0.26279524f, 0.04106502f, -0.05558027f, -0.05388707f, 0.09192917f, -0.09094112f, 0.14649053f, 
    0.05791165f, -0.09307706f, -0.06530287f, 0.00678588f, -0.03613878f, 0.07938059f, -0.03205593f, 0.17097722f, 
    0.17197222f, -0.01208642f, -0.23032144f, -0.16099001f, 0.04674045f, 0.00453344f, 0.22798727f, 0.78716862f, 
    0.19219489f, 0.06843791f, 0.07991553f, 0.19956455f, -0.07771407f, -0.08079512f, 0.05512962f, 0.15287568f, 
    0.09156951f, -0.20264472f, -0.54215831f, -0.38121995f, 0.01604655f, -0.14381640f, -0.31987032f, -0.01297589f, 
    0.08038999f, -0.18798125f, 0.17875013f, 0.07689448f, 0.03452147f, 0.10854732f, 0.00115119f, -0.01365179f, 
    0.07872123f, -0.00549940f, -0.04755573f, 0.06895952f, -0.06595229f, -0.09007950f, 0.01846832f, 0.08055751f, 
    -0.19547296f, -0.04420886f, -0.09806289f, -0.10409354f, 0.48144490f, -0.14879893f, 0.27972370f, 0.26086584f, 
    -0.02303688f, 0.13687561f, 0.09009825f, 0.09341466f, -0.03789904f, -0.19198170f, 0.11574858f, 0.00632594f, 
    0.03033899f, -0.04013078f, 0.01712940f, 0.12994081f, -0.11326202f, -0.46840650f, -0.07094151f, 0.29605418f, 
    0.05442978f, 0.17412588f, -0.07522698f, 0.00842261f, 0.05062638f, 0.16002430f, -0.96650177f, -0.26657677f, 
    -0.64840668f, 0.13659556f, 0.02753047f, -0.13898502f, 0.04809017f, -0.08799144f, -0.00433702f, -0.38832921f, 
    -0.37424964f, -0.29861435f, -0.16096318f, -0.15508357f, -0.23077704f, 0.04906597f, -0.13126160f, 0.00775123f, 
    -0.28652358f, 0.07013003f, 0.24544270f, 0.00067240f, 0.08480489f, -0.03428101f, -0.08581576f, 0.11895101f, 
    0.00991942f, 0.10936353f, -0.17446950f, 0.19053587f, -0.17549066f, 0.13104014f, -0.04815134f, 0.01621863f, 
    0.05590538f, 0.03590641f, 0.13110811f, 0.01141855f, 0.09183886f, -0.08359059f, 0.13975561f, 0.15476128f, 
    0.10975126f, 0.17627019f, 0.18140295f, -0.14069165f, -0.28570461f, -0.18875311f, -0.19052145f, -0.03260852f, 
    -0.02028934f, 0.21780492f, 0.08488534f, -0.01822892f, -0.11778224f, -0.06117147f, -0.11643038f, -0.07290285f, 
    0.00465265f, -0.17178854f, -0.15629564f, -0.03916247f, 0.05697017f, -0.59516358f, 0.16903223f, 0.29391453f, 
    0.05557424f, 0.15370414f, -0.17137067f, -0.00766664f, -0.07786459f, 0.00525341f, 0.54077375f, 0.11302046f, 
    -0.13965963f, -0.14991021f, 0.05944734f, 0.17685010f, 0.20993140f, -0.09036893f, 0.07486148f, 0.16044335f, 
    -0.28720161f, -0.41212732f, 0.23120612f, 0.21097808f, 0.00680219f, -0.10397560f, -0.03668389f, -0.03077879f, 
    -0.06981522f, 0.06502412f, 0.00518997f, -0.06429394f, -0.09673597f, -0.03013755f, -0.06549799f, -0.09373974f, 
    0.08367795f, 0.30620009f, 0.12629165f, -0.03467855f, 0.01376933f, 0.01507747f, 0.13667481f, -0.04846145f, 
    0.01039883f, 0.17834610f, -0.00696641f, 0.49133059f, 0.18743867f, 0.01785769f, -0.06390006f, -0.22414012f, 
    0.20012812f, 0.30359137f, 0.25595537f, -0.22575189f, -0.73419040f, -0.74413151f, 0.08459311f, -0.04886016f, 
    -0.22682117f, -0.08734023f, -0.02324241f, -0.05028422f, 0.12437598f, -0.00836895f, -0.04744483f, -0.00008703f, 
    0.11662304f, 0.09346974f, -0.12362652f, 0.05519820f, 0.08542684f, -0.33046815f, 0.26212603f, -0.25617656f, 
    0.09982782f, -0.05317208f, -0.10729721f, 0.11252707f, -0.06390624f, -0.01853470f, -0.32070172f, 0.00683518f, 
    0.23690957f, -0.21561392f, -0.22591017f, -0.07362337f, -0.08105333f, -0.01708946f, 0.03335822f, 0.18402942f, 
    0.09777847f, -0.33597845f, -0.11590941f, 0.14448924f, 0.17184192f, 0.04095699f, 0.11624099f, 0.02779598f, 
    -0.15511727f, 0.24278957f, 0.42253047f, 0.02574333f, 0.15087664f, 0.08174088f, -0.05719277f, 0.14751743f, 
    0.12290761f, 0.01755751f, 0.15310024f, 0.13477989f, 0.03796659f, 0.12004477f, 0.28910995f, 0.11440789f, 
    0.18279883f, 0.23821165f, -0.18519665f, 0.05454994f, -0.01699583f, -0.12324486f, -0.00874220f, -0.05345680f, 
    -0.17736165f, -0.04954313f, 0.07666440f, -0.66448587f, 0.00874815f, 0.45404357f, -0.09642266f, 0.02840691f, 
    -0.24616238f, -0.21593572f, -0.16976228f, 0.12443569f, -0.27298376f, 0.59746939f, 0.50809050f, 0.06317750f, 
    0.21094064f, 0.22483207f, -0.04044954f, 0.14847405f, 0.04786413f, -0.94306034f, -0.14937162f, -0.12646855f, 
    -0.21765625f, 0.17215687f, -0.19487640f, -0.03273121f, -0.09615446f, 0.10203767f, -0.33535668f, -0.62165582f, 
    -0.65047044f, -0.14941140f, -0.15548849f, -0.11769240f, 0.06764001f, 0.05537356f, 0.06447992f, 0.26261830f, 
    -0.11879447f, -0.02029186f, 0.23289968f, 0.20026651f, 0.06143670f, 0.25144142f, 0.03157277f, 0.02300882f, 
    -0.05312408f, 0.05448449f, 0.19192399f, 0.09534275f, 0.21527877f, -0.13014297f, -0.02709761f, 0.03804665f, 
    0.25198829f, 0.13837911f, 0.01603961f, -0.06400026f, 0.09021454f, 0.04722383f, -0.14911050f, -0.05444746f, 
    0.15016930f, -0.09531352f, 0.28897473f, 0.23924524f, 0.42413256f, 0.14427328f, 0.01082567f, -0.41563979f, 
    0.15201873f, 0.18596122f, 0.21403456f, -0.16333152f, 0.11578154f, 0.36413813f, -0.04138834f, 0.02472678f, 
    -0.16600965f, -0.30162784f, 0.08495280f, -0.06290414f, 0.02170063f, 0.01137900f, -0.12570097f, -0.03807954f, 
    0.05687296f, -0.05581672f, 0.07229993f, -0.00425485f, -0.12559246f, 0.04334080f, 0.17043415f, -0.39603233f, 
    0.05119060f, 0.05850059f, -0.02165300f, 0.14712685f, 0.01985385f, -0.01616727f, 0.28852811f, -0.04041146f, 
    0.69384921f, -0.10255128f, 0.24070668f, 0.04651643f, -0.19913736f, 0.00326202f, 0.02107439f, -0.19264500f, 
    -0.29501578f, -0.03415633f, 0.06351616f, 0.30180594f, -0.03077398f, -0.07093743f, 0.03101341f, -0.09929719f, 
    -0.14236619f, 0.06049847f, 0.43385413f, 0.05490995f, 0.00921805f, -0.14748417f, -0.09634318f, -0.00930260f, 
    -0.19939758f, -0.05103950f, 0.12492616f, 0.30486885f, 0.19670062f, 0.03429753f, -0.08003768f, 0.09525839f, 
    0.08674327f, 0.09720067f, 0.23101582f, 0.05037929f, -0.29565945f, -0.09349819f, -0.04831834f, 0.06887759f, 
    -0.07631071f, -0.15490825f, -0.00848947f, 0.07911350f, 0.08320203f, 0.25533965f, -0.17152998f, -0.05761985f, 
    -0.08652257f, 0.08896945f, 0.21017064f, -0.03308890f, -0.49320665f, -0.48172975f, -0.05553642f, 0.13580909f, 
    -0.00773817f, 0.04735442f, 0.00276755f, -0.04808652f, 0.00933681f, -0.40193811f, 0.15424633f, 0.34611535f, 
    0.04166456f, -0.00707951f, -0.07755813f, -0.09179215f, -0.18703973f, 0.03123781f, -0.08022490f, -0.08278183f, 
    0.17875732f, -0.18015040f, -0.04037095f, 0.09338380f, -0.24990878f, 0.07056278f, 0.23540290f, -0.69479686f, 
    0.15864456f, 0.37133116f, 0.13927628f, 0.14954944f, -0.17510930f, -0.13319191f, 0.04880342f, 0.10292223f, 
    0.08406682f, 0.12964906f, 0.06156059f, 0.12549923f, 0.04025894f, 0.02915814f, -0.05861345f, -0.01176102f, 
    -0.01231728f, -0.06511401f, -0.08514047f, -0.31019777f, -0.07515919f, -0.23657882f, -0.11268372f, 0.04150597f, 
    -0.19457893f, 0.03841091f, -0.31729016f, 0.29294416f, 0.42421255f, 0.00831646f, 0.03319204f, 0.09466179f, 
    -0.20524594f, -0.01237665f, 0.21323228f, -0.20358311f, 0.33662960f, 0.56903863f, 0.23481110f, 0.24242781f, 
    -0.31404507f, -0.15467562f, 0.05882711f, 0.06470111f, -0.28736594f, -0.07567730f, -0.02292458f, 0.16185334f, 
    -0.04431767f, -0.02528832f, 0.13847512f, 0.06678969f, 0.06550738f, 0.13678342f, -0.01804473f, 0.49486145f, 
    0.14969781f, -0.09483448f, 0.05406468f, 0.02565416f, 0.09356203f, 0.16304821f, 0.34816080f, -0.04585162f, 
    0.09841880f, 0.10674618f, -0.08890946f, -0.03126834f, -0.02096311f, -0.01546915f, 0.12662008f, -0.31827644f, 
    0.21057042f, -0.59900242f, -0.32881102f, 0.02615498f, -0.00443002f, 0.10701275f, 0.25750846f, -0.31993657f, 
    -0.10643905f, 0.23006691f, -0.01721175f, 0.03629340f, 0.05882776f, -0.15525757f, 0.23965104f, 0.06881694f, 
    0.12998405f, 0.01392307f, 0.09791677f, -0.24859266f, 0.01082925f, 0.06043088f, -0.32062209f, -0.04820031f, 
    -0.06955799f, -0.13601872f, 0.09168942f, 0.10071625f, 0.18883853f, 0.17688730f, 0.05947250f, 0.15790567f, 
    0.01970137f, 0.06016679f, 0.06856009f, -0.16164730f, 0.06404944f, 0.43985131f, -0.14966172f, 0.02004524f, 
    -0.11095124f, -0.02525184f, -0.05163224f, 0.03171389f, -0.18046990f, 0.12243136f, 0.46593586f, -0.11003404f, 
    -0.19235656f, -0.27088052f, -0.05641490f, 0.02045507f, -0.02529781f, 0.34877062f, 0.03018882f, 0.11025361f, 
    0.13237372f, 0.11600216f, 0.05544847f, 0.03198260f, 0.07697374f, 0.14251228f, 0.29163897f, 0.18182929f, 
    0.79867131f, -0.00076184f, 0.13362846f, -0.14089499f, -0.09852441f, -0.04299831f, -0.06180257f, -0.56676602f, 
    -0.00649279f, 0.32823741f, 0.08448809f, -0.10025299f, -0.34553552f, -0.12114371f, 0.12868397f, -0.10100446f, 
    -0.04157360f, -0.19094142f, -0.08813676f, 0.18628883f, -0.08599802f, -0.59274650f, -0.21589415f, -0.33716512f, 
    -0.52890944f, 0.00240528f, 0.03110018f, -0.62169117f, 0.21294029f, -0.04726656f, 0.07825502f, 0.04429446f, 
    0.06264886f, 0.11104817f, 0.02393533f, 0.04313319f, -0.08494472f, 0.06027065f, 0.08685535f, -0.36734536f, 
    -0.11181823f, -0.30975324f, -0.20125128f, -0.09244166f, 0.10848863f, 0.27652726f, -0.12156914f, -0.19392620f, 
    0.27028111f, 0.06016991f, 0.21225496f, 0.06251270f, 0.18271197f, 0.10918400f, 0.05623229f, 0.02805138f, 
    0.03889376f, 0.16167246f, -0.01904253f, 0.02108418f, -0.24973433f, 0.01896232f, 0.14643493f, -0.08783288f, 
    -0.05287481f, 0.11086808f, 0.04718329f, 0.17130730f, 0.18138321f, -0.04071980f, -0.06493097f, -0.14368525f, 
    -0.08286204f, 0.07250948f, -0.02744320f, -0.08453924f, -0.08501862f, 0.02062644f, -0.05720908f, -0.10149368f, 
    -0.35326156f, 0.42678332f, -0.06561551f, 0.07303794f, -0.02009733f, 0.08923343f, 0.09241275f, -0.15750650f, 
    0.01589132f, -0.17230499f, -0.29772738f, -0.04183132f, 0.17510952f, 0.23690712f, 0.02690511f, -0.02480152f, 
    0.19824471f, 0.07534835f, -0.08684596f, -0.23432320f, 0.11225342f, 0.35358110f, 0.07257342f, 0.00120891f, 
    -0.02683944f, 0.32398173f, -0.09233143f, 0.23652419f, -0.00839380f, 0.11476418f, -0.00354499f, -0.03154356f, 
    -0.24665439f, -0.19292685f, -0.26807100f, 0.04185542f, 0.10939731f, 0.15034671f, -0.00209759f, 0.20104709f, 
    0.28534141f, 0.06890567f, 0.21518560f, 0.30911171f, 0.21301430f, 0.19452639f, 0.15643793f, -0.01156464f, 
    -0.01656356f, 0.12523685f, 0.18626413f, 0.07158060f, -0.07153563f, 0.13066693f, -0.06978656f, 0.01260627f, 
    -0.18747082f, 0.04219965f, 0.00183655f, -0.01440709f, -0.21312937f, -0.05470440f, 0.16633317f, -0.29695120f, 
    0.11773014f, -0.04078120f, -0.08788499f, -0.17980890f, 0.01655772f, 0.04005668f, 0.03296077f, 0.38027745f, 
    0.20983304f, 0.01610228f, -0.00869721f, -0.10870949f, 0.09634793f, 0.02499059f, 0.03915589f, -0.08437286f, 
    0.19824177f, 0.05694679f, 0.08189705f, 0.00207209f, 0.17362362f, 0.10275471f, 0.08058968f, -0.12228476f, 
    -0.34846148f, 0.21191901f, 0.04042061f, 0.15407491f, 0.04466532f, 0.13435496f, -0.02668541f, 0.02407747f, 
    -0.09169371f, -0.21757510f, 0.00569786f, -0.23730689f, 0.27102110f, -0.14434820f, 0.03767385f, 0.32979563f, 
    0.21256043f, -0.16225812f, 0.28195384f, 0.61648899f, 0.49489042f, -0.00421684f, -0.02770009f, -0.03835721f, 
    0.10713428f, -0.00942731f, 0.03023215f, -0.04925521f, 0.15189920f, 0.16371587f, 0.15355994f, 0.10754695f, 
    0.16589592f, 0.07632898f, -0.15885043f, 0.03017244f, 0.10395128f, 0.03790374f, -0.15755333f, 0.19010484f, 
    0.17799775f, 0.19946784f, -0.04217144f, -0.10378160f, -0.07407189f, -0.23881392f, -0.34826100f, -0.19208880f, 
    -0.19000879f, -0.07320543f, 0.26227427f, -0.23268948f, -0.23836230f, -0.30783582f, -0.14741975f, 0.08448352f, 
    0.17768344f, 0.09336732f, -0.02599492f, -0.10324056f, 0.09327652f, 0.04204300f, -0.09288970f, -0.08460212f, 
    -0.04960338f, -0.00940657f, 0.04900596f, 0.13114123f, -0.05900317f, -0.00724015f, -0.12266203f, -0.06549721f, 
    -0.12037744f, 0.05897299f, 0.13993193f, 0.19330494f, 0.02517928f, -0.07183272f, 0.04556078f, -0.06742212f, 
    -0.01425172f, -0.00570403f, 0.13911128f, 0.00157536f, 0.05852837f, 0.06272592f, -0.07819970f, 0.16165556f, 
    0.22232348f, -0.22309974f, -0.32246268f, -0.11602849f, 0.04900491f, -0.02456458f, -0.00894675f, 0.09454945f, 
    -0.00891667f, -0.05678884f, -0.24707247f, 0.13449687f, 0.08338510f, 0.08002974f, 0.20161588f, -0.12862012f, 
    -0.09039839f, -0.06353234f, -0.13814464f, 0.00892480f, 0.03699742f, -0.12239204f, -0.11972313f, -0.27028933f, 
    0.04361344f, -0.05720377f, 0.17792496f, 0.03905914f, -0.10380716f, -0.04745712f, 0.21012950f, 0.07461178f, 
    0.03849588f, 0.18368499f, -0.31385723f, 0.01876943f, 0.02584667f, -0.05754166f, 0.00866862f, 0.05895965f, 
    -0.10583480f, 0.09110597f, 0.14569056f, -0.15170930f, 0.06866965f, -0.00695000f, 0.02386943f, -0.02354622f, 
    0.01526642f, 0.03585617f, 0.02306455f, 0.01324927f, -0.05768303f, 0.02563079f, -0.03285317f, -0.07214361f, 
    -0.07205074f, -0.00481339f, 0.04139051f, 0.00461943f, -0.00190117f, 0.03993431f, 0.05261147f, -0.04805375f, 
    -0.01379950f, 0.02664105f, -0.03690577f, -0.02937664f, 0.02207535f, -0.01115606f, 0.02036348f, -0.00174272f, 
    0.00634225f, 0.02619016f, -0.03222608f, -0.00910944f, -0.03217449f, -0.04444129f, 0.00589467f, -0.02152456f, 
    -0.02613130f, -0.04562402f, 0.01807134f, -0.02383382f, 0.03984687f, -0.04463532f, -0.02084829f, -0.01412559f, 
    -0.07263294f, -0.04486289f, -0.01999785f, 0.03546399f, -0.01628048f, -0.05292603f, -0.01683697f, -0.02162079f, 
    0.03496738f, -0.03505518f, -0.04556612f, -0.01364635f, -0.02183671f, -0.04182604f, -0.02204443f, -0.04287308f, 
    -0.00111322f, 0.00046055f, 0.00128675f, 0.03287314f, 0.02772967f, -0.01850002f, -0.03017616f, 0.02601200f, 
    -0.05156077f, 0.03314629f, 0.02614635f, -0.01230425f, 0.02532543f, -0.02303271f, -0.04898218f, -0.02423915f, 
    -0.02235535f, -0.01874799f, -0.03943389f, -0.04562450f, -0.04556420f, -0.03135135f, -0.05367508f, -0.05842078f, 
    -0.05702982f, -0.01156028f, 0.05262607f, 0.01019978f, -0.00871337f, 0.00723672f, -0.05824365f, 0.02692540f, 
    0.02709661f, -0.02101217f, -0.04248438f, 0.03852763f, -0.07365625f, -0.03509218f, 0.01061529f, -0.03842742f, 
    0.00728790f, -0.03146649f, -0.04779604f, -0.02129853f, 0.02859641f, -0.05051175f, -0.05513521f, -0.04275855f, 
    0.03242881f, -0.02510253f, -0.05874776f, 0.01180110f, 0.00920748f, -0.04086670f, 0.00924162f, 0.00490079f, 
    -0.06877785f, -0.02780348f, 0.01880426f, 0.03037585f, -0.02611787f, -0.05126949f, 0.01040870f, -0.04726367f, 
    0.01262091f, -0.02711606f, -0.01797205f, -0.05222839f, -0.04319046f, -0.04576012f, -0.06701720f, -0.05082496f, 
    0.03081170f, 0.00028639f, 0.01957595f, -0.02114554f, -0.00587375f, 0.00562103f, 0.00669371f, -0.02133914f, 
    0.00149462f, 0.01615592f, 0.00765291f, -0.06056380f, -0.03821117f, -0.00297703f, -0.04493143f, -0.07347862f, 
    -0.06243807f, 0.03831143f, 0.02189009f, 0.01642565f, -0.03544045f, -0.03448162f, -0.05101100f, 0.03471098f, 
    -0.01903339f, -0.02334240f, -0.03994714f, 0.01391273f, -0.00021058f, -0.03403403f, -0.04927448f, -0.00714834f, 
    -0.02582883f, 0.00505528f, -0.04555654f, 0.03970076f, -0.05246549f, -0.05388006f, -0.04948748f, -0.04594230f, 
    0.02265980f, -0.00150749f, -0.05992294f, 0.02613707f, 0.04243941f, 0.03616911f, 0.02549873f, -0.05235790f, 
    -0.05625680f, -0.00046558f, 0.03857246f, -0.06860603f, -0.06897216f, -0.07189444f, -0.06759760f, -0.02500455f, 
    -0.01028006f, 0.00036800f, 0.03808140f, -0.04877887f, 0.03788118f, -0.03961326f, 0.00956505f, -0.00505920f, 
    -0.04265058f, -0.05488154f, 0.02055253f, -0.07162242f, -0.00429415f, 0.01696595f, 0.00119053f, -0.02588179f, 
    -0.00724428f, 0.02789626f, 0.05713420f, 0.03967075f, 0.03976416f, -0.03111754f, -0.02841246f, -0.05512761f, 
    -0.02519030f, 0.03633734f, -0.03179420f, -0.04742011f, -0.02792651f, -0.03424951f, 0.01795875f, -0.02742114f, 
    -0.06552483f, -0.02885940f, -0.02183633f, 0.03095710f, -0.05099159f, -0.03469457f, -0.00574640f, -0.01593678f, 
    -0.02900240f, -0.01154143f, 0.02700227f, 0.00338932f, 0.04990582f, 0.00178471f, 0.00927021f, -0.02051289f, 
    -0.03193580f, -0.04468564f, 0.02857321f, -0.00367971f, -0.00437729f, -0.02755774f, -0.04654302f, -0.00942056f, 
    -0.02724725f, -0.02911147f, -0.03456503f, -0.04930370f, -0.02975591f, 0.03607465f, -0.01738281f, -0.05647054f, 
    -0.00832497f, -0.05218573f, 0.05273477f, 0.03821129f, 0.05119039f, -0.01885653f, 0.02428273f, -0.04700406f, 
    -0.02944757f, -0.02545131f, -0.06313819f, 0.02742960f, -0.03046300f, -0.00782142f, 0.05594873f, -0.00637680f, 
    0.01122232f, -0.04972598f, 0.05014472f, 0.02781188f, -0.01804321f, -0.02341428f, -0.00304154f, 0.03181543f, 
    -0.03176947f, 0.04537461f, -0.03343124f, -0.03901052f, -0.02858062f, -0.03100321f, -0.03325055f, 0.03585750f, 
    -0.06108769f, -0.01085718f, 0.02739757f, -0.04835846f, -0.05328656f, 0.03267504f, -0.02793345f, -0.03128461f, 
    -0.36677569f, 0.31935662f, -0.38717440f, -0.06645387f, -0.01083691f, -0.01611489f, -0.18375349f, -0.10787523f, 
    0.03095941f, 0.23160274f, 0.15471342f, -0.31194133f, 0.01558383f, 0.03023835f, -0.04895078f, 0.01243769f, 
    0.05062801f, -0.09421163f, -0.22523814f, -0.21348058f, -0.18975982f, -0.09555471f, 0.11237420f, -0.16504039f, 
    -0.25019169f, 0.01199963f, -0.21412891f, -0.13672037f, 0.16524985f, 0.11234391f, 0.02359028f, -0.12941077f, 
    -0.18429719f, -0.07501036f, 0.20632587f, 0.12966919f, 0.15486437f, -0.08167876f, -0.29504389f, 0.10004778f, 
    -0.04855215f, 0.06903214f, -0.06446439f, 0.15980613f, -0.02739016f, 0.09266558f, 0.02332387f, 0.00081287f, 
    -0.08946397f, -0.08092320f, 0.16519308f, 0.04251200f, -0.03151448f, 0.20115200f, -0.00171120f, 0.04949543f, 
    0.10564594f, 0.05320634f, -0.13234966f, -0.22687057f, -0.02277288f, 0.01304848f, 0.14580166f, -0.17348759f, 
    -0.77350217f, -0.39057541f, 0.36919895f, -0.43342900f, 0.05332627f, -0.07282884f, -0.14656916f, 0.04255171f, 
    0.07115399f, 0.38986221f, -0.24814832f, 0.01117973f, 0.39395455f, 0.09042506f, 0.08714167f, 0.09351194f, 
    0.17870919f, 0.17273442f, 0.11984132f, -0.14806497f, -0.09184889f, 0.21179631f, 0.23357145f, 0.12104967f, 
    -0.01102910f, -0.04260866f, -0.11079320f, -0.10015367f, -0.28994432f, -0.13468140f, -0.06573837f, 0.18730161f, 
    -0.20231278f, -0.00380907f, 0.04889173f, 0.14608732f, 0.40038145f, 0.01431026f, 0.10868925f, 0.04260468f, 
    -0.16443884f, 0.14984143f, 0.20556600f, 0.13545413f, 0.15426616f, -0.43132544f, -0.33860999f, -0.03066467f, 
    -0.32338387f, -0.05784386f, 0.09940292f, -0.19509187f, 0.14535269f, -0.03891734f, 0.09774251f, -0.13484640f, 
    0.15477015f, 0.31500602f, 0.17166312f, -0.05674845f, -0.00782150f, 0.23804741f, 0.38031280f, -0.30054551f, 
    0.02035331f, -0.07930502f, -0.09065216f, 0.02520811f, -0.05252170f, 0.03986667f, 0.07367416f, -0.26997060f, 
    -0.04329607f, 0.19299556f, -0.20090893f, -0.21044052f, -0.12418380f, -0.01846932f, 0.01028837f, 0.10517176f, 
    0.31018779f, -0.25798437f, -0.05321142f, -0.09112203f, -0.16924202f, -0.06379820f, 0.06828074f, 0.03483707f, 
    -0.09015570f, 0.06529094f, -0.37775818f, 0.08781388f, -0.00938437f, 0.11555372f, -0.18365312f, 0.05906111f, 
    0.33015740f, -0.03689341f, 0.44145375f, 0.10087129f, 0.15913671f, -0.21761578f, -0.01680324f, -0.02331172f, 
    -0.11206973f, 0.18551207f, 0.08614115f, -0.04956072f, 0.53038466f, 0.16510852f, -0.21710987f, -0.24608663f, 
    0.17210475f, 0.01318353f, 0.12539652f, 0.08141637f, -0.07736719f, -0.16013560f, -0.18181895f, -0.06891842f, 
    0.01473088f, 0.03100603f, 0.03665186f, 0.21940216f, 0.08705405f, -0.03110866f, 0.31268096f, -0.11172409f, 
    0.04656936f, 0.05626726f, -0.04515241f, 0.20307776f, -0.01065403f, 0.23527440f, 0.16319606f, 0.10102845f, 
    0.00742882f, 0.09669689f, -0.24277735f, 0.15666501f, 0.02389021f, 0.02691856f, -0.16705392f, -0.39254251f, 
    0.19007732f, 0.22278428f, -0.13010515f, -0.19019529f, -0.28033036f, 0.09400560f, 0.27716929f, 0.02173571f, 
    0.05681383f, -0.05238135f, -0.01077972f, -0.16268994f, 0.25311002f, 0.07985261f, 0.13688703f, 0.27187377f, 
    0.02960760f, -0.20966883f, -0.09904330f, 0.00875379f, -0.07678176f, 0.12431595f, -0.09474565f, 0.11969216f, 
    0.14399794f, -0.29763535f, 0.29430214f, 0.31780848f, 0.24972378f, -0.13047969f, -0.24277574f, -0.08018657f, 
    -0.17612122f, 0.08851223f, 0.17185308f, -0.38571569f, 0.14730081f, -0.36011249f, -0.13348447f, -0.01749529f, 
    0.38312596f, -0.05005819f, 0.07942525f, -0.06484102f, 0.22093545f, 0.22911713f, -0.10560033f, 0.00882466f, 
    0.09670217f, -0.23867050f, -0.00678224f, 0.18566662f, -0.07702430f, 0.40642059f, 0.06002130f, -0.18325390f, 
    0.05786377f, -0.13259332f, -0.01128510f, 0.06746568f, 0.13083810f, -0.07847401f, -0.10202225f, 0.43576071f, 
    0.04603082f, -0.16508098f, -0.17128734f, -0.14496987f, -0.05365664f, -0.22355774f, -0.06019577f, -0.12558067f, 
    0.20601323f, 0.05632686f, -0.17149940f, -0.02289182f, -0.00976401f, 0.10636982f, 0.19317597f, 0.10711782f, 
    0.05649365f, 0.15332109f, 0.05346686f, 0.20206279f, 0.41921040f, 0.10265420f, 0.16967425f, 0.22523746f, 
    0.22353879f, 0.02576773f, 0.24488783f, 0.21628377f, -0.07044059f, -0.21182075f, -0.05648648f, -0.08277082f, 
    -0.07566761f, 0.16465199f, 0.23810169f, 0.10756455f, -0.25011715f, 0.20265396f, 0.25203255f, 0.11545347f, 
    0.13437434f, 0.00296363f, 0.16284211f, 0.22588840f, 0.06371634f, -0.61912817f, -0.00781387f, 0.18957011f, 
    -0.02795992f, -0.03972338f, -0.15553316f, 0.04133347f, 0.03216082f, -0.16807495f, -0.02649343f, 0.12999897f, 
    0.04052859f, -0.04535589f, 0.13685745f, -0.07405806f, 0.00953265f, -0.26669207f, -0.18450838f, 0.02912467f, 
    0.00042858f, 0.05458491f, 0.05294642f, -0.26193535f, -0.23937859f, -0.01348995f, 0.09709523f, 0.12577735f, 
    -0.61932570f, -0.04433456f, 0.17618075f, -0.02555072f, 0.01098098f, 0.11146244f, -0.11651336f, -0.02816712f, 
    0.00805659f, -0.01823342f, -0.05344061f, -0.00423400f, 0.13402897f, 0.10497146f, -0.45530820f, -0.29593483f, 
    0.03435208f, 0.12600525f, 0.03657565f, 0.00244045f, -0.18156365f, -0.05831729f, -0.09823450f, -0.15654981f, 
    -0.05724707f, 0.00905407f, -0.11469095f, 0.00384912f, -0.09264652f, -0.12897182f, -0.01669996f, -0.08494006f, 
    -0.18947205f, -0.25114363f, -0.04677076f, -0.00779092f, 0.03235921f, 0.06971750f, -0.30388686f, 0.03316865f, 
    0.29246014f, 0.07138145f, 0.05783074f, 0.06364975f, -0.15606435f, -0.26706269f, -0.03568140f, 0.16052662f, 
    0.12053485f, -0.05157649f, -0.22684786f, -0.29014993f, -0.09743062f, -0.08243001f, 0.02682020f, 0.07071412f, 
    0.03567013f, 0.09938023f, -0.10596171f, -0.10107484f, -0.08550868f, 0.15190184f, -0.08041283f, 0.12640551f, 
    0.16607688f, 0.13456187f, 0.10093864f, 0.00606462f, -0.01435982f, -0.08262904f, 0.18668540f, -0.09883226f, 
    -0.02643004f, 0.10134192f, 0.03332459f, 0.10656036f, 0.05818710f, -0.20466554f, -0.10070939f, -0.12914713f, 
    -0.46714550f, 0.13766450f, 0.03529834f, 0.05909899f, 0.13165101f, 0.30818939f, 0.09551857f, 0.04019397f, 
    0.04129669f, 0.02171502f, 0.03138946f, 0.16406518f, -0.04864353f, -0.09823128f, -0.28207582f, 0.00268800f, 
    0.01288609f, -0.09418864f, -0.13646808f, 0.11853130f, -0.01401246f, 0.14431290f, 0.01493117f, 0.27346009f, 
    0.07726802f, 0.15058710f, 0.52868408f, -0.15320225f, -0.29853860f, 0.18123798f, 0.17994061f, -0.00169579f, 
    0.03264277f, -0.33310482f, -0.23751777f, -0.86494017f, -0.20197219f, 0.27078348f, 0.11744050f, 0.02903906f, 
    0.12133337f, -0.00351012f, 0.09223451f, -0.07382669f, 0.05039024f, -0.06838416f, 0.13177170f, 0.14904608f, 
    -0.17832227f, 0.10160400f, 0.16165724f, 0.03992234f, 0.03491940f, 0.37070581f, -0.03856025f, -0.40628338f, 
    0.02831498f, 0.02952623f, 0.15312749f, -0.05922595f, 0.20169058f, 0.10831181f, -0.35023528f, 0.14020441f, 
    0.19026986f, -0.27974531f, 0.01238253f, -0.14119434f, 0.10240185f, 0.12272273f, 0.19201250f, -0.13842368f, 
    -0.13196342f, -0.23090664f, 0.15752308f, 0.11367845f, -0.00612903f, 0.32471260f, 0.10710098f, 0.09274982f, 
    -0.02713924f, 0.12022580f, 0.02999614f, -0.19876467f, -0.10301843f, -0.11595899f, -0.12103877f, 0.04921517f, 
    0.26493812f, -0.03853411f, -0.19722754f, -0.00893455f, -0.12065915f, -0.09152953f, -0.06326689f, 0.31937641f, 
    0.05820164f, 0.25642264f, 0.28014624f, -0.01783215f, 0.02156999f, 0.16335879f, -0.12517284f, -0.02009098f, 
    -0.08395001f, -0.23168506f, 0.06051838f, -0.05053424f, 0.04027135f, 0.20060278f, -0.07540023f, 0.01177375f, 
    0.06181739f, -0.07261766f, 0.05561819f, 0.03531835f, 0.53218198f, 0.28336057f, -0.12129092f, -0.11914062f, 
    0.07962763f, 0.07863200f, 0.01305562f, -0.03908598f, 0.10568085f, -0.05660655f, 0.11394461f, -0.00920636f, 
    -0.14108396f, -0.01377099f, -0.08969493f, 0.04260084f, -0.00754128f, 0.04943179f, 0.05824288f, -0.05284964f, 
    -0.16851243f, 0.05486236f, 0.01954697f, 0.05243550f, 0.00976684f, -0.10391150f, -0.04131510f, 0.03666426f, 
    -0.31629139f, 0.14831261f, 0.03283823f, 0.03944046f, 0.11910258f, -0.02826054f, 0.05139513f, 0.01610540f, 
    0.02479955f, 0.05282069f, 0.03041027f, -0.06016459f, 0.01085980f, -0.05491339f, -0.04273649f, -0.05074386f, 
    0.02717028f, -0.01160545f, -0.06414387f, 0.04141900f, -0.02466968f, -0.05442123f, 0.00141168f, 0.03358116f, 
    0.05202584f, -0.03694912f, 0.00828739f, 0.02370630f, -0.01827627f, 0.04000209f, 0.00126788f, -0.02167195f, 
    0.04677671f, 0.05216507f, 0.00007594f, -0.02945447f, -0.04932711f, 0.00691931f, 0.01232858f, -0.03486289f, 
    -0.00958388f, -0.00232408f, -0.01010431f, -0.04759303f, -0.02818030f, -0.00001707f, -0.01978888f, -0.02513868f, 
    -0.05690078f, 0.03379555f, 0.00010056f, -0.05436585f, 0.05096844f, -0.00236661f, -0.04850915f, -0.04201509f, 
    -0.00272976f, -0.01523649f, 0.05013926f, -0.03425984f, -0.01537155f, -0.05527647f, 0.01999141f, -0.03469712f, 
    0.03349769f, 0.02944156f, 0.02907236f, -0.02717382f, -0.00805695f, -0.01787725f, -0.02779910f, 0.01457393f, 
    0.00413015f, -0.01259006f, 0.00028102f, -0.00643712f, 0.01575745f, -0.01233791f, -0.04809062f, 0.01513901f, 
    0.04056170f, -0.06345682f, 0.04639579f, -0.04240066f, -0.02921942f, 0.03020794f, 0.03008798f, -0.04403968f, 
    -0.01202224f, -0.04778231f, -0.00101920f, 0.00721295f, -0.00101448f, 0.02205017f, -0.03953541f, -0.00043293f, 
    -0.03968913f, -0.02118581f, -0.04104272f, -0.02900769f, 0.04306819f, -0.06284604f, 0.04276192f, -0.06412862f, 
    -0.04380984f, -0.02699458f, 0.01746462f, -0.06298485f, 0.00674033f, -0.03213921f, 0.01290549f, -0.04818239f, 
    0.03986651f, -0.03253021f, -0.05053454f, -0.02835332f, 0.01523339f, -0.01515615f, -0.04826852f, 0.03094818f, 
    -0.03665733f, 0.00765834f, 0.02442911f, -0.02532326f, 0.02341737f, 0.02240307f, 0.03598313f, -0.04313099f, 
    0.04597412f, -0.04976859f, 0.02573709f, -0.05212141f, -0.00091984f, 0.02251393f, -0.03650942f, -0.03008137f, 
    0.00425899f, 0.00255461f, -0.03306772f, 0.00097534f, -0.05307399f, 0.04916555f, 0.00658325f, -0.05313018f, 
    0.04186065f, 0.01943931f, -0.01309359f, -0.04580109f, 0.01419397f, -0.01316115f, 0.03594107f, -0.02711347f, 
    -0.00207948f, -0.03104817f, -0.01983889f, 0.01756347f, 0.00612721f, 0.01816251f, -0.01929227f, -0.06024040f, 
    -0.00767594f, -0.04028384f, -0.04495341f, -0.01278222f, -0.02349292f, 0.00934150f, 0.03200786f, -0.03276704f, 
    0.00469913f, -0.06476989f, -0.02387854f, -0.04262097f, 0.03709998f, -0.03651833f, -0.02791280f, -0.01678060f, 
    -0.02924588f, 0.05233586f, -0.00610077f, -0.03028510f, -0.03276769f, -0.01997208f, -0.05975713f, -0.01301535f, 
    -0.00322206f, 0.00533303f, 0.05017138f, 0.01613683f, -0.00283022f, 0.01730682f, 0.00421963f, 0.02977820f, 
    -0.01269335f, 0.05275232f, -0.02952286f, -0.01027008f, 0.01638477f, 0.02303817f, 0.00711469f, -0.04435945f, 
    -0.04057882f, -0.00725584f, 0.00836390f, -0.00932044f, -0.06123211f, -0.03787328f, 0.03442241f, 0.03347494f, 
    -0.01780123f, -0.03212174f, -0.01275021f, 0.01032788f, -0.02102108f, 0.04040059f, -0.01063166f, -0.06396124f, 
    -0.06257159f, -0.01572960f, -0.00986112f, -0.02208718f, 0.02943452f, 0.03123306f, 0.00568725f, -0.06427205f, 
    -0.05721252f, -0.03384741f, 0.04688766f, -0.00781957f, 0.00847794f, 0.01844879f, -0.04053890f, -0.04750016f, 
    -0.02810770f, -0.00580952f, 0.01700086f, -0.03957308f, -0.05017630f, -0.06191751f, -0.02145809f, -0.05290928f, 
    -0.03096864f, 0.00473407f, 0.04769490f, -0.00009542f, -0.01667211f, -0.02408332f, -0.00744573f, 0.00090698f, 
    0.05576616f, 0.00948516f, -0.00466115f, 0.02368880f, 0.01073965f, -0.04464415f, 0.01620956f, 0.04939826f, 
    -0.00217569f, -0.02319384f, -0.00781334f, 0.00353689f, 0.03222719f, -0.03639441f, -0.02672925f, -0.05658927f, 
    0.01025505f, 0.03031899f, -0.03454132f, -0.04683430f, -0.02840997f, 0.02133458f, 0.02951091f, -0.01849903f, 
    0.03768035f, -0.01825008f, -0.03539553f, 0.04050354f, -0.00816357f, 0.04484630f, -0.04569018f, -0.04525573f, 
    0.00008789f, 0.00568884f, 0.01902363f, -0.02831354f, 0.02094977f, -0.05135256f, -0.06480274f, -0.00315834f, 
    -0.05164323f, 0.04729153f, 0.01245809f, 0.02689254f, -0.00011231f, -0.02237517f, 0.01343436f, 0.03906383f, 
    -0.08482920f, -0.46306145f, -0.51194644f, -0.05345168f, -0.06200198f, -0.18310843f, 0.12845892f, -0.00306559f, 
    -0.11458589f, 0.11381764f, -0.13494092f, -0.06075811f, 0.04624072f, -0.11171859f, 0.11386016f, 0.00430038f, 
    0.01697937f, -0.11639000f, 0.13868372f, -0.04299842f, -0.13406272f, -0.03972380f, 0.02431391f, -0.27329892f, 
    0.04494625f, 0.20799856f, 0.11051409f, -0.18298742f, 0.09535249f, 0.19447291f, 0.12623318f, 0.04916788f, 
    -0.06576987f, 0.03359432f, 0.20025334f, -0.01775916f, -0.26221064f, 0.27107120f, 0.16255593f, 0.37781605f, 
    -0.06164974f, -0.00422308f, 0.22439098f, -0.13986032f, 0.07699695f, -0.01841827f, 0.23873399f, 0.29985431f, 
    -0.09918369f, 0.15399566f, 0.03070847f, 0.02709590f, 0.14198002f, 0.11883643f, -0.17682499f, -0.10689344f, 
    0.24840537f, 0.03120264f, -0.01586630f, 0.01098712f, 0.02308969f, 0.00614090f, -0.06589912f, 0.23961146f, 
    -0.34760576f, -0.21305104f, -0.22278215f, 0.10283918f, 0.10006942f, 0.15750438f, 0.00381318f, 0.12451328f, 
    0.01480693f, -0.23389678f, 0.03738514f, 0.09832793f, 0.15780929f, 0.15894040f, -0.11985815f, -0.14431567f, 
    0.01493691f, -0.07972591f, -0.11289789f, -0.01019562f, -0.12870812f, 0.08225410f, 0.17597097f, 0.08412471f, 
    -0.05671756f, -0.13421945f, 0.03154401f, -0.00582215f, -0.29128206f, 0.09127035f, -0.20778738f, 0.18400045f, 
    0.33572766f, 0.04172727f, -0.01665920f, -0.07457370f, 0.22054942f, -0.10656393f, -0.22109015f, -0.11359323f, 
    0.07241732f, 0.21446455f, 0.12022687f, -0.14664756f, -0.44942740f, 0.58718181f, -0.35698518f, -0.26794282f, 
    -0.03531327f, -0.28698415f, -0.19968787f, -0.20496976f, -0.05813108f, -0.02755745f, -0.46028087f, -0.01136598f, 
    0.28867444f, 0.08312888f, 0.10994551f, -0.12791847f, -0.10848318f, 0.11086614f, -0.25983536f, -0.14756165f, 
    0.14125794f, -0.10549572f, -0.13460828f, -0.01141594f, -0.17733769f, 0.12738492f, 0.01894160f, -0.06552193f, 
    0.02329409f, 0.20283708f, -0.16602984f, 0.29182458f, -0.26042360f, -0.04712103f, -0.01396460f, -0.05034100f, 
    -0.35316211f, 0.55616277f, 0.01273979f, 0.01209821f, -0.15116380f, -0.19724303f, 0.01145558f, -0.17810807f, 
    0.02953760f, 0.24971405f, 0.20740595f, -0.03049098f, -0.05971963f, -0.15707444f, -0.08075635f, -0.03804013f, 
    0.05816803f, 0.00799759f, -0.55823112f, 0.19070731f, 0.25346923f, 0.05210187f, 0.29724830f, 0.27782989f, 
    -0.01364571f, 0.37521461f, -0.07234769f, 0.01358762f, -0.01155116f, 0.25068450f, -0.18068749f, -0.05545125f, 
    -0.30699182f, -0.11024831f, -0.06825483f, -0.01254215f, -0.39006117f, 0.18177921f, -0.14189455f, 0.09270000f, 
    0.14616743f, 0.06706548f, 0.14561878f, 0.04333756f, -0.12840550f, -0.39739746f, -0.18234511f, 0.21305273f, 
    -0.04588243f, 0.08533289f, -0.05287153f, 0.09133367f, -0.06908178f, 0.10559019f, -0.13212104f, -0.08605527f, 
    -0.03670856f, 0.01264870f, 0.15634981f, 0.24238339f, 0.12626763f, 0.12040959f, -0.05271946f, 0.30947697f, 
    -0.24641573f, -0.70434171f, 0.12902471f, -0.00610191f, -0.21548685f, -0.08290961f, 0.17230122f, -0.20650163f, 
    0.19371268f, -0.51995718f, -0.04413041f, 0.15695606f, 0.06927761f, 0.16185804f, 0.06672981f, -0.15273041f, 
    0.05310049f, 0.38693354f, -0.07124670f, 0.11569249f, 0.17715873f, 0.10018224f, 0.05234011f, 0.00192953f, 
    0.30462730f, 0.14472033f, -0.66481751f, 0.13831131f, -0.33660883f, -0.00027799f, -0.04328175f, -0.17971613f, 
    -0.25478536f, 0.01692624f, 0.01881701f, -0.06363676f, -0.42207059f, -0.23155883f, 0.06908743f, 0.00687460f, 
    0.09335352f, -0.14589690f, -0.01882124f, 0.17414708f, 0.07762131f, -0.26423320f, 0.29351383f, 0.11205467f, 
    0.12927195f, 0.10030545f, -0.12357762f, 0.08025470f, 0.06355069f, -0.00841941f, -0.24168104f, 0.09265167f, 
    0.01688579f, 0.11991253f, 0.14563861f, 0.02731048f, -0.04264122f, -0.05842422f, -0.04119440f, -0.12184179f, 
    0.25798091f, -0.13972518f, -0.16571166f, -0.30806267f, -0.02338405f, 0.17945412f, 0.23803140f, -0.25303903f, 
    0.13562976f, 0.29491016f, 0.11158416f, 0.21869752f, 0.19693317f, 0.12059410f, -0.10553110f, 0.15332025f, 
    -0.10915817f, -0.09302089f, -0.05953627f, 0.02883217f, -0.23564321f, -0.13869807f, 0.23843551f, 0.14683838f, 
    -0.17897223f, -0.13249189f, -0.60014433f, -0.28999585f, -0.30607119f, 0.16077955f, 0.18620129f, 0.12816335f, 
    0.02297639f, -0.01669730f, -0.41103294f, 0.03417910f, -0.29884455f, 0.00075021f, 0.10975381f, -0.13788125f, 
    0.32167497f, -0.28404909f, -0.15718305f, 0.01788823f, 0.05127240f, -0.23193610f, 0.18441698f, 0.06609721f, 
    0.17626750f, 0.00993831f, 0.00872651f, -0.09315394f, 0.00718733f, 0.13503104f, 0.16131324f, -0.06706546f, 
    -0.07607438f, -0.02012102f, 0.11326154f, 0.08815391f, -0.04567513f, -0.11259104f, 0.10655950f, 0.19660001f, 
    -0.06113835f, -0.05194702f, -0.19093421f, -0.03824198f, -0.03042025f, 0.24664205f, -0.27236554f, -0.53691000f, 
    -0.60284215f, -0.04173859f, -0.13871099f, 0.03295166f, -0.01381879f, -0.02444820f, 0.03414367f, -0.25842196f, 
    0.06012709f, -0.04622798f, -0.13117604f, -0.02388790f, -0.04980169f, 0.04089329f, 0.02346294f, 0.09499016f, 
    -0.04010114f, -0.68362135f, -0.29250562f, -0.11823476f, 0.04231649f, -0.06603987f, -0.08056335f, -0.08445427f, 
    0.17757837f, 0.18256871f, -0.14534016f, -0.45142218f, -0.18284334f, 0.13903166f, -0.02172328f, -0.01282831f, 
    -0.18824954f, 0.15474762f, -0.15245599f, -0.09562684f, 0.06136393f, 0.11138856f, 0.08682250f, -0.05251683f, 
    0.29025710f, 0.00776821f, -0.02001923f, -0.27399871f, -0.60589308f, 0.00199253f, -0.15982379f, -0.07269337f, 
    -0.08560751f, 0.00475598f, -0.11116844f, 0.04082729f, 0.25929707f, 0.09587847f, -0.08146946f, -0.14914498f, 
    -0.08363642f, -0.18189213f, -0.15498222f, -0.04587226f, 0.10733218f, -0.39534700f, -0.28822786f, -0.09947161f, 
    -0.18542491f, 0.04069292f, -0.03020241f, 0.01561583f, 0.03017133f, 0.10889959f, 0.37036106f, 0.19460884f, 
    -0.32266411f, 0.03055706f, 0.12324957f, 0.13466483f, 0.37047604f, 0.11150793f, 0.04697876f, 0.57566893f, 
    -0.11062469f, -0.22281167f, -0.09720233f, 0.11379022f, -0.03695341f, 0.00335262f, 0.04370592f, 0.15204322f, 
    0.16659681f, 0.10531358f, -0.03345815f, -0.28222710f, -0.20829855f, -0.17105438f, -0.04302689f, 0.00970077f, 
    -0.01706086f, 0.33066499f, 0.19991690f, -0.04202916f, -0.04576660f, 0.01389643f, 0.17208923f, 0.09851703f, 
    0.05933322f, 0.06201885f, -0.34642467f, 0.29057240f, -0.05573689f, 0.14695129f, 0.02314869f, 0.02287563f, 
    0.11217131f, 0.26444712f, 0.22126952f, -0.03095306f, -0.32536086f, -0.31805435f, -0.12216782f, 0.07926097f, 
    -0.21322946f, 0.01151645f, -0.16777863f, 0.16530083f, 0.09495033f, 0.12152517f, 0.03283465f, -0.03209841f, 
    -0.02559161f, 0.06391231f, 0.19872388f, -0.12124959f, 0.04275807f, 0.03113114f, 0.05666316f, 0.03129188f, 
    -0.09248689f, 0.14948972f, 0.01103131f, -0.13099083f, -0.15178436f, -0.14208359f, -0.71743315f, 0.06644946f, 
    0.15264943f, 0.03649765f, -0.09203347f, 0.04535562f, -0.05420048f, -0.09517812f, 0.01297642f, 0.51401901f, 
    -0.00271919f, -0.21296799f, -0.06238205f, 0.17497447f, 0.34842142f, 0.12397920f, 0.13041151f, 0.05390467f, 
    -0.19082171f, -0.05062460f, 0.03914033f, -0.03740989f, -0.02609895f, -0.00530071f, 0.13469741f, 0.05769625f, 
    -0.07684010f, 0.08665504f, 0.16916239f, 0.04343818f, 0.26270667f, 0.28760841f, 0.22063181f, 0.10411180f, 
    0.29168823f, 0.03893087f, -0.02843298f, 0.02137252f, -0.08287410f, -0.11357635f, -0.18052337f, 0.10331325f, 
    0.25696197f, 0.01756139f, -0.06301451f, -0.37540889f, -0.26477286f, 0.01494117f, -0.13097374f, -0.09658363f, 
    -0.05275986f, 0.05851151f, 0.10058095f, 0.03165615f, -0.70160407f, 0.03560695f, -0.13655695f, -0.00536567f, 
    0.11112069f, -0.01249046f, -0.07887150f, -0.19427532f, 0.11675049f, -0.26410452f, -0.69966733f, -0.37203273f, 
    -0.25700888f, 0.02572626f, -0.07174565f, -0.01644728f, -0.09117319f, 0.04945474f, -0.55623716f, 0.46124035f, 
    -0.42115748f, -0.12710734f, -0.10012219f, -0.14029334f, 0.17613944f, 0.04178816f, 0.24171859f, 0.13202772f, 
    0.29016796f, 0.36994430f, 0.10832078f, 0.16287139f, 0.17126681f, 0.22995353f, -0.02833570f, 0.08050779f, 
    -0.22483204f, 0.04508243f, 0.03102683f, 0.15954801f, -0.08168367f, 0.05981058f, 0.07910112f, 0.08294413f, 
    0.00981314f, 0.09880413f, -0.04970406f, 0.29393393f, -0.14678697f, -0.10724502f, 0.15490492f, -0.05082437f, 
    0.11967694f, 0.02097161f, 0.06259052f, 0.00960764f, -0.10786012f, -0.35985744f, -0.01183990f, 0.15123785f, 
    0.02442247f, 0.12479230f, -0.02698120f, 0.14872386f, 0.01602895f, 0.00719749f, 0.06778952f, -0.16683173f, 
    0.17581072f, 0.22808488f, -0.21017523f, -0.07781421f, -0.00880581f, -0.04208144f, 0.10884507f, -0.11289819f, 
    -0.23602603f, -0.04669072f, -0.09521164f, 0.01222174f, 0.06621981f, 0.07528933f, 0.07603593f, 0.43998876f, 
    0.00548864f, -0.13030227f, -0.06411756f, -0.04306131f, -0.00197629f, -0.20378193f, 0.30130321f, 0.38499421f, 
    0.03636538f, 0.06156275f, 0.02595719f, -0.15050611f, -0.06920148f, -0.19710936f, -0.16920097f, 0.10333853f, 
    0.13289438f, 0.03619009f, 0.06635088f, -0.28350928f, 0.58382845f, 0.10071463f, 0.39959121f, -0.34044969f, 
    -0.20195329f, -0.07266961f, 0.28171813f, 0.05524682f, 0.14006203f, -0.16148660f, 0.04747558f, -0.09878380f, 
    -0.06549340f, -0.26719770f, 0.21373169f, 0.17286001f, 0.10042210f, 0.19688939f, -0.38352272f, -0.01020959f, 
    0.00814985f, 0.00421168f, 0.03254448f, -0.05723055f, -0.15231869f, 0.20395552f, -0.21515110f, -0.11084221f, 
    0.10154822f, 0.09102531f, 0.13642722f, -0.20669146f, -0.08907715f, -0.13827297f, 0.11695024f, -0.07272882f, 
    -0.15718579f, 0.22361174f, -0.14191744f, -0.23739378f, 0.10737917f, 0.10636292f, 0.17179245f, 0.05424583f, 
    -0.08256929f, -0.03537615f, -0.22876108f, -0.03726764f, -0.11607832f, 0.23321882f, -0.13365032f, 0.37641197f, 
    -0.23567612f, -0.01568321f, 0.00845147f, -0.08593215f, 0.03808224f, -0.02097047f, -0.19101261f, -0.08878158f, 
    -0.20415296f, 0.16113895f, 0.15721360f, 0.04289346f, -0.24277730f, -0.15778141f, 0.00257725f, -0.07809366f, 
    -0.19202173f, 0.08746792f, 0.10509051f, 0.10372145f, 0.05092970f, -0.14438367f, 0.04543589f, 0.26532209f, 
    -0.01763033f, 0.05164710f, 0.16998486f, -0.05220265f, 0.10102467f, -0.27952531f, 0.12094495f, 0.11054829f, 
    -0.00066788f, -0.37229994f, -0.24823128f, 0.10407220f, 0.05063799f, 0.16960523f, -0.17143898f, -0.11662138f, 
    0.10784774f, 0.00527975f, -0.20318380f, -0.25519651f, 0.00178763f, 0.40484521f, 0.11569408f, -0.29627657f, 
    -0.00090374f, -0.13520451f, -0.24048494f, -0.02730421f, -0.36700654f, -0.60964274f, 0.02442641f, -0.12273560f, 
    0.01938852f, -0.11791758f, 0.04045056f, -0.13658682f, -0.01739480f, -0.11021853f, -0.09998044f, 0.04013512f, 
    -0.19816101f, -0.00095906f, 0.12527469f, 0.16385633f, 0.12996045f, 0.25572744f, -0.22555384f, -0.65738118f, 
    -0.03334548f, 0.04662231f, 0.03729737f, -0.04649470f, -0.14637665f, 0.08917205f, 0.21363968f, 0.16256049f, 
    0.14919697f, 0.02691342f, 0.08172520f, -0.03966224f, -0.02864070f, 0.19815111f, 0.11797749f, -0.14419086f, 
    -0.20441566f, 0.13505130f, 0.05921701f, -0.09298988f, 0.04869829f, -0.12717098f, 0.26513734f, -0.08561765f, 
    0.27088594f, -0.03059200f, 0.00038703f, -0.27576274f, -0.29135656f, 0.01178102f, 0.04706534f, 0.02953910f, 
    -0.02213314f, -0.19067903f, -0.08837539f, 0.37853345f, -0.05831469f, 0.06743979f, -0.11056244f, -0.07923256f, 
    -0.01548013f, 0.35310245f, -0.03017109f, 0.01078554f, 0.11999015f, 0.04734986f, -0.18955258f, -0.16965549f, 
    0.28401512f, 0.00526631f, 0.08984093f, 0.31654286f, 0.07179504f, 0.51799816f, -0.11877035f, -0.15602568f, 
    -0.27581793f, 0.00446925f, 0.15029177f, 0.05500368f, 0.17181067f, 0.01566860f, -0.17742631f, 0.04358174f, 
    0.10087986f, -0.05135812f, 0.04043244f, 0.02136603f, 0.05432153f, -0.04835398f, 0.29706588f, 0.35202497f, 
    -0.11114410f, -0.08566545f, -0.05761799f, -0.00607403f, -0.06042702f, -0.05421630f, 0.20601697f, 0.49229914f, 
    0.21591023f, -0.06740583f, -0.02275433f, -0.06684572f, -0.00044973f, -0.08387069f, -0.17603686f, 0.31161019f, 
    -0.12495944f, -0.01025417f, 0.13648430f, -0.14915259f, 0.04494236f, 0.03010037f, -0.02778419f, 0.01778969f, 
    -0.50780439f, -0.33982742f, -0.41463453f, -0.00283108f, 0.02216025f, -0.11091785f, 0.04550535f, 0.03416172f, 
    -0.00131624f, -0.31896806f, 0.01685476f, 0.33936736f, 0.06921382f, -0.00759580f, 0.10051616f, -0.07260861f, 
    0.06302580f, 0.11157562f, -0.17218299f, -0.31424478f, 0.15402159f, -0.23634492f, 0.08171402f, 0.12915921f, 
    0.04797642f, -0.11450073f, -0.00782585f, 0.29064310f, 0.35171375f, 0.11884588f, -0.01255636f, -0.00786706f, 
    0.08829281f, -0.06822518f, 0.05615121f, 0.23003767f, 0.15826997f, 0.04293810f, 0.03243415f, -0.22870390f, 
    0.08817323f, -0.17349894f, 0.13880447f, 0.19041058f, -0.00061431f, -0.05304522f, 0.09541630f, 0.28716394f, 
    -0.05729541f, -0.14774777f, -0.17865486f, -0.08556291f, 0.03691809f, 0.15808199f, -0.32821280f, -0.24547225f, 
    -0.49315304f, -0.04914055f, 0.02743141f, -0.10666104f, 0.01845586f, 0.01613710f, -0.08155355f, 0.06994247f, 
    -0.05069492f, -0.24058762f, -0.23068376f, -0.62237030f, 0.06074989f, -0.11412498f, -0.07998451f, -0.14321895f, 
    -0.53282291f, 0.27081075f, 0.50243539f, -0.02561824f, 0.14608681f, -0.14984278f, -0.11531394f, 0.01207036f, 
    0.04666328f, -0.43233371f, -0.01267458f, 0.41986036f, -0.08955151f, 0.08708950f, -0.14133538f, -0.42989627f, 
    -0.17690925f, -0.00939323f, 0.09432301f, 0.08434919f, 0.04663666f, -0.02269621f, 0.18487847f, 0.06845414f, 
    0.10424025f, 0.10261422f, 0.14253983f, 0.11595398f, -0.03609772f, 0.20182976f, -0.10901172f, 0.00678435f, 
    0.07710262f, -0.10826416f, -0.24644461f, -0.00912787f, 0.13294910f, 0.09644426f, -0.00844546f, -0.08392833f, 
    -0.29194632f, -0.10496321f, -0.13985008f, 0.00408395f, -0.03104722f, -0.25394437f, 0.06853600f, 0.25022814f, 
    -0.17011887f, 0.09838864f, -0.31112167f, 0.00747901f, 0.07035211f, -0.03141434f, 0.49953613f, -0.17487770f, 
    0.05258345f, 0.16976984f, -0.16776836f, 0.08394361f, 0.01592773f, 0.42852843f, 0.11773832f, -0.06243921f, 
    -0.06581724f, 0.21658181f, -0.01794696f, 0.01090795f, -0.23654255f, 0.03247510f, 0.06511472f, 0.24484062f, 
    0.06327129f, 0.01172047f, -0.04203935f, -0.28936291f, -0.36601761f, -0.34777567f, 0.19763075f, -0.01368038f, 
    0.09044308f, 0.04743963f, 0.04368992f, 0.06386138f, 0.00291527f, 0.02627984f, 0.01162682f, 0.01654725f, 
    0.27598184f, 0.14641394f, 0.20525542f, 0.15311337f, 0.37818867f, -0.02370073f, -0.11146124f, 0.09904667f, 
    -0.07907512f, -0.00820664f, 0.33690900f, -0.63471973f, -0.30240318f, 0.08440896f, -0.10529216f, -0.06144648f, 
    -0.22231682f, 0.26644796f, 0.09319064f, 0.10248546f, 0.04241297f, -0.07921976f, -0.02545336f, 0.00432376f, 
    0.02153242f, -0.13679327f, 0.07117817f, 0.14520399f, 0.08459093f, -0.27175203f, 0.25328672f, -0.19193454f, 
    -0.34664896f, 0.03579962f, 0.00230216f, 0.09094158f, 0.05500459f, 0.08050283f, -0.39964607f, -0.17742020f, 
    -0.10042948f, 0.04593632f, -0.11476629f, -0.03955666f, 0.14237039f, -0.04611298f, -0.10734487f, 0.47296378f, 
    0.03453508f, 0.04518033f, 0.05050955f, -0.11927102f, 0.28393018f, 0.05544762f, 0.00547256f, 0.13737892f, 
    -0.15834038f, 0.13698979f, 0.17743522f, -0.13016333f, 0.10230508f, 0.11816602f, 0.03213961f, 0.09144891f, 
    0.06922788f, -0.03035105f, 0.33026963f, 0.30676776f, 0.00444285f, 0.10962836f, 0.30932704f, -0.01100940f, 
    0.00349944f, 0.23807459f, -0.02277209f, -0.02843506f, -0.00194392f, -0.09565123f, -0.15454553f, 0.27072325f, 
    0.03606404f, 0.00175583f, 0.05060901f, -0.34256116f, -0.03016224f, 0.36036241f, -0.25188613f, -0.18158494f, 
    -0.10624620f, 0.07802603f, 0.05815821f, -0.00537520f, -0.30158123f, 0.22920908f, 0.47930723f, -0.17474568f, 
    0.15203971f, 0.09595039f, 0.06919882f, -0.06987752f, 0.06792508f, -0.47704613f, 0.10821889f, -0.18631999f, 
    -0.09894870f, -0.00490217f, -0.13141307f, 0.05685720f, 0.04642148f, -0.05821925f, -0.55094111f, -0.15380274f, 
    -0.18743293f, -0.15811801f, -0.11558362f, -0.24029008f, 0.27493358f, -0.05450536f, 0.09008016f, 0.30770016f, 
    0.07557013f, 0.06450720f, 0.16730987f, 0.11658125f, 0.03625913f, 0.25490806f, 0.06475873f, 0.06538159f, 
    -0.01949240f, -0.02022736f, 0.03340441f, -0.01319496f, 0.01512645f, -0.05439834f, -0.00555356f, 0.02825790f, 
    0.04032547f, -0.04701315f, -0.00321350f, 0.02981058f, 0.05324258f, 0.04688952f, -0.02184844f, -0.02227329f, 
    0.00222270f, 0.02606094f, -0.03213350f, -0.04812027f, 0.03487130f, -0.04738500f, 0.03763398f, -0.00231751f, 
    0.04466019f, 0.03955439f, 0.04072547f, -0.05597098f, -0.03902840f, -0.02608971f, 0.02536373f, 0.01463067f, 
    -0.05993254f, 0.02499189f, 0.03557438f, 0.03188079f, 0.02933886f, -0.03210257f, -0.02349048f, -0.05715172f, 
    0.02938640f, -0.04712066f, -0.03720177f, 0.02206364f, -0.00751990f, -0.00966499f, 0.02943290f, 0.02839474f, 
    0.04405951f, 0.00658639f, -0.05789967f, -0.04805147f, -0.04453840f, 0.05468928f, -0.02950902f, -0.05437563f, 
    0.04378071f, 0.00919042f, -0.05503530f, 0.01864131f, -0.00282632f, -0.06142953f, -0.05688038f, -0.05235059f, 
    -0.06264109f, -0.01684228f, 0.02079656f, 0.03278437f, -0.00399803f, -0.06490947f, 0.02538520f, 0.03588125f, 
    0.04366031f, 0.02332410f, -0.05902878f, -0.02492936f, 0.03744346f, -0.01259468f, 0.02611939f, 0.02945402f, 
    -0.00934187f, -0.01206010f, 0.03120423f, -0.01662441f, 0.02788848f, -0.03770697f, 0.04533541f, -0.03870065f, 
    0.05533398f, -0.03332282f, -0.01551436f, 0.00403468f, -0.06199887f, -0.03733247f, 0.04219978f, -0.03107509f, 
    0.02959735f, 0.01892917f, 0.01729095f, -0.03718515f, -0.03447938f, -0.03318015f, -0.05711206f, -0.03978247f, 
    -0.02549206f, -0.03570763f, -0.05082057f, 0.02935085f, -0.03877455f, 0.01592892f, -0.06455764f, -0.01336438f, 
    -0.07003158f, -0.00496177f, -0.02491958f, -0.04314537f, -0.05836465f, -0.03682761f, -0.01388430f, 0.04303021f, 
    -0.03200835f, 0.04194755f, -0.06471050f, 0.02738537f, 0.02526775f, -0.05192344f, -0.04719431f, -0.04225087f, 
    0.03492816f, -0.02076190f, -0.00613212f, -0.04914064f, 0.00841650f, -0.05465765f, -0.00838967f, 0.02837933f, 
    -0.05462192f, 0.00323857f, -0.00511105f, 0.03739263f, 0.00482857f, -0.01993948f, 0.02423706f, -0.05098796f, 
    -0.02517177f, -0.02955864f, -0.03755433f, 0.02647461f, 0.03026220f, 0.03153280f, 0.02128365f, -0.04878464f, 
    0.01758346f, -0.03744893f, 0.02236674f, 0.00695936f, -0.07072046f, -0.04538400f, -0.02266559f, -0.06327415f, 
    -0.02472579f, -0.01838077f, -0.00705346f, -0.05185609f, -0.06468236f, -0.04999207f, 0.04161483f, -0.00642651f, 
    -0.05445205f, 0.04379674f, -0.00187171f, 0.02314272f, -0.07652064f, -0.00325595f, 0.01454796f, -0.05767236f, 
    -0.06907640f, -0.06042389f, -0.04672685f, -0.03151996f, 0.00478893f, -0.03528548f, 0.00193575f, -0.06000745f, 
    0.00195113f, -0.04246751f, -0.00445372f, 0.00439173f, 0.04022825f, 0.01364864f, -0.03541404f, -0.01517025f, 
    0.05430952f, -0.06472459f, 0.03024287f, 0.00373703f, 0.00833856f, 0.01872112f, -0.00944782f, 0.04613672f, 
    0.03439808f, 0.02627008f, 0.01819199f, -0.02608278f, 0.03126043f, 0.05037428f, -0.03228584f, 0.04279032f, 
    -0.05483752f, -0.07448310f, -0.04525327f, -0.05726405f, 0.01285762f, -0.05937901f, 0.03400325f, -0.05627187f, 
    -0.00369787f, -0.02773984f, -0.05096534f, -0.02600975f, -0.02309373f, 0.01140794f, -0.00049969f, -0.01386402f, 
    -0.01416841f, -0.04037838f, -0.00972431f, 0.03222598f, -0.04395631f, 0.03633204f, -0.06452589f, 0.02417562f, 
    -0.05812568f, -0.03275057f, 0.01513207f, -0.00355017f, -0.01424078f, -0.04402859f, 0.03664055f, -0.03141792f, 
    -0.01267824f, -0.03124659f, 0.03612988f, 0.00880609f, 0.05603401f, 0.03446319f, -0.04444033f, 0.02334350f, 
    0.03720356f, -0.01098369f, 0.03641926f, -0.04262114f, 0.00224697f, -0.01395432f, -0.03665582f, 0.00679764f, 
    0.00817541f, -0.02857315f, -0.05716399f, 0.04549619f, -0.00823055f, -0.02169186f, -0.01344684f, 0.01104861f, 
    -0.06210958f, -0.03702230f, 0.04992550f, -0.06093986f, 0.01453126f, 0.02824620f, -0.02281558f, -0.00058743f, 
    -0.02084901f, -0.00635333f, -0.04115913f, -0.06249996f, -0.01971567f, 0.03250108f, 0.03234299f, 0.02711983f, 
    -0.04956378f, 0.02414552f, 0.03003782f, 0.01882914f, 0.03936043f, 0.04259602f, 0.01848224f, 0.03757022f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    -0.05603638f, -0.01338009f, 0.21391246f, -0.03665287f, -0.03656614f, -0.03575775f, 0.18864523f, 0.01543902f, 
    0.34748617f, -0.07382733f, 0.13161239f, -0.06391436f, 0.00671238f, -0.06004938f, 0.06498841f, 0.33930272f, 
    -0.01612619f, 0.23848590f, 0.08657375f, 0.17991997f, 0.43030503f, -0.21135597f, -0.05161382f, -0.06029697f, 
    -0.03091785f, 0.04372188f, -0.05456515f, 0.29651406f, 0.34297645f, 0.15320998f, 0.20566861f, -0.00931217f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.37192246f, -0.13325094f, -0.23627464f, 0.43647879f, 0.12976030f, 0.08936324f, -0.33177674f, 0.01931992f, 
    -0.02883011f, 0.14241038f, -0.51990122f, -0.02387564f, -0.12404447f, 0.06152248f, 0.21075857f, -0.63556564f, 
    0.59127980f, -0.46951011f, 0.08279870f, -0.32578707f, 0.02912873f, 0.02943868f, -0.01008590f, -0.11727811f, 
    0.30293202f, 0.14313427f, -0.05476763f, -0.80774397f, -0.41329658f, 0.31352070f, -0.25703990f, -0.01351043f, 
    0.57498741f, 0.06921984f, 0.02788724f, -0.17516758f, -0.45354798f, 0.05111389f, 0.20290552f, -0.15371484f, 
    1.03178501f, 0.23992521f, -0.29157868f, -0.43489754f, -0.14226303f, 0.06786332f, 0.22831106f, -0.02361346f, 
    0.40827224f, 0.41004330f, 0.15840337f, -0.10575824f, -0.09893230f, -0.03749583f, -0.12188730f, -0.09860621f, 
    0.16116145f, 0.25912905f, 0.08267049f, -0.36723292f, 0.26926005f, -0.10614663f, -0.07962959f, -0.15828183f, 
    -0.63552409f, 0.10952827f, 0.00512834f, -0.32102224f, 0.40986356f, -0.10439730f, -0.06274869f, -0.18063822f, 
    0.00937977f, 0.08575036f, 0.24267156f, 0.06067423f, -0.43592888f, 0.00861072f, 0.42187211f, -0.14204094f, 
    -0.60912704f, 0.20344280f, -0.09258533f, -0.52875519f, 0.52805293f, 0.09761371f, -0.06825103f, 0.08967423f, 
    0.34887904f, -0.12517810f, 0.06659278f, 0.04828786f, -0.87029964f, 0.15835322f, 0.50253803f, 0.09795687f, 
    -0.73530149f, -0.12536809f, -0.32979044f, 0.27521196f, 0.12193196f, 0.01814762f, -0.39298591f, -0.10669070f, 
    -0.40313810f, -0.11125027f, 0.15568134f, 0.16469648f, 0.33904874f, -0.04297243f, 0.13490300f, -0.58514017f, 
    -0.05681158f, 0.35016966f, -0.30535665f, -1.08517063f, -0.49352944f, 0.52308881f, -0.05419597f, 0.00639161f, 
    0.44862044f, 0.14713517f, -0.12597366f, 0.62913829f, -0.59846729f, -0.54087043f, -0.92027587f, -0.01709789f, 
    0.52471912f, 0.15058531f, 0.12325598f, -0.05080519f, 0.09656180f, 0.06657720f, -0.13075025f, -0.05452273f, 
    -0.47008473f, -0.05407069f, 0.48886943f, 0.18632248f, -0.07454091f, -0.12708738f, -0.15861422f, 0.41732484f, 
    -0.06265778f, -0.22874035f, 0.06588326f, -0.19906512f, -0.39933485f, 0.25815549f, 0.23120107f, -0.05421218f, 
    -0.11088622f, -0.18940689f, 0.14103231f, -0.13765362f, -0.31681764f, 0.27611500f, -0.31678018f, -0.08990882f, 
    -0.31045997f, 0.02187919f, 0.06855008f, 0.28795660f, 0.28214478f, -0.13356675f, 0.34799114f, -0.14832364f, 
    -0.37783715f, 0.02463266f, 0.49391723f, -0.15162012f, -0.18082234f, 0.00045958f, -0.25949425f, 0.30023298f, 
    0.17900908f, 0.27080193f, 0.01420737f, 0.28886425f, -0.46710950f, -0.38553467f, -0.32990333f, -0.10451655f, 
    0.02327762f, 0.18371192f, 0.02776986f, -0.19849896f, -0.24536574f, 0.26796824f, -0.05278179f, 0.11363327f, 
    -0.48156187f, 0.08195572f, 0.43707401f, -0.09039605f, 0.36726132f, 0.11165725f, -0.20888473f, -0.07972226f, 
    -0.18303759f, -0.46337125f, -0.26317382f, 0.20785670f, -0.32327640f, -0.00914748f, -0.00967742f, -0.52544951f, 
    -0.59396178f, -1.04689598f, 0.41096553f, -0.45888755f, 0.66712433f, -0.18427853f, 0.23519103f, -0.04718266f, 
    -0.01385997f, -0.04109877f, 0.09001230f, -0.10459471f, 0.56181812f, -0.13829631f, 0.22431366f, 0.06449926f, 
    -0.08829369f, 0.15245706f, -0.18410739f, 0.09981484f, 0.16142493f, -0.01338759f, -0.08583776f, -0.15341114f, 
    -0.42207429f, 0.46675563f, 0.24651457f, -0.03928116f, 0.02896800f, 0.15517469f, -0.40230498f, -0.59976530f, 
    -0.20480384f, -0.48244819f, 0.33788669f, 0.45441493f, -0.41901088f, 0.09308872f, 0.09923839f, 0.02203066f, 
    -0.26607209f, -0.33296096f, -0.09289378f, 0.24303685f, 0.03874675f, -0.05127328f, -0.01919552f, -0.13363095f, 
    -0.35905701f, 0.12495265f, -0.17658415f, 0.47330454f, -0.99846292f, -0.10309320f, 0.46200854f, -0.14220139f, 
    -0.18922676f, 0.12465358f, -0.44619673f, -0.38113439f, -0.50550222f, 0.03007360f, -0.12040251f, 0.16475822f, 
    -0.16179997f, 0.13091068f, -0.49807018f, -0.25314820f, 0.07633850f, 0.25620547f, -0.07058927f, 0.00238491f, 
    -0.36958271f, 0.22562894f, -0.08020542f, 0.77045196f, 0.77180755f, 0.01331293f, 0.03408284f, -0.08099885f, 
    0.43553934f, -0.15208998f, 0.19850759f, -0.16323875f, -0.29370028f, 0.03209706f, -0.19086155f, -0.10485629f, 
    -0.02893333f, -0.60571551f, 0.39499682f, 0.67680556f, 0.09635918f, 0.13233805f, -0.27995887f, 0.42694777f, 
    0.05209680f, 0.02260596f, -0.13832501f, 0.27069294f, 0.14821596f, -0.40297550f, 0.35258949f, 0.04055875f, 
    -0.80754417f, 0.08677501f, 0.14697857f, 0.31352118f, -0.43042257f, -0.14161971f, -0.33058617f, 0.10239788f, 
    -0.09988520f, 0.03866524f, -0.50061929f, -0.58320731f, -0.05484862f, -0.06166707f, 0.43587846f, -0.08736812f, 
    -0.21920687f, -0.80241549f, -0.20699389f, -0.29075256f, 0.72845417f, 0.05959864f, 0.26656887f, -0.28233185f, 
    -0.51476210f, -0.10157789f, -0.20796312f, -0.52486616f, 0.05270694f, 0.14287667f, -0.48638284f, -0.01729656f, 
    -0.26432112f, -0.13294904f, 0.10790522f, 0.04052560f, -0.19998786f, 0.55155098f, -0.02697039f, -0.09491844f, 
    -0.21998337f, -0.15895000f, 0.44578713f, -0.12254912f, -0.39175069f, 0.12910281f, 0.06367569f, 0.11655591f, 
    -0.16523637f, -0.21432838f, -0.57274437f, -0.05382410f, 0.28462645f, -0.17861699f, -0.03315363f, 0.32342607f, 
    -0.48473561f, -0.40642092f, -0.85098124f, 0.53308415f, -0.16604988f, 0.15673038f, 0.44048640f, 0.00379144f, 
    0.55202103f, -0.66162062f, 0.17023885f, 0.00121584f, 0.17357171f, -0.65341288f, 0.24547100f, -0.14051726f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.28399757f, 0.07492219f, -0.07880750f, 0.07312687f, -0.07779647f, 0.00671507f, -0.04547740f, -0.22541520f, 
    0.06569342f, 0.27965763f, 0.04067219f, -0.12052734f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
