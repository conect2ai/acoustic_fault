#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -1.99907315f, -0.68130571f, 1.18432879f, 0.69864213f, -0.20155556f, 1.00231349f, 0.55571145f, 0.51104951f, 
    0.24560748f, -0.69858438f, -0.12164398f, -0.37502012f, 0.21397527f, 0.27788523f, 0.20162296f, 0.07298350f, 
    0.25057441f, -0.19968531f, -0.29763561f, 0.31172183f, -0.00119179f, 0.15720335f, -0.02868254f, 0.00576884f, 
    0.08796162f, -0.86644232f, 1.52232635f, -0.67627543f, -0.81605744f, -0.47188807f, 0.49202806f, 0.85980093f, 
    -0.69548190f, 0.73355401f, 0.74611992f, 0.04175729f, -0.13817486f, 0.13090338f, -0.28215030f, 0.20568080f, 
    0.38029191f, 0.02803602f, 0.35385928f, 0.36427927f, -0.28033993f, 0.11067728f, -0.37744117f, 0.10581706f, 
    0.13546452f, 0.57892805f, -0.90338421f, -0.92575473f, -0.74961525f, -0.23030753f, 0.03768940f, -1.16847253f, 
    -0.26130730f, 0.16142665f, 0.02549515f, 0.45404851f, 0.77814770f, -0.43507785f, 0.50729358f, -0.43268350f, 
    0.32782468f, 0.13618907f, 0.44214404f, 0.04655875f, -0.36473042f, 0.54352802f, -0.11187548f, -0.19034095f, 
    -0.15113141f, 0.53166389f, 0.48732123f, 1.34468079f, 0.83484858f, 0.29868010f, 0.99802780f, 1.67012763f, 
    1.01380289f, -0.02363192f, -0.02611825f, 0.00717061f, 0.41039464f, -0.52126348f, 0.12094960f, 0.14016949f, 
    0.26963317f, 0.31353432f, -0.21207643f, -0.04682728f, 0.29271600f, 0.07536484f, 0.07175075f, 0.35474855f, 
    0.20219837f, 0.29430687f, -0.17409667f, 0.09956324f, 1.61884737f, 1.08032930f, -0.04532269f, 0.25653598f, 
    -0.93494868f, 0.30014753f, 0.09365240f, -0.05649575f, 0.81972384f, 0.18222402f, 0.36294866f, 0.15656488f, 
    -0.52597660f, -0.43127924f, 0.20742533f, -0.25817844f, -0.56791687f, -0.49163947f, 0.00899501f, 0.29680181f, 
    -0.08564498f, -0.06444877f, 0.30294517f, -0.32712847f, -0.12469404f, 1.35513210f, 0.71172702f, -1.04561269f, 
    0.16146699f, -0.86896920f, -0.80789375f, -0.76145589f, -0.59644032f, 0.23970559f, -0.59171134f, -0.49873275f, 
    -0.03768157f, 0.37290078f, 0.32442564f, -0.10631810f, -0.01842726f, -0.08561355f, -0.64750689f, 0.20081060f, 
    -0.01932380f, 0.16875350f, 0.23010114f, 0.06556638f, -0.31683639f, 0.16589676f, -0.26341626f, 0.19675395f, 
    0.42951897f, 0.33851218f, 0.23492184f, -0.13123955f, -1.19961572f, 0.00288448f, -0.01891259f, -0.63608670f, 
    0.35069764f, -0.70939428f, 0.15457849f, 0.52121145f, -0.54176271f, 0.18560381f, 0.60270530f, 0.23857988f, 
    -0.05171620f, 0.50858873f, 0.38641670f, 0.69356376f, 0.30327088f, -0.04012863f, -0.78698254f, -0.14427504f, 
    -0.97230983f, -0.93567777f, -1.03286910f, -0.62279350f, -0.31402835f, 1.26385903f, 0.80112308f, 0.09769364f, 
    0.78668225f, -0.02271696f, -0.12712447f, -0.33307430f, -0.42835668f, -0.66697550f, -0.05930861f, 0.24868719f, 
    -0.13286909f, 0.05305497f, -0.07992512f, -0.39694685f, 0.04278160f, -0.09563563f, -0.43498778f, 0.16978563f, 
    1.22687471f, 1.55063212f, 1.08831882f, 1.00176275f, 0.85727310f, -0.34750727f, -0.12542516f, -0.19466703f, 
    -0.24064995f, 0.19407730f, 0.13558556f, 0.15387990f, -0.22062746f, 0.02298715f, 0.34920791f, 0.09337895f, 
    0.05801194f, 0.47169006f, 0.36160296f, 0.51413840f, 0.24313343f, -0.02913382f, -0.44390365f, 0.04945258f, 
    0.80454159f, -0.32269531f, -2.04395175f, -0.45184737f, 0.74571341f, 0.32307640f, -0.16195084f, 1.57020140f, 
    0.54928368f, -0.42940009f, 0.47075006f, 0.35080689f, 0.34836572f, 0.01749075f, -0.12785351f, 0.32306200f, 
    -0.47064146f, -0.15104294f, -0.15086037f, -0.21682471f, -0.32190832f, -0.00828157f, 0.08405788f, -0.13252650f, 
    -0.09459995f, 0.06419145f, 0.06267357f, 0.27326256f, -1.25586951f, -1.51939106f, -0.71176469f, 0.97024316f, 
    -0.71797103f, 0.00372046f, -0.70314962f, -0.50816876f, 0.69307470f, -0.10436650f, 0.24593985f, 0.22824843f, 
    -0.02463236f, 0.19933739f, 0.11616761f, -0.03161632f, -0.14137527f, 0.28105748f, -0.24259908f, -0.14300221f, 
    0.48508149f, -0.42674273f, 0.19981287f, 0.03185379f, -0.90724468f, 0.90948373f, 0.75997776f, 1.17043161f, 
    -0.97449511f, -0.07320285f, -0.94450891f, -1.17784619f, 0.20072456f, 0.38201877f, 0.46179944f, 0.23952773f, 
    0.46180195f, 0.10236049f, 0.01867711f, 0.21772830f, 0.18055549f, -0.00204485f, 0.32334763f, 0.10429026f, 
    -0.06073657f, -0.30485949f, -0.00177797f, 0.18023933f, 0.42245534f, 1.67040443f, 1.05507946f, -0.22732259f, 
    -0.67130250f, -1.28377926f, 1.20530736f, -0.51519042f, -0.82818347f, -0.46968830f, -0.00028383f, 0.32727167f, 
    -0.54202682f, 0.07194389f, -0.06413671f, -0.10914007f, -0.43848681f, -0.28406993f, 0.07311162f, -0.18760416f, 
    0.11916497f, 0.26869068f, 0.31493729f, 0.13302912f, 0.16063556f, 1.00058782f, 0.62564588f, 0.39420459f, 
    0.94556147f, 0.91496879f, -0.31939214f, 0.85571742f, 1.04574788f, 1.00010717f, 0.50463724f, -0.85738009f, 
    -0.02214187f, -0.09996428f, 0.13718070f, -0.17637356f, 0.20250344f, -0.20733844f, 0.11839161f, -0.01344081f, 
    0.39592841f, -0.10222428f, -0.08303926f, 0.40387109f, 0.16315112f, -0.09234001f, 1.58687890f, 0.24503566f, 
    -0.79144424f, 1.46650720f, 0.40579578f, 0.66877794f, 0.46455944f, -0.01009367f, -0.10557840f, -0.40964693f, 
    -0.14331281f, -0.44376138f, -0.26880130f, -0.22588594f, -0.28049710f, -0.04439065f, -0.05018599f, -0.22558314f, 
    -0.34742549f, -0.22973716f, -0.25545850f, -0.43032068f, -0.48850623f, -0.37582242f, 0.02183506f, -0.59664291f, 
    0.06950657f, 0.93327302f, 0.66356915f, -0.31854138f, -1.28506851f, -0.36819398f, 0.24904419f, -0.13526849f, 
    -0.46569902f, 0.57765245f, 0.16714367f, -0.44547391f, -0.07654254f, 0.50298405f, 0.02824147f, 0.36615619f, 
    -0.00661604f, 0.09687843f, 0.45966798f, 0.40585226f, 0.22367273f, -0.15053442f, 0.09050002f, 0.15097426f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.42143330f, 0.01419944f, 0.52308708f, 0.32792044f, 0.54299068f, 0.17718619f, 0.33465263f, 0.09111638f, 
    0.30281350f, 0.32434240f, 0.62940723f, 0.35340649f, 0.42919585f, 0.24193360f, 0.18191881f, 0.18030430f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.09679562f, -0.05224426f, 0.27006975f, 0.40280384f, -0.24199213f, 0.15202834f, 0.02226938f, 0.10088855f, 
    0.05660564f, -0.20191199f, 0.10772131f, -0.13490167f, 0.97785980f, 0.12543334f, 0.16917284f, -0.52681941f, 
    0.02978065f, 0.04005529f, 0.09303992f, -0.38605300f, 0.01799501f, -0.17355900f, -0.09501490f, -0.00639687f, 
    -0.51485515f, -0.22676367f, -0.50061619f, 0.09533051f, -0.09038157f, 0.19484422f, -0.16370034f, 0.01440142f, 
    -0.06253093f, 0.19671008f, 0.16177258f, -0.06295045f, 0.41924778f, -0.36880270f, 0.16433261f, 0.36444381f, 
    -0.24801800f, -0.12972058f, -0.03901876f, 0.06222740f, -0.05517343f, 0.15276863f, -0.07450897f, -0.06082320f, 
    -0.13343903f, -0.13262220f, -0.40861776f, 0.00600863f, -0.08679206f, -0.13621008f, 0.12108117f, 0.00569661f, 
    0.12555139f, -0.08646346f, 0.12323292f, -0.04540968f, -0.12626404f, -0.03191834f, 0.18593584f, -0.10631368f, 
    0.02298308f, 0.15734406f, -0.05504704f, 0.15478984f, -0.26706818f, -0.13131087f, -0.08362086f, 0.10458383f, 
    -0.10522958f, -0.15940610f, -0.06130178f, 0.11301698f, 0.06660575f, 0.22719067f, -0.03090535f, -0.07931501f, 
    0.10522147f, -0.13681480f, -0.18923028f, 0.00072721f, -0.09266590f, 0.13988940f, 0.16939510f, -0.88147569f, 
    0.07114926f, 0.13867064f, 0.19967134f, 0.09305902f, 0.08453468f, -0.04565643f, 0.05294356f, 0.00374732f, 
    0.31325644f, -0.06545413f, 0.10366235f, -0.21738127f, -0.34893453f, -0.20462458f, 0.06463626f, 0.13076288f, 
    0.11888170f, 0.03274653f, -0.27047843f, 0.06375591f, -0.55318457f, 0.35934550f, -0.14030822f, -0.00503397f, 
    0.07111251f, -0.09080385f, -0.09353048f, -0.13418485f, 0.01471668f, 0.04531194f, 0.05212182f, 0.05457113f, 
    -0.13200478f, -0.36766201f, 0.16253668f, -0.22792709f, -0.30196825f, 0.07330415f, 0.18889168f, 0.07838675f, 
    -0.11278184f, -0.03043026f, -0.10969581f, -0.05026355f, 0.34053433f, -0.41695270f, -0.10899747f, 0.21069966f, 
    -0.28963497f, -0.04990006f, 0.01710553f, -0.06144438f, -0.10171077f, -0.01257084f, -0.16891219f, 0.08940408f, 
    -0.12505943f, 0.19115143f, 0.09384609f, -0.07356156f, -0.19608480f, 0.11975469f, -0.27919310f, 0.00629144f, 
    -0.19021244f, -0.02836018f, 0.03046052f, -0.16639924f, 0.24746363f, 0.02857117f, -0.31141517f, 0.36012509f, 
    -0.34161425f, 0.07295738f, -0.19035344f, 0.08169642f, -0.05402066f, 0.03863949f, 0.21147330f, -0.02292182f, 
    0.27321216f, -0.14314379f, -0.11995603f, 0.50503069f, -0.32107928f, 0.11979581f, 0.17892751f, 0.09077623f, 
    -0.05321147f, -0.01607599f, 0.01937509f, -0.18362376f, 0.27897337f, 0.21621101f, -0.11228142f, 0.39612818f, 
    -0.01673088f, 0.01939229f, 0.07887645f, -0.15715590f, 0.17878897f, -0.05145118f, 0.27080807f, 0.05295076f, 
    -0.78837603f, 0.44714746f, -0.09129335f, 0.09212228f, -0.05305717f, 0.08824086f, 0.00054483f, -0.06611010f, 
    -0.19154409f, 0.20598868f, 0.00417945f, -0.00579466f, -0.64169908f, -0.21434285f, -0.15458567f, -0.41773626f, 
    -0.06749070f, -0.18510385f, -0.04702372f, 0.19544849f, 0.32328898f, -0.05688311f, 0.06422377f, 0.13436006f, 
    0.48487839f, -0.17007457f, -0.07842509f, -0.11465920f, 0.13990910f, 0.06261332f, -0.08876117f, 0.12521307f, 
    -0.07743955f, -0.26104304f, 0.04890194f, 0.16755861f, 0.24500962f, -0.04088148f, 0.05171321f, 0.22451051f, 
    -0.19069338f, -0.04776193f, 0.02208129f, -0.00850930f, -0.05027072f, 0.05815170f, 0.00579031f, 0.05593309f, 
    0.31772360f, -0.06469005f, 0.31710365f, 0.10172404f, -0.10023817f, -0.13470258f, -0.02746218f, 0.11984361f, 
    -0.20682056f, 0.06955618f, -0.28235275f, 0.11857692f, 0.24858075f, -0.57585603f, -0.20903131f, -0.42029661f, 
    -0.18091856f, -0.17565592f, -0.05841298f, 0.28170064f, -0.16426349f, 0.00133079f, -0.22128190f, -0.06416316f, 
    -0.37136090f, 0.13362776f, 0.01174153f, -0.12304918f, 0.03911684f, -0.18208736f, 0.07035650f, 0.00830030f, 
    0.06848142f, -0.08853818f, -0.05670855f, 0.01730480f, 0.29449996f, -0.30680621f, -0.14990452f, -0.21011053f, 
    0.10828360f, -0.15839833f, -0.08872943f, 0.04240552f, 0.00521054f, -0.01663030f, -0.06961943f, -0.06550057f, 
    0.52073431f, 0.15157571f, -0.04368158f, 0.43014637f, -0.07802688f, 0.01562199f, 0.13759615f, -0.00081641f, 
    0.00535756f, 0.02724608f, -0.04046951f, 0.03621321f, 0.26044458f, -0.31825459f, -0.09108366f, 0.15515174f, 
    -0.17653972f, 0.04591397f, 0.05578303f, 0.04379530f, -0.01835123f, -0.20769668f, 0.02080960f, -0.00798254f, 
    0.08905002f, -0.03782156f, 0.02302932f, -0.28081438f, 0.01546165f, 0.02420729f, 0.13145036f, -0.05916744f, 
    0.02678461f, 0.15269281f, 0.29613322f, -0.05698518f, -0.29908249f, -0.31348988f, -0.06503225f, -0.12894215f, 
    -0.11306367f, 0.07247446f, -0.10242846f, 0.04385540f, 0.04022828f, 0.12544155f, 0.09216651f, -0.18760872f, 
    -0.03018277f, 0.31951591f, -0.20961486f, -0.21198793f, -0.10015285f, 0.02083102f, 0.00116359f, 0.03121482f, 
    0.19645509f, -0.01315552f, 0.07270139f, 0.14018624f, 0.56988209f, -0.03543836f, 0.15482670f, 0.31301883f, 
    0.06525172f, -0.07164156f, 0.08910934f, 0.03910338f, -0.00228304f, 0.10969951f, -0.00018937f, 0.06488867f, 
    0.28638884f, -0.51884758f, 0.09086210f, 0.18825793f, 0.17248414f, 0.14090186f, -0.40354419f, 0.01374026f, 
    0.16649184f, 0.01757607f, -0.29190397f, -0.09955250f, -0.68393934f, 0.03536106f, -0.23981878f, 0.03498808f, 
    -0.08834589f, 0.03226657f, -0.29183024f, -0.09338827f, -0.16704656f, 0.09790656f, -0.08237442f, 0.02218902f, 
    0.53163487f, -0.15749729f, -0.06711376f, -0.15032387f, -0.27084079f, -0.04296332f, -0.08408486f, -0.02684237f, 
    0.19792807f, 0.09008396f, -0.05378158f, -0.31767672f, 0.37937492f, -0.07233315f, 0.13468795f, 0.06778934f, 
    0.09596545f, -0.06177795f, 0.07908528f, 0.14248399f, -0.22738186f, -0.04080970f, 0.06241229f, -0.24819584f, 
    0.52552646f, -0.37108511f, 0.03410319f, 0.06571957f, -0.27093881f, -0.13975792f, -0.07227557f, 0.05251794f, 
    -0.28715059f, 0.09906696f, 0.10117253f, -0.18071887f, 0.03837127f, -0.07156312f, 0.23569223f, -0.08450513f, 
    0.15899934f, 0.09979947f, 0.05797320f, -0.17434660f, 0.02537312f, 0.10314412f, -0.15257673f, 0.18811713f, 
    0.43423492f, -0.13119525f, 0.11424358f, -0.10076664f, -0.24787840f, -0.25675586f, 0.14432405f, 0.04397340f, 
    -0.16022389f, 0.05949036f, 0.07329065f, -0.19803822f, -0.72071534f, -0.26900798f, -0.45032522f, -0.60233641f, 
    0.00013445f, -0.09937510f, 0.23342831f, -0.23948759f, -0.05173868f, 0.34093443f, 0.06047536f, -0.14141461f, 
    -0.42681053f, 0.13609412f, -0.24580820f, 0.13977665f, -0.09054635f, 0.24188457f, -0.25183946f, -0.29859352f, 
    -0.13320164f, -0.17404731f, 0.01183428f, -0.09392834f, 0.31997082f, 0.36256582f, 0.24913946f, 0.37894857f, 
    -0.26569185f, -0.31045118f, 0.20658328f, 0.18823664f, -0.12925576f, 0.02472889f, 0.10514524f, 0.09608773f, 
    -0.09531781f, -0.04829350f, -0.08725230f, 0.15959233f, 0.13086279f, 0.10684188f, 0.02862716f, -0.13047309f, 
    0.08361650f, -0.01088917f, -0.00247547f, 0.00368588f, 0.89065152f, -0.07315125f, 0.53196454f, 0.09319340f, 
    -0.07538190f, -0.01577893f, 0.00834703f, 0.02676702f, 0.02083552f, -0.05725282f, 0.16282417f, 0.08567728f, 
    -0.69005597f, 0.08075913f, 0.16840327f, -0.01229654f, -0.03365957f, -0.32442379f, -0.02710782f, -0.16351382f, 
    -0.04691660f, -0.21505223f, -0.10305101f, -0.12206277f, 0.66396731f, 0.05773187f, -0.21707869f, 0.12506188f, 
    0.17105600f, -0.03807723f, 0.02594303f, -0.11262218f, -0.17916411f, -0.02601789f, -0.17801434f, -0.14372595f, 
    0.08050191f, 0.20784937f, -0.41140673f, -0.46842384f, -0.08576224f, -0.03732067f, -0.08858001f, -0.12027322f, 
    0.00385315f, -0.27900174f, -0.09328141f, -0.17076729f, 0.04246220f, 0.07670368f, -0.10749511f, 0.01356894f, 
    0.08094387f, -0.01794761f, 0.02864027f, -0.00541437f, -0.24482876f, 0.08022913f, 0.12016813f, 0.08742783f, 
    0.22094648f, -0.20578830f, -0.15191680f, -0.37171355f, 0.14828996f, 0.01629865f, -0.15129519f, 0.14574140f, 
    -0.04876562f, 0.14001001f, -0.00127264f, -0.24384944f, 0.16370393f, 0.09883696f, -0.65301746f, 0.09070767f, 
    0.05636831f, -0.04062704f, 0.16863050f, 0.04284920f, -0.07668331f, -0.00523270f, 0.01116402f, -0.04483619f, 
    0.04027564f, 0.02042998f, 0.06168310f, -0.25283858f, -0.03925301f, -0.24124314f, -0.01973752f, 0.08855979f, 
    0.00747316f, -0.04433563f, 0.12130778f, 0.02387793f, 0.05461896f, 0.41791019f, 0.35464346f, -0.37187302f, 
    -0.21328281f, 0.00259929f, -0.08882551f, 0.14085199f, -0.06546476f, -0.19026028f, -0.08199976f, 0.15639579f, 
    0.20346473f, 0.20437419f, -0.15078716f, 0.00947441f, -0.07184757f, -0.10082738f, -0.09461971f, -0.08232258f, 
    -0.07899161f, -0.29340780f, 0.11106753f, -0.05682617f, -0.56447172f, -0.42976633f, -0.42991242f, 0.38591233f, 
    -0.12161299f, 0.09472965f, -0.15617611f, -0.25461456f, 0.09637304f, -0.36073974f, 0.01401572f, 0.08365603f, 
    -0.02477897f, -0.58434319f, -0.67240274f, -0.12018144f, -0.00981249f, 0.05918068f, -0.03697820f, -0.00715948f, 
    0.01309092f, 0.15802380f, 0.06691115f, -0.07054213f, 0.59045780f, -0.10350486f, 0.07875881f, 0.14779504f, 
    -0.00566847f, -0.02182562f, 0.28897843f, 0.06629182f, 0.30625901f, 0.02164849f, -0.05340663f, -0.09893658f, 
    0.40039510f, 0.23173654f, -0.18861227f, 0.47115421f, 0.03142874f, 0.28935248f, 0.01722598f, -0.00758540f, 
    -0.01776612f, 0.09091749f, -0.08753965f, 0.03008019f, -0.19827284f, -0.13010241f, -0.21822254f, -0.11208230f, 
    -0.05095611f, 0.07459284f, -0.05737584f, 0.06083737f, -0.14384463f, 0.14117877f, 0.00145165f, 0.22405516f, 
    -0.78493786f, -0.63523734f, -0.34435779f, 0.32073447f, -0.13871077f, -0.19438662f, 0.03596187f, -0.06728929f, 
    0.06549034f, -0.19522759f, 0.08914759f, -0.04464785f, 0.38944641f, -0.00469508f, 0.07027837f, 0.10313102f, 
    -0.04139708f, -0.01297556f, 0.05789569f, -0.10692807f, -0.08563152f, 0.11123893f, -0.10333385f, 0.13991514f, 
    0.26761079f, -0.05673651f, -0.34134746f, 0.21894214f, -0.17507456f, -0.21073624f, 0.09418469f, 0.08037456f, 
    0.16366269f, -0.00010625f, -0.09544165f, -0.07981024f, -0.56272459f, 0.38655117f, 0.40864965f, 0.59456342f, 
    0.31176019f, 0.20416741f, 0.07864919f, -0.20474471f, -0.01898584f, -0.16015115f, -0.27216530f, -0.05308769f, 
    -0.65648246f, 0.59841728f, 0.15572810f, 0.00537138f, 0.03360943f, 0.03785915f, -0.07269262f, 0.02820120f, 
    0.05039619f, 0.08760422f, 0.12371824f, 0.02374565f, -0.85143340f, -0.37363812f, -0.14703295f, -0.40849546f, 
    -0.21273862f, -0.05212266f, -0.05210797f, -0.07929973f, -0.01967384f, -0.14730382f, -0.07547896f, 0.05302276f, 
    0.08328837f, -0.47522411f, 0.00556035f, 0.10024125f, -0.17295718f, 0.03163657f, 0.26078096f, -0.01407615f, 
    -0.04011906f, -0.09202547f, 0.34099433f, -0.00148475f, -0.40037483f, 0.51538122f, 0.26617581f, 0.04450633f, 
    0.15429014f, -0.16981402f, 0.16819526f, -0.07360010f, -0.14679034f, -0.18748087f, 0.09977550f, -0.25965038f, 
    0.03075861f, 0.47142303f, -0.48902026f, -0.78302968f, 0.12514931f, -0.02336784f, 0.10439854f, 0.00789098f, 
    -0.12956238f, -0.04391663f, 0.01884013f, 0.12714341f, -0.19116765f, -0.20600463f, 0.02258334f, -0.01064707f, 
    0.00413036f, -0.03462661f, -0.00688225f, -0.09545969f, 0.01875290f, -0.04258294f, -0.14770715f, 0.02777082f, 
    0.25849172f, 0.08968522f, -0.16691037f, 0.24801792f, -0.04027053f, 0.02654871f, 0.23160982f, 0.18724538f, 
    0.19126384f, 0.01404001f, 0.06136452f, -0.15362808f, 0.21725427f, -0.21646573f, -0.11340220f, 0.25382817f, 
    -0.00848557f, -0.07723198f, 0.02105995f, 0.05663826f, -0.00108088f, -0.08987284f, -0.06369614f, 0.09301379f, 
    -0.37764269f, 0.11940721f, 0.23894519f, -0.15901950f, -0.09054010f, 0.05531816f, -0.01510181f, -0.07231837f, 
    0.12646013f, -0.10813612f, 0.07990760f, 0.00713830f, 0.06786268f, 0.00105044f, 0.08796822f, 0.26643789f, 
    -0.25430247f, -0.07763597f, 0.03496748f, -0.31908816f, 0.12805390f, 0.07317499f, 0.07833834f, -0.00660849f, 
    0.11716548f, 0.10123871f, 0.08105229f, 0.12648550f, -0.12465552f, 0.18724051f, -0.16112264f, -0.18498789f, 
    -0.01418129f, -0.15676761f, 0.15844597f, 0.10099908f, -0.91563892f, -0.01569029f, 0.41978997f, 0.28109914f, 
    -0.09358637f, 0.09295062f, 0.12692076f, 0.14602160f, -0.16895415f, 0.11677693f, 0.17949653f, -0.02152176f, 
    -0.14997309f, -0.06511106f, 0.14095473f, 0.12981053f, -0.12659183f, -0.13642296f, 0.08172107f, 0.05246084f, 
    0.10135657f, -0.01078863f, 0.02320304f, -0.33801675f, -1.23338640f, 0.50306386f, -0.01221431f, -0.11995730f, 
    -0.07614852f, -0.02472418f, 0.05185690f, -0.04180380f, -0.08567390f, -0.14949721f, -0.07294809f, 0.10890970f, 
    0.05058483f, 0.32710364f, -0.27168921f, 0.26396611f, 0.11660021f, 0.03700958f, 0.14506887f, 0.19552334f, 
    -0.10271952f, 0.03653874f, 0.07450976f, 0.07692108f, -0.64105988f, -0.12124480f, 0.41177082f, -0.05870169f, 
    0.10360703f, -0.11559249f, -0.11844938f, -0.11909768f, 0.26641458f, -0.03679257f, -0.08668776f, -0.16312256f, 
    -0.73592585f, -0.13778019f, 0.44351122f, -0.03919867f, -0.07266718f, -0.14823394f, 0.07759483f, -0.16160288f, 
    0.08685645f, 0.04499647f, 0.01262912f, -0.14522098f, 0.09703007f, -0.04054330f, -0.20593736f, 0.33754671f, 
    -0.09921498f, -0.05379756f, 0.17675053f, 0.06106054f, 0.04716786f, -0.01369498f, -0.01385796f, 0.03353191f, 
    0.55025280f, 0.37204915f, -0.23189506f, -0.05286650f, -0.04069590f, -0.05571198f, 0.21292000f, 0.16228002f, 
    -0.27078980f, -0.08127268f, 0.26519060f, 0.23081167f, -0.13951750f, -0.34714997f, 0.01693415f, -0.06279468f, 
    0.03188939f, -0.02909395f, 0.02141128f, -0.06455269f, -0.18213297f, -0.00175590f, -0.23515519f, -0.16097899f, 
    -1.06733620f, -0.37304169f, 0.24202365f, 0.13789247f, 0.08387844f, -0.12325164f, 0.07406922f, -0.13746183f, 
    0.11699644f, 0.07058915f, -0.07001948f, 0.13525550f, -0.23022044f, -0.11524876f, -0.01436851f, -0.03004860f, 
    0.06400521f, 0.17664355f, 0.00620891f, -0.45341685f, 0.02580601f, -0.00126242f, 0.01994369f, -0.04099639f, 
    -0.69975531f, -0.13712870f, -0.24658757f, 0.13312048f, -0.01160197f, 0.04130686f, -0.01915756f, -0.12296800f, 
    -0.15274906f, 0.04243756f, -0.17886463f, 0.49130514f, 0.01530077f, 0.02952939f, 0.43405333f, -0.25301111f, 
    0.12741841f, -0.05621267f, 0.02324098f, 0.02166901f, 0.10315740f, 0.07480918f, 0.02437121f, 0.07107043f, 
    0.30330896f, 0.16652413f, -0.14334504f, 0.00855401f, 0.18710278f, -0.06482922f, -0.15007654f, -0.09288152f, 
    -0.19088747f, 0.13904390f, -0.09407038f, -0.28065917f, 0.24263893f, 0.28820223f, 0.25224006f, 0.12559879f, 
    0.04761163f, -0.06150347f, 0.18631645f, 0.06412347f, -0.07053897f, -0.16287936f, 0.14248581f, -0.10448844f, 
    0.03125780f, -0.32604504f, 0.17279200f, 0.34259051f, 0.11170695f, -0.15474349f, 0.16215406f, 0.07847224f, 
    0.11885615f, 0.19575630f, -0.03336240f, 0.14514643f, -0.02150335f, -0.24747616f, -0.53849876f, -0.04976269f, 
    0.00290361f, 0.10974038f, -0.20734298f, -0.04645977f, 0.12424542f, -0.23427379f, -0.21848617f, 0.09406245f, 
    -0.02119249f, -0.03862322f, 0.07610025f, 0.00676229f, -0.05093814f, 0.34802696f, -0.07624946f, 0.01155212f, 
    -0.30483955f, 0.21989265f, 0.24152967f, 0.17703620f, -0.82130688f, 0.20980361f, -0.11620404f, -0.43018255f, 
    0.13258447f, 0.01247986f, -0.10651113f, 0.03405235f, 0.01260764f, -0.08617137f, 0.08906379f, -0.22979826f, 
    -0.63660949f, -0.36375800f, 0.10204180f, 0.15635538f, 0.20049062f, -0.05484368f, -0.13082208f, 0.01709185f, 
    0.13694882f, 0.13519245f, 0.07826614f, 0.12004098f, 0.30566075f, 0.03249329f, 0.12892906f, -0.10152186f, 
    0.13102151f, 0.06010195f, -0.08259069f, 0.02897620f, -0.21632943f, 0.05143395f, 0.17046309f, 0.29540688f, 
    -0.16410036f, -0.16307572f, -0.10519391f, 0.29420766f, -0.10566350f, -0.07835288f, -0.00244901f, 0.15522154f, 
    0.00730992f, 0.14306739f, -0.14504357f, -0.09535893f, 0.03359663f, 0.27109802f, 0.39648506f, -0.25466573f, 
    -0.03405165f, -0.01217676f, 0.00254062f, -0.19594572f, 0.07625969f, 0.01336071f, 0.07866127f, -0.07313948f, 
    -0.22782160f, 0.26316515f, 0.28409430f, -0.03167517f, -0.11319663f, -0.00695930f, -0.24438329f, -0.22949943f, 
    0.03617314f, -0.10158161f, -0.26088113f, -0.01605308f, 0.10187573f, -0.08688477f, -0.06324119f, -0.08369294f, 
    -0.26599559f, -0.12538075f, -0.05406410f, 0.30545872f, 0.09785940f, 0.19196564f, 0.09227552f, 0.06905297f, 
    0.47748879f, -0.77282542f, -0.00308063f, 0.03175626f, 0.05067460f, 0.17119138f, -0.07864213f, 0.04771027f, 
    0.09560649f, -0.04270039f, -0.11811050f, -0.18808776f, -0.05735253f, -0.11399380f, -0.15455721f, 0.44887567f, 
    0.05169478f, 0.22050524f, 0.07942416f, 0.01261918f, -0.14004733f, 0.27925012f, -0.13545190f, -0.10101636f, 
    -0.57159328f, 0.09859030f, -0.42955765f, -0.11422846f, 0.00983324f, -0.04935566f, -0.03968128f, -0.15777518f, 
    0.18934819f, 0.04123266f, 0.04895826f, -0.44299942f, -0.16523287f, 0.12471268f, 0.36761603f, -0.54328662f, 
    -0.36004174f, -0.07296182f, -0.05038524f, 0.13079548f, -0.01613411f, -0.13316359f, 0.01033295f, -0.03262584f, 
    -0.79926634f, 0.08633517f, -0.17419189f, 0.29250923f, -0.01133277f, 0.03510234f, 0.04454767f, -0.05227787f, 
    0.09115281f, 0.03834355f, 0.11689451f, 0.10142663f, -0.16796261f, -0.00678806f, -0.09427833f, 0.25072214f, 
    0.11738552f, 0.11309215f, 0.05715786f, -0.02927712f, -0.06212239f, 0.04986357f, -0.05662577f, 0.13916743f, 
    0.07999974f, -0.06500264f, -0.13042764f, -0.58388889f, -0.11621073f, -0.03751146f, -0.09419689f, -0.11074385f, 
    -0.34643787f, 0.08309173f, 0.10011431f, -0.07045139f, -0.37564561f, -0.27573907f, -0.39876020f, -0.17634626f, 
    -0.01494567f, 0.02625407f, -0.18721047f, -0.09844732f, 0.01625891f, -0.06257865f, 0.33531803f, 0.09592222f, 
    -0.11373069f, 0.51493335f, 0.25336161f, -0.49204046f, -0.02697186f, -0.04185447f, -0.04975603f, 0.05804777f, 
    0.23422813f, -0.17345314f, -0.13222960f, -0.18029954f, 0.67716664f, -0.61781526f, 0.21260054f, -0.11825643f, 
    -0.12634353f, -0.03250459f, 0.12246901f, 0.05131625f, 0.10793541f, 0.03585152f, 0.21233705f, 0.29680815f, 
    0.50568461f, -0.07178977f, -0.68521005f, 0.16727871f, -0.19304538f, -0.06272071f, -0.01946388f, -0.16663980f, 
    -0.07534277f, -0.10138565f, -0.09011548f, -0.01063756f, 0.44789377f, 0.16187423f, 0.00811049f, 0.02385081f, 
    0.05414172f, 0.07350320f, 0.03539198f, -0.00680549f, 0.09189205f, -0.03340905f, -0.03781988f, -0.10358278f, 
    -0.08294708f, -0.16951030f, 0.07245717f, -0.00938043f, 0.31941360f, 0.08735491f, 0.01363073f, 0.03835513f, 
    -0.23841175f, 0.08696763f, 0.08315463f, 0.12253606f, -0.59444016f, 0.15307955f, 0.42861277f, -0.23664969f, 
    -0.01703880f, -0.08864497f, 0.10278126f, 0.16272682f, -0.11989131f, 0.02670291f, -0.12028554f, 0.18822281f, 
    -0.17400800f, 0.06492471f, 0.00033064f, -0.21471205f, -0.23763585f, 0.06010364f, 0.10792135f, 0.07118312f, 
    0.09069568f, -0.01433057f, -0.02710223f, 0.11122072f, 0.29710472f, 0.00990556f, 0.10312755f, -0.02821071f, 
    0.14476041f, 0.24565685f, 0.23767197f, 0.02716580f, 0.17343181f, -0.06426352f, 0.02671995f, -0.16811077f, 
    0.26384264f, -0.10804027f, 0.08201700f, 0.00754847f, 0.28569517f, -0.04531602f, -0.09358673f, -0.06203740f, 
    -0.09780850f, -0.07232749f, 0.03900559f, -0.05205431f, -0.68068403f, 0.32210293f, -0.10860883f, 0.18903254f, 
    0.32341450f, -0.20182379f, -0.12383220f, 0.21392870f, -0.10108546f, 0.05877483f, 0.13088414f, -0.09038026f, 
    0.24274123f, 0.21666865f, 0.39385018f, 0.15664573f, 0.04471821f, 0.01641862f, 0.07011189f, -0.03435897f, 
    -0.01285415f, -0.09549854f, -0.03614518f, -0.28267235f, -0.40067124f, 0.40600687f, -0.29636869f, -0.33264899f, 
    0.03049726f, 0.03187259f, -0.03195098f, -0.14603098f, -0.18395442f, 0.11715280f, 0.04647515f, -0.15367968f, 
    -0.66532058f, -0.16642123f, -0.31453231f, -0.23763272f, -0.36470178f, 0.08622580f, 0.01413451f, -0.04744558f, 
    -0.13265370f, -0.14324504f, 0.08851357f, -0.00282999f, 0.11258584f, 0.37836394f, -0.00225221f, 0.35652855f, 
    -0.20554666f, 0.07213547f, -0.01161665f, 0.12329084f, -0.25447723f, 0.06851094f, 0.10271129f, -0.09895288f, 
    -0.25303304f, 0.07853395f, -0.14209294f, 0.27589968f, -0.06865138f, 0.10318854f, -0.09797598f, -0.08146041f, 
    -0.11112559f, -0.14884165f, 0.04752799f, -0.22313902f, 0.40305939f, 0.36292168f, 0.42071214f, 0.27801952f, 
    0.23702633f, 0.20940281f, 0.29297388f, -0.07462053f, -0.08185415f, -0.00017076f, -0.16921750f, -0.19583298f, 
    -0.77464962f, -0.24819906f, -0.22933961f, -0.30366227f, 0.06315678f, -0.07072748f, -0.01205301f, -0.02663306f, 
    -0.11020113f, -0.00916021f, -0.02739855f, 0.10384616f, 0.24818954f, -0.01818379f, 0.18431360f, -0.31966051f, 
    -0.30490118f, 0.20320059f, -0.02278915f, 0.06235974f, -0.09889203f, 0.10938699f, -0.26693836f, 0.12548976f, 
    0.16929016f, 0.37718984f, 0.17753875f, 0.35545656f, 0.17784241f, -0.14319292f, -0.19733576f, 0.10348330f, 
    -0.13348114f, -0.06220216f, -0.09618741f, -0.22612369f, 0.11956885f, -0.56475741f, 0.10911157f, 0.02536322f, 
    -0.16214493f, -0.13406439f, -0.02793537f, 0.06450108f, 0.14021148f, -0.03244391f, -0.10474154f, -0.00270572f, 
    0.46191350f, -1.00140131f, 0.08495148f, 0.26076600f, -0.13565679f, -0.00428330f, -0.04872760f, -0.06990533f, 
    -0.08437322f, -0.11352616f, 0.13524491f, -0.01173228f, -0.11112761f, 0.05591831f, -0.16478963f, 0.03073818f, 
    -0.00774103f, 0.17536277f, -0.15486385f, -0.15010433f, 0.06710173f, 0.00348677f, 0.02653822f, -0.32779706f, 
    -0.16301428f, 0.45794028f, 0.09991600f, -0.18029290f, -0.34099314f, 0.03140769f, -0.04613425f, -0.16537400f, 
    -0.01812989f, -0.05399410f, -0.22321661f, -0.02058204f, 0.51122904f, -0.50913352f, -0.15502052f, 0.05393351f, 
    0.15252872f, -0.19015156f, 0.06152002f, -0.19290496f, 0.27991816f, -0.16404974f, 0.01619940f, -0.14390279f, 
    -0.03330125f, -0.33965772f, 0.02056352f, -0.05951291f, -0.21833724f, -0.14265743f, 0.05867786f, -0.20568386f, 
    -0.27196792f, -0.00295640f, 0.01713356f, 0.02524360f, 0.00279957f, 0.55498344f, -0.48591614f, 0.24576043f, 
    -0.07274569f, 0.15151514f, -0.32315558f, 0.03275602f, -0.18351500f, -0.08894961f, 0.18107350f, 0.00376221f, 
    -0.43926278f, -0.16270612f, 0.19470637f, -0.18527982f, 0.02646633f, -0.04143345f, -0.06872791f, -0.11575462f, 
    -0.09072470f, 0.01403595f, -0.18573128f, 0.27357844f, 0.17368440f, -0.10071367f, 0.05016651f, 0.39377847f, 
    0.17116304f, 0.13797870f, -0.10609442f, -0.06282271f, 0.03586092f, 0.08458720f, -0.05793115f, -0.13549775f, 
    0.25943029f, 0.09320444f, -0.15518512f, 0.02566225f, 0.19258867f, -0.17922303f, -0.23940399f, -0.06546339f, 
    -0.09533520f, 0.21927306f, -0.41436735f, 0.08493420f, -0.30673087f, -0.11936416f, -0.44921610f, -0.31658667f, 
    -0.03107010f, -0.06803349f, -0.29999423f, 0.13479327f, 0.27951962f, -0.05983530f, -0.00703442f, -0.25807974f, 
    -0.26307589f, -0.21999538f, -0.01294487f, -0.24568911f, 0.10028421f, -0.27322069f, 0.01466003f, 0.35268974f, 
    -0.02802821f, 0.39783129f, -0.05880809f, 0.05189988f, -0.32794288f, 0.25042209f, 0.00299136f, 0.09603813f, 
    -0.23448558f, -0.12436909f, -0.23808309f, -0.11275470f, -0.10464142f, -0.09123369f, -0.21117257f, -0.02110239f, 
    -0.05933613f, -0.24512249f, -0.02034454f, 0.40204227f, 0.22907558f, 0.09019487f, -0.05256201f, -0.00056635f, 
    -0.19319285f, 0.14665958f, 0.27793026f, 0.07313026f, -0.04707712f, -0.06388786f, 0.13227834f, 0.06116030f, 
    -0.01865629f, 0.03515206f, -0.09616827f, 0.13852109f, 0.10784713f, -0.04804449f, -0.08524544f, -0.07220262f, 
    -0.15082169f, 0.76371461f, -0.05104791f, -0.28116962f, 0.26919505f, -0.19872583f, -0.27612114f, -0.08347233f, 
    0.06012676f, -0.21742116f, -0.11201637f, 0.21136570f, -0.23439328f, -0.33210531f, -0.42098755f, -0.07768689f, 
    -0.06705169f, -0.06235103f, -0.12473121f, -0.08931179f, 0.03577441f, 0.16468109f, 0.12128136f, 0.12454210f, 
    0.20675412f, -0.25809515f, -0.71315020f, 0.12761411f, 0.19758388f, -0.12269270f, 0.03453140f, -0.17004271f, 
    0.12716344f, 0.04601579f, -0.17169195f, 0.01425463f, 0.56839645f, -0.01377637f, 0.06227517f, 0.23390348f, 
    0.24654725f, -0.13036138f, 0.04276740f, -0.08268453f, 0.06734047f, 0.21131542f, 0.03511804f, -0.22185132f, 
    0.10306995f, -0.03501561f, 0.16086638f, 0.26091433f, -0.09802092f, -0.08611153f, 0.01160544f, -0.08003958f, 
    -0.03494221f, 0.09349669f, -0.00524583f, -0.15214907f, -0.03695763f, -0.51410508f, 0.25066581f, -0.13878362f, 
    0.13838159f, -0.04577097f, 0.03916077f, 0.04223614f, 0.22727105f, 0.16522299f, -0.02387687f, 0.24184527f, 
    0.71141917f, 0.31380227f, -0.14368989f, 0.25607598f, 0.26368725f, -0.21019456f, 0.09397323f, 0.27811256f, 
    -0.01627168f, -0.11637051f, -0.03045836f, 0.18865018f, 0.20220186f, -0.38930428f, 0.58970338f, 0.03374179f, 
    -0.18587032f, -0.20987445f, 0.13826226f, 0.13690898f, -0.14784156f, 0.04528471f, 0.08492060f, 0.05057292f, 
    0.07136085f, -0.38522372f, 0.34756941f, -0.04234799f, 0.02958676f, -0.13216330f, 0.13606326f, 0.07859441f, 
    -0.07131521f, -0.01394455f, 0.10020921f, -0.09399535f, -0.62510407f, 0.77803183f, -0.86039746f, -0.31670401f, 
    0.13650142f, 0.16009656f, -0.07038385f, 0.04018339f, -0.10184242f, -0.13119708f, -0.05399260f, -0.17219591f, 
    0.04085001f, 0.45185322f, 0.39830410f, 0.00951293f, -0.03317015f, 0.09043784f, 0.13661273f, -0.07711513f, 
    0.15164331f, -0.12793951f, 0.20032421f, 0.01787189f, -0.77899343f, 0.30757713f, 0.35621271f, -0.22784325f, 
    -0.00229450f, 0.23541881f, 0.20707275f, -0.33096099f, -0.12342125f, -0.23851797f, -0.06318735f, 0.09068988f, 
    0.23864625f, 0.20159027f, 0.13287401f, -0.48199403f, -0.10888705f, -0.12978671f, 0.05128184f, -0.08488595f, 
    0.00812480f, 0.06390234f, -0.14290951f, -0.13429545f, -0.13969545f, -0.66471571f, -0.13350466f, 0.18679705f, 
    0.23289905f, 0.04944836f, 0.12633072f, 0.15206689f, -0.13876365f, 0.22924182f, 0.14235879f, -0.10853341f, 
    -0.14058107f, -0.05899789f, 0.02523831f, -0.14687863f, 0.09393434f, -0.01203585f, -0.21744201f, -0.09237516f, 
    -0.02533985f, -0.03784512f, -0.18367277f, -0.39031294f, -0.32884616f, -0.32121295f, -0.10122187f, 0.04335852f, 
    0.03244710f, 0.04040841f, -0.07923242f, -0.22540681f, 0.18660873f, 0.37372208f, -0.11779024f, -0.11609287f, 
    -0.65101230f, -0.19926488f, 0.53175646f, -0.00471794f, -0.05583333f, 0.21739197f, -0.12122594f, 0.21400362f, 
    0.03231201f, -0.11200956f, -0.04791835f, -0.08377481f, -0.46816060f, 0.37164861f, -0.20890634f, -0.77144307f, 
    0.08890512f, -0.10922439f, 0.12779349f, -0.04002357f, 0.01274608f, -0.00992215f, -0.07459853f, -0.02305054f, 
    0.26093879f, -0.42918634f, 0.15861049f, -0.09049886f, 0.03814679f, 0.08556450f, -0.11809161f, 0.02896915f, 
    -0.14999957f, -0.12144037f, 0.02118352f, 0.16437933f, -0.18323985f, -0.18598044f, -0.00533781f, 0.15422678f, 
    0.13984445f, 0.16774502f, -0.04026636f, -0.10497094f, 0.06311895f, -0.14263478f, -0.02375034f, 0.08055059f, 
    -0.64465564f, 0.44657484f, -0.28864425f, -0.32184336f, 0.19291306f, -0.15120316f, -0.00011420f, 0.07482360f, 
    0.00259086f, 0.18217549f, 0.14307244f, 0.08615966f, 0.11967465f, -0.05559518f, 0.14865042f, -0.09069168f, 
    -0.00852395f, 0.01452259f, 0.02791241f, -0.14329743f, 0.03170959f, -0.01403375f, 0.00448877f, -0.08904455f, 
    0.17746374f, 0.26788622f, -0.08723606f, 0.12135426f, -0.15446721f, 0.13353570f, 0.13921177f, -0.06907152f, 
    0.04530569f, 0.04183283f, 0.03060611f, -0.02109600f, -0.21778537f, -0.09017224f, -0.35344589f, 0.36458084f, 
    -0.03957051f, 0.01578543f, -0.10280082f, -0.07254457f, 0.18486734f, 0.08278677f, 0.17895919f, 0.01457699f, 
    -0.09802184f, 0.24799807f, 0.16216537f, -0.12844573f, 0.33750096f, 0.13044032f, -0.00437476f, 0.12443785f, 
    0.10196450f, 0.08950973f, 0.01262190f, 0.31200647f, -0.95437849f, -0.38639161f, -0.32773110f, -0.40587059f, 
    0.21314932f, -0.17189360f, 0.06184535f, 0.19698922f, 0.07437216f, 0.01143269f, 0.16028020f, 0.12348736f, 
    -0.95796275f, -0.47752559f, 0.16946545f, -0.17038964f, 0.20089926f, 0.06747173f, 0.09665778f, -0.03077220f, 
    0.23424973f, -0.01832625f, -0.12784430f, 0.16398865f, -0.41099539f, -0.57136768f, 0.35305625f, 0.04354220f, 
    0.22112212f, 0.00310355f, -0.11847939f, -0.00191862f, 0.16974738f, 0.11016147f, 0.07644102f, 0.10207232f, 
    -0.11928930f, 0.21994899f, 0.15679359f, -0.28237113f, 0.20044515f, -0.07412902f, 0.15871882f, 0.31352958f, 
    0.07844523f, 0.19425842f, 0.24161339f, 0.09443300f, 0.52141726f, 0.09604285f, -0.08715536f, -0.18677674f, 
    -0.28236204f, 0.11677212f, 0.05347043f, -0.10156505f, 0.14985183f, -0.25339776f, -0.12639785f, -0.26783973f, 
    -1.11955369f, -0.23208983f, -0.25219971f, -0.27098107f, 0.16233876f, 0.02111195f, -0.29658693f, -0.02803871f, 
    0.11839187f, 0.07459366f, 0.01262792f, 0.18639396f, 0.43739593f, 0.01848356f, -0.19506827f, 0.10233944f, 
    -0.06163293f, -0.10464478f, -0.05409653f, 0.10410311f, -0.10455433f, -0.01096222f, -0.14076470f, -0.11499824f, 
    -0.04138909f, -0.14678170f, 0.16794786f, -0.37331462f, -0.04334912f, 0.04351701f, 0.15322262f, -0.14759834f, 
    -0.09344044f, 0.14791742f, 0.13203840f, 0.17765620f, 0.29937366f, 0.11150779f, -0.01627875f, -0.20414618f, 
    -0.23079313f, 0.00728918f, -0.15621798f, 0.28840718f, 0.01283834f, 0.04879604f, 0.21076614f, 0.17902239f, 
    -0.87120122f, -0.12488419f, -0.07232949f, 0.04388900f, 0.03904870f, 0.23486559f, 0.03160943f, 0.09386270f, 
    0.04599464f, -0.14915371f, -0.20984431f, -0.01860850f, -0.34052777f, -0.41224793f, -0.29893601f, -0.17816405f, 
    -0.01991680f, -0.02555860f, -0.03350464f, -0.03106178f, 0.01125241f, 0.03719231f, 0.20856321f, -0.01706867f, 
    -0.83798134f, -0.27297622f, -0.13455191f, -0.26526582f, 0.00528072f, -0.21106246f, -0.15707427f, -0.08916984f, 
    0.33113986f, -0.18998833f, -0.22368446f, -0.03065080f, -0.28055662f, 0.50481433f, 0.21108574f, -0.01864471f, 
    0.11611044f, 0.22608723f, -0.08206502f, 0.11229014f, -0.22781798f, 0.17701882f, 0.06000955f, 0.24762565f, 
    -0.48797974f, -0.17625991f, 0.24329346f, -0.04905844f, -0.15921013f, -0.06378338f, -0.17185116f, 0.02306369f, 
    -0.08022443f, 0.16187391f, 0.08122376f, 0.13286179f, 0.08053771f, -0.05143869f, -0.02838324f, 0.17166206f, 
    -0.22919796f, -0.06308435f, -0.00093924f, 0.25798452f, -0.03187522f, 0.10316094f, -0.06945176f, -0.04758817f, 
    0.07518579f, 0.26287064f, 0.27412790f, -0.06011496f, -0.19407561f, -0.13937345f, 0.13999136f, -0.12457536f, 
    0.07899088f, 0.08154843f, -0.07102653f, -0.38092953f, 0.15380654f, -0.04097926f, -0.28194547f, -0.01802610f, 
    0.05686457f, 0.05050184f, 0.04997497f, -0.06436479f, 0.09661157f, -0.02242599f, -0.03016653f, -0.07024592f, 
    0.28598785f, -0.20132744f, 0.08125987f, -0.09745167f, 0.09500057f, 0.23488215f, -0.08439917f, 0.06839813f, 
    0.03473239f, -0.16180362f, 0.14426710f, 0.24683271f, 0.22586222f, 0.42192566f, -0.43983039f, 0.10990432f, 
    0.10258131f, 0.08891220f, -0.20886669f, -0.14395945f, 0.02670461f, 0.15874910f, -0.06420441f, -0.10082323f, 
    0.16145591f, -0.12157042f, -0.00916189f, -0.00671957f, -0.19585608f, -0.00181334f, -0.05295057f, 0.12554041f, 
    0.05907964f, -0.12537244f, 0.17378022f, -0.22533140f, -0.30721170f, 0.12909502f, -0.20171440f, 0.16077593f, 
    -0.06369007f, -0.19639984f, 0.11352314f, -0.04493630f, -0.11139982f, 0.01038825f, 0.05075585f, -0.14830285f, 
    0.56951278f, 0.25962642f, -0.24467602f, -0.22506310f, 0.13953184f, -0.19397742f, 0.04810421f, 0.07181081f, 
    -0.09208879f, -0.07733729f, -0.00561007f, 0.00987088f, -0.21893622f, -0.04110949f, -0.13698295f, 0.23594762f, 
    0.40855342f, 0.04359651f, 0.22154722f, 0.03735369f, 0.05808803f, -0.25849140f, 0.10802778f, 0.01844813f, 
    0.35042468f, -0.70349920f, -0.18140534f, 0.07738335f, 0.06753301f, 0.14763880f, -0.04900012f, -0.21132974f, 
    -0.05204874f, 0.08781001f, -0.00889053f, -0.07007679f, -0.19382265f, 0.06476218f, -0.45821592f, 0.11956485f, 
    0.02434156f, -0.06383442f, 0.01197999f, 0.12709512f, -0.00140279f, -0.04539092f, -0.05684585f, 0.01675423f, 
    0.98731625f, 0.11588573f, -0.16273935f, 0.21391863f, -0.02929289f, -0.16051231f, -0.07437026f, 0.01264514f, 
    0.03866767f, 0.03615424f, 0.16832288f, -0.10019457f, -0.98652184f, 0.03916515f, -0.36489007f, -0.55265850f, 
    -0.01782628f, 0.02189209f, -0.09575273f, 0.43212512f, 0.07478326f, -0.21703185f, -0.19646208f, -0.29281875f, 
    -0.31992939f, -0.69551098f, 0.33758819f, -0.32292035f, 0.25413254f, -0.01678879f, 0.13368735f, -0.14320835f, 
    -0.09794606f, 0.12925816f, 0.12022321f, 0.16111712f, -0.01723756f, 0.03346370f, 0.11308414f, -0.19428961f, 
    0.04906161f, 0.04122181f, 0.03399312f, -0.09324356f, 0.02167840f, -0.24325085f, -0.15729979f, 0.04402170f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.15872662f, 0.12449837f, -0.13906303f, 0.08124443f, 0.09715828f, 0.08212280f, -0.03734168f, -0.14652936f, 
    -0.08919480f, 0.00482611f, 0.21283416f, -0.01344587f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
