#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.28156981f, 1.04167449f, -0.80065823f, -0.48913658f, -0.79474711f, -0.64800054f, -0.21589884f, 0.16578840f, 
    0.87878597f, -0.80776614f, -0.98887092f, -0.76190478f, 0.54537100f, 0.44878796f, 0.68780440f, 0.52009934f, 
    -0.03699487f, 0.42479968f, -0.01287384f, 0.36912397f, 0.25316900f, 1.17046773f, -0.89363658f, -1.05380619f, 
    0.03051837f, 0.15072967f, 0.19922647f, 0.41716886f, -0.60218263f, 0.53181440f, -0.28932083f, 0.17633392f, 
    0.18159182f, 0.28624439f, 0.26924008f, -0.53532463f, 1.01501286f, 0.78743958f, 0.82899892f, -0.30800602f, 
    -0.56321907f, -0.42347389f, 0.39894530f, -0.20904000f, -0.32457405f, -0.71960115f, -0.87240452f, -0.83848304f, 
    0.54462314f, -0.27001956f, -0.45861277f, 0.25495076f, 0.12925696f, 0.76458102f, -0.62074631f, 1.04709184f, 
    0.66385764f, -0.09258831f, -0.30273905f, -0.11062066f, -0.51516110f, 0.00032420f, -0.18396172f, -0.66334391f, 
    0.17914660f, 0.05409323f, -0.43561125f, 0.32948452f, 0.79209286f, -0.70154113f, -0.44582528f, 1.08345699f, 
    0.40623075f, -0.45228767f, 0.30849987f, 0.56425691f, 0.15557320f, 0.17366971f, -0.21202162f, -0.92006737f, 
    -0.72630525f, -0.02395248f, -0.67990458f, 0.75002623f, 0.12327562f, -0.33560011f, 0.03722897f, 0.55672526f, 
    0.02931292f, 0.42710462f, 0.53702068f, 0.10257044f, -0.67185682f, -0.10487263f, 0.14442405f, -0.55616796f, 
    0.34058654f, 0.52303582f, 0.79977596f, 0.95601368f, 0.86322558f, -0.89290869f, -0.05321634f, -0.16390221f, 
    -0.02212092f, 0.02303995f, -0.05843336f, -0.22015886f, -0.27080891f, 0.58192092f, -0.98756933f, -0.43306980f, 
    -0.62372041f, -0.79212713f, -0.61796248f, -0.71560955f, -0.50759906f, 0.95546114f, 0.71401989f, 0.22026446f, 
    0.63852990f, 0.14828536f, 0.07177997f, 0.36766070f, -0.15759100f, 0.02538464f, -0.32185429f, 0.65019011f, 
    -0.39443010f, 0.11286230f, -0.33183864f, 0.35460222f, 0.67369580f, -0.51096845f, -0.34846884f, -0.29729611f, 
    -1.38527369f, -0.68618143f, 0.11070737f, 0.40339923f, 0.89557678f, 0.20396693f, -0.01163221f, -0.41988942f, 
    0.86893004f, 0.13645671f, 0.58991683f, -0.11454251f, 0.55307162f, -0.25939286f, 0.15417542f, 0.53070891f, 
    0.13001499f, 0.52156723f, -0.48311174f, 0.52696443f, 0.13538286f, 0.43316942f, -0.33284414f, 0.56786734f, 
    -0.26773146f, -0.15455383f, 0.44274580f, -0.31887391f, 1.29397488f, 0.18008769f, -0.90736622f, 0.79552418f, 
    -0.29782984f, -0.35194165f, 0.25133920f, -0.77746266f, -0.78098834f, -0.26959211f, -0.68504322f, -0.77046341f, 
    -0.24520333f, -0.51623946f, -0.63275307f, 0.81004238f, -0.97373819f, -0.67792535f, -0.18279065f, -0.14891638f, 
    0.17652701f, -1.36618233f, 0.23904870f, 0.00976880f, 0.25131950f, 0.86871260f, -0.85993707f, -1.22615671f, 
    -0.50323474f, -0.51634115f, -0.07374506f, -0.22682123f, -0.40200421f, -0.08340718f, -0.10327817f, 0.16175683f, 
    0.33589691f, -0.51162112f, 0.11618424f, -0.10422629f, -0.15627360f, 1.13260937f, -0.89961445f, 0.36641371f, 
    0.07299897f, -0.13154899f, -0.82419306f, 0.63062370f, 0.31427455f, 0.84100109f, -0.83634692f, -0.30955091f, 
    0.33118376f, 0.83519161f, 0.51903647f, -0.81265628f, -0.64773315f, -0.18820083f, -0.26991719f, -0.66179192f, 
    -0.62020004f, 0.19586159f, -0.15127854f, 0.47590432f, 0.50562543f, 0.62953967f, -0.34872374f, -0.39888987f, 
    -0.47455341f, 0.07450294f, 0.41182020f, 0.42275259f, -0.26238856f, 0.81750792f, 0.77173984f, 0.83817285f, 
    0.30398011f, 0.07152977f, 0.11135033f, 1.02859700f, -0.14830846f, -0.56107622f, 0.34237573f, -0.34380174f, 
    0.77516466f, -0.68648207f, -0.05947862f, 0.43395591f, -0.72410798f, 0.60696518f, 0.76799095f, -0.13482080f, 
    0.47033751f, -0.40613720f, -0.66929179f, 0.06654160f, -0.17282166f, -1.17077243f, -0.72036982f, -0.73657387f, 
    0.64067292f, 0.66028422f, 0.34679398f, -0.66085541f, -0.44329685f, -0.52189612f, -0.62096494f, -0.93642604f, 
    0.93786353f, 1.04147696f, -0.11027117f, -0.65653878f, 0.14510527f, -0.62310636f, -0.82337701f, -0.81480044f, 
    1.22708106f, -0.70991880f, -0.07924183f, 1.03766143f, -0.09606218f, 0.06687855f, -0.03571285f, 0.04021621f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.19919001f, 0.42936471f, 0.16027981f, 0.33686307f, -0.03273675f, -0.04290663f, -0.06665142f, 0.39770603f, 
    0.03320196f, 0.32126290f, 0.16482779f, 0.33013481f, -0.00360611f, 0.12850501f, 0.66282070f, 0.64768291f, 
    0.24674383f, 0.22720252f, -0.01408943f, -0.24695262f, 0.22263262f, 0.48953456f, 0.20705761f, -0.18595169f, 
    -0.38051248f, 0.37929872f, 0.28685895f, -0.09759815f, 0.19587009f, -0.05833351f, -0.12448527f, 0.46062559f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.21860278f, 0.22060573f, -0.55445790f, 0.02558841f, 0.26487535f, -0.09706527f, 0.02305198f, 0.02162278f, 
    -0.13817203f, 0.34644550f, 0.30055055f, 0.25885063f, -0.02690232f, -0.42646888f, -0.37428045f, 0.01266363f, 
    0.01676460f, 0.09733701f, -0.68085599f, -0.18922822f, 0.04860931f, -0.15235586f, -0.03055381f, -0.15772502f, 
    0.13755962f, -0.17055225f, -0.05571437f, -0.19179828f, -0.04804368f, -0.06144274f, -0.19435634f, 0.16943820f, 
    0.02140084f, -0.15308936f, 0.20419416f, -0.19456160f, 0.10262117f, -0.31053996f, -0.12519966f, 0.11647814f, 
    0.18096913f, -0.02747975f, -0.02281717f, 0.03854480f, -0.14695713f, 0.07936350f, 0.44345728f, -0.08454816f, 
    0.07187346f, -0.05217501f, -0.16854487f, 0.08174682f, 0.10026059f, 0.14453006f, -0.15845492f, -0.37117925f, 
    -0.04303788f, 0.05938716f, 0.14807327f, -0.21763134f, -0.06690627f, -0.03735431f, 0.09442995f, 0.04086636f, 
    -0.06970490f, 0.12233980f, -0.13172601f, -0.04667094f, -0.10999411f, 0.13657941f, 0.07806568f, 0.11476085f, 
    -0.07326417f, -0.02838553f, -0.14805396f, 0.02896939f, -0.07157270f, 0.00570995f, -0.12956847f, 0.00775751f, 
    0.26294485f, -0.13089488f, 0.05272653f, -0.20428467f, -0.08937672f, 0.35699984f, -0.12911557f, 0.13975884f, 
    -0.05154391f, 0.10065334f, 0.21688291f, 0.15789147f, -0.15809123f, -0.06571221f, -0.05575765f, 0.06746589f, 
    0.20020244f, 0.20321453f, 0.22307089f, 0.18122458f, -0.34995335f, -0.70790654f, 0.06448721f, 0.07662148f, 
    0.03412219f, -0.03189084f, -0.07122372f, 0.04772609f, 0.33087260f, 0.28205079f, 0.10625974f, 0.02405418f, 
    0.09328775f, -0.01402855f, 0.13815452f, 0.02148607f, 0.06139440f, 0.06656368f, 0.03378268f, 0.04870854f, 
    0.04473230f, -0.02153196f, -0.00947397f, 0.09464861f, -0.05435081f, -0.04714784f, -0.06736284f, 0.26592061f, 
    0.06804039f, 0.08600673f, 0.20688942f, -0.04322872f, 0.00334892f, 0.13690601f, 0.03183062f, -0.07000953f, 
    0.23233329f, 0.28753224f, -0.04864258f, -0.17179726f, 0.17030276f, -0.07715935f, 0.00093818f, -0.14829889f, 
    0.03447810f, -0.01396950f, -0.20714417f, 0.15553810f, 0.11143243f, -0.04245326f, 0.08137722f, 0.09686077f, 
    -0.08945077f, -0.08221127f, 0.04154391f, -0.09782421f, -0.15797135f, 0.07960796f, 0.10256670f, 0.00558924f, 
    0.03920055f, -0.20945306f, -0.04536152f, 0.00632688f, 0.08553876f, 0.08537742f, 0.07251392f, -0.12805383f, 
    -0.28660560f, -0.06111071f, -0.01639302f, 0.09859048f, 0.46698588f, 0.16424263f, 0.06171984f, -0.02787480f, 
    -0.02832297f, 0.14034919f, -0.04771247f, 0.05792137f, -0.15760611f, 0.27789912f, -0.11602702f, -0.01141550f, 
    -0.08888657f, -0.02425797f, 0.08381259f, -0.00321643f, -0.09903085f, -0.05382790f, 0.20121561f, -0.23357885f, 
    -0.04116613f, -0.02260498f, 0.22688034f, 0.15068980f, -0.02119078f, -0.06601320f, -0.31660864f, 0.40976217f, 
    0.17774105f, -0.05383912f, 0.38477674f, -0.24801995f, 0.06515210f, 0.27692023f, -0.27591172f, -0.34667820f, 
    -0.03104886f, 0.00591004f, -0.15254234f, -0.17744401f, 0.01630926f, -0.15609530f, 0.08173884f, -0.01188333f, 
    0.24893063f, -0.40375951f, 0.12009668f, 0.19123368f, 0.04576774f, -0.21842584f, 0.12568524f, 0.17103098f, 
    0.18838370f, -0.10530526f, -0.00812249f, 0.05051549f, -0.10849052f, -0.02627353f, -0.00117556f, 0.15441854f, 
    -0.14651802f, 0.18302043f, 0.20564948f, 0.14952208f, 0.09168006f, -0.19551553f, -0.24481711f, -0.12655146f, 
    0.16121429f, -0.01039865f, 0.08118760f, -0.04776836f, -0.00213800f, -0.21074681f, -0.17917325f, -0.18140686f, 
    0.02795260f, 0.16175404f, -0.08837185f, 0.17645152f, -0.24681996f, -0.14156263f, -0.18448132f, -0.01049238f, 
    -0.06234574f, -0.25357047f, -0.05868541f, -0.17017883f, 0.11273674f, -0.12552306f, 0.07231677f, 0.06663118f, 
    -0.00906969f, -0.21909869f, -0.06238969f, -0.04880300f, -0.10605527f, -0.23535600f, -0.53176808f, -0.35822150f, 
    0.13785909f, -0.08017121f, -0.01796724f, 0.05032448f, -0.06258202f, 0.14361016f, -0.11692775f, -0.14130589f, 
    0.33230308f, -0.02916410f, -0.14668357f, 0.30482647f, -0.04906797f, 0.14488797f, 0.14354981f, -0.03757516f, 
    -0.30606967f, -0.06318802f, 0.34774646f, -0.27649775f, -0.02603701f, -0.12769215f, 0.06095361f, 0.06465447f, 
    0.21681491f, 0.47765440f, -0.48239279f, -0.45950085f, 0.08494215f, 0.03518287f, 0.02811749f, 0.19124520f, 
    -0.03520067f, -0.02052158f, -0.20640017f, 0.13520263f, 0.06858828f, -0.38354078f, -0.22881743f, -0.17332895f, 
    0.14705931f, 0.14073220f, -0.05653183f, 0.12928298f, -0.10248006f, 0.03783615f, -0.06232442f, 0.14890325f, 
    -0.12182489f, 0.06055603f, -0.04069167f, 0.17743593f, 0.17609546f, 0.24907950f, 0.16534527f, -0.25764269f, 
    -0.19656597f, -0.05199586f, 0.04120903f, 0.15733549f, -0.07912976f, 0.08259341f, -0.50172251f, 0.05035472f, 
    -0.03719533f, 0.10383239f, -0.01608020f, 0.04606417f, -0.18858962f, -0.09303896f, 0.52006513f, 0.13223547f, 
    -0.14226265f, 0.03581104f, -0.03085049f, -0.01162950f, -0.04542659f, 0.05538315f, -0.19641741f, 0.47135684f, 
    0.10576474f, -0.19105820f, 0.21608455f, -0.06947187f, -0.00208183f, -0.08420184f, -0.14707613f, -0.05581852f, 
    -0.10488696f, -0.05584222f, 0.12809429f, 0.00016593f, -0.04093706f, -0.12130822f, -0.09293074f, -0.09577072f, 
    0.40198827f, -0.03137922f, -0.08237157f, -0.05594904f, -0.03524619f, 0.02771484f, 0.05599239f, 0.17874892f, 
    0.18048483f, -0.08651546f, -0.21859324f, 0.00519819f, 0.23035339f, -0.02974155f, 0.14184201f, -0.06614327f, 
    0.13330208f, 0.17963843f, 0.09693055f, -0.26604760f, 0.04472858f, 0.19334491f, -0.12145755f, -0.07785353f, 
    0.00821276f, 0.03103548f, 0.14833570f, -0.09910146f, -0.20437777f, 0.06623803f, 0.13102932f, -0.02487188f, 
    -0.04785075f, 0.15627657f, 0.05895441f, 0.08610509f, 0.03467897f, -0.04921912f, 0.21372198f, 0.19900605f, 
    -0.08768559f, -0.10955853f, 0.03031704f, 0.10749468f, 0.03900821f, -0.09778811f, 0.13118498f, 0.30044225f, 
    0.04054907f, 0.02630161f, -0.02110342f, 0.17844307f, 0.07886833f, -0.04943547f, 0.11458229f, 0.46944579f, 
    -0.49924639f, -0.53782415f, -0.08669109f, -0.05779652f, 0.06307786f, 0.06498624f, -0.24782108f, -0.07652861f, 
    0.05888570f, 0.24776067f, 0.10757908f, -0.02387473f, 0.10550682f, 0.02141902f, 0.11521267f, 0.03913252f, 
    -0.20484979f, -0.07862912f, 0.03921115f, 0.12454865f, -0.13468094f, 0.00089087f, 0.01155528f, 0.26017675f, 
    -0.18878281f, 0.15295626f, 0.13540401f, -0.04999990f, 0.08271027f, 0.07590191f, -0.02874487f, 0.08108126f, 
    0.00236915f, 0.07930838f, -0.15502867f, -0.04564722f, -0.07342097f, -0.10356040f, 0.04061354f, -0.16093895f, 
    0.24345508f, 0.08162021f, -0.09292325f, 0.19062501f, 0.04451450f, -0.42023179f, 0.19385582f, -0.02156161f, 
    -0.03199499f, -0.12902227f, -0.03982450f, 0.06736519f, 0.15112661f, -0.00413273f, -0.40463090f, -0.16284357f, 
    -0.17613547f, 0.08977959f, 0.41641396f, 0.09276121f, -0.02724280f, -0.08271066f, -0.10264078f, 0.22936960f, 
    -0.09954439f, 0.13342795f, 0.14280322f, -0.05614677f, -0.10267200f, 0.12538916f, 0.02614447f, -0.44853896f, 
    0.12195309f, 0.24422516f, -0.15122701f, -0.06993785f, -0.16870108f, 0.00356774f, -0.10703303f, 0.04585730f, 
    0.36470217f, 0.13496098f, 0.07857712f, -0.07050146f, -0.24207941f, -0.12808456f, 0.04083334f, 0.06262195f, 
    0.00080248f, -0.01745728f, 0.07576561f, 0.10449337f, 0.02454527f, -0.10342032f, -0.05355091f, -0.06617682f, 
    -0.27071700f, 0.08497307f, -0.23856421f, 0.08380637f, -0.03110525f, -0.10322129f, 0.06319758f, 0.08066647f, 
    -0.09761213f, -0.03284777f, -0.01936046f, -0.05603082f, -0.29733950f, 0.09614042f, 0.06853548f, -0.04825646f, 
    0.00961463f, 0.15258095f, -0.07282140f, -0.00068511f, 0.20945659f, 0.06474048f, -0.18597803f, 0.17786591f, 
    -0.08434612f, -0.16860574f, 0.06763174f, 0.01734496f, -0.31162030f, 0.60672057f, -0.32066205f, -0.49227381f, 
    0.04257796f, 0.03786704f, -0.01625961f, 0.04971922f, 0.03576280f, 0.02115005f, -0.24568845f, -0.12376302f, 
    -0.29034308f, -0.08049241f, 0.14439045f, 0.02815824f, 0.12890527f, -0.18631408f, 0.49697176f, 0.13262062f, 
    0.05159240f, -0.15036422f, -0.05752260f, 0.12521636f, -0.09205969f, 0.18182729f, 0.10110373f, -0.08650175f, 
    -0.24984664f, 0.22100481f, 0.56765783f, 0.21606533f, -0.15757948f, 0.01095403f, -0.12898041f, 0.16353358f, 
    -0.04412958f, 0.05091527f, 0.22550666f, 0.36410064f, -0.15667188f, 0.11651277f, -0.09535703f, -0.09510192f, 
    0.08777749f, -0.04295810f, 0.01464961f, 0.03908981f, 0.18834247f, -0.11150248f, -0.21043119f, 0.00459879f, 
    -0.00010330f, -0.08216711f, -0.06886573f, -0.47241145f, -0.32098362f, -0.25689927f, -0.36865354f, -0.03522361f, 
    -0.06262230f, 0.17170469f, 0.17587188f, -0.08550143f, -0.79130846f, -0.22358754f, 0.56429821f, 0.06704740f, 
    0.10595474f, -0.10529865f, -0.20213972f, -0.11603910f, -0.11553550f, 0.55564159f, 0.20920992f, 0.50700796f, 
    -0.12846290f, -0.01337143f, 0.02862014f, 0.09743857f, 0.30285761f, 0.13481618f, 0.20334429f, -0.20601344f, 
    0.15227145f, -0.09900145f, -0.04245628f, 0.05031162f, -0.18550733f, 0.04711183f, -0.18355310f, -0.32887164f, 
    -0.02853890f, -0.39473227f, -0.13045879f, -0.08487950f, 0.01987399f, -0.06429717f, 0.05776034f, 0.09794678f, 
    -0.09357782f, -0.08458059f, 0.00259650f, -0.14714067f, 0.01854987f, 0.05383287f, 0.24593052f, 0.12023038f, 
    0.05417544f, 0.08980317f, -0.07910391f, -0.38079768f, -0.03970830f, 0.16509117f, 0.05253559f, 0.30696899f, 
    -0.05434943f, 0.04444250f, -0.14157371f, -0.22911163f, 0.00675885f, 0.09884056f, 0.00917350f, -0.22230385f, 
    0.08254941f, 0.22372882f, 0.20727521f, -0.87724429f, 0.30696362f, 0.17588268f, 0.11918691f, -0.22916901f, 
    0.22853372f, -0.10732836f, 0.02531582f, 0.01209768f, 0.09119013f, 0.13454127f, 0.17094187f, -0.08482167f, 
    -0.06333818f, -0.00086143f, 0.05760581f, -0.11418858f, 0.05595564f, -0.17538948f, -0.09773000f, -0.20657597f, 
    0.57347250f, -0.08626758f, -0.07434995f, -0.12274460f, 0.00253882f, 0.19160010f, -0.20144355f, -0.23556776f, 
    0.01787822f, 0.14783567f, -0.15827629f, 0.09828983f, -0.01797741f, -0.14046870f, 0.01096091f, 0.11319042f, 
    0.36577904f, 0.20638086f, -0.09277298f, 0.21826734f, -0.16389009f, -0.07883538f, -0.04365485f, -0.02977676f, 
    -0.24084224f, -0.26074451f, -0.24930166f, 0.02853318f, -0.01271077f, 0.01161145f, -0.08676593f, -0.02641099f, 
    -0.06032749f, -0.39486173f, -0.43901926f, 0.05417008f, -0.15614399f, -0.11650939f, -0.21956852f, 0.17379361f, 
    -0.20513502f, -0.07949229f, -0.24375543f, -0.43220767f, -0.35554650f, -0.00078403f, -0.00027210f, -0.05348289f, 
    0.03467784f, 0.12478287f, 0.04860173f, 0.30742308f, 0.27220163f, 0.11998393f, 0.11254761f, 0.25244284f, 
    0.10824070f, -0.01687472f, -0.13373856f, -0.00922382f, 0.44876507f, 0.10990074f, 0.48645324f, 0.11686241f, 
    -0.00131707f, -0.09876060f, 0.07883355f, 0.11930023f, 0.12244446f, 0.06098948f, 0.27502120f, 0.07268012f, 
    -0.00596184f, -0.12014562f, 0.02780008f, -0.17040493f, 0.00710619f, 0.04088704f, 0.18009757f, -0.15941821f, 
    0.40281489f, -0.38028765f, 0.10857885f, -0.06214698f, -0.12231489f, 0.29321530f, -0.06150298f, -0.24170099f, 
    0.17731823f, 0.25211588f, -0.23999877f, 0.14288905f, -0.05361521f, 0.00423977f, 0.14349534f, -0.02535844f, 
    0.16253351f, 0.18679522f, 0.47542569f, -0.07716212f, -0.06795367f, -0.03274975f, -0.08069507f, -0.13375302f, 
    0.04956318f, -0.01561836f, -0.04511314f, 0.02253325f, -0.06782457f, 0.05242513f, 0.06319857f, 0.04533056f, 
    -0.11549799f, -0.03707977f, 0.22104380f, 0.11331414f, 0.18657812f, -0.26583216f, -0.29831746f, 0.14190347f, 
    -0.14913596f, -0.06917628f, 0.08467512f, 0.07711635f, 0.11261737f, 0.25104621f, 0.02199535f, 0.01362227f, 
    -0.23003058f, 0.04954973f, -0.07530827f, 0.04618260f, 0.35270765f, -0.22114989f, -0.12830660f, -0.10733705f, 
    0.04078241f, -0.21126868f, 0.11557560f, 0.00253257f, -0.15067533f, 0.03330220f, 0.18148202f, 0.45868230f, 
    -0.03647096f, 0.26238650f, 0.03558866f, 0.02285181f, 0.15473863f, -0.12935114f, 0.08845287f, -0.39148527f, 
    0.15418233f, -0.07347166f, 0.00433575f, -0.19947065f, 0.18261328f, 0.04217318f, -0.17103332f, -0.55003756f, 
    -0.40496427f, 0.09781681f, -0.27881616f, -0.03193294f, 0.07460071f, -0.20277536f, -0.10436629f, -0.07387901f, 
    0.25102994f, -0.58752674f, -0.31982565f, 0.09896483f, 0.15031679f, 0.09373735f, 0.15246530f, 0.09217191f, 
    0.19891545f, -0.19925673f, 0.27889475f, 0.35638344f, 0.08131410f, 0.07817251f, 0.06151617f, -0.16514432f, 
    0.01283985f, 0.11752501f, -0.30896109f, -0.77825230f, 0.00373009f, 0.23504891f, 0.26260853f, -0.08986545f, 
    0.46945596f, 0.18100005f, 0.21112210f, 0.26739383f, 0.12632875f, 0.07471536f, 0.01113124f, -0.06483240f, 
    0.14890344f, 0.16120426f, 0.08763835f, 0.12044865f, -0.09849106f, -0.38601300f, -0.16557671f, -0.17187789f, 
    0.01599947f, -0.10553581f, -0.05943245f, 0.07165390f, 0.07587895f, -0.57059711f, 0.14245912f, 0.21548200f, 
    -0.10131652f, 0.01353779f, -0.21318233f, 0.12698962f, 0.03193074f, 0.14018054f, -0.14310946f, -0.23768376f, 
    0.09372590f, -0.02784260f, -0.01974617f, -0.05886815f, 0.01903895f, -0.08975217f, -0.08519071f, -0.06387366f, 
    -0.05529638f, 0.26268578f, 0.09881305f, 0.12890542f, 0.12593423f, 0.25523084f, 0.11840847f, 0.20663846f, 
    -0.09323432f, 0.08578826f, -0.12602510f, -0.12877302f, -0.11584354f, -0.06177796f, 0.10626294f, 0.06454703f, 
    -0.06877375f, -0.00143712f, 0.00052157f, -0.06812824f, -0.03397990f, -0.01895262f, 0.35933197f, 0.26037842f, 
    0.11635479f, 0.07472086f, 0.08561653f, -0.11800297f, -0.16299056f, -0.02473135f, -0.03723115f, -0.04477925f, 
    0.05551875f, 0.25840530f, 0.02755269f, 0.37006503f, -0.09156542f, -0.02352573f, -0.04623958f, 0.04321085f, 
    0.00045657f, 0.04980847f, 0.03275790f, 0.01900029f, -0.14328726f, -0.33978873f, -0.35912737f, 0.09742964f, 
    0.09888136f, 0.14668298f, 0.04107398f, 0.00206452f, -0.02277823f, -0.03229874f, -0.17882590f, -0.05594230f, 
    -0.14237386f, -0.15058717f, -0.20540281f, 0.00217406f, -0.05305405f, -0.14593047f, 0.12459826f, 0.04146278f, 
    0.00610239f, 0.26633838f, 0.05859317f, 0.01261487f, 0.26338857f, 0.15639067f, 0.24768461f, -0.00344666f, 
    0.29147935f, 0.32099050f, 0.15677524f, 0.22105822f, 0.10905226f, -0.09169632f, 0.13603435f, 0.02076663f, 
    -0.01559355f, -0.08043163f, -0.03362012f, -0.11529448f, -0.05447664f, 0.00218740f, -0.12167104f, 0.12160940f, 
    0.10165332f, 0.15264685f, 0.05763924f, -0.06231779f, 0.04855397f, -0.08431651f, -0.00167101f, 0.06355410f, 
    0.08328249f, 0.02072590f, -0.14308794f, 0.04625023f, 0.03680836f, -0.12454794f, -0.14393218f, 0.01923246f, 
    -0.11033700f, -0.15757574f, -0.02970094f, -0.39193222f, -0.85213768f, -0.28818759f, -0.07198755f, -0.03471348f, 
    -0.11437060f, 0.19215125f, -0.04156502f, 0.18507582f, -0.59057111f, -0.21604477f, -0.09403054f, 0.04274684f, 
    0.04352507f, 0.00559602f, 0.06251841f, 0.15582508f, 0.09917612f, -0.09864339f, -0.11324841f, -0.25974622f, 
    0.13813052f, 0.06655324f, 0.02532562f, 0.06147794f, 0.08071709f, 0.03687254f, 0.26357105f, -0.23317179f, 
    -0.06647032f, 0.14497727f, -0.20168345f, 0.16925877f, 0.42308339f, 0.23819135f, 0.26611114f, 0.32847655f, 
    -0.34010795f, -0.16291255f, -0.06874247f, 0.04046329f, -0.04039548f, 0.42962959f, -0.04919295f, 0.12125769f, 
    -0.50584251f, -0.61679542f, -0.32905617f, -0.09992958f, 0.06750916f, -0.14946511f, -0.18870224f, -0.02215026f, 
    0.05881713f, -0.15281063f, 0.07629808f, 0.05454213f, -0.08825494f, -0.02764677f, -0.02829712f, 0.19856243f, 
    0.22504950f, 0.07914861f, -0.03933186f, 0.01472923f, -0.00277705f, 0.12957716f, -0.00131929f, 0.01222780f, 
    0.08172376f, 0.01837625f, 0.15867199f, -0.01184346f, -0.06997322f, -0.08633195f, -0.12787643f, -0.26511550f, 
    0.01986287f, 0.00080934f, 0.00418774f, 0.12380363f, -0.03392691f, -0.02582402f, 0.26087785f, 0.01842796f, 
    -0.03552088f, 0.08130094f, 0.12697731f, 0.05184368f, 0.09880059f, -0.26054981f, -0.18019468f, -0.01184389f, 
    -0.24659123f, -0.14819464f, -0.07313747f, -0.05142140f, 0.03047834f, 0.04127871f, 0.02956755f, 0.18580109f, 
    -0.10954103f, -0.01348600f, 0.07540668f, -0.07613277f, 0.11284428f, -0.00592794f, -0.32598880f, -0.10031015f, 
    0.08473623f, 0.05369863f, 0.26438019f, 0.01708672f, 0.03168717f, 0.34702027f, 0.03792004f, 0.08049520f, 
    -0.05181527f, -0.01364082f, -0.00316812f, -0.01278142f, 0.03633860f, -0.03885417f, 0.01697748f, -0.05099998f, 
    -0.02017361f, -0.05579298f, -0.06581107f, -0.04596362f, -0.02944937f, -0.02713785f, -0.02628772f, 0.00244803f, 
    -0.00356156f, -0.02596889f, 0.02775966f, 0.03976423f, 0.03765405f, 0.02960181f, 0.03076805f, -0.03233796f, 
    -0.05587261f, -0.04632348f, 0.03038457f, 0.03129813f, -0.01709658f, -0.02309629f, -0.01887705f, -0.00911452f, 
    0.01248122f, -0.00460620f, -0.00481310f, -0.04615885f, 0.01538043f, -0.04506978f, -0.00881016f, 0.03600294f, 
    0.03147960f, -0.03629955f, -0.04957689f, -0.03498220f, -0.04406087f, 0.00330854f, -0.04495063f, -0.00054900f, 
    0.00971573f, 0.00584234f, -0.05475278f, 0.00005397f, -0.01704663f, -0.03769969f, -0.05988760f, 0.02539360f, 
    -0.00050987f, -0.01871555f, 0.02233764f, -0.00508791f, 0.05484212f, -0.04343589f, -0.05735347f, -0.02320810f, 
    -0.06001737f, -0.05473819f, 0.03863486f, 0.03991722f, 0.01414602f, -0.04598328f, -0.04801276f, 0.02315921f, 
    -0.02609752f, -0.05399773f, 0.04205482f, 0.03262873f, -0.05472153f, -0.00381926f, -0.00990401f, -0.04372573f, 
    -0.01024339f, -0.04110223f, -0.02721911f, -0.05715248f, -0.03842166f, 0.05542081f, 0.05400471f, -0.00623660f, 
    -0.00393866f, 0.03272587f, -0.01339171f, -0.01722656f, -0.05760625f, 0.02571148f, -0.01491158f, -0.04751049f, 
    0.03007340f, -0.01511086f, -0.00354739f, -0.01326204f, -0.01989119f, -0.05015055f, -0.01744239f, 0.04596829f, 
    -0.01199890f, -0.01183247f, 0.02276726f, -0.02369383f, -0.01973738f, 0.00123442f, 0.00254012f, -0.04090645f, 
    0.05359979f, 0.00431930f, -0.05494719f, -0.00345349f, 0.04649939f, -0.04819808f, 0.00456865f, -0.05922037f, 
    0.01897983f, 0.04321144f, -0.05317554f, 0.05101662f, 0.01763010f, -0.06130363f, 0.02610658f, 0.02292580f, 
    -0.03201596f, -0.00626882f, -0.05272005f, -0.02236691f, -0.00549732f, 0.00152635f, 0.00236349f, -0.05173328f, 
    -0.04392947f, -0.01183079f, -0.02667945f, -0.03320960f, -0.05830332f, -0.05248198f, -0.04644877f, 0.02764223f, 
    -0.03895494f, -0.02605257f, -0.02418314f, -0.04898509f, 0.01294558f, -0.00668799f, 0.02699045f, -0.05058543f, 
    0.00235431f, -0.01576418f, -0.05645426f, 0.04333625f, 0.01318157f, -0.01833764f, -0.00039363f, 0.04733037f, 
    -0.03839348f, 0.02155809f, -0.06327587f, 0.04112833f, 0.05770123f, 0.01593233f, 0.02309355f, 0.04336862f, 
    0.04053405f, 0.04705403f, -0.04852296f, 0.02131647f, -0.03263565f, -0.00782802f, 0.05235482f, -0.03126185f, 
    0.03191079f, 0.03041407f, 0.03855371f, 0.01886072f, 0.02676651f, 0.00816951f, -0.01108861f, -0.04174640f, 
    0.00883584f, -0.04587898f, 0.01233122f, 0.02879588f, 0.03096307f, -0.01475105f, 0.00374905f, -0.05142906f, 
    0.00601465f, -0.02552854f, -0.00617006f, -0.04322670f, 0.00146893f, 0.03035599f, -0.03310644f, 0.02451205f, 
    -0.05682248f, -0.04941115f, 0.01995345f, 0.00533687f, 0.05162727f, 0.02025671f, 0.03671285f, -0.03815117f, 
    -0.03392722f, -0.06499993f, 0.04947209f, 0.03756114f, 0.03621523f, 0.04963294f, 0.03826247f, -0.05363156f, 
    -0.05420775f, 0.04399534f, -0.04116882f, 0.00203079f, 0.03370418f, 0.00436744f, -0.01298364f, 0.00485935f, 
    0.03723118f, 0.03896005f, 0.00707149f, 0.01215890f, -0.03441229f, -0.04156242f, 0.05382232f, 0.04796265f, 
    -0.04818304f, 0.04236865f, 0.00457448f, -0.02873721f, -0.00728990f, 0.02017796f, 0.00309544f, -0.06397787f, 
    -0.05833884f, -0.04763170f, -0.05237160f, 0.03429489f, -0.02560940f, -0.03451750f, -0.04430090f, 0.00963138f, 
    0.02431596f, -0.05974055f, 0.00652419f, 0.01366070f, -0.04468751f, -0.05679376f, -0.03049780f, 0.00868335f, 
    0.01663962f, -0.01052934f, 0.00087604f, 0.02116757f, -0.02908752f, -0.02863230f, 0.04252712f, 0.03775499f, 
    -0.04878966f, -0.04239207f, 0.04034877f, -0.01638079f, 0.04306637f, 0.01734049f, -0.03957565f, -0.03960562f, 
    -0.02905430f, 0.00114497f, 0.04351123f, 0.00233922f, -0.04800931f, -0.05692505f, -0.03576814f, -0.01609205f, 
    0.03768719f, -0.04837221f, 0.01039156f, -0.02891092f, 0.02329252f, -0.00288422f, 0.04037935f, -0.04024243f, 
    -0.44303167f, -0.27824575f, 0.05103076f, -0.06396921f, 0.04535953f, 0.11356055f, 0.08451719f, 0.11393528f, 
    0.03114675f, 0.43875122f, -0.08952026f, -0.49024153f, 0.12753399f, 0.11537164f, 0.13734336f, 0.08326098f, 
    0.12496856f, -0.03844024f, -0.38907722f, 0.53356510f, 0.22810991f, 0.02786844f, -0.09335630f, 0.17512898f, 
    0.03353437f, -0.03709425f, -0.01152343f, 0.28753796f, -0.05595964f, -0.17911173f, 0.00435724f, 0.05210475f, 
    -0.23698865f, -0.01536258f, -0.13382758f, 0.17502277f, -0.25514838f, 0.01973144f, 0.02746285f, 0.03552858f, 
    0.03550104f, -0.07039066f, 0.02705279f, 0.08807001f, -0.12606940f, 0.51283467f, 0.23052479f, -1.09628057f, 
    0.00635538f, -0.23339172f, -0.09755447f, 0.00819637f, -0.03405023f, -0.00818149f, 0.11841161f, 0.07327618f, 
    0.05756553f, -0.02903251f, -0.04735797f, -0.11893503f, -0.12445749f, 0.06461070f, 0.04652977f, 0.31963655f, 
    -0.03687969f, -0.09982602f, 0.02393763f, 0.26600254f, 0.19585212f, 0.05428708f, -0.07182112f, 0.10021477f, 
    0.01423470f, 0.14452286f, 0.12221565f, 0.11946619f, -0.19815505f, -0.00151514f, 0.00258134f, 0.24088179f, 
    0.01668746f, 0.15490790f, -0.15282939f, -0.19283316f, -0.21018046f, -0.17811699f, -0.26895678f, 0.08993614f, 
    0.00036311f, 0.16087601f, -0.12223899f, -0.03782770f, -0.13745910f, -0.05927428f, -0.28865957f, -0.08661104f, 
    0.08298985f, 0.03763132f, 0.03929074f, -0.54125476f, 0.07158858f, -0.12172767f, -0.00728107f, 0.16829173f, 
    0.06870350f, 0.08419549f, 0.13054630f, 0.15730752f, -0.15171005f, -0.10354352f, 0.01351489f, -0.10361175f, 
    0.05461188f, -0.08034157f, 0.14249891f, 0.00511102f, 0.21160671f, -0.29270011f, 0.20664553f, 0.03962658f, 
    -0.13168524f, -0.14877334f, -0.08474897f, -0.02141889f, -0.03830339f, -0.15465780f, 0.25631353f, 0.25417918f, 
    -0.14819951f, 0.16082114f, 0.17999497f, 0.12027977f, 0.24197806f, 0.13943467f, -0.12407887f, 0.32211444f, 
    -0.03442980f, -0.47457087f, 0.04662637f, 0.14004284f, 0.27517530f, 0.14531235f, 0.10097932f, 0.00266767f, 
    -0.10270129f, 0.13724764f, -0.03764670f, 0.01453526f, -0.11073241f, -0.16480140f, 0.09556016f, -0.15901482f, 
    -0.10178380f, 0.02570722f, 0.13246185f, -0.31271428f, 0.13339613f, 0.11340108f, -0.17374107f, 0.07422733f, 
    -0.09627064f, -0.07745980f, 0.24117644f, -0.01828874f, -0.01678889f, 0.10917451f, -0.23890510f, -0.05721529f, 
    -0.25834370f, -0.14266080f, -0.10493021f, 0.20741314f, 0.11446267f, -0.35659921f, -0.08555635f, -0.15254296f, 
    -0.00474369f, -0.12351986f, -0.25224808f, -0.00264941f, 0.13907175f, 0.40648255f, -0.56813908f, -0.15615748f, 
    -0.05744188f, 0.00505296f, -0.03473563f, -0.10311072f, 0.07237970f, 0.30706823f, -0.50181884f, -0.66535109f, 
    0.07219061f, 0.13143648f, -0.00336796f, 0.00862101f, -0.09397671f, 0.14815336f, -0.12623459f, 0.14595886f, 
    0.44681111f, 0.00938858f, 0.09425487f, -0.08696274f, -0.11143093f, 0.46735865f, 0.09899574f, -0.24365836f, 
    0.16674912f, 0.01741978f, -0.01117972f, 0.05712817f, -0.01385152f, 0.25533342f, -0.02460757f, -0.02090804f, 
    -0.28302515f, 0.14615755f, 0.17576155f, -0.05022511f, -0.03447632f, -0.03046388f, 0.01261263f, 0.03355480f, 
    0.02110287f, -0.08166382f, 0.11940681f, 0.06006742f, 0.10215489f, -0.23138891f, -0.10229342f, -0.03499598f, 
    -0.11127216f, -0.09038927f, -0.11051577f, 0.01227171f, 0.10243832f, -0.29073068f, -0.03379506f, -0.22314073f, 
    0.18551576f, 0.18282878f, 0.07214022f, -0.36816448f, -0.27868721f, -0.17337993f, -0.21495780f, 0.14232317f, 
    0.18238655f, 0.08801916f, 0.03096438f, 0.26811644f, 0.11585063f, -0.00870269f, 0.06305911f, -0.01966288f, 
    -0.04388636f, -0.16757874f, -0.00697468f, -0.02413328f, 0.12459798f, 0.29421762f, -0.30407953f, -0.44074813f, 
    -0.10604851f, 0.02220058f, 0.15254018f, -0.07401790f, 0.00916199f, -0.00250891f, 0.11002126f, -0.08302961f, 
    -0.40549183f, -0.09673781f, -0.19441643f, 0.17177141f, 0.30275962f, 0.22339945f, -0.11182304f, 0.02868762f, 
    0.07551003f, -0.25375548f, -0.28041211f, 0.34479728f, 0.07134641f, 0.13001259f, 0.21632589f, 0.04870686f, 
    -0.44525924f, -0.17638227f, 0.39072397f, 0.05470229f, 0.24788536f, 0.20006676f, 0.04524321f, 0.03569882f, 
    0.29005146f, 0.13317999f, -0.03703296f, -0.41119814f, 0.07671427f, 0.05809974f, -0.09011839f, 0.04696620f, 
    -0.00822123f, 0.07011145f, -0.20300288f, 0.22560008f, 0.59839815f, -0.16526410f, -0.06100425f, 0.11156251f, 
    0.16420747f, 0.22362083f, 0.23286058f, 0.19115253f, -0.13535450f, 0.07572564f, -0.05020236f, 0.15878722f, 
    0.20866100f, 0.14036770f, 0.20226361f, 0.11316898f, -0.19206332f, -0.06533983f, 0.02870757f, -0.11896507f, 
    -0.07722572f, -0.14065537f, -0.00725903f, 0.07640051f, 0.03435574f, 0.26917788f, -0.18847729f, 0.13344586f, 
    -0.28532812f, 0.19637866f, 0.03272533f, 0.07123493f, -0.06259280f, -0.06045295f, -0.01865790f, 0.09158061f, 
    -0.32363397f, -0.09649953f, -0.03507447f, -0.03930308f, 0.02368910f, 0.05379849f, 0.06400679f, 0.22970761f, 
    0.37631959f, -0.36930764f, 0.12355749f, 0.06676589f, 0.06774930f, -0.06795555f, -0.04004440f, 0.07310431f, 
    0.01540304f, -0.08181147f, 0.08459795f, -0.03900390f, -0.01100711f, -0.09670903f, 0.00547089f, -0.24155582f, 
    -0.07176432f, -0.19677721f, -0.04713927f, 0.03236404f, 0.04968091f, 0.16356814f, 0.07158627f, 0.09921504f, 
    0.27890393f, 0.17659454f, -0.17181998f, -0.07674845f, 0.11275784f, 0.13494557f, 0.08426656f, 0.07093317f, 
    -0.08449645f, -0.12528959f, 0.28271034f, -0.16645208f, 0.09956799f, -0.01944125f, -0.06692038f, 0.01885669f, 
    0.12689023f, -0.00830737f, 0.00863366f, 0.04681930f, -0.20412025f, -0.31194153f, 0.10382113f, 0.06007511f, 
    0.08007705f, 0.10821082f, 0.03747501f, 0.02568947f, -0.26640895f, -0.06574813f, -0.01405473f, 0.09179305f, 
    -0.10797181f, -0.02896998f, -0.06743504f, 0.02221554f, 0.09332917f, 0.05308284f, -0.00162424f, 0.32803372f, 
    0.22442672f, 0.01258204f, 0.13667434f, 0.11667053f, -0.10969733f, -0.03381739f, -0.07643270f, 0.12910929f, 
    -0.04390043f, -0.51106876f, 0.14816825f, -0.15864512f, 0.09398849f, 0.00653059f, 0.05996437f, -0.03128722f, 
    -0.03913444f, 0.00535872f, 0.15686996f, -0.01227773f, -0.03586113f, 0.03503880f, 0.02593585f, -0.01089609f, 
    0.22310615f, -0.01875665f, 0.14912117f, 0.12217124f, -0.09842955f, 0.17202133f, -0.00198864f, 0.11741119f, 
    0.25326747f, 0.12774375f, -0.18074378f, -0.03548759f, -0.14322211f, -0.12876885f, 0.08664110f, -0.13519315f, 
    0.02400466f, 0.30294085f, -0.05555457f, -0.04434905f, -0.19594294f, -0.06959318f, -0.00784950f, -0.00213640f, 
    -0.08883368f, 0.08093592f, 0.12116456f, -0.17021997f, 0.12403542f, -0.25441641f, 0.25389352f, 0.10808850f, 
    0.09880041f, 0.00104350f, 0.04242784f, -0.02989127f, 0.01590437f, -0.27175695f, -0.40716717f, -0.43239066f, 
    -0.06661721f, 0.04610501f, 0.03996400f, 0.16306478f, 0.09836472f, -0.23598030f, 0.33294201f, 0.11699133f, 
    0.26609874f, 0.07753120f, 0.12714888f, -0.02833108f, 0.16637459f, 0.15251943f, 0.22374707f, -0.18520002f, 
    0.22590040f, 0.41818187f, -0.00538825f, -0.06574441f, -0.04991392f, -0.21564060f, 0.13781737f, 0.00559030f, 
    -0.16294220f, -0.09903864f, -0.37589726f, -0.14506678f, -0.03435559f, -0.04941904f, -0.07127100f, -0.06906795f, 
    -0.10490251f, 0.00288458f, 0.12639190f, 0.03536966f, -0.18508352f, 0.03275134f, -0.16509649f, 0.11925760f, 
    -0.04913953f, -0.21871987f, -0.04073381f, 0.01445515f, -0.01483205f, 0.04242648f, 0.01986178f, -0.04070870f, 
    -0.05961301f, -0.29315019f, -0.18904874f, -0.02558806f, 0.00014729f, -0.20286773f, -0.02658431f, 0.01412569f, 
    0.05311588f, -0.24902673f, 0.03286691f, 0.08180972f, 0.11071821f, -0.00377181f, -0.25972879f, -0.01827270f, 
    0.11350580f, -0.14010745f, 0.12508890f, 0.07011463f, -0.15392709f, 0.38246605f, 0.12181189f, 0.11743446f, 
    0.07472108f, 0.00721389f, -0.24804421f, -0.13847749f, -0.05262354f, -0.00864320f, -0.03778965f, -0.45647478f, 
    0.04407587f, -0.11712018f, 0.29692709f, -0.27105826f, -0.18374029f, -0.01227206f, -0.30680636f, 0.44393232f, 
    0.20974077f, 0.06957313f, 0.01247085f, -0.06283561f, 0.07856251f, 0.03937694f, -0.33407664f, 0.03599381f, 
    0.16500358f, -0.10853986f, -0.30782130f, 0.08777815f, -0.29657859f, -0.27170780f, -0.17063807f, -0.10529217f, 
    -0.27660137f, -0.08503162f, -0.40079802f, 0.00463299f, 0.01106786f, 0.21105100f, 0.15427604f, -0.10007002f, 
    0.07747766f, 0.06051592f, 0.01021972f, -0.11963827f, -0.37785655f, -0.04366664f, -0.09528109f, 0.01025988f, 
    -0.07462802f, 0.05624690f, 0.00645875f, 0.13130072f, -0.14797097f, 0.03103583f, 0.10896038f, 0.14240298f, 
    -0.08241689f, -0.14098246f, -0.21556085f, 0.01263279f, 0.14481719f, -0.14035659f, 0.24710399f, -0.01753999f, 
    -0.11354247f, -0.15043411f, -0.09064656f, -0.22474937f, -0.09093247f, 0.08616997f, -0.05447068f, 0.02767966f, 
    -0.21206552f, 0.03318122f, 0.13148050f, -0.14700216f, -0.07777759f, -0.13666509f, -0.53304356f, 0.06819187f, 
    -0.22261454f, -0.01651139f, -0.09681389f, 0.16941783f, 0.19703470f, 0.10226098f, -0.11506991f, -0.64874035f, 
    -0.28421903f, -0.30612472f, 0.10056575f, 0.03844046f, 0.19938926f, 0.15836357f, 0.14084606f, -0.00826165f, 
    0.31398350f, -0.03852774f, 0.04985843f, -0.01945933f, 0.18346865f, -0.20588398f, 0.19146453f, 0.11123312f, 
    0.13664714f, -0.16955012f, -0.01618009f, 0.06211912f, -0.04949157f, 0.01860096f, 0.11569499f, 0.00855853f, 
    -0.05027689f, 0.05652920f, 0.02968871f, 0.06935057f, -0.18436712f, 0.02095538f, -0.05427070f, -0.02372633f, 
    -0.18545417f, -0.06743303f, -0.24069878f, -0.13906461f, 0.17225432f, -0.13958135f, 0.12273685f, -0.14690636f, 
    -0.04360641f, 0.21541679f, 0.15820201f, -0.13369413f, -0.03431656f, 0.23323938f, 0.21411176f, 0.05698099f, 
    -0.03739831f, -0.00746795f, -0.08555073f, -0.03115580f, 0.14027497f, 0.02965461f, 0.36651045f, -0.11270548f, 
    0.27945533f, 0.07966245f, 0.08672235f, 0.01819492f, -0.13060048f, -0.15326875f, -0.16071987f, 0.03964699f, 
    -0.31318063f, 0.00881686f, -0.06972332f, 0.26057813f, 0.12653640f, 0.14665554f, 0.12630531f, 0.10684622f, 
    -0.09622972f, 0.20981896f, 0.10953214f, 0.17414910f, 0.12488714f, 0.08208890f, 0.08601364f, 0.16072056f, 
    0.10837306f, -0.26913732f, -0.04111613f, 0.12674065f, 0.10274150f, -0.17492619f, 0.10791943f, -0.16919985f, 
    -0.19833592f, -0.13914855f, -0.44454309f, -0.17295808f, -0.09727536f, -0.06982637f, 0.02361121f, 0.10377783f, 
    -0.02922353f, 0.04484857f, -0.16824210f, -0.06140597f, -0.32855850f, -0.25742018f, 0.19861901f, -0.25192222f, 
    0.06820080f, 0.19767465f, 0.02539152f, 0.23429960f, 0.34571624f, 0.17198449f, -0.03010306f, 0.16786197f, 
    -0.04237036f, 0.02426047f, 0.01145846f, -0.27995139f, 0.47174209f, 0.15749075f, 0.11459006f, -0.06518784f, 
    -0.00682692f, -0.02227493f, -0.06655291f, 0.00788827f, -0.23414616f, 0.09702018f, 0.41112205f, 0.37552565f, 
    0.04620570f, 0.26129881f, -0.03785377f, 0.15609096f, 0.06434849f, -0.02667176f, 0.11824556f, -0.21996470f, 
    0.09685179f, 0.06467516f, 0.16455317f, -0.32435286f, -0.05319829f, -0.14642791f, 0.15552832f, -0.07505052f, 
    0.01896732f, -0.16905038f, 0.09519408f, -0.15876925f, 0.10613716f, 0.17126150f, 0.08426715f, 0.12025250f, 
    -0.30085117f, 0.24413171f, 0.05500966f, 0.01491637f, -0.25815696f, -0.12383348f, -0.01058168f, -0.04750352f, 
    0.11742521f, 0.17409524f, -0.12597238f, 0.03211599f, 0.16094118f, 0.08390395f, 0.10220607f, 0.12214167f, 
    0.02953666f, 0.03301820f, -0.07508779f, 0.28787553f, -0.45666328f, -0.12384251f, -0.16551350f, -0.14550012f, 
    -0.13037939f, 0.00332849f, 0.13986416f, 0.34953120f, 0.64682406f, -0.39599058f, -0.14102656f, 0.03584922f, 
    0.23046237f, -0.02217549f, 0.00967379f, -0.01507511f, -0.36709389f, -0.18391831f, 0.24766694f, 0.08231283f, 
    0.34168237f, 0.14151630f, -0.01772299f, 0.16406363f, -0.10358912f, 0.08170004f, -0.09762746f, 0.36550015f, 
    0.07042926f, 0.11175261f, 0.06306827f, 0.19800551f, 0.13053101f, 0.14192602f, 0.51574981f, -0.20312697f, 
    0.22286759f, -0.02433767f, -0.01628646f, 0.25072613f, 0.11138213f, 0.11006087f, 0.00243539f, -0.42366621f, 
    -0.27623132f, -0.62937552f, 0.01163093f, -0.06654665f, 0.09380636f, 0.09531222f, 0.03128810f, 0.05067515f, 
    0.45218006f, -0.19377583f, -0.23883495f, -0.41234097f, -0.17584732f, -0.14938363f, 0.04690758f, 0.08688313f, 
    0.15326090f, 0.04782079f, -0.30160072f, -0.55152035f, 0.00395213f, 0.09909698f, 0.15369360f, -0.00092166f, 
    -0.04960272f, 0.21614684f, -0.38570061f, -0.22626418f, -0.07395723f, -0.27891427f, -0.08002256f, -0.17938338f, 
    0.15694745f, 0.14042862f, 0.30164164f, 0.39210901f, -0.31909540f, 0.29882053f, 0.00621970f, 0.02112685f, 
    0.16067548f, -0.14381157f, -0.05845148f, 0.03298786f, 0.13986810f, -0.58772361f, -0.21764782f, 0.06499147f, 
    0.02545175f, -0.20474777f, -0.07391166f, -0.01120541f, 0.18000191f, 0.00799764f, 0.10865335f, 0.11090050f, 
    -0.01077177f, -0.03091687f, 0.25245374f, -0.03860705f, -0.07389961f, 0.06480058f, -0.82116085f, -0.42650235f, 
    -0.40314460f, 0.16202392f, -0.12131076f, -0.10715964f, 0.09385170f, 0.01792165f, -0.25496733f, -0.54380518f, 
    -0.58429879f, 0.03822261f, 0.15275040f, 0.06321976f, -0.05652385f, 0.19183892f, -0.01513269f, 0.12079516f, 
    0.61021960f, -0.15063946f, -0.04666382f, -0.06156509f, -0.19693314f, -0.10590613f, 0.12047355f, -0.16877517f, 
    -0.15784746f, -0.03021871f, -0.07025215f, -0.07037593f, -0.18373737f, -0.06717653f, 0.19993289f, 0.01636732f, 
    0.19700396f, 0.25083247f, 0.19305372f, -0.04231034f, -0.30739287f, -0.16128792f, -0.04065824f, 0.09794483f, 
    0.21139058f, 0.00344091f, 0.13855080f, 0.72115320f, -0.06823164f, -0.76298183f, 0.09379537f, -0.14772886f, 
    0.23357266f, 0.00617390f, 0.14954615f, -0.13661677f, 0.01509158f, 0.33419228f, 0.33597708f, 0.08570112f, 
    -0.05701624f, 0.10761103f, 0.12079097f, 0.02268913f, 0.18462506f, 0.13805185f, -0.25948036f, -0.21078771f, 
    0.05506175f, 0.07837736f, -0.09861313f, 0.11001911f, -0.06779840f, 0.19066758f, -0.14838563f, 0.11302988f, 
    -0.17828980f, 0.05252213f, 0.01198151f, 0.12675430f, 0.13668744f, 0.16045772f, -0.06665891f, 0.43012679f, 
    -0.49753442f, -0.19293676f, -0.07421487f, 0.14374112f, 0.14344828f, 0.04953694f, 0.06914836f, 0.02037345f, 
    -0.22073722f, -0.32673207f, -0.17988682f, 0.25492379f, 0.14875047f, 0.07044596f, 0.35434869f, -0.10090186f, 
    0.21983440f, 0.24722660f, -0.23853035f, -0.67357826f, -0.18897718f, 0.15642393f, -0.12569794f, 0.17770822f, 
    -0.21378674f, 0.11099057f, 0.37459907f, -0.77215433f, -0.20148140f, -0.15418459f, -0.14223231f, 0.01527180f, 
    -0.14430313f, -0.03977841f, -0.19946547f, 0.33881491f, 0.15718919f, 0.34061536f, 0.09047016f, 0.09943271f, 
    0.05093937f, 0.28650367f, 0.07074613f, 0.19829082f, 0.21622442f, 0.24303365f, 0.43010268f, -0.01893050f, 
    0.04508194f, 0.12847270f, 0.08621220f, -0.01661476f, 0.12462615f, 0.19314712f, 0.21214141f, 0.23731628f, 
    0.04035295f, 0.11552861f, 0.11278826f, 0.26546445f, 0.27316278f, -0.05218812f, -0.27943438f, -0.27463073f, 
    0.24657787f, -0.20837681f, 0.03838523f, -0.06212602f, 0.04728296f, 0.19034086f, 0.03637442f, -0.25612843f, 
    -0.47981530f, -0.32061547f, 0.04892206f, -0.27563873f, -0.07946128f, 0.15831277f, 0.08452603f, -0.01112397f, 
    -0.26545164f, 0.04568376f, -0.25700256f, 0.13244550f, -0.22851691f, -0.21930452f, -0.15911053f, -0.04695397f, 
    -0.09952580f, 0.27221176f, -0.33764836f, -0.16186738f, -0.00672110f, -0.15212397f, -0.10295285f, 0.01802245f, 
    -0.06037620f, -0.04782559f, 0.28289822f, -0.37289363f, -0.49124727f, -0.31988636f, -0.22626756f, -0.24983782f, 
    0.08506013f, 0.09264737f, 0.29023114f, 0.62790549f, -0.11101753f, -0.02403772f, -0.08628172f, -0.04847863f, 
    0.08126886f, 0.15497503f, 0.03884163f, 0.03272640f, -1.00360608f, -0.37974706f, -0.19300483f, 0.26110956f, 
    -0.20317942f, 0.07944670f, 0.11441837f, 0.05835751f, -0.09048414f, -0.08498792f, 0.12043598f, 0.00502212f, 
    -0.03585273f, -0.03193327f, -0.01539933f, 0.10975681f, -0.06904090f, 0.10313150f, 0.02587087f, -0.07104366f, 
    -0.15376312f, -0.01578969f, -0.05310478f, 0.06690305f, 0.02309559f, 0.03077644f, -0.20291080f, -0.67211646f, 
    0.14517058f, -0.62126571f, -0.00746055f, -0.21512176f, -0.19471899f, 0.24239834f, -0.01180549f, -0.10844079f, 
    0.02596709f, 0.00250076f, 0.02256598f, 0.01000095f, 0.00809402f, 0.02585971f, -0.05183516f, 0.01298689f, 
    0.00921278f, -0.06257577f, 0.01422325f, 0.01659514f, -0.05446651f, 0.03402536f, -0.00307650f, -0.05658157f, 
    -0.04670726f, -0.06742018f, 0.02459210f, -0.06140312f, -0.05555882f, -0.05116777f, -0.04874932f, -0.00199173f, 
    -0.04268960f, -0.06157248f, -0.05239419f, 0.01941240f, -0.06376096f, -0.01608523f, -0.04996037f, -0.04850163f, 
    0.05039378f, 0.02959464f, 0.04536948f, -0.04421907f, -0.00175270f, -0.03085156f, 0.02969953f, -0.00974288f, 
    0.05045060f, -0.06499406f, -0.00114555f, -0.04933793f, -0.03299930f, 0.00716612f, -0.00352733f, -0.06596807f, 
    0.04227645f, -0.00398076f, 0.03807640f, -0.02687341f, 0.02464874f, -0.00637674f, -0.00156426f, 0.01567795f, 
    0.02686921f, -0.03109781f, -0.00557539f, -0.04820233f, -0.03238264f, 0.03597523f, 0.01977021f, -0.04864857f, 
    -0.01547561f, 0.00258101f, -0.01859474f, 0.03155141f, -0.03218235f, 0.01679499f, 0.02642394f, 0.02006311f, 
    0.02517588f, -0.00110796f, 0.03899749f, 0.05002451f, -0.00531848f, -0.01107835f, 0.01417512f, -0.05042943f, 
    -0.00936300f, -0.05730036f, 0.04834671f, -0.06457286f, -0.02978090f, 0.03228909f, 0.04009317f, 0.01547352f, 
    0.01364258f, 0.02640289f, 0.02301375f, -0.01793799f, 0.02954723f, 0.00949973f, 0.01049492f, 0.05092499f, 
    -0.05259149f, 0.01840637f, -0.02363442f, -0.01933728f, -0.01581649f, -0.04589233f, -0.04271354f, -0.03471676f, 
    0.00468665f, -0.06263252f, -0.00493565f, 0.04006299f, -0.02106963f, -0.05014588f, 0.01380101f, -0.06097826f, 
    -0.00125281f, -0.04904387f, -0.06316382f, -0.02813833f, 0.01121781f, -0.06423043f, 0.03055227f, -0.02060642f, 
    -0.03978495f, -0.03273952f, -0.02530075f, 0.02087538f, 0.03880002f, 0.04374440f, 0.03572562f, -0.01202498f, 
    -0.05192826f, 0.04149904f, -0.03565187f, 0.03745922f, 0.02822774f, -0.00891253f, -0.01513756f, 0.01582973f, 
    -0.04364103f, -0.03088739f, -0.04874728f, -0.03816305f, -0.05257428f, 0.00163263f, -0.05281768f, 0.01435161f, 
    0.03401266f, -0.06317190f, -0.00339010f, -0.01247102f, 0.00041705f, 0.02882442f, 0.05713092f, 0.00100050f, 
    0.03011510f, -0.03149336f, 0.02290558f, -0.06215591f, -0.05451454f, -0.02158795f, -0.02274602f, -0.00159006f, 
    -0.00884655f, -0.02909559f, -0.02782152f, 0.02123897f, -0.03339027f, -0.05120123f, -0.05276060f, -0.02783769f, 
    -0.01704206f, -0.03348145f, -0.03079460f, -0.00841220f, 0.00310223f, -0.01738420f, -0.00300528f, 0.00479309f, 
    0.02010077f, 0.00332085f, -0.04058944f, 0.00159682f, 0.00993575f, 0.04298307f, -0.06482452f, 0.01681164f, 
    -0.00105507f, -0.00316517f, -0.05493491f, 0.00677642f, 0.00055136f, -0.04971391f, -0.01335780f, -0.04624150f, 
    0.00717574f, 0.03413285f, 0.00608508f, 0.04637287f, -0.00075491f, -0.00064188f, -0.01912580f, -0.02808494f, 
    -0.03269069f, 0.00485224f, 0.01228419f, -0.02288545f, -0.02163119f, -0.04230979f, 0.00243428f, 0.04741970f, 
    -0.01280530f, 0.05080818f, 0.03306936f, -0.01018634f, -0.04807404f, -0.06273706f, 0.05289158f, -0.02949115f, 
    -0.01644652f, 0.04170929f, -0.06663064f, -0.05260606f, 0.02662741f, 0.03213419f, -0.03789356f, 0.01190612f, 
    0.01997292f, 0.00424652f, 0.03228647f, -0.01295688f, 0.02161929f, 0.04756474f, 0.01520610f, -0.00202714f, 
    -0.01176274f, 0.03450047f, -0.03916023f, -0.04201872f, 0.03679935f, 0.02055048f, -0.02824570f, 0.00425831f, 
    0.01084403f, -0.00886269f, -0.05474040f, -0.02246820f, -0.02807514f, 0.03754465f, 0.02843305f, -0.02030031f, 
    -0.06208859f, -0.04691684f, -0.02505093f, 0.04310151f, 0.03188933f, -0.00443582f, 0.03760941f, 0.03082308f, 
    -0.05426002f, 0.02682242f, 0.03686549f, 0.02340554f, -0.02429526f, -0.03660326f, -0.02644924f, -0.05616239f, 
    -0.01966110f, -0.03472599f, 0.00275396f, -0.00620496f, 0.02275070f, -0.03909583f, 0.03263247f, 0.02499743f, 
    0.02981642f, 0.00441749f, 0.01730087f, -0.05372683f, 0.00759379f, 0.05219530f, 0.00362994f, 0.04021328f, 
    -0.05203202f, -0.02812607f, -0.03975600f, -0.00577268f, -0.00244934f, -0.04526845f, 0.01596559f, 0.01961660f, 
    0.25744718f, 0.04426578f, -0.03716598f, -0.14528243f, 0.25705385f, 0.12794958f, -0.18735847f, 0.08158085f, 
    0.04630953f, -0.32246444f, -0.26994795f, -0.41351750f, -0.03253528f, 0.04534261f, 0.11735737f, -0.10820196f, 
    -0.23177914f, -0.19542341f, 0.01000873f, -0.01457458f, 0.30241781f, 0.17081121f, 0.07942822f, -0.07570420f, 
    0.04971090f, 0.01456026f, 0.08548527f, 0.14630537f, -0.04552633f, 0.36705625f, 0.02770370f, 0.10890636f, 
    0.13563254f, -0.05453169f, -0.05469513f, -0.04194404f, 0.42853463f, 0.18950355f, 0.49314609f, 0.06697414f, 
    0.00370672f, -0.17015263f, -0.05239715f, -0.09020470f, -0.03226892f, -0.07222393f, -0.04093688f, 0.02153185f, 
    -0.26891685f, -0.03116505f, 0.27010703f, 0.07436410f, -0.22855680f, -0.25123715f, 0.01042808f, 0.04832832f, 
    0.39755097f, 0.07429683f, -0.06960183f, -0.20148441f, -0.01347293f, 0.02953710f, 0.05738955f, -0.06929830f, 
    0.04521533f, 0.26128697f, 0.01041551f, -0.16645879f, -0.07058824f, 0.03285550f, -0.12717360f, -0.00784435f, 
    0.04578151f, -0.13165994f, 0.07669020f, -0.00668700f, -0.11310419f, -0.05843315f, -0.04603115f, 0.05472758f, 
    0.17982119f, 0.11509196f, 0.00044727f, 0.00864357f, 0.02610976f, 0.03044828f, 0.10376642f, 0.15229955f, 
    -0.11678525f, -0.03272538f, 0.22232455f, 0.07262181f, -0.07113634f, 0.08659916f, -0.06366004f, 0.27147421f, 
    0.13106394f, 0.22811827f, -0.42797789f, 0.40324840f, -0.06140221f, -0.11352752f, 0.09781835f, 0.07263412f, 
    -0.09278948f, -0.06979974f, -0.09994874f, -0.00621177f, -0.31827292f, -0.00936334f, -0.41545781f, 0.03315628f, 
    0.09045594f, -0.13988952f, 0.13107644f, 0.06975202f, -0.03066849f, 0.23868012f, 0.11519031f, -0.00565914f, 
    0.15055443f, 0.06965503f, -0.01206622f, -0.02337199f, -0.05194919f, -0.11704643f, 0.05641998f, 0.08319027f, 
    0.07676646f, 0.11579104f, -0.01181865f, 0.03726806f, 0.00830925f, 0.09037913f, 0.22354944f, -0.24244554f, 
    0.05448696f, 0.01110372f, -0.06248387f, -0.00543265f, 0.06289037f, -0.22813465f, -0.04896016f, -0.13200215f, 
    0.18095270f, 0.07888224f, -0.00026315f, 0.17110135f, 0.04643870f, 0.04173061f, -0.05402204f, -0.04832065f, 
    -0.07068004f, 0.07840893f, -0.01363880f, 0.16433193f, 0.12824248f, 0.04790418f, 0.04193368f, -0.15767932f, 
    -0.11621209f, -0.06104337f, -0.08062096f, -0.06163036f, 0.33788976f, -0.17266321f, 0.04611125f, -0.17485909f, 
    -0.00770400f, -0.08955584f, -0.05817979f, -0.03972265f, 0.03867556f, 0.23510614f, 0.01864722f, -0.18818086f, 
    -0.06839430f, 0.07291877f, 0.06567252f, -0.01711876f, 0.13812982f, -0.03190813f, 0.21437477f, -0.26060700f, 
    -0.24581778f, -0.12472035f, 0.07970959f, -0.01287566f, -0.00851928f, -0.16044094f, 0.03765970f, -0.12122216f, 
    -0.05548348f, -0.28116804f, -0.08581288f, 0.12058493f, -0.06137965f, -0.09386066f, 0.18662031f, -0.07189462f, 
    0.13912696f, -0.06320690f, -0.11826932f, -0.10235561f, -0.00874422f, 0.00646920f, 0.19947234f, 0.03888133f, 
    -0.01836028f, 0.04194001f, 0.17192672f, -0.14073770f, 0.01680537f, -0.14889999f, 0.06166347f, 0.10108445f, 
    0.12251417f, -0.08323618f, 0.36827719f, 0.05497416f, -0.00368205f, -0.27125147f, -0.06358485f, -0.05560035f, 
    0.04215857f, 0.02042411f, 0.19413194f, 0.19328186f, -0.08824063f, 0.03058982f, -0.01561952f, -0.00826643f, 
    0.06572413f, 0.04522267f, 0.11374549f, -0.02204054f, -0.11573141f, 0.10501398f, 0.08457645f, 0.08317011f, 
    0.09086211f, 0.00043348f, -0.04966727f, 0.28531691f, -0.04525745f, -0.23302628f, 0.01358213f, 0.00618524f, 
    0.07460603f, -0.15956502f, -0.25064793f, -0.20709780f, -0.08357430f, 0.13073003f, 0.40006259f, 0.00613574f, 
    -0.03508074f, -0.07021744f, 0.11798645f, -0.01663401f, -0.01955906f, 0.06443916f, -0.01678929f, 0.08778950f, 
    0.05797998f, -0.10530220f, 0.04402117f, -0.08201031f, 0.04564892f, -0.05325498f, -0.58611745f, -0.27022392f, 
    0.27776536f, -0.03582501f, 0.01734561f, 0.16071680f, -0.03189499f, -0.04075386f, -0.05042569f, 0.00416312f, 
    -0.08945299f, -0.02944395f, 0.08683518f, -0.05666642f, -0.05759288f, 0.07041960f, -0.20709614f, 0.03558863f, 
    -0.02529616f, -0.17726882f, -0.24665354f, 0.22196424f, 0.06668942f, 0.04063563f, -0.03343247f, -0.08761518f, 
    0.05132362f, -0.45070645f, 0.26843658f, 0.16728306f, 0.02889447f, 0.04200931f, 0.01638723f, -0.14198275f, 
    0.11441291f, -0.14230180f, -0.04378171f, -0.35157824f, -0.20644139f, -0.07312065f, -0.00586865f, 0.14358506f, 
    0.09645487f, 0.17961667f, 0.21235895f, 0.08292495f, 0.14457828f, 0.17939895f, -0.00393956f, -0.07316915f, 
    0.25686729f, 0.19113655f, 0.02069716f, 0.13105264f, 0.21841462f, -0.17291158f, 0.06279399f, -0.02680445f, 
    -0.09894112f, -0.07651034f, -0.01865003f, -0.05411259f, 0.02588282f, -0.26890373f, 0.57171559f, 0.44442528f, 
    -0.07289684f, -0.13718471f, 0.03812816f, 0.14784181f, 0.02429950f, 0.06166764f, -0.22461863f, -0.26964113f, 
    0.25934383f, 0.06614385f, -0.05820584f, -0.18525739f, -0.14166525f, 0.03288424f, -0.01589200f, -0.43740937f, 
    -0.00751224f, -0.12596191f, 0.09132648f, -0.06675290f, 0.18473220f, 0.13496545f, -0.02976637f, 0.02941391f, 
    0.07457925f, -0.00497956f, -0.12282043f, 0.01673135f, -0.05297012f, -0.02452095f, -0.02274824f, -0.07325864f, 
    0.00860635f, 0.00572371f, 0.01949052f, 0.03472116f, 0.05064871f, 0.09327962f, 0.16391289f, 0.04523630f, 
    0.09460216f, 0.03222419f, -0.02460147f, -0.10792328f, -0.41524985f, -0.00930422f, -0.01934534f, -0.03573877f, 
    -0.08254492f, 0.08005769f, 0.00567818f, 0.16968457f, -0.09337696f, -0.14765684f, 0.09362751f, 0.00470678f, 
    0.05962922f, 0.17746514f, -0.05241739f, 0.11979347f, 0.17788447f, 0.16227451f, -0.17051433f, -0.02839480f, 
    -0.13695760f, 0.02385157f, 0.05182086f, 0.05141081f, 0.13923027f, 0.12700985f, -0.02284268f, 0.13058142f, 
    0.00011444f, -0.00191844f, -0.09720345f, -0.08011301f, -0.22332184f, -0.00892405f, 0.02738294f, 0.01352349f, 
    0.28703403f, 0.01332728f, 0.07528646f, 0.19118644f, 0.07763021f, 0.15597296f, 0.11901867f, -0.32250288f, 
    0.17536464f, 0.00628919f, 0.04079245f, 0.03495207f, 0.03349647f, 0.03600271f, 0.13327010f, -0.03413137f, 
    0.13903101f, -0.01458178f, 0.07050674f, -0.07011205f, -0.03280767f, 0.04178992f, 0.02651005f, 0.02112143f, 
    0.00256287f, 0.12587680f, 0.02738526f, 0.04750495f, -0.16610204f, -0.07553218f, 0.03799925f, -0.13873126f, 
    -0.07350908f, 0.14594726f, 0.11757894f, 0.04102881f, 0.30717328f, -0.03713106f, -0.14174026f, -0.05111218f, 
    -0.11920193f, 0.05598711f, -0.04538859f, -0.31105995f, 0.38828710f, 0.10705902f, -0.05150070f, -0.29152247f, 
    -0.07752401f, -0.02771516f, -0.00500624f, 0.02112689f, -0.19050622f, 0.23708774f, 0.14835237f, 0.00861268f, 
    -0.14170697f, -0.04280748f, 0.11688757f, 0.19957474f, 0.09766312f, -0.09731441f, 0.16950306f, -0.41717452f, 
    -0.04223600f, -0.01903096f, -0.15098321f, -0.02263824f, -0.00794453f, -0.11334056f, 0.04970180f, 0.24469203f, 
    0.28711024f, 0.09609188f, 0.15995334f, 0.18733297f, 0.17845047f, -0.10864113f, 0.12591013f, 0.08436265f, 
    0.14277400f, 0.29384074f, -0.25752658f, -0.04900955f, -0.09815560f, 0.14864266f, 0.12360618f, 0.02590484f, 
    0.25349870f, -0.36804017f, -0.26636028f, -0.03954208f, -0.09204300f, -0.24879675f, -0.00919309f, -0.01581090f, 
    0.01136273f, -0.01387086f, -0.03354745f, 0.15445824f, -0.01461008f, 0.12214144f, -0.14125885f, 0.03618698f, 
    -0.11980600f, 0.04652838f, 0.04782546f, 0.05218815f, 0.06134440f, -0.08078302f, -0.13517876f, -0.06037368f, 
    -0.10330326f, -0.07367293f, 0.05326565f, 0.15126978f, 0.05761805f, 0.05607016f, -0.14421956f, -0.08345164f, 
    -0.20162892f, -0.04546470f, -0.25989509f, -0.22478798f, -0.19639400f, -0.17879678f, 0.41686505f, 0.11369658f, 
    0.13762914f, -0.23253711f, -0.04192086f, 0.04766956f, -0.03251762f, -0.53466249f, 0.14001542f, 0.10451641f, 
    -0.10530819f, 0.00998144f, -0.13517261f, -0.07615615f, -0.01653169f, -0.10627944f, -0.21385688f, -0.55706668f, 
    -0.14825618f, 0.22086520f, 0.01195599f, -0.10453995f, -0.02342065f, -0.05501334f, 0.08596353f, -0.10433111f, 
    -0.13571876f, 0.09450813f, -0.03358327f, 0.14688537f, 0.03063353f, 0.04170398f, 0.18702602f, 0.05495666f, 
    -0.08961338f, -0.05740532f, -0.35886070f, -0.07607989f, -0.14890742f, 0.26478058f, 0.20860018f, 0.18274786f, 
    -0.02604129f, -0.14121741f, -0.06267066f, -0.16785598f, -0.18999302f, 0.18375148f, -0.22814010f, -0.03141518f, 
    0.06002410f, 0.04914059f, -0.01966932f, 0.04594086f, 0.37615949f, 0.03820202f, -0.20649658f, 0.08303126f, 
    0.16339870f, 0.15224630f, 0.00251338f, -0.16736016f, 0.12462726f, -0.01092633f, -0.04384574f, 0.06594867f, 
    -0.06358057f, -0.13524590f, -0.09209994f, 0.01651638f, 0.25810474f, -0.16331930f, 0.02563145f, -0.11655486f, 
    -0.00960273f, -0.15430911f, -0.05125307f, 0.17193948f, 0.15762506f, 0.28107709f, 0.12967147f, -0.10420690f, 
    -0.05255660f, 0.00509473f, 0.02335619f, -0.04328414f, 0.07162368f, -0.12165896f, 0.07909147f, -0.17732202f, 
    -0.01615228f, -0.11682863f, 0.03413495f, 0.10118189f, 0.20369244f, 0.07861316f, -0.06585099f, 0.01762157f, 
    0.34042516f, 0.07785154f, 0.27355242f, -0.35250971f, -0.10597212f, 0.37733123f, 0.14154892f, -0.10701234f, 
    -0.16331156f, -0.02524978f, 0.10635784f, -0.09894686f, 0.06613572f, -0.04200062f, 0.10126362f, -0.10606830f, 
    -0.03889610f, -0.00900305f, -0.03027952f, 0.06224222f, -0.02127129f, 0.11188390f, -0.18041058f, 0.09560353f, 
    0.26342309f, -0.07202039f, -0.06693357f, -0.02620417f, -0.09624872f, 0.07049186f, 0.00722211f, -0.01142190f, 
    0.17729409f, 0.14389323f, -0.16656618f, -0.05363560f, -0.00967854f, 0.01564129f, 0.04711797f, -0.16096053f, 
    0.12736806f, -0.13664889f, 0.13018666f, -0.10597035f, 0.12490471f, 0.09657014f, -0.38175762f, -0.15070480f, 
    0.01791589f, -0.06596481f, -0.04061733f, -0.08652952f, -0.17222357f, 0.30713245f, 0.14217025f, -0.08571278f, 
    -0.24788019f, 0.09057012f, 0.01318057f, -0.08724772f, 0.01874908f, -0.16952053f, -0.18276858f, -0.04631339f, 
    -0.11877986f, 0.05964402f, 0.06499828f, -0.01845863f, 0.16794160f, -0.01223591f, -0.00252920f, 0.06085222f, 
    0.07821687f, -0.22522642f, -0.01699549f, 0.02773975f, -0.06227809f, -0.11737428f, 0.03635269f, 0.12088227f, 
    0.33567491f, 0.12060511f, -0.10678587f, 0.08263525f, 0.06270428f, -0.08364466f, -0.15449068f, 0.17683017f, 
    -0.00400039f, -0.02590903f, 0.19500887f, 0.02054402f, -0.02067594f, 0.31465602f, -0.02758463f, -0.04149684f, 
    0.12661955f, 0.06333945f, 0.35960293f, 0.09539058f, -0.06254350f, -0.04816864f, 0.10977505f, -0.11480619f, 
    0.12494944f, 0.04159391f, -0.31058013f, 0.52718920f, 0.17713980f, -0.32130924f, -0.08314501f, -0.00778754f, 
    -0.03333678f, 0.02343031f, 0.05974815f, -0.01551477f, 0.24729578f, 0.07956997f, -0.14148030f, -0.01771754f, 
    0.00946324f, -0.00841787f, -0.10593808f, 0.04384270f, 0.08765198f, 0.10355670f, 0.00933379f, -0.25873995f, 
    -0.03951950f, -0.21198319f, 0.10547103f, 0.11044796f, -0.06117894f, 0.07994419f, -0.04215820f, -0.06551957f, 
    -0.05285899f, 0.09135611f, 0.16236271f, -0.30146733f, -0.07061814f, 0.10909790f, 0.29397964f, -0.22651435f, 
    0.05705146f, 0.12711498f, 0.15952669f, -0.01572695f, -0.07565999f, -0.10237566f, 0.19686595f, 0.25504687f, 
    -0.10394254f, 0.01127841f, -0.11244635f, -0.28546461f, 0.00160610f, 0.06194296f, 0.01206981f, 0.00574692f, 
    0.00453917f, -0.04000971f, 0.12210400f, -0.13296349f, -0.16725366f, -0.04143455f, -0.03369177f, 0.11170948f, 
    -0.15462969f, -0.28175670f, 0.01072429f, -0.06692763f, -0.22907244f, -0.10957309f, 0.06691054f, -0.07184698f, 
    -0.02090827f, -0.00287169f, -0.02085717f, 0.07014482f, 0.12267041f, -0.01480258f, -0.03704736f, -0.17190497f, 
    0.03959791f, -0.08308084f, 0.05551116f, -0.00839049f, -0.04036815f, -0.02730168f, 0.00172412f, -0.24909735f, 
    0.16544163f, 0.10879332f, 0.08962814f, 0.12978542f, -0.02659615f, 0.29464844f, 0.01843637f, -0.33281004f, 
    0.18475817f, 0.15343833f, 0.07205891f, -0.22322249f, -0.06531082f, 0.09803052f, 0.20517738f, -0.00945403f, 
    -0.15856703f, 0.00278290f, 0.20850025f, -0.01214061f, -0.08894055f, -0.08343311f, 0.06268022f, -0.07723972f, 
    -0.21900624f, -0.24758898f, 0.07717488f, 0.05989540f, 0.07508159f, 0.00693688f, -0.13477014f, -0.11399923f, 
    -0.51960379f, -0.34007248f, -0.06855112f, 0.02649605f, 0.10755500f, 0.12068680f, -0.00122244f, -0.15395454f, 
    0.08797181f, 0.29720861f, 0.08836047f, -0.47654483f, -0.19229195f, 0.06647549f, -0.08106280f, 0.01955276f, 
    -0.03771137f, -0.07607266f, -0.36180276f, 0.01725441f, -0.16755740f, -0.04814896f, 0.14279336f, 0.16248739f, 
    -0.02688376f, -0.00419018f, 0.01130970f, 0.24950886f, -0.06303670f, -0.09705674f, -0.04770714f, -0.01060924f, 
    0.02847015f, 0.13141301f, 0.06580748f, 0.00913071f, 0.15138158f, 0.03718472f, 0.14476317f, 0.05980981f, 
    -0.05889608f, 0.08642017f, -0.03365260f, -0.23825404f, 0.11667423f, 0.73696327f, 0.43652928f, -0.13158648f, 
    -0.19102523f, -0.00428730f, 0.08597263f, 0.14088370f, 0.06028728f, 0.16524680f, -0.04633992f, 0.03529724f, 
    0.19187361f, -0.01331502f, 0.03695930f, 0.04045305f, -0.11855874f, -0.33095318f, 0.12613645f, 0.01695904f, 
    0.12588705f, -0.00214844f, 0.00611635f, 0.07682722f, -0.16592126f, 0.24990207f, -0.14174490f, 0.07655723f, 
    -0.04297060f, -0.07501149f, 0.11164396f, 0.06447663f, -0.03141646f, 0.01161241f, 0.01412384f, -0.14318450f, 
    0.10842724f, 0.10712165f, 0.30782139f, -0.03434623f, 0.01448253f, 0.01138318f, 0.05682668f, -0.07672710f, 
    0.16062114f, 0.01720848f, -0.00408142f, -0.12772237f, 0.06723434f, 0.05089467f, 0.04692198f, 0.00080040f, 
    0.10707218f, -0.02715191f, -0.00606450f, -0.11289125f, -0.12786622f, -0.02603126f, -0.07126564f, -0.01827394f, 
    -0.01565442f, 0.15468627f, 0.10282699f, 0.04732394f, 0.18609807f, -0.15112723f, -0.44399321f, 0.05099153f, 
    -0.05353417f, -0.21842735f, -0.12751709f, 0.14849854f, -0.04035082f, 0.14412980f, 0.09836403f, 0.15779728f, 
    0.08630623f, 0.01296210f, -0.01481566f, 0.00738202f, -0.11164717f, 0.02141512f, -0.13237481f, 0.10929073f, 
    -0.07761532f, -0.01705537f, 0.16455302f, -0.21813479f, -0.04285067f, 0.12163480f, -0.00297151f, 0.25458407f, 
    0.11260381f, -0.46756962f, -0.33941942f, -0.02687528f, -0.20052481f, 0.02068485f, 0.00703704f, -0.05769661f, 
    0.12956721f, 0.03933687f, 0.18802769f, 0.02006221f, 0.04403978f, -0.02814702f, -0.07820280f, -0.06582483f, 
    0.07719567f, 0.18771248f, 0.03428677f, 0.09367154f, 0.17924544f, 0.25761160f, 0.10414978f, -0.15636405f, 
    0.07977420f, -0.00491199f, 0.01137142f, 0.09623194f, 0.11316276f, 0.21112975f, 0.09580866f, 0.12415162f, 
    0.20042951f, 0.28470874f, -0.06301706f, 0.61394590f, 0.32917461f, -0.29389489f, -0.08364558f, -0.06569573f, 
    -0.12675931f, 0.01099465f, -0.00888031f, -0.17871688f, 0.41560659f, 0.21728237f, -0.02410267f, -0.06942376f, 
    -0.02008021f, -0.07003259f, -0.01278362f, 0.04264680f, -0.01004077f, 0.18498893f, 0.01583301f, -0.53020799f, 
    -0.01166696f, -0.00099904f, -0.18136609f, -0.14676790f, -0.01932339f, 0.06645446f, 0.14192508f, 0.00347463f, 
    0.14204328f, -0.07184219f, -0.09431875f, -0.07959083f, 0.22139859f, -0.14130253f, 0.10380209f, 0.09722109f, 
    0.08279055f, 0.02579506f, -0.06234685f, -0.01445490f, -0.27209961f, -0.03815443f, -0.03670040f, 0.11163912f, 
    -0.19284980f, -0.21001993f, 0.05259970f, 0.00095194f, -0.00946221f, 0.08678769f, -0.13159613f, 0.07542489f, 
    0.17581303f, -0.00426784f, 0.04892763f, 0.17299123f, 0.06031697f, 0.10434005f, 0.07211043f, 0.01228713f, 
    -0.01168863f, 0.04826087f, 0.17455930f, 0.15049335f, 0.25041538f, -0.16886893f, -0.11674051f, -0.37117779f, 
    -0.05445481f, -0.18637761f, -0.11910533f, 0.21470569f, 0.11983874f, 0.19510764f, 0.06979176f, -0.11389659f, 
    -0.12671331f, -0.09867300f, -0.24938463f, 0.19717465f, 0.01866072f, 0.11829695f, 0.19203578f, 0.07317130f, 
    0.21907538f, 0.08431869f, -0.03546970f, -0.02563145f, -0.06522560f, 0.26469907f, 0.33772397f, -0.12116386f, 
    -0.14298241f, -0.07678561f, -0.10624742f, 0.07515749f, -0.06860652f, -0.08762313f, -0.18597631f, -0.11977129f, 
    -0.04180157f, -0.17169055f, 0.18139513f, -0.07335326f, 0.22361723f, 0.11213237f, -0.02856941f, 0.07597543f, 
    0.04452305f, -0.00615769f, -0.29222140f, -0.02460166f, 0.05043890f, 0.15469883f, -0.20261575f, -0.12970534f, 
    -0.03689832f, 0.11687979f, -0.17140275f, -0.06652275f, 0.03587279f, 0.10901496f, 0.33045846f, 0.21300741f, 
    0.03975550f, -0.29653534f, -0.30081511f, -0.05238840f, 0.01025240f, 0.04726091f, 0.13219967f, -0.01183217f, 
    0.02987647f, -0.00636310f, -0.20060094f, -0.02430165f, 0.33931851f, -0.07603384f, 0.01151007f, -0.21745141f, 
    0.04934786f, 0.30197471f, 0.35465604f, 0.04523887f, 0.22798076f, 0.36194474f, -0.01760357f, 0.14065512f, 
    0.20061803f, 0.08232981f, 0.09083588f, 0.11545020f, 0.06707989f, 0.31135666f, 0.17673098f, -0.02868062f, 
    -0.19411337f, -0.07173728f, 0.06388992f, 0.08072128f, 0.01857874f, -0.07738069f, 0.03233844f, 0.17344387f, 
    -0.19526795f, -0.00786119f, -0.02484806f, 0.09299928f, -0.00631081f, 0.01473416f, 0.05134020f, 0.17984961f, 
    0.22607170f, 0.09164063f, -0.10016423f, -0.07700542f, 0.04503783f, 0.05603059f, -0.04073741f, -0.00116056f, 
    0.27876654f, 0.03996427f, -0.03985132f, 0.10456108f, 0.24292718f, 0.10978162f, -0.04167710f, -0.08167402f, 
    0.07850847f, -0.12846766f, 0.08560978f, -0.04789808f, 0.00592984f, -0.09832601f, 0.00398588f, -0.04104661f, 
    -0.23599926f, 0.08770958f, -0.05063942f, 0.10080814f, -0.07185188f, 0.20851453f, 0.10500133f, -0.18167269f, 
    0.20702469f, 0.21810463f, -0.07873426f, -0.14010960f, -0.13294178f, 0.10947008f, 0.03044239f, -0.00495535f, 
    0.18011588f, 0.05811301f, 0.08610550f, 0.24196304f, 0.02707869f, 0.02828262f, 0.07783411f, 0.01140246f, 
    0.01288189f, 0.04471415f, -0.03548836f, 0.03301390f, 0.03535763f, -0.01747217f, -0.19982128f, -0.14067446f, 
    -0.01426373f, -0.00144634f, 0.16423805f, 0.12492103f, -0.07445940f, 0.09763852f, 0.06347618f, 0.14060439f, 
    -0.10319175f, -0.24435973f, -0.20352852f, -0.15465818f, -0.02762435f, -0.00011808f, -0.04125360f, 0.16961354f, 
    0.12565933f, -0.03114196f, -0.17380267f, 0.37832713f, -0.11027521f, 0.12043997f, 0.06687538f, -0.29901108f, 
    -0.05022769f, -0.12198887f, 0.10938453f, 0.06808504f, 0.02061580f, -0.11213611f, 0.04404561f, -0.11131085f, 
    0.15674709f, 0.13182485f, 0.12429198f, 0.02825378f, -0.12381384f, -0.06872488f, -0.05048351f, -0.04786205f, 
    0.16296704f, 0.12437060f, 0.20556381f, 0.21068807f, -0.18722816f, 0.10895936f, -0.00432039f, -0.18679565f, 
    -0.07793079f, 0.22205333f, 0.00744011f, 0.22683419f, 0.17097501f, -0.08172057f, -0.04053924f, -0.18663675f, 
    -0.05269249f, 0.15286420f, -0.10431750f, -0.23689644f, -0.03159218f, -0.08500917f, -0.18031751f, -0.12520963f, 
    0.04210066f, 0.12672375f, 0.08858668f, 0.09985918f, 0.00315342f, -0.02837432f, 0.26338014f, -0.09529363f, 
    -0.21147569f, -0.10360068f, 0.06628401f, 0.22857040f, -0.01511729f, -0.07912860f, 0.17856652f, -0.18629715f, 
    -0.11382473f, 0.04240942f, 0.16227585f, 0.00774293f, 0.01612997f, 0.03331441f, 0.04754332f, -0.07873254f, 
    0.34055644f, 0.16451064f, 0.07650289f, -0.05369704f, 0.05688911f, 0.05987706f, 0.26892063f, -0.11163156f, 
    -0.01013880f, 0.41844177f, -0.18401885f, -0.10291284f, 0.18585640f, -0.33577767f, 0.24190086f, -0.02189135f, 
    -0.17545517f, 0.11670738f, 0.04453833f, -0.04555969f, -0.18373872f, -0.07107805f, 0.10913731f, 0.04695517f, 
    -0.09962496f, 0.13353750f, -0.03989262f, 0.13750878f, -0.15587661f, 0.07676253f, -0.16048099f, 0.27688736f, 
    -0.07855056f, -0.01821813f, -0.01224233f, -0.00353039f, 0.01408653f, -0.03515089f, -0.04134625f, -0.01947261f, 
    -0.12396459f, 0.14186302f, 0.09475098f, 0.07858229f, -0.05678498f, 0.12865581f, -0.12832558f, 0.02553178f, 
    0.05180452f, -0.22688167f, -0.07122219f, -0.09672514f, -0.10893504f, -0.00676824f, 0.31828496f, 0.11135340f, 
    -0.10509453f, -0.17157537f, 0.08919264f, -0.08520726f, -0.07291842f, -0.41617680f, -0.03790060f, 0.01350742f, 
    0.01845019f, -0.08756317f, -0.24751295f, -0.18098773f, -0.24868624f, -0.24911855f, -0.25486553f, -0.11966574f, 
    0.27337825f, -0.06120005f, 0.08778545f, 0.03011440f, -0.33176345f, -0.02497296f, 0.08143947f, 0.01048994f, 
    -0.10546210f, 0.18135554f, 0.16271171f, -0.19003849f, 0.14152963f, -0.04864237f, 0.05716709f, 0.07236897f, 
    -0.35727385f, -0.33377600f, -0.02468860f, 0.11684871f, -0.00635796f, 0.19019373f, 0.03963955f, -0.14211836f, 
    0.09555721f, 0.41439873f, -0.07201594f, 0.18002231f, -0.02284816f, -0.00186780f, -0.24275149f, 0.12223195f, 
    0.10020170f, -0.00395281f, -0.08271436f, -0.78776020f, -0.31582224f, -0.01852631f, -0.15884560f, 0.01671360f, 
    -0.10851522f, 0.16368899f, 0.16636786f, -0.34138364f, -0.15080585f, 0.09937422f, 0.17242880f, 0.12365323f, 
    0.01747738f, 0.02491263f, -0.00793964f, 0.44825599f, 0.33072874f, -0.39691091f, -0.18855990f, 0.01095177f, 
    -0.09888778f, -0.03122549f, 0.00116893f, -0.02582167f, -0.00177022f, 0.15796249f, -0.12515850f, 0.20976500f, 
    0.11866421f, 0.17227383f, 0.00314596f, -0.05236321f, -0.20272550f, 0.18849875f, -0.01238766f, -0.27305806f, 
    -0.05585690f, -0.04321071f, -0.01176978f, 0.04465859f, -0.06119044f, -0.04702327f, -0.02358790f, -0.43725079f, 
    0.01682036f, 0.07979938f, -0.01223207f, 0.06146851f, 0.07138330f, -0.06967261f, -0.06282073f, 0.21507052f, 
    0.03534890f, -0.11649375f, -0.05063403f, 0.04790834f, -0.03229017f, -0.06897826f, 0.17138474f, -0.12381201f, 
    0.08919013f, 0.03796680f, -0.12175240f, -0.05300407f, 0.12031689f, 0.05830767f, 0.24970502f, -0.10491879f, 
    -0.08158856f, -0.25258985f, -0.03064639f, -0.05082273f, 0.10710883f, 0.02822329f, 0.15537667f, 0.07910835f, 
    -0.22462337f, -0.16915211f, 0.19617097f, -0.12659127f, 0.17549604f, -0.46637565f, -0.03558416f, -0.02682938f, 
    0.10615359f, 0.04885839f, 0.02803080f, -0.05080562f, -0.11552289f, 0.01913461f, -0.23493223f, 0.15562256f, 
    -0.01906760f, 0.20334023f, 0.00976179f, 0.13503933f, -0.00119694f, 0.19827867f, 0.03001284f, -0.11072836f, 
    -0.09892038f, -0.06745073f, -0.02113975f, 0.05441540f, 0.13774413f, -0.02940200f, -0.13801986f, -0.00682797f, 
    0.13969700f, -0.01871116f, 0.12452433f, 0.33889908f, 0.03347431f, -0.06695460f, -0.17644241f, 0.11706058f, 
    -0.06712294f, 0.08666103f, 0.02857422f, -0.06582467f, -0.06644737f, 0.08821923f, 0.18601321f, -0.07075521f, 
    0.01952015f, -0.08845665f, 0.12273232f, 0.00001016f, -0.00733493f, 0.14527135f, 0.06758545f, 0.00846192f, 
    -0.00397832f, 0.04945212f, -0.17902777f, 0.28749564f, -0.11950570f, -0.03032578f, 0.08769225f, 0.02890195f, 
    0.01204241f, -0.09970804f, -0.33510682f, -0.64023393f, 0.14857632f, -0.01204583f, -0.04119605f, 0.12362345f, 
    0.01423033f, 0.04593466f, -0.10911410f, -0.06182965f, 0.14310545f, 0.29907182f, -0.03894475f, 0.03811783f, 
    -0.09767203f, -0.08110476f, -0.01974010f, 0.16976619f, 0.11544046f, 0.02487366f, 0.00002759f, -0.04620204f, 
    0.01888839f, -0.18516484f, -0.14516732f, -0.02209022f, 0.11190227f, -0.09934255f, 0.19631234f, -0.17892225f, 
    0.03777296f, 0.10522293f, -0.00450678f, 0.09331039f, 0.01835303f, -0.13269763f, -0.36776665f, 0.27153015f, 
    0.51928091f, 0.04951611f, -0.09110857f, 0.06369433f, 0.11891043f, -0.21309179f, 0.41092104f, -0.31946185f, 
    -0.20618558f, 0.17618540f, 0.16097496f, -0.00559949f, -0.07633618f, -0.13174434f, 0.17786795f, -0.12434676f, 
    0.46679747f, 0.26572451f, -0.53816438f, -0.17798598f, -0.08620228f, -0.07272899f, 0.03795030f, -0.04580300f, 
    0.00691842f, -0.04652959f, -0.24725640f, 0.37353051f, 0.09030819f, -0.02058971f, 0.11936282f, 0.12855706f, 
    -0.09465756f, 0.07900333f, 0.35747021f, 0.22043636f, 0.31937036f, -0.24291080f, -0.19541872f, -0.03907632f, 
    -0.00907760f, -0.02067872f, -0.09058912f, 0.07984491f, 0.09373826f, -0.17554320f, 0.00709119f, -0.18203020f, 
    -0.09002002f, 0.05566212f, -0.00645995f, -0.08849443f, -0.21321949f, -0.37044024f, 0.33545673f, 0.06748129f, 
    0.01842343f, -0.10257478f, 0.16580722f, -0.02213606f, -0.07491894f, -0.02321406f, 0.04033373f, 0.07851338f, 
    0.01925303f, 0.09051974f, -0.12204469f, 0.13794157f, 0.21673849f, 0.00799440f, -0.20822442f, -0.43131462f, 
    -0.50092155f, -0.03258593f, -0.04540208f, 0.04688618f, 0.13630189f, -0.10700928f, 0.02811192f, -0.00865081f, 
    -0.47512779f, 0.33483845f, -0.18323018f, -0.00105792f, 0.35654923f, -0.11010784f, 0.08912594f, -0.28851601f, 
    0.04273225f, 0.01208528f, -0.04183271f, -0.01098701f, 0.01343357f, -0.02614782f, -0.03306430f, -0.03087531f, 
    -0.06680120f, -0.01681035f, -0.00381861f, 0.00238750f, -0.04244187f, 0.00931856f, -0.03526906f, 0.04245070f, 
    -0.05368841f, 0.01339530f, 0.00226403f, 0.00127814f, 0.02632220f, -0.05607410f, -0.07062554f, 0.03332285f, 
    -0.05398173f, -0.01705160f, 0.02013382f, 0.01723099f, -0.05119561f, -0.01154370f, 0.00600733f, -0.07265108f, 
    0.02169912f, -0.03788407f, -0.07328457f, -0.06372289f, -0.02759037f, -0.03608832f, -0.03865068f, -0.01903210f, 
    -0.05197036f, -0.01210203f, -0.04236822f, 0.00912127f, -0.05080466f, -0.03348370f, -0.07705565f, -0.01678161f, 
    -0.01890896f, 0.02276985f, -0.06204024f, -0.06777672f, 0.01770598f, -0.08995214f, 0.03769872f, -0.04622948f, 
    0.02803230f, -0.04952601f, -0.06191353f, -0.05611825f, -0.03416415f, -0.05925386f, 0.02378544f, 0.02454667f, 
    0.01800709f, -0.04792914f, -0.05312148f, -0.05398998f, 0.03572928f, 0.03975428f, 0.00484292f, -0.03493950f, 
    0.04040432f, -0.01609911f, 0.02040081f, 0.03290200f, -0.03854632f, -0.06259594f, 0.00814503f, -0.00974786f, 
    -0.01505070f, 0.01797547f, 0.02291523f, -0.02889682f, -0.03664460f, -0.03570341f, -0.06870844f, -0.00581252f, 
    -0.00157203f, 0.01188530f, -0.05441652f, -0.03664982f, -0.05041473f, -0.02725738f, -0.00439957f, 0.03957230f, 
    0.00633988f, -0.02125015f, -0.04310750f, -0.02801247f, -0.01025821f, -0.02886128f, -0.05362260f, 0.04010627f, 
    -0.05847146f, 0.00452201f, 0.01969440f, -0.05871766f, -0.07368569f, -0.05460396f, 0.03264393f, -0.05177756f, 
    -0.04084453f, -0.02035924f, -0.05594323f, 0.03083582f, -0.00538367f, -0.03220903f, -0.00106596f, -0.02688109f, 
    0.03460278f, 0.03990981f, -0.02433713f, 0.04012427f, -0.02820527f, -0.05872513f, -0.06531255f, -0.01818389f, 
    -0.05406919f, -0.05034059f, 0.04094058f, 0.03977248f, -0.01904554f, 0.00230404f, 0.02635266f, -0.06941918f, 
    0.02625564f, -0.06090518f, 0.03755663f, 0.00071317f, -0.01014315f, -0.06591325f, -0.03229979f, 0.02303181f, 
    -0.04722853f, 0.03201064f, -0.03227206f, -0.01003764f, -0.02186090f, 0.03492567f, -0.00938572f, 0.02722323f, 
    -0.00153949f, -0.01894920f, 0.03612000f, 0.04232129f, 0.02057056f, -0.00148736f, -0.04575866f, 0.03625425f, 
    -0.05986851f, -0.05895099f, -0.02631168f, -0.04674752f, -0.01041468f, 0.01098333f, -0.07850634f, 0.01566929f, 
    -0.07987297f, 0.01340453f, -0.04165699f, 0.00905417f, -0.04463921f, 0.02568478f, -0.02716724f, -0.03894345f, 
    0.02656465f, -0.02982328f, 0.02078015f, 0.00843190f, -0.03971732f, -0.00108516f, -0.03527898f, -0.01300730f, 
    0.04545695f, -0.01114128f, -0.05735682f, -0.07624356f, 0.01697957f, -0.00243469f, 0.03880414f, 0.00232650f, 
    -0.04108582f, -0.06699200f, 0.01441427f, 0.01596783f, -0.05491232f, -0.06488591f, -0.02397941f, -0.04975108f, 
    -0.02299024f, -0.01743572f, 0.04016329f, 0.04156278f, -0.00894978f, -0.00933569f, -0.05067769f, -0.03077926f, 
    -0.04556412f, -0.01977255f, -0.04198434f, -0.01114513f, 0.04182149f, -0.03986909f, 0.01283186f, -0.04675234f, 
    -0.05728497f, -0.04775368f, -0.06589691f, 0.00251756f, -0.05182900f, 0.02647741f, -0.06292281f, 0.01754527f, 
    -0.00339204f, -0.05499219f, 0.00105836f, -0.05299563f, -0.06239805f, -0.04374421f, -0.01071251f, -0.04118960f, 
    -0.04892938f, -0.07030229f, -0.04244417f, -0.01965342f, -0.05457270f, 0.02467443f, -0.00346082f, 0.02980241f, 
    -0.05411189f, -0.03497908f, 0.03153068f, 0.05120197f, -0.05011228f, -0.01172104f, -0.02794965f, -0.04397365f, 
    0.00298953f, -0.01193366f, -0.01016608f, 0.00011945f, -0.06041183f, 0.00446245f, -0.02919283f, 0.02126683f, 
    -0.02484623f, -0.07491422f, -0.02210364f, -0.04100275f, -0.00044685f, 0.00822367f, -0.05204712f, 0.02117125f, 
    0.03770087f, -0.01484005f, -0.07363661f, 0.00903924f, 0.01957994f, 0.02955543f, -0.03049540f, 0.03485507f, 
    0.00790594f, -0.00072493f, 0.03185282f, -0.04517789f, -0.07411511f, 0.02331688f, 0.01743408f, 0.04710800f, 
    -0.00804127f, -0.03936547f, 0.02912287f, 0.02536967f, 0.02517694f, -0.04969495f, 0.02358564f, -0.02298384f, 
    0.02362682f, 0.03418349f, 0.02567615f, 0.03233958f, -0.11917293f, 0.13411513f, 0.14474976f, 0.18198980f, 
    0.12010777f, -0.09294192f, -0.32361808f, -0.02213047f, 0.09201893f, 0.10749047f, -0.09125737f, -0.06897929f, 
    0.06871652f, 0.24972135f, -0.00461919f, -0.06528731f, 0.48282838f, 0.09643847f, 0.04601375f, -0.18219972f, 
    -0.10436468f, 0.19406074f, 0.13459934f, -0.18526554f, -0.28495416f, -0.08978516f, 0.06875138f, -0.02475567f, 
    -0.01286083f, -0.01583410f, -0.00129895f, 0.18765487f, -0.49070498f, -0.57844830f, 0.11980487f, 0.05863744f, 
    -0.07606063f, 0.05733935f, 0.03103060f, 0.00428400f, 0.16559927f, 0.03212070f, -0.09113078f, 0.20545816f, 
    0.04463418f, 0.30897450f, 0.15420695f, -0.16997853f, 0.35615623f, 0.15819328f, -0.44814077f, -0.33017743f, 
    -0.08145974f, 0.02654174f, -0.01991886f, 0.11489913f, -0.03318762f, -0.05789138f, 0.07091086f, -0.13456397f, 
    0.00965928f, -0.08540040f, -0.09415908f, -0.09244619f, -0.28691238f, 0.09330482f, 0.06298741f, 0.14930688f, 
    -0.24483019f, -0.13895607f, 0.16523321f, -0.04914041f, 0.00631959f, 0.07590578f, 0.07692198f, 0.09580255f, 
    -0.13557126f, 0.06995147f, -0.19545920f, -0.23836921f, 0.01680469f, 0.17155573f, -0.14652306f, 0.11282026f, 
    0.28499773f, -0.04173082f, -0.08023370f, -0.05331147f, -0.13387376f, 0.12196084f, -0.18302922f, 0.18233280f, 
    0.32708275f, 0.30479848f, 0.22628731f, -0.23594348f, -0.05040119f, -0.01732684f, -0.02299835f, -0.12436196f, 
    -0.00301773f, -0.06825313f, -0.01012852f, 0.04465625f, 0.21929862f, -0.00430256f, 0.13145857f, -0.10779274f, 
    -0.07112455f, 0.08100302f, 0.14347643f, 0.02062892f, -0.11121585f, -0.48417619f, -0.56862074f, -0.00086461f, 
    0.10133338f, -0.04708249f, 0.10913342f, 0.12723649f, 0.09740324f, 0.05902694f, -0.21249415f, 0.06962486f, 
    -0.12193415f, 0.14308190f, -0.04345368f, 0.06772774f, -0.01854581f, 0.17903307f, 0.05208537f, 0.14151278f, 
    -0.08450709f, 0.15570934f, -0.06095916f, 0.10153048f, -0.00107469f, -0.03859628f, -0.04454989f, 0.13148692f, 
    -0.16909407f, -0.15366170f, -0.22062819f, 0.04664620f, -0.04339312f, 0.14050704f, 0.22886029f, 0.14307691f, 
    0.13683307f, -0.21933670f, -0.40420762f, 0.12777753f, -0.12308171f, -0.01993864f, -0.10223176f, 0.12492558f, 
    0.25252715f, -0.05712210f, -0.81250399f, -0.36295310f, -0.81709188f, 0.01334504f, -0.01553057f, -0.25347492f, 
    0.14849904f, 0.08198653f, -0.00680523f, 0.24559152f, 0.12868403f, 0.12857828f, -0.18191928f, 0.29402834f, 
    -0.21148774f, 0.09251876f, 0.07435794f, -0.21626334f, 0.34379762f, -0.00049478f, 0.20758408f, 0.03312102f, 
    0.05442410f, 0.07447572f, 0.02571380f, 0.12508437f, 0.06139705f, 0.22877274f, 0.14966981f, 0.32308519f, 
    -0.13448371f, 0.06119698f, 0.21248396f, -0.03608409f, -0.10829248f, -0.03858757f, 0.09655625f, -0.04386117f, 
    -0.23780422f, 0.18071103f, 0.11276748f, -0.03010017f, 0.13547228f, -0.06940584f, 0.11132129f, -0.51661682f, 
    -0.11663184f, -0.00618474f, -0.08940690f, 0.05153526f, -0.08672631f, -0.06725014f, 0.15020432f, 0.09588583f, 
    -0.38241774f, -0.13736972f, 0.24180867f, 0.02686543f, -0.05822322f, 0.11813875f, 0.00460727f, -0.01975209f, 
    0.11145221f, -0.29357064f, -0.25624689f, 0.06540725f, -0.06111978f, -0.02607782f, 0.00896947f, 0.18326074f, 
    0.02258744f, 0.03452597f, 0.05218083f, -0.00181623f, 0.05973526f, -0.00204904f, -0.06889575f, 0.03569742f, 
    0.09937307f, 0.03109823f, -0.01002807f, 0.07709698f, -0.25473982f, -0.47310290f, -0.02072014f, 0.04982263f, 
    -0.07092551f, 0.16723962f, 0.03171450f, -0.15087117f, -0.28606585f, 0.03488213f, -0.16425012f, -0.02156913f, 
    -0.04143932f, 0.06988668f, 0.01057157f, 0.03384125f, -0.04479260f, 0.48070934f, 0.15554494f, 0.18036889f, 
    0.11694447f, 0.10888787f, -0.09704389f, 0.13324623f, -0.15950672f, 0.06411030f, 0.31797057f, 0.00039765f, 
    0.11098494f, -0.23464158f, 0.00329548f, 0.08621742f, 0.11628734f, 0.12967053f, -0.32494149f, -0.17489079f, 
    -0.44476786f, -0.20168369f, 0.05223515f, -0.12276257f, -0.07436215f, -0.08357901f, -0.17779081f, 0.29044297f, 
    0.35401645f, 0.27073768f, 0.25804833f, -0.25455907f, 0.13110566f, 0.17605199f, 0.17527814f, -0.21000221f, 
    -0.14283673f, -0.06579906f, -0.05949913f, 0.03959889f, 0.04216604f, 0.10685269f, -0.08883815f, -0.07598264f, 
    0.05067858f, 0.02212431f, -0.18428905f, -0.09763263f, -0.07220683f, -0.28154773f, -0.14507939f, 0.01455066f, 
    0.05472694f, -0.09568581f, -0.00902652f, -0.67069769f, -0.07715701f, 0.18895198f, -0.06923419f, 0.20260394f, 
    0.03293383f, 0.00909590f, -0.01583570f, 0.27386665f, 0.10987950f, -0.26880968f, 0.06648242f, -0.14161631f, 
    0.16777641f, -0.02739092f, -0.12052886f, -0.08883322f, 0.01911156f, 0.36077034f, 0.39370713f, -0.04212016f, 
    -0.06376026f, -0.05640263f, -0.10468525f, 0.02912465f, 0.02013146f, -0.07166947f, -0.11890890f, 0.44858217f, 
    0.15376352f, 0.28435621f, -0.04290871f, 0.18660167f, -0.21716598f, 0.03310679f, -0.08356369f, 0.13655354f, 
    -0.30393559f, -0.18480554f, -0.03817097f, 0.06346755f, -0.01708910f, 0.10042444f, 0.08306213f, 0.05389207f, 
    0.15673915f, -0.12950408f, -0.10353111f, -0.21069315f, -0.08873377f, 0.15882209f, 0.03271491f, -0.07596934f, 
    0.21206471f, -0.52825677f, 0.26827174f, 0.31588572f, -0.00439293f, -0.23245865f, 0.15293439f, -0.01139500f, 
    -0.18117042f, 0.03660401f, -0.17715739f, 0.01020092f, 0.21245840f, -0.09804602f, -0.15040775f, 0.22801547f, 
    -0.18516950f, -0.07953178f, -0.12887181f, 0.25586948f, -0.15659234f, -0.04518145f, 0.11765288f, 0.03908960f, 
    -0.04098604f, 0.22560067f, 0.09766051f, -0.25942719f, 0.13302204f, 0.18548290f, 0.15868615f, -0.16157611f, 
    -0.04762351f, 0.13138679f, 0.04261310f, -0.03969412f, 0.03803439f, 0.25460571f, -0.09231738f, -0.28033975f, 
    0.30529055f, 0.06284086f, -0.11188195f, 0.04614162f, 0.06099698f, 0.07830562f, -0.06819347f, -0.32882985f, 
    -0.03936375f, 0.01546374f, -0.20500743f, 0.19177398f, -0.00255178f, 0.01484087f, 0.20600764f, 0.00308113f, 
    -0.25389904f, -0.12314556f, 0.16392064f, 0.01889224f, 0.09787434f, -0.08040238f, 0.04174398f, 0.00162356f, 
    -0.24971262f, -0.03441049f, 0.36289543f, -0.11691515f, 0.31251287f, -0.02803806f, -0.02667852f, -0.02171668f, 
    0.22074518f, -0.52568454f, 0.14173326f, 0.13386403f, -0.12361909f, 0.09457999f, 0.03110906f, 0.15006073f, 
    -0.02410909f, 0.22206461f, -0.43744552f, -0.17942458f, 0.18701908f, -0.06512572f, -0.20965269f, -0.10215784f, 
    -0.00953279f, -0.43718627f, 0.07788850f, 0.50001639f, 0.33672151f, 0.19791770f, -0.00911072f, -0.10750104f, 
    -0.07386506f, 0.11657312f, -0.04459651f, 0.16583648f, 0.51267171f, 0.40177846f, 0.22093137f, 0.25803167f, 
    -0.19667315f, 0.01010013f, -0.12554444f, -0.02897179f, -0.06863678f, -0.05479084f, 0.08908588f, 0.15146844f, 
    0.08527109f, 0.10869426f, 0.15327878f, 0.03624881f, -0.15489876f, -0.10432786f, -0.22518843f, 0.21755850f, 
    0.73328018f, -0.22565818f, 0.08775330f, -0.02945838f, -0.08217796f, 0.20204449f, 0.40508869f, -0.33691674f, 
    -0.07969411f, 0.12900467f, 0.01595262f, -0.13971646f, -0.19641604f, -0.03671565f, 0.15880883f, 0.27513653f, 
    0.01502243f, 0.27817854f, 0.43920904f, -0.04512760f, 0.00968651f, -0.32679781f, 0.07363756f, -0.05803196f, 
    -0.10135742f, -0.11564748f, -0.19586167f, -0.24184956f, -0.07225485f, -0.18291380f, -0.08353687f, 0.09765841f, 
    -0.03364420f, 0.04807549f, -0.15141183f, -0.31573388f, -0.50448549f, 0.04784559f, -0.14406411f, -0.15164861f, 
    0.05208856f, 0.05134148f, 0.13686889f, -0.59929311f, -0.13039936f, -0.55005544f, 0.03212949f, -0.23873886f, 
    -0.20879772f, 0.35135484f, 0.19379582f, -0.04524503f, -0.05762722f, 0.46120292f, 0.00667501f, 0.10195645f, 
    -0.16357118f, 0.10989632f, -0.06231040f, 0.02391960f, 0.01218306f, 0.35960242f, -0.23316719f, -0.33684507f, 
    0.02869556f, 0.07220217f, 0.01818140f, 0.01481842f, 0.20358843f, 0.17040226f, 0.03841620f, 0.07455741f, 
    -0.29774433f, 0.10397722f, -0.11745188f, 0.12070322f, 0.02177242f, 0.07709286f, 0.23391218f, 0.12137766f, 
    -0.33742911f, -0.00316171f, -0.26988003f, -0.17598872f, 0.26347256f, -0.23995797f, -0.01109248f, 0.06709819f, 
    0.15699796f, 0.11862035f, 0.02284960f, -0.24312714f, 0.12771617f, 0.27813444f, -0.08761846f, 0.05594258f, 
    -0.22074197f, -0.45643130f, -0.25287500f, -0.33279115f, 0.16164497f, 0.07957801f, 0.06673629f, 0.13208577f, 
    0.03214895f, 0.11352054f, -0.16748491f, -0.56869942f, 0.06700128f, -0.35246235f, 0.00629136f, 0.04872011f, 
    0.01844173f, 0.14835042f, -0.12583260f, -0.04852910f, -0.08757836f, -0.20821145f, 0.10719727f, -0.11103644f, 
    0.07774564f, 0.13498214f, 0.21046984f, 0.08997641f, -0.16515578f, -0.56371981f, -0.14849219f, 0.17795126f, 
    0.11844393f, 0.17511277f, 0.06680325f, 0.11993557f, 0.06938823f, -0.18300927f, -0.18841231f, -0.01375949f, 
    0.06650022f, 0.00146380f, -0.19149359f, 0.20765266f, 0.08745641f, -0.05235219f, -0.12693563f, -0.63249159f, 
    0.21618867f, 0.02467707f, 0.04490446f, 0.08766484f, 0.08496694f, 0.09526838f, -0.08727463f, 0.06908431f, 
    -0.39197341f, -0.46255973f, 0.02166425f, 0.04956985f, -0.12920558f, -0.25938433f, 0.10498043f, -0.11638649f, 
    0.19625357f, 0.01843048f, -0.25547707f, 0.10926288f, 0.05637145f, -0.02709938f, -0.02350097f, 0.04567838f, 
    0.31656638f, 0.21150684f, -0.10358360f, 0.04504263f, 0.11526904f, 0.01112324f, 0.09676931f, -0.17386810f, 
    -0.21153253f, -0.01546923f, -0.03753860f, 0.05743026f, 0.01616429f, -0.01188576f, 0.23012282f, 0.02443034f, 
    -0.03926201f, -0.26530045f, -0.07630908f, 0.66654515f, 0.21603516f, -0.53286421f, 0.25943950f, -0.12711294f, 
    0.02120361f, 0.15626676f, 0.06132839f, 0.05063578f, 0.41084841f, 0.28018421f, 0.53147537f, 0.00529503f, 
    -0.11516979f, 0.15711658f, -0.07752967f, -0.11075746f, -0.01487204f, 0.06561157f, -0.18475741f, -0.20940553f, 
    0.19204585f, 0.04953824f, 0.04374353f, 0.13696632f, -0.09457646f, 0.10505174f, 0.19700615f, 0.13645302f, 
    -0.39741313f, -0.01943409f, 0.04981512f, -0.05414356f, -0.07290156f, -0.01707047f, -0.05639315f, -0.21299666f, 
    -0.08729255f, -0.50213403f, 0.17702013f, 0.00333652f, -0.02786962f, 0.04146039f, 0.02851075f, -0.06671374f, 
    -0.13529721f, -0.10538588f, 0.05723850f, 0.14570706f, 0.19023542f, 0.08318608f, 0.18367603f, -0.04923191f, 
    0.01757916f, 0.07284716f, -0.21669059f, -0.09872111f, 0.18868835f, 0.00281489f, 0.02570130f, 0.10468871f, 
    -0.14076905f, 0.13420115f, -0.00653055f, -0.44423100f, -0.09890229f, 0.12423038f, -0.16201936f, 0.15771987f, 
    -0.11359993f, 0.19647297f, -0.04947656f, 0.22198911f, 0.02890801f, 0.30540493f, 0.13459808f, -0.10781755f, 
    -0.24796002f, -0.04737116f, -0.16050512f, 0.09719183f, 0.01923106f, 0.12231563f, 0.40785432f, 0.15971808f, 
    -0.02195537f, 0.11209771f, 0.05870998f, -0.09345172f, 0.02865384f, 0.18311258f, 0.21756029f, -0.17645507f, 
    0.05228158f, -0.03836074f, 0.00699331f, -0.05302432f, -0.16399990f, -0.11937071f, -0.11297845f, -0.07197251f, 
    0.30631980f, -0.06924339f, 0.21939972f, -0.03012602f, -0.15032391f, 0.12661764f, 0.08168636f, 0.07664095f, 
    -0.11193503f, -0.25031927f, 0.16346665f, -0.10165859f, -0.07584110f, -0.02531029f, 0.16169520f, 0.06148579f, 
    0.21113154f, -0.37534440f, -0.10504702f, 0.23920415f, -0.12313887f, 0.09034630f, -0.00349006f, 0.21061639f, 
    0.06415990f, 0.12324006f, -0.25746584f, -0.16382672f, 0.14730924f, 0.10665981f, -0.02737515f, 0.14148512f, 
    0.06433482f, 0.08265630f, 0.16440108f, -0.08160477f, -0.19466361f, 0.09379302f, 0.08005184f, -0.03113125f, 
    -0.20293838f, -0.22454414f, 0.02207939f, -0.02246136f, 0.23235784f, -0.16659565f, 0.19162835f, 0.10980660f, 
    0.05418102f, 0.17745261f, -0.11113828f, -0.24167615f, -0.10825537f, -0.39773765f, 0.19534238f, -0.02875092f, 
    0.01082883f, 0.08774662f, 0.17480195f, -0.00636444f, -0.26791695f, -0.34814963f, 0.03143867f, -0.24665588f, 
    0.10697275f, 0.07346052f, 0.15633544f, 0.05196251f, 0.01085619f, -0.08418321f, -0.51510626f, 0.30524051f, 
    0.09341841f, 0.08627276f, -0.09521034f, 0.01303976f, 0.00824440f, 0.04544487f, 0.03409221f, 0.26090497f, 
    0.14511348f, -0.13613316f, -0.11326543f, -0.01259400f, 0.09761721f, -0.15878542f, -0.11970935f, 0.20635767f, 
    0.20043808f, -0.13309097f, 0.11061111f, 0.05358735f, 0.05411643f, -0.13277289f, 0.08238478f, 0.09421307f, 
    -0.11857252f, -0.07488454f, 0.11214525f, 0.42073178f, 0.03335170f, 0.03878647f, -0.07859127f, -0.09983870f, 
    -0.11457686f, 0.07720582f, 0.09409043f, -0.05311022f, 0.01766843f, 0.17707078f, 0.08578147f, -0.19969706f, 
    -0.05059947f, 0.27684623f, -0.03923604f, 0.24127431f, -0.24169117f, 0.05831974f, 0.03436286f, -0.02659399f, 
    0.11703067f, 0.09757148f, -0.05993882f, -0.06325472f, 0.40212965f, 0.22425279f, 0.10726637f, -0.13903219f, 
    0.06155199f, 0.11710910f, -0.00203874f, 0.14887039f, 0.04831490f, -0.24175522f, -0.12632275f, -0.01608573f, 
    -0.26449159f, -0.14868608f, -0.07632231f, 0.01054743f, -0.12833229f, -0.19162807f, 0.15955505f, 0.06287088f, 
    -0.05772202f, 0.07997572f, -0.04156008f, 0.00874682f, -0.00336181f, 0.11471668f, -0.28608003f, 0.09410803f, 
    0.17694837f, 0.23320566f, -0.04981645f, -0.11558953f, 0.13663957f, 0.27053347f, -0.03635300f, -0.05358307f, 
    -0.04974789f, -0.37668577f, -0.22960037f, -0.09668145f, -0.04359818f, 0.10217642f, -0.03062616f, -0.13659520f, 
    0.13482159f, 0.10530415f, -0.02097229f, -0.04612875f, -0.02225722f, 0.17979810f, 0.15961918f, 0.08390579f, 
    -0.07672112f, -0.13377734f, 0.01037363f, 0.03044412f, 0.11346975f, -0.01755223f, 0.14596620f, -0.11666494f, 
    0.21687031f, -0.07170264f, -0.19627975f, 0.34732962f, -0.09372978f, -0.08066723f, 0.12827107f, -0.07213183f, 
    0.17178582f, -0.12329424f, 0.04803286f, 0.09544846f, -0.18956174f, -0.18980344f, -0.21297096f, -0.07022260f, 
    0.04174469f, 0.07612821f, 0.04392819f, 0.12088040f, 0.18977378f, 0.05572138f, 0.16254285f, 0.03849099f, 
    -0.18953253f, 0.02020885f, 0.07088321f, -0.09140560f, 0.05342801f, -0.20822249f, 0.16894315f, -0.02474198f, 
    -0.19464864f, -0.05274078f, -0.05976050f, 0.03213784f, 0.21508817f, 0.13501079f, 0.19583242f, 0.01922489f, 
    -0.01118763f, 0.45459545f, 0.06113118f, 0.14437881f, 0.16131072f, -0.10510051f, -0.02040689f, 0.19895151f, 
    0.12784953f, 0.12135540f, 0.00196115f, -0.07617079f, 0.10757449f, -0.01502052f, 0.00402530f, 0.06162742f, 
    -0.11732548f, 0.05333427f, -0.21036507f, 0.00136084f, -0.02489787f, -0.01275793f, 0.05781478f, -0.03801252f, 
    -0.05909197f, 0.00393698f, 0.38098693f, -0.29490218f, 0.10192931f, 0.00760205f, -0.09918004f, 0.34521681f, 
    -0.00992160f, -0.08596568f, -0.05797133f, -0.29770190f, 0.00821049f, -0.09749449f, -0.37435558f, 0.23202221f, 
    0.06020121f, -0.06523275f, -0.02288147f, 0.01000519f, -0.38116753f, -0.13153102f, -0.12273268f, -0.07820217f, 
    0.08033437f, 0.14820780f, 0.01485661f, -0.11940457f, 0.02381615f, 0.04485315f, -0.01485678f, 0.14607723f, 
    -0.00651879f, 0.06498559f, 0.18039617f, -0.08905667f, 0.03478147f, 0.28587064f, 0.22279373f, -0.49079654f, 
    -0.11431858f, 0.06363515f, -0.03897502f, 0.10850029f, 0.15290755f, -0.23614213f, -0.09290338f, -0.07345757f, 
    -0.13264677f, -0.06239916f, -0.17282531f, -0.20303205f, -0.05812981f, 0.02451264f, 0.03904494f, -0.08367933f, 
    0.51417309f, -0.17854130f, 0.17075908f, -0.21509694f, -0.10605711f, -0.04202350f, 0.00797679f, 0.00959439f, 
    -0.12939778f, -0.00636957f, -0.05395110f, -0.19109868f, 0.01483851f, -0.03879575f, -0.06119585f, 0.08494046f, 
    -0.08475468f, -0.01588060f, -0.17562957f, 0.11052220f, 0.05417538f, -0.01276742f, 0.15583217f, 0.17064318f, 
    0.03045891f, 0.27773571f, 0.10248910f, 0.15287811f, -0.22092947f, 0.02014194f, 0.01479948f, -0.15949798f, 
    0.02583210f, -0.14427660f, 0.18551914f, -0.15111712f, -0.12885967f, -0.08402202f, -0.07297296f, 0.15597281f, 
    0.14458732f, -0.10720622f, -0.02257676f, 0.13992301f, -0.29503036f, -0.52384043f, 0.00694955f, 0.11702208f, 
    -0.28996378f, 0.19599007f, 0.04573812f, 0.23464575f, -0.07653427f, 0.18518692f, -0.06846648f, -0.23789515f, 
    0.39932126f, -0.61811411f, 0.09496062f, 0.13439399f, 0.23538759f, 0.10578958f, 0.15645993f, -0.15843843f, 
    -0.30036622f, -0.26345080f, 0.11670082f, 0.09774981f, -0.04473969f, 0.01627810f, -0.01494551f, -0.08941530f, 
    -0.24018893f, -0.04276036f, 0.40518352f, -0.02812283f, 0.11488382f, 0.16951793f, 0.23472461f, 0.06397092f, 
    0.26665348f, 0.10315897f, 0.02565520f, -0.23023485f, 0.08462356f, -0.11621009f, -0.02649245f, -0.04000555f, 
    0.03547265f, 0.06952429f, 0.01117914f, -0.19091064f, 0.26235211f, -0.19447577f, 0.07637275f, -0.00277308f, 
    0.06436697f, 0.18348585f, 0.13829829f, 0.12466173f, 0.19972120f, 0.13712330f, 0.03348687f, 0.04929563f, 
    0.11195543f, -0.36399505f, 0.02321170f, 0.16195320f, -0.26095682f, -0.16624002f, 0.01892033f, -0.11428805f, 
    0.06178972f, 0.00287754f, -0.08459047f, 0.34453407f, -0.06266174f, 0.39268211f, 0.39307985f, -0.30417126f, 
    -0.12111731f, 0.11760928f, 0.03782529f, 0.25272566f, 0.24631561f, 0.03300670f, -0.11912887f, -0.13807318f, 
    0.03985286f, 0.07003195f, 0.03699745f, 0.09730738f, -0.20862272f, -0.13318330f, -0.22775105f, 0.17844780f, 
    -0.05539829f, 0.13849092f, 0.24401157f, 0.11031980f, -0.00678090f, 0.13548984f, -0.06593142f, -0.05126398f, 
    -0.04303760f, -0.01283899f, 0.07415216f, 0.03922262f, 0.18001600f, 0.11444575f, -0.34642234f, -0.54360229f, 
    -0.72475106f, -0.05198466f, 0.05495874f, 0.18088511f, -0.10878440f, 0.04679147f, 0.15331177f, 0.13809656f, 
    0.24101901f, 0.10062328f, -0.21412677f, 0.02957144f, -0.00015435f, -0.04184688f, -0.04707053f, 0.06249393f, 
    0.19153616f, 0.05723570f, 0.24072583f, -0.06174332f, -0.02862388f, 0.15017845f, 0.01271475f, 0.08437413f, 
    0.01392401f, 0.01367822f, 0.04268990f, -0.14699632f, 0.28901204f, 0.28395942f, 0.29770014f, 0.06153505f, 
    0.16281757f, -0.02701907f, 0.05570320f, -0.08837265f, -0.51436031f, -0.14792159f, -0.09202654f, -0.03065876f, 
    -0.17020755f, 0.10022344f, -0.14022116f, -0.39978394f, -0.19681962f, -0.06453168f, -0.07560437f, 0.20878445f, 
    0.08629429f, 0.00052513f, 0.05875626f, 0.05896343f, -0.02699623f, -0.13014328f, -0.11511149f, 0.06801248f, 
    0.17089169f, -0.31225437f, 0.08936743f, -0.08360356f, -0.12206484f, -0.19887908f, -0.09026247f, 0.06148936f, 
    -0.16929291f, -0.13669266f, 0.05806299f, -0.16416273f, 0.04117659f, 0.07077050f, -0.18519503f, 0.05878851f, 
    0.15261115f, 0.08808253f, 0.06624784f, 0.11174138f, -0.12801899f, 0.29711023f, 0.17690447f, -0.43812728f, 
    0.08502741f, 0.08414073f, 0.08614768f, -0.03245970f, 0.01253437f, 0.10620522f, 0.01759681f, 0.16236824f, 
    -0.21743014f, -0.05329163f, -0.00215515f, 0.31360006f, 0.04561692f, -0.10499433f, 0.15308844f, 0.04924712f, 
    0.04177307f, 0.22889663f, 0.15774557f, -0.03162064f, 0.31531930f, 0.18786518f, -0.10204262f, 0.01887916f, 
    0.10510747f, 0.07824019f, 0.05041758f, 0.12281567f, 0.11325688f, 0.12100639f, 0.05661570f, 0.14713554f, 
    0.03303266f, 0.07310782f, -0.06503057f, -0.11759210f, 0.05411778f, -0.28034717f, 0.07278746f, 0.12873217f, 
    0.22021046f, 0.16714884f, 0.00320856f, 0.20448746f, -0.06916510f, 0.28729862f, 0.30232278f, 0.02461714f, 
    0.17167743f, 0.04628661f, -0.07683620f, 0.04309422f, 0.00393790f, -0.23384522f, -0.21006611f, -0.11321708f, 
    -0.21847662f, -0.20435068f, -0.05580399f, 0.12725423f, 0.09189002f, 0.11671993f, -0.58228850f, 0.01139274f, 
    -0.32485631f, -0.08884063f, -0.09730468f, -0.05694086f, -0.12060961f, 0.02628570f, 0.05701673f, -0.22498602f, 
    -0.36728680f, -0.19770716f, -0.06083634f, -0.11863998f, -0.09991829f, 0.22931419f, 0.17693457f, -0.01740964f, 
    -0.26947606f, -0.24610628f, -0.11904698f, 0.05048791f, -0.05498597f, 0.04985253f, 0.19866383f, 0.28291622f, 
    0.02135046f, -0.04763391f, -0.20298892f, 0.08368385f, -0.08585777f, -0.06988083f, 0.09994759f, 0.20190729f, 
    0.04093403f, 0.18830071f, -0.16976660f, -0.19058806f, -0.25545567f, 0.16140185f, 0.15986693f, -0.16739061f, 
    0.17492235f, 0.03246559f, -0.17542884f, -0.20027012f, -0.30876380f, -0.07825930f, -0.07256816f, 0.32800269f, 
    0.16906865f, 0.14013323f, 0.12844355f, 0.21564539f, -0.32069531f, -0.63125950f, -0.61734456f, -0.09904306f, 
    0.05220924f, 0.18158980f, 0.18017100f, 0.03202748f, 0.08623383f, -0.15464620f, 0.05040567f, 0.12929833f, 
    -0.18196207f, -0.25236407f, 0.49419317f, 0.09309177f, 0.13742206f, 0.22725560f, 0.02774050f, 0.16126420f, 
    0.05829240f, -0.40674782f, -0.14368375f, 0.27124256f, 0.25521210f, 0.23447458f, -0.05960131f, 0.00521364f, 
    -0.14554802f, 0.02015854f, -0.41879216f, -0.41478279f, 0.37253109f, -0.30168951f, 0.16837572f, 0.17900157f, 
    0.40417829f, -0.08049886f, 0.10079631f, 0.10932794f, -0.22992590f, -0.07385605f, 0.04298270f, -0.14099546f, 
    0.19299781f, 0.17282566f, 0.25644082f, 0.28096771f, -0.64366615f, -0.66872126f, -0.54793876f, 0.00151978f, 
    -0.08367191f, -0.14177535f, -0.13513923f, -0.02092670f, 0.06873444f, -0.25595459f, -0.27220124f, 0.10669592f, 
    0.15277520f, 0.11386766f, -0.00678604f, -0.01086018f, -0.07356531f, -0.12608133f, -0.05492504f, 0.10387696f, 
    -0.01736196f, -0.19435148f, -0.15062238f, -0.22554547f, 0.05847197f, -0.21581854f, -0.17944372f, 0.50261259f, 
    -0.12845540f, -0.01760923f, 0.04646730f, 0.14809851f, -0.05531695f, 0.14394654f, 0.14432532f, 0.06792935f, 
    -0.23980282f, 0.13075824f, -0.18242434f, -0.18551686f, -0.05360498f, 0.16997069f, 0.17317194f, 0.09202310f, 
    -0.02150448f, 0.21199405f, -0.19900130f, -0.31454098f, -0.07227652f, 0.10445854f, 0.08624676f, 0.01346325f, 
    0.11255258f, -0.00660833f, -0.36034542f, -0.45546925f, 0.06930497f, -0.01931513f, -0.05309231f, -0.05275625f, 
    0.10807990f, 0.10974971f, 0.15441670f, 0.51777285f, 0.02296938f, 0.09760976f, 0.00162637f, 0.00802028f, 
    -0.02834335f, 0.10856184f, -0.11834609f, 0.15397529f, 0.23369184f, -0.05081747f, 0.23993248f, -0.04101636f, 
    0.13655472f, 0.06363840f, 0.12507261f, 0.28862500f, 0.13077621f, -0.24234061f, -0.12090360f, -0.38239065f, 
    -0.29940856f, -0.35454029f, -0.54484022f, 0.00738834f, 0.28702909f, 0.10725819f, 0.50523257f, -0.02635065f, 
    0.15601839f, 0.00769772f, 0.03804539f, 0.22591773f, 0.02435937f, 0.25074264f, 0.25473386f, -0.15145428f, 
    0.14405592f, 0.20904891f, 0.11166225f, 0.18316677f, -0.02288767f, -0.05192127f, 0.01151615f, 0.10234772f, 
    -0.35028306f, -0.36118752f, -0.00427240f, 0.00238365f, -0.17761740f, -0.17915234f, -0.04141645f, 0.21089238f, 
    0.07274602f, -0.03190782f, -0.14517924f, 0.09782606f, 0.12712257f, -0.01180924f, 0.25043675f, 0.12302653f, 
    0.13774630f, 0.18835178f, -0.24910535f, -0.59324294f, -0.23458296f, -0.00073453f, -0.16718753f, -0.26989758f, 
    0.02172522f, -0.05549602f, -0.21496943f, -0.19391885f, -0.18534383f, 0.06475372f, 0.09451988f, -0.09992144f, 
    -0.08889224f, -0.23388027f, 0.30582038f, 0.22218239f, -0.04947477f, -0.09305948f, 0.20811579f, 0.09166458f, 
    0.10836136f, 0.18903381f, -0.10588891f, 0.11004599f, -0.01817887f, 0.10292843f, 0.00997276f, 0.01147289f, 
    0.00761066f, 0.08755299f, 0.04868067f, -0.05187549f, 0.14738187f, 0.09505853f, 0.19941600f, -0.12567569f, 
    0.24099554f, -0.11535426f, -0.03189931f, 0.03204710f, 0.31087455f, 0.14469025f, 0.44644821f, 0.00691360f, 
    -0.00707925f, -0.24862558f, -0.26961651f, -0.27565438f, -0.28409258f, 0.02493959f, -0.11594909f, 0.26738322f, 
    -0.05650689f, -0.60653263f, -0.13047549f, -0.52699566f, -0.17241101f, -0.19434287f, -0.05197528f, 0.05799036f, 
    -0.01742629f, -0.09723856f, 0.00559385f, -0.21816941f, -0.00868296f, -0.16773167f, -0.19364597f, 0.10318853f, 
    0.07405424f, 0.14048490f, -0.09300784f, -0.05564042f, 0.17990978f, 0.02928136f, 0.01417510f, -0.33344316f, 
    -0.08173769f, -0.02030726f, 0.07291280f, -0.45478779f, -0.25177646f, -0.10239312f, 0.12385199f, 0.07702938f, 
    -0.07468467f, 0.02640259f, 0.22457762f, 0.01004265f, 0.53661680f, 0.27205601f, 0.04415134f, -0.13899961f, 
    -0.12909767f, -0.23408283f, 0.20397697f, -0.14699164f, 0.04951821f, -0.19468667f, 0.07812303f, 0.01828748f, 
    0.09840862f, 0.06390734f, -0.06543205f, -0.09522370f, 0.00490497f, 0.03110110f, -0.52554888f, 0.34052336f, 
    0.11714496f, 0.03167311f, -0.11021370f, -0.00388675f, 0.09036656f, 0.21712872f, 0.17561473f, 0.78800189f, 
    -0.10874090f, 0.19366443f, 0.09140538f, 0.07139657f, 0.24309698f, 0.07724038f, 0.05977815f, 0.12648205f, 
    -0.10094621f, 0.16751756f, 0.04485801f, 0.38097686f, -0.18185252f, -0.10370351f, -0.17393062f, -0.19094488f, 
    -0.07165543f, -0.03894694f, -0.14454058f, 0.23710544f, 0.03044699f, 0.04757675f, -0.07402703f, 0.01430831f, 
    -0.15039216f, -0.14217074f, 0.40142858f, -0.03741579f, 0.00345010f, -0.00980017f, 0.03131815f, 0.47175154f, 
    -0.15255988f, 0.06786992f, -0.17808937f, -0.20240250f, 0.20314547f, -0.05731510f, 0.09296428f, 0.01559927f, 
    0.00146568f, 0.14155832f, -0.09824983f, 0.05015073f, 0.21975948f, 0.35984498f, -0.18355606f, -0.20135018f, 
    -0.13086182f, 0.01018034f, 0.02852841f, 0.13214460f, -0.02652608f, -0.07710876f, -0.17776850f, -0.43739018f, 
    0.05044228f, -0.20465487f, 0.05355884f, -0.08634184f, -0.21031746f, -0.09117180f, 0.29288989f, -0.06933632f, 
    -0.11174129f, 0.02484572f, -0.04844003f, 0.08694228f, 0.11176936f, 0.03589365f, -0.06375217f, 0.05440709f, 
    0.01007412f, -0.08902542f, 0.10201056f, -0.06227028f, -0.11794335f, -0.18107268f, -0.18707158f, -0.36183706f, 
    -0.10873740f, 0.19446993f, -0.15883729f, 0.03092089f, 0.13444805f, 0.01677871f, 0.25698081f, 0.10741900f, 
    -0.05377243f, -0.01677706f, -0.02886787f, 0.00011669f, 0.20765260f, 0.00772404f, -0.10003032f, -0.35141978f, 
    -0.28202963f, -0.53980178f, -0.03511258f, 0.06325082f, -0.01808192f, 0.05296864f, 0.09677557f, -0.09105956f, 
    -0.62686563f, -0.66043133f, -0.41742986f, -0.32615110f, 0.27944928f, 0.29691908f, -0.13901703f, 0.06663238f, 
    0.09996749f, 0.17706731f, 0.15276758f, 0.09976056f, 0.01650154f, 0.03880623f, 0.41652113f, 0.24515638f, 
    0.06394867f, -0.01311452f, -0.04554664f, 0.10866077f, 0.17866813f, 0.05706602f, 0.07623956f, -0.03102598f, 
    -0.01302580f, 0.08133373f, 0.07798815f, 0.10946248f, 0.15097393f, -0.06957647f, -0.15998046f, -0.07525239f, 
    0.02097008f, -0.06288347f, 0.10223088f, 0.02554789f, 0.09292486f, -0.04460204f, 0.04424129f, -0.19738907f, 
    0.12546426f, 0.28776994f, -0.05688132f, 0.00280727f, 0.12312755f, 0.07925706f, 0.07922472f, 0.19820110f, 
    0.15902653f, 0.16991572f, -0.00184818f, -0.00722078f, -0.00940255f, 0.03717325f, 0.04145341f, 0.01518299f, 
    -0.17106594f, 0.08156602f, -0.07796874f, -0.01476873f, 0.02169685f, 0.01984740f, 0.01241541f, 0.05614686f, 
    0.08641324f, -0.23295504f, 0.39617038f, 0.04072224f, -0.18896732f, -0.12483420f, 0.03247976f, 0.04359116f, 
    0.18366434f, 0.00084842f, -0.14640792f, 0.11113218f, 0.10085713f, -0.01291586f, 0.18132983f, 0.04037892f, 
    0.29361898f, -0.08918069f, -0.06776750f, 0.09420387f, -0.12107129f, -0.26292342f, -0.31863794f, 0.07049406f, 
    0.07559314f, 0.13617623f, -0.02234809f, -0.07509816f, -0.03160442f, -0.21737610f, 0.06663027f, 0.27114254f, 
    -0.05443917f, 0.33338085f, 0.06029481f, -0.03239953f, 0.12804967f, 0.13421920f, 0.20710526f, 0.11382382f, 
    -0.11583994f, -0.07183873f, 0.10784150f, 0.08436270f, -0.04907973f, -0.27218056f, -0.08484264f, -0.17637819f, 
    0.22852841f, 0.22842327f, 0.17827812f, 0.14109574f, -0.05371140f, 0.35462230f, -0.16456132f, 0.04222574f, 
    0.02716420f, 0.47810307f, -0.12342195f, 0.06920335f, -0.06795408f, 0.21663277f, 0.22211403f, 0.08984397f, 
    -0.03852207f, -0.00769870f, -0.05320623f, -0.06666353f, 0.03936971f, 0.05161345f, 0.06384650f, 0.08136031f, 
    0.00866875f, -0.17002489f, -0.13886611f, -0.04498510f, 0.05425915f, 0.08477902f, 0.07580833f, 0.11177624f, 
    -0.11987113f, -0.22025089f, -0.30218592f, -0.34330666f, 0.07684898f, 0.09393159f, -0.03642904f, -0.00567904f, 
    0.11281232f, 0.21446905f, -0.01843223f, 0.08555260f, 0.24245207f, -0.15308775f, -0.20326816f, 0.11856044f, 
    0.07176363f, 0.14629982f, 0.00081982f, 0.00878831f, -0.13251744f, -0.07176991f, -0.17611961f, 0.07219099f, 
    0.00325929f, 0.14179361f, 0.44754475f, 0.12909359f, 0.22383738f, 0.28204483f, 0.09760343f, -0.00628850f, 
    -0.11933333f, 0.00983194f, 0.21467496f, 0.14735061f, 0.23455825f, 0.12005974f, 0.11144760f, 0.10910401f, 
    -0.08264669f, 0.28334334f, 0.16448179f, 0.11333288f, 0.08358306f, 0.00754830f, -0.08383627f, -0.10347186f, 
    0.19499810f, -0.25175813f, 0.04351256f, 0.00921151f, 0.06484028f, -0.13238813f, -0.07436966f, 0.10703616f, 
    -0.09532429f, -0.10475741f, 0.33087716f, 0.35659051f, -0.03189569f, 0.10183980f, 0.00568560f, -0.00476948f, 
    0.11322904f, 0.03727815f, -0.19531639f, -0.14645392f, 0.10199289f, -0.15700427f, 0.13477162f, -0.17997448f, 
    0.16831663f, 0.12190162f, 0.22570115f, 0.11737332f, 0.14680362f, 0.03992401f, 0.13374357f, -0.09425262f, 
    0.06506966f, 0.09508205f, 0.16234823f, 0.13595097f, -0.15964317f, 0.04412492f, -0.06763942f, -0.03815957f, 
    -0.07762930f, 0.00188903f, -0.05190445f, -0.22963189f, 0.02323195f, -0.93491125f, -0.30365703f, 0.55688119f, 
    0.00796096f, 0.06373389f, -0.04579211f, 0.01014429f, -0.01476585f, 0.03572678f, 0.17989098f, 0.08969121f, 
    0.05594086f, -0.14944325f, -0.11990579f, -0.13702784f, -0.19308817f, 0.04056557f, -0.07644495f, 0.42584836f, 
    -0.03175798f, -0.10335376f, -0.30674851f, 0.20883633f, -0.24475035f, 0.11554383f, 0.18316475f, 0.02740515f, 
    -0.04910006f, 0.02034342f, -0.06025198f, 0.01140131f, 0.05270265f, -0.14783907f, 0.17064980f, -0.10644738f, 
    -0.03175650f, 0.16053921f, -0.04498990f, -0.04168845f, -0.05930495f, 0.05608677f, 0.05576883f, -0.04520883f, 
    0.00049626f, 0.07345431f, -0.12979174f, -0.23367009f, -0.11769456f, -0.22911578f, 0.10587108f, -0.12424870f, 
    -0.06764765f, -0.01647417f, 0.05004379f, 0.33625513f, 0.30669031f, 0.08484509f, 0.04792330f, -0.08808994f, 
    -0.04622701f, 0.00790657f, -0.10042404f, 0.25908563f, -0.04383314f, -0.07491767f, 0.35263351f, 0.03491592f, 
    0.02904722f, -0.06096204f, 0.25969887f, 0.16386113f, -0.00873281f, -0.05000104f, 0.05311144f, 0.00514084f, 
    -0.12399955f, -0.32739180f, -0.09305131f, -0.02680933f, 0.05389884f, 0.12822929f, 0.03916740f, 0.16899908f, 
    -0.13920490f, 0.06543449f, -0.15112050f, 0.32681575f, -0.09215412f, -0.04901889f, 0.43709251f, 0.04925815f, 
    0.30979767f, 0.34626827f, 0.20104337f, 0.08388901f, -0.00256431f, 0.07445961f, 0.09142164f, -0.02510499f, 
    -0.23249891f, -0.01301609f, 0.03964304f, -0.17977242f, -0.18383341f, -0.04921845f, -0.12604730f, 0.07213301f, 
    0.01835650f, -0.03902111f, 0.09753884f, 0.11780291f, -0.03677060f, -0.22808297f, -0.08658985f, 0.18152517f, 
    0.12633684f, 0.13563082f, 0.07529909f, 0.04405112f, 0.05716841f, -0.03595702f, -0.03519883f, -0.11191475f, 
    -0.36338359f, 0.06836089f, -0.16684252f, -0.42133179f, -0.16804847f, 0.13651490f, -0.01273902f, 0.03981231f, 
    -0.11343221f, 0.04071289f, 0.07870037f, -0.17274392f, -0.43456751f, 0.00405734f, 0.44894150f, 0.06933940f, 
    0.03340242f, -0.06527409f, -0.03552513f, 0.03000310f, 0.18916178f, -0.02136821f, 0.21975105f, 0.31327954f, 
    -0.03132228f, 0.11414468f, -0.08691658f, 0.04604619f, -0.05863288f, -0.02411459f, 0.21227963f, -0.46677241f, 
    0.08043098f, 0.01114029f, 0.00024249f, 0.09748057f, -0.26076901f, -0.05570427f, 0.33858034f, -0.06697746f, 
    0.09523920f, -0.10046215f, -0.02195541f, -0.30050579f, -0.00280515f, -0.00304118f, -0.00769163f, 0.42572129f, 
    0.14160860f, 0.00758270f, 0.07640639f, -0.03875029f, -0.06894075f, -0.04427797f, 0.05453764f, -0.08939711f, 
    -0.34091991f, 0.01570046f, 0.00637244f, 0.03873508f, -0.07500989f, 0.00246490f, -0.20253539f, 0.35389653f, 
    0.24580009f, -0.21792504f, 0.04837853f, -0.02460468f, -0.03754112f, -0.11330693f, -0.14461410f, 0.03152283f, 
    0.11442515f, 0.03824357f, 0.07789760f, -0.04957056f, 0.04401876f, -0.00984690f, -0.11948238f, 0.13310678f, 
    -0.23488143f, 0.18482706f, -0.24278882f, 0.11116385f, 0.31763577f, 0.16892530f, 0.13000633f, -0.01112700f, 
    -0.04862979f, -0.06944899f, 0.07736408f, 0.14674191f, -0.06874190f, -0.44786292f, 0.19080421f, 0.22594228f, 
    0.03269267f, 0.00976665f, -0.04134990f, 0.14582507f, 0.04740805f, -0.24369195f, -0.26535031f, 0.29548231f, 
    0.14170197f, 0.04422915f, 0.18131852f, -0.31735903f, 0.24881902f, 0.12560071f, 0.00072653f, 0.33115572f, 
    -0.07287890f, 0.06136576f, 0.11127596f, -0.19351034f, 0.34939176f, -0.00184077f, -0.01660176f, 0.24497409f, 
    0.05457075f, 0.28040260f, 0.12272606f, -0.15910400f, 0.03228164f, 0.06309930f, -0.07836699f, 0.10405092f, 
    0.06586774f, -0.05357230f, -0.55463362f, -0.59533888f, 0.04931214f, 0.10515084f, 0.09988015f, 0.03007944f, 
    -0.02256813f, -0.01149941f, -0.00999987f, 0.55295503f, -0.12282321f, 0.15653557f, -0.21067402f, 0.11317894f, 
    0.11016862f, 0.19883916f, 0.03118749f, 0.25659177f, 0.22219475f, -0.00713521f, -0.02616453f, 0.14054279f, 
    -0.11673853f, 0.16989031f, 0.06598268f, -0.04814081f, 0.13537925f, 0.06628139f, -0.00084065f, -0.11456898f, 
    -0.12104551f, -0.15624295f, -0.04555802f, 0.00554915f, 0.07503533f, -0.25645465f, 0.14998467f, -0.47139052f, 
    0.07979317f, 0.08921821f, -0.08328082f, 0.07415391f, -0.18465964f, 0.03618954f, 0.08374251f, 0.12693949f, 
    0.05464163f, 0.08577062f, -0.11861471f, 0.01751708f, -0.12057230f, 0.00698276f, 0.07387349f, 0.15403666f, 
    -0.34875908f, 0.17108789f, 0.10597869f, 0.04547923f, 0.07933257f, 0.11103056f, -0.04845288f, 0.09725521f, 
    -0.11843751f, 0.15862468f, -0.05555079f, -0.01763457f, -0.11670185f, -0.05272314f, 0.11209840f, 0.05149889f, 
    0.09337726f, -0.02105358f, -0.07455004f, -0.02046683f, 0.07900199f, -0.02798378f, -0.03971485f, -0.01141138f, 
    0.06495413f, 0.01785864f, -0.00043275f, 0.06931092f, -0.08832952f, 0.03938168f, -0.06522954f, 0.04822272f, 
    0.10167050f, 0.11607613f, 0.10232939f, 0.28756845f, 0.03091163f, -0.06197068f, -0.07208207f, 0.29471028f, 
    -0.02869360f, 0.06671123f, 0.01810033f, 0.01854417f, -0.55048597f, -0.15040256f, -0.28890061f, 0.06485406f, 
    0.09840586f, 0.17542996f, 0.06880903f, 0.04588927f, 0.04026942f, 0.03695720f, 0.11852704f, -0.00071432f, 
    -0.05436965f, -0.11690160f, -0.06311031f, 0.14984503f, 0.01367089f, -0.08729717f, 0.06259692f, 0.36936152f, 
    -0.03036555f, 0.10514870f, 0.32052991f, 0.13419639f, -0.02036242f, 0.13801309f, 0.10354564f, -0.15486367f, 
    -0.82545811f, -0.59940088f, -0.06017778f, 0.15202096f, -0.01349190f, 0.09805262f, 0.00321960f, 0.01623871f, 
    0.11194047f, 0.15446562f, -0.02521366f, -0.11934019f, -0.10138886f, -0.10831311f, 0.17651506f, 0.03186825f, 
    -0.03784398f, 0.09282362f, 0.23089767f, -0.17236733f, -0.00379495f, -0.00525722f, -0.11926469f, 0.23454693f, 
    -0.06267650f, -0.13737047f, -0.01746291f, -0.12947400f, 0.00434367f, 0.00111401f, -0.06987579f, -0.21094340f, 
    0.00909681f, 0.00218086f, -0.04012034f, -0.36161700f, -0.14571454f, -0.44886312f, 0.00277563f, -0.06296651f, 
    0.00306750f, 0.14184211f, 0.06009012f, 0.07598433f, -0.54288006f, -0.06923763f, -0.52741420f, 0.03383750f, 
    0.03294946f, 0.06105687f, 0.08882382f, 0.01323191f, 0.05885643f, -0.42065731f, -0.46699440f, -0.33464319f, 
    0.06986763f, 0.29347649f, 0.15661776f, 0.03888885f, -0.04756644f, 0.10254189f, -0.04927098f, 0.43313557f, 
    0.23763080f, -0.04209693f, 0.05488073f, -0.07494406f, -0.03792914f, 0.17218323f, 0.19465756f, -0.01630044f, 
    0.40542623f, -0.07187642f, -0.16775927f, 0.19124319f, -0.11999117f, -0.02036850f, 0.02482967f, 0.18822077f, 
    0.17343056f, 0.26739752f, 0.19858629f, 0.01321786f, -0.09007978f, -0.19229122f, -0.00536360f, -0.07883543f, 
    0.11727671f, -0.07165826f, 0.07022708f, 0.12259392f, 0.09423196f, -0.06721097f, 0.04162553f, 0.05707141f, 
    -0.04423206f, 0.16019982f, 0.16892277f, 0.14172778f, -0.02140379f, -0.10863553f, -0.04432761f, -0.06940774f, 
    0.05008314f, -0.09225287f, 0.03180465f, 0.24845631f, -0.30516160f, 0.10704911f, -0.11906892f, -0.00196801f, 
    -0.04928080f, -0.02299896f, -0.13721074f, -0.02474209f, -0.00584923f, 0.08021451f, 0.12339147f, 0.16675119f, 
    -0.14344807f, 0.01571295f, -0.09473171f, 0.02088846f, 0.07240824f, 0.00897992f, -0.85430914f, -0.87806839f, 
    -0.40237004f, -0.35048720f, 0.10990375f, 0.19042912f, 0.00953322f, 0.06200894f, -0.38553217f, 0.00082438f, 
    -0.73495197f, 0.10031819f, -0.22604325f, 0.06878900f, 0.15715148f, 0.02204754f, -0.06562302f, 0.09363764f, 
    0.22870749f, -0.21916395f, -0.04090374f, 0.15143645f, 0.11731641f, 0.01956840f, 0.05677344f, -0.07877178f, 
    -0.13668521f, 0.27654725f, 0.15053421f, 0.13113472f, -0.01717958f, -0.14459532f, -0.02116858f, 0.01809160f, 
    -0.18345027f, 0.07937958f, -0.54636651f, 0.09116601f, 0.04915330f, 0.00685917f, -0.00258646f, -0.12089669f, 
    -0.17639105f, -0.07907047f, 0.34196919f, 0.01166932f, 0.07427470f, 0.13945100f, -0.02351986f, 0.53767133f, 
    -0.30995029f, 0.08065459f, -0.13068959f, -0.03405632f, 0.07844056f, -0.17602374f, 0.02719331f, 0.07499941f, 
    0.03275532f, 0.17561138f, 0.20735416f, 0.00221999f, 0.15896094f, 0.39494053f, -0.08549520f, -0.15758432f, 
    -0.09070981f, 0.08458558f, -0.02137042f, 0.02025996f, -0.08454578f, -0.01503931f, -0.39958096f, -0.03879773f, 
    0.11804720f, -0.09014744f, 0.01213054f, -0.07570920f, -0.14274587f, -0.10089330f, 0.19476359f, 0.23709622f, 
    0.07131895f, -0.03303702f, -0.04796914f, 0.09565939f, 0.04266394f, -0.04816474f, -0.02523593f, -0.01529010f, 
    0.15161401f, -0.18816592f, 0.17869130f, 0.10735764f, -0.13628915f, 0.04258155f, -0.01129399f, -0.21093820f, 
    -0.14143974f, 0.03526193f, -0.11104368f, -0.00351157f, 0.19007124f, 0.11209830f, 0.23779771f, 0.12814957f, 
    -0.07581350f, 0.13085231f, -0.11251479f, -0.10780508f, 0.04577782f, 0.01482207f, -0.07390562f, -0.19053170f, 
    0.06599756f, -0.51410121f, -0.19109759f, -0.05449372f, -0.03125319f, -0.07449953f, -0.03333913f, -0.23005857f, 
    -0.32037261f, -0.23293932f, -0.29014090f, -0.34367996f, 0.35625333f, 0.37493846f, -0.04923544f, 0.02405172f, 
    0.14195125f, 0.23670205f, 0.10958327f, 0.00980140f, 0.21669090f, 0.07308669f, 0.40011665f, 0.06739494f, 
    -0.03122846f, -0.11645743f, 0.01974038f, 0.22542794f, 0.33914870f, -0.01494597f, 0.12191471f, 0.00473999f, 
    0.03715314f, 0.05669811f, 0.04562701f, 0.01702573f, 0.04111309f, -0.16905972f, -0.08148650f, 0.11636014f, 
    -0.11202494f, 0.02232574f, 0.20836729f, 0.05101292f, 0.18374434f, 0.12351729f, 0.22688897f, 0.06806879f, 
    -0.27835444f, 0.20289607f, 0.11206143f, 0.14223981f, 0.22086611f, 0.07301737f, 0.23653354f, 0.14787465f, 
    0.15202616f, 0.11969487f, -0.15204208f, -0.00526639f, -0.13630138f, -0.03172463f, -0.00531150f, -0.11060105f, 
    -0.12293606f, 0.15722549f, -0.05496319f, -0.16228664f, -0.00407928f, 0.04191261f, 0.09959392f, 0.06398910f, 
    0.17240433f, -0.03011404f, 0.35419554f, 0.12203654f, -0.30815542f, -0.17805783f, 0.07605898f, -0.02140802f, 
    0.18297538f, 0.31935495f, -0.22816035f, 0.19072038f, 0.02133325f, 0.19947669f, 0.21992053f, -0.05507064f, 
    0.04529294f, 0.03156018f, 0.05398121f, 0.06287140f, 0.12915103f, -0.25289044f, 0.00530732f, 0.18488358f, 
    0.04651601f, 0.10918316f, 0.07822982f, 0.02925508f, 0.00273776f, -0.11852816f, -0.03755710f, 0.39546317f, 
    0.08834525f, 0.10223550f, 0.00808321f, 0.02226707f, 0.15691634f, 0.14272070f, 0.06746525f, 0.09574037f, 
    -0.29131034f, 0.16748907f, 0.20223410f, 0.07191308f, 0.09780814f, -0.11132645f, -0.01222636f, -0.11811712f, 
    0.23727073f, 0.13193408f, 0.14548701f, 0.23286793f, -0.21285640f, 0.18637866f, -0.00429738f, 0.24303880f, 
    0.19849253f, 0.30742264f, 0.22066252f, 0.12916972f, 0.03248560f, 0.08829468f, 0.04959644f, 0.04358084f, 
    0.01110424f, -0.06003821f, -0.03824942f, -0.27389845f, 0.13009168f, 0.10541692f, 0.03955172f, 0.07772336f, 
    0.01480819f, 0.04891355f, -0.03025573f, 0.03829560f, -0.04120523f, 0.12959130f, 0.11259831f, 0.07929049f, 
    -0.08562016f, -0.27455634f, -0.24850227f, -0.46597719f, 0.17020699f, -0.02018748f, 0.04525881f, 0.02208746f, 
    -0.04896271f, 0.17055699f, 0.20886748f, 0.17076245f, 0.34904352f, 0.12241764f, -0.17278038f, 0.06219024f, 
    0.06811409f, 0.07379892f, -0.00036752f, 0.03140740f, 0.03748825f, -0.01588508f, -0.42605305f, -0.14788462f, 
    0.17761242f, 0.09814359f, 0.47400182f, 0.13335314f, 0.18224013f, 0.24125883f, 0.19133040f, 0.15689442f, 
    -0.12190032f, 0.08365157f, 0.27115068f, 0.08270560f, 0.17007948f, 0.20416440f, 0.13609232f, 0.08580603f, 
    0.20448971f, -0.10685694f, 0.07371645f, 0.28646898f, 0.04387319f, 0.21162860f, 0.04239437f, 0.18218544f, 
    -0.13452199f, 0.25782448f, -0.40467626f, 0.00973364f, -0.27389318f, 0.19531332f, 0.17888917f, -0.07838804f, 
    -0.14046989f, -0.15937276f, 0.17714937f, 0.24611841f, -0.08376209f, 0.10898023f, -0.12790978f, -0.10811634f, 
    0.06493030f, -0.04289208f, 0.01071351f, 0.06363694f, 0.53003687f, 0.04324351f, -0.24663419f, -0.17240307f, 
    0.04809532f, 0.13434143f, -0.00443608f, 0.05081488f, 0.15900742f, 0.35494223f, 0.00966797f, 0.08164117f, 
    0.00650141f, -0.07013944f, 0.15905349f, 0.05205420f, 0.18264005f, 0.20660159f, -0.10748240f, -0.11581153f, 
    -0.31063429f, -0.32770088f, 0.06728546f, 0.16303605f, -0.09153341f, -0.33238259f, 0.05744374f, 0.32405028f, 
    -0.27038538f, -0.01140726f, -0.19393294f, -0.06470519f, -0.21892095f, -0.19047052f, -0.47806713f, -0.04096433f, 
    -0.29787225f, -0.05233217f, -0.07862515f, 0.02269181f, 0.08733191f, -0.00350789f, -0.17381504f, -0.07903010f, 
    0.31264216f, -0.21003237f, 0.09714299f, -0.09288088f, 0.13928334f, 0.04577978f, 0.12988016f, 0.11066189f, 
    -0.18285190f, -0.32605827f, 0.28988001f, 0.09843173f, 0.04350227f, -0.10023897f, -0.04764664f, 0.04682275f, 
    0.37564120f, -0.16281836f, -0.13864318f, 0.14935815f, -0.04932884f, 0.21704577f, -0.16333541f, -0.14387453f, 
    -0.02251008f, -0.19499668f, -0.02911202f, -0.07585477f, -0.01585777f, 0.06388446f, -0.01030482f, -0.07337540f, 
    0.08206792f, -0.15523705f, -0.22150627f, 0.12117505f, -0.02182286f, 0.18772331f, 0.05318017f, -0.06686561f, 
    0.17117684f, 0.11945845f, 0.05889897f, 0.10717043f, -0.03092998f, -0.03644949f, -0.12382720f, -0.13288961f, 
    -0.01491437f, 0.13315873f, 0.05624860f, 0.06983897f, -0.04402716f, 0.21589023f, 0.13720213f, 0.01471628f, 
    -0.04099704f, -0.08628612f, -0.13408791f, 0.00432423f, 0.12385134f, -0.22694857f, -0.07982019f, -0.02379741f, 
    0.16790611f, -0.13274491f, -0.22491783f, 0.44795057f, 0.10061873f, 0.24760403f, 0.01112570f, -0.16410586f, 
    0.26320574f, 0.08679359f, 0.06513502f, -0.16897690f, 0.28649071f, -0.01956990f, 0.09908988f, 0.27371153f, 
    0.25934896f, 0.04118578f, 0.06118912f, -0.00881298f, 0.00595433f, -0.04826125f, -0.00791029f, -0.02579357f, 
    -0.23467709f, 0.13684686f, 0.03556645f, 0.21536449f, -0.10782816f, 0.18431625f, -0.00961678f, 0.10568476f, 
    0.11776511f, -0.11475297f, -0.26207832f, 0.39310998f, 0.06852159f, -0.16761713f, 0.12229706f, -0.10887921f, 
    0.33233494f, -0.22829594f, -0.12382869f, -0.07836243f, 0.01314287f, 0.02213536f, -0.24475318f, 0.16667353f, 
    -0.01638724f, 0.05087918f, 0.09579755f, 0.00983259f, -0.47406378f, 0.01416177f, 0.31524673f, -0.02708849f, 
    0.03700994f, -0.27164835f, 0.14089030f, 0.01126068f, -0.06304112f, -0.11763729f, -0.03936297f, -0.24254856f, 
    -0.11911279f, 0.07935946f, 0.53713065f, 0.00117358f, 0.01211505f, 0.13159087f, -0.15639479f, -0.19834302f, 
    0.34939975f, 0.17369737f, -0.15476726f, -0.37156931f, -0.02823157f, -0.00120317f, 0.17778853f, -0.33828467f, 
    -0.24569057f, 0.42908370f, -0.04147380f, 0.00832216f, -0.09085187f, -0.06964476f, 0.37006155f, 0.34032622f, 
    -0.44364712f, 0.06227204f, -0.00697492f, -0.14412181f, -0.17417775f, -0.00560921f, 0.07040221f, -0.02567255f, 
    -0.07778429f, -0.12739009f, -0.09753821f, -0.18559362f, 0.03766830f, 0.01222817f, -0.21799326f, 0.16153280f, 
    0.02121369f, 0.01689839f, -0.20436461f, -0.08963298f, -0.18694164f, 0.13564773f, 0.04568090f, 0.08252961f, 
    0.11951523f, 0.10743994f, -0.00722022f, -0.09541626f, 0.06823686f, 0.01417522f, 0.02171823f, -0.14856818f, 
    0.12950370f, 0.15383166f, -0.08634946f, -0.12406123f, -0.69276303f, -0.17710069f, -0.17855340f, -0.00869398f, 
    0.17113125f, -0.06976508f, 0.13409819f, -0.08969693f, -0.17462343f, -0.48842168f, -0.02192160f, -0.27886415f, 
    0.19388458f, 0.08068044f, -0.14780635f, -0.22727963f, 0.08976767f, 0.35617167f, -0.29297826f, -0.04499088f, 
    0.52200586f, 0.16313665f, 0.25941065f, -0.25498891f, -0.17984296f, 0.25463590f, 0.28145009f, -0.35935888f, 
    -0.31312662f, 0.22470744f, 0.04599132f, -0.19317894f, 0.38605511f, -0.01068361f, -0.05164072f, 0.00839258f, 
    -0.40412495f, -0.48054302f, -0.30362308f, -0.04147812f, -0.22418542f, -0.35951447f, -0.09556347f, 0.00160065f, 
    0.15246077f, 0.11785572f, -0.02854014f, 0.00199005f, -0.03537377f, 0.26637170f, 0.22752848f, 0.11121238f, 
    0.02306031f, -0.01716983f, -0.65136206f, -0.00845044f, -0.06070056f, -0.09446613f, -0.23810995f, -0.01338320f, 
    0.11698726f, 0.11004861f, -0.01741966f, 0.11776362f, 0.13679247f, -0.16528092f, 0.16357517f, 0.04810524f, 
    -0.12772574f, 0.02826487f, -0.10261859f, 0.06618054f, -0.37893045f, -0.09048717f, -0.19976945f, 0.02290063f, 
    -0.39861515f, 0.05746239f, 0.04976365f, -0.03821927f, 0.06810291f, -0.27968490f, 0.00601034f, 0.41394982f, 
    -0.03234304f, 0.02720516f, 0.14014085f, -0.09168536f, 0.05712840f, 0.16428688f, 0.15870000f, -0.03207814f, 
    -0.05348564f, -0.13415304f, -0.12662424f, -0.07584709f, 0.01011175f, -0.06514594f, 0.01861078f, -0.28427276f, 
    -0.09644634f, -0.07397768f, 0.15992373f, 0.08321386f, 0.02598149f, 0.19069891f, -0.03154860f, 0.28925014f, 
    0.20243891f, -0.04831814f, 0.10103698f, 0.02339769f, 0.07683808f, -0.13826127f, 0.00849216f, -0.01304248f, 
    0.12148387f, -0.13717973f, 0.11652812f, -0.39183217f, 0.01472853f, 0.07492831f, 0.02161076f, -0.00333157f, 
    0.19675407f, 0.03474291f, -0.06564409f, -0.15633187f, -0.28940761f, -0.01017942f, -0.08050004f, 0.07690760f, 
    0.01333489f, -0.00058607f, 0.11455544f, 0.12698232f, -0.02268671f, 0.54883462f, -0.03274614f, -0.04680729f, 
    0.00713613f, -0.07621137f, 0.00742206f, -0.08103526f, -0.36200231f, -0.00729016f, -0.19085011f, 0.10014620f, 
    -0.13938044f, 0.02499524f, 0.10196815f, 0.14813314f, 0.03213050f, -0.30802631f, 0.08558085f, 0.13234454f, 
    -0.13800518f, -0.12749085f, -0.02190103f, 0.01539853f, 0.11909266f, -0.03153611f, 0.00226057f, -0.04660261f, 
    0.10326748f, 0.11639605f, 0.01752705f, 0.18704052f, -0.01938775f, -0.00451837f, 0.09569868f, 0.27147770f, 
    0.44164565f, -0.02162804f, -0.15128532f, 0.06017029f, 0.06267968f, 0.23836312f, -0.03410372f, -0.11204965f, 
    -0.12211992f, -0.03421659f, -0.04773764f, -0.29795009f, -0.06130392f, -0.15977129f, 0.09007581f, -0.06040877f, 
    -0.00026667f, 0.07105824f, 0.11096837f, -0.28116468f, -0.16631411f, 0.14502358f, -0.07393749f, 0.07777815f, 
    0.04836284f, 0.22990383f, 0.09578662f, 0.05420276f, -0.52019209f, -0.18458079f, 0.04471732f, -0.11852612f, 
    0.06955311f, 0.07796083f, 0.04183457f, -0.33388585f, -0.03469563f, -0.05214038f, -0.16895239f, -0.04562638f, 
    -0.12970275f, 0.03873612f, -0.01625686f, 0.07069006f, 0.04126910f, 0.01677366f, -0.03505825f, 0.00919305f, 
    -0.05316566f, 0.16192891f, 0.00015898f, 0.07174122f, 0.00064647f, 0.36780247f, 0.08063423f, -0.11297565f, 
    0.00797536f, 0.00156775f, -0.09878378f, 0.18373424f, 0.07422815f, -0.02389261f, -0.05627913f, -0.17471969f, 
    0.06154448f, -0.09882466f, -0.09931723f, -0.36845654f, 0.14045802f, -0.03509580f, -0.06910574f, -0.35963359f, 
    0.07749970f, 0.18392803f, 0.09809596f, -0.11804108f, 0.07134797f, -0.10153916f, -0.01918245f, -0.00921451f, 
    -0.27726030f, -0.17771192f, -0.39300230f, -0.08244953f, -0.10799635f, -0.20216869f, -0.05374104f, 0.00987222f, 
    0.06006449f, 0.15333679f, 0.08796057f, 0.24682599f, -0.05279230f, 0.04407774f, 0.00749516f, 0.00996417f, 
    -0.09576229f, 0.07303155f, -0.13622977f, -0.07246910f, -0.02774177f, -0.17403843f, -0.12234622f, -0.09103674f, 
    0.01440517f, 0.02559008f, 0.13329355f, 1.20449173f, 0.05849944f, 0.07282241f, -0.10082418f, 0.05995346f, 
    -0.06236580f, -0.14365445f, -0.01736445f, -0.02992674f, 0.07435190f, 0.07517679f, 0.13140386f, 0.06369168f, 
    0.07040459f, 0.02623271f, 0.22742453f, 0.22107992f, 0.01402706f, 0.03134988f, 0.40266591f, 0.55109364f, 
    -0.05789185f, -0.18109196f, -0.15021001f, 0.17960851f, 0.00514210f, -0.05557102f, 0.56318724f, 0.17490259f, 
    0.05505091f, 0.02673979f, -0.11500008f, -0.01307544f, 0.04430067f, -0.06046001f, -0.01216237f, -0.31146872f, 
    -0.41521111f, -0.38716757f, 0.03711202f, 0.03878672f, 0.07144295f, 0.07947330f, -0.01032564f, 0.07925903f, 
    -0.02237975f, -0.01553600f, -0.03989211f, -0.03399564f, -0.02976651f, -0.00722583f, -0.01527843f, 0.00627607f, 
    0.02288049f, -0.00063540f, 0.00403691f, 0.02908746f, 0.04083801f, -0.03418405f, -0.03415243f, -0.03127279f, 
    0.01691238f, -0.02009711f, -0.05439023f, 0.01521813f, -0.05049747f, 0.00319227f, -0.06133832f, -0.03980457f, 
    0.04904383f, -0.02834300f, 0.01175085f, 0.05268865f, -0.01612386f, 0.01930279f, -0.03529392f, -0.06112957f, 
    -0.05782835f, -0.01434081f, 0.01693240f, 0.01153407f, -0.00201922f, 0.00780177f, 0.03378800f, -0.03000922f, 
    0.00138245f, -0.04054247f, -0.04961184f, 0.01834830f, -0.04496428f, -0.02923793f, -0.03139884f, 0.01159524f, 
    -0.00062314f, 0.00274908f, -0.03676422f, 0.00627054f, 0.01929636f, 0.03112155f, 0.00675247f, 0.00583312f, 
    0.03141155f, 0.00634867f, -0.02534264f, 0.04471010f, -0.03571764f, -0.02428938f, -0.01191447f, 0.02560920f, 
    -0.03642042f, -0.01530895f, 0.03649049f, -0.01059296f, -0.01247244f, -0.01148051f, -0.03257441f, 0.01430317f, 
    -0.01841420f, -0.02927902f, -0.02683623f, -0.02227814f, -0.00662265f, 0.03581542f, -0.04202180f, -0.04067030f, 
    0.00025688f, 0.00935798f, -0.03033273f, -0.03555666f, -0.02984077f, 0.04759547f, 0.04018265f, -0.01509627f, 
    0.04733987f, -0.06234337f, -0.04116228f, -0.02140065f, 0.04351355f, -0.01336874f, -0.04767893f, 0.03056294f, 
    0.03151281f, -0.06811076f, -0.06123103f, -0.03779848f, 0.04884684f, 0.04223628f, -0.03747408f, -0.05417291f, 
    0.04305833f, -0.04324708f, -0.05035155f, 0.04226906f, 0.05076623f, 0.04543612f, 0.03238806f, -0.04864243f, 
    -0.00720445f, -0.02285407f, 0.03178789f, -0.01696442f, -0.05052857f, -0.00382598f, 0.00728161f, 0.02580669f, 
    0.01871629f, 0.02808070f, -0.02953336f, -0.04261144f, 0.02433532f, -0.05580136f, -0.05204218f, 0.02945562f, 
    0.04348904f, 0.02026030f, -0.01667583f, -0.04145334f, -0.00458592f, -0.02560569f, -0.04489392f, -0.05405737f, 
    -0.03233188f, 0.01080434f, -0.01789809f, 0.04039009f, 0.03949172f, 0.04552798f, -0.06467523f, -0.00155840f, 
    -0.04932435f, -0.01685937f, -0.03692887f, -0.02772952f, 0.04226117f, -0.02047313f, -0.06758078f, 0.04011531f, 
    -0.06087942f, 0.02209224f, 0.03365047f, 0.00334104f, 0.03368469f, -0.03495494f, -0.01364169f, -0.06282793f, 
    0.04037419f, 0.00444308f, 0.00239350f, -0.04187749f, 0.03150895f, -0.01376156f, 0.04616367f, -0.02572026f, 
    -0.04528601f, 0.02571976f, -0.01393555f, 0.01402728f, 0.02563907f, 0.00102937f, 0.04824023f, -0.03768723f, 
    -0.05598311f, -0.01651767f, -0.03137879f, -0.05285766f, -0.05215196f, -0.06232190f, 0.01270421f, -0.02284870f, 
    -0.05650354f, -0.01169192f, -0.05889912f, 0.00508667f, -0.02999548f, -0.04573105f, -0.03691313f, 0.01869314f, 
    -0.01636773f, -0.02739393f, -0.02577454f, 0.04744327f, -0.02606894f, -0.02075114f, 0.00645184f, -0.02624892f, 
    0.04310059f, -0.00064133f, -0.02292432f, 0.01935625f, -0.03129162f, 0.03826062f, -0.04058703f, 0.00555812f, 
    -0.00846412f, -0.06218280f, 0.01918611f, 0.04562577f, -0.01406475f, 0.02759258f, 0.01596397f, -0.05030051f, 
    0.03364526f, 0.01700065f, -0.05890172f, -0.00299975f, 0.01136210f, 0.04667189f, -0.06186511f, -0.05202727f, 
    -0.02721652f, -0.01254183f, -0.06111002f, 0.04127726f, 0.04586382f, -0.03411655f, -0.00892752f, -0.06040812f, 
    -0.02828451f, -0.00208051f, -0.03812898f, -0.00331094f, -0.00000438f, 0.01750059f, 0.01988371f, 0.02431324f, 
    0.03390241f, -0.03867627f, 0.01301634f, -0.03957929f, -0.05984309f, 0.02307358f, -0.04564122f, 0.00815774f, 
    0.00149063f, -0.06622734f, -0.06098440f, 0.00500996f, -0.02380369f, -0.06095626f, -0.02171036f, -0.02188533f, 
    0.04666599f, 0.01814410f, 0.02948790f, -0.00006931f, -0.04286024f, -0.01204126f, -0.01295955f, -0.02075944f, 
    -0.00319069f, 0.05445839f, 0.02935434f, 0.05445565f, -0.02684304f, -0.03530732f, 0.01079757f, 0.01053846f, 
    -0.02199350f, 0.02998739f, 0.01765670f, 0.00022432f, 0.03849655f, 0.02621549f, -0.01662468f, -0.06651432f, 
    0.00890863f, 0.00654260f, -0.00401451f, 0.01885881f, 0.00044025f, 0.02069618f, 0.02487077f, -0.02022158f, 
    0.02939644f, -0.00738570f, 0.00661681f, 0.05132958f, 0.03817178f, -0.01317901f, -0.05263732f, -0.00304681f, 
    -0.00412663f, 0.01264220f, -0.06079225f, -0.06248109f, 0.03796663f, 0.02658652f, -0.00953589f, -0.00357325f, 
    -0.00578644f, -0.03481219f, -0.00694537f, 0.02775580f, 0.01164291f, -0.06430656f, 0.00057737f, -0.03074763f, 
    -0.01473617f, -0.02824708f, -0.03201945f, -0.00746690f, 0.01627121f, -0.05231190f, -0.04920506f, 0.04268552f, 
    -0.05749934f, -0.03864768f, 0.04836882f, 0.04949184f, 0.02187628f, 0.00223558f, 0.04040848f, 0.00855891f, 
    -0.02977655f, -0.02706415f, 0.04672166f, -0.02381616f, -0.04786065f, -0.02245986f, 0.03786881f, -0.03098935f, 
    -0.01160867f, -0.06013259f, 0.03240383f, 0.01962150f, -0.00829020f, 0.00043855f, -0.03267258f, -0.04449117f, 
    -0.03890090f, 0.03450843f, -0.03530969f, -0.06318440f, -0.02249138f, -0.04102221f, 0.00721443f, -0.04592993f, 
    0.03508884f, -0.05411147f, -0.02871819f, 0.03738012f, -0.01790463f, 0.01096224f, -0.02136041f, -0.02579855f, 
    0.01809746f, 0.01239984f, 0.00149977f, 0.00246160f, -0.04284813f, -0.04507687f, -0.05401450f, -0.01641827f, 
    -0.00756141f, 0.03587895f, 0.00229963f, -0.02432869f, 0.02820490f, -0.03699221f, 0.03814373f, 0.00244002f, 
    -0.05166424f, 0.02768390f, 0.02966057f, -0.05989926f, 0.02467795f, -0.03059012f, -0.05712905f, -0.05982428f, 
    -0.02524095f, -0.06054832f, 0.02207460f, -0.03150840f, 0.00561716f, 0.03836346f, 0.04642811f, 0.04756676f, 
    -0.06162083f, 0.01966237f, -0.01347246f, 0.04922197f, -0.00900984f, -0.03327232f, -0.03747275f, 0.04849152f, 
    0.03899512f, 0.01638007f, -0.04675141f, -0.03681609f, 0.00124202f, -0.04844709f, 0.00921043f, 0.02828257f, 
    -0.00575399f, -0.01432647f, 0.03057554f, -0.05323988f, -0.03378572f, -0.05512527f, -0.04535011f, -0.06136156f, 
    0.01777061f, -0.05008659f, 0.00572576f, -0.04402389f, -0.06255171f, 0.03623218f, -0.05690042f, -0.03535169f, 
    -0.06104093f, 0.00419180f, -0.04785179f, 0.04037385f, 0.02878949f, -0.03316879f, -0.04746084f, -0.03409478f, 
    0.00064248f, 0.00237495f, -0.01351559f, 0.02602400f, 0.01400917f, -0.00170706f, -0.06184108f, 0.01876128f, 
    -0.03171762f, -0.05975465f, 0.04696866f, -0.04429531f, 0.01963116f, -0.04874204f, -0.02838420f, -0.00149493f, 
    0.02941006f, -0.05738339f, -0.04700760f, 0.04623710f, 0.01324256f, 0.01669382f, 0.02793839f, -0.03208586f, 
    0.03683136f, 0.00403686f, 0.02394514f, 0.02279713f, -0.04138391f, -0.03421449f, -0.00562895f, -0.00069520f, 
    0.04208695f, 0.03466142f, 0.01170272f, -0.05635281f, -0.01688137f, 0.03012869f, -0.02817368f, -0.03368467f, 
    0.00197230f, 0.00862951f, -0.00940398f, -0.01812406f, 0.02321385f, 0.03600636f, -0.03510993f, 0.04837658f, 
    0.05065466f, 0.02436585f, -0.01784612f, 0.00540080f, -0.04974589f, 0.00127396f, -0.05721846f, 0.00502358f, 
    -0.02647063f, -0.04414304f, -0.05612890f, 0.02382917f, -0.01278061f, -0.04742552f, 0.05085298f, -0.02954899f, 
    0.05060944f, -0.02467894f, 0.00150418f, 0.04569724f, 0.04774067f, -0.03810749f, -0.01738119f, -0.03399671f, 
    -0.00238651f, -0.01155003f, -0.04424075f, -0.03609631f, 0.04536120f, -0.04678790f, 0.02541480f, 0.01601220f, 
    0.02266480f, -0.02585242f, -0.03694841f, -0.03585665f, -0.01601698f, 0.04940883f, -0.02921395f, -0.02359184f, 
    -0.04968519f, -0.05724700f, -0.00034620f, 0.03577637f, -0.01274632f, 0.02714960f, 0.01800775f, -0.04360233f, 
    -0.03288645f, -0.03125533f, 0.03652612f, -0.06326096f, 0.00279084f, 0.00009223f, 0.00119156f, 0.03123536f, 
    -0.02097473f, 0.03023841f, -0.01494021f, -0.00411664f, 0.00977515f, -0.02517760f, -0.04825459f, -0.01515966f, 
    -0.00740877f, 0.00289760f, 0.03791276f, -0.01972128f, 0.04902705f, -0.00844998f, -0.02331543f, 0.03817124f, 
    -0.01996124f, 0.03512961f, -0.01184311f, -0.00845641f, -0.04366171f, -0.00581292f, -0.02876325f, -0.05409387f, 
    -0.05250353f, 0.01033855f, -0.00197906f, 0.03265644f, -0.00259376f, -0.02704948f, -0.00774908f, -0.01791988f, 
    0.02586180f, -0.04181910f, 0.01016434f, 0.02242374f, -0.04547430f, -0.02400734f, -0.03832147f, 0.04745853f, 
    0.36958522f, -0.20335117f, -0.11655788f, 0.00397206f, 0.09989202f, -0.06904355f, 0.17899825f, 0.18627578f, 
    0.37292671f, -0.00448361f, 0.07460332f, -0.08343141f, -0.14216812f, -0.06321474f, -0.02259284f, -0.04844653f, 
    0.06185112f, -0.04244268f, -0.17879751f, 0.22707033f, 0.13327239f, 0.06556084f, -0.00129170f, -0.05205747f, 
    0.12442981f, 0.30259678f, 0.24603598f, -0.09803084f, -0.06353357f, 0.22311619f, 0.10958647f, 0.11860340f, 
    0.08432881f, 0.17786358f, 0.15824416f, -0.22207032f, -0.69117075f, -0.63098973f, 0.23588549f, 0.03076766f, 
    0.09387237f, 0.12895682f, 0.02200530f, 0.02743178f, -0.14435360f, -0.25907269f, 0.02284239f, -0.02628012f, 
    0.11929694f, -0.18321796f, 0.09358077f, 0.14625791f, 0.24387008f, 0.05474434f, -0.02230960f, -0.19113493f, 
    0.13191962f, -0.03602124f, 0.18686371f, 0.13387626f, -0.15681694f, 0.10173669f, -0.22792657f, 0.20179284f, 
    -0.21283877f, 0.67147815f, -0.07047601f, -0.15865459f, -0.09551870f, 0.14792168f, -0.02182833f, -0.07081545f, 
    -0.19268583f, -0.13773707f, 0.14994282f, -0.12848893f, -0.13192292f, -0.13956320f, 0.21858288f, -0.06624912f, 
    -0.17491449f, -0.09166630f, -0.14968549f, 0.29409844f, -0.03167254f, 0.10549861f, 0.08575023f, 0.24643281f, 
    -0.13900737f, 0.08825670f, -0.03563724f, 0.18962386f, -0.25515130f, -0.06565768f, -0.00296571f, 0.02249547f, 
    0.12599294f, 0.26629806f, 0.27289993f, -0.24936883f, -0.35661155f, -0.24326390f, 0.01455211f, -0.05422336f, 
    -0.13287334f, 0.18378338f, -0.19468278f, -0.09358750f, 0.10998446f, -0.01319705f, -0.05990648f, 0.12701656f, 
    0.12453268f, 0.11408090f, 0.02491492f, 0.03868288f, 0.09273972f, -0.75353199f, -0.43698373f, -0.10909430f, 
    0.04381635f, -0.02721553f, -0.05668084f, 0.00299687f, 0.00819757f, -0.23172450f, 0.04838478f, 0.18424545f, 
    0.23173517f, 0.07167422f, 0.00943227f, -0.27088818f, 0.08494318f, 0.08286412f, 0.22831663f, 0.12658627f, 
    0.08838305f, 0.01032785f, -0.15028150f, 0.03770804f, -0.03653099f, -0.08155577f, -0.09326688f, -0.07594357f, 
    -0.51833123f, -0.09669272f, 0.14398710f, 0.10685887f, 0.00736831f, -0.08392645f, -0.03871354f, 0.03244653f, 
    0.16337764f, -0.21178974f, 0.19221164f, 0.16509482f, -0.07656115f, 0.27463308f, 0.05757000f, 0.08963007f, 
    -0.13520257f, 0.16620703f, -1.10901940f, -0.56879973f, 0.36984414f, -0.20787466f, 0.01573914f, -0.25732875f, 
    -0.05934916f, -0.06242637f, -0.06252471f, 0.03796466f, 0.18032202f, 0.18032408f, -0.06901761f, -0.25671086f, 
    0.07361969f, 0.06822344f, -0.13236256f, -0.08018240f, 0.12551582f, 0.17113335f, -0.24019049f, 0.16250327f, 
    -0.28235337f, 0.22071370f, 0.04087113f, 0.09622595f, -0.06609935f, 0.14866802f, 0.28247941f, -0.18737003f, 
    -0.12822330f, 0.17198798f, 0.19568059f, -0.01914478f, -0.14117806f, 0.05344318f, 0.11057048f, -0.07884055f, 
    0.21184415f, -0.01181088f, 0.04998492f, 0.20823960f, 0.20398636f, -0.01268717f, 0.10140884f, -0.34921390f, 
    0.10042341f, -0.12066597f, -0.20353618f, 0.06137556f, -0.05373574f, 0.06840444f, -0.08518957f, 0.08032168f, 
    -0.59326833f, -0.31911996f, 0.39387867f, -0.11258256f, 0.19198793f, -0.11335874f, 0.03764315f, -0.03091515f, 
    0.05459428f, -0.29076338f, -0.16264893f, 0.14524017f, -0.19371596f, -0.11569057f, -0.00883510f, 0.25797665f, 
    0.05157828f, -0.00667055f, -0.04240367f, 0.02524287f, 0.16605856f, 0.20594893f, -0.07916663f, -0.35539216f, 
    -0.13850318f, -0.07444852f, 0.00662922f, -0.36287692f, -0.43704459f, -0.20772383f, -0.01983246f, -0.10453295f, 
    -0.19751577f, -0.08934323f, 0.14929788f, -0.08510644f, 0.25234076f, 0.06108439f, 0.03116089f, -0.07577610f, 
    -0.07849220f, 0.15754761f, 0.03330670f, 0.09723776f, 0.08632513f, 0.63995820f, 0.09071635f, -0.11322609f, 
    -0.05361336f, 0.01966167f, 0.07866894f, -0.08168264f, -0.07836638f, -0.19370952f, 0.22068039f, 0.43589574f, 
    -0.12519991f, -0.05997951f, -0.30071443f, 0.04296909f, 0.07213286f, -0.21536136f, 0.04921244f, 0.20207337f, 
    0.01897180f, 0.33420345f, 0.05502938f, -0.00686963f, 0.03992174f, -0.05392271f, 0.05871408f, 0.00951618f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.14637034f, 0.08850272f, -0.12113515f, 0.49299720f, 0.04169076f, 0.14736965f, 0.10956476f, 0.17973208f, 
    0.03347256f, -0.01437042f, 0.25316843f, 0.29847252f, -0.07891808f, 0.10287139f, 0.11910163f, 0.10219033f, 
    0.00948133f, 0.17967549f, -0.16302575f, -0.06149955f, 0.14358197f, -0.00255220f, 0.18572633f, -0.10715120f, 
    0.22378705f, 0.27527398f, 0.12026940f, 0.06492446f, 0.29723987f, 0.02949859f, -0.02723640f, 0.13067883f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.16522466f, -0.48351353f, 0.10895209f, -0.28055823f, -0.03012489f, 0.17763089f, -0.45209417f, 0.42959836f, 
    0.38253745f, 0.07335518f, -0.32508263f, -0.42211479f, 0.55314809f, 0.45837933f, -0.21582428f, 0.22219947f, 
    0.00255255f, 0.27986163f, 0.41120020f, -0.08265858f, -0.11950015f, 0.08607566f, -0.85755301f, 0.07059374f, 
    -0.51054788f, -0.07505229f, -0.20808327f, -0.20271061f, -0.12453693f, 0.12988912f, -0.11958474f, 0.29132879f, 
    -0.33594707f, -0.07927912f, 0.00993504f, 0.08260620f, -0.17231357f, -0.33049691f, 0.17355059f, 0.32969043f, 
    0.39071387f, 0.10135044f, 0.26397493f, 0.28081438f, 0.09858006f, 0.31690550f, 0.16583237f, 0.13784945f, 
    -0.07377315f, 0.37563825f, -0.18295714f, -0.12647443f, -0.17946191f, 0.17631386f, -0.20932502f, -0.15963829f, 
    -0.19833560f, 0.43126827f, -0.29285428f, -0.17459825f, 0.77232605f, 0.00219761f, -0.14927377f, -0.31171325f, 
    -0.42201963f, -0.53237659f, -0.10673899f, 0.28932300f, 0.04000286f, -0.26506421f, -0.21202083f, 0.13524716f, 
    -0.80921382f, -0.00278501f, -0.41547355f, 0.16263513f, -0.58192760f, 0.00575686f, 0.14822026f, -0.04970171f, 
    0.15004879f, -0.14323336f, -0.63354683f, 0.18379524f, 0.12595238f, -0.33249655f, 0.38007361f, 0.00775939f, 
    0.45433214f, -0.55579716f, -0.02006760f, -0.14536740f, 1.00217724f, -0.02549965f, -0.16032736f, -0.19636346f, 
    -0.36929005f, 0.13685650f, 0.15338863f, -0.44213420f, -0.16106151f, 0.06586625f, 0.32547250f, -0.31655023f, 
    -0.44121215f, 0.03096108f, -0.17612880f, -1.09457922f, 0.14962606f, 0.44700715f, -0.45449337f, -0.57041872f, 
    -0.10643704f, 0.19855234f, 0.23863836f, 0.12535323f, -0.59437811f, -0.05191699f, 0.53101242f, 0.06884922f, 
    0.02834978f, -0.55284542f, 0.28306079f, -0.31287244f, -0.14868356f, 0.15543537f, -0.00891410f, 0.13127269f, 
    0.45008653f, 0.40290737f, 0.69900453f, -0.37546644f, -0.08768797f, -0.30959088f, -0.28222972f, 0.01761788f, 
    0.08204895f, 0.14923038f, 0.19691335f, 0.29779986f, -0.44116390f, -0.12825330f, -0.04169624f, 0.22406003f, 
    0.02228533f, 0.15533763f, 0.09303851f, 0.21640083f, 0.03625593f, -0.23317386f, -0.28836173f, 0.14163212f, 
    -0.22145706f, -0.33415186f, -0.03475212f, -0.02057957f, -0.15499699f, -0.07845303f, -0.12116353f, -0.42863059f, 
    0.18759353f, -0.24318440f, -0.57036304f, 0.15831588f, -0.00899596f, -0.01961481f, -0.26959509f, -0.02077067f, 
    0.68867207f, 0.14979039f, 0.34294361f, -0.05695434f, 0.09482852f, -0.24314989f, 0.26318458f, -0.41335243f, 
    0.14065616f, -0.22188979f, 0.43981969f, 0.51325357f, -0.15014079f, 0.35490885f, 0.15749939f, -0.23537353f, 
    -0.03887128f, 0.10776941f, -0.23595271f, -0.20855905f, -0.38230348f, -0.07629740f, -0.13625769f, 0.23252000f, 
    0.06605035f, -0.79441464f, -0.37476176f, 0.54430151f, -0.02546683f, 0.45521322f, -0.03648503f, -0.32279187f, 
    -0.55561978f, 0.10215873f, -0.24639925f, 0.50042641f, 0.24377723f, -0.03092263f, -0.26786840f, -0.09545106f, 
    -0.11631107f, -1.35478568f, -0.54947555f, -0.29770654f, -0.06642739f, -0.47460222f, 0.17019786f, 0.39338839f, 
    -0.07706427f, -0.31198293f, 0.28182447f, 0.22622530f, 0.13487597f, -0.06343679f, -0.15015136f, -1.27258193f, 
    -0.12963654f, 0.31928104f, 0.59303224f, -0.54640323f, 0.06429328f, 0.61131573f, 0.60538530f, 0.17857066f, 
    -0.16176280f, 0.01153550f, -0.23337729f, -0.31286746f, 0.04815621f, 0.06614856f, -0.04139554f, 0.16302608f, 
    0.13548696f, -0.35283649f, -0.42870662f, 0.09509521f, -0.30365333f, -0.07549334f, -0.09093270f, 0.03663918f, 
    -0.18626285f, 0.50087225f, -0.06274118f, -0.13087653f, -0.20958534f, 0.01005487f, -0.18108428f, -0.70647031f, 
    0.01486735f, 0.48603645f, -0.17976743f, 0.27918470f, 0.02926536f, 0.76143330f, 0.08993968f, -0.72839355f, 
    -0.55041826f, -0.08551091f, -0.05258311f, -0.17286703f, -0.16168860f, -0.04828517f, -0.00571139f, -0.59612608f, 
    -0.04651026f, 0.22663130f, -0.90653712f, -0.26467490f, 0.10170576f, 0.52552032f, 0.33281392f, -0.25084770f, 
    -0.18034983f, 0.32392412f, -0.25569642f, -0.48863918f, 0.28594437f, 0.05401114f, 0.04719136f, 0.28121388f, 
    0.63041520f, 0.08272091f, -0.76264596f, 0.15433873f, 0.13029146f, -0.23360974f, -0.17735747f, 0.45112184f, 
    -0.00192100f, 0.01151394f, 0.21800162f, -0.47302094f, -0.52074850f, -0.30350664f, -0.20355661f, 0.33710733f, 
    -0.08026285f, 0.17060591f, -0.33610117f, -0.53564978f, 0.15732557f, -0.58829606f, -0.37954837f, 0.20259988f, 
    -0.18490860f, -0.09902839f, 0.30399841f, -0.12229107f, -0.33442774f, -0.10580988f, -0.12277751f, 0.53683549f, 
    0.25353599f, 0.01782599f, -0.17511639f, 0.33693603f, -0.18212813f, -0.55805993f, 0.29300603f, -0.84954077f, 
    -0.86781216f, 0.05716556f, -0.06329343f, 0.30209941f, -0.53065664f, -0.59763414f, 0.23586464f, 0.72130543f, 
    0.00700664f, -0.15869802f, 0.36441550f, 0.09941870f, -0.55023527f, 0.50177926f, 0.33671346f, -0.27546409f, 
    0.07565157f, -0.31560576f, -0.35736924f, -0.17744750f, -0.52517861f, 0.12662220f, -0.07352293f, 0.54765964f, 
    -0.65762758f, 0.20457388f, -0.36483353f, -0.16446427f, -0.14103800f, -0.56215286f, 0.14105065f, -0.31952846f, 
    -0.17999157f, -0.06658295f, 0.02553330f, -0.15186793f, 0.58080232f, -0.24160759f, 0.42592719f, -0.34152651f, 
    0.12153389f, -0.22789942f, 0.15708895f, -0.61593831f, 0.40686762f, -0.16340569f, 0.10903937f, 0.08043463f, 
    0.10691246f, -0.29967535f, -0.07679912f, 0.81179708f, -0.81329095f, -0.13476811f, -0.14423789f, 0.08209160f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.25997019f, 0.11770210f, 0.25115573f, -0.11920381f, 0.12017247f, -0.01346600f, -0.03243361f, -0.25865483f, 
    0.06602503f, 0.06688417f, -0.13363369f, -0.14041543f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
