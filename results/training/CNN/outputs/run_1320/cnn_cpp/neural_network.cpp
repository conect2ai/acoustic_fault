#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.48128575f, 1.30953717f, 0.14299807f, 0.65875316f, -1.04568028f, -1.10922539f, -0.71987802f, -0.30867386f, 
    0.14620115f, 0.41600582f, 0.33166999f, -0.43238565f, -0.18255424f, 0.27185261f, 0.16429447f, 0.11894614f, 
    0.12644088f, 0.18377563f, 0.17595963f, -0.25231892f, 0.00856752f, 0.19815353f, -0.35530198f, -0.20935220f, 
    -0.33600697f, -0.19555035f, -0.32173252f, 0.03755952f, 0.59433025f, 0.61062151f, 0.49009773f, 0.24339610f, 
    -0.27914095f, 0.05838170f, 0.53859395f, 0.10387529f, 0.01834628f, -0.02262410f, -0.14546920f, 0.26982638f, 
    -0.13623036f, 0.02677511f, -0.11208913f, 0.07202217f, -0.08786555f, -0.30644172f, -0.33298591f, -0.21518011f, 
    -0.29299247f, -0.31230339f, 0.10369395f, -1.17429817f, 0.06486388f, 0.67058980f, 0.14695619f, 0.87921691f, 
    0.70492071f, -0.63799232f, -0.39369196f, -0.62275738f, 0.81213146f, -0.61794490f, -0.15475772f, -0.16665006f, 
    -0.29277185f, 0.08518123f, 0.05628193f, 0.11211962f, 0.34659085f, -0.36971590f, -0.05871177f, 0.04943429f, 
    -0.13586661f, -0.18016440f, 0.04464744f, -0.76812845f, -0.45788062f, -0.33019245f, -0.53511888f, -0.34357145f, 
    -0.44948798f, -0.53420269f, -0.49725825f, -0.44025463f, -0.55718595f, 0.28782636f, 0.61088246f, 0.20791204f, 
    -0.09275859f, -0.46395180f, -0.19093762f, -0.26442826f, -0.30957204f, -0.31528386f, -0.39821565f, -0.25340682f, 
    0.02473889f, -0.28431690f, -0.31438801f, -0.37675801f, -0.13719910f, -0.72086316f, -1.04850161f, -0.90819883f, 
    -0.91932660f, 1.11592042f, 1.00687182f, 0.15209793f, -0.40504146f, 0.92534918f, 0.03117032f, 0.42573565f, 
    -0.29204795f, 0.01584102f, -0.15236048f, -0.06728434f, -0.07865334f, 0.22609019f, -0.16628253f, -0.08804903f, 
    -0.11163588f, -0.05911994f, -0.17548226f, 0.22583675f, -0.05268580f, -1.06738317f, -0.45065889f, -1.03039181f, 
    0.00576120f, -0.09289964f, 0.07937831f, 0.41636324f, -0.68760931f, -0.64713007f, -0.05314592f, -0.42662537f, 
    -0.68324077f, -0.66628897f, -0.60052973f, -0.32199979f, -0.42311424f, -0.05210406f, -0.05460799f, -0.44700500f, 
    -0.32366759f, 0.01980862f, -0.20186083f, -0.01221101f, 0.05845238f, -0.09708924f, -0.81206656f, -0.72870255f, 
    -0.31404346f, -0.08407477f, -0.00906799f, -0.84589833f, -1.03791988f, -0.49424088f, -0.00161872f, -0.67602849f, 
    0.26575771f, -0.22852781f, 0.05861595f, 0.45121369f, 0.43282145f, 0.05988277f, -0.13826551f, 0.09188266f, 
    -0.34012511f, -0.40672770f, 0.00868286f, 0.47623283f, 0.04554110f, 0.06679758f, 0.55438852f, 0.52712005f, 
    -0.19840865f, 0.34692886f, 0.19436638f, 0.07792486f, -0.05172426f, -0.16958040f, -0.47352222f, -0.00434192f, 
    0.38387293f, 0.35551444f, -0.34558240f, 0.05059713f, 0.02049340f, 0.44833332f, 0.14438960f, 0.27835515f, 
    0.09923118f, 0.05084676f, 0.21395417f, -0.14522985f, 0.31041661f, 0.39491728f, -0.04689196f, 0.35815966f, 
    0.53337854f, 0.62368643f, 0.60760611f, 0.28941026f, 0.41372654f, 0.12865676f, 0.27691200f, 0.18290277f, 
    0.18299507f, -0.04280305f, 0.15366845f, 0.05062604f, 0.26314878f, -0.16089670f, -0.25846243f, -0.00222230f, 
    -0.18636787f, -0.10105693f, -0.09855127f, 0.04528979f, 0.20699500f, 0.01395548f, -0.02653467f, 0.11839616f, 
    -0.17319377f, -0.99682432f, 0.72848177f, 0.84400856f, 0.07385842f, -0.17876646f, -0.15588017f, 0.12831807f, 
    -0.20267572f, 0.02931851f, -0.13163656f, -0.30540684f, 0.11976455f, -0.03243480f, 0.13122992f, -0.25299102f, 
    0.04056675f, 0.11046433f, -0.04021951f, -0.43617275f, -0.27675176f, -0.24942666f, -0.39106089f, -0.20137540f, 
    -0.09181567f, -0.71385348f, 0.45534247f, -0.30416739f, 0.22059020f, -0.68071842f, -1.03227246f, 0.31502604f, 
    -0.25316301f, -0.38303652f, 0.03219888f, -0.05601558f, 0.10930399f, 0.41726357f, 0.53598207f, 0.51620328f, 
    0.42811653f, -0.04006792f, 0.20640086f, 0.24789472f, 0.31690532f, -0.03180151f, -0.07334473f, -0.28242236f, 
    -0.02955327f, 0.02088969f, -0.33728310f, 0.73564005f, 0.45324835f, 0.20861828f, -0.32147306f, -0.47806460f, 
    0.01259213f, 0.39885691f, 0.16879934f, -0.06206020f, -0.14001606f, 0.02507791f, 0.00041924f, -0.01938705f, 
    0.12679192f, -0.53806996f, -0.39422971f, -0.41674301f, 0.01045364f, 0.02091469f, 0.31373072f, -0.25999129f, 
    0.17420736f, 0.17330185f, -0.02867481f, 0.52013916f, -1.24693918f, 0.80683053f, 1.16374767f, -0.98468941f, 
    0.34321940f, -0.70815194f, -0.11864290f, 0.30362651f, 0.08767280f, -0.17523731f, -0.39400759f, -0.28256255f, 
    0.36788335f, -0.80268478f, 0.23937689f, 0.21159482f, -0.02372552f, -0.19057593f, 0.17476667f, -0.05628457f, 
    -0.13843007f, 0.21649382f, 0.13629526f, -0.10090651f, 0.22280976f, 0.49361283f, 0.37990537f, -0.48798877f, 
    -0.20968437f, 0.25778785f, -0.73724192f, -0.49151924f, 0.28311345f, 0.14632672f, -0.49539995f, 0.59772271f, 
    0.33162397f, -0.18654126f, 0.37156993f, -0.15626910f, 0.24786347f, 0.07661620f, 0.03527145f, -0.11793335f, 
    -0.26655263f, -0.12296375f, 0.32092395f, 0.10957331f, -0.16638978f, 0.72531319f, -0.97309774f, -0.91028064f, 
    -0.98706603f, -0.29201365f, 0.65694743f, -0.11101478f, -0.08466646f, 0.80226427f, 0.78916657f, 0.23391964f, 
    -0.22338180f, -0.28265494f, 0.28634256f, 0.13765585f, -0.00994421f, -0.19711509f, -0.20850141f, 0.00314183f, 
    0.44788024f, -0.31116569f, 0.34617317f, 0.03005052f, 0.27943444f, 0.14811695f, -0.04709226f, -0.33604062f, 
    0.71252048f, -0.79602104f, -0.03266539f, 0.25996241f, -0.29905680f, 0.02932137f, 0.54126740f, 0.53654623f, 
    0.48461688f, 0.04547100f, -0.04420676f, -0.50724101f, -0.48579699f, 0.11647046f, 0.15514819f, 0.37311310f, 
    0.02750027f, -0.30460376f, -0.21002293f, -0.62521219f, 0.02858730f, 0.33410132f, -0.17996362f, -0.38050741f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.49979153f, 0.20003490f, 0.09715417f, -0.01617786f, 0.32936248f, 0.01988553f, 0.18191551f, 0.50406861f, 
    -0.46199065f, 0.07648420f, -0.08576801f, 0.56253856f, 0.45127383f, 0.07405504f, 0.18201193f, 0.49043292f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.03169196f, -0.06470181f, -0.07173713f, 0.04998799f, -0.05648568f, -0.05039660f, 0.05263345f, 0.01328713f, 
    -0.08319423f, -0.00179124f, 0.04382952f, 0.01923710f, -0.03187015f, 0.00381280f, 0.04723845f, -0.07582126f, 
    -0.00203612f, 0.03418816f, -0.04885307f, -0.07633581f, -0.07055771f, 0.00678368f, -0.07514180f, 0.02381311f, 
    -0.03548615f, -0.05808127f, 0.02090665f, 0.05316459f, -0.05979884f, -0.01420442f, 0.01521181f, -0.01253394f, 
    0.00744618f, -0.05731100f, 0.02956353f, -0.04823881f, -0.02984264f, 0.04727325f, 0.02433831f, 0.00191451f, 
    0.01767467f, 0.03123108f, 0.05765158f, -0.00396593f, 0.00104584f, -0.03889113f, -0.01076499f, 0.03118776f, 
    -0.03740228f, -0.01574085f, -0.00411946f, -0.02010755f, 0.00570894f, -0.00487584f, -0.00350903f, 0.00816015f, 
    0.04865391f, -0.04537334f, -0.03177895f, 0.04590430f, 0.03926647f, -0.02417554f, -0.06323010f, 0.00641763f, 
    -0.03920145f, 0.04532621f, -0.08171853f, -0.07655904f, -0.00215015f, -0.03093352f, -0.00911357f, 0.05651370f, 
    -0.01895189f, -0.01309899f, 0.06198698f, -0.01121307f, 0.06028002f, 0.05198947f, -0.05533198f, 0.06563652f, 
    0.05269040f, -0.06433916f, 0.03485187f, -0.03127151f, -0.00434956f, 0.01357021f, -0.08949932f, -0.04832367f, 
    -0.03765178f, -0.02331220f, 0.04389646f, -0.02431556f, 0.02215479f, 0.02549233f, 0.04677588f, 0.01668209f, 
    0.03277533f, 0.02461943f, -0.04181767f, -0.02252594f, 0.03604275f, 0.04858054f, -0.01942877f, -0.00160167f, 
    -0.02459275f, -0.03057732f, 0.02571768f, -0.06440121f, -0.02049740f, -0.04615032f, -0.06691770f, -0.07652554f, 
    0.00848984f, -0.02069486f, -0.06996515f, 0.04479389f, 0.02473512f, 0.05781433f, -0.07225359f, 0.04775886f, 
    -0.04548711f, -0.07567432f, 0.01783780f, -0.02867466f, -0.02316892f, 0.05576940f, -0.08105817f, -0.00864509f, 
    -0.01673143f, -0.04950156f, 0.04043245f, -0.01791744f, 0.01008141f, -0.01704439f, -0.05943899f, 0.04792454f, 
    -0.00605049f, -0.08196996f, 0.02581007f, 0.01930570f, -0.00567407f, -0.06578972f, 0.01909447f, -0.03947775f, 
    -0.00488175f, -0.03586647f, -0.06048891f, -0.06820752f, 0.03959149f, 0.00402755f, -0.07274250f, -0.03102147f, 
    -0.00498559f, -0.07298685f, -0.01422840f, -0.06146481f, -0.02127578f, -0.07937845f, -0.08451566f, -0.07415873f, 
    -0.01089176f, -0.02472731f, 0.03580142f, 0.04328548f, -0.08982900f, -0.04716252f, 0.02235927f, 0.00438413f, 
    -0.01803153f, -0.06219450f, 0.00827846f, -0.06121669f, 0.02804445f, 0.05594124f, -0.01756870f, -0.02069066f, 
    0.03715774f, -0.06760807f, -0.05452853f, -0.01229020f, -0.02804810f, -0.03489431f, 0.04945691f, 0.04154442f, 
    -0.08014847f, -0.01556840f, -0.03151414f, 0.01506251f, 0.00278603f, 0.02905667f, 0.04635305f, 0.01997065f, 
    -0.35163575f, -0.01294819f, 0.45579574f, -0.42106578f, 0.01306516f, -0.01780187f, -0.17768393f, 0.21625888f, 
    -0.00679569f, -0.18537304f, 0.09011102f, -0.09932461f, 0.07245209f, 0.12321009f, -0.09222136f, 0.00503983f, 
    -0.12434019f, -0.07415882f, -0.11607333f, -0.21087028f, -0.08983471f, -0.14011969f, 0.13277727f, -0.20194604f, 
    -0.10772232f, 0.31051120f, 0.08842497f, 0.10596250f, 0.06567883f, 0.13316239f, 0.14305165f, 0.26834843f, 
    0.11566989f, 0.03998943f, 0.34896016f, 0.10651669f, -0.06224640f, -0.19274406f, -0.28351253f, 0.04256940f, 
    0.06517372f, 0.17608054f, -0.08152129f, 0.24248049f, -0.20970429f, 0.13466032f, -0.11422715f, 0.01962234f, 
    0.39345416f, -0.38195729f, -0.04918569f, 0.05117600f, 0.04094147f, 0.21186118f, 0.10304214f, 0.11792943f, 
    -0.10100462f, 0.16130036f, 0.05090222f, 0.26724711f, 0.35262492f, -0.00474027f, 0.12978198f, -0.05343308f, 
    0.12294499f, -0.06570480f, -0.09062047f, -0.00990170f, 0.03972520f, 0.04107225f, -0.04967256f, -0.07055496f, 
    -0.06580671f, -0.02978583f, -0.20276900f, -0.10300566f, 0.03033945f, -0.03494352f, 0.01153698f, 0.21298255f, 
    -0.19828758f, -0.00048148f, 0.02837334f, 0.03735895f, 0.06895905f, 0.05421870f, -0.02745551f, -0.19256206f, 
    -0.11600813f, -0.06493936f, 0.01798714f, -0.09368495f, -0.01386305f, 0.11059390f, -0.00199227f, 0.02910724f, 
    0.08641927f, 0.25339374f, 0.14242026f, -0.07760128f, -0.21941411f, -0.24492176f, -0.15616879f, -0.29885098f, 
    -0.14635120f, -0.04938355f, -0.03019371f, 0.13826326f, 0.08430566f, 0.37057826f, 0.04827756f, -0.43192479f, 
    0.05431005f, 0.06804828f, -0.10518406f, 0.12732002f, -0.08673404f, 0.03385870f, -0.18467034f, -0.26061004f, 
    -0.06315029f, -0.27095115f, -0.08364183f, -0.11243448f, -0.03159259f, -0.00198176f, 0.10754778f, 0.11159964f, 
    0.09563566f, -0.15708467f, 0.03038760f, -0.00442038f, 0.20815583f, 0.23623265f, 0.38713402f, -0.17673482f, 
    0.06707793f, 0.01479394f, -0.05504627f, 0.15712823f, 0.02836304f, 0.10461240f, 0.17241988f, 0.08840865f, 
    0.51432562f, 0.01106887f, -0.12256308f, -0.16858684f, -0.06956288f, 0.03605998f, -0.17372721f, 0.11458252f, 
    -0.15589522f, 0.14110684f, -0.08781615f, 0.03567578f, -0.12926447f, 0.07907128f, -0.08569431f, 0.02531562f, 
    0.24384345f, 0.06171570f, 0.08233488f, -0.17747751f, -0.03715751f, 0.10170805f, -0.01019812f, 0.27276352f, 
    0.16822383f, 0.09142979f, -0.18960775f, 0.01658864f, 0.33070943f, -0.12953649f, 0.28687394f, 0.05120423f, 
    -0.05512842f, 0.01937822f, 0.10017221f, 0.06823537f, -0.10526987f, 0.25219449f, 0.42595312f, 0.11060665f, 
    0.13323487f, 0.04010439f, -0.15471847f, -0.20909290f, -0.09980258f, 0.28826827f, -0.17129500f, 0.08417160f, 
    0.10064974f, -0.22613049f, 0.27820599f, -0.20912232f, -0.09722321f, 0.08523116f, 0.09157854f, 0.07365600f, 
    0.07207252f, -0.02570369f, 0.11025613f, 0.01750785f, -0.00139575f, 0.24980524f, -0.21569797f, -0.04784289f, 
    -0.13647282f, 0.06200406f, -0.10846272f, 0.04734231f, 0.11387523f, 0.27404779f, 0.19651544f, 0.18143736f, 
    -0.19002709f, -0.14479376f, 0.44156298f, 0.13611916f, -0.10104481f, 0.10852921f, 0.27823463f, 0.14065181f, 
    0.05305200f, 0.30813432f, 0.30683777f, 0.26547197f, 0.06077127f, -0.06618223f, -0.04864869f, 0.02513938f, 
    0.16775626f, 0.07725179f, 0.18074039f, 0.01779483f, 0.10120612f, 0.36036533f, -0.06342354f, 0.06705519f, 
    0.08223276f, 0.20149140f, -0.09550330f, 0.47808543f, 0.02674342f, 0.12383243f, 0.24406056f, 0.02012609f, 
    -0.03924783f, 0.15563177f, 0.18963605f, 0.22754540f, 0.17252374f, -0.15206912f, -0.24206801f, 0.13409860f, 
    0.09464683f, -0.03920814f, -0.01054575f, 0.04380662f, -0.13694492f, 0.10170443f, 0.08286098f, 0.03473408f, 
    0.07379858f, 0.02302671f, -0.10663798f, -0.15155241f, -0.07292221f, -0.09739382f, -0.02380631f, -0.03287584f, 
    -0.08865142f, -0.02801899f, -0.03337257f, -0.31132957f, 0.04849589f, -0.21668778f, 0.09570947f, 0.03456908f, 
    -0.29197147f, -0.16483048f, -0.08245780f, -0.15281489f, -0.42674643f, -0.34421310f, -0.21054202f, -0.79562354f, 
    0.17832433f, 0.01394638f, -0.10520142f, -0.21069078f, -0.01055018f, -0.15195681f, -0.00321226f, -0.23746891f, 
    -0.17033310f, 0.13491137f, -0.00288768f, 0.08260757f, 0.32409301f, 0.18957514f, -0.09267084f, 0.03499432f, 
    -0.04504137f, -0.08800570f, 0.05647079f, 0.16646716f, 0.13614401f, 0.43206823f, 0.18247947f, 0.47962087f, 
    0.40428552f, -0.18755922f, -0.00242095f, -0.02304352f, -0.13123685f, 0.08855920f, 0.18331915f, -0.02906434f, 
    0.04633325f, -0.00905635f, -0.19620211f, 0.24789222f, -0.06004087f, -0.11810420f, 0.17747617f, -0.15676591f, 
    0.14050102f, 0.04270864f, -0.22327715f, -0.07943282f, -0.40607530f, -0.35440415f, -0.04598144f, -0.33496624f, 
    0.22601771f, -0.17126584f, -0.10991893f, -0.19029124f, -0.08103266f, 0.29536712f, -0.04927221f, -0.19501872f, 
    -0.05009631f, -0.16811419f, -0.13652317f, 0.00585453f, 0.15334608f, 0.07910280f, -0.17761588f, -0.02727436f, 
    -0.09880104f, 0.02393572f, 0.11129825f, 0.17135705f, -0.14277513f, 0.01015521f, -0.06504349f, -0.56441408f, 
    0.39628050f, 0.41502127f, -0.03683668f, 0.07711560f, 0.19172299f, 0.12002428f, 0.04058461f, 0.11965846f, 
    -0.20152605f, 0.08766428f, -0.09134222f, 0.01216286f, -0.10122271f, -0.02368166f, 0.02810097f, -0.04365141f, 
    0.03191397f, 0.07712471f, -0.01991938f, 0.12216329f, -0.03562354f, 0.39456153f, 0.25027725f, 0.10783152f, 
    0.58120519f, -0.16837469f, -0.73557979f, 0.34293249f, 0.02630605f, -0.02030816f, 0.46239573f, 0.16136046f, 
    -0.04062412f, 0.25689390f, -0.16356166f, -0.11537090f, -0.19379717f, -0.15054178f, -0.06918005f, -0.12483072f, 
    0.02300001f, -0.09393308f, 0.00026517f, 0.13196558f, 0.11482985f, 0.10518834f, -0.05101613f, 0.09831560f, 
    -0.06071071f, 0.15913457f, 0.13155185f, 0.24203633f, 0.27672535f, 0.13091205f, -0.12377392f, -0.38364750f, 
    -0.20656358f, 0.00926194f, -0.22403868f, 0.01050523f, -0.02402375f, 0.01447619f, 0.27652138f, -0.03781842f, 
    0.02347034f, -0.02323068f, 0.18876290f, -0.26836568f, 0.08342450f, 0.02038300f, 0.07623475f, -0.05623406f, 
    -0.47249579f, 0.38240474f, 0.17599632f, 0.15564606f, 0.05152040f, -0.00487333f, 0.07733347f, 0.03228397f, 
    -0.05382028f, 0.02476890f, 0.06452730f, -0.04088837f, -0.38873184f, -0.07858880f, -0.28635806f, 0.09994630f, 
    -0.11462596f, 0.23531939f, 0.27422041f, 0.06601798f, -0.01718511f, 0.09352074f, 0.20562758f, 0.25249183f, 
    0.06348896f, 0.04071711f, 0.11833881f, 0.13007623f, 0.17265828f, -0.02642173f, 0.05618699f, -0.09652354f, 
    0.07475970f, -0.02994287f, -0.06549563f, 0.08257941f, -0.04050871f, -0.09030893f, -0.23000306f, 0.07786926f, 
    0.26001388f, 0.02050657f, 0.17839596f, 0.19403672f, 0.18912292f, -0.02354651f, 0.00729900f, 0.02827475f, 
    -0.03506757f, -0.24702305f, -0.19905329f, -0.13103639f, 0.07597969f, 0.08951109f, -0.08282471f, 0.07223685f, 
    0.08013364f, 0.09199035f, -0.17213334f, -0.23776415f, 0.12251502f, 0.00747481f, 0.13289726f, 0.29195881f, 
    -0.06884484f, 0.05242367f, 0.00183463f, -0.13291550f, 0.07213601f, -0.02947773f, -0.05297867f, 0.15284163f, 
    0.07688814f, 0.11282388f, -0.07556681f, 0.06718651f, -0.04085387f, -0.10154860f, -0.03575289f, 0.01944790f, 
    -0.03720794f, 0.03674532f, -0.22282979f, -0.01933532f, -0.09030313f, -0.16219415f, -0.15241806f, 0.12582283f, 
    0.03838200f, -0.02395982f, 0.04055754f, -0.16568148f, 0.06001461f, -0.08450197f, 0.03246686f, 0.19789657f, 
    -0.08465026f, -0.39479861f, 0.21006724f, 0.21205103f, 0.06647747f, 0.10659891f, 0.25368515f, 0.13691181f, 
    0.06411813f, -0.16047135f, 0.04662355f, -0.01771722f, 0.02052636f, -0.02381897f, -0.10073761f, -0.16263749f, 
    -0.00478675f, 0.15809567f, 0.19872887f, 0.37255734f, 0.12415542f, 0.01680849f, 0.08296201f, -0.16625282f, 
    -0.13867636f, 0.03106880f, 0.15919486f, -0.06445457f, -0.20468570f, 0.05300765f, -0.23644826f, 0.28734884f, 
    0.12986761f, 0.07725413f, -0.17302074f, 0.14028008f, 0.28254315f, 0.05768879f, -0.47782898f, -0.17725478f, 
    -0.32457101f, -0.06642695f, 0.00819315f, 0.28081256f, -0.10764553f, -0.14288484f, 0.28235653f, -0.08689258f, 
    -0.00522447f, 0.00875789f, -0.08954185f, 0.30427006f, 0.06686632f, 0.31067052f, 0.18483372f, 0.04475657f, 
    0.03787320f, 0.09259327f, 0.06211213f, 0.13351169f, 0.12415607f, -0.20950371f, 0.09557307f, -0.38009891f, 
    0.05752828f, -0.03474070f, -0.01989098f, 0.05174046f, 0.24995826f, 0.17798828f, 0.14993893f, 0.03685731f, 
    -0.11776274f, 0.81652659f, 0.13118888f, -0.03802136f, 0.14131451f, 0.22798762f, 0.17612223f, 0.04521273f, 
    0.03789894f, 0.02496017f, -0.00180912f, 0.07794069f, -0.26104107f, -0.09156772f, -0.10783885f, -0.10716452f, 
    0.17342226f, -0.00289341f, 0.09776517f, -0.03790625f, 0.05768106f, -0.01935479f, 0.00097864f, -0.08738685f, 
    -0.55107546f, -0.35086954f, 0.40760329f, -0.11546062f, -0.12399297f, 0.00199047f, 0.11848407f, 0.03638921f, 
    0.09936720f, 0.09247772f, 0.17474680f, 0.18130678f, -0.20312005f, -0.01522655f, 0.06126893f, 0.06821119f, 
    -0.13962397f, -0.08625468f, 0.00315460f, 0.13529280f, 0.06133801f, 0.01626261f, 0.10539998f, 0.12285601f, 
    -0.05284625f, -0.40470052f, -0.17864908f, 0.16577470f, 0.30286360f, 0.03650603f, 0.06374133f, -0.05431424f, 
    0.06697404f, -0.18593447f, -0.24809189f, 0.03562691f, -0.07436877f, -0.20807406f, 0.03451203f, -0.16295716f, 
    -0.02488766f, 0.04668561f, -0.04267613f, -0.05652827f, 0.24587680f, -0.24832131f, -0.02106182f, 0.18832067f, 
    -0.22245407f, 0.02830411f, 0.00188004f, -0.38197750f, 0.05163072f, -0.10430730f, -0.24597776f, -0.07537261f, 
    0.00112598f, -0.05038442f, 0.01121176f, -0.10121692f, 0.02133439f, 0.37914401f, 0.14800221f, 0.22886461f, 
    0.02316083f, 0.22353965f, 0.08333591f, -0.10373862f, 0.14646102f, 0.03436978f, 0.21075356f, 0.00163456f, 
    -0.34549049f, -0.10833333f, -0.12407909f, 0.07941785f, -0.11787056f, 0.03635218f, 0.05383743f, 0.12669566f, 
    -0.03411308f, 0.12013214f, -0.00007761f, -0.18936099f, -0.35177764f, 0.16297773f, -0.12838653f, 0.03645508f, 
    -0.01529691f, -0.05460346f, -0.09893685f, -0.01054520f, 0.22927661f, 0.18745761f, 0.20133425f, 0.23034716f, 
    0.13648844f, 0.01220099f, -0.03955438f, 0.27320796f, 0.14475265f, 0.14146857f, -0.07254450f, 0.29776806f, 
    -0.08676639f, -0.08090921f, 0.08613980f, 0.23492898f, -0.26999933f, -0.16368540f, -0.38824028f, 0.24187575f, 
    0.08263627f, 0.05401475f, -0.05449357f, 0.00927939f, -0.10346128f, 0.05323547f, 0.02059950f, 0.06183489f, 
    0.47822529f, -0.22206274f, -0.02681665f, 0.04212423f, 0.10979689f, -0.22676843f, 0.07903337f, -0.03422773f, 
    -0.08414409f, -0.06741212f, 0.03956337f, -0.04634700f, 0.62264043f, 0.02617254f, 0.00664098f, 0.00676201f, 
    -0.09154715f, -0.01612986f, 0.07950206f, 0.08306044f, 0.18101355f, 0.07153542f, 0.15788159f, 0.09989820f, 
    -0.42030039f, 0.02740151f, 0.31894046f, -0.15446983f, -0.09558102f, -0.02576804f, -0.26274869f, -0.25947037f, 
    0.14208485f, 0.01412412f, 0.07578864f, 0.24305025f, -0.44987869f, 0.08132450f, -0.25364247f, 0.01911248f, 
    0.05982214f, 0.06268865f, -0.02910088f, -0.06911934f, -0.14971076f, -0.04955017f, -0.08017883f, 0.11644795f, 
    -0.36740729f, 0.03804433f, 0.02781127f, 0.26628876f, -0.34191227f, -0.10803413f, -0.13991742f, -0.09559052f, 
    -0.06541315f, 0.11413117f, 0.02656257f, 0.11068510f, 0.34555587f, 0.24379322f, 0.11032309f, 0.29974741f, 
    0.28171945f, 0.05130716f, 0.10313107f, 0.19926611f, 0.08375691f, -0.06371795f, -0.02851325f, 0.11004926f, 
    0.81486422f, 0.73289895f, -0.03590156f, 0.20900792f, 0.36039346f, 0.03726925f, 0.01117994f, -0.00915030f, 
    0.05170342f, 0.00824335f, 0.10534863f, -0.04703543f, 0.40990347f, 0.22191526f, 0.24571691f, 0.38072774f, 
    0.10127282f, 0.05851832f, 0.18018427f, -0.09013873f, -0.17138577f, -0.12085946f, -0.07657196f, -0.01549569f, 
    0.31277895f, 0.58373398f, 0.40931928f, 0.28346848f, -0.17679939f, 0.20262858f, 0.09608490f, 0.14288019f, 
    -0.08686857f, 0.11647847f, -0.02525511f, -0.13020991f, -0.19981247f, -0.09898628f, -0.15221599f, -0.16134946f, 
    -0.20050041f, -0.09175227f, -0.00076225f, -0.01358762f, -0.10628772f, 0.05509374f, 0.14784931f, -0.10077565f, 
    -0.15249284f, -0.46543002f, -0.27397606f, -0.06212665f, 0.02624622f, 0.07082037f, 0.01007564f, 0.13205974f, 
    0.13641180f, 0.05613717f, 0.15856749f, 0.14716601f, 0.13339332f, 0.06850357f, -0.04268061f, -0.13068733f, 
    -0.08280327f, -0.21383232f, 0.04887826f, -0.04615538f, -0.22123022f, -0.02930829f, 0.12970975f, 0.21483225f, 
    -0.05341848f, 0.02787713f, 0.27708957f, 0.27111754f, 0.22263081f, 0.09800198f, 0.16163906f, 0.03672530f, 
    -0.09343697f, 0.08178001f, 0.12143986f, 0.12803595f, 0.03974464f, -0.31123692f, -0.26884151f, -0.14960432f, 
    -0.04884781f, 0.10149008f, -0.07336032f, 0.10515016f, -0.11676677f, -0.11105698f, -0.16735445f, -0.16242038f, 
    0.56752652f, -0.06397540f, 0.23489732f, -0.10827312f, -0.17037426f, -0.17475289f, 0.04446481f, -0.09791191f, 
    0.02251711f, -0.07380236f, -0.03324835f, -0.19503903f, 0.19098987f, 0.05148208f, 0.43204030f, 0.15675114f, 
    -0.13960984f, 0.26520711f, 0.21855068f, -0.05617561f, -0.15497236f, 0.18393955f, -0.00842837f, 0.02932495f, 
    0.02624376f, 0.64819384f, 0.32477108f, 0.02531292f, -0.11011626f, 0.27635160f, -0.03438761f, 0.05762316f, 
    -0.00145045f, 0.05001788f, 0.09559152f, -0.13680455f, -0.40075755f, -0.22491638f, 0.05304992f, -0.12979394f, 
    0.07872912f, -0.06129729f, 0.11250156f, -0.05586642f, -0.16978575f, 0.05428990f, -0.09680243f, 0.21505988f, 
    -0.15259260f, 0.23453467f, -0.18566242f, 0.03668947f, 0.29470062f, 0.02996063f, 0.04961912f, 0.05545538f, 
    -0.00171851f, 0.12804140f, -0.12099034f, -0.07888099f, -0.26473072f, -0.11466708f, -0.16713610f, -0.11289465f, 
    0.10000412f, -0.01775774f, -0.02225692f, -0.03089997f, 0.25302741f, 0.19962908f, -0.00884740f, 0.10674473f, 
    -0.19346170f, 0.25633410f, -0.06217123f, 0.57260597f, 0.20741048f, -0.08023980f, -0.26622254f, 0.01351058f, 
    -0.11680885f, 0.11650554f, 0.04120807f, -0.04909256f, -0.07150657f, -0.28675807f, -0.02479488f, -0.00176684f, 
    -0.20856042f, -0.05198157f, -0.03161439f, -0.07009621f, 0.04143410f, 0.14387986f, -0.13518052f, 0.05077776f, 
    -0.08136924f, 0.41364068f, 0.76944971f, 0.43416810f, -0.06444222f, 0.13384631f, -0.03432150f, 0.11093508f, 
    -0.06460597f, 0.06480546f, -0.01566801f, 0.10136788f, -0.40815750f, -0.29298961f, -0.08064725f, 0.11261272f, 
    -0.05597692f, 0.06751770f, 0.16570990f, -0.03634985f, -0.02349183f, 0.03733053f, 0.04002468f, 0.06592228f, 
    -0.25488925f, -0.21667929f, -0.18003041f, 0.04599071f, 0.06391073f, -0.08277705f, -0.16620897f, 0.01607939f, 
    0.07949372f, 0.03033037f, -0.05137499f, 0.13319021f, -0.02022167f, 0.21131358f, -0.06157950f, 0.11801866f, 
    0.10062269f, -0.17088893f, -0.04842830f, 0.13314559f, -0.00608189f, 0.11383300f, -0.05874350f, -0.05104450f, 
    -0.27938962f, -0.11714181f, -0.00172710f, -0.40832758f, -0.22214942f, -0.08207575f, -0.09619987f, -0.10937238f, 
    0.02427576f, 0.15730216f, -0.05523821f, 0.04239810f, 0.27574104f, 0.02160533f, -0.07527731f, -0.20088996f, 
    0.11651837f, -0.06369752f, -0.04517469f, -0.07437928f, 0.18047683f, 0.09976571f, 0.20115000f, 0.26398242f, 
    -0.27449957f, 0.16443157f, -0.01794635f, 0.14395194f, 0.09396980f, 0.01502977f, 0.23991793f, 0.12112617f, 
    -0.00278536f, -0.10545330f, -0.22671591f, -0.14854254f, -0.19020045f, 0.11486687f, 0.39053294f, -0.14799488f, 
    -0.06202343f, 0.03138611f, -0.02939290f, -0.03420632f, 0.11941627f, 0.09582610f, 0.01203331f, 0.04036867f, 
    0.66469967f, -0.32487848f, 0.23264247f, -0.15213622f, 0.01817309f, 0.02914693f, 0.13750274f, 0.01070663f, 
    -0.04207203f, 0.02577050f, 0.11608902f, -0.05219645f, -0.23334458f, 0.03378790f, 0.04525899f, -0.11749739f, 
    -0.06010401f, 0.07547913f, -0.01894611f, 0.18951619f, -0.05545174f, -0.09893316f, 0.17897955f, -0.03107174f, 
    -0.19991617f, -0.00135070f, 0.08228571f, 0.26190388f, -0.04657470f, -0.04011269f, 0.03220357f, 0.16517046f, 
    -0.00852449f, 0.07504666f, 0.11371591f, 0.02237044f, 0.05600825f, 0.08622752f, -0.10815719f, -0.11957209f, 
    -0.01831189f, -0.09485352f, -0.01660066f, -0.00682728f, 0.04143178f, 0.19253241f, 0.17071129f, 0.17323643f, 
    0.10829954f, 0.14871879f, -0.54203433f, -0.05539799f, -0.14917235f, 0.08515362f, 0.33298406f, 0.08879881f, 
    -0.01831964f, -0.03679393f, -0.03149733f, -0.07679617f, 0.23388551f, -0.10178566f, 0.28469002f, 0.15530671f, 
    -0.00318136f, -0.16624548f, -0.25561574f, -0.05233205f, 0.01681287f, -0.14586365f, -0.05097717f, -0.18410861f, 
    0.24748611f, -0.17650673f, 0.14101167f, -0.00505147f, -0.17853791f, 0.26021296f, -0.00308943f, 0.05002388f, 
    0.09261423f, -0.06456593f, -0.28187227f, 0.19024099f, -0.12906262f, 0.24392746f, 0.30704105f, -0.02206874f, 
    0.15519112f, 0.06791191f, -0.05150672f, 0.38048041f, 0.06514386f, -0.06180539f, -0.05519671f, -0.10022263f, 
    0.53047407f, -0.18070136f, 0.05031752f, -0.94953638f, 0.07386322f, -0.28049517f, -0.19403529f, -0.00367863f, 
    0.06146501f, -0.06185288f, -0.14416356f, -0.10537199f, 0.13598168f, 0.40212521f, 0.34649885f, -0.01930957f, 
    0.31962079f, 0.11607482f, -0.01118222f, 0.13661309f, 0.22989085f, 0.01317043f, -0.07485662f, 0.09568957f, 
    -0.13236913f, 0.41625980f, 0.09659227f, 0.26072156f, 0.09171706f, 0.29760796f, 0.19543719f, 0.11518689f, 
    -0.09131949f, 0.07332444f, -0.06251825f, 0.03523180f, -0.05418881f, -0.12151180f, -0.25417185f, -0.22332448f, 
    0.15168303f, 0.16217953f, 0.08123776f, 0.10509383f, 0.03449048f, 0.13774998f, 0.09224837f, 0.13109399f, 
    -0.04070212f, -0.20166793f, -0.03962672f, 0.20484556f, -0.05144363f, -0.06353843f, -0.02451472f, -0.11670331f, 
    0.10603151f, -0.05959939f, 0.08887044f, -0.06254578f, -0.39454657f, -0.22255887f, 0.06043021f, 0.02355457f, 
    0.06603026f, 0.16749041f, -0.00161818f, 0.06932742f, -0.06916477f, -0.27042654f, -0.32765034f, -0.32351258f, 
    -0.12670258f, 0.08505692f, -0.10643870f, -0.39338341f, -0.17375858f, 0.02341403f, -0.04215761f, 0.22960119f, 
    -0.16729431f, 0.00151598f, 0.09884376f, -0.22665684f, 0.31365708f, -0.14713304f, -0.21941656f, 0.14959654f, 
    -0.10215328f, -0.06548395f, 0.12511174f, -0.07118993f, 0.29697329f, 0.08077358f, -0.02720615f, 0.36493677f, 
    -0.71267498f, -0.01788002f, 0.13259171f, 0.28101268f, 0.07076464f, 0.09946353f, 0.32394406f, 0.29136512f, 
    -0.08986987f, 0.19175224f, 0.06209517f, 0.09024370f, -0.26525059f, -0.18771179f, -0.03420437f, 0.03997207f, 
    0.13527398f, 0.08530340f, 0.25046730f, -0.11745214f, 0.00998143f, 0.04625789f, -0.18740064f, 0.21571615f, 
    -0.29407308f, -0.09163692f, 0.11069299f, 0.21874313f, 0.07857691f, -0.16323151f, 0.05055955f, 0.15035497f, 
    0.10938054f, -0.11542301f, 0.00429731f, 0.00460710f, -0.09562867f, 0.11195644f, 0.34072378f, 0.17216508f, 
    -0.00973772f, -0.13851002f, -0.00896999f, -0.12711017f, 0.24698114f, -0.09305952f, -0.03773391f, -0.08753949f, 
    -0.08847337f, -0.31821018f, 0.48895046f, -0.01083729f, 0.17564826f, -0.11016353f, -0.16235623f, 0.20575093f, 
    0.01862672f, 0.16061355f, -0.14502186f, -0.04612336f, -0.41291118f, 0.06148569f, -0.32711750f, -0.07244406f, 
    0.01431784f, 0.00484242f, -0.11239490f, -0.01914656f, -0.00855877f, -0.04641702f, -0.09748343f, -0.05294928f, 
    -0.42893517f, 0.52733332f, -0.06443884f, 0.26796985f, 0.25773430f, -0.19118501f, -0.04921325f, -0.09247950f, 
    0.00101417f, -0.01804825f, 0.19397731f, 0.03814347f, 0.11760809f, -0.20059991f, 0.15686172f, 0.32797840f, 
    0.03904888f, 0.08709218f, -0.05011976f, -0.09750678f, -0.12798798f, -0.05373733f, 0.01585452f, 0.17925860f, 
    0.07357482f, 0.59317440f, 0.37629789f, 0.47436988f, 0.07320365f, 0.14232774f, 0.03242368f, 0.01224039f, 
    0.01604609f, -0.05938059f, -0.00124445f, 0.06268089f, -0.29231465f, -0.17755902f, 0.34110296f, 0.17711486f, 
    0.00815106f, 0.09979888f, 0.23871851f, 0.04289822f, 0.01371283f, -0.00324707f, -0.11204935f, -0.02156407f, 
    -0.09354501f, -0.06518515f, -0.02620246f, 0.32677037f, 0.00641440f, 0.11932464f, -0.10945092f, 0.16817997f, 
    -0.10768175f, 0.06774541f, 0.11297458f, 0.03510791f, -0.17156798f, 0.20956066f, -0.08316546f, 0.14200732f, 
    0.08088090f, -0.11433776f, -0.06658677f, 0.22333534f, -0.03659035f, 0.15911880f, -0.02489413f, 0.11284832f, 
    0.11803588f, -0.07201377f, 0.02882360f, -0.05079328f, -0.37948442f, -0.34647137f, -0.31150323f, -0.06764788f, 
    -0.05630502f, 0.02816888f, -0.06361810f, -0.06930149f, 0.17367166f, 0.10997426f, 0.32150698f, -0.29531839f, 
    0.07124954f, -0.04197769f, -0.06325903f, -0.24338581f, 0.08398037f, -0.20299470f, 0.12447518f, 0.01796453f, 
    -0.44959575f, -0.15394072f, -0.05488253f, 0.10228757f, 0.15923975f, -0.07503647f, -0.01450671f, -0.02826278f, 
    0.04002919f, -0.03316252f, 0.12490101f, -0.19668993f, 0.30955881f, 0.03533681f, 0.19145192f, -0.21142705f, 
    -0.06699882f, 0.09928361f, -0.14917235f, -0.10573005f, 0.00244072f, 0.06966627f, -0.02283447f, -0.17495064f, 
    0.84776139f, -0.13292132f, 0.64866126f, -0.09821771f, 0.07604448f, -0.02281927f, 0.24079415f, -0.11776887f, 
    -0.10896766f, 0.16098166f, 0.02636283f, -0.04901433f, 0.15112555f, -0.03809891f, 0.17559446f, -0.15164299f, 
    0.15822779f, 0.29310247f, -0.00216009f, 0.17535368f, 0.07043527f, -0.04594218f, 0.08299688f, 0.08925364f, 
    -0.32424873f, 0.24131379f, 0.01381122f, 0.02061567f, -0.09196047f, 0.22134538f, 0.10272105f, 0.13311625f, 
    0.05998830f, 0.11668108f, 0.28844967f, -0.13469510f, -0.01356819f, -0.02939654f, -0.03893609f, -0.02178572f, 
    0.09490773f, -0.14925313f, -0.02627249f, -0.09593146f, 0.01409759f, 0.00503998f, -0.21014561f, 0.20617421f, 
    0.02246631f, 0.21105014f, -0.63118964f, -0.33963546f, 0.06356453f, 0.17602442f, 0.19989608f, 0.01284274f, 
    0.23584798f, 0.00825618f, 0.01799554f, 0.18731101f, 0.29151848f, -0.08300421f, 0.37810856f, 0.26967630f, 
    -0.01914336f, 0.03122254f, -0.12925565f, 0.04165602f, 0.14952232f, 0.03208801f, 0.09350815f, 0.02558361f, 
    0.17174152f, -0.87819159f, 0.43374261f, -0.29340851f, 0.14006098f, 0.33964643f, -0.11411037f, 0.30848205f, 
    0.27407151f, 0.06403024f, -0.07254917f, -0.06431409f, -0.16838719f, 0.13068481f, 0.16386290f, -0.02098752f, 
    -0.06269033f, 0.13478604f, -0.04415582f, 0.11766555f, 0.05674563f, -0.02870170f, -0.05673501f, -0.03066036f, 
    0.61239356f, 0.17699651f, 0.71835262f, -0.35385612f, -0.09235056f, -0.29221645f, -0.17251056f, 0.06353343f, 
    0.14603572f, 0.03289784f, -0.08126914f, 0.03251649f, -0.09974150f, -0.14829160f, 0.34781840f, -0.07596286f, 
    -0.02143255f, 0.00878939f, 0.08259756f, 0.00079357f, -0.01540108f, -0.09981895f, -0.10894602f, -0.05542334f, 
    -0.35944372f, 0.14764066f, -0.15903144f, 0.07268444f, 0.01435694f, -0.02250765f, -0.11100031f, -0.02534208f, 
    -0.12889557f, -0.00080369f, 0.00582763f, -0.08336192f, 0.04643262f, -0.13193356f, -0.06565803f, -0.04743212f, 
    0.08179463f, 0.20263547f, 0.18774185f, 0.19984457f, -0.03409132f, 0.07133966f, -0.05709952f, 0.01362898f, 
    -0.14086695f, -0.13834848f, -0.11885370f, 0.12083009f, -0.03254185f, -0.10716421f, 0.07568320f, 0.02428574f, 
    0.10935605f, -0.12075244f, -0.13592848f, 0.04421356f, 0.08720976f, -0.34444138f, -0.07757398f, 0.01431703f, 
    0.02551635f, 0.02869914f, -0.03577638f, -0.07535628f, -0.20881802f, 0.05514676f, 0.09933468f, 0.08493678f, 
    0.10751304f, 0.23042239f, 0.00050975f, -0.28400588f, -0.02282940f, -0.13650168f, -0.12688352f, -0.18954973f, 
    -0.05367847f, 0.27313197f, 0.07976589f, 0.08421611f, 0.08797519f, 0.03203973f, -0.13022189f, -0.31583223f, 
    0.09434806f, 0.03646718f, 0.11782946f, 0.10891882f, 0.02147744f, -0.03197416f, -0.12394763f, -0.05818844f, 
    -0.65326029f, -0.22668627f, -0.43598017f, 0.38412201f, 0.02733609f, 0.21291488f, 0.26071763f, 0.23069185f, 
    0.12323955f, 0.05858554f, 0.14152291f, -0.10444070f, -0.40194082f, -0.09822498f, -0.26326671f, -0.07717815f, 
    -0.02188892f, -0.24669442f, 0.24614161f, -0.03556704f, 0.11991947f, 0.06096032f, 0.00300319f, 0.10326201f, 
    -0.48670357f, 0.36515370f, 0.38097361f, 0.55820739f, -0.23646717f, 0.02201463f, -0.00931770f, 0.16667475f, 
    -0.02554699f, -0.05201702f, 0.00908609f, 0.04943972f, -0.11174081f, 0.16949870f, 0.52709126f, 0.34371462f, 
    -0.00586787f, -0.03442886f, 0.13788937f, -0.17950648f, 0.42767125f, 0.16309099f, 0.08008908f, 0.01561804f, 
    -0.20080903f, -0.19480874f, 0.43758884f, -0.07363173f, -0.12685639f, 0.13890734f, 0.20353663f, 0.21504204f, 
    -0.21614781f, -0.02233510f, -0.08132276f, -0.10837010f, -0.11931228f, 0.26197803f, -0.20322284f, -0.39173517f, 
    -0.02682394f, 0.03124145f, -0.00626512f, -0.22418328f, -0.17745408f, -0.18797573f, -0.11936234f, -0.28461009f, 
    -0.19091789f, 0.62651145f, 0.22390562f, 0.46276873f, -0.03064900f, -0.11586379f, 0.23845021f, 0.01975647f, 
    -0.18490717f, 0.00418689f, 0.05523109f, 0.14171812f, 0.09889457f, -0.31486064f, -0.17013425f, 0.19208045f, 
    0.13634828f, -0.06422715f, -0.02941797f, 0.26646349f, -0.08543977f, 0.04112536f, -0.10374159f, -0.13224398f, 
    -0.35792172f, -0.15769371f, -0.43698192f, 0.40147671f, 0.13888307f, -0.12158652f, 0.18929721f, 0.15993227f, 
    0.02501911f, 0.04295520f, -0.07940380f, -0.04494501f, 0.20045586f, -0.12094930f, -0.16687746f, 0.21727301f, 
    0.09813708f, 0.06648777f, 0.07227459f, 0.12380018f, -0.04528590f, -0.01236856f, -0.07736538f, 0.12889735f, 
    0.15608206f, 0.01245657f, -0.21275169f, 0.13570762f, 0.09935393f, 0.08082972f, -0.02847980f, 0.19537297f, 
    0.00610361f, 0.09769834f, -0.03056523f, 0.06900536f, -0.00592726f, -0.02671525f, 0.03337201f, -0.16511720f, 
    -0.07543733f, -0.09815937f, 0.12542191f, 0.03745432f, 0.01112797f, 0.09838556f, 0.16317751f, 0.14259118f, 
    0.01737108f, 0.28302673f, 0.12821354f, -0.11210611f, -0.10791221f, -0.16301349f, -0.12026460f, -0.03912703f, 
    -0.10273118f, 0.01500424f, -0.09355351f, -0.08125228f, 0.24576397f, 0.42709720f, 0.21619695f, -0.17768387f, 
    -0.21527572f, 0.00588235f, 0.06751975f, 0.06343568f, 0.06288145f, -0.08249243f, -0.10767225f, -0.05754563f, 
    -0.39702827f, -0.38431942f, 0.02476382f, 0.07258961f, 0.05994826f, -0.04590254f, 0.11785388f, 0.30575672f, 
    -0.04521117f, -0.04455724f, -0.02632290f, -0.04469764f, -0.03097175f, 0.06424186f, 0.05947668f, 0.03578881f, 
    -0.22368604f, -0.03612076f, 0.01811106f, 0.05603681f, 0.11982708f, 0.18092571f, 0.18083338f, 0.04680697f, 
    0.79978609f, -0.18319413f, 0.62214774f, -0.08370679f, -0.08620324f, 0.18122274f, 0.17490339f, 0.01123916f, 
    -0.12311327f, 0.07750306f, -0.05014883f, 0.11830654f, 0.05798248f, -0.03217823f, 0.00974900f, 0.27264059f, 
    -0.01386685f, 0.10184714f, 0.05955248f, 0.07629044f, -0.03090962f, 0.15742300f, 0.27935907f, 0.17072791f, 
    0.60145408f, -0.19054477f, -0.32992026f, -0.35194829f, -0.04865651f, -0.03948541f, 0.09099904f, 0.18394724f, 
    0.07693567f, 0.23520042f, 0.05406429f, -0.09652220f, 0.19842447f, 0.02841508f, 0.02676635f, -0.15499376f, 
    -0.10841573f, 0.02876195f, -0.17551051f, -0.15294369f, -0.13134328f, -0.08708791f, -0.17549656f, -0.07448066f, 
    0.03389506f, -0.06956410f, -0.08040698f, -0.05550263f, -0.05982951f, 0.02818961f, -0.06258793f, -0.02392545f, 
    0.00897131f, -0.04365835f, 0.00620837f, -0.05829507f, 0.03510909f, -0.05315484f, -0.07542198f, -0.03154103f, 
    0.06494540f, -0.03225764f, -0.04471316f, 0.05832457f, 0.02030840f, -0.01976857f, -0.00659178f, -0.03070519f, 
    -0.03284658f, 0.01646575f, 0.03525329f, -0.01689686f, -0.06461599f, 0.03949282f, -0.00095670f, 0.04060768f, 
    -0.05735363f, 0.02470570f, -0.01026000f, -0.07552505f, 0.00261158f, -0.00695682f, -0.02669732f, 0.01071550f, 
    -0.02262059f, -0.02490183f, 0.04336737f, -0.05810039f, 0.01944680f, -0.03272261f, -0.06337800f, 0.03320068f, 
    -0.06010058f, 0.00572699f, -0.00366822f, 0.02306490f, -0.00455732f, -0.00190032f, 0.03744807f, -0.00795352f, 
    -0.03381311f, 0.00396461f, -0.02427397f, 0.00187874f, 0.02279026f, -0.07692322f, 0.00037350f, 0.02610557f, 
    -0.02556692f, -0.04938767f, -0.02622452f, -0.02073133f, -0.04079469f, 0.00071022f, -0.00287897f, -0.01509960f, 
    0.01236120f, 0.02299324f, -0.02359958f, -0.00077317f, 0.02208501f, -0.01809686f, 0.03681658f, 0.02045039f, 
    0.02293125f, 0.01007639f, -0.01009104f, 0.04112579f, -0.06502225f, 0.04871169f, 0.04862123f, 0.06135804f, 
    -0.02822234f, -0.06541693f, -0.04441499f, 0.05806036f, -0.00667162f, -0.02776372f, -0.00891050f, 0.05908855f, 
    0.02393252f, -0.07943494f, -0.04125793f, -0.05524500f, -0.05656067f, 0.03708427f, 0.01043009f, 0.02605319f, 
    -0.02712983f, -0.00662052f, -0.07672046f, 0.01367329f, -0.01408035f, -0.03116268f, 0.06452251f, -0.03193837f, 
    -0.07687573f, -0.01089429f, -0.07327017f, -0.06746384f, 0.03129079f, 0.05368574f, 0.01077869f, -0.01266118f, 
    0.05365712f, -0.01508457f, -0.00178983f, -0.06480948f, -0.07514530f, -0.01171640f, -0.01725542f, 0.05861245f, 
    0.01228403f, 0.00276401f, 0.01993897f, -0.00031768f, -0.05692657f, -0.02718295f, 0.03600068f, 0.00384234f, 
    0.01109140f, 0.00494962f, -0.03942926f, -0.06415180f, -0.01372478f, 0.03447374f, -0.04769177f, 0.05098332f, 
    -0.03389360f, -0.00310107f, 0.03023254f, 0.03656979f, -0.02035986f, -0.02564332f, 0.03690963f, 0.01532787f, 
    -0.06235792f, -0.06618241f, -0.01739341f, -0.01649634f, -0.05989909f, -0.01885475f, -0.07844780f, 0.04199960f, 
    -0.04475526f, -0.04048835f, 0.04609037f, 0.01736270f, -0.06233812f, -0.05044487f, 0.02874170f, -0.07754803f, 
    0.02214709f, -0.05847706f, -0.00618605f, 0.01018411f, 0.00405416f, -0.05376533f, 0.00938056f, -0.03442360f, 
    -0.03310344f, -0.05134667f, -0.06620751f, -0.04507057f, 0.01018599f, -0.02237088f, -0.03642502f, 0.01216725f, 
    0.01580594f, 0.06187435f, 0.06272998f, -0.01323586f, 0.03281257f, -0.00634729f, -0.02370771f, -0.01463658f, 
    -0.44654563f, 0.08894338f, 0.01000128f, 0.16977066f, 0.11244646f, 0.17287304f, 0.00149393f, -0.03582374f, 
    -0.23318854f, -0.01014657f, 0.02018543f, -0.15295938f, 0.01123839f, -0.16120711f, 0.01569832f, -0.25143197f, 
    0.02158652f, 0.00050349f, -0.04137088f, -0.20764337f, -0.11666705f, -0.00618452f, 0.00451260f, -0.03884541f, 
    0.64211386f, 0.15407674f, -0.23247990f, -0.16379905f, 0.07325007f, -0.02609401f, 0.07818323f, -0.02236561f, 
    -0.15415038f, -0.04182885f, -0.11681224f, 0.03270053f, 0.31074798f, 0.30655611f, 0.08026516f, 0.00371903f, 
    0.14773908f, 0.11792371f, 0.05495880f, 0.24317214f, -0.09411230f, -0.03122050f, 0.01236578f, -0.03059280f, 
    0.21274589f, -0.59347802f, -0.59988755f, 0.03046405f, 0.13079219f, 0.19044261f, 0.11798825f, -0.00427181f, 
    0.13445537f, 0.10906401f, 0.14715905f, 0.05607158f, 0.43172905f, 0.63449097f, -0.26549831f, -0.11771934f, 
    0.20423821f, 0.10539316f, 0.04862433f, 0.09120110f, 0.07184016f, -0.06817687f, -0.00782567f, 0.24110515f, 
    0.76757944f, 0.30094731f, 0.18943101f, 0.03679581f, 0.19262947f, 0.18136114f, 0.27316171f, 0.32722774f, 
    0.10630829f, 0.03691315f, 0.02546200f, 0.00929875f, -0.13196349f, -0.18557531f, -0.08908482f, -0.26688942f, 
    0.25194862f, 0.07698915f, -0.10162588f, -0.08488324f, 0.04564943f, 0.18534043f, 0.17165282f, 0.16901678f, 
    -0.27685326f, 0.13651550f, 0.20483491f, 0.24804427f, 0.10775026f, 0.00902999f, -0.08909405f, -0.18063076f, 
    0.05288304f, -0.01378851f, 0.02126273f, 0.07521962f, -0.05794878f, 0.36642602f, 0.20119061f, 0.32198429f, 
    -0.02536351f, 0.05983398f, -0.01350695f, -0.01113736f, 0.09720831f, -0.12585899f, -0.16251491f, -0.07662370f, 
    -0.12440982f, -0.22697419f, -0.09175925f, -0.00988583f, 0.10600331f, 0.13587497f, 0.11246683f, 0.35994500f, 
    0.04594356f, 0.07325971f, -0.14214714f, -0.18350323f, -0.36637494f, -0.02498009f, -0.29381201f, 0.34649059f, 
    -0.13827582f, -0.03724016f, 0.02005441f, -0.01703876f, 0.17255035f, 0.19262876f, 0.13744147f, 0.22386886f, 
    0.20922811f, 0.42381716f, 0.07513647f, 0.21167327f, 0.22999622f, 0.16992302f, 0.00256972f, 0.06865183f, 
    0.16321753f, 0.08150439f, -0.01391698f, -0.00323187f, -0.22702383f, 0.08697759f, -0.05111453f, 0.21611252f, 
    0.10254059f, -0.11673668f, 0.32402557f, -0.05366300f, -0.04006578f, 0.09689347f, 0.07406116f, 0.11988112f, 
    0.55640596f, -0.35825732f, -0.40593749f, -0.30498469f, 0.14740166f, 0.00735051f, 0.10303579f, -0.12260778f, 
    0.12564664f, 0.00695640f, -0.15835062f, 0.17031448f, -0.02815476f, -0.06959094f, -0.08536880f, -0.18184619f, 
    -0.15592471f, 0.02687375f, -0.03061768f, -0.04634251f, 0.02591150f, -0.10185406f, 0.03346590f, 0.05935106f, 
    -0.32942066f, -0.54865694f, -0.03978977f, -0.32278180f, -0.02411288f, 0.19587360f, 0.12980320f, 0.21398877f, 
    -0.15213352f, -0.03547998f, -0.08876380f, -0.21262741f, 0.00768367f, -0.03284575f, 0.09757490f, -0.04274588f, 
    0.06132993f, -0.09566568f, 0.08344796f, -0.05768036f, 0.10149576f, 0.05292945f, 0.11619189f, -0.05345573f, 
    0.18485489f, 0.30863509f, -0.07089315f, -0.21899052f, 0.18515997f, -0.34734842f, -0.02943682f, -0.20785896f, 
    -0.04060986f, -0.04763854f, 0.04007574f, 0.01251801f, 0.16188757f, -0.02168223f, -0.22878176f, -0.14761345f, 
    0.15245254f, 0.20454910f, 0.02602500f, 0.05179191f, -0.18071491f, -0.14344633f, -0.15153837f, 0.05049753f, 
    0.21770129f, -0.10282106f, 0.50660425f, 0.37459770f, 0.01119974f, 0.15316600f, 0.06232259f, -0.09866340f, 
    0.10439632f, -0.01836129f, -0.05434161f, -0.06015303f, 0.19645691f, 0.09306816f, 0.11119876f, -0.32044810f, 
    0.15326266f, -0.15646149f, -0.02664848f, 0.00892938f, 0.04779274f, 0.00685143f, -0.11144806f, 0.11200403f, 
    -0.15279518f, -0.24245293f, -0.35571921f, -0.29907537f, 0.11140545f, 0.22975211f, 0.07348002f, -0.08888528f, 
    -0.00373769f, 0.19370840f, -0.11414613f, 0.12237962f, -0.24840932f, -0.08875053f, -0.06458591f, 0.22501566f, 
    0.10571814f, -0.01145472f, 0.06542896f, 0.11944257f, 0.16163115f, 0.22084372f, 0.07213759f, 0.38872969f, 
    -0.34689230f, -0.14185356f, -0.12351985f, -0.02928983f, -0.29362968f, -0.31332880f, -0.12724547f, -0.23857263f, 
    -0.11315570f, -0.20028895f, -0.12732135f, 0.03020599f, 0.14897427f, -0.11829066f, 0.23211007f, -0.25016853f, 
    -0.08683085f, 0.03042226f, 0.01242953f, 0.33441332f, 0.07012161f, -0.00564359f, -0.04938731f, -0.21137442f, 
    -0.06061015f, -0.34371445f, -0.41853830f, -0.25292191f, 0.06669391f, -0.11576332f, 0.22133817f, 0.13706616f, 
    0.11763430f, -0.16704121f, 0.11160493f, -0.02677262f, 0.00432854f, 0.17162307f, -0.03862233f, 0.25845370f, 
    -0.13005836f, -0.20988871f, 0.06986495f, -0.04380368f, 0.27326474f, 0.12297089f, 0.00261946f, 0.22555460f, 
    0.39013249f, 0.11273853f, 0.32844603f, 0.17520711f, 0.11488080f, 0.15627635f, 0.01970320f, 0.14991269f, 
    0.04209101f, 0.21354334f, 0.08439807f, 0.23299421f, -0.32696790f, 0.24087562f, -0.24863560f, -0.35819823f, 
    0.15069112f, 0.03973423f, 0.15640235f, -0.15464209f, 0.22655492f, 0.08842568f, -0.14375000f, 0.36140159f, 
    -0.26708207f, 0.38409320f, -0.18418348f, -0.15211610f, -0.18791655f, 0.04887153f, 0.06901594f, -0.06498905f, 
    0.06764766f, 0.12814157f, -0.02183353f, -0.04938799f, 0.22053131f, 0.14246862f, -0.02089443f, -0.03711256f, 
    0.01051232f, -0.09631066f, 0.11138893f, 0.05322081f, 0.13740747f, 0.17352504f, 0.00010484f, 0.23413761f, 
    0.11883724f, -0.13288252f, 0.62552530f, 0.24660248f, 0.35105887f, -0.12765269f, -0.13267235f, 0.28343949f, 
    -0.14396743f, -0.07896652f, 0.15045309f, -0.19145477f, -0.01224854f, 0.03076785f, -0.26275054f, -0.09583224f, 
    -0.05584763f, -0.04690834f, 0.05515836f, 0.01104770f, -0.07238672f, -0.13994297f, 0.11060582f, 0.05601312f, 
    -0.14822163f, 0.53778034f, -0.44662210f, -0.21527806f, 0.25007853f, -0.19008832f, 0.35039014f, -0.04277419f, 
    0.08848102f, 0.11527421f, 0.13200547f, 0.11546741f, -0.09211625f, -0.18589431f, -0.00504548f, 0.10911072f, 
    -0.08485926f, 0.03931236f, -0.11666627f, -0.20618349f, 0.04757386f, 0.14589545f, -0.00988465f, 0.02684724f, 
    -0.66817695f, -0.12282018f, -0.38412777f, 0.12127644f, -0.10829747f, 0.29991859f, 0.19852357f, -0.02023106f, 
    0.13798125f, -0.08874523f, 0.00892790f, 0.07517111f, -0.05477075f, 0.13197513f, 0.38640949f, -0.02774426f, 
    -0.15122953f, -0.19171625f, -0.20146841f, -0.02022273f, 0.25168002f, 0.12583220f, 0.25297844f, 0.10300186f, 
    0.01266267f, -0.31368291f, 0.21736892f, 0.18551600f, 0.01041428f, 0.02634521f, 0.14752544f, -0.05439430f, 
    0.17962599f, -0.03563771f, -0.00421917f, 0.04885361f, -0.02157844f, 0.12047023f, 0.07342274f, -0.01171678f, 
    0.14797452f, -0.02035619f, -0.10741091f, 0.05850581f, 0.08136868f, 0.04225114f, -0.02171351f, 0.01699205f, 
    0.14692771f, 0.21312737f, 0.12691671f, -0.02833503f, -0.20480247f, -0.06749388f, -0.14141084f, -0.02432801f, 
    -0.31722367f, -0.12740694f, 0.02049097f, -0.01570628f, 0.16094503f, -0.02189409f, 0.03003898f, -0.00386252f, 
    0.22059789f, 0.28025702f, -0.08480182f, -0.03332441f, -0.05346102f, 0.02712604f, 0.13926367f, -0.19474344f, 
    -0.18740141f, -0.24074844f, -0.11633072f, -0.10110874f, -0.20689534f, 0.07566453f, 0.03943688f, -0.03242629f, 
    0.23862249f, -0.25495476f, -0.12068935f, -0.11900304f, 0.16180335f, 0.13421381f, 0.20537838f, -0.18883000f, 
    0.00084246f, 0.03253743f, -0.10383083f, 0.05469882f, -0.12265630f, 0.01243911f, -0.00998213f, 0.17609267f, 
    0.09224202f, 0.49741688f, 0.20217603f, -0.03306552f, 0.36423519f, -0.06094341f, -0.09678158f, 0.16530436f, 
    0.01015773f, 0.10091197f, 0.06544412f, -0.05222349f, 0.16700928f, -0.00929283f, 0.10755277f, -0.01744516f, 
    0.21365350f, 0.31762868f, -0.24921454f, 0.22251466f, -0.03298068f, -0.01569807f, -0.13215223f, 0.15282530f, 
    -0.16856028f, -0.36923164f, -0.05247423f, -0.13718843f, 0.28464672f, -0.00056157f, 0.30364177f, -0.13848466f, 
    0.05333324f, 0.00384544f, 0.08623010f, -0.17710906f, 0.08248104f, -0.11379336f, -0.03274048f, 0.23042609f, 
    0.00644811f, 0.08620032f, -0.24719332f, -0.04478745f, 0.18505733f, 0.12114078f, -0.04405903f, 0.20532139f, 
    0.29559761f, -0.02474185f, -0.44624439f, -0.14558265f, -0.32236010f, 0.07454785f, 0.17632534f, 0.06903417f, 
    0.08514538f, -0.01513196f, 0.12703905f, 0.11197076f, 0.07260019f, 0.19113420f, -0.00002400f, -0.02900712f, 
    0.02248114f, -0.00842512f, -0.07198803f, -0.06110038f, 0.20531239f, 0.12008142f, 0.17256901f, 0.10311165f, 
    -0.21581876f, -0.20406120f, 0.25121453f, 0.34607556f, 0.13596256f, 0.25758895f, -0.19487813f, 0.22946717f, 
    0.01689812f, 0.02758979f, 0.19569710f, -0.15065162f, -0.36699528f, -0.26101464f, 0.04934936f, 0.17706658f, 
    0.13314995f, -0.15707442f, 0.13021381f, 0.02054021f, 0.03478749f, 0.16550392f, -0.04765644f, 0.05430234f, 
    0.17284961f, -0.29540953f, -0.15213124f, 0.12841184f, -0.12850387f, -0.25015971f, 0.07216619f, 0.29253346f, 
    -0.10476786f, 0.03699395f, 0.12192763f, 0.22301628f, -0.11321045f, -0.22484340f, -0.23607706f, 0.02625990f, 
    0.19336054f, 0.05320109f, 0.02582281f, -0.03031594f, -0.03424964f, 0.09811125f, 0.05533566f, -0.06772041f, 
    -0.10018024f, -0.20137261f, -0.06694046f, 0.06032234f, -0.00093544f, -0.22968584f, -0.16778253f, 0.08896827f, 
    -0.14622505f, -0.03100706f, 0.05972438f, -0.11022729f, 0.11631381f, -0.01121750f, -0.13105370f, -0.12676306f, 
    0.02486424f, 0.08026896f, 0.02925366f, 0.08072770f, -0.01028856f, -0.08453724f, -0.05375053f, -0.20802441f, 
    0.15196030f, 0.00091809f, -0.09060270f, -0.01516601f, -0.02486881f, -0.06690852f, -0.03393100f, -0.07104737f, 
    0.07369549f, 0.17103958f, 0.02032665f, 0.01383701f, 0.20461228f, 0.25583053f, -0.05465463f, 0.04419944f, 
    -0.01426590f, 0.02171738f, 0.03967813f, -0.14602029f, 0.10381345f, 0.12998858f, 0.23885195f, 0.16055478f, 
    0.04678848f, 0.08144362f, 0.05048809f, -0.00206252f, 0.04573702f, 0.08941584f, 0.16705833f, 0.14580566f, 
    0.07626309f, -0.07704036f, -0.11732196f, 0.20432000f, 0.12556434f, 0.04470520f, 0.23021786f, 0.13107973f, 
    0.00332603f, -0.02171063f, 0.12146441f, -0.06830163f, -0.09585559f, -0.00209175f, -0.10287604f, -0.26169622f, 
    0.09500198f, -0.28012896f, -0.10651265f, -0.22080846f, -0.03178662f, 0.20572351f, 0.03424354f, -0.37952709f, 
    0.05098002f, -0.07645589f, -0.03135890f, -0.19937642f, 0.05823388f, 0.04749103f, 0.04066606f, -0.13797857f, 
    0.32336342f, -0.04796265f, 0.14089431f, 0.17017919f, -0.04382761f, -0.09898464f, 0.05091805f, -0.25454235f, 
    0.46071735f, 0.19784854f, -0.08253675f, -0.01549380f, 0.07550481f, -0.01297740f, -0.17953838f, 0.27718413f, 
    -0.25606737f, 0.02307972f, -0.10056081f, 0.25829852f, 0.19066983f, -0.04083155f, -0.10185216f, -0.19773149f, 
    -0.01005369f, -0.00714677f, 0.04139142f, 0.09223688f, -0.14592648f, 0.18930064f, 0.29205343f, -0.15932959f, 
    -0.01140190f, 0.19299473f, -0.22497857f, 0.30738744f, 0.24368989f, 0.06708331f, -0.09369290f, -0.03982004f, 
    -0.08608652f, 0.13012899f, -0.05466506f, -0.05714808f, -0.16465005f, -0.21488793f, -0.04546063f, 0.09913892f, 
    0.05513425f, -0.05029744f, 0.00594622f, -0.02370504f, 0.15277888f, 0.11810487f, 0.00154359f, 0.02439580f, 
    -0.33176276f, 0.51837993f, -0.21814758f, 0.33237889f, 0.12933168f, 0.00379644f, -0.16899437f, 0.06084266f, 
    0.00960908f, -0.06845153f, 0.01363169f, -0.12128067f, -0.15116988f, -0.09191856f, 0.12344223f, 0.06423140f, 
    -0.07946963f, -0.20195107f, 0.07322072f, -0.01840751f, 0.04888316f, -0.02895896f, 0.02170123f, -0.04259256f, 
    -0.18467350f, 0.44705644f, 0.60698336f, -0.15771416f, -0.22472012f, 0.08333436f, -0.04566559f, -0.08658205f, 
    0.02294969f, -0.18972987f, -0.13195293f, 0.19349383f, -0.35510519f, -0.03793895f, 0.02467514f, 0.24423516f, 
    -0.08758783f, 0.13703331f, 0.04431889f, -0.05970453f, 0.16338001f, 0.11884509f, 0.23458923f, 0.20637184f, 
    -0.04635412f, -0.03986182f, -0.12760012f, 0.08842858f, 0.19286898f, 0.17216842f, 0.01901497f, 0.15586223f, 
    0.07135189f, 0.00426331f, 0.08392081f, 0.22498843f, -0.04796867f, 0.11372280f, -0.09655862f, 0.00196462f, 
    0.21274887f, -0.13767907f, -0.19766502f, -0.01148871f, 0.08329802f, 0.11509646f, -0.02013119f, -0.01199939f, 
    -0.24925429f, -0.13712692f, -0.04733678f, -0.15871429f, -0.12252892f, -0.00528190f, -0.18501134f, -0.07530772f, 
    -0.07648973f, -0.03103428f, 0.07519662f, 0.00084932f, 0.07315394f, 0.23028660f, 0.21869546f, 0.15905635f, 
    0.15982617f, 0.08356198f, -0.00573282f, -0.08371238f, 0.07527572f, -0.01113784f, 0.19100097f, 0.09886051f, 
    -0.17354774f, 0.06238981f, -0.07863272f, -0.06878765f, -0.02695332f, -0.14117436f, 0.11826953f, -0.05124488f, 
    -0.15259282f, -0.24546418f, -0.13381624f, -0.07754954f, -0.17891937f, -0.07238673f, 0.13173549f, -0.01172713f, 
    -0.09547071f, 0.08189207f, -0.05264988f, -0.00391991f, 0.11442226f, 0.04186607f, 0.01272647f, 0.22129956f, 
    0.33247086f, -0.32398364f, 0.26446864f, -0.15388522f, 0.04147916f, -0.06681567f, 0.17663583f, 0.09463221f, 
    -0.02329636f, -0.01220226f, 0.12320518f, -0.00340829f, -0.18584670f, -0.09708269f, 0.02730297f, -0.15620564f, 
    0.05726029f, 0.06227930f, 0.03794585f, 0.34324718f, 0.09700864f, -0.05874440f, 0.10800956f, 0.03496938f, 
    -0.36021724f, -0.23505567f, 0.10710028f, 0.39984137f, -0.00118343f, -0.25044492f, 0.07906198f, -0.23033459f, 
    0.04613740f, 0.12209571f, 0.04832697f, 0.00931004f, 0.00656181f, -0.01630864f, -0.10450432f, -0.03296217f, 
    -0.01767387f, -0.07106031f, 0.04236365f, -0.14116016f, 0.03662084f, 0.11839768f, 0.11541215f, 0.18609226f, 
    0.07671099f, 0.32209870f, 0.06390327f, -0.07887945f, 0.28143626f, 0.08749272f, 0.36607864f, 0.12331044f, 
    -0.09903948f, -0.08955756f, 0.06649905f, -0.13326691f, -0.06785619f, -0.03722912f, 0.02281110f, 0.12488645f, 
    -0.17757237f, -0.08574726f, -0.09704699f, -0.15199204f, 0.10627653f, -0.02171972f, 0.09595665f, 0.10908320f, 
    0.41514495f, -0.85960197f, 0.07432834f, 0.28266203f, -0.29414409f, 0.27589822f, 0.33622324f, 0.12193284f, 
    0.11321500f, 0.28825548f, 0.08037098f, 0.12876397f, 0.06515965f, 0.11976343f, 0.01147107f, -0.26473904f, 
    -0.05218035f, 0.21249633f, -0.06387749f, 0.09895583f, 0.02402169f, 0.06739571f, -0.04095985f, -0.07401827f, 
    0.29178777f, 0.12452844f, -0.29399380f, -0.30389616f, -0.18645827f, -0.00167775f, -0.09883282f, 0.15034893f, 
    0.02278275f, 0.17033114f, -0.04202383f, -0.02262608f, 0.21964829f, 0.04652859f, 0.08568946f, -0.02979949f, 
    0.27457556f, 0.00570840f, 0.08805043f, 0.10866539f, 0.17411169f, 0.02164144f, 0.15368670f, 0.05663690f, 
    -0.08402123f, 0.31423122f, -0.04854948f, -0.27632090f, -0.02181285f, -0.05816994f, 0.02668530f, -0.07040457f, 
    -0.09954690f, -0.08056417f, 0.01523420f, -0.11561929f, 0.04885183f, 0.13741067f, 0.07422654f, -0.01361354f, 
    0.26665553f, 0.23529467f, 0.10997491f, 0.09604688f, -0.17648801f, 0.10753235f, 0.10686302f, -0.08093909f, 
    0.17780802f, 0.15881759f, 0.06643358f, 0.05108114f, -0.09294180f, 0.12667103f, -0.02365902f, 0.00697974f, 
    -0.13268074f, -0.06642035f, -0.12101140f, -0.02328455f, -0.16883454f, -0.29204592f, -0.16342327f, -0.23901646f, 
    -0.02660994f, -0.01697939f, -0.10839304f, 0.28618047f, 0.03787473f, 0.11688219f, -0.23120601f, -0.14123304f, 
    -0.07091419f, -0.11927985f, -0.02492599f, -0.18028831f, -0.07711176f, -0.03728294f, 0.10398042f, 0.08619977f, 
    0.10705367f, 0.06339019f, -0.20008208f, -0.18290237f, 0.31028545f, 0.04624796f, 0.47037855f, -0.02539771f, 
    0.04245398f, 0.02254926f, 0.09691215f, 0.12003590f, -0.15958428f, 0.04213548f, -0.10619806f, 0.22584563f, 
    -0.46254006f, 0.08205272f, 0.01336206f, -0.06020388f, -0.01365910f, -0.00219648f, 0.20634432f, 0.17341223f, 
    0.09020670f, 0.03294858f, -0.03465330f, -0.07302672f, 0.02654869f, 0.04385958f, 0.03095418f, -0.08399111f, 
    0.09868921f, -0.03227240f, 0.13047601f, 0.07569680f, -0.23298259f, 0.15929759f, -0.02110613f, 0.06339492f, 
    -0.28716493f, -0.02801019f, 0.15136112f, 0.04322265f, 0.27432704f, 0.12104552f, 0.01386634f, 0.16840701f, 
    -0.01596966f, -0.07478802f, -0.07227480f, -0.08557443f, -0.48160744f, 0.33807033f, 0.27136707f, 0.25593281f, 
    -0.09214144f, 0.03203121f, -0.12881880f, -0.04271376f, 0.24643199f, 0.18929687f, 0.04055829f, 0.07227690f, 
    0.45615590f, 0.19995648f, -0.36888137f, 0.29402116f, 0.16785297f, -0.12158309f, 0.14118947f, 0.11768165f, 
    0.01352776f, 0.20862120f, 0.11626248f, -0.02067106f, -0.02326750f, -0.27533424f, 0.04231638f, 0.16483073f, 
    -0.07670418f, -0.15504134f, 0.03688654f, 0.03342791f, 0.11598290f, 0.06764617f, 0.00606971f, 0.25661606f, 
    0.06542401f, -0.09224741f, -0.23152842f, -0.10835817f, -0.09952591f, 0.16023594f, 0.16411571f, -0.13584328f, 
    0.12320627f, -0.04720190f, -0.09508981f, 0.10500767f, 0.13310023f, 0.44858980f, 0.44084793f, -0.10497511f, 
    -0.01250445f, 0.01476303f, 0.14737390f, -0.06523241f, 0.09551165f, -0.14041916f, 0.21394186f, 0.09247102f, 
    -0.13646953f, 0.31541979f, -0.38088745f, -0.55982035f, -0.00548595f, -0.00736355f, -0.22917609f, 0.02713811f, 
    -0.01605674f, -0.03666730f, 0.17230321f, 0.01216783f, -0.11280639f, 0.37962291f, 0.01588966f, 0.16226128f, 
    -0.05541071f, 0.07526836f, 0.05368787f, 0.15082981f, 0.06866185f, -0.09771635f, 0.10728276f, 0.18034983f, 
    0.29492244f, 0.24735810f, 0.36723718f, 0.04943212f, 0.13983281f, 0.06232841f, 0.22337203f, -0.03596276f, 
    0.12193570f, -0.12533656f, -0.05301600f, -0.06746607f, 0.00968278f, -0.01624619f, -0.20330045f, 0.01847929f, 
    0.16095570f, 0.17243934f, 0.08361537f, 0.06543519f, -0.02543669f, -0.04983976f, -0.06862219f, -0.15869799f, 
    0.04677526f, -0.23142307f, 0.02100554f, 0.14236845f, 0.04263328f, 0.10308265f, -0.02787735f, 0.04170286f, 
    -0.03408161f, 0.06007751f, -0.02358339f, -0.07983466f, -0.41321263f, -0.24619173f, -0.01802748f, 0.46920675f, 
    0.11601660f, -0.02266032f, -0.10121279f, -0.03218731f, 0.03974088f, -0.09592016f, 0.03019705f, -0.00119551f, 
    0.13293204f, 0.05668066f, -0.15557331f, -0.10560348f, -0.10893554f, 0.06093770f, -0.17920175f, 0.04177560f, 
    0.00908733f, 0.00476067f, -0.05973963f, -0.07939839f, 0.17646079f, -0.14133647f, -0.09746842f, 0.26659596f, 
    0.06864028f, 0.00762345f, -0.02847633f, -0.06661948f, 0.01387913f, -0.03110973f, -0.02787719f, 0.10778010f, 
    -0.70705920f, 0.14813019f, 0.00713031f, 0.08472160f, 0.27880540f, -0.03841839f, 0.17997269f, 0.13478288f, 
    -0.01288831f, 0.01924011f, -0.09517989f, -0.09159364f, 0.27407119f, -0.07237273f, 0.05275445f, -0.13915458f, 
    0.07279989f, 0.23045939f, 0.03100341f, 0.16943060f, -0.10803932f, -0.12389062f, -0.19666994f, -0.17939453f, 
    -0.30412048f, -0.19080886f, 0.24017200f, 0.02877267f, 0.19198994f, 0.07564694f, -0.02410942f, -0.10572483f, 
    0.05344259f, -0.08653686f, -0.02086907f, 0.01148315f, -0.05948355f, -0.01219315f, -0.14166051f, 0.17015398f, 
    -0.15606745f, -0.01407272f, -0.10342573f, 0.14739017f, -0.00848011f, -0.07542711f, 0.14559633f, 0.02439854f, 
    -0.15596139f, 0.10129745f, -0.00880932f, 0.02892906f, 0.07816678f, -0.01624690f, -0.06022028f, -0.08305280f, 
    0.06391590f, -0.00957351f, -0.11584076f, 0.05417047f, 0.02885378f, 0.17144839f, 0.04927468f, 0.03002869f, 
    -0.02572270f, -0.06921028f, -0.00093427f, -0.02599646f, -0.10753232f, -0.09436857f, -0.18053482f, -0.08514173f, 
    0.37533420f, -0.45919010f, 0.02259105f, 0.09436078f, -0.20836198f, 0.12959805f, -0.17419872f, 0.32828093f, 
    0.13358586f, 0.05804199f, -0.02048968f, -0.22901680f, 0.18215849f, -0.03774376f, 0.26526287f, 0.34193534f, 
    -0.06106343f, 0.04743154f, -0.06389751f, 0.19210605f, -0.00650120f, 0.02380903f, -0.04087726f, 0.05713539f, 
    0.61161494f, 0.10703070f, 0.20886159f, -0.24375811f, -0.20095442f, -0.18512535f, -0.18472195f, -0.05108871f, 
    0.11727439f, 0.02870336f, -0.18194509f, -0.04941235f, -0.06563276f, -0.06030634f, 0.31273216f, 0.15033719f, 
    0.02783674f, 0.06137777f, 0.18136515f, 0.08671252f, 0.04679677f, -0.02581619f, -0.20028767f, -0.00488527f, 
    -0.10845076f, 0.23133029f, 0.03078933f, 0.35876209f, 0.03236866f, 0.15403764f, -0.03875362f, 0.20363714f, 
    -0.16475271f, -0.00038839f, 0.03558520f, 0.02929832f, 0.05911036f, 0.05424319f, 0.09052549f, 0.09231367f, 
    0.01708522f, 0.00756113f, -0.02174178f, -0.00222363f, -0.13206948f, 0.15285680f, 0.00060520f, 0.13192080f, 
    0.15579595f, 0.31979099f, 0.18791971f, 0.18590438f, -0.05074075f, -0.07018979f, -0.00441284f, 0.02039188f, 
    0.19457075f, 0.09937494f, -0.00618887f, 0.13545597f, 0.04590661f, -0.18957508f, -0.15130432f, -0.16763170f, 
    -0.03418515f, -0.10952861f, -0.09128411f, -0.10318054f, -0.05255458f, -0.11690798f, -0.04975551f, 0.00157812f, 
    -0.40051937f, -0.02904220f, 0.05603696f, -0.00233190f, 0.19792610f, 0.09081451f, -0.03037209f, 0.15928198f, 
    -0.09304743f, 0.01490373f, -0.01795682f, -0.20902897f, 0.35935843f, 0.32253242f, 0.24724762f, 0.03122140f, 
    -0.03655852f, -0.02421395f, 0.02321369f, 0.01213320f, 0.06292535f, 0.06278268f, -0.05674976f, 0.06008529f, 
    -0.13768670f, -0.17769606f, 0.09922000f, 0.27915055f, 0.02552588f, -0.08175500f, 0.22803782f, -0.07904536f, 
    0.14838165f, 0.13618559f, -0.08597989f, 0.02649369f, -0.23002020f, 0.01421490f, 0.07639707f, 0.01084399f, 
    0.06454908f, -0.14230505f, 0.14833346f, -0.08929807f, -0.09107991f, -0.10937642f, 0.00851778f, 0.23635058f, 
    -0.43026623f, -0.11903903f, -0.19499223f, -0.16989391f, -0.41163582f, -0.11557068f, -0.08212598f, -0.07472786f, 
    0.04310517f, -0.08772782f, 0.08626760f, -0.13481659f, -0.23011525f, -0.11942159f, 0.09079880f, -0.07142781f, 
    0.06703421f, 0.00513644f, 0.08703768f, -0.10609341f, 0.23590238f, 0.04422572f, -0.25149259f, 0.17043948f, 
    0.37745053f, 0.23370577f, -0.23970141f, 0.24958208f, 0.04810402f, 0.06137370f, 0.32228279f, 0.08419103f, 
    -0.18730257f, -0.01721491f, -0.01952545f, 0.00902490f, -0.33886611f, 0.04316339f, -0.15557130f, 0.02687527f, 
    -0.08855388f, -0.06985874f, -0.01459358f, -0.01058144f, 0.22642423f, 0.12304267f, -0.04842289f, 0.14268316f, 
    -0.05484386f, 0.15831831f, 0.04581315f, 0.43954855f, -0.10482386f, 0.01394400f, 0.22413121f, -0.21811327f, 
    -0.13062744f, 0.07310341f, -0.13730730f, 0.21596821f, 0.19573621f, 0.33281821f, 0.12417527f, -0.32776132f, 
    0.28891966f, -0.02418502f, 0.12704708f, -0.04763068f, 0.08215553f, -0.10093851f, -0.12265773f, -0.14579478f, 
    -0.40712833f, 0.45785469f, -0.53339726f, -0.14256537f, -0.10059229f, -0.10878541f, -0.18167591f, 0.03137060f, 
    -0.15794638f, 0.01688899f, -0.05291105f, -0.06443624f, 0.04775743f, 0.31126940f, -0.40007347f, 0.16886538f, 
    0.03036018f, 0.26413658f, -0.02102272f, -0.01251668f, -0.03838405f, -0.11024838f, 0.08440851f, 0.04798929f, 
    0.36924469f, 0.21290635f, 0.05890263f, -0.23195805f, 0.14808784f, 0.11165543f, 0.11176965f, 0.02335881f, 
    0.10483319f, -0.04360458f, -0.18223935f, 0.01945664f, -0.04581754f, 0.04805725f, -0.10881972f, 0.09408332f, 
    0.04030992f, 0.06208220f, 0.18026341f, -0.07230990f, 0.07945056f, -0.05736170f, 0.10436304f, -0.08951487f, 
    0.15805320f, -0.15268952f, -0.01047690f, -0.08411739f, 0.14168942f, 0.25635001f, -0.08834700f, 0.04156292f, 
    -0.13811001f, -0.05055168f, -0.07768360f, -0.08461778f, -0.40146506f, 0.05413434f, 0.17768417f, 0.35823047f, 
    -0.03938887f, 0.09494856f, -0.06046195f, 0.03245146f, 0.09035783f, -0.01415989f, 0.04557736f, 0.14219458f, 
    0.08487339f, 0.04553140f, -0.06247772f, 0.02485544f, -0.25178319f, 0.06668849f, -0.15030660f, 0.07039569f, 
    -0.02952916f, 0.07533370f, -0.06520742f, -0.06163043f, -0.01364014f, -0.01056637f, 0.03727336f, 0.16734228f, 
    -0.16773243f, -0.01775584f, 0.08454486f, 0.01381550f, 0.00970395f, -0.08684219f, 0.03305256f, 0.13140088f, 
    -0.36433330f, -0.11522786f, 0.47902966f, -0.16321848f, -0.03565330f, 0.25290105f, 0.22618413f, 0.18881571f, 
    0.07645234f, 0.06614929f, 0.05982434f, 0.08019463f, 0.27485526f, -0.04102950f, 0.08082908f, 0.23366760f, 
    -0.23156944f, 0.20522323f, -0.09329497f, 0.07544287f, -0.11243064f, 0.12567721f, 0.10205692f, -0.15270691f, 
    -0.02837509f, -0.15077546f, 0.11624846f, -0.10522885f, 0.11221365f, -0.04934036f, -0.11259115f, -0.07502429f, 
    0.00848178f, 0.03426360f, 0.04907864f, -0.04120596f, 0.10450119f, 0.08080442f, -0.19112299f, 0.11184034f, 
    -0.26922578f, 0.11866151f, -0.03071417f, 0.10639597f, -0.08896197f, -0.19453147f, 0.23723008f, -0.07469925f, 
    -0.02346686f, -0.08910504f, 0.03642848f, 0.09939185f, 0.20490149f, 0.19688134f, -0.00146947f, 0.38201642f, 
    0.00434328f, 0.16364115f, 0.20431440f, -0.01709087f, 0.19984242f, -0.12524314f, 0.13547607f, -0.10037234f, 
    0.08298001f, -0.09561072f, -0.09411000f, -0.07421637f, -0.07942753f, -0.15237413f, 0.01024854f, -0.22622065f, 
    0.81380451f, -0.15955323f, -0.10399327f, -0.55617958f, -0.03855050f, -0.35731626f, 0.33981511f, 0.09729615f, 
    0.05717346f, -0.15924296f, -0.27603471f, 0.03359530f, 0.06032304f, 0.13879080f, 0.04142257f, 0.02242243f, 
    0.10143054f, 0.17172891f, 0.05586379f, 0.01992461f, 0.04194799f, -0.15233439f, -0.00303932f, -0.06797550f, 
    -0.24641670f, -0.57127798f, -0.39001650f, -0.18482742f, 0.00222362f, 0.09249403f, -0.02847338f, 0.18697202f, 
    0.08240605f, -0.16533449f, 0.33020234f, -0.10421971f, 0.22845644f, 0.39524373f, 0.13289732f, -0.33222938f, 
    -0.21852176f, -0.25117627f, 0.03787948f, 0.06146535f, -0.02564362f, -0.00529508f, 0.01733012f, 0.15416315f, 
    0.11748754f, 0.03861798f, 0.47565824f, 0.19050571f, -0.04060899f, 0.17457375f, 0.09542985f, -0.07298648f, 
    0.07185631f, 0.03755630f, -0.00628862f, 0.02579461f, -0.07326444f, -0.04671127f, 0.02783881f, -0.04535402f, 
    0.09279672f, -0.00935990f, -0.20513825f, -0.17257756f, 0.02942123f, 0.03829467f, 0.07848969f, 0.04350427f, 
    0.02756133f, 0.03072774f, -0.07790702f, 0.01014125f, 0.02913231f, -0.08264352f, -0.07501689f, -0.08270112f, 
    0.16720431f, -0.07256979f, 0.04243910f, -0.00999090f, -0.28540638f, -0.26826560f, -0.17213076f, 0.19323407f, 
    -0.00672079f, -0.00685472f, -0.00844383f, 0.06824610f, 0.25136429f, -0.20208390f, -0.17661989f, -0.35632944f, 
    0.06193163f, -0.02849029f, -0.12177851f, -0.06523857f, 0.01811908f, 0.32862607f, 0.25068188f, 0.13552405f, 
    0.03500825f, -0.02371730f, 0.02223164f, 0.02391839f, -0.10118560f, 0.00446975f, -0.22565690f, 0.42256957f, 
    0.11396965f, -0.05360686f, -0.07332329f, -0.03917313f, 0.08284849f, 0.09835374f, -0.04249121f, 0.23093602f, 
    -0.52824301f, 0.77778280f, -0.19881928f, 0.58842242f, 0.22861992f, -0.08956940f, -0.08814318f, 0.01003924f, 
    -0.13368225f, 0.01609016f, 0.07120122f, -0.12029988f, -0.00275184f, 0.09348214f, -0.09291770f, -0.01776531f, 
    0.11700332f, -0.15584457f, 0.10459206f, -0.10682221f, 0.02793802f, -0.14713126f, -0.04694573f, 0.10956340f, 
    0.75917804f, -0.13294435f, -0.05301227f, -0.28854546f, 0.08237305f, -0.01059405f, 0.17304672f, 0.10989936f, 
    0.04713754f, 0.13334469f, -0.07503812f, 0.07272901f, 0.00314684f, 0.11783087f, 0.16865008f, 0.10828974f, 
    0.04137307f, 0.11150578f, -0.01837054f, 0.06746987f, 0.24819981f, -0.29974967f, -0.17079450f, -0.11503544f, 
    0.01475000f, -0.05335793f, -0.02725708f, -0.04658053f, 0.02008387f, -0.00796550f, -0.00851910f, 0.05479604f, 
    0.00851417f, 0.01074182f, 0.00055079f, -0.03325766f, -0.04701617f, -0.01550278f, 0.05946469f, 0.04824309f, 
    -0.03583413f, 0.02200984f, 0.01445276f, -0.05622486f, 0.00153921f, -0.04108275f, -0.01013719f, -0.02757960f, 
    -0.01240009f, -0.04349998f, -0.06190509f, 0.05431313f, -0.00017830f, -0.04782688f, -0.07524269f, 0.03925506f, 
    -0.01534377f, -0.03626068f, 0.05323626f, -0.06452017f, -0.03143770f, -0.02633485f, -0.04977025f, -0.03566638f, 
    0.05169799f, -0.05520107f, 0.03337435f, -0.03284611f, -0.00353408f, -0.07299075f, -0.06615459f, 0.01468639f, 
    0.02762157f, 0.03321815f, -0.04721412f, 0.00405954f, -0.00372273f, 0.05067137f, -0.02146053f, 0.02932622f, 
    -0.02647994f, -0.01969638f, -0.05873979f, -0.00396972f, -0.03577768f, 0.04684971f, 0.02986641f, -0.01792692f, 
    0.02911452f, -0.03134289f, -0.02433941f, 0.01843457f, 0.04488646f, -0.06852207f, -0.03245253f, -0.07332716f, 
    0.01576434f, 0.00969577f, -0.02801857f, 0.01792688f, -0.03282850f, 0.05519862f, -0.07602181f, -0.06060300f, 
    0.04908473f, -0.00987161f, 0.02174208f, -0.05979460f, 0.04841715f, -0.00507045f, -0.01008830f, -0.03881330f, 
    -0.06946567f, 0.03167864f, -0.03972193f, 0.00385468f, -0.04549631f, -0.00830490f, 0.05138849f, 0.04217118f, 
    -0.04052066f, -0.01675785f, -0.05667716f, -0.00909401f, -0.05066172f, -0.01480700f, -0.00090755f, -0.03786810f, 
    0.01306831f, 0.04406197f, -0.06595255f, -0.04130216f, 0.00290309f, 0.06167338f, -0.05459327f, -0.03631631f, 
    -0.05008936f, 0.02783171f, 0.03910712f, -0.03318993f, 0.03035980f, 0.02024781f, -0.07353495f, 0.03894280f, 
    -0.06467561f, -0.05382522f, -0.00654586f, 0.01716358f, 0.04573962f, 0.04034467f, -0.06341367f, -0.06174110f, 
    -0.07172860f, -0.04844317f, 0.04023020f, 0.04580312f, -0.06029898f, -0.08102453f, 0.06225039f, -0.06180697f, 
    0.04427527f, -0.01602260f, -0.00051332f, -0.03259584f, -0.04030252f, -0.06964064f, -0.07991520f, 0.03333819f, 
    -0.02436252f, 0.05227992f, -0.07678763f, 0.05817499f, 0.00681707f, -0.00687438f, -0.01951323f, -0.02319657f, 
    -0.03633426f, -0.04613498f, -0.06568419f, -0.05853176f, -0.02522355f, -0.02300091f, 0.06229201f, -0.01583617f, 
    0.01465767f, 0.03759524f, -0.03765199f, -0.03220780f, -0.02412008f, 0.03008028f, 0.04249087f, 0.04189704f, 
    -0.03453817f, -0.01232010f, 0.03755355f, 0.00188160f, 0.01349659f, -0.04500742f, 0.04974053f, -0.04125297f, 
    -0.03998719f, 0.02942115f, -0.01128829f, -0.00319343f, -0.05237454f, -0.00260228f, 0.04052792f, 0.05792161f, 
    0.00724387f, -0.02212469f, -0.00291125f, -0.04709525f, 0.01286069f, 0.03681916f, -0.06073732f, -0.03739293f, 
    -0.04971962f, -0.00838755f, 0.01464941f, -0.01035991f, 0.04551877f, 0.04176283f, -0.03244912f, 0.05556867f, 
    -0.04446797f, -0.03493179f, -0.05291728f, -0.05556933f, 0.00101560f, -0.00375930f, 0.00660432f, -0.05085879f, 
    0.06264517f, -0.05073185f, 0.03911309f, 0.05459226f, 0.04891152f, 0.04444724f, -0.04872886f, 0.01485785f, 
    -0.07560951f, -0.05566776f, 0.04539644f, -0.01390209f, -0.05503811f, 0.03615603f, -0.01723518f, 0.05649153f, 
    0.01803980f, 0.04705371f, -0.00672768f, 0.03818692f, -0.04106918f, -0.04503883f, -0.01419124f, -0.07130866f, 
    0.01883192f, 0.05140814f, -0.00473025f, -0.07761025f, -0.07940432f, 0.05528706f, -0.00461391f, -0.03586386f, 
    0.05846089f, 0.00023849f, 0.05359126f, -0.06672364f, 0.04971740f, -0.07653154f, 0.00389916f, 0.03584019f, 
    0.05225105f, -0.01359192f, -0.06141454f, -0.01748186f, -0.04653333f, 0.05404202f, -0.03867001f, -0.00347492f, 
    -0.04738427f, -0.01153561f, -0.07071774f, -0.01168711f, -0.01001805f, -0.06058234f, 0.03509572f, 0.03725005f, 
    -0.06552642f, -0.04024304f, 0.05379355f, 0.04273144f, -0.03157264f, -0.02448506f, -0.02499856f, -0.04931112f, 
    -0.00177022f, 0.00977836f, -0.06153817f, 0.05434514f, -0.03727677f, 0.00348093f, -0.01547454f, 0.01393755f, 
    -0.08066914f, 0.04550857f, -0.07311253f, 0.00687275f, -0.04900817f, -0.03575521f, 0.02294325f, 0.03998104f, 
    -0.05023273f, -0.05205918f, 0.05744978f, 0.03077336f, -0.06484304f, 0.06139334f, -0.04685363f, -0.06098709f, 
    0.01569726f, 0.06634266f, -0.06867152f, -0.00785457f, -0.04230295f, -0.05910267f, 0.02217238f, -0.06331776f, 
    -0.06925306f, -0.03532071f, -0.06877370f, -0.03213115f, -0.01675389f, 0.05750617f, -0.04066347f, 0.00671451f, 
    0.03718337f, 0.03389747f, 0.04624833f, -0.01957748f, -0.02413008f, -0.01649160f, 0.04438986f, 0.03051296f, 
    -0.03226272f, -0.03129718f, -0.05872309f, 0.00129551f, 0.05122595f, -0.05227778f, -0.05761559f, 0.00150010f, 
    0.04512177f, -0.03201605f, 0.01245269f, -0.03226874f, -0.00027347f, 0.05798498f, -0.01445292f, -0.05131912f, 
    -0.05703209f, -0.01369799f, -0.05643930f, 0.04405262f, 0.03680491f, -0.07157141f, -0.05078301f, -0.00282876f, 
    -0.07253308f, 0.02887044f, -0.04331198f, 0.05094170f, 0.01456736f, -0.05069068f, -0.04223817f, -0.05214752f, 
    0.01064093f, -0.03456025f, 0.04364831f, 0.02120589f, -0.02898134f, 0.01290265f, -0.01257881f, -0.07962056f, 
    -0.06374955f, -0.07065392f, 0.00698798f, -0.04254971f, 0.00553764f, -0.03224344f, -0.03553862f, 0.00255659f, 
    -0.05047506f, -0.04384594f, 0.05020634f, -0.01883405f, -0.04642045f, -0.02573025f, -0.01355594f, 0.06225187f, 
    0.01903979f, 0.05372792f, 0.01635465f, -0.05992967f, -0.03479530f, 0.01174314f, -0.06327869f, 0.02617987f, 
    -0.01523020f, 0.00025190f, 0.05571766f, -0.01929618f, -0.04163445f, -0.05141070f, 0.03188925f, -0.04055529f, 
    0.02313268f, -0.00902877f, -0.01999270f, 0.00052459f, 0.02986622f, -0.06662939f, 0.00480337f, -0.03605846f, 
    -0.05387458f, 0.03466624f, 0.03706196f, 0.01491103f, 0.04651571f, -0.02207969f, -0.05890543f, -0.00609533f, 
    -0.03783087f, -0.00922431f, -0.00917224f, 0.04831146f, 0.04997224f, -0.04980779f, 0.04182703f, -0.04081127f, 
    0.02002113f, 0.01247185f, -0.02956956f, 0.00050844f, -0.04696482f, -0.06761832f, -0.03822070f, -0.03180139f, 
    0.00704880f, -0.01322844f, -0.05412707f, -0.02729841f, -0.01760364f, 0.01087017f, 0.05760429f, -0.00533288f, 
    -0.03901503f, 0.04332262f, 0.03046446f, -0.02102397f, 0.02268869f, -0.05355434f, -0.03303824f, -0.03314530f, 
    -0.00002872f, -0.08320081f, 0.04921521f, 0.06016766f, -0.04883702f, 0.02914852f, 0.00200758f, -0.05385531f, 
    -0.05855429f, -0.04369960f, -0.01926721f, -0.07976757f, 0.06218740f, -0.03344743f, 0.02472452f, -0.04599540f, 
    0.00342646f, 0.03394075f, 0.03467594f, 0.04956916f, 0.04221491f, -0.07251678f, -0.05950285f, -0.06183203f, 
    0.04388871f, -0.03110947f, 0.04613044f, -0.03628771f, 0.04589697f, 0.02156859f, -0.02251328f, -0.00473872f, 
    0.05363882f, 0.04821707f, 0.06015717f, -0.03969379f, 0.05691994f, 0.03194669f, 0.02020213f, 0.01607884f, 
    0.00532685f, -0.06362013f, -0.02154011f, 0.01977827f, -0.03748856f, -0.05710194f, -0.07214528f, -0.03845274f, 
    -0.02559328f, -0.03899708f, 0.00038230f, 0.04342107f, -0.07874852f, -0.01885282f, -0.05456017f, 0.02412651f, 
    0.05670168f, 0.02282334f, 0.06765758f, -0.05148564f, 0.06085704f, 0.02175760f, 0.00110090f, 0.02831550f, 
    -0.02110701f, -0.02793445f, -0.01999371f, -0.06995507f, -0.03702558f, -0.02168073f, -0.03926634f, 0.01954252f, 
    -0.00471576f, -0.03503171f, 0.05605657f, -0.01888255f, 0.03470564f, -0.07046497f, -0.00154961f, 0.01477661f, 
    0.04618827f, 0.04590357f, -0.03711727f, 0.00181516f, -0.01714915f, -0.01935373f, -0.07645687f, 0.01405600f, 
    0.04479646f, -0.06199100f, -0.01652966f, -0.06455497f, 0.05971850f, -0.06418635f, 0.04360705f, -0.01742146f, 
    0.00994288f, -0.07981350f, -0.00433831f, -0.00212541f, 0.07209660f, -0.03180626f, -0.02044710f, -0.01692807f, 
    0.04224566f, -0.05851832f, -0.03358472f, -0.08384007f, -0.01810626f, -0.06374586f, -0.06812302f, -0.01497979f, 
    -0.02865029f, -0.07983970f, 0.02427312f, -0.02011898f, 0.05770829f, -0.03807962f, -0.00271307f, 0.02852581f, 
    -0.03351551f, -0.03768874f, -0.04243199f, 0.01185645f, 0.04451697f, 0.00147386f, 0.00157281f, -0.06358624f, 
    -0.05208558f, 0.01839085f, 0.03090696f, 0.04800900f, -0.00435813f, 0.02324432f, -0.01653484f, -0.05506412f, 
    0.06015135f, -0.03964888f, 0.03109217f, 0.05430334f, 0.03280779f, -0.06350478f, 0.02639937f, -0.03791216f, 
    0.02756675f, -0.07095449f, 0.01301921f, 0.03640605f, -0.02018720f, -0.05869884f, 0.00438066f, 0.02685979f, 
    0.01825998f, 0.02900149f, -0.04443269f, 0.00324911f, 0.01104408f, -0.05896185f, -0.01728506f, -0.02053033f, 
    -0.00415415f, -0.07486161f, 0.04086715f, 0.06285997f, 0.01448815f, 0.05587261f, 0.00412842f, -0.01809795f, 
    -0.06622355f, 0.04835402f, 0.05210934f, -0.04357824f, 0.06029869f, -0.01662300f, 0.00449599f, 0.02713918f, 
    0.00357922f, -0.02852384f, 0.01284481f, 0.02330818f, -0.07396569f, -0.02771352f, -0.06724689f, -0.01879967f, 
    -0.04137147f, 0.01875223f, 0.06166490f, -0.01365252f, 0.02133531f, -0.01503264f, 0.05793827f, 0.05039774f, 
    0.01425543f, -0.05326983f, 0.00565470f, 0.00204573f, -0.00295194f, 0.01281914f, 0.06314690f, -0.06683239f, 
    0.06067403f, -0.01925411f, -0.01106475f, -0.06504974f, -0.02966257f, 0.00342814f, -0.06436905f, 0.06027666f, 
    -0.05538912f, -0.07058734f, 0.00434156f, 0.04082632f, -0.01133534f, 0.06304581f, -0.06496993f, -0.04305877f, 
    0.02964805f, -0.05588459f, -0.01232433f, 0.05145255f, 0.04450601f, -0.01050264f, -0.06552041f, -0.05072471f, 
    0.02786655f, -0.01797979f, -0.05829427f, 0.03825234f, -0.06754846f, 0.00444541f, -0.06563567f, -0.00742044f, 
    -0.05712987f, 0.02146913f, 0.06556694f, -0.02906909f, -0.00025175f, -0.03465140f, 0.04417725f, -0.06872906f, 
    -0.00767345f, 0.06020533f, 0.02746792f, -0.01595061f, -0.06154181f, -0.07294812f, 0.04441503f, -0.01567354f, 
    -0.01513733f, 0.01327592f, -0.00834957f, -0.00198516f, -0.04998199f, -0.01401411f, -0.07733507f, -0.01341043f, 
    -0.06638315f, 0.02801105f, 0.04706287f, -0.06250959f, 0.01517474f, -0.03168192f, 0.00285674f, -0.05425796f, 
    -0.06994809f, 0.00411598f, 0.01226633f, -0.02919250f, 0.00973625f, -0.07816330f, -0.03781641f, 0.00687521f, 
    0.05906664f, -0.06077315f, -0.02631561f, -0.03739027f, -0.02621124f, -0.02003186f, 0.05755717f, 0.05942450f, 
    -0.00376106f, 0.00297776f, 0.04220067f, -0.05796254f, -0.06886234f, 0.02343773f, -0.05697851f, -0.05850249f, 
    0.01617933f, -0.06813370f, 0.05849237f, -0.06683111f, -0.06737479f, -0.05118672f, -0.05130681f, -0.02548689f, 
    -0.00157372f, -0.04548320f, -0.01755077f, 0.02211975f, -0.04192811f, 0.03915874f, -0.05308393f, -0.03895826f, 
    -0.00091643f, -0.07200660f, -0.02179340f, 0.05569515f, -0.06410592f, 0.00795936f, 0.03916626f, -0.02335382f, 
    0.05963768f, -0.02066566f, 0.04666379f, -0.08002159f, -0.02532793f, 0.05565123f, 0.05248819f, -0.07058816f, 
    -0.07104519f, -0.02987619f, 0.00562813f, -0.04259408f, 0.04066437f, 0.00514801f, 0.04356153f, -0.06630725f, 
    0.59437668f, 0.00541129f, -0.15668009f, 0.16187087f, 0.00675005f, 0.07352347f, 0.18567586f, 0.21776855f, 
    0.06400067f, 0.09034635f, 0.04520218f, 0.08126203f, 0.11586298f, -0.06427551f, -0.18259102f, -0.12341480f, 
    -0.07310489f, -0.08809149f, 0.05239348f, 0.03455103f, 0.20336010f, 0.19257730f, 0.15630940f, -0.02673527f, 
    -0.59034657f, 0.62983662f, -0.04558122f, -0.07154346f, 0.04172116f, 0.20712586f, 0.21331695f, 0.00783169f, 
    0.16817535f, -0.04083591f, 0.18667363f, 0.00972632f, -0.31293616f, -0.06379082f, 0.21494377f, 0.15472807f, 
    0.10637897f, -0.07525589f, 0.08248386f, -0.07873791f, 0.13650583f, -0.01488092f, 0.08771018f, -0.06082411f, 
    -0.63495642f, 0.02210244f, 0.10210463f, -0.20148510f, -0.09914879f, -0.05723191f, -0.01391910f, 0.10829011f, 
    0.02565081f, -0.02002431f, 0.22401385f, 0.10343421f, -0.27681547f, 0.02401141f, 0.16230354f, 0.22203431f, 
    -0.09570289f, -0.01674126f, -0.07287925f, 0.08250721f, 0.11137439f, 0.04601000f, 0.16933340f, 0.06269492f, 
    -0.10717004f, -0.30231529f, 0.17539820f, 0.29674691f, 0.13841401f, -0.07788554f, 0.13787790f, 0.00408129f, 
    -0.01305122f, -0.17048615f, -0.17633888f, -0.14477763f, -0.01975953f, -0.08023826f, 0.03003428f, -0.08449990f, 
    0.12763219f, 0.12570827f, 0.20246404f, 0.02166983f, 0.19911586f, -0.07664862f, -0.00659792f, -0.04256156f, 
    0.15421252f, -0.05098514f, 0.02338087f, -0.16956870f, -0.00484050f, 0.01516249f, -0.01698481f, 0.13056244f, 
    -0.08720753f, 0.07551353f, 0.15006970f, 0.00126352f, -0.11072434f, 0.17730802f, 0.02535902f, 0.33142865f, 
    0.13174964f, 0.15176831f, 0.07053294f, -0.17184928f, 0.06129386f, 0.02825444f, 0.29111487f, 0.03631842f, 
    -0.15332282f, 0.03072182f, 0.06198054f, -0.02436890f, -0.15232623f, -0.13268238f, -0.19639099f, -0.12257354f, 
    0.13994013f, 0.05731146f, 0.02007324f, -0.02917003f, 0.06897465f, 0.10166193f, -0.02064871f, -0.09920686f, 
    0.01418263f, -0.04205837f, -0.08935310f, -0.12533355f, -0.02528754f, -0.02956002f, -0.00638841f, 0.09241583f, 
    -0.26795676f, -0.05764196f, -0.12180685f, 0.09702431f, 0.17961408f, 0.07558819f, -0.04067948f, 0.22807233f, 
    -0.12431245f, -0.01030919f, 0.01649971f, 0.07469982f, 0.21006106f, -0.27375531f, -0.01017021f, 0.02458893f, 
    0.22257011f, 0.08976844f, -0.18354098f, 0.17016254f, 0.07914680f, -0.15932196f, -0.16555782f, -0.09693740f, 
    0.07399806f, -0.25538653f, 0.10357008f, -0.01709587f, 0.17070387f, -0.02603116f, -0.00080862f, -0.00347231f, 
    -0.01798106f, -0.07956402f, 0.11756389f, -0.09646199f, 0.66828644f, -0.10008573f, -0.04479462f, 0.11448023f, 
    -0.04235413f, 0.02290204f, -0.11548752f, -0.11597653f, 0.13812174f, 0.15106326f, 0.26734358f, -0.11169977f, 
    -0.65222013f, 0.22369827f, 0.35425577f, -0.44414446f, 0.02488882f, 0.21433254f, -0.27447408f, -0.06552561f, 
    0.24941485f, -0.09876740f, 0.03557225f, 0.16958097f, 0.14012238f, -0.11077537f, 0.12482228f, 0.24577810f, 
    -0.05454208f, -0.02121260f, -0.13585232f, -0.14265735f, 0.10386569f, 0.18943419f, 0.06988999f, 0.03082527f, 
    0.23144774f, -0.00862461f, -0.26669937f, -0.31258497f, 0.01811307f, 0.08547226f, 0.03195304f, 0.46328458f, 
    0.24507411f, 0.11521928f, 0.10346859f, 0.06609710f, 0.15185654f, 0.13999911f, -0.17702860f, 0.03255935f, 
    0.14481159f, 0.14031047f, -0.04735525f, 0.28755638f, 0.23886651f, 0.03236057f, 0.17123592f, 0.22475700f, 
    0.58563328f, -0.19722755f, 0.15725440f, -0.21594077f, 0.16127838f, 0.12223223f, -0.14315496f, -0.19934952f, 
    0.09245966f, 0.15231538f, 0.09535558f, 0.02127538f, 0.35108668f, 0.10487091f, 0.20358406f, -0.14346296f, 
    0.19911242f, 0.10528932f, -0.09097185f, -0.06023685f, -0.08492359f, -0.01614780f, -0.11254242f, -0.11148551f, 
    0.09805759f, 0.15319885f, 0.05269361f, -0.16963761f, -0.01358515f, 0.15457769f, 0.05513532f, 0.11080280f, 
    -0.06018073f, -0.15529741f, -0.09620519f, -0.19831997f, -0.18106389f, -0.22328044f, -0.02061355f, -0.28043732f, 
    -0.07170077f, 0.06722158f, -0.17887235f, -0.00127151f, -0.04194110f, -0.12825882f, -0.17697668f, -0.27520972f, 
    -0.07550916f, -0.17911167f, -0.04485770f, 0.43990934f, -0.09976193f, -0.01407242f, 0.02696992f, -0.06963775f, 
    0.08424526f, -0.06746674f, 0.23830862f, 0.20812042f, -0.02371967f, 0.20687933f, 0.07196502f, 0.17921785f, 
    0.11739250f, 0.00916851f, -0.05649238f, 0.01595425f, -0.04796902f, 0.08042113f, 0.06180205f, 0.11236558f, 
    -0.02403383f, 0.04947770f, 0.22908315f, -0.16549392f, -0.07142736f, -0.05958778f, 0.03397892f, -0.10933702f, 
    0.17405568f, 0.16380495f, 0.32624337f, 0.13941965f, 0.02306503f, -0.10860396f, -0.27702749f, -0.15228915f, 
    0.03653020f, 0.04244425f, -0.11183693f, 0.10178207f, 0.00028001f, -0.11419489f, -0.20061700f, -0.35126239f, 
    -0.06530800f, 0.25447068f, -0.29314303f, -0.08097780f, 0.01089480f, -0.02007956f, -0.14157863f, -0.03780955f, 
    0.06478374f, -0.03404840f, -0.17130655f, -0.25162199f, -0.37612900f, -0.04499659f, -0.08444256f, 0.17059015f, 
    -0.00810035f, 0.25058076f, 0.08921450f, -0.06732139f, -0.18455505f, -0.11124941f, -0.32253912f, -0.12014906f, 
    0.15086734f, 0.13160981f, 0.20580021f, 0.32153890f, 0.17325228f, -0.05966561f, 0.25027385f, -0.15745531f, 
    -0.09853271f, -0.12436353f, -0.00676294f, -0.22662461f, -0.28693661f, 0.01219080f, 0.33005118f, 0.21971865f, 
    0.14668414f, 0.00314208f, -0.04148437f, -0.35807118f, 0.22095314f, 0.28516540f, 0.02733629f, 0.21068749f, 
    -0.06409433f, -0.04104813f, -0.04895898f, -0.04372577f, 0.00587635f, 0.02937176f, -0.00422298f, -0.00695999f, 
    0.06469308f, -0.05014347f, -0.02333633f, -0.03202250f, 0.03551487f, 0.05889153f, -0.00338933f, -0.04796826f, 
    0.04527019f, 0.02419474f, -0.04631518f, -0.00594866f, 0.02903772f, 0.00279058f, -0.00702575f, 0.00805401f, 
    -0.02952707f, 0.03938745f, 0.04853507f, 0.00907650f, -0.04939338f, 0.04759024f, 0.03621618f, 0.03901122f, 
    -0.01304103f, -0.03907347f, -0.06270183f, 0.05130370f, -0.01899424f, 0.01548532f, -0.05727427f, -0.04974567f, 
    -0.04574416f, 0.06403662f, -0.01603419f, -0.01443989f, -0.07168381f, -0.00099742f, -0.02117663f, -0.05602414f, 
    0.06391138f, 0.06703767f, -0.03978339f, -0.05075327f, -0.07165273f, 0.04097705f, 0.03458992f, -0.05038365f, 
    -0.05045029f, -0.02498280f, -0.03304601f, 0.04932202f, 0.04555785f, 0.00377679f, -0.05751490f, -0.06658652f, 
    -0.00626528f, -0.03654074f, 0.00014832f, -0.03603893f, -0.05154446f, -0.06033240f, -0.04265032f, 0.01866388f, 
    0.02362164f, -0.01169224f, 0.02648094f, 0.03285957f, -0.04224825f, 0.06500977f, 0.02269424f, 0.06559165f, 
    -0.05932701f, -0.02987910f, 0.04264985f, -0.04609535f, 0.01741022f, 0.05968173f, -0.06725930f, -0.04303282f, 
    -0.04397259f, -0.02868916f, -0.06783415f, 0.02339504f, -0.06739674f, 0.02877085f, 0.03719250f, 0.04662695f, 
    -0.06066662f, -0.06761725f, -0.05390288f, 0.03999550f, 0.04211030f, -0.03179293f, 0.00694678f, 0.06288771f, 
    -0.01442065f, 0.05027078f, -0.00012146f, 0.04017623f, -0.04987967f, 0.00838568f, -0.05041277f, -0.03794697f, 
    0.06811936f, 0.02722877f, -0.07184543f, -0.05070881f, -0.02050480f, -0.05551157f, 0.03766130f, 0.06185132f, 
    -0.02749252f, -0.05445114f, -0.05195741f, 0.01727480f, -0.07006984f, -0.03392566f, 0.04446692f, -0.02574308f, 
    -0.07801564f, 0.06352076f, 0.02030923f, 0.04493898f, -0.03870425f, -0.04635962f, -0.06458683f, -0.07272592f, 
    0.01991528f, 0.03693136f, 0.06263857f, 0.00477270f, -0.02509359f, 0.04185997f, 0.04788664f, -0.06823780f, 
    -0.07498135f, 0.05796700f, 0.01401966f, 0.03312320f, -0.01167580f, -0.00437392f, 0.01959822f, -0.00786210f, 
    -0.07360690f, 0.03910480f, -0.00215839f, 0.01450408f, -0.01093950f, 0.04758682f, -0.03186374f, -0.01895516f, 
    -0.04492314f, -0.00326382f, -0.06975371f, -0.01286990f, 0.01419690f, -0.00342388f, -0.00682893f, -0.01429790f, 
    -0.06575760f, -0.01954864f, -0.07150427f, -0.05230600f, -0.07299280f, 0.01955464f, -0.04777318f, -0.05225435f, 
    0.01992302f, -0.00956617f, 0.05067423f, -0.04310934f, 0.04225872f, -0.07246473f, 0.02862282f, -0.00396390f, 
    -0.00006901f, 0.02402653f, -0.04217994f, -0.04562379f, 0.04078036f, -0.04470569f, -0.05593473f, 0.00083289f, 
    -0.08959862f, -0.03049795f, -0.30394277f, 0.48792920f, 0.11533065f, 0.41219991f, 0.11807530f, -0.18086952f, 
    0.30529502f, 0.02600077f, 0.08903782f, 0.23330407f, 0.31065884f, -0.14692856f, 0.12339963f, -0.24496701f, 
    -0.11667868f, -0.10770138f, -0.11994455f, -0.07571238f, 0.33633643f, 0.41055217f, 0.12509616f, 0.46387634f, 
    0.37410909f, -0.15852514f, 0.22591068f, -0.18265650f, 0.28070268f, -0.05068915f, -0.02561746f, 0.36406055f, 
    0.38088551f, 0.07782447f, -0.02407556f, 0.05318129f, 0.17932701f, 0.16820125f, 0.26016355f, 0.22003396f, 
    0.17516688f, -0.08534269f, 0.26827729f, -0.07796068f, 0.32232061f, 0.09802634f, 0.13982564f, 0.16373698f, 
    0.02509196f, 0.03319752f, 0.24154206f, 0.33739814f, -0.11315441f, -0.07248075f, 0.05914140f, 0.09968150f, 
    0.17751502f, 0.00784232f, 0.08196615f, 0.25057817f, -0.13559960f, -0.10007314f, -0.20521329f, 0.05893018f, 
    -0.06756165f, -0.01050092f, 0.13445322f, 0.13036738f, -0.01635637f, -0.03543045f, 0.07118203f, 0.14582896f, 
    0.23482797f, -0.03288795f, 0.08076856f, 0.04368417f, 0.11712148f, 0.06786557f, -0.00011652f, 0.05635566f, 
    -0.10360109f, -0.26033521f, -0.23464654f, -0.14902292f, -0.28200459f, -0.53447783f, 0.05274178f, -0.07765454f, 
    0.22246200f, 0.18696000f, -0.25940332f, -0.14010476f, -0.04141751f, -0.39541981f, -0.32475653f, -0.66696757f, 
    -0.12919092f, -0.07423075f, -0.21795984f, 0.05118040f, 0.29352102f, 0.03084669f, 0.03153870f, 0.03872976f, 
    0.10518257f, -0.07495084f, -0.06914486f, 0.22350423f, 0.28549942f, -0.05104983f, -0.11570007f, 0.68038231f, 
    -0.14372857f, -0.20407662f, -0.00912147f, -0.34729019f, 0.11028059f, 0.21714407f, 0.35432726f, 0.54294169f, 
    0.21294576f, 0.30956757f, -0.00829869f, 0.30955765f, -0.10901767f, 0.10467095f, -0.03668076f, -0.03768986f, 
    0.25034362f, -0.01092075f, -0.51671118f, 0.11903991f, -0.60721278f, 0.07615279f, -0.20457903f, 0.00274613f, 
    0.08252899f, 0.03228586f, -0.23896042f, -0.13033378f, -0.22606348f, -0.39903352f, -0.28017578f, -0.47744426f, 
    -0.28083944f, 0.23582345f, -0.27977154f, 0.37695879f, 0.16158773f, 0.10206950f, -0.03004813f, -0.23789211f, 
    -0.14602798f, -0.42172995f, -0.14778925f, -0.35583103f, -0.40920919f, -0.15773445f, -0.15462098f, -0.29917607f, 
    0.10479545f, 0.05188687f, -0.01197292f, 0.22734810f, -0.05772978f, -0.35040894f, -0.03965371f, -0.62343055f, 
    0.44626769f, 0.08096003f, 0.22143604f, 0.14337528f, -0.16360994f, 0.17636390f, -0.06340207f, 0.06445585f, 
    -0.03398342f, -0.02767613f, -0.32091737f, -0.19592220f, 0.48094389f, -0.01564669f, -0.02188160f, -0.09455551f, 
    -0.18105924f, -0.15199116f, 0.11662944f, 0.11715966f, 0.20443408f, 0.10961944f, 0.37258905f, 0.11627050f, 
    0.05280202f, -0.06138388f, -0.07521873f, 0.04626759f, 0.03526224f, -0.03694346f, -0.05317824f, -0.04746290f, 
    -0.06683913f, -0.01540887f, 0.03152366f, -0.07273897f, -0.06473207f, 0.02037015f, -0.04638098f, 0.01001443f, 
    -0.02800328f, -0.03025015f, -0.02969738f, -0.00747134f, -0.05418611f, 0.02766153f, -0.01956805f, 0.01814482f, 
    -0.02695695f, 0.02855504f, 0.04399567f, -0.05124783f, -0.03962087f, 0.06025524f, 0.00346012f, -0.06639177f, 
    0.02284073f, -0.05831632f, 0.06428611f, 0.05913339f, -0.06305198f, 0.02768859f, -0.05595381f, 0.00992280f, 
    -0.05105376f, 0.01399677f, -0.06596204f, -0.01361251f, 0.05423505f, -0.06388766f, -0.03301018f, -0.07389417f, 
    0.06283624f, 0.05847590f, 0.01302843f, 0.05905625f, -0.07404386f, 0.02659177f, -0.06463344f, -0.07478960f, 
    0.01675858f, -0.00043634f, -0.04471416f, -0.00863849f, -0.03139066f, -0.03544880f, -0.01170733f, -0.04410282f, 
    -0.04881285f, -0.01176301f, 0.01242183f, 0.05089494f, -0.05188066f, 0.02485494f, -0.04528398f, 0.06144207f, 
    0.03525537f, -0.05270890f, -0.06826716f, 0.03574853f, 0.06211947f, 0.05653360f, -0.04746602f, 0.05681669f, 
    0.04907630f, 0.01604964f, 0.04357812f, -0.07150611f, 0.01147787f, -0.07805448f, -0.00166021f, -0.03802016f, 
    0.05738106f, -0.02465828f, -0.06679125f, -0.01758984f, -0.04119840f, -0.01887758f, 0.02071673f, -0.07728892f, 
    0.02061655f, -0.02959063f, 0.01458037f, 0.03215487f, -0.02344478f, 0.03712077f, 0.04831073f, 0.02025117f, 
    0.03969485f, 0.01585419f, 0.02689993f, 0.02136014f, -0.06912687f, 0.01750173f, 0.00325024f, -0.06568860f, 
    0.02623912f, 0.00364708f, -0.01299303f, -0.07076726f, 0.02275613f, 0.02162675f, -0.06840986f, -0.03161741f, 
    -0.01221083f, -0.01056558f, 0.00251488f, -0.08035605f, -0.05241858f, -0.03766098f, -0.06333925f, -0.07930560f, 
    0.06716633f, 0.00142216f, 0.00087197f, 0.06101701f, 0.01958994f, -0.01013022f, -0.05531095f, -0.05155301f, 
    0.00630148f, -0.00806557f, 0.05422110f, 0.05673559f, -0.05341981f, 0.04413028f, -0.02865417f, -0.05617085f, 
    -0.03141872f, -0.07926148f, -0.04093055f, -0.07016823f, -0.01516417f, -0.04753055f, -0.06487751f, -0.06748059f, 
    -0.06644719f, -0.07830951f, 0.04072887f, 0.02321276f, 0.06114553f, -0.01164459f, 0.02829604f, 0.02057211f, 
    -0.01049648f, 0.05060951f, -0.05557520f, -0.03697097f, 0.06030730f, 0.04868731f, -0.06426388f, 0.03266808f, 
    0.03002642f, -0.00463501f, -0.07234314f, 0.02764246f, -0.04300689f, -0.02178405f, 0.05475150f, 0.03987258f, 
    -0.00046537f, 0.01875949f, 0.00423467f, -0.07513931f, -0.02795400f, -0.00812994f, -0.03233837f, -0.06984390f, 
    -0.00471631f, 0.04156070f, 0.00764946f, 0.03783553f, -0.08139305f, 0.00537508f, 0.05266134f, 0.02713180f, 
    0.58598453f, -0.41802868f, 0.04592850f, 0.07331761f, 0.05851279f, 0.14100859f, 0.28228375f, 0.16225508f, 
    0.02076937f, -0.00848765f, 0.12424881f, -0.07632075f, -0.13062450f, 0.11522197f, -0.08718510f, 0.09123708f, 
    -0.01590385f, 0.07858291f, 0.04760660f, 0.10391010f, 0.10090720f, -0.05003615f, 0.13229853f, 0.05871752f, 
    -0.28457180f, -0.12588528f, -0.21221076f, 0.02070394f, 0.17836669f, 0.26129538f, 0.08249035f, -0.22491264f, 
    -0.05371049f, 0.34596938f, 0.17381825f, 0.11384118f, -0.37051201f, -0.34074020f, 0.19622612f, -0.00057219f, 
    0.04447339f, 0.11564772f, -0.06322495f, 0.01438813f, -0.05491724f, 0.00117031f, -0.02023518f, 0.03225051f, 
    -0.33280799f, 0.26885480f, -0.23478137f, 0.17176692f, 0.17386115f, -0.07790060f, -0.03350757f, 0.09244583f, 
    0.05497428f, 0.04142991f, -0.04143440f, 0.02018710f, -0.51060230f, -0.76303107f, -0.65762502f, -0.15615526f, 
    0.19132641f, 0.12148698f, 0.12117941f, 0.04783307f, -0.09547050f, 0.01329453f, -0.03489259f, 0.18729347f, 
    -0.56046039f, -0.20166253f, -0.30394399f, -0.55000585f, -0.23013686f, -0.38153732f, -0.08920570f, -0.28774321f, 
    -0.15121634f, -0.09595340f, 0.00263808f, -0.11943050f, 0.04888887f, 0.05814303f, -0.04809129f, 0.11947043f, 
    0.06495564f, 0.02521789f, 0.04411469f, 0.14342296f, -0.07896589f, -0.06618333f, -0.03682067f, -0.10270175f, 
    0.29166898f, 0.05897026f, -0.03971143f, 0.07051535f, -0.13735573f, -0.14925927f, -0.03995082f, -0.01056457f, 
    -0.12535380f, 0.04259364f, -0.12547684f, -0.08041830f, 0.15126204f, -0.14197175f, 0.24636160f, -0.07772491f, 
    -0.06069852f, 0.05077156f, 0.03127735f, 0.11236586f, -0.01297218f, -0.15829477f, 0.07394504f, 0.06496413f, 
    0.01590488f, -0.21972951f, -0.16962351f, -0.11852444f, 0.14050874f, 0.01058562f, -0.05833316f, 0.11349504f, 
    0.25054458f, -0.20856668f, -0.25884944f, -0.01795751f, 0.54585177f, 0.04113870f, 0.23411813f, 0.01005741f, 
    -0.03228994f, -0.21941294f, -0.02258221f, -0.03754625f, 0.00555017f, -0.09887720f, -0.07430911f, 0.00172121f, 
    -0.07625769f, -0.42878857f, 0.62223113f, -0.41276559f, 0.05778687f, 0.20168857f, 0.27475181f, 0.01016446f, 
    -0.07653917f, 0.00776753f, 0.09631540f, 0.05453366f, 0.38084185f, 0.05797743f, -0.02789690f, -0.19952472f, 
    0.24447082f, 0.35216576f, -0.10667977f, 0.05772170f, -0.20500951f, -0.04738647f, 0.00055549f, 0.01204090f, 
    -0.66580218f, 0.53753120f, 0.33954254f, -0.07741850f, 0.03933379f, 0.22218107f, -0.09096179f, 0.13139912f, 
    -0.23647018f, -0.02408242f, -0.04060914f, 0.03983260f, -0.02997147f, 0.18021560f, -0.06703766f, -0.06510208f, 
    -0.16627203f, -0.00378451f, -0.10081847f, 0.18912162f, -0.16648252f, 0.23814349f, 0.11643268f, -0.03020278f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.01155126f, 0.15723671f, -0.14004038f, 0.03938986f, 0.12562411f, -0.26687571f, 0.26214945f, 0.15394349f, 
    0.17675932f, 0.22771969f, -0.16759090f, 0.00582747f, -0.06024141f, 0.15823480f, 0.22529183f, 0.07346456f, 
    0.26579866f, 0.19084622f, 0.13791572f, 0.13584039f, 0.00265545f, 0.01725755f, 0.05982441f, -0.03227325f, 
    -0.07627189f, -0.02749288f, 0.15118690f, 0.06088935f, 0.06339515f, -0.13226247f, -0.02818736f, 0.28558120f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.09016670f, -0.12161245f, 0.35494655f, -0.36698899f, -0.60210854f, 0.37238061f, -0.80268216f, -0.13193069f, 
    -0.40433136f, -0.14733882f, -0.19471213f, -0.15387428f, 0.25176352f, 0.17369181f, -0.27923021f, -0.53748286f, 
    -0.33614403f, 0.28861722f, 0.04939592f, -0.50020510f, 0.39759302f, 0.25543970f, -0.06553852f, -0.12660381f, 
    -0.00841318f, 0.16342299f, -0.74230170f, 0.33059689f, 0.01096147f, 0.14464356f, 0.13845694f, -0.27133340f, 
    0.13706501f, 0.47322205f, -0.25322187f, -0.70792687f, -0.66276932f, 0.21566956f, -0.29895681f, 0.40135112f, 
    0.21521907f, 0.11539330f, -0.21683124f, -0.02066155f, 0.05052243f, 0.15529653f, 0.16567308f, 0.06500699f, 
    -0.01101432f, 0.30006588f, -0.00464706f, 0.26172343f, -0.51871544f, 0.05445438f, -0.13528192f, 0.12598304f, 
    0.00051218f, -0.03557964f, -0.24162890f, 0.23896900f, 0.15346479f, -0.92863238f, -0.12737422f, 0.64923614f, 
    0.17023648f, 0.13630532f, -0.14405455f, -0.43963981f, 0.43797976f, 0.17095681f, 0.41363132f, -0.33934259f, 
    0.35286921f, 0.35942277f, -0.66706365f, 0.01484434f, -0.68551058f, 0.42580715f, 0.04607161f, -0.34645233f, 
    0.22477216f, -0.24519692f, -0.49101385f, 0.05603850f, -0.61327398f, -0.30984044f, 0.11887342f, -0.03567422f, 
    -0.03314548f, -0.07214180f, 0.06555104f, 0.34302223f, -0.08239140f, 0.05399322f, 0.02008593f, -0.28568897f, 
    -0.10076668f, 0.19901454f, 0.22418751f, -0.12239824f, 0.15191776f, 0.23961407f, -0.00074480f, -0.46917817f, 
    0.23472883f, -0.88852137f, 0.37182653f, 0.05031192f, 0.20891415f, -0.04510813f, -0.04939583f, 0.35135293f, 
    0.07605351f, -0.90493953f, -0.21441965f, -0.29762310f, -0.04073590f, -0.26576766f, -0.05256467f, -0.15551960f, 
    0.08489296f, -0.14585806f, 0.01064058f, 0.12156557f, 0.07920220f, 0.02951990f, -0.17385474f, -0.21215306f, 
    -0.14567026f, -0.89653456f, 0.02621567f, 0.40040964f, -0.45423767f, 0.10460267f, 0.05929582f, -0.20747906f, 
    0.18019906f, 0.00721925f, -0.38638121f, 0.03023959f, 0.03731797f, -0.43574607f, -0.10995850f, 0.04434419f, 
    0.08995128f, -0.27397993f, 0.23350483f, 0.37332708f, -0.00201821f, 0.05167278f, 0.11597484f, -0.07237751f, 
    0.01204661f, -0.05732358f, -0.10262737f, -0.06297797f, -0.02254216f, 0.49585623f, 0.06418748f, -0.58658528f, 
    0.14200915f, -0.34616944f, -0.90612739f, 0.16820475f, 0.21604683f, -0.17976677f, -0.38661179f, 0.52621120f, 
    -0.03169965f, -0.10757500f, -0.24892464f, -0.16037057f, 0.22520430f, 0.17647769f, 0.24135542f, -0.77244729f, 
    0.09162603f, -0.06263618f, 0.42486715f, -0.09780454f, 0.35902300f, 0.30553547f, -0.05380843f, 0.05492343f, 
    0.11379537f, -0.14855321f, 0.22714788f, -0.11480489f, 0.06526762f, -0.24652228f, -0.04178946f, -0.28814948f, 
    0.05126531f, -0.21856073f, 0.40891239f, 0.57990223f, 0.01085754f, -0.93271762f, 0.14513604f, -0.47593775f, 
    -0.09624797f, 0.36900240f, -0.56318444f, -0.02199033f, -1.01802349f, 0.49455836f, -0.11587822f, 0.21823236f, 
    -0.04558903f, -0.04147619f, 0.04437398f, -0.62451243f, -0.07621971f, 0.05497881f, 0.00316227f, -0.11216380f, 
    0.04566692f, 0.08160428f, 0.18195891f, -0.76924336f, -0.02169734f, 0.11343883f, 0.07004108f, 0.60624611f, 
    -0.13868661f, 0.16508554f, 0.21942332f, -0.45645604f, 0.46651897f, -0.59141642f, -0.77219397f, 0.06933842f, 
    -0.60046816f, 0.00985638f, 0.54469353f, 0.13335530f, 0.15469475f, -0.40667081f, -0.12312244f, 0.34857133f, 
    -0.53317684f, -0.10991784f, -0.45099664f, 0.17054313f, -0.56763846f, 0.33240750f, -0.00869476f, 0.15761043f, 
    0.13315970f, 0.08509995f, 0.25394922f, -0.07091457f, 0.14104882f, 0.31558964f, -0.17518115f, -0.28045633f, 
    0.01042233f, 0.31756231f, -0.62390536f, -0.10323532f, 0.30628467f, -0.86044711f, 0.33430347f, -0.72977149f, 
    -0.11409963f, -0.34149766f, 0.39571416f, -0.10308696f, 0.49960867f, 0.36978289f, 0.29591927f, -0.15385230f, 
    0.18817705f, 0.24547742f, -0.54755843f, -0.05116879f, -0.31588149f, -0.00436142f, -0.10328446f, -0.05640192f, 
    -0.10412627f, 0.16763644f, -0.25901669f, -0.77806252f, -0.03128190f, -0.51917011f, 0.10148028f, -0.28950444f, 
    -0.05162523f, 0.01580566f, 0.12137616f, 0.01027171f, 0.16997783f, -0.30835781f, 0.08992416f, 0.41320390f, 
    -0.70562434f, 0.47637135f, -1.00867438f, -0.08090556f, -0.16357003f, -0.72484881f, -0.55223978f, 0.32726929f, 
    0.23607841f, 0.27892208f, 0.19345184f, -0.25648087f, 0.05727912f, -0.41755408f, -0.13787511f, -0.00974382f, 
    -0.05792344f, 0.10339714f, 0.12371874f, 0.27075848f, -0.08302227f, 0.25058988f, -0.09751426f, -0.50227976f, 
    -0.00931557f, -0.11854690f, -0.20848189f, 0.22929770f, -0.10085844f, 0.13028166f, 0.43702736f, 0.28825262f, 
    0.33359855f, -0.04347906f, 0.61001700f, -0.04758829f, -0.05831082f, 0.30728468f, -0.53834748f, -0.11330728f, 
    0.25920290f, 0.02841528f, -0.46915483f, 0.26955119f, 0.21197912f, -0.74006104f, 0.01255733f, 0.08461166f, 
    -0.04844758f, 0.02979566f, -0.50169104f, -0.54193920f, -0.14856723f, -0.68640023f, -0.02756737f, 0.14299473f, 
    -0.07528434f, 0.12376098f, 0.25923628f, -0.01872032f, -0.08606023f, 0.00663734f, 0.05132731f, -0.58482879f, 
    0.34104517f, -0.46978688f, 0.31730190f, 0.05272475f, -0.46999630f, -1.05726433f, 0.43191865f, 0.11264978f, 
    0.14642040f, 0.30634460f, 0.16584133f, -0.45356166f, 0.54691595f, -0.58980620f, 0.14627920f, -0.16083743f, 
    -0.05956303f, 0.09041233f, 0.35357460f, -0.55623871f, -0.03263737f, -0.57273203f, 0.00031740f, 0.37270251f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.01836843f, 0.24324112f, 0.23882905f, -0.16116166f, -0.10227277f, -0.08482326f, 0.30138794f, -0.32294443f, 
    0.12758547f, -0.08807216f, -0.33747059f, 0.14104019f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
