#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.42094916f, 0.49820310f, 0.70017284f, 0.27712068f, -0.46926722f, 0.24872787f, 0.18078046f, 0.23716722f, 
    0.04734806f, -0.59180248f, -0.55122006f, 0.26428056f, 0.52004856f, 0.05032802f, 0.80153376f, 0.20039751f, 
    -0.17590992f, 0.06902890f, -0.40072903f, -0.54138756f, -0.13355435f, -0.13892806f, 0.59281969f, -0.09815969f, 
    0.41063148f, 0.24479523f, 0.53877527f, -0.44777358f, -0.47063908f, -0.49947655f, 0.33905315f, -0.45292887f, 
    -0.41827407f, -0.34044689f, -0.26060265f, -0.04978035f, 0.69690257f, 0.84237170f, -0.19111784f, 0.25488925f, 
    0.36253083f, -0.15348704f, 0.52910936f, 0.24268344f, -0.02094757f, 0.02302351f, 0.77704126f, -0.53783464f, 
    0.40894565f, -0.29902202f, -0.67562312f, 0.01517246f, 0.06258203f, -0.13144982f, 0.77392209f, -0.34166083f, 
    0.13494724f, 0.84466010f, 0.46961948f, 0.05144206f, -0.12051251f, 0.11820246f, -0.13798864f, 0.67890882f, 
    0.70807433f, 0.58677340f, -0.17464356f, -0.31634533f, 0.06733000f, -0.28105131f, -0.30842531f, -0.04387717f, 
    -0.87157345f, 0.71767294f, 0.33486566f, -0.03522865f, -0.49993557f, -0.49631828f, 0.12828076f, -0.00791069f, 
    0.24624924f, -0.54246449f, 0.51485175f, 0.81454122f, 0.55930734f, 0.52053124f, 0.24644254f, -0.08931289f, 
    -0.16880500f, 0.03498632f, 0.48602858f, -0.58668476f, 0.41444603f, 0.35089597f, -0.46087086f, 0.52182972f, 
    0.17432885f, -0.18357678f, -0.17508791f, -0.82230359f, -0.87414569f, -0.90334117f, 0.12193621f, 0.04555882f, 
    0.32173008f, 0.10748137f, 0.05501759f, 0.06361979f, 0.76278245f, -0.74660033f, -0.60922843f, -0.64256173f, 
    -0.11378274f, 0.16750211f, -0.09977935f, -0.16748284f, 0.43596178f, -0.15083443f, -0.79723269f, -0.15238334f, 
    0.36762574f, 0.06840079f, 0.21218564f, -0.42970392f, -0.16357282f, -0.39294499f, 0.48841375f, -0.12748447f, 
    0.33514315f, -0.64613920f, -0.77348113f, 0.46599481f, 0.17046113f, -0.02077908f, -0.11040089f, 0.81987029f, 
    0.18183891f, 0.23776184f, -0.90190434f, 0.45058975f, -0.52557617f, -0.03002792f, -0.04791576f, 0.14574769f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.04513717f, 0.03715007f, -0.10492183f, -0.51268363f, -0.14624450f, -0.15198608f, -0.24456920f, 0.21748959f, 
    0.03235297f, 0.17046039f, 0.18220788f, -0.01715799f, -0.24436146f, 0.02908547f, -0.12666167f, 0.17392468f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.31801426f, 0.10526421f, 0.08997845f, -0.05700128f, 0.11514718f, -0.13254489f, -0.15116657f, 0.06311470f, 
    0.14665927f, 0.15790458f, -0.02493067f, 0.18339010f, 0.19971849f, -0.01188994f, -0.08772549f, -0.02983657f, 
    -0.03244618f, 0.05597521f, 0.16890386f, 0.19411747f, 0.28902367f, 0.04300420f, -0.15014471f, 0.07314356f, 
    0.09974132f, 0.27504089f, 0.07488190f, 0.45908138f, 0.26040113f, 0.17880227f, -0.11172489f, -0.00475957f, 
    0.32110682f, 0.01386565f, 0.13377890f, -0.02323423f, -0.50869262f, -0.29865909f, -0.18663773f, -0.18120630f, 
    -0.20921102f, -0.28127772f, 0.05565573f, -0.01328660f, -0.02140805f, -0.03423369f, 0.03689413f, 0.06337279f, 
    -0.17520726f, 0.00461006f, 0.08071349f, -0.05215942f, -0.05094162f, -0.35325143f, 0.28116491f, 0.06060986f, 
    -0.09483941f, 0.08741674f, 0.02035598f, -0.06108256f, 0.18514813f, 0.15480582f, 0.10907245f, -0.26500031f, 
    -0.27242133f, 0.14721306f, -0.10390588f, -0.11641310f, 0.03778472f, -0.08266819f, -0.10141264f, 0.24948232f, 
    -0.28857535f, -0.13975997f, 0.00500226f, 0.08247818f, 0.06866330f, 0.07231061f, 0.01777272f, -0.10435376f, 
    -0.03987384f, -0.23655851f, 0.20226753f, 0.08935420f, 0.09417485f, -0.05637388f, -0.13787903f, 0.16709240f, 
    0.18017466f, 0.10198037f, -0.01253989f, -0.00801915f, -0.04609373f, 0.19047563f, 0.15493733f, -0.14641210f, 
    0.07477854f, 0.07933654f, 0.05605200f, 0.36644399f, 0.32645881f, 0.19284320f, 0.10813994f, 0.00664351f, 
    0.12276180f, 0.10492197f, 0.20822404f, 0.16144231f, -0.17488550f, 0.11263300f, -0.03196919f, 0.13375510f, 
    -0.02182123f, -0.12657660f, -0.23055375f, -0.10898554f, -0.22685741f, 0.18865700f, -0.13289832f, 0.06185570f, 
    0.17275424f, 0.29580250f, -0.15323748f, 0.13254221f, 0.07347346f, -0.30391198f, 0.01283968f, -0.10388944f, 
    -0.06669433f, -0.08604658f, -0.05352363f, -0.00164323f, -0.02695657f, 0.07121690f, 0.02393226f, -0.20639941f, 
    -0.11077335f, 0.16307107f, -0.12882589f, -0.06497546f, 0.08511670f, 0.00917029f, -0.07235090f, 0.14169520f, 
    0.23885988f, 0.33647686f, 0.12531359f, -0.03783480f, 0.00380527f, -0.00972960f, 0.08482863f, 0.10104246f, 
    -0.11432400f, -0.06690188f, 0.20275511f, 0.01522299f, 0.18594441f, 0.25368872f, 0.03273796f, -0.00686175f, 
    -0.12592371f, -0.13642704f, -0.06988788f, 0.00382113f, -0.01298492f, 0.04989804f, 0.07176289f, -0.02426322f, 
    0.02377712f, -0.12831356f, -0.22475033f, -0.53322899f, -0.04062041f, 0.04479454f, 0.11631195f, 0.19643189f, 
    -0.03870480f, 0.12458254f, -0.06543520f, -0.11646870f, 0.17144495f, 0.40021133f, 0.06902197f, -0.02569766f, 
    -0.07319642f, 0.02342339f, -0.01379371f, 0.11507227f, 0.11973676f, -0.06597172f, -0.28923339f, 0.13707946f, 
    0.08303131f, -0.10354964f, -0.13618596f, -0.05053931f, -0.00634780f, -0.10849448f, 0.24585648f, -0.26957971f, 
    -0.40101647f, -0.11540384f, -0.02800990f, 0.05084429f, -0.01752319f, 0.13121311f, 0.12342919f, 0.25428486f, 
    0.28152731f, 0.02544522f, -0.31623679f, -0.12528966f, -0.07340577f, 0.10190308f, 0.24940117f, 0.07921748f, 
    -0.03157467f, -0.15210982f, -0.07847763f, -0.01299222f, -0.17714730f, -0.04222987f, -0.11960986f, 0.00201462f, 
    0.01566760f, 0.12320412f, 0.02829618f, 0.39831874f, 0.00918905f, -0.03597606f, 0.08106229f, 0.02613352f, 
    -0.15056090f, -0.02913985f, 0.27814761f, -0.19892350f, 0.12968498f, -0.08698265f, 0.08261556f, 0.02011962f, 
    -0.05031069f, -0.05379763f, 0.06455570f, -0.15683703f, -0.03931291f, -0.35915819f, 0.00661808f, 0.07335734f, 
    0.05866886f, -0.10034523f, 0.09121066f, 0.03750182f, -0.48627159f, -0.05187179f, -0.10046936f, 0.08181571f, 
    -0.00272096f, -0.11439916f, -0.20479487f, 0.11612722f, -0.08298637f, 0.43367922f, 0.02432283f, -0.22157244f, 
    -0.05118381f, -0.06178170f, 0.06033523f, 0.22186995f, -0.02233604f, -0.02668433f, 0.25275990f, 0.02417461f, 
    0.01901871f, -0.11829948f, -0.10683393f, 0.03876102f, 0.08515716f, 0.18329260f, 0.21307959f, 0.05625987f, 
    -0.17104807f, -0.02429344f, -0.16122355f, 0.16357772f, 0.09174071f, -0.07098963f, -0.02862460f, 0.08308338f, 
    0.03277602f, 0.09023852f, -0.25392675f, -0.07335304f, 0.18885651f, -0.00015468f, 0.13609193f, -0.08761776f, 
    -0.10744927f, -0.09352873f, 0.08614839f, 0.13719964f, -0.07889402f, -0.09497802f, 0.12233157f, 0.09079473f, 
    -0.01045174f, 0.08583262f, 0.07627865f, 0.01429843f, 0.13631834f, 0.02783861f, 0.10444274f, -0.05007609f, 
    0.02424365f, -0.00347252f, 0.00814509f, 0.23588118f, 0.42045745f, 0.11677296f, 0.09050771f, 0.04964601f, 
    0.21750923f, -0.18577677f, -0.04486325f, 0.06596844f, 0.03639491f, 0.43493912f, 0.17446163f, -0.04694886f, 
    -0.10223823f, -0.08708963f, 0.02261024f, 0.03204514f, 0.13963363f, -0.18295085f, -0.11810376f, 0.15108828f, 
    0.03843557f, -0.10310890f, -0.19793375f, -0.16061592f, 0.13741490f, 0.01449349f, -0.26599711f, -0.04676842f, 
    0.00385546f, 0.19904335f, -0.05041030f, 0.16219868f, 0.08940582f, -0.08055214f, 0.13340817f, -0.24749207f, 
    -0.01569914f, -0.12927982f, -0.20128950f, -0.02062416f, 0.07053518f, 0.04752067f, -0.05243849f, 0.07759569f, 
    0.03865545f, -0.09769440f, -0.00777708f, 0.16254622f, 0.03887726f, -0.18187436f, -0.12742361f, -0.10745476f, 
    -0.14568488f, 0.50058365f, -0.05346598f, 0.09742901f, -0.12704073f, 0.16733380f, -0.24356292f, 0.08629044f, 
    -0.01596427f, 0.20503484f, -0.15772855f, -0.12065852f, -0.49122790f, 0.12122888f, -0.08059832f, -0.08819180f, 
    -0.19881156f, -0.19865419f, 0.00877347f, 0.18825030f, 0.03076728f, 0.19186887f, 0.03793418f, 0.01562539f, 
    0.05043229f, 0.19796230f, 0.15069978f, 0.00627711f, 0.63891798f, 0.19848642f, 0.04130664f, -0.05944214f, 
    0.02103683f, 0.00430323f, -0.06521855f, -0.02966542f, -0.13257501f, -0.05245399f, 0.11559366f, 0.17643912f, 
    0.03247737f, 0.21528850f, -0.06835387f, -0.15404001f, 0.02606504f, -0.18664038f, -0.08511321f, 0.05423031f, 
    -0.21974853f, -0.17251186f, 0.07927662f, -0.08941329f, -0.15419881f, -0.05373579f, 0.15655707f, -0.08902650f, 
    0.02319026f, -0.17891403f, 0.09448441f, -0.12014339f, 0.08596206f, -0.30567175f, -0.02650532f, -0.17388852f, 
    -0.31952554f, -0.03843000f, 0.06097707f, 0.02806391f, -0.20082003f, -0.02941981f, -0.01584580f, -0.07771402f, 
    -0.16462123f, 0.27205020f, -0.00403843f, 0.09919459f, -0.13811864f, 0.03606776f, 0.07787891f, -0.06822746f, 
    0.15485108f, -0.06058891f, 0.01241392f, 0.20595463f, 0.12490725f, -0.07707035f, 0.06837437f, -0.20176747f, 
    -0.16585703f, 0.00888992f, 0.02727789f, 0.00369652f, 0.11984762f, 0.22349222f, 0.25354743f, -0.08092472f, 
    -0.17450383f, -0.01295153f, 0.01108101f, 0.06164260f, 0.02856950f, 0.02519355f, 0.04031117f, 0.12672144f, 
    -0.00719569f, 0.01227647f, -0.26262289f, -0.19133849f, -0.08009829f, 0.37120333f, -0.10750628f, -0.11713441f, 
    -0.22570328f, -0.04197334f, -0.10753522f, 0.00239752f, 0.15931189f, 0.14954193f, -0.13168354f, -0.05345801f, 
    0.02564578f, 0.01634498f, 0.04944992f, -0.13332611f, 0.07842548f, 0.18994236f, -0.04482000f, -0.10113922f, 
    -0.19245975f, 0.04703140f, 0.17892386f, -0.15958691f, -0.05858867f, 0.20807692f, 0.13812546f, -0.00698795f, 
    -0.18918419f, -0.07649437f, 0.27716339f, 0.20969237f, -0.20547564f, -0.07681616f, 0.18375461f, -0.14548467f, 
    0.02934059f, -0.24876319f, 0.10989191f, 0.26618317f, -0.04236518f, -0.02866321f, 0.19600680f, -0.16841622f, 
    0.00659170f, -0.16302529f, 0.04542433f, -0.20043263f, 0.03500212f, 0.03858225f, 0.00104526f, 0.00625952f, 
    0.01665509f, -0.07916234f, 0.06020209f, 0.00686092f, 0.06762707f, 0.16799861f, -0.07819410f, 0.03642568f, 
    -0.01346544f, 0.05045904f, 0.21491180f, 0.12200389f, 0.12415879f, 0.11096637f, 0.00775613f, -0.20174541f, 
    0.28807300f, 0.01230277f, 0.11465252f, 0.09147830f, 0.11754326f, 0.05694597f, 0.18731016f, 0.15630841f, 
    -0.11830831f, 0.16504106f, -0.10232762f, -0.02740081f, 0.08911986f, 0.16281110f, -0.08400890f, -0.31281453f, 
    -0.26028845f, 0.07153270f, 0.04289551f, 0.12403978f, 0.02550401f, -0.12558240f, -0.42698973f, -0.11812181f, 
    -0.14326409f, 0.12908001f, 0.00255723f, -0.18414357f, -0.05925648f, -0.10996576f, 0.08392242f, 0.16113421f, 
    -0.06752100f, -0.03435930f, -0.05079397f, -0.04857641f, -0.02717197f, 0.02924132f, -0.02658006f, -0.01017676f, 
    -0.01499643f, -0.04977560f, -0.08972185f, -0.09281807f, -0.01384029f, -0.05187117f, -0.09265678f, -0.05336073f, 
    -0.06230085f, -0.08098942f, -0.01047763f, -0.07681562f, 0.04149557f, 0.03691796f, -0.00338536f, -0.04541604f, 
    -0.08551473f, 0.06481646f, 0.03423618f, 0.00879888f, -0.08301960f, 0.03824739f, -0.06314011f, -0.08010037f, 
    -0.06253445f, 0.04409394f, 0.06506781f, 0.03740766f, -0.00801636f, -0.00055011f, -0.06786516f, 0.01980011f, 
    0.01342878f, -0.01239200f, 0.02780945f, -0.07215237f, -0.06675347f, 0.01102999f, -0.09323178f, 0.00717376f, 
    0.06300445f, -0.05765147f, 0.02070609f, -0.07261661f, 0.06343652f, 0.02331902f, -0.02475762f, -0.04962697f, 
    0.00363964f, 0.01354367f, -0.00505518f, 0.03981623f, -0.08600711f, -0.06067245f, 0.01664208f, -0.01533810f, 
    0.03358474f, -0.01203538f, -0.04043586f, -0.00480546f, -0.05802751f, -0.00336833f, -0.03832906f, 0.05727290f, 
    -0.02281429f, -0.02413515f, 0.01418631f, -0.03051318f, -0.00086747f, -0.03103721f, -0.08291090f, -0.05094657f, 
    -0.00741430f, -0.01727858f, -0.07061323f, -0.09144418f, -0.05066659f, 0.01590786f, -0.05193677f, 0.05622470f, 
    0.01386547f, -0.06081444f, 0.04697598f, -0.01258197f, -0.05297364f, 0.03660097f, -0.07128728f, -0.00170606f, 
    -0.07931382f, 0.01826965f, 0.01494112f, -0.03037423f, -0.01025041f, -0.03330161f, -0.04609415f, -0.01844721f, 
    -0.09341139f, -0.09646738f, -0.05002803f, 0.04010981f, -0.05403977f, -0.04749746f, -0.07284736f, -0.05525104f, 
    -0.00308564f, 0.06169786f, 0.06557821f, -0.03464156f, -0.07862412f, 0.06291719f, -0.07667383f, -0.01983822f, 
    -0.01097012f, -0.03165718f, -0.09963535f, -0.01966556f, -0.07622854f, -0.02767274f, -0.04837047f, -0.08548996f, 
    0.01475869f, -0.08136159f, -0.07498398f, -0.05083352f, -0.02261817f, 0.05810185f, 0.04662142f, 0.01856066f, 
    0.01542216f, -0.03385882f, -0.04496019f, 0.06381605f, -0.03022460f, -0.05729758f, 0.03402514f, -0.07708897f, 
    0.04722349f, 0.00626109f, -0.11435206f, 0.07765727f, -0.21167122f, -0.09419454f, 0.06038292f, 0.03588612f, 
    0.12207271f, -0.10423020f, 0.24909450f, -0.15937610f, -0.17763199f, -0.00339365f, -0.02576788f, -0.02196619f, 
    0.06994234f, -0.00005130f, -0.23960289f, 0.04262689f, -0.27160594f, -0.21687001f, -0.05924216f, 0.06792182f, 
    0.07080138f, -0.03958965f, -0.18066892f, 0.14080507f, -0.20372517f, -0.07246950f, 0.03438250f, 0.02778970f, 
    0.13386041f, 0.07300176f, 0.05576937f, -0.06441449f, 0.47151756f, 0.06931175f, -0.06600182f, -0.12869921f, 
    -0.04147892f, 0.04685927f, -0.07292803f, -0.00899328f, 0.04016562f, -0.18558334f, -0.05968649f, -0.37745702f, 
    0.19437090f, 0.12280636f, 0.15103331f, 0.11995687f, 0.02677113f, -0.30424169f, -0.04740357f, -0.08162436f, 
    -0.01830090f, 0.02571813f, -0.00155604f, -0.28501034f, 0.00501586f, 0.11460983f, 0.25413838f, 0.02043976f, 
    0.02984794f, -0.20694220f, 0.09000115f, -0.02030704f, 0.05650707f, -0.08763506f, -0.06899966f, -0.12835129f, 
    -0.05978182f, -0.39410493f, -0.02161118f, 0.16205516f, 0.07849503f, 0.19511262f, 0.13819024f, -0.17624509f, 
    -0.18166412f, -0.08482770f, -0.00068982f, -0.09316017f, 0.03923224f, -0.05574986f, -0.35216910f, -0.01838095f, 
    0.10394698f, 0.19617090f, -0.28851718f, -0.07457213f, 0.29430589f, 0.01971442f, 0.09586629f, 0.05457735f, 
    0.12190720f, 0.06405645f, 0.01204629f, -0.00024155f, 0.03065014f, -0.16900077f, -0.08894878f, -0.03986157f, 
    0.00770997f, -0.08842984f, 0.11676139f, -0.04971380f, -0.42391449f, 0.01021787f, 0.10805027f, 0.45974562f, 
    -0.05930619f, 0.16509622f, 0.04920460f, 0.03297587f, -0.12044130f, 0.13140872f, 0.05479661f, -0.13888960f, 
    -0.08982448f, 0.07989720f, -0.14528286f, 0.00679737f, -0.12896290f, -0.07656866f, 0.34718445f, 0.29079100f, 
    -0.13100775f, 0.12139863f, -0.00866165f, 0.21668342f, -0.06515243f, 0.04064755f, 0.03492993f, -0.01818041f, 
    0.14225101f, 0.01984635f, 0.23927510f, 0.06186675f, 0.05601522f, -0.01118257f, 0.09845647f, 0.19701849f, 
    -0.18033445f, 0.12479381f, 0.25430304f, 0.00809708f, 0.13303238f, 0.07357933f, 0.10480261f, 0.09248918f, 
    -0.01708334f, -0.18319976f, -0.61250454f, -0.29256251f, 0.09745443f, -0.04638217f, 0.12069278f, -0.01888707f, 
    -0.03593265f, 0.00630914f, -0.24369672f, -0.33137411f, -0.15499321f, 0.00892153f, 0.10936885f, 0.07412104f, 
    -0.02271875f, -0.15597212f, 0.03618175f, -0.16924213f, 0.22663693f, -0.00407246f, 0.18514289f, -0.01142833f, 
    -0.03542156f, 0.20045210f, 0.18998656f, -0.02556327f, -0.34133616f, 0.00798481f, -0.10560738f, -0.09947070f, 
    -0.11405459f, -0.10632280f, 0.09211349f, -0.04210576f, -0.10700271f, 0.03551260f, -0.10657406f, 0.34444281f, 
    0.04662388f, 0.12753893f, 0.07365180f, 0.09485227f, 0.15272565f, 0.16450000f, -0.30971479f, -0.25131536f, 
    0.08218221f, -0.05125983f, 0.08473420f, -0.00781273f, -0.08473506f, 0.12937298f, -0.04967782f, -0.07478189f, 
    0.22300369f, 0.46399757f, 0.22769088f, 0.10562786f, -0.01457594f, 0.05824637f, 0.00498832f, 0.07361349f, 
    0.27035096f, -0.16168244f, -0.07410637f, 0.01634862f, 0.06133092f, 0.08387919f, 0.12086710f, 0.02692545f, 
    0.00928140f, 0.50431472f, -0.06645439f, -0.16756400f, 0.07073782f, 0.07242706f, 0.06950832f, 0.00113823f, 
    -0.02331700f, -0.07892746f, -0.00685995f, 0.00835573f, 0.01091653f, 0.06059804f, -0.05373326f, -0.07588651f, 
    -0.03278518f, -0.13205940f, 0.13500127f, -0.45606720f, -0.02822411f, 0.05996828f, 0.14091979f, 0.12113769f, 
    -0.02085795f, -0.12355790f, 0.10310859f, 0.01565173f, -0.20468147f, -0.44171330f, -0.44045141f, -0.11101139f, 
    -0.13139211f, 0.02833787f, 0.01520920f, 0.01675660f, -0.07932427f, 0.05246571f, 0.02892257f, -0.23806562f, 
    -0.08511189f, -0.09431186f, 0.03502575f, 0.03655278f, -0.08365376f, -0.00254531f, -0.12596245f, 0.06727993f, 
    0.15267652f, -0.26308969f, 0.05421130f, -0.07385740f, -0.04997009f, 0.09073753f, -0.06144245f, 0.07157194f, 
    0.36900392f, 0.05602250f, -0.09245659f, 0.15549524f, 0.20392279f, -0.14600641f, -0.03635881f, -0.01824532f, 
    -0.12110549f, 0.29182914f, -0.05461809f, 0.09964181f, 0.17912452f, -0.02548856f, 0.10609309f, -0.08913959f, 
    -0.12401030f, 0.14368106f, -0.11348223f, 0.09108832f, -0.11316302f, 0.02428419f, -0.18055591f, -0.08796657f, 
    -0.10054896f, -0.08959418f, -0.08845417f, -0.31073096f, 0.26177672f, -0.04202443f, -0.04869683f, 0.04876973f, 
    -0.06991977f, -0.17822002f, 0.08354031f, 0.09529158f, -0.34469882f, 0.09776843f, 0.22572291f, 0.02221315f, 
    -0.10224928f, 0.23327783f, -0.06971481f, 0.24992420f, 0.33763355f, 0.21151152f, -0.13514110f, -0.05574996f, 
    -0.16369706f, -0.19952965f, 0.01023829f, -0.04358732f, 0.05261588f, -0.17004643f, 0.02367524f, -0.62178230f, 
    0.03707122f, -0.00287443f, -0.12194932f, 0.02190351f, -0.04396588f, -0.14740717f, 0.48568454f, -0.02037710f, 
    0.21923737f, -0.04372127f, -0.23939590f, 0.16142297f, 0.05119682f, 0.23305355f, 0.09003808f, -0.20043869f, 
    0.10181782f, 0.22747551f, 0.15054145f, 0.20148304f, -0.02938105f, 0.03897738f, 0.14704078f, -0.04408154f, 
    -0.20412990f, 0.08356930f, -0.20771220f, 0.00472981f, -0.15246747f, 0.03815743f, 0.07083151f, -0.13643616f, 
    -0.04159318f, 0.13984290f, -0.08040420f, -0.10982676f, 0.03523146f, 0.03203389f, 0.04455891f, 0.02291012f, 
    0.08080354f, 0.25940824f, -0.05496228f, 0.18998633f, -0.20033535f, -0.02770365f, 0.04539019f, 0.15789823f, 
    0.07094329f, -0.01457494f, 0.06889664f, -0.40203628f, 0.02930645f, 0.54803556f, 0.01256651f, 0.06328516f, 
    -0.06278883f, -0.14316039f, 0.05857848f, -0.02433899f, 0.32374480f, -0.08893781f, 0.00154966f, -0.13051127f, 
    -0.05271865f, -0.06681810f, -0.04660354f, -0.03586914f, 0.04213567f, -0.18809177f, 0.04207865f, 0.11664540f, 
    0.03926670f, -0.11516613f, -0.00554751f, -0.04297482f, 0.08717487f, 0.03153248f, -0.39336702f, -0.10097326f, 
    -0.16660313f, 0.07886973f, 0.05528475f, -0.06219298f, -0.10484190f, 0.02015912f, 0.03993133f, 0.02400867f, 
    0.24316551f, -0.30498445f, 0.07151935f, 0.00193002f, 0.03497251f, -0.05686007f, -0.00969364f, 0.07643456f, 
    -0.03734533f, 0.10275904f, 0.15185350f, 0.02052689f, -0.04247572f, 0.02713585f, 0.12307752f, 0.01418845f, 
    -0.02832858f, -0.03481134f, 0.26805013f, -0.26148272f, 0.11731683f, 0.09978575f, -0.04760731f, -0.10674345f, 
    -0.12526025f, -0.14171466f, 0.23548587f, -0.21092771f, 0.09122750f, -0.06634317f, 0.05906679f, 0.18736453f, 
    -0.06780967f, -0.06446526f, -0.07269236f, -0.43221706f, 0.07031821f, 0.03827299f, 0.18369241f, 0.17612195f, 
    0.06399050f, 0.02965982f, 0.11799128f, -0.00021859f, 0.04334152f, -0.07420950f, 0.06944265f, -0.11421143f, 
    -0.14889845f, -0.07253795f, -0.01658505f, 0.01123594f, -0.02747893f, -0.09462368f, -0.65307122f, -0.18072818f, 
    0.08251802f, 0.03360504f, -0.03207765f, -0.10702403f, 0.08695316f, -0.03274522f, 0.02006727f, -0.38209319f, 
    0.07935001f, 0.01888230f, -0.14788187f, -0.05170943f, -0.07181285f, 0.02333806f, 0.11807396f, -0.10666958f, 
    0.05824322f, -0.18525887f, -0.06017230f, 0.07991941f, 0.07123520f, 0.01171624f, -0.00635528f, 0.05242074f, 
    0.22774175f, -0.02042764f, -0.38182563f, -0.00145990f, 0.01853075f, 0.07620545f, 0.02792425f, -0.04032069f, 
    0.06265147f, 0.27345476f, 0.28952280f, 0.10084466f, -0.18312743f, 0.22655784f, 0.04410277f, 0.01280272f, 
    0.11077142f, -0.04700818f, -0.48839259f, 0.37936682f, -0.01263791f, 0.00765060f, -0.02627444f, 0.04413866f, 
    0.02322135f, -0.13370459f, -0.10195315f, 0.30416003f, 0.07935628f, 0.19809274f, 0.00049754f, -0.13568626f, 
    -0.03861729f, 0.00315972f, 0.02465413f, 0.20819579f, 0.05553681f, -0.83288294f, -0.11518218f, 0.11004093f, 
    -0.06214452f, 0.10625816f, -0.00474028f, -0.12603079f, -0.06573769f, 0.20305339f, -0.14082886f, 0.08337967f, 
    0.04162983f, 0.15949704f, -0.13911882f, 0.18970902f, 0.14046077f, 0.07280698f, -0.51049936f, -0.16394041f, 
    -0.09172112f, 0.02721435f, -0.05225849f, -0.01452499f, -0.12819830f, 0.05701800f, 0.06230846f, 0.25258270f, 
    0.24773888f, -0.35365304f, 0.09495425f, -0.02206686f, 0.04609535f, 0.06373335f, -0.08159245f, -0.09155888f, 
    0.45472476f, -0.00370678f, 0.14542435f, 0.11694282f, 0.09078995f, 0.04650829f, 0.17757402f, 0.19993600f, 
    0.20693631f, -0.32471937f, -0.06753069f, 0.04505292f, -0.03796824f, 0.14537643f, 0.12884255f, -0.01338203f, 
    0.01415894f, -0.19018543f, -0.37695500f, 0.00025140f, -0.19402361f, -0.14920053f, 0.22357111f, 0.10067137f, 
    -0.14615986f, 0.01891344f, -0.04813368f, 0.09773773f, 0.01867306f, -0.17028359f, -0.33676451f, -0.03770344f, 
    -0.23781510f, 0.08480816f, 0.11727807f, 0.08049665f, 0.25175524f, -0.10038840f, 0.03645149f, 0.11936302f, 
    0.17036986f, -0.08448733f, 0.18353815f, -0.10661349f, 0.04895887f, 0.13125938f, -0.24344631f, 0.02426008f, 
    0.07933440f, 0.00313923f, -0.24660365f, -0.15673876f, -0.04915548f, -0.07578170f, -0.40211338f, -0.27925614f, 
    -0.01095728f, 0.20183024f, 0.09745910f, -0.03354783f, -0.20741422f, -0.02128152f, -0.19754539f, 0.53458768f, 
    0.13646607f, -0.09868487f, 0.01365121f, -0.17437464f, 0.02071963f, 0.05009995f, -0.01520779f, 0.10468315f, 
    0.02996171f, -0.09558536f, 0.08061627f, -0.13217740f, 0.00715890f, 0.02911890f, 0.02552168f, -0.15485661f, 
    0.03237479f, -0.19610786f, -0.00738208f, -0.14380321f, -0.01791960f, 0.19887839f, -0.13792373f, -0.12368742f, 
    0.06706782f, 0.11993188f, -0.06554410f, -0.20857136f, 0.05028328f, 0.05597283f, 0.07412580f, -0.04810541f, 
    0.01382391f, -0.00653215f, -0.11118506f, 0.13713737f, 0.11917616f, -0.22816488f, -0.06743555f, 0.07434792f, 
    -0.17433414f, 0.16334066f, 0.12911442f, 0.01033137f, -0.01352793f, 0.09523156f, -0.34243399f, 0.12564389f, 
    -0.28714442f, -0.12029103f, 0.08170579f, 0.11650316f, 0.07945465f, -0.36380276f, 0.08883402f, -0.10206462f, 
    -0.15693907f, -0.07392107f, -0.17481291f, -0.28217417f, 0.01879673f, -0.09276720f, 0.04530111f, 0.06841480f, 
    0.11916009f, 0.09871899f, -0.04361835f, 0.09423000f, 0.04271692f, -0.04850133f, 0.13646652f, 0.10789707f, 
    0.35920620f, 0.09047425f, 0.07866600f, 0.18142597f, 0.06324419f, 0.03509587f, -0.00208414f, 0.05161320f, 
    0.04567122f, 0.04038443f, -0.22683154f, -0.02680401f, -0.02670451f, -0.11417226f, -0.07119764f, -0.10270085f, 
    0.17698915f, 0.41652516f, 0.15827815f, -0.02496185f, 0.12008251f, 0.17725572f, -0.22503299f, -0.06090866f, 
    -0.16157402f, 0.13785282f, 0.04790538f, 0.01760327f, 0.12947139f, 0.04825450f, -0.00860341f, -0.11203399f, 
    -0.02495361f, 0.02106112f, -0.10704774f, -0.19136593f, -0.06690848f, 0.17016950f, 0.09362148f, 0.23128268f, 
    0.16219513f, -0.01734257f, 0.06504985f, -0.16656926f, -0.29312780f, -0.01404019f, 0.17503551f, 0.26997793f, 
    -0.05776986f, -0.08740754f, 0.18071856f, -0.03066470f, 0.09243039f, -0.13958740f, 0.06592204f, -0.27696893f, 
    0.02554465f, -0.15595491f, 0.07912602f, 0.19906320f, 0.04743376f, 0.07827238f, -0.39188641f, 0.04411109f, 
    0.15176125f, -0.19383796f, -0.11734848f, 0.03214215f, 0.05549389f, -0.04112588f, 0.11755542f, 0.24409117f, 
    -0.02234712f, -0.18323669f, -0.00565974f, 0.15396158f, 0.04604129f, -0.19670539f, -0.03591180f, 0.01495748f, 
    -0.00114201f, -0.05576814f, -0.19018394f, -0.05284196f, -0.10252155f, 0.07026739f, -0.08382931f, -0.07164070f, 
    0.08990858f, -0.19844258f, -0.13823394f, -0.18636572f, -0.06419998f, -0.04922526f, -0.15889122f, 0.11837566f, 
    0.09165442f, 0.15550184f, 0.07689789f, -0.23304921f, -0.06790695f, 0.11154473f, -0.03724058f, 0.09661315f, 
    0.12660444f, -0.16098432f, 0.01861225f, -0.17196126f, -0.19672257f, 0.17490728f, 0.23377854f, 0.20743956f, 
    -0.01872166f, 0.14614674f, -0.10281514f, 0.09031293f, 0.39549756f, 0.12517592f, 0.19344950f, -0.28651902f, 
    -0.35383958f, -0.03854167f, -0.12209015f, -0.05306362f, -0.05409207f, 0.37792552f, 0.10800356f, 0.10492525f, 
    0.09373422f, -0.02057886f, -0.08733404f, -0.33565825f, 0.16385306f, 0.06759441f, 0.08556042f, 0.16859122f, 
    -0.18957280f, -0.09410975f, -0.08806353f, 0.05471858f, 0.09723739f, 0.22857744f, 0.24926750f, 0.38502499f, 
    -0.26075464f, -0.10213550f, 0.02821426f, -0.05621101f, -0.02359241f, -0.16201073f, -0.12098345f, -0.04913672f, 
    -0.04393354f, 0.04207850f, 0.03376548f, 0.02621817f, -0.09976708f, -0.04787095f, 0.01342115f, 0.01509366f, 
    -0.03586066f, -0.05777341f, -0.00821456f, 0.07006688f, -0.02511368f, -0.06154921f, -0.08099224f, -0.02034751f, 
    -0.11325166f, -0.03491930f, -0.02212723f, -0.07800033f, -0.07606614f, -0.11653020f, -0.11741468f, 0.00468828f, 
    0.07111049f, -0.07636669f, 0.08325639f, -0.04067753f, -0.04657051f, -0.00903199f, 0.07356229f, 0.03807099f, 
    0.07492136f, 0.04907469f, -0.04312678f, -0.05990028f, -0.06427316f, -0.06137312f, 0.00815293f, -0.03248206f, 
    -0.05354755f, 0.01752524f, 0.01677143f, -0.01566854f, -0.04999708f, -0.05729132f, 0.05644907f, 0.06399576f, 
    -0.04440889f, -0.09354267f, 0.05724559f, -0.08038779f, -0.03127059f, -0.07221172f, -0.03605462f, -0.03547506f, 
    -0.06338509f, -0.00347965f, 0.02668720f, 0.01873457f, -0.06900631f, -0.10232791f, 0.02791723f, -0.04600304f, 
    -0.08273468f, -0.06808004f, -0.06632953f, 0.01162580f, -0.08061695f, 0.05506646f, -0.01907518f, -0.01723888f, 
    -0.05582216f, 0.00198782f, -0.00952412f, -0.09463073f, -0.04989520f, -0.07138118f, -0.08714724f, 0.00435915f, 
    -0.09553657f, -0.10866448f, -0.08441771f, 0.04660203f, 0.03675288f, -0.03874427f, 0.03797810f, -0.08538367f, 
    -0.04039589f, -0.05601106f, -0.06762473f, -0.01427711f, 0.00978227f, -0.02226901f, -0.06948032f, -0.07224678f, 
    -0.05576099f, -0.07614833f, 0.06325723f, 0.06740958f, -0.02808128f, -0.04841978f, -0.07738898f, -0.03243709f, 
    0.02681060f, 0.06019002f, -0.05184923f, 0.06201408f, -0.04712446f, -0.09523123f, -0.01107246f, 0.04201319f, 
    -0.03161617f, -0.04671472f, 0.00673978f, -0.05391551f, 0.00744262f, 0.05079580f, -0.04257330f, -0.06275123f, 
    0.02618427f, 0.04978354f, 0.02746962f, 0.01567705f, 0.02687433f, 0.06241230f, 0.07347810f, -0.00636072f, 
    0.03000541f, -0.05784121f, 0.05462615f, -0.03346809f, -0.00765902f, 0.04013129f, 0.04415403f, -0.03401457f, 
    0.02534081f, -0.06666710f, -0.05580670f, -0.04554641f, -0.04929007f, -0.00430446f, -0.01564928f, -0.02201026f, 
    -0.07164828f, -0.01250117f, -0.07396074f, 0.03712807f, 0.06631521f, -0.04767164f, 0.02997766f, 0.07424551f, 
    -0.03478794f, 0.02091923f, -0.08045312f, -0.02315075f, -0.03169010f, 0.00631485f, 0.06763174f, -0.01179822f, 
    0.04963471f, -0.10094994f, -0.03366561f, -0.07384198f, 0.03696233f, 0.02700413f, -0.07180630f, -0.08310093f, 
    -0.06093137f, 0.02439522f, -0.01372639f, 0.01374808f, -0.06346830f, -0.00224369f, 0.02746620f, 0.04135152f, 
    0.05380644f, 0.04537002f, 0.03286775f, -0.00243683f, 0.05850693f, -0.08779053f, -0.07107404f, 0.03542640f, 
    -0.08702171f, -0.04973485f, -0.00454910f, -0.07935239f, 0.00005930f, -0.00462623f, -0.05810082f, 0.03480745f, 
    -0.04971328f, 0.01720386f, -0.03359026f, -0.01769711f, -0.07157884f, -0.05924169f, -0.07955484f, 0.06449816f, 
    -0.07928949f, -0.07643556f, 0.00825895f, -0.06055559f, 0.01235684f, -0.00238594f, -0.08055092f, 0.00883972f, 
    -0.09772000f, 0.01127207f, 0.05609628f, -0.07990663f, -0.05873930f, -0.05216644f, 0.05760592f, -0.04417247f, 
    -0.08574555f, -0.01856101f, -0.02626224f, 0.00153657f, -0.06785096f, -0.03090525f, -0.05745421f, 0.04159662f, 
    -0.07379101f, 0.00711665f, 0.05352305f, 0.07601187f, -0.07834449f, 0.07630345f, -0.07722224f, -0.08217292f, 
    0.03666033f, -0.06257590f, -0.03994536f, -0.03882663f, 0.07715785f, -0.06609586f, -0.05775636f, -0.01582813f, 
    0.01689340f, -0.01820106f, -0.05711471f, 0.05937945f, 0.02029744f, -0.05651006f, 0.06711818f, 0.05524595f, 
    -0.03441779f, -0.08422050f, -0.02063671f, -0.06416804f, -0.03378352f, 0.03219601f, -0.08847246f, -0.09128892f, 
    0.04846660f, -0.04196299f, 0.05146052f, -0.08356853f, -0.02962362f, -0.04620817f, 0.02773680f, 0.04067232f, 
    0.03081224f, 0.03754577f, -0.08051331f, -0.02357099f, 0.05733446f, -0.07858757f, 0.00648612f, -0.05020789f, 
    0.00315213f, 0.01758148f, -0.00094182f, -0.02590244f, -0.06025652f, 0.00237874f, 0.06186128f, 0.05320276f, 
    0.06800958f, -0.07129988f, 0.07273676f, -0.08826954f, -0.07854488f, -0.03307625f, 0.01049925f, -0.03258051f, 
    -0.03338651f, -0.03722462f, -0.07238367f, -0.12585826f, 0.19695367f, -0.18722591f, 0.01084337f, -0.05634428f, 
    0.02131199f, 0.04301950f, -0.03193796f, 0.16870357f, 0.17381759f, 0.06110626f, 0.04353436f, -0.02625110f, 
    -0.32236969f, -0.10059153f, -0.15657048f, 0.04789845f, 0.02533163f, 0.20767006f, -0.17768309f, 0.17442471f, 
    -0.12126667f, -0.06769026f, -0.10458393f, -0.11482961f, -0.01399352f, -0.01327549f, 0.20395146f, 0.00580156f, 
    0.01926274f, 0.07811804f, -0.07236765f, 0.37730548f, -0.12326123f, -0.01555403f, 0.10673805f, 0.04573345f, 
    -0.08551733f, -0.12797001f, 0.04012519f, -0.08391937f, 0.14464532f, 0.16705054f, 0.09019799f, 0.29253626f, 
    -0.19174901f, -0.02705902f, -0.04847919f, -0.05445521f, 0.19371609f, 0.14573371f, -0.24918365f, 0.08066294f, 
    -0.21462859f, 0.20245118f, 0.07315284f, 0.03932577f, -0.16117099f, 0.06298097f, -0.20727509f, 0.13623381f, 
    0.04595654f, -0.12795801f, 0.16914463f, 0.16466759f, 0.04334449f, -0.02254760f, -0.06330314f, -0.06799841f, 
    0.12120681f, 0.14942184f, 0.23379974f, -0.02845237f, -0.06833203f, 0.00730183f, 0.03477560f, 0.03044789f, 
    0.05878450f, 0.06021450f, 0.04404455f, -0.06719236f, 0.02981620f, 0.09228158f, 0.31186411f, 0.13441660f, 
    0.07193889f, -0.18799481f, -0.05126159f, 0.28925768f, -0.10169607f, -0.10812014f, 0.16272597f, 0.02968829f, 
    0.15214707f, -0.12468931f, -0.11680383f, -0.06489523f, -0.08490566f, 0.12926301f, 0.16300765f, 0.16873814f, 
    -0.01466038f, -0.08958968f, 0.00398745f, 0.13575070f, 0.43827450f, -0.01112828f, -0.06738041f, -0.03636797f, 
    0.19449285f, -0.25517008f, 0.11484926f, 0.12181781f, -0.01798431f, 0.03842095f, -0.10103011f, 0.38290018f, 
    -0.11772584f, -0.05764155f, 0.16156775f, 0.09921225f, 0.06895854f, 0.06722896f, -0.07018419f, -0.25511560f, 
    -0.37134463f, 0.03961736f, 0.18723942f, -0.04581583f, 0.08652706f, 0.08232339f, 0.04035961f, 0.05138839f, 
    0.12480733f, -0.00914297f, -0.26924211f, -0.15206651f, 0.04389053f, -0.00361791f, 0.07870292f, 0.13996570f, 
    -0.09262817f, -0.04732399f, 0.01582830f, 0.06657328f, 0.02844770f, 0.04230929f, -0.05644908f, -0.03344117f, 
    0.20610940f, -0.03526232f, 0.26375398f, 0.24827316f, -0.03665444f, 0.17180926f, -0.15549162f, -0.04435212f, 
    0.14642341f, -0.13338329f, 0.19578730f, 0.13811561f, -0.08128191f, -0.14340664f, 0.06923623f, 0.02855192f, 
    0.16920693f, 0.18391582f, -0.02893111f, -0.06835117f, 0.08212020f, -0.12036532f, -0.17964205f, 0.22836281f, 
    -0.18960463f, -0.10553497f, 0.20329177f, -0.12338524f, -0.05461498f, -0.57663316f, 0.13295431f, -0.07228228f, 
    -0.09545937f, 0.05845366f, 0.08704581f, -0.02489443f, 0.22095890f, -0.35161585f, -0.17041269f, -0.27327433f, 
    -0.07094486f, -0.10601153f, 0.01673412f, 0.06348698f, -0.07735525f, -0.04479663f, 0.04302625f, 0.14809272f, 
    0.18902220f, -0.00905039f, 0.14894846f, -0.13270189f, 0.10916299f, -0.08653226f, 0.07307462f, -0.28791016f, 
    0.04539188f, 0.08741415f, 0.28393617f, -0.16520266f, 0.03060788f, -0.11808770f, -0.10299422f, -0.04348517f, 
    -0.19219925f, 0.14337704f, -0.28857872f, -0.02874702f, -0.04854139f, -0.02722634f, -0.15573654f, -0.02202947f, 
    -0.00895419f, 0.17982851f, 0.21216996f, -0.15673363f, -0.06655081f, 0.27764174f, 0.00066495f, 0.11607193f, 
    -0.04303962f, -0.12066383f, -0.04682364f, 0.07125095f, 0.00870020f, 0.09371009f, -0.14124480f, -0.12855875f, 
    0.10417035f, -0.08382254f, 0.01755344f, 0.27618617f, 0.32311547f, 0.28061491f, -0.00774502f, -0.10468908f, 
    -0.04181372f, 0.03285312f, 0.04278122f, 0.07222948f, 0.10335062f, 0.00359293f, 0.06638806f, 0.07427463f, 
    -0.04724820f, 0.18434168f, 0.05894312f, -0.02498997f, 0.20566338f, 0.08842172f, 0.15121110f, -0.02481740f, 
    -0.10601688f, 0.14804046f, 0.15035060f, -0.01302399f, 0.05624045f, -0.04959428f, -0.15677576f, -0.13663459f, 
    -0.27000728f, 0.16532610f, -0.24835099f, -0.05738069f, 0.12043093f, -0.11826900f, 0.25608560f, -0.49463069f, 
    -0.32961693f, -0.04222669f, 0.17220102f, 0.05403481f, 0.02214333f, -0.09744017f, -0.02402162f, -0.17613046f, 
    -0.54068488f, -0.45057505f, -0.29935589f, 0.26112041f, 0.20522693f, 0.07498644f, -0.05923576f, 0.04867201f, 
    -0.11650686f, 0.43871373f, 0.13015130f, 0.01419954f, -0.08329855f, -0.00141259f, -0.04893193f, -0.10817253f, 
    0.22870612f, 0.05048382f, -0.11911118f, 0.07293156f, 0.21963955f, -0.12734722f, -0.08599089f, -0.09460805f, 
    0.07632453f, 0.22093675f, 0.09626293f, -0.01616469f, -0.16920628f, -0.01333049f, 0.05196826f, -0.09028997f, 
    0.24336256f, -0.10999975f, -0.00507635f, 0.03775277f, -0.16120729f, -0.14721842f, -0.10479276f, -0.01501983f, 
    -0.10929816f, -0.08619415f, 0.00607497f, 0.04574710f, 0.01190132f, 0.60514629f, -0.23016763f, -0.00020548f, 
    0.07922345f, -0.03146587f, 0.00520265f, -0.08605523f, 0.15207049f, -0.13430986f, -0.41707391f, -0.22436470f, 
    -0.26786011f, 0.07781144f, 0.02778066f, -0.13060308f, 0.03318221f, 0.17352031f, 0.02519352f, -0.34278315f, 
    -0.38077238f, 0.00073772f, 0.20436712f, 0.31384262f, 0.22609194f, -0.17177983f, -0.00737737f, 0.03911383f, 
    0.50808787f, 0.33807293f, -0.04346123f, 0.10412490f, -0.14640328f, -0.07067730f, -0.07072695f, -0.05768428f, 
    0.12308504f, -0.00776292f, -0.06649703f, -0.09598196f, -0.10701390f, 0.03227221f, 0.06462870f, 0.03269383f, 
    0.03336389f, 0.02990460f, -0.05036920f, 0.02876116f, -0.02382844f, -0.07644323f, 0.01025283f, 0.17259809f, 
    -0.09993240f, 0.04003021f, -0.01698733f, 0.28320649f, 0.12613665f, 0.01665517f, -0.10237529f, 0.07322296f, 
    -0.05860737f, 0.02682516f, -0.04779043f, 0.01916931f, 0.24453196f, -0.02880843f, -0.08214345f, -0.24821141f, 
    -0.07230160f, -0.08686092f, 0.06087404f, 0.04720254f, -0.03958665f, 0.20074016f, 0.00077155f, 0.07003425f, 
    0.10035677f, -0.03355814f, -0.09816577f, 0.04264087f, 0.05010432f, 0.02875874f, -0.15518740f, -0.04911774f, 
    0.18664318f, 0.02591744f, 0.12865914f, -0.08504628f, 0.06931335f, -0.00452512f, -0.08631756f, -0.13300925f, 
    0.23188521f, 0.12517382f, 0.14489941f, 0.05619086f, 0.05576993f, -0.00597183f, -0.06825352f, -0.18289831f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.19608869f, 0.13901649f, -0.27089822f, -0.00132619f, -0.07318918f, 0.26005888f, 0.20433226f, 0.13351844f, 
    0.10550692f, 0.09734420f, 0.03032223f, 0.01240416f, -0.00417346f, -0.06354812f, 0.05132258f, 0.14996016f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.43599850f, 0.26052538f, -0.14891754f, -0.14040296f, 0.13183601f, 0.37925553f, -0.11785646f, 0.01278845f, 
    -0.36715224f, 0.04417399f, 0.43834299f, 0.17713328f, -0.04148531f, -0.24272305f, 0.05557833f, -0.02104655f, 
    0.31005064f, -0.26942068f, -0.28512198f, 0.00182303f, 0.09577738f, 0.11616566f, 0.29352731f, -0.40316570f, 
    0.18820968f, 0.73557818f, -0.17034097f, 0.09980568f, -0.09867504f, -0.03991535f, -0.23199981f, 0.19063812f, 
    0.25717771f, 0.16109090f, -0.51729572f, 0.31200993f, -0.13322142f, 0.04300229f, 0.45100644f, -0.17952698f, 
    -0.28466693f, -0.20532060f, -0.20452625f, -0.00536421f, -0.15770245f, 0.08378241f, -0.29854369f, 0.02049412f, 
    -0.29312593f, 0.24894729f, 0.10413712f, -0.45257893f, -0.09392472f, 0.18710338f, 0.09311087f, 0.43348607f, 
    0.56333917f, -0.26125580f, -0.01223107f, 0.15415257f, 0.11528758f, -0.38790634f, 0.42102283f, 0.05513540f, 
    0.31368479f, -0.21198966f, 0.25983709f, -0.44431683f, 0.05777353f, 0.16776329f, 0.05306444f, 0.17126215f, 
    -0.13910459f, -0.17265004f, 0.35485086f, -0.02294972f, -0.02517894f, -0.19974396f, 0.43610707f, -0.24116507f, 
    0.46167409f, 0.31372413f, -0.17555240f, 0.19035359f, 0.15256211f, -0.12107346f, -0.09501460f, -0.04551079f, 
    0.02017457f, -0.46571818f, -0.02251029f, 0.03830225f, -0.24696195f, -0.29211301f, 0.27511987f, -0.01788016f, 
    0.11057607f, 0.16880681f, -0.38132992f, -0.15595895f, -0.06381259f, 0.03399374f, -0.31668943f, -0.12020213f, 
    0.35194093f, 0.27139944f, -0.28476158f, 0.05268985f, 0.21151201f, 0.06499035f, -0.22833779f, 0.36966640f, 
    0.40847254f, 0.06001866f, -0.26973030f, -0.29018396f, 0.08614431f, 0.36083689f, 0.09402361f, -0.19833304f, 
    0.07055537f, 0.06165687f, -0.20009731f, -0.07433148f, -0.16032097f, -0.23334835f, -0.52185225f, 0.38638988f, 
    -0.21754345f, 0.34580639f, 0.42741084f, 0.38198498f, 0.22137412f, 0.32827920f, -0.28020400f, -0.07260966f, 
    -0.44313595f, -0.12385146f, 0.52154380f, 0.17043594f, 0.24067208f, 0.06629278f, 0.02995164f, -0.17650254f, 
    -0.09153262f, -0.02469611f, -0.01276925f, 0.04934552f, 0.12081641f, -0.24241492f, -0.01416725f, -0.12880382f, 
    -0.21595514f, 0.01117012f, -0.02724218f, 0.04900977f, -0.24093613f, -0.05987453f, -0.24843684f, 0.04771724f, 
    -0.25216782f, -0.10220814f, -0.04487315f, -0.19610617f, -0.02481208f, 0.01953176f, 0.12219750f, 0.27070880f, 
    0.32844850f, 0.59841764f, 0.24818136f, -0.11575984f, 0.25564867f, 0.45193091f, -0.39151561f, -0.31425557f, 
    0.04657307f, 0.24959685f, 0.22032791f, 0.46777183f, 0.07931793f, 0.04569167f, 0.21652488f, 0.31092557f, 
    -0.22578931f, 0.32070687f, -0.47280788f, 0.09597196f, -0.19929180f, -0.33427465f, 0.44824532f, -0.41885087f, 
    0.01951686f, -0.06414667f, 0.37124273f, -0.12260450f, -0.11726204f, -0.01949838f, 0.50119829f, 0.30076590f, 
    -0.33089191f, 0.18364729f, -0.11205305f, 0.00904822f, -0.17071180f, 0.20876890f, 0.00913334f, -0.36844179f, 
    0.35126415f, -0.21346995f, -0.27125835f, -0.41944972f, 0.23032267f, 0.34294820f, -0.10671718f, 0.05455134f, 
    0.29165831f, 0.45319304f, 0.20839125f, -0.13143076f, -0.22591582f, -0.32786849f, 0.45360270f, -0.12535357f, 
    0.35541764f, 0.04098534f, 0.59712434f, -0.22011985f, -0.05047092f, 0.02446216f, -0.17038918f, -0.05044363f, 
    -0.46970379f, -0.29497638f, 0.65089959f, -0.12433253f, -0.10884584f, 0.10121763f, -0.15084784f, -0.20852239f, 
    0.19430654f, -0.19881666f, -0.05686486f, -0.11838664f, 0.15586290f, -0.09722968f, -0.15218993f, 0.47546321f, 
    0.57606888f, -0.17150961f, -0.04713353f, 0.12519230f, 0.22865599f, 0.13651232f, 0.20038086f, -0.06550640f, 
    -0.10949082f, 0.15265399f, 0.31478828f, 0.22376026f, 0.18815751f, -0.44259679f, -0.14984412f, -0.25264460f, 
    -0.04283634f, 0.07007868f, 0.28788012f, -0.07692581f, -0.14320418f, 0.33109048f, -0.02870688f, 0.21108931f, 
    0.26801744f, -0.25628951f, -0.30364215f, -0.06946066f, -0.19764251f, 0.14346582f, -0.16663295f, -0.18084991f, 
    -0.15769780f, 0.06332903f, -0.07751764f, 0.02794816f, -0.03240569f, 0.10334679f, -0.38822305f, 0.56464666f, 
    0.32052940f, -0.15766242f, 0.00182417f, 0.02330196f, 0.00411920f, -0.27949286f, -0.52154386f, 0.12013602f, 
    -0.43096080f, -0.27195916f, -0.30943969f, -0.01202689f, 0.14931485f, 0.17234989f, 0.25898534f, 0.41559049f, 
    0.28600600f, 0.20235991f, 0.15314372f, -0.22493128f, 0.16617361f, -0.11037915f, 0.44661936f, 0.25325099f, 
    0.29150340f, -0.08523817f, -0.38216141f, 0.19159146f, -0.04000166f, -0.09493253f, 0.20257322f, -0.12856473f, 
    -0.23958382f, -0.22984117f, 0.21816608f, -0.21762371f, -0.12307703f, -0.21961869f, 0.11503216f, -0.04666381f, 
    0.22822502f, -0.01262447f, -0.01059491f, 0.20459619f, 0.01557164f, -0.21201751f, -0.12772590f, 0.06939018f, 
    0.03564287f, 0.25389132f, 0.02928934f, 0.43697339f, -0.02736392f, -0.12659681f, 0.13097681f, 0.02585804f, 
    -0.59056264f, 0.19867384f, 0.36047220f, -0.20127924f, -0.06846912f, 0.20621376f, -0.16791411f, -0.32397878f, 
    0.27309045f, -0.11221822f, 0.11457032f, 0.07300700f, 0.20283662f, -0.02160317f, -0.51964784f, -0.36426005f, 
    -0.12370553f, -0.38714820f, 0.38569623f, 0.00041557f, -0.20588666f, 0.37890768f, -0.11682826f, 0.05016327f, 
    0.06366231f, -0.13570942f, 0.42338085f, -0.71691990f, -0.23973259f, 0.19314951f, -0.28326398f, 0.67075688f, 
    0.53039253f, -0.05041601f, 0.26095438f, -0.05825446f, -0.23951682f, 0.01213446f, 0.18775116f, -0.09240526f, 
    0.37401065f, -0.16843326f, -0.05720224f, 0.39176172f, -0.23405385f, -0.24553369f, -0.20305458f, -0.08195841f, 
    -0.11244128f, -0.13158374f, 0.06824398f, -0.15771976f, -0.18688035f, 0.02775404f, 0.17979278f, 0.31347924f, 
    -0.19062713f, -0.19292313f, -0.20822385f, 0.03687369f, -0.22770095f, -0.06061343f, 0.13818634f, 0.18946779f, 
    -0.21936007f, -0.23511656f, 0.05626816f, -0.22631648f, 0.23459685f, -0.15414077f, 0.08910700f, -0.22329530f, 
    -0.15061624f, 0.15522717f, -0.48056468f, -0.06784342f, -0.18147561f, 0.31139600f, -0.34668940f, 0.32750052f, 
    0.07953618f, 0.33273789f, 0.16418020f, 0.05612637f, 0.07176600f, 0.12236349f, 0.32479125f, -0.29433468f, 
    0.14040068f, -0.24159274f, -0.42960465f, 0.17590150f, -0.16566497f, -0.01054704f, -0.22651032f, 0.43851081f, 
    -0.23505028f, 0.28807020f, -1.02401876f, 0.21214853f, -0.13073188f, -0.08963858f, -0.05492064f, 0.21749042f, 
    -0.10973853f, -0.16374984f, 0.00294802f, 0.13941804f, 0.05993789f, 0.07487515f, -0.21663103f, -0.18302196f, 
    -0.17143926f, -0.07535031f, -0.18218553f, 0.08938026f, -0.15217438f, -0.13955620f, -0.08199561f, -0.22035912f, 
    0.01145468f, 0.20617342f, 0.06202376f, -0.41443080f, 0.04064894f, -0.01493985f, 0.08700989f, -0.32503510f, 
    0.65200692f, 0.21008427f, -0.14896676f, -0.16668248f, -0.22476640f, -0.14139362f, -0.10781343f, 0.29136813f, 
    0.19930454f, 0.46904552f, 0.39225259f, 0.26124343f, 0.04694879f, -0.05246173f, 0.26060337f, -0.34432867f, 
    0.14898589f, -0.35740548f, -0.05419340f, 0.23065007f, -0.05697967f, 0.25124329f, -0.22669721f, -0.46957806f, 
    -0.05574024f, -0.17424473f, -0.22340474f, 0.06577187f, -0.15420544f, -0.22666414f, -0.22337735f, -0.04150634f, 
    -0.12177058f, 0.05660732f, -0.24475586f, 0.18304089f, 0.13626415f, -0.07910131f, 0.18175101f, -0.02244416f, 
    -0.20551446f, 0.26974025f, -0.41847193f, -0.01176847f, 0.09417736f, 0.11531328f, -0.10680923f, -0.02186362f, 
    0.33693090f, 0.26855987f, -0.08072835f, 0.07353897f, 0.01937234f, 0.35341209f, -0.21065946f, -0.27054629f, 
    0.26758295f, 0.09167223f, -0.35529202f, -0.06111598f, 0.26014665f, -0.40514719f, 0.71020150f, 0.08328122f, 
    0.00118083f, -0.14149424f, -0.24620971f, -0.08758869f, -0.02400286f, 0.11974743f, -0.62692231f, 0.16527626f, 
    -0.09296440f, -0.11271596f, -0.10684489f, -0.35853747f, 0.02958030f, -0.22384867f, 0.14729249f, -0.04137461f, 
    -0.54844087f, -0.43804944f, 0.52397448f, -0.22025768f, -0.15572794f, 0.48329568f, 0.18038857f, 0.01461353f, 
    -0.32992837f, -0.38880494f, 0.43750745f, 0.14865579f, 0.17257801f, 0.20746966f, -0.01881263f, 0.40260223f, 
    -0.12414137f, 0.40225625f, 0.18160322f, 0.04065410f, 0.17205621f, 0.46439388f, -0.36687082f, -0.03310069f, 
    0.23550822f, -0.39039251f, 0.02084481f, -0.24095006f, -0.01669759f, -0.08875024f, -0.19576958f, -0.40659177f, 
    -0.26235780f, 0.04959448f, 0.46176359f, -0.07765908f, 0.13302991f, 0.16225268f, 0.56449896f, 0.31228217f, 
    -0.05909571f, -0.18695962f, -0.20890555f, 0.19464482f, -0.04290825f, -0.25131777f, 0.19746637f, -0.24635105f, 
    0.01575751f, -0.22318758f, 0.02730392f, -0.08524516f, -0.15934810f, -0.06730025f, -0.27631480f, -0.17788446f, 
    -0.07511989f, 0.36137453f, -0.03351985f, -0.00759532f, -0.06280261f, 0.19094211f, 0.42105076f, 0.18118389f, 
    -0.01382452f, 0.49827382f, 0.26400700f, -0.17554452f, -0.18535762f, -0.26414523f, -0.25879440f, -0.14743884f, 
    -0.19475086f, 0.20438524f, -0.05817404f, -0.00530307f, 0.13503835f, -0.03701793f, -0.08339071f, 0.21963190f, 
    -0.19325610f, -0.13995942f, -0.11620004f, 0.08479066f, -0.04182820f, 0.16558853f, 0.30561152f, 0.15313014f, 
    0.12065546f, 0.06509521f, -0.06971771f, -0.26179135f, -0.09092921f, 0.00648829f, 0.71168029f, 0.53264731f, 
    -0.06776635f, -0.40880007f, 0.22103205f, 0.02250210f, -0.07044873f, -0.09251288f, 0.34841084f, -0.15860446f, 
    0.08399240f, -0.31926608f, 0.40430930f, 0.25707388f, -0.10424566f, -0.25586492f, 0.35999924f, 0.49829739f, 
    -0.32400936f, -0.04994569f, -0.29605031f, 0.16936263f, 0.11806113f, -0.21268843f, 0.45772278f, -0.16577907f, 
    -0.20308673f, -0.03881216f, -0.09286562f, -0.22112074f, -0.24257579f, -0.20594528f, -0.12755218f, 0.20088848f, 
    -0.19209462f, -0.02523142f, -0.13233024f, 0.03834149f, -0.03603330f, -0.07574061f, -0.24524629f, 0.19429830f, 
    0.41245767f, -0.08330903f, 0.13294835f, -0.30890530f, 0.02482009f, 0.09521025f, 0.44258377f, -0.24091257f, 
    0.16796206f, 0.60902047f, -0.10976827f, 0.06883054f, -0.11554414f, -0.32932684f, -0.02459455f, -0.18285938f, 
    -0.15503882f, 0.09151077f, -0.63342583f, -0.09537176f, 0.20297506f, 0.42637235f, 0.16199014f, 0.59969157f, 
    0.43550280f, -0.02495468f, 0.25511643f, -0.21799368f, 0.01531894f, -0.06819752f, -0.13068315f, -0.48879769f, 
    0.28134429f, 0.07164845f, 0.20202211f, -0.11837744f, -0.14474267f, 0.21842209f, 0.22299580f, -0.21478075f, 
    -0.44921693f, 0.43605927f, 0.35798037f, 0.16941142f, -0.19346550f, 0.00083327f, 0.09690224f, -0.37424883f, 
    -0.24493614f, -0.20977074f, -0.18201330f, -0.09224683f, -0.13313878f, -0.01735240f, -0.24113438f, -0.04337063f, 
    0.14454234f, 0.06485561f, -0.15475848f, -0.17107290f, 0.10628808f, -0.17503807f, 0.14724311f, -0.23274273f, 
    0.26135883f, 0.06151364f, -0.14009403f, -0.55219126f, -0.08631873f, 0.25509965f, 0.26111469f, 0.25346988f, 
    0.01319007f, -0.49584076f, -0.21407411f, 0.09456195f, -0.12239923f, 0.03217861f, 0.19205175f, 0.16491762f, 
    0.22220063f, 0.30807003f, 0.48437110f, -0.14288066f, -0.00300014f, 0.11932170f, 0.40980688f, -0.68796039f, 
    0.34051654f, -0.22490993f, -0.08579959f, 0.11087272f, -0.16054979f, -0.13151881f, -0.13040374f, -0.30290797f, 
    0.35560817f, -0.28494599f, 0.35010418f, 0.01516586f, -0.15613568f, -0.04023358f, -0.19338134f, -0.90613890f, 
    -0.25625417f, 0.21769691f, 0.22519933f, 0.13473527f, -0.20136824f, -0.12571722f, 0.46298757f, 0.23292401f, 
    0.15096426f, 0.36745587f, -0.35877204f, 0.47430161f, 0.04144323f, -0.08376980f, 0.10155956f, -0.18373388f, 
    -0.43037030f, -0.07892596f, 0.23129497f, 0.15229343f, -0.01361381f, 0.13375367f, 0.03496027f, -0.25618911f, 
    0.26938784f, 0.16146778f, -0.23954245f, -0.25371033f, 0.01211687f, 0.47654063f, -0.43130139f, -0.42082736f, 
    -0.07769426f, 0.28559712f, -0.16883497f, -0.08094842f, -0.01466441f, -0.19586223f, 0.29589689f, 0.25354153f, 
    -0.06305863f, -0.38603362f, -0.25737914f, -0.02277954f, 0.14733709f, -0.01738358f, -0.13532518f, 0.48169616f, 
    0.53192377f, -0.02906900f, 0.12632780f, 0.25878358f, -0.18034421f, 0.12652652f, 0.11672671f, 0.49698088f, 
    0.10351004f, -0.10322014f, -0.09271616f, 0.09547884f, -0.16119924f, -0.23175277f, -0.11505881f, -0.17354296f, 
    0.05211706f, 0.09745431f, 0.08404959f, -0.14943987f, 0.04759663f, -0.08866891f, -0.17667358f, -0.09839271f, 
    -0.22660333f, -0.36880183f, -0.18442184f, -0.23667844f, 0.04192758f, -0.08964470f, 0.09508651f, 0.34571901f, 
    0.14277050f, -0.18096557f, 0.21694775f, -0.17695744f, 0.01670412f, 0.63450527f, -0.55004990f, 0.12887537f, 
    0.27462178f, -0.19019644f, -0.46810892f, 0.38424766f, 0.09324487f, -0.19901307f, 0.27614781f, 0.13310166f, 
    -0.32369161f, 0.07765654f, -0.19436108f, 0.19407977f, 0.22667454f, 0.30440640f, -0.29263449f, 0.20876521f, 
    0.08392856f, 0.10093128f, -0.00421062f, 0.06441886f, -0.11899307f, -0.20199426f, -0.02986022f, 0.10874505f, 
    -0.17575300f, -0.26151022f, -0.25535139f, 0.23398033f, 0.01068732f, -0.26285627f, -0.18017390f, -0.05145960f, 
    0.18563001f, 0.20311858f, -0.13187185f, -0.29353496f, 0.14609303f, 0.05854370f, 0.35695082f, 0.38007620f, 
    0.36992189f, -0.55126899f, 0.23538770f, -0.10598988f, 0.19382365f, -0.07145266f, 0.14154385f, -0.12561899f, 
    0.12344622f, -0.36153057f, -0.11826666f, 0.43438882f, 0.06118119f, 0.11929474f, -0.41529071f, -0.15116318f, 
    -0.17176780f, 0.44191590f, 0.32506377f, 0.01951127f, 0.08232534f, 0.16515909f, 0.06767894f, 0.29374257f, 
    0.32255903f, 0.40202096f, -0.04854146f, -0.04782818f, -0.19419049f, 0.41407952f, 0.15018657f, -0.32889825f, 
    -0.00834664f, -0.01050655f, -0.04539320f, 0.20510152f, 0.14186159f, -0.15268813f, -0.44104058f, -0.27278277f, 
    -0.19956888f, 0.39026633f, 0.03774673f, 0.02878792f, -0.04332408f, -0.06132505f, 0.46543738f, -0.02026032f, 
    -0.17984019f, -0.56259477f, 0.40768060f, 0.14984460f, 0.19797096f, 0.27564880f, -0.33454826f, -0.04223878f, 
    0.32985121f, -0.07165193f, 0.17596179f, -0.10983543f, -0.23526865f, 0.10139980f, 0.03579199f, 0.20619391f, 
    0.04767921f, 0.08338100f, -0.23561528f, 0.20239298f, -0.00600829f, -0.12831734f, 0.33161521f, -0.48461059f, 
    -0.23229089f, -0.21523732f, 0.10578039f, -0.15384939f, -0.24039811f, -0.19783565f, 0.01068461f, -0.10715818f, 
    -0.12817219f, -0.24544311f, -0.01278046f, 0.19975027f, -0.08123264f, -0.13666368f, 0.19254163f, -0.08944476f, 
    0.12949324f, -0.28640562f, -0.13647659f, 0.00020563f, -0.14806065f, -0.13563578f, 0.23688905f, 0.54499304f, 
    -0.40356776f, -0.22490321f, 0.08233108f, 0.12771586f, 0.07253896f, -0.06106553f, 0.05387736f, 0.34227225f, 
    -0.18397854f, -0.25101277f, 0.17324591f, 0.05408613f, -0.08000529f, -0.16894081f, 0.12383866f, -0.02849361f, 
    -0.20283593f, 0.20099469f, -0.22616301f, -0.22418824f, -0.15595001f, -0.11024152f, 0.00796018f, 0.02553293f, 
    0.25902620f, 0.33372340f, 0.12680249f, -0.46085218f, -0.11390402f, 0.30667251f, -0.06351311f, -0.25319812f, 
    0.40153918f, -0.34233958f, 0.03038962f, 0.05653367f, 0.13132252f, -0.19182687f, 0.04713760f, -0.06539713f, 
    0.09152927f, 0.27720615f, 0.19791834f, -0.08184122f, -0.12578145f, -0.22073945f, 0.07711335f, -0.09351860f, 
    0.56763506f, -0.18577228f, -0.44749564f, -0.20139298f, -0.07981305f, 0.09493539f, -0.25139248f, 0.10244144f, 
    -0.21219100f, 0.28075305f, -0.23565695f, -0.49143931f, -0.21315995f, 0.48880190f, 0.39751372f, 0.47500986f, 
    0.39352426f, -0.18615258f, -0.30319053f, 0.08777896f, 0.00041577f, -0.10867622f, -0.18740115f, -0.00867279f, 
    0.38633582f, -0.20448995f, 0.43726262f, -0.23923829f, -0.13769868f, 0.15067288f, 0.06043422f, -0.15166284f, 
    -0.39888069f, -0.28370568f, 0.68788230f, -0.25051397f, 0.02833509f, -0.11376324f, -0.05555254f, -0.06983823f, 
    0.37678266f, 0.28486574f, 0.22391689f, 0.13719003f, 0.02963109f, 0.22818169f, -0.30299601f, -0.00981076f, 
    -0.23208846f, -0.14562899f, 0.37976119f, 0.14754276f, 0.15336849f, -0.06142191f, -0.01392846f, -0.41326189f, 
    0.24734759f, -0.24945414f, -0.20186654f, -0.08824444f, -0.13307986f, -0.21266505f, -0.15751153f, -0.06628168f, 
    0.23708829f, -0.11900255f, -0.11706942f, -0.13731652f, 0.12848464f, -0.23618025f, -0.19019112f, -0.17801693f, 
    0.19970767f, -0.11225866f, -0.34905159f, -0.04693789f, -0.06931496f, 0.34354550f, 0.53665942f, 0.04174558f, 
    0.10354865f, 0.35802439f, 0.18280964f, 0.14557204f, 0.18518506f, -0.28477269f, 0.31664565f, -0.26402184f, 
    -0.41959712f, -0.24658746f, 0.37986240f, 0.31910786f, 0.16643988f, 0.09381094f, -0.23526418f, 0.45727688f, 
    0.24317299f, 0.05097580f, 0.34633857f, -0.17588484f, -0.07344296f, 0.27083659f, 0.40254250f, 0.01592882f, 
    0.20336768f, 0.21393017f, -0.22841586f, -0.15999405f, 0.25799567f, 0.22130342f, 0.06566892f, 0.01040401f, 
    0.34518194f, -0.15790491f, -0.30198380f, -0.01326021f, -0.16707888f, -0.14846617f, -0.12463544f, 0.26304093f, 
    -0.09585452f, -0.18795387f, -0.17883731f, 0.19192898f, 0.11850828f, -0.14910123f, 0.14611708f, 0.00348647f, 
    -0.23143208f, -0.17315571f, -0.06713490f, 0.08906460f, 0.17690329f, -0.14101531f, -0.25801849f, 0.05363278f, 
    -0.00882363f, -0.36509290f, -0.06981964f, -0.01803638f, 0.00673731f, 0.04979808f, -0.16303736f, -0.39017153f, 
    0.17300382f, 0.40077615f, 0.10545716f, -0.10384586f, 0.07220399f, 0.27837452f, -0.29420686f, 0.16827226f, 
    -0.21755971f, 0.38026631f, -0.50103551f, -0.27133539f, 0.18337110f, 0.33145803f, -0.40924546f, 0.01982696f, 
    -0.48993194f, -0.34345669f, 0.06824647f, -0.02841847f, 0.04642182f, 0.40271524f, 0.01744824f, -0.10184258f, 
    0.06903261f, -0.21791628f, 0.07871667f, 0.07978436f, 0.06445837f, -0.09482056f, -0.22171086f, -0.20799685f, 
    -0.24877366f, -0.03619114f, -0.12586510f, 0.11948010f, -0.15136346f, -0.22619042f, -0.15686628f, -0.07594079f, 
    -0.17211917f, -0.11155605f, 0.10533252f, -0.07703298f, 0.21723893f, -0.07727388f, 0.31926855f, -0.35503158f, 
    0.27238446f, 0.74416935f, -0.11954298f, 0.03398383f, 0.11970795f, 0.17861158f, 0.06625179f, 0.10666339f, 
    -0.20690270f, -0.36930144f, -0.49976990f, 0.15665439f, -0.08475405f, -0.27865702f, 0.38731021f, 0.46253860f, 
    -0.34248161f, 0.03653143f, 0.27052480f, 0.12051356f, 0.23999751f, 0.40244168f, -0.40113848f, 0.10016508f, 
    -0.25835073f, 0.01220294f, 0.12936233f, -0.10592091f, 0.13005686f, -0.23251514f, -0.23057358f, -0.27071920f, 
    0.11690632f, -0.21122928f, 0.01664189f, -0.13120711f, -0.01898322f, -0.06926746f, 0.16995944f, -0.00618070f, 
    -0.12116084f, -0.14632951f, 0.53923732f, -0.29789859f, 0.15112081f, -0.28937489f, 0.15807749f, 0.19565603f, 
    0.09667788f, 0.02519809f, 0.45445719f, -0.23986632f, -0.10948896f, 0.21787828f, -0.42235327f, 0.29222775f, 
    -0.04691143f, 0.12890294f, -0.24376267f, 0.06776369f, -0.10809256f, -0.13848835f, 0.46933499f, -0.27849656f, 
    0.39467004f, 0.12337366f, -0.33891582f, 0.10295419f, 0.04203270f, 0.42448360f, -0.40161511f, -0.08651965f, 
    -0.06332645f, 0.28168067f, -0.20024784f, -0.26495048f, 0.02197751f, 0.31330624f, 0.17137979f, 0.42161760f, 
    0.30609414f, -0.03209437f, -0.00476039f, -0.05348074f, 0.09958256f, 0.26912767f, -0.10907813f, -0.30604264f, 
    0.31216395f, -0.10498133f, -0.39352858f, 0.17392702f, -0.02217845f, 0.40072435f, -0.46484604f, 0.14490260f, 
    -0.26738498f, 0.07017136f, -0.17783986f, 0.19541703f, -0.05252371f, -0.06090267f, -0.18791351f, 0.46376106f, 
    0.08712805f, 0.29849854f, 0.08587465f, -0.09977435f, -0.20515729f, -0.10249874f, 0.31951565f, 0.42880264f, 
    -0.17037849f, -0.57990813f, 0.26049852f, -0.14414226f, 0.12745737f, 0.00821420f, 0.15341058f, -0.21622773f, 
    0.25118369f, 0.14308716f, 0.29666582f, 0.36242181f, -0.12513293f, -0.44031700f, -0.19115436f, -0.35756633f, 
    -0.20031984f, -0.00723570f, 0.19366838f, 0.15146852f, 0.17599712f, 0.25302190f, 0.03359618f, -0.13340162f, 
    -0.24810851f, 0.25142846f, 0.48447961f, 0.21295069f, 0.09288479f, 0.11984499f, 0.10813946f, 0.40437475f, 
    -0.18029483f, -0.31629533f, 0.36117750f, -0.00540183f, 0.19179340f, 0.20360121f, 0.34977490f, -0.28817514f, 
    -0.08235679f, 0.28551829f, 0.12288141f, -0.20511945f, -0.11095452f, -0.25830194f, 0.01819528f, 0.09958640f, 
    -0.21630602f, 0.34293863f, -0.23273259f, 0.26972061f, 0.12434465f, -0.24750823f, 0.09102427f, 0.37017968f, 
    0.10247947f, 0.42801189f, 0.46784049f, 0.23589700f, -0.02475700f, -0.40442455f, 0.17600206f, 0.00236812f, 
    0.14215769f, -0.15360180f, 0.01307120f, 0.26762816f, 0.03803237f, 0.33735314f, -0.30454457f, -0.36504015f, 
    0.08584183f, -0.07701427f, -0.05899088f, -0.20305307f, -0.05103877f, 0.01510173f, 0.01055293f, 0.05686914f, 
    -0.11028084f, -0.23448738f, -0.13906156f, 0.20314142f, -0.13661620f, -0.10865687f, 0.16372223f, -0.13903765f, 
    -0.40818053f, 0.23773047f, -0.34196767f, 0.20716985f, 0.22070080f, 0.33598253f, 0.29747871f, 0.33385682f, 
    -0.34531784f, 0.21441619f, 0.15223481f, -0.11345366f, 0.17092225f, 0.06535966f, -0.79702681f, 0.08638056f, 
    0.14093724f, -0.56127179f, 0.29216841f, 0.16348898f, 0.01671793f, -0.23480421f, -0.22145857f, 0.07844857f, 
    -0.20604257f, 0.56596947f, 0.46051663f, -0.11792913f, -0.11577672f, 0.29462489f, -0.46625111f, 0.15851651f, 
    -0.17791258f, 0.20041245f, -0.61549622f, -0.05432279f, 0.06027308f, 0.44529760f, 0.30727035f, 0.10994350f, 
    0.03648209f, 0.61354524f, -0.05360210f, -0.19733897f, 0.18815219f, -0.05915956f, -0.82124913f, -0.44643533f, 
    -0.19939815f, 0.12647668f, 0.65957415f, -0.12351112f, -0.16023757f, 0.22705863f, -0.37519592f, -0.36570266f, 
    0.64231789f, -0.20499523f, 0.03002364f, 0.19652267f, 0.23811434f, 0.22141038f, 0.16010571f, 0.14863418f, 
    -0.02330869f, 0.02298619f, 0.23235931f, 0.00534325f, 0.14197421f, -0.31675529f, 0.19258763f, -0.42974308f, 
    -0.51454455f, -0.48712596f, -0.22413304f, -0.23732074f, 0.11444408f, 0.01116126f, 0.26973018f, 0.18831156f, 
    0.29766169f, 0.36418703f, -0.20684293f, 0.17112346f, -0.25733164f, 0.34509966f, 0.18002558f, -0.25345320f, 
    -0.47108024f, 0.36647013f, 0.36101884f, -0.12431917f, -0.15423937f, -0.15072785f, -0.07820923f, -0.31043333f, 
    -0.02579517f, -0.00487154f, -0.41016781f, -0.07577746f, 0.05098274f, -0.39490795f, 0.04221855f, 0.59542680f, 
    -0.16732259f, -0.31605673f, 0.23437816f, -0.01100499f, -0.25511315f, 0.22221363f, -0.30129018f, 0.29997116f, 
    0.21748701f, -0.27394947f, 0.01883803f, 0.36863750f, 0.19806181f, 0.11082686f, -0.05701594f, 0.64292842f, 
    -0.43012294f, -0.13839209f, 0.39994970f, -0.15132791f, -0.13175370f, -0.36331305f, 0.46432999f, -0.05687758f, 
    0.14326602f, -0.00480742f, -0.20836492f, -0.51775050f, -0.20047578f, 0.30930755f, 0.16534320f, 0.22044232f, 
    0.30092555f, 0.22981444f, 0.10291880f, -0.07798067f, 0.24463433f, -0.19829784f, -0.02564847f, 0.16238783f, 
    -0.02398252f, 0.19803524f, -0.03497705f, 0.44170305f, 0.03253472f, -0.00543888f, 0.03639068f, 0.63870317f, 
    -0.11663254f, -0.71469057f, 0.33136031f, -0.14437996f, 0.17219961f, -0.31160781f, 0.42903921f, -0.22692467f, 
    -0.15632688f, -0.19604559f, 0.10514937f, 0.09219765f, 0.17159583f, 0.25756100f, -0.47352213f, -0.04475258f, 
    0.00877169f, 0.33204865f, 0.01749442f, -0.09063167f, -0.14253379f, 0.24728741f, 0.27977568f, 0.27772966f, 
    0.22857055f, -0.28598064f, 0.23398526f, 0.04524667f, 0.11258355f, -0.12017626f, 0.52941722f, -0.48566186f, 
    0.03954227f, 0.35570541f, -0.10970240f, 0.13909423f, -0.19426414f, -0.06576472f, -0.03186295f, -0.08884746f, 
    0.12207797f, 0.34718531f, 0.64631432f, -0.01939334f, -0.12914509f, 0.04114623f, -0.04211911f, -0.46605510f, 
    0.39291701f, 0.01488283f, 0.19424061f, 0.26960963f, -0.08938983f, -0.01491624f, -0.12040742f, -0.35549384f, 
    -0.22385280f, -0.17485182f, 0.18562983f, -0.16091129f, 0.23423082f, 0.12541448f, -0.05236987f, 0.18178743f, 
    0.07111852f, -0.03712545f, -0.12574004f, 0.17691714f, 0.24752381f, -0.21679454f, -0.21914998f, 0.14686397f, 
    -0.22139309f, -0.16691901f, 0.06411212f, 0.16415434f, -0.23331395f, 0.05648202f, 0.10358734f, -0.12971668f, 
    -0.14074068f, -0.08418670f, 0.14756848f, -0.03423040f, -0.05174284f, -0.21303889f, 0.13776037f, -0.04502364f, 
    0.42492840f, 0.12328138f, 0.02814256f, -0.29422972f, -0.04958576f, 0.10038674f, 0.27088958f, -0.14504071f, 
    0.14343320f, -0.19931439f, 0.10129734f, -0.20277709f, 0.05754965f, -0.06647728f, 0.18076424f, -0.43754390f, 
    -0.16034447f, -0.00916115f, -0.21989892f, 0.04879075f, 0.05309673f, 0.08800368f, -0.04815631f, 0.55064946f, 
    -0.14582124f, 0.32044980f, 0.38574460f, 0.14754960f, -0.10270055f, -0.10976542f, 0.45021018f, 0.35426334f, 
    0.12725574f, 0.14424320f, -0.36260626f, 0.18291803f, 0.01936834f, 0.42608204f, -0.41606882f, -0.10427846f, 
    -0.08802627f, 0.61475962f, 0.02301674f, 0.00050446f, 0.00666988f, -0.03288444f, -0.21237709f, 0.09870957f, 
    -0.28871167f, 0.16387467f, -0.18939538f, -0.24175765f, 0.09207911f, 0.48264799f, 0.20996182f, 0.45082361f, 
    0.25174809f, -0.04271820f, 0.16371988f, -0.10323058f, -0.03499174f, -0.12045968f, 0.29768273f, 0.03447729f, 
    0.05612636f, 0.01461521f, 0.19777751f, -0.11874528f, 0.22864638f, -0.45139700f, 0.15469927f, -0.30624273f, 
    -0.39442196f, 0.39730179f, -0.34973145f, 0.07854271f, 0.10670234f, 0.25928554f, -0.03673217f, 0.25071335f, 
    0.49030650f, -0.16497914f, 0.11497801f, -0.13873681f, -0.22999467f, 0.05797821f, -0.66108310f, 0.24161533f, 
    -0.11439347f, -0.11119719f, 0.65723658f, 0.07957420f, -0.07049001f, 0.07368650f, -0.47198611f, 0.14721298f, 
    -0.39847207f, 0.04015470f, -1.22465122f, -0.41775694f, 0.03189191f, 0.38445389f, 0.35885170f, 0.32561389f, 
    0.17830846f, 0.06886829f, -0.42057690f, -0.08247581f, 0.23975608f, 0.32747534f, -0.43034479f, -0.15434431f, 
    0.37368852f, -0.42088395f, -0.21914056f, 0.02696333f, 0.21974924f, 0.33470336f, -0.19493322f, 0.54440558f, 
    -0.32948354f, 0.33821988f, -0.41710508f, 0.03345266f, 0.08098382f, -0.12323677f, 0.49110392f, -0.06538522f, 
    0.12013502f, -0.39209747f, -0.18433511f, -0.03548131f, 0.08141481f, 0.29475319f, 0.30922201f, 0.31591612f, 
    -0.01091251f, 0.48150590f, 0.03050607f, -0.16176999f, -0.23487568f, -0.21359134f, 0.13459226f, 0.18684973f, 
    -0.38029349f, 0.11901236f, 0.04489520f, 0.27748489f, 0.15016325f, 0.23459028f, -0.16383474f, 0.21460332f, 
    -0.24339855f, 0.13043515f, 0.16815750f, -0.07537040f, 0.10309408f, 0.20681407f, 0.20890595f, 0.09435318f, 
    -0.12604351f, -0.34280077f, -0.39963657f, 0.07057149f, -0.17799109f, 0.22051135f, 0.45608106f, -0.28526485f, 
    -0.17043723f, 0.12397798f, -0.01303409f, 0.02805340f, -0.19825700f, -0.10225302f, 0.11066309f, 0.51656294f, 
    0.36431742f, -0.31562805f, 0.06300890f, 0.04038360f, 0.16086215f, -0.22291476f, 0.14066795f, 0.19585234f, 
    -0.43913087f, 0.10770218f, 0.46446294f, 0.09272922f, -0.08936525f, -0.09717028f, 0.31672537f, -0.08978605f, 
    0.17043422f, 0.01444070f, 0.25896809f, -0.12114155f, -0.22842745f, 0.10561404f, 0.23921101f, 0.13606291f, 
    0.35658288f, -0.34059316f, 0.22306655f, -0.22564994f, -0.23056175f, -0.01217543f, 0.29865134f, -0.28573930f, 
    0.07892381f, 0.32723960f, 0.30518219f, -0.19909899f, 0.00903373f, -0.32747707f, 0.44556090f, 0.00690342f, 
    -0.47284362f, -0.26553905f, -0.19412056f, -0.13294370f, 0.19816355f, 0.28402162f, -0.15125290f, 0.02935835f, 
    0.36474198f, 0.05121145f, -0.14378093f, 0.17878495f, 0.01341599f, 0.25850698f, -0.06732004f, -0.20708252f, 
    0.01059306f, 0.41307771f, -0.22082090f, -0.22102699f, -0.17153130f, -0.10666395f, -0.10509000f, -0.22781385f, 
    -0.06369199f, -0.08060767f, 0.01032886f, -0.16194753f, -0.17304114f, 0.35898662f, 0.16549844f, 0.62950891f, 
    0.07920381f, -0.49935725f, 0.04111326f, -0.20799010f, -0.03469887f, 0.01718005f, 0.21160407f, 0.13625386f, 
    0.11520552f, 0.20623298f, -0.36609739f, -0.04005894f, -0.12613729f, -0.25284085f, 0.08199804f, -0.26326698f, 
    0.32777718f, 0.32354727f, -0.20733005f, -0.01643462f, 0.20664917f, 0.24119267f, -0.34860846f, 0.09547596f, 
    0.38048381f, 0.10166836f, -0.12599093f, -0.23485884f, 0.10642744f, 0.13577104f, 0.01890986f, 0.14499065f, 
    0.25039598f, -0.21788910f, 0.35585415f, -0.13011731f, -0.05277543f, -0.28616971f, 0.10585839f, -0.26725689f, 
    0.26716897f, -0.05395317f, 0.00609959f, 0.11716203f, 0.17398524f, -0.15729077f, -0.00317057f, -0.21545145f, 
    -0.37206662f, -0.13407476f, 0.20273180f, -0.06279954f, 0.18609320f, 0.41518533f, -0.44876158f, 0.26642755f, 
    0.04378483f, 0.34085783f, -0.66748434f, -0.34073561f, -0.24633662f, 0.11289912f, -0.28772739f, 0.32160598f, 
    0.35681725f, -0.36876097f, -0.10274877f, 0.17632104f, 0.07516024f, 0.40019310f, 0.02811315f, -0.42690369f, 
    -0.14841676f, -0.33720413f, -0.20191900f, 0.08120737f, 0.10738213f, 0.07780010f, 0.42106563f, 0.10406023f, 
    -0.41268709f, 0.15048963f, -0.20572004f, -0.03555289f, -0.04915740f, 0.44045982f, -0.35047913f, 0.06876565f, 
    0.06098388f, -0.36007199f, 0.41272092f, 0.36926311f, -0.12613848f, -0.12596114f, 0.31316209f, 0.04589306f, 
    -0.18425682f, 0.44575557f, -0.26161405f, -0.24363749f, 0.22553304f, -0.03046762f, 0.30996206f, -0.33350012f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.01220305f, 0.24582091f, 0.54563212f, 0.00632779f, 0.25693747f, 0.37898883f, 0.23344499f, 0.00895939f, 
    -0.10314953f, -0.18878484f, -0.06937574f, -0.23138517f, 0.02271735f, 0.40426758f, -0.28989422f, -0.15153988f, 
    -0.66252643f, 0.47661072f, -0.40622079f, 0.12939510f, 0.09943620f, 0.12732162f, 0.30515188f, 0.21203914f, 
    0.26603198f, -0.19749828f, 0.21226878f, 0.42448372f, 0.06484580f, 0.08434367f, -0.09544320f, -0.10623522f, 
    0.51985443f, 0.46911162f, 0.33758384f, -0.11000922f, -0.36415753f, 0.00716676f, -0.20173270f, 0.50477618f, 
    0.41145128f, -0.05469520f, -0.10776597f, 0.16921429f, 0.28668049f, 0.19253705f, 0.18482143f, 0.05057115f, 
    0.17269588f, -0.13147433f, 0.32266226f, 0.21973851f, -0.01964406f, -0.21932229f, 0.42465356f, 0.36827162f, 
    0.05456679f, 0.53020591f, 0.02053618f, 0.44994360f, 0.05504869f, -0.10565681f, -0.07614240f, 0.01630376f, 
    -0.16930242f, 0.13870837f, 0.12717299f, -0.15956169f, 0.19839025f, -0.25532007f, -0.15381375f, 0.33922523f, 
    -0.18395765f, 0.54599112f, 0.17236762f, -0.23903866f, 0.50127542f, 0.01420677f, 0.31836417f, 0.42656118f, 
    0.04484113f, -0.50048530f, 0.48855734f, 0.25825512f, 0.06509471f, 0.36765239f, -0.13906087f, -0.28355372f, 
    -0.40958169f, 0.03611603f, -0.19088905f, 0.25303435f, -0.23642679f, 0.08801234f, -0.08195315f, -0.13275136f, 
    0.43260989f, 0.40575001f, -0.02781957f, 0.26172543f, -0.12901361f, 0.01286037f, 0.00714734f, -0.10293201f, 
    -0.25003245f, 0.20918263f, 0.44640297f, -0.29871139f, 0.15180705f, -0.05062207f, 0.08556656f, -0.19838318f, 
    0.20935504f, 0.13107696f, 0.26145524f, 0.12241121f, 0.60061413f, -0.21972682f, 0.10532237f, -0.07984547f, 
    0.36781052f, 0.35542509f, 0.53195846f, 0.21970376f, 0.47844312f, 0.61978656f, 0.38552234f, -0.35773602f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.06581336f, -0.31405911f, 0.11000618f, 0.06459039f, -0.05463806f, 0.21292447f, 0.06323369f, -0.05143572f, 
    0.38124299f, 0.05197697f, -0.16797839f, -0.17067739f, -0.25736153f, -0.30364412f, 0.13056600f, -0.17958416f, 
    -0.16707528f, 0.01859990f, -0.39139441f, -0.17849538f, -0.05675784f, 0.18482731f, 0.22631817f, -0.09393179f, 
    0.00103151f, -0.01236961f, 0.17547163f, -0.21850489f, -0.04281003f, -0.09201299f, 0.21924032f, -0.08567873f, 
    0.15511441f, -0.18059097f, -0.16377379f, -0.27961391f, -0.60267770f, 0.00827724f, -0.24199732f, 0.10854655f, 
    -0.16174206f, -0.13410138f, 0.00354115f, -0.32879215f, 0.13113998f, -0.04203494f, -0.01668312f, -0.05735311f, 
    0.30507636f, -0.12058342f, 0.23479700f, 0.09398641f, -0.34677604f, 0.00253231f, 0.20303248f, -0.04096955f, 
    -0.07858740f, 0.06989386f, -0.11655067f, 0.16848654f, 0.19910859f, -0.01257638f, 0.06028599f, -0.51275510f, 
    -0.02501613f, 0.21585041f, 0.07371259f, -0.70587426f, -0.03153233f, 0.29141951f, -0.04916159f, -0.31889999f, 
    -0.02659873f, 0.10542681f, 0.02329807f, -0.17545693f, 0.36185190f, 0.08795913f, -0.22818542f, -0.07212877f, 
    -0.01603233f, -0.33570364f, 0.00241843f, 0.01973271f, -0.05396961f, 0.16827436f, 0.13554309f, 0.09308261f, 
    0.07258756f, 0.21680905f, -0.09559259f, -0.18363041f, -0.59164196f, -1.13985252f, 0.32194623f, 0.37952900f, 
    0.12790971f, 0.03844024f, -0.38882294f, -0.07919070f, 0.10292751f, -0.04766588f, -0.01854002f, 0.40566692f, 
    -0.05203196f, 0.04951406f, 0.11317369f, -0.28745255f, 0.04257049f, -0.03953902f, 0.00810734f, 0.19725296f, 
    -0.79748541f, -0.90574908f, -0.40545490f, 0.08465276f, -0.14023496f, -0.63396502f, 0.03603958f, 0.06228460f, 
    0.06080614f, -0.03610178f, 0.08185556f, -0.04415800f, 0.12537161f, 0.37200528f, 0.03845784f, -0.09064622f, 
    0.11548061f, -0.00839711f, -0.13016489f, 0.31300840f, 0.02105377f, 0.16378392f, 0.05493202f, 0.33006459f, 
    -0.31312895f, 0.08439313f, 0.08939435f, -0.08519072f, -0.26622579f, 0.35640934f, -0.06477341f, 0.15322903f, 
    -0.28184727f, 0.03803417f, 0.40022644f, 0.14770053f, -0.09073617f, -0.39010206f, 0.03263649f, 0.09259051f, 
    -0.19639465f, -0.05891465f, -0.05631924f, 0.57388532f, 0.08127696f, 0.16851549f, 0.04530228f, 0.00765155f, 
    0.29479232f, 0.11467723f, -1.00917506f, -0.31452256f, -0.08841098f, -0.08234727f, 0.00640083f, -0.24397515f, 
    0.05104209f, 0.58920348f, 0.08480775f, 0.18103281f, 0.18797970f, 0.01935976f, -0.08512040f, 0.06414618f, 
    0.22444692f, -0.31027773f, -0.18531203f, 0.11514439f, -0.11425975f, -0.03592747f, -0.42310742f, -0.38628227f, 
    0.02263799f, 0.22030340f, -0.29122087f, 0.31624538f, -0.00472672f, 0.15186293f, -0.07741154f, -0.02972717f, 
    -0.04439190f, 0.32816830f, 0.10054962f, 0.32773286f, 0.05508566f, 0.04383667f, 0.02369720f, 0.13043703f, 
    -0.23164299f, 0.13951358f, 0.02672285f, 0.15540320f, -0.14580789f, 0.00302105f, -0.10580738f, -0.93554312f, 
    -0.01449859f, 0.24352698f, 0.14080888f, 0.17976727f, 0.22801396f, -0.00189557f, -0.28152561f, -0.15645501f, 
    -0.28743416f, -0.01615891f, 0.03136832f, -0.81117582f, 0.34043196f, 0.26595712f, 0.16715805f, -0.03634366f, 
    -0.00878599f, -0.75342339f, 0.19861214f, 0.14412627f, 0.03478273f, -0.21156861f, -0.09954726f, 0.11517751f, 
    -0.01108151f, -0.03325799f, 0.22475643f, -0.18340604f, -0.07274964f, 0.04574052f, -0.53491336f, 0.11390220f, 
    -0.11282672f, 0.10715458f, -0.03267663f, -0.29006922f, -0.63596439f, 0.02479210f, 0.26248574f, -0.26427171f, 
    0.14592426f, -0.11789662f, 0.09446222f, 0.36545441f, -0.14568521f, 0.17806043f, -0.73687971f, 0.04687295f, 
    -0.66913646f, -0.19291793f, -0.68110108f, 0.27213809f, 0.00600945f, -0.51180100f, 0.18168969f, -0.40749931f, 
    -0.21831329f, -0.05663161f, 0.33187991f, -0.60900950f, -0.04173987f, -0.18548654f, -1.05040038f, 0.30185440f, 
    -0.09773859f, -0.21877538f, -0.57574081f, 0.01647873f, -0.03066866f, -0.81739783f, -0.28067157f, 0.63806814f, 
    -0.51941741f, 0.04228462f, 0.08264489f, -0.68431360f, -0.05483986f, 0.28651229f, -0.18155949f, 0.06860013f, 
    0.20214976f, -0.39944199f, -0.36871025f, 0.44083706f, -0.17921337f, -0.02842573f, 0.01823407f, 0.11759489f, 
    -0.01139728f, -0.57823336f, 0.02602209f, -0.44910255f, -0.24477653f, -0.39608842f, 0.03168977f, 0.04018069f, 
    -0.21469773f, -0.27933225f, -0.84524798f, -0.11251120f, 0.50053102f, 0.07508480f, 0.39776474f, -0.39102608f, 
    0.04056440f, 0.08682778f, -0.16507517f, -0.24319445f, 0.02134471f, -0.28739318f, 0.06223140f, 0.06120889f, 
    -0.08529902f, 0.19559737f, 0.18812744f, 0.11465144f, -0.96290576f, -0.64110750f, -0.07013642f, -0.18700439f, 
    0.37674204f, 0.01688857f, 0.02703844f, 0.23050682f, -0.36288324f, 0.03867435f, 0.16339499f, -0.28559804f, 
    -0.04145850f, 0.46551248f, 0.12886263f, 0.24308561f, -0.37388891f, 0.01658492f, -0.55075771f, 0.15411747f, 
    0.26620150f, -0.02957217f, 0.01286171f, -0.60482407f, -0.01882146f, -0.48036999f, 0.65593362f, -0.20544378f, 
    -0.80976570f, 0.02453826f, -0.68719363f, 0.14574663f, -0.45813960f, 0.20393242f, -0.44615954f, 0.00053746f, 
    0.04066159f, -0.06560297f, -0.30247068f, 0.13068043f, -0.13743669f, 0.20027871f, 0.09727176f, -0.42626014f, 
    -0.34644502f, -0.23609261f, -0.02182775f, 0.15399921f, -0.17048432f, -0.99360794f, 0.10098793f, 0.05655378f, 
    -0.42006969f, 0.26531392f, 0.03236473f, -0.36231741f, -0.35736915f, 0.06227762f, 0.06117498f, -0.56412327f, 
    0.01612545f, 0.24212180f, 0.02404906f, -0.30437046f, -0.71224743f, 0.00687136f, 0.30218068f, 0.46828505f, 
    -0.27076560f, -0.01031928f, -0.19892344f, 0.62529653f, -0.35949296f, -0.33154711f, -0.40750858f, -0.00450018f, 
    0.01940339f, 0.33345497f, 0.39039522f, -0.15815325f, 0.01929135f, -0.17566763f, 0.15912527f, -0.20842075f, 
    0.18703453f, 0.07420507f, -0.68627512f, 0.14920446f, -0.01597949f, 0.34137467f, -0.24550883f, -0.02847352f, 
    -0.90355706f, -0.10844795f, 0.14435175f, 0.26578754f, 0.10947993f, -0.04402390f, -0.32344094f, -0.08946642f, 
    -0.84101009f, -0.10939897f, 0.06814334f, -0.18139710f, -0.72978246f, -0.47403675f, -0.00108467f, 0.00175576f, 
    -0.08835366f, 0.08296397f, -0.21290268f, 0.18875818f, 0.28373638f, 0.03561449f, 0.63185811f, 0.31404886f, 
    -0.03808429f, -0.57812417f, 0.19670974f, -0.32883769f, -0.49597347f, -0.43537611f, -0.02123916f, 0.05275020f, 
    -0.09462571f, 0.11956624f, 0.03833218f, -0.62691873f, -0.31321120f, -0.21203528f, 0.03621352f, -0.74003041f, 
    -0.11281398f, 0.09099045f, -0.02991712f, 0.17207879f, -0.50918841f, 0.05033459f, -0.10371932f, 0.33658671f, 
    -0.00746025f, 0.29948807f, -0.21970332f, -0.92109573f, 0.41742027f, -0.69415551f, 0.06921776f, -0.50244874f, 
    0.51493347f, -0.18252316f, 0.01272922f, -0.50076711f, 0.25148228f, -0.96152163f, 0.02496658f, -0.01400045f, 
    -0.34452096f, 0.24155574f, -0.19040492f, -0.05695002f, -0.21430731f, 0.13813047f, -0.28340444f, -0.73533529f, 
    0.00469098f, -0.08285241f, -0.66245133f, 0.02734556f, 0.13844016f, -0.37826607f, 0.12666564f, 0.35337606f, 
    -1.04192686f, -0.09649330f, 0.07865421f, -0.03726630f, 0.23788102f, -0.21302854f, -0.75147641f, -0.23830220f, 
    -0.00941927f, -0.21004468f, 0.04324073f, -0.61403191f, 0.18934749f, -0.60325134f, 0.11234964f, 0.04322707f, 
    -0.38931996f, 0.13056934f, 0.04324618f, -0.14068539f, -0.06268257f, -0.10629760f, -0.07803520f, -0.59362632f, 
    -0.41995940f, -0.02634591f, 0.05810446f, 0.01706950f, 0.25795013f, -0.04947581f, -0.43581742f, 0.14794335f, 
    -0.12926570f, -0.05946314f, -0.52931654f, 0.08865242f, 0.08856604f, -0.01663450f, -0.07548182f, -0.17175254f, 
    0.03949859f, -0.00295555f, 0.09472600f, 0.11777678f, 0.00314695f, -0.05227529f, -0.03301681f, -0.04551566f, 
    0.07561526f, 0.24551015f, 0.58685160f, 0.07746091f, 0.00344538f, 0.02156246f, -0.42918882f, 0.05851689f, 
    0.19920674f, 0.31181526f, -0.02504838f, 0.16653880f, -0.09142416f, -0.11180502f, -0.04627245f, 0.09562352f, 
    -0.06235208f, 0.02972891f, -0.01983657f, -0.27613187f, 0.19469677f, -0.10042055f, 0.35070753f, 0.19330958f, 
    -0.09974288f, 0.04327521f, -0.03617980f, -0.51979661f, -0.01402014f, -0.04920232f, -0.06545155f, 0.30547947f, 
    -0.05840983f, -0.19812387f, 0.05982225f, -0.26843551f, 0.05589524f, -0.38065186f, -0.04072745f, -0.02248233f, 
    0.02702422f, -0.02433720f, 0.02814518f, 0.02750089f, 0.37761450f, 0.04310707f, 0.08485395f, 0.44166541f, 
    0.03183043f, -0.00079599f, 0.10955437f, -0.05677597f, -0.30535579f, 0.07174013f, -0.02658539f, -0.06692316f, 
    -0.33147857f, 0.01878682f, 0.02888057f, -0.31609711f, -0.05332697f, -0.94160712f, -0.14705363f, -0.11543667f, 
    -0.26980314f, 0.35340339f, -0.14570878f, -0.04089297f, -0.24316958f, -0.09281652f, 0.54853916f, -0.20339029f, 
    0.03689822f, -0.03092005f, -0.06892566f, -0.11518218f, -0.23224793f, -0.09461197f, 0.06271111f, -0.37264815f, 
    0.19431210f, -0.01216037f, 0.07074361f, -0.07378080f, 0.31176358f, 0.22493213f, 0.08664694f, 0.12329743f, 
    -0.09990560f, 0.06036893f, 0.04126592f, -0.54237092f, 0.00310427f, 0.49515018f, 0.24832551f, 0.24851485f, 
    0.24845998f, 0.02788008f, 0.06430119f, -0.41324005f, 0.12955415f, 0.07599849f, -0.06763754f, 0.24360400f, 
    0.09332672f, 0.00810292f, -0.14212522f, -0.02453660f, 0.09620040f, 0.25850642f, 0.11405171f, -0.21836506f, 
    0.01782126f, -0.08747684f, 0.28748879f, 0.11863246f, -0.02212685f, 0.04171525f, -0.01408440f, 0.15128545f, 
    0.00050446f, 0.01157090f, 0.03085634f, 0.14835282f, -0.08230776f, -0.07965140f, 0.21599557f, 0.05901887f, 
    -0.17405455f, 0.22337602f, -0.16672216f, -0.34476498f, 0.29829183f, 0.04672944f, 0.17255120f, -0.10881445f, 
    0.13569440f, -0.35502857f, 0.06761868f, 0.18350825f, 0.46238863f, 0.21642964f, 0.08488290f, 0.06862850f, 
    0.09675218f, 0.35558760f, 0.02845692f, 0.17714988f, -0.53629965f, 0.03516040f, -0.48828128f, 0.04133750f, 
    0.04387951f, 0.06041153f, -0.14716996f, 0.17835911f, 0.16254796f, 0.31157786f, -0.02108927f, -0.24950443f, 
    -0.01774603f, 0.12046161f, -0.01215855f, 0.22236376f, 0.32872438f, 0.20954770f, -0.05687540f, 0.12567149f, 
    -0.26861221f, -0.04501745f, 0.07576744f, -0.38642141f, -0.56129885f, 0.04676054f, 0.00413895f, -0.47537866f, 
    -0.01273130f, -0.04110473f, 0.05626933f, -0.05287208f, -0.53959084f, 0.11930171f, 0.11311875f, -0.01792935f, 
    -0.46537557f, 0.12209529f, -0.07187580f, 0.46999669f, -1.13725424f, 0.34406719f, -0.12678415f, 0.14953007f, 
    0.20563363f, -0.10089940f, -0.48039901f, 0.09589298f, -1.05678511f, -0.30713210f, -0.14403029f, 0.12642081f, 
    -0.07893308f, 0.03130072f, 0.14227962f, -0.23359510f, -0.06957800f, -0.04937574f, 0.05014811f, -0.93719864f, 
    0.37042519f, 0.30246386f, -0.03437501f, -0.19169593f, -0.06517985f, -0.15586412f, 0.06273760f, 0.07535339f, 
    0.16186148f, -0.11918599f, -0.01272088f, 0.17710976f, 0.06606796f, -0.24247509f, -0.15031564f, -0.05449546f, 
    -0.11889956f, 0.26243684f, 0.17738087f, -0.41826579f, -0.22851175f, -0.11464634f, 0.11011476f, 0.01615896f, 
    -0.37290958f, -0.02591995f, 0.13112868f, 0.17793350f, 0.25960094f, -0.22576414f, -0.87776953f, -0.71108919f, 
    0.07422073f, 0.02420343f, -0.08488442f, 0.11145664f, 0.06164074f, 0.20713861f, -0.45221391f, -0.99511057f, 
    -0.21357657f, 0.03951071f, -0.19319932f, 0.77961093f, 0.06391582f, 0.19191954f, 0.15864782f, -0.04879061f, 
    0.08298843f, 0.28013092f, -0.56414872f, 0.04790128f, -1.17683685f, 0.03164745f, 0.18327814f, -0.00349630f, 
    0.02184284f, 0.03970559f, -0.05160240f, 0.43194380f, -0.49997982f, 0.17776966f, 0.03141202f, -0.17652926f, 
    0.42636165f, -0.77295333f, 0.16410026f, -0.16288193f, -0.30261415f, -0.08627968f, -0.09287314f, 0.15853824f, 
    -0.08357097f, -0.14631365f, -0.20951758f, 0.08699186f, 0.07870556f, -0.17969963f, -0.08046682f, 0.15479216f, 
    0.04690488f, -0.14421695f, 0.04390094f, -0.41339770f, -0.77403563f, -0.39064476f, -0.00618820f, 0.11584754f, 
    -0.34360689f, 0.07990103f, 0.03474909f, 0.13755627f, -0.41277191f, -0.01306393f, 0.31423369f, 0.11050705f, 
    0.02304646f, -0.18707618f, 0.29117116f, 0.01881471f, -0.00006723f, -0.07009581f, 0.07170913f, -0.14136000f, 
    0.11716729f, 0.20773721f, -0.02316484f, 0.06689897f, -0.04387839f, 0.09097344f, -0.18439542f, -0.32906210f, 
    0.18709286f, -0.00760064f, 0.36194608f, 0.04787423f, 0.42574272f, -0.27904728f, 0.38790578f, 0.17266151f, 
    0.03041084f, 0.06789891f, 0.09235386f, -0.22232419f, 0.03344120f, -0.07012791f, 0.25370649f, -0.60513341f, 
    -0.14010875f, -0.11538468f, 0.07636163f, 0.01199774f, 0.08196568f, -0.25318006f, -0.21954517f, 0.22679609f, 
    0.13832943f, -0.41935748f, 0.23444545f, -0.19698787f, 0.06974611f, -0.30040824f, 0.18472776f, -0.01102449f, 
    0.02073749f, -0.21716957f, -0.22485401f, 0.13125981f, -0.05162043f, -0.22850314f, -0.51492882f, -0.30739009f, 
    0.38857281f, -0.03787852f, -0.06751309f, 0.36709455f, 0.09914474f, -0.85566795f, 0.47072861f, -0.09745257f, 
    0.37356031f, -0.14445415f, 0.13057540f, -0.01356641f, 0.03341367f, 0.22639203f, 0.13191243f, -0.19400364f, 
    0.06511794f, 0.07117185f, -0.34192771f, -0.39513674f, 0.03296509f, -0.06238835f, 0.06769998f, -0.00470697f, 
    -0.91211474f, -0.99754328f, 0.31168428f, 0.23895009f, 0.13782373f, -0.01964764f, 0.08786028f, -0.31692216f, 
    -0.25510433f, 0.11849819f, -0.04933950f, -0.34589073f, -0.26582703f, 0.04680555f, -0.00953369f, -0.33961210f, 
    -0.01600370f, 0.09658879f, -0.13941976f, -0.38291597f, -0.23479852f, -0.05464388f, 0.05107789f, -0.12008525f, 
    -0.00339425f, -0.42722461f, -0.00641067f, -0.20427002f, 0.00800638f, 0.07323568f, -0.05607213f, -0.06623463f, 
    -0.01159326f, -0.15012577f, -0.17934807f, -0.06404883f, 0.22335343f, 0.22044134f, 0.06389895f, -0.24794656f, 
    0.15162809f, -0.67421222f, -0.02665566f, 0.07862845f, -1.17080069f, -0.00564553f, -0.25157303f, 0.08794957f, 
    -0.04111060f, 0.28644377f, -0.88799798f, -0.41730568f, -0.31917855f, -0.21700695f, 0.12088779f, 0.17305328f, 
    0.34557125f, 0.18739954f, -0.09274790f, -0.08788786f, 0.25585026f, 0.03984524f, 0.17565238f, -0.07582295f, 
    -0.19867441f, -0.26858974f, 0.13307840f, -0.96833712f, 0.12266277f, 0.01377920f, -0.18176101f, 0.20564115f, 
    0.07133518f, -0.02537206f, -0.15218662f, -0.04747500f, -0.41434452f, -0.16026922f, -0.03679731f, 0.35959068f, 
    -0.18874207f, -0.46170703f, -0.30450615f, -0.05284734f, -0.54883879f, 0.20755728f, 0.06545482f, 0.04006792f, 
    -0.43451899f, -0.29603586f, -1.09641111f, -0.22795802f, 0.04598742f, -0.58432686f, -0.03943907f, 0.16999765f, 
    0.29640329f, -0.36470667f, -0.05782132f, 0.17163229f, 0.14078704f, 0.06089642f, -0.21790074f, -0.39547369f, 
    0.17586127f, -0.05173013f, -0.18574779f, 0.41665769f, 0.23279026f, 0.14319329f, -0.55403811f, -0.04425325f, 
    -0.88497394f, -0.62784261f, -0.17413899f, 0.01916842f, 0.05770746f, 0.09838554f, -0.41919619f, 0.05789544f, 
    -0.40577814f, 0.00321666f, 0.21572486f, -0.38677186f, 0.06967161f, -0.83002621f, -0.44219580f, -0.06957200f, 
    -0.22929969f, -0.28262660f, -0.80622506f, -0.06929091f, -0.16579501f, 0.06487766f, 0.20106940f, 0.13599636f, 
    0.20313872f, 0.39031062f, -0.00047481f, -0.12085458f, 0.35972327f, 0.18766837f, 0.05970965f, 0.09214821f, 
    -0.41941023f, -0.15375443f, 0.06191489f, 0.03912248f, -0.16443259f, -0.01143316f, -0.68071079f, -0.17477529f, 
    -0.06834964f, -0.01917646f, -0.07986236f, 0.09999973f, -0.25195566f, 0.25875571f, -0.00832221f, 0.13440987f, 
    0.07820447f, -0.17106506f, -0.32047743f, 0.18191786f, -0.34290716f, 0.18151905f, -0.02029370f, 0.21418530f, 
    0.14807545f, -0.03600448f, -0.07872460f, -0.29108340f, -0.01624543f, 0.07425816f, -0.34437302f, -0.48062190f, 
    -0.06498350f, -1.09588301f, -0.70511299f, 0.08726872f, -0.02250883f, 0.16828586f, -0.58304894f, 0.22678077f, 
    0.11926474f, -0.47755721f, -0.06565934f, 0.36676779f, -0.58525342f, -0.10582428f, -0.42481551f, -0.28781286f, 
    0.13622575f, -0.30486417f, 0.47730356f, -0.00867637f, 0.51957899f, -0.02663044f, -0.39808670f, -0.66645777f, 
    0.02466626f, 0.02669622f, 0.03250901f, 0.41240287f, 0.01557114f, 0.22326395f, -0.27483526f, -0.20853890f, 
    -0.32271540f, 0.42169002f, 0.18175951f, 0.23392138f, -0.54669124f, 0.25774536f, 0.00202582f, 0.06820744f, 
    0.03910897f, 0.33111694f, -0.81984472f, 0.03806023f, -0.66026866f, -0.01016412f, -0.65415156f, 0.20991509f, 
    -0.02323896f, -0.41211900f, 0.05136367f, -0.34459677f, 0.10495349f, 0.19901381f, -0.18240842f, -0.35244173f, 
    0.07968698f, 0.04242025f, -0.06671280f, -0.26046926f, -0.03553611f, -0.31232905f, 0.10435737f, -0.20829864f, 
    -0.07847296f, -0.25885767f, 0.11190873f, -0.12221831f, 0.04836263f, 0.09700677f, 0.01909032f, -0.03813207f, 
    -0.05977498f, 0.06598587f, -0.14803484f, -0.79348165f, 0.06489250f, -0.56037098f, 0.05771559f, 0.00942533f, 
    0.00753468f, 0.22066131f, 0.40228117f, -0.06047157f, -0.05317539f, 0.04166421f, 0.00441434f, 0.03596827f, 
    0.23572770f, -0.22399157f, 0.04254982f, -1.02907372f, 0.22804281f, -0.01995319f, -0.06457644f, 0.12884673f, 
    -0.61321223f, -0.20228839f, 0.16527438f, -0.49396428f, -0.07293925f, -0.05215326f, 0.12541251f, -0.00909246f, 
    -0.05906629f, 0.23381487f, -0.14915361f, -0.04910168f, 0.33875945f, -0.16742559f, -0.05304319f, 0.01066320f, 
    0.07213575f, -0.26736099f, -0.04207050f, 0.09855628f, 0.01630835f, 0.16064234f, 0.04954080f, -0.04393111f, 
    -0.06355841f, -0.06250706f, -0.03798255f, -0.25633204f, 0.43861243f, 0.03155640f, -0.35832268f, 0.24164480f, 
    0.05864633f, 0.04034591f, -0.03100724f, 0.05272510f, -0.12523569f, 0.28543964f, 0.06006386f, 0.11715249f, 
    -0.35162798f, 0.09088863f, -0.07231158f, 0.55546540f, -0.64604002f, 0.37390551f, -0.32551613f, -0.49966744f, 
    0.01821509f, 0.31001726f, 0.19447803f, -0.06721849f, 0.37980300f, -0.39075920f, -0.46567225f, -0.40550688f, 
    -0.03268890f, -0.04022335f, 0.00955128f, -0.04519168f, -0.22596839f, -0.02555758f, -0.03915246f, 0.08793832f, 
    0.71082985f, -0.67432106f, -0.09969366f, 0.09643454f, 0.02054863f, 0.14031726f, -0.01761279f, 0.03219002f, 
    -0.40945476f, 0.16358207f, -0.18387794f, 0.32568949f, 0.04213233f, 0.04981384f, 0.05486077f, -0.52204263f, 
    0.20410718f, 0.25495446f, 0.01282662f, 0.46928295f, 0.27115655f, 0.04039535f, 0.09956439f, 0.20499584f, 
    -0.34050480f, -0.01398130f, -1.32456779f, -0.73306054f, -0.54971617f, 0.49443305f, 0.22802232f, -0.16443251f, 
    -0.62979090f, 0.17610727f, -0.03802690f, -0.26748621f, -0.04908627f, -0.37653610f, 0.03131720f, 0.04221903f, 
    0.07463763f, -0.03484325f, 0.08263833f, 0.12739943f, 0.08289512f, 0.09693736f, -1.12826538f, -0.00408968f, 
    -0.37555882f, -0.38026860f, -0.18312702f, -0.40525684f, 0.19214310f, 0.02089665f, -0.05843325f, 0.07238207f, 
    0.02401226f, -0.58573371f, 0.02978399f, 0.20469892f, -0.05930125f, 0.08519565f, 0.04999775f, 0.16680753f, 
    -0.63821906f, 0.17539030f, -0.22468475f, 0.35913128f, 0.18190169f, -0.09244154f, -0.60030520f, 0.01464828f, 
    -0.02873142f, 0.00425969f, 0.15567319f, -0.16589691f, -1.04192972f, -0.48995230f, -0.03624918f, 0.12199048f, 
    0.07238708f, -0.04096751f, -0.26097944f, 0.62170005f, 0.34032401f, -0.31785253f, -0.04517938f, 0.32205847f, 
    -0.02801863f, 0.07868190f, -0.06444366f, 0.01006630f, -1.02312219f, 0.00854215f, 0.06470076f, -0.36246127f, 
    -0.03953229f, -0.41476956f, -0.25506437f, -0.17157416f, 0.26493761f, -0.24531011f, -0.33308658f, -0.34694171f, 
    -0.21002270f, -1.05356312f, 0.02446567f, -0.89683717f, -0.08489914f, -0.85295779f, -0.06958435f, -0.65213597f, 
    0.16194713f, -0.10531573f, 0.21294390f, 0.26293358f, -0.32457009f, 0.17052069f, -0.25813618f, -0.72333604f, 
    -0.00512424f, 0.02604308f, -0.17403755f, 0.24946287f, 0.13658608f, 0.20940636f, 0.08811214f, 0.11939994f, 
    -0.17513084f, 0.24162330f, 0.27393657f, 0.01611409f, 0.44722331f, 0.02167208f, -0.23671365f, -0.47985855f, 
    0.05800355f, 0.16194850f, -0.10267270f, 0.12485667f, -0.03887956f, -0.58214921f, -0.01537764f, -0.63072419f, 
    -0.02570786f, 0.20363626f, -0.10487344f, -0.43138182f, -0.18792500f, -0.32660148f, 0.09364583f, -0.47091219f, 
    0.25204396f, 0.03436999f, 0.42144215f, 0.03774567f, -0.11259247f, 0.08738191f, -0.20742184f, -0.17258865f, 
    0.07187797f, -0.07050101f, -0.35726357f, -0.66292703f, 0.08062585f, 0.20941126f, -0.00707296f, -0.20064838f, 
    -0.08116747f, -0.08047943f, 0.22933121f, -0.21255200f, 0.05474241f, 0.00516170f, -0.20060329f, 0.08242617f, 
    0.32544374f, -0.49760211f, -0.37829661f, 0.33766195f, 0.05563556f, -0.10575868f, 0.23385002f, -0.09366378f, 
    -0.48779356f, -0.21575829f, 0.01397403f, 0.07547043f, -0.79608339f, 0.16274178f, -0.00142223f, -0.56588066f, 
    -0.41574964f, 0.18901350f, 0.15447295f, 0.10659150f, 0.09641100f, -0.05936281f, -0.17265975f, -0.00682615f, 
    0.02018806f, -0.47279024f, 0.29310715f, -0.04276859f, -0.31905204f, -0.15467328f, -0.00594933f, -0.36690715f, 
    -0.06843983f, -0.58834577f, -0.22287530f, -0.86226207f, -0.20428364f, 0.07239775f, -0.05177908f, 0.08620553f, 
    0.24175189f, -0.21978487f, 0.05153641f, 0.16827172f, -0.09564358f, 0.06790873f, 0.30344677f, -0.04208280f, 
    0.07715343f, -0.13657461f, 0.08365736f, 0.09553510f, 0.02080944f, -0.46881685f, 0.09191419f, -0.01333372f, 
    -0.16482379f, -0.16289635f, -0.02566735f, 0.11884201f, 0.34230709f, 0.01444592f, 0.11457709f, -0.15709515f, 
    0.21466531f, -0.40305775f, 0.04469668f, -0.04924162f, 0.00175350f, 0.24163732f, 0.00931596f, 0.13312089f, 
    -0.05091930f, -0.03286778f, -0.43055713f, 0.16849250f, 0.27148432f, -0.07769892f, 0.08239058f, -0.04029818f, 
    -0.77516884f, -0.13180412f, 0.10793770f, 0.25042295f, 0.02267222f, -0.02080714f, -0.36680919f, -0.80548698f, 
    0.14750548f, -0.48874649f, 0.15853283f, -0.35304207f, -0.01797362f, -0.57960010f, 0.04663252f, 0.18414252f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.25578642f, -0.03528211f, -0.00353789f, -0.00875589f, 0.10929380f, -0.11219021f, -0.00780733f, -0.50669247f, 
    -0.14011396f, -0.10214275f, 0.21625929f, -0.13467754f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
