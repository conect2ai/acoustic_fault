#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.64634997f, 0.56620085f, -0.20197973f, -0.57054186f, 0.31653982f, -0.45854664f, -0.04443287f, 0.47951451f, 
    -0.09037140f, -0.38805890f, -0.45407489f, 0.61106139f, -0.00096032f, -0.34503642f, -0.60113358f, -0.07848246f, 
    -0.35110733f, -0.13933055f, -0.48954856f, -0.32572442f, -0.21998700f, 0.37336236f, -0.14999107f, 0.19036242f, 
    -0.16140133f, -0.26538289f, -0.24968781f, 0.49241039f, -0.54924470f, -0.01920331f, -0.57223403f, -0.52492243f, 
    -0.41833377f, 0.46434921f, -0.38891181f, 0.24446031f, -0.80835247f, 1.04777753f, 0.00151920f, -0.02186999f, 
    0.37386081f, 0.35996935f, 0.14426142f, 0.09485833f, 0.16623139f, -0.30775794f, -0.59476066f, -0.03372448f, 
    0.33195972f, 0.26276070f, -0.37641028f, 0.12309442f, -0.15313587f, -0.39224321f, 0.49152294f, 0.43850854f, 
    -0.25173137f, -0.08902907f, -0.34459254f, 0.27976966f, 0.26616251f, 0.42027184f, -0.19226250f, -0.18606496f, 
    -0.14412156f, -0.42604342f, -0.23778811f, -0.43818986f, -0.19121031f, -0.10941321f, -0.38161218f, 0.22323152f, 
    0.92252225f, 0.64615780f, -0.30363262f, -0.30667746f, -0.18339033f, -0.35455793f, 0.26132712f, -0.07351078f, 
    -0.01631608f, 0.44716623f, -0.64411926f, -0.53087145f, -0.08774439f, 0.49987170f, 0.18835615f, 0.20325145f, 
    0.44447786f, -0.01269599f, -0.19945221f, -0.12879699f, -0.29850760f, -0.07419635f, -0.16013993f, -0.33635557f, 
    -0.31052893f, -0.31564647f, -0.14835440f, 0.38676924f, -0.86295390f, 0.50689328f, -0.48831922f, -0.06245570f, 
    -0.23817711f, -0.03603103f, 0.39455169f, -0.47354805f, -0.79040730f, 0.39830151f, 0.31743279f, -0.56622797f, 
    0.11268170f, 0.68995923f, -0.11477437f, -0.07899374f, -0.16521834f, 0.64424264f, -0.38797837f, 0.07456420f, 
    0.42109844f, -0.15016282f, -0.14618385f, -0.25991973f, 0.29949644f, -0.21994847f, 0.45249563f, 0.40796503f, 
    0.02982805f, 0.50588316f, -0.64813447f, -0.04842799f, -0.32455164f, 0.07012478f, 0.29213223f, 0.11749585f, 
    0.17466034f, 0.21279037f, 0.51542252f, 0.39470467f, -0.32741451f, 0.39502326f, -0.04460791f, -0.01507503f, 
    -0.06294254f, 0.39033222f, 0.53112590f, 0.14673349f, -0.21323696f, -0.04970180f, -0.40151218f, -0.35591984f, 
    -0.19387108f, -0.25204536f, 0.13035633f, -0.71586972f, -0.15786891f, 0.35307133f, 0.27075416f, 0.35786083f, 
    0.22124465f, 0.35569388f, 0.37119442f, -0.20628303f, -0.34536004f, -0.14971694f, -0.19073147f, -0.51185948f, 
    -0.12556873f, 0.57512361f, 0.64089513f, 0.47740147f, 0.02597983f, 0.21958640f, -0.12253178f, -0.39454791f, 
    0.24111991f, -0.27091852f, 0.11741410f, 0.35232386f, -0.12186946f, 0.16823624f, 0.05831362f, -0.42085224f, 
    0.01511123f, -0.20958821f, 0.46485308f, 0.30691159f, 0.29201508f, 0.69801342f, -0.16764179f, -0.73304057f, 
    -0.38852456f, -0.15551519f, 0.94503462f, -0.37965822f, -0.41807771f, -0.17233072f, -0.42588314f, 0.16662791f, 
    0.10229485f, 0.35711411f, -0.20051065f, 0.17203327f, -0.18366542f, 0.57467246f, -0.09795211f, -0.45342344f, 
    -0.06051285f, 0.07670762f, 0.58895499f, 0.53585023f, 0.64867395f, -0.32686281f, 0.21811043f, 0.12957624f, 
    0.04510860f, 0.76878542f, -0.52758330f, -0.24426249f, -0.45852759f, -0.30597323f, -0.11343448f, -0.47177139f, 
    -0.20351523f, 0.57016957f, 0.21505417f, 0.32655150f, -0.05108314f, 0.44559434f, 0.29730654f, -0.17254356f, 
    -0.35723138f, 0.58298647f, 0.26750958f, -0.28735465f, 0.12506337f, 0.38317481f, 0.36807948f, -0.01606417f, 
    0.01719372f, -0.62980920f, -0.36883703f, 0.35835978f, 0.36903578f, -0.11300633f, -0.57045025f, -0.00076333f, 
    0.47791895f, 0.61630464f, -0.09594622f, -0.28999820f, -0.62356400f, -0.71911234f, 0.01890401f, 0.28913239f, 
    0.58653039f, 0.39398021f, -0.23144202f, -0.01454832f, 0.22452331f, -0.37814710f, -0.10490225f, 0.00705661f, 
    0.08703860f, -0.15773924f, 0.63313860f, 0.35162270f, -0.19833586f, -0.24433938f, 0.07574462f, -0.24147567f, 
    0.22729272f, 0.49193889f, -0.43403661f, 0.73425436f, 0.00699020f, 0.06370428f, -0.15495574f, 0.54688412f, 
    -0.02046308f, -0.20022751f, -0.08275630f, 0.45198041f, 0.25641260f, -0.21953058f, -0.01341349f, -0.35950899f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.24391440f, -0.24632947f, 0.21652991f, -0.27652270f, -0.06850725f, 0.17532521f, 0.34284547f, 0.08049070f, 
    -0.02480862f, -0.24062350f, -0.26801020f, 0.16521527f, 0.01237053f, 0.18568791f, -0.00766151f, -0.05849861f, 
    0.10674375f, 0.03987052f, 0.08788233f, 0.22173992f, 0.00179360f, -0.34134939f, 0.04887596f, -0.09181777f, 
    -0.26972288f, -0.20589259f, -0.11764653f, -0.05940581f, -0.03130083f, -0.03480336f, 0.07308985f, 0.17977703f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.51574343f, -0.15449518f, 0.06924181f, 0.25619265f, 0.13012570f, 0.03690561f, 0.09398094f, 0.11642452f, 
    -0.12055596f, -0.04259558f, -0.12190419f, -0.02231639f, -0.04789795f, 0.00724378f, -0.02715086f, -0.10609192f, 
    -0.02471845f, -0.01823090f, -0.04759125f, -0.18228176f, -0.18711422f, 0.01144432f, 0.01993028f, 0.03956631f, 
    0.01475239f, 0.09337837f, 0.03106450f, 0.01565824f, -0.35016978f, -0.07683109f, -0.15811297f, 0.07132298f, 
    -0.00612338f, 0.02079865f, -0.03027255f, -0.11058866f, 0.00432162f, 0.06938643f, -0.26918295f, -0.17082794f, 
    -0.00295955f, 0.07751102f, 0.15186796f, 0.13978177f, -0.06208203f, -0.10266484f, -0.19451134f, -0.25162265f, 
    -0.08384003f, 0.07095718f, -0.01803048f, 0.02542266f, 0.05780580f, 0.11890254f, 0.28498459f, -0.05453283f, 
    -0.13863397f, -0.04895127f, -0.09800925f, 0.06312852f, 0.06510828f, 0.08452726f, -0.02574492f, -0.24857992f, 
    -0.27268746f, -0.20911533f, -0.06528380f, 0.11905207f, -0.12414946f, -0.02394500f, 0.02744663f, 0.05935869f, 
    0.35115647f, -0.23700665f, -0.27972758f, -0.00429289f, 0.01312875f, -0.04007713f, 0.02462812f, 0.08605637f, 
    0.06430504f, -0.09451281f, -0.03840388f, -0.17421585f, -0.07844367f, 0.14676929f, 0.11430126f, 0.10080530f, 
    0.03911870f, -0.08121809f, -0.09330245f, -0.13458441f, -0.24884754f, -0.12471110f, -0.02613259f, -0.11923149f, 
    -0.27246210f, 0.01788760f, 0.08787757f, 0.07716496f, -0.37285775f, -0.08853096f, 0.03825076f, 0.07535935f, 
    0.13155960f, -0.03774083f, 0.03138289f, 0.17696965f, 0.21572706f, -0.00130412f, -0.08967630f, -0.04698145f, 
    0.09899873f, 0.10937616f, 0.05622697f, 0.12680158f, 0.07817002f, -0.03180615f, 0.14990829f, -0.08790899f, 
    0.10544225f, 0.13111711f, 0.19202112f, 0.06559149f, -0.04676184f, 0.07292333f, -0.11912125f, 0.08418691f, 
    0.10669852f, -0.06174837f, -0.02390763f, 0.06072857f, 0.18561396f, -0.13276461f, 0.06651644f, 0.07848846f, 
    0.07223804f, 0.02701958f, -0.16378337f, -0.01773737f, -0.00786185f, 0.05210415f, 0.09731945f, 0.01851224f, 
    0.05584235f, 0.08245871f, -0.05249357f, 0.06429796f, -0.02511654f, -0.04211774f, -0.02316807f, -0.10654592f, 
    0.10321489f, 0.01700947f, 0.08030170f, -0.22182782f, 0.07460863f, 0.09680234f, 0.00394903f, 0.12067512f, 
    -0.00967246f, -0.05336930f, 0.03335256f, 0.08708067f, 0.02835325f, 0.00470132f, 0.04079540f, -0.18228357f, 
    0.04253479f, 0.00748732f, -0.26798368f, 0.13891266f, -0.02561272f, 0.08269254f, 0.00486988f, -0.03099934f, 
    0.01783073f, 0.08366214f, -0.11264909f, 0.08456153f, 0.02265179f, -0.07206209f, -0.08335202f, -0.06940000f, 
    0.06530686f, -0.03773644f, 0.03314470f, 0.03170054f, -0.24412148f, -0.04538130f, 0.05359190f, -0.05605375f, 
    0.05315395f, -0.05980642f, 0.06678965f, -0.07052416f, 0.14024024f, 0.13961683f, -0.12132354f, 0.10980959f, 
    -0.00898948f, 0.03870255f, 0.16489679f, 0.05409552f, 0.10477506f, 0.08881103f, 0.01353380f, -0.05477284f, 
    -0.00285433f, -0.24104013f, -0.07005946f, 0.01142801f, -0.18997443f, -0.01343766f, -0.08277521f, 0.03784054f, 
    -0.37203160f, -0.15348479f, -0.22102293f, -0.12841433f, 0.14940554f, -0.01609024f, 0.08514098f, 0.01349702f, 
    0.06101926f, 0.04164373f, 0.14387177f, -0.05899588f, -0.14044867f, 0.01776323f, -0.00548107f, 0.07011352f, 
    -0.16438800f, 0.10081908f, 0.03630104f, 0.20125099f, 0.00148024f, -0.11537434f, -0.15852569f, -0.22290245f, 
    0.08486604f, -0.03577956f, 0.11758836f, 0.31980351f, -0.18598053f, -0.13320987f, 0.01890864f, 0.06975053f, 
    -0.08181712f, 0.00043758f, 0.20084372f, 0.09922643f, -0.25802001f, -0.12501277f, -0.14813977f, -0.07519112f, 
    0.19155376f, 0.05253502f, 0.05163568f, -0.00933229f, -0.00996974f, 0.00343190f, -0.08338040f, -0.10928872f, 
    0.03494103f, -0.06648226f, -0.00880197f, -0.02719235f, 0.03704658f, 0.00291764f, -0.01958508f, 0.01904777f, 
    0.07904648f, -0.01266231f, -0.05955299f, 0.09595020f, -0.04004697f, -0.11841129f, 0.07522634f, -0.05045500f, 
    0.12952131f, -0.05142318f, -0.04518981f, 0.13668019f, -0.09678446f, -0.04964538f, 0.10502592f, 0.01227525f, 
    0.09203830f, 0.19716647f, 0.19672678f, -0.12141357f, 0.11188635f, 0.11562743f, 0.14514738f, -0.07635139f, 
    0.03149487f, -0.15016878f, 0.14845300f, 0.33607140f, 0.10216927f, 0.00791175f, -0.01950779f, 0.02434387f, 
    0.14141302f, -0.18224837f, -0.12633573f, 0.03186771f, 0.05126123f, 0.05791478f, -0.03188102f, 0.19023378f, 
    -0.01473019f, 0.05575698f, 0.11824164f, 0.09039316f, -0.07374101f, 0.26475853f, -0.02846534f, 0.11568680f, 
    0.16464384f, 0.06118504f, -0.15000398f, -0.13105188f, -0.09012847f, 0.09232067f, -0.20018026f, -0.07603687f, 
    0.10154718f, -0.10282692f, 0.02663559f, 0.21333534f, 0.08468670f, -0.20903784f, 0.12082182f, 0.04962584f, 
    -0.01318322f, 0.05350212f, -0.01329096f, 0.01331496f, -0.04614442f, 0.13750167f, 0.15476066f, 0.12541994f, 
    -0.09524152f, -0.00385978f, -0.06184139f, -0.00189126f, 0.00902376f, -0.00953965f, -0.07173090f, 0.04553271f, 
    0.00933342f, 0.21161936f, 0.06932006f, 0.13260326f, 0.05876076f, 0.05862158f, -0.08597940f, 0.07051155f, 
    0.31968030f, 0.01683597f, -0.14371891f, -0.08518118f, -0.11373610f, 0.08772693f, 0.12413911f, -0.16030765f, 
    -0.01886491f, -0.29348633f, -0.22833064f, 0.24643084f, -0.14229828f, 0.01178420f, -0.16531178f, 0.10264891f, 
    0.07855061f, 0.00001889f, -0.02607257f, 0.04338148f, 0.23394138f, 0.03406442f, 0.08057267f, 0.01382872f, 
    0.08287949f, 0.04337736f, 0.05151181f, 0.14674191f, 0.04563979f, 0.16441871f, 0.11882826f, 0.14355770f, 
    0.17184620f, 0.06810093f, 0.16323875f, 0.10532624f, 0.20441441f, 0.03498017f, -0.20096593f, 0.12981026f, 
    -0.06966116f, -0.14615701f, 0.14934000f, 0.12947170f, 0.03739958f, -0.15875272f, 0.01395831f, 0.07904921f, 
    -0.04625085f, 0.26244932f, -0.04773720f, 0.08033919f, -0.08486697f, 0.18390226f, 0.26670647f, 0.04475136f, 
    0.09081003f, -0.25327030f, 0.13244790f, -0.15682709f, 0.03298734f, 0.05630551f, -0.02484290f, 0.05019854f, 
    0.02936070f, 0.27010703f, 0.25755557f, 0.12194517f, -0.01993918f, -0.08085534f, -0.04468519f, 0.13614617f, 
    0.07874767f, 0.03253062f, -0.00425121f, -0.13147660f, 0.07277723f, -0.01492945f, -0.00434865f, 0.19388938f, 
    0.06972408f, -0.18412445f, 0.00815751f, 0.27307808f, -0.16999283f, 0.09360998f, -0.05180658f, -0.07100322f, 
    0.04282833f, -0.07482021f, -0.01956873f, 0.25471175f, 0.24968846f, -0.01954788f, 0.03144821f, 0.02478441f, 
    0.01593931f, -0.07950781f, -0.31603798f, 0.00373485f, 0.03633016f, -0.13769063f, -0.01911951f, 0.06803466f, 
    -0.02132907f, 0.11852791f, -0.02913476f, -0.12813641f, -0.10106639f, -0.07662086f, 0.02434595f, -0.13335963f, 
    -0.10950834f, -0.09878965f, -0.16114721f, -0.22046460f, -0.32203707f, -0.12340670f, -0.12478635f, -0.11972347f, 
    -0.11437390f, 0.04688037f, -0.03024460f, 0.11370433f, 0.04057546f, 0.01932439f, -0.04762936f, -0.03528183f, 
    -0.20351386f, 0.07331017f, 0.01677039f, 0.01995398f, -0.06339716f, 0.08470604f, 0.23999606f, -0.27388382f, 
    -0.15382411f, -0.18691698f, -0.09850603f, 0.02681036f, 0.04578380f, -0.06274907f, 0.10110360f, -0.01804563f, 
    0.28981414f, 0.09172504f, 0.07053886f, 0.17468998f, 0.15991253f, -0.08904845f, 0.05097311f, 0.07329091f, 
    0.17911258f, -0.05758515f, 0.06706022f, -0.02516507f, -0.17868477f, 0.11472622f, -0.16043572f, 0.16452640f, 
    -0.00800785f, -0.09151953f, -0.03409990f, -0.08600362f, -0.29032066f, -0.00455714f, 0.09739929f, -0.09586053f, 
    0.11376739f, 0.01148837f, -0.00253798f, 0.02595139f, 0.07757339f, -0.18140391f, 0.10574055f, -0.05222970f, 
    0.11084572f, -0.01888502f, 0.10883694f, 0.07753892f, -0.40256959f, -0.24506891f, -0.04236316f, -0.04213282f, 
    0.02640838f, -0.00822849f, -0.02376192f, 0.03537650f, -0.12090159f, -0.21565264f, -0.02223533f, 0.01609174f, 
    0.03863502f, 0.12382893f, -0.02747192f, -0.03630958f, 0.09202702f, 0.16845424f, -0.18808238f, -0.06365754f, 
    -0.13628367f, 0.06304771f, -0.06345695f, 0.06779520f, 0.02194739f, 0.18916428f, 0.24557664f, -0.24744289f, 
    -0.13234733f, -0.10851714f, 0.07476389f, 0.15404993f, 0.13865936f, 0.22776005f, 0.04224690f, 0.11112020f, 
    -0.60548413f, -0.27959025f, -0.10909466f, 0.18584418f, 0.02289129f, -0.27355477f, 0.11485548f, 0.07314048f, 
    0.13150986f, -0.19844306f, -0.12653106f, 0.10744326f, 0.22256020f, -0.02515007f, -0.08085181f, -0.02982811f, 
    -0.03649019f, -0.04834095f, -0.05747235f, 0.06856749f, 0.07666580f, -0.15230085f, 0.03771817f, 0.01167612f, 
    -0.05294862f, 0.06194602f, 0.17768723f, 0.02808738f, -0.15822585f, -0.11147413f, 0.05436237f, -0.20318834f, 
    -0.19417337f, -0.08553862f, -0.15090899f, -0.13339858f, -0.04692356f, -0.00343693f, -0.03192494f, 0.13843882f, 
    -0.00951670f, 0.01077529f, 0.08500536f, 0.17397106f, -0.15052128f, -0.22214149f, 0.05501190f, 0.05241369f, 
    -0.05520556f, -0.01588081f, 0.09533782f, -0.03698949f, 0.03172421f, 0.19223961f, 0.27508587f, 0.03408594f, 
    -0.10102238f, 0.04498474f, 0.02985944f, 0.20175551f, 0.11016040f, 0.13841920f, -0.07385754f, -0.07182071f, 
    -0.00836360f, 0.01897850f, 0.09756549f, -0.03327789f, -0.01159525f, -0.00946273f, -0.07067764f, 0.03341402f, 
    0.48385432f, -0.33785018f, -0.29382125f, -0.11516793f, -0.03391909f, 0.06087936f, 0.09463615f, 0.03115931f, 
    0.02061858f, -0.17139941f, 0.09098036f, 0.27388033f, -0.09201463f, -0.03341733f, 0.01774981f, 0.08744672f, 
    0.02785527f, -0.04318378f, -0.10778192f, -0.02183696f, 0.06547061f, -0.03153500f, -0.02250946f, 0.12289599f, 
    -0.05208666f, 0.04847870f, -0.00345339f, 0.06566467f, -0.37105688f, -0.15289406f, 0.11932898f, -0.12116305f, 
    0.02832355f, -0.02353264f, -0.06497559f, -0.00676651f, -0.02185868f, -0.02299356f, -0.10229822f, 0.07358550f, 
    0.03595920f, 0.00362940f, -0.04656185f, 0.10999055f, 0.08113428f, 0.09632929f, 0.02938528f, 0.01768547f, 
    0.03866800f, -0.01018853f, 0.08256219f, 0.09408323f, -0.05187656f, -0.07246194f, 0.12332987f, 0.06788727f, 
    0.18345341f, -0.06660659f, -0.05921422f, -0.01623341f, 0.21548991f, 0.02521718f, -0.12261841f, 0.04565657f, 
    0.02729476f, 0.11694469f, 0.10674733f, 0.04543130f, -0.00260868f, -0.01690419f, 0.11028145f, 0.05076234f, 
    -0.08633069f, -0.03087289f, -0.03190961f, 0.09680390f, 0.07701814f, -0.15012780f, -0.01121335f, 0.06147230f, 
    0.16849950f, 0.03552199f, 0.20559886f, 0.00789764f, 0.00791326f, -0.09603020f, 0.00372418f, 0.07514780f, 
    0.09316858f, -0.08565558f, 0.08285804f, 0.18217893f, -0.35916981f, -0.03092485f, -0.04540949f, 0.06895979f, 
    -0.09077370f, -0.13995762f, -0.11964402f, 0.14535086f, 0.04942638f, -0.06686892f, 0.01828926f, 0.05469593f, 
    0.09783196f, 0.11059937f, 0.02652338f, -0.07876933f, 0.00236305f, 0.00334717f, -0.24733080f, -0.06043402f, 
    0.04693284f, -0.07081266f, -0.05024506f, 0.00432468f, -0.20906070f, 0.09343596f, -0.18935582f, 0.03568900f, 
    -0.17370601f, -0.02123774f, 0.08239654f, -0.02955057f, 0.09004603f, 0.12457941f, -0.07513627f, 0.08537865f, 
    -0.20247845f, 0.14479671f, -0.05284736f, 0.03451256f, 0.09632848f, -0.02461030f, -0.05948323f, -0.00465005f, 
    0.26922315f, -0.10658922f, -0.03714568f, -0.06884609f, -0.03559503f, -0.07621700f, 0.07842465f, -0.01095713f, 
    -0.03004250f, -0.41081205f, -0.16928168f, 0.02686212f, -0.10917708f, -0.08053795f, 0.04113884f, -0.10651115f, 
    0.06051569f, 0.11582609f, 0.05902780f, 0.02680750f, -0.09454356f, 0.10024452f, -0.07030229f, 0.14852193f, 
    0.09484800f, -0.16104619f, 0.05094890f, 0.07313680f, -0.05984905f, 0.01250293f, -0.02740894f, -0.07973702f, 
    -0.11023510f, -0.11168122f, 0.14720814f, 0.20317712f, -0.22783121f, -0.14345196f, -0.02655165f, -0.06485349f, 
    0.02638453f, 0.02410988f, 0.14082706f, 0.12742142f, -0.13018456f, 0.06674563f, 0.22570822f, -0.01487570f, 
    0.03817908f, -0.01609366f, -0.18363640f, 0.03432375f, 0.07722598f, 0.07639123f, 0.14834043f, 0.16663414f, 
    -0.12413388f, -0.01157727f, 0.00862458f, 0.01051920f, -0.07154126f, 0.17364103f, 0.16248338f, 0.25615337f, 
    0.01473512f, -0.01978383f, 0.00318935f, 0.15484014f, 0.09344353f, -0.02378407f, -0.14256179f, 0.01980270f, 
    -0.06312793f, -0.01050611f, 0.01408240f, 0.19929504f, -0.01607827f, 0.01983969f, 0.06176312f, 0.11486376f, 
    0.00043441f, 0.01045475f, 0.04844319f, -0.00577347f, -0.03728809f, 0.00318099f, 0.00404148f, 0.00638402f, 
    -0.01067007f, -0.04902850f, 0.04189627f, -0.05963629f, -0.01880369f, -0.02404287f, -0.04622947f, -0.06772852f, 
    -0.03916388f, -0.05983854f, 0.01319442f, -0.02154975f, -0.01197269f, -0.02425144f, -0.01310873f, 0.04368404f, 
    -0.06520513f, -0.04755223f, 0.00669414f, -0.06624587f, 0.04125591f, 0.00217494f, 0.02820411f, -0.00446180f, 
    0.00139819f, 0.03650374f, -0.03890570f, 0.02509014f, 0.00677298f, 0.02308133f, -0.01206032f, -0.04104674f, 
    -0.02822545f, 0.03455147f, -0.02155316f, 0.04935414f, 0.02386914f, -0.00554708f, -0.01727212f, 0.03836594f, 
    -0.00536593f, -0.01684406f, -0.06861656f, 0.00794805f, -0.04133996f, 0.03071252f, -0.04346201f, -0.03319183f, 
    0.01934247f, 0.03796904f, -0.03522857f, 0.02312599f, 0.03091491f, -0.04397586f, -0.04917383f, -0.03246900f, 
    -0.00337087f, -0.03975759f, -0.05601570f, -0.01571811f, 0.01357831f, -0.01857773f, 0.01969332f, 0.01382207f, 
    0.01888631f, -0.06416269f, -0.02035025f, 0.02188580f, -0.01949552f, 0.00682002f, 0.00552344f, 0.01200540f, 
    -0.02643778f, 0.04954740f, 0.02906917f, -0.00939065f, 0.03805529f, -0.00967002f, -0.02380109f, 0.04220735f, 
    0.02078326f, 0.02843579f, -0.04300667f, -0.03124774f, 0.01043465f, -0.01189202f, -0.01017282f, -0.04573980f, 
    0.02641452f, -0.05566562f, -0.04388814f, -0.03013589f, -0.02611446f, 0.01682883f, 0.05229143f, 0.04859625f, 
    -0.03722212f, -0.05788352f, -0.04726515f, 0.02750856f, -0.00778150f, 0.03298250f, -0.05180796f, -0.04412374f, 
    -0.01352284f, -0.06448860f, -0.00350373f, -0.03450098f, -0.04061247f, -0.00702531f, -0.04119364f, -0.05129789f, 
    -0.06034236f, 0.01251339f, -0.04647104f, 0.04812270f, -0.06781686f, -0.03444764f, -0.00705193f, 0.01373098f, 
    -0.02600460f, 0.01866639f, -0.05870144f, 0.01649841f, -0.02682665f, -0.05228901f, -0.05240452f, -0.03607799f, 
    0.00513913f, 0.04334806f, -0.03378724f, -0.03662563f, -0.00806692f, -0.03411338f, 0.04312906f, -0.01431380f, 
    0.03475370f, -0.03981737f, 0.05077324f, 0.03963511f, -0.02297728f, -0.04284084f, 0.00251217f, 0.02571470f, 
    0.01588195f, -0.03977973f, 0.03605125f, -0.03707173f, -0.06260657f, -0.01763541f, -0.01560285f, -0.04056402f, 
    0.03756325f, -0.00187431f, -0.06106146f, -0.01031614f, 0.02439303f, 0.04211155f, -0.00382249f, -0.03889599f, 
    -0.05583373f, -0.04415334f, -0.05604773f, -0.01566554f, 0.04410199f, 0.02353734f, -0.03442214f, -0.02786133f, 
    0.04830470f, 0.00104161f, 0.02812533f, 0.04535937f, -0.05660610f, -0.01187426f, -0.06012510f, -0.06269793f, 
    -0.02928579f, 0.04479586f, 0.01060729f, 0.00097675f, -0.04247845f, 0.02629896f, 0.02386302f, 0.02017943f, 
    0.01995611f, 0.03071723f, -0.03801261f, -0.06072723f, -0.00583765f, -0.06328366f, -0.01554620f, -0.04405028f, 
    0.00976535f, 0.04837092f, -0.04645520f, -0.04417782f, -0.05305137f, -0.00682237f, -0.00836394f, 0.04479391f, 
    -0.02428453f, -0.01211383f, -0.00395030f, 0.03582461f, -0.03514382f, 0.00657455f, -0.04810530f, -0.05812407f, 
    -0.05704067f, 0.00842060f, -0.03526769f, 0.02059583f, -0.03506948f, 0.03268555f, -0.00940274f, -0.01390865f, 
    0.02297869f, 0.02762585f, -0.03768178f, -0.03495666f, -0.02127132f, -0.04172401f, -0.00978133f, 0.02709186f, 
    0.01162245f, -0.03918605f, -0.01983372f, -0.03942143f, -0.04668760f, -0.06447453f, -0.05831209f, 0.05006273f, 
    -0.01166337f, 0.04878420f, 0.00191750f, 0.00598447f, -0.03737559f, 0.00990449f, 0.03473821f, 0.02037485f, 
    0.02992053f, -0.00594474f, 0.04178916f, -0.01237545f, -0.06179209f, -0.01971820f, 0.03384810f, -0.00927260f, 
    -0.01754426f, -0.04054046f, -0.02882129f, 0.04599100f, -0.05288095f, 0.01225874f, -0.04060055f, -0.00999374f, 
    -0.00284649f, 0.03325969f, 0.04818596f, 0.00451841f, 0.02438553f, -0.03214789f, -0.00088473f, 0.04282726f, 
    0.04558659f, 0.04738267f, -0.00269844f, 0.03878297f, 0.00470377f, 0.03080525f, -0.03475950f, 0.00391352f, 
    0.00074115f, 0.04371004f, 0.03280476f, 0.02641968f, 0.02284952f, 0.04036749f, 0.01609170f, -0.02844072f, 
    0.17965350f, 0.25270870f, 0.23086517f, 0.07829194f, 0.30664489f, -0.07599749f, 0.01019483f, 0.12078565f, 
    -0.09755830f, -0.09118500f, 0.11580590f, 0.14799862f, 0.01406084f, 0.07852657f, -0.22052456f, -0.02436947f, 
    -0.02582084f, 0.13371249f, -0.05687640f, 0.04739112f, 0.18480706f, -0.04717295f, -0.02253262f, 0.12519109f, 
    -0.04099353f, 0.02488650f, 0.03722789f, -0.01941359f, -0.22954559f, 0.26337096f, -0.15899004f, -0.00334502f, 
    0.23674680f, -0.02242993f, -0.09240202f, 0.14089943f, 0.04966759f, 0.03676256f, -0.09649332f, -0.05798455f, 
    0.03484912f, -0.18551318f, 0.03640510f, 0.18950324f, 0.12127484f, -0.00653276f, 0.04206580f, 0.10053426f, 
    0.00394548f, 0.00778149f, -0.00987316f, 0.09420460f, -0.05998043f, 0.03334593f, -0.10720985f, 0.10707610f, 
    -0.13305603f, 0.08673712f, 0.04010166f, -0.12021046f, 0.12739635f, 0.11556929f, 0.03957918f, -0.13150258f, 
    -0.02644946f, 0.07183283f, 0.01462363f, -0.02959816f, 0.08046412f, 0.05634682f, 0.00147806f, 0.23599400f, 
    -0.21578838f, -0.00098719f, 0.10909800f, 0.05847519f, 0.03496259f, 0.04534530f, 0.06290717f, -0.04981269f, 
    0.02446872f, -0.18230921f, 0.13833988f, 0.05549377f, 0.02818902f, -0.09358250f, -0.00115109f, -0.06605640f, 
    0.08166852f, 0.07126010f, -0.02961648f, -0.09607710f, 0.20792674f, -0.07448160f, -0.07841865f, -0.12646435f, 
    0.15623379f, 0.11919315f, 0.02254941f, 0.05181928f, -0.01740274f, 0.13972051f, -0.11779434f, 0.18246733f, 
    0.01264363f, 0.05238248f, 0.20881312f, 0.04465003f, 0.08914483f, -0.13774362f, -0.05986397f, -0.01450823f, 
    -0.15103891f, -0.02708126f, 0.05877108f, 0.02645546f, 0.15267603f, -0.07453636f, 0.09276533f, 0.08747104f, 
    -0.19460455f, 0.04060731f, -0.06581492f, 0.05336431f, 0.03627822f, 0.20372145f, -0.29448014f, -0.10974899f, 
    0.03154408f, 0.07141063f, -0.00298907f, -0.08084595f, 0.02312406f, 0.16007552f, 0.13924281f, 0.04442625f, 
    -0.05689233f, 0.01387777f, 0.03185688f, 0.00753302f, -0.03299740f, 0.00966504f, 0.08783563f, 0.01043721f, 
    -0.07095389f, -0.06994984f, -0.11915108f, -0.05131742f, -0.00087164f, -0.01457789f, 0.05261531f, -0.06085023f, 
    0.01333200f, -0.13376682f, -0.02825117f, 0.04549735f, 0.03052185f, 0.01047144f, -0.10509224f, 0.04875462f, 
    0.13558045f, 0.12571006f, 0.08106176f, -0.08300962f, 0.18859984f, 0.02225416f, 0.08044375f, 0.17140555f, 
    0.08485076f, 0.21748367f, 0.15558811f, -0.12866883f, -0.08029509f, -0.04679467f, -0.08373947f, 0.08036131f, 
    0.16722517f, 0.05943183f, -0.00120968f, 0.21085213f, -0.11906352f, -0.18399943f, -0.17403771f, 0.00056169f, 
    0.21892625f, -0.07618739f, 0.19541723f, 0.25555018f, -0.05244753f, -0.18523911f, -0.09946021f, 0.06172327f, 
    0.04020325f, -0.12946191f, 0.13670436f, 0.04908003f, -0.06216728f, -0.00302456f, 0.14307082f, 0.05611454f, 
    -0.10690060f, 0.21007185f, 0.02150678f, -0.01826529f, 0.03589682f, 0.07912508f, 0.04498665f, -0.19518581f, 
    -0.08286306f, 0.04153229f, 0.03725682f, 0.00208539f, 0.03499698f, -0.04221058f, 0.01115284f, -0.01004479f, 
    -0.09512424f, -0.23152348f, 0.17918421f, 0.08100891f, -0.03024216f, -0.13843071f, 0.15304570f, -0.04101635f, 
    0.04072440f, -0.26348066f, -0.07162432f, -0.18098478f, -0.06341071f, -0.17008384f, -0.00183225f, 0.05981898f, 
    0.17521524f, 0.11467240f, -0.12345748f, -0.05965856f, 0.15864415f, -0.09056688f, 0.05821448f, -0.11876073f, 
    -0.00929467f, -0.16114381f, -0.19753860f, -0.06569933f, 0.10975892f, 0.08085823f, 0.16309492f, 0.06128474f, 
    0.05976339f, 0.20358293f, -0.10479873f, 0.02421238f, -0.23724332f, -0.10499378f, 0.20708905f, 0.10048630f, 
    0.05621013f, -0.02066883f, -0.08404068f, -0.06904185f, -0.01938636f, -0.22765911f, 0.12651211f, 0.20117615f, 
    0.04855317f, 0.04206900f, 0.14881609f, -0.09866245f, -0.16737199f, 0.09959140f, -0.23864923f, -0.02158363f, 
    -0.11630065f, 0.03296211f, -0.00591347f, 0.01338384f, -0.09708185f, 0.05710255f, 0.16965854f, -0.02046801f, 
    0.04333250f, 0.01960768f, 0.05741859f, 0.11335423f, 0.06455971f, 0.03092127f, -0.00091579f, -0.12929997f, 
    -0.23112923f, 0.32127962f, 0.22838882f, 0.01585279f, 0.25481746f, 0.18138067f, -0.08482498f, 0.17083099f, 
    -0.11201733f, -0.23078291f, -0.23403201f, 0.05181482f, -0.04859497f, 0.05018233f, 0.00721711f, 0.02472100f, 
    -0.08035097f, -0.10313166f, -0.27950206f, 0.11789308f, -0.00597340f, -0.01146452f, 0.04209692f, -0.04530291f, 
    0.07401808f, -0.03345053f, -0.03523047f, 0.02639642f, -0.16585003f, 0.37478614f, -0.15567875f, -0.10842363f, 
    0.23470595f, -0.00902728f, -0.08771763f, -0.12232600f, -0.21005872f, 0.28890491f, 0.01292611f, -0.01641523f, 
    0.16920301f, 0.05077390f, -0.09758863f, 0.03924679f, -0.05730006f, -0.14159539f, -0.08174507f, 0.00110334f, 
    -0.06295262f, -0.11590129f, 0.09378684f, 0.00258718f, -0.02132980f, -0.09539578f, -0.20069006f, -0.02422103f, 
    -0.12070282f, 0.00326069f, 0.08105314f, -0.01436748f, -0.01233913f, 0.13679811f, 0.01610563f, 0.05122649f, 
    0.17153282f, 0.18274878f, -0.05175745f, 0.01072679f, 0.00947688f, 0.07672333f, -0.05308226f, 0.02873679f, 
    -0.08581206f, -0.46622154f, -0.00127731f, 0.09785116f, 0.10807692f, -0.08193459f, 0.07983418f, 0.01960388f, 
    0.17132115f, 0.03837221f, 0.20225172f, -0.05955514f, -0.20106255f, -0.30669722f, 0.00922351f, 0.05526438f, 
    0.08162486f, 0.01723663f, -0.02606380f, 0.15000676f, 0.06593419f, 0.02604315f, 0.01497392f, -0.06296810f, 
    0.11545004f, 0.06202505f, 0.19858064f, -0.02888658f, 0.31810889f, 0.25987974f, -0.10681476f, 0.02364586f, 
    0.15821619f, -0.01929450f, 0.09909674f, -0.21546425f, -0.66421187f, 0.17596079f, -0.15346490f, -0.11025379f, 
    -0.11815424f, 0.00994555f, -0.01999525f, -0.07426174f, 0.04135988f, 0.05777039f, -0.00117848f, 0.13796417f, 
    -0.12218889f, -0.16559955f, 0.14668953f, -0.09086140f, 0.09443561f, -0.10985533f, -0.09521440f, -0.48804697f, 
    0.19059864f, -0.17517458f, 0.02397522f, -0.01913392f, -0.02672411f, -0.03134942f, 0.14277059f, 0.03929118f, 
    0.08338745f, 0.17433503f, -0.13954027f, -0.17629670f, -0.08997362f, 0.06757905f, -0.13622634f, -0.02115585f, 
    -0.13027000f, -0.29268584f, 0.12110728f, 0.04209737f, -0.00405574f, -0.04506055f, 0.00139058f, -0.08640061f, 
    -0.06776433f, -0.00351372f, 0.27243963f, 0.09488644f, 0.01961610f, -0.16189058f, 0.07076468f, 0.03333323f, 
    -0.05692865f, -0.03456419f, 0.04934716f, -0.00175000f, -0.23906788f, 0.05737524f, 0.14653359f, 0.01379181f, 
    0.04319357f, -0.05732481f, 0.03247733f, -0.13532323f, -0.20355050f, -0.12318284f, -0.13477902f, -0.07727157f, 
    0.07088345f, -0.10666557f, -0.10894391f, 0.06786261f, -0.03991606f, 0.15087271f, -0.03502173f, -0.00244692f, 
    0.05916946f, 0.05071607f, 0.10645498f, 0.07990255f, 0.01224257f, -0.30868697f, -0.03812550f, -0.32436210f, 
    0.19480617f, 0.07060650f, 0.04349246f, 0.02218792f, -0.12517244f, 0.31605715f, -0.01690872f, 0.14443563f, 
    0.08995381f, -0.08702940f, 0.05757143f, 0.02929895f, 0.06342200f, 0.11265952f, -0.27483383f, -0.04351886f, 
    0.25678959f, 0.12060869f, -0.13557230f, -0.11494765f, -0.17941977f, 0.13701357f, 0.09326760f, -0.05348945f, 
    0.22477594f, -0.07168998f, 0.16102633f, 0.10983358f, 0.25400040f, -0.23199980f, 0.16270484f, 0.03773645f, 
    0.27184650f, -0.07147715f, 0.11774830f, 0.08796102f, -0.18497068f, -0.09863172f, 0.02846874f, -0.07860377f, 
    -0.04140193f, 0.07992756f, -0.11387541f, 0.06338108f, -0.11367597f, -0.05781826f, 0.02211082f, 0.21105938f, 
    0.00122729f, -0.07594386f, -0.14617258f, -0.32186502f, -0.01733151f, -0.03815294f, -0.11261879f, 0.31176120f, 
    0.07172973f, -0.07643297f, -0.06978476f, 0.13955252f, -0.33740857f, 0.09381219f, -0.21848200f, -0.06324045f, 
    -0.09748806f, -0.00461466f, 0.09843096f, 0.06455389f, 0.02970878f, -0.16924958f, 0.36656198f, -0.00301706f, 
    -0.29805174f, -0.12558785f, -0.17774230f, 0.13151421f, -0.13374294f, 0.04386934f, -0.10482150f, 0.38925150f, 
    0.42344108f, -0.24776922f, -0.16347022f, -0.25308126f, 0.08087001f, -0.13905568f, -0.19274317f, -0.06386268f, 
    0.12349289f, -0.10725717f, 0.10980416f, -0.10969587f, 0.11421650f, -0.01569690f, 0.04752267f, 0.04731943f, 
    -0.09203504f, -0.03373396f, 0.14640108f, 0.16141249f, 0.00977282f, 0.00499677f, 0.32568133f, 0.06651153f, 
    0.09292981f, -0.18893133f, -0.13183562f, -0.11450776f, 0.08911018f, -0.03756317f, 0.06924874f, 0.09845048f, 
    -0.09639149f, 0.02383679f, -0.15860349f, -0.00444902f, -0.08325376f, -0.03323464f, -0.03205398f, -0.02418339f, 
    -0.09212703f, -0.14026386f, -0.13530517f, -0.22727282f, 0.09570747f, -0.30547488f, 0.13881816f, -0.03902739f, 
    -0.13894854f, 0.02212805f, 0.12886825f, 0.17855358f, 0.15382454f, 0.00164657f, 0.04585195f, 0.22169547f, 
    -0.11146133f, 0.02768234f, 0.08196490f, -0.04363530f, -0.02831122f, -0.12796620f, 0.02045707f, -0.01659990f, 
    -0.01298578f, 0.06098381f, 0.03352155f, -0.07147526f, -0.17557819f, 0.04782707f, 0.27903780f, 0.00320216f, 
    0.09055135f, -0.05430072f, 0.02000079f, 0.18329787f, -0.10047149f, 0.06843443f, 0.22311929f, -0.10854132f, 
    -0.14999738f, -0.06497446f, 0.11853620f, 0.01498824f, -0.01175975f, 0.13674393f, 0.07821972f, 0.05909864f, 
    -0.08240794f, -0.10008415f, -0.08428189f, -0.03119048f, 0.04439069f, -0.09950907f, -0.02614348f, 0.06568205f, 
    0.09074742f, -0.00943184f, 0.01752488f, 0.00162743f, -0.06364395f, 0.12719722f, 0.08408915f, 0.08027927f, 
    -0.15636982f, 0.02594734f, -0.12906113f, -0.31190664f, -0.10060186f, -0.00516420f, 0.03264208f, 0.05945205f, 
    0.08281025f, -0.16906413f, -0.11996764f, 0.20962667f, -0.03211898f, -0.05427137f, 0.16975138f, 0.04485073f, 
    0.06370778f, 0.02947010f, -0.02841728f, 0.11008456f, 0.25596824f, -0.05323059f, -0.00038081f, -0.02088919f, 
    -0.18179756f, 0.07185052f, -0.10732070f, -0.02830704f, 0.02344807f, -0.03482570f, 0.11379953f, -0.03978539f, 
    -0.14615633f, 0.17375454f, 0.02359321f, 0.04225875f, -0.05565607f, 0.10940801f, -0.05479423f, 0.00375929f, 
    0.21602537f, -0.07088019f, 0.07519200f, -0.17932887f, 0.20409611f, 0.03544697f, 0.13287093f, -0.07583759f, 
    -0.00860359f, 0.17274663f, 0.07544469f, -0.12268621f, -0.08766898f, -0.09636018f, 0.07813122f, 0.09267411f, 
    0.02663490f, 0.07444972f, -0.05405094f, -0.01339602f, -0.12568121f, -0.01215414f, 0.02143629f, -0.05625791f, 
    -0.11112531f, -0.08067261f, 0.02481628f, -0.02051144f, 0.07518681f, 0.07860927f, -0.09889091f, 0.10217191f, 
    0.02318764f, 0.09532672f, -0.03191245f, -0.27924189f, -0.06681611f, 0.00482049f, 0.01341630f, -0.10403857f, 
    0.26262891f, -0.03148252f, 0.30488744f, 0.08669782f, 0.00188088f, 0.17254384f, -0.00529776f, 0.25801310f, 
    -0.00308150f, 0.10137562f, -0.00124286f, 0.10328815f, 0.02279801f, -0.17118935f, -0.05017730f, 0.01113744f, 
    -0.02110620f, 0.00328908f, 0.11198386f, 0.29756841f, 0.25254279f, 0.02446233f, 0.19584446f, -0.01944419f, 
    0.05163774f, 0.02162778f, -0.12539081f, -0.13932590f, 0.00862167f, -0.11310918f, -0.05548544f, 0.06935256f, 
    0.19512892f, 0.15780151f, 0.03608598f, 0.00311611f, 0.00873004f, 0.10580428f, 0.16221596f, -0.06437054f, 
    -0.06876043f, 0.04924701f, 0.08488585f, 0.13390745f, 0.03935809f, -0.07159651f, 0.01804295f, 0.06010455f, 
    -0.43635619f, -0.16855715f, -0.34036893f, 0.10469685f, 0.12923093f, 0.02459054f, 0.20258892f, 0.01208847f, 
    -0.06145217f, 0.07307485f, 0.15799418f, 0.14193861f, -0.08106444f, -0.07199382f, -0.11463179f, -0.08688107f, 
    0.04109456f, -0.17437743f, 0.04433039f, 0.17820664f, -0.12376182f, -0.08796848f, 0.03345037f, 0.09148624f, 
    0.02676674f, -0.15136316f, -0.21128708f, 0.33724555f, 0.06804500f, 0.04486736f, -0.13722748f, -0.06595079f, 
    0.10788459f, -0.19568066f, 0.07369698f, 0.04078732f, -0.10937327f, -0.08713812f, 0.08515045f, 0.06191166f, 
    0.05939131f, -0.08435459f, -0.03926214f, -0.05091678f, -0.03181700f, -0.09382730f, -0.14197752f, -0.05882310f, 
    -0.19830334f, 0.07559559f, 0.05735904f, -0.22975454f, -0.05624171f, 0.03855742f, 0.00798479f, 0.07710472f, 
    -0.05307825f, 0.00324131f, -0.07583689f, 0.15815356f, -0.05494165f, -0.02854268f, -0.07726011f, -0.11836548f, 
    0.18460183f, -0.04187506f, -0.11406960f, 0.06843860f, 0.04171690f, -0.06535706f, -0.13286352f, -0.11579721f, 
    -0.12561229f, -0.16173157f, -0.03578597f, -0.16239120f, -0.03031957f, -0.16412140f, 0.06008258f, 0.04525824f, 
    -0.15794164f, 0.26409391f, -0.03810689f, -0.03942804f, 0.07397279f, -0.17557526f, -0.00319864f, 0.00443215f, 
    0.01460363f, 0.20702147f, 0.00744015f, 0.07329540f, 0.08453541f, 0.02526425f, -0.00438796f, 0.12496091f, 
    0.10942242f, 0.02259232f, -0.01151200f, 0.02741892f, 0.19375643f, -0.09373410f, -0.14255929f, -0.08585300f, 
    -0.16723858f, 0.11391253f, 0.00451668f, 0.02557082f, -0.41901422f, -0.23790690f, -0.34599805f, 0.00872089f, 
    -0.03943720f, 0.05662851f, -0.02247927f, 0.04185786f, -0.02193644f, 0.25696409f, -0.09610820f, 0.15891586f, 
    0.00688007f, 0.02136665f, 0.16789725f, 0.14001560f, 0.15565644f, -0.09139259f, 0.09965959f, -0.18438852f, 
    0.26161131f, 0.03215874f, 0.16493262f, 0.10796131f, 0.02356635f, 0.01118100f, 0.06418683f, -0.04489490f, 
    0.16897503f, 0.06822307f, 0.01515976f, 0.04118748f, 0.18009795f, -0.02391986f, 0.07802319f, 0.14555860f, 
    0.02330295f, 0.01285900f, 0.04654301f, -0.01418657f, -0.04971405f, 0.02823881f, -0.00342672f, -0.01620476f, 
    0.02031970f, 0.09496401f, 0.05723217f, -0.63098615f, 0.06380446f, 0.04924705f, -0.09915296f, -0.00053211f, 
    0.21610150f, -0.05886671f, 0.02277964f, 0.18768069f, 0.20788699f, 0.11088738f, -0.08547741f, 0.18749338f, 
    0.13175219f, 0.12939604f, 0.08625153f, 0.21911816f, 0.14537521f, -0.16059031f, -0.08812738f, 0.05136809f, 
    -0.18482137f, -0.02436775f, 0.01312495f, -0.08638425f, -0.94958252f, -0.43510541f, 0.12623219f, -0.05500743f, 
    -0.07449709f, 0.07997042f, 0.08118878f, 0.06372380f, -0.10143673f, 0.37695196f, 0.00164162f, -0.21609785f, 
    0.09730382f, 0.06510234f, -0.05993592f, 0.08021598f, 0.00176746f, 0.04992842f, 0.06368788f, -0.06875589f, 
    -0.18321809f, 0.01621880f, 0.08181435f, 0.04178143f, -0.00702740f, -0.04254197f, 0.02165127f, -0.23404354f, 
    -0.04951017f, -0.09999646f, -0.12780437f, 0.07941379f, 0.03222013f, 0.02793596f, 0.06866696f, 0.00046342f, 
    -0.22880548f, -0.02396491f, -0.12778600f, -0.00985000f, -0.03988980f, -0.05382317f, 0.02844011f, 0.02735993f, 
    0.10793865f, -0.33052015f, -0.25869000f, -0.32268479f, 0.07158531f, 0.02084965f, 0.05085610f, 0.03614716f, 
    0.08889602f, 0.08799015f, 0.15033109f, 0.01713948f, 0.09044116f, -0.06427527f, -0.03982682f, -0.11169998f, 
    0.01056672f, -0.10436445f, 0.07599013f, 0.19605030f, 0.14205007f, -0.03457123f, 0.07471033f, 0.03599981f, 
    0.00939227f, 0.07839882f, -0.01466674f, 0.15791871f, 0.20153904f, 0.00568337f, 0.09174505f, -0.02877081f, 
    -0.07150316f, -0.01350030f, 0.07863442f, 0.19070460f, -0.04857927f, 0.52427685f, 0.28472096f, 0.13319623f, 
    -0.13372646f, 0.03017149f, 0.20014457f, 0.16860917f, -0.05526329f, -0.03314826f, -0.41596940f, -0.21296245f, 
    -0.19041146f, 0.03934391f, 0.12581819f, 0.01299979f, -0.11256637f, -0.01264361f, 0.07128811f, -0.48620772f, 
    -0.24596001f, -0.29918221f, -0.06119293f, 0.18816489f, -0.04792100f, 0.03072143f, 0.12446135f, 0.20299090f, 
    -0.31380776f, 0.03967702f, -0.06620331f, -0.12364198f, -0.07825780f, -0.04676535f, -0.09482294f, -0.02386376f, 
    0.00143959f, 0.24879709f, 0.15647309f, 0.13727574f, -0.06177083f, 0.16481610f, -0.03882127f, 0.00859187f, 
    -0.11769193f, 0.18917108f, 0.22721782f, -0.41164032f, -0.12183441f, -0.05277847f, -0.01394526f, -0.07978619f, 
    0.03962171f, 0.00405584f, 0.03652846f, 0.04437874f, -0.13571058f, -0.03105047f, 0.00833873f, -0.03703746f, 
    -0.01678076f, -0.02453281f, -0.05361757f, 0.01560497f, 0.08627688f, -0.19144492f, -0.21385352f, 0.07749357f, 
    -0.00069502f, 0.10994706f, 0.02099676f, -0.13983728f, 0.19859649f, -0.46142027f, -0.29099259f, -0.10803597f, 
    0.01176815f, 0.02736818f, 0.04855945f, 0.04872885f, -0.05586260f, -0.12382172f, -0.02790859f, -0.34896678f, 
    -0.00881412f, -0.16234179f, 0.10706808f, 0.06030524f, -0.00832043f, 0.05570570f, -0.04549756f, 0.65107912f, 
    -0.23354070f, 0.10436632f, -0.10220216f, 0.00400319f, 0.02760036f, 0.00119357f, 0.07528412f, 0.02794868f, 
    0.01613432f, -0.02523615f, -0.02819467f, 0.01054613f, -0.05403144f, -0.06046160f, -0.04113314f, -0.02107000f, 
    -0.04062330f, 0.05535997f, -0.03569552f, 0.00564376f, -0.01293086f, -0.05090496f, -0.02281261f, 0.01619085f, 
    -0.01715680f, -0.04115419f, 0.04908668f, 0.04292602f, -0.01247788f, -0.00673433f, 0.01077092f, -0.04183089f, 
    -0.05411616f, -0.05741769f, 0.01723856f, 0.00359516f, -0.00824076f, -0.04861426f, 0.03712393f, -0.04250248f, 
    -0.04514836f, -0.03570225f, 0.03981317f, -0.00686359f, -0.01838832f, -0.01410528f, 0.01218751f, -0.01613788f, 
    -0.06132604f, -0.00783947f, -0.01373916f, -0.00580222f, -0.05146674f, -0.05226412f, 0.03558505f, -0.04301017f, 
    -0.05649704f, 0.00104476f, -0.05461859f, 0.01831809f, -0.04872740f, -0.01927710f, 0.01176647f, 0.04051428f, 
    -0.03194730f, -0.04480404f, -0.05684547f, 0.05258882f, -0.00185971f, -0.04760253f, 0.04806288f, 0.02042757f, 
    0.05046181f, -0.03616787f, -0.03624636f, 0.01454940f, -0.05766771f, -0.04604228f, -0.03532538f, 0.04302006f, 
    -0.04931445f, -0.03359430f, -0.03642051f, 0.01385124f, 0.02122205f, -0.06426171f, 0.03245853f, -0.05066550f, 
    -0.03198083f, 0.01421323f, -0.02565565f, -0.00837104f, -0.00828811f, -0.01784262f, -0.03964233f, 0.00457312f, 
    -0.04426828f, -0.02836831f, -0.02130766f, 0.04705030f, -0.04877387f, 0.00325181f, -0.05270680f, 0.04918414f, 
    -0.04030140f, -0.04926419f, -0.05711326f, 0.05837086f, 0.04019058f, -0.03752899f, 0.04568043f, -0.04744799f, 
    0.03983622f, 0.04753601f, 0.03562874f, -0.05369881f, 0.04675714f, -0.01444714f, -0.04020685f, -0.00887975f, 
    0.01582573f, -0.02210860f, 0.02864155f, 0.00071205f, -0.04222011f, 0.00442567f, -0.03846765f, -0.05803265f, 
    0.04972439f, -0.03975452f, -0.05530360f, 0.01435420f, -0.03087434f, -0.04157089f, 0.04159377f, 0.01379042f, 
    -0.01043703f, -0.00212054f, 0.02079976f, -0.03796050f, -0.04219975f, -0.00515742f, -0.01529249f, 0.01264871f, 
    0.01020322f, -0.03423287f, -0.03343754f, -0.02476017f, -0.06110730f, -0.00600908f, -0.02942427f, -0.06326070f, 
    0.05054069f, -0.00451571f, 0.04889248f, 0.01165002f, 0.01756743f, -0.03515745f, 0.02245358f, 0.04754374f, 
    0.01869991f, -0.05591419f, -0.05985949f, -0.00444839f, -0.05329645f, -0.04970899f, 0.03783539f, 0.04505032f, 
    -0.02037623f, -0.04391261f, -0.04138173f, 0.05104880f, -0.02024250f, -0.02183410f, 0.02615348f, 0.04276089f, 
    0.04869531f, 0.04683669f, 0.01392930f, -0.02831608f, -0.03732932f, -0.02074894f, 0.04431386f, 0.01978224f, 
    -0.01496614f, 0.03736997f, 0.01821394f, -0.02686619f, -0.06278019f, 0.00167175f, 0.01097281f, 0.03895169f, 
    0.03111841f, 0.05074986f, 0.02186583f, 0.01874641f, 0.04907950f, 0.01392149f, 0.02556689f, -0.04710587f, 
    0.00366250f, -0.03586602f, -0.01513880f, 0.01044579f, -0.01190782f, -0.01600087f, -0.05201212f, -0.05926270f, 
    -0.01975876f, -0.04431251f, 0.02259952f, 0.04955434f, -0.01953613f, -0.02427349f, -0.04440520f, 0.02357084f, 
    0.03249107f, -0.03368216f, -0.03566534f, -0.01697767f, -0.04673743f, 0.04645768f, -0.04730026f, -0.04554306f, 
    0.00763207f, -0.02129059f, 0.02927860f, -0.01409430f, 0.03508025f, 0.03841478f, 0.04140035f, -0.05867406f, 
    -0.02082056f, 0.02256411f, 0.03183030f, -0.05862315f, 0.02742122f, 0.03320011f, 0.02429271f, 0.05239324f, 
    0.03971613f, 0.03758017f, -0.04525626f, -0.00098242f, -0.05254912f, -0.01298361f, 0.05092585f, 0.01413971f, 
    -0.04416498f, 0.00950832f, 0.03034591f, -0.04999442f, -0.00911706f, 0.00732480f, 0.03205587f, -0.05267448f, 
    -0.04647144f, 0.00069465f, -0.04436982f, -0.03162555f, -0.02936246f, 0.04788102f, -0.01884082f, -0.00791328f, 
    0.00407928f, -0.01232769f, 0.00761043f, -0.02926836f, 0.01175496f, -0.00671440f, -0.00871980f, -0.01143244f, 
    -0.05409282f, -0.02057897f, 0.01901022f, 0.02864466f, 0.01552651f, -0.00937253f, 0.02954818f, 0.04358639f, 
    -0.01771127f, 0.04297710f, -0.03059659f, 0.01461632f, 0.00599944f, -0.04748427f, -0.05919479f, -0.03155448f, 
    -0.01540806f, 0.01864625f, -0.01229365f, 0.04877891f, -0.01663029f, -0.03606295f, 0.01259324f, -0.05201104f, 
    0.08633984f, -0.00728197f, 0.06813792f, 0.11030942f, 0.05992234f, 0.06842558f, 0.20630381f, -0.08060749f, 
    0.10847778f, -0.22712420f, -0.15669173f, 0.09331339f, 0.11554369f, 0.05295295f, -0.05369399f, -0.03091170f, 
    0.09933489f, 0.01558206f, 0.14218509f, 0.05995920f, 0.05691280f, 0.07105461f, 0.05607487f, 0.07330730f, 
    -0.02351710f, 0.07598998f, 0.02818316f, -0.01701532f, -0.24587382f, 0.06673048f, -0.05455034f, -0.03234545f, 
    -0.05171390f, -0.00904509f, 0.10761070f, -0.04147881f, -0.10168595f, -0.03306442f, -0.22029881f, -0.04837109f, 
    0.04424360f, -0.10795794f, 0.02126872f, 0.13818899f, 0.15426007f, 0.06305716f, 0.08750091f, 0.12401247f, 
    -0.05560367f, 0.03423296f, 0.10744515f, 0.06603304f, 0.13472457f, 0.05319249f, 0.06385358f, 0.01474902f, 
    0.03594331f, 0.05995206f, 0.06703798f, 0.03190790f, 0.12000569f, 0.13697906f, 0.18290210f, -0.10546843f, 
    -0.05993595f, 0.04761507f, -0.01373703f, 0.11907762f, 0.01926902f, -0.01598420f, 0.11394718f, 0.05722632f, 
    0.00113901f, 0.03784487f, 0.07337265f, -0.08141962f, 0.00311460f, -0.01273807f, -0.02542843f, -0.13674736f, 
    -0.03622961f, -0.06030229f, 0.05897338f, 0.03914855f, 0.08997171f, -0.13325612f, -0.02194761f, -0.05930417f, 
    -0.18207327f, 0.12837465f, -0.17276376f, -0.12145130f, -0.04881360f, 0.00104470f, 0.06475492f, 0.04872896f, 
    -0.06053992f, 0.15226626f, -0.06269263f, 0.02584493f, -0.06157740f, 0.13526878f, 0.04818599f, 0.13934124f, 
    0.08953786f, 0.02314569f, 0.10768745f, 0.26107413f, 0.03088150f, 0.05602441f, -0.11646028f, -0.19803198f, 
    0.07546086f, -0.04643243f, 0.12148083f, 0.04730010f, 0.04687621f, -0.05344700f, 0.20386408f, 0.22518128f, 
    0.03195535f, -0.18317835f, 0.11124365f, 0.04610390f, 0.17273168f, 0.06680257f, -0.08031560f, -0.02594698f, 
    -0.01350641f, 0.22831544f, 0.07949502f, -0.04280157f, 0.01561316f, 0.18239282f, 0.13063155f, -0.07693884f, 
    0.00068588f, -0.07834955f, 0.02950520f, 0.06377263f, -0.00586665f, -0.05896318f, 0.01451676f, 0.08208793f, 
    -0.01929187f, -0.03393494f, -0.07422762f, 0.01748883f, -0.01837753f, 0.03076204f, 0.04585332f, 0.01748133f, 
    -0.04158037f, -0.12914355f, 0.07065144f, 0.08851279f, -0.02375156f, -0.03068155f, 0.05869354f, 0.05939828f, 
    -0.12668486f, 0.07152133f, 0.00611028f, -0.09719118f, 0.08083362f, 0.13037683f, 0.02788981f, -0.04606739f, 
    0.23548384f, 0.02133276f, 0.08138622f, -0.02530257f, 0.10967910f, -0.02543833f, 0.08362515f, 0.05336526f, 
    0.13340357f, 0.14044119f, 0.10446445f, 0.09671615f, -0.22802202f, -0.16024058f, -0.14522840f, 0.05452134f, 
    0.02516958f, -0.15636364f, 0.11917736f, 0.16196194f, 0.09626846f, -0.07122593f, -0.10411298f, -0.05681391f, 
    0.04872238f, -0.15615124f, -0.00066310f, -0.08522206f, 0.01130068f, 0.21665832f, 0.10383965f, 0.05569758f, 
    -0.18176109f, 0.00300997f, -0.01528134f, 0.03217700f, 0.13008675f, 0.10134163f, 0.11264983f, 0.08410720f, 
    -0.04725456f, -0.10683343f, -0.11492854f, -0.00377268f, 0.25505468f, -0.09227815f, -0.25545293f, -0.00607903f, 
    -0.12218882f, -0.14189851f, 0.01313434f, 0.13749832f, 0.09331184f, -0.13398387f, 0.03053917f, -0.01857715f, 
    0.02208752f, -0.12100714f, 0.01969184f, -0.28086507f, -0.08668030f, 0.01455965f, -0.15901461f, 0.08609628f, 
    0.08906101f, -0.12081198f, 0.04947139f, -0.23216476f, 0.02901474f, -0.01999381f, -0.00366542f, -0.09951102f, 
    0.04838796f, -0.05610619f, -0.13755164f, 0.04051889f, -0.10974355f, -0.02281286f, 0.13422942f, -0.00384000f, 
    0.16820891f, -0.05612459f, 0.15144488f, 0.07201126f, 0.25948027f, 0.08042185f, 0.02763881f, -0.07773389f, 
    -0.00156700f, 0.05057015f, -0.01818768f, -0.31740105f, -0.04313133f, 0.08147948f, 0.03874977f, -0.08223057f, 
    0.01106591f, -0.02374435f, 0.07460354f, -0.10877623f, 0.17348623f, 0.02487600f, -0.11498676f, -0.04852720f, 
    -0.04428347f, -0.14185728f, -0.06617627f, 0.09073666f, -0.04619200f, 0.16995980f, 0.16356853f, -0.07164344f, 
    -0.03183745f, -0.02428485f, 0.00882205f, -0.00968055f, 0.15220574f, 0.02405427f, -0.13423368f, 0.06900109f, 
    0.34047744f, -0.04881031f, 0.22576784f, 0.02456473f, -0.02431136f, 0.09525642f, -0.04309507f, -0.00705051f, 
    0.03159361f, -0.04706260f, 0.15700844f, 0.35313389f, -0.12182086f, -0.17743534f, -0.14277042f, 0.14960462f, 
    -0.11134839f, -0.11309150f, -0.22133651f, 0.09421695f, -0.00331072f, 0.03410325f, 0.06593197f, 0.07114688f, 
    0.00230181f, 0.03403778f, 0.20437156f, 0.11302880f, -0.07255080f, 0.23593955f, -0.07602496f, -0.01109368f, 
    -0.02396999f, -0.14824423f, -0.14774853f, -0.17464741f, 0.18019801f, -0.07550027f, -0.05915928f, -0.39124516f, 
    -0.08906051f, -0.19075067f, 0.11490896f, 0.11012285f, -0.03242370f, -0.17923112f, 0.12856740f, 0.24858816f, 
    0.04086354f, 0.08722983f, 0.10615569f, 0.08425180f, -0.03024829f, 0.11246166f, 0.24520510f, 0.27317473f, 
    -0.30866349f, 0.04457904f, -0.09369143f, 0.09758215f, 0.15644528f, -0.04477106f, 0.09001032f, -0.01891290f, 
    -0.02631913f, 0.26845792f, -0.01437460f, -0.07234795f, -0.02199598f, -0.00699310f, -0.00234398f, -0.03568542f, 
    0.25040743f, 0.20871021f, -0.03419393f, -0.01481726f, -0.10700607f, 0.07342045f, 0.08512416f, -0.16423886f, 
    -0.01110102f, -0.20133294f, -0.15626231f, 0.40180582f, -0.11905722f, -0.12534775f, -0.20143341f, 0.12690625f, 
    0.13701589f, 0.09660568f, -0.09159946f, 0.01463964f, 0.18988951f, -0.06137169f, -0.12470414f, -0.01899471f, 
    0.11095070f, 0.04187062f, 0.17802300f, 0.06885535f, -0.01415975f, 0.16827518f, -0.12747175f, 0.16729321f, 
    0.01642437f, 0.16844788f, -0.02360179f, 0.10326564f, 0.27292225f, -0.11618380f, -0.31796369f, -0.07822365f, 
    0.10959534f, -0.01446111f, -0.01155134f, 0.00620454f, -0.13976420f, -0.13357762f, 0.11474600f, -0.00337370f, 
    -0.07228474f, 0.15174545f, -0.07189510f, 0.14956151f, -0.10437161f, 0.11260025f, -0.05179872f, 0.08216018f, 
    -0.26418588f, -0.06133395f, 0.09090342f, 0.08090248f, 0.19082202f, 0.02778339f, -0.05800175f, 0.04720527f, 
    -0.00098421f, 0.15759774f, 0.13873038f, -0.25230089f, 0.02673778f, 0.28710109f, 0.10190071f, 0.06687564f, 
    0.11231452f, 0.00726801f, -0.13382663f, 0.07043011f, 0.13525043f, -0.01543115f, -0.16293861f, 0.08988397f, 
    -0.01987551f, -0.06330787f, -0.06338841f, 0.16174370f, -0.16461961f, -0.07191840f, 0.03906230f, 0.12887497f, 
    0.04421002f, 0.01134402f, 0.02876569f, 0.20329273f, 0.16804008f, -0.15345764f, 0.09360513f, -0.12271492f, 
    0.02062768f, 0.06562295f, -0.01533278f, -0.21881218f, 0.01521150f, -0.29878205f, 0.04123206f, 0.02199227f, 
    -0.04583025f, 0.02342196f, 0.11236762f, -0.00095159f, 0.06048157f, -0.26740575f, -0.14563704f, -0.16572522f, 
    -0.08724171f, 0.06493958f, -0.00397869f, 0.02601428f, -0.03668572f, 0.02601418f, -0.23997748f, -0.07535094f, 
    0.05808777f, -0.27446327f, -0.09192428f, -0.07971010f, 0.05924457f, -0.11008342f, 0.13855381f, -0.10863359f, 
    -0.24431297f, -0.14421631f, 0.15153454f, -0.10267089f, 0.18306775f, -0.05069795f, 0.24679716f, -0.11340664f, 
    -0.04342482f, 0.02843717f, -0.00964236f, -0.23124959f, 0.02325676f, 0.10291238f, 0.17116548f, 0.14448759f, 
    0.39916164f, 0.03870670f, 0.21225032f, 0.05079537f, -0.04879777f, 0.05578246f, -0.10182782f, 0.11713192f, 
    -0.20204680f, -0.03390098f, 0.03189958f, -0.06309947f, -0.12320529f, -0.14841047f, -0.06059290f, 0.04641685f, 
    0.18003638f, 0.09619528f, 0.03792668f, -0.10232512f, -0.13242991f, -0.08551299f, 0.00449436f, 0.08664053f, 
    0.03050818f, 0.09330583f, -0.13742945f, 0.12151635f, 0.07673243f, -0.41919446f, 0.03388835f, -0.25676423f, 
    0.01811546f, 0.20829946f, -0.08558743f, 0.17521138f, -0.54736632f, -0.08237822f, 0.14154316f, 0.07299219f, 
    0.06571119f, -0.08019435f, 0.08230169f, 0.04636760f, 0.00813615f, -0.14590251f, -0.06006132f, -0.08908735f, 
    -0.00629566f, 0.00849727f, 0.05417229f, 0.19986427f, -0.04343147f, 0.11606786f, -0.05413035f, -0.03354574f, 
    -0.17701560f, -0.05218986f, -0.08500831f, -0.03606692f, 0.10923143f, 0.04792194f, 0.12738927f, 0.03760281f, 
    -0.04930155f, -0.00954996f, 0.16924232f, 0.06819236f, 0.04083689f, 0.10134533f, 0.04011750f, 0.13570371f, 
    -0.21825388f, -0.08049628f, -0.42671433f, 0.03810530f, -0.02537047f, -0.16281015f, 0.04734343f, -0.04945906f, 
    -0.02515076f, -0.16656843f, -0.39452034f, 0.07824133f, -0.13555643f, -0.15026537f, -0.10153828f, 0.06127670f, 
    0.02341641f, 0.07588270f, 0.28968602f, -0.02903560f, 0.03422666f, 0.04227068f, 0.08412052f, -0.01570203f, 
    0.00810466f, 0.08640364f, 0.02827786f, 0.24757324f, 0.00539224f, -0.21508476f, -0.11116848f, -0.15493898f, 
    -0.00965955f, 0.06517354f, -0.01105772f, -0.03353995f, 0.04275216f, 0.11546230f, -0.03015785f, -0.22051258f, 
    -0.18087749f, 0.00082288f, 0.08564742f, -0.04703806f, 0.09876203f, 0.07695400f, -0.10305065f, 0.01146758f, 
    -0.00467192f, 0.12949239f, 0.02310315f, 0.12720759f, 0.05854157f, 0.00011843f, 0.01704968f, -0.00343347f, 
    -0.09123777f, 0.09830848f, 0.04955789f, 0.18501663f, 0.12692268f, 0.01678093f, -0.03886436f, -0.02758412f, 
    0.10910219f, 0.02879797f, -0.02165871f, -0.09924392f, -0.10091669f, 0.03677602f, -0.00882178f, 0.03922656f, 
    0.12339869f, -0.16576254f, -0.24547032f, 0.07614387f, 0.01580830f, 0.03403978f, 0.07846033f, -0.04703697f, 
    -0.00384154f, -0.17418915f, -0.08088452f, 0.10439467f, -0.04471317f, -0.22701658f, -0.03368937f, -0.00532695f, 
    0.01514553f, -0.08347410f, -0.11640264f, -0.24045080f, -0.22981973f, -0.09354593f, 0.06959821f, 0.03152331f, 
    0.02434391f, -0.01867197f, 0.13329446f, -0.46829888f, -0.44442409f, -0.20106708f, -0.01833786f, -0.03672987f, 
    -0.03243331f, 0.14135408f, -0.03909458f, 0.12549283f, -0.18295376f, 0.03553270f, -0.04780625f, -0.07025550f, 
    0.00946098f, 0.05121675f, -0.03914677f, 0.15793833f, 0.10855442f, 0.05012010f, -0.11733229f, 0.11885858f, 
    -0.03685567f, -0.01308651f, -0.11899205f, 0.15676928f, 0.01068394f, 0.06772798f, -0.00047279f, -0.04606121f, 
    0.08985918f, 0.12884338f, -0.03002725f, 0.10476854f, 0.01475034f, -0.00719165f, 0.04404080f, 0.04057435f, 
    -0.05041966f, 0.16974728f, -0.14607826f, -0.10011572f, -0.04338713f, 0.00260382f, 0.11581834f, 0.03923867f, 
    -0.03036693f, -0.00322362f, -0.08241539f, 0.04619414f, 0.07446355f, -0.08399812f, -0.03857886f, 0.08060282f, 
    0.20088972f, 0.24521807f, 0.16294454f, -0.11051908f, 0.04929131f, -0.13724840f, -0.08446700f, 0.05869491f, 
    0.11573494f, -0.05765549f, 0.05450520f, 0.20531051f, 0.30714232f, -0.08391491f, -0.00161124f, -0.05077283f, 
    -0.02943870f, -0.02157293f, -0.02783525f, -0.09177286f, -0.17660290f, -0.15900038f, 0.15474926f, 0.05851556f, 
    0.02736577f, 0.09236002f, 0.00117864f, -0.08307286f, 0.13316041f, -0.02086479f, -0.05275510f, -0.04595962f, 
    0.01966807f, 0.03249185f, 0.03678408f, -0.01905047f, -0.05983520f, -0.32754827f, -0.55674934f, -0.58801895f, 
    0.12533717f, -0.36467153f, 0.24241573f, -0.10933413f, 0.11258887f, -0.14923331f, 0.15077843f, 0.09270832f, 
    0.06821858f, -0.03821388f, -0.01150286f, 0.06955355f, 0.16278118f, 0.05853715f, -0.03820435f, 0.05534383f, 
    0.32174760f, -0.05024027f, -0.26378801f, -0.19822772f, -0.36321539f, 0.02631661f, 0.13086979f, -0.00035071f, 
    -0.15877070f, -0.17669474f, -0.25338182f, -0.07779731f, -0.08487000f, 0.10440536f, 0.01337778f, -0.01153152f, 
    -0.06350881f, -0.13018152f, -0.06303611f, -0.04797817f, 0.00622918f, 0.03867034f, -0.03019200f, 0.12815942f, 
    -0.01667240f, 0.11585882f, 0.17500988f, 0.01513744f, 0.09296425f, -0.13460627f, 0.01668002f, -0.24828224f, 
    0.03103906f, 0.10210336f, 0.22537731f, -0.17593080f, -0.21681236f, -0.07513706f, -0.01097680f, 0.02967104f, 
    -0.00450977f, 0.03585124f, 0.08829959f, 0.03274216f, 0.12980954f, 0.30916610f, -0.02662844f, 0.14041798f, 
    0.07315661f, -0.18759643f, -0.01390809f, -0.01583063f, 0.01997403f, 0.22899914f, 0.10901987f, 0.26913685f, 
    -0.09352484f, -0.06092570f, -0.14038676f, -0.02373751f, 0.06311164f, 0.06154678f, 0.19054013f, -0.00041158f, 
    -0.09148254f, -0.11994611f, 0.05435048f, -0.15930843f, 0.09335544f, 0.01214754f, -0.04731422f, 0.13355725f, 
    0.00343517f, -0.08126345f, 0.01711264f, -0.06724604f, 0.03281133f, -0.04387923f, 0.10065380f, 0.20831105f, 
    0.02955731f, 0.04859802f, 0.03764483f, -0.02087683f, 0.01014863f, -0.03003645f, -0.01786066f, -0.03550575f, 
    -0.06128383f, -0.06038982f, -0.04190179f, 0.04917936f, -0.02504621f, -0.02498115f, -0.04833919f, -0.05242913f, 
    -0.03401290f, -0.02924535f, -0.03534694f, -0.00459181f, 0.00515429f, -0.00427577f, 0.01813501f, -0.05004957f, 
    -0.02549355f, 0.03875420f, -0.01383228f, -0.00995271f, 0.05290385f, -0.05567469f, -0.03060246f, -0.04297697f, 
    -0.00348090f, -0.03136796f, 0.01795803f, -0.02462450f, -0.03747898f, -0.06312291f, 0.01078553f, -0.03070721f, 
    -0.03062952f, 0.03630995f, -0.03651778f, -0.04385133f, -0.04207870f, -0.02545302f, 0.02794275f, -0.03900288f, 
    0.00788923f, 0.00640423f, 0.00436677f, -0.05498466f, -0.01067412f, -0.02029679f, -0.02705627f, -0.05638339f, 
    -0.03424406f, -0.06243154f, -0.04071971f, -0.02634822f, -0.02777834f, -0.04173387f, -0.01619422f, -0.02722335f, 
    -0.01193167f, 0.04884814f, -0.03675454f, -0.03769835f, 0.00771231f, 0.03330744f, -0.00819887f, -0.03457541f, 
    -0.03022222f, 0.01466805f, -0.04479598f, 0.04191599f, -0.06335011f, 0.04347768f, -0.02613348f, -0.00317148f, 
    -0.05974687f, -0.00014532f, -0.02210666f, -0.01312597f, -0.05194537f, -0.00311003f, -0.00513001f, -0.05599178f, 
    0.03260378f, -0.03702638f, 0.03240753f, 0.02599357f, 0.05760875f, 0.00480957f, -0.00669222f, 0.04313076f, 
    -0.03165728f, -0.00663896f, -0.01764398f, -0.03398148f, -0.00107369f, -0.06611449f, -0.00071737f, 0.00931770f, 
    0.02937106f, -0.00983284f, -0.05859568f, 0.02136357f, -0.06597167f, -0.05976406f, -0.01982994f, 0.01439305f, 
    -0.02284635f, 0.04082423f, 0.04645604f, -0.00112998f, 0.04019110f, -0.02691261f, -0.00068708f, -0.04997572f, 
    -0.04662990f, -0.01594059f, 0.04705794f, -0.06175721f, -0.03509326f, -0.05541803f, -0.04229667f, 0.04169744f, 
    0.00530333f, 0.04048071f, -0.03479525f, 0.04563292f, -0.00648941f, 0.03211201f, -0.05067115f, -0.00121979f, 
    0.02008015f, -0.04442950f, 0.02495212f, -0.01575296f, -0.03656659f, -0.06262852f, 0.00337765f, -0.05063503f, 
    0.00713597f, 0.03186603f, 0.02867638f, 0.01062680f, 0.02866761f, -0.03708369f, 0.05225428f, -0.04424443f, 
    -0.04812394f, 0.02475473f, -0.04186820f, -0.01489817f, 0.04154632f, 0.01288557f, 0.03075145f, -0.02842710f, 
    -0.06185513f, 0.04388435f, 0.00313198f, -0.05676626f, 0.02631103f, -0.00765756f, -0.04458845f, 0.03188651f, 
    -0.03357714f, -0.01427401f, 0.02641938f, -0.06569676f, -0.00843474f, 0.02239672f, 0.04875420f, 0.01850598f, 
    -0.02364756f, 0.04150563f, 0.03234097f, 0.03373050f, 0.04647421f, -0.04089302f, -0.04514511f, -0.00196720f, 
    0.05125716f, 0.01570531f, -0.02682243f, 0.02126882f, -0.04388466f, -0.01030588f, -0.02763812f, -0.03787562f, 
    -0.03375706f, 0.03022602f, 0.01044277f, -0.01072298f, 0.00695047f, 0.01828702f, -0.05198231f, 0.04674650f, 
    -0.01857668f, -0.01026535f, -0.00316025f, 0.02410532f, 0.03068824f, 0.00441654f, -0.00085345f, -0.00432689f, 
    0.02924495f, 0.03194289f, -0.00015664f, -0.00600695f, -0.04355751f, -0.03875603f, -0.01355722f, -0.01688234f, 
    -0.05417847f, 0.01835777f, 0.06461866f, -0.00498093f, -0.02432200f, 0.04477760f, 0.01976766f, 0.00308871f, 
    -0.04991783f, -0.00604394f, 0.04045649f, 0.03626544f, 0.00570301f, 0.02004049f, 0.02108090f, -0.05589989f, 
    -0.05500014f, -0.06571298f, 0.04380704f, 0.00102548f, -0.05537575f, -0.01054681f, 0.00068818f, -0.03712980f, 
    -0.00558626f, -0.00694342f, -0.03795578f, 0.01922131f, -0.02698441f, -0.02794221f, -0.00410581f, 0.03744375f, 
    0.01146419f, -0.05647945f, -0.00918508f, 0.02619076f, 0.04366567f, -0.04248950f, -0.06602457f, -0.04771954f, 
    0.00301331f, 0.01311467f, -0.00408709f, -0.02632407f, -0.01959600f, 0.04986311f, 0.01209235f, 0.00555592f, 
    0.03880823f, 0.03899321f, 0.01101907f, -0.03685945f, 0.04510310f, 0.02627797f, 0.04225812f, -0.01798486f, 
    0.01968111f, 0.01933922f, 0.00243654f, -0.02396757f, 0.04591344f, 0.04527438f, 0.02447560f, -0.01001664f, 
    0.01187378f, -0.00646238f, -0.05607296f, 0.02660778f, -0.00093196f, -0.03158049f, 0.02367104f, 0.02570760f, 
    -0.01399123f, -0.02468394f, -0.06115074f, 0.02818247f, -0.01125733f, -0.03107214f, -0.02866418f, 0.02422842f, 
    0.01383765f, 0.03292449f, -0.00673325f, -0.00042077f, -0.00979488f, 0.02045870f, -0.06242964f, -0.01883465f, 
    0.00190313f, -0.01923620f, 0.03213257f, -0.00575580f, -0.03276629f, -0.03513267f, 0.00187483f, -0.00747330f, 
    -0.04853294f, 0.04214102f, -0.00830960f, -0.05661587f, 0.04351096f, -0.04297059f, 0.01547994f, -0.02229927f, 
    -0.00840184f, -0.00687040f, 0.01311246f, 0.01716630f, -0.00508979f, -0.04207667f, -0.04053966f, -0.00211889f, 
    0.03687075f, -0.01872747f, -0.05409594f, -0.04006913f, 0.04189438f, 0.04866296f, -0.04257375f, -0.03400815f, 
    0.01503420f, 0.00597904f, -0.03948659f, -0.05677314f, 0.01092272f, 0.04447710f, -0.06888576f, 0.03467513f, 
    -0.00960673f, -0.01754031f, 0.02969344f, -0.04730055f, -0.04607704f, 0.02835141f, -0.01707008f, 0.02702967f, 
    0.02599606f, -0.03941786f, -0.01174887f, -0.04844747f, -0.02282428f, -0.00762129f, 0.04632594f, -0.03219936f, 
    -0.00915920f, 0.00978661f, 0.04975335f, 0.01427130f, 0.05294430f, 0.00579649f, -0.05816599f, -0.04348484f, 
    -0.04159221f, 0.00130268f, 0.02080547f, 0.04202435f, 0.03892796f, -0.06507725f, -0.03170162f, 0.00906480f, 
    0.00437069f, 0.04499978f, -0.00540953f, -0.00636325f, -0.04145297f, -0.02851452f, -0.00892178f, 0.00375164f, 
    0.02902338f, -0.04785420f, 0.02888437f, -0.03422721f, 0.03118341f, -0.02615781f, 0.01398786f, 0.00561224f, 
    -0.00297379f, -0.06926357f, 0.00460760f, -0.01879576f, 0.03705288f, 0.02706200f, -0.02395762f, 0.00386008f, 
    -0.03847751f, 0.00134605f, 0.03609880f, 0.00004250f, -0.00773016f, -0.05080966f, 0.01200095f, 0.04087933f, 
    -0.00428091f, 0.00009639f, -0.01090694f, 0.02437104f, -0.03461529f, 0.00442485f, 0.03386009f, -0.04313989f, 
    0.03236597f, -0.02477622f, 0.01377645f, 0.04690830f, -0.05588743f, -0.01869822f, -0.03495155f, 0.03112240f, 
    -0.00369513f, -0.00126485f, -0.00861855f, -0.06044392f, 0.01073976f, 0.00913111f, -0.00025275f, 0.04028242f, 
    0.02056637f, 0.01857223f, 0.04884897f, -0.05255285f, -0.00488278f, -0.01106819f, 0.01191432f, -0.02772075f, 
    -0.00509143f, 0.04215099f, -0.01555132f, 0.03237879f, 0.02962394f, -0.00795747f, -0.02056791f, -0.05300160f, 
    -0.03238454f, -0.03312534f, -0.02731632f, -0.03683882f, -0.06113878f, 0.03081834f, -0.04148681f, -0.04603572f, 
    0.04496611f, 0.00425827f, -0.02586110f, -0.02985428f, 0.01964299f, -0.00371468f, 0.02541323f, -0.03494620f, 
    -0.04423151f, -0.01672309f, -0.04373027f, 0.03662050f, -0.00978038f, 0.02999537f, 0.00798385f, -0.00112912f, 
    0.03754760f, -0.03077487f, 0.02098522f, 0.02349751f, -0.02450495f, -0.05985513f, 0.02078037f, -0.06770030f, 
    -0.04769382f, -0.02638991f, 0.01681239f, 0.00635065f, 0.01828549f, 0.01757954f, -0.05716979f, 0.04231350f, 
    0.01494843f, 0.03044114f, -0.01251428f, 0.02874464f, 0.00931274f, -0.02896337f, 0.02952034f, -0.01821095f, 
    0.03426148f, 0.03691188f, -0.01144371f, 0.00142630f, -0.02411452f, 0.01206459f, 0.01255114f, 0.00185751f, 
    -0.02429412f, 0.00241877f, 0.04238176f, -0.06006035f, 0.02856968f, 0.04555718f, -0.03585942f, 0.00758041f, 
    0.00895459f, -0.04274091f, 0.04563969f, -0.04987605f, -0.06950328f, 0.01457501f, -0.04692016f, 0.04305446f, 
    -0.02564750f, -0.03849877f, -0.01411214f, -0.04898916f, -0.04539199f, -0.00916464f, 0.04255948f, 0.00406228f, 
    0.03188768f, -0.02528619f, -0.00315210f, -0.05939231f, -0.05795646f, 0.00120812f, -0.04204707f, -0.00155130f, 
    0.02156255f, 0.02025850f, -0.01723147f, -0.06388627f, -0.06172719f, 0.01620056f, 0.00662517f, -0.06178287f, 
    -0.03796118f, 0.04658796f, -0.04704924f, 0.00026015f, -0.01505478f, -0.06980101f, 0.02996949f, 0.04582560f, 
    0.02871186f, -0.05728522f, 0.01384072f, 0.03606996f, -0.05564397f, 0.00626491f, -0.06753162f, 0.04706530f, 
    -0.03170729f, 0.00926321f, -0.03748544f, 0.04557367f, -0.05557556f, 0.04808836f, -0.02446134f, 0.01007682f, 
    -0.02557478f, 0.03868306f, 0.04212908f, -0.03924378f, 0.00173573f, -0.03895676f, 0.01295503f, -0.00038520f, 
    -0.30122009f, -0.29917616f, 0.19863796f, 0.15242884f, 0.09940903f, 0.02483986f, 0.06588387f, -0.01233257f, 
    0.06229474f, -0.23076959f, -0.02598634f, 0.08503606f, -0.13022010f, 0.24369039f, -0.08771108f, 0.11891390f, 
    -0.05619290f, -0.05163611f, -0.00088270f, 0.06643233f, -0.22763425f, 0.02710317f, 0.06193320f, -0.03138829f, 
    -0.10947669f, -0.02330069f, -0.10036345f, -0.51022691f, -0.02386539f, -0.10359234f, -0.00608930f, 0.12496050f, 
    -0.10173959f, -0.03668018f, -0.04261067f, -0.04194559f, -0.04846391f, -0.04280826f, -0.26433924f, 0.04439411f, 
    -0.11566621f, 0.30359539f, -0.01504874f, -0.01289030f, 0.00523825f, 0.07471719f, -0.13231863f, -0.14991470f, 
    0.15952136f, 0.04909643f, -0.04731608f, -0.01712592f, 0.01422489f, 0.11155313f, 0.15581763f, 0.11615512f, 
    0.02292648f, 0.01820265f, -0.13501129f, 0.05613029f, 0.03823555f, 0.00715274f, 0.13023046f, -0.08168693f, 
    -0.03359952f, -0.21320990f, -0.10745615f, -0.02900265f, -0.01718747f, 0.09704737f, 0.02041644f, -0.08595700f, 
    0.18636094f, 0.00265495f, -0.00185877f, -0.05328554f, 0.04562715f, 0.02143719f, -0.05180494f, -0.06632914f, 
    0.00614267f, -0.34151527f, -0.09533781f, 0.04352258f, -0.06389830f, 0.03613380f, 0.30930755f, 0.00810518f, 
    -0.10415491f, -0.13527647f, -0.01567531f, 0.04110838f, -0.44531977f, -0.04272134f, -0.09408534f, 0.03489293f, 
    0.02671528f, 0.01804443f, -0.03029879f, -0.09236316f, -0.27655390f, 0.05578438f, 0.06588786f, 0.05133029f, 
    0.19952361f, -0.04060170f, -0.04867956f, 0.09641988f, -0.14457753f, 0.14631261f, -0.13173467f, 0.05566630f, 
    0.04352878f, 0.00034778f, -0.06065954f, 0.17927262f, -0.00240319f, -0.02062840f, -0.09634463f, 0.15178061f, 
    0.04235000f, 0.02589164f, 0.27507356f, 0.02554293f, -0.07307480f, 0.05110899f, -0.08253659f, 0.21996209f, 
    0.19397309f, -0.12976444f, -0.05091399f, -0.00518737f, 0.07785143f, 0.14022800f, -0.07644952f, -0.05541125f, 
    -0.00008439f, 0.11741956f, -0.07001179f, 0.01216843f, -0.11063040f, 0.04218706f, 0.29123905f, 0.07468484f, 
    -0.10906795f, 0.19564366f, 0.08664596f, 0.04454440f, 0.05365873f, -0.15393700f, 0.00087165f, 0.15479778f, 
    0.19975050f, -0.13218234f, 0.10507970f, -0.09571593f, -0.03058686f, 0.03746155f, 0.18902835f, -0.00302459f, 
    0.01022600f, -0.15202264f, 0.06710740f, 0.06525602f, -0.16589537f, 0.09390973f, -0.09525808f, 0.07495130f, 
    0.18091665f, 0.05934940f, -0.00140736f, 0.20368952f, 0.15632154f, 0.11090592f, 0.05463471f, 0.06749982f, 
    0.19114256f, 0.10815310f, -0.03854912f, 0.02281104f, -0.05730324f, -0.07392687f, -0.13985491f, 0.02483874f, 
    0.13605368f, 0.02740268f, -0.01624095f, 0.02979806f, 0.12245638f, -0.44102263f, 0.22194749f, -0.34128070f, 
    -0.22178841f, -0.03015269f, 0.12839237f, 0.00438021f, 0.00876315f, 0.00339930f, -0.15925305f, -0.05574974f, 
    0.13678654f, -0.04669171f, -0.05881664f, 0.03646848f, 0.14136027f, -0.10113211f, 0.05538633f, -0.25024143f, 
    -0.18321390f, -0.22717161f, 0.00259628f, 0.05664289f, -0.02913454f, -0.04701064f, -0.18773137f, 0.07355618f, 
    -0.24601379f, -0.19112539f, -0.38822612f, -0.16011943f, -0.05216340f, 0.15119240f, 0.06424901f, -0.02387422f, 
    -0.10470828f, 0.02987213f, 0.19589728f, 0.06164196f, -0.22183542f, 0.06704408f, -0.12148320f, -0.09092623f, 
    -0.02181627f, 0.02092529f, -0.06974106f, -0.15615709f, 0.00653591f, 0.09386212f, -0.01471714f, -0.28262958f, 
    -0.13959937f, 0.11770134f, 0.19485742f, 0.22934282f, 0.06814118f, 0.34023714f, -0.04627781f, -0.11983786f, 
    0.01173148f, -0.05239056f, 0.22830385f, 0.05319166f, -0.33441916f, -0.08899289f, 0.12855342f, 0.02540346f, 
    0.08877941f, -0.08709563f, -0.07393356f, -0.07508094f, 0.00532332f, -0.10999293f, 0.10237228f, -0.13655989f, 
    0.03155897f, -0.18833390f, 0.02477571f, 0.01142169f, -0.01131938f, 0.12176616f, -0.31319395f, 0.23949087f, 
    0.03487916f, -0.09534316f, -0.01874788f, 0.05099413f, 0.06286801f, -0.05968192f, 0.02262827f, -0.13291833f, 
    -0.06919076f, 0.12996982f, -0.06071376f, 0.06935066f, 0.01108135f, -0.05299710f, 0.09371438f, 0.02427484f, 
    0.27129969f, 0.04024601f, 0.08312318f, 0.07568080f, 0.05762613f, -0.09195515f, 0.01735990f, -0.08050054f, 
    0.04058086f, 0.22047193f, 0.19426201f, -0.13367775f, 0.07316118f, -0.01066872f, -0.09910874f, 0.03671905f, 
    -0.13464910f, -0.19626813f, 0.17097358f, 0.01427320f, 0.00521719f, -0.02076847f, -0.02531729f, -0.05006530f, 
    0.03780672f, -0.00627706f, -0.11417694f, 0.09244290f, 0.13458449f, 0.13662189f, -0.03560167f, 0.22163460f, 
    -0.00847308f, -0.09657612f, 0.00216109f, -0.22228631f, 0.00510568f, 0.12414724f, 0.30658561f, 0.04556328f, 
    -0.02184971f, -0.07917143f, -0.08167391f, 0.08872877f, -0.00824892f, 0.21344921f, -0.16768931f, -0.07538497f, 
    -0.07577624f, -0.06074613f, -0.08738574f, -0.10216058f, -0.04655619f, -0.12271956f, -0.18438859f, -0.11185417f, 
    0.06821919f, -0.08560906f, -0.03053952f, 0.15683183f, -0.05665932f, 0.09654052f, 0.15976994f, 0.07295058f, 
    0.10406635f, -0.03945063f, 0.01113170f, -0.02970198f, 0.02573880f, 0.02078494f, -0.06281759f, -0.18767725f, 
    -0.17318821f, 0.02266440f, 0.13935843f, 0.09876081f, 0.03047624f, 0.05683605f, -0.16943008f, -0.05316988f, 
    0.08956975f, 0.29406115f, -0.12669626f, 0.05725617f, -0.06417004f, -0.03813127f, -0.08969221f, -0.03817338f, 
    0.06869123f, -0.14410615f, 0.19992997f, 0.03001351f, 0.05598348f, 0.03032205f, 0.03042004f, -0.14885259f, 
    0.09220459f, -0.11777099f, -0.09303866f, 0.16510646f, 0.00876701f, 0.03669224f, -0.00041852f, -0.01900529f, 
    0.04272177f, -0.08195364f, 0.02661707f, -0.13888551f, -0.06595014f, 0.03522726f, 0.18280625f, -0.15070477f, 
    0.02536148f, -0.15628746f, -0.11407216f, 0.14821593f, 0.00388089f, -0.09154766f, -0.23502125f, 0.09075202f, 
    0.01587481f, -0.13043809f, -0.03144289f, 0.02938626f, -0.05398584f, -0.12035645f, -0.15095600f, -0.24580714f, 
    -0.10195419f, 0.05153340f, 0.02088569f, 0.17074566f, -0.08934629f, -0.08630498f, 0.08559275f, 0.02955500f, 
    -0.11297189f, 0.09952717f, 0.00069643f, -0.08131494f, 0.09175995f, -0.00449358f, 0.03574907f, -0.01761030f, 
    -0.07235914f, -0.04450946f, 0.02849993f, -0.10448793f, -0.07203279f, 0.00422208f, -0.08089133f, -0.17908882f, 
    -0.34731501f, 0.10911024f, -0.00741616f, 0.27863365f, -0.09275584f, -0.09733915f, -0.08203918f, -0.01986124f, 
    0.02174601f, -0.00470223f, -0.01711661f, -0.05984566f, 0.07896474f, -0.07567760f, 0.05567454f, -0.01248593f, 
    0.19870113f, -0.04753119f, 0.19384620f, -0.26562491f, -0.02547744f, 0.01617126f, 0.10789520f, -0.00063339f, 
    0.08918607f, 0.07164146f, 0.03913005f, 0.08632100f, 0.20871273f, -0.00104771f, 0.16231018f, 0.04067881f, 
    0.02770515f, -0.09174365f, 0.09329616f, 0.06208684f, 0.04544364f, 0.00675890f, -0.05848227f, 0.04503012f, 
    0.09977872f, -0.06390658f, 0.07986947f, 0.14609630f, -0.03909367f, -0.14022532f, 0.15425271f, 0.03543599f, 
    0.10422247f, -0.08409780f, -0.00860629f, -0.03590225f, -0.10029387f, 0.09721708f, -0.03824466f, 0.15386519f, 
    0.06827834f, 0.14756157f, 0.10409498f, -0.06803191f, -0.14383805f, 0.03700906f, -0.03825451f, 0.01150524f, 
    0.00168882f, 0.26537579f, 0.16356060f, -0.11734115f, -0.00658914f, 0.10334952f, -0.01913331f, -0.18401302f, 
    -0.13232735f, 0.02803354f, -0.15228088f, 0.09529557f, 0.20266217f, 0.14316881f, 0.21062160f, 0.09087168f, 
    0.00772116f, 0.22553162f, -0.03219992f, -0.09130920f, 0.16943467f, 0.01414676f, -0.02216129f, -0.13529594f, 
    -0.16438733f, 0.03232491f, -0.12421529f, -0.02387258f, -0.02475172f, 0.06095349f, 0.00774409f, -0.09646513f, 
    0.08020087f, 0.08326476f, 0.02396021f, 0.14060366f, 0.37942064f, 0.10665667f, 0.06954069f, -0.09369944f, 
    -0.01230013f, -0.25785491f, -0.03489296f, 0.03807733f, 0.01482893f, 0.07420323f, -0.07868506f, 0.13564458f, 
    0.05802602f, -0.00936850f, 0.06063413f, -0.02195750f, 0.03797014f, -0.03582722f, -0.00268390f, -0.05545862f, 
    0.03999898f, 0.16432051f, -0.01511769f, 0.00604513f, -0.06135526f, -0.07285330f, 0.10794112f, 0.08673752f, 
    -0.11952373f, 0.12677073f, 0.14653961f, -0.12476268f, -0.03755814f, -0.10622305f, 0.00079373f, 0.03652124f, 
    -0.00054768f, -0.03703380f, -0.03596396f, -0.07364783f, 0.15228309f, -0.01698299f, -0.01985707f, 0.04932998f, 
    -0.03451024f, 0.15281554f, -0.10496408f, -0.00279559f, 0.00477051f, -0.01099692f, 0.03327127f, 0.02420786f, 
    -0.00803065f, 0.06459448f, 0.14779298f, 0.00169919f, 0.10012038f, -0.09372479f, 0.04280300f, 0.09980227f, 
    0.03225997f, -0.02750009f, 0.12366775f, 0.00761576f, 0.28240505f, 0.07585397f, -0.07182270f, 0.12190820f, 
    -0.20230323f, -0.14084755f, -0.08954915f, -0.07770812f, -0.05773229f, 0.09079407f, -0.16446903f, 0.05627982f, 
    -0.13073771f, -0.01165707f, 0.01860685f, 0.24474263f, 0.08692725f, 0.17124309f, -0.00462424f, 0.06935567f, 
    0.06026453f, -0.11594447f, 0.12412701f, 0.05370156f, 0.01458502f, 0.01236391f, -0.01921779f, 0.04121382f, 
    -0.08466575f, 0.06267630f, 0.07471487f, 0.02912025f, 0.07012971f, 0.12465484f, -0.00062215f, 0.15167023f, 
    0.23914397f, 0.24509385f, -0.01023822f, 0.08524797f, -0.03894306f, -0.03056129f, -0.00115031f, 0.00162969f, 
    -0.11886726f, -0.25258955f, -0.40960780f, 0.13154916f, 0.14309447f, 0.03994981f, -0.02331809f, -0.03303767f, 
    0.14017719f, -0.08210731f, -0.09525583f, -0.21911544f, -0.06770025f, -0.07461858f, 0.02631045f, -0.04332249f, 
    0.19821084f, -0.04518612f, 0.16620661f, 0.11682031f, 0.22733538f, -0.00302670f, -0.08451341f, 0.08838390f, 
    0.18076634f, 0.00988781f, 0.17815699f, -0.05676345f, 0.03568959f, 0.11235350f, -0.04209723f, -0.05754934f, 
    0.07397170f, 0.06174396f, 0.13044232f, 0.01891196f, -0.48529407f, -0.06440990f, 0.09303746f, -0.12379062f, 
    0.05616754f, -0.11482718f, 0.03971512f, 0.16371277f, 0.19349897f, -0.06128437f, -0.29954016f, -0.09651308f, 
    0.03495816f, -0.07228868f, 0.02017349f, 0.11197969f, 0.03241362f, 0.05354582f, -0.31669909f, -0.27305895f, 
    -0.23673575f, 0.00319236f, 0.10169782f, 0.13799694f, 0.02730519f, -0.08288246f, -0.08124864f, -0.07562292f, 
    -0.07752643f, 0.06662427f, -0.05097145f, -0.05821516f, -0.13210018f, 0.15029065f, 0.04429599f, -0.03031369f, 
    -0.34148765f, -0.47508428f, -0.20374265f, 0.05101227f, -0.03773018f, 0.06941335f, 0.18834402f, -0.19680728f, 
    -0.17869709f, -0.03330081f, -0.15149073f, -0.15494765f, -0.00908023f, -0.06137685f, 0.02019376f, 0.07853106f, 
    0.08473628f, 0.00401653f, 0.07865267f, 0.25167251f, 0.02782680f, 0.00066358f, 0.01826683f, -0.00651129f, 
    -0.02611830f, 0.08051557f, 0.06588503f, -0.18191367f, -0.19776630f, -0.24985404f, -0.07164752f, 0.12896614f, 
    0.02642073f, 0.02172129f, 0.02853826f, 0.01965600f, 0.23691139f, 0.21640678f, 0.19157657f, 0.09362630f, 
    0.06921068f, -0.01235199f, -0.09826555f, -0.01009664f, 0.04646120f, -0.06423318f, 0.07268250f, -0.19246511f, 
    -0.05935366f, 0.13116920f, 0.02265079f, 0.08978949f, -0.04829960f, 0.04064016f, -0.00553230f, 0.03199303f, 
    -0.07613533f, -0.21039400f, 0.14354223f, -0.06418627f, 0.05396352f, -0.01203842f, 0.01193502f, 0.13996382f, 
    -0.02183567f, -0.07833520f, -0.20380405f, -0.00650550f, -0.23236559f, 0.14049217f, 0.04470048f, 0.10545521f, 
    0.08862184f, 0.17558604f, 0.05500606f, 0.02999789f, -0.11875058f, -0.03786700f, -0.09129836f, -0.08310580f, 
    -0.00562268f, 0.16659863f, -0.07321906f, 0.03524456f, 0.06798674f, 0.03682020f, -0.23649979f, 0.09234397f, 
    -0.07422855f, 0.11862861f, 0.03149398f, -0.14485160f, 0.01870456f, -0.17866305f, -0.15444145f, 0.00831783f, 
    0.06164380f, -0.11839137f, 0.05862870f, -0.30765921f, -0.13994870f, 0.00456404f, 0.12220211f, 0.01063892f, 
    -0.07754739f, 0.03389870f, 0.05305128f, 0.14222071f, 0.19301069f, -0.13822339f, -0.01294111f, -0.16538076f, 
    -0.01746383f, 0.10789604f, -0.00856085f, -0.07485667f, 0.08217081f, -0.08371736f, -0.11224771f, 0.16755904f, 
    -0.15267156f, 0.00131774f, -0.13618611f, 0.12103976f, 0.13158397f, 0.13265780f, 0.18462041f, 0.04890983f, 
    0.05417199f, -0.13902797f, -0.11342689f, -0.10893359f, 0.14771464f, 0.00302787f, 0.05726817f, -0.04216973f, 
    -0.02229536f, 0.05638647f, 0.03087246f, -0.12021688f, 0.06401714f, -0.01594093f, 0.04329263f, 0.09003318f, 
    -0.04893348f, -0.21948205f, -0.12545787f, 0.14463176f, 0.05976269f, 0.06156874f, 0.09150720f, -0.22592211f, 
    0.05512025f, 0.11829942f, 0.12913203f, -0.02624559f, -0.07804146f, -0.13529351f, 0.09858739f, 0.06343877f, 
    -0.14018176f, 0.02195577f, -0.00098815f, -0.11812860f, 0.06436238f, -0.00859993f, 0.01365421f, 0.11418134f, 
    -0.04310779f, 0.13894442f, 0.18453680f, -0.23915252f, -0.25256440f, -0.06313541f, 0.07343876f, 0.16023144f, 
    -0.10872555f, -0.04671589f, -0.01372333f, 0.02890450f, 0.10128798f, -0.02876044f, -0.06209496f, 0.11944848f, 
    0.11615218f, 0.01999095f, 0.06421147f, -0.04759416f, -0.06819724f, 0.01031517f, -0.06102408f, 0.04003173f, 
    -0.10341119f, 0.11477755f, 0.17018823f, -0.08986770f, 0.06256643f, 0.18579485f, 0.09536242f, -0.07298886f, 
    0.12914976f, 0.00544524f, 0.05163253f, -0.07573371f, -0.02732004f, 0.02189720f, -0.03828970f, 0.06317077f, 
    -0.01318754f, -0.06161884f, -0.06769915f, -0.09155255f, 0.11798477f, -0.10126500f, 0.05335401f, 0.01877015f, 
    0.19543235f, 0.08417146f, 0.02435127f, 0.00086873f, -0.02112258f, -0.08654528f, -0.10592823f, 0.10514925f, 
    0.10509802f, -0.31229657f, 0.16903333f, -0.11708710f, -0.13078660f, 0.12675530f, 0.08422193f, -0.20750278f, 
    -0.02411805f, -0.00698824f, 0.03922090f, 0.06130221f, 0.13433945f, -0.14553340f, -0.02512805f, -0.08584770f, 
    -0.04152086f, 0.06237341f, 0.13437311f, 0.14738412f, -0.10400350f, -0.13295920f, -0.10378255f, -0.05315249f, 
    -0.03084804f, 0.11733848f, 0.04261501f, 0.05214054f, 0.24823558f, 0.18194079f, -0.01494269f, -0.05360686f, 
    0.07512423f, 0.20417884f, 0.03822545f, 0.07224093f, -0.05731200f, -0.14153121f, 0.01807557f, 0.01799510f, 
    -0.05552578f, 0.01406616f, 0.03528595f, -0.04231694f, 0.07876062f, 0.04219053f, 0.01798089f, 0.15657182f, 
    0.21573424f, 0.02275141f, -0.15088122f, -0.00779128f, 0.04530801f, 0.29334080f, -0.10096823f, -0.03870700f, 
    0.20763388f, 0.03409120f, -0.06934525f, 0.08103906f, -0.06447886f, -0.02583958f, 0.16747427f, 0.03019785f, 
    0.02310574f, 0.06183869f, -0.07009040f, -0.25334343f, -0.01555834f, 0.06720738f, 0.00097279f, 0.13626572f, 
    0.04716738f, -0.03509771f, 0.11070246f, -0.04648501f, -0.07010818f, 0.05914824f, -0.11712388f, -0.18219516f, 
    -0.26983392f, 0.01535962f, -0.26846552f, -0.12291788f, 0.04386910f, 0.06009523f, -0.05593760f, -0.09176601f, 
    0.10782491f, -0.13820942f, -0.06305933f, 0.30064076f, 0.03711350f, 0.08365011f, -0.02697524f, 0.00335646f, 
    -0.00751343f, -0.00387757f, 0.18621945f, -0.10489340f, -0.15829372f, -0.12726370f, -0.05327696f, 0.05467350f, 
    0.14452532f, -0.16397320f, -0.16944593f, -0.06159989f, -0.05236630f, -0.32485649f, -0.14430754f, 0.42454317f, 
    0.10889684f, -0.08547173f, 0.16694857f, 0.10458110f, 0.11555896f, 0.10337244f, -0.09123758f, 0.15754554f, 
    -0.06940278f, 0.05954426f, 0.01529642f, -0.03577296f, 0.07273304f, -0.09046507f, -0.26823381f, -0.14425781f, 
    0.05195154f, -0.09717923f, 0.01897656f, 0.03685146f, -0.08111659f, -0.13824089f, -0.13056223f, -0.12347847f, 
    0.00551801f, -0.10689951f, -0.00684795f, -0.31140533f, -0.14071399f, 0.02034266f, -0.14957260f, 0.07390012f, 
    -0.04452030f, 0.36886674f, 0.29919413f, 0.04082199f, -0.08966628f, 0.03749748f, 0.01594078f, 0.04394240f, 
    -0.08648793f, -0.24164908f, -0.35591939f, -0.16625889f, 0.03616577f, -0.05039953f, 0.12714383f, 0.01598387f, 
    0.20428951f, -0.03426640f, -0.13896959f, 0.20924859f, 0.07257359f, 0.15273514f, 0.08250352f, 0.06358585f, 
    -0.04783010f, -0.09653392f, -0.02146066f, 0.00665769f, 0.02758247f, 0.11895299f, -0.08599611f, 0.07954877f, 
    0.04575582f, -0.02058535f, -0.30682045f, -0.12697390f, 0.03127573f, 0.16926941f, 0.06892889f, 0.24366228f, 
    0.03372182f, -0.07982931f, 0.10854564f, -0.08381853f, -0.04890522f, -0.06085869f, -0.16527697f, 0.16003291f, 
    0.20483486f, 0.02018250f, 0.06982696f, 0.11694229f, 0.01908721f, 0.00690021f, -0.20425093f, -0.18731098f, 
    -0.08470800f, 0.05550704f, -0.01521820f, 0.02728326f, -0.01452952f, 0.00342412f, 0.14039941f, -0.08876230f, 
    -0.15403025f, -0.11369683f, -0.13303700f, 0.01367502f, 0.03676576f, -0.01185034f, 0.11234230f, 0.02633163f, 
    0.10283450f, -0.10699137f, -0.12128732f, -0.05944308f, -0.02700365f, -0.11316342f, 0.12451933f, 0.08195342f, 
    -0.02633415f, 0.00108320f, 0.03880790f, -0.15996650f, 0.14106339f, -0.01178748f, -0.12565652f, 0.03618740f, 
    0.00015576f, -0.10769003f, 0.05281708f, -0.19866140f, -0.25841990f, 0.05838597f, 0.12562399f, -0.15362115f, 
    -0.14461213f, -0.01298861f, -0.09837630f, 0.02474268f, -0.05185127f, 0.04426515f, -0.11142936f, 0.00337676f, 
    0.09308913f, -0.17280656f, -0.12582786f, -0.00921867f, -0.04073977f, 0.10901267f, -0.16045494f, 0.02301439f, 
    -0.03948702f, -0.00780603f, 0.13185574f, -0.06221564f, -0.19796512f, 0.09763342f, 0.29405746f, 0.10608836f, 
    0.12882507f, 0.04232578f, 0.06688134f, -0.05346704f, -0.08087048f, 0.13443653f, 0.02787149f, 0.13766746f, 
    -0.03953681f, 0.15526769f, -0.02996489f, 0.01728355f, -0.10516345f, -0.03813880f, 0.00108293f, 0.04870553f, 
    0.50622952f, 0.05486741f, 0.09061179f, -0.05746512f, -0.01203876f, -0.11515626f, -0.03518156f, -0.01566772f, 
    0.02120698f, -0.26075324f, 0.03146693f, -0.15921931f, -0.13042365f, 0.17394401f, -0.12854116f, -0.00424327f, 
    -0.00246921f, -0.12760739f, -0.01837683f, 0.00206963f, -0.04409319f, -0.00860423f, -0.00801980f, -0.13495512f, 
    0.10496759f, -0.09265786f, -0.13943584f, 0.13228019f, -0.19922578f, -0.25439140f, 0.19097814f, -0.01305403f, 
    0.15191661f, -0.12217581f, 0.00735363f, -0.03597705f, 0.00830853f, -0.05172889f, 0.03576464f, -0.15778981f, 
    0.24710454f, 0.01957837f, -0.02466861f, -0.09444630f, -0.16033646f, 0.13187966f, 0.01782350f, -0.08969991f, 
    0.00671903f, -0.00578435f, 0.12267470f, 0.00390545f, 0.07316753f, 0.11138978f, 0.41177979f, -0.05120885f, 
    0.19321150f, -0.06146350f, 0.01255315f, 0.08488742f, 0.04444236f, 0.21516420f, -0.03092382f, -0.04062335f, 
    0.13681352f, 0.09091208f, -0.09118408f, 0.14185099f, -0.11891836f, 0.12578808f, 0.02878322f, 0.09361327f, 
    0.16256630f, -0.03814245f, -0.02480174f, 0.04511440f, 0.05336655f, 0.06263988f, 0.02649385f, 0.05968633f, 
    -0.01542128f, -0.22063667f, 0.01314931f, -0.05921407f, 0.01031571f, 0.21321933f, 0.00223475f, -0.03139554f, 
    -0.05789144f, 0.00857811f, -0.01872990f, -0.05644320f, -0.02163158f, -0.01350942f, 0.10467649f, -0.04521255f, 
    0.07192308f, 0.05553382f, 0.06301820f, 0.47047117f, 0.04016829f, 0.14060022f, -0.02311355f, 0.14908430f, 
    0.10455656f, 0.00460363f, 0.19946216f, -0.00927715f, 0.01786167f, 0.05235111f, -0.05199505f, 0.08934832f, 
    0.15308495f, 0.04824382f, 0.05121391f, 0.08442371f, 0.10466865f, -0.38342798f, -0.18797320f, 0.19232818f, 
    -0.16650487f, 0.00001709f, -0.10062131f, 0.02233453f, -0.06886894f, -0.18736018f, -0.12440839f, 0.07408661f, 
    0.09712640f, 0.03804599f, 0.07979248f, -0.12106432f, 0.06211779f, 0.05633070f, 0.00844662f, -0.23942421f, 
    0.04243240f, -0.10047308f, 0.05145403f, 0.10774418f, -0.01790095f, -0.15967940f, -0.10891489f, -0.09903192f, 
    -0.14924444f, -0.20435452f, -0.22832951f, 0.16823260f, -0.11814743f, -0.21413349f, -0.15557131f, -0.08697562f, 
    -0.12104474f, 0.22301246f, 0.19504957f, 0.14505854f, -0.18131387f, 0.03620809f, -0.03375355f, -0.03497189f, 
    0.04986520f, -0.02958804f, -0.25090694f, -0.07592162f, -0.18356343f, 0.07261109f, 0.08246484f, 0.03157933f, 
    -0.00611633f, -0.16204481f, 0.00516960f, 0.15063278f, -0.01931124f, 0.04045014f, -0.02563301f, 0.02871300f, 
    -0.06353871f, 0.05272061f, -0.13107952f, -0.01790583f, -0.16565360f, -0.03116906f, 0.09330119f, 0.08095342f, 
    0.06767062f, 0.00012060f, -0.13154848f, 0.01598648f, 0.03191531f, 0.03595178f, -0.22096342f, 0.14612672f, 
    -0.01957258f, 0.00017648f, -0.05035676f, 0.05384590f, -0.39369261f, 0.13879788f, -0.08494594f, -0.15174575f, 
    0.14774987f, -0.03332856f, -0.01087437f, 0.15244204f, -0.08070457f, -0.14793122f, -0.01657513f, -0.02941485f, 
    -0.01484500f, -0.21333468f, -0.08539256f, 0.05406227f, -0.04072759f, -0.00392781f, -0.01803315f, 0.00645967f, 
    -0.07101898f, 0.19240186f, 0.22147384f, 0.00908313f, 0.07416166f, 0.09377754f, -0.02692373f, 0.17765580f, 
    -0.04329059f, -0.00041027f, 0.11921897f, -0.01399035f, -0.04680308f, 0.03995025f, 0.13426651f, 0.05563401f, 
    0.14401643f, -0.36996678f, 0.00909967f, 0.00395454f, -0.00546434f, -0.07060909f, 0.01004623f, -0.00558067f, 
    -0.23738644f, -0.20625703f, -0.05650674f, 0.19200900f, 0.20109761f, -0.01897023f, 0.15428367f, -0.03708783f, 
    0.10463696f, 0.03131444f, -0.08627053f, -0.07738978f, 0.00203506f, 0.10050289f, 0.08442034f, -0.00631185f, 
    -0.10987607f, 0.01497759f, 0.08278301f, 0.05760219f, -0.05799876f, -0.03970290f, 0.02490171f, -0.02935420f, 
    0.02976618f, -0.03395816f, -0.01339029f, -0.17744738f, -0.18596649f, -0.14783302f, -0.06020736f, -0.06006236f, 
    -0.01996712f, -0.14240612f, -0.00264383f, 0.06201372f, -0.10668408f, 0.17193179f, -0.02054641f, 0.01591200f, 
    0.06219717f, 0.04639872f, -0.00390044f, 0.08507676f, 0.02727828f, 0.11452089f, -0.08328779f, -0.11488222f, 
    -0.02674772f, 0.04991006f, -0.03281116f, 0.08251845f, -0.03054698f, 0.03367191f, -0.14269476f, -0.04388351f, 
    -0.00978679f, 0.19472978f, -0.00459286f, -0.15669774f, 0.01840844f, 0.03028277f, 0.13306203f, 0.01086138f, 
    0.02290568f, 0.04645056f, 0.04774417f, 0.08001529f, -0.00533317f, 0.03627729f, -0.04713329f, 0.01152356f, 
    0.07573538f, -0.10892632f, -0.20264232f, 0.22380017f, 0.35235062f, 0.00454340f, 0.26129889f, -0.02593958f, 
    0.13502364f, -0.04685923f, 0.10656813f, -0.02788828f, -0.11363231f, -0.11798105f, 0.34662166f, 0.10059964f, 
    -0.11246715f, 0.08642221f, 0.05303206f, -0.11767115f, 0.00982605f, 0.15396443f, 0.01707465f, 0.05319360f, 
    0.00023492f, 0.18580334f, 0.01048356f, 0.11568987f, -0.06696156f, 0.00372840f, 0.05581448f, -0.13808928f, 
    0.05008084f, -0.09554737f, 0.09044912f, 0.00283458f, -0.01065848f, -0.02918163f, -0.00599440f, -0.08418965f, 
    -0.04068299f, -0.12736940f, -0.08546753f, 0.00757772f, -0.15216951f, -0.15884055f, 0.08585858f, -0.16709898f, 
    -0.14982052f, -0.15948883f, -0.01738651f, -0.04476646f, -0.04823714f, 0.01386394f, -0.26522818f, -0.20542607f, 
    -0.17362972f, -0.01867401f, 0.11932102f, -0.09725612f, -0.11800492f, -0.07879943f, -0.09984764f, 0.15219679f, 
    0.14287408f, -0.02899463f, 0.00610390f, 0.11889273f, 0.14495808f, -0.13242683f, 0.12449844f, -0.06304088f, 
    0.27126232f, -0.02400728f, 0.26409250f, 0.00996263f, -0.07942851f, 0.20859013f, 0.06138500f, 0.22619803f, 
    0.05699077f, -0.13832140f, -0.21847682f, 0.29324418f, -0.01530723f, 0.18675403f, 0.10848009f, -0.14997359f, 
    -0.11416821f, -0.00531485f, 0.06366622f, 0.24790639f, 0.12501739f, 0.05467758f, -0.01320277f, -0.13893226f, 
    0.02956424f, 0.12775087f, 0.12177836f, 0.04051758f, -0.06630141f, -0.24141134f, -0.10172121f, 0.10353479f, 
    0.07682958f, 0.08002755f, 0.05359748f, -0.12666778f, 0.06799909f, 0.10653151f, 0.08369315f, 0.00267179f, 
    0.00206833f, -0.19899400f, 0.05604124f, 0.14789766f, -0.03522672f, -0.06767985f, -0.10299614f, 0.00285770f, 
    0.07398907f, 0.19493999f, -0.09670848f, 0.20335190f, 0.05351842f, 0.05543573f, 0.08847706f, 0.06509526f, 
    -0.22517876f, -0.17444445f, -0.07533392f, -0.06748690f, -0.08272354f, 0.17431551f, 0.00442418f, -0.11130076f, 
    -0.17564172f, -0.09590302f, -0.04872627f, -0.05594051f, 0.04188769f, 0.09440216f, -0.01011813f, 0.09739785f, 
    -0.28837222f, -0.15022323f, -0.19181907f, 0.08116550f, -0.00475874f, -0.13143425f, -0.03352368f, -0.07530120f, 
    0.09263020f, -0.14773281f, 0.01170207f, -0.05284880f, 0.17955355f, -0.02752787f, -0.18813533f, -0.05527771f, 
    -0.10486703f, -0.07722025f, -0.03160716f, 0.09227678f, 0.07954321f, -0.02254242f, 0.03349249f, 0.01708995f, 
    0.06191017f, 0.05418931f, 0.16579920f, -0.14562032f, -0.01087453f, -0.02105431f, -0.06243785f, 0.11779559f, 
    -0.04097575f, 0.20805143f, 0.04425591f, -0.03491992f, -0.10726759f, -0.20960204f, -0.01828662f, -0.01303219f, 
    -0.09908319f, 0.06910828f, -0.01164322f, 0.10326051f, -0.02168626f, -0.12409028f, -0.13176073f, -0.15468554f, 
    -0.20045546f, 0.04005935f, 0.22132957f, 0.01747989f, 0.11498374f, 0.02514546f, 0.00638863f, 0.09990516f, 
    0.08709649f, -0.17024213f, -0.03465781f, -0.25878364f, -0.04825470f, -0.06197209f, 0.23534362f, 0.07506073f, 
    0.10909883f, 0.10813301f, -0.34287617f, 0.07502057f, 0.13319883f, 0.00501880f, 0.02846968f, -0.11473418f, 
    -0.08167419f, -0.02422958f, -0.14482929f, -0.18371664f, 0.17394112f, -0.13825890f, 0.03651642f, -0.05736599f, 
    -0.11114691f, -0.02232860f, 0.08921151f, 0.13227220f, -0.14362481f, 0.06259263f, 0.27462089f, -0.00116647f, 
    0.09944629f, -0.03622096f, -0.06957198f, 0.07381278f, 0.06566574f, -0.06533366f, 0.09331960f, -0.06922304f, 
    0.15649097f, -0.07668642f, -0.05292038f, 0.02338310f, -0.17087924f, -0.17479584f, 0.01805264f, 0.13918649f, 
    0.16402540f, 0.06480026f, 0.13975686f, 0.03765259f, -0.01313721f, -0.00006072f, 0.07980021f, -0.01206230f, 
    0.28850320f, 0.18178236f, -0.19607179f, -0.05346677f, -0.09612383f, 0.10960232f, 0.02255416f, 0.05923456f, 
    0.25719482f, -0.18914139f, 0.04298673f, 0.14234662f, 0.03307496f, -0.08047982f, -0.02097739f, 0.02645943f, 
    -0.07956754f, 0.15728605f, -0.22374600f, -0.06003285f, -0.03764712f, -0.05643927f, 0.03162436f, -0.02538802f, 
    -0.17338905f, -0.02266178f, -0.00036080f, 0.12036813f, 0.02677521f, -0.11048860f, -0.04526601f, -0.08514979f, 
    0.06078276f, 0.04639357f, -0.01861661f, 0.00226995f, 0.04164144f, 0.02007826f, 0.08613532f, -0.03134218f, 
    0.23291014f, -0.17572726f, -0.11855511f, 0.04276203f, -0.46408236f, -0.19004442f, 0.20173630f, -0.00165246f, 
    0.00763710f, -0.02251859f, 0.02240476f, -0.02946970f, 0.03919396f, 0.31539476f, -0.01315948f, 0.14535072f, 
    0.11724579f, -0.20187816f, 0.13154665f, 0.06856810f, 0.02148763f, -0.10561388f, 0.27404684f, -0.27347016f, 
    0.08404707f, 0.11245041f, 0.04079447f, -0.04738537f, 0.02671640f, 0.00530470f, -0.06241596f, -0.08612325f, 
    0.05548815f, 0.06441337f, -0.01552070f, -0.00760756f, 0.05091885f, -0.09131162f, -0.00706088f, -0.03861718f, 
    0.11163212f, -0.17962354f, 0.08813951f, -0.00566222f, -0.00046099f, -0.06919440f, 0.01899722f, 0.11801717f, 
    0.10928196f, 0.02162141f, -0.04347296f, -0.06525020f, -0.04256140f, -0.04628977f, 0.04800856f, 0.01733228f, 
    0.09362491f, 0.04742043f, -0.07538299f, -0.08273630f, -0.27039549f, 0.07795645f, 0.00704638f, 0.02793518f, 
    0.19647998f, 0.09617592f, 0.17924924f, 0.10565287f, 0.13126764f, 0.17629203f, 0.10999665f, 0.08093458f, 
    0.06889849f, -0.06100117f, 0.04741344f, -0.04739823f, -0.09967575f, 0.00677874f, 0.05894249f, 0.08223987f, 
    0.11239764f, -0.04105122f, 0.07533436f, 0.20276892f, 0.09634193f, -0.21158555f, -0.02122960f, -0.17490613f, 
    -0.01836187f, 0.01707691f, -0.22914989f, -0.11542536f, -0.09615854f, -0.13318586f, -0.05382214f, -0.00967891f, 
    0.23137215f, 0.05383476f, 0.08614083f, 0.03565490f, 0.13199872f, -0.13642675f, -0.00810170f, -0.11079784f, 
    -0.01488551f, 0.16863166f, 0.00161211f, 0.05745726f, -0.01743719f, -0.02790227f, -0.02897647f, 0.07874483f, 
    0.26791245f, 0.08079862f, -0.59328991f, -0.05465531f, -0.01201849f, 0.04657120f, 0.06099423f, 0.18764693f, 
    -0.04505651f, 0.11667507f, 0.05258561f, 0.19422482f, -0.06811896f, -0.09571683f, -0.05273116f, -0.06351926f, 
    -0.14704727f, -0.01179721f, 0.15488653f, -0.10257237f, 0.02530791f, 0.06856856f, -0.06130248f, -0.05585024f, 
    0.08452085f, -0.02882046f, -0.14438264f, 0.06521428f, -0.12593375f, 0.29550862f, -0.08110219f, -0.05475865f, 
    -0.02476086f, 0.11069331f, 0.11990853f, 0.09788290f, -0.32512569f, -0.13561261f, 0.12013618f, 0.19534996f, 
    0.04635501f, -0.03832607f, 0.03801596f, -0.07609108f, -0.05762053f, -0.30934459f, -0.27139312f, 0.17202199f, 
    0.18596418f, -0.06808519f, -0.10541563f, -0.14683403f, -0.00878461f, -0.13093868f, -0.18169151f, -0.11139532f, 
    0.33988458f, 0.07282601f, -0.14393155f, 0.03237898f, -0.08004931f, -0.06137042f, 0.08461405f, -0.03269505f, 
    0.04525739f, 0.01816102f, 0.07588336f, -0.02278596f, -0.14247781f, -0.06640430f, -0.07600734f, -0.05079818f, 
    -0.03133922f, -0.13222829f, -0.00491956f, 0.17545986f, -0.07408281f, -0.09122054f, 0.19181228f, -0.12047191f, 
    0.00637580f, -0.09838404f, 0.12095966f, 0.14021754f, 0.04878464f, 0.04302736f, 0.07203603f, -0.10682084f, 
    -0.05289605f, 0.16249947f, -0.06931498f, -0.22020711f, -0.42686692f, 0.03496225f, -0.10516737f, -0.19223090f, 
    0.06879348f, 0.05736528f, -0.02322984f, 0.10599804f, 0.19236048f, 0.00545108f, 0.02923279f, 0.03054055f, 
    0.13179994f, 0.05809994f, 0.07953466f, 0.07494381f, 0.21764565f, 0.33475727f, 0.29819083f, -0.12201785f, 
    -0.05495569f, 0.19409235f, 0.14542687f, -0.16237722f, -0.07326280f, -0.09447119f, -0.21037878f, -0.43062398f, 
    -0.05155702f, 0.01053353f, -0.06473401f, 0.11100313f, -0.10115585f, -0.08829354f, 0.04630001f, -0.14278895f, 
    0.16917859f, 0.03428141f, -0.00889990f, 0.00635974f, -0.14118665f, -0.04052779f, -0.05674763f, 0.13225807f, 
    0.04676005f, -0.21857119f, 0.03464419f, -0.03356414f, -0.13306008f, -0.05431305f, -0.07615041f, 0.06421281f, 
    0.25054616f, -0.22378756f, 0.02804801f, 0.03725104f, -0.06167563f, 0.07800790f, 0.04570919f, -0.09582569f, 
    0.06590533f, 0.07829317f, -0.13319218f, -0.15500921f, -0.02453757f, -0.11779581f, 0.12956609f, 0.04895438f, 
    0.01983015f, -0.07621323f, 0.13374534f, -0.01721644f, -0.03268034f, 0.03181741f, -0.01638502f, -0.05934877f, 
    -0.30487412f, -0.08074786f, 0.18010679f, -0.13362652f, -0.08001919f, -0.03528564f, -0.16965778f, 0.08849072f, 
    0.13744207f, -0.08036967f, 0.07320475f, -0.06174222f, -0.01523761f, 0.24549256f, 0.17116697f, -0.00348080f, 
    0.05281192f, 0.14100319f, 0.01791181f, 0.11748879f, -0.07900994f, 0.08681791f, -0.05355923f, 0.13575813f, 
    -0.01909191f, -0.01980122f, 0.11291822f, 0.04193432f, 0.09396865f, 0.13651028f, 0.21896307f, -0.06502363f, 
    0.16588694f, -0.12395605f, 0.04971085f, 0.00183555f, 0.17168464f, -0.18548252f, 0.11311008f, 0.09295385f, 
    0.21117803f, 0.24848957f, -0.04642481f, -0.01929672f, -0.01420503f, 0.17018548f, -0.04792537f, 0.09367218f, 
    0.00234408f, 0.02961176f, -0.03538867f, 0.00900989f, 0.13136682f, -0.10517010f, 0.05270854f, -0.15847702f, 
    0.10864597f, 0.22513941f, -0.08882228f, -0.31494859f, 0.07897607f, 0.04841561f, 0.06087207f, 0.05953060f, 
    0.06189408f, -0.17966235f, -0.23608337f, -0.02025224f, 0.11275095f, 0.04963754f, -0.05364264f, 0.09810209f, 
    0.02516949f, 0.01292351f, 0.15530185f, 0.03068623f, -0.19899900f, 0.08627496f, 0.00765149f, 0.02406868f, 
    0.01110850f, 0.07779393f, -0.07894249f, -0.02304929f, -0.01429191f, 0.05282209f, 0.03660373f, 0.16507909f, 
    -0.04542403f, 0.18306786f, 0.04617110f, -0.07212939f, 0.06318057f, -0.05212866f, -0.01728463f, -0.03026020f, 
    0.12058408f, -0.16083428f, 0.06721711f, -0.06414765f, -0.03466187f, -0.05836651f, 0.10241249f, 0.12676220f, 
    0.13190338f, -0.00166461f, -0.00406183f, -0.02343214f, 0.06434314f, 0.04319005f, 0.11212148f, 0.09458992f, 
    0.20855433f, -0.03790214f, -0.19051211f, -0.06370813f, -0.19271280f, 0.12289136f, -0.03861550f, -0.01277202f, 
    0.07246613f, -0.12932929f, 0.00482857f, 0.03020467f, 0.06775621f, 0.21953803f, -0.08191261f, 0.04321488f, 
    -0.07902698f, 0.06499940f, 0.02597031f, 0.06494720f, -0.03054828f, -0.03604933f, 0.15417342f, -0.03719735f, 
    -0.08577594f, -0.02068389f, 0.01457021f, 0.08316906f, 0.03114330f, -0.00788468f, 0.01338476f, -0.07476208f, 
    -0.02960536f, -0.11447720f, 0.23333365f, 0.03257377f, -0.08538865f, 0.26052317f, -0.04043131f, 0.00736537f, 
    -0.00782218f, -0.13769118f, 0.05742060f, -0.01012003f, 0.06749710f, -0.12931991f, -0.47142938f, -0.01148085f, 
    -0.05409467f, -0.06716314f, 0.09004467f, -0.03437990f, -0.07455705f, -0.00544055f, 0.03248931f, 0.07182748f, 
    0.03283232f, 0.01881719f, 0.04786396f, 0.00637703f, -0.02623816f, -0.09163562f, 0.14124258f, 0.23220725f, 
    0.09511763f, -0.03037177f, 0.10900050f, -0.12625831f, 0.02860589f, -0.01735269f, -0.17061400f, 0.01972750f, 
    0.06607562f, 0.06987557f, 0.01756057f, -0.22231728f, -0.05535593f, -0.10054414f, -0.00118796f, -0.01656977f, 
    -0.04058793f, -0.31346121f, -0.06290342f, 0.01251597f, -0.02630945f, -0.02792713f, 0.01272928f, 0.02224597f, 
    0.01525154f, -0.28567278f, -0.05881527f, 0.37630686f, -0.11919294f, 0.09076874f, -0.03205956f, 0.10962039f, 
    0.13749547f, 0.03732172f, 0.08246752f, -0.28544286f, -0.34697333f, -0.13549101f, -0.08626883f, 0.06147528f, 
    0.02149679f, 0.05483748f, -0.14388284f, -0.08197640f, -0.14961874f, 0.18749511f, -0.09794328f, 0.01913970f, 
    0.08781437f, -0.11754645f, 0.10397404f, -0.05463282f, 0.25820705f, 0.27548820f, -0.12152690f, -0.07304098f, 
    0.01204258f, -0.19746433f, 0.03224675f, -0.05209287f, 0.05564551f, 0.00765942f, -0.29599664f, -0.11086981f, 
    -0.11056547f, -0.05847912f, 0.06329386f, 0.05959490f, 0.02020606f, -0.03529825f, 0.14020230f, 0.05614878f, 
    0.16408297f, 0.01967983f, -0.07458772f, 0.09524330f, 0.13175115f, 0.10382476f, 0.02357488f, -0.02269946f, 
    -0.03323776f, -0.07091446f, -0.03632510f, 0.00535499f, -0.16385637f, 0.04068129f, 0.14374435f, -0.07248931f, 
    0.22419474f, 0.25808650f, 0.14163952f, -0.05452433f, -0.24328461f, 0.03041223f, -0.08044697f, -0.07265596f, 
    0.17985660f, -0.14472014f, -0.49993005f, -0.31558675f, -0.08063994f, 0.07585470f, 0.19575775f, 0.01416527f, 
    0.06172622f, 0.08472023f, -0.14359938f, 0.15267077f, 0.09504738f, -0.08683798f, -0.16623957f, -0.06824349f, 
    0.07748140f, 0.16685042f, -0.02153933f, 0.14852910f, -0.18698180f, 0.09022664f, 0.14970143f, 0.18504295f, 
    0.02179953f, -0.18054606f, 0.17393504f, -0.21665668f, 0.03206880f, 0.06856564f, 0.00342658f, 0.10497780f, 
    0.07553579f, -0.07353704f, -0.08231118f, -0.11477818f, -0.00214703f, 0.28492814f, -0.02588764f, 0.21192443f, 
    -0.00919091f, 0.00978399f, -0.05236034f, 0.12670934f, 0.11246647f, 0.10471149f, 0.16858585f, 0.16879161f, 
    0.18461923f, -0.06882624f, -0.05743577f, -0.02757234f, 0.06956077f, 0.08660392f, -0.03721339f, 0.14627090f, 
    0.03965794f, 0.18936658f, -0.13234888f, -0.02069532f, -0.07305692f, 0.14120331f, -0.19894393f, -0.03330691f, 
    0.05784163f, 0.11225645f, 0.08882899f, 0.01881535f, -0.02447408f, -0.09014612f, 0.00405237f, 0.03556262f, 
    0.13955887f, -0.09561055f, -0.22717333f, -0.53909165f, -0.02714391f, 0.05490014f, -0.05259595f, -0.09525114f, 
    0.02078893f, 0.06533279f, -0.36413997f, -0.04923281f, 0.36979258f, -0.04589143f, -0.05903947f, 0.17361961f, 
    -0.03649632f, 0.13037771f, 0.06483123f, 0.21153621f, 0.10548712f, -0.00584389f, 0.06631692f, 0.03298483f, 
    -0.03468039f, 0.00313716f, 0.10167843f, 0.00343473f, -0.07142292f, -0.08876241f, -0.11521364f, 0.02678483f, 
    0.03551574f, 0.04012365f, -0.02285171f, 0.03726688f, 0.25096416f, -0.41379899f, -0.04132184f, -0.09523820f, 
    -0.04637267f, -0.00825585f, 0.20130286f, -0.11788670f, 0.04598645f, -0.04687842f, 0.15618369f, 0.17665367f, 
    0.09355199f, 0.09048507f, 0.08063676f, -0.07742365f, 0.11504789f, -0.05445870f, 0.00642338f, 0.00136926f, 
    0.13874473f, -0.22314705f, 0.06709687f, -0.09568395f, -0.25325173f, -0.05733496f, -0.22150566f, 0.05370203f, 
    -0.42489433f, 0.18917073f, -0.05985562f, -0.02033729f, -0.12078980f, 0.12844659f, -0.16482992f, 0.00772737f, 
    0.01535850f, 0.13605307f, 0.05436868f, -0.00819108f, -0.03460491f, -0.14934051f, -0.09442560f, -0.29488623f, 
    0.19759634f, -0.04704089f, -0.06926120f, -0.14029714f, 0.02461241f, -0.10148346f, -0.03779094f, -0.05097966f, 
    -0.06946374f, 0.01133064f, 0.11510634f, 0.00056823f, 0.05430643f, 0.21918762f, 0.03959341f, -0.03994426f, 
    -0.06762859f, -0.12020165f, -0.03896616f, 0.06063728f, -0.04856186f, -0.11906617f, -0.73886305f, 0.00561204f, 
    0.02988663f, -0.15669817f, -0.15003482f, -0.07444986f, -0.05958218f, -0.09132423f, 0.01040643f, -0.13490850f, 
    0.12556659f, -0.00471612f, -0.04505026f, -0.03346393f, -0.15006240f, 0.01482659f, 0.09947798f, 0.11992440f, 
    -0.03335329f, -0.09992824f, 0.13310310f, -0.23483305f, -0.02723955f, -0.09800567f, -0.01956075f, 0.08939838f, 
    -0.08101290f, 0.05613698f, -0.01618219f, -0.02822243f, 0.08269445f, 0.09215362f, 0.14063865f, 0.17207380f, 
    -0.00930081f, -0.05164453f, 0.01318967f, -0.12207752f, -0.01890147f, 0.05246135f, 0.04652569f, -0.15184313f, 
    0.03872098f, 0.33449313f, 0.12254392f, -0.01874445f, -0.10041489f, 0.03805334f, 0.01943815f, -0.01312283f, 
    -0.04936975f, -0.11976272f, 0.18673572f, 0.07785609f, 0.21738552f, 0.04372241f, -0.01331769f, 0.02347804f, 
    -0.04468298f, 0.12835701f, -0.07939040f, -0.03085857f, 0.20585883f, 0.23981906f, -0.21076453f, 0.08453023f, 
    -0.15402454f, -0.10322400f, -0.00872037f, -0.07710546f, -0.05399870f, -0.09416220f, -0.25908709f, -0.14219020f, 
    -0.08810002f, 0.12360626f, -0.13377234f, 0.02857562f, 0.17264099f, 0.27341133f, -0.03471481f, 0.07818821f, 
    0.02368736f, -0.00611568f, 0.01054358f, -0.03270340f, 0.06396197f, -0.01929705f, -0.07288074f, 0.09935042f, 
    -0.19637699f, 0.01005525f, 0.00193275f, -0.13233350f, 0.02032080f, 0.04329065f, 0.02443428f, 0.14051035f, 
    0.14177601f, 0.20329264f, -0.00648546f, 0.13075398f, -0.10697114f, 0.05187566f, 0.09055563f, -0.10303587f, 
    -0.39516830f, -0.14480723f, 0.12383499f, -0.09079812f, -0.01678983f, 0.01033794f, -0.06355882f, 0.05020520f, 
    0.00811256f, 0.09879138f, 0.06117706f, -0.16897278f, 0.07272418f, -0.07763601f, -0.01109215f, -0.02439034f, 
    0.18657234f, 0.06926175f, 0.20590112f, 0.17688274f, 0.12051895f, -0.05741075f, 0.12599935f, 0.06773666f, 
    0.01587298f, 0.01138253f, -0.08268833f, -0.10168974f, 0.04255554f, 0.06085999f, 0.03184410f, 0.03068530f, 
    -0.03973290f, 0.10146753f, -0.14366470f, 0.09812947f, -0.03829403f, -0.01286227f, 0.03388135f, -0.00578243f, 
    -0.07919074f, -0.09492998f, -0.03527251f, -0.02522018f, 0.11438242f, -0.07876926f, -0.15792635f, -0.10922148f, 
    0.06510488f, 0.03110691f, 0.15513414f, -0.05088896f, 0.13455667f, 0.15830953f, -0.16715677f, -0.19984710f, 
    -0.19881612f, -0.08129594f, 0.11196522f, 0.01880715f, 0.05960565f, 0.03341313f, -0.02675579f, 0.03452674f, 
    -0.20839912f, -0.04595355f, 0.11750682f, -0.01954309f, -0.00697612f, 0.02256892f, -0.04427931f, 0.21415819f, 
    -0.15150736f, -0.11291922f, -0.00964861f, 0.01708542f, 0.14450054f, -0.06922452f, 0.08363156f, 0.06415618f, 
    -0.00196628f, -0.04309343f, -0.13700692f, -0.06179893f, 0.02331915f, 0.06958238f, 0.23951069f, 0.01223268f, 
    0.10937450f, 0.09549404f, 0.10655619f, 0.14272960f, 0.09067462f, 0.08395257f, 0.00085589f, 0.02384156f, 
    0.04808939f, -0.09065909f, 0.08497328f, -0.16631271f, -0.13687362f, -0.05072610f, -0.03375425f, 0.07272664f, 
    0.01586203f, 0.16543543f, 0.18637560f, 0.00690381f, 0.18961598f, 0.15295367f, 0.00222673f, -0.01704182f, 
    0.00320444f, 0.04686493f, 0.03537649f, -0.09455933f, 0.19764909f, 0.17032751f, 0.17702234f, -0.10758454f, 
    -0.01280841f, -0.05767092f, -0.19623870f, -0.02758598f, 0.01330143f, -0.12198059f, -0.09765232f, -0.01175502f, 
    0.03613128f, -0.03942610f, 0.04608889f, 0.04773109f, -0.00822448f, -0.01163797f, 0.19273137f, -0.04398848f, 
    -0.37466866f, -0.22074598f, 0.08372699f, 0.03384971f, -0.08542867f, 0.04089907f, 0.00699632f, 0.04649917f, 
    -0.09276126f, 0.10942714f, 0.02190451f, -0.15474981f, -0.00818032f, 0.02887652f, -0.05577837f, 0.00042496f, 
    -0.03808976f, 0.03657490f, -0.31952992f, -0.29060718f, 0.14319544f, 0.03779136f, 0.02740606f, 0.10197065f, 
    0.14428465f, 0.00292459f, 0.25227293f, -0.00467369f, 0.11048400f, -0.02311372f, -0.03616077f, -0.07519985f, 
    0.03988134f, 0.04246105f, -0.02327177f, -0.17703205f, -0.04385649f, -0.11092515f, 0.03504340f, -0.00074328f, 
    -0.10496277f, -0.02659392f, -0.01071551f, 0.11648602f, 0.28308451f, -0.10923946f, -0.05709858f, 0.09876412f, 
    0.11077163f, 0.11085844f, -0.02434950f, 0.03373631f, 0.09721035f, 0.16717070f, -0.26591879f, 0.15737842f, 
    0.01461214f, -0.00884516f, 0.02035133f, -0.00725308f, 0.04746384f, 0.06713742f, -0.06332590f, 0.07141370f, 
    -0.08650676f, 0.03365584f, 0.06241162f, 0.01876944f, 0.05579712f, -0.03456890f, -0.09035079f, 0.11520578f, 
    -0.00953513f, -0.02592322f, 0.12687337f, 0.02719321f, 0.07283089f, 0.05903604f, -0.01184914f, 0.09014796f, 
    -0.07522176f, -0.03709925f, -0.00497433f, 0.00001872f, -0.00201305f, -0.06255118f, 0.02062684f, -0.07355814f, 
    0.00349441f, -0.07300652f, -0.06361620f, -0.01489279f, 0.01819639f, -0.02548811f, 0.01343046f, 0.02298296f, 
    -0.08150952f, -0.03015414f, -0.00511305f, -0.06902924f, -0.04389158f, -0.01012187f, 0.04316233f, -0.04720845f, 
    -0.03554809f, -0.05823879f, -0.03511027f, -0.03225159f, -0.09115130f, -0.03209760f, -0.03606766f, -0.03150663f, 
    0.01804944f, -0.02962638f, 0.02882987f, -0.06025367f, 0.02575676f, -0.02333695f, -0.01409171f, 0.01285089f, 
    0.01836694f, 0.01913697f, 0.01173298f, -0.01305071f, -0.00365318f, -0.05029393f, -0.01488628f, -0.01194212f, 
    -0.07291519f, -0.06508018f, -0.02979139f, -0.05466063f, -0.00782477f, 0.01940757f, -0.01477788f, -0.06094771f, 
    0.00965640f, -0.02649625f, 0.00897092f, -0.06262568f, -0.03878918f, -0.00691019f, 0.01762716f, -0.00958172f, 
    -0.01769295f, -0.05810124f, -0.05503312f, -0.02786786f, -0.04581982f, -0.03002708f, -0.05253300f, -0.04779287f, 
    0.02556475f, -0.05378253f, -0.03135091f, -0.03799575f, -0.04000173f, -0.03627649f, 0.01824674f, -0.06329723f, 
    -0.00735182f, -0.05347145f, -0.06962131f, 0.01666817f, -0.00222544f, -0.03045132f, -0.05484096f, 0.01380929f, 
    -0.03825489f, -0.03210749f, 0.02920592f, -0.05421902f, 0.01830937f, -0.04998660f, 0.01943039f, 0.02355694f, 
    0.01627556f, -0.00805673f, 0.04369460f, 0.02022196f, -0.07365857f, -0.04942317f, -0.01106336f, -0.05605705f, 
    0.01919111f, -0.04067821f, 0.02081469f, -0.02748369f, 0.00912642f, -0.02829113f, 0.00990650f, 0.02812510f, 
    -0.02499406f, -0.01933248f, -0.04281155f, 0.01709396f, 0.00994960f, -0.00554098f, -0.05444641f, -0.00489199f, 
    0.02859904f, -0.00574704f, -0.00957180f, -0.07778408f, -0.00691431f, 0.00778712f, -0.08196691f, -0.02370105f, 
    0.00084765f, -0.05585944f, 0.00766957f, 0.05032212f, -0.06282959f, -0.02193819f, 0.02813284f, -0.00228237f, 
    0.04209070f, 0.03537655f, 0.00402692f, -0.01454745f, -0.02382613f, -0.00909225f, -0.03580539f, -0.00297258f, 
    0.00873329f, 0.01823390f, -0.01904238f, -0.00463299f, -0.04589686f, 0.02096087f, -0.04081042f, -0.01925946f, 
    0.00108614f, 0.00702962f, -0.05651308f, -0.08276232f, 0.00093340f, -0.05365297f, 0.00843165f, -0.02092056f, 
    -0.00336401f, -0.04615899f, -0.06463043f, -0.02626308f, 0.01701486f, -0.01131334f, 0.01837115f, 0.01648205f, 
    -0.02247398f, 0.03892063f, -0.05102878f, 0.00267877f, -0.06567384f, 0.01898867f, -0.06857314f, -0.05635561f, 
    -0.03030425f, -0.01441972f, -0.03755261f, -0.03305174f, 0.00481669f, 0.02401792f, 0.01039641f, -0.07819743f, 
    0.01476160f, 0.00271246f, -0.04522241f, -0.02967746f, 0.02429546f, 0.01465800f, 0.03051554f, 0.01457930f, 
    -0.02887476f, 0.04363143f, -0.01599355f, 0.01036110f, -0.07050890f, -0.04018201f, -0.04560786f, -0.02082941f, 
    -0.07338436f, -0.05837965f, -0.05043109f, 0.00450023f, -0.06510821f, -0.05066793f, -0.03982762f, 0.05072960f, 
    0.01744733f, -0.04926133f, -0.01877483f, -0.03025425f, -0.08036333f, -0.03840212f, -0.07379029f, -0.02380541f, 
    0.01896986f, -0.00852373f, 0.01537145f, -0.03382188f, 0.02450808f, -0.06346913f, -0.06689568f, -0.05856549f, 
    -0.04775072f, -0.05562320f, 0.02393804f, 0.02776485f, -0.04333483f, -0.06694869f, -0.03026915f, 0.00102362f, 
    -0.05795743f, -0.07712588f, -0.00989411f, 0.04679299f, -0.02713020f, -0.00963822f, -0.05850737f, -0.00199944f, 
    -0.00265610f, -0.04374807f, 0.02232578f, -0.02198566f, 0.03932989f, -0.02931712f, 0.01362842f, 0.01521139f, 
    -0.05865207f, -0.00910753f, -0.08600225f, 0.00663481f, -0.03662469f, -0.07813614f, 0.00749156f, -0.01870328f, 
    -0.06116834f, -0.00688834f, -0.02360577f, 0.01051736f, 0.02396982f, 0.01525738f, -0.00310500f, -0.07132222f, 
    -0.05624954f, 0.02091084f, -0.02003631f, 0.02067351f, 0.00848354f, 0.03773697f, -0.02002973f, -0.03409888f, 
    -0.05153095f, -0.05836762f, -0.08194116f, -0.06194361f, 0.01976167f, -0.04765318f, -0.04836552f, 0.04251435f, 
    -0.03876032f, -0.02959933f, -0.00326337f, -0.04373768f, 0.01468759f, -0.01021688f, -0.00799375f, 0.00060005f, 
    0.08005158f, 0.01393581f, -0.14657860f, 0.12226088f, 0.23363860f, 0.08751653f, -0.07327356f, -0.00472792f, 
    0.07926206f, 0.17386021f, 0.05971212f, 0.12375080f, 0.16026805f, -0.05361896f, -0.05167364f, 0.07787108f, 
    0.07842981f, 0.02518730f, -0.08745676f, 0.04725323f, 0.07940272f, 0.09735288f, 0.01418165f, 0.04697615f, 
    0.10804416f, 0.15910876f, 0.13562040f, 0.04805708f, 0.15020058f, -0.01275095f, 0.38281727f, 0.22599514f, 
    -0.03493426f, -0.10875397f, 0.16193253f, -0.04105423f, 0.10300286f, 0.05812766f, -0.03096790f, -0.02375868f, 
    0.05382939f, 0.13611414f, 0.01244771f, 0.05381562f, -0.05470191f, -0.05018185f, 0.04519668f, 0.03744381f, 
    -0.05655037f, 0.10417752f, 0.01374735f, 0.11605687f, 0.06226555f, 0.22994076f, 0.00274090f, 0.13889118f, 
    -0.14931811f, -0.06893974f, -0.06527992f, 0.02860472f, -0.00451995f, 0.00954215f, 0.05082410f, 0.05724369f, 
    -0.09314742f, -0.01344697f, 0.23146090f, 0.09091941f, 0.01742758f, -0.08271489f, -0.06389796f, 0.08133113f, 
    -0.05415419f, 0.39494127f, -0.04218235f, 0.01317432f, -0.10611410f, -0.12294684f, 0.06078022f, 0.12827399f, 
    0.10042223f, -0.35361344f, 0.01526572f, 0.10088842f, 0.00724773f, -0.03020135f, -0.03474948f, -0.03251048f, 
    -0.18713339f, -0.06371666f, 0.16336454f, 0.08599314f, 0.25365251f, 0.13581342f, -0.07953116f, -0.05940772f, 
    -0.06570813f, 0.08822802f, 0.23908792f, -0.02615558f, 0.06512178f, -0.03744208f, 0.05240976f, 0.12390829f, 
    -0.03858424f, 0.11134364f, 0.07323845f, 0.18485874f, 0.15516992f, 0.14124149f, -0.08286962f, -0.01451912f, 
    0.08643885f, 0.12561820f, 0.07504584f, -0.04150381f, 0.00396945f, -0.07017099f, 0.10001502f, 0.02217086f, 
    0.04427746f, 0.00258355f, -0.02694095f, 0.03642934f, 0.16481893f, 0.07614028f, 0.13954744f, 0.18868431f, 
    0.03698404f, -0.06301762f, 0.01239685f, -0.00381885f, -0.11183745f, 0.07230620f, -0.09489566f, 0.22035249f, 
    -0.04177085f, 0.02246750f, -0.02263707f, 0.05335328f, 0.01423818f, -0.08457310f, -0.08526629f, -0.03739792f, 
    0.28112608f, 0.08214428f, -0.05384226f, 0.05418139f, -0.09199683f, 0.09684556f, 0.10161956f, 0.18147042f, 
    0.01840542f, -0.17017654f, -0.10998183f, -0.01423815f, 0.02734147f, 0.07536276f, -0.16278805f, -0.10517937f, 
    -0.29439318f, -0.07048914f, -0.03197516f, -0.05494639f, 0.03034167f, 0.11697621f, 0.16299911f, -0.01944294f, 
    -0.16363637f, -0.21898228f, -0.22821163f, -0.04519068f, 0.17864078f, -0.10868540f, 0.07682647f, 0.09624019f, 
    -0.04778899f, -0.05109851f, 0.05110323f, -0.07408487f, -0.11901311f, -0.07511044f, -0.09292340f, 0.05550223f, 
    -0.07148141f, -0.02538130f, -0.21283031f, -0.45248702f, -0.34616584f, -0.23795833f, 0.24816649f, -0.17362700f, 
    -0.16603862f, 0.03419441f, 0.17280190f, 0.19050622f, 0.26457033f, 0.01817663f, 0.06968728f, -0.03148375f, 
    -0.02227594f, -0.02225850f, -0.06316102f, 0.01541954f, -0.01777325f, -0.10528004f, -0.01389437f, -0.03843189f, 
    -0.39404374f, -0.04281376f, -0.01974744f, 0.10122379f, 0.11346050f, -0.09785566f, -0.11509306f, -0.11039346f, 
    0.10598846f, 0.23031291f, 0.09817683f, 0.15968730f, 0.03583724f, -0.03438501f, 0.03653443f, 0.07516084f, 
    0.04689511f, -0.09640926f, -0.01251278f, -0.03128106f, -0.04726933f, 0.03238381f, 0.02565842f, 0.00720716f, 
    -0.07152791f, -0.02671174f, 0.01640894f, -0.03472343f, -0.10948034f, -0.02273026f, 0.09442634f, 0.07335579f, 
    0.19168423f, 0.08561858f, -0.04171229f, -0.07592798f, 0.25646141f, -0.05681087f, 0.02323451f, 0.00222153f, 
    -0.04402498f, 0.11893535f, -0.06111069f, 0.05712231f, 0.01878022f, -0.27673185f, 0.18256113f, -0.09000412f, 
    0.15625133f, 0.07725522f, -0.00648927f, -0.20702222f, 0.06820831f, 0.02417304f, -0.00935192f, 0.03664081f, 
    0.12739737f, 0.12290092f, -0.08144819f, 0.06841687f, 0.09406792f, 0.08343849f, 0.21555082f, 0.00299605f, 
    -0.00570689f, 0.14012896f, -0.02853327f, 0.00996271f, -0.01457376f, 0.11230896f, -0.01400679f, -0.24193850f, 
    0.24383163f, -0.03668827f, 0.06647914f, 0.05441302f, 0.15582471f, 0.13274461f, 0.07235350f, 0.03464366f, 
    0.04810981f, 0.03551952f, -0.06259947f, -0.01753809f, -0.05494870f, -0.00515637f, -0.04385855f, -0.03661070f, 
    0.04146915f, -0.02465709f, -0.04733467f, 0.04952509f, 0.00540658f, 0.01237806f, -0.05814077f, 0.01580002f, 
    -0.04134565f, -0.02028725f, -0.06467504f, 0.01661997f, -0.03870392f, -0.02494087f, 0.01222816f, -0.06074882f, 
    0.01870856f, 0.00817820f, -0.05309157f, 0.01649436f, 0.02956890f, 0.01775219f, -0.01741616f, 0.04642663f, 
    -0.00764936f, -0.05818759f, 0.02121253f, -0.06038794f, 0.01397990f, -0.03218412f, 0.00606112f, -0.00665110f, 
    -0.00848880f, -0.02513498f, 0.00354293f, 0.01146035f, -0.04742157f, 0.05000285f, 0.01495313f, -0.06238324f, 
    -0.04635099f, 0.03073561f, -0.00816925f, -0.00212483f, 0.00739132f, 0.00958050f, -0.00076811f, -0.01852532f, 
    0.00456646f, -0.00337416f, 0.05111488f, -0.02991728f, -0.06117208f, -0.03230209f, 0.01243843f, -0.01845279f, 
    -0.05320146f, -0.04256057f, -0.03323653f, -0.01318200f, 0.00001282f, 0.02053206f, -0.02322427f, 0.01941232f, 
    -0.02805181f, -0.03960988f, -0.05578588f, 0.04360557f, 0.04150033f, -0.03993492f, -0.02968498f, 0.03782637f, 
    -0.04903299f, 0.01305881f, 0.05268575f, -0.05715290f, -0.00093879f, -0.02200140f, -0.00886700f, 0.03301998f, 
    0.00763799f, 0.02588470f, -0.04777608f, 0.01149556f, -0.04572891f, -0.00675156f, 0.03104667f, -0.02385961f, 
    0.03288107f, -0.04501858f, -0.00136068f, 0.03378534f, -0.04686112f, -0.05890779f, 0.03732361f, -0.03242505f, 
    0.03045341f, -0.05806502f, -0.02370677f, -0.02118165f, -0.01361605f, -0.05615946f, -0.04044409f, -0.03641652f, 
    -0.00196264f, -0.02539734f, 0.04460836f, -0.05097885f, -0.01559841f, -0.03562245f, -0.00672152f, 0.04888925f, 
    -0.05305190f, 0.00397132f, -0.03014408f, -0.04894519f, -0.05486769f, -0.04678298f, 0.02470084f, 0.00944387f, 
    0.02495684f, 0.00655989f, 0.04120485f, -0.05127338f, -0.00331129f, -0.05683835f, -0.03701223f, 0.04653045f, 
    -0.02568619f, -0.03761123f, 0.03286414f, -0.01132998f, 0.04888358f, -0.05225708f, -0.03561638f, 0.02097081f, 
    -0.02556779f, 0.03757865f, 0.00614571f, 0.02994225f, 0.01468923f, 0.02730553f, 0.05013832f, 0.00625137f, 
    0.00013311f, -0.00825010f, -0.03439305f, 0.02564123f, -0.05789210f, 0.01148688f, -0.03203372f, -0.01655083f, 
    -0.05708339f, 0.04007515f, 0.03759205f, 0.02162908f, -0.03596800f, -0.04952395f, 0.03540942f, -0.04308052f, 
    -0.02686878f, 0.03543598f, -0.04625434f, -0.04538512f, 0.01680911f, -0.00898443f, -0.04884503f, -0.02704106f, 
    0.00651736f, -0.00892793f, 0.02836436f, 0.01104638f, -0.04757288f, 0.01834699f, 0.04120971f, 0.00241538f, 
    -0.04035482f, -0.05044624f, -0.05376161f, -0.03272495f, 0.00472821f, 0.05735822f, -0.01028562f, -0.05240216f, 
    0.00744523f, 0.05117124f, -0.00216268f, -0.05577391f, -0.00247615f, -0.05852693f, -0.05704039f, 0.04627964f, 
    -0.03581895f, 0.01085403f, -0.04647096f, 0.01123434f, 0.02400542f, -0.00719951f, 0.02485153f, -0.04083842f, 
    -0.04538473f, -0.00602928f, 0.04210588f, -0.04552179f, 0.01889115f, 0.01393786f, -0.04902144f, -0.00491529f, 
    -0.02464707f, 0.02502690f, 0.01694171f, -0.03501510f, 0.04193867f, -0.00029990f, -0.05308015f, 0.04974542f, 
    -0.03006417f, -0.06224469f, -0.00030369f, -0.02200789f, 0.00505180f, 0.02010930f, 0.01579861f, 0.01552258f, 
    0.01555539f, -0.02854819f, -0.02727091f, -0.02749644f, -0.01245832f, 0.02544274f, -0.06443401f, -0.05857790f, 
    0.03873413f, -0.05861914f, -0.02266827f, -0.03629900f, -0.02992366f, 0.05041070f, 0.02834265f, 0.02526592f, 
    -0.02525207f, 0.03560403f, -0.01625695f, -0.03091715f, 0.02087017f, -0.05145643f, 0.00139574f, 0.01063871f, 
    -0.05995570f, 0.03092134f, -0.05286715f, -0.01595051f, -0.03962385f, -0.05535543f, -0.04032766f, 0.03407934f, 
    0.04350594f, -0.05223100f, 0.04499651f, -0.00328948f, -0.00833748f, 0.01381051f, -0.02626937f, 0.02941364f, 
    -0.02731362f, -0.02955651f, -0.01572607f, -0.04012697f, 0.04549386f, -0.00132760f, -0.05746599f, 0.04262584f, 
    0.03045269f, 0.02704477f, -0.00665597f, -0.00822015f, 0.04894979f, -0.02115045f, -0.03097910f, -0.03718203f, 
    0.10624611f, 0.08901381f, 0.17864797f, -0.00579435f, -0.12984069f, 0.00736091f, 0.14723670f, -0.07093393f, 
    -0.05586201f, 0.00787788f, 0.25229543f, 0.09291896f, 0.05583056f, 0.07354202f, 0.07366277f, -0.04353185f, 
    0.02547381f, -0.16544460f, 0.19290932f, 0.04471278f, 0.03073809f, -0.10360271f, -0.07838231f, 0.07039867f, 
    -0.17626743f, 0.06383933f, -0.09869196f, 0.00660567f, 0.09292655f, -0.04044328f, -0.09611561f, 0.14532824f, 
    -0.03841139f, -0.01907799f, 0.05724429f, 0.03111391f, -0.08397021f, -0.34543973f, -0.08220328f, 0.14477077f, 
    -0.03470923f, -0.02867900f, 0.06560361f, 0.01919542f, 0.04711951f, 0.14758708f, 0.12912983f, 0.04396636f, 
    -0.00964647f, -0.01907083f, 0.11933341f, -0.08100548f, -0.02243049f, -0.02477537f, -0.00503053f, -0.04104149f, 
    -0.06157218f, 0.14762650f, -0.00356977f, 0.00831819f, 0.03325495f, -0.00578379f, 0.06706781f, 0.01667823f, 
    -0.00086158f, 0.16560656f, 0.01967091f, 0.04545612f, 0.00537423f, -0.00215043f, 0.02718845f, -0.01397331f, 
    -0.07952391f, 0.04108611f, -0.15354194f, -0.00436262f, 0.12456393f, -0.09676047f, 0.18484041f, 0.01623524f, 
    0.08916324f, 0.02235239f, 0.08875135f, 0.02308453f, 0.22230971f, 0.05889183f, 0.16105817f, -0.00387943f, 
    -0.08083136f, -0.09853972f, -0.00814725f, 0.06260664f, 0.13489726f, 0.02757872f, 0.03249888f, -0.17236976f, 
    -0.05445767f, 0.03579071f, -0.05176459f, 0.06247988f, 0.02727780f, 0.02951682f, 0.16486160f, -0.01931897f, 
    0.10986761f, -0.00003696f, 0.05195207f, -0.14063822f, 0.06994624f, -0.10146464f, -0.00185135f, 0.01619396f, 
    -0.11614608f, -0.01363847f, -0.09147733f, -0.05317871f, -0.09443583f, -0.02415135f, 0.09885345f, -0.11155102f, 
    -0.10342433f, -0.08543380f, -0.03593925f, 0.14364403f, -0.10115059f, 0.05354570f, -0.09872873f, -0.02397172f, 
    -0.00669497f, 0.14476477f, 0.05229265f, -0.05541978f, 0.12072799f, 0.01959665f, -0.01805528f, -0.09534752f, 
    -0.02591812f, -0.14490014f, 0.16207549f, 0.06301583f, 0.14205165f, 0.09142302f, -0.10789601f, 0.07365954f, 
    -0.08454359f, -0.11773252f, -0.01934619f, 0.09559942f, 0.02620203f, 0.04692057f, -0.21442506f, -0.32337186f, 
    -0.30253893f, -0.00490089f, 0.07056672f, 0.06035401f, 0.20834984f, -0.15059610f, -0.03336693f, -0.11591031f, 
    0.04083756f, -0.05568257f, 0.14990735f, 0.16048096f, 0.25082001f, -0.06657548f, -0.08967000f, -0.09003072f, 
    0.13152559f, -0.12345541f, 0.07147785f, 0.07864921f, -0.01109433f, 0.10141908f, -0.03292103f, 0.14847210f, 
    0.06824262f, 0.07373913f, 0.11525121f, 0.02724404f, -0.04143773f, 0.03964438f, 0.02126744f, 0.15517195f, 
    -0.08213322f, -0.11225712f, 0.14617643f, 0.14714879f, -0.00414955f, 0.06700269f, -0.22279935f, 0.23659672f, 
    -0.04624930f, 0.16087209f, 0.24396455f, -0.26369691f, -0.11514013f, -0.09811751f, -0.08819176f, 0.03772692f, 
    -0.09575897f, 0.04783237f, 0.14302513f, -0.08683597f, 0.13841358f, 0.03338892f, 0.07670265f, 0.20134503f, 
    -0.08582070f, -0.22942829f, 0.06679858f, 0.12454081f, 0.10219365f, 0.07202653f, 0.08388272f, 0.02658300f, 
    -0.03913384f, -0.11271904f, 0.19057629f, 0.16789265f, 0.09583340f, -0.03332470f, -0.03339265f, -0.08833127f, 
    0.01427307f, -0.07927375f, -0.17494659f, -0.27967387f, 0.02400010f, 0.07084470f, 0.01263310f, 0.03160614f, 
    0.02604845f, -0.14335653f, 0.13981172f, 0.00007802f, 0.02818049f, -0.04535942f, -0.05479575f, -0.01204519f, 
    0.10665353f, -0.18270977f, -0.10680284f, 0.04942527f, -0.14717685f, -0.24581921f, 0.10165555f, -0.02640259f, 
    -0.06436610f, -0.19639489f, 0.00583042f, 0.04037427f, -0.01249065f, -0.01278255f, -0.07254086f, 0.14735304f, 
    -0.01330630f, -0.01851593f, -0.24256185f, 0.06247060f, -0.00758765f, -0.02444435f, 0.02787768f, -0.02089711f, 
    0.19338167f, 0.14999664f, 0.17179695f, 0.10698489f, -0.02790898f, -0.28317052f, -0.03792580f, -0.12950285f, 
    -0.11345838f, -0.01644929f, -0.01705871f, 0.05314973f, 0.01047915f, 0.17043458f, -0.17506446f, 0.01160672f, 
    -0.16039591f, -0.06405721f, -0.04338501f, 0.15706983f, 0.00708896f, -0.02340357f, -0.05387161f, -0.16055332f, 
    -0.03021988f, -0.06192345f, -0.05160838f, -0.04073624f, -0.03258484f, 0.00905044f, 0.00606045f, 0.03267068f, 
    -0.00519678f, -0.01171428f, 0.00440864f, 0.04215840f, -0.05021284f, -0.03103564f, -0.02774143f, -0.05155008f, 
    0.01996019f, -0.02126776f, -0.02667754f, -0.03702753f, 0.00450880f, -0.04254686f, 0.01644265f, 0.02503198f, 
    -0.01420554f, -0.00775358f, 0.00911997f, -0.05979643f, -0.04762825f, -0.01500885f, -0.00392184f, -0.04951575f, 
    -0.04189482f, -0.01097743f, -0.00162884f, -0.00607068f, 0.01264094f, -0.01410331f, 0.00783418f, -0.02377140f, 
    0.05124686f, -0.02659681f, -0.02285572f, 0.04472402f, -0.02378569f, -0.03951276f, -0.03806826f, -0.02561885f, 
    0.04537439f, -0.00862143f, -0.05580572f, -0.00048479f, -0.03924208f, -0.02522986f, 0.02064307f, 0.02058788f, 
    0.03458159f, -0.04169444f, -0.04240072f, 0.00656062f, 0.03298737f, -0.06235087f, -0.01508206f, 0.04301336f, 
    -0.06275604f, 0.04506747f, 0.02509661f, 0.05109404f, 0.04857900f, -0.00182711f, -0.02853513f, -0.02633282f, 
    -0.03556662f, 0.00670939f, -0.04028259f, -0.00671653f, 0.04561282f, 0.01045793f, -0.05741801f, -0.01475134f, 
    -0.05500665f, -0.04693093f, 0.02400143f, 0.03410693f, -0.01599384f, -0.01424540f, 0.00283199f, 0.04562711f, 
    -0.02553648f, -0.05875706f, -0.00368828f, 0.03825158f, 0.02914227f, -0.05808607f, 0.01509495f, 0.02769237f, 
    -0.04001334f, 0.02083256f, 0.01886771f, -0.02335021f, 0.02102256f, -0.02562522f, -0.04099450f, 0.02238658f, 
    0.02189654f, 0.03940704f, -0.02057716f, -0.00815972f, -0.04874879f, -0.06026295f, -0.02360534f, 0.00868111f, 
    -0.06088990f, 0.04707932f, 0.02561435f, -0.04747073f, 0.00449162f, -0.05926101f, -0.04164417f, -0.01429012f, 
    -0.06072053f, 0.03951166f, 0.02117404f, 0.03505060f, -0.05280815f, -0.05209246f, 0.01679211f, 0.00869584f, 
    0.04928092f, 0.00146184f, 0.02387102f, 0.00003349f, 0.04670628f, 0.01283791f, -0.00846040f, -0.06262740f, 
    -0.03139422f, -0.02116369f, 0.01580655f, 0.05252535f, -0.05916765f, -0.03902276f, -0.05851996f, -0.02898576f, 
    -0.00200223f, 0.00434526f, -0.05170822f, -0.06155660f, 0.03994963f, 0.02587476f, -0.04669015f, 0.00653247f, 
    0.02234680f, 0.02468286f, 0.01355017f, 0.00619253f, 0.01566526f, -0.04722597f, -0.00201896f, -0.04340278f, 
    0.01207104f, 0.00919803f, -0.01536155f, -0.01112301f, -0.05481575f, 0.05050226f, 0.03218241f, -0.02293868f, 
    0.04359906f, -0.05804758f, -0.02158052f, -0.06044661f, -0.04104971f, -0.04603921f, 0.02348089f, 0.01992315f, 
    -0.06177992f, -0.00282058f, 0.03942303f, 0.01665668f, -0.06015782f, 0.04664040f, 0.02566783f, -0.00956801f, 
    -0.00420691f, -0.02918456f, -0.00517081f, 0.04971603f, -0.04369634f, -0.06267208f, -0.04830214f, -0.04667742f, 
    -0.03561702f, 0.03132042f, 0.02622310f, 0.02370187f, 0.05179432f, -0.04587673f, -0.02774471f, 0.01134175f, 
    -0.00958827f, -0.04175799f, 0.04434300f, -0.04294290f, -0.04505937f, -0.04938633f, 0.04108560f, 0.03070283f, 
    -0.05842632f, 0.00536777f, -0.06051198f, 0.00470064f, -0.02935790f, -0.00136684f, -0.03493473f, -0.02678638f, 
    -0.00992567f, 0.01075903f, -0.04366321f, -0.02214100f, -0.02738475f, -0.04346208f, 0.03341149f, -0.05642805f, 
    0.01785373f, -0.04612156f, 0.02692634f, -0.05738041f, -0.04185066f, -0.00694915f, -0.05917056f, -0.01662927f, 
    0.04298218f, -0.00761317f, 0.03419166f, -0.00705237f, -0.04085532f, 0.01040403f, 0.01947062f, -0.00808145f, 
    -0.01951854f, -0.01094061f, -0.05414832f, 0.01611074f, 0.02613799f, -0.01432378f, 0.02814012f, -0.02751302f, 
    0.00918339f, -0.02452024f, -0.01775184f, -0.01102643f, -0.06394954f, 0.00204245f, 0.04942017f, 0.02370110f, 
    -0.00413402f, 0.03446622f, -0.04171560f, 0.05313518f, -0.02183866f, 0.04604105f, 0.03455018f, -0.03920107f, 
    0.04931513f, -0.00931610f, 0.01915941f, 0.04168927f, -0.02144340f, -0.02061688f, -0.00196003f, 0.00535142f, 
    0.04379433f, 0.05255936f, -0.05920835f, 0.05235084f, -0.00837983f, -0.00926803f, -0.04130524f, -0.01065521f, 
    0.02185247f, -0.05519216f, -0.02968406f, -0.01694251f, -0.02169301f, -0.00987850f, 0.04380070f, -0.01856657f, 
    -0.04327919f, -0.10709248f, -0.00492130f, -0.09282405f, 0.06800534f, -0.00533579f, 0.13217333f, 0.16274786f, 
    0.01770952f, 0.26462981f, 0.03262886f, -0.07115474f, -0.10205337f, 0.04700477f, 0.09859675f, 0.05108894f, 
    0.01254984f, -0.03499141f, 0.10453843f, -0.13706516f, 0.10359108f, -0.09314089f, 0.00042326f, 0.10368077f, 
    0.12279354f, -0.05115561f, -0.01268803f, 0.06891140f, 0.30485398f, 0.11966447f, -0.19480820f, 0.02995000f, 
    -0.19946347f, 0.03564684f, -0.02144642f, -0.04157179f, -0.04833821f, -0.03961067f, -0.46964049f, -0.09495261f, 
    -0.17626706f, 0.05775739f, 0.13796155f, 0.17607501f, 0.02424709f, 0.26868466f, -0.18975738f, 0.05445927f, 
    0.05152132f, -0.00231081f, 0.02505983f, 0.06935561f, 0.07033443f, -0.00598068f, -0.06482607f, -0.09666105f, 
    -0.16520892f, 0.00165531f, 0.10782072f, -0.21281090f, 0.04775767f, 0.14517245f, 0.00445074f, 0.20808585f, 
    0.18776627f, 0.22037207f, -0.08039498f, 0.03597886f, -0.00464526f, -0.00094919f, 0.12698269f, -0.00647046f, 
    0.01430479f, -0.08408658f, -0.21139385f, 0.16456889f, 0.00468290f, 0.05768789f, -0.03435700f, -0.07106677f, 
    0.01961015f, 0.20095354f, -0.15644899f, -0.16924748f, 0.10420653f, -0.05021163f, 0.15168661f, -0.08182807f, 
    0.03652330f, -0.08244019f, 0.12940089f, 0.08917191f, 0.23286000f, -0.03364566f, 0.02878967f, 0.00345006f, 
    0.23141539f, 0.00560544f, 0.11602283f, 0.11724399f, 0.06029799f, 0.07067996f, -0.02883663f, 0.05505153f, 
    0.05325461f, 0.03914602f, 0.00069716f, 0.09139538f, -0.58047760f, -0.23710535f, 0.07755856f, -0.14085355f, 
    0.00172125f, -0.12220529f, 0.16514497f, -0.00189406f, 0.02790973f, 0.09673164f, -0.25619039f, -0.21495080f, 
    -0.00145114f, 0.13041344f, -0.07036909f, 0.13919167f, -0.04841610f, 0.11759321f, -0.16892155f, -0.36785832f, 
    -0.02249249f, -0.10542402f, 0.11141891f, -0.02113163f, -0.01634409f, -0.05829882f, -0.08692481f, -0.09645658f, 
    -0.11962149f, -0.21400298f, 0.08713012f, -0.11228774f, -0.08483592f, 0.08246546f, 0.03666719f, -0.07743830f, 
    -0.08727469f, -0.07527996f, -0.18872392f, 0.04682321f, 0.06844023f, 0.00317225f, 0.11386795f, 0.00944118f, 
    -0.13594919f, 0.11517511f, -0.21493213f, -0.19018301f, -0.09531739f, -0.01090214f, 0.13875224f, 0.01184298f, 
    0.08645886f, 0.04408906f, 0.19289748f, 0.27970985f, 0.12613183f, -0.02416226f, -0.02743240f, 0.00059688f, 
    0.02328415f, 0.09854549f, 0.09980776f, -0.07394142f, -0.34080333f, -0.10386496f, -0.10346331f, 0.09548247f, 
    -0.06134548f, -0.03548018f, 0.02527952f, -0.02626078f, 0.24555112f, 0.02194086f, 0.04865683f, -0.07080296f, 
    -0.07102856f, -0.17250265f, 0.10162540f, 0.13116312f, -0.05018239f, -0.12444004f, 0.04664844f, -0.03629415f, 
    -0.08504426f, 0.07900025f, 0.01194048f, 0.09383416f, 0.01796118f, -0.14236854f, -0.20245235f, -0.14246446f, 
    -0.07658009f, -0.09499680f, -0.02621271f, 0.10834467f, 0.13609566f, -0.00814656f, 0.06287508f, 0.03437508f, 
    -0.03065456f, -0.42536277f, -0.06847266f, -0.06119141f, -0.04148865f, 0.13436578f, 0.00264632f, 0.06694940f, 
    0.06662109f, 0.32419139f, 0.18465246f, -0.23534273f, -0.16410796f, 0.05815849f, 0.03325168f, -0.01031707f, 
    0.03370492f, 0.09545789f, -0.45460346f, -0.18516371f, 0.01754977f, 0.16198295f, -0.06771415f, 0.04519544f, 
    -0.18464306f, -0.11025686f, 0.16723065f, -0.44407308f, -0.05617670f, -0.00898283f, -0.17420791f, -0.06559055f, 
    0.07738646f, 0.05717669f, 0.02675395f, -0.45295176f, -0.09361921f, -0.10246652f, 0.03736298f, -0.06582067f, 
    0.03289780f, 0.05214220f, -0.00848079f, -0.00021038f, 0.21522658f, -0.28597546f, 0.03154032f, -0.03060680f, 
    0.03358128f, 0.26789144f, 0.10993005f, -0.13166191f, 0.03108633f, -0.04426451f, -0.35469025f, 0.16346079f, 
    -0.24933450f, 0.00980391f, -0.12974747f, 0.00003799f, 0.03541430f, -0.02983285f, 0.39479867f, 0.12655425f, 
    -0.16330776f, -0.30974549f, -0.00602986f, -0.01916247f, 0.02743020f, -0.04296874f, 0.00810463f, -0.10229183f, 
    -0.00447264f, -0.04704072f, 0.15228589f, -0.01859502f, 0.04311709f, 0.03089787f, -0.01837810f, -0.01390574f, 
    0.17848232f, 0.02321885f, -0.01329626f, -0.07813843f, 0.02387504f, 0.06572774f, -0.05261969f, -0.00055276f, 
    0.06368434f, 0.27218583f, 0.14151411f, -0.02485375f, -0.05668659f, -0.11029972f, -0.09676736f, -0.02556688f, 
    0.16598894f, 0.09760853f, 0.14002842f, 0.06290779f, -0.16493264f, -0.07121388f, 0.05428984f, 0.00661966f, 
    0.09249144f, 0.02333523f, -0.16367908f, 0.42337427f, 0.02482886f, -0.16105916f, -0.18382947f, -0.14498301f, 
    0.04483787f, -0.09151004f, 0.12327924f, 0.03775200f, 0.61055648f, 0.13413820f, -0.15465049f, -0.22494647f, 
    0.08683094f, -0.09288067f, 0.03749629f, -0.06429220f, -0.20506018f, 0.18145216f, -0.07316259f, -0.22051726f, 
    -0.04065323f, 0.01479241f, 0.07382759f, 0.09146060f, -0.02457361f, 0.04116740f, -0.34412664f, 0.16310079f, 
    0.16473255f, 0.06912528f, -0.01472051f, 0.03419242f, 0.12007755f, 0.06169206f, 0.04247984f, 0.15499362f, 
    0.04776238f, -0.10886575f, -0.00274318f, -0.04309347f, 0.08465579f, -0.00673708f, 0.02064998f, -0.05249608f, 
    -0.85919094f, 0.04374680f, 0.01603567f, -0.03732599f, -0.01081431f, 0.12525851f, 0.02441778f, 0.03244139f, 
    0.09555688f, -0.10672871f, -0.35652265f, -0.31848100f, 0.05815509f, 0.05556259f, 0.01310235f, 0.01384185f, 
    0.01016052f, 0.07494291f, 0.25859472f, 0.14723818f, -0.11293858f, 0.06897999f, 0.03853407f, -0.07734712f, 
    0.17887191f, 0.17031945f, -0.01754520f, 0.34383315f, -0.00278064f, -0.21447678f, -0.15474631f, -0.00356103f, 
    0.07893011f, -0.02929518f, 0.10779845f, 0.13357231f, 0.15538643f, 0.10416543f, 0.06287435f, 0.10839587f, 
    0.00936369f, -0.01427552f, 0.06120260f, 0.03073316f, 0.00862803f, 0.10454869f, -0.15839633f, 0.08177044f, 
    -0.15472788f, 0.23626526f, 0.13575722f, 0.13111958f, -0.05820891f, 0.04401025f, -0.46807030f, -0.37764302f, 
    0.25221890f, -0.11835451f, 0.01159765f, 0.02448400f, 0.06494546f, 0.05284435f, -0.06325947f, 0.03746177f, 
    0.21916212f, 0.22313893f, -0.19273478f, 0.01581410f, -0.13048382f, 0.16203792f, -0.01775419f, -0.01426100f, 
    -0.21408208f, 0.07000352f, 0.09969992f, 0.05583245f, -0.00298999f, -0.08740364f, 0.00628053f, -0.09662618f, 
    0.05905705f, -0.34877974f, -0.19268595f, -0.26336390f, 0.07800656f, 0.00689810f, 0.01145131f, 0.03139974f, 
    0.07185116f, 0.03427573f, 0.16011642f, -0.27125371f, 0.02530693f, -0.09961975f, -0.10973685f, -0.03197642f, 
    0.10121570f, -0.04738535f, 0.15447254f, 0.10494755f, 0.07848613f, -0.02180879f, 0.04906859f, 0.08968244f, 
    0.03632564f, 0.10198008f, 0.06049473f, 0.11456962f, -0.04006534f, 0.06721326f, 0.04810754f, -0.00157458f, 
    -0.10458849f, -0.00982328f, 0.13906230f, -0.03388382f, 0.05700405f, 0.36037076f, -0.04622221f, -0.01649383f, 
    0.06873159f, 0.00342705f, -0.16708925f, 0.06896771f, -0.04844603f, -0.10992381f, 0.14975509f, -0.04712176f, 
    0.08702224f, -0.14544807f, 0.00495390f, -0.01107306f, 0.04694268f, 0.10564268f, 0.06762195f, -0.15692140f, 
    -0.16072178f, -0.05284945f, -0.20447043f, 0.08084196f, -0.13497722f, 0.03659468f, -0.11175866f, -0.03022429f, 
    -0.19629711f, -0.29625070f, -0.21104731f, -0.26330101f, -0.03353430f, -0.23238312f, 0.00246356f, 0.13056873f, 
    0.05661031f, -0.03810855f, 0.25138304f, 0.10461453f, -0.01268319f, -0.01489007f, -0.15152194f, 0.00844323f, 
    -0.08372167f, 0.06402761f, -0.21658342f, -0.09119969f, 0.23826340f, -0.11280587f, -0.10870088f, -0.04618831f, 
    0.05005938f, -0.12456317f, 0.11354423f, -0.32464796f, 0.18774781f, 0.17752448f, 0.03704506f, -0.11125574f, 
    0.00678615f, -0.02766553f, -0.00424251f, 0.10332108f, 0.08662172f, 0.00244257f, -0.27455235f, -0.12146826f, 
    0.06455208f, 0.03205778f, 0.06107426f, -0.07443256f, 0.03036305f, -0.09042513f, 0.02442961f, 0.08933181f, 
    0.01243315f, 0.05657907f, 0.04695171f, -0.00437332f, -0.08192535f, -0.02650998f, -0.31789675f, -0.05228301f, 
    0.18230964f, -0.14881839f, -0.02429238f, -0.11645323f, 0.12074824f, -0.01032765f, -0.04526260f, -0.07737540f, 
    0.08736778f, 0.29666379f, -0.05315331f, -0.05342129f, -0.15234521f, 0.04110812f, -0.00185814f, 0.05346749f, 
    -0.08793346f, 0.02429280f, -0.18282144f, 0.01344422f, 0.00957711f, -0.11692455f, -0.09411555f, 0.02793942f, 
    -0.08166914f, 0.15411483f, 0.21854214f, 0.00665820f, 0.08868746f, 0.18737167f, 0.02148123f, -0.07110626f, 
    -0.22595711f, -0.02087534f, 0.04782981f, 0.04175171f, -0.06929153f, 0.03189591f, -0.12557407f, 0.02479849f, 
    0.09892031f, 0.19067566f, 0.16686955f, -0.21721238f, -0.21299477f, 0.10444667f, 0.02296298f, 0.08200485f, 
    -0.01170617f, -0.06235277f, 0.07399406f, -0.07446555f, 0.08184521f, 0.19983141f, 0.18328573f, 0.00389726f, 
    0.07561666f, 0.15572350f, 0.06797652f, -0.17267911f, -0.13898683f, 0.00668037f, -0.15010542f, -0.05364874f, 
    0.01446117f, 0.01079580f, 0.08358931f, 0.04489402f, 0.03107979f, 0.13390332f, 0.01735811f, 0.01028145f, 
    0.07168517f, 0.00246808f, -0.01755757f, -0.00908787f, 0.09156193f, -0.04814727f, -0.09664961f, -0.08530223f, 
    -0.08858045f, -0.04891703f, 0.12848106f, 0.01491687f, 0.02283802f, -0.07911322f, -0.05431253f, -0.06480425f, 
    0.03073059f, 0.20368418f, 0.22899494f, -0.09594695f, -0.14378028f, 0.11282827f, 0.01906040f, 0.11437911f, 
    0.01363437f, -0.05285409f, -0.06301883f, 0.07980596f, -0.08310489f, 0.17122732f, 0.04974131f, 0.08661707f, 
    -0.02299353f, 0.01205106f, 0.07685627f, -0.09189311f, -0.06246470f, 0.16226588f, 0.04701334f, 0.00738836f, 
    -0.08161172f, -0.12626831f, 0.13847394f, -0.19966133f, 0.03040564f, 0.10153850f, 0.03409271f, 0.00933869f, 
    0.03217895f, -0.07159634f, -0.19917354f, -0.08311298f, 0.02413872f, 0.25941670f, 0.08969159f, -0.03920019f, 
    0.17222838f, 0.00540194f, -0.27279004f, 0.00014845f, -0.11735535f, -0.04766109f, 0.15987703f, -0.02245610f, 
    0.02921046f, -0.01171038f, 0.17408678f, -0.08636297f, -0.03107016f, -0.07588432f, 0.18229020f, 0.27224654f, 
    0.14455834f, -0.00098162f, -0.04888206f, 0.07381190f, -0.00015899f, -0.07484980f, 0.12372575f, -0.02605377f, 
    0.00663042f, 0.02928610f, 0.10522599f, 0.04143571f, 0.09570041f, 0.06280667f, -0.10026200f, -0.13252722f, 
    0.07890390f, 0.06827431f, 0.09924387f, -0.04496055f, 0.03175190f, -0.05268995f, 0.10749884f, 0.05501566f, 
    0.00829030f, 0.13977084f, -0.05629588f, -0.12152603f, -0.00391246f, 0.00527405f, 0.03913134f, -0.13520595f, 
    0.04657331f, -0.08756860f, -0.11316425f, 0.08652850f, -0.08945289f, 0.04702420f, -0.03188973f, 0.14228226f, 
    -0.21160366f, -0.12279380f, -0.24529625f, -0.01928666f, 0.19335419f, -0.00342792f, -0.10137737f, -0.04249102f, 
    0.01341556f, -0.04026206f, -0.00597787f, -0.16181432f, 0.03926465f, -0.10827348f, 0.06477295f, 0.13763432f, 
    0.02586898f, 0.08145630f, -0.17389132f, -0.30962718f, -0.08083083f, 0.18300863f, 0.13445108f, 0.26387390f, 
    -0.06711034f, 0.01857954f, -0.03789550f, 0.02597842f, 0.10063092f, 0.04505439f, -0.06842791f, 0.18028276f, 
    -0.15832162f, -0.05254884f, 0.03904660f, -0.04196193f, 0.03524257f, -0.03091488f, -0.18577187f, -0.04079134f, 
    -0.03538885f, 0.11927689f, 0.09039633f, -0.08353956f, -0.01607659f, -0.12527992f, -0.00780558f, -0.05040501f, 
    0.12727748f, 0.02389459f, 0.16154285f, 0.18230781f, 0.05588828f, 0.11628009f, -0.08915291f, -0.01727459f, 
    0.04532000f, -0.01926852f, -0.05591844f, 0.06243997f, 0.15713799f, 0.04869949f, 0.04676599f, 0.00563151f, 
    0.06958506f, -0.17175093f, -0.09734306f, 0.02962830f, 0.20693810f, 0.03259533f, -0.08658805f, 0.04347062f, 
    -0.05155037f, 0.05819404f, 0.12846175f, 0.07813729f, 0.25435746f, 0.04786807f, -0.01969331f, 0.12924840f, 
    0.01467993f, 0.09940812f, -0.14073834f, -0.08969531f, 0.26381266f, 0.18034674f, -0.18175828f, -0.05228099f, 
    -0.10654485f, -0.09271010f, -0.01662817f, 0.04178643f, -0.02548143f, 0.11906930f, 0.31998301f, 0.01126185f, 
    -0.07716779f, 0.12844835f, 0.02766154f, 0.01036118f, -0.03700941f, 0.08160439f, 0.06073199f, 0.19614847f, 
    0.00190512f, -0.04438481f, -0.07170472f, 0.03913761f, -0.01312813f, 0.07260978f, -0.24836814f, -0.00745675f, 
    -0.00790565f, 0.28503087f, -0.01083236f, -0.01378324f, -0.01594453f, 0.11323112f, 0.03508770f, -0.02354712f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.00253397f, 0.18628159f, 0.12427600f, -0.02983814f, 0.12363215f, -0.00888630f, 0.11246147f, 0.08321832f, 
    0.00628609f, 0.18256739f, 0.10807401f, 0.13187556f, -0.06098687f, 0.03321628f, 0.11956444f, -0.08955853f, 
    -0.00207959f, -0.10460294f, 0.14438942f, -0.02200745f, 0.07099321f, -0.14445330f, 0.07392678f, 0.00709372f, 
    -0.06797485f, 0.04512022f, 0.02286234f, 0.07505709f, 0.02981712f, 0.01208256f, 0.06351461f, -0.10141876f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.07990248f, -0.14756823f, 0.02623245f, -0.02544468f, 0.08785412f, 0.00654416f, 0.02328141f, -0.15123321f, 
    0.16403186f, -0.13633582f, -0.09333019f, -0.10289402f, -0.04908034f, 0.08644816f, -0.00187973f, -0.15457867f, 
    -0.11411221f, -0.17149523f, -0.07836760f, 0.05347038f, -0.01526751f, -0.07284468f, 0.01953850f, 0.03150458f, 
    -0.00522244f, -0.10365655f, 0.05443405f, -0.03078903f, 0.12133574f, -0.04238806f, -0.14692397f, -0.06120188f, 
    -0.11447734f, 0.04475991f, -0.02422144f, -0.11487567f, 0.08810758f, -0.41444921f, -0.09529305f, 0.47027966f, 
    0.16127959f, 0.02579990f, 0.05188747f, -0.55423957f, 0.02386031f, -0.12563057f, 0.25666210f, -0.02821830f, 
    -0.14248563f, -0.00474370f, -0.01506354f, 0.04846402f, 0.08794355f, 0.14850238f, 0.21986128f, 0.20380922f, 
    -0.01243975f, -0.11511312f, 0.09749921f, 0.21407838f, -0.05961711f, -0.06468583f, 0.42297578f, -0.30639336f, 
    0.18418923f, -0.06653329f, -0.14607421f, 0.05961312f, -0.02413426f, -0.38357648f, 0.14885226f, 0.31363350f, 
    -0.12696062f, 0.29161406f, 0.27356988f, -0.60659486f, -0.04086760f, -0.07986423f, 0.19904175f, -0.19996205f, 
    -0.31299216f, 0.26581118f, 0.34547067f, 0.12802389f, -0.07110313f, -0.30698833f, -0.01763568f, -0.17334190f, 
    -0.15875003f, 0.12698494f, 0.10417927f, 0.26610944f, 0.06537315f, -0.22754799f, 0.33291805f, -0.20083539f, 
    -0.50047481f, -0.23156244f, -0.21833503f, -0.13480668f, -0.12275705f, -0.07429636f, -0.32750577f, 0.42570794f, 
    0.17059018f, -0.04422181f, 0.00301964f, 0.04529303f, 0.16503079f, 0.05490680f, -0.21963209f, 0.26557884f, 
    0.28978676f, 0.01608924f, -0.37996066f, 0.13598438f, 0.04158244f, 0.03873230f, -0.28878224f, 0.07175782f, 
    0.15693630f, 0.08876690f, -0.04022691f, 0.16935964f, 0.04707965f, 0.32211229f, 0.38755736f, 0.03134182f, 
    0.07404517f, 0.34351769f, 0.36580461f, 0.15797861f, 0.07850447f, -0.02254182f, 0.22718699f, -0.02626189f, 
    0.07311823f, 0.03203509f, 0.20214935f, -0.06334314f, 0.04820025f, 0.05168840f, 0.33067712f, -0.28329024f, 
    -0.09453684f, -0.11343894f, 0.04794926f, -0.15929900f, 0.27441841f, -0.29508659f, -0.42688978f, -0.18422602f, 
    -0.06173449f, 0.13633771f, 0.09971517f, 0.05327790f, 0.07033893f, -0.25190172f, -0.27663729f, 0.02471169f, 
    -0.18312354f, 0.07421171f, 0.06360100f, -0.05959389f, -0.11310743f, -0.44273281f, -0.19941974f, 0.33606690f, 
    0.08350623f, 0.13450912f, 0.11587948f, 0.51747936f, 0.09241112f, 0.12171517f, -0.01237461f, -0.11561166f, 
    0.25075498f, -0.14275578f, -0.07476988f, -0.24581917f, -0.27864528f, 0.01049010f, 0.08516428f, 0.30309731f, 
    -0.15836373f, 0.29715312f, 0.13062379f, -0.18645406f, 0.12483272f, 0.30647308f, -0.10729282f, 0.03478420f, 
    0.37939209f, -0.04671801f, 0.05865673f, -0.01197602f, -0.08369507f, -0.03691669f, 0.02893356f, -0.27459186f, 
    0.05019579f, 0.06877086f, 0.10941423f, -0.24514753f, -0.02867432f, -0.09652737f, 0.36036047f, -0.03441819f, 
    0.00659874f, 0.18594962f, 0.06576125f, -0.10518912f, -0.28056684f, 0.06193101f, 0.22747977f, -0.15819165f, 
    0.17911328f, 0.05879979f, 0.02381080f, -0.03976606f, 0.03170191f, -0.16329569f, 0.19577783f, 0.14850794f, 
    -0.32026580f, 0.26555032f, 0.08656102f, -0.08545235f, 0.03076385f, -0.06507647f, -0.12941828f, -0.05938921f, 
    0.10402544f, 0.18106681f, 0.22166641f, 0.37459290f, -0.12838697f, -0.04882655f, -0.26496008f, -0.12038007f, 
    0.09563806f, -0.25350547f, -0.27663192f, 0.03101731f, -0.07263185f, -0.02663872f, -0.19361606f, 0.12031028f, 
    -0.11319879f, 0.22724462f, 0.02242694f, 0.22451429f, 0.00777584f, 0.43410590f, -0.39603627f, -0.13007453f, 
    -0.10130854f, 0.04453475f, -0.03578367f, -0.12106377f, 0.04053543f, 0.03443052f, -0.05116972f, 0.17302400f, 
    0.15974568f, -0.08174300f, -0.18818465f, -0.13628303f, -0.12664264f, 0.11011083f, 0.21861094f, 0.24924095f, 
    0.10912480f, 0.01985974f, 0.25355855f, 0.26788846f, -0.07896543f, 0.08074431f, 0.24525774f, 0.15014999f, 
    -0.11499550f, -0.23730415f, -0.11638001f, 0.19842371f, 0.12261796f, -0.01360954f, 0.53228962f, -0.02592826f, 
    -0.08805189f, 0.21827005f, 0.15148212f, -0.10894012f, 0.18949492f, -0.08937107f, -0.14500301f, -0.43499836f, 
    0.10989586f, 0.01394041f, 0.21007311f, 0.08212398f, 0.08879184f, -0.06470825f, -0.12780449f, 0.09071466f, 
    -0.04375979f, 0.18108815f, -0.17248969f, -0.02163223f, -0.21456270f, -0.21590827f, -0.08191603f, -0.11326693f, 
    -0.04395143f, 0.27358174f, -0.04419687f, 0.24061167f, 0.07706180f, -0.08726031f, -0.46426806f, 0.28117847f, 
    -0.13563858f, -0.02674491f, -0.08736385f, -0.16917987f, 0.09052884f, 0.11093921f, 0.13210262f, 0.03167406f, 
    0.10483879f, -0.11386804f, 0.13218822f, -0.14307092f, -0.07356774f, -0.03801001f, -0.33038396f, 0.24610244f, 
    0.27499294f, -0.41395226f, -0.09531868f, 0.20568569f, 0.05145404f, 0.02350537f, 0.10012653f, 0.16361852f, 
    0.04518769f, 0.08548845f, 0.13750382f, 0.24418995f, -0.05819389f, 0.14898822f, 0.53580594f, -0.16112210f, 
    -0.05455176f, -0.10445438f, 0.03919413f, -0.09700537f, -0.12138425f, -0.01937728f, -0.00373534f, -0.10666064f, 
    -0.10153718f, -0.09141622f, 0.08367328f, -0.16494328f, -0.05368310f, -0.16499221f, -0.18427326f, 0.12952572f, 
    -0.25382912f, -0.02793934f, -0.00949845f, -0.09928821f, 0.13233313f, -0.18157063f, -0.09092357f, -0.12074827f, 
    0.17076223f, 0.04132856f, -0.10367577f, -0.14990996f, -0.07796805f, -0.19470541f, -0.00648439f, 0.02522687f, 
    -0.01952014f, 0.22465010f, 0.01046316f, -0.11039921f, 0.13875110f, -0.14623009f, -0.25165069f, -0.33130980f, 
    -0.05701916f, -0.03970081f, 0.17091003f, 0.40267467f, 0.15319140f, -0.07036711f, -0.34993303f, -0.09155890f, 
    0.04733840f, 0.13218164f, -0.26388586f, -0.21733773f, -0.13418114f, -0.00021037f, -0.14349139f, 0.23122944f, 
    -0.00997709f, 0.25682911f, -0.09533462f, 0.10796910f, -0.10869542f, 0.29439887f, -0.15934123f, -0.06686801f, 
    0.02990341f, 0.01556594f, 0.02800290f, 0.10076479f, 0.04674500f, -0.54040170f, -0.04279004f, 0.08000924f, 
    -0.13706221f, -0.00260222f, 0.20630439f, 0.55410242f, -0.05434424f, 0.08221646f, -0.17347310f, 0.05877507f, 
    -0.01068943f, -0.19110818f, -0.40071559f, -0.15782055f, -0.24033089f, -0.11174246f, -0.04346055f, 0.08518475f, 
    0.02603346f, 0.34791535f, 0.04365321f, -0.09082188f, 0.18152589f, 0.31541288f, -0.03798326f, 0.09381925f, 
    0.02996518f, 0.31537461f, 0.24467707f, -0.09990876f, 0.00938952f, -0.30783820f, 0.00157913f, 0.14784986f, 
    -0.10162920f, -0.07394107f, 0.23421624f, -0.06605220f, -0.10029420f, -0.07986819f, 0.20865664f, -0.07976516f, 
    -0.08083481f, 0.14928749f, 0.12503834f, 0.06176730f, 0.11441931f, -0.45944250f, -0.32160002f, -0.10324651f, 
    -0.00928820f, 0.15526965f, 0.03663006f, 0.12001239f, -0.11688951f, -0.13471943f, -0.37822676f, -0.15307318f, 
    -0.05725930f, -0.03282000f, -0.14923306f, -0.05526596f, -0.07131208f, 0.01892688f, -0.07056649f, 0.13357902f, 
    0.16849992f, -0.08064193f, 0.01328395f, -0.03977410f, -0.11112406f, -0.06206939f, -0.03980553f, -0.17152388f, 
    -0.07468715f, -0.12388929f, 0.11570336f, 0.15147258f, -0.07421815f, -0.17591454f, 0.07703122f, -0.13018055f, 
    0.12087353f, -0.14566831f, -0.02038133f, 0.05963977f, 0.11046257f, 0.01217749f, -0.04539860f, -0.01479582f, 
    0.02428968f, -0.06144988f, -0.00256457f, 0.08144582f, 0.07807161f, 0.33021438f, 0.18402502f, 0.39371967f, 
    0.03655116f, -0.07981556f, 0.12914708f, -0.11657155f, -0.08231333f, 0.06584893f, 0.32624450f, -0.22121304f, 
    0.30214432f, -0.17701416f, -0.15478872f, 0.11392921f, 0.28181079f, -0.31983212f, 0.00319379f, 0.05442844f, 
    0.13166796f, -0.11349687f, -0.14237916f, 0.00962549f, -0.06050246f, 0.01163479f, -0.16350019f, -0.13730940f, 
    -0.11098967f, 0.03898314f, 0.09885291f, 0.13150172f, -0.16709740f, -0.45268407f, 0.22596726f, 0.41438526f, 
    0.11945569f, -0.01255665f, -0.04260506f, -0.35856271f, 0.09269776f, -0.03387209f, 0.29826742f, -0.01079457f, 
    0.16761495f, -0.10905904f, 0.17728840f, 0.25760305f, 0.00748195f, 0.01895619f, 0.16407046f, 0.02484851f, 
    0.16013093f, -0.08569451f, -0.08290481f, 0.20131856f, -0.11717974f, 0.24723917f, 0.08572874f, 0.02077015f, 
    -0.26022819f, 0.09624478f, 0.06836011f, -0.10223056f, 0.07538080f, -0.03432681f, -0.05853955f, 0.42587006f, 
    0.00590775f, 0.10584101f, -0.17208439f, -0.06734969f, 0.07252087f, -0.08100379f, 0.30707949f, 0.06686420f, 
    0.07208927f, 0.00843828f, 0.30202538f, -0.21677789f, 0.22838452f, -0.21583243f, 0.15217091f, 0.21504423f, 
    0.00980205f, -0.27417833f, -0.08128066f, -0.22705106f, 0.12927157f, -0.20764090f, -0.11757995f, 0.12650582f, 
    -0.05456554f, -0.15675192f, -0.18354313f, -0.14558718f, 0.13672358f, -0.20662740f, -0.06800281f, -0.08118003f, 
    0.16498938f, -0.00922710f, 0.10373661f, 0.07709178f, 0.03255998f, -0.01638636f, -0.08771229f, -0.11415116f, 
    -0.09929841f, 0.12110447f, -0.12763315f, -0.17657208f, -0.18543695f, 0.15050358f, -0.03117957f, 0.03851076f, 
    -0.05958964f, -0.15935677f, -0.03529788f, -0.02267084f, 0.14655903f, -0.09908391f, -0.15358356f, 0.01267107f, 
    0.03851817f, 0.16664252f, -0.01030361f, -0.06363517f, -0.19133788f, -0.06121605f, -0.18819419f, 0.21473159f, 
    0.03471263f, 0.04158098f, 0.10837656f, 0.25724354f, -0.13738011f, -0.02733778f, 0.13122977f, -0.18274102f, 
    0.19865127f, 0.08671477f, 0.31660461f, 0.00509302f, -0.18068452f, 0.06926868f, 0.36073545f, 0.25201124f, 
    -0.15076263f, 0.06139368f, 0.06797156f, -0.06488722f, 0.16192412f, 0.36762363f, -0.45364612f, 0.14548807f, 
    0.18187290f, -0.12738800f, 0.28478724f, -0.01834642f, 0.00474397f, 0.30310544f, 0.03015081f, 0.26254922f, 
    -0.12007791f, -0.16005151f, -0.22488056f, 0.07865631f, -0.15372159f, 0.02265752f, -0.00101202f, -0.15526533f, 
    0.42752945f, 0.16637745f, 0.03528366f, 0.20375939f, 0.26067549f, 0.15650384f, 0.15097654f, 0.01661071f, 
    0.13769753f, -0.02484588f, -0.00854395f, -0.16147000f, 0.07515788f, 0.32998684f, -0.11987585f, 0.25620914f, 
    0.09666721f, -0.11186447f, 0.10125825f, 0.06218696f, 0.05688462f, 0.36430049f, -0.13442041f, 0.16400166f, 
    -0.11513935f, -0.10956927f, -0.13342439f, 0.34535319f, -0.04791382f, -0.10321342f, -0.18589872f, 0.12044686f, 
    0.28198108f, -0.06286768f, 0.15786311f, 0.28401950f, 0.07727174f, 0.24162373f, 0.31669149f, 0.08019229f, 
    -0.14997934f, -0.01929717f, 0.03560420f, -0.05384695f, -0.01966839f, 0.26545483f, -0.03053906f, 0.14615275f, 
    0.02420278f, -0.07157799f, -0.19093411f, 0.00110633f, -0.00274643f, -0.12162219f, -0.13663338f, -0.01682460f, 
    0.14781207f, -0.19856049f, -0.00784240f, 0.11466710f, 0.14060336f, -0.10310198f, -0.10003787f, 0.07743257f, 
    0.06983525f, 0.06706563f, -0.18637866f, 0.10413695f, 0.05385092f, 0.04658332f, -0.10848920f, 0.02703157f, 
    -0.10531956f, -0.08695689f, 0.04183901f, -0.13850121f, 0.07177528f, -0.14257871f, -0.08000343f, -0.23347597f, 
    0.19767746f, 0.18515822f, 0.06472117f, 0.15860043f, 0.10984632f, -0.22344519f, 0.13856302f, 0.04363295f, 
    -0.12619843f, -0.04124035f, 0.18427253f, 0.08778184f, 0.12524720f, -0.06535759f, 0.10247790f, -0.31888998f, 
    -0.07145026f, 0.06439459f, 0.16902332f, -0.16830476f, 0.19692455f, -0.02531719f, -0.24759540f, -0.29341048f, 
    0.10347062f, 0.08801001f, 0.08722725f, -0.32274440f, -0.13366885f, -0.06057397f, -0.41883719f, 0.12127485f, 
    -0.17581142f, 0.14243367f, -0.21180451f, 0.11132409f, 0.09086343f, -0.03127935f, -0.13493337f, 0.40576327f, 
    -0.02270349f, 0.14703594f, -0.10245999f, -0.41258657f, -0.01438954f, -0.10387221f, 0.31872872f, -0.00741261f, 
    0.07627269f, -0.10374173f, 0.31793484f, 0.13758688f, 0.28827652f, -0.02250307f, 0.03030600f, 0.23098783f, 
    -0.14941850f, -0.21899559f, 0.08259746f, 0.23434551f, -0.16764429f, -0.24114802f, -0.02448581f, -0.00730413f, 
    0.27230814f, -0.02191569f, -0.00834771f, -0.11387351f, -0.14021218f, -0.31881681f, -0.11273044f, -0.06036733f, 
    -0.15787339f, -0.11710446f, 0.00039164f, 0.30241209f, 0.15631770f, 0.10092679f, -0.26388207f, 0.11001888f, 
    0.06770105f, 0.06389905f, 0.01407495f, 0.14590669f, -0.38475892f, 0.09789722f, 0.57358176f, 0.23335598f, 
    0.01679704f, 0.15176249f, 0.14601289f, -0.02316896f, 0.07784828f, 0.09407306f, 0.46493217f, 0.10886268f, 
    -0.16095945f, 0.03454645f, 0.11320142f, 0.14525832f, -0.04254762f, -0.06229851f, -0.12080423f, 0.09492560f, 
    -0.00766076f, -0.16768655f, -0.03535055f, -0.05291061f, 0.08466379f, 0.10184160f, -0.06523451f, 0.05465257f, 
    -0.06077145f, -0.13603631f, -0.06031585f, 0.02414043f, 0.05726429f, 0.00070816f, 0.05400845f, -0.16994937f, 
    0.11457241f, 0.03828654f, 0.07910479f, 0.08770429f, 0.00763505f, 0.04394348f, 0.13605599f, -0.14899144f, 
    0.33268869f, -0.11789691f, 0.00977601f, -0.12302396f, 0.21717030f, -0.03617002f, -0.01618677f, 0.10764745f, 
    0.02178695f, 0.19316410f, -0.15450025f, -0.02894619f, 0.03863981f, -0.13591243f, 0.42223546f, -0.24252495f, 
    -0.07629164f, 0.35942435f, 0.04597923f, -0.05386813f, -0.18063284f, -0.15236858f, -0.21951139f, -0.30589822f, 
    0.07103399f, 0.06814379f, -0.03555713f, 0.03186861f, 0.09729254f, -0.07749820f, 0.25606462f, 0.01625987f, 
    0.32808903f, -0.11312189f, 0.23660111f, 0.04081368f, 0.19533941f, 0.12746745f, 0.23386951f, 0.19032012f, 
    -0.05729751f, 0.16615768f, -0.11625038f, -0.19041020f, -0.06878750f, -0.12624164f, 0.27367166f, -0.21361934f, 
    0.14095637f, 0.09498893f, 0.02261347f, 0.33937699f, 0.21674225f, -0.16632196f, 0.12593317f, -0.27082670f, 
    -0.01004755f, -0.21714446f, 0.12630038f, 0.19273536f, 0.12730974f, -0.26824003f, 0.48643145f, -0.19102949f, 
    0.02265563f, -0.17025124f, -0.01788083f, -0.15332028f, 0.19004513f, 0.11154898f, -0.16901883f, -0.45998400f, 
    0.15203033f, 0.17845623f, -0.01589110f, 0.12798759f, 0.00932932f, -0.05296558f, -0.26955137f, 0.21987168f, 
    0.23091076f, -0.24601115f, -0.16384922f, 0.13598506f, -0.07968356f, 0.06064338f, -0.09088992f, 0.14344187f, 
    0.03306781f, 0.11869744f, 0.16573527f, 0.04371994f, 0.00528332f, 0.28026021f, 0.46144050f, 0.12344015f, 
    0.45711902f, 0.08665287f, -0.01077060f, 0.13510960f, 0.12971896f, -0.04865446f, 0.01370634f, -0.20373294f, 
    -0.09006982f, -0.03051105f, -0.10707272f, 0.11537674f, -0.06190154f, 0.12713601f, 0.29150286f, -0.36973944f, 
    -0.17673071f, -0.12411794f, 0.15561076f, -0.10733989f, -0.34698403f, 0.25281098f, 0.49201608f, 0.01885978f, 
    -0.08393019f, 0.00015729f, 0.00601631f, -0.11850954f, 0.04476091f, 0.12637310f, -0.20786680f, 0.12723494f, 
    -0.21970485f, 0.16405915f, -0.25883389f, 0.02562800f, 0.19579534f, 0.20339602f, -0.04637006f, 0.02013677f, 
    -0.01979823f, 0.08659188f, 0.06102495f, -0.16171362f, 0.10784565f, 0.10088508f, -0.18473683f, 0.18973286f, 
    0.24473792f, -0.28950271f, -0.25188047f, 0.01895779f, 0.21762073f, -0.07028072f, 0.33447281f, 0.33370999f, 
    0.17413929f, -0.02909630f, 0.09947062f, -0.16318370f, 0.14631757f, 0.24959201f, -0.10812818f, 0.22311080f, 
    0.39972839f, 0.09767196f, 0.25579771f, 0.11378283f, 0.04934543f, 0.21147515f, 0.13441990f, -0.21417144f, 
    -0.13695732f, 0.16197953f, -0.11032780f, -0.01708665f, -0.12955435f, 0.13030948f, 0.31790543f, -0.19463965f, 
    -0.00377582f, 0.20853744f, 0.16708593f, -0.25737473f, 0.13406779f, 0.01351471f, -0.04318348f, -0.35097325f, 
    -0.09277973f, 0.11819638f, -0.12320951f, -0.01210954f, -0.11373039f, -0.37074313f, -0.19618531f, 0.15751785f, 
    0.14961569f, 0.00471297f, -0.32185599f, 0.12598793f, 0.24623093f, 0.21509147f, 0.02733636f, -0.06789634f, 
    0.00213720f, 0.22660030f, 0.05829303f, -0.11217222f, -0.12647383f, -0.08360362f, 0.18585637f, 0.34438086f, 
    -0.06962167f, -0.12807962f, -0.26067486f, 0.11381766f, -0.10722449f, -0.21914247f, -0.17683192f, 0.08731548f, 
    -0.11940626f, -0.00658448f, 0.10008229f, -0.07921073f, 0.06007173f, -0.47137338f, 0.22071262f, -0.19656526f, 
    -0.16460998f, -0.06253569f, 0.11476334f, -0.14424741f, 0.04603507f, 0.05084564f, 0.12482195f, 0.10663114f, 
    0.03965885f, 0.05424040f, 0.02850074f, 0.04675993f, 0.03261239f, -0.09455380f, 0.39927560f, 0.02033572f, 
    -0.16542876f, 0.17087556f, 0.16671802f, -0.06075425f, 0.19620225f, 0.05083825f, -0.13942213f, -0.16641802f, 
    -0.05205170f, 0.03180654f, -0.09590527f, -0.11027592f, 0.10275892f, -0.41631263f, 0.14723149f, 0.00779744f, 
    0.05520768f, -0.01984772f, 0.22793199f, 0.05772617f, 0.01228041f, -0.02003062f, -0.26468688f, -0.18044008f, 
    0.02222214f, 0.11326932f, -0.01964164f, 0.25498846f, -0.15646611f, -0.12631613f, -0.05558830f, -0.21871930f, 
    0.23988472f, 0.33094347f, 0.10267676f, -0.44566524f, -0.00109543f, 0.14060020f, -0.17908496f, -0.09867679f, 
    -0.02342342f, 0.23646180f, 0.15554145f, -0.14966787f, -0.00235543f, 0.29103297f, -0.49151853f, 0.28989345f, 
    -0.14938252f, 0.03468551f, -0.18919024f, -0.14327040f, 0.19636458f, -0.44806314f, -0.08777145f, 0.09071354f, 
    -0.06141926f, 0.24542226f, 0.16376865f, 0.12402748f, -0.08708248f, 0.06469122f, 0.08938948f, 0.14934483f, 
    0.07993475f, -0.18111983f, -0.01904895f, -0.28631753f, -0.23375168f, -0.21604890f, -0.16972454f, 0.26356548f, 
    0.14025548f, 0.22671647f, 0.15109327f, 0.03812044f, -0.13426211f, 0.11146586f, 0.03142898f, 0.21606247f, 
    -0.14622949f, 0.04628835f, -0.12870285f, -0.08779433f, -0.14429381f, -0.03621846f, -0.10294730f, -0.08477633f, 
    0.00882178f, -0.21384093f, 0.02396289f, -0.01877604f, 0.06132385f, -0.16170236f, 0.13256933f, 0.07683776f, 
    -0.16824424f, -0.20953459f, 0.08996022f, -0.17426607f, 0.05363804f, 0.02704293f, -0.05471446f, 0.01090036f, 
    0.10198823f, -0.04847655f, -0.15237744f, -0.09450728f, -0.11768631f, -0.04151524f, 0.07623400f, 0.13261166f, 
    -0.35197559f, 0.01628774f, -0.44914523f, -0.05646961f, 0.08125050f, -0.16703154f, -0.05066529f, 0.00934787f, 
    -0.13886566f, 0.11301102f, -0.20445175f, -0.08299246f, -0.06998929f, -0.18127911f, 0.18468592f, 0.09978660f, 
    -0.15373027f, 0.31763139f, 0.17565241f, 0.01664229f, -0.50871205f, 0.20234676f, -0.03996001f, 0.17659171f, 
    0.12778318f, 0.18450934f, -0.02561222f, 0.14794466f, 0.02955695f, -0.15809503f, 0.52593362f, 0.15083468f, 
    -0.08493230f, -0.22182132f, -0.20588252f, -0.15301099f, -0.12030224f, 0.04127017f, -0.06663664f, 0.03144260f, 
    -0.00845978f, -0.07348459f, 0.15801641f, 0.08928958f, 0.15244246f, -0.04926328f, -0.11014266f, 0.06139028f, 
    0.05127489f, 0.02833941f, -0.01610749f, -0.06665458f, 0.01889974f, 0.01312053f, -0.14014204f, 0.04751401f, 
    -0.05655837f, -0.18570016f, 0.07629568f, -0.20023683f, 0.02385535f, -0.00344776f, 0.08764411f, 0.06418473f, 
    0.31520438f, -0.05337168f, 0.02001794f, 0.02509422f, -0.07059406f, 0.23587686f, -0.13654257f, 0.19549289f, 
    -0.10719308f, -0.15437993f, 0.02119887f, 0.22036450f, 0.02666181f, 0.12586546f, -0.02710958f, -0.10352967f, 
    0.34617054f, -0.02825794f, 0.14848730f, 0.00144357f, -0.13741703f, 0.13197385f, 0.54023755f, 0.03230132f, 
    0.15949024f, 0.11029461f, -0.13619216f, -0.13467409f, 0.14978954f, 0.17377655f, 0.11978544f, 0.05399076f, 
    -0.15968964f, 0.07486644f, -0.23884204f, -0.02161107f, 0.19356225f, 0.15127929f, 0.09495751f, 0.06239723f, 
    -0.03201770f, 0.19058628f, 0.25113145f, -0.51032043f, 0.07103580f, 0.16104333f, 0.15622626f, -0.20409778f, 
    0.14141899f, -0.07912011f, 0.17728293f, 0.21479641f, 0.11035375f, -0.15827107f, 0.13255756f, -0.03462174f, 
    0.15038761f, -0.22869970f, 0.08026607f, 0.10839077f, 0.11749152f, 0.03159404f, 0.09844586f, -0.14333485f, 
    -0.12411386f, 0.17233442f, -0.09636571f, 0.04335332f, 0.21292518f, 0.15794291f, 0.26881441f, -0.24173643f, 
    0.08016741f, 0.15948032f, 0.30702090f, -0.30115688f, 0.01555543f, 0.05153533f, 0.04031847f, 0.30449674f, 
    -0.21258630f, -0.13961969f, -0.11172177f, 0.11974744f, -0.15299636f, -0.47229058f, 0.01215334f, 0.04486670f, 
    -0.13664983f, -0.10289852f, -0.10329150f, 0.06667508f, -0.11187125f, -0.26012242f, 0.36244112f, -0.17769928f, 
    -0.00465262f, 0.29250684f, 0.03921830f, -0.03856602f, 0.04543085f, -0.10884953f, -0.33400357f, -0.32698849f, 
    -0.15415400f, 0.15253758f, 0.34866416f, 0.28544685f, 0.08888385f, -0.15804388f, 0.03645390f, 0.02043466f, 
    0.25503406f, 0.18764223f, 0.06278808f, -0.11948927f, -0.31813928f, -0.11604375f, 0.21388845f, -0.00247454f, 
    0.15075250f, 0.17671153f, 0.03220429f, 0.11920178f, -0.06220916f, 0.06264445f, -0.48963022f, 0.22203459f, 
    -0.23444012f, 0.13164556f, -0.08640345f, 0.08755802f, 0.12640695f, 0.43126905f, 0.03801941f, -0.29633629f, 
    -0.10353396f, 0.03073411f, 0.22195630f, -0.31006542f, 0.15352656f, -0.14913061f, 0.04952744f, -0.03846091f, 
    -0.06301029f, 0.09125286f, -0.12713435f, -0.02793806f, 0.18910885f, -0.38184980f, 0.03170300f, -0.10385887f, 
    -0.00911120f, -0.16350898f, -0.10462729f, 0.15295544f, -0.00359795f, 0.00117133f, -0.11270526f, 0.18942572f, 
    0.42776695f, 0.06012622f, 0.10171153f, 0.12030658f, 0.10190313f, -0.32179093f, 0.08376477f, 0.44803646f, 
    0.16498552f, 0.14332619f, -0.08785786f, -0.32841480f, 0.04419636f, -0.02025067f, 0.15295403f, -0.31804878f, 
    0.00593767f, -0.16383182f, -0.01476329f, -0.08239508f, 0.05410704f, 0.03181051f, 0.02758204f, 0.06010670f, 
    0.01161619f, 0.03296541f, -0.02190039f, 0.02871520f, 0.15446781f, -0.09523780f, 0.15615951f, -0.27806926f, 
    -0.39124373f, -0.02959972f, -0.00537388f, -0.17126298f, -0.11612580f, 0.05330465f, 0.24737564f, 0.03966453f, 
    -0.14548251f, -0.11235566f, -0.36321273f, 0.15995418f, -0.01239889f, -0.12419967f, 0.12353972f, 0.20256488f, 
    0.11316065f, -0.02802297f, 0.21991739f, -0.11894709f, 0.24069472f, 0.19067827f, 0.04895897f, 0.38279930f, 
    0.01813902f, -0.10850331f, 0.06320955f, 0.11262532f, -0.04982117f, 0.16443211f, -0.39423528f, 0.06657188f, 
    0.06602668f, -0.23764324f, -0.16653615f, 0.09540027f, -0.21132861f, -0.29236478f, -0.01418375f, 0.28185129f, 
    -0.15710941f, -0.02394844f, -0.18713723f, -0.16988735f, 0.13142458f, -0.09367990f, 0.26223746f, -0.14990336f, 
    0.25190720f, 0.12795937f, 0.14644350f, 0.10703161f, 0.11101092f, 0.10214345f, 0.45905212f, 0.22556387f, 
    0.12938544f, 0.04257481f, 0.13389026f, 0.12601316f, -0.16439945f, 0.14908347f, 0.35244334f, -0.14170246f, 
    0.04576074f, 0.12904480f, 0.37905610f, -0.10594443f, -0.09999011f, 0.18453698f, 0.15071508f, 0.25917125f, 
    0.00533316f, -0.08926877f, 0.12359278f, -0.08224733f, 0.01649499f, 0.16432212f, -0.08765181f, -0.19623576f, 
    -0.16565190f, 0.04743253f, -0.04873254f, 0.47096074f, -0.00748314f, -0.03991080f, -0.32789457f, -0.29162064f, 
    -0.11777418f, 0.16758354f, -0.12300040f, 0.16510767f, -0.08417392f, 0.18843387f, -0.43387356f, -0.12170729f, 
    0.28887847f, -0.09305222f, 0.18627805f, -0.06740250f, 0.00529250f, -0.31127000f, 0.16379467f, 0.53072035f, 
    0.01826743f, -0.11008891f, -0.15826039f, -0.11885293f, 0.15567149f, -0.03830507f, 0.05669254f, -0.17611711f, 
    -0.09074650f, 0.12234704f, 0.10524080f, 0.14106242f, 0.11612547f, 0.22982189f, 0.07091894f, 0.01977995f, 
    0.16157553f, -0.01691944f, -0.09632997f, 0.19429056f, -0.15729898f, 0.12999703f, 0.34965166f, -0.19659030f, 
    0.27034101f, 0.18368310f, -0.01369521f, -0.05255221f, 0.21567498f, 0.02861847f, 0.02582686f, -0.26886317f, 
    -0.10314729f, 0.24479528f, -0.02014391f, -0.20359717f, -0.03149305f, -0.14792052f, 0.19382289f, -0.03597892f, 
    -0.18885228f, -0.11991107f, 0.01712758f, -0.12546010f, -0.12948240f, -0.41240066f, -0.34704614f, 0.14517708f, 
    0.15467171f, 0.04586447f, 0.17635006f, 0.07384750f, 0.13571970f, -0.38799402f, 0.20876303f, -0.24452519f, 
    0.21700524f, 0.24282750f, 0.31058797f, 0.09009231f, -0.14834620f, -0.14418980f, 0.03584182f, 0.40890464f, 
    -0.16044369f, 0.16243513f, 0.10061053f, 0.12478671f, 0.12178838f, 0.07160216f, 0.17357260f, -0.30605325f, 
    -0.01186935f, 0.04212694f, 0.19918171f, 0.06410298f, -0.09841716f, -0.00964712f, 0.36628810f, -0.14461982f, 
    -0.08008144f, -0.01431379f, -0.06292496f, 0.03832614f, 0.00148670f, 0.07520770f, -0.39696854f, 0.00743780f, 
    -0.08403896f, 0.03793917f, -0.21691711f, 0.02461799f, 0.08316928f, -0.03800151f, -0.25361568f, -0.21371208f, 
    0.15366788f, 0.00322386f, 0.07136729f, 0.01170573f, 0.14123061f, 0.03991089f, -0.14103028f, 0.27136469f, 
    0.18884622f, -0.01490077f, -0.24100663f, 0.03815025f, 0.02498787f, 0.10102858f, 0.02018930f, 0.29243797f, 
    0.14887919f, 0.05804268f, -0.10450553f, -0.10616449f, -0.11296636f, 0.24536490f, 0.24419475f, 0.09757444f, 
    -0.39811736f, 0.07545219f, 0.01848381f, -0.02567224f, -0.03402904f, -0.02072580f, 0.09716649f, 0.39354673f, 
    0.09659666f, -0.07085952f, -0.40222111f, -0.25807339f, 0.14667684f, 0.06022417f, -0.09325766f, -0.11513577f, 
    -0.49404407f, -0.09834062f, -0.12165499f, -0.01632555f, 0.12215332f, 0.04384065f, 0.20268740f, -0.36624342f, 
    -0.15318440f, 0.08906971f, 0.06521049f, -0.09519196f, -0.09842920f, -0.30915770f, 0.07793621f, 0.35793161f, 
    -0.29493782f, 0.13395926f, -0.25157872f, -0.08645593f, 0.25236177f, -0.27602986f, 0.26609665f, -0.05366866f, 
    -0.14428388f, 0.17460264f, 0.03966404f, -0.26580995f, 0.03772585f, -0.00772156f, -0.06998233f, 0.20324433f, 
    -0.13670231f, -0.14679226f, -0.14903352f, 0.02135367f, 0.00843956f, -0.16485506f, -0.24346623f, 0.21511480f, 
    0.05923947f, -0.14145152f, 0.03180486f, 0.22340830f, -0.04605500f, -0.21044581f, 0.53043199f, -0.13459241f, 
    -0.10934039f, 0.03490316f, -0.22455510f, -0.13398318f, -0.11503386f, 0.01941116f, -0.71937180f, -0.08729444f, 
    0.13607442f, 0.02502074f, 0.25123826f, -0.35453066f, -0.06015120f, -0.03426974f, -0.42533162f, 0.02436223f, 
    0.12883662f, 0.18019423f, -0.42601258f, 0.04073370f, -0.65545005f, -0.23915140f, 0.07398705f, 0.25279927f, 
    0.16703688f, 0.04100194f, 0.10322049f, 0.15338010f, -0.03872354f, 0.11567377f, 0.21766777f, 0.18381943f, 
    -0.09869506f, 0.33984169f, 0.15357009f, -0.00114605f, 0.16272721f, -0.53096163f, -0.10675310f, -0.16015442f, 
    0.03390558f, 0.20801891f, 0.07288351f, -0.17047425f, -0.14082502f, 0.07376560f, 0.32641605f, -0.35649592f, 
    -0.17000692f, 0.29182026f, -0.02608431f, -0.24591908f, -0.31525806f, -0.42027265f, -0.39651775f, -0.05267334f, 
    -0.01170595f, 0.23094083f, 0.01163847f, 0.12718286f, -0.01161973f, -0.11191071f, -0.37574023f, 0.14079553f, 
    0.00864846f, 0.05404015f, 0.18228276f, 0.06645548f, 0.20807944f, 0.21937789f, -0.11317421f, -0.38045463f, 
    0.09069966f, 0.06563606f, 0.18765154f, 0.34475383f, 0.00594113f, 0.16408768f, -0.32116932f, -0.15169758f, 
    0.21600723f, -0.15976407f, 0.02382650f, 0.01216969f, 0.21534315f, 0.00559218f, -0.32074916f, -0.08451035f, 
    -0.03041493f, 0.03684872f, 0.08459658f, -0.11493496f, 0.14102106f, -0.00489030f, -0.30965567f, -0.10370994f, 
    -0.25440419f, 0.27883908f, -0.22016989f, 0.14465110f, -0.08906288f, 0.09699200f, -0.04526490f, -0.10980997f, 
    -0.06389757f, 0.11944367f, 0.23034132f, -0.32821605f, 0.15323043f, -0.03357763f, 0.29195803f, -0.05213403f, 
    0.02837467f, 0.08411474f, 0.21018292f, 0.25181675f, 0.17257890f, -0.16149993f, 0.02081846f, -0.10866280f, 
    0.12337974f, -0.23971082f, 0.00782159f, 0.30417877f, -0.01548769f, 0.01577687f, 0.03712426f, -0.03018052f, 
    0.00726105f, 0.00223185f, 0.07545228f, -0.13773313f, 0.20743082f, -0.30921552f, -0.09187866f, -0.16362253f, 
    0.03590916f, 0.03581984f, 0.31345677f, -0.08653238f, 0.02163809f, -0.03737279f, 0.06122011f, 0.02345871f, 
    -0.30736634f, 0.33222720f, -0.04731604f, -0.19247529f, -0.22944722f, -0.01998665f, -0.06607787f, -0.17938110f, 
    0.07208807f, 0.20728792f, 0.05709679f, 0.13441519f, -0.11917665f, -0.34409431f, 0.19868810f, 0.15235473f, 
    -0.39961603f, 0.15977624f, 0.04830885f, 0.07596929f, -0.19960570f, 0.19833317f, 0.13237604f, 0.26243356f, 
    0.12251408f, 0.16791123f, -0.27769846f, -0.20386894f, 0.01841203f, 0.01189013f, 0.40700033f, 0.10700958f, 
    -0.18968691f, 0.16105358f, 0.12438749f, -0.25357094f, 0.15642014f, 0.10787492f, -0.05910445f, 0.14668316f, 
    -0.11663293f, -0.17117286f, 0.13477206f, -0.20924155f, 0.12503521f, 0.03867143f, -0.26915541f, 0.25435624f, 
    -0.24555123f, 0.16963659f, 0.36393273f, 0.04304004f, 0.14475453f, 0.04999797f, -0.17038234f, -0.55352628f, 
    -0.08068763f, 0.09615187f, 0.31776872f, 0.07212552f, 0.17427909f, 0.01519764f, -0.22862186f, -0.01971631f, 
    -0.07509599f, 0.02064987f, -0.15702496f, 0.23321199f, 0.13488066f, -0.31957525f, 0.04874545f, -0.15928370f, 
    -0.11852315f, 0.01180772f, -0.16266230f, 0.21298531f, -0.03591162f, -0.13236800f, -0.11839910f, 0.11521567f, 
    -0.20306644f, 0.02115889f, -0.19842798f, 0.17631005f, -0.15388978f, 0.12987034f, 0.09577280f, 0.26464847f, 
    -0.10582517f, -0.04305474f, 0.00468521f, -0.10972453f, 0.16338804f, 0.03258820f, 0.22165015f, 0.05112509f, 
    0.39221019f, -0.18486115f, -0.18390669f, 0.15975238f, 0.18179086f, -0.10300373f, -0.20796672f, 0.13743258f, 
    -0.00161530f, -0.20746031f, 0.01961443f, 0.05806151f, 0.11076666f, 0.32975212f, -0.01877707f, -0.13555811f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.05378041f, -0.07048016f, 0.01967584f, -0.14702100f, 0.06250949f, -0.08453061f, -0.00387615f, 0.26628533f, 
    0.11413760f, -0.03369661f, 0.17461798f, -0.06298807f, 0.27295989f, 0.08274986f, 0.18248861f, 0.14197505f, 
    0.27602077f, 0.10458382f, 0.33975217f, -0.17067558f, 0.16889882f, -0.18229282f, -0.33574373f, 0.03095738f, 
    0.22053853f, -0.00459920f, 0.02154730f, -0.02603670f, 0.12708066f, 0.06390531f, -0.15344581f, 0.03213970f, 
    -0.09026421f, -0.00073849f, -0.01635544f, -0.00544037f, 0.20937735f, 0.26395410f, -0.16144507f, -0.21591304f, 
    -0.08793104f, 0.00832968f, 0.32454953f, 0.25344646f, 0.18064211f, 0.26365432f, -0.03838624f, -0.04651975f, 
    0.11515970f, 0.02483578f, -0.12708409f, 0.13752224f, 0.27362233f, 0.08631880f, 0.01332951f, 0.17642976f, 
    0.01764267f, 0.31460992f, 0.07140125f, 0.21935003f, 0.09645589f, -0.02110772f, -0.13106689f, 0.02183327f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.02002360f, 0.10011428f, -0.28225929f, 0.05860651f, 0.09661360f, 0.04424377f, 0.08132879f, -0.09551243f, 
    0.08244945f, -0.12789367f, -0.07894363f, 0.05687348f, -0.10357463f, -0.23312490f, -0.09844919f, -0.11650336f, 
    0.30807367f, 0.14808299f, 0.35197449f, -0.05456674f, 0.25327557f, -0.03308011f, -0.05873465f, -0.02665114f, 
    0.12004544f, 0.24753690f, -0.01341138f, -0.09242028f, -0.09638119f, -0.00886839f, -0.11308345f, 0.18268667f, 
    0.14328830f, -0.04182484f, 0.02480422f, 0.05574014f, 0.01057985f, -0.00986187f, -0.10678928f, -0.15880933f, 
    0.07475518f, 0.26927817f, 0.19319704f, -0.09527798f, 0.17526141f, 0.10350285f, 0.12205233f, -0.19239347f, 
    0.04238501f, -0.22255990f, -0.18438558f, -0.20316829f, 0.17847832f, 0.04371549f, -0.06836892f, 0.00737526f, 
    -0.43040720f, -0.22706112f, -0.01414640f, -0.00271825f, -0.13055508f, 0.19188963f, -0.04165474f, 0.22530736f, 
    -0.04126310f, -0.09202901f, 0.21489280f, -0.22368911f, -0.06573366f, -0.12799671f, -0.05763549f, -0.04975278f, 
    0.03270478f, -0.01046484f, -0.00228038f, 0.01683580f, 0.06756602f, 0.07650995f, -0.08128875f, 0.02980700f, 
    -0.02158673f, 0.03195617f, -0.16990530f, 0.02379116f, -0.03200136f, -0.02118479f, -0.04629644f, 0.03477478f, 
    0.07231504f, -0.12393724f, -0.00744218f, 0.06375158f, 0.09208108f, -0.02480811f, -0.04725899f, 0.10018508f, 
    -0.05745899f, -0.07645193f, -0.12884055f, -0.12725969f, 0.00714770f, -0.07616188f, 0.01066317f, -0.04002209f, 
    0.01787075f, -0.06819039f, 0.01443655f, 0.05877544f, 0.07755765f, -0.08947525f, 0.06351990f, -0.18423286f, 
    0.02764725f, -0.08877604f, 0.04671558f, -0.03562675f, 0.02337395f, -0.09919932f, 0.04429950f, -0.16629978f, 
    -0.11948197f, -0.07748403f, 0.04452160f, 0.01185668f, -0.06415828f, -0.02837749f, -0.07721081f, -0.17403345f, 
    -0.02232084f, -0.10572559f, 0.13197598f, -0.11408260f, 0.37248632f, -0.01906278f, -0.04821721f, 0.31044990f, 
    -0.35056886f, 0.29700726f, -0.06035618f, 0.11356721f, 0.11080188f, 0.20665087f, 0.44420737f, 0.08529478f, 
    0.13179433f, 0.11658695f, -0.17199832f, -0.08580085f, 0.19839470f, -0.33122808f, -0.40841979f, -0.15359710f, 
    0.26601872f, -0.19005615f, -0.39656359f, 0.03658382f, 0.17453358f, -0.01375675f, 0.00631046f, -0.16134457f, 
    -0.09558503f, 0.08738697f, 0.05431147f, -0.08822086f, 0.22793144f, 0.12541798f, -0.04465754f, -0.29390463f, 
    -0.00040065f, -0.16366971f, 0.02761199f, 0.11760773f, 0.11480121f, 0.12505260f, 0.11888255f, -0.46924913f, 
    -0.61070377f, 0.66540343f, -0.24689141f, 0.19474746f, 0.17541753f, -0.00282632f, 0.14114484f, -0.03942323f, 
    0.21298476f, 0.58487308f, 0.47971117f, 0.07469130f, 0.11224872f, -0.06971645f, 0.21274236f, -0.04870741f, 
    0.03930967f, -0.16685800f, -0.03993385f, -0.06152500f, 0.13666598f, 0.41951975f, 0.17087087f, 0.00574153f, 
    -0.34402820f, 0.27140996f, -0.30629861f, -0.06410690f, 0.25482371f, 0.17238168f, 0.22809978f, -0.05619918f, 
    -0.15726408f, -0.07004094f, 0.02513158f, -0.00084020f, 0.19276583f, -0.18722221f, -0.22578166f, 0.00313179f, 
    0.15709609f, -0.06444300f, 0.21075162f, -0.08431457f, 0.30635652f, -0.29106590f, -0.06497282f, 0.11936544f, 
    -0.25831234f, -0.03008500f, -0.27783984f, -0.14980075f, 0.41999793f, 0.19223377f, -0.13992405f, 0.30594984f, 
    -0.03474703f, 0.07245301f, -0.06946062f, -0.09052530f, 0.30232042f, -0.09173138f, -0.07767534f, -0.30109206f, 
    -0.37638047f, -0.03555103f, -0.11157876f, 0.08174843f, 0.15942989f, 0.08492782f, -0.15143627f, -0.13535213f, 
    0.29312038f, 0.50160098f, 0.14422496f, 0.02457907f, 0.28442815f, 0.00693225f, 0.15053590f, -0.30999258f, 
    -0.07011494f, -0.15495820f, -0.00845748f, -0.07784753f, -0.12310852f, 0.03848342f, -0.01237579f, -0.04889545f, 
    0.02670809f, -0.12019798f, -0.04391563f, 0.09038468f, 0.05663663f, -0.13598311f, 0.01625446f, -0.08851369f, 
    0.06754988f, -0.00561761f, -0.09463744f, -0.00691235f, -0.11310676f, 0.08711042f, 0.00956111f, -0.01402874f, 
    -0.02620718f, -0.12142631f, 0.05954421f, -0.08438100f, 0.01003830f, -0.06985636f, 0.05037971f, -0.12803321f, 
    0.08241280f, -0.02802934f, 0.07220604f, 0.06270856f, -0.08869991f, -0.13428469f, -0.03301020f, -0.07110479f, 
    0.00162318f, 0.07753891f, -0.08398391f, -0.03914433f, -0.07790945f, -0.15990652f, -0.13024135f, -0.12852098f, 
    -0.08562285f, -0.01599653f, -0.10372350f, 0.06269386f, -0.04332613f, 0.01556450f, -0.10029329f, -0.09016614f, 
    -0.13775788f, 0.09647743f, 0.00433253f, -0.07019015f, -0.10961957f, -0.17711034f, -0.03970085f, -0.02808723f, 
    0.04735804f, 0.03732676f, 0.17494090f, 0.21828339f, -0.26969811f, 0.17961560f, 0.01732191f, 0.23262808f, 
    -0.00314765f, 0.13001361f, 0.00358085f, 0.01626830f, 0.22391687f, 0.34571099f, -0.00230332f, 0.03695311f, 
    -0.16575691f, 0.21839018f, -0.11105286f, 0.09027126f, 0.04543993f, -0.21649882f, -0.04904639f, -0.04279799f, 
    -0.10905796f, -0.03619402f, 0.46476242f, -0.07077812f, 0.12017892f, -0.20344906f, 0.19321500f, 0.12700570f, 
    0.00694828f, -0.24646918f, -0.02785112f, -0.09222084f, -0.10371118f, 0.19428855f, -0.05175873f, 0.36844286f, 
    -0.02720228f, 0.15704823f, -0.15027912f, 0.01412393f, 0.18998921f, -0.19660282f, 0.03233254f, 0.01375392f, 
    0.13650241f, -0.35212627f, 0.14712708f, 0.00528195f, 0.00445466f, 0.21979105f, -0.12557723f, 0.23622702f, 
    0.10647998f, 0.04197101f, -0.43091896f, -0.01670174f, 0.15279035f, -0.32615468f, -0.09270194f, -0.07827107f, 
    -0.02823976f, -0.12738895f, 0.02212061f, -0.08893584f, -0.02141769f, -0.11558753f, -0.01895618f, 0.01172786f, 
    -0.07321694f, -0.03195808f, 0.04964303f, -0.12410566f, -0.06599409f, 0.00128118f, -0.11031061f, -0.02938162f, 
    -0.03896056f, 0.07450265f, -0.05594562f, -0.11037634f, -0.04712714f, 0.08263516f, 0.05920738f, -0.05020566f, 
    -0.10103198f, -0.05811756f, 0.07419883f, -0.11782376f, -0.13039024f, 0.01078801f, -0.11741948f, 0.02442720f, 
    -0.08589420f, -0.16585931f, -0.08389506f, -0.12287932f, -0.15710258f, 0.07335078f, -0.07792369f, -0.08085844f, 
    -0.11978827f, -0.01345860f, 0.03855497f, 0.03554026f, -0.11178356f, 0.09200875f, -0.08092299f, 0.01829394f, 
    -0.10253775f, -0.05648056f, -0.07867236f, 0.02385556f, 0.01149326f, -0.10861409f, -0.07730687f, -0.02409643f, 
    0.08150396f, 0.05985501f, -0.05481205f, -0.01481586f, -0.11698896f, 0.01338896f, -0.14582328f, -0.08436631f, 
    0.05964075f, 0.05397214f, 0.40663266f, -0.33025712f, 0.22176822f, 0.11830953f, 0.27919278f, 0.02001808f, 
    -0.23466051f, 0.23941968f, -0.21239182f, 0.09181418f, 0.11321404f, 0.29744095f, 0.31530711f, -0.05516899f, 
    0.13661361f, 0.00670932f, 0.03414626f, -0.05262262f, 0.13169086f, -0.37897575f, -0.23961556f, 0.11409073f, 
    0.10937994f, -0.05427142f, 0.08925910f, 0.10731178f, 0.22372472f, 0.05969974f, -0.10846651f, -0.00653106f, 
    -0.23042537f, 0.10333674f, 0.11115301f, -0.01820865f, 0.23170131f, 0.21324624f, -0.00652230f, 0.12940396f, 
    -0.08268960f, -0.10305572f, -0.03115491f, 0.12931262f, 0.18589911f, 0.05615292f, 0.09283467f, -0.30652469f, 
    -0.17604686f, 0.10887433f, -0.07022179f, 0.38662940f, 0.24289745f, -0.17827094f, -0.06797637f, 0.18347642f, 
    -0.17317441f, 0.57206649f, -0.04511867f, 0.07759814f, 0.39809975f, -0.23426335f, 0.28121072f, -0.12507267f, 
    -0.02560681f, 0.11001303f, -0.18984641f, 0.23669392f, -0.14312226f, 0.07839732f, -0.19790526f, 0.37040138f, 
    -0.04780674f, 0.09181564f, 0.23111665f, 0.07178563f, 0.29587939f, 0.24116424f, -0.10553895f, -0.06859286f, 
    -0.09352031f, 0.12507558f, 0.08755831f, -0.05776567f, 0.22365640f, 0.07176308f, 0.01511041f, 0.01055156f, 
    -0.06023351f, 0.04719185f, 0.05482269f, -0.01693945f, -0.27596441f, -0.12523368f, 0.17680082f, -0.05322238f, 
    0.33092529f, -0.16635598f, -0.03317752f, -0.15964045f, 0.03180882f, 0.18931782f, -0.04751047f, 0.15245470f, 
    0.02360370f, 0.03883085f, 0.02037254f, -0.01890988f, 0.20100248f, -0.02799418f, -0.08542041f, 0.01996740f, 
    -0.28646672f, 0.06703021f, -0.22501573f, -0.22653115f, 0.06441572f, 0.09984469f, 0.00061536f, 0.13402574f, 
    0.23180684f, -0.18424948f, 0.07301720f, 0.02172468f, -0.16821432f, -0.09933674f, 0.06456187f, -0.00284580f, 
    0.08492716f, 0.09045780f, 0.20735347f, 0.15238804f, 0.01426278f, -0.17610087f, 0.08609390f, 0.03323547f, 
    -0.00858032f, -0.13700062f, -0.23866621f, 0.10580070f, -0.14704439f, -0.14067756f, 0.14029802f, -0.11407135f, 
    -0.25783116f, 0.22548783f, 0.15257971f, 0.02580134f, -0.04019495f, 0.12663370f, -0.08013374f, -0.01541538f, 
    0.09808312f, 0.42461997f, -0.29962021f, 0.07842059f, 0.04516385f, 0.10512369f, -0.17041776f, -0.12678617f, 
    -0.19349504f, 0.07021228f, -0.32161748f, 0.12954552f, 0.10946412f, 0.10625115f, -0.01509742f, 0.26472983f, 
    -0.09743876f, -0.16406557f, 0.05543367f, -0.18823604f, 0.08208977f, -0.02041283f, 0.05299519f, -0.01265693f, 
    0.02957895f, 0.19363151f, 0.04989820f, 0.01616190f, 0.06600752f, -0.28824669f, 0.22836229f, 0.12123010f, 
    -0.27366635f, 0.09875438f, -0.15679200f, 0.19774784f, -0.00174058f, 0.18496865f, -0.00715396f, -0.03302960f, 
    0.02707890f, -0.35209954f, -0.09557024f, -0.19918622f, -0.08819366f, -0.46616966f, -0.19652902f, -0.26577854f, 
    0.14544381f, 0.00505261f, -0.00743952f, -0.17629254f, -0.11314582f, -0.13759874f, 0.02255052f, -0.01874293f, 
    -0.50313991f, -0.14400110f, 0.16675934f, 0.06254698f, 0.04682112f, 0.04816795f, 0.20476004f, -0.01927009f, 
    0.03579034f, -0.13700399f, -0.09235284f, -0.07121329f, -0.17862415f, 0.01858864f, -0.08297297f, 0.01288860f, 
    -0.01042102f, 0.12106494f, 0.25499117f, 0.03322822f, 0.07504866f, -0.43297321f, 0.07905053f, 0.19666602f, 
    0.09598194f, -0.03873388f, -0.37960500f, -0.08445507f, 0.01193174f, -0.08646997f, -0.22062263f, 0.11365487f, 
    0.09188443f, -0.04670711f, 0.03611249f, -0.04431301f, -0.01930418f, -0.05309079f, 0.22460802f, -0.26362756f, 
    0.08950440f, 0.23985404f, 0.07213996f, -0.38289025f, -0.17200395f, 0.08310353f, -0.31065300f, -0.11678462f, 
    -0.02087413f, -0.20727699f, -0.52626413f, -0.21908668f, 0.00167065f, 0.17715579f, 0.12599933f, -0.00329870f, 
    -0.15765853f, 0.01193071f, -0.05071731f, -0.05911014f, 0.20229776f, 0.30412844f, -0.05002359f, -0.04686080f, 
    0.08104731f, -0.29898450f, 0.05788923f, -0.02384756f, 0.03784694f, 0.02778140f, 0.00554628f, -0.12544546f, 
    0.22499597f, -0.27007791f, 0.08459086f, 0.07363057f, -0.00242136f, 0.12509780f, 0.06736398f, -0.03935244f, 
    0.06817119f, 0.16168232f, -0.03639686f, 0.14025544f, 0.20347612f, 0.08129703f, 0.07310377f, -0.30566493f, 
    -0.00765378f, 0.24119124f, -0.13457541f, 0.01856489f, 0.27607152f, 0.08745200f, -0.17367968f, -0.19610910f, 
    -0.25853804f, -0.11805354f, -0.14995217f, -0.17621776f, 0.11235636f, 0.10717982f, -0.16419642f, -0.20356955f, 
    -0.28259838f, -0.03380977f, 0.36985853f, -0.25912908f, 0.14703695f, -0.24678653f, 0.22321281f, -0.02623074f, 
    -0.09499370f, -0.11752323f, -0.00357006f, 0.01946711f, 0.05628009f, -0.03804763f, -0.02085461f, -0.04032270f, 
    0.02284317f, -0.00099629f, -0.02251038f, -0.09458146f, -0.13297655f, 0.00173547f, -0.10825235f, 0.12335616f, 
    -0.06116389f, -0.06314968f, -0.09256042f, -0.02334855f, -0.11544415f, 0.02429276f, -0.12220167f, -0.10569200f, 
    -0.15544832f, -0.12424322f, 0.07205239f, 0.12273600f, 0.07752275f, -0.07222272f, -0.10560635f, -0.05541344f, 
    -0.08208822f, 0.01443341f, 0.07533562f, -0.01380106f, -0.02180844f, 0.03205955f, -0.08960928f, 0.03386308f, 
    -0.11774422f, -0.17449766f, 0.07613188f, 0.05975826f, 0.07819004f, -0.00429007f, -0.03149636f, 0.04856506f, 
    -0.12294630f, -0.14020345f, -0.08525274f, -0.12650633f, -0.01956848f, -0.05308869f, -0.01386270f, -0.07289039f, 
    -0.12127104f, -0.11382788f, -0.07523799f, 0.05723999f, -0.05995034f, 0.05639043f, -0.05557840f, -0.11970536f, 
    0.08337630f, 0.03277002f, 0.08478992f, -0.05785510f, 0.16071254f, -0.42365125f, 0.20024619f, -0.01810749f, 
    0.33410043f, 0.19989084f, 0.03580840f, -0.04147366f, 0.12536056f, -0.39672092f, -0.18932559f, 0.09733301f, 
    -0.28148785f, -0.04068155f, 0.12663364f, -0.07569943f, -0.15328689f, -0.06337358f, -0.08777853f, 0.11676483f, 
    -0.04268138f, 0.16314755f, 0.06487945f, -0.08198489f, 0.21390150f, 0.12323628f, 0.18667224f, -0.04838362f, 
    -0.02602798f, -0.08037204f, 0.49892607f, 0.15938066f, -0.12586854f, 0.00283382f, 0.14465789f, 0.28208175f, 
    0.00625087f, -0.32911265f, 0.24159864f, 0.32175958f, 0.03651200f, 0.17602029f, -0.09317357f, -0.03314153f, 
    -0.08177225f, -0.37157136f, -0.18773380f, 0.31725529f, -0.07551906f, 0.14041236f, 0.21264291f, 0.20031741f, 
    0.32624784f, -0.11292893f, 0.05592272f, 0.17500462f, 0.21283792f, -0.06022565f, 0.33467785f, -0.24978660f, 
    0.06595975f, 0.20547566f, 0.32433358f, -0.21559657f, 0.07930429f, -0.10956133f, -0.07778384f, -0.00963973f, 
    0.12524503f, 0.14627953f, 0.13879544f, -0.04860113f, -0.03422539f, -0.06723005f, 0.01626325f, -0.09205201f, 
    0.01833823f, -0.09791148f, 0.10993978f, 0.06190584f, -0.20001656f, -0.43756455f, -0.44540709f, 0.07027503f, 
    0.01033952f, 0.08870333f, -0.20804039f, 0.03620805f, -0.01848079f, -0.07550295f, 0.04087624f, -0.41440329f, 
    0.26970130f, 0.00927294f, 0.58746988f, -0.09536095f, -0.20621791f, 0.09118618f, 0.02267261f, 0.22880954f, 
    0.02157706f, -0.40303677f, 0.39339107f, 0.35139209f, -0.05314561f, 0.30250594f, 0.04542935f, -0.06983571f, 
    -0.48264256f, -0.28436613f, -0.33809954f, 0.30581450f, -0.19371128f, 0.22310022f, 0.08015984f, 0.34014893f, 
    0.21518210f, 0.24442531f, -0.00571555f, 0.11664794f, 0.02344666f, 0.02192190f, 0.13420878f, 0.06221143f, 
    -0.04188302f, -0.10219754f, -0.08203921f, 0.28804737f, -0.15424541f, -0.01965600f, -0.28205886f, 0.22457713f, 
    -0.13301672f, 0.01243761f, 0.09880030f, -0.02520892f, 0.22915599f, 0.06886521f, 0.10971545f, 0.08487846f, 
    -0.01753351f, 0.12213777f, -0.13687721f, 0.08466932f, 0.21729124f, 0.17343351f, -0.03940478f, 0.05829144f, 
    -0.22031227f, -0.02896577f, 0.16048668f, 0.11684881f, -0.28477857f, -0.37872338f, 0.15645398f, -0.14977355f, 
    0.01220988f, -0.26577413f, -0.22568184f, -0.38331923f, -0.01498074f, 0.10707975f, 0.02561448f, 0.04262621f, 
    0.07792242f, -0.11684265f, 0.03284467f, -0.12173226f, 0.14138705f, 0.03531449f, -0.30003828f, -0.06121614f, 
    0.00351159f, 0.44601494f, -0.03811709f, -0.05378862f, -0.11272036f, 0.01159103f, -0.23339024f, 0.08675855f, 
    0.49909577f, -0.12258673f, 0.00695057f, 0.12828320f, -0.09344785f, -0.17714083f, 0.12575801f, 0.14494286f, 
    -0.00476950f, 0.10490203f, -0.06835259f, -0.15614721f, 0.03400035f, -0.09146364f, -0.02356775f, 0.00023523f, 
    0.06714933f, -0.09484964f, -0.08699581f, -0.00713167f, -0.04973221f, -0.12353438f, -0.04434837f, 0.10168859f, 
    -0.11048728f, -0.12019639f, -0.08041641f, 0.00129935f, 0.00309359f, 0.01128980f, -0.14458507f, 0.05934720f, 
    -0.17135586f, 0.09328578f, 0.00084323f, 0.01173688f, -0.09240367f, -0.10563969f, -0.06660087f, 0.00160453f, 
    0.06783057f, 0.05576159f, 0.05520130f, -0.00729603f, 0.06070305f, -0.06865335f, 0.03973012f, 0.08625650f, 
    0.00382918f, -0.05655332f, -0.09426571f, -0.10865892f, -0.07065139f, 0.07017017f, 0.08829062f, -0.15383402f, 
    0.12644160f, -0.07505596f, 0.00247968f, -0.15158728f, 0.03026029f, 0.06231604f, -0.02784334f, -0.04864596f, 
    -0.01371923f, -0.07779161f, -0.11526450f, -0.01926698f, -0.09869979f, -0.03426180f, -0.13221665f, 0.07469890f, 
    -0.05703840f, -0.07974368f, -0.01549176f, 0.00716937f, -0.07123574f, -0.13214770f, 0.08507831f, -0.15579885f, 
    -0.15984921f, 0.00764422f, 0.08383383f, 0.08394603f, 0.00145341f, 0.05247100f, 0.04616175f, -0.08793551f, 
    0.09331921f, 0.07589342f, 0.04580091f, 0.12316066f, 0.02327076f, -0.14558642f, 0.03908256f, 0.08903356f, 
    0.09133375f, -0.00881339f, -0.04766650f, -0.00708669f, -0.06882430f, 0.06454135f, 0.04690412f, -0.00528675f, 
    -0.04991930f, -0.07546140f, 0.08017945f, -0.10959499f, -0.02732349f, -0.07206886f, -0.04827987f, 0.07531243f, 
    0.12012359f, -0.05298576f, -0.07660343f, -0.10354190f, 0.03140644f, -0.09528264f, 0.08458469f, -0.13679576f, 
    -0.05140002f, -0.03486083f, 0.08607817f, 0.06595989f, -0.14129807f, -0.03349209f, 0.02013671f, -0.10127880f, 
    0.08415670f, -0.08628220f, -0.09206021f, -0.07676198f, -0.01241133f, -0.02425248f, -0.00574162f, -0.07443357f, 
    0.03116705f, -0.08215962f, 0.09375378f, 0.03710599f, -0.09115572f, 0.03276352f, -0.09527175f, -0.06324127f, 
    0.04407994f, -0.13089274f, 0.05095311f, -0.00876807f, 0.00086157f, -0.06428149f, 0.04725625f, -0.01349162f, 
    0.02330560f, 0.06288154f, -0.11535233f, -0.01184618f, 0.01751659f, -0.11304871f, -0.14941858f, -0.09834284f, 
    -0.10530768f, 0.01783440f, 0.09623366f, -0.03930399f, 0.05557296f, -0.15316498f, 0.01130552f, 0.10039996f, 
    -0.11131201f, 0.04774855f, -0.02802373f, 0.05281255f, -0.07598712f, -0.10356348f, -0.09998921f, 0.08274795f, 
    0.03522405f, 0.02993991f, 0.01006619f, -0.01453286f, 0.06919441f, -0.10659079f, -0.01451445f, -0.17831737f, 
    -0.06563479f, -0.09332116f, -0.07003529f, -0.02153329f, -0.02962444f, -0.01660794f, 0.01683631f, -0.08274495f, 
    0.00273033f, -0.11873955f, -0.05071905f, 0.08697305f, -0.13508523f, -0.04967394f, -0.15826800f, -0.17716423f, 
    -0.06897564f, 0.19474806f, 0.30406868f, -0.09696765f, 0.06937036f, -0.00807258f, -0.00625712f, 0.12115026f, 
    -0.04051274f, -0.04300941f, 0.01049191f, -0.04431869f, -0.08201654f, -0.01491385f, 0.15193659f, 0.02588908f, 
    -0.10210110f, -0.11359932f, 0.17745458f, -0.03104826f, -0.15775584f, -0.32537600f, -0.21245116f, 0.06513707f, 
    0.03991278f, 0.11383989f, 0.15530780f, 0.13520691f, 0.14399566f, 0.10768713f, 0.08211495f, -0.09092499f, 
    -0.07276089f, -0.06575585f, 0.58786464f, 0.13774735f, -0.12484661f, 0.03760707f, 0.02100445f, -0.05004799f, 
    -0.09245589f, -0.13674788f, 0.06665288f, 0.20308043f, 0.09868034f, 0.05202409f, 0.20082870f, -0.03284786f, 
    -0.15189683f, -0.14802806f, -0.07613780f, 0.30741021f, 0.06407503f, 0.05967072f, 0.09172626f, 0.14937569f, 
    0.00120907f, -0.09538770f, 0.16951737f, -0.05528228f, 0.14938641f, -0.18546750f, 0.05626388f, -0.10885635f, 
    0.10482419f, -0.09569789f, -0.20498799f, -0.31203380f, 0.18257128f, 0.11643630f, -0.19911508f, 0.36864743f, 
    -0.19970922f, 0.28879574f, 0.01450952f, -0.07358576f, 0.37173811f, 0.04489961f, 0.25467375f, 0.02090184f, 
    -0.06529567f, -0.03709698f, 0.08000385f, 0.11773698f, 0.17060535f, -0.19961759f, -0.08364932f, 0.02691251f, 
    -0.07950572f, -0.02172793f, 0.09749717f, 0.11881547f, -0.18475838f, -0.26010492f, -0.02776661f, -0.26764342f, 
    0.16312458f, -0.10338304f, -0.09661233f, -0.14366214f, 0.23397470f, 0.02694591f, -0.04057752f, -0.30655634f, 
    0.17015235f, -0.23717061f, 0.19314785f, 0.10599090f, 0.30539834f, 0.35009351f, -0.32508430f, 0.17008331f, 
    -0.42162183f, 0.15080300f, -0.27635565f, -0.02296648f, 0.13788758f, 0.15537724f, -0.29692999f, -0.03528549f, 
    0.40579489f, 0.13767301f, 0.16973241f, 0.24088682f, 0.02684449f, 0.02496815f, 0.38012683f, -0.05760524f, 
    0.01421511f, 0.17693095f, 0.21257448f, 0.10507065f, 0.13480851f, 0.08809093f, 0.02394215f, -0.19486479f, 
    0.21151420f, -0.18102416f, -0.29577509f, -0.05421268f, -0.11548534f, -0.40146983f, 0.02530988f, 0.02556637f, 
    -0.01385480f, 0.14132695f, 0.20030724f, -0.03787689f, 0.27278116f, -0.10509381f, -0.05473100f, 0.05000131f, 
    -0.06483497f, 0.13297290f, -0.07838403f, 0.01365459f, 0.02579065f, 0.02110114f, -0.19001868f, 0.19896492f, 
    0.00272908f, -0.01143816f, -0.12147136f, 0.01321453f, 0.12345016f, 0.05591233f, -0.01205723f, 0.07464043f, 
    -0.10484882f, 0.04089971f, 0.20892148f, -0.10413050f, 0.15695634f, 0.01811700f, 0.12021975f, -0.03894947f, 
    0.34497032f, -0.35921672f, 0.04487290f, -0.07897863f, 0.03168573f, -0.13662620f, -0.32909763f, -0.08953516f, 
    -0.06774482f, 0.30667478f, -0.38696587f, 0.34044939f, 0.09328023f, 0.16564646f, -0.20772021f, -0.17138830f, 
    -0.11163338f, -0.08060891f, -0.35273078f, 0.22078176f, -0.18620341f, 0.07365978f, 0.04564598f, 0.20691696f, 
    -0.08545756f, 0.29536077f, -0.02347222f, -0.03001254f, 0.22426881f, 0.16027090f, -0.10751903f, -0.05892999f, 
    -0.14745629f, -0.07735961f, -0.32766867f, 0.02089893f, 0.14684144f, -0.16320181f, -0.00837161f, 0.10699283f, 
    -0.19648647f, -0.18864915f, 0.59489012f, -0.03658895f, -0.17903835f, -0.15316880f, 0.05270320f, 0.11053801f, 
    0.17440137f, -0.07559779f, -0.23473439f, -0.11340105f, 0.03608090f, -0.07101495f, 0.00961498f, 0.22541180f, 
    0.08541670f, 0.30396056f, 0.05368882f, 0.11244181f, 0.31253341f, 0.17555310f, -0.28592435f, -0.14788914f, 
    -0.07758567f, -0.01894051f, -0.21501377f, -0.17188072f, -0.06789742f, 0.12215319f, -0.21143822f, -0.12295686f, 
    0.63543808f, -0.03563195f, 0.19575334f, 0.12887527f, 0.13654180f, -0.34851730f, 0.28228635f, 0.06089144f, 
    -0.12252109f, 0.11790434f, 0.01677516f, 0.38489741f, -0.02082948f, 0.32261911f, -0.13227783f, 0.20047837f, 
    0.02761518f, -0.18563853f, -0.02301423f, -0.02331458f, 0.10030446f, 0.21777056f, 0.11597636f, -0.06120956f, 
    0.04402537f, 0.22618459f, 0.19666989f, 0.08273606f, 0.32197094f, 0.10210180f, -0.00414767f, 0.05707438f, 
    0.02332416f, 0.20587909f, 0.31043154f, -0.06015173f, -0.37409648f, -0.12642355f, -0.23595920f, 0.08055140f, 
    0.10113088f, -0.16018152f, -0.05786530f, -0.00403999f, -0.08345658f, 0.09456935f, 0.01058068f, -0.11506175f, 
    -0.01480220f, 0.28577268f, -0.04406143f, -0.06125835f, -0.01927900f, -0.13838270f, 0.31598854f, 0.00843228f, 
    0.28065309f, -0.17620476f, 0.03709387f, -0.17678759f, 0.22945172f, -0.02111319f, 0.11775846f, 0.08949837f, 
    -0.10712422f, -0.30339772f, -0.27858844f, -0.14871895f, -0.25275773f, -0.10873499f, -0.28332603f, 0.23229407f, 
    -0.11071542f, 0.18752937f, 0.49027297f, -0.01487661f, 0.23520654f, -0.10896526f, 0.08058870f, 0.03898267f, 
    0.19349912f, 0.09093241f, -0.05286449f, -0.07758300f, -0.02665148f, -0.02448749f, 0.08355672f, -0.03878945f, 
    -0.00879401f, 0.11416212f, 0.18544802f, -0.04887235f, -0.19982357f, -0.25526774f, -0.35991108f, 0.11718557f, 
    0.13521728f, 0.18715017f, -0.30804622f, -0.11011084f, 0.39705998f, 0.16276011f, 0.05109551f, -0.11286135f, 
    -0.07526225f, 0.11897144f, 0.45251837f, 0.19206934f, -0.07022077f, -0.05848493f, -0.11242548f, 0.20882145f, 
    -0.11489625f, -0.29363516f, 0.09713306f, 0.14093693f, 0.15232770f, 0.31120872f, -0.01340893f, -0.12348806f, 
    -0.02162987f, -0.02685199f, -0.04826161f, 0.37035549f, -0.00365268f, -0.13945128f, -0.22036760f, 0.26413560f, 
    -0.09763572f, 0.25563374f, 0.00347662f, 0.21025129f, 0.25072429f, -0.02174714f, 0.06987166f, 0.01255211f, 
    -0.08832207f, -0.02698447f, -0.00842426f, -0.05658680f, 0.04340576f, -0.03296330f, 0.12878820f, 0.08872019f, 
    -0.14981191f, -0.01425517f, 0.03901866f, 0.00762145f, 0.14392971f, -0.07858701f, 0.16095610f, 0.03701898f, 
    0.03948198f, -0.09239494f, -0.01486326f, -0.09624989f, -0.12216955f, -0.02691019f, -0.15655194f, -0.01219141f, 
    0.07332602f, -0.13128895f, -0.04887270f, -0.09451757f, 0.07906372f, 0.07281949f, -0.13145342f, 0.05123064f, 
    -0.12843132f, -0.12165793f, 0.02451123f, 0.02714735f, 0.10510754f, -0.10175486f, -0.11586154f, 0.00876381f, 
    -0.08852623f, -0.06909136f, -0.04145409f, 0.07316928f, -0.08233310f, 0.09060616f, 0.05597608f, -0.14412220f, 
    0.08728857f, 0.05830964f, 0.08175206f, 0.00410183f, 0.01302571f, -0.05876105f, 0.00842914f, 0.10318102f, 
    -0.11212382f, 0.13665599f, 0.11422458f, -0.10450102f, 0.05911702f, -0.13281496f, 0.06177879f, -0.06510638f, 
    0.03634372f, 0.12944894f, 0.39080143f, -0.27471030f, 0.31451929f, -0.10212122f, 0.00165297f, 0.13835847f, 
    -0.06299567f, 0.04274458f, 0.00945252f, 0.01823827f, 0.14742021f, 0.00538472f, 0.37165043f, 0.09552588f, 
    0.08477754f, 0.17720869f, -0.14508677f, -0.06879941f, -0.13388951f, -0.20769435f, -0.25251603f, 0.06077649f, 
    0.01837630f, -0.06926703f, -0.08431760f, 0.04910542f, 0.13656734f, 0.30227125f, -0.08155677f, 0.08359039f, 
    -0.22036771f, 0.06112356f, 0.11203423f, 0.02129055f, -0.13692839f, -0.01123181f, 0.08573791f, -0.17106317f, 
    -0.05534352f, -0.28261131f, 0.14225172f, 0.25664246f, -0.03184137f, 0.08141735f, 0.24465415f, -0.43752608f, 
    -0.08603782f, 0.39357677f, -0.03808138f, 0.44659781f, 0.23193033f, -0.16376454f, 0.01078268f, 0.15178204f, 
    0.02399568f, 0.32693145f, 0.03003484f, 0.14570548f, 0.04525853f, -0.45962822f, 0.09218010f, -0.03381282f, 
    -0.00812517f, 0.25884819f, 0.13807496f, 0.12989514f, 0.02370587f, -0.04022785f, -0.07983120f, 0.07869899f, 
    0.14809668f, -0.17774639f, 0.20766653f, -0.09341377f, -0.12127852f, -0.09060193f, 0.15983976f, -0.03723344f, 
    0.30609947f, 0.13172966f, -0.11503996f, 0.04254359f, -0.11269394f, -0.10480481f, 0.10146838f, 0.04952701f, 
    0.06710326f, 0.23484801f, 0.02679017f, 0.09940085f, -0.20725659f, 0.06925037f, -0.05097863f, 0.09081615f, 
    0.04815690f, -0.07435668f, 0.12060284f, -0.10393074f, -0.43286425f, -0.04445945f, -0.09751429f, -0.33461633f, 
    -0.07185570f, 0.01452493f, 0.26653039f, 0.21549815f, -0.05699264f, 0.02895770f, 0.19077055f, -0.21323438f, 
    0.20369938f, 0.15029669f, 0.26729721f, -0.14345957f, 0.10171271f, -0.10389555f, -0.12723328f, 0.18099721f, 
    -0.26770490f, -0.49256983f, -0.12101366f, 0.21312673f, -0.04608417f, -0.37330940f, 0.02067614f, 0.20640939f, 
    -0.07622634f, 0.09511489f, -0.07843447f, -0.01504264f, -0.02282997f, -0.13203532f, 0.03152872f, 0.07662277f, 
    0.06154273f, -0.04452667f, 0.06274467f, -0.00212969f, 0.06970643f, -0.12359177f, -0.10318552f, 0.01549253f, 
    -0.09866691f, 0.04029080f, -0.02496185f, -0.07662021f, -0.04530476f, -0.03820505f, -0.10324361f, 0.00690649f, 
    0.09546188f, 0.00120807f, 0.07727304f, -0.00739680f, -0.03292983f, -0.06588107f, -0.02173394f, -0.12202682f, 
    -0.11718492f, -0.13112281f, 0.01768880f, -0.01418108f, 0.08600655f, -0.03649401f, -0.00180972f, 0.09169254f, 
    -0.04706432f, 0.10145126f, -0.09076315f, 0.02745048f, -0.08661751f, -0.12497534f, -0.01913630f, -0.03136078f, 
    -0.12550029f, -0.11447956f, -0.14137672f, 0.06203202f, 0.01208984f, -0.01575332f, 0.06324302f, -0.04039413f, 
    -0.07637473f, 0.05704036f, -0.03569363f, -0.02537617f, -0.04966879f, -0.09002403f, 0.05831569f, -0.07594368f, 
    0.11947472f, 0.09843826f, -0.17667530f, -0.00490835f, -0.07606188f, -0.00543769f, 0.02932398f, 0.09046971f, 
    -0.15697852f, -0.14823610f, -0.00335770f, 0.00901196f, -0.10322763f, -0.04427382f, -0.09107208f, -0.04755896f, 
    0.14613195f, -0.06403371f, -0.11313198f, 0.06960244f, -0.02455006f, 0.01769422f, -0.03631929f, 0.11818464f, 
    -0.14655615f, 0.07670756f, 0.08701370f, 0.07151046f, -0.16066617f, -0.07386938f, -0.04369012f, -0.14583190f, 
    0.07062679f, -0.07156501f, -0.11269093f, 0.06073117f, -0.08190811f, 0.07696704f, -0.02124338f, 0.04933551f, 
    0.04649907f, 0.04685856f, 0.08535729f, -0.12701486f, -0.09444080f, -0.08276009f, 0.11932510f, -0.06011823f, 
    -0.05839248f, -0.05839604f, 0.09837019f, -0.11721988f, -0.07324883f, 0.02654450f, 0.03843947f, 0.02396778f, 
    -0.10427009f, -0.14913502f, -0.11169287f, -0.16519949f, -0.03198910f, -0.03576660f, -0.07776137f, -0.03266480f, 
    -0.12302138f, -0.00754852f, -0.12671769f, 0.08438256f, -0.03111893f, -0.13208365f, -0.00339625f, 0.05822928f, 
    0.06545362f, -0.01238999f, -0.06540952f, -0.08337140f, -0.06112489f, -0.09182161f, 0.02762445f, -0.04000306f, 
    0.01854064f, -0.02071169f, 0.00822282f, 0.01127023f, -0.04943035f, -0.08369181f, 0.01180262f, -0.11987318f, 
    -0.11214958f, 0.06761561f, 0.02118248f, -0.01646966f, -0.00064262f, 0.05640805f, -0.09910277f, -0.09967538f, 
    -0.03897965f, -0.01709515f, -0.09465540f, -0.13702327f, -0.04392274f, -0.04550943f, -0.02550873f, -0.02385530f, 
    -0.02731115f, -0.01670086f, 0.04788272f, 0.05090963f, -0.07715981f, -0.13172698f, 0.08171999f, 0.07182427f, 
    -0.03568809f, 0.00682739f, -0.06059060f, 0.09011202f, 0.00501601f, 0.02250531f, 0.00206172f, -0.14597499f, 
    -0.07426289f, 0.10358119f, -0.12255064f, -0.11829890f, 0.02711832f, -0.02270155f, -0.03602241f, -0.04075908f, 
    0.05642447f, 0.01484190f, -0.05203126f, 0.01243691f, 0.04620304f, -0.09536145f, -0.10422089f, -0.10751677f, 
    0.04100465f, 0.02041361f, -0.12913860f, -0.05027646f, 0.05602531f, 0.10420144f, 0.07682969f, 0.08768111f, 
    0.07948732f, 0.05729403f, 0.00540641f, 0.10696559f, 0.03111570f, -0.07733704f, 0.01294718f, 0.11633144f, 
    -0.12329347f, -0.11200615f, 0.11101332f, -0.02095319f, -0.10954572f, -0.03745955f, -0.06130913f, -0.11731589f, 
    -0.08388710f, -0.12726244f, 0.04060990f, 0.06074298f, 0.00854698f, -0.00460802f, 0.08793598f, 0.07475237f, 
    0.10049149f, 0.01923519f, -0.00496649f, -0.04180754f, -0.07522224f, -0.12849830f, 0.08582897f, 0.06249501f, 
    0.04799850f, -0.08253222f, 0.00949465f, -0.07443342f, -0.07165024f, -0.09767410f, -0.00561303f, -0.02547913f, 
    -0.02968303f, -0.03277148f, -0.04837126f, 0.11674639f, 0.01517603f, 0.00126195f, -0.09196982f, 0.00091666f, 
    0.01915635f, -0.00227770f, -0.33735377f, 0.30075857f, -0.38220489f, 0.16393790f, -0.04927129f, 0.03513466f, 
    0.08121935f, 0.08229370f, 0.11576355f, 0.08265403f, 0.21546665f, 0.07033354f, -0.04138537f, -0.08030128f, 
    -0.19561958f, 0.09692663f, -0.20507257f, -0.05921359f, 0.05322584f, 0.11377337f, 0.15697090f, 0.09912320f, 
    -0.19255258f, -0.05248301f, 0.22148998f, -0.06073194f, -0.51439357f, -0.48587722f, 0.07315108f, 0.05825351f, 
    0.00981810f, -0.36429960f, -0.48916730f, -0.44560504f, 0.27693555f, 0.03923989f, -0.10930425f, 0.00356686f, 
    -0.03848101f, 0.35812381f, -0.13138685f, -0.11685482f, 0.00629445f, 0.10042673f, -0.38020667f, -0.25144646f, 
    0.26210877f, -0.01278426f, -0.20376644f, -0.21172027f, -0.11013250f, 0.23139577f, -0.07413066f, -0.13303159f, 
    0.31633639f, -0.05656741f, -0.12885594f, 0.10471707f, -0.28356439f, -0.06208029f, 0.09732313f, 0.12591614f, 
    -0.06815369f, 0.05884900f, -0.09173915f, -0.12135010f, -0.05379229f, 0.06875328f, -0.01274768f, -0.06079237f, 
    0.07091249f, 0.03334740f, 0.04491447f, -0.06631238f, 0.10885818f, 0.09245560f, -0.10216799f, -0.11732329f, 
    -0.07264234f, -0.00998428f, 0.04911754f, 0.02931036f, -0.12740357f, -0.02461850f, -0.15677558f, -0.04977624f, 
    -0.10269008f, -0.00792047f, -0.03704201f, -0.09038334f, -0.08517224f, -0.02237865f, 0.00353942f, -0.08495156f, 
    -0.06371930f, -0.03077799f, 0.00210566f, 0.04652106f, -0.15882191f, -0.12994188f, 0.05252613f, -0.08936124f, 
    0.02741939f, -0.12539932f, 0.12950619f, -0.05348426f, -0.10373604f, -0.06706546f, -0.06039583f, -0.08120365f, 
    0.01275097f, -0.03200468f, 0.01297035f, -0.07037046f, -0.12592816f, -0.05272857f, -0.05469406f, -0.11736227f, 
    -0.06990355f, 0.04685571f, -0.02305570f, -0.01434389f, 0.04164647f, 0.03846661f, -0.10743003f, -0.00307604f, 
    0.08256207f, 0.21171878f, 0.17724727f, 0.26526025f, -0.11933565f, 0.07727603f, -0.01623477f, -0.19837639f, 
    0.25688806f, -0.21045282f, 0.21534528f, 0.12195116f, -0.23015229f, -0.00590383f, -0.11334156f, 0.10481451f, 
    0.14112659f, 0.33487850f, 0.13862857f, 0.01784343f, 0.00030865f, 0.05412263f, 0.12818693f, 0.12570092f, 
    -0.21898651f, 0.19623025f, 0.35190415f, -0.08564118f, 0.15077476f, 0.06485882f, 0.02441278f, 0.14601605f, 
    -0.02309407f, 0.09770484f, -0.02121207f, 0.00089195f, -0.28783226f, 0.08215219f, 0.07911211f, 0.02184901f, 
    0.10576213f, 0.12731554f, 0.11463249f, -0.05177265f, -0.03638751f, -0.17697224f, 0.22849126f, 0.12698027f, 
    0.56637168f, -0.00909461f, 0.12550218f, -0.21667267f, 0.04930164f, 0.15483446f, 0.13903442f, -0.09499516f, 
    -0.17650637f, -0.18030232f, -0.25756618f, -0.02060049f, -0.25846729f, -0.05048409f, -0.04360734f, 0.17733985f, 
    -0.09738886f, -0.00680054f, -0.15973207f, 0.24029021f, 0.03313460f, 0.05736110f, -0.11065619f, 0.15146874f, 
    0.02968368f, -0.10356533f, 0.18031229f, 0.02876190f, 0.06893323f, 0.14425023f, 0.07354324f, 0.12073524f, 
    0.07998373f, 0.12858889f, 0.17559297f, 0.08977131f, -0.15420578f, 0.06185751f, -0.16428693f, 0.10881998f, 
    -0.04147098f, 0.17923415f, -0.39694285f, 0.06235293f, -0.19332911f, -0.05057727f, 0.23236185f, -0.31510407f, 
    0.21475969f, -0.08381519f, 0.33374280f, -0.10439633f, -0.24288405f, 0.17932370f, -0.07845645f, 0.09059401f, 
    0.04145909f, -0.29016674f, 0.26714456f, 0.22891055f, -0.05195282f, 0.01504308f, 0.00610885f, -0.17199671f, 
    -0.11221484f, -0.15066311f, -0.11083797f, 0.03537802f, -0.07793513f, 0.26672029f, -0.07694685f, 0.19297618f, 
    -0.13209228f, -0.02223541f, 0.13133177f, 0.12697558f, -0.19279540f, -0.21758750f, -0.08847999f, 0.28091356f, 
    -0.01597981f, 0.10417875f, 0.23936225f, -0.21439353f, 0.24027202f, -0.23600981f, -0.06686396f, 0.11272322f, 
    -0.08319173f, 0.05027384f, 0.06726065f, 0.01209357f, 0.05805558f, -0.13015772f, 0.12704454f, -0.09053908f, 
    -0.07675273f, 0.14383510f, -0.05325596f, -0.13095506f, -0.25288323f, -0.03639719f, -0.10687596f, -0.13145779f, 
    0.02046278f, -0.17230435f, -0.10204216f, -0.04395020f, 0.05317217f, 0.13040873f, -0.02925188f, -0.02021785f, 
    -0.07469342f, -0.07353975f, -0.16324477f, 0.03393545f, -0.08506256f, -0.05203342f, -0.13657668f, -0.07184367f, 
    0.02406724f, -0.06081963f, 0.06644116f, 0.12253200f, -0.14146693f, -0.04367715f, 0.09012920f, -0.00533297f, 
    -0.04470610f, 0.40763220f, 0.28680214f, -0.00144876f, 0.19925684f, -0.01410527f, 0.30004537f, 0.04718705f, 
    -0.07061285f, -0.11449728f, -0.10089220f, 0.07211979f, 0.04648519f, -0.07550099f, 0.18112445f, 0.01222361f, 
    0.10358477f, 0.17875996f, -0.39647096f, 0.46584326f, -0.09550270f, -0.05600513f, -0.33179188f, 0.18369403f, 
    0.17628618f, -0.04947588f, 0.20335312f, 0.15523849f, 0.09572341f, 0.08268928f, -0.10591507f, 0.00146990f, 
    0.19587241f, 0.11985292f, -0.02413546f, -0.11345046f, 0.09221286f, 0.16771552f, 0.23859242f, 0.08353808f, 
    -0.22562635f, 0.08748709f, -0.28698459f, -0.04090312f, -0.22751033f, -0.20656820f, 0.25157073f, -0.02516734f, 
    0.09417114f, -0.20016040f, -0.13581590f, -0.27735069f, -0.09390350f, 0.13448697f, -0.09490057f, 0.17941006f, 
    -0.09188022f, -0.04327727f, 0.23496865f, -0.03104377f, 0.10864361f, 0.18268804f, -0.19818582f, -0.08091188f, 
    0.00974597f, 0.09478401f, -0.03628378f, -0.27852520f, 0.02339273f, 0.26840240f, 0.19052272f, 0.15995735f, 
    0.17149486f, -0.26718324f, -0.01157889f, 0.21099140f, -0.21271691f, -0.18868700f, 0.06448122f, 0.32713875f, 
    -0.02435111f, -0.08510724f, 0.31762803f, -0.20093411f, -0.07336541f, -0.39171022f, -0.01347308f, -0.37629870f, 
    0.07704905f, 0.00177989f, 0.17889753f, -0.03552084f, -0.14022833f, -0.44789678f, -0.27683121f, -0.06938472f, 
    -0.24061462f, -0.05300801f, 0.01116924f, 0.13932513f, -0.17844385f, -0.18838876f, 0.02385863f, -0.08751261f, 
    -0.16144642f, -0.08694238f, 0.13463774f, -0.01411231f, 0.40660051f, 0.25742289f, 0.26249257f, -0.01385163f, 
    0.08952954f, 0.15597050f, 0.56608987f, 0.06693050f, 0.04470177f, -0.02350317f, 0.01066895f, 0.36040553f, 
    0.02927475f, -0.24921216f, 0.09879044f, 0.19866218f, -0.00186490f, 0.27392364f, -0.08259371f, -0.08627509f, 
    0.02886589f, -0.22752467f, -0.07500909f, 0.27318677f, -0.28821850f, 0.19854400f, 0.03347347f, 0.04462141f, 
    0.16840683f, -0.00425015f, 0.09543429f, 0.14057079f, 0.33833668f, -0.00353694f, 0.17206126f, -0.29384607f, 
    0.01475178f, -0.03469983f, -0.11496422f, -0.01528637f, 0.06126356f, -0.06777263f, 0.01269304f, -0.11667543f, 
    -0.10541707f, -0.09817702f, -0.03605329f, 0.04573292f, 0.00500869f, -0.07648611f, 0.01929634f, -0.09806651f, 
    -0.02527273f, -0.06752852f, -0.14624956f, -0.06651749f, -0.04576792f, -0.13802421f, -0.13884726f, 0.01215416f, 
    0.03856896f, -0.13296190f, 0.12401430f, 0.05177297f, -0.04884235f, -0.02587418f, -0.00694444f, -0.15283281f, 
    -0.09709448f, -0.05419046f, -0.12945180f, 0.06542610f, 0.06963907f, -0.15468343f, 0.11751615f, -0.02439430f, 
    -0.02938546f, 0.01296505f, -0.07180104f, -0.00446117f, -0.00851492f, -0.07875565f, -0.04658541f, 0.01075316f, 
    0.04243701f, -0.00817593f, -0.04313989f, -0.10572512f, 0.08459833f, 0.10250489f, -0.03016075f, -0.02930827f, 
    -0.12853917f, -0.09324257f, -0.04292143f, -0.07129275f, -0.00032651f, 0.07633843f, 0.00626615f, -0.00088696f, 
    0.01134047f, 0.05890915f, -0.22557960f, 0.18490566f, -0.01983493f, -0.00355766f, 0.19823660f, -0.05335990f, 
    0.09917412f, -0.01205876f, 0.24667875f, 0.00654884f, -0.14319395f, -0.06013124f, -0.33993053f, -0.07087825f, 
    0.24510872f, 0.01501391f, 0.07873120f, -0.02023981f, 0.06582902f, -0.03293904f, 0.14607158f, -0.08444149f, 
    0.00103180f, 0.04277569f, 0.43536517f, -0.05117267f, -0.09779719f, 0.16985907f, 0.08176325f, 0.16145219f, 
    0.35788921f, -0.04884373f, 0.17826991f, -0.10666898f, -0.16114761f, 0.08864225f, -0.06507510f, -0.13243385f, 
    0.06527241f, 0.33743337f, 0.15277226f, 0.15548047f, 0.03531502f, 0.04552026f, 0.05667372f, -0.31815526f, 
    0.09710568f, -0.29025295f, -0.15653105f, 0.01091762f, 0.14653628f, 0.11997141f, -0.15621741f, 0.01271849f, 
    -0.36483824f, -0.60847384f, -0.06150590f, 0.01738516f, -0.10633171f, -0.20593141f, -0.00621230f, 0.29010418f, 
    -0.06815076f, 0.13292816f, 0.06154256f, 0.20909449f, 0.03477945f, 0.00350275f, 0.00636566f, -0.18059175f, 
    0.19145571f, -0.19832838f, 0.10050909f, -0.06907263f, -0.04527608f, -0.20606741f, 0.18594708f, -0.12476936f, 
    0.34227875f, 0.28715634f, 0.11111684f, 0.04155059f, 0.02850818f, 0.02878281f, -0.15149358f, 0.06716628f, 
    -0.04445852f, 0.15390939f, 0.03074232f, 0.01366577f, -0.02272924f, 0.23373307f, -0.01834871f, 0.09489774f, 
    0.03069300f, -0.10044467f, -0.09127707f, -0.07254655f, -0.27877963f, 0.03730540f, 0.03537504f, -0.06582424f, 
    0.06763539f, -0.09525894f, 0.10348350f, 0.02407981f, -0.13869455f, -0.18262841f, 0.32835543f, -0.02812414f, 
    0.38643971f, 0.01462834f, 0.25617167f, -0.17339355f, 0.11494325f, -0.06479982f, -0.04702462f, 0.09528837f, 
    -0.21149668f, -0.18574817f, -0.27793458f, -0.06900825f, -0.31060326f, -0.16576043f, 0.04251653f, 0.14120051f, 
    0.06150979f, -0.08631772f, -0.27296847f, 0.00483068f, -0.01288599f, -0.20118092f, -0.01116288f, 0.16868740f, 
    0.13491848f, -0.14710616f, 0.04065981f, -0.00279252f, -0.03809221f, -0.20421197f, -0.05998452f, -0.02333897f, 
    0.50632375f, 0.06451319f, 0.18679594f, 0.03781716f, 0.06642831f, 0.23191619f, 0.09182195f, 0.01067244f, 
    0.06558799f, 0.15564759f, -0.00963895f, -0.06035795f, -0.38797081f, 0.04703863f, -0.04854582f, 0.01100714f, 
    0.26878554f, 0.00506231f, -0.18355900f, 0.00728934f, -0.06104708f, -0.09770439f, -0.06590769f, -0.39560473f, 
    -0.08481535f, 0.26069742f, 0.12520403f, 0.00322909f, -0.05057421f, 0.31296706f, 0.12843007f, -0.03958914f, 
    0.16933194f, 0.14915374f, -0.08067289f, -0.09236462f, 0.15635544f, 0.09726293f, 0.18894042f, -0.04118963f, 
    -0.07730819f, -0.30635229f, 0.01546163f, 0.23415637f, -0.32814339f, 0.17034715f, 0.18022621f, 0.15931317f, 
    -0.12264603f, 0.04094279f, 0.36730027f, -0.17462642f, 0.18681449f, -0.05586098f, -0.03707466f, -0.05157043f, 
    -0.18131214f, 0.04526629f, 0.12805967f, -0.14805901f, 0.11993162f, 0.17047133f, 0.22538580f, -0.03844938f, 
    -0.00148291f, 0.00186545f, -0.00165138f, 0.04255344f, -0.15721545f, -0.93580824f, -0.74727392f, -0.05687089f, 
    0.02829339f, 0.06098964f, -0.09913286f, -0.00800292f, -0.04817529f, -0.10104164f, -0.05762468f, -0.76829469f, 
    0.18436086f, -0.16909158f, 0.26333076f, -0.07065895f, -0.31982943f, 0.19883156f, 0.03552507f, 0.11288005f, 
    -0.01776827f, -0.50091988f, 0.03472778f, 0.32940778f, 0.01507216f, 0.16892500f, 0.24713945f, 0.07034144f, 
    -0.47964621f, -0.36626697f, -0.22337164f, 0.45966518f, -0.17055783f, 0.09885125f, 0.06263348f, 0.27834743f, 
    0.11142354f, 0.35858011f, -0.05727314f, 0.05686800f, 0.23035456f, -0.16992337f, -0.03475339f, -0.11821226f, 
    0.10093024f, -0.19958624f, -0.32701132f, 0.05443576f, 0.15155120f, 0.40435252f, 0.24328028f, 0.03800825f, 
    0.02864344f, 0.07208792f, -0.13342710f, -0.06415645f, 0.12645517f, 0.41616079f, -0.02459509f, -0.08380066f, 
    -0.02195969f, -0.10504799f, -0.10290665f, 0.01779894f, 0.23078495f, 0.07169263f, 0.01995021f, -0.00339707f, 
    0.15564744f, -0.16510034f, 0.20379239f, -0.00961241f, -0.00246647f, 0.05596605f, 0.10767965f, 0.14786080f, 
    -0.05568443f, 0.19462113f, -0.21505190f, -0.05011856f, 0.17779420f, 0.12017757f, -0.09567404f, -0.13595206f, 
    -0.07486880f, 0.22324224f, -0.36370268f, -0.11606351f, 0.25868183f, -0.07580210f, 0.01912533f, -0.25659224f, 
    -0.22880451f, -0.01724896f, 0.05392944f, -0.08055557f, 0.26587924f, -0.06064092f, 0.03466535f, -0.11531225f, 
    -0.10493919f, 0.15637106f, 0.11238317f, -0.17114460f, 0.28272456f, -0.12954901f, 0.16226731f, -0.00601221f, 
    -0.11385185f, 0.04788670f, -0.13323125f, 0.01177205f, -0.13141008f, -0.02843615f, -0.00191115f, 0.25430462f, 
    0.06935122f, 0.22836521f, 0.06247211f, 0.02871630f, 0.15688251f, -0.04126348f, 0.06954456f, 0.01558596f, 
    0.24105044f, 0.02117509f, 0.05055366f, -0.08314010f, 0.02351427f, -0.03222480f, 0.19965291f, 0.00287868f, 
    -0.12152871f, 0.40605003f, -0.17573558f, -0.08314157f, -0.13842878f, -0.21176989f, 0.16391115f, -0.25408059f, 
    0.33267745f, -0.01323148f, -0.15720139f, -0.09514653f, 0.03629852f, 0.21175651f, -0.04660774f, 0.05642746f, 
    -0.03045267f, -0.13954988f, 0.29227135f, 0.13897611f, 0.12217092f, 0.26269630f, -0.31407803f, 0.17891873f, 
    -0.30023691f, -0.10331847f, -0.35211304f, -0.02285070f, -0.10992523f, 0.29690650f, -0.11793999f, -0.00050475f, 
    0.16108353f, -0.00404267f, 0.23887682f, 0.22344957f, 0.00872602f, 0.00795116f, -0.01358645f, 0.21825613f, 
    -0.03889553f, 0.01331137f, 0.34805316f, -0.16573650f, 0.40678760f, -0.14499217f, -0.00833859f, 0.06730139f, 
    -0.05628780f, 0.15031326f, 0.00359674f, -0.06337485f, -0.00379536f, -0.04480190f, 0.37214065f, 0.12306747f, 
    0.21709815f, -0.00949947f, 0.04346389f, -0.02532361f, -0.08488910f, -0.09001880f, -0.24034879f, -0.03935273f, 
    0.14537060f, 0.16290094f, -0.36666277f, 0.01025866f, 0.21864420f, 0.05527110f, 0.00707810f, -0.13545600f, 
    0.04264119f, 0.15040176f, 0.15569387f, 0.13841921f, -0.14088374f, 0.01157729f, 0.03498492f, 0.05754351f, 
    0.03986392f, -0.18804184f, 0.19665754f, 0.14132757f, 0.16846205f, 0.34280899f, -0.03241574f, -0.15591921f, 
    -0.33236161f, 0.42306080f, 0.12863833f, 0.39979413f, 0.13398753f, -0.10511950f, 0.36820304f, -0.02722776f, 
    -0.04140715f, 0.16300280f, 0.17636919f, 0.29174766f, 0.32126051f, -0.02898534f, 0.40595931f, 0.06780045f, 
    -0.07491504f, -0.01450051f, -0.21658157f, 0.05072235f, -0.19291146f, 0.46696052f, -0.00765235f, 0.18550359f, 
    -0.01548402f, -0.06212374f, 0.08718219f, -0.01825384f, 0.29372519f, 0.50352705f, -0.05093689f, -0.07702614f, 
    -0.20142086f, -0.15182719f, 0.16719869f, -0.11844276f, 0.18665308f, 0.05692542f, 0.03041026f, -0.08979956f, 
    0.13291195f, -0.22736767f, 0.34152180f, 0.01373481f, -0.00289690f, -0.10949122f, 0.22074085f, 0.07974132f, 
    0.08868302f, 0.09387965f, 0.21453467f, 0.00209123f, 0.26715291f, 0.07452142f, -0.02070022f, 0.16661845f, 
    0.05255752f, 0.02894673f, -0.29612538f, -0.01252449f, 0.14977039f, -0.34479001f, 0.10538102f, 0.05737814f, 
    -0.10100356f, -0.11476507f, 0.07267169f, 0.12419530f, 0.02399602f, 0.27062234f, -0.22460005f, -0.03242576f, 
    0.19728340f, 0.25116503f, 0.11511626f, -0.32427537f, -0.00828898f, 0.01442534f, -0.28282216f, -0.04075894f, 
    0.06616813f, 0.29927692f, 0.41208813f, 0.25817665f, -0.06594172f, 0.22115795f, 0.24857980f, -0.17978351f, 
    0.15102884f, 0.08717844f, -0.14903657f, 0.04810180f, -0.21520235f, -0.05650854f, 0.07196352f, -0.01660265f, 
    -0.24343073f, 0.33067864f, -0.00461458f, -0.00097753f, 0.22421102f, 0.07551105f, -0.07831726f, 0.09961605f, 
    0.06749645f, 0.14601047f, 0.14686456f, 0.15468472f, 0.17814276f, 0.08031234f, -0.15524793f, 0.16413362f, 
    -0.02551983f, -0.01846021f, -0.28949651f, 0.08408356f, 0.00714512f, -0.02248244f, -0.06826154f, 0.28606689f, 
    0.04590949f, 0.14944817f, -0.06583739f, 0.02323818f, 0.08055650f, 0.04869105f, 0.14797668f, -0.06182870f, 
    0.25935465f, 0.11075008f, 0.20985924f, -0.03474222f, 0.12773170f, -0.06599410f, 0.01989502f, -0.00798372f, 
    0.32046562f, 0.35938498f, -0.24988778f, -0.00416665f, 0.22308137f, 0.05428189f, -0.06773929f, 0.02129209f, 
    -0.10403346f, 0.13603887f, 0.24584609f, 0.07427534f, 0.23636532f, -0.04378799f, 0.12166407f, 0.03810237f, 
    -0.09608034f, 0.11154734f, -0.15503642f, -0.01213133f, -0.14649391f, -0.17023499f, 0.32432342f, -0.09965307f, 
    0.45482039f, 0.21776532f, 0.19772473f, -0.09311276f, 0.26676819f, 0.09168323f, -0.17142996f, -0.02132227f, 
    0.03418279f, 0.24601571f, -0.27895442f, -0.08111825f, 0.10482506f, -0.08935835f, -0.25295246f, 0.09795293f, 
    0.01296346f, 0.09918361f, -0.16166964f, -0.02252033f, 0.02773749f, 0.08502210f, -0.02078455f, -0.24530010f, 
    -0.07298447f, -0.01207242f, 0.25087926f, 0.08604567f, 0.19685033f, 0.06350970f, 0.25831366f, -0.13484442f, 
    0.19391090f, 0.01375878f, 0.01571857f, -0.10487358f, 0.25708887f, -0.04553833f, 0.16822435f, -0.01806700f, 
    -0.28842667f, 0.03635923f, -0.15865496f, 0.25676945f, -0.11189948f, 0.04783214f, -0.11183994f, 0.23958951f, 
    0.05276486f, 0.22802202f, 0.43406689f, 0.22307289f, -0.28128517f, -0.00346683f, 0.12735645f, 0.04961446f, 
    0.09250263f, 0.08513050f, 0.07940103f, 0.00352677f, -0.00924591f, -0.04477230f, -0.18173113f, 0.05681962f, 
    -0.31383371f, 0.13191764f, -0.21913505f, 0.03078019f, 0.03764881f, -0.25266391f, -0.17137998f, 0.08937506f, 
    -0.11434994f, 0.02760560f, 0.61403984f, 0.13935415f, 0.03646309f, 0.15939175f, -0.02198167f, 0.35227400f, 
    0.02779721f, -0.19892551f, -0.06373000f, -0.09785408f, -0.30652475f, 0.02861612f, -0.06480389f, 0.33873054f, 
    0.06999287f, -0.02839240f, -0.02203391f, -0.08060601f, 0.11758810f, -0.03650840f, 0.13912383f, -0.07980207f, 
    0.31286913f, -0.16240887f, 0.28231356f, 0.03540638f, 0.14996165f, 0.10630605f, -0.02698937f, 0.12087458f, 
    0.34256640f, 0.03271976f, -0.53516734f, 0.19076616f, 0.23584478f, -0.26579869f, 0.08487795f, 0.00247537f, 
    0.09633109f, -0.11879473f, 0.11122845f, -0.14986293f, -0.08226817f, -0.03918499f, 0.03956400f, -0.05038049f, 
    -0.15783560f, 0.11144556f, -0.12583414f, -0.12824845f, -0.07528068f, 0.01922623f, 0.09941763f, 0.00889945f, 
    -0.06335600f, -0.11153734f, -0.11917810f, 0.08643135f, -0.03189751f, -0.09665942f, 0.03319699f, -0.10525426f, 
    0.04291785f, -0.01710297f, 0.06073843f, -0.09713908f, -0.01170103f, 0.11753862f, -0.14591432f, 0.07305207f, 
    -0.14201359f, -0.12133900f, -0.06360804f, 0.00609105f, -0.06735697f, -0.08997071f, -0.09744696f, -0.13546510f, 
    -0.07075389f, -0.00411404f, -0.03524014f, 0.09074417f, 0.02411749f, -0.15431333f, 0.01211129f, -0.17844050f, 
    0.05717297f, -0.02710446f, -0.01613920f, -0.15408793f, -0.01351655f, 0.05962878f, 0.08452068f, -0.08673722f, 
    -0.02382396f, 0.04241338f, 0.08627596f, -0.02263744f, -0.07575969f, -0.01752200f, 0.01621640f, -0.04243174f, 
    -0.09257765f, 0.08618847f, -0.00854789f, 0.03728807f, 0.05452261f, 0.04954843f, -0.03944623f, 0.06307310f, 
    -0.07824081f, -0.08815581f, 0.02138924f, 0.11686477f, -0.05922826f, -0.10113617f, -0.08080555f, -0.09658465f, 
    0.01072149f, -0.10713456f, -0.10237692f, 0.10629565f, 0.07580558f, 0.08106828f, 0.00671227f, -0.08382128f, 
    -0.03431770f, -0.01572884f, -0.09604824f, 0.05227658f, 0.04874572f, 0.02548660f, -0.11353537f, -0.07911231f, 
    -0.14965782f, -0.11875889f, -0.03527710f, -0.09005535f, 0.04156054f, -0.04520372f, -0.11959651f, -0.05734386f, 
    -0.03804798f, -0.03041057f, -0.05432858f, -0.10340295f, 0.02461984f, 0.02926675f, 0.05784738f, 0.01717415f, 
    -0.10848842f, -0.03869599f, 0.09136911f, -0.10043508f, -0.06097901f, -0.07732753f, 0.10487990f, 0.06891592f, 
    0.09707703f, -0.05557721f, 0.04013544f, 0.06186357f, -0.10255173f, -0.08367306f, -0.09871688f, -0.04395746f, 
    0.09826680f, -0.06984995f, 0.01392308f, -0.02349186f, -0.06672723f, -0.04095084f, 0.01983367f, 0.05977464f, 
    -0.11360944f, 0.03877477f, 0.00640056f, 0.11795419f, -0.04016535f, -0.09156496f, 0.03847925f, -0.02441223f, 
    0.09970205f, -0.10483901f, -0.13623025f, 0.07334185f, 0.00259356f, 0.03725592f, 0.09170721f, 0.00231659f, 
    0.06079442f, 0.10192771f, 0.07896844f, 0.07773390f, -0.01780557f, -0.09087052f, -0.12157524f, 0.02104162f, 
    0.00056547f, -0.10188965f, -0.05263770f, -0.03875680f, 0.07970638f, -0.07952680f, 0.01881114f, -0.04073103f, 
    -0.03895834f, -0.10172943f, 0.09801997f, 0.02807029f, -0.13440704f, 0.06147075f, 0.07510351f, -0.01194930f, 
    -0.11368111f, -0.13370717f, 0.02960970f, 0.04904574f, 0.06670008f, 0.11997606f, -0.09953097f, -0.06558049f, 
    0.08651905f, 0.04135396f, -0.09976590f, -0.02771133f, 0.06294372f, -0.06679345f, -0.13979128f, 0.00421418f, 
    0.00947972f, 0.32187742f, 0.35686296f, -0.21596168f, -0.07724034f, 0.00106944f, 0.17018265f, -0.19168484f, 
    0.20870230f, 0.07742870f, -0.04037676f, 0.15003744f, -0.06452353f, -0.11973137f, 0.04333156f, 0.04675399f, 
    -0.04920772f, 0.13450056f, -0.04236211f, -0.05247591f, 0.05611094f, -0.19084504f, -0.15802768f, -0.08057591f, 
    0.04768034f, 0.45538592f, -0.19396874f, -0.01651769f, 0.17836194f, 0.03667116f, -0.14942801f, 0.10299525f, 
    0.08057968f, 0.13610931f, 0.12963621f, -0.07767384f, -0.18814468f, -0.01163292f, 0.08417104f, 0.44270197f, 
    -0.10904256f, 0.05889731f, 0.26618665f, 0.07875014f, 0.14726999f, 0.04591956f, 0.06546696f, -0.06218450f, 
    0.44399241f, -0.17100856f, 0.03531111f, 0.18899383f, 0.06624805f, 0.03498266f, 0.09141469f, -0.02753565f, 
    -0.33740756f, 0.16345951f, -0.42028078f, 0.17983794f, 0.19663469f, -0.03677368f, -0.19095889f, 0.02379613f, 
    0.00846589f, -0.09295428f, 0.04367593f, 0.10893515f, -0.13692966f, -0.01611116f, 0.02550088f, 0.05697993f, 
    -0.02541279f, -0.05062258f, -0.01447250f, 0.11131566f, -0.12851351f, -0.10924761f, -0.12659879f, 0.00171557f, 
    -0.08569222f, 0.03938382f, -0.03597711f, -0.01627545f, -0.09089082f, 0.00470304f, 0.03898532f, 0.03069489f, 
    -0.09036958f, 0.02014622f, -0.02723562f, 0.12727810f, -0.07193432f, 0.09743965f, 0.03954685f, -0.03136214f, 
    0.04882349f, 0.04640869f, -0.06570608f, -0.11415045f, -0.15998217f, 0.01672414f, -0.07113858f, -0.12782785f, 
    0.09526688f, 0.07691099f, -0.05190728f, -0.02693740f, -0.06901574f, 0.05686190f, -0.05437091f, -0.13300709f, 
    0.07252102f, 0.01914720f, -0.05282767f, 0.07670482f, 0.06372120f, -0.09247531f, 0.01114981f, -0.02002985f, 
    -0.09604578f, 0.04553157f, -0.02794638f, -0.09407935f, -0.10442840f, -0.09618893f, 0.04253996f, -0.03547428f, 
    0.06713052f, -0.03415801f, -0.01034673f, -0.09351534f, -0.10514465f, -0.12395392f, -0.05661178f, -0.01965286f, 
    -0.08583944f, 0.09823304f, -0.05671582f, 0.04637666f, -0.05110078f, 0.07260132f, 0.06529202f, -0.03417541f, 
    -0.08071010f, -0.03891765f, 0.05746505f, -0.01362005f, -0.00738259f, -0.10082693f, -0.08414505f, -0.00291951f, 
    0.06618068f, -0.05855666f, -0.09760080f, -0.03366503f, 0.01916681f, 0.05122918f, -0.09157360f, 0.07267468f, 
    -0.09918948f, -0.11083385f, -0.08436853f, -0.07945731f, 0.06640689f, 0.01623951f, -0.05153996f, -0.01351371f, 
    -0.01789714f, 0.10535495f, 0.06556198f, 0.05622715f, 0.06959194f, 0.06454213f, -0.04264255f, -0.02380714f, 
    -0.03032503f, -0.10450706f, 0.11669010f, -0.04475911f, -0.09752734f, 0.08143000f, -0.08258913f, 0.00044686f, 
    0.08688018f, -0.09934652f, 0.00756906f, -0.07286897f, 0.05114074f, -0.11115128f, -0.07089369f, 0.06023440f, 
    -0.04955985f, -0.13330294f, -0.03817827f, 0.10652830f, -0.11786231f, -0.01695299f, -0.08806136f, -0.00595938f, 
    -0.05622182f, -0.13096672f, 0.00484509f, 0.10558823f, 0.01444609f, 0.11656225f, -0.05425255f, -0.03476562f, 
    0.02790710f, -0.07775576f, 0.06043852f, 0.10082234f, -0.07887144f, -0.10637958f, -0.04674339f, 0.06977118f, 
    0.05771442f, -0.06302911f, -0.01686446f, -0.01436661f, -0.12393101f, 0.00750470f, 0.03228144f, 0.09165758f, 
    -0.08655547f, -0.02129582f, -0.03288217f, 0.01126944f, -0.11794264f, 0.01547370f, -0.07227315f, -0.04912537f, 
    0.02320567f, 0.02464153f, -0.09955011f, -0.07956697f, -0.03622979f, -0.03694781f, -0.02852245f, 0.06047016f, 
    0.02911485f, -0.02185576f, -0.01285072f, 0.06272556f, 0.02164224f, -0.00477287f, -0.05754948f, -0.02977759f, 
    -0.00869338f, -0.08430052f, -0.07156365f, -0.05985609f, -0.05069394f, -0.07723551f, 0.07373416f, -0.07604744f, 
    0.12177162f, 0.14345689f, 0.26326746f, 0.17269503f, -0.13053253f, -0.06054252f, 0.04980639f, -0.01745811f, 
    0.28260213f, -0.26187345f, 0.20427969f, 0.02537104f, -0.07518342f, -0.05954260f, -0.00303871f, 0.02289961f, 
    0.26997435f, 0.24505515f, -0.10655100f, 0.02154038f, -0.11762907f, 0.03892168f, -0.02776894f, 0.01326964f, 
    -0.12400363f, 0.19398099f, 0.13548563f, -0.00594171f, 0.18031403f, 0.29701290f, 0.08421600f, -0.14284122f, 
    -0.00496416f, -0.15694489f, 0.00009943f, -0.16441827f, -0.48451281f, -0.04630021f, -0.01211994f, 0.08094435f, 
    -0.03946204f, 0.03699185f, 0.08723975f, 0.01933012f, -0.18904141f, -0.11346196f, 0.22648786f, -0.26038215f, 
    0.38668653f, -0.07073082f, 0.33725345f, 0.03797320f, -0.06736156f, -0.04619573f, -0.29622534f, 0.17305396f, 
    -0.12851116f, -0.34234464f, -0.21585663f, 0.12650752f, -0.10123736f, -0.42106435f, -0.17183255f, 0.26881373f, 
    0.04383992f, 0.15332985f, 0.09048431f, -0.11690874f, 0.01298196f, -0.02571427f, -0.04839437f, 0.22562489f, 
    0.02078626f, 0.20305167f, 0.17315301f, -0.02108070f, 0.04581822f, -0.13044409f, 0.04007449f, -0.08940731f, 
    0.21343945f, 0.02555512f, 0.08177399f, 0.09106552f, 0.03501829f, -0.02122384f, -0.02597341f, -0.10311137f, 
    0.06349418f, 0.41618788f, -0.08246588f, 0.02477747f, -0.18607074f, -0.18435213f, 0.10774610f, -0.15037839f, 
    0.15768103f, -0.12549435f, -0.02886800f, -0.09381135f, -0.11973721f, 0.07105482f, 0.11157630f, -0.04473066f, 
    0.01129495f, 0.09445700f, 0.34250733f, 0.20339915f, 0.24643502f, 0.32415777f, -0.15795185f, 0.03909092f, 
    -0.29921773f, -0.17180049f, -0.29503107f, -0.05892757f, 0.05780529f, 0.17861800f, -0.01072147f, 0.13468030f, 
    -0.11665350f, -0.19399925f, 0.14045152f, 0.36950517f, -0.09441558f, -0.08385454f, 0.12566158f, 0.05499958f, 
    -0.11238919f, 0.27403736f, 0.36281541f, 0.36974129f, -0.17651881f, -0.08115299f, 0.10188129f, -0.15561493f, 
    0.34796789f, -0.12306906f, 0.00611918f, -0.05428118f, -0.12967031f, -0.08764865f, -0.04257919f, 0.05486211f, 
    -0.17527173f, 0.19927645f, 0.08729634f, 0.00414087f, 0.11078794f, -0.14854695f, -0.07354254f, -0.07409654f, 
    -0.17640117f, 0.19500825f, 0.35597724f, 0.08441458f, 0.12735397f, 0.18185896f, 0.06131535f, -0.05536715f, 
    -0.14389925f, -0.03846079f, 0.18736649f, 0.02868201f, -0.25188947f, 0.10953705f, 0.24469948f, 0.29298535f, 
    0.00647794f, 0.11886311f, 0.21815999f, 0.14663395f, -0.03341909f, -0.07007679f, 0.08649677f, -0.06090159f, 
    0.46441904f, -0.14164089f, 0.14599676f, 0.10062597f, 0.17280217f, 0.14250539f, 0.03460074f, 0.02490598f, 
    0.10768460f, -0.13452809f, -0.50059867f, 0.12865835f, -0.00418648f, -0.09685221f, 0.04488688f, 0.11974494f, 
    0.05507189f, 0.02046054f, -0.07695789f, -0.13736308f, -0.11903222f, -0.00976528f, 0.00305930f, -0.00938270f, 
    -0.11651312f, -0.05068503f, -0.12898166f, -0.04257142f, 0.05724799f, -0.11104222f, 0.09594782f, -0.04543188f, 
    0.08603368f, -0.00660126f, -0.07939343f, -0.03942052f, -0.05555369f, -0.11240450f, -0.04343576f, -0.00437880f, 
    -0.13319087f, -0.10809608f, -0.03390007f, -0.08398618f, -0.12288515f, -0.18157183f, -0.03094425f, -0.02821750f, 
    -0.10796129f, 0.00147738f, 0.07645842f, -0.00936530f, -0.04872691f, -0.04270806f, 0.01950453f, -0.01836955f, 
    -0.07572288f, -0.03047253f, -0.01459281f, 0.08710424f, -0.09295160f, -0.08019666f, -0.11699316f, 0.02864850f, 
    0.05330170f, 0.00935719f, 0.03824985f, -0.05244907f, -0.01235572f, -0.17469653f, 0.01644917f, -0.04118504f, 
    -0.10726897f, 0.11660182f, -0.06575431f, -0.00560715f, -0.12098178f, 0.01566799f, -0.01561823f, 0.01426651f, 
    0.00339353f, -0.03657205f, 0.12130538f, -0.32363024f, -0.11329958f, -0.17815442f, -0.19064686f, 0.23799738f, 
    0.12977159f, 0.33147943f, 0.23909062f, -0.05829069f, 0.11380708f, -0.07870004f, 0.18804157f, 0.05578950f, 
    -0.04082730f, 0.07546373f, -0.09801555f, -0.06553513f, 0.03324113f, -0.17334683f, -0.02177487f, -0.08199296f, 
    0.04664684f, -0.05499389f, 0.08555637f, 0.01173756f, -0.11648086f, -0.19515109f, 0.18452439f, -0.26995403f, 
    0.10290138f, -0.16142675f, 0.06093754f, -0.11617317f, -0.03695836f, 0.04036120f, 0.02056695f, -0.09689197f, 
    0.06145083f, -0.24460478f, 0.01415961f, 0.16092475f, 0.19598559f, 0.31725788f, -0.37167755f, 0.39005387f, 
    -0.18083645f, 0.03157257f, -0.25441563f, 0.09221631f, -0.08878683f, 0.05251573f, -0.03361523f, 0.11765002f, 
    0.31799898f, 0.22091979f, 0.20764816f, 0.20883940f, -0.02949986f, -0.13094911f, 0.32377103f, -0.12805746f, 
    -0.02351305f, 0.15484682f, 0.19997859f, -0.19780217f, 0.01144425f, -0.14061564f, -0.02308596f, -0.18260282f, 
    0.15852803f, -0.20851149f, -0.32706034f, 0.03244073f, -0.28360486f, -0.54581499f, 0.31124204f, 0.01804815f, 
    0.11910459f, 0.08796445f, 0.28919172f, -0.07867296f, 0.12897341f, -0.00677314f, -0.11534657f, 0.04183479f, 
    -0.05983978f, 0.45497358f, -0.17060432f, -0.08362466f, -0.16019124f, -0.14354958f, -0.24228828f, 0.08810006f, 
    -0.11888868f, -0.06053549f, -0.23264261f, 0.13337649f, 0.10707808f, -0.08988521f, 0.25391090f, 0.02649192f, 
    -0.07518059f, -0.02708166f, 0.24192549f, -0.16082476f, 0.02943499f, -0.03227491f, 0.13588472f, 0.19816214f, 
    0.19418253f, -0.20537814f, -0.11703971f, -0.00642685f, 0.14620340f, -0.13597624f, -0.37140197f, -0.08857615f, 
    0.05883540f, 0.31050545f, -0.15713848f, 0.31454030f, 0.02625374f, 0.19596936f, -0.15474766f, -0.21794251f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.10018570f, -0.11736777f, 0.22549047f, 0.09654900f, -0.07947099f, -0.13660336f, -0.12000255f, 0.14965476f, 
    0.21583931f, 0.00400287f, 0.08152098f, 0.17684551f, 0.03323735f, -0.05850833f, 0.10253807f, -0.08757941f, 
    -0.09486131f, 0.06617638f, -0.12096894f, -0.03322935f, 0.18648648f, 0.15197256f, -0.09110999f, 0.12272296f, 
    0.13043478f, 0.02586049f, 0.18568066f, 0.04857776f, 0.00254348f, -0.03304381f, -0.08504075f, 0.03464000f, 
    -0.14343919f, 0.01033962f, -0.13388394f, 0.13387074f, 0.15562485f, -0.02937927f, -0.01820623f, -0.03353592f, 
    -0.00088370f, 0.07997727f, 0.03921697f, 0.25277412f, 0.12369976f, -0.00372796f, 0.14925240f, 0.10333704f, 
    -0.24667123f, 0.24462758f, -0.15082110f, 0.03033083f, -0.13451630f, -0.04355282f, 0.03229623f, 0.06231132f, 
    -0.02619947f, -0.04022926f, 0.03693969f, 0.18771751f, -0.00694223f, -0.16689181f, 0.09911364f, 0.42406607f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.19579591f, -0.01474871f, -0.48332718f, -0.30338299f, -0.14259388f, 0.13785198f, -0.00118423f, -0.49033159f, 
    0.09169941f, -0.15370665f, -0.03048845f, -0.11724619f, 0.02522950f, -0.16777118f, -0.15399058f, 0.18645160f, 
    -0.02355495f, 0.07558431f, -0.03406476f, -0.38275564f, -0.00826262f, -0.35315707f, 0.03854816f, 0.10502461f, 
    -0.47674721f, -0.03569390f, -0.62524551f, -0.08267298f, -0.07537705f, -0.05566856f, 0.04891097f, 0.10258371f, 
    0.32166302f, 0.03321570f, 0.23083737f, 0.10232677f, -0.25137338f, 0.18877202f, -0.00717682f, 0.06036649f, 
    0.07177842f, 0.04755168f, -0.01666967f, -0.33328030f, -0.14084022f, 0.12134765f, -0.68785179f, 0.07559478f, 
    -0.01248145f, -0.31595233f, 0.16534144f, 0.04575898f, -0.03924069f, 0.07775157f, -0.15611146f, 0.04575480f, 
    0.09736803f, -0.07562553f, 0.01784226f, -0.11391294f, 0.09225492f, -0.12128561f, 0.01779917f, -1.10541546f, 
    0.26629299f, -0.06648891f, -0.48149884f, -0.40177560f, -0.07090155f, -0.01102437f, -0.08270285f, -0.20596108f, 
    0.05092293f, 0.06760377f, 0.11640954f, -0.00454380f, -0.09611481f, -0.28757334f, 0.00348612f, -0.01137835f, 
    0.00526262f, 0.01396464f, -0.07134937f, 0.03566888f, -0.40242732f, 0.29904246f, -0.82368392f, 0.33069941f, 
    -0.11074162f, 0.00711895f, -0.18299583f, 0.29932547f, 0.03437753f, 0.00695224f, 0.01243835f, 0.12247630f, 
    -0.54678553f, -0.09429190f, 0.17236799f, 0.11198009f, -0.00743036f, 0.08334903f, -0.18553101f, -0.09620808f, 
    0.20519274f, 0.21014763f, 0.12889782f, -0.20390953f, -0.12484165f, -0.01920104f, -0.18386541f, -0.00773440f, 
    0.01460761f, 0.18331422f, -0.04799719f, -0.03504379f, -0.12122896f, 0.08523519f, 0.06698006f, 0.11253225f, 
    0.07803646f, 0.06809485f, 0.21280305f, 0.05330367f, 0.14473753f, -0.03956242f, -0.26785865f, 0.24498563f, 
    -0.28658423f, -0.13754074f, 0.32836634f, 0.02882141f, -0.08100209f, -0.15896870f, 0.08324620f, 0.11567320f, 
    -0.13347799f, -0.13828769f, 0.19358198f, -0.14606422f, -0.10001937f, -0.19155414f, 0.26827738f, -0.12860678f, 
    0.03524010f, 0.04510621f, 0.03172740f, 0.10495905f, 0.20562723f, -0.32360753f, -0.56455112f, -0.02078414f, 
    0.07996533f, 0.03045792f, 0.13816270f, -0.48593855f, -0.00312786f, -0.01523995f, -0.00256655f, 0.03580898f, 
    -0.24129348f, -0.07013716f, 0.03189736f, 0.08698479f, 0.02922984f, -0.58258730f, 0.02603834f, 0.11339866f, 
    -0.59828824f, -0.09552443f, -0.02283783f, 0.68742990f, -0.20403653f, -0.00311788f, 0.00757760f, 0.14353889f, 
    -0.06094772f, -0.04380484f, -0.47962978f, -0.03299825f, -0.05779372f, -0.02223171f, 0.02192432f, -0.03963036f, 
    0.05028279f, -0.13690995f, -0.41203552f, -0.08426321f, -0.38342649f, -0.03580673f, 0.14597346f, -0.14669302f, 
    -0.40410709f, 0.04630779f, -0.02316850f, 0.05440481f, -0.04027858f, 0.15742670f, -0.13246976f, -0.11413419f, 
    0.08905718f, -0.20226730f, -1.09239626f, -0.18935283f, -0.03431954f, 0.20188393f, 0.19832762f, 0.09157200f, 
    -0.01660234f, -0.12695330f, 0.02231681f, 0.13507524f, 0.08763048f, 0.01865683f, 0.08381505f, 0.05858394f, 
    -0.03754953f, -0.19660990f, -0.13683675f, -0.25237426f, -0.04897055f, 0.00761374f, 0.04784193f, -0.12747103f, 
    -0.07595441f, 0.01089261f, -0.09047744f, -0.01447517f, -0.10789678f, -0.07125819f, 0.21074171f, 0.03826175f, 
    -0.18742928f, -0.37742150f, -0.43721002f, 0.36817512f, -0.08643600f, 0.00114522f, -0.15252490f, 0.16932315f, 
    0.08310163f, -0.35908559f, 0.23948275f, 0.00734369f, -0.01083214f, -0.03770901f, -0.06180751f, 0.02502717f, 
    0.03316119f, -0.02367975f, -0.36656201f, -0.02234037f, 0.08737780f, -0.25670427f, 0.12586613f, -0.74588269f, 
    -0.01267342f, -0.04874318f, 0.00838115f, -0.00683288f, -0.10540744f, -0.15056431f, -0.05934867f, -0.32312313f, 
    0.10153960f, 0.23024699f, -0.03595027f, 0.03248413f, -0.08559176f, 0.05732830f, 0.05112622f, 0.14678155f, 
    -0.00302670f, 0.01828794f, -0.12243026f, -0.24422410f, 0.23929249f, -0.34803900f, 0.18006389f, -0.00377654f, 
    -0.20605037f, -0.13482966f, -0.37295604f, -0.12457383f, 0.09488878f, -0.11732600f, 0.01074821f, -0.10066422f, 
    0.09175525f, -0.08553851f, -0.13507709f, 0.03692772f, -0.04214039f, 0.18522997f, -0.38391772f, -0.11019787f, 
    -0.05864321f, -0.33645472f, 0.12129219f, -0.30461600f, 0.00969681f, 0.12268554f, -0.11114206f, 0.04141888f, 
    0.03915859f, -0.10169780f, -0.20806918f, -0.03316233f, 0.08113363f, -0.12517105f, -0.40939882f, -0.15775032f, 
    -0.00787875f, -0.02520481f, -0.40588298f, 0.15873781f, -0.20694372f, -0.07498886f, 0.13210447f, 0.10304413f, 
    0.04177126f, -0.01603297f, 0.14371550f, -0.56809801f, -0.15079825f, -0.18841282f, -0.07896420f, -0.04075508f, 
    0.05857607f, 0.11725494f, 0.02600756f, -0.15127333f, -0.07579315f, -0.09645882f, 0.02293323f, 0.05223712f, 
    -0.10479645f, 0.07803061f, -0.09178717f, 0.05160436f, 0.12316086f, -0.13065925f, -0.06846736f, 0.08578531f, 
    -0.10986036f, -0.04194580f, 0.21125512f, 0.24503051f, -0.01240867f, -0.03764421f, 0.03431942f, 0.03867440f, 
    -0.17713638f, -0.16018991f, 0.04908612f, -0.04256455f, 0.14927688f, -0.00729684f, -0.37424973f, 0.01246243f, 
    -0.01235286f, 0.04448507f, 0.13608512f, -0.07975416f, -0.10583532f, 0.03901506f, 0.10033076f, -0.26894996f, 
    0.04797716f, 0.15897563f, 0.02183478f, -0.03482389f, -0.06841108f, 0.02857609f, 0.00738743f, 0.01760058f, 
    -0.08982573f, -0.03277924f, 0.05613959f, 0.10829714f, -0.01195890f, -0.02190558f, 0.18305399f, -0.45447138f, 
    -0.21356522f, 0.14466503f, 0.45872474f, 0.31287289f, -0.01533793f, -0.39567223f, 0.03326996f, 0.19880563f, 
    -0.70286340f, 0.08408803f, 0.05695236f, 0.09647059f, 0.09270175f, -0.40457037f, -0.67426771f, -0.33695596f, 
    -0.06917398f, -0.02194640f, 0.00936977f, 0.02389900f, -0.08396505f, -0.11592678f, -0.41452560f, -0.40729007f, 
    0.15936348f, 0.16519910f, 0.31173339f, -0.72717804f, 0.11477161f, 0.05682772f, 0.05872378f, 0.01396559f, 
    -0.11381464f, -0.09943040f, -0.37546307f, -0.50802624f, 0.13418911f, -0.35101062f, -0.28951195f, -0.00851457f, 
    -0.46645519f, -0.14117339f, -0.19924925f, -0.49726290f, 0.11096330f, -0.78019565f, 0.15268312f, 0.05887001f, 
    0.02625746f, 0.12420384f, -0.53914934f, 0.10436974f, 0.02007001f, -0.13213691f, -0.25236610f, -0.11417748f, 
    -0.07350412f, -0.07410945f, -0.13993336f, -0.78675228f, -0.74612981f, 0.07927581f, -0.39874750f, -0.28794661f, 
    0.06366406f, 0.07299850f, -0.37105703f, 0.08573905f, -0.00879212f, 0.51190931f, 0.08845115f, 0.03444756f, 
    -0.17895429f, -0.13333099f, -0.03073138f, 0.23194276f, -0.10838553f, -0.14042231f, -0.19625160f, -0.56984365f, 
    -0.07448495f, 0.06181638f, 0.00641353f, -0.32215282f, -0.09358349f, -0.11821778f, 0.48506415f, -0.02035481f, 
    -0.19043396f, 0.04194399f, -0.26825538f, -0.33724314f, -0.10805762f, 0.06122427f, 0.09254961f, 0.06846226f, 
    -0.12319253f, -0.05556583f, 0.04619442f, -0.51643151f, -0.31913355f, -0.47739494f, -0.12955415f, -0.01328678f, 
    0.41201559f, -0.10401180f, -0.05688369f, -0.21659827f, 0.22267926f, -0.37014470f, -0.25657791f, 0.18072961f, 
    0.18208525f, -0.08561074f, 0.26790631f, -0.06207997f, -0.06503593f, -0.10227881f, 0.14382982f, -0.02024619f, 
    0.07448231f, -0.10994788f, 0.07682964f, -0.42299855f, -0.21400414f, -0.11527079f, -0.52765840f, -0.21399616f, 
    -0.25882375f, -0.02110428f, -0.50211793f, -0.28137764f, -0.03427491f, -0.03580631f, -0.02269159f, -0.07091647f, 
    -0.41057557f, 0.00365692f, -0.18106245f, -0.18187992f, -0.03375968f, 0.23703167f, 0.02077442f, -0.11252311f, 
    -0.06261385f, 0.03987549f, 0.00325179f, 0.04806554f, -0.54653698f, -0.03502965f, -0.23815557f, -0.32970700f, 
    0.15848725f, 0.08852994f, 0.12810563f, 0.13126031f, -0.12425224f, -0.08075239f, -0.03837105f, 0.08750629f, 
    -0.14683530f, 0.10931528f, 0.20526133f, -0.24533139f, 0.27022249f, -0.49589214f, 0.38142276f, -0.07489231f, 
    0.04940674f, 0.17567615f, -0.03116663f, -0.00186409f, -0.24334690f, -0.35194537f, 0.07071217f, -0.43307269f, 
    0.02762047f, -0.05676783f, 0.32053471f, -0.14313151f, -0.12928487f, -0.05763333f, 0.08635364f, 0.07460187f, 
    -0.09694354f, -0.12166302f, 0.40884575f, -0.13611013f, 0.34950778f, 0.02922554f, 0.02392356f, -0.20870793f, 
    0.05708075f, -0.11947656f, 0.12509802f, 0.29593998f, 0.00515241f, 0.00219571f, -0.12113661f, 0.13689370f, 
    0.07137560f, -0.18923411f, -0.20998308f, 0.30449709f, -0.04725380f, -0.15165648f, -0.36122626f, -0.19278629f, 
    -0.06615323f, -0.08847401f, -0.02983315f, 0.03578868f, 0.25983426f, -0.11778918f, 0.17572685f, -0.04408759f, 
    -0.10956259f, -0.09927107f, -0.24268453f, -0.52064681f, 0.01239255f, -0.05297069f, 0.01462670f, 0.10920126f, 
    -0.47677171f, -0.14706010f, -0.32184675f, -0.33873466f, -0.03517730f, -0.46282309f, 0.09857976f, -0.15604635f, 
    -0.30454731f, 0.09763186f, -0.20030934f, -0.35184291f, 0.22732446f, 0.02461693f, 0.00008608f, 0.20587987f, 
    -0.18900396f, -0.05744805f, -0.50853372f, -0.01891153f, -0.03039420f, -0.11716958f, -0.40604317f, -0.05859943f, 
    0.09374803f, -0.08619460f, -0.24942628f, -0.05617380f, -0.46297675f, -0.12197739f, 0.10088672f, 0.03770746f, 
    0.12081977f, 0.04139201f, -0.18913589f, -0.55779934f, 0.00536835f, -0.87080795f, -0.10052979f, -0.12179136f, 
    -0.04267237f, -0.25435033f, -0.72543478f, 0.13746800f, -0.07544996f, 0.36155614f, 0.26989707f, -0.49067059f, 
    -0.13956645f, -0.02405490f, -0.18020071f, 0.21496293f, 0.01650488f, -0.58047473f, -0.33683753f, -0.44320557f, 
    0.10314684f, 0.10245209f, -0.03874579f, 0.07975815f, 0.06775118f, -0.09876175f, -0.09310411f, -0.08970445f, 
    -0.32001865f, -0.02983377f, -0.19499525f, 0.21147312f, -0.15048240f, -0.10031986f, 0.31787533f, -0.06946211f, 
    0.34132668f, -0.11067818f, 0.16437569f, 0.18745670f, -0.35219693f, 0.13460234f, 0.03799155f, -0.32966334f, 
    -0.67175168f, -0.22036964f, -0.47821128f, -0.16178210f, -0.01557014f, -0.10113961f, -0.03593435f, 0.00599617f, 
    0.03154838f, 0.08666368f, -0.02822317f, 0.12739232f, -0.04201909f, -0.07718293f, 0.13876794f, -0.13471909f, 
    0.09790180f, 0.07170766f, 0.01650906f, 0.10551808f, 0.03819307f, -0.26838756f, -0.00872561f, 0.13572158f, 
    -0.39291072f, 0.21488182f, -0.44305012f, -0.27903792f, -0.13008896f, 0.00934750f, -0.10468347f, -0.28042516f, 
    -0.04683703f, 0.02343689f, 0.01459804f, -0.00309532f, -0.06522658f, 0.31445175f, -0.48627034f, -0.32812551f, 
    0.24976121f, -0.09572506f, -0.10141990f, -0.55839944f, -0.07812088f, -0.13575707f, -0.05701587f, 0.04860433f, 
    -0.09957360f, -0.05645195f, -0.00718645f, -0.46481019f, -0.09553438f, -0.28597933f, 0.10243573f, -0.06924371f, 
    -0.46881565f, -0.02982469f, -0.33155173f, -0.14277095f, -0.15404986f, 0.05670107f, 0.12154022f, -0.24621063f, 
    0.18939036f, 0.27398315f, -0.07517536f, -0.05062628f, -0.02929405f, -0.09039291f, 0.38200527f, 0.10116142f, 
    -0.09124026f, 0.09624957f, -0.38655904f, -0.07077527f, 0.01043322f, -0.01106619f, -0.14403351f, 0.40305710f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.15479109f, 0.17932449f, 0.14363019f, -0.18759070f, -0.04963548f, 0.04039525f, 0.03169112f, -0.12562396f, 
    -0.07606317f, 0.20392425f, 0.05033642f, -0.10776453f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
