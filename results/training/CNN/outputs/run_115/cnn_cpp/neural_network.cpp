#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.75968218f, 0.01437722f, -0.25862131f, -0.76373923f, -0.20937599f, -0.42987287f, -0.49722469f, -0.46589637f, 
    -0.12663947f, -0.59010649f, -0.05887089f, -0.20511645f, -0.75772923f, 0.15986642f, -0.59770215f, 0.62220365f, 
    0.40406525f, 0.52971095f, 0.37997434f, -0.87224305f, -0.30037126f, -0.69612563f, -0.66093791f, -0.16641602f, 
    -0.30391628f, 0.04462809f, 0.28100413f, -1.08855057f, 0.36757925f, 0.03160667f, -0.10466016f, 0.85920125f, 
    -0.23108442f, 0.04326457f, -0.19328222f, -0.59328532f, 1.04566491f, 0.69732612f, 0.23575355f, -0.46577457f, 
    0.76987433f, -0.27220187f, 0.42080066f, 0.23992479f, 0.26239222f, 0.05993578f, 0.54001510f, 0.17468707f, 
    0.32339790f, -0.13068861f, -1.50658727f, -0.20008054f, 0.03809885f, 0.07747439f, 0.78769428f, -0.11380202f, 
    0.42244950f, 0.90479833f, 0.58075708f, 0.27985623f, -0.42770025f, -0.40040955f, -0.03947531f, -0.34332800f, 
    -0.55205089f, -0.89612937f, 0.64665931f, -0.38345703f, 0.84363955f, -0.07946061f, -0.06788900f, 0.21200384f, 
    0.39197886f, -0.37108576f, -0.78185195f, 0.42047763f, 0.70522434f, -1.07078278f, 0.34550968f, -0.31700429f, 
    -0.11413676f, 0.40662500f, 0.82585377f, -0.68721658f, -0.58040357f, -0.58716947f, 0.18842922f, -0.14434728f, 
    -0.43104026f, -0.32834220f, -0.01462497f, 0.89212382f, 0.78145748f, -0.44065577f, 0.24904695f, 0.23628001f, 
    -0.51394218f, -0.51180154f, 0.27838859f, 0.96804273f, 0.50747412f, 0.86747372f, 0.45082971f, -0.15972033f, 
    0.59716284f, -0.16413020f, 0.25966188f, -0.20697686f, -0.72552645f, -0.77512407f, -0.94207746f, 0.14103964f, 
    1.14959788f, 0.99724281f, -0.20470387f, -0.14234103f, -0.04958915f, -0.85961288f, -1.32144785f, -0.99548453f, 
    -0.79272503f, -0.09940837f, -0.10759899f, 0.24555580f, 0.13728482f, 0.16841574f, -0.25425038f, 0.59182382f, 
    -0.36565962f, 0.82894093f, -0.49448061f, -0.38618204f, -0.33128724f, -0.34225798f, -0.41760170f, 0.64386070f, 
    0.53113264f, 0.53286076f, -0.74159324f, -0.83830327f, -0.40597209f, -0.28018737f, 0.56052035f, -0.14537346f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.53134060f, 0.16182302f, -0.12840362f, 0.15548095f, 0.34903926f, 0.39453158f, -0.05454317f, 0.12769137f, 
    0.09289339f, 0.28177202f, 0.21132079f, 0.24568029f, 0.22868685f, 0.51926786f, -0.26738903f, 0.22177771f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.02789978f, -0.12879023f, 0.08305738f, 0.27983996f, -0.00081047f, -0.06344273f, -0.10795468f, -0.10312653f, 
    -0.05679814f, -0.12897407f, 0.08734048f, -0.04922711f, 0.19152775f, 0.06759977f, 0.08391353f, -0.10703988f, 
    -0.00173584f, -0.05758682f, 0.32419494f, 0.11263912f, 0.02274342f, -0.30652484f, 0.03102058f, -0.24903753f, 
    0.04208403f, 0.15322125f, -0.00282328f, 0.19367607f, 0.32518989f, 0.04547240f, 0.09662050f, -0.07126039f, 
    -0.01388375f, 0.07962397f, -0.12344209f, -0.00361178f, -0.33729813f, -0.26364520f, 0.08789189f, -0.00347795f, 
    -0.03856988f, -0.13966985f, 0.07094979f, 0.16978276f, 0.02663168f, -0.40329394f, -0.09566255f, -0.27350220f, 
    -0.00250915f, -0.02702291f, 0.13765277f, -0.00629759f, 0.09337324f, -0.25492331f, -0.10256915f, -0.50626773f, 
    -0.07253620f, 0.08824512f, -0.11478557f, -0.08485807f, 0.04227171f, 0.05136271f, -0.00152271f, 0.12652427f, 
    0.04613126f, 0.26980948f, -0.06525544f, 0.10158174f, 0.08109522f, 0.25731277f, 0.00650863f, -0.02074867f, 
    -0.38721415f, 0.24867663f, 0.27797234f, -0.05622248f, -0.00418559f, 0.14313099f, 0.01796525f, -0.03727254f, 
    0.20555747f, -0.21260452f, -0.07850810f, 0.19233178f, 0.03819028f, 0.15646456f, -0.23610085f, 0.14219426f, 
    -0.17203470f, 0.09191320f, 0.29673162f, -0.05949244f, 0.16389742f, -0.08561644f, -0.17955135f, 0.21362206f, 
    0.21671583f, 0.12890275f, -0.21097803f, 0.08496177f, -0.03571409f, -0.08194595f, 0.07981953f, -0.13834323f, 
    0.02307679f, 0.26257959f, 0.15362620f, -0.01367657f, 0.48475024f, -0.28801298f, 0.27679092f, -0.05120999f, 
    0.15929058f, 0.15182315f, 0.11189529f, 0.20474577f, 0.19603088f, 0.13587153f, -0.15754807f, 0.46021509f, 
    0.18281391f, 0.05295430f, 0.06415963f, -0.04613438f, 0.21706866f, 0.09003934f, 0.31448776f, -0.00340639f, 
    0.07060988f, 0.00533260f, -0.04350782f, 0.03020218f, -0.13022745f, -0.18818109f, 0.14549424f, -0.44158164f, 
    0.14125906f, -0.06220531f, -0.01241684f, -0.11980696f, -0.25058064f, -0.17096356f, -0.03467001f, -0.10874491f, 
    -0.08702832f, 0.08627617f, -0.16207537f, 0.26801544f, 0.09826712f, 0.07768741f, -0.25695035f, 0.01650077f, 
    -0.12997532f, 0.23790757f, -0.11980267f, -0.50038528f, -0.10512991f, -0.17000096f, 0.27189434f, -0.00324480f, 
    -0.06329331f, -0.09655966f, -0.06280806f, -0.19749427f, -0.08697616f, 0.17075157f, 0.00517490f, 0.06147800f, 
    0.05273746f, -0.08533251f, 0.24411540f, 0.00075634f, -0.10763349f, -0.24376558f, 0.04899406f, 0.07761117f, 
    0.07710835f, 0.10271864f, -0.02790349f, -0.03679699f, 0.14336595f, -0.02472269f, 0.23434393f, 0.35462788f, 
    -0.14258520f, -0.05768137f, 0.00589636f, -0.11240101f, 0.07419678f, -0.16314064f, -0.22179824f, -0.06944230f, 
    0.05995313f, 0.17189485f, -0.04656352f, 0.01248701f, 0.10714328f, 0.28718567f, 0.22263943f, 0.21583927f, 
    0.35245860f, -0.01212685f, -0.08656352f, -0.13614763f, -0.08142255f, 0.27698082f, 0.02655181f, -0.11253834f, 
    0.41614625f, 0.02824846f, 0.06994203f, 0.03789094f, 0.02897554f, -0.00010526f, -0.03127991f, -0.37375045f, 
    0.25850937f, -0.13607708f, -0.13559516f, -0.01400534f, -0.29508665f, 0.17274344f, 0.17974921f, -0.09333561f, 
    -0.04869084f, -0.17614082f, -0.24300174f, -0.14938876f, -0.09828661f, -0.00107178f, 0.21100074f, -0.16070989f, 
    -0.07665677f, -0.11622115f, -0.10930795f, 0.00371174f, -0.05343453f, 0.05086222f, -0.04821753f, -0.01826309f, 
    -0.11756757f, -0.05867843f, 0.01365892f, -0.09357843f, 0.01173544f, -0.12531558f, 0.30682734f, -0.06076463f, 
    -0.25776801f, 0.03316084f, -0.05180602f, 0.32887208f, 0.39648321f, 0.16862305f, 0.30683556f, -0.13633785f, 
    0.06402782f, -0.06619488f, 0.00611885f, 0.01390582f, -0.09158216f, 0.46691722f, 0.05909669f, -0.00857753f, 
    0.24167277f, -0.08755834f, 0.05159250f, -0.08405474f, 0.11509031f, -0.05326489f, -0.22463934f, 0.13606387f, 
    -0.24496180f, 0.02708804f, 0.14475538f, -0.09857874f, -0.18833913f, -0.13622999f, -0.17319997f, -0.50576842f, 
    -0.12532641f, -0.08817752f, 0.14022823f, 0.01276990f, 0.19121589f, -0.08648234f, 0.01258619f, 0.02764785f, 
    0.03460928f, 0.04558143f, 0.03415970f, -0.02117339f, 0.01997611f, -0.05864241f, -0.04638016f, -0.06511135f, 
    -0.06421924f, -0.07781415f, -0.02190989f, -0.10692958f, 0.00072463f, -0.02090474f, -0.07665048f, 0.05925917f, 
    -0.07046530f, -0.10291884f, 0.01321564f, 0.04750274f, -0.02981487f, 0.07098319f, -0.03949405f, -0.01077979f, 
    -0.07589558f, -0.08245397f, -0.06061834f, -0.04401543f, -0.01794286f, 0.01919893f, -0.03101020f, -0.04639533f, 
    -0.08672227f, 0.05205252f, -0.10710379f, -0.03381024f, 0.03374893f, -0.12218495f, -0.06414083f, -0.03697066f, 
    -0.08715411f, -0.02216793f, -0.00617140f, -0.07639080f, 0.00226124f, -0.00324762f, 0.01095637f, 0.05487724f, 
    -0.01813990f, 0.01483620f, -0.00328419f, -0.06982128f, -0.03941548f, -0.10683093f, 0.01409118f, -0.09146248f, 
    0.06753808f, 0.01246490f, -0.11542571f, -0.02314661f, 0.00305817f, 0.02922737f, -0.02364233f, -0.12169201f, 
    0.02822070f, -0.03990323f, -0.06972779f, -0.06020939f, 0.01888149f, -0.00643466f, -0.08321554f, 0.07935164f, 
    -0.00539759f, 0.03070793f, -0.01375031f, -0.03285078f, -0.00433115f, -0.01608358f, 0.02836648f, -0.05806162f, 
    -0.07947367f, 0.06673359f, -0.04941504f, -0.01937216f, -0.00375053f, 0.05755385f, -0.10274985f, -0.06817365f, 
    0.03506622f, -0.09821905f, -0.03542513f, 0.00542680f, -0.01863750f, -0.05796136f, -0.01558319f, 0.01158916f, 
    -0.02392642f, -0.01799977f, 0.03864290f, 0.04233949f, 0.04463720f, -0.05277507f, 0.01161032f, -0.04312660f, 
    -0.03661210f, -0.06910744f, -0.04928521f, -0.00147986f, -0.04937839f, 0.04842477f, -0.05149900f, 0.01894571f, 
    -0.00261516f, -0.08189114f, -0.10608201f, -0.07301736f, 0.06203743f, 0.03121985f, -0.06686424f, -0.08247229f, 
    -0.04877934f, -0.03991170f, -0.02622588f, 0.00441869f, 0.05327364f, -0.10707375f, 0.07410930f, -0.11308914f, 
    0.02206746f, -0.05159323f, -0.12063241f, -0.09048011f, -0.05850342f, -0.06304529f, 0.01840799f, -0.06427651f, 
    0.04405795f, 0.04343330f, -0.06214122f, -0.02607136f, 0.06276199f, 0.01518543f, -0.04996818f, 0.02405889f, 
    0.11033204f, 0.06651089f, 0.14869432f, -0.01277109f, 0.13937813f, 0.24047376f, -0.07471250f, -0.14989559f, 
    -0.03526558f, -0.09682894f, -0.12473341f, 0.02190099f, -0.01364659f, -0.14058258f, -0.04870784f, -0.05230344f, 
    0.05153099f, -0.00994449f, 0.27354890f, 0.12412491f, -0.14329341f, -0.14844240f, -0.08803161f, -0.10742436f, 
    -0.00432904f, -0.01639025f, -0.05481029f, 0.12083551f, 0.24789979f, 0.28168693f, 0.06650767f, -0.10785275f, 
    0.06953452f, -0.05221435f, 0.19013111f, 0.08194657f, -0.28015903f, -0.24433154f, 0.12833375f, 0.07439116f, 
    0.03555983f, -0.13313232f, -0.03571675f, -0.09998755f, -0.10892695f, -0.11857907f, -0.38953134f, -0.21686891f, 
    -0.07489239f, -0.10893469f, -0.01347542f, 0.01077574f, 0.04646119f, 0.21448475f, -0.02326977f, -0.13458566f, 
    -0.15620807f, -0.02225262f, 0.15680039f, -0.15264031f, 0.03112415f, -0.09407558f, 0.12110715f, 0.35699263f, 
    0.22189970f, 0.09935841f, 0.07295495f, 0.38631618f, -0.09585522f, 0.04479474f, 0.03661193f, -0.02928937f, 
    0.36560050f, 0.31344396f, -0.06327668f, -0.07379480f, -0.13544251f, -0.11386346f, -0.10516907f, -0.01692183f, 
    -0.12549682f, -0.09951890f, -0.22290225f, -0.26281995f, -0.07875152f, 0.09788927f, 0.11068517f, -0.11170489f, 
    -0.04288954f, -0.11162147f, -0.48594090f, 0.00235290f, 0.20287599f, -0.03293399f, 0.03520266f, 0.07620701f, 
    -0.06615803f, -0.07463229f, 0.13285656f, -0.12969539f, 0.22425433f, 0.06641604f, 0.18898645f, 0.10614944f, 
    0.05255250f, -0.13392493f, -0.04395580f, 0.01292713f, 0.14345303f, 0.37198117f, -0.10861304f, 0.10168287f, 
    -0.09477011f, 0.05174767f, 0.08477214f, 0.06587976f, -0.08922420f, -0.15074997f, 0.40576598f, 0.09645626f, 
    0.27756706f, -0.17193013f, 0.04345703f, 0.09743942f, 0.06471743f, -0.06441125f, 0.75677168f, -0.13776609f, 
    -0.08228574f, -0.13616341f, -0.05691503f, 0.10350377f, 0.11318734f, 0.11925124f, -0.10759959f, 0.10031562f, 
    -0.91929501f, 0.05071111f, -0.05252141f, 0.13843310f, 0.18448932f, -0.14537224f, -0.03759908f, 0.04880812f, 
    -0.43997416f, -0.05142446f, 0.10514703f, -0.05395707f, -0.04135973f, -0.03065533f, 0.05512926f, -0.00984523f, 
    0.03837505f, -0.22485936f, 0.03558526f, 0.05762606f, 0.04620099f, 0.14211282f, -0.07429459f, 0.03961064f, 
    0.10405543f, -0.36519122f, 0.25759053f, 0.25638694f, -0.10954463f, 0.07969541f, -0.16410558f, -0.14259669f, 
    0.25563857f, 0.22391176f, 0.03531636f, -0.12562135f, 0.17155281f, 0.24045093f, -0.07849564f, -0.27465409f, 
    0.00040852f, -0.15821293f, 0.03417892f, 0.09167595f, 0.28885093f, 0.03265033f, 0.13578866f, -0.16663034f, 
    -0.10755578f, -0.13299464f, 0.27337465f, 0.00270763f, -0.04145253f, 0.35249543f, -0.40053400f, -0.07006774f, 
    0.06767259f, -0.04981149f, -0.01421552f, -0.07004573f, -0.00461852f, 0.13461255f, -0.74498957f, -0.23459749f, 
    -0.05500203f, 0.17415012f, 0.30511397f, 0.44121867f, 0.10182507f, -0.02794944f, -0.17896286f, 0.23759703f, 
    -0.12042284f, 0.19350386f, 0.15193528f, 0.21348999f, -0.02603913f, -0.14048237f, 0.17312962f, -0.19852376f, 
    -0.21628974f, -0.28152514f, 0.12073211f, 0.07234140f, -0.07961114f, 0.02846958f, -0.44173703f, 0.03986246f, 
    0.23906626f, 0.43343744f, 0.09709980f, -0.05595784f, 0.06672632f, 0.11529455f, -0.05813343f, 0.18893024f, 
    0.07085481f, 0.03181387f, 0.12821805f, 0.21408589f, 0.02915798f, 0.03745907f, -0.13038749f, 0.05350937f, 
    -0.06407114f, -0.14431591f, 0.02204560f, 0.02669805f, -0.04788549f, -0.15690088f, 0.09518345f, 0.03229322f, 
    0.08240582f, 0.30268103f, 0.07411324f, -0.06521765f, -0.38010871f, 0.03385618f, 0.27544874f, 0.09149400f, 
    -0.03022988f, 0.06189917f, -0.05990258f, 0.01173274f, 0.14717332f, -0.26172864f, 0.25002551f, 0.05590934f, 
    -0.00884918f, 0.00261092f, -0.00148482f, -0.01688218f, -0.00727351f, -0.01652015f, 0.09697383f, 0.07090677f, 
    0.03631667f, 0.08331424f, -0.10210013f, 0.11589333f, -0.04689630f, 0.10626947f, -0.01660896f, 0.09138400f, 
    -0.08312150f, -0.14657022f, -0.00720174f, 0.03163288f, -0.15217301f, 0.19599040f, -0.02601331f, 0.25691566f, 
    0.05085964f, -0.34586275f, 0.12612452f, 0.01028814f, 0.03877931f, 0.00314292f, 0.02186466f, 0.09590050f, 
    -0.03258583f, -0.26605213f, -0.05125747f, -0.10958524f, -0.01400103f, -0.21742624f, -0.01090385f, 0.16492106f, 
    0.02860191f, -0.11887674f, 0.08349156f, 0.04414416f, 0.17533050f, -0.37006286f, -0.11871147f, -0.04446213f, 
    0.06123404f, 0.15815924f, 0.06119847f, 0.25385520f, 0.08673722f, 0.27836820f, 0.10829225f, 0.03551266f, 
    0.13485262f, 0.18218994f, -0.30697152f, -0.31343490f, -0.39977825f, 0.00410289f, 0.01081301f, 0.00588671f, 
    -0.04991185f, 0.13584140f, 0.04093683f, -0.07960723f, -0.22371998f, -0.22636771f, 0.06804117f, 0.03342092f, 
    -0.20144540f, -0.08433791f, -0.09531190f, 0.09216338f, 0.00310765f, 0.19522938f, 0.31902868f, 0.12479506f, 
    -0.03266117f, -0.02145736f, -0.30108240f, 0.05222949f, 0.08865088f, 0.06969384f, 0.06468434f, 0.20717837f, 
    -0.03852513f, 0.03735484f, 0.37031361f, 0.21228401f, -0.06559999f, 0.06937260f, -0.00615504f, 0.03501057f, 
    -0.41809466f, -0.25165093f, -0.10541052f, 0.04851400f, -0.06302820f, -0.15731159f, 0.01440803f, 0.05555452f, 
    0.04128794f, 0.02326371f, -0.09601513f, 0.18429902f, -0.22911799f, -0.21253711f, -0.07548098f, -0.16502120f, 
    0.35847786f, -0.02548643f, 0.04933409f, 0.06466924f, 0.08720945f, 0.01453807f, 0.23541152f, -0.15658985f, 
    0.01146613f, 0.09788350f, -0.15292749f, 0.07139380f, -0.12824297f, 0.05794259f, -0.00181356f, -0.06048106f, 
    -0.02709262f, -0.01877370f, 0.11057699f, -0.16469012f, 0.31107941f, 0.30256179f, -0.41057676f, 0.29031879f, 
    0.27621940f, 0.03218441f, 0.01358083f, 0.04110782f, 0.05975213f, -0.39093795f, 0.00262214f, 0.02879817f, 
    0.05107088f, 0.09876528f, -0.20745039f, 0.07186697f, 0.07141432f, 0.01407965f, 0.16350365f, 0.26479980f, 
    0.05087699f, 0.03361747f, -0.05932193f, -0.01942187f, 0.15783170f, -0.10701919f, 0.05688488f, 0.23600522f, 
    0.03575531f, 0.14513525f, -0.36285704f, -0.10232456f, -0.00266561f, -0.28440049f, -0.01155036f, 0.16176601f, 
    -0.11269289f, 0.08421142f, 0.18793584f, -0.03594669f, 0.09915378f, -0.16447438f, -0.06568098f, 0.07823131f, 
    0.32642817f, 0.33282265f, 0.08091836f, 0.06768204f, -0.18345796f, -0.22356126f, 0.02381413f, -0.04240238f, 
    0.07014426f, 0.01013895f, 0.37079310f, -0.04008133f, -0.25754732f, -0.02881072f, 0.04039368f, -0.06667562f, 
    0.37796903f, 0.00126982f, 0.08363362f, 0.35060826f, 0.21191369f, -0.07098903f, -0.16473068f, -0.15013903f, 
    0.08771934f, -0.17383514f, 0.13985281f, 0.24890235f, -0.25403064f, 0.16708651f, 0.09770402f, 0.03786290f, 
    -0.06426497f, 0.02716791f, 0.12042679f, -0.22826086f, 0.01774669f, 0.16994280f, -0.17731389f, 0.11058735f, 
    0.06730951f, -0.04410572f, 0.07719180f, 0.15477557f, 0.05023384f, -0.01752085f, -0.10937428f, -0.03829608f, 
    -0.09606288f, 0.06295962f, 0.14230357f, 0.19617453f, -0.05745910f, 0.13568458f, -0.34770358f, 0.06989782f, 
    -0.21891208f, 0.27953458f, -0.12989745f, -0.05724131f, 0.31359348f, -0.05232430f, -0.08613908f, -0.06401260f, 
    -0.02365516f, -0.07670932f, 0.22131473f, 0.03088136f, -0.07757045f, -0.24110785f, -0.05411372f, 0.07556930f, 
    0.09175174f, 0.02235879f, 0.25283045f, -0.00792633f, -0.05546264f, 0.43431437f, 0.05613155f, 0.11333633f, 
    -0.08664593f, -0.15491851f, 0.08727317f, 0.00237419f, 0.16017070f, 0.15050185f, 0.02931992f, 0.08947959f, 
    0.03723346f, -0.08080557f, -0.04560518f, -0.05237690f, -0.15134868f, -0.39248011f, 0.20147988f, 0.14871368f, 
    0.29582468f, -0.05397659f, -0.14494753f, -0.25746208f, -0.05278158f, -0.07833867f, 0.24905060f, -0.30018651f, 
    0.04252844f, 0.00435368f, 0.13114654f, -0.13306086f, 0.11819469f, 0.09542335f, -0.20265730f, -0.03458460f, 
    -0.01919348f, 0.02375046f, -0.12852928f, -0.00097860f, -0.06983595f, -0.01589720f, 0.24295291f, -0.23689154f, 
    -0.03917792f, -0.18684515f, -0.03524894f, -0.03116733f, -0.16545241f, -0.07142387f, 0.19541353f, -0.06201221f, 
    0.19374801f, -0.00875473f, 0.13223730f, 0.13180879f, -0.11663619f, -0.06717373f, 0.07527974f, -0.10561474f, 
    -0.22720584f, 0.02112543f, -0.36929628f, 0.31856441f, -0.16951722f, 0.04701862f, 0.06373999f, -0.01276333f, 
    -0.02779547f, -0.15719385f, -0.26826105f, -0.24012332f, 0.09265629f, 0.17580321f, 0.00189409f, -0.18902776f, 
    -0.12320615f, -0.16077618f, 0.03937795f, 0.16075252f, 0.05725018f, 0.00851046f, 0.40276173f, 0.23343807f, 
    -0.08568502f, 0.05439087f, 0.14914608f, 0.02130264f, -0.11339810f, -0.09606405f, -0.38144675f, -0.06201922f, 
    -0.00941091f, -0.05487254f, 0.16962999f, -0.00396111f, 0.91564941f, 0.12809499f, -0.12814435f, -0.21822649f, 
    -0.11574934f, 0.03044139f, 0.03452679f, -0.09928447f, -0.00198193f, -0.29949287f, -0.18361101f, -0.28526095f, 
    -0.04032824f, 0.00106584f, -0.11826113f, -0.08446053f, -0.02735421f, 0.22169001f, 0.19994138f, -0.06307444f, 
    0.09860575f, -0.07005719f, 0.01511185f, -0.08623982f, 0.02441875f, -0.03873894f, -0.03990887f, -0.04584587f, 
    0.29315507f, -0.29092354f, 0.13566115f, 0.05063039f, 0.13950713f, -0.11036568f, 0.01930052f, -0.07445331f, 
    0.40881422f, -0.32208833f, -0.19445898f, -0.23050179f, -0.07428803f, -0.01825500f, -0.25496122f, -0.00119360f, 
    -0.11372855f, 0.09801446f, 0.06300098f, 0.03803110f, -0.02669328f, 0.32548338f, 0.08099025f, 0.15417619f, 
    0.00139876f, 0.04855209f, 0.13750754f, 0.23646934f, -0.10083739f, 0.10393429f, 0.11096857f, -0.00591314f, 
    -0.09556661f, -0.03060826f, -0.44096664f, 0.35632840f, -0.08075517f, 0.07199660f, -0.05180456f, -0.10016556f, 
    0.14816362f, 0.05914026f, 0.11512049f, -0.05360937f, 0.24576421f, 0.23250869f, -0.21553135f, 0.09387208f, 
    0.03199469f, 0.01524400f, -0.04572533f, 0.08844920f, 0.02605761f, 0.41841510f, 0.38066685f, -0.09669642f, 
    -0.02632494f, 0.14962351f, -0.02235202f, 0.00927842f, 0.01214602f, -0.02876644f, -0.36869615f, -0.64926368f, 
    -0.17185567f, 0.02928298f, 0.01951014f, -0.08213814f, 0.04800035f, 0.18792577f, -0.07324687f, 0.24690567f, 
    0.03097733f, -0.00875523f, -0.05069553f, -0.15946485f, -0.12172639f, 0.08681005f, 0.12980919f, 0.05806307f, 
    0.23579696f, -0.34630182f, -0.17739235f, 0.24032395f, 0.11437198f, 0.15052372f, -0.06572936f, 0.03849123f, 
    -0.13535599f, 0.11152694f, -0.31333521f, -0.13612896f, 0.13265659f, -0.17002624f, 0.19353437f, 0.23080997f, 
    0.19107153f, 0.10456522f, -0.92344201f, -0.00996442f, 0.15750961f, 0.06491923f, 0.05640765f, 0.14740054f, 
    -0.21735086f, 0.08606358f, 0.00011464f, -0.30452758f, 0.00840848f, -0.12555411f, 0.11569967f, 0.01903799f, 
    0.11866499f, 0.19862312f, -0.14406005f, -0.17771721f, 0.20374586f, 0.17442520f, -0.17359553f, -0.05643597f, 
    0.16210882f, 0.02036503f, -0.12203967f, 0.01196637f, 0.27457997f, 0.07080244f, -0.00608367f, 0.18106709f, 
    0.11002263f, -0.11515309f, 0.11452720f, -0.01484811f, 0.22651261f, 0.13189290f, -0.31733826f, 0.10049458f, 
    0.34031993f, -0.07109832f, -0.13138016f, -0.27101758f, 0.27017361f, 0.08614785f, 0.16572434f, -0.09685447f, 
    0.46529284f, -0.11352396f, 0.01678364f, -0.10614721f, 0.28594446f, -0.03193752f, 0.10445812f, 0.09979405f, 
    -0.05397154f, 0.13488217f, -0.26137570f, 0.07402333f, -0.09575688f, 0.14392146f, 0.03017888f, 0.00101982f, 
    -0.07335915f, -0.10409127f, 0.16756947f, -0.29666749f, 0.25138131f, -0.04847334f, 0.20589098f, 0.04367054f, 
    0.07385749f, -0.07424173f, -0.06563725f, 0.01126120f, 0.12030939f, 0.09259041f, -0.22598526f, 0.00194449f, 
    -0.09024395f, 0.25015807f, 0.08451378f, -0.16797498f, -0.08458775f, 0.09396693f, -0.04094508f, 0.09590209f, 
    0.04622804f, 0.09282416f, 0.04295519f, 0.08491990f, 0.05206928f, -0.01469935f, -0.41880924f, 0.01884504f, 
    -0.00723390f, -0.11032012f, 0.22806434f, -0.05884532f, 0.03041565f, -0.24797902f, -0.11599483f, -0.00157599f, 
    -0.01904564f, -0.07448084f, 0.04018025f, 0.02985947f, -0.02153678f, -0.08668946f, -0.30873221f, -0.53331691f, 
    -0.27532208f, 0.23446150f, 0.03036328f, -0.00460613f, 0.11794106f, -0.02004389f, -0.39269188f, 0.26690769f, 
    -0.16892284f, -0.10731220f, -0.10128990f, -0.05537671f, 0.20933408f, -0.09039120f, 0.07412432f, -0.13377732f, 
    -0.20766620f, 0.06165272f, -0.06415434f, 0.15668440f, 0.20183630f, 0.26781493f, 0.03538153f, -0.08891025f, 
    0.19719782f, -0.17941512f, -0.10312135f, -0.30869633f, 0.10273096f, 0.07504697f, 0.02498609f, 0.07580166f, 
    -0.08268178f, -0.01043770f, 0.53979015f, 0.03960032f, 0.06822500f, 0.11255328f, -0.21630867f, 0.03120580f, 
    0.03864315f, -0.09628366f, 0.05955175f, -0.58188528f, 0.13336112f, -0.19427106f, 0.11381356f, -0.00107178f, 
    0.15608206f, -0.13057412f, -0.09232382f, -0.13425858f, 0.23011433f, 0.16821867f, -0.39422372f, 0.18158811f, 
    -0.11823914f, 0.06218668f, 0.08292328f, -0.24531901f, -0.00385316f, -0.23945394f, -0.22720467f, -0.71257794f, 
    -0.06211975f, -0.16975003f, 0.16854733f, 0.12131012f, 0.02630167f, 0.10404773f, 0.28554627f, 0.16075328f, 
    0.09783414f, -0.21530586f, -0.04710307f, 0.05284889f, 0.12123183f, 0.04474339f, 0.31548521f, -0.32480684f, 
    0.08747025f, 0.11960052f, -0.04937886f, 0.26008528f, 0.12827542f, -0.12602200f, 0.07253677f, 0.07447432f, 
    0.14839414f, -0.19262357f, 0.24048752f, 0.05495211f, 0.03225315f, 0.00035105f, -0.09394456f, 0.08748842f, 
    0.15883102f, -0.40309709f, -0.06149919f, -0.09787621f, 0.01662683f, -0.07150356f, -0.07226586f, -0.00990570f, 
    0.15668198f, -0.04734112f, -0.24263415f, 0.11891319f, -0.04943459f, 0.24059929f, 0.02488963f, -0.13620380f, 
    -0.08603948f, 0.08638819f, 0.12730600f, 0.22802530f, 0.33580536f, 0.04853104f, 0.07897250f, 0.20867674f, 
    -0.03194100f, -0.01760255f, -0.07372684f, -0.15026304f, -0.10238032f, -0.02044016f, 0.48866850f, -0.04701169f, 
    -0.12193446f, 0.03568762f, -0.05262378f, 0.22066414f, 0.02861065f, -0.42257544f, 0.13785903f, 0.64879489f, 
    0.16098544f, 0.00912867f, 0.08362349f, -0.02312676f, 0.08585253f, 0.07322925f, -0.20848165f, -0.21113221f, 
    -0.69707495f, -0.06121490f, -0.02769511f, -0.24754162f, 0.02631589f, 0.08591558f, -0.12104677f, -0.14946038f, 
    0.11590245f, -0.24393389f, 0.16812238f, 0.03326157f, -0.18298502f, 0.04946946f, -0.10398194f, -0.14902546f, 
    0.24973674f, 0.13014095f, -0.03536708f, -0.00334840f, 0.10542952f, 0.07130636f, -0.11616585f, 0.12008659f, 
    -0.15183336f, 0.33399102f, 0.06038678f, -0.19304624f, -0.26853466f, 0.14711179f, 0.09494920f, 0.35981333f, 
    -0.07286957f, 0.04978244f, 0.05717853f, 0.36131990f, -0.39164054f, 0.17246002f, -0.27098888f, 0.06815926f, 
    -0.11672455f, 0.03138912f, -0.00203893f, -0.15055484f, -0.59014505f, -0.12163126f, 0.13377158f, 0.23317182f, 
    -0.14314827f, -0.08356294f, 0.07266489f, 0.10542534f, 0.05793911f, 0.02646809f, 0.09647969f, 0.15425907f, 
    -0.11050277f, -0.06943006f, -0.01710594f, 0.12101986f, 0.07985036f, 0.24286401f, 0.31491649f, -0.49350086f, 
    0.22149618f, -0.01928234f, 0.26525638f, 0.04453084f, 0.24998946f, 0.05776338f, -0.05505865f, -0.10129395f, 
    -0.12479892f, 0.04171472f, -0.01113566f, 0.05089531f, 0.11919209f, 0.02946283f, 0.13955936f, -0.27749753f, 
    0.31269598f, -0.05497521f, 0.10042024f, 0.04896020f, 0.28562480f, -0.04548552f, -0.10570298f, -0.13263439f, 
    -0.17537147f, -0.09028351f, -0.13147284f, 0.12417761f, 0.13664421f, -0.06387378f, 0.28222334f, -0.07393996f, 
    0.15636808f, -0.00088708f, -0.09301788f, 0.06592478f, 0.00162926f, -0.06044369f, 0.18265796f, -0.29502261f, 
    -0.17616452f, 0.07858364f, 0.24995477f, -0.23781680f, 0.02993103f, 0.05257627f, 0.21211565f, 0.22155502f, 
    0.10826579f, -0.08318826f, 0.35366917f, -0.03029635f, 0.39975503f, 0.18530264f, 0.17895773f, -0.04466819f, 
    0.12698229f, 0.02782364f, 0.26114959f, 0.14684963f, -0.02891601f, -0.16869883f, -0.21209225f, 0.03862016f, 
    -0.07960785f, -0.24561881f, -0.05426518f, -0.09932406f, -0.11724791f, -0.32169005f, 0.06506720f, -0.46649465f, 
    0.32426196f, 0.26870924f, 0.12944928f, 0.08257414f, -0.00276635f, 0.10979214f, -0.40460411f, -0.06590487f, 
    0.18061322f, 0.09091197f, 0.01164248f, -0.18456036f, -0.03748778f, -0.10615803f, -0.42559502f, 0.34156147f, 
    0.20023631f, -0.07217103f, 0.18212554f, 0.07826258f, 0.43150473f, -0.03952418f, 0.12789097f, 0.08402225f, 
    -0.31239128f, -0.13448958f, 0.06153643f, 0.04989979f, 0.31414247f, 0.07654457f, 0.08941425f, -0.15968385f, 
    -0.03602215f, 0.25964931f, 0.07979245f, 0.09471324f, -0.15217218f, -0.03789600f, -0.09445363f, -0.01183202f, 
    -0.04621278f, 0.13727722f, 0.41400814f, 0.20834903f, 0.03506690f, 0.08428597f, -0.00378699f, 0.13089149f, 
    0.22045976f, 0.04224054f, 0.02663314f, 0.03949746f, -0.02282306f, -0.15951408f, -0.09233186f, 0.05212785f, 
    -0.15133102f, -0.00772080f, 0.01722662f, -0.19799384f, -0.31655914f, -0.35919034f, -0.12681007f, 0.05595585f, 
    -0.02188113f, -0.02221550f, 0.13784117f, 0.08829343f, -0.05857491f, 0.03935255f, -0.03599157f, 0.08882074f, 
    -0.02147491f, -0.04258389f, 0.12829016f, -0.02440871f, 0.14316705f, 0.22025688f, -0.63420826f, -0.17320538f, 
    -0.04284970f, 0.09893236f, 0.03549389f, -0.10856178f, 0.18520594f, 0.11533344f, 0.09776757f, 0.26558846f, 
    0.27252889f, -0.03589772f, -0.03908886f, 0.19572748f, 0.00481259f, 0.03131869f, 0.22826323f, 0.06157792f, 
    0.00030688f, 0.14954382f, -0.37217841f, -0.17898777f, 0.04353637f, 0.09050610f, -0.12443337f, 0.12541679f, 
    -0.06919356f, -0.05020151f, 0.10344889f, 0.02046948f, 0.11101597f, -0.01233981f, 0.05597339f, -0.19383475f, 
    -0.21626030f, -0.06945831f, -0.10144575f, -0.17114297f, -0.17540303f, 0.20473419f, -0.00843903f, -0.00836104f, 
    -0.13218336f, -0.13005857f, -0.19316047f, -0.80730563f, -0.62255186f, 0.00485036f, 0.17796437f, 0.17151435f, 
    0.08505580f, 0.05080248f, 0.00216527f, 0.06581082f, 0.51877582f, -0.10258162f, -0.02668139f, -0.20168427f, 
    -0.02913168f, -0.16008654f, -0.00709473f, 0.25566599f, -0.12573272f, -0.16484514f, 0.15126079f, -0.16999632f, 
    0.00659329f, -0.08516355f, 0.01278802f, 0.00310408f, 0.26382557f, -0.03661199f, 0.31304324f, -0.31575420f, 
    -0.08761189f, 0.09704974f, 0.14094563f, -0.11989707f, -0.03053909f, -0.32032469f, -0.01502239f, 0.40356708f, 
    -0.07691395f, 0.20878592f, 0.31545281f, -0.01374572f, 0.12221794f, -0.02575511f, 0.01660884f, -0.09673093f, 
    0.02903523f, -0.02627772f, -0.10432868f, -0.10090566f, 0.00763201f, -0.00489947f, 0.02814732f, -0.06958481f, 
    0.02376955f, 0.01730193f, 0.00882894f, -0.08028377f, -0.05559020f, -0.07069428f, -0.03583790f, 0.01862903f, 
    0.04416764f, -0.01322392f, -0.00406905f, 0.00474757f, -0.06355189f, -0.01086511f, 0.05695993f, -0.07986183f, 
    -0.08198139f, -0.06619965f, -0.08509293f, -0.00115743f, -0.10895907f, -0.07105609f, -0.03564471f, -0.04614384f, 
    -0.01002535f, 0.04634839f, -0.11895302f, -0.06523520f, -0.05966812f, 0.02662070f, -0.03863188f, -0.09627616f, 
    -0.07355136f, -0.07876597f, 0.03947243f, 0.01994372f, -0.09794161f, 0.04358317f, -0.03641874f, -0.06070211f, 
    -0.05087848f, 0.02639120f, -0.01957531f, -0.03942440f, -0.00573485f, -0.02387249f, -0.09444046f, -0.00482967f, 
    -0.01608967f, -0.03575538f, -0.10518306f, -0.09888016f, -0.07253391f, 0.02325756f, -0.05507571f, -0.08712111f, 
    -0.09579104f, -0.10085942f, -0.08790736f, -0.07670394f, 0.02533043f, 0.03753226f, 0.03685325f, -0.01201447f, 
    -0.07728694f, -0.07256673f, -0.10625695f, -0.10809836f, 0.04444584f, 0.03721660f, 0.04577848f, -0.02329758f, 
    -0.04452013f, 0.02656964f, 0.04984386f, 0.01592871f, -0.05637567f, 0.01434052f, -0.02095198f, -0.03711377f, 
    0.02894607f, -0.03543605f, -0.11802192f, 0.03677190f, -0.07118281f, -0.05644146f, 0.05516375f, -0.06859715f, 
    -0.05383860f, -0.05983494f, 0.02199800f, 0.01189901f, -0.04557670f, -0.01816510f, -0.04330199f, -0.10207447f, 
    0.03435015f, -0.08757683f, -0.02830067f, 0.04519330f, 0.01093415f, -0.03378436f, -0.01112070f, -0.11738089f, 
    -0.01336898f, 0.00741293f, -0.05180877f, -0.03640918f, -0.07416957f, -0.03939455f, -0.02033212f, 0.01587941f, 
    0.01831635f, -0.05502978f, -0.06944454f, -0.06449099f, -0.04790324f, -0.08308349f, 0.04096381f, -0.10000128f, 
    0.05235865f, -0.06028701f, 0.00417738f, -0.04837965f, 0.05623038f, -0.01244272f, -0.00620789f, -0.08224502f, 
    -0.00186121f, -0.02614622f, -0.10445517f, -0.08013728f, 0.07216093f, 0.02335661f, -0.05415852f, -0.04297461f, 
    -0.14253786f, -0.46252906f, -0.13981442f, 0.08723425f, 0.10237312f, 0.17660336f, -0.03394367f, 0.04890933f, 
    -0.00874592f, 0.16205138f, 0.03479972f, -0.15327659f, -0.01067671f, 0.17774399f, 0.08724866f, -0.07691033f, 
    -0.28295055f, -0.21259961f, -0.08087373f, -0.43500656f, 0.16659670f, 0.02110669f, 0.07635808f, -0.09775049f, 
    -0.04999980f, 0.19213662f, 0.01768904f, 0.44137216f, -0.02118304f, -0.52075368f, 0.05324556f, -0.18511690f, 
    0.16131559f, 0.11479887f, 0.19168738f, -0.03284108f, 0.28369758f, 0.23407583f, 0.02583994f, -0.04863607f, 
    -0.02818276f, 0.20650215f, -0.05309464f, -0.02068644f, -0.09919291f, 0.06156788f, -0.44386846f, -0.07591949f, 
    -0.11768356f, 0.09981097f, 0.05171364f, 0.03579111f, 0.04082980f, -0.08851784f, -0.43763590f, 0.10499936f, 
    0.22320312f, -0.02858979f, 0.07973231f, 0.06913666f, -0.17312407f, 0.11995318f, 0.14977387f, -0.14108843f, 
    0.31280839f, 0.06780222f, 0.00758601f, 0.09001308f, 0.02399924f, -0.07538806f, -0.14544524f, 0.15679663f, 
    0.10565612f, -0.63494152f, 0.46592012f, -0.10697401f, -0.23062406f, 0.05407668f, 0.10540081f, 0.09811284f, 
    0.03623112f, -0.29020563f, -0.54900700f, -0.26114231f, 0.02674516f, 0.11259619f, 0.04536945f, -0.13546821f, 
    -0.01659825f, -0.00368757f, 0.04304352f, 0.29527786f, -0.19703490f, -0.09625066f, 0.14826760f, 0.27082926f, 
    -0.04080068f, -0.10921048f, -0.10542411f, -0.52269626f, 0.09480049f, -0.29154742f, -0.11033218f, 0.04631678f, 
    0.14815979f, -0.10844072f, -0.05907170f, -0.01794903f, 0.45205218f, 0.00539788f, 0.16731443f, 0.00297664f, 
    -0.02216368f, -0.03707123f, 0.19969530f, -0.12401284f, 0.18873602f, 0.48202449f, -0.42598331f, 0.09374887f, 
    -0.27363709f, 0.11073694f, -0.02148797f, 0.03495403f, -0.08569296f, 0.04402646f, 0.32015669f, -0.17955962f, 
    0.41055307f, -0.20202345f, 0.34802279f, -0.05561901f, -0.05195385f, 0.07519571f, -0.08039317f, -0.35107586f, 
    0.35069638f, 0.08068872f, 0.05763387f, -0.07193772f, 0.04925125f, -0.04704031f, 0.01548477f, -0.23335536f, 
    0.11726044f, 0.23865440f, 0.04314386f, -0.27127263f, 0.07260553f, 0.11169249f, 0.10409769f, 0.23683557f, 
    -0.08793689f, 0.16480318f, 0.08216724f, -0.10949874f, 0.20139049f, 0.14625317f, 0.03400042f, 0.16023782f, 
    0.02475108f, 0.00871567f, -0.17674440f, 0.00212808f, -0.49447599f, 0.03097754f, -0.02018232f, -0.04949583f, 
    0.12476066f, -0.19663389f, 0.20088862f, -0.01402441f, -0.33281091f, -0.22100307f, -0.13453431f, 0.13648017f, 
    -0.06853154f, -0.09000625f, 0.12959574f, 0.22911011f, -0.04814048f, 0.57135719f, 0.21762174f, -0.20081268f, 
    -0.00628376f, -0.03417937f, 0.00062170f, -0.23688456f, -0.08373294f, 0.20150638f, 0.15174611f, -0.00975872f, 
    0.02692622f, -0.02743615f, 0.05907505f, 0.18980357f, 0.10457614f, 0.24982521f, -0.15190107f, -0.07602252f, 
    -0.11573570f, 0.13888903f, 0.20201968f, 0.21764824f, -0.07557758f, -0.09115817f, -0.24665616f, -0.24871023f, 
    -0.51531827f, -0.25942722f, -0.01310648f, -0.04749860f, 0.30527723f, -0.22388712f, -0.07931934f, 0.14118980f, 
    -0.38408256f, -0.53179145f, -0.18766069f, -0.05471599f, -0.15926711f, 0.14111803f, -0.10250425f, -0.01486904f, 
    0.01505156f, -0.25425339f, -0.28461182f, 0.29929247f, -0.03105374f, -0.18697251f, -0.19474068f, 0.23945381f, 
    0.10722500f, 0.11679276f, 0.05762629f, 0.22435862f, 0.12951793f, 0.18820043f, 0.02171608f, 0.13214466f, 
    0.12925433f, -0.24600837f, -0.03438298f, -0.38300970f, 0.39207041f, 0.49196699f, 0.08797675f, 0.09981944f, 
    0.12948050f, 0.13297936f, -0.09647902f, -0.19858794f, -0.07306074f, -0.42673099f, -0.03750390f, -0.02068947f, 
    -0.06240140f, 0.19706695f, 0.17413196f, -0.11359961f, 0.10167145f, -0.16920792f, -0.01490630f, 0.05941039f, 
    0.16981545f, -0.01298217f, 0.03444180f, 0.07362916f, -0.12091968f, 0.05630289f, 0.26373544f, -0.06417037f, 
    0.09370357f, 0.11878036f, 0.11544146f, -0.18596934f, 0.21858874f, 0.12511444f, 0.10211343f, 0.12395944f, 
    0.34789604f, 0.27204499f, -0.25466922f, -0.01352237f, -0.03103141f, 0.04531460f, -0.13922758f, -0.02612372f, 
    0.24211945f, -0.11974810f, -0.20763749f, -0.02048018f, 0.07732315f, 0.29537427f, -0.01852762f, 0.39028093f, 
    0.06448510f, -0.47166878f, -0.40557939f, -0.00837999f, 0.06552281f, 0.03212316f, -0.00133870f, 0.00298662f, 
    0.03865637f, -0.37976953f, -0.19869195f, -0.34644359f, -0.07463435f, 0.02069193f, 0.20849065f, 0.04004194f, 
    -0.04530670f, -0.04229557f, -0.09117170f, -0.17145109f, -0.13046239f, 0.05102862f, 0.05368002f, 0.05059605f, 
    -0.07262203f, -0.12102402f, 0.18401761f, -0.05363332f, -0.03437499f, 0.10797513f, 0.06126276f, -0.11316846f, 
    -0.28137887f, -0.09517743f, 0.02850951f, 0.05462719f, 0.07183629f, 0.01527756f, 0.20891996f, -0.18224706f, 
    0.09128395f, -0.07647534f, 0.07788130f, -0.13344614f, 0.55064464f, 0.00628869f, 0.19372757f, -0.01856405f, 
    -0.10285852f, -0.07742169f, -0.09926125f, -0.04004231f, 0.08399999f, 0.19356035f, 0.01989963f, -0.01419748f, 
    -0.18206190f, 0.08384142f, 0.17973118f, -0.05459650f, 0.28177559f, -0.05409699f, -0.18170896f, -0.23129773f, 
    0.00066413f, -0.02242497f, 0.18932253f, 0.03934161f, 0.31538162f, 0.18941118f, 0.05204427f, -0.00565948f, 
    -0.07410981f, -0.16138229f, -0.05676926f, 0.22718684f, -0.14525881f, 0.04867247f, 0.11421922f, -0.02983147f, 
    0.14905638f, 0.07416609f, -0.00309618f, 0.10612479f, -0.10886589f, -0.07881348f, -0.20834181f, -0.06076203f, 
    0.23311719f, 0.24356841f, 0.08090396f, 0.30443707f, 0.23234676f, 0.25337994f, -0.21183152f, -0.40516859f, 
    0.01521871f, 0.04234155f, 0.05511835f, 0.07828359f, 0.13146678f, -0.33078030f, -0.22749069f, 0.23953190f, 
    0.08547962f, 0.04354459f, -0.07009935f, -0.14922684f, -0.07584182f, -0.20923276f, 0.03816990f, 0.03298231f, 
    0.05397126f, -0.05229880f, 0.14299056f, -0.13057183f, -0.05104670f, -0.22119741f, -0.36434475f, -0.26149923f, 
    -0.07328394f, -0.24917595f, -0.01782774f, -0.02641109f, 0.14993122f, 0.02726089f, -0.06910830f, 0.01499232f, 
    -0.06030086f, 0.18218862f, -0.21262887f, -0.17080005f, -0.12150837f, 0.16199058f, 0.08686221f, 0.09269661f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    -0.10508852f, 0.03203724f, -0.01324406f, -0.14567912f, 0.09993908f, -0.16486023f, 0.13110487f, 0.03938338f, 
    0.17335749f, -0.05613329f, 0.24217699f, 0.13261276f, 0.01875271f, -0.00623232f, 0.13317116f, 0.19972698f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.35788202f, 0.39511281f, -0.09168904f, -0.69581556f, 0.52709424f, -0.12116839f, 0.53161329f, 0.58099157f, 
    -0.74115795f, 0.48367774f, 0.39586288f, 0.24438483f, 0.08228713f, 0.53512257f, -0.12123559f, -0.11663982f, 
    -0.26347908f, -0.14428096f, -0.17736225f, 0.15173073f, 0.50374126f, -0.13727181f, 0.00516612f, 0.58608758f, 
    0.14187227f, -0.58677769f, 0.19069473f, 0.29280600f, -0.08156503f, -0.01943432f, -0.13014124f, 0.09196494f, 
    0.02912651f, 0.33737415f, 0.02617111f, 0.40150926f, 0.20168138f, -0.33299223f, 0.25644016f, -0.43342456f, 
    -0.03241147f, 0.45694041f, 0.28808233f, 0.24577396f, 0.02127365f, -0.35315305f, -0.23629379f, -0.05444013f, 
    -0.18598291f, 0.10050313f, -0.22329172f, -0.19455624f, -0.03577625f, -0.04659671f, -0.18592995f, 0.22271262f, 
    -0.14081813f, -0.20673504f, -0.20928790f, -0.16645603f, 0.15063153f, -0.21684135f, 0.03949709f, 0.16949646f, 
    0.24263780f, 0.19481029f, -0.06036630f, 0.30469695f, -0.12623571f, 0.32402238f, -0.07804246f, 0.40617216f, 
    0.58573854f, -0.18685806f, -0.51853567f, -0.13266566f, -0.06247471f, 0.54676479f, -0.09978328f, 0.28576022f, 
    0.21136127f, 0.13072172f, 0.24428219f, 0.05642233f, -0.14055458f, 0.44961116f, 0.42168516f, -0.22234255f, 
    0.04902126f, -0.04288279f, -0.09349810f, -0.60724258f, -0.17877159f, -0.36975080f, 0.33365008f, 0.17056501f, 
    0.01490998f, 0.61382937f, -0.10325798f, -0.20939325f, 0.00664447f, -0.03498169f, -0.28774819f, -0.06096730f, 
    0.35733998f, -0.19507432f, 0.41760260f, -0.14576785f, 0.07895739f, -0.05349233f, -0.26609477f, 0.12231781f, 
    -0.46706799f, 0.31467718f, 0.09327634f, -0.02228200f, -0.25417012f, 0.15539059f, -0.33907300f, 0.04517085f, 
    0.00738727f, 0.30743772f, 0.33833274f, 0.12145916f, 0.22145915f, -0.18198241f, 0.33102405f, 0.21384135f, 
    0.39956838f, 0.00055333f, 0.02342020f, 0.32803366f, -0.52299809f, -0.14437056f, -0.03579601f, -0.18922907f, 
    0.09368630f, 0.33571818f, 0.03599769f, 0.31827760f, 0.15834494f, -0.35415447f, -0.21083774f, 0.52511495f, 
    -0.22160675f, 0.20986849f, 0.23076077f, -0.07733322f, -0.18826871f, -0.00935313f, 0.06509730f, -0.01411357f, 
    -0.13108945f, -0.07246094f, -0.05983071f, -0.17014444f, 0.17459536f, -0.18219815f, 0.05838059f, -0.15018299f, 
    0.22155501f, -0.05650997f, -0.16526410f, 0.25311941f, -0.28481248f, 0.08364375f, -0.39186096f, 0.00233775f, 
    0.50773764f, -0.69169074f, 0.17213172f, 0.36631975f, 0.13464674f, -0.03684244f, 0.23052627f, -0.12118743f, 
    0.02616342f, 0.09973072f, 0.10586585f, 0.30325565f, 0.42313376f, -0.38815162f, 0.15807325f, 0.01264482f, 
    0.18816935f, 0.31174579f, -0.22236048f, 0.83398908f, 0.08631612f, 0.36690626f, -0.02087635f, -0.58755296f, 
    -0.03276027f, 0.44708103f, 0.04145688f, -0.54169339f, -0.45330036f, -0.08012241f, -0.07970987f, 0.03172211f, 
    0.43810701f, -0.30126414f, -0.11894427f, 0.33560973f, -0.03098383f, 0.61705530f, 0.28510618f, 0.17596869f, 
    0.24867946f, -0.32119003f, -0.19944839f, -0.14124215f, -0.10349903f, 0.67083079f, 0.01507115f, -0.41899776f, 
    0.16879453f, 0.08920392f, 0.08157692f, -0.63298970f, -0.21194217f, -0.04984735f, 0.22426257f, 0.51873291f, 
    0.11468434f, 0.42424050f, 0.17731105f, 0.19704802f, 0.02088698f, 0.18323420f, -0.54993129f, 0.09347232f, 
    0.56739008f, 0.34261185f, 0.32720023f, -0.46970829f, 0.02057510f, -0.40570307f, -0.01591949f, 0.40861881f, 
    -0.14934123f, -0.01225477f, -0.09223908f, 0.19216830f, -0.08594897f, -0.17340249f, 0.05924767f, -0.19251540f, 
    0.18156683f, -0.09790799f, -0.00586331f, -0.19492152f, 0.12231389f, 0.00079241f, -0.18606037f, -0.17137232f, 
    0.55136776f, 0.13745648f, -0.14781049f, 0.59929794f, 0.03125806f, 0.13916917f, -0.03927423f, 0.00401617f, 
    -0.18752740f, 0.62024319f, -0.47006974f, -0.01972419f, 0.04317454f, 0.08901825f, -0.37262636f, -0.42827797f, 
    -0.13950484f, 0.63396448f, 0.09127466f, -0.25584784f, 0.08144294f, 0.01538425f, -0.23050959f, -0.18988726f, 
    -0.12732598f, -0.30302772f, 0.41978300f, -0.00423401f, -0.19154038f, 0.02180733f, 0.08541061f, 0.30056629f, 
    0.38847309f, 0.57758653f, -0.05808362f, 0.43485793f, -0.30410397f, -0.49391550f, -0.13189581f, 0.01522292f, 
    0.29887673f, 0.00799011f, -0.26179338f, -0.13614655f, 0.10741343f, 0.15350834f, 0.23129864f, 0.07553318f, 
    0.35747877f, -0.58643031f, -0.18693905f, 0.47939727f, 0.22736889f, 0.17098086f, 0.21194869f, -0.05724286f, 
    -0.18777505f, -0.52630299f, 0.04356257f, 0.19693007f, 0.16114482f, -0.11255283f, 0.25923592f, -0.09802490f, 
    0.60191834f, 0.09308007f, -0.12158756f, 0.66386402f, -0.18160740f, 0.45933473f, -0.20308626f, -0.30373517f, 
    0.08582222f, -0.50888264f, -0.20558138f, 0.40727052f, -0.06905919f, 0.21626963f, -0.29957205f, -0.11862338f, 
    0.17051980f, -0.51177257f, -0.00106155f, 0.12735611f, 0.60267270f, 0.33551905f, 0.61278927f, -0.35707510f, 
    -0.38084942f, 0.00020385f, -0.10529273f, 0.14148097f, -0.19680485f, 0.36387214f, 0.43083087f, -0.37995711f, 
    0.30584988f, -0.38845611f, -0.25361854f, 0.24714860f, 0.50681657f, 0.38244075f, -0.21394452f, 0.44281265f, 
    -0.01660569f, -0.77298695f, -0.07749403f, -0.35312483f, -0.23933323f, 0.11635482f, 0.39656925f, 0.16413845f, 
    0.32460639f, -0.04210965f, -0.02159306f, 0.31435186f, 0.69107515f, -0.00824830f, 0.48126709f, -0.23559457f, 
    -0.76178062f, -0.48931578f, -0.17171298f, 0.52573407f, -0.08346668f, -0.11969236f, 0.48306224f, -0.14027311f, 
    0.16133788f, -0.11858153f, -0.19493674f, 0.10594323f, 0.14441258f, 0.66996747f, 0.21226373f, -0.04562723f, 
    0.14421062f, 0.72593021f, -0.06470008f, -0.20244771f, 0.03291750f, -0.28206843f, -0.33055142f, 0.21377042f, 
    0.32239416f, 0.05597125f, -0.13881765f, 0.56252682f, -0.16635840f, 0.65107793f, 0.08219358f, -0.31495667f, 
    -0.52832693f, -0.77610093f, -0.20100923f, 0.09228168f, 0.22164546f, 0.02766838f, 0.17517515f, -0.42502221f, 
    -0.00431234f, -0.26901656f, -0.13221213f, 0.28621623f, -0.04144715f, 0.35150936f, -0.20475352f, 0.34987247f, 
    -0.06214766f, 0.10264110f, 0.28754953f, -0.52366143f, -0.18330379f, -0.29782256f, 0.68109357f, 0.66495335f, 
    0.56644142f, 0.39398485f, 0.23465298f, 0.07636569f, -0.20121564f, 0.28549385f, 0.25623125f, 0.49545813f, 
    0.11237155f, 0.11865332f, -0.49299705f, -0.26868796f, -0.06195837f, 0.41544244f, -0.38627762f, 0.01293934f, 
    0.04174354f, 0.14734150f, -0.20056185f, -0.16206208f, -0.26391613f, 0.16259499f, -0.39409190f, 0.73055416f, 
    0.00116310f, 0.26859590f, 0.12251305f, -0.24692820f, 0.21083544f, 0.11482422f, 0.42791262f, 0.48346132f, 
    0.20183164f, 0.48014104f, -0.01719410f, -0.81149077f, -0.08086315f, -0.28809598f, 0.47329444f, -0.15487950f, 
    -0.27157953f, -0.00571277f, 0.30889541f, 0.54326850f, 0.02586706f, 0.23516819f, -0.04255565f, -0.25524321f, 
    -0.01045005f, -0.08258525f, 0.14883088f, 0.29856074f, -0.51423031f, -0.44969907f, 0.13806121f, -0.51807213f, 
    0.94598496f, 0.25299528f, 0.10687435f, 0.59834921f, 0.06566151f, 0.14757150f, 0.11400029f, -0.30806997f, 
    -0.10040355f, -0.23168698f, 0.09241015f, -0.06337115f, -0.47289091f, 0.20293356f, -0.45932516f, 0.55581528f, 
    0.09617340f, 0.13748352f, 0.36168191f, -0.08608213f, -0.13237938f, 0.03937679f, 0.17283486f, 0.57094073f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.46852967f, 0.12943023f, -0.12800299f, 0.05334261f, -0.04993205f, 0.33941904f, 0.58464819f, -0.13750885f, 
    0.27727005f, 0.00628512f, -0.01490864f, -0.14867634f, 0.07206064f, 0.18352722f, -0.08542509f, -0.19345230f, 
    -0.59012312f, 0.56641757f, 0.17518988f, 0.16866997f, -0.02709964f, 0.30678016f, -0.28375193f, 0.32539403f, 
    -0.23331468f, -0.54888666f, 0.24179596f, 0.05836021f, 0.12819248f, 0.54727870f, -0.28362915f, -0.01477273f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.25625384f, 0.01395936f, -0.39006385f, -0.00060826f, 0.52933782f, 0.23041950f, -0.10343464f, -0.39937997f, 
    0.25757536f, -0.14389116f, 0.11462069f, -0.32189113f, -0.26925197f, 0.25351542f, 0.04668152f, -0.12927468f, 
    -0.56007022f, -0.08748356f, -0.10885150f, 0.13348432f, 0.43367857f, 0.05405049f, 0.30296648f, -0.06384122f, 
    0.37718192f, -0.55575407f, 0.04686931f, 0.48917401f, 0.08699990f, -0.39754209f, -1.01093149f, 0.03107390f, 
    -0.21699817f, -0.00922529f, -0.47995889f, 0.12723181f, 0.38420868f, -0.30686286f, -0.04165975f, 0.08161847f, 
    0.10595853f, -0.08175758f, 0.21994008f, -0.17679998f, 0.36190987f, 0.06587529f, 0.28441975f, -0.16473047f, 
    0.91215241f, 0.04352373f, 0.37122104f, -0.20028518f, -0.14201081f, -0.32954779f, 0.11349388f, -0.39977419f, 
    -0.46176800f, -0.80590206f, 0.20462166f, 0.18825902f, 0.33052766f, -0.16099511f, 0.01142771f, 0.43171024f, 
    0.57662827f, -0.18224491f, -0.41437876f, 0.00695764f, 0.39667138f, -0.71095985f, 0.02561878f, 0.01791437f, 
    -0.81885928f, -0.14022653f, -0.47087198f, 0.24058060f, 0.59322727f, -0.18351170f, -0.42520425f, -0.08942170f, 
    -0.97303939f, 0.14864686f, -0.33194584f, -0.53298545f, -1.06544650f, 0.19821195f, -0.29608399f, -0.26788244f, 
    -0.07942571f, -1.20994115f, -0.46021360f, 0.62447852f, 0.12597190f, 0.55119991f, -0.37453923f, 0.06623054f, 
    -0.27728990f, -0.03277616f, 0.09572355f, -0.17537649f, 0.05578794f, -0.42123812f, -0.59463447f, -0.85334206f, 
    0.01936338f, -0.08741797f, 0.14491431f, 0.51050407f, -0.02220806f, -0.16946985f, -0.69547379f, 0.12633558f, 
    -0.22868127f, -0.51463974f, -0.13809504f, 0.32439357f, -0.05738318f, 0.47705552f, -0.04642002f, 0.26234257f, 
    -0.10878145f, -0.07314432f, -0.58931190f, -0.34800673f, -0.47561631f, -0.27451727f, 0.50908202f, -0.42855042f, 
    -0.03538748f, -0.32876936f, 0.10512266f, -0.18229377f, -0.12761483f, 0.49888021f, -0.16970146f, -0.23350839f, 
    0.12491835f, -0.01613500f, -0.47275382f, -0.22210328f, -0.29863116f, 0.26115301f, -0.08777218f, 0.02861710f, 
    -0.65412176f, -0.02757793f, 0.26990369f, -0.04382563f, -0.24356194f, 0.24660020f, -0.01953993f, 0.27356613f, 
    0.00670815f, 0.22976625f, 0.14233306f, 0.15020460f, -0.00743419f, 0.10659408f, -0.44824135f, -0.52719563f, 
    -0.24711972f, -0.00388607f, -0.14858270f, -0.08149270f, -0.00955321f, 0.31620571f, 0.23383260f, 0.18060715f, 
    -0.30769020f, 0.13930494f, 0.21997723f, -0.50652701f, 0.06884176f, 0.26492360f, 0.31470203f, 0.14490750f, 
    0.35361725f, 0.21631442f, -0.30195856f, -0.13623753f, 0.45128849f, -0.08275589f, 0.15280412f, -0.29585829f, 
    -0.20112710f, 0.72969270f, 0.25232345f, -0.58631468f, -0.01586033f, -0.04814008f, -0.03040791f, 0.12860839f, 
    -0.04140642f, 0.19020046f, -0.25242966f, 0.15160619f, -0.52960032f, -0.00047230f, -0.14158061f, 0.29038483f, 
    -0.16645399f, -0.10749236f, 0.28465423f, -0.31648684f, -0.12632652f, 0.00467190f, -0.09657669f, -0.15608521f, 
    -1.04787898f, 0.14389466f, -0.29014558f, 0.36811945f, -1.08960080f, 0.09719160f, 0.36562654f, 0.27256942f, 
    -0.55947876f, -0.78095996f, 0.43158588f, -1.06785166f, 0.14441648f, -0.15437905f, -0.53783929f, 0.39192012f, 
    -0.74268854f, -0.67388123f, -0.00273100f, -0.21052931f, 0.35518157f, 0.28571332f, -0.58930266f, -0.22748452f, 
    0.04123485f, -0.00377502f, 0.25113037f, -0.01376490f, 0.01776097f, 0.13193415f, 0.00056896f, -0.15463424f, 
    0.68632662f, -0.73291576f, 0.23457745f, 0.03553306f, 0.43687978f, 0.10133061f, 0.26631436f, -0.20555629f, 
    0.20321281f, 0.35158688f, -0.25516951f, 0.52295232f, -0.52652192f, -0.56023324f, 0.05086995f, -0.54412478f, 
    -0.11933579f, -0.22351907f, 0.53921109f, -0.05470634f, -0.04162565f, -0.29202077f, 0.20401314f, 0.57525873f, 
    0.53769821f, -0.00410280f, -0.06652191f, 0.05149389f, -0.31339324f, -0.59736758f, 0.52775592f, 0.14708574f, 
    -0.23445216f, 0.09910180f, 0.47811174f, -0.77403110f, -0.13324864f, -0.80293131f, -0.77901423f, -0.77284563f, 
    0.26948425f, -0.91796941f, -0.03331870f, 0.02878335f, 0.10818956f, -0.50432432f, 0.27207825f, 0.22899510f, 
    0.19217598f, -0.33242184f, 0.03802770f, -0.06312179f, -0.81319237f, 0.16267653f, -0.11376144f, 0.22484921f, 
    0.10574955f, 0.01930814f, -0.78270859f, -0.46712533f, -0.59776521f, 0.33975911f, 0.18106045f, -0.05643372f, 
    0.05699128f, 0.03122150f, -1.03053892f, -0.04259043f, 0.19151156f, 0.15944529f, -0.17086937f, -0.13298178f, 
    0.43817407f, 0.33398518f, 0.34748054f, -0.37144485f, 0.08752874f, 0.04772167f, -0.40569729f, 0.28580356f, 
    -0.14568271f, -0.29167956f, 0.29931787f, 0.03989994f, -0.33769363f, -0.35443962f, 0.18791251f, 0.09599090f, 
    0.51368213f, 0.02613843f, 0.30069312f, 0.14284603f, 0.54523879f, -0.39393151f, -0.33726272f, -0.06608162f, 
    -0.51104647f, 0.18787456f, 0.12571080f, 0.07634282f, 0.27148610f, -0.17092367f, -0.58608311f, 0.01907373f, 
    -0.42020813f, -0.37457696f, -1.20441425f, -0.01131549f, -0.38757977f, 0.60860550f, 0.45201308f, -0.19620590f, 
    0.32795742f, 0.60299903f, 0.15480660f, -0.12843940f, -0.19455209f, -0.41890222f, 0.02761419f, -0.32372588f, 
    -0.91673571f, -0.12902923f, -0.12833017f, 0.32252356f, -0.50317764f, -0.79219997f, -0.07282170f, 0.12248939f, 
    -0.07655022f, 0.01713924f, -0.33733431f, -0.00376324f, -0.62578046f, 0.20504300f, 0.24528639f, 0.27706212f, 
    -0.21858108f, -1.18400192f, -0.24779472f, -0.12069546f, -0.12277553f, 0.15178111f, -0.67265540f, -0.32532424f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.01682915f, -0.29533702f, 0.04646296f, 0.01454571f, 0.19627741f, 0.04578811f, -0.25631723f, -0.76833558f, 
    -0.54221088f, 0.30439875f, 0.44976479f, 0.28634658f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
