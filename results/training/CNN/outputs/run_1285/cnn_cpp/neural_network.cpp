#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.79765445f, 0.33568037f, 0.10458937f, -0.41232726f, -0.63489175f, 0.72624665f, 0.20810197f, -0.15598573f, 
    -0.25431114f, -0.40828601f, -0.12151687f, 0.00313113f, -0.20241977f, -0.03804500f, 0.01051040f, 0.22548109f, 
    -0.29742864f, 0.17308311f, 0.00151380f, -0.02050574f, -0.35173166f, 0.03726924f, -0.02526174f, -0.08309292f, 
    -0.09287158f, -0.89406943f, 0.23088180f, 0.26788715f, -0.56223983f, -0.40432903f, 0.22351715f, 0.15673716f, 
    0.16174798f, 0.11545762f, 0.30788866f, -0.26030242f, -0.26439545f, 0.03668155f, -0.27988285f, 0.23615722f, 
    0.05215063f, 0.29759261f, 0.06551263f, -0.04322128f, -0.06661674f, -0.17707655f, 0.10452225f, -0.36205497f, 
    -0.36620638f, 0.04496020f, 0.08584756f, 0.31486669f, 0.30797079f, -0.50415879f, -0.12228072f, 0.11328105f, 
    -0.08422714f, -0.10291824f, 0.19730036f, -0.30494136f, -0.35880882f, 0.37346372f, -0.10366058f, 0.18611194f, 
    -0.23100153f, 0.30312198f, 0.20770395f, -0.04572343f, 0.02118911f, -0.14817341f, 0.18313067f, 0.13450360f, 
    -0.17776769f, 0.04064487f, 0.28161472f, 0.25143588f, 0.43079713f, -0.10072535f, -0.43398577f, -0.79766202f, 
    -0.48734573f, -0.11150134f, -0.15935002f, -0.12485588f, 0.00035452f, 0.36736026f, -0.03805289f, 0.41114503f, 
    0.38033772f, 0.32958958f, -0.12553266f, -0.00296386f, -0.16342191f, -0.53548086f, -0.12409487f, 0.24166000f, 
    0.27802628f, -0.02217743f, 0.03238074f, -0.08156950f, -0.45996454f, -0.56283951f, -0.58383918f, -0.46378517f, 
    -0.70259053f, 0.73052818f, 0.51716900f, -0.25462273f, -0.36128181f, -0.09763281f, -0.04757386f, -0.08799051f, 
    -0.16488513f, -0.28427294f, 0.12258999f, -0.14026351f, 0.33124667f, -0.02225970f, -0.44329914f, -0.03842749f, 
    -0.13211110f, -0.30840078f, 0.13394524f, 0.13049558f, -0.11362993f, -0.79514980f, -0.54734105f, 0.00187718f, 
    0.67334318f, 0.72440106f, -0.58151156f, -0.29047430f, 0.13156267f, -0.39503783f, -0.21354660f, 0.07823616f, 
    0.02934017f, -0.08284082f, 0.22900540f, -0.30161703f, 0.26686454f, -0.07088993f, 0.25218639f, -0.40067208f, 
    -0.20612071f, 0.05054369f, 0.07462873f, -0.08629366f, 0.22292626f, 0.03635831f, -0.58318180f, -0.54429406f, 
    -0.51468456f, 0.26833200f, 0.41560644f, 0.09895101f, 0.09293679f, 0.07447691f, 0.36301726f, 0.46092659f, 
    0.10165671f, -0.11692575f, 0.11758497f, 0.10280421f, -0.10356884f, -0.08609246f, -0.06662228f, -0.06281096f, 
    0.06917388f, -0.09440118f, -0.11496501f, -0.20483746f, -0.16648608f, -0.17654647f, -0.09620390f, 0.66767550f, 
    -0.49718323f, -0.22876853f, -0.05180204f, 0.43027645f, 0.29361036f, 0.33595031f, -0.16579348f, -0.53173149f, 
    -0.27685809f, -0.05145786f, 0.07192036f, 0.33563980f, -0.33107138f, -0.12960309f, -0.05766098f, -0.10345025f, 
    0.12775125f, 0.05336660f, 0.05932179f, -0.12168255f, -0.22077726f, -0.18366101f, -0.05156244f, 0.11046942f, 
    0.25427812f, -0.50940770f, -0.61643493f, 0.17306635f, -0.24353033f, 0.15885030f, 0.11383327f, 0.08421022f, 
    0.18984823f, 0.50248170f, -0.01596138f, 0.18218659f, -0.28192168f, -0.05169663f, 0.17570345f, 0.01949853f, 
    -0.08833480f, 0.14964190f, 0.39379615f, -0.24906477f, 0.14953877f, -0.34011847f, 0.13283478f, 0.07142726f, 
    -0.19352968f, 0.21221481f, -0.02493453f, 0.12878226f, 0.29259762f, 0.35871711f, 0.07917588f, 0.01037701f, 
    0.31142852f, 0.24046698f, -0.00482057f, -0.02875717f, 0.24655546f, 0.20237361f, -0.07231403f, -0.22635159f, 
    -0.03932273f, -0.18328249f, 0.08495963f, -0.15011336f, -0.00680271f, -0.09056310f, 0.07355022f, 0.07230270f, 
    -0.05365638f, 0.13892773f, -0.67890650f, -0.41009092f, -0.42811710f, -0.27007142f, 0.31834725f, 0.54797989f, 
    0.06037381f, 0.24251655f, 0.31581327f, 0.11367735f, -0.08483831f, 0.19767345f, -0.23239438f, 0.10573883f, 
    -0.30181196f, -0.12439505f, -0.00570611f, 0.29446563f, -0.22880428f, -0.21266408f, 0.14606692f, 0.34052640f, 
    0.04652851f, 0.00576913f, 0.23948854f, -0.42180702f, -0.17068447f, 0.37994510f, -0.60484552f, -0.72323060f, 
    0.47245383f, 0.11556714f, -0.19679566f, 0.30046821f, 0.52294624f, 0.15418045f, -0.14205131f, -0.03154074f, 
    -0.06140435f, 0.04003354f, 0.07751875f, 0.08964093f, -0.11817304f, 0.26027176f, -0.08812715f, -0.08302581f, 
    0.35261607f, 0.25871256f, -0.12137592f, -0.25334725f, -0.46061292f, 0.23646455f, 0.26365361f, -0.26844761f, 
    -0.36950639f, 0.00699611f, -0.05173210f, 0.11731863f, 0.06294633f, -0.27973685f, 0.19825153f, -0.12927499f, 
    0.09996724f, 0.52783316f, -0.29342684f, 0.13231891f, -0.22946717f, -0.46506175f, 0.05032984f, -0.02109212f, 
    0.16296540f, 0.00465228f, 0.21742375f, 0.09722323f, 0.26072046f, -0.83835131f, -0.19334087f, -0.47653884f, 
    -0.41630638f, -0.57855880f, 0.37131369f, -0.11126824f, -0.20951465f, 0.06254478f, 0.24609181f, -0.11347426f, 
    -0.46185598f, -0.23642313f, -0.25601694f, -0.24553958f, 0.20545784f, 0.02732944f, 0.07156428f, -0.07549658f, 
    -0.32276526f, -0.06265046f, -0.30433631f, 0.08669890f, -0.13216656f, 0.24144909f, -0.52951139f, -0.50997692f, 
    -0.07560694f, 0.02511008f, 0.02196095f, -0.13225980f, -0.35827199f, -0.41815498f, -0.13946567f, -0.35383767f, 
    0.07874788f, -0.07822239f, -0.11273203f, -0.18649061f, -0.39800674f, -0.13224885f, 0.13496900f, 0.03627077f, 
    0.27949831f, -0.02151259f, 0.06144447f, 0.23437504f, 0.24663296f, 0.16173220f, 0.24127090f, -0.00977446f, 
    0.07938518f, 0.40982461f, 0.47736597f, 0.14249030f, -0.35792696f, -0.46226764f, -0.46298057f, -0.33724073f, 
    -0.17945381f, -0.17522369f, -0.15788792f, -0.33854586f, -0.22544044f, -0.14899142f, -0.04908736f, 0.11582244f, 
    0.25535613f, 0.02631781f, -0.23259786f, -0.05793711f, -0.05209004f, -0.18270877f, -0.09129345f, -0.11439290f, 
    0.22000235f, -0.60400003f, -0.56385010f, -0.55608970f, -0.71337515f, 0.58287120f, 0.12918131f, -0.06975108f, 
    -0.30174556f, 0.21536800f, -0.00044460f, 0.35566512f, -0.20305637f, -0.18551509f, 0.09877809f, -0.45327589f, 
    -0.22553003f, -0.01544042f, -0.36830634f, 0.20480579f, -0.22813565f, -0.02709366f, 0.12041890f, 0.27335855f, 
    -0.22333327f, -0.11596988f, 0.22440603f, 0.01571361f, -0.04299953f, 0.31956646f, 0.09824786f, -0.09703975f, 
    -0.10318282f, -0.03116736f, -0.12113589f, -0.23647310f, 0.55787677f, -0.38827822f, -0.07032426f, -0.14385247f, 
    0.23572768f, 0.45369840f, -0.17208244f, -0.25755304f, 0.08425263f, -0.29468960f, -0.21081838f, 0.10823791f, 
    0.16030253f, 0.11435563f, -0.20828894f, -0.70529413f, 0.24307142f, 0.22222538f, 0.63269502f, 0.32936674f, 
    0.26040396f, 0.37727013f, 0.05289339f, -0.22388144f, -0.35666737f, -0.34852496f, 0.10461618f, -0.15969023f, 
    0.34085059f, -0.08888169f, -0.23615633f, -0.24019744f, -0.01895499f, -0.11345102f, 0.10605109f, -0.42143580f, 
    -0.01602464f, 0.34534723f, -0.12781098f, -0.75796938f, -0.15550153f, -0.24054472f, -0.61062461f, -0.53328210f, 
    0.18758970f, 0.48195562f, 0.16873443f, -0.03113622f, -0.00340558f, -0.05935340f, -0.27052069f, -0.21368444f, 
    -0.14600180f, 0.14343077f, -0.27474308f, -0.20972240f, -0.20512947f, 0.06108842f, -0.42383349f, -0.15351430f, 
    -0.28030193f, 0.20696178f, -0.28475475f, -0.51112944f, -0.74331337f, -0.15347613f, -0.09129629f, -0.52244055f, 
    -0.11778934f, -0.13823910f, -0.11937854f, 0.09686764f, 0.55449480f, 0.33067995f, -0.04842708f, -0.10852747f, 
    -0.31430364f, -0.52991951f, -0.29160425f, 0.34100676f, -0.18548647f, -0.33942172f, 0.32018614f, 0.32103258f, 
    -0.25688949f, -0.29235649f, 0.05295990f, -0.21358944f, -0.09929517f, 0.81091481f, -0.84069419f, -0.80029058f, 
    -0.16949676f, 0.21743932f, 0.48608464f, 0.60875827f, 0.26591900f, -0.12525891f, -0.21454200f, 0.37326822f, 
    -0.26050594f, -0.27996874f, -0.37200716f, -0.07144934f, -0.01408962f, 0.18344083f, 0.26868013f, -0.06095098f, 
    -0.13612038f, 0.04933991f, -0.10967228f, -0.14601098f, 0.06349012f, 0.06832524f, -0.31263214f, -0.04312250f, 
    -0.08704634f, -0.66355467f, -0.59512520f, 0.53579789f, -0.31084657f, -0.03035448f, 0.44081119f, 0.56750262f, 
    0.30205131f, 0.41436160f, -0.09965032f, -0.05628019f, -0.20392349f, -0.34434959f, -0.14465626f, -0.00294317f, 
    -0.09014003f, -0.20647343f, 0.15360178f, 0.03717142f, 0.28699124f, -0.05390384f, 0.15674761f, 0.02426999f, 
    0.71574217f, 0.48346904f, -0.27446628f, -0.59064084f, -0.37468651f, -0.00610640f, 0.27355361f, 0.07668128f, 
    0.14430115f, 0.09399942f, -0.19550759f, 0.26930630f, -0.10864200f, -0.10280418f, 0.34855071f, 0.07492907f, 
    0.06598214f, -0.23865052f, -0.19831015f, 0.05553465f, -0.09906967f, -0.51187098f, -0.17415169f, -0.03504340f, 
    -0.43288961f, -0.41819906f, 0.05061981f, 0.18288890f, 0.39488637f, 0.56123275f, -0.77531201f, 0.40604234f, 
    -0.41195363f, 0.22763731f, -0.04470472f, -0.20520267f, 0.07401812f, 0.37859067f, -0.39385024f, -0.11326351f, 
    0.07748590f, -0.08273233f, 0.29650545f, 0.13948724f, -0.12902723f, 0.04168003f, -0.15202756f, 0.14351705f, 
    -0.16533028f, 0.66916800f, -0.89113098f, -0.11384452f, 0.16018495f, 0.61893994f, -0.01607222f, -0.24328950f, 
    -0.03321759f, 0.08962072f, -0.14009519f, -0.22351874f, 0.12984835f, 0.11466523f, -0.37169847f, 0.04608566f, 
    -0.06413071f, -0.02595638f, 0.19762678f, 0.23263960f, -0.03477563f, 0.07111850f, -0.30734393f, -0.18102601f, 
    0.34276676f, 0.03064735f, -0.15749146f, 0.24284488f, 0.05909139f, -0.36864889f, 0.20187432f, -0.32374769f, 
    0.38194841f, 0.07978251f, -0.27021521f, -0.16435641f, 0.34031260f, -0.12708728f, 0.04383168f, 0.43827525f, 
    -0.42471582f, 0.07347305f, -0.04646179f, 0.19767718f, -0.26355928f, -0.18134633f, -0.12749536f, 0.15535519f, 
    -0.05014015f, 0.18845950f, 0.21299058f, -0.33641234f, -0.14440286f, -0.36360207f, -0.34495315f, 0.34100455f, 
    -0.17795306f, -0.30830050f, -0.14769167f, 0.34778532f, -0.43242851f, 0.37863404f, 0.29020789f, 0.44853792f, 
    -0.02335590f, 0.24863826f, -0.13217145f, -0.19363075f, -0.26658896f, 0.14111470f, 0.15622090f, 0.21654686f, 
    -0.09199316f, 0.17832577f, 0.07139280f, -0.14232285f, 0.22482692f, -0.07537401f, 0.17202370f, 0.19039218f, 
    0.20164305f, -0.17219664f, -0.02789642f, 0.05673282f, -0.06202424f, 0.02434102f, -0.22282748f, 0.06241323f, 
    0.02727596f, 0.07646856f, 0.12990788f, 0.13528943f, 0.18999773f, -0.03613018f, -0.16096254f, 0.07762758f, 
    0.11068330f, -0.33020094f, -0.25489271f, -0.21472214f, -0.19287224f, -0.21498698f, -0.08887134f, 0.26777178f, 
    0.10822182f, -0.26418009f, 0.46049240f, 0.31904465f, 0.09527644f, -0.49521792f, -0.05653140f, -0.06783140f, 
    -0.06988224f, 0.20037062f, -0.28398472f, 0.23080674f, -0.01559311f, -0.05954036f, -0.06417083f, 0.08997595f, 
    -0.04769942f, 0.10172731f, 0.21303254f, -0.30327064f, -0.06900737f, 0.31685281f, 0.21485582f, 0.18264502f, 
    0.08919331f, 0.11388135f, 0.16270056f, -0.04019416f, 0.06663740f, 0.23518093f, 0.16006555f, 0.03999553f, 
    0.04034267f, -0.19622192f, 0.14322001f, -0.15766162f, -0.33233005f, 0.19363001f, -0.16040459f, 0.19838595f, 
    -0.20808613f, -0.01548720f, 0.16032697f, 0.01262545f, -0.29742730f, -0.01117379f, -0.33581197f, 0.60471308f, 
    0.12811561f, -0.48138031f, -0.86630940f, -0.64837563f, -0.06411363f, -0.00941311f, 0.18195443f, 0.00447410f, 
    0.17061423f, 0.02177233f, 0.28700885f, 0.36787578f, -0.01665824f, 0.22017108f, 0.24802555f, 0.00556325f, 
    -0.11890244f, -0.22440830f, 0.05104807f, 0.24997503f, -0.29696783f, -0.35470510f, 0.06819539f, -0.01358521f, 
    -0.65622622f, 0.29034615f, 0.24575266f, 0.14962214f, -0.37432790f, 0.40347683f, 0.24377862f, -0.80243909f, 
    -0.43266201f, 0.05466780f, -0.22305156f, -0.08724487f, 0.27333203f, -0.02877185f, 0.03297697f, 0.07142118f, 
    -0.19184175f, -0.11511292f, -0.03954808f, -0.10426750f, -0.13098085f, -0.07042588f, -0.30930194f, 0.01702045f, 
    -0.52673978f, -0.75934052f, 0.27519131f, -0.41878942f, -0.89796889f, -0.49538815f, 0.40450069f, 0.20546800f, 
    0.29238448f, 0.64067024f, 0.41139776f, 0.00455166f, 0.30694658f, -0.09626207f, 0.05216352f, -0.17070547f, 
    -0.30434105f, -0.11730725f, -0.15039219f, 0.03186352f, -0.14711137f, -0.00633953f, 0.29425102f, 0.21000031f, 
    0.05587611f, -0.14014411f, -0.22747612f, -0.25050735f, -0.52568555f, 0.15903880f, 0.55806583f, 0.16566667f, 
    0.30442646f, 0.72330135f, -0.41135052f, -0.22155607f, -0.19716609f, -0.26143065f, -0.33671907f, 0.31630105f, 
    -0.18874829f, -0.01774474f, 0.24218245f, 0.12566134f, 0.12474414f, 0.13636483f, 0.06185642f, -0.06246471f, 
    -0.01807106f, -0.13094172f, -0.07528222f, -0.91683078f, 0.45495063f, -0.21394634f, -0.25786850f, 0.33574343f, 
    -0.14003600f, 0.16532563f, 0.20821856f, 0.37313497f, -0.08832330f, -0.33677661f, -0.13141195f, -0.16367805f, 
    0.16230643f, -0.12481014f, 0.33322921f, 0.10068718f, -0.05048989f, 0.04950035f, 0.15331291f, -0.26627249f, 
    -0.11023682f, -0.05704518f, -0.29603636f, -0.30434391f, 0.01833770f, 0.30806676f, 0.32998186f, 0.06027459f, 
    0.04731960f, 0.18696485f, 0.11462243f, -0.29820266f, -0.05409295f, 0.05831470f, 0.14551583f, -0.08788414f, 
    -0.17100133f, -0.00167254f, 0.22314018f, -0.01774966f, -0.33144957f, 0.06236274f, -0.00548938f, 0.06623214f, 
    -0.21777830f, 0.13601118f, -0.13050103f, 0.17986724f, 0.09633557f, 0.18208019f, 0.82904434f, 0.98173714f, 
    -0.47213230f, -0.98297650f, -0.62031484f, 0.13747346f, -0.33257741f, -0.07334189f, -0.08950204f, 0.22580853f, 
    -0.24757549f, 0.36272311f, -0.32667932f, -0.21662708f, -0.02859318f, -0.30593961f, 0.09253269f, 0.13983096f, 
    -0.03229393f, -0.05184142f, 0.06275032f, -0.00930224f, -0.26803821f, 0.35866165f, -0.06629917f, 0.03746418f, 
    -0.54981244f, -0.39592871f, -0.43614718f, -0.56306827f, -0.56303692f, -0.62406844f, -0.70580292f, -0.69865060f, 
    0.47624210f, 0.36719573f, 0.40956476f, -0.06942028f, -0.12218890f, 0.16090140f, 0.22335641f, -0.17205441f, 
    0.19711828f, -0.12462661f, -0.05086751f, 0.04513326f, -0.07869586f, -0.32985604f, -0.07681754f, 0.26274678f, 
    -0.50972301f, -0.35237718f, -0.11342061f, 0.41119173f, -0.04229846f, -0.01210486f, 0.07493607f, 0.18915164f, 
    0.37356547f, -0.17439812f, -0.22280595f, 0.34240240f, -0.16194870f, -0.01813103f, -0.27333215f, -0.15957420f, 
    0.05128982f, 0.08551324f, -0.28610387f, 0.36080766f, 0.28652540f, -0.19765848f, -0.02810875f, 0.36680457f, 
    -0.77257055f, -0.82450932f, -0.29514033f, 0.40615630f, 0.49729940f, 0.15666798f, 0.00116747f, -0.14083658f, 
    -0.10123254f, 0.35371497f, -0.17704453f, -0.11869613f, -0.18526582f, 0.67345154f, -0.67078030f, -0.04318921f, 
    0.06578066f, -0.12550734f, 0.25053638f, -0.20525998f, -0.33035073f, 0.23502664f, 0.12500256f, -0.06935129f, 
    -0.35149413f, -0.89311743f, -0.50683075f, -0.59176922f, 0.18368515f, 0.70226592f, -0.13948204f, -0.34705427f, 
    -0.40185684f, 0.25116897f, 0.58102727f, 0.54739398f, 0.28453124f, 0.18858537f, -0.12673466f, 0.18504396f, 
    -0.10143502f, -0.13824917f, -0.23173307f, 0.24767923f, 0.00048745f, 0.18102631f, -0.11209244f, 0.04887189f, 
    0.04042538f, -0.03695723f, 0.21178296f, 0.98781765f, 0.26549461f, -0.40641367f, -0.46958804f, -0.48290235f, 
    -0.04535031f, -0.07134321f, -0.14237258f, -0.26941139f, -0.01837249f, -0.13454223f, 0.45104572f, -0.42344210f, 
    0.10560259f, 0.22681865f, 0.39970815f, -0.02935264f, -0.02529508f, -0.39793891f, 0.01992984f, -0.00848260f, 
    -0.29895136f, -0.09845480f, -0.36351380f, 0.32150111f, -0.17895804f, 0.02454285f, 0.06683259f, 0.21312183f, 
    0.40768728f, -0.06980467f, -0.26328775f, -0.30131525f, 0.21922375f, -0.00424369f, 0.23234195f, 0.02412404f, 
    -0.33943203f, -0.20984372f, 0.29820159f, -0.01639147f, 0.08166063f, -0.05068504f, -0.21912910f, 0.10550590f, 
    -0.30677247f, 0.06586309f, -0.14135033f, -0.27217743f, 0.58097935f, 0.11620801f, -0.24353358f, -0.22835885f, 
    0.44974634f, -0.20040677f, 0.15001903f, -0.10902978f, -0.33068857f, -0.46532547f, 0.29477391f, -0.36928988f, 
    0.32943645f, -0.04849956f, 0.03138625f, 0.08098271f, -0.21019784f, 0.03311414f, -0.17502953f, -0.02127591f, 
    -0.03640544f, 0.17376617f, 0.21505739f, 0.21182339f, 0.21057567f, 0.42470807f, 0.93577850f, -0.08171114f, 
    -0.70377648f, 0.05443485f, 0.05801662f, -0.04615729f, -0.24661355f, -0.34235427f, -0.65788954f, -0.20763832f, 
    0.13228336f, -0.09482742f, 0.22993182f, 0.01534590f, 0.27327701f, -0.05056802f, 0.35089314f, 0.24853356f, 
    -0.38910124f, -0.13790943f, -0.05242596f, -0.19945082f, 0.04363604f, 0.29292399f, -0.51690280f, -0.31630927f, 
    -0.24982186f, -0.31671992f, -0.11213052f, -0.08526454f, -0.34913668f, -0.48767459f, -0.49118325f, -0.24029762f, 
    -0.09439695f, -0.22737101f, -0.13193265f, -0.23827261f, -0.24650240f, -0.02959903f, -0.32477871f, -0.25627106f, 
    0.05886377f, 0.04190335f, -0.10819040f, -0.07349433f, -0.22744024f, -0.21023533f, -0.29712248f, -0.49555445f, 
    -0.24981034f, -0.19087248f, -0.15882532f, -0.27865034f, 0.01640365f, 0.15001211f, -0.09882591f, 0.38042605f, 
    0.33870819f, 0.16122891f, -0.07656293f, 0.17907156f, 0.09843582f, 0.09807514f, 0.06245013f, 0.25888053f, 
    -0.11167774f, -0.10070134f, 0.05389787f, -0.10933799f, 0.03833419f, -0.17658632f, -0.09775253f, 0.16541789f, 
    -0.20841770f, -0.36437973f, -0.02719983f, 0.27017123f, -0.06489843f, -0.29312730f, 0.37331593f, -0.75759369f, 
    -0.58412778f, -0.30168524f, 0.57414281f, 0.49526927f, 0.03010872f, -0.32167828f, 0.35114840f, 0.01143505f, 
    -0.15563756f, -0.14992774f, -0.14126651f, 0.10564235f, -0.33572358f, -0.12029754f, -0.00717520f, 0.01856478f, 
    -0.04428179f, 0.04437278f, -0.05300381f, 0.00056494f, 0.28514463f, -0.07430597f, 0.07253040f, 0.06311300f, 
    -0.36373466f, -0.24616836f, 0.52686799f, 0.40742508f, 0.04274008f, -0.40418813f, -0.38263679f, 0.35078830f, 
    -0.18592757f, 0.12481432f, 0.20511259f, 0.21084177f, -0.31941405f, -0.14771341f, -0.10235313f, 0.24782036f, 
    -0.19012478f, 0.17637815f, -0.51108533f, 0.00925828f, -0.45398730f, -0.46458921f, -0.06142152f, -0.24996144f, 
    0.10307839f, 0.07575510f, -0.32643697f, -0.10522746f, 0.55666888f, 0.64659619f, 0.16971193f, -0.30991772f, 
    0.19709739f, -0.34522668f, -0.17156720f, -0.18412197f, -0.18468744f, -0.18283796f, 0.00637026f, 0.53665125f, 
    -0.25869510f, 0.18032290f, 0.41611999f, 0.13276744f, -0.19536416f, -0.30690965f, 0.01714315f, -0.51057535f, 
    -0.05223957f, -0.09190468f, -0.17842172f, 0.29208910f, 0.03605131f, -0.04296533f, 0.66386288f, -0.39645767f, 
    0.25081471f, -0.06498826f, -0.42012033f, -0.24418195f, 0.20060641f, 0.19505730f, -0.14224374f, -0.11113029f, 
    -0.17347199f, -0.23129590f, 0.32577989f, 0.32774287f, -0.25101739f, 0.21039824f, 0.11679938f, 0.20328365f, 
    -0.33867747f, -0.10005080f, 0.07229313f, 0.10765809f, 0.25275648f, 0.16742037f, -0.21139933f, -0.04993018f, 
    0.48647347f, -0.42258447f, -0.09208086f, -0.09648099f, -0.26443505f, -0.01808385f, -0.26631957f, 0.05866459f, 
    0.21932474f, 0.18546554f, 0.20707853f, 0.10516521f, 0.19422609f, -0.58092773f, 0.14384046f, 0.25100958f, 
    0.21832122f, 0.25453252f, -0.26701695f, -0.54535711f, -0.23681621f, 0.10933579f, 0.29232681f, 0.02328750f, 
    0.22065470f, 0.01329776f, -0.04335704f, 0.18956262f, -0.10580879f, -0.03352468f, -0.04981273f, -0.18191184f, 
    0.02079955f, -0.26794335f, -0.32614329f, -0.27705079f, -0.08328641f, -0.40819529f, -0.79265612f, 0.25719643f, 
    0.34110963f, -0.48975068f, -0.11763182f, -0.26090559f, -0.28915784f, -0.29753858f, -0.22386071f, -0.31790394f, 
    -0.17331371f, -0.14667688f, 0.00247244f, -0.45867264f, -0.27436364f, 0.00117716f, -0.09743232f, -0.14633872f, 
    0.09910957f, -0.22656068f, -0.08917126f, 0.07937294f, -0.13586161f, -0.12235250f, 0.01612231f, -0.92462099f, 
    -0.26270893f, 0.46936673f, 0.29854265f, 0.05428918f, -0.01023323f, -0.17815283f, 0.31436250f, 0.02565583f, 
    0.44824576f, 0.10598873f, 0.10958574f, 0.14144315f, -0.13132310f, -0.12093914f, -0.26431391f, -0.20229971f, 
    -0.14765072f, -0.32271773f, 0.37419561f, 0.20424637f, -0.05095083f, 0.08174887f, -0.23855627f, 0.31762287f, 
    -1.07082760f, -0.37449524f, -0.17660755f, -0.78290576f, -0.23503001f, 0.54959053f, -0.15109853f, -0.19547048f, 
    0.31913948f, 0.60802042f, 0.12989640f, 0.03945910f, -0.02096102f, 0.14886065f, -0.21058391f, 0.12864766f, 
    -0.15528087f, 0.05461330f, -0.12886627f, -0.11402223f, -0.04942242f, 0.25713477f, -0.09459820f, 0.11692630f, 
    0.15160260f, 0.03312206f, -0.51283395f, -0.38199061f, 0.26235268f, 0.05808891f, 0.68166375f, -0.04723224f, 
    -0.25331026f, -0.03687664f, 0.14528556f, 0.25272343f, -0.10365699f, 0.01081623f, -0.17036347f, 0.08598834f, 
    -0.01948474f, -0.13042909f, 0.43835312f, -0.32489520f, 0.01470298f, -0.30427006f, -0.02837549f, -0.08661073f, 
    0.38515887f, 0.20080021f, -0.42296055f, -0.27052173f, 0.03463616f, 0.45144162f, 0.42568696f, -0.56594348f, 
    -0.56696677f, -0.02356679f, 0.52536654f, 0.48393017f, -0.35564145f, -0.29776987f, -0.04504822f, 0.29239979f, 
    0.35448086f, 0.06315587f, -0.18667233f, 0.13489872f, 0.17453016f, -0.49935898f, -0.19728510f, -0.08110692f, 
    0.36445370f, 0.18553570f, 0.02747356f, -0.46612501f, -0.46447414f, -0.14585659f, 0.05118970f, 0.16035368f, 
    -0.52293044f, -0.55919284f, -0.52467185f, 0.05850086f, -0.21563816f, -0.10313831f, -0.09194610f, -0.25553459f, 
    -0.16287078f, -0.33265609f, -0.38102898f, -0.21573296f, -0.18765593f, -0.28319225f, -0.38258708f, -0.13429485f, 
    0.11838426f, 0.02959259f, -0.18405427f, -0.06463206f, 0.39818698f, 0.31480822f, -0.05772471f, 0.01603034f, 
    -0.03866020f, 0.04146476f, 0.05060648f, -0.18563916f, 0.05754852f, 0.06881028f, 0.29778737f, 0.18921064f, 
    -0.37636971f, -0.40945736f, 0.33424684f, 0.19943769f, 0.02526367f, -0.16923447f, 0.12684847f, -0.25722066f, 
    0.16507328f, 0.17008427f, 0.01408470f, -0.11945038f, -0.39679271f, -0.20173571f, -0.53397995f, -0.66245979f, 
    -0.54514831f, 0.02233662f, 0.60267699f, 0.20629406f, -0.16345213f, -0.03830295f, -0.22415514f, -0.43027386f, 
    -0.17733353f, 0.02942738f, 0.52503955f, -0.10372442f, 0.06627627f, -0.08327424f, -0.09106118f, -0.17147781f, 
    0.05487312f, 0.10218760f, 0.15567245f, 0.07756222f, -0.26164618f, -0.48836768f, 0.20271131f, -0.14985459f, 
    0.10206930f, 0.15157139f, 0.03058534f, -0.26772353f, -0.63422239f, 0.19142850f, -0.14459430f, 0.54101527f, 
    0.15225182f, 0.37035459f, -0.07376152f, -0.39139143f, -0.09449089f, 0.04088246f, -0.17334823f, -0.26419774f, 
    -0.06551339f, -0.68721771f, -0.26339200f, 0.17805846f, -0.18253541f, 0.00547794f, -0.06594650f, 0.22859684f, 
    0.35813114f, 0.47805414f, 0.17399356f, 0.26733488f, -0.24759543f, -0.11571338f, 0.13083483f, -0.22632882f, 
    0.04809909f, 0.24774855f, -0.23104788f, -0.27303666f, 0.04271378f, 0.34907156f, 0.06544722f, 0.11883381f, 
    -0.15405108f, 0.06895261f, 0.01837295f, 0.02172746f, 0.03004560f, -0.23387121f, 0.09386703f, -0.13027576f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.01915260f, 0.09884985f, -0.00133215f, 0.23652568f, -0.16325557f, 0.40694675f, -0.08013777f, 0.08158000f, 
    0.06145154f, -0.05860482f, 0.07198808f, -0.01590224f, -0.17703609f, -0.18737087f, -0.08976567f, -0.24446122f, 
    0.17184183f, 0.15260519f, 0.18519184f, -0.22828731f, 0.19980146f, 0.16789536f, 0.14647670f, 0.06499770f, 
    0.10172163f, 0.18755768f, 0.06927329f, 0.31644297f, -0.07971153f, 0.12220000f, -0.06268816f, 0.12669301f, 
    0.06645373f, -0.04106637f, 0.01416609f, -0.03260157f, 0.15918961f, 0.09068683f, -0.07134241f, 0.25063324f, 
    0.21827567f, 0.06586493f, 0.21883124f, 0.23462306f, -0.04635663f, 0.13733406f, -0.18515977f, -0.27713129f, 
    0.16080950f, 0.38397303f, -0.03218877f, 0.45203072f, -0.04938186f, -0.14267480f, -0.28357372f, 0.10172285f, 
    0.33654198f, 0.32847345f, 0.20782238f, -0.13282180f, 0.29995421f, 0.04443363f, 0.02995346f, 0.03121626f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.09230235f, 0.10072584f, -0.16161324f, -0.10691040f, -0.12006989f, 0.07758230f, -0.04215858f, -0.03089508f, 
    -0.00460603f, -0.01834485f, -0.11610480f, -0.15139112f, 0.18859676f, -0.06585824f, 0.24093369f, 0.02051115f, 
    0.10664597f, 0.07012802f, -0.10281199f, -0.02877511f, -0.02458143f, 0.00794661f, -0.04656494f, -0.12380336f, 
    0.17760761f, -0.04265870f, 0.04535791f, -0.02337802f, -0.16055503f, -0.04121160f, 0.04310261f, -0.05934560f, 
    -0.04666469f, 0.03384291f, 0.01586701f, -0.04267650f, 0.02589692f, -0.44934022f, 0.12448956f, 0.08061026f, 
    -0.00732405f, 0.07275943f, 0.06288885f, -0.00161055f, -0.09330785f, 0.05066692f, -0.06628261f, -0.00425934f, 
    0.25934315f, 0.26421538f, 0.28528664f, 0.07402290f, 0.16313542f, 0.02874723f, 0.00778692f, -0.09790461f, 
    0.02708944f, 0.09251614f, -0.00276508f, -0.07732031f, -0.24207495f, 0.16601038f, 0.20172606f, 0.01075049f, 
    -0.02050498f, 0.17003940f, 0.10279505f, 0.17625934f, -0.04819191f, -0.04330149f, -0.05875012f, 0.07535566f, 
    -0.19824687f, -0.01489523f, -0.05038534f, -0.05287948f, -0.03016425f, 0.00491371f, -0.00857024f, 0.03211984f, 
    -0.05167151f, -0.06412938f, -0.01546952f, -0.01241084f, 0.04117594f, 0.27919579f, -0.26380795f, 0.08066306f, 
    -0.12713395f, -0.08292974f, -0.11055116f, -0.00161483f, 0.12808366f, -0.05887165f, -0.10519707f, 0.03116559f, 
    -0.23510063f, 0.18936643f, -0.04706615f, -0.02526924f, 0.07522572f, 0.05423886f, -0.05613444f, -0.04092376f, 
    -0.02366361f, 0.02633737f, 0.15665069f, 0.01901841f, 0.02881677f, -0.04609581f, -0.02357609f, -0.00245933f, 
    -0.10488314f, 0.00579528f, -0.08079432f, -0.00289239f, -0.00408729f, -0.04505093f, 0.05748658f, 0.04008057f, 
    -0.21284610f, 0.18133330f, 0.09915508f, -0.01942153f, -0.03056186f, 0.18969329f, 0.04003216f, -0.07918801f, 
    0.00536440f, -0.01259245f, 0.07040765f, -0.02087881f, 0.25446481f, 0.00835995f, 0.13933773f, 0.00389342f, 
    0.11538000f, -0.02253325f, 0.02343982f, 0.10096392f, -0.15460311f, -0.03006817f, 0.03236242f, 0.00043019f, 
    0.09526902f, -0.02145355f, 0.22182915f, 0.02524631f, 0.07692694f, 0.07486966f, 0.05199341f, 0.09655583f, 
    0.02495232f, 0.09487992f, -0.05355862f, 0.08066539f, 0.26114076f, 0.24270675f, 0.18402363f, 0.06701136f, 
    0.15163898f, 0.12846613f, -0.01151426f, 0.08918211f, -0.00948168f, -0.04978838f, -0.00448547f, 0.03766073f, 
    -0.01222953f, 0.35442176f, 0.07092654f, 0.01488423f, 0.01579722f, 0.14325465f, 0.27008063f, 0.16275041f, 
    -0.01525818f, -0.01592179f, -0.03988886f, -0.02228845f, -0.23534578f, 0.04010665f, 0.02404736f, -0.15406981f, 
    -0.02919091f, -0.04991925f, -0.04928501f, 0.08839435f, -0.02426210f, 0.00213311f, -0.00389971f, 0.02396497f, 
    0.16473837f, 0.11949567f, -0.01405810f, 0.11793577f, -0.05978763f, 0.04558503f, 0.07854669f, 0.06210434f, 
    0.10838316f, 0.12637310f, -0.16715620f, -0.13257802f, 0.07337610f, 0.03368550f, 0.02682980f, -0.06872058f, 
    -0.00433285f, -0.06470656f, -0.05186030f, -0.11227208f, -0.06407982f, 0.07559475f, 0.05984728f, 0.12589049f, 
    -0.01032718f, 0.16291568f, 0.02639287f, 0.12336597f, -0.05025206f, 0.03143636f, 0.04634876f, -0.03317508f, 
    0.00397145f, -0.00890742f, -0.12025448f, -0.13431415f, 0.35171801f, 0.10617941f, 0.14834155f, -0.00431170f, 
    0.07992112f, 0.05949230f, -0.05501457f, 0.02116704f, -0.00744155f, 0.05773567f, -0.06077272f, -0.06743988f, 
    0.19691224f, 0.14959231f, 0.03845974f, -0.05249681f, 0.02466322f, 0.01298401f, 0.01779654f, 0.01860366f, 
    0.04466670f, -0.02562852f, -0.12994161f, 0.06007561f, 0.15971722f, 0.36984295f, -0.24089554f, 0.16482612f, 
    0.00992557f, 0.00709950f, 0.03948138f, -0.01577321f, 0.01092229f, -0.06212607f, -0.04528562f, 0.11315476f, 
    0.03848282f, 0.14549163f, -0.12048057f, -0.13448168f, -0.08194678f, 0.06633159f, -0.04981538f, 0.07911525f, 
    0.10752217f, 0.06605936f, 0.16957368f, -0.00035568f, 0.04401251f, -0.20416488f, 0.23898298f, -0.04981596f, 
    0.05090090f, -0.02308082f, -0.15138926f, -0.00915714f, 0.08263768f, -0.13731414f, -0.11608063f, 0.02595077f, 
    -0.38334632f, 0.43924031f, 0.24952555f, 0.18766271f, -0.14456835f, -0.06899045f, 0.08000357f, 0.04377330f, 
    -0.09727019f, -0.03075509f, -0.02074781f, -0.10436261f, -0.25881541f, 0.40319952f, -0.12294660f, 0.18929490f, 
    0.00059423f, 0.06848519f, -0.12231708f, 0.02002157f, 0.01335136f, 0.07126484f, -0.03128468f, -0.02900758f, 
    0.17510878f, -0.04404547f, 0.03109208f, 0.00338405f, -0.10606600f, 0.11452814f, 0.08505532f, -0.07474391f, 
    -0.11387576f, 0.05984435f, 0.13922533f, 0.05295020f, 0.00458292f, 0.03359059f, -0.21933910f, 0.09966772f, 
    0.09553359f, 0.23935200f, 0.17281269f, 0.17289610f, 0.04464981f, 0.12079400f, 0.04097751f, 0.01013727f, 
    0.01020890f, -0.02086380f, 0.05141403f, -0.04299751f, -0.10001312f, -0.09068076f, -0.15042591f, 0.00902447f, 
    -0.04351729f, 0.00150187f, -0.07393009f, -0.05714506f, -0.00406867f, -0.00803741f, -0.03562440f, 0.04034213f, 
    0.05562586f, -0.07685686f, -0.00972639f, -0.01386090f, 0.14187944f, 0.03671795f, 0.05984768f, 0.03633704f, 
    0.04091960f, -0.08411505f, -0.06141749f, 0.04788038f, -0.07994195f, -0.02685099f, -0.13135341f, -0.05264286f, 
    -0.01754742f, -0.06572562f, 0.10821924f, 0.08831614f, 0.08813484f, -0.25906095f, -0.10030887f, 0.16813250f, 
    0.06896894f, 0.04867719f, -0.06132441f, -0.07783924f, 0.11305781f, 0.05676039f, -0.11810046f, -0.03806272f, 
    0.09465560f, 0.25945517f, 0.22472446f, 0.03307559f, 0.07176263f, -0.03170672f, -0.06302495f, -0.07615613f, 
    0.04832486f, -0.09463168f, 0.19203357f, 0.03024701f, 0.05650821f, -0.05210788f, -0.12590981f, 0.00471966f, 
    0.02211674f, 0.02137350f, -0.01720739f, -0.04449780f, -0.06430251f, 0.02913702f, -0.01772101f, -0.02886548f, 
    0.14722529f, 0.02298837f, 0.03368166f, -0.04858296f, -0.05248105f, 0.00579703f, 0.03520034f, -0.08174393f, 
    -0.08266757f, 0.03090803f, 0.00799617f, -0.08105593f, 0.02927931f, -0.00525274f, 0.06956457f, 0.05707366f, 
    -0.02017434f, 0.02576420f, -0.04333635f, -0.02726159f, -0.07527023f, 0.01671525f, -0.05919743f, -0.09787363f, 
    0.04273743f, 0.06120520f, -0.03682325f, -0.02804123f, -0.06235766f, -0.12127936f, -0.03242658f, -0.03064079f, 
    0.07686905f, 0.05616424f, -0.04246559f, 0.03839214f, 0.36281690f, -0.16236891f, 0.58121842f, -0.16064116f, 
    0.03578917f, 0.09623409f, -0.14109579f, -0.03738523f, -0.05712824f, -0.05907110f, -0.00276277f, -0.01144003f, 
    0.14362183f, -0.14426544f, -0.10943428f, -0.08100538f, 0.11205264f, 0.04327653f, 0.02399821f, -0.04847637f, 
    -0.04930402f, -0.01087031f, 0.03592343f, 0.07252882f, -0.30366182f, 0.16720892f, 0.01842933f, 0.17671899f, 
    -0.06383166f, 0.05160055f, -0.05507147f, 0.00364379f, 0.06927300f, -0.04072656f, 0.20939682f, -0.01926068f, 
    -0.23644844f, 0.37343702f, 0.00933791f, 0.01925084f, 0.08133264f, -0.07987650f, 0.16359384f, -0.02770712f, 
    -0.02078873f, 0.05668356f, 0.01388297f, -0.01914749f, -0.35952592f, 0.30264777f, -0.25709447f, -0.02600642f, 
    0.05362837f, 0.01360640f, -0.00420540f, 0.22367443f, 0.07226048f, 0.01296724f, -0.00943008f, 0.03943958f, 
    0.12031535f, -0.25887105f, 0.33717009f, -0.04436415f, 0.00686949f, -0.03556450f, 0.03422027f, 0.00050301f, 
    -0.09408864f, -0.01802444f, 0.01054306f, 0.05200991f, -0.17955922f, 0.13729285f, -0.08509312f, -0.00255907f, 
    -0.11050321f, -0.03436702f, -0.03120630f, -0.03283260f, 0.05020982f, -0.12396854f, 0.11728906f, 0.08478978f, 
    0.10185593f, 0.10530250f, -0.03039083f, 0.10375242f, -0.10000718f, 0.24766283f, 0.04022019f, -0.08355141f, 
    -0.09094075f, 0.02180276f, 0.09028324f, 0.07223549f, 0.27454558f, -0.21074024f, -0.03585146f, -0.00249022f, 
    -0.01244072f, 0.12992202f, -0.07385388f, -0.07602070f, 0.04359633f, 0.08318413f, 0.10279188f, 0.01821632f, 
    0.11321404f, 0.10662840f, -0.03247882f, 0.01265982f, 0.17407364f, 0.05757450f, -0.02558115f, 0.05581831f, 
    -0.00732803f, -0.03209197f, -0.06873183f, -0.03003434f, -0.07155256f, -0.09205899f, 0.07510748f, 0.02537696f, 
    0.12903497f, 0.00107774f, -0.01791218f, 0.00931351f, -0.08040070f, -0.00396538f, 0.02085769f, -0.01236471f, 
    -0.00856606f, 0.24328543f, 0.03710642f, 0.04586391f, 0.11056932f, 0.04344811f, -0.03067367f, 0.07529731f, 
    0.13907482f, 0.07508750f, 0.02762325f, 0.02363656f, -0.13285451f, 0.11147044f, 0.02391204f, -0.00253570f, 
    0.06028017f, 0.02887402f, -0.02936713f, -0.08688467f, 0.10209777f, -0.09471895f, -0.02844561f, -0.07489022f, 
    0.31027281f, -0.07740931f, -0.00975180f, 0.06735552f, 0.02758794f, 0.29070607f, 0.10119748f, 0.16214411f, 
    0.06852419f, 0.01611860f, -0.03365473f, 0.00554357f, -0.11875537f, 0.04609425f, -0.01870731f, -0.05671453f, 
    0.06096303f, 0.21210156f, -0.18249492f, -0.10837531f, 0.18491468f, 0.02407262f, 0.05702006f, -0.05764415f, 
    -0.03013313f, -0.09266486f, 0.13892995f, -0.04223365f, 0.00693391f, 0.03225887f, -0.06911479f, -0.01021358f, 
    -0.00507382f, -0.01199673f, 0.07770424f, 0.01853264f, -0.24545635f, 0.18311991f, 0.07535789f, -0.12295230f, 
    -0.05247801f, -0.07023965f, 0.03465810f, 0.05822181f, 0.00522992f, 0.03123913f, -0.23621623f, 0.03778348f, 
    0.26295656f, 0.11569730f, 0.00739655f, -0.03642315f, 0.09434838f, 0.12314416f, -0.01674327f, 0.18142650f, 
    -0.03615727f, -0.01083583f, 0.02168087f, -0.12177870f, -0.05119446f, -0.05579759f, 0.20930846f, -0.24089490f, 
    0.02064090f, -0.01350923f, 0.03427153f, 0.03430519f, 0.04887417f, -0.07659636f, 0.03560982f, 0.04723338f, 
    0.14972328f, 0.23905267f, -0.00675084f, 0.06620512f, 0.11167678f, 0.04467861f, -0.04686972f, 0.06059476f, 
    -0.06576996f, -0.06399991f, 0.08557454f, 0.00661446f, -0.16363135f, 0.19734383f, -0.26274642f, 0.04173277f, 
    0.09280468f, 0.00839682f, 0.02517028f, -0.14001617f, 0.17377776f, 0.02735949f, 0.07878975f, 0.10120482f, 
    -0.48997584f, 0.28501755f, 0.22959097f, -0.09557362f, -0.16620022f, -0.07559863f, -0.07512198f, -0.02051490f, 
    -0.11322447f, -0.04177165f, -0.07034072f, 0.01123776f, -0.03529595f, 0.24041045f, -0.03654153f, -0.00572216f, 
    0.07287546f, 0.15403686f, -0.00499469f, 0.06785968f, -0.05900802f, -0.08593775f, -0.09886448f, -0.04164322f, 
    -0.06259179f, 0.01974309f, 0.03823449f, 0.03949366f, -0.03011660f, -0.08887835f, -0.06926061f, -0.02929219f, 
    -0.10876840f, -0.04273779f, 0.04383338f, 0.01660217f, 0.04886660f, 0.22185248f, 0.06354795f, 0.21232940f, 
    0.17377102f, -0.21052687f, 0.07757752f, 0.00931836f, -0.03230434f, 0.06549029f, 0.02694310f, -0.11516345f, 
    -0.38218611f, 0.17015307f, 0.30055818f, 0.14507486f, -0.02123342f, -0.00469521f, -0.04808432f, 0.01065504f, 
    -0.19298069f, -0.04793193f, -0.13509050f, 0.00544162f, 0.03026830f, -0.07718398f, -0.00870588f, -0.01623574f, 
    -0.03876172f, -0.10802855f, -0.02774470f, -0.02588411f, 0.05768697f, -0.00022910f, -0.03880956f, 0.01889194f, 
    0.03026449f, -0.01944940f, 0.02610024f, 0.00218480f, 0.02963025f, -0.03537168f, 0.02421401f, -0.00296487f, 
    -0.02803905f, -0.03128760f, 0.00092046f, -0.03496245f, -0.03993555f, -0.03964576f, -0.01135305f, -0.03186125f, 
    -0.01846055f, -0.00882745f, -0.01281865f, -0.01170376f, 0.03009906f, -0.02511111f, -0.00417791f, -0.03215480f, 
    0.01894341f, -0.01807735f, 0.00246891f, -0.03601068f, 0.00073596f, 0.02878611f, 0.01533889f, -0.02207550f, 
    -0.00381308f, -0.02287224f, -0.03632627f, -0.00976114f, -0.02398859f, 0.03074614f, 0.02885217f, 0.02182605f, 
    -0.01620163f, -0.01854805f, 0.01605023f, -0.00462927f, -0.03593739f, -0.03036083f, 0.02369169f, -0.02480251f, 
    -0.00911351f, -0.00479039f, -0.01128721f, 0.00930988f, 0.03090825f, 0.00978532f, 0.02122346f, -0.03510572f, 
    -0.03363526f, -0.03720878f, 0.02357212f, -0.01605503f, -0.03872053f, -0.02982441f, -0.03810985f, 0.00655391f, 
    -0.01843743f, -0.01219166f, 0.01540032f, 0.01821274f, 0.00025843f, 0.00923857f, 0.01822295f, 0.00434352f, 
    0.02154170f, -0.01327363f, -0.00317952f, -0.02853700f, -0.02156312f, -0.01388367f, 0.02993934f, -0.03494693f, 
    -0.01524908f, 0.01977742f, -0.00203885f, 0.00576069f, -0.02801737f, -0.01122431f, -0.04062740f, 0.01026510f, 
    0.01901592f, 0.02512840f, -0.03927190f, 0.00205618f, -0.00928637f, 0.01583430f, 0.00387316f, -0.03928265f, 
    0.02791378f, -0.02094761f, 0.00742817f, -0.01884715f, -0.03260094f, -0.03285489f, -0.03595447f, -0.03309729f, 
    -0.01929653f, 0.01294790f, -0.02995870f, -0.01543579f, -0.03186344f, -0.00195868f, -0.03867742f, -0.03197119f, 
    -0.01306534f, 0.02402531f, -0.03084851f, -0.01865990f, -0.00096898f, -0.02820345f, 0.02203810f, 0.02268656f, 
    0.00224412f, 0.01294702f, -0.02435027f, 0.02128005f, -0.00662839f, 0.00554266f, 0.02649022f, -0.01979062f, 
    -0.03673845f, 0.01960625f, 0.00488805f, -0.01379579f, -0.01890170f, 0.01373293f, 0.00329616f, -0.01183440f, 
    0.02623653f, -0.01255382f, 0.01136912f, -0.03980982f, -0.01854571f, 0.02827678f, -0.01508288f, -0.03892645f, 
    0.02519928f, -0.00002654f, 0.00319591f, 0.00414673f, 0.03051081f, -0.02199925f, -0.02066941f, -0.02732672f, 
    0.01415546f, 0.00837157f, -0.01075843f, -0.03376231f, -0.03084891f, 0.00475405f, -0.00336148f, -0.02854052f, 
    -0.02069657f, -0.00244823f, 0.01832511f, 0.00217816f, 0.02541897f, 0.01224726f, -0.03849297f, -0.03885037f, 
    0.00967592f, 0.01754615f, -0.01789305f, -0.00527332f, 0.00392687f, -0.02248419f, -0.01356496f, -0.02435051f, 
    -0.01680114f, -0.04131330f, 0.02910661f, -0.03192234f, 0.02583682f, 0.02161775f, 0.03101655f, -0.00406120f, 
    -0.01711082f, -0.00967983f, 0.02731210f, 0.01918168f, 0.01003378f, -0.03991800f, 0.01407731f, -0.01372821f, 
    -0.01119900f, 0.01410910f, -0.04080851f, 0.02216285f, -0.03328160f, 0.01022057f, 0.00719629f, -0.01274046f, 
    -0.03393796f, 0.00476578f, -0.03591460f, -0.00622693f, -0.04135565f, 0.03043516f, 0.02695760f, -0.02883146f, 
    -0.03153276f, -0.01208096f, 0.00323830f, -0.01355462f, -0.00260206f, -0.03078427f, -0.04069246f, -0.01932656f, 
    0.00789591f, -0.01341313f, 0.00413878f, -0.01105583f, 0.01454421f, -0.00451992f, -0.03611974f, -0.03301430f, 
    0.01676077f, -0.02863116f, -0.03789439f, -0.02485223f, 0.00330895f, -0.02431598f, -0.03710515f, -0.02376445f, 
    -0.03685123f, -0.00866198f, -0.01869468f, -0.03210044f, 0.02557840f, 0.02298705f, 0.02204887f, 0.00406828f, 
    -0.03785288f, -0.00428890f, -0.02302151f, 0.02442805f, -0.00466971f, 0.02666905f, -0.01487972f, -0.02316144f, 
    0.02420657f, 0.01912859f, 0.01242812f, -0.02481474f, -0.01171059f, -0.00909199f, -0.03566917f, -0.02152021f, 
    -0.02395272f, 0.01198392f, -0.01300984f, -0.02874137f, 0.02951815f, 0.02957851f, -0.01965879f, -0.01868038f, 
    -0.00691266f, 0.00633088f, -0.02492387f, 0.02000449f, -0.03938512f, 0.01602624f, -0.02209311f, -0.00310713f, 
    -0.00165785f, -0.02574992f, 0.01143879f, -0.00537535f, -0.03648160f, -0.01432330f, -0.02667738f, -0.01858329f, 
    -0.02919665f, -0.01843771f, -0.02251780f, -0.00064725f, -0.01898761f, -0.03064493f, -0.03737122f, -0.02654635f, 
    0.00046823f, -0.03955966f, -0.02964022f, -0.02608453f, 0.02751707f, 0.01688054f, -0.02901405f, -0.03559627f, 
    0.02804595f, -0.01421906f, -0.00884439f, -0.04201671f, -0.01373893f, -0.03515332f, -0.01445536f, -0.02616161f, 
    -0.02121092f, -0.00518835f, 0.00881164f, -0.04175375f, 0.02224004f, -0.00680613f, -0.00708535f, -0.00040180f, 
    0.02521840f, -0.02346387f, -0.03160757f, -0.00897895f, 0.02055744f, -0.04136627f, -0.01688915f, -0.00413778f, 
    -0.01038807f, 0.00136625f, 0.00750719f, 0.02644323f, -0.01236555f, 0.00520760f, -0.00566146f, 0.01924962f, 
    -0.03533459f, -0.00734036f, 0.01290661f, 0.01943922f, -0.02079848f, 0.00154250f, 0.01198748f, -0.00673256f, 
    0.00412614f, -0.01027960f, 0.02544607f, -0.00304858f, -0.03790563f, -0.03045613f, -0.04196724f, 0.02664126f, 
    -0.02392576f, 0.02702148f, -0.02108082f, 0.01606975f, -0.03913255f, -0.01354292f, -0.03726020f, 0.02133752f, 
    -0.00685783f, 0.02194563f, 0.01638087f, -0.01836202f, 0.00277467f, -0.03679162f, -0.03581165f, 0.02016972f, 
    -0.03260396f, -0.04187609f, 0.01210894f, -0.01915164f, 0.00009052f, -0.00420491f, -0.01439747f, 0.00519412f, 
    -0.01034384f, 0.00087275f, 0.01668027f, -0.01705015f, -0.02853446f, -0.03036789f, 0.01940433f, -0.00348593f, 
    0.02159222f, -0.03078958f, 0.00756594f, 0.01323126f, -0.03107409f, -0.03656018f, -0.02807503f, -0.00951516f, 
    0.02752462f, -0.00468823f, 0.02220253f, 0.01683170f, 0.00083166f, -0.03772303f, 0.00901395f, -0.01278006f, 
    -0.02250601f, 0.01466438f, 0.01675151f, 0.01291582f, -0.01663839f, -0.03699512f, 0.02042595f, 0.02633590f, 
    0.00972758f, -0.03741302f, 0.02486994f, -0.00165352f, 0.01081083f, -0.02562219f, -0.00580855f, -0.03062505f, 
    -0.00919776f, 0.00473855f, 0.02825417f, -0.03527461f, 0.02989242f, 0.01835914f, -0.03045656f, -0.03480162f, 
    -0.00031478f, 0.00263862f, -0.01926583f, 0.00572785f, 0.02270986f, -0.01698853f, 0.01707066f, -0.00878932f, 
    0.00532188f, -0.00679982f, -0.02838305f, -0.02512944f, 0.01421528f, -0.03904200f, -0.00371346f, -0.00265666f, 
    0.01155983f, -0.00048043f, -0.02726512f, 0.01503875f, -0.03782119f, -0.04239944f, -0.01201492f, 0.00557508f, 
    0.00784377f, -0.01359579f, 0.00051483f, 0.00550315f, -0.03264321f, 0.00613607f, -0.03399626f, -0.04016554f, 
    0.01951597f, 0.01901283f, 0.00102789f, -0.00908678f, -0.03037534f, 0.02523561f, -0.03905329f, 0.01055199f, 
    -0.01490969f, -0.01419625f, -0.03640456f, -0.02534861f, -0.00734461f, 0.01377690f, 0.00488009f, 0.01063352f, 
    -0.02148137f, -0.00184608f, 0.00273032f, 0.01293737f, 0.00170797f, -0.03570502f, -0.00952125f, -0.03029850f, 
    -0.01314495f, 0.02575264f, 0.00632166f, -0.03550766f, 0.00055279f, -0.04129505f, -0.00700782f, -0.04278609f, 
    0.00793738f, -0.00149954f, -0.03757436f, 0.02649504f, -0.00319941f, -0.01734184f, 0.00805517f, -0.00081835f, 
    0.00829838f, 0.00070951f, 0.02461093f, -0.00856382f, -0.03947145f, 0.02412183f, -0.01077004f, -0.00027071f, 
    -0.00820300f, -0.00661379f, 0.01806985f, -0.00745851f, -0.00813884f, -0.02403199f, 0.00903435f, 0.00102625f, 
    0.00367813f, -0.03320379f, -0.00335761f, -0.01914320f, -0.03986274f, -0.01877712f, -0.01308964f, 0.00547175f, 
    -0.03030746f, -0.01953722f, -0.00429261f, -0.02410886f, -0.02735126f, -0.00300436f, 0.02881820f, -0.00196231f, 
    -0.01310388f, -0.02791373f, 0.02710620f, 0.02450724f, -0.01452832f, 0.01345628f, 0.00592532f, -0.01130075f, 
    -0.00284605f, -0.00562842f, 0.00500561f, -0.00170672f, -0.03397693f, 0.01484066f, -0.03279456f, 0.02363385f, 
    -0.00686704f, -0.00742365f, -0.02867690f, -0.02002546f, -0.03052189f, -0.02021396f, -0.01899676f, 0.01522807f, 
    0.02730041f, -0.01023680f, -0.03840015f, -0.03947635f, 0.01467046f, 0.01287342f, 0.02524106f, -0.04264728f, 
    0.01224138f, 0.02326267f, -0.01070435f, 0.00457829f, -0.04047342f, 0.02550998f, 0.00839723f, 0.02507808f, 
    -0.03302024f, -0.00976029f, 0.01885075f, 0.00765865f, -0.02069748f, 0.02118973f, 0.01164460f, -0.00146194f, 
    -0.00396158f, -0.01704551f, -0.01485278f, -0.03916240f, 0.01233771f, -0.00800789f, -0.04101184f, 0.01594028f, 
    -0.01863222f, 0.00618737f, 0.00301458f, -0.01593039f, 0.01237682f, -0.01372102f, -0.02050780f, -0.03992673f, 
    0.00808259f, 0.00294344f, -0.02729293f, -0.02415385f, -0.00606441f, -0.03934063f, 0.02875562f, 0.01691111f, 
    -0.02472179f, 0.00107689f, -0.01841046f, -0.01675057f, 0.00232080f, -0.02821831f, -0.02408184f, -0.00029818f, 
    0.03091723f, 0.02780861f, -0.02073685f, -0.00006041f, -0.03768188f, 0.01763833f, 0.02117454f, 0.01077365f, 
    -0.03289996f, 0.01808778f, 0.01313100f, -0.00115492f, -0.01515740f, 0.01005426f, 0.01396802f, -0.02909481f, 
    0.02852884f, -0.01668817f, 0.01331942f, 0.01312548f, -0.02584869f, 0.00946402f, 0.02180851f, -0.02533328f, 
    0.01793217f, 0.02038711f, -0.03791353f, -0.01331169f, -0.01798961f, 0.00317761f, -0.01020826f, -0.00615350f, 
    -0.03369768f, -0.00614562f, 0.02041071f, 0.00417913f, -0.04292079f, -0.02943418f, -0.02627401f, -0.02206225f, 
    0.02451381f, -0.01848660f, -0.01646844f, 0.02864278f, 0.01842354f, -0.02237060f, 0.00151394f, -0.03732022f, 
    0.01129786f, -0.01675654f, 0.00553129f, 0.01328608f, -0.02549225f, -0.03153081f, -0.02058530f, -0.03986271f, 
    -0.03043277f, 0.01169106f, 0.00319981f, 0.01067292f, 0.00422175f, -0.00318029f, -0.03455891f, 0.02168719f, 
    0.02503117f, 0.01846588f, -0.00726377f, -0.00665980f, 0.02207332f, -0.03661093f, -0.02275626f, 0.01593826f, 
    0.01265349f, -0.01231199f, -0.02854408f, -0.00465543f, 0.02936236f, 0.00571121f, -0.00643959f, 0.02473833f, 
    0.02666079f, -0.01239741f, 0.02122272f, -0.02685489f, -0.01018733f, -0.02511817f, -0.03856027f, -0.04211165f, 
    -0.00864759f, -0.03270758f, -0.01769867f, 0.02145977f, -0.04232498f, -0.03941021f, -0.01740998f, 0.00574845f, 
    -0.01400401f, 0.00709121f, -0.04115725f, -0.03662570f, -0.03008363f, -0.04149684f, 0.01904938f, -0.00321847f, 
    -0.01500636f, 0.01520310f, 0.00716491f, -0.00674755f, 0.01063297f, 0.01252733f, -0.02873429f, -0.01053485f, 
    0.01299844f, 0.00378782f, -0.00086883f, -0.01776731f, -0.02509665f, -0.01558900f, -0.03527622f, -0.03873802f, 
    -0.02436736f, -0.00278764f, 0.01387289f, -0.00286883f, -0.01733991f, 0.02673289f, -0.01564237f, 0.00353088f, 
    0.02188339f, 0.01832951f, -0.02229573f, 0.00239965f, -0.03330086f, -0.02584622f, 0.02020467f, 0.01399328f, 
    -0.02080728f, -0.01167735f, -0.03512543f, -0.01410630f, -0.00044720f, 0.02691030f, -0.01099383f, -0.01853294f, 
    -0.03625488f, 0.00357017f, 0.02439298f, 0.02283379f, 0.02745883f, -0.01309015f, -0.00649563f, -0.03931276f, 
    0.02525952f, 0.01358630f, 0.02099849f, 0.02298541f, -0.01488624f, 0.01555247f, -0.02831657f, 0.01911352f, 
    0.02699979f, 0.01609639f, -0.02541057f, 0.02609834f, 0.02904218f, -0.03412372f, 0.02739789f, -0.02331273f, 
    -0.02091223f, -0.01139086f, 0.11828160f, -0.13594763f, 0.03240198f, 0.00158654f, 0.09243488f, 0.10830595f, 
    0.13188642f, 0.00566695f, 0.14688489f, -0.03087131f, 0.33885151f, -0.16730118f, 0.08132191f, 0.17969637f, 
    0.05666131f, -0.09835575f, -0.01637643f, 0.04882208f, -0.00254881f, -0.05010992f, 0.09799352f, 0.27608430f, 
    -0.16327780f, 0.21519449f, -0.28359035f, -0.12691747f, 0.12770192f, 0.00617187f, -0.09870096f, 0.11214889f, 
    -0.08284966f, 0.10317322f, -0.18871751f, -0.03086055f, 0.16028771f, 0.21840411f, -0.05145495f, -0.00715634f, 
    0.01931171f, 0.02921120f, 0.06809200f, -0.02114443f, 0.09361721f, 0.02630534f, -0.16473149f, -0.14377113f, 
    -0.27378684f, -0.01828188f, 0.14609665f, 0.08772948f, 0.06975745f, -0.04583635f, -0.02340546f, 0.08154888f, 
    -0.05062140f, 0.00125041f, 0.00818001f, 0.03857558f, -0.03973439f, 0.16731818f, -0.11009294f, 0.25523892f, 
    0.22302952f, 0.01412835f, 0.01618593f, 0.13556944f, -0.01241601f, -0.04414769f, 0.01098636f, 0.03440651f, 
    -0.00317947f, -0.10036968f, 0.34352362f, 0.07764883f, -0.01489424f, -0.01296931f, -0.13381256f, 0.09398232f, 
    0.00264229f, 0.08297682f, 0.04201015f, 0.00635991f, -0.24246609f, 0.12990396f, 0.00981526f, -0.17849310f, 
    0.05562501f, -0.01793758f, 0.04980440f, 0.10368004f, 0.16716927f, -0.01845062f, 0.05889732f, -0.02634880f, 
    -0.01822049f, -0.03928750f, 0.34717214f, -0.20075171f, -0.02211670f, -0.01018610f, 0.04161478f, -0.02520472f, 
    0.08142655f, 0.00286134f, 0.18487953f, -0.01536819f, -0.23030709f, -0.27143696f, -0.13296150f, -0.06356163f, 
    -0.05266437f, -0.05979856f, -0.12994538f, -0.10196769f, -0.00864113f, 0.00352791f, 0.13255113f, 0.08053008f, 
    0.08753998f, 0.05456147f, 0.21220823f, 0.06896034f, 0.17797954f, 0.00775781f, -0.00819111f, -0.06102728f, 
    0.00461271f, -0.07605742f, 0.00882492f, -0.01498731f, 0.12554197f, -0.05891231f, 0.01681990f, 0.02796796f, 
    -0.07850262f, -0.11615516f, 0.04350339f, 0.12760226f, 0.10772560f, -0.07987038f, 0.02307480f, 0.14880954f, 
    0.04032258f, 0.32467580f, -0.33785707f, -0.07200795f, 0.05494642f, 0.08517085f, -0.16557208f, -0.07281458f, 
    0.05907343f, 0.12484043f, -0.06590138f, -0.22039062f, -0.12115253f, -0.14598295f, 0.04221997f, 0.28114292f, 
    -0.05025643f, -0.04957517f, -0.00944065f, 0.17260338f, -0.04970443f, -0.06507324f, -0.03341036f, 0.15137576f, 
    -0.31456265f, -0.03942933f, 0.12916496f, 0.17660356f, 0.04106095f, 0.11110564f, 0.13321404f, 0.12628786f, 
    0.01082920f, -0.03403401f, -0.01076770f, -0.04302126f, -0.07468329f, -0.19328576f, 0.11827559f, 0.38882199f, 
    0.06048676f, 0.08204038f, 0.16156334f, 0.21608724f, 0.06062240f, 0.02690609f, -0.06899804f, -0.05328757f, 
    -0.09205618f, 0.08373756f, 0.23129387f, 0.07870504f, -0.03726405f, 0.02931528f, -0.00802090f, -0.07102740f, 
    0.05078794f, 0.04050153f, 0.07037541f, 0.01911693f, -0.10798553f, -0.08162954f, -0.03112753f, -0.06299829f, 
    0.02547074f, 0.05959161f, 0.01672740f, -0.04374056f, -0.10598817f, -0.05216125f, 0.05631383f, -0.02423856f, 
    -0.04327306f, 0.50618458f, -0.11152525f, 0.07885391f, -0.08123688f, -0.01589469f, -0.03284232f, 0.00798352f, 
    -0.11346131f, 0.06397335f, -0.00534057f, 0.05595856f, 0.10282762f, 0.15721999f, 0.16298842f, 0.12911847f, 
    0.01598020f, -0.13469386f, 0.10543865f, 0.01861643f, 0.13013248f, 0.02401190f, 0.20924875f, 0.08167899f, 
    -0.02049632f, -0.05823740f, 0.01165854f, 0.20814164f, -0.03461735f, -0.10076311f, -0.07137774f, 0.16722673f, 
    -0.04804888f, 0.02442111f, -0.00566220f, 0.25461560f, -0.13089526f, 0.45411643f, 0.28130931f, -0.06265220f, 
    0.08500250f, -0.01444824f, -0.02169318f, 0.04785119f, -0.04736708f, -0.06710052f, 0.04055374f, 0.01631755f, 
    0.15280278f, 0.20785853f, 0.10723225f, -0.02086747f, -0.16900900f, -0.05923454f, 0.00642427f, -0.14317213f, 
    0.02253580f, 0.00997171f, -0.00718993f, 0.15522353f, 0.06470224f, 0.03693309f, -0.34315476f, -0.06158744f, 
    -0.02718368f, -0.07466580f, 0.01699517f, -0.13992336f, 0.14710277f, 0.10432365f, 0.14017348f, 0.11832220f, 
    -0.41280991f, 0.00349901f, 0.10457647f, -0.15243556f, -0.02336445f, 0.03395869f, -0.22049280f, -0.03156421f, 
    0.05369630f, 0.12912974f, 0.11960439f, -0.08924549f, -0.28638536f, 0.15886977f, 0.09553415f, -0.12214341f, 
    -0.04327223f, 0.04726059f, 0.21410482f, 0.01483039f, -0.02770028f, 0.06667234f, -0.00846447f, -0.08573326f, 
    -0.02548274f, -0.03591644f, -0.34819514f, -0.15160520f, 0.12211496f, 0.00324925f, -0.10503720f, -0.15766159f, 
    -0.14203227f, -0.19896230f, 0.00065289f, 0.00839103f, -0.03026428f, 0.22466627f, -0.00259381f, -0.09953328f, 
    0.13222417f, -0.03508131f, 0.10018799f, -0.00963058f, 0.05489485f, 0.02199821f, -0.04562232f, -0.14136778f, 
    -0.21044314f, -0.22953995f, -0.11555459f, -0.09724034f, -0.15982914f, -0.04473260f, -0.02665496f, -0.03059399f, 
    0.08541053f, 0.12547040f, 0.03654670f, 0.05857601f, -0.01745726f, -0.08283982f, 0.18729205f, -0.22418623f, 
    0.16464919f, -0.06439144f, -0.31252170f, 0.01331311f, 0.14983693f, 0.00258340f, -0.00302770f, 0.11944924f, 
    -0.17160566f, -0.16461281f, -0.20747195f, -0.02481541f, -0.01084612f, -0.01395792f, -0.01563566f, -0.02888584f, 
    0.14927460f, 0.00279101f, 0.17523485f, 0.03103708f, -0.04215192f, 0.41050908f, 0.09819723f, 0.10507561f, 
    -0.01354101f, -0.14301836f, 0.00006165f, 0.07999764f, 0.00095273f, 0.16181570f, 0.00617121f, 0.11632271f, 
    0.05761638f, -0.11502679f, 0.20972858f, 0.05562552f, 0.01895895f, 0.14689574f, -0.05674939f, -0.04538804f, 
    0.07633954f, 0.13691902f, 0.16053599f, 0.14347503f, 0.53230286f, 0.35080099f, 0.05367602f, 0.24371113f, 
    -0.14928673f, -0.21759616f, -0.06800050f, -0.06914753f, 0.13541032f, -0.06968329f, -0.00300354f, 0.11056092f, 
    -0.08592374f, 0.05753703f, -0.10267768f, -0.06568301f, -0.06653095f, -0.08728803f, -0.08361172f, -0.00006814f, 
    -0.10939912f, 0.01549010f, -0.04093136f, -0.02271776f, 0.15396798f, 0.11419674f, -0.05720589f, 0.09514480f, 
    -0.05182887f, -0.09824152f, 0.01153121f, -0.00977837f, -0.05022550f, 0.04222251f, 0.03664635f, 0.02256472f, 
    -0.23632108f, -0.18631257f, 0.06606904f, -0.02501602f, 0.19837244f, -0.04800263f, -0.04475274f, -0.05472792f, 
    0.00013350f, -0.13818496f, -0.08715121f, 0.05864970f, -0.12782347f, 0.18590268f, -0.18330392f, 0.08900182f, 
    0.12174537f, -0.05422993f, -0.04625687f, -0.00825956f, 0.05610497f, 0.03404578f, -0.04908806f, 0.04401729f, 
    -0.06300096f, 0.04275093f, 0.10368877f, 0.05739573f, 0.22571513f, 0.15333402f, 0.16162142f, 0.08712738f, 
    0.09770734f, 0.01043157f, 0.08363687f, 0.05391768f, 0.06001914f, -0.00125369f, 0.19177704f, -0.10204358f, 
    -0.09653821f, 0.03816503f, -0.04875927f, -0.09649948f, 0.00942154f, 0.01326049f, 0.01003890f, 0.11801211f, 
    -0.26462138f, 0.00956995f, 0.35094714f, 0.00158262f, -0.03255803f, 0.00667490f, -0.10850023f, 0.05858205f, 
    0.06686538f, 0.01227675f, 0.10922569f, 0.08908539f, -0.08066760f, -0.21509248f, 0.34541926f, -0.03641159f, 
    0.00998642f, -0.05597178f, -0.04037145f, 0.07462025f, 0.13182993f, -0.03062826f, 0.03289181f, -0.03028245f, 
    0.03226078f, 0.04447183f, -0.15974882f, 0.02077994f, 0.06160470f, -0.02448092f, 0.07900931f, -0.10623148f, 
    0.12339022f, 0.07454837f, 0.12426398f, -0.01332950f, -0.07256397f, -0.20638646f, -0.07354442f, -0.15636764f, 
    0.00741370f, 0.02546278f, 0.07333893f, 0.09095645f, 0.18652178f, 0.09203648f, 0.15348649f, 0.04530226f, 
    -0.26773947f, -0.26960453f, -0.18122670f, -0.02722332f, 0.23923521f, -0.01891821f, 0.06792098f, -0.02994687f, 
    -0.00641828f, -0.34403598f, -0.13088235f, -0.16389434f, -0.25614119f, 0.12225560f, 0.12518141f, -0.06114532f, 
    0.04672224f, 0.07840789f, 0.00539505f, -0.02662942f, -0.09105904f, -0.05804465f, 0.06607297f, -0.10280414f, 
    -0.14539929f, -0.06864902f, 0.11663059f, 0.09962621f, 0.03700059f, 0.02330778f, 0.00493094f, 0.09132696f, 
    0.12472344f, 0.00825463f, 0.07759417f, 0.12468176f, 0.26808375f, -0.09341347f, 0.11668015f, 0.31126115f, 
    -0.03336189f, -0.01378400f, -0.06716571f, 0.11715635f, 0.00011085f, 0.05581922f, -0.03573892f, 0.23074079f, 
    -0.00246980f, -0.06759758f, 0.12188119f, 0.01470359f, 0.26866567f, 0.05171272f, -0.00595180f, 0.08501358f, 
    0.01427876f, 0.09686512f, -0.06564181f, 0.07762907f, 0.18855922f, -0.31270000f, 0.04778934f, -0.17006844f, 
    0.07710036f, 0.08077998f, 0.02985158f, 0.09757110f, 0.01683661f, 0.10915841f, 0.00606829f, 0.03711421f, 
    0.06310543f, 0.15720315f, 0.22260538f, 0.05177592f, -0.06682052f, -0.06710216f, 0.04304278f, 0.03552284f, 
    0.01435623f, 0.03608662f, -0.12781224f, 0.04591540f, 0.00613106f, 0.11532074f, 0.20202680f, -0.00190874f, 
    -0.05872257f, 0.10563001f, 0.07593120f, -0.10199636f, 0.01596230f, 0.04390144f, 0.07800301f, 0.00047072f, 
    -0.09970248f, -0.06594129f, -0.07467755f, -0.00495445f, 0.07128360f, -0.04065363f, -0.17622003f, -0.01129745f, 
    -0.08848291f, -0.18046716f, 0.02644078f, 0.02246138f, -0.14858618f, -0.17385958f, 0.04304665f, 0.22717182f, 
    -0.07187008f, 0.00353022f, 0.02460540f, -0.07953097f, 0.27176762f, 0.23260476f, 0.12134001f, 0.13916813f, 
    -0.04848721f, -0.13807197f, 0.16043469f, -0.00040626f, 0.08490903f, -0.01621222f, -0.00697908f, 0.09597781f, 
    0.00778965f, -0.01960120f, 0.14505315f, 0.02824776f, -0.00331388f, 0.14614941f, 0.21429434f, 0.41174310f, 
    -0.01026560f, 0.13075794f, -0.26147109f, 0.07279664f, 0.09929726f, 0.04098141f, -0.06922362f, -0.10143414f, 
    0.04546020f, 0.01881737f, 0.20871316f, 0.18832602f, 0.05476691f, -0.03928623f, 0.01384227f, -0.04281983f, 
    0.05293710f, -0.12492528f, -0.11501914f, 0.11761871f, 0.05176090f, -0.01902905f, 0.21395187f, -0.25348744f, 
    0.03080845f, 0.21665567f, -0.12158699f, -0.07990555f, -0.11947060f, 0.03465408f, -0.10458260f, 0.01648623f, 
    -0.08616064f, -0.16936751f, -0.07506120f, 0.29067874f, -0.10897797f, -0.02226952f, -0.06575415f, -0.06276806f, 
    0.04074004f, -0.09042063f, -0.14737867f, -0.00440078f, -0.09899759f, 0.01128805f, 0.14175543f, 0.14198352f, 
    -0.04151818f, 0.05930344f, 0.19031711f, 0.02841173f, 0.00928921f, 0.10221461f, 0.05700185f, 0.05532029f, 
    -0.04031137f, -0.20471092f, -0.24719496f, -0.24827529f, 0.04997861f, -0.00072270f, -0.14169562f, 0.02631320f, 
    0.20028111f, 0.03557064f, 0.02351303f, 0.23619393f, -0.08596750f, 0.09257292f, 0.11272261f, 0.03071301f, 
    0.07034030f, -0.05657167f, -0.13608210f, 0.12156314f, 0.04734554f, 0.00226531f, 0.02267485f, 0.04021601f, 
    -0.13314460f, -0.15326482f, 0.02772984f, 0.19820429f, -0.07992896f, -0.04262917f, 0.01251572f, -0.06793056f, 
    0.13140900f, -0.02433003f, 0.14549379f, 0.10904945f, -0.48960644f, -0.47310114f, -0.27722412f, -0.02809758f, 
    0.00979831f, -0.06135145f, -0.01177201f, 0.03895060f, -0.01519144f, -0.02048823f, -0.08995198f, 0.08673722f, 
    0.18574993f, -0.07699937f, -0.29838514f, -0.14267702f, 0.01463082f, -0.13614798f, 0.02179292f, 0.11943006f, 
    -0.03580637f, 0.00579250f, -0.14636527f, -0.03673992f, -0.21428481f, 0.12103334f, -0.07239303f, -0.01309939f, 
    0.01698885f, -0.07353278f, -0.04645263f, 0.00012872f, 0.11916206f, 0.02455018f, 0.00532894f, 0.04978007f, 
    -0.12473570f, 0.07450394f, -0.16191404f, -0.03642175f, 0.07684230f, 0.01124335f, 0.01271440f, 0.14787450f, 
    -0.00523500f, 0.02590707f, 0.06048184f, 0.06993809f, -0.01064722f, 0.14307347f, 0.00805184f, -0.04530243f, 
    0.01943554f, 0.04113827f, 0.02806346f, -0.01066733f, 0.03374662f, 0.03291159f, 0.00489527f, -0.02854210f, 
    0.19995035f, 0.07756652f, -0.01137047f, -0.20560038f, -0.00610899f, -0.01233632f, -0.00844028f, 0.13068095f, 
    0.01994734f, -0.03007837f, 0.03552016f, -0.07410346f, 0.05717704f, -0.05193771f, 0.30490544f, 0.01473661f, 
    0.19675648f, 0.08021910f, 0.10109031f, 0.16209644f, 0.08653763f, -0.09089923f, 0.02873657f, 0.01601132f, 
    0.14716035f, -0.04615181f, 0.09530988f, 0.14346607f, -0.02965022f, -0.01823812f, -0.05534722f, -0.00376934f, 
    -0.06179957f, -0.08394038f, 0.03041321f, 0.07074265f, 0.19125293f, -0.54608893f, -0.10177012f, -0.30156574f, 
    -0.04636130f, 0.05659163f, -0.05781256f, 0.12181264f, 0.08924814f, -0.04254618f, 0.04247095f, -0.06636325f, 
    0.26104382f, -0.12187391f, 0.18778433f, -0.13819796f, 0.03342110f, -0.10836302f, -0.08077266f, 0.08566248f, 
    0.04200016f, 0.04853151f, 0.00473342f, -0.03618383f, -0.11022850f, -0.15274034f, -0.02229402f, -0.03735890f, 
    -0.03220555f, -0.03282024f, 0.01126731f, -0.07121556f, 0.11431415f, -0.04483659f, 0.13364421f, 0.09811269f, 
    0.14054868f, 0.17195271f, 0.00245786f, 0.01141529f, -0.05337550f, 0.15868390f, 0.08379736f, -0.00252267f, 
    0.13021737f, 0.01810547f, 0.10245449f, 0.04364141f, -0.15697365f, -0.03667492f, -0.11767942f, -0.23535538f, 
    -0.09178448f, -0.16122398f, 0.03155375f, 0.11697724f, 0.10540131f, 0.12535526f, -0.01679663f, 0.04540005f, 
    0.00274659f, 0.13373952f, -0.25135949f, -0.06563425f, -0.03164840f, 0.06556720f, 0.11628452f, 0.07485142f, 
    0.10433844f, -0.03909324f, -0.05510239f, 0.01850329f, -0.04806609f, 0.17511553f, 0.01792874f, -0.06352999f, 
    -0.00133017f, 0.00420436f, -0.01202682f, 0.13810512f, 0.00961887f, -0.15756232f, -0.04493705f, -0.11089534f, 
    0.09377950f, 0.12428635f, 0.10429082f, -0.03737160f, -0.01707818f, 0.06018949f, 0.08422665f, 0.15570176f, 
    0.04743750f, -0.00823513f, 0.00257758f, 0.07392094f, -0.03996175f, -0.12726662f, -0.10678806f, -0.10052167f, 
    0.13548245f, 0.03257471f, 0.00384363f, 0.12672952f, 0.00513286f, -0.13788235f, -0.00200063f, -0.11478175f, 
    0.26758143f, -0.00046390f, 0.02010836f, -0.20624441f, -0.00000814f, 0.04485182f, -0.08871763f, -0.00426419f, 
    -0.00209439f, -0.00786487f, 0.02491160f, -0.13189048f, -0.20640032f, -0.01182875f, -0.04462922f, 0.07191423f, 
    0.21217020f, 0.04947471f, 0.11230473f, 0.02140630f, 0.06551652f, -0.07991850f, 0.13583201f, -0.07367598f, 
    0.21251656f, -0.22499003f, 0.19816898f, 0.20921440f, -0.00695168f, -0.01201403f, -0.01513546f, -0.00211055f, 
    0.04356748f, 0.05735215f, -0.05409012f, -0.12561092f, -0.08769157f, 0.18349275f, -0.05383008f, -0.08038181f, 
    0.08286730f, -0.13475692f, 0.02479110f, 0.04624818f, 0.05309280f, -0.04528842f, -0.15542248f, -0.13131645f, 
    -0.25180563f, 0.11686804f, 0.07628004f, -0.04170334f, -0.03275114f, 0.03251757f, -0.00356638f, 0.05929745f, 
    0.02589758f, 0.01500153f, -0.19278051f, -0.04221120f, 0.36984250f, -0.36473888f, 0.04786310f, -0.06648323f, 
    -0.07694911f, 0.02075275f, -0.03838547f, 0.00591181f, 0.14999074f, -0.05521353f, -0.05625037f, -0.02989128f, 
    0.09896721f, 0.09108987f, 0.05417822f, -0.25668189f, -0.08311748f, -0.06127009f, 0.07606747f, -0.00213193f, 
    0.06411151f, -0.10519787f, 0.07707299f, 0.07602660f, -0.32179165f, 0.05822349f, -0.16025980f, 0.10092510f, 
    0.00621299f, -0.00257018f, -0.11121584f, -0.05681646f, 0.04552461f, -0.10212994f, -0.24146613f, 0.09817651f, 
    0.08013269f, -0.05358325f, 0.00372915f, 0.33450362f, 0.04540538f, 0.03686816f, -0.18152638f, -0.06183520f, 
    0.33801770f, 0.19529666f, 0.00598065f, 0.00322555f, 0.18336678f, -0.47881660f, 0.09820665f, -0.25411913f, 
    0.06151869f, 0.10778376f, -0.01194266f, 0.10239232f, 0.11742172f, -0.09952036f, 0.10989720f, -0.00721117f, 
    -0.10623188f, -0.00523724f, -0.01445168f, 0.09405850f, 0.04679900f, 0.17056665f, 0.09182163f, 0.12468087f, 
    -0.02459266f, -0.04854312f, 0.05005851f, 0.17709883f, 0.12101953f, 0.18956330f, 0.07593038f, 0.09876328f, 
    0.05999029f, -0.05512705f, 0.06633829f, 0.06193091f, 0.12778428f, 0.09337269f, -0.00506134f, 0.04239998f, 
    -0.15282778f, -0.05500084f, 0.01502639f, -0.06634583f, 0.04483448f, -0.00280365f, -0.08404223f, -0.05753985f, 
    -0.00465416f, -0.06632017f, -0.01944260f, -0.03173526f, 0.07637938f, -0.18446165f, 0.15249746f, -0.09331702f, 
    -0.04291173f, -0.01771251f, -0.09330741f, 0.12529460f, 0.11130434f, 0.15884866f, 0.03864269f, 0.16607915f, 
    -0.21250644f, 0.01913713f, -0.05706924f, 0.08984842f, 0.02061412f, -0.03983926f, -0.05395724f, -0.08392806f, 
    0.08106966f, -0.22070234f, -0.01195161f, 0.12473971f, 0.03383579f, 0.00214782f, 0.06455775f, -0.06817796f, 
    -0.00343433f, -0.07915121f, -0.05075355f, -0.03976398f, -0.04843479f, 0.04649897f, -0.02533586f, -0.01556822f, 
    0.16907495f, -0.01175866f, 0.04745158f, -0.16802828f, 0.03085222f, -0.05285424f, -0.18526834f, -0.05189651f, 
    -0.01992787f, -0.05543775f, 0.00446463f, -0.11141723f, -0.20980208f, 0.07689756f, -0.06969678f, -0.11135230f, 
    -0.11666556f, -0.15511796f, 0.09864063f, -0.05040891f, 0.03650072f, 0.03664557f, 0.04352800f, 0.04335655f, 
    -0.12546316f, -0.10401703f, 0.14776970f, 0.07273871f, -0.00463370f, -0.05251801f, -0.12334350f, 0.06178872f, 
    0.07716650f, 0.11603525f, 0.09750000f, 0.04233075f, -0.31973994f, -0.01228550f, 0.03700568f, 0.16794297f, 
    -0.01897363f, 0.00138209f, -0.04168519f, 0.00935852f, 0.00811328f, 0.08109676f, -0.12714586f, -0.04844984f, 
    -0.15857257f, -0.23581629f, 0.06307431f, 0.05043957f, 0.03108402f, 0.06532627f, -0.00307796f, 0.03733896f, 
    0.02825313f, 0.02941700f, -0.04311404f, 0.01290542f, -0.18258139f, 0.21015611f, -0.36004445f, 0.01473477f, 
    -0.01645004f, -0.05454122f, -0.00675482f, 0.13742688f, 0.02532352f, -0.03931285f, -0.09111387f, 0.10541087f, 
    0.16873769f, 0.33850765f, 0.04701559f, -0.04498725f, -0.01139785f, -0.04118021f, 0.09660933f, 0.11941309f, 
    -0.03381853f, -0.01389956f, -0.01542095f, -0.03097050f, 0.09571330f, -0.12392662f, 0.10559156f, -0.01797120f, 
    -0.07072745f, 0.04310491f, -0.07337982f, 0.02682880f, 0.02863729f, 0.08101854f, 0.05471076f, 0.12152293f, 
    0.06129064f, 0.04567799f, 0.21018849f, 0.14520624f, -0.00064841f, -0.08449647f, 0.06575525f, -0.14678201f, 
    0.17336388f, 0.06010841f, 0.05649494f, -0.02166487f, 0.17548373f, 0.05795635f, 0.16226147f, 0.11049493f, 
    0.01229238f, 0.00362497f, -0.11690355f, 0.02366161f, -0.03267279f, -0.06071640f, -0.01438989f, 0.06159987f, 
    -0.21905419f, 0.11076125f, -0.21592292f, 0.13084267f, 0.12856615f, 0.00897584f, 0.04895260f, -0.09288561f, 
    0.04924233f, -0.16470288f, 0.03259567f, -0.09228987f, -0.02129473f, -0.21733721f, 0.06837315f, -0.08938199f, 
    -0.03587824f, -0.09478267f, -0.08493678f, 0.01514596f, 0.03192947f, -0.11578031f, 0.10565916f, -0.04727815f, 
    0.02800890f, -0.10814146f, -0.09232052f, -0.13712411f, -0.03751129f, 0.07756547f, 0.16705190f, 0.14817078f, 
    0.12854944f, 0.01650875f, 0.09123226f, 0.12611265f, -0.22451928f, 0.19641335f, -0.45457396f, -0.11315012f, 
    0.09873214f, -0.01549783f, 0.19862969f, 0.06540497f, -0.00150507f, 0.00765065f, -0.01241878f, 0.07290973f, 
    0.05281362f, 0.18322699f, 0.07008266f, -0.08535028f, -0.01195892f, 0.03645917f, 0.01519097f, 0.04670889f, 
    0.03072564f, 0.00906580f, -0.03558112f, -0.02501902f, -0.00541971f, -0.04275776f, -0.11058175f, -0.09968001f, 
    -0.02208598f, 0.02991417f, -0.04982387f, 0.00741396f, -0.01319607f, 0.08032416f, 0.08542896f, 0.09626581f, 
    0.26396182f, 0.20693555f, 0.24947827f, -0.17874862f, 0.05893449f, -0.00195625f, -0.08902695f, 0.06413773f, 
    0.00068266f, 0.10730599f, -0.04395424f, 0.04613104f, 0.04179749f, -0.03030076f, 0.21046089f, -0.08080181f, 
    0.10897285f, 0.12814343f, -0.01994618f, 0.10753137f, 0.09738688f, 0.01391535f, 0.02313629f, 0.11737438f, 
    0.04449410f, 0.07489605f, 0.12744719f, -0.06635782f, -0.02855553f, 0.19667070f, -0.02966879f, -0.10170147f, 
    0.05861923f, -0.11251651f, -0.01871930f, -0.02526499f, 0.07346985f, 0.10804114f, 0.18014601f, -0.31826261f, 
    0.01744622f, 0.17264959f, -0.05959203f, 0.06460779f, 0.01754165f, 0.02987107f, 0.08799897f, 0.04284534f, 
    -0.10073616f, -0.03601507f, -0.01381993f, 0.04400456f, -0.04851346f, -0.05488709f, -0.03400830f, -0.02107732f, 
    0.14626402f, -0.06401620f, 0.01908729f, 0.22588509f, -0.07513486f, -0.02484405f, 0.10052422f, 0.04598175f, 
    0.06156535f, -0.02562245f, -0.08757930f, -0.10998151f, -0.16583289f, -0.12545151f, 0.06479668f, -0.10293831f, 
    -0.16068143f, 0.26028085f, -0.02167736f, 0.08437520f, -0.05492100f, 0.00884602f, 0.03346404f, 0.16751923f, 
    0.08274697f, 0.02444119f, 0.02326647f, -0.07503439f, 0.20594551f, 0.03660689f, 0.06916681f, 0.17560220f, 
    -0.08433846f, -0.00038899f, -0.00626343f, 0.06915079f, -0.09415532f, -0.02879584f, 0.05556096f, 0.04030860f, 
    0.06442251f, 0.03288773f, -0.08083308f, -0.04419343f, -0.11234654f, 0.07706799f, 0.06657335f, 0.09762816f, 
    0.01400804f, -0.05101117f, 0.03533293f, 0.06063763f, 0.47460312f, -0.16479237f, -0.13058494f, -0.02964222f, 
    0.00144035f, 0.20816953f, -0.00212564f, -0.08298730f, 0.01577290f, -0.06231341f, -0.08678882f, 0.34289658f, 
    -0.36499107f, 0.03814906f, 0.25374213f, 0.17559695f, 0.29122031f, 0.08608324f, -0.01548456f, 0.03677498f, 
    0.18811369f, -0.06922217f, -0.13063544f, 0.06178435f, 0.08176357f, 0.15110047f, 0.17019024f, 0.01439210f, 
    0.01950064f, 0.01231075f, 0.03850757f, 0.00008474f, 0.09800459f, -0.01677483f, -0.01692423f, 0.02360725f, 
    -0.07964116f, -0.13958025f, 0.01121433f, -0.14456522f, 0.03121203f, -0.01346590f, 0.00952571f, -0.02244026f, 
    0.08320719f, 0.02966360f, -0.02430112f, 0.08928857f, 0.09483202f, 0.07769808f, -0.00066293f, -0.02847431f, 
    -0.02190481f, -0.00666018f, 0.04128786f, 0.00657781f, 0.02521905f, 0.07603275f, 0.03648656f, 0.00019652f, 
    -0.19907573f, -0.23488285f, 0.10928963f, 0.15774900f, -0.04188480f, 0.05307052f, 0.00676583f, -0.08916511f, 
    0.06275579f, -0.23791832f, 0.02304100f, 0.02203355f, -0.39041728f, -0.30806744f, -0.00853555f, 0.02218019f, 
    0.05887943f, 0.01814595f, 0.02474518f, -0.00037637f, -0.05859781f, 0.06098787f, -0.04633916f, 0.05233464f, 
    -0.02900992f, -0.03735823f, 0.02832197f, -0.01461228f, -0.03568581f, -0.01972109f, 0.02255070f, -0.02984563f, 
    -0.00518526f, 0.00389168f, -0.03230627f, 0.02302006f, -0.02252418f, -0.00425250f, -0.01258202f, 0.03006095f, 
    -0.02372563f, -0.01224089f, -0.00970407f, -0.01036735f, -0.03766477f, 0.01187521f, -0.00874219f, 0.00147317f, 
    0.01066906f, 0.02801848f, -0.03765585f, 0.02287698f, 0.02231802f, -0.01716497f, -0.03149869f, -0.02414395f, 
    -0.02550895f, -0.04000119f, -0.02706745f, 0.00340600f, 0.00661330f, 0.00264976f, 0.01042106f, -0.03732327f, 
    -0.00210849f, -0.01179619f, -0.03267470f, -0.03120824f, -0.01639692f, -0.01789331f, -0.01410393f, 0.02913966f, 
    0.00007318f, -0.01112246f, -0.02277923f, -0.01098178f, -0.02131797f, -0.01453093f, -0.03754491f, -0.00452230f, 
    -0.00339052f, -0.01751947f, -0.03042973f, -0.01223523f, -0.02371427f, -0.02754632f, -0.04134052f, 0.02855064f, 
    0.01979214f, -0.00887103f, -0.03969340f, -0.01595290f, -0.02605113f, -0.03297815f, -0.02407929f, -0.01416304f, 
    0.00960007f, -0.03977832f, 0.02450421f, 0.01249391f, -0.02934307f, 0.00185397f, -0.01234079f, -0.02005912f, 
    0.00665939f, 0.01226580f, -0.00693543f, -0.02884289f, -0.03169783f, 0.02682646f, -0.01823318f, 0.02278399f, 
    0.02756414f, -0.02297242f, -0.01363335f, 0.02929306f, 0.02352281f, -0.00865569f, 0.00047353f, 0.02204850f, 
    -0.02730217f, -0.00453400f, 0.00653284f, -0.02238093f, 0.01368814f, -0.03786143f, -0.02973316f, -0.01571489f, 
    -0.01443413f, -0.02798798f, -0.02481410f, -0.00448171f, 0.01545520f, -0.01701820f, -0.00636237f, 0.00700636f, 
    -0.02058752f, -0.02345720f, 0.00018466f, 0.03773709f, 0.00826686f, -0.02131756f, -0.03322443f, 0.01186661f, 
    -0.02094396f, -0.04060855f, -0.01527547f, -0.03391099f, 0.02826539f, -0.01296954f, 0.01535118f, -0.00865036f, 
    -0.01969145f, 0.02073839f, 0.01700215f, 0.02610628f, -0.02074177f, -0.02251401f, -0.00062753f, -0.02738695f, 
    -0.01167872f, -0.03443532f, -0.00985271f, -0.04137444f, -0.03624801f, 0.02073789f, -0.00611334f, -0.03065035f, 
    0.00490863f, 0.02854926f, -0.03075997f, -0.00182309f, 0.02749786f, -0.00701318f, -0.03486331f, 0.00601735f, 
    0.01366133f, 0.02439005f, -0.03168798f, 0.01731063f, 0.02969269f, -0.00295200f, 0.01967350f, 0.02528069f, 
    0.02575724f, -0.00481442f, 0.02601601f, -0.04183716f, -0.03066651f, -0.02619148f, 0.00804360f, 0.02729031f, 
    -0.03827111f, 0.02667186f, -0.02433669f, 0.02754023f, 0.01380145f, -0.01555429f, 0.02866912f, 0.00156783f, 
    -0.01639647f, -0.03799747f, -0.01107401f, -0.00332369f, -0.02824803f, -0.02396336f, -0.01379663f, -0.01438786f, 
    -0.03695928f, 0.02594559f, -0.02215324f, 0.01619002f, -0.03187290f, 0.01525894f, 0.01747657f, -0.03675402f, 
    -0.00763022f, 0.01708389f, -0.04053429f, -0.03787964f, -0.00905613f, 0.02740899f, 0.02601887f, -0.03166597f, 
    -0.02488152f, 0.02690902f, -0.03614296f, -0.03517379f, -0.00498391f, 0.01399525f, -0.01831202f, 0.01323205f, 
    -0.01105949f, 0.02337534f, -0.00264108f, 0.02676468f, -0.02061899f, 0.02393633f, -0.03521126f, -0.03005928f, 
    -0.02973465f, -0.04012390f, -0.01333679f, -0.03741029f, 0.01058740f, 0.01042439f, -0.03870403f, -0.02347959f, 
    0.02261019f, 0.00233257f, -0.02615521f, 0.00858825f, 0.02146344f, 0.01966481f, 0.02380540f, -0.03208895f, 
    0.00269981f, -0.01499208f, 0.01638039f, -0.00560415f, 0.02913373f, 0.00518159f, -0.00576910f, -0.04117401f, 
    -0.02727989f, -0.02576660f, -0.03941102f, 0.01526610f, -0.00096016f, -0.02086266f, -0.01243624f, -0.02158907f, 
    -0.00619292f, -0.03329598f, -0.04047837f, -0.03026003f, 0.00259209f, 0.01302173f, 0.00759216f, 0.01702240f, 
    0.00860825f, -0.03527332f, -0.00346023f, 0.00548853f, 0.01333973f, -0.03887672f, 0.01581026f, -0.01731418f, 
    0.01452873f, 0.02597110f, 0.01545899f, 0.02870740f, -0.02928584f, -0.02241193f, -0.02065367f, -0.00027840f, 
    0.01631582f, 0.00120469f, -0.02449946f, -0.01639834f, 0.00822937f, -0.01347676f, -0.03197238f, 0.00511980f, 
    0.00669973f, -0.03303857f, 0.02212530f, -0.00914363f, -0.03729388f, -0.01869342f, 0.02946770f, -0.02052764f, 
    -0.02971813f, -0.00895850f, -0.02535446f, -0.02640330f, -0.00033760f, -0.02910035f, 0.02099296f, -0.00458277f, 
    0.02366386f, -0.01754673f, 0.00826489f, -0.02020327f, -0.01989128f, -0.02241093f, -0.01467519f, -0.00642991f, 
    0.00535963f, -0.01897255f, 0.02542031f, -0.03590458f, -0.02949344f, 0.01570889f, 0.02695297f, -0.03680201f, 
    0.00570361f, -0.02595865f, 0.01066188f, 0.02121028f, 0.00435190f, -0.03332848f, -0.01745469f, -0.02878442f, 
    0.01624353f, 0.01720902f, 0.00264839f, -0.01486941f, -0.03934319f, 0.00723831f, 0.02686722f, -0.04094102f, 
    0.01882938f, -0.01333944f, -0.02045642f, 0.01631948f, -0.00406720f, 0.01345398f, -0.00607333f, -0.00406129f, 
    -0.02908596f, -0.00158988f, -0.02527416f, -0.02985090f, 0.00629888f, -0.04162714f, -0.01869539f, -0.01279871f, 
    0.01922089f, -0.00781380f, -0.00135221f, 0.02541446f, 0.02041174f, -0.00700739f, 0.01025867f, -0.01598441f, 
    0.02454238f, -0.02440153f, -0.00811584f, 0.00249243f, -0.01058872f, -0.03640842f, -0.02400406f, -0.01016893f, 
    -0.03792800f, -0.01056571f, -0.02827131f, 0.01003479f, -0.00256222f, -0.03222288f, -0.02262721f, 0.02101955f, 
    -0.02590164f, -0.00701977f, -0.04148820f, 0.02390211f, 0.00744170f, 0.01286144f, 0.02916231f, -0.00025203f, 
    0.00435862f, -0.01653033f, -0.01373745f, -0.00400298f, -0.03673416f, -0.02693875f, -0.01279929f, 0.00070009f, 
    -0.03176207f, 0.00171830f, -0.01289477f, -0.03160273f, 0.02611453f, -0.00784198f, -0.01377601f, -0.03910054f, 
    -0.02521717f, -0.03071304f, -0.03233385f, 0.00683860f, -0.02201078f, -0.01104422f, -0.01326923f, 0.01242068f, 
    0.00098377f, -0.02290935f, -0.01651937f, 0.00962621f, 0.02426982f, 0.00152950f, -0.01189675f, -0.01579998f, 
    -0.04184281f, 0.00426860f, -0.01932539f, 0.02937712f, 0.00816303f, -0.03704932f, -0.02373871f, -0.03244584f, 
    -0.02280916f, -0.03569626f, -0.01660279f, -0.02310179f, 0.01777824f, 0.00574653f, -0.01682569f, 0.00574439f, 
    0.02054674f, 0.00239757f, 0.00517056f, 0.01994830f, -0.02498162f, 0.00599655f, 0.02539475f, -0.03514700f, 
    0.02770966f, -0.04195242f, 0.00350464f, 0.00715527f, 0.00546371f, -0.01966557f, 0.01827813f, 0.00693885f, 
    0.01092333f, 0.01693339f, 0.00988118f, 0.00589939f, 0.02210657f, -0.03694950f, 0.00948393f, -0.03530218f, 
    -0.01891879f, -0.01599895f, -0.03777267f, 0.02671715f, -0.04096425f, 0.02794522f, -0.01010221f, 0.02587648f, 
    0.01217091f, -0.01278173f, -0.03163338f, -0.01248134f, -0.03113190f, -0.02794163f, -0.03663054f, 0.02549819f, 
    -0.01959898f, -0.01905307f, -0.00053455f, 0.02416400f, -0.00976835f, -0.00591372f, 0.00910671f, -0.00517065f, 
    0.02880822f, 0.01009672f, -0.02221869f, 0.00518743f, 0.02074881f, -0.01889134f, -0.03371748f, 0.02169413f, 
    -0.00796323f, 0.02557621f, -0.02103020f, -0.03601022f, 0.01903788f, -0.00112701f, 0.01737509f, -0.00353227f, 
    0.00996615f, -0.02259608f, -0.04030192f, -0.01105364f, 0.00926962f, 0.00252483f, 0.01026767f, -0.01591985f, 
    0.02049067f, -0.02655208f, 0.01480807f, -0.02586485f, -0.01855552f, -0.00701935f, -0.02408422f, -0.00621139f, 
    0.02555070f, -0.02095128f, -0.02228552f, -0.03324470f, 0.02668812f, 0.02937061f, -0.01814980f, -0.00911616f, 
    -0.01646763f, -0.00213661f, 0.01854115f, 0.01872626f, 0.02861367f, -0.01513123f, -0.03078126f, 0.02855306f, 
    -0.01211596f, 0.00027606f, -0.02214087f, 0.01948380f, 0.01723179f, 0.01612257f, 0.01923677f, -0.01920146f, 
    -0.02043646f, -0.03252009f, 0.02326257f, -0.02442900f, -0.03582218f, 0.02948426f, 0.00378661f, -0.03595228f, 
    -0.01281666f, -0.01364645f, 0.02743648f, -0.00414885f, -0.01193696f, -0.02453548f, -0.02037228f, -0.02882731f, 
    -0.02878012f, 0.00187891f, 0.00952761f, 0.02707592f, -0.01395620f, 0.00621859f, 0.00580224f, 0.00621569f, 
    0.00120470f, -0.03650138f, -0.00611965f, 0.01834823f, -0.00946870f, -0.03116394f, -0.01662872f, -0.00821472f, 
    0.00951815f, 0.01461721f, -0.02678953f, -0.01601535f, -0.00997259f, -0.03475302f, -0.03667745f, -0.01833183f, 
    -0.03865990f, 0.03007020f, 0.00603977f, -0.03400718f, -0.00470541f, 0.01898491f, -0.03913262f, -0.03137563f, 
    -0.02393107f, -0.00123538f, -0.03384731f, -0.02143097f, -0.02329594f, -0.03831019f, -0.03767816f, 0.02911304f, 
    -0.03994329f, 0.02356518f, -0.03076393f, -0.02508572f, -0.00993462f, -0.00673931f, -0.00936460f, 0.01444527f, 
    0.01823541f, -0.03245549f, 0.00721269f, 0.00840465f, -0.00002376f, -0.03721862f, 0.00606948f, 0.01951239f, 
    0.00793150f, 0.00745607f, -0.00533797f, 0.00560549f, -0.01928085f, -0.01731681f, 0.02978966f, 0.01399436f, 
    -0.01650997f, -0.00244183f, 0.01294802f, -0.02544563f, -0.00266402f, -0.02509981f, -0.02939697f, -0.00115089f, 
    0.02896310f, -0.03922078f, 0.00877444f, 0.01043770f, -0.00656136f, 0.01429389f, -0.01169252f, -0.01791704f, 
    -0.02080483f, -0.00813088f, 0.00557628f, -0.00038026f, 0.02089448f, 0.00120118f, -0.00048496f, 0.01576334f, 
    -0.02093227f, 0.01390480f, -0.03167314f, -0.02987029f, -0.01981347f, -0.03004638f, -0.02738512f, 0.01313429f, 
    -0.01823325f, -0.01190049f, -0.01645331f, -0.03735718f, -0.03425745f, -0.00983311f, -0.01536847f, 0.01016801f, 
    -0.00400183f, 0.01353103f, 0.02275264f, 0.00531373f, -0.00414260f, -0.02199038f, -0.02213768f, 0.00959551f, 
    -0.02708062f, 0.01165867f, -0.02004424f, -0.01898352f, 0.02890342f, -0.03929624f, -0.01972720f, 0.00162830f, 
    -0.00013216f, -0.02784716f, -0.01039851f, -0.00070762f, 0.01952440f, -0.00429511f, 0.02848073f, -0.00646463f, 
    -0.03054092f, 0.01654372f, 0.02998454f, -0.03435233f, 0.01555644f, 0.00759440f, 0.01545175f, -0.02430349f, 
    -0.02285308f, 0.00671105f, 0.00326610f, 0.01787281f, 0.00427955f, 0.01046302f, -0.02688715f, -0.03910109f, 
    -0.00024266f, -0.01963796f, -0.00988965f, 0.00956201f, -0.02647353f, 0.01969550f, 0.00239712f, -0.01015890f, 
    -0.01631340f, -0.00235871f, 0.00630992f, 0.01780326f, 0.02903304f, -0.01684765f, -0.00160404f, -0.01383928f, 
    -0.04091273f, -0.01214840f, -0.01598805f, -0.04174841f, -0.02231872f, 0.01113862f, 0.01256005f, 0.00169935f, 
    0.01822424f, -0.00605348f, -0.00030817f, 0.02735830f, 0.01753924f, 0.01096904f, 0.02455256f, 0.00065523f, 
    -0.03087457f, 0.01805422f, 0.01213889f, 0.00526461f, 0.00844458f, 0.02756823f, -0.03745060f, 0.02826075f, 
    -0.01473336f, -0.00606151f, -0.02882256f, -0.01665790f, -0.03588563f, 0.00092559f, -0.02977882f, -0.03405235f, 
    -0.00996010f, 0.02787713f, -0.03831828f, 0.02947015f, -0.00327670f, 0.02094748f, 0.00082184f, 0.00572874f, 
    0.02766745f, 0.01843072f, 0.00860752f, -0.00847738f, -0.01181358f, 0.02499251f, 0.02024927f, -0.02534551f, 
    0.00795035f, -0.02028011f, 0.02700473f, -0.01655530f, 0.00326385f, -0.02494122f, -0.03646954f, 0.00007167f, 
    -0.01071079f, 0.02937014f, -0.01274187f, -0.01577096f, 0.01275777f, -0.01812641f, -0.01625059f, -0.01654142f, 
    -0.21290849f, -0.19310454f, 0.16744702f, 0.30911475f, -0.11998807f, 0.03671337f, -0.08636966f, 0.01044887f, 
    -0.03829273f, 0.00657527f, -0.11182315f, -0.01330613f, 0.34590831f, -0.12057175f, 0.25443339f, 0.10614397f, 
    0.06723536f, 0.02173286f, -0.00668410f, 0.01641175f, -0.10957687f, 0.06189875f, -0.03559691f, -0.17062521f, 
    0.06674451f, -0.02761798f, 0.10336303f, 0.06465515f, -0.23365347f, -0.04714815f, -0.00428093f, 0.00580078f, 
    -0.01691833f, 0.02397949f, 0.03404286f, 0.04479763f, -0.00584808f, -0.19916870f, 0.02674830f, 0.14435954f, 
    0.10062145f, 0.09027229f, 0.08552788f, 0.06094593f, -0.07530379f, 0.01805994f, -0.03597368f, 0.05813447f, 
    0.14166659f, 0.08267026f, 0.04939047f, 0.18909472f, 0.06228119f, 0.02809775f, 0.00716757f, -0.05035910f, 
    -0.05659552f, 0.03719525f, -0.01846742f, 0.03720163f, 0.05710183f, 0.28272179f, -0.16710585f, -0.09552439f, 
    -0.08517768f, 0.10687568f, -0.05387322f, 0.07999071f, -0.01063729f, 0.03272030f, -0.05164088f, 0.07029770f, 
    -0.18683448f, 0.00596218f, -0.10189474f, -0.01620443f, 0.02022753f, 0.05859522f, -0.00526017f, -0.04312051f, 
    -0.19308443f, -0.09433712f, -0.14131729f, -0.24706963f, 0.00962265f, 0.27636334f, -0.26833007f, 0.37155405f, 
    -0.07249139f, -0.03126140f, -0.04815031f, 0.00646653f, 0.05669808f, -0.06520617f, 0.15201537f, 0.04403047f, 
    -0.18585388f, 0.11164778f, -0.00869400f, 0.00565189f, 0.03683193f, 0.07261363f, -0.02391333f, 0.01475819f, 
    -0.00936186f, 0.02009563f, 0.04738093f, -0.05896821f, -0.25511602f, -0.19710393f, -0.04830169f, -0.12810799f, 
    -0.09452494f, 0.00716409f, -0.00300068f, 0.00098837f, 0.02151169f, -0.01132907f, 0.05425919f, 0.11891890f, 
    0.09219116f, 0.20124583f, -0.05050969f, 0.11763034f, 0.11718244f, 0.12157957f, 0.02944346f, -0.08781933f, 
    -0.03216284f, 0.14167762f, 0.02725491f, 0.10072815f, 0.38779542f, 0.01811407f, 0.18921144f, 0.16915941f, 
    0.11330073f, 0.08112898f, 0.06121136f, 0.04832520f, -0.11412859f, -0.01911886f, -0.03612092f, 0.03865228f, 
    0.17179653f, 0.07768582f, 0.15322573f, 0.05832287f, -0.09769072f, 0.05348375f, 0.02816270f, 0.10308667f, 
    0.01496492f, 0.14236674f, 0.13485728f, 0.02616166f, 0.23119859f, 0.06055733f, 0.01937546f, 0.07679798f, 
    0.08400564f, 0.09376341f, 0.04976465f, -0.01205059f, -0.07140283f, 0.03280501f, 0.03276687f, -0.00189396f, 
    0.07396834f, 0.12253553f, -0.11484812f, 0.00108595f, -0.01716856f, -0.00530776f, 0.01493697f, 0.08130502f, 
    -0.07461662f, -0.01580162f, -0.01734238f, 0.01915251f, -0.13097854f, 0.08373409f, 0.03600723f, -0.06463313f, 
    -0.13084690f, -0.06643702f, 0.01970658f, 0.03363681f, -0.01242250f, 0.01667131f, 0.02916031f, 0.01830148f, 
    -0.01288690f, -0.04375827f, 0.08993369f, 0.14447263f, 0.03593297f, 0.07914960f, 0.13723081f, 0.05036749f, 
    0.05208930f, 0.08759294f, -0.11318939f, -0.03713519f, 0.07316930f, -0.00469348f, 0.09011268f, -0.07149090f, 
    -0.03958106f, -0.15377502f, 0.02992934f, -0.13351510f, -0.00173183f, 0.09232704f, 0.12416174f, 0.10625174f, 
    -0.30724624f, 0.34296149f, -0.15490316f, -0.22252251f, -0.12074168f, 0.04941151f, 0.05646079f, -0.04268112f, 
    0.02636917f, -0.00209648f, 0.06882189f, -0.12154841f, 0.28049856f, -0.05712712f, 0.16949303f, 0.10358093f, 
    0.12891676f, 0.03985149f, -0.03849379f, 0.01092677f, -0.10853897f, 0.10212876f, -0.06051401f, -0.16337223f, 
    0.28465286f, 0.09064716f, 0.03124557f, -0.10832735f, 0.06593154f, 0.12929730f, 0.09799073f, -0.05189206f, 
    -0.00749372f, -0.04903951f, -0.08994640f, -0.05885237f, 0.10479544f, 0.39831889f, -0.12714899f, 0.28159976f, 
    0.01689105f, -0.01618025f, -0.02023156f, -0.01723205f, -0.01542785f, 0.06522864f, -0.02327274f, 0.10009265f, 
    0.08310650f, -0.00381255f, -0.01294403f, -0.00442788f, 0.05295722f, 0.03356525f, -0.00866773f, 0.06999456f, 
    -0.03577681f, 0.16268499f, 0.04107187f, 0.03274933f, -0.16838220f, -0.11696851f, 0.25340885f, -0.02456192f, 
    -0.03770516f, -0.05740575f, -0.03490226f, 0.00229755f, -0.08344588f, -0.12862083f, -0.02138270f, -0.01120135f, 
    -0.28564736f, 0.47296113f, -0.01695426f, -0.03492329f, -0.09760349f, 0.02357006f, 0.03281642f, -0.07019090f, 
    -0.10332800f, -0.09720130f, 0.11747965f, -0.14035225f, -0.28598619f, 0.50116283f, -0.17608614f, 0.26363090f, 
    -0.05007989f, -0.01457185f, -0.06556053f, -0.11770464f, 0.08389308f, 0.03342637f, 0.00020014f, -0.06438091f, 
    0.11875091f, -0.03614880f, 0.01152985f, 0.05686052f, -0.04890580f, 0.03005268f, 0.14498444f, -0.16184069f, 
    -0.04799940f, 0.15918830f, 0.15894209f, 0.01882573f, 0.08256362f, -0.06773225f, -0.10976057f, 0.03122162f, 
    0.02143807f, 0.13958509f, 0.14419894f, 0.19116758f, -0.05973998f, 0.01144720f, 0.09323817f, -0.02449326f, 
    -0.12907913f, -0.03482265f, 0.02850758f, -0.03409116f, -0.08513912f, -0.04815538f, -0.08240768f, 0.03565409f, 
    -0.02360842f, -0.00328906f, -0.02003006f, -0.05407878f, -0.12897822f, -0.11904179f, 0.02594231f, 0.02970854f, 
    0.02065835f, -0.07244742f, -0.00537280f, 0.00983613f, -0.00338245f, -0.07515926f, 0.16278437f, 0.02476355f, 
    -0.19621029f, -0.15252760f, -0.06268581f, -0.09564520f, -0.06157341f, 0.02645639f, 0.00002744f, -0.01759459f, 
    -0.05325521f, 0.06524715f, 0.03928809f, 0.04998262f, -0.15448485f, -0.25404707f, 0.06790067f, 0.24098703f, 
    0.04177144f, 0.04714540f, -0.07985301f, 0.05187390f, -0.02758346f, -0.04485032f, -0.06963561f, 0.01185362f, 
    0.09733129f, 0.26877412f, 0.10605102f, 0.06747166f, 0.06582747f, 0.08607647f, -0.01266369f, -0.10717822f, 
    -0.12771830f, -0.07753097f, 0.06384338f, -0.01603568f, 0.42880398f, -0.15234815f, -0.00996958f, 0.18162872f, 
    0.08374099f, 0.09981382f, 0.06276228f, -0.00189356f, -0.05610395f, 0.17204425f, -0.05372334f, 0.03813965f, 
    0.34263372f, 0.04498477f, -0.03037612f, 0.02623475f, 0.03982001f, 0.04354629f, 0.07408213f, -0.05165627f, 
    -0.09591061f, -0.05150654f, -0.07535677f, -0.09571856f, 0.26783180f, 0.06780478f, -0.03075853f, -0.05706346f, 
    -0.00676661f, 0.08638182f, -0.00627830f, 0.04870078f, -0.16287644f, -0.07688314f, -0.06477928f, -0.18172796f, 
    -0.11849906f, -0.05182132f, -0.11490085f, -0.15883419f, -0.14871062f, -0.08756085f, -0.03239066f, -0.00975796f, 
    0.04105603f, 0.03832833f, 0.03923522f, 0.02268161f, 0.20818329f, -0.06452003f, 0.35675752f, 0.03401120f, 
    -0.05705915f, 0.01622477f, -0.11487380f, 0.02150413f, -0.02581418f, -0.05311593f, 0.08753194f, 0.00883039f, 
    0.04579580f, -0.13783653f, -0.11246882f, 0.07239868f, 0.01115460f, 0.05001279f, 0.06158412f, 0.01090833f, 
    -0.01086601f, 0.03671088f, 0.00553868f, 0.07128891f, -0.22969489f, 0.26902521f, -0.04348554f, 0.12492605f, 
    0.06910265f, 0.02928613f, 0.00773632f, -0.05642555f, 0.08537138f, 0.07680587f, 0.18071876f, 0.03129521f, 
    -0.11023574f, 0.31528345f, -0.19899228f, -0.01994749f, 0.06685369f, 0.02566430f, 0.07669409f, 0.01555075f, 
    -0.12958179f, -0.11047148f, -0.07498305f, -0.05754903f, 0.01298218f, 0.20179109f, -0.28885540f, -0.11465424f, 
    0.07305869f, 0.09055373f, 0.06652056f, -0.01126655f, -0.06949529f, -0.00608003f, -0.10543976f, 0.04714981f, 
    -0.10814283f, -0.24924721f, 0.30307597f, 0.04828699f, 0.00651401f, 0.00078743f, 0.02185149f, 0.02558505f, 
    -0.08770509f, 0.19268154f, -0.07521120f, 0.09326924f, -0.27100548f, 0.12241870f, -0.11671032f, 0.00439482f, 
    -0.02900701f, 0.05590835f, -0.00436507f, -0.03731719f, 0.02633191f, 0.03830696f, -0.01684946f, 0.03678301f, 
    -0.02773812f, 0.04662225f, -0.03876780f, 0.16131063f, -0.05776491f, 0.02868994f, -0.07955395f, -0.09424908f, 
    -0.08100695f, 0.05458337f, 0.12308694f, 0.12640445f, 0.02013888f, -0.34983280f, 0.30011654f, 0.19519049f, 
    -0.05324784f, -0.01562858f, 0.07005095f, -0.08353540f, 0.01265857f, 0.08332087f, 0.05495124f, -0.03076983f, 
    0.15610653f, 0.02327448f, -0.09000506f, 0.04512580f, 0.06391378f, 0.01908529f, 0.02138630f, 0.04130262f, 
    -0.04703866f, -0.01109308f, -0.08187053f, -0.05576649f, -0.06183022f, -0.00988495f, 0.06045217f, 0.03020684f, 
    0.03130775f, 0.09263790f, -0.00118373f, 0.06874169f, -0.11094908f, -0.02595107f, 0.00322739f, 0.00014550f, 
    0.06551252f, 0.01873411f, -0.10821646f, 0.04662062f, 0.07290333f, 0.04915873f, 0.01597175f, 0.18493113f, 
    0.10588323f, 0.01386242f, 0.03360779f, -0.03940297f, -0.11695424f, -0.00080744f, 0.05012468f, -0.01350003f, 
    -0.03611553f, 0.05071663f, -0.02637745f, -0.05424903f, 0.02505900f, 0.05685386f, 0.05479464f, 0.01122899f, 
    0.18571679f, -0.07552353f, -0.01670300f, 0.14204672f, 0.11449776f, 0.06540124f, 0.03074889f, 0.12414533f, 
    -0.03279075f, 0.05228367f, -0.03849660f, 0.05963765f, -0.02212687f, 0.00072912f, 0.07529084f, -0.00532485f, 
    0.06497578f, 0.04858465f, -0.05100366f, 0.04301253f, 0.09298245f, -0.04886851f, 0.23492821f, -0.05514228f, 
    -0.02390577f, -0.02822082f, 0.15110052f, -0.09401216f, 0.02808719f, -0.02149571f, -0.01013418f, 0.04101714f, 
    0.03837406f, -0.00926634f, 0.11978688f, 0.11711210f, -0.12037930f, 0.20585240f, 0.01749983f, -0.21637638f, 
    -0.07647599f, -0.05885134f, 0.05532724f, 0.00096352f, -0.18125242f, 0.00010502f, -0.23618585f, -0.11454622f, 
    0.30699056f, -0.07307458f, 0.00547379f, -0.05667070f, 0.02169702f, 0.08321424f, -0.04425582f, 0.08444168f, 
    -0.04940179f, -0.00657477f, -0.03866444f, -0.01074894f, -0.09997562f, 0.10377760f, 0.14468189f, -0.43653521f, 
    0.02229964f, 0.03696135f, 0.03017685f, 0.03199048f, 0.00617202f, -0.03003651f, 0.09247629f, 0.00514338f, 
    0.24421296f, 0.09323418f, -0.07411622f, 0.02209160f, 0.06190219f, 0.13993494f, -0.04870054f, 0.01121835f, 
    -0.11629846f, 0.04897917f, 0.06201566f, 0.01476821f, -0.12933017f, 0.24001190f, -0.28068510f, 0.09461628f, 
    0.19082294f, 0.01782002f, 0.02261047f, -0.10437624f, 0.08389409f, 0.09662917f, 0.07883986f, 0.08399385f, 
    0.05664045f, 0.43646821f, 0.02183556f, -0.41419283f, -0.15213789f, -0.07431093f, 0.09541891f, -0.20485233f, 
    0.03111844f, -0.01065667f, 0.07721927f, 0.06428672f, 0.07348563f, 0.09483057f, -0.11118781f, -0.01855428f, 
    0.05764379f, 0.05380268f, 0.07871643f, 0.07343314f, -0.05901524f, -0.06770334f, -0.04791868f, 0.00640662f, 
    -0.27514678f, -0.04025882f, 0.04687668f, -0.04898860f, -0.08901857f, 0.01203232f, -0.07577105f, -0.01233048f, 
    -0.05543908f, 0.06886656f, -0.03292862f, 0.12985438f, 0.16374062f, 0.04392215f, -0.20712736f, 0.23629797f, 
    -0.00312308f, -0.05764996f, 0.03984725f, 0.00165133f, -0.12200452f, 0.02844391f, -0.06775887f, -0.01340867f, 
    -0.43664697f, 0.22297996f, 0.08737788f, -0.08823211f, -0.00018412f, -0.01325201f, -0.07897001f, -0.05872233f, 
    -0.14123048f, 0.00120605f, -0.17405875f, -0.02788343f, -0.15665905f, -0.16582151f, -0.06246647f, -0.18056579f, 
    -0.15546101f, -0.09041434f, 0.03397696f, -0.02219007f, 0.02262902f, 0.02823411f, 0.04268863f, 0.01373443f, 
    0.01391456f, -0.03032423f, -0.15615159f, -0.13974965f, 0.00791412f, 0.09611444f, -0.15073024f, -0.05486006f, 
    0.11418340f, -0.01425390f, 0.02533573f, -0.07154941f, -0.26014516f, 0.17178589f, 0.11372416f, -0.13031851f, 
    0.02944713f, -0.03576088f, 0.24850303f, 0.27821705f, 0.00038615f, 0.02675851f, 0.12693708f, 0.03118613f, 
    -0.12296286f, -0.09881531f, 0.09630556f, -0.01593386f, 0.14609499f, 0.21847926f, -0.02036064f, 0.14998591f, 
    -0.10913287f, -0.07069971f, 0.10167664f, 0.09290706f, 0.24105524f, -0.05259051f, 0.08424775f, -0.12226330f, 
    -0.00441326f, 0.04065613f, 0.06741998f, 0.03477328f, -0.15955508f, 0.11043510f, -0.11277774f, 0.03292668f, 
    -0.21275009f, 0.13997434f, -0.26438171f, -0.06884035f, 0.02397485f, 0.18456936f, 0.06172566f, -0.00861247f, 
    -0.16864471f, -0.10404260f, -0.03818727f, -0.00215183f, 0.37145662f, 0.02242901f, 0.19993688f, 0.02050948f, 
    0.13023044f, 0.03480458f, 0.12929624f, -0.07706018f, 0.29038906f, -0.15719742f, 0.15207958f, 0.10298415f, 
    -0.31394899f, -0.08844094f, -0.00062483f, -0.16288576f, 0.01467926f, -0.04908397f, -0.01147662f, 0.03691306f, 
    0.12737136f, -0.03081199f, 0.05735753f, -0.00827034f, -0.21393196f, 0.12425500f, -0.03923469f, 0.09841932f, 
    -0.02681062f, 0.13155369f, -0.10105034f, 0.03192629f, -0.06552843f, 0.08238289f, -0.09495492f, 0.01440090f, 
    -0.13420483f, -0.00622982f, -0.25508201f, 0.09018913f, 0.09890612f, -0.06905371f, 0.18806884f, 0.19249727f, 
    0.14227609f, 0.13825941f, 0.00938204f, -0.04456121f, -0.02504548f, -0.00022675f, -0.06876604f, 0.01338244f, 
    -0.11546059f, -0.05797055f, -0.07930271f, -0.03859675f, -0.02166210f, 0.00925765f, 0.05975004f, 0.00681197f, 
    -0.30097744f, -0.07525468f, 0.06550863f, 0.15345314f, 0.01475221f, -0.00810041f, -0.02434937f, -0.19243979f, 
    -0.03943226f, -0.08676156f, 0.11582808f, 0.05125173f, -0.37165850f, -0.22214501f, -0.24419780f, 0.11019327f, 
    0.12895562f, -0.03678006f, 0.08709716f, 0.00099506f, 0.05364305f, 0.17069118f, 0.04462891f, 0.03321659f, 
    -0.14640294f, -0.13935506f, 0.00300214f, -0.12961444f, 0.21422607f, 0.08178406f, 0.07866475f, -0.10782483f, 
    0.02675616f, 0.23918298f, -0.15727288f, -0.06711489f, -0.25140518f, -0.09039259f, -0.02726261f, -0.20939270f, 
    -0.03786394f, -0.03290299f, 0.05430858f, 0.04167987f, -0.15052530f, -0.14944115f, -0.02576731f, 0.11008582f, 
    0.12959591f, 0.10564511f, 0.12295832f, -0.11467776f, 0.07708525f, 0.06010529f, 0.05105450f, -0.12645099f, 
    -0.03436276f, -0.03325259f, 0.03696455f, -0.04627969f, 0.07991137f, 0.12728368f, 0.16349380f, -0.03385511f, 
    0.08325200f, -0.01969794f, 0.07287520f, -0.08363074f, -0.06697961f, -0.07846312f, -0.07405701f, -0.06326008f, 
    -0.04943998f, 0.10473327f, -0.21131533f, 0.10658536f, 0.04247925f, 0.10861770f, -0.02516774f, -0.01948414f, 
    0.02577864f, 0.07903557f, 0.12311481f, 0.03419081f, 0.04105139f, -0.04670239f, 0.08176196f, 0.05115863f, 
    0.05898397f, 0.09883270f, -0.08852219f, 0.00652727f, -0.00247417f, -0.11954325f, 0.10969470f, 0.16038600f, 
    0.11977364f, 0.00278710f, 0.22104013f, -0.00716793f, -0.02015603f, -0.11830303f, -0.05304690f, 0.03847391f, 
    0.00243879f, -0.11444352f, -0.10471994f, 0.19955082f, -0.19333878f, 0.06411365f, -0.26053777f, -0.23001124f, 
    -0.01858212f, 0.01439315f, 0.04185765f, 0.00285189f, 0.04315555f, -0.03743779f, -0.07101014f, -0.13251987f, 
    0.16094780f, -0.18258582f, 0.15286662f, -0.01718808f, 0.02746323f, -0.00006158f, 0.08560894f, 0.16414455f, 
    0.07529051f, -0.01364900f, 0.11385827f, 0.09517895f, -0.29627013f, 0.09913605f, -0.28297079f, 0.11440705f, 
    0.01945416f, 0.18437175f, 0.04199742f, -0.01804073f, -0.08156686f, -0.07509477f, 0.11139281f, 0.06394217f, 
    -0.40911481f, -0.13046974f, 0.00456797f, 0.38525188f, -0.07418602f, -0.02386964f, 0.00006007f, -0.06868927f, 
    0.09609409f, 0.07354427f, 0.16163325f, -0.01969504f, 0.06434716f, -0.19049634f, -0.03821208f, 0.02869777f, 
    0.02857521f, 0.01403171f, 0.05008908f, 0.04287098f, -0.15560201f, 0.05386713f, 0.12561616f, -0.06749674f, 
    0.10996456f, 0.11359124f, 0.40441710f, 0.36054710f, 0.38632774f, -0.07754930f, 0.13991332f, 0.11440387f, 
    0.18344255f, 0.00533673f, 0.06938605f, -0.04695333f, 0.11110251f, -0.12626390f, 0.09054149f, 0.11017401f, 
    0.16852225f, 0.11438049f, -0.07705753f, 0.18171808f, -0.02225827f, 0.09710597f, -0.01122633f, 0.04686086f, 
    0.03033566f, 0.02958944f, 0.10084251f, -0.04767802f, 0.00004219f, 0.01591397f, -0.04931372f, -0.01357089f, 
    0.07223391f, 0.07588806f, -0.06883778f, 0.18866317f, 0.11238246f, 0.10214344f, 0.14160007f, -0.11379064f, 
    -0.11905473f, -0.00720663f, -0.02178488f, -0.02497679f, -0.12286620f, -0.09653881f, 0.06369051f, -0.16225442f, 
    -0.08272945f, -0.08107132f, -0.10514635f, -0.05131564f, -0.01735124f, -0.05530604f, -0.00714474f, 0.00961425f, 
    -0.14591651f, -0.02088271f, 0.05181320f, -0.16419169f, -0.26608980f, 0.16418989f, -0.13410096f, -0.01556657f, 
    0.02841592f, -0.10761625f, 0.14312068f, -0.00231967f, 0.10872512f, 0.03088561f, -0.04933071f, 0.09721454f, 
    0.00789085f, -0.06272206f, -0.06272393f, -0.11219114f, -0.07977003f, -0.08134519f, -0.10096495f, -0.04993236f, 
    -0.13371110f, -0.08604603f, -0.07180486f, -0.11803257f, 0.24338385f, -0.07246009f, -0.17399007f, -0.10944421f, 
    -0.07665213f, -0.13259095f, -0.12907082f, 0.18951100f, 0.04630714f, -0.05494702f, -0.01903523f, -0.07519592f, 
    -0.46963844f, 0.07006694f, 0.04227328f, 0.08404859f, -0.01141827f, -0.02842211f, 0.11755821f, 0.05101876f, 
    0.33248881f, -0.03723361f, -0.04904521f, -0.06137264f, -0.55717099f, -0.24649836f, -0.00149182f, 0.08702700f, 
    -0.05464649f, 0.02859031f, -0.17124720f, 0.08639568f, 0.08384386f, 0.10550130f, 0.04821843f, -0.09767624f, 
    -0.01792235f, 0.16915408f, -0.03482393f, -0.18995152f, -0.07007848f, 0.00586541f, 0.05359119f, -0.01171393f, 
    -0.18173298f, 0.04899427f, 0.01259972f, -0.01944209f, -0.18987018f, 0.02501876f, 0.11330768f, -0.23379418f, 
    -0.07598265f, 0.08849685f, 0.03564864f, 0.13620682f, 0.04679248f, -0.01346341f, 0.07674582f, -0.16501087f, 
    -0.05068090f, 0.14892879f, -0.06681982f, -0.01025285f, 0.05094442f, -0.04597129f, -0.01984134f, 0.00574872f, 
    0.13272870f, -0.06813899f, -0.05528373f, 0.03848888f, -0.06816269f, -0.24750461f, -0.03924456f, 0.28830606f, 
    0.32353175f, -0.13570885f, 0.36062023f, -0.10100699f, -0.10700689f, 0.02143357f, -0.06805885f, 0.20642731f, 
    0.05980635f, -0.12784067f, -0.06346788f, -0.20527638f, 0.09358897f, -0.00101024f, -0.07122012f, -0.14824520f, 
    -0.10068766f, -0.06740053f, -0.04443591f, -0.03884376f, -0.14007971f, -0.04474525f, -0.05591351f, 0.05899511f, 
    0.01622894f, -0.19480954f, -0.08154252f, 0.01436790f, 0.05274493f, 0.00568203f, 0.17917797f, 0.19359967f, 
    -0.05231799f, 0.17849055f, 0.09954985f, -0.07710905f, 0.11914963f, -0.02064123f, 0.03589477f, -0.02740028f, 
    0.10135214f, 0.13323310f, 0.05041882f, 0.08707538f, -0.24946284f, 0.27532685f, 0.15977535f, -0.03193267f, 
    -0.01541074f, -0.06472961f, 0.10926099f, 0.04624495f, 0.04468044f, -0.12862410f, 0.11880610f, -0.10401417f, 
    0.26510349f, -0.04917893f, 0.07997411f, 0.14728831f, 0.06515367f, 0.11718049f, 0.06569910f, 0.27183405f, 
    0.06722833f, 0.10347323f, 0.22723077f, -0.08263446f, -0.08258802f, 0.03757938f, -0.14701110f, -0.04334851f, 
    -0.04501902f, -0.00976092f, 0.00361836f, 0.03383493f, -0.02463446f, -0.01185662f, 0.06471770f, 0.03923604f, 
    -0.03862092f, -0.10309504f, -0.14050944f, -0.19154133f, 0.04967328f, 0.33593854f, -0.16428484f, 0.05078238f, 
    0.04080756f, 0.01380941f, -0.08696350f, -0.01431927f, -0.08156764f, -0.01514050f, -0.13952677f, -0.22651494f, 
    0.11824059f, 0.28177798f, -0.14269719f, 0.16400895f, -0.00213422f, -0.04579077f, 0.08524785f, 0.16504203f, 
    0.07127015f, 0.07553446f, 0.07205732f, -0.11948282f, -0.04624677f, -0.01303000f, -0.04104304f, -0.11202831f, 
    -0.01632133f, 0.03171774f, -0.01619789f, 0.03124177f, -0.29353970f, -0.09172450f, -0.02204910f, -0.11173084f, 
    0.04499867f, -0.14878446f, -0.02658903f, 0.14779130f, -0.01160016f, -0.09561075f, -0.02226201f, -0.06348415f, 
    -0.03709053f, 0.23292147f, 0.03228847f, 0.16634125f, 0.05419016f, -0.00766819f, 0.07632410f, -0.18610306f, 
    0.11419663f, -0.02777047f, -0.01868036f, -0.00309442f, -0.08876517f, 0.34308204f, -0.25609136f, 0.27123043f, 
    0.12857704f, -0.17542076f, 0.22303694f, 0.19633970f, 0.06675698f, 0.09601732f, 0.07558925f, 0.16265500f, 
    -0.01108858f, -0.01351015f, -0.00327900f, -0.13936196f, -0.22377908f, -0.02020859f, 0.05105906f, 0.17779149f, 
    0.01842562f, -0.16074829f, 0.10190380f, -0.01568715f, 0.15057941f, 0.12338905f, 0.11193670f, 0.34459323f, 
    0.05969781f, 0.10061173f, 0.21826656f, 0.06996726f, 0.12017485f, 0.02529359f, -0.01574008f, 0.01162399f, 
    -0.10063710f, -0.22949609f, 0.04738507f, 0.06521261f, -0.04856870f, -0.15338519f, -0.11261822f, -0.09649765f, 
    -0.02833256f, -0.08448809f, 0.05688942f, 0.06089435f, -0.11011294f, -0.06952894f, 0.01362089f, -0.05267675f, 
    -0.06292234f, -0.03913749f, -0.01534805f, 0.07039773f, 0.19638249f, -0.03278774f, -0.04260887f, -0.03041611f, 
    -0.00461621f, 0.14554805f, 0.23439100f, -0.19704577f, -0.01541687f, -0.09099027f, 0.10568810f, -0.00891142f, 
    -0.00960358f, 0.03189631f, -0.04989504f, -0.01517130f, -0.28727534f, -0.41597694f, 0.29564902f, 0.28139287f, 
    -0.00443323f, -0.15231793f, 0.04559572f, -0.03736322f, 0.21299531f, -0.02681797f, 0.21479112f, 0.06914303f, 
    -0.53516698f, -0.03013005f, 0.17953829f, -0.20595340f, 0.13509727f, -0.00395322f, 0.11465707f, 0.04065285f, 
    0.04601946f, 0.03462084f, -0.07181977f, -0.06091365f, -0.29666552f, -0.00153087f, 0.06185336f, 0.24262537f, 
    0.04514763f, 0.02900895f, 0.14382836f, 0.04246340f, 0.26491249f, -0.06800824f, 0.04746792f, 0.17352800f, 
    0.32797265f, -0.19734748f, 0.18489051f, 0.01966077f, 0.06534773f, -0.00690159f, 0.04786137f, 0.25666189f, 
    0.06096293f, 0.07213295f, -0.06132982f, 0.10229918f, 0.17567794f, 0.10615148f, 0.13840275f, -0.17614554f, 
    -0.04556768f, -0.08556684f, -0.02914521f, -0.08536958f, 0.01124953f, -0.00800269f, 0.09999809f, 0.04253801f, 
    -0.00141404f, 0.27492228f, -0.07036138f, 0.12643805f, 0.03982797f, -0.04893463f, 0.03592506f, 0.07148508f, 
    -0.04499498f, 0.12991066f, 0.07657606f, -0.05242524f, 0.04555871f, 0.20899381f, -0.01517571f, -0.07732311f, 
    0.19357102f, 0.10791300f, 0.11938172f, -0.14981972f, -0.07186370f, -0.00097487f, -0.08637754f, -0.00598174f, 
    0.35587454f, 0.31337446f, 0.09302995f, -0.01540341f, 0.07074166f, -0.11161026f, 0.09815251f, 0.14908160f, 
    0.04025859f, 0.06837057f, 0.20435946f, 0.07495933f, 0.02454498f, 0.15839456f, 0.03907559f, -0.04499529f, 
    0.13971533f, -0.04571657f, -0.05455044f, -0.00494272f, -0.08443779f, -0.08482029f, -0.03180917f, -0.13094550f, 
    -0.03443355f, -0.01482603f, 0.02044341f, -0.00783100f, -0.00691595f, -0.00078032f, 0.00029585f, 0.02927520f, 
    -0.01413724f, 0.02528903f, -0.01603014f, 0.02876453f, -0.02817413f, -0.04191137f, 0.00353939f, 0.00632606f, 
    -0.01028734f, 0.02241948f, 0.00109755f, 0.00695115f, 0.01104022f, -0.00262840f, 0.02776778f, 0.02874966f, 
    -0.01272033f, -0.02077097f, -0.02054546f, 0.00276977f, 0.00404694f, -0.03083228f, 0.02691877f, 0.01359682f, 
    -0.01782347f, -0.03712881f, -0.02736131f, -0.00821691f, 0.00642954f, 0.02048498f, -0.03526318f, 0.01990633f, 
    -0.01234706f, -0.00527267f, 0.00785436f, -0.02365590f, 0.02057873f, -0.02343534f, 0.00109240f, -0.01192687f, 
    -0.02533266f, -0.02636367f, 0.02473863f, 0.03225779f, 0.01066901f, -0.03036639f, -0.01604970f, 0.01147600f, 
    0.00184505f, -0.00805544f, 0.02453187f, 0.02597181f, -0.00365701f, -0.03290742f, -0.04152141f, 0.01082827f, 
    -0.03824569f, -0.02152846f, 0.01786115f, 0.02069540f, -0.04048432f, -0.00793882f, -0.00193688f, 0.00567363f, 
    0.01685403f, -0.03751158f, -0.04010839f, 0.02708079f, -0.01994624f, 0.01966099f, -0.01384029f, -0.02726551f, 
    0.02937755f, -0.01780510f, 0.00196566f, 0.00486286f, -0.02807464f, -0.01305597f, -0.02983947f, -0.02421362f, 
    0.02256698f, 0.01683256f, -0.02806280f, -0.02279784f, 0.00095191f, -0.02604380f, -0.00806742f, -0.04146487f, 
    -0.03509127f, 0.02833398f, -0.00911572f, 0.01043190f, -0.02221785f, -0.03834673f, 0.02367087f, 0.00217760f, 
    0.02033036f, -0.03712263f, -0.00186502f, 0.00665233f, 0.01587397f, 0.02525864f, 0.00524057f, -0.00377564f, 
    -0.01850818f, -0.02932474f, 0.02516446f, 0.00390232f, 0.02600427f, 0.02630501f, 0.02821115f, 0.00898272f, 
    0.00913134f, 0.01729216f, -0.01575883f, 0.02668208f, 0.01793445f, -0.02407284f, -0.00687528f, -0.02709212f, 
    -0.01496071f, 0.00627053f, -0.02717096f, 0.01191543f, 0.00837674f, -0.00000401f, -0.03217055f, -0.02828486f, 
    0.00013051f, -0.00694830f, -0.00301470f, 0.00907268f, -0.01614639f, -0.00618477f, 0.00799695f, 0.00595369f, 
    0.01342718f, -0.02222667f, -0.02145805f, -0.01004433f, 0.00561064f, -0.01336561f, 0.00190903f, -0.04117741f, 
    0.01535363f, -0.03575940f, -0.02161854f, 0.01152640f, 0.02708491f, -0.00098705f, 0.01087240f, 0.01766265f, 
    -0.01079061f, -0.01356787f, 0.02815761f, 0.02406513f, -0.02059752f, -0.00538572f, -0.02801034f, -0.01146333f, 
    0.01389069f, -0.03284383f, -0.00494282f, -0.02415263f, 0.01514513f, 0.01955065f, 0.02735477f, 0.00693805f, 
    0.00860114f, 0.00988143f, -0.03091167f, 0.02122604f, -0.01653109f, 0.00597410f, -0.00149876f, -0.00220951f, 
    -0.01840408f, -0.01854068f, -0.00881626f, 0.01408233f, -0.02363253f, 0.01955468f, 0.01111316f, -0.02273214f, 
    -0.00316665f, 0.02089700f, -0.00896105f, -0.00657968f, -0.00595627f, 0.02628568f, 0.01946490f, -0.01715104f, 
    -0.01915771f, -0.00741546f, -0.03539852f, -0.02399978f, -0.03013503f, -0.02810695f, -0.02181307f, -0.02844996f, 
    -0.01229914f, -0.02381872f, -0.02397699f, 0.02043102f, -0.02708101f, 0.01071710f, -0.03227634f, 0.02456076f, 
    -0.00392277f, -0.00655105f, 0.02097108f, -0.00143072f, -0.00275333f, -0.00755214f, 0.01993148f, 0.02848479f, 
    0.01630912f, -0.01555149f, 0.02161279f, -0.00565469f, -0.00757117f, -0.01545954f, 0.03560184f, 0.04054083f, 
    0.02280097f, -0.00644612f, -0.02172033f, -0.04014505f, -0.01893297f, -0.00089493f, -0.01418908f, -0.02870338f, 
    0.02653466f, -0.01019209f, -0.00867995f, -0.00183527f, -0.01519897f, 0.00271637f, -0.00877721f, 0.01187073f, 
    -0.00625762f, 0.01558445f, -0.03724999f, -0.01704695f, 0.00237025f, -0.03601209f, 0.01028078f, -0.01546589f, 
    -0.00294583f, -0.02918992f, 0.00794466f, -0.03269046f, -0.02029992f, 0.00301447f, -0.00539389f, -0.00658580f, 
    -0.00681303f, 0.01095820f, -0.03404430f, 0.00385759f, -0.03732830f, 0.00404209f, 0.00432168f, -0.01878265f, 
    0.02391919f, -0.03952651f, -0.00605239f, 0.01219834f, -0.02739470f, 0.00394258f, 0.02133779f, -0.02442874f, 
    -0.03054448f, -0.03342944f, 0.02196447f, -0.02862059f, -0.02740368f, 0.01802437f, -0.02048932f, -0.03531432f, 
    -0.00635847f, -0.00114756f, 0.01890780f, -0.02288752f, 0.02616087f, 0.01086999f, -0.03681646f, -0.01295864f, 
    0.01470923f, -0.01466269f, 0.02591585f, 0.00678853f, -0.01718053f, -0.00590094f, -0.03862970f, 0.00310550f, 
    0.00470676f, 0.00168678f, 0.02482952f, 0.00718344f, -0.01001850f, -0.02540196f, -0.01875406f, -0.00906636f, 
    0.00137104f, 0.00349609f, -0.00305542f, -0.02189611f, 0.03001826f, -0.00904988f, -0.00790656f, 0.00840191f, 
    0.01904670f, -0.01613673f, -0.02331062f, 0.00617900f, -0.00890192f, -0.01454121f, 0.00814705f, -0.02837452f, 
    -0.02409042f, -0.01803190f, 0.00987535f, -0.02545889f, 0.00235693f, 0.02261511f, -0.01883910f, 0.01785319f, 
    -0.02302306f, -0.03767310f, -0.01428821f, -0.02209870f, -0.00474548f, -0.01180088f, 0.01102973f, 0.00914818f, 
    -0.00858569f, 0.01201125f, 0.00263052f, 0.02453318f, -0.01635182f, -0.02769767f, 0.01381781f, -0.03619988f, 
    -0.01619478f, -0.00206567f, 0.03881450f, -0.03975917f, -0.04088910f, 0.01346342f, 0.02424323f, 0.00057551f, 
    -0.01336101f, -0.01544808f, -0.02253369f, 0.00867128f, -0.01736567f, -0.01838173f, -0.02787881f, -0.03130769f, 
    -0.04184143f, 0.02446254f, -0.03552033f, 0.02423426f, -0.01642751f, -0.01062758f, 0.00734907f, 0.01977065f, 
    -0.03128227f, -0.02375652f, -0.02164114f, 0.01378188f, -0.01401290f, 0.01011572f, 0.00934930f, -0.02313563f, 
    -0.01654459f, 0.00602160f, -0.03111603f, -0.03238871f, 0.02758909f, -0.02329035f, 0.00253241f, -0.01851319f, 
    -0.03347094f, -0.00402751f, 0.00083221f, -0.03215894f, -0.01197633f, 0.04065109f, 0.01517236f, -0.02881415f, 
    0.00645518f, -0.03782069f, 0.01819438f, 0.02625408f, 0.01959858f, -0.01947380f, 0.01787185f, 0.02843603f, 
    -0.03808485f, -0.01639720f, 0.01638706f, -0.00839553f, 0.02756631f, 0.01061565f, -0.00494182f, -0.02457139f, 
    0.00653149f, -0.01575557f, -0.00052512f, -0.00062591f, 0.00852365f, 0.00373153f, -0.01748103f, 0.00210410f, 
    -0.03940798f, 0.00783574f, -0.04017229f, 0.01988645f, -0.02112207f, -0.01283053f, -0.01595166f, 0.00317068f, 
    -0.03403828f, 0.02276780f, 0.00405134f, 0.02544932f, 0.00948530f, 0.01196829f, 0.02742062f, 0.01649438f, 
    -0.04161135f, 0.02844291f, 0.02926390f, -0.00642767f, -0.02987880f, 0.01533403f, 0.01498114f, 0.01317408f, 
    -0.01962200f, -0.04171503f, 0.02076807f, -0.01439432f, -0.02807451f, 0.02924257f, -0.01584112f, -0.00526118f, 
    -0.01298113f, -0.03377027f, 0.00131861f, -0.02787784f, 0.02138807f, 0.02355309f, -0.01536930f, -0.00962131f, 
    0.01715991f, -0.02731946f, -0.00067961f, -0.00612563f, 0.01077932f, 0.00592612f, -0.00331118f, 0.01097508f, 
    -0.00817037f, -0.00167076f, -0.03261346f, -0.02588771f, -0.01987604f, 0.02034596f, -0.01368417f, -0.03843003f, 
    -0.02935902f, -0.00145839f, -0.01569648f, -0.00539404f, -0.01627356f, -0.00162070f, -0.03839544f, 0.00338146f, 
    0.00736818f, 0.00888279f, -0.03064478f, -0.00647831f, 0.00500549f, -0.01863380f, -0.01957414f, 0.02257677f, 
    -0.00832734f, -0.00605149f, -0.03482281f, 0.02828566f, -0.02772910f, -0.01062581f, -0.02716055f, 0.00886675f, 
    0.00867936f, -0.00123998f, 0.02526689f, 0.02076459f, -0.04144276f, -0.01900584f, 0.01657967f, 0.02613222f, 
    -0.00196798f, 0.02194059f, -0.00161015f, 0.02527816f, -0.04095066f, -0.03032053f, -0.03641430f, -0.01081570f, 
    -0.01913290f, 0.01046782f, -0.03474272f, -0.00179616f, -0.03673031f, -0.00296012f, -0.00556368f, -0.00904449f, 
    0.01628697f, 0.00548745f, 0.01874171f, -0.01490088f, -0.04117607f, -0.00407307f, 0.00892654f, -0.03528724f, 
    -0.01693875f, 0.02766277f, -0.01670897f, -0.01642228f, 0.02348624f, -0.01598424f, -0.00960051f, 0.02165454f, 
    -0.02885684f, -0.04066598f, 0.01742905f, 0.02175953f, -0.00548812f, -0.01977637f, -0.02094742f, -0.02832027f, 
    0.03294933f, -0.02457514f, -0.04042393f, 0.00703965f, -0.03606219f, -0.03943641f, -0.03463505f, 0.02854419f, 
    -0.00653797f, -0.02285730f, -0.02528842f, 0.00084066f, 0.02187780f, 0.02709998f, 0.00369884f, -0.03496385f, 
    0.00118229f, 0.01043112f, -0.02352243f, -0.03190038f, -0.01639685f, -0.01622460f, 0.00892420f, 0.01959215f, 
    0.00780037f, 0.01463330f, 0.01947691f, 0.01038009f, 0.02014517f, -0.02573223f, 0.01461244f, 0.00559662f, 
    0.02542503f, 0.02509142f, -0.00313869f, 0.01356567f, -0.02142449f, 0.01518149f, -0.02425879f, -0.02985570f, 
    0.00101344f, 0.01500793f, 0.01193210f, -0.01429828f, -0.01870002f, -0.02352705f, -0.01632747f, -0.03475391f, 
    0.02574735f, 0.00884880f, -0.02452738f, 0.01478554f, -0.02641170f, 0.01922709f, -0.01648873f, 0.02986692f, 
    0.02589934f, -0.00814877f, 0.01742893f, 0.00280282f, 0.01079494f, -0.01283093f, -0.01198676f, -0.00588254f, 
    -0.02927638f, -0.03447340f, -0.00627273f, -0.02880324f, 0.01147934f, -0.00820371f, -0.01364206f, 0.02124946f, 
    -0.00909461f, 0.03000031f, -0.04108579f, -0.00769286f, -0.03251820f, -0.01637722f, -0.02982521f, -0.04201605f, 
    0.02470408f, -0.03822721f, -0.03189926f, 0.00516050f, -0.03328659f, -0.03472274f, -0.02084929f, -0.03208604f, 
    0.01491349f, 0.01893739f, -0.03440017f, 0.00476117f, 0.02561219f, -0.04071501f, -0.04084351f, 0.01225473f, 
    0.01969630f, 0.00484007f, -0.02454066f, 0.00625880f, -0.01553112f, 0.01786033f, 0.00276510f, -0.00898559f, 
    -0.02643797f, 0.02354685f, -0.00834018f, -0.03627842f, -0.01207606f, -0.00272018f, -0.03405788f, -0.03182298f, 
    -0.03429125f, 0.01379933f, 0.00177601f, -0.02106135f, 0.01763854f, 0.02227013f, -0.00566479f, -0.00124879f, 
    -0.03688428f, 0.01611114f, 0.01010741f, 0.02339699f, -0.04065406f, -0.02892817f, -0.00425817f, -0.00843679f, 
    0.00195950f, -0.01655266f, -0.04091361f, 0.01167450f, -0.01618611f, 0.02163251f, -0.03909497f, -0.03575005f, 
    -0.03521762f, -0.02277721f, -0.03046366f, -0.03439036f, 0.00421261f, -0.02244476f, 0.02260736f, -0.01718697f, 
    -0.03412973f, -0.02046501f, -0.00875830f, 0.02529557f, 0.01662740f, 0.00530859f, -0.01014065f, 0.02456778f, 
    -0.02202679f, -0.01249203f, -0.03410214f, 0.02915034f, 0.00990750f, -0.00382889f, -0.01370621f, -0.04205950f, 
    -0.01173159f, -0.01538527f, -0.00944098f, 0.00433742f, 0.00822150f, -0.03100883f, -0.00337839f, -0.02931166f, 
    -0.00316393f, 0.01649305f, -0.04018821f, 0.02572673f, -0.03201432f, 0.00207979f, -0.02681962f, 0.01197361f, 
    -0.00628743f, -0.03063046f, -0.03686715f, -0.03197135f, -0.00062227f, -0.02169631f, -0.02807420f, -0.00708849f, 
    0.01020454f, -0.03882014f, 0.01063524f, -0.02574600f, -0.01446713f, -0.03911841f, 0.01767627f, -0.02707010f, 
    -0.04103381f, -0.00797184f, -0.01886117f, 0.02432786f, -0.00941726f, -0.00758864f, -0.01942776f, -0.01815516f, 
    -0.03876294f, -0.02396524f, 0.01328951f, 0.02929640f, -0.02676753f, -0.00715009f, 0.01287982f, -0.01354368f, 
    0.00391120f, -0.00273331f, 0.02501878f, 0.00863121f, -0.01136883f, 0.01185070f, 0.01500401f, -0.03371935f, 
    0.24126402f, 0.11020599f, 0.19879363f, 0.09978206f, 0.01757660f, -0.00002626f, 0.05734071f, -0.01976721f, 
    -0.11415567f, 0.02837228f, -0.00038827f, 0.13358992f, 0.02097289f, -0.01610799f, 0.02928886f, -0.11106418f, 
    -0.00810732f, 0.04184973f, 0.02484732f, -0.11895064f, 0.08471979f, -0.01094351f, 0.05684484f, -0.02519210f, 
    0.15765636f, -0.05781316f, 0.12691329f, -0.01222078f, -0.01680001f, -0.02485073f, 0.24568269f, -0.18321924f, 
    -0.04207585f, -0.03362326f, -0.06762352f, -0.15772633f, -0.01006187f, -0.14389001f, 0.21814166f, 0.01750050f, 
    0.02880338f, -0.04756581f, 0.07631068f, -0.00137153f, -0.01085705f, -0.05491792f, -0.02429251f, 0.03650696f, 
    0.08521710f, 0.05553180f, 0.30047205f, 0.11947601f, -0.02054492f, -0.17977491f, -0.04861847f, -0.05306308f, 
    -0.00523681f, 0.09089810f, -0.05155768f, -0.09268174f, -0.43342847f, -0.20139576f, 0.09247310f, 0.05269201f, 
    -0.15758651f, 0.16131911f, 0.03179396f, -0.04780275f, -0.09645967f, 0.01255084f, -0.01225539f, -0.06538992f, 
    -0.19071594f, 0.14433721f, -0.18818617f, -0.09846845f, -0.07759504f, -0.07027118f, -0.04521216f, -0.04589183f, 
    -0.04168280f, 0.14163908f, -0.01477924f, 0.13623174f, 0.11609260f, 0.03507041f, 0.07554317f, 0.05693490f, 
    0.02749178f, 0.11563579f, 0.02527907f, 0.02747444f, -0.02676556f, 0.03669461f, 0.02293507f, 0.14400397f, 
    -0.16187051f, 0.32183558f, -0.21086770f, -0.01041548f, -0.07794912f, 0.12465423f, -0.07872269f, -0.01582267f, 
    0.08646709f, 0.04703559f, -0.00362989f, 0.15412284f, 0.21031600f, 0.16834670f, 0.06775583f, 0.08701363f, 
    -0.00386920f, -0.01903374f, -0.02748534f, -0.01430670f, -0.00509794f, -0.03279790f, -0.03030663f, -0.03670277f, 
    -0.18170294f, 0.12143308f, 0.10740466f, 0.12413065f, -0.19954555f, -0.07003202f, -0.03174232f, 0.07476577f, 
    -0.01325727f, -0.02100609f, -0.06531603f, -0.13434032f, 0.08152767f, 0.32244581f, 0.08747675f, 0.01000186f, 
    0.04556432f, -0.16920289f, 0.07769156f, -0.04930244f, -0.19863418f, 0.03059703f, 0.06886482f, -0.02708467f, 
    -0.00165960f, -0.03491211f, 0.18600653f, -0.05609511f, 0.07865948f, -0.06839374f, 0.07552423f, 0.00075626f, 
    -0.07246403f, -0.28663942f, -0.09120587f, 0.06702161f, 0.05128791f, 0.04010889f, 0.04975913f, 0.09354552f, 
    0.05464842f, -0.02428164f, 0.09434193f, -0.05507026f, 0.02868419f, 0.00634194f, -0.03816042f, -0.10961194f, 
    -0.10763907f, -0.01021863f, -0.07475900f, 0.09437859f, -0.03200847f, 0.01725357f, -0.11627790f, -0.11371037f, 
    -0.08898174f, 0.01695739f, -0.13363995f, -0.03754878f, -0.09360050f, -0.15720724f, -0.29816183f, -0.14274333f, 
    -0.06214475f, 0.03146809f, -0.08029772f, -0.13720955f, -0.04746592f, -0.04222894f, -0.04498081f, 0.00054242f, 
    0.09899256f, 0.27343127f, -0.02631703f, 0.01139192f, -0.06906459f, -0.11403060f, -0.02251891f, 0.17655723f, 
    0.02437724f, 0.06760228f, -0.12862633f, 0.05997831f, 0.15795580f, -0.08084759f, 0.08298768f, 0.18769538f, 
    -0.09553918f, 0.14912930f, -0.00066620f, 0.15764192f, -0.04897493f, 0.11580154f, -0.09861048f, -0.04177829f, 
    -0.03814965f, -0.17770499f, -0.04172883f, 0.06386324f, 0.07856534f, 0.05240176f, 0.03368048f, -0.03457322f, 
    0.06329538f, 0.11542995f, 0.08706088f, 0.02861203f, 0.01811402f, -0.08215322f, 0.12881668f, -0.05709840f, 
    -0.08312611f, -0.04151859f, -0.04195264f, 0.05588845f, 0.03426141f, 0.05695752f, -0.01220897f, 0.19715422f, 
    -0.13174739f, 0.02709592f, -0.09603985f, 0.06598067f, 0.04272911f, 0.08019444f, -0.02673145f, -0.07221115f, 
    0.01523346f, 0.08061866f, 0.00723515f, -0.14245775f, -0.06640904f, 0.00051395f, 0.01639148f, 0.24743597f, 
    0.05207445f, 0.04939427f, -0.09022566f, 0.02409541f, 0.05823979f, 0.04915651f, 0.00334470f, 0.01593429f, 
    0.12036610f, 0.31898060f, -0.00196593f, 0.10771238f, -0.06808987f, -0.08883524f, 0.04235006f, 0.20954421f, 
    0.00894548f, -0.09947629f, -0.09075991f, 0.00535199f, 0.38003916f, -0.11392683f, 0.17318435f, -0.17834032f, 
    0.06013365f, -0.00360184f, 0.09316807f, -0.01746933f, 0.11273028f, 0.08598043f, 0.10443279f, 0.15402426f, 
    -0.12824897f, 0.03991351f, 0.27056593f, 0.30352432f, -0.08215100f, 0.06199094f, 0.13986510f, -0.02390675f, 
    0.03308100f, 0.00814056f, 0.00132113f, 0.00867646f, -0.02744914f, -0.02602021f, -0.09429055f, 0.22492521f, 
    -0.09330070f, 0.04866079f, 0.01585368f, 0.09331792f, -0.00495460f, -0.05656176f, -0.04685883f, -0.05581039f, 
    0.12223256f, -0.07133070f, 0.15340050f, -0.07048478f, -0.02183276f, 0.10924132f, 0.15402596f, 0.08664158f, 
    -0.04856248f, -0.09638501f, 0.02540640f, -0.10663741f, -0.20621143f, 0.00047869f, 0.11447576f, 0.13105188f, 
    0.01796507f, 0.13902076f, -0.12434688f, 0.05865139f, 0.07683194f, -0.02764693f, -0.01797509f, 0.11177642f, 
    0.07043597f, 0.03924036f, -0.01209107f, -0.00327661f, 0.01994338f, 0.02393988f, -0.05841003f, 0.04458967f, 
    0.14386940f, 0.03120197f, 0.08044422f, 0.16546056f, 0.06051779f, 0.01022474f, 0.08801370f, 0.07558668f, 
    -0.06012273f, 0.11499187f, 0.04846691f, -0.08950876f, -0.04373771f, 0.06454492f, 0.13537183f, -0.14177090f, 
    0.23617768f, -0.00601987f, 0.07892319f, -0.00426036f, -0.04453001f, -0.04511349f, 0.00592549f, 0.03668398f, 
    0.09107310f, 0.12392659f, 0.07164139f, 0.14304158f, 0.21724427f, -0.08831941f, 0.05352140f, -0.10907695f, 
    -0.06413643f, 0.11007996f, 0.05603101f, -0.05456414f, 0.17952031f, 0.08893459f, 0.00466663f, 0.03637107f, 
    0.21697532f, -0.16050220f, 0.05074956f, 0.15437230f, 0.17403436f, -0.02259277f, 0.16304588f, 0.02763867f, 
    -0.00159999f, 0.09024917f, 0.07212868f, 0.22314844f, -0.09365905f, 0.31163248f, 0.15284492f, -0.16165526f, 
    0.00644684f, -0.09580512f, -0.11390452f, 0.13201463f, -0.09142453f, -0.11314020f, -0.01203511f, 0.07091697f, 
    -0.38388973f, -0.14845343f, 0.35538709f, 0.06027603f, 0.11005872f, 0.24535137f, -0.09265666f, -0.04682693f, 
    0.08613168f, 0.06929070f, 0.11030696f, 0.01084063f, -0.08265235f, -0.11641849f, 0.11728889f, -0.14891937f, 
    0.03419571f, -0.05908677f, -0.02427007f, -0.02733759f, 0.05255692f, 0.14691466f, 0.08377112f, 0.13709125f, 
    0.24479283f, 0.16963215f, -0.03247686f, 0.11964381f, -0.05454248f, 0.02446321f, 0.04849170f, -0.01146791f, 
    -0.06162619f, 0.05628701f, -0.04878454f, -0.06811343f, 0.37686810f, -0.24749602f, 0.48720101f, -0.26055232f, 
    -0.06657924f, 0.17416452f, 0.01614492f, 0.03662015f, 0.01936935f, 0.02274015f, -0.04582765f, -0.11498083f, 
    -0.11725260f, -0.21721527f, 0.17962041f, 0.04130130f, -0.19869749f, -0.06290673f, -0.12323814f, -0.16444750f, 
    0.01268074f, -0.02135948f, -0.03790427f, 0.01728717f, -0.13841195f, 0.19231901f, 0.08439738f, 0.08407410f, 
    -0.09246799f, 0.15326397f, -0.04990902f, 0.12554957f, 0.04723603f, -0.04556182f, -0.02451004f, -0.12771751f, 
    -0.04058061f, 0.05704561f, 0.03098065f, 0.07072221f, -0.03320939f, -0.01262548f, 0.11109405f, 0.01269407f, 
    -0.01353248f, 0.14017928f, 0.04865649f, 0.01688124f, -0.54442966f, 0.19803874f, -0.32773235f, 0.32152024f, 
    -0.08995982f, -0.03965626f, -0.14855818f, 0.11240482f, 0.02824836f, 0.17194973f, -0.05715510f, -0.02548957f, 
    0.29168773f, -0.11838488f, 0.27243057f, -0.16716114f, 0.01508369f, 0.09414990f, 0.06273001f, -0.04458782f, 
    -0.05112618f, 0.05531497f, -0.09283645f, 0.16342832f, 0.13697690f, 0.13068563f, -0.02541107f, 0.10570597f, 
    -0.04579124f, 0.03779666f, 0.02026027f, 0.05009603f, -0.04593271f, 0.06434274f, 0.03875467f, 0.08730631f, 
    0.17244975f, -0.06031727f, 0.10052702f, 0.05687466f, -0.05487328f, 0.11293811f, -0.02759407f, 0.12747779f, 
    -0.15138680f, -0.06024248f, 0.00406941f, -0.06271933f, 0.48928529f, -0.09244818f, 0.06479562f, -0.01364180f, 
    -0.00944849f, 0.03163847f, 0.16870427f, 0.03785799f, -0.06454267f, 0.01803161f, -0.06529605f, -0.07691523f, 
    -0.04883660f, -0.19347174f, -0.16619802f, 0.04270735f, 0.02467431f, -0.05244467f, -0.11159379f, -0.03832366f, 
    0.02878184f, 0.02688497f, 0.01888908f, 0.13227238f, -0.10587440f, 0.03512460f, 0.01505765f, -0.01418264f, 
    -0.07913516f, -0.11350466f, -0.04488566f, -0.10806085f, 0.00389110f, -0.00354350f, -0.03322612f, -0.11587766f, 
    -0.17735094f, 0.11911609f, 0.05762085f, 0.20027076f, -0.22136752f, 0.09067360f, -0.09194758f, -0.00584960f, 
    0.01129581f, 0.08029073f, 0.06307136f, 0.05456496f, -0.08635035f, 0.25070122f, -0.09201681f, 0.13780841f, 
    0.02615652f, 0.04265823f, 0.06931850f, -0.04022442f, -0.00825966f, 0.01109253f, -0.12361076f, -0.11027424f, 
    -0.00232690f, 0.02378087f, 0.21242489f, 0.13542068f, -0.06975202f, 0.02747002f, -0.13084061f, 0.15147457f, 
    -0.05084290f, 0.08819463f, -0.01467722f, -0.00393954f, -0.00399596f, 0.12337875f, 0.11845183f, 0.13581666f, 
    -0.05786996f, 0.04876301f, -0.09022688f, 0.04516259f, 0.04184157f, -0.01477447f, -0.14038512f, -0.03671216f, 
    -0.03017052f, 0.02610238f, 0.12327641f, -0.04934663f, -0.06813772f, -0.01179584f, 0.01457532f, 0.00496202f, 
    -0.11935578f, -0.10475311f, -0.05041347f, -0.22318795f, -0.25037262f, 0.01342122f, -0.14351581f, -0.01650440f, 
    -0.01206676f, -0.01628257f, -0.04272404f, 0.04615353f, 0.00865860f, 0.09015510f, 0.11211890f, 0.17562665f, 
    -0.03322164f, -0.29034948f, -0.12101400f, 0.00762257f, 0.07017190f, -0.05119743f, -0.00496750f, -0.20245735f, 
    -0.00070973f, 0.05263470f, -0.02881754f, 0.10859975f, -0.03268914f, 0.19886713f, 0.08500088f, -0.14541067f, 
    -0.09441693f, -0.06582941f, 0.12654160f, -0.05955950f, -0.09630781f, -0.04392312f, -0.03501823f, 0.11113498f, 
    0.09074817f, 0.30871055f, 0.04403379f, 0.12809806f, -0.04508889f, -0.19635770f, 0.00623954f, 0.04038141f, 
    -0.00589435f, 0.05311554f, 0.06609172f, -0.06846513f, -0.17689961f, 0.32296324f, -0.10714004f, 0.29110432f, 
    0.01662563f, -0.10242866f, 0.12918708f, 0.14235468f, -0.06644443f, 0.06513858f, 0.04121438f, -0.06714711f, 
    -0.43567723f, -0.01116984f, -0.27558592f, 0.03245882f, 0.06387456f, 0.08346526f, 0.13792042f, 0.14038269f, 
    -0.14462867f, 0.06269171f, 0.04552303f, -0.09425393f, -0.25239721f, -0.04600548f, -0.23940870f, 0.04637381f, 
    0.13337140f, 0.10791831f, -0.10278907f, 0.00922336f, -0.03669312f, 0.06429823f, 0.05190618f, 0.10504565f, 
    0.20002793f, 0.14560436f, 0.09673081f, 0.14377654f, -0.00441146f, 0.05267225f, 0.06417922f, 0.02510403f, 
    -0.04009837f, -0.01533682f, 0.05504512f, 0.05006947f, -0.18273780f, 0.08641465f, 0.30463016f, 0.09845874f, 
    -0.02191166f, -0.11242582f, -0.09167375f, 0.03882971f, 0.04420274f, -0.00751363f, 0.02797828f, -0.06058451f, 
    -0.08917706f, 0.06812145f, -0.12723996f, -0.29531139f, -0.08897787f, 0.02724883f, -0.03651180f, 0.03370282f, 
    -0.08241434f, 0.04555411f, 0.00078632f, -0.02524498f, 0.26854253f, 0.15517025f, -0.00997091f, 0.05682511f, 
    -0.00850607f, 0.02885468f, 0.04529557f, 0.02171284f, 0.00703328f, -0.03109456f, 0.00930891f, -0.07016178f, 
    -0.08723886f, -0.10426081f, 0.15525968f, 0.03173297f, -0.20970234f, 0.02547992f, 0.09990918f, 0.08891261f, 
    -0.10775715f, 0.15252504f, 0.11994995f, 0.21103248f, 0.24144910f, 0.18309101f, -0.01689208f, 0.00685133f, 
    -0.02098028f, 0.15912180f, -0.05825964f, -0.05137904f, 0.10784035f, 0.07899214f, -0.13078268f, 0.01243420f, 
    0.06718408f, -0.15746239f, -0.02182262f, -0.02775634f, -0.20737310f, -0.07685056f, 0.07846595f, -0.06586729f, 
    -0.00640925f, -0.17443974f, -0.18025267f, -0.23807757f, 0.01003146f, 0.12128542f, -0.04954423f, -0.11690806f, 
    -0.12990458f, -0.11450578f, 0.05065829f, 0.00195782f, 0.15842977f, 0.02559709f, 0.00544372f, 0.00993570f, 
    0.23992372f, -0.01296018f, 0.07090414f, 0.00740286f, 0.06442244f, 0.09801360f, -0.01926537f, -0.12904452f, 
    0.02853739f, -0.05374076f, -0.08440665f, 0.00906306f, -0.21381062f, 0.01423628f, -0.06300379f, -0.10131566f, 
    0.07837162f, -0.05963869f, 0.00686357f, 0.01956169f, -0.18664944f, 0.04786678f, -0.07069850f, -0.07418686f, 
    0.07389902f, 0.09243748f, 0.07178973f, 0.24917112f, -0.00572530f, -0.09130841f, -0.04984703f, -0.13875130f, 
    0.06954148f, 0.12700735f, 0.11421164f, 0.13403666f, 0.05628825f, -0.00158994f, -0.04499251f, 0.19408154f, 
    -0.01566358f, -0.09543753f, 0.00986436f, 0.00179974f, 0.08411848f, 0.05931107f, 0.09676640f, 0.05741924f, 
    0.06973460f, 0.10983948f, 0.10704317f, 0.18824580f, -0.00954698f, -0.10210980f, -0.01675541f, -0.09281725f, 
    -0.05651718f, -0.03573456f, 0.05406723f, 0.18638006f, 0.02186421f, 0.02016651f, 0.06628653f, 0.25107279f, 
    0.13292709f, 0.08941428f, 0.00170802f, 0.06335377f, -0.05687839f, 0.00787061f, -0.02552308f, -0.08751491f, 
    0.07134362f, 0.10681593f, 0.01393053f, 0.08499931f, 0.13064952f, 0.08029258f, -0.02764642f, -0.04376107f, 
    -0.13437231f, -0.10392125f, -0.12466778f, -0.07674279f, 0.31254476f, 0.23387228f, 0.11068718f, 0.04791294f, 
    -0.04488849f, 0.09372896f, 0.00954432f, -0.13123992f, -0.03485132f, -0.12556460f, -0.02964856f, 0.13357224f, 
    -0.01674483f, -0.05188647f, 0.19959052f, 0.07323214f, -0.19708142f, -0.12637430f, -0.02542275f, 0.12700191f, 
    -0.01477303f, -0.28043470f, -0.04615707f, -0.18511866f, 0.23789005f, 0.16493465f, 0.08043937f, -0.01563683f, 
    0.15446386f, 0.07842772f, 0.05014726f, -0.08710128f, 0.04663595f, 0.16149443f, 0.01674735f, -0.01185862f, 
    0.05784625f, 0.02111708f, -0.08901385f, -0.11429931f, -0.06378262f, -0.07471624f, 0.05628791f, 0.05129488f, 
    -0.05802408f, -0.11768384f, -0.03496993f, -0.09059180f, 0.00578373f, 0.16508833f, -0.06059552f, -0.04144804f, 
    -0.12918910f, -0.08185633f, 0.02792590f, 0.08445682f, -0.06005804f, 0.00998609f, 0.00130038f, 0.02118662f, 
    0.05322756f, 0.02521014f, 0.05521075f, -0.03954024f, -0.06143676f, -0.09194793f, 0.04054655f, 0.01711133f, 
    -0.06172279f, -0.02750623f, -0.16517906f, 0.04784575f, -0.05704850f, 0.02533407f, -0.24961887f, 0.11232947f, 
    0.08676365f, 0.04842784f, -0.03278364f, 0.03452966f, 0.02545497f, 0.05542389f, -0.10852110f, -0.17209089f, 
    -0.18889996f, 0.16912371f, 0.01912455f, 0.16083874f, 0.02550947f, 0.01811130f, 0.05173939f, -0.13227674f, 
    -0.02340066f, 0.06440582f, 0.23204431f, 0.03692505f, 0.08614145f, -0.03666495f, 0.20315729f, 0.13162655f, 
    0.08427263f, 0.09480730f, -0.10762246f, -0.07583703f, -0.04760405f, 0.02592817f, 0.09774968f, 0.29963416f, 
    0.06677210f, 0.22731154f, 0.03180648f, -0.16001293f, 0.13701078f, 0.10598260f, 0.03559433f, -0.08509237f, 
    0.04435475f, 0.01892830f, 0.25165325f, 0.10721417f, 0.24420653f, 0.07958312f, 0.01279636f, 0.13578197f, 
    0.02166155f, -0.05912245f, -0.06566342f, 0.00711869f, -0.07694740f, 0.09494658f, 0.03135170f, 0.09060205f, 
    0.20255375f, 0.12825799f, 0.16691688f, -0.18638074f, 0.04500956f, -0.05815967f, -0.04316493f, -0.01959449f, 
    -0.05859758f, 0.04191297f, -0.15682213f, 0.03256847f, -0.13846864f, 0.02689869f, 0.13741367f, -0.17518662f, 
    0.01270353f, -0.01534187f, 0.02960745f, 0.09202402f, 0.08895092f, 0.10012457f, 0.13354799f, 0.09724742f, 
    0.06154576f, -0.20643656f, -0.30033031f, -0.18985982f, -0.09487308f, -0.00186668f, 0.13024370f, 0.05244919f, 
    -0.09773778f, -0.12115209f, 0.03650676f, 0.04487794f, -0.18496218f, 0.08695438f, -0.16453753f, 0.35469419f, 
    -0.08852640f, -0.10545889f, 0.08245299f, -0.06756949f, 0.04856629f, -0.03465225f, -0.01797497f, -0.09927992f, 
    0.07736524f, -0.16898502f, 0.03426076f, -0.01989415f, 0.12063531f, 0.01207407f, 0.07912908f, -0.00557923f, 
    -0.04708198f, -0.09852589f, 0.01072777f, -0.38089040f, 0.06171822f, -0.03519192f, 0.02528972f, -0.03657866f, 
    -0.01335116f, -0.08231529f, 0.01781045f, 0.10887799f, 0.07204869f, 0.01055786f, 0.01515754f, -0.03954099f, 
    -0.03249730f, -0.00759599f, -0.05375534f, -0.00979037f, 0.05577556f, 0.13028589f, 0.08318985f, 0.05540502f, 
    0.18126053f, 0.12463582f, 0.02681063f, 0.15035540f, -0.02180100f, -0.06110494f, -0.06684806f, 0.02210057f, 
    -0.01864412f, 0.12040399f, -0.05460425f, 0.00465948f, -0.10700063f, -0.13724242f, 0.06519178f, -0.09767368f, 
    0.02026309f, -0.07780401f, 0.06124146f, 0.11807767f, 0.08128468f, 0.15389515f, 0.07027762f, 0.06013957f, 
    0.01391944f, 0.16590105f, 0.12624100f, 0.14931928f, -0.11501867f, 0.02876404f, 0.26476347f, -0.05291258f, 
    -0.13066277f, 0.06989194f, 0.00098397f, -0.09418952f, -0.04373363f, 0.10945789f, 0.09405008f, 0.04272633f, 
    0.08862491f, 0.14373453f, -0.16064787f, -0.00093432f, 0.00644042f, 0.05216235f, -0.04981117f, -0.00219726f, 
    -0.13902585f, 0.05478052f, 0.12476889f, 0.24409558f, 0.19424960f, 0.04239203f, 0.16024695f, 0.09506506f, 
    0.04483735f, 0.02548846f, -0.06813575f, -0.05010660f, -0.13683267f, -0.05585198f, -0.09739280f, 0.11256494f, 
    0.36372194f, -0.23077463f, 0.05241632f, 0.19088502f, 0.12273654f, 0.13069524f, 0.06053505f, 0.13326052f, 
    0.12170162f, -0.03265223f, -0.00846823f, 0.14273165f, -0.01675622f, -0.09866708f, -0.04489804f, 0.15511571f, 
    0.06894275f, 0.04292703f, 0.00655116f, -0.02876557f, 0.10306093f, 0.19607919f, 0.22708474f, 0.40636984f, 
    0.12353978f, -0.00130466f, 0.01338936f, 0.13100871f, -0.06441930f, 0.08473916f, 0.05216077f, -0.02453437f, 
    -0.16943100f, -0.07422691f, -0.02558224f, -0.04205166f, 0.18446094f, 0.01019912f, 0.24033603f, -0.23709860f, 
    -0.06631805f, 0.16116467f, -0.11354204f, 0.03318475f, -0.03554325f, -0.04060521f, -0.00529342f, -0.19493297f, 
    0.04724198f, 0.07624137f, -0.14146070f, -0.08067527f, -0.18516798f, -0.01002201f, 0.06366581f, 0.16155660f, 
    0.07324101f, 0.04227984f, 0.02002980f, -0.04648195f, 0.01574481f, 0.13037539f, -0.06419898f, 0.28715467f, 
    0.10007518f, 0.05149336f, 0.00837571f, -0.10509036f, -0.06536010f, -0.01898729f, -0.07145174f, -0.25418845f, 
    0.05915781f, -0.02098444f, -0.12095040f, 0.25363803f, 0.11906551f, 0.02092465f, 0.05230734f, 0.02189486f, 
    0.04331039f, -0.10353944f, 0.10596536f, 0.07445412f, -0.09630180f, 0.05801862f, 0.06881845f, 0.22754796f, 
    0.04005221f, -0.11614856f, -0.02360578f, -0.15485145f, 0.17701004f, 0.08190212f, -0.05917536f, 0.02400012f, 
    -0.12015489f, -0.05378461f, 0.14510511f, -0.23962796f, -0.00662319f, 0.03012516f, -0.02900247f, 0.05952017f, 
    -0.00941606f, 0.11892958f, -0.04009859f, 0.21438795f, 0.00153082f, -0.07123537f, -0.00712950f, 0.12168950f, 
    0.02795295f, 0.10714091f, 0.07979438f, -0.07253136f, 0.03339930f, 0.13637143f, 0.04438202f, 0.07449841f, 
    0.20097005f, 0.03863294f, 0.03540361f, -0.04121397f, -0.07921337f, 0.05783656f, 0.06710039f, -0.05432832f, 
    -0.14908664f, -0.05996114f, -0.08502190f, -0.20753363f, 0.26048321f, -0.36642343f, 0.20861781f, 0.26902381f, 
    -0.07385922f, -0.00533439f, -0.04897890f, -0.01864093f, -0.04875454f, -0.00518098f, -0.12484165f, -0.26323745f, 
    0.10376143f, 0.03889557f, -0.09346531f, 0.00426280f, 0.04226872f, 0.14319786f, 0.13967162f, 0.12844822f, 
    -0.04454923f, -0.00751996f, 0.04991539f, -0.02541399f, 0.11584783f, 0.15471184f, 0.12386076f, 0.04673028f, 
    -0.05401983f, 0.01245586f, 0.00607030f, -0.16135968f, 0.02148253f, 0.07486060f, -0.05711268f, 0.01280574f, 
    0.05542022f, -0.10200951f, -0.21596074f, -0.09399601f, -0.14400737f, 0.06664642f, -0.06656072f, 0.09365530f, 
    0.04535463f, 0.01396032f, 0.08199672f, -0.02673013f, -0.07647023f, -0.12929560f, 0.02129847f, 0.00126748f, 
    -0.16456246f, -0.02514710f, -0.13185070f, -0.20048814f, 0.07322378f, 0.02296617f, -0.00122359f, -0.07552718f, 
    0.05753936f, 0.05028818f, -0.05318036f, -0.08784847f, 0.08748080f, -0.08381183f, -0.11198717f, -0.01780269f, 
    -0.03561466f, 0.09058117f, -0.11015760f, -0.13978085f, 0.11347102f, -0.02131069f, -0.07941841f, -0.09682313f, 
    0.04516403f, -0.11906342f, -0.10603437f, 0.13339426f, -0.05557659f, 0.04096666f, 0.05943692f, -0.09170491f, 
    -0.16841044f, -0.02442360f, 0.08263837f, -0.06435497f, 0.09639768f, 0.13409102f, 0.02414907f, 0.00153207f, 
    -0.06775446f, -0.01779147f, -0.14906120f, -0.19036463f, -0.11925987f, 0.14908904f, -0.03928053f, -0.04411366f, 
    0.05273816f, -0.01994408f, 0.00953421f, -0.03597106f, 0.00485910f, 0.12212244f, 0.07804231f, 0.20749752f, 
    0.13806991f, 0.03257450f, -0.17804798f, -0.07096125f, -0.03445105f, 0.10336354f, 0.00524484f, -0.00927228f, 
    -0.05134736f, -0.03399474f, 0.02501713f, 0.04779233f, -0.23559892f, 0.16082954f, 0.07457811f, -0.08396243f, 
    0.03825230f, 0.08816756f, -0.03878438f, -0.04022354f, -0.04387081f, -0.01456202f, -0.16378453f, -0.09460615f, 
    0.20383900f, 0.16468942f, 0.07317347f, 0.08763774f, -0.04009028f, 0.00855442f, -0.03703063f, -0.01339409f, 
    -0.00729936f, -0.03277792f, 0.06464830f, -0.02384411f, 0.02526443f, 0.13296060f, -0.05365572f, 0.09438020f, 
    0.14211981f, -0.17825921f, -0.09419972f, -0.06620288f, -0.11780165f, 0.06813726f, 0.05551019f, -0.11389182f, 
    -0.14811015f, 0.24692535f, -0.11012333f, -0.04119999f, 0.10832925f, -0.10401285f, 0.10276375f, -0.19133532f, 
    0.01128813f, 0.04878258f, 0.09088166f, -0.08909438f, 0.03763674f, 0.02314674f, -0.18469861f, -0.09836262f, 
    0.17828916f, 0.05413543f, 0.03209544f, -0.02993290f, -0.01478201f, -0.03552200f, -0.04224040f, -0.00646591f, 
    -0.01650743f, -0.09752335f, -0.09827188f, 0.15973404f, -0.08683181f, 0.15108682f, 0.05352017f, -0.00815013f, 
    -0.06886657f, -0.04187671f, -0.08019341f, 0.10878123f, 0.12098247f, -0.07859245f, -0.04695247f, 0.13338985f, 
    -0.08626491f, -0.02363587f, 0.08936770f, 0.12632565f, -0.03475532f, -0.04320790f, 0.06626260f, 0.05247276f, 
    -0.28900003f, -0.04980452f, -0.03743942f, 0.05865385f, 0.01947070f, 0.06890900f, -0.07453239f, -0.09899725f, 
    -0.21151145f, 0.07007110f, -0.11480603f, 0.04067276f, 0.10894009f, 0.02218365f, -0.13111924f, 0.07883186f, 
    -0.00311723f, 0.15655622f, 0.05616441f, 0.02221450f, 0.04102960f, 0.00951987f, -0.05159892f, 0.01367021f, 
    -0.01646848f, -0.03942086f, 0.01372997f, -0.00972626f, 0.02874020f, -0.01484686f, 0.00621179f, -0.01502379f, 
    -0.00569190f, -0.03470504f, -0.02705174f, -0.03077906f, -0.00106548f, 0.00350141f, -0.00151266f, -0.02598844f, 
    -0.02381825f, 0.01580941f, -0.02067924f, -0.01351389f, 0.00414845f, -0.01759592f, 0.01562904f, -0.01443376f, 
    -0.00196440f, -0.01878754f, -0.01182643f, -0.01344713f, -0.02203241f, -0.03007334f, 0.02920292f, -0.02425848f, 
    -0.03203836f, 0.00880158f, -0.02265841f, 0.03317774f, 0.00423259f, 0.01205290f, -0.00708549f, 0.01715761f, 
    -0.01917873f, -0.01169219f, 0.00730794f, -0.03761001f, -0.01897484f, -0.01102880f, 0.01841947f, 0.01966945f, 
    0.02471661f, 0.02374044f, 0.01451874f, -0.03680352f, -0.02039855f, -0.03279991f, -0.01453614f, -0.00362123f, 
    0.01507992f, 0.02028066f, 0.00084190f, 0.01069321f, 0.00925384f, -0.01794554f, 0.00397453f, -0.02195183f, 
    -0.02649568f, 0.00657486f, -0.03848739f, 0.03076912f, -0.04276540f, 0.01487944f, -0.03429579f, -0.00947448f, 
    -0.00868101f, -0.02641861f, 0.01440569f, -0.02864134f, -0.02122717f, -0.01334447f, -0.01499484f, -0.02540917f, 
    0.01024398f, -0.03883006f, -0.00493772f, 0.02649200f, 0.00393862f, -0.03197512f, 0.00709025f, 0.01519542f, 
    -0.02340762f, -0.02946706f, -0.02072261f, -0.02003306f, -0.00845059f, 0.03261757f, -0.03037140f, 0.03220275f, 
    0.02725069f, 0.01916311f, -0.00044811f, 0.00894576f, -0.02219143f, 0.01180443f, 0.02309070f, -0.03547040f, 
    0.02086516f, 0.01174152f, -0.03466336f, -0.03555220f, 0.01062558f, -0.02215206f, 0.01473493f, 0.01650087f, 
    -0.00966052f, -0.00957666f, -0.02392561f, -0.04086103f, 0.01831401f, -0.03022327f, 0.02101396f, -0.00853129f, 
    0.03236083f, 0.03301262f, 0.01095977f, 0.01987089f, -0.00947394f, -0.01124225f, -0.00236802f, 0.02500080f, 
    -0.03979423f, 0.03334127f, -0.03394581f, 0.00996173f, -0.00966514f, -0.00342661f, -0.03501631f, 0.02971226f, 
    0.01149668f, -0.02523202f, -0.02692899f, 0.02232443f, -0.02830871f, 0.02255575f, 0.00112194f, -0.01068674f, 
    -0.02270363f, -0.03709083f, -0.03531543f, -0.03548314f, -0.01003007f, -0.00725454f, 0.00190585f, -0.01551145f, 
    0.01724664f, -0.03314840f, -0.02045067f, -0.00468450f, 0.00396448f, -0.01445692f, 0.02130864f, -0.02446162f, 
    0.01816090f, -0.01737562f, -0.02901368f, -0.00246793f, -0.01970257f, 0.02605458f, 0.00951159f, 0.00844423f, 
    -0.03160472f, -0.01938909f, -0.01129780f, -0.02566972f, -0.02924096f, 0.00335427f, -0.03444364f, -0.01758767f, 
    -0.00547959f, 0.02333925f, 0.02846508f, 0.00860490f, -0.03615982f, -0.01523449f, -0.02841127f, -0.02245940f, 
    0.02581356f, -0.01219610f, 0.01894112f, 0.02437243f, -0.02362700f, -0.01986569f, -0.00543287f, 0.02828292f, 
    0.01604734f, -0.04175956f, -0.02443011f, 0.00161935f, -0.02162609f, -0.03933167f, 0.00368386f, -0.02835753f, 
    0.03080636f, 0.01632021f, -0.03982687f, -0.02863927f, 0.00442970f, 0.00989321f, 0.03143245f, 0.00937564f, 
    -0.02656432f, 0.02917635f, -0.00347292f, 0.01934898f, -0.03351725f, 0.01298517f, -0.03129288f, -0.01061209f, 
    0.00420040f, 0.01463952f, -0.02741473f, 0.01080453f, -0.00903980f, 0.01039652f, 0.00384108f, 0.01612916f, 
    -0.00785231f, 0.00959536f, 0.03124302f, -0.03550304f, -0.02643867f, -0.01465850f, 0.02019389f, -0.02260172f, 
    0.03244432f, 0.00726490f, -0.03111628f, 0.03062394f, 0.01747192f, -0.01886834f, -0.01005644f, -0.01034644f, 
    -0.01406520f, -0.02664555f, 0.03111837f, 0.00779940f, 0.01928189f, 0.02038628f, -0.02645927f, 0.02643067f, 
    -0.02070313f, -0.03522798f, -0.03182910f, -0.00565745f, -0.02536651f, 0.02756521f, -0.00735643f, -0.02476731f, 
    -0.01425306f, -0.00306990f, -0.01384513f, 0.00930312f, 0.01886394f, -0.01004858f, 0.00724657f, -0.02069377f, 
    0.01436289f, -0.00114249f, 0.02685656f, -0.02141139f, -0.02676332f, 0.02625219f, -0.03427731f, -0.03087137f, 
    0.01085185f, -0.03518607f, 0.01236734f, -0.03364568f, 0.01027823f, -0.03018417f, -0.01776267f, -0.03599579f, 
    0.01542422f, 0.01972885f, -0.03330998f, 0.00052319f, -0.01125042f, -0.02003653f, -0.03343415f, 0.00902151f, 
    0.02059894f, -0.01545846f, 0.01041385f, -0.00032591f, -0.00394218f, -0.02516212f, 0.02940277f, -0.00183543f, 
    0.00020796f, 0.02511475f, 0.02443150f, 0.02522180f, 0.01492674f, 0.02921128f, -0.01186111f, 0.02285128f, 
    -0.01315123f, 0.01423719f, -0.02874381f, -0.02187484f, -0.03653800f, -0.00985081f, -0.00206038f, 0.01039428f, 
    0.00959871f, -0.02871394f, 0.00367115f, 0.02485413f, -0.01614851f, -0.01987951f, 0.00907684f, 0.00282699f, 
    -0.03082805f, -0.02870885f, -0.00101436f, 0.00398922f, -0.02135294f, 0.01146329f, -0.03454047f, 0.01169056f, 
    0.00183442f, -0.03131068f, -0.03128438f, 0.02565455f, -0.03058748f, -0.02595280f, 0.01208125f, -0.00184929f, 
    0.03660580f, 0.00144587f, -0.02951685f, -0.04063528f, -0.01980523f, -0.03112285f, -0.02665876f, -0.03310761f, 
    0.00965754f, 0.01134111f, 0.03312581f, 0.01731221f, -0.00217253f, -0.03481197f, -0.03407995f, 0.02606581f, 
    -0.03385530f, -0.00530682f, 0.00453742f, 0.01719343f, -0.02648268f, -0.01513285f, 0.01157872f, 0.02809722f, 
    -0.02907169f, -0.02910565f, -0.03413276f, -0.03738971f, -0.01502683f, 0.00199445f, -0.00657696f, -0.01223586f, 
    0.00332668f, -0.03026020f, -0.02126279f, 0.00223883f, -0.00129320f, 0.00966893f, -0.01989247f, -0.02993416f, 
    0.01856654f, -0.01430316f, -0.02016969f, -0.02006493f, 0.01129571f, -0.03386474f, 0.01415674f, 0.03054699f, 
    -0.02121142f, 0.01463213f, -0.03729920f, 0.02607009f, 0.01986977f, 0.02584361f, 0.00958323f, -0.00385333f, 
    -0.01188408f, -0.01212050f, 0.02271981f, 0.01110186f, 0.01492134f, 0.01567045f, -0.02496977f, -0.01758871f, 
    -0.00037529f, -0.00620136f, 0.00780626f, -0.01656304f, 0.02985222f, 0.01471071f, 0.02855001f, -0.02468820f, 
    -0.02481685f, 0.00658825f, -0.03837638f, -0.03750273f, 0.00159092f, -0.01090012f, -0.02211121f, -0.00870129f, 
    -0.02177139f, -0.03601323f, 0.01536301f, -0.04120693f, -0.01629977f, -0.03905371f, -0.01382569f, -0.03084446f, 
    -0.02124740f, 0.01132396f, 0.02311877f, -0.02990631f, 0.02259874f, 0.00460567f, 0.00227257f, -0.03506142f, 
    -0.00058045f, -0.01385796f, 0.00346561f, 0.01217101f, 0.00846965f, 0.02928523f, 0.00353213f, 0.01552279f, 
    0.02191739f, 0.01924415f, 0.01010106f, -0.00002369f, 0.01661342f, 0.01025338f, -0.03616356f, -0.03175549f, 
    0.02540174f, -0.02418003f, -0.01712315f, 0.02559318f, 0.02041300f, -0.00502789f, -0.00937681f, -0.03687738f, 
    0.00495518f, 0.01209959f, -0.01855526f, 0.02033927f, 0.00817328f, -0.00431107f, -0.02815806f, -0.03558933f, 
    0.03135533f, -0.02348802f, 0.00484727f, 0.02574330f, -0.00613773f, 0.02825011f, -0.01225812f, 0.01606050f, 
    -0.03455568f, 0.00970982f, -0.02948698f, 0.01988249f, -0.03403116f, 0.01183293f, 0.00670483f, 0.00023003f, 
    0.02743264f, -0.01279038f, -0.00541818f, -0.03592538f, -0.03288653f, -0.03394528f, -0.01774530f, 0.01723988f, 
    0.01149741f, 0.02091238f, 0.01009837f, 0.01663336f, -0.04182934f, -0.00181150f, 0.02877546f, 0.02325442f, 
    -0.00448098f, -0.02500756f, -0.02762506f, -0.00513727f, -0.01495919f, 0.03747114f, 0.00605188f, -0.02969327f, 
    -0.02742920f, -0.03858811f, -0.00925017f, 0.01029389f, 0.01708207f, -0.00902435f, 0.01586637f, 0.01091759f, 
    0.02244464f, 0.00092337f, -0.00241018f, -0.02108090f, -0.03595807f, -0.03550865f, -0.01062839f, -0.01962859f, 
    -0.00995565f, -0.01487360f, 0.00113395f, 0.02794670f, 0.01509634f, 0.01532506f, -0.02524488f, 0.00964233f, 
    0.02948007f, 0.00173825f, -0.00202943f, 0.01127082f, -0.00611488f, 0.00662182f, -0.01871561f, 0.01842850f, 
    -0.02098613f, -0.01219958f, -0.02201905f, -0.02964130f, -0.01689669f, -0.01684880f, -0.00297188f, 0.01320038f, 
    0.01175656f, 0.00197412f, -0.00399408f, -0.01641376f, -0.03293310f, -0.00669405f, -0.00973160f, 0.01158582f, 
    0.02835507f, -0.01453137f, 0.00536193f, 0.01020731f, -0.02716408f, 0.00295867f, -0.03837211f, -0.00983955f, 
    0.01175119f, 0.00525834f, -0.00983090f, 0.02539541f, 0.01281386f, -0.02076069f, 0.00357369f, 0.02737786f, 
    0.00626498f, 0.00072309f, 0.02988478f, 0.00354848f, -0.00265494f, 0.02411675f, -0.00086107f, 0.00695399f, 
    0.02484985f, 0.00628299f, -0.01525820f, -0.02308743f, -0.04059172f, -0.03603717f, -0.02632413f, -0.00823750f, 
    -0.02008281f, -0.01552003f, 0.01249092f, -0.02997992f, -0.02838513f, 0.01590982f, 0.00849104f, 0.02119407f, 
    -0.03789056f, 0.00626339f, -0.00288352f, -0.03716942f, -0.00943172f, -0.02315541f, -0.03629981f, -0.02499877f, 
    -0.03042373f, 0.00979230f, -0.00921843f, -0.01794566f, -0.02715047f, -0.00912053f, 0.02246563f, -0.00070263f, 
    -0.02150989f, -0.00473326f, -0.01986269f, 0.02361733f, -0.03558030f, 0.02187667f, -0.02636937f, 0.01917175f, 
    0.02539069f, -0.02146416f, -0.02036886f, 0.01628904f, -0.00197113f, -0.02819265f, 0.03237319f, -0.01694394f, 
    0.00961479f, -0.02718059f, 0.02086320f, -0.03432830f, 0.00655304f, 0.01669665f, -0.00390534f, 0.02633761f, 
    -0.02139155f, 0.01837123f, -0.02344239f, 0.02460971f, 0.00801579f, 0.02419379f, -0.03781819f, -0.03764705f, 
    -0.03191935f, -0.00347273f, -0.02742197f, -0.03292914f, -0.00798622f, -0.02231471f, 0.01670079f, -0.03128343f, 
    0.01342549f, -0.03077069f, -0.00292241f, -0.01260303f, -0.01832138f, -0.02732608f, -0.03194093f, -0.01427463f, 
    0.01424538f, -0.04259151f, -0.01983273f, -0.00213447f, -0.02816785f, 0.01206851f, -0.02162032f, -0.03761537f, 
    -0.02677348f, 0.00064292f, -0.02127222f, 0.03369149f, -0.00652684f, 0.02776482f, 0.02944895f, -0.03801529f, 
    -0.01065661f, 0.00174234f, -0.03335199f, -0.00438321f, 0.00532374f, 0.02548259f, -0.00551671f, -0.01662230f, 
    -0.02309216f, 0.01167274f, -0.02782100f, 0.02574448f, 0.00063865f, -0.03311893f, 0.02120697f, -0.01363654f, 
    0.00116157f, -0.02483998f, -0.01999141f, -0.03005638f, 0.00435551f, 0.01624396f, -0.00212978f, 0.03271790f, 
    0.00257742f, 0.02949571f, -0.03873239f, 0.02281767f, -0.00398094f, 0.01832693f, 0.00973219f, -0.04265642f, 
    -0.03783997f, 0.00773954f, 0.02973458f, 0.00044502f, -0.02280457f, 0.02109464f, 0.00847012f, 0.01439406f, 
    -0.02961471f, 0.01016217f, -0.01421003f, 0.01951187f, -0.01351873f, -0.02006978f, -0.02184418f, -0.02832805f, 
    0.02500165f, -0.03558244f, -0.03971172f, 0.00279721f, -0.00318016f, 0.01638852f, -0.00545469f, -0.00030279f, 
    -0.00337137f, -0.02654428f, -0.01991856f, 0.01637850f, 0.01634128f, -0.02938961f, -0.03249082f, 0.01933718f, 
    -0.03844971f, 0.00099805f, 0.00207763f, -0.02043159f, 0.01373924f, -0.00299440f, -0.00370514f, 0.02394615f, 
    -0.04313835f, 0.00658261f, -0.00133393f, 0.02637473f, 0.01087132f, 0.00369600f, 0.02184783f, -0.01074914f, 
    -0.03380887f, -0.03239018f, -0.01494041f, -0.03577626f, 0.00684988f, 0.00187449f, -0.03737272f, -0.01434727f, 
    0.00223417f, 0.02509357f, -0.01299928f, 0.00000473f, 0.02833152f, -0.03919228f, -0.02237666f, -0.03396531f, 
    0.17432782f, 0.15580137f, -0.33433712f, -0.05970796f, -0.02764760f, -0.06915358f, 0.04506809f, 0.06684270f, 
    -0.09606697f, 0.00450639f, 0.08381141f, 0.08323828f, -0.29810047f, 0.27516049f, -0.09261858f, -0.22320983f, 
    0.03804552f, 0.00060483f, 0.05945844f, 0.02260568f, 0.02911165f, -0.09712265f, -0.06821080f, 0.08939619f, 
    0.02636588f, 0.03750025f, -0.09861892f, -0.00577101f, -0.02523468f, 0.00250088f, 0.13563280f, -0.06755915f, 
    0.06709006f, -0.04266319f, 0.00925057f, -0.04281477f, 0.28911808f, 0.29345617f, 0.21594343f, 0.09987590f, 
    0.03469497f, 0.05951969f, 0.09366256f, 0.19255722f, 0.02217158f, 0.12696899f, 0.05983014f, -0.03424514f, 
    0.35036162f, 0.22686836f, -0.10485274f, -0.08294506f, 0.06981514f, 0.03076180f, 0.00721671f, 0.04720319f, 
    -0.00220610f, 0.00839559f, 0.03554091f, -0.00743385f, 0.10701560f, -0.00170943f, 0.66779280f, -0.03158510f, 
    -0.05825526f, -0.05872535f, -0.02055017f, -0.03601588f, 0.02272814f, -0.09429079f, -0.02906015f, -0.09094708f, 
    -0.09279122f, -0.07511152f, -0.04414630f, -0.01554486f, 0.02013976f, 0.04084476f, 0.05751263f, -0.01039914f, 
    -0.02025511f, -0.02839343f, -0.04082042f, 0.18075140f, 0.13484704f, -0.24315712f, -0.07986789f, -0.26159638f, 
    -0.05772425f, -0.03691659f, 0.07240877f, -0.12870699f, -0.12627086f, 0.04534264f, -0.15555969f, 0.24928348f, 
    0.12947430f, -0.06250780f, -0.09188275f, -0.00202471f, 0.09119873f, -0.10780362f, -0.01373457f, 0.01985322f, 
    -0.02020304f, -0.11824778f, -0.06208616f, -0.00916273f, -0.21434043f, -0.33184823f, -0.20291169f, -0.08053441f, 
    0.13742547f, 0.06606241f, 0.01228984f, -0.00192354f, 0.03289723f, 0.07040311f, 0.02256097f, 0.07803112f, 
    0.30437374f, 0.21942046f, -0.04450756f, -0.09113387f, -0.00236078f, 0.16568811f, -0.00663704f, -0.02920631f, 
    0.00482480f, -0.03372547f, 0.08112679f, -0.05134149f, -0.02247155f, -0.08421049f, -0.14630678f, -0.22389250f, 
    0.01931005f, 0.08767760f, 0.16573283f, -0.06192837f, -0.07725180f, -0.01882082f, 0.03506571f, -0.05731231f, 
    -0.10282218f, 0.01645677f, 0.11841213f, 0.13474013f, 0.14036176f, 0.02163865f, 0.08320762f, -0.03832107f, 
    0.12576751f, -0.05532111f, -0.06504124f, -0.03103817f, 0.13987491f, 0.27067485f, 0.09221230f, -0.16684242f, 
    0.10570645f, 0.02051125f, -0.00339710f, 0.09735630f, -0.01270535f, -0.04679834f, 0.00395308f, 0.04266266f, 
    0.39538774f, 0.29341283f, 0.37254354f, 0.23307139f, -0.08320156f, 0.06091256f, 0.02647832f, 0.02978915f, 
    0.07492582f, -0.01841670f, -0.03455596f, -0.01095419f, 0.42099714f, 0.11489351f, 0.02465339f, -0.14687367f, 
    -0.09595370f, -0.13976355f, -0.06008796f, 0.13079500f, 0.00664149f, 0.05313493f, -0.00736733f, 0.03935575f, 
    0.34104979f, -0.01270724f, -0.20856284f, -0.10738441f, 0.09179123f, 0.03601715f, -0.06421223f, 0.07336951f, 
    -0.00321630f, 0.00101903f, 0.05371248f, 0.01675581f, -0.13724960f, -0.02383833f, -0.19823997f, 0.03849929f, 
    -0.04568401f, 0.02714290f, -0.07458077f, 0.04362960f, 0.01716127f, 0.02581047f, -0.04713291f, -0.11864389f, 
    -0.26015645f, -0.52950978f, 0.19851226f, -0.18035682f, 0.04514220f, 0.01144315f, -0.03088964f, -0.06363641f, 
    -0.10795910f, -0.06402302f, 0.01539177f, 0.03109658f, 0.00419344f, 0.13948107f, -0.19362246f, 0.11105055f, 
    0.12038352f, 0.05473299f, -0.07481889f, -0.01463297f, 0.03371234f, 0.02576186f, 0.07189848f, 0.18801916f, 
    -0.04287906f, 0.11477771f, 0.15991458f, -0.04985831f, 0.03032562f, 0.02715440f, 0.12298935f, 0.06128821f, 
    -0.03979686f, -0.09879506f, 0.03912497f, 0.04574212f, 0.30037719f, -0.28389457f, -0.16167022f, 0.01211911f, 
    -0.03216217f, 0.08591313f, 0.04724936f, -0.06122226f, -0.05193093f, 0.00678256f, 0.05725515f, 0.00606150f, 
    0.11939835f, -0.13775322f, 0.11556215f, -0.20037682f, 0.06275558f, 0.04899562f, 0.00166580f, 0.06170169f, 
    0.04529598f, 0.06286426f, 0.02038064f, -0.06366123f, -0.36169761f, -0.20466591f, -0.12775251f, 0.02663583f, 
    -0.01848538f, -0.00301479f, -0.08446655f, -0.02253911f, 0.04107074f, -0.08288816f, -0.11729030f, 0.17364271f, 
    0.17694528f, -0.20419790f, 0.23656878f, -0.21281959f, -0.14073408f, 0.11798742f, -0.00226303f, -0.05994870f, 
    0.01831889f, 0.00030005f, -0.14260125f, 0.12031959f, 0.22864269f, -0.45169720f, 0.11923362f, -0.24115933f, 
    -0.02769996f, -0.02465207f, -0.07309560f, -0.04414813f, 0.03293078f, -0.01407235f, -0.06818832f, 0.06100109f, 
    0.01966253f, 0.22494920f, 0.04716191f, 0.10982172f, 0.12285456f, 0.09901056f, -0.05663713f, 0.10850446f, 
    0.03759441f, -0.03004816f, -0.14621753f, -0.09275436f, 0.30601087f, 0.18737689f, 0.16266131f, 0.02226661f, 
    0.12674476f, 0.07098902f, -0.06604934f, 0.06054629f, 0.10268783f, 0.02430891f, -0.09304900f, 0.04609285f, 
    -0.09313671f, -0.15884842f, -0.01147073f, -0.08695794f, 0.08454496f, 0.03471971f, -0.03090453f, -0.03358276f, 
    0.10375419f, -0.01038823f, 0.11545177f, 0.11931863f, -0.14614764f, -0.14514007f, -0.22416340f, -0.13660844f, 
    -0.03528168f, 0.04993822f, 0.03500057f, -0.01362621f, 0.06781172f, -0.04237874f, -0.14626503f, -0.01823501f, 
    -0.16705365f, -0.31172884f, -0.11671167f, -0.08633314f, 0.05626473f, 0.03050009f, -0.00837711f, 0.01387370f, 
    0.06115682f, -0.00991864f, -0.03109899f, 0.02704295f, 0.19586179f, -0.05678506f, -0.01140757f, -0.00619286f, 
    0.03785167f, 0.04604090f, -0.01020503f, -0.01102236f, 0.15361232f, -0.01150026f, 0.01448756f, 0.01924703f, 
    -0.13356033f, 0.28709599f, -0.19678922f, 0.06157803f, -0.04900163f, -0.09524701f, -0.04149662f, 0.06290404f, 
    -0.00017924f, -0.12883921f, -0.01766795f, 0.07846060f, -0.19911668f, -0.28251174f, -0.16304938f, -0.16895220f, 
    0.09507953f, 0.12847953f, -0.06496822f, 0.09846081f, 0.04696274f, -0.06078964f, 0.05390056f, 0.07744349f, 
    0.04395454f, 0.00995835f, 0.00803073f, -0.01641369f, -0.05912078f, 0.09890386f, -0.00900983f, 0.01036947f, 
    -0.04216029f, -0.01669239f, 0.02889694f, -0.00972106f, -0.28068286f, -0.08982195f, 0.05634597f, 0.03317620f, 
    0.04485122f, 0.02406864f, -0.07671016f, 0.04651115f, 0.00446003f, -0.01332330f, 0.03733706f, 0.13948825f, 
    -0.13665804f, -0.33672664f, -0.23712185f, 0.00419891f, -0.00118810f, -0.03539797f, -0.00836789f, -0.02534470f, 
    0.04811468f, 0.03039796f, 0.00713173f, 0.05732130f, -0.00149324f, 0.33544880f, -0.24076162f, 0.14558336f, 
    -0.16108689f, -0.12816016f, 0.09827837f, -0.06615479f, 0.01884420f, -0.04913362f, -0.08903559f, 0.01129315f, 
    0.52923471f, 0.60450619f, 0.46421415f, 0.21136844f, -0.09245641f, -0.11863398f, -0.03006562f, 0.21645653f, 
    -0.02833083f, 0.00049165f, -0.01630550f, -0.01270551f, -0.04536167f, -0.13456678f, 0.04900688f, -0.05968940f, 
    0.00383972f, -0.00370659f, -0.00425189f, -0.03110757f, -0.03547874f, -0.08652760f, -0.21448070f, -0.06468902f, 
    0.34454134f, -0.06954605f, 0.05644856f, 0.13926950f, -0.05064323f, 0.06124984f, 0.02305165f, -0.09194125f, 
    0.03281955f, 0.08456945f, -0.03025569f, 0.00896785f, 0.11577591f, 0.27357671f, 0.22035573f, 0.08834691f, 
    0.02950975f, 0.05216985f, 0.01078460f, -0.07117876f, 0.13444538f, -0.00256784f, -0.01269852f, -0.00042725f, 
    0.01184420f, 0.33435217f, -0.14048360f, 0.06126020f, -0.07154662f, -0.04678506f, -0.01468647f, 0.01114037f, 
    0.08362221f, -0.01659109f, 0.16897573f, -0.00000418f, -0.11039505f, -0.24875031f, -0.15587747f, -0.13653466f, 
    -0.03715241f, -0.03684208f, -0.02848843f, -0.01350922f, -0.07192401f, -0.09408500f, -0.00042140f, 0.11310539f, 
    0.22039141f, 0.20130484f, -0.00855616f, -0.13011946f, 0.10991801f, 0.01611456f, -0.01007570f, 0.06824770f, 
    0.02129743f, 0.01293502f, -0.00871142f, 0.01024185f, 0.20894969f, 0.32065561f, -0.39884368f, 0.04917532f, 
    0.01039017f, 0.00134706f, 0.11489401f, 0.05744598f, -0.02929942f, 0.05699261f, -0.05807675f, 0.04907409f, 
    0.23446736f, 0.33616018f, 0.22394621f, 0.09787552f, 0.06749677f, 0.11152776f, 0.02354006f, 0.18549520f, 
    0.00212329f, -0.03573063f, 0.07512624f, 0.18803917f, 0.02957950f, 0.04581820f, 0.08928925f, -0.04664878f, 
    0.03710026f, 0.04279695f, 0.02958490f, 0.10978274f, 0.04574390f, -0.02353901f, 0.02529612f, -0.04392123f, 
    0.46334618f, 0.41637075f, 0.20905788f, 0.03855485f, 0.00801239f, -0.12475962f, 0.08161525f, 0.10598478f, 
    0.01793632f, -0.00223805f, -0.03832315f, -0.00009173f, -0.05296377f, -0.03782712f, -0.25911745f, -0.08166283f, 
    -0.02928667f, -0.14010240f, -0.02080012f, 0.00654954f, -0.04749899f, -0.03514476f, -0.02477107f, -0.06597495f, 
    0.21432941f, 0.35392290f, 0.23539148f, 0.21379073f, 0.16380610f, 0.13904482f, -0.00466278f, 0.06829090f, 
    0.08750330f, 0.02641284f, 0.09795990f, -0.04204778f, 0.14472437f, 0.09043049f, 0.07207675f, -0.05318883f, 
    0.03888943f, 0.06181258f, -0.03107820f, 0.13390298f, -0.03435739f, -0.00686064f, -0.09987846f, -0.06391106f, 
    -0.09836888f, -0.15743807f, -0.06693874f, -0.02053776f, 0.13999599f, 0.03013522f, 0.00690481f, -0.06063422f, 
    0.02068122f, -0.02394255f, -0.14853567f, 0.07662711f, -0.05970310f, 0.06846759f, 0.08313403f, 0.03652914f, 
    -0.00250912f, -0.04395461f, -0.03855629f, 0.04277194f, -0.05978019f, -0.11374944f, 0.08558708f, 0.15255716f, 
    0.04387934f, 0.44763374f, 0.14106052f, 0.29632291f, 0.01572217f, 0.03429060f, 0.20698322f, 0.14462313f, 
    0.00345713f, -0.02431278f, 0.00263159f, 0.00580904f, -0.45779330f, -0.21207654f, -0.01577972f, -0.10708547f, 
    -0.02530196f, 0.00799139f, 0.05499227f, -0.07712220f, -0.03686809f, 0.03646349f, -0.22830778f, 0.07400689f, 
    0.12480375f, 0.10356908f, 0.02039908f, -0.10306286f, -0.02639989f, 0.07510330f, 0.03988932f, -0.02375500f, 
    0.00495884f, -0.07121664f, 0.04207471f, 0.01173276f, 0.20319591f, -0.15198249f, -0.15137082f, -0.09797395f, 
    -0.14883867f, 0.02384610f, -0.01875303f, -0.07683609f, 0.08601138f, -0.03332721f, -0.11802347f, -0.03290993f, 
    -0.40505490f, 0.02928977f, 0.39544043f, -0.13104817f, 0.11512943f, -0.12203027f, -0.11690333f, -0.00102607f, 
    0.04447733f, -0.06571471f, -0.11381442f, -0.04619041f, 0.25314406f, 0.26363760f, 0.35896608f, 0.14035556f, 
    0.06681862f, 0.12100031f, 0.09855493f, 0.09378169f, 0.01516749f, -0.10010319f, -0.05593431f, 0.06781315f, 
    -0.20083565f, -0.18880878f, -0.28956199f, -0.12765442f, -0.00718032f, 0.02407029f, 0.02853029f, -0.01384131f, 
    -0.04104279f, 0.07706298f, 0.15929814f, -0.05120467f, 0.22144674f, 0.23037215f, 0.02244024f, -0.04394362f, 
    0.02848707f, 0.10437341f, -0.02824887f, -0.00442505f, -0.06869780f, -0.03825960f, -0.01628557f, 0.02488446f, 
    -0.13333163f, -0.28028592f, 0.29488522f, 0.03381318f, -0.05620107f, -0.00940596f, -0.04959681f, -0.06895446f, 
    -0.06166161f, -0.01304585f, 0.08304743f, 0.02753658f, -0.10964083f, -0.18147342f, -0.22866832f, -0.19424269f, 
    0.09417896f, 0.04122878f, -0.03347931f, -0.03150545f, 0.07948925f, 0.04200175f, 0.04963281f, 0.02678025f, 
    0.67411691f, 0.28419751f, -0.13642508f, 0.04532227f, -0.03714381f, -0.01011192f, 0.02579591f, 0.07113504f, 
    -0.04099977f, 0.04820161f, 0.03059700f, -0.05289785f, -0.18452570f, 0.06727058f, -0.10133332f, -0.04965157f, 
    0.09432897f, 0.01049268f, -0.15517464f, 0.03273300f, 0.00755988f, -0.04021126f, -0.11723648f, 0.19790940f, 
    0.04552329f, 0.08514023f, -0.04943235f, 0.03139612f, -0.04636857f, 0.02477032f, -0.07911784f, -0.11088897f, 
    -0.04690716f, -0.02090416f, -0.07794420f, -0.03628409f, -0.36981583f, -0.40635741f, 0.07476103f, 0.02066197f, 
    0.16292666f, 0.11571711f, 0.08721808f, 0.08396529f, 0.12036686f, 0.07930607f, 0.00908791f, -0.02725986f, 
    -0.25111666f, -0.50504965f, -0.54466307f, -0.39966890f, 0.06932668f, -0.20803693f, -0.05811191f, 0.15128005f, 
    0.01466421f, -0.01188666f, -0.14645407f, -0.01130589f, -0.44979936f, -0.17756298f, 0.11146228f, -0.01642396f, 
    0.08616006f, 0.13722053f, 0.08220594f, 0.10364593f, -0.02113427f, -0.03325308f, -0.04309434f, 0.02345436f, 
    0.10409644f, 0.01789340f, -0.03519407f, 0.00321440f, 0.01591884f, -0.00320142f, -0.00627300f, 0.00868975f, 
    -0.06634075f, -0.20192732f, -0.02818833f, 0.03409030f, 0.21297231f, 0.12679586f, 0.17714848f, 0.02076744f, 
    0.03518737f, 0.07673214f, 0.04898143f, -0.05875161f, 0.10360010f, 0.19663608f, -0.03407854f, 0.10170843f, 
    0.08583747f, 0.05065748f, 0.00934330f, -0.01678939f, -0.03434853f, 0.02628767f, 0.04750108f, -0.04727151f, 
    -0.13896176f, -0.16716899f, 0.05887258f, -0.04486822f, 0.24956135f, 0.12744994f, 0.13074671f, 0.10612755f, 
    0.01898405f, 0.02693217f, 0.01737509f, -0.03206046f, 0.02689487f, 0.02169328f, 0.02622023f, 0.04390782f, 
    0.07576875f, -0.05926817f, -0.39580348f, -0.54048711f, 0.01918220f, 0.14462979f, -0.16800937f, 0.05215969f, 
    -0.03742586f, -0.15898143f, 0.00942855f, -0.08315394f, 0.12609434f, -0.06612778f, -0.16518241f, -0.09576750f, 
    0.03108283f, -0.10451268f, 0.05424551f, 0.07098449f, -0.19948529f, -0.06462765f, 0.09062500f, -0.09455774f, 
    -0.00283514f, 0.07526750f, 0.04262432f, 0.09741484f, 0.00024336f, -0.05018087f, 0.00085615f, -0.11089512f, 
    -0.02083496f, -0.03306568f, -0.08750223f, 0.00148447f, -0.34727186f, -0.42056742f, -0.58911222f, -0.52427024f, 
    0.20743135f, -0.03983331f, -0.13604881f, 0.13842572f, 0.01894158f, -0.01356292f, -0.06919924f, -0.08723836f, 
    -0.00403672f, 0.07490758f, -0.05827904f, 0.05010340f, 0.06574839f, 0.12566280f, 0.21362840f, 0.17093222f, 
    -0.00710064f, -0.00254709f, -0.03862948f, -0.07547908f, 0.16912384f, -0.13539286f, 0.11329675f, 0.07926156f, 
    -0.05729035f, -0.18701079f, 0.02683998f, 0.24515387f, 0.02942507f, -0.04631181f, 0.02636311f, 0.01094107f, 
    -0.34417713f, -0.44024590f, -0.65930545f, -0.68023044f, 0.00899066f, -0.04719485f, 0.13043898f, 0.11044510f, 
    0.12180116f, 0.05676943f, -0.05456902f, -0.15808240f, 0.10721112f, 0.05592320f, 0.06079129f, 0.11088193f, 
    -0.09089166f, 0.05983265f, -0.02888411f, 0.02951072f, -0.05778005f, 0.13196966f, 0.04576456f, 0.04788012f, 
    0.35482079f, 0.11615384f, 0.18513551f, 0.33020350f, 0.04568332f, 0.05280665f, 0.08656467f, 0.00454134f, 
    0.02582646f, 0.10699987f, 0.07400776f, -0.08807667f, -0.18946558f, -0.50517601f, -0.48174268f, -0.25962192f, 
    0.03904048f, -0.09202792f, -0.09018990f, 0.07315273f, 0.04856471f, -0.01098369f, -0.13494498f, 0.15702361f, 
    -0.53829616f, -0.30697411f, -0.19837567f, -0.08102717f, -0.03493212f, -0.03128293f, -0.08894958f, -0.09843901f, 
    -0.01742058f, -0.05714846f, -0.04984955f, 0.14809206f, 0.19998208f, -0.32204556f, -0.37952042f, -0.34340355f, 
    0.01271655f, 0.04942624f, 0.10510466f, -0.03343736f, -0.02586898f, -0.12310916f, -0.00115498f, 0.06244370f, 
    -0.06902473f, -0.25348359f, -0.57363963f, -0.70716882f, -0.08502485f, 0.03333355f, -0.07135267f, 0.12470628f, 
    0.20134750f, 0.03552197f, 0.24294172f, -0.12881713f, 0.17647646f, 0.03551063f, 0.17324351f, 0.08994044f, 
    0.05121156f, 0.03704919f, 0.04504358f, -0.00147063f, 0.37497777f, -0.07887246f, -0.09977821f, 0.14067987f, 
    -0.03560735f, 0.14528394f, 0.23010479f, -0.20444356f, -0.10730600f, 0.28252602f, -0.06040422f, -0.05859750f, 
    -0.05438308f, -0.10421966f, 0.16501783f, 0.05107236f, 0.11291759f, 0.19289130f, 0.16948403f, 0.23325610f, 
    0.00181055f, 0.03741278f, 0.10044727f, 0.00006375f, 0.06130934f, 0.03559284f, 0.04136727f, 0.06875939f, 
    0.04932665f, 0.06666544f, 0.03091197f, 0.09212943f, -0.02073840f, 0.19316454f, 0.07575480f, -0.23995753f, 
    -0.05720073f, -0.09566374f, -0.08327075f, 0.00978881f, -0.22743437f, -0.10204859f, -0.21204041f, -0.02180493f, 
    0.24385177f, 0.26037937f, 0.09484395f, 0.02507805f, 0.07801703f, 0.14338097f, 0.04201059f, 0.05204549f, 
    0.09575167f, 0.04123615f, 0.08485217f, 0.07277712f, 0.05515644f, -0.02728228f, -0.01331179f, 0.06411680f, 
    0.10225792f, -0.00616230f, 0.02376245f, 0.13664399f, 0.13533412f, 0.10930578f, 0.05149942f, 0.04726074f, 
    0.08552362f, 0.04841498f, -0.00621301f, -0.03217354f, 0.04836028f, -0.02401167f, -0.07594755f, -0.01916123f, 
    0.15773691f, 0.04717364f, 0.11718763f, 0.12525253f, 0.05049540f, 0.02648910f, 0.01949186f, 0.04309890f, 
    0.18174088f, 0.07024827f, 0.08749667f, 0.14660686f, -0.06592593f, -0.09996887f, 0.01757846f, 0.01058447f, 
    0.09167987f, 0.11310042f, 0.04075251f, 0.00047898f, 0.25784177f, 0.11709298f, 0.01530094f, -0.02661664f, 
    0.12934496f, 0.14999229f, -0.11332506f, -0.15862086f, 0.09922004f, -0.11114378f, -0.02371722f, -0.04692622f, 
    -0.15837570f, -0.10273493f, 0.15996251f, 0.08798106f, 0.02330532f, -0.51573682f, -0.42613778f, -0.35447526f, 
    -0.01190702f, -0.09081893f, 0.01207910f, 0.07337473f, -0.00364432f, -0.13991672f, 0.11621469f, -0.05997385f, 
    -0.07087960f, 0.10278769f, -0.04223518f, 0.00218828f, 0.01120364f, -0.00027161f, -0.06249553f, -0.00094143f, 
    -0.02342192f, -0.04731256f, 0.13011113f, 0.00306629f, -0.00249584f, -0.04037747f, -0.00952460f, -0.00366344f, 
    0.07442623f, 0.01322368f, 0.00802197f, -0.01357590f, -0.00949780f, -0.15743028f, -0.20711359f, 0.08581999f, 
    0.29734546f, 0.17408955f, 0.10198307f, 0.18170968f, -0.05460287f, 0.04296025f, 0.03920358f, 0.04196665f, 
    0.02014986f, 0.03673988f, 0.05478185f, -0.00667699f, 0.40849766f, 0.25392336f, 0.16857955f, -0.12698129f, 
    0.00467147f, 0.17438754f, -0.25538477f, -0.04565553f, 0.05326167f, -0.07015140f, 0.00001406f, -0.02214310f, 
    0.13786510f, 0.10414781f, 0.26576126f, 0.15452027f, 0.23857602f, 0.08239277f, -0.07145080f, 0.04194282f, 
    -0.03609388f, -0.03381282f, -0.02627651f, 0.04205733f, 0.06771690f, 0.06631988f, 0.16803259f, 0.05902515f, 
    -0.04482456f, 0.14980848f, -0.00075540f, 0.04572376f, -0.01286662f, -0.06420733f, -0.01224089f, -0.22909054f, 
    0.15054697f, -0.14822748f, -0.48510715f, -0.27884704f, 0.01329603f, 0.16672501f, -0.00869360f, -0.06802518f, 
    -0.00434288f, -0.04095201f, 0.15261139f, -0.11505197f, -0.06324834f, -0.02277354f, -0.10095759f, -0.10963291f, 
    -0.00843721f, 0.22050908f, -0.00658474f, 0.13830405f, 0.03308306f, 0.07332509f, -0.03487325f, 0.02781466f, 
    0.07939672f, 0.07796289f, 0.21694516f, 0.02497511f, 0.15936187f, 0.01245922f, 0.21848865f, -0.06549495f, 
    0.14002155f, 0.08271834f, 0.01214887f, 0.09013015f, 0.16026339f, 0.18149927f, 0.10574585f, 0.07874007f, 
    0.04727640f, 0.03731273f, -0.05522662f, 0.02552345f, 0.22791195f, -0.00513385f, 0.09833916f, 0.28111619f, 
    0.10357830f, 0.11054803f, 0.16006801f, 0.12030549f, -0.08586343f, 0.05570686f, -0.01056233f, -0.13765246f, 
    -0.01356754f, -0.03538841f, -0.04740155f, -0.00040899f, 0.25014278f, 0.08969649f, -0.04697404f, 0.08921359f, 
    0.06047972f, 0.13503109f, 0.01474217f, -0.00308799f, -0.01534521f, 0.06067793f, -0.00166560f, 0.00955503f, 
    -0.41522869f, -0.40686658f, -0.35289931f, 0.07425287f, 0.19609801f, 0.01654610f, 0.10413989f, 0.19635801f, 
    0.02866514f, 0.00578666f, -0.00441040f, 0.08151176f, -0.03110363f, -0.03218916f, 0.05020071f, 0.01516253f, 
    -0.00221373f, 0.01462498f, -0.00067997f, -0.02471764f, -0.16050440f, -0.10871200f, 0.03273449f, -0.08729539f, 
    -0.16489828f, -0.05635899f, -0.09948144f, 0.06134649f, 0.21825726f, 0.00071144f, -0.02296392f, 0.06806283f, 
    0.12667540f, 0.06229909f, -0.08332674f, 0.03269998f, 0.02268105f, 0.13121037f, 0.03097493f, 0.04761938f, 
    -0.02928267f, 0.13290100f, 0.09343845f, -0.04891028f, 0.15741745f, -0.00036681f, -0.07229457f, -0.05987250f, 
    -0.60136634f, -0.60839283f, -0.44284812f, 0.24244818f, 0.22755250f, 0.29308021f, 0.03381834f, -0.00576022f, 
    0.03739498f, 0.18086898f, -0.01897873f, 0.06355569f, -0.63049608f, -0.35715958f, -0.25712779f, -0.29567611f, 
    0.06366137f, 0.21503352f, -0.09038354f, -0.03410587f, 0.03101677f, 0.06629343f, -0.01446634f, -0.07001542f, 
    0.11677192f, 0.14717199f, 0.10884488f, 0.08624034f, 0.00571322f, 0.03094998f, 0.02501613f, 0.03740359f, 
    0.00775182f, -0.05054125f, -0.03656531f, -0.10299940f, -0.12078700f, -0.00552761f, 0.06664441f, 0.01386319f, 
    -0.00585087f, 0.03475031f, -0.00369640f, 0.03849680f, -0.07959613f, -0.01499173f, -0.02993828f, 0.08833297f, 
    -0.50382560f, -0.84163344f, -0.39792144f, 0.11868682f, 0.19635765f, 0.04270118f, 0.04511669f, 0.19815660f, 
    0.00683186f, 0.01882626f, -0.08212897f, -0.08071445f, 0.21018349f, 0.25082740f, 0.02437776f, -0.05377932f, 
    -0.05470985f, 0.04677523f, 0.01408706f, -0.00423486f, -0.10663090f, 0.10729490f, -0.04824910f, 0.06824266f, 
    0.06101116f, -0.55760884f, -0.78259093f, -0.36217543f, 0.02155710f, 0.02575328f, -0.05362570f, 0.03869326f, 
    -0.03990316f, -0.12400282f, 0.01613085f, -0.08420764f, 0.09167443f, 0.21304689f, -0.12678878f, -0.00657625f, 
    -0.02697442f, 0.22969331f, -0.07039198f, 0.01261259f, -0.01451754f, 0.04559329f, -0.05609531f, 0.03767793f, 
    -0.53059363f, 0.06968904f, 0.22980882f, -0.02965191f, -0.14810853f, -0.01771737f, 0.08738989f, 0.01325031f, 
    0.04461329f, 0.02476088f, 0.10024954f, -0.16566758f, -0.57961696f, -0.53902251f, -0.17973682f, -0.03148757f, 
    0.05180901f, 0.10355955f, -0.03391008f, 0.07052104f, 0.00030887f, -0.04805755f, -0.09102803f, -0.09594227f, 
    0.13683179f, 0.21268295f, 0.01613076f, 0.09386317f, 0.06934369f, -0.02662414f, -0.03505811f, 0.06145029f, 
    0.10112608f, 0.06069209f, -0.04447279f, 0.04957474f, -0.32005435f, -0.16231079f, -0.36847952f, -0.36645815f, 
    0.01425827f, -0.18727171f, -0.07614817f, 0.01370741f, -0.06514337f, -0.03321533f, 0.03208980f, -0.06662456f, 
    -0.00593125f, 0.16716678f, 0.42213798f, 0.31336612f, 0.00211817f, 0.01337256f, -0.05766789f, -0.01087635f, 
    0.01794097f, -0.05012465f, 0.04589871f, -0.05219201f, 0.19341438f, 0.09615777f, 0.11632760f, 0.12111922f, 
    -0.01511538f, -0.04707711f, 0.04154206f, 0.07003367f, 0.01738736f, 0.03281520f, -0.02736321f, 0.03239571f, 
    -0.02498610f, 0.01747423f, 0.02217921f, -0.01487760f, -0.00007292f, 0.02337183f, 0.00942640f, 0.02637656f, 
    0.02051557f, 0.01937806f, -0.03663016f, 0.00419787f, -0.02763786f, -0.01115900f, 0.02522491f, 0.01789018f, 
    0.02705450f, -0.04070776f, 0.02342847f, -0.01431358f, 0.01562540f, -0.02952928f, 0.02594236f, 0.02612283f, 
    -0.00225094f, -0.00964954f, 0.00241616f, -0.03264946f, -0.01861249f, -0.00331848f, -0.01597860f, 0.00810337f, 
    0.02592793f, 0.00524442f, 0.01366759f, 0.01929318f, 0.01106537f, -0.02447764f, 0.02099962f, -0.02464064f, 
    0.02014178f, 0.01886271f, -0.00660022f, -0.00573969f, -0.01717341f, -0.01444899f, -0.00396307f, -0.02553540f, 
    0.01173708f, 0.02609492f, 0.02769954f, -0.01064051f, 0.02180869f, -0.01087030f, -0.00026608f, 0.02415726f, 
    -0.01284203f, -0.03333401f, -0.02097662f, -0.03362459f, 0.02942905f, 0.01096802f, -0.01729147f, 0.01168446f, 
    -0.02678080f, -0.00315323f, 0.02833547f, 0.02340779f, -0.02000519f, -0.02285569f, -0.03503245f, 0.02459381f, 
    0.03530687f, -0.02160098f, -0.02827880f, -0.04278031f, -0.02850711f, 0.02113068f, -0.01006321f, 0.00959372f, 
    0.02433072f, -0.01582851f, 0.01006402f, 0.01170485f, -0.00137962f, -0.00984909f, -0.00344588f, -0.01625219f, 
    0.00976247f, -0.02198431f, -0.00401396f, 0.00397267f, 0.01821691f, -0.02744019f, 0.02242269f, -0.02589885f, 
    0.02280082f, 0.01065209f, 0.02276906f, -0.01546599f, 0.02567644f, 0.01852979f, 0.00899355f, 0.01875038f, 
    0.02209890f, -0.01130210f, 0.01007829f, 0.00638300f, 0.01685423f, -0.02594591f, 0.00850930f, -0.03229076f, 
    0.00476274f, 0.02341545f, -0.03402091f, -0.04075111f, -0.01623777f, -0.01101031f, -0.03918233f, 0.01722593f, 
    -0.03833241f, 0.00215982f, 0.00762155f, -0.03748486f, 0.02385524f, -0.02179995f, 0.02849239f, 0.02073253f, 
    -0.01208454f, -0.01720287f, -0.00759180f, -0.00066255f, 0.02657768f, -0.01230951f, 0.00661096f, -0.00161516f, 
    -0.00621143f, -0.03419857f, 0.01789579f, 0.01716653f, -0.01669811f, 0.00852124f, -0.01793656f, 0.00597225f, 
    -0.02974086f, -0.04144209f, 0.02785513f, -0.03854485f, -0.00798421f, -0.01605131f, 0.02688572f, 0.00398974f, 
    0.00765036f, -0.03766858f, -0.02983508f, -0.03833988f, -0.03399554f, -0.02348616f, -0.01129246f, -0.02157286f, 
    -0.03391410f, -0.01427760f, -0.03498926f, 0.03377642f, -0.02226079f, 0.02001333f, -0.01458087f, 0.02059742f, 
    -0.01801228f, -0.02627371f, 0.00006595f, 0.01588323f, -0.00077949f, -0.03129663f, -0.00925392f, 0.00884437f, 
    -0.00746814f, -0.00470867f, -0.02702734f, -0.03462239f, 0.01765603f, -0.01250414f, 0.03712280f, 0.04002220f, 
    -0.01054117f, -0.00047127f, -0.03432415f, -0.00148944f, -0.00456007f, -0.02546531f, 0.00460124f, -0.02817902f, 
    -0.04095082f, -0.01842469f, -0.02481262f, 0.01209112f, -0.01976270f, -0.03152417f, 0.02504199f, -0.01584374f, 
    -0.02681840f, 0.00607391f, -0.01312770f, 0.01639593f, -0.03074792f, 0.02488506f, -0.04023346f, 0.01503275f, 
    -0.00266348f, -0.03697049f, 0.02123323f, -0.02689729f, 0.00734433f, 0.01814270f, 0.00296827f, 0.02480963f, 
    0.02766016f, 0.02247035f, 0.01316218f, 0.01202756f, 0.02284947f, -0.00747518f, 0.01888410f, 0.00205903f, 
    -0.01711441f, 0.01596211f, -0.03189651f, 0.02389520f, -0.00854325f, 0.03384336f, 0.00387594f, -0.00418012f, 
    -0.02175896f, 0.00672503f, -0.04292367f, -0.00432537f, 0.02880599f, -0.02917785f, 0.02806182f, 0.00568870f, 
    0.02776980f, 0.00949953f, -0.01527717f, 0.01989816f, 0.00112739f, 0.01820008f, -0.02387443f, -0.02083163f, 
    -0.02118874f, -0.04040492f, -0.03108967f, 0.00919630f, 0.00666141f, -0.03794966f, -0.01393851f, -0.02663380f, 
    -0.03565331f, 0.02108259f, -0.02103152f, -0.01560734f, -0.01464544f, -0.02891077f, 0.00078260f, -0.03569208f, 
    -0.03637549f, 0.00688957f, -0.04043447f, -0.02945999f, -0.01147777f, -0.00089787f, -0.02812828f, -0.01423830f, 
    -0.00092482f, -0.03359476f, -0.01790132f, -0.03841555f, 0.00895355f, -0.00336497f, -0.00757428f, -0.03879438f, 
    -0.02209068f, 0.01427337f, -0.01150644f, -0.00645204f, -0.02005347f, -0.04196251f, -0.01938295f, -0.02106534f, 
    0.00759918f, 0.02772442f, -0.02689124f, 0.01365064f, -0.00211545f, -0.02827206f, -0.02976294f, -0.03078653f, 
    -0.00986306f, -0.01054969f, -0.02090984f, -0.02931715f, -0.01017109f, -0.01474229f, -0.03192870f, 0.00124578f, 
    -0.03055448f, 0.00472293f, -0.00754578f, 0.01569626f, 0.00861571f, 0.01624854f, 0.02431000f, 0.00410826f, 
    -0.03575541f, 0.00171004f, -0.03685513f, -0.03683418f, 0.00148137f, -0.01229246f, -0.00206697f, 0.00209316f, 
    0.00111409f, -0.00147458f, 0.02827036f, 0.02955808f, -0.02514995f, 0.00809955f, 0.02879013f, -0.02583958f, 
    -0.00324380f, 0.00044615f, -0.01235210f, -0.01498902f, -0.01970055f, 0.02233265f, 0.00011254f, -0.02237738f, 
    -0.02192965f, 0.02014587f, -0.03889092f, 0.00382671f, 0.00107728f, -0.01399425f, -0.02943685f, 0.01999244f, 
    0.01478104f, 0.02621879f, 0.01333872f, 0.00348306f, -0.03023759f, -0.00008736f, 0.02953492f, 0.01761783f, 
    0.01708181f, -0.00824281f, -0.00026743f, -0.02762899f, -0.04090015f, -0.03587959f, -0.01564025f, -0.02631067f, 
    -0.03888386f, 0.01855558f, -0.01786510f, 0.01520449f, -0.02025803f, -0.02128605f, 0.01319646f, -0.03490044f, 
    0.02578750f, -0.02033635f, 0.01107911f, 0.00598347f, -0.04044187f, -0.00494873f, -0.00592268f, 0.00081264f, 
    -0.00958120f, 0.00933753f, -0.03164522f, 0.01549447f, 0.02657371f, 0.00070580f, 0.02409998f, 0.02140303f, 
    0.00246021f, -0.01756447f, -0.01230542f, 0.01106562f, 0.01181243f, 0.02798573f, 0.02133647f, -0.00196977f, 
    0.02633674f, -0.00209132f, -0.03612395f, -0.03192958f, 0.00957212f, 0.01991075f, -0.02123014f, -0.02436171f, 
    0.01008688f, 0.01239609f, -0.00541544f, 0.01971806f, 0.00435459f, -0.03718746f, -0.02059989f, -0.01835928f, 
    -0.02257499f, -0.00904036f, -0.03930435f, -0.02718388f, 0.00006845f, -0.00062490f, -0.00241059f, 0.01925021f, 
    -0.03227801f, -0.04053553f, -0.00291673f, -0.04012492f, 0.00812220f, 0.00899352f, 0.00871143f, 0.01118214f, 
    0.01153872f, -0.02689683f, -0.01643466f, 0.00702388f, -0.04099462f, 0.00820823f, -0.03324956f, 0.02652214f, 
    -0.00923964f, 0.00085903f, 0.01256667f, 0.00737699f, -0.03781379f, 0.01264557f, -0.04058112f, 0.00186789f, 
    -0.00303781f, -0.02687820f, -0.01202183f, -0.03285021f, -0.00319829f, 0.02274440f, 0.01775816f, -0.00390240f, 
    -0.00493574f, -0.03507532f, 0.02367046f, -0.01855356f, 0.01439018f, -0.04231810f, 0.02024887f, -0.00684489f, 
    -0.00103289f, -0.01176751f, 0.01133318f, -0.00577336f, -0.01552021f, -0.02790237f, 0.02101334f, -0.01679296f, 
    -0.00177317f, -0.04066937f, -0.04051013f, -0.02906165f, -0.03037905f, -0.02482362f, 0.02718476f, 0.02615944f, 
    -0.00908393f, -0.04132461f, -0.00766503f, -0.01828084f, -0.01740875f, 0.01238421f, 0.02708835f, 0.00842164f, 
    -0.02977095f, 0.00784447f, 0.02020132f, -0.01284294f, -0.04004175f, -0.01335170f, -0.02894835f, 0.01634312f, 
    0.00154600f, 0.00798628f, 0.00115495f, -0.01041311f, 0.02516080f, -0.01911387f, -0.01318341f, 0.02919056f, 
    -0.00081622f, 0.01338291f, 0.00594410f, 0.00736052f, -0.00339019f, 0.02267712f, -0.03456494f, -0.00609577f, 
    0.01353589f, -0.00937261f, 0.00248283f, -0.00746622f, -0.01639078f, 0.00789925f, -0.00959503f, -0.01579642f, 
    0.00043031f, -0.02829397f, 0.00476934f, 0.00848738f, -0.00217390f, 0.01091835f, 0.00813532f, 0.01714354f, 
    -0.03095009f, -0.03265777f, 0.00357085f, 0.01834565f, 0.01425920f, 0.01380691f, -0.00712340f, -0.01469163f, 
    -0.02289551f, -0.01185801f, 0.00649534f, 0.02322448f, -0.00761040f, -0.03795642f, -0.03634344f, 0.00558340f, 
    -0.00861399f, 0.01955855f, 0.00529105f, 0.01982784f, 0.01585396f, 0.01857734f, -0.00266405f, -0.03385951f, 
    -0.03831982f, -0.01867448f, -0.02029417f, 0.02976160f, 0.00457812f, 0.01171438f, 0.02323500f, -0.04301151f, 
    -0.02416754f, -0.02774957f, -0.02554720f, -0.02495030f, -0.01314216f, 0.00731604f, -0.03063236f, -0.00366888f, 
    -0.01321990f, -0.01212307f, 0.00306870f, -0.02735122f, -0.00854607f, -0.03221461f, -0.04107593f, -0.02495678f, 
    -0.03185059f, -0.01391772f, -0.03537200f, -0.02181041f, 0.01770712f, -0.01111724f, -0.02806655f, -0.04169418f, 
    0.01335683f, -0.03564357f, -0.01873837f, -0.00443483f, -0.00904385f, -0.01241597f, -0.00204910f, -0.01193239f, 
    -0.03315013f, -0.03313901f, 0.00333815f, 0.01804043f, -0.02063864f, -0.00010907f, 0.02231866f, 0.00829400f, 
    0.01829151f, -0.04071061f, -0.00217061f, 0.02961120f, -0.01955735f, -0.03184215f, -0.01653115f, -0.02311300f, 
    -0.02149720f, 0.01195002f, 0.01072640f, 0.02042704f, 0.02042202f, -0.01392043f, -0.00782033f, 0.01558817f, 
    -0.00904507f, -0.01065057f, -0.02776767f, -0.00522734f, -0.00572604f, 0.01421764f, -0.01479844f, -0.02428750f, 
    0.01939973f, -0.00553265f, -0.01070282f, -0.00267278f, 0.01045066f, 0.01115402f, 0.00067695f, 0.02885539f, 
    -0.00403708f, -0.00742964f, -0.00907490f, -0.04211203f, -0.00767419f, -0.03019940f, 0.01516571f, -0.04091638f, 
    -0.02767383f, -0.00517715f, 0.02749223f, -0.01237117f, -0.01925024f, -0.00894443f, 0.01368408f, 0.00431092f, 
    0.01050398f, -0.01603542f, -0.01624090f, 0.02253838f, 0.00858053f, -0.01941106f, 0.03292372f, -0.02877370f, 
    0.04138558f, 0.02682607f, 0.02246455f, -0.00821317f, -0.00111423f, -0.02934593f, -0.03458270f, -0.01263369f, 
    -0.00296308f, -0.03838783f, 0.02042603f, 0.00949528f, 0.02344652f, -0.03358892f, -0.00932921f, -0.02331181f, 
    0.01588185f, -0.02884937f, 0.01150244f, 0.02045023f, 0.00781761f, -0.01280467f, 0.02197074f, -0.03336654f, 
    0.01015493f, -0.01743975f, -0.00093957f, 0.00701239f, -0.01621968f, 0.01817115f, 0.00599388f, 0.02194427f, 
    0.02565081f, -0.02154659f, -0.02565849f, -0.02475034f, 0.02151601f, -0.02514137f, -0.02299998f, 0.00272371f, 
    0.02348649f, -0.02019159f, -0.00083175f, 0.02836740f, 0.01358016f, -0.01803516f, -0.02228630f, 0.00451273f, 
    -0.03125207f, 0.00851574f, -0.03072632f, -0.01708232f, 0.01349880f, -0.04217579f, 0.01537556f, -0.02406121f, 
    0.02357627f, -0.00903214f, -0.04128940f, 0.02137971f, 0.02284866f, 0.00066040f, 0.00593006f, -0.01896833f, 
    0.02661782f, 0.02278016f, -0.01205319f, 0.01648425f, -0.04072703f, 0.02148530f, 0.02933551f, 0.01519551f, 
    -0.03775246f, 0.01308387f, -0.04202595f, 0.01280042f, 0.00084655f, -0.01202435f, -0.02643858f, 0.00635191f, 
    -0.00637574f, 0.00808631f, -0.00290579f, 0.01511220f, 0.00829775f, -0.01940293f, -0.00396567f, -0.02077342f, 
    -0.00537164f, -0.03841277f, -0.03711010f, -0.01560667f, -0.00745219f, 0.01688308f, 0.02705316f, -0.02422442f, 
    0.01443867f, -0.03945738f, 0.02362784f, -0.02134445f, -0.03849970f, 0.00745857f, 0.02876712f, 0.00767087f, 
    -0.02667473f, -0.00921503f, 0.01762588f, -0.04110691f, 0.02868985f, 0.01313824f, 0.01414294f, -0.01862519f, 
    -0.01132648f, -0.02475087f, -0.01442620f, -0.00151996f, -0.02088042f, -0.02441217f, -0.01960384f, -0.00629513f, 
    -0.03166584f, 0.01521705f, 0.02470867f, -0.01022503f, -0.02468298f, -0.03374254f, -0.00786437f, 0.02360859f, 
    -0.03297244f, -0.03368689f, -0.00550611f, 0.01463446f, 0.01944345f, 0.01907303f, -0.02971223f, -0.03486773f, 
    -0.02910829f, 0.01454255f, 0.02850498f, -0.03753342f, -0.01848386f, -0.00507644f, 0.01110770f, 0.00998691f, 
    -0.03221713f, 0.00490051f, 0.01935554f, 0.02695655f, 0.03987736f, -0.02356993f, -0.02650694f, -0.00608903f, 
    -0.01236592f, 0.00024359f, -0.00313715f, -0.01492339f, -0.00288517f, -0.01681576f, 0.01083860f, 0.01905210f, 
    0.00789331f, -0.02880501f, -0.01337752f, -0.02099855f, -0.00843404f, -0.00461589f, 0.01568723f, 0.01774066f, 
    0.00094171f, -0.03337910f, -0.02672473f, 0.02973906f, -0.01660875f, -0.04118658f, -0.02594176f, -0.01240921f, 
    -0.01639177f, -0.02266520f, -0.02539258f, 0.00071280f, 0.02971211f, 0.02031004f, -0.00435373f, 0.01597848f, 
    -0.00329567f, -0.01424193f, -0.00292819f, 0.01514860f, -0.01790162f, -0.01534664f, 0.00273425f, -0.01670916f, 
    -0.03690868f, 0.02701277f, 0.01937573f, -0.03883746f, 0.00592009f, -0.01432838f, 0.01327055f, -0.02205722f, 
    -0.01791246f, 0.00888598f, 0.02163591f, -0.02237780f, -0.02260466f, 0.00171648f, -0.02751321f, -0.01894567f, 
    0.00873945f, 0.00440537f, -0.00626291f, -0.03799390f, -0.03000861f, -0.00286071f, 0.01150201f, -0.04144028f, 
    -0.00901433f, 0.01460278f, -0.01684240f, 0.02073674f, 0.00625866f, -0.00534186f, -0.02764282f, -0.01782387f, 
    0.03041774f, -0.02345128f, 0.02701659f, 0.00003468f, -0.00281812f, -0.04088270f, 0.02601307f, -0.02808822f, 
    -0.01326270f, -0.00982598f, 0.00378503f, -0.01861297f, 0.02365922f, -0.00629340f, -0.01997119f, 0.01998004f, 
    0.03015033f, 0.00518910f, -0.01749565f, -0.02813936f, 0.00062310f, -0.03318292f, -0.02570183f, -0.01055318f, 
    -0.03744855f, -0.02655810f, 0.02637595f, 0.02066615f, 0.00619478f, 0.01457921f, -0.00570232f, 0.01533176f, 
    0.01271359f, 0.02023982f, 0.01668738f, -0.00471327f, -0.00264695f, -0.02329820f, 0.01377410f, -0.00216424f, 
    -0.00221462f, -0.01569041f, -0.02570901f, -0.01264803f, -0.02523819f, -0.01145863f, 0.02487238f, -0.02817063f, 
    -0.02615706f, 0.03358452f, 0.02932919f, 0.01159955f, -0.01028565f, -0.01261642f, 0.01246020f, -0.01877086f, 
    -0.02457564f, 0.00766078f, 0.00803937f, -0.02062736f, -0.02419739f, -0.02666120f, -0.02896714f, -0.00018798f, 
    -0.01329717f, 0.02157302f, 0.02844052f, -0.01028365f, 0.02755027f, -0.03250322f, 0.02048031f, -0.03131549f, 
    -0.02622330f, -0.02826839f, 0.01022522f, 0.01793200f, 0.00785468f, 0.01005465f, -0.01554305f, 0.00562326f, 
    0.02975256f, 0.01204887f, -0.02525063f, -0.00132904f, -0.00214139f, 0.02638624f, 0.01341853f, 0.00005680f, 
    0.03141064f, 0.00635706f, 0.00664201f, 0.02450212f, -0.02848041f, -0.01001070f, -0.02266845f, -0.02141882f, 
    -0.03500808f, 0.00750885f, 0.01056671f, -0.02324112f, -0.02407201f, 0.00554388f, -0.01428943f, 0.01428664f, 
    0.00176906f, 0.02844593f, 0.03768323f, -0.03444904f, -0.00724339f, -0.00227517f, 0.00932532f, 0.03443838f, 
    -0.02185418f, -0.01203513f, -0.01389632f, -0.01249128f, 0.00825853f, 0.00846470f, -0.01804025f, 0.01808229f, 
    0.02068830f, -0.02335448f, -0.01954642f, -0.03390335f, -0.01665697f, -0.03310726f, -0.01500904f, 0.00675397f, 
    0.00515247f, -0.02246771f, -0.01308160f, -0.01033333f, 0.00538631f, 0.00660567f, 0.00655822f, -0.03244285f, 
    -0.03354415f, 0.01169934f, -0.02099170f, 0.00677782f, 0.00355864f, 0.00561132f, 0.03190425f, -0.01232428f, 
    -0.01771930f, 0.02782451f, 0.01974717f, -0.03556773f, -0.03702697f, -0.02271098f, -0.01560468f, -0.03930818f, 
    -0.01773841f, 0.00370606f, -0.01480927f, -0.02661978f, 0.01785362f, 0.01157042f, -0.00865963f, 0.01669924f, 
    -0.01201871f, -0.01220274f, 0.00455889f, -0.03743421f, -0.03958720f, -0.00017826f, -0.02223319f, -0.00523385f, 
    0.03453693f, -0.02987526f, 0.03765598f, 0.02719345f, 0.02595750f, 0.00423753f, 0.00468697f, 0.02264369f, 
    -0.03959339f, 0.03077812f, -0.00364493f, -0.01775563f, 0.02437985f, -0.01891051f, -0.02565661f, 0.01535893f, 
    -0.00694884f, -0.02489495f, -0.03134321f, 0.02839133f, 0.01369572f, 0.02930812f, -0.01222474f, -0.03616288f, 
    0.02156498f, -0.00003576f, -0.00027523f, 0.00476289f, -0.01296611f, -0.02355123f, -0.01851248f, -0.03187593f, 
    -0.04107512f, 0.00647367f, 0.01494332f, 0.02700016f, -0.03608398f, -0.01677617f, -0.01368252f, 0.02362105f, 
    -0.01055627f, -0.04132605f, -0.00825168f, -0.01695314f, -0.00412237f, -0.01537824f, -0.02057904f, 0.01733181f, 
    0.01105796f, 0.02368753f, -0.01434874f, 0.02554128f, -0.00566130f, -0.02175472f, -0.03428390f, 0.02091140f, 
    -0.01161478f, -0.01087787f, -0.00643696f, -0.01381632f, 0.01650792f, 0.01370175f, -0.01055270f, 0.00051263f, 
    -0.01543208f, 0.00013290f, -0.00845877f, -0.00853064f, -0.02995510f, 0.00044288f, 0.00867384f, -0.02978296f, 
    -0.02384810f, -0.01801286f, 0.01367579f, -0.00078234f, 0.02617683f, -0.01594005f, 0.02178556f, 0.00972730f, 
    0.00956685f, -0.01183967f, -0.03360224f, 0.02186138f, -0.00718184f, -0.03598552f, 0.02434979f, 0.01662050f, 
    -0.03240918f, 0.01141486f, 0.02055985f, 0.00574121f, -0.01519956f, 0.01888566f, 0.00770859f, -0.00504240f, 
    -0.00079203f, 0.00803866f, 0.02216394f, -0.02868659f, 0.02252607f, -0.03065286f, 0.00426127f, -0.02428188f, 
    -0.00591149f, -0.00859453f, 0.01090830f, -0.01194229f, -0.01822761f, -0.03095754f, 0.03032407f, -0.01804035f, 
    -0.04072151f, 0.00646483f, 0.03117592f, 0.01969459f, 0.00309697f, 0.02915174f, 0.03207286f, 0.01895242f, 
    0.00952107f, -0.00662296f, -0.00503474f, 0.01674538f, -0.00205785f, 0.02836536f, 0.00854981f, -0.02063546f, 
    -0.01813408f, 0.02893108f, -0.01706368f, -0.00850373f, 0.03268250f, -0.00623286f, -0.01993728f, -0.01578231f, 
    -0.01238757f, -0.01922023f, 0.00260815f, 0.00961110f, 0.00689111f, 0.01297912f, 0.00344251f, 0.02845339f, 
    0.00677959f, -0.03195048f, 0.01647709f, -0.01906944f, 0.02864152f, 0.00584680f, -0.02500462f, 0.00328640f, 
    -0.03966699f, 0.01925124f, -0.01667038f, 0.02566184f, -0.02923257f, 0.00712871f, 0.01498569f, -0.04065480f, 
    -0.02331977f, -0.00780451f, -0.03843080f, -0.02364919f, 0.00195023f, -0.00756599f, 0.02581260f, 0.01716118f, 
    -0.02804643f, 0.03196137f, 0.03206545f, 0.00673312f, -0.00124110f, -0.02056647f, 0.01548901f, -0.01583619f, 
    -0.02281866f, 0.00048318f, -0.01542342f, -0.03914297f, -0.00890247f, 0.00770183f, 0.00686962f, -0.02876490f, 
    0.01007149f, -0.03537688f, 0.02215630f, -0.02881609f, -0.02987167f, 0.01606842f, 0.02245683f, -0.00377848f, 
    0.02265357f, 0.01709257f, -0.03099354f, 0.02476551f, -0.00774187f, -0.01065818f, -0.03273853f, -0.03712458f, 
    0.01741911f, -0.00744515f, 0.01003995f, -0.02241427f, 0.01874601f, 0.02137923f, -0.01724627f, -0.01990654f, 
    0.01374842f, 0.03089439f, -0.00195858f, 0.02543247f, 0.01623567f, -0.02967876f, -0.04005757f, 0.02518270f, 
    0.01273514f, 0.01901664f, 0.00732827f, 0.01439260f, -0.02955921f, 0.00620499f, -0.00548718f, -0.00604862f, 
    -0.02751995f, -0.01843910f, -0.01417643f, -0.01574760f, -0.02496198f, -0.02245823f, 0.01767883f, 0.02711691f, 
    -0.00575947f, 0.00542951f, 0.01525197f, -0.02136552f, 0.00320394f, -0.02111144f, 0.00068930f, 0.01572089f, 
    0.00707906f, 0.02994362f, 0.00764919f, 0.02006343f, -0.00902660f, -0.00798332f, 0.02066674f, 0.00582265f, 
    0.03038712f, 0.02031738f, 0.00584134f, 0.01945431f, 0.00483521f, 0.02044113f, -0.02440443f, -0.03323849f, 
    -0.01536061f, 0.00167530f, 0.02837803f, 0.01626182f, 0.01433767f, -0.00624321f, -0.02225230f, 0.02185098f, 
    -0.03035996f, -0.00640384f, -0.01975594f, -0.03117646f, 0.00315291f, -0.01617578f, -0.01557102f, 0.00335505f, 
    0.02062695f, -0.00018582f, -0.03807022f, 0.00434499f, 0.02095716f, 0.01563997f, 0.02919803f, -0.03501116f, 
    0.02389335f, -0.02675623f, -0.03399542f, -0.01413345f, 0.00244072f, -0.00269328f, 0.01525238f, 0.00234885f, 
    0.02066616f, 0.02106005f, -0.01277862f, 0.00534140f, -0.03182847f, -0.03738120f, 0.02656945f, -0.00679871f, 
    0.00736777f, 0.00971930f, -0.03203169f, -0.01252205f, 0.00823510f, -0.01547064f, -0.01765260f, -0.03087088f, 
    -0.02012954f, -0.01593021f, 0.00006276f, 0.02298806f, 0.00536828f, 0.00835566f, 0.01512306f, -0.03756456f, 
    -0.01879472f, -0.02225042f, 0.01447113f, 0.00842590f, -0.00279424f, 0.00931338f, -0.00264460f, -0.03505736f, 
    0.00031143f, -0.03915782f, -0.00692915f, -0.00359135f, 0.02704556f, -0.01520355f, -0.02042687f, 0.02265422f, 
    0.02361074f, 0.00114794f, -0.03864389f, -0.01344787f, 0.01213946f, -0.02379654f, -0.02496371f, 0.01652143f, 
    -0.01748546f, -0.01699194f, -0.02756810f, -0.02796077f, -0.02219627f, 0.01286350f, -0.02530735f, -0.00362559f, 
    0.00416300f, 0.00005273f, 0.02668608f, -0.03026704f, 0.01350486f, -0.02943844f, -0.03633099f, -0.00956698f, 
    -0.03298724f, 0.00746543f, -0.02767700f, -0.02905321f, -0.02981471f, 0.00796537f, 0.03078145f, 0.01934639f, 
    0.03314604f, 0.03455280f, 0.01857081f, 0.03091231f, -0.00916133f, 0.00532407f, -0.00409307f, 0.00443783f, 
    -0.02390286f, -0.02213720f, -0.01090033f, -0.03248860f, 0.00210956f, 0.03204261f, 0.03470159f, -0.01621810f, 
    0.00688870f, -0.03037019f, -0.01065890f, -0.02301326f, 0.00854407f, -0.02931101f, -0.01182994f, 0.02850103f, 
    0.00206349f, 0.02773640f, 0.02531145f, -0.03659150f, 0.02065816f, 0.00713478f, -0.02725465f, -0.02799166f, 
    0.02212927f, 0.02239108f, 0.02046638f, -0.00762432f, -0.00151863f, 0.00821370f, 0.02556036f, -0.01288353f, 
    -0.01297937f, -0.00581356f, 0.00715841f, -0.02099444f, -0.00114815f, 0.01310985f, 0.02601094f, -0.00085545f, 
    -0.00602954f, -0.00855261f, -0.03834969f, 0.03012419f, 0.01261015f, -0.02551004f, 0.02657838f, 0.01448927f, 
    0.00468842f, 0.01191003f, -0.00977616f, -0.02516557f, -0.00263852f, -0.02255366f, -0.01795920f, 0.01201333f, 
    0.01003439f, 0.01430816f, -0.03060193f, -0.01238869f, 0.02707883f, -0.02605507f, 0.01268385f, -0.00106439f, 
    0.00270232f, -0.00910668f, -0.02223951f, 0.03252307f, 0.03230473f, -0.03310993f, -0.00780580f, -0.02551394f, 
    0.02329389f, -0.02994557f, -0.00955685f, 0.01336820f, 0.00356166f, 0.00450224f, 0.02891640f, 0.02193268f, 
    -0.01159582f, -0.02118129f, -0.01374330f, 0.02382317f, -0.01648041f, 0.03021256f, -0.00806653f, -0.01723347f, 
    0.03880794f, -0.02598327f, 0.00085464f, -0.02015309f, -0.01260818f, -0.02673188f, 0.00019720f, -0.01090045f, 
    -0.01905544f, -0.03288124f, -0.03579487f, -0.02934365f, -0.01420901f, -0.03525655f, -0.02622181f, 0.00250477f, 
    -0.02652212f, -0.01464187f, -0.00883341f, -0.00673780f, 0.00368026f, -0.00057727f, -0.03159169f, 0.02709459f, 
    -0.02084314f, -0.00251824f, 0.01101179f, -0.02752207f, -0.01405330f, -0.00846925f, -0.03153729f, 0.01883216f, 
    -0.00068581f, 0.01149329f, -0.01101836f, 0.01653405f, 0.00648531f, -0.00959180f, -0.00864823f, 0.00906405f, 
    0.00610103f, -0.03224887f, -0.00950709f, -0.02616719f, -0.01724823f, -0.02177375f, -0.03319523f, 0.02767197f, 
    0.01849261f, -0.01579940f, 0.03214245f, -0.04185607f, 0.00313491f, 0.01150963f, 0.00957327f, -0.00670779f, 
    0.01464755f, 0.02077647f, -0.00526416f, 0.02009257f, -0.01558623f, -0.02079005f, 0.01955506f, -0.03443494f, 
    0.03057446f, 0.02705242f, -0.02381359f, -0.01107620f, -0.03505964f, -0.03495829f, -0.01339361f, 0.03086026f, 
    -0.02941691f, 0.02849300f, -0.03561699f, 0.00381714f, 0.00879558f, -0.02483546f, 0.00567459f, -0.01748708f, 
    0.02717401f, -0.03267967f, -0.00771693f, -0.02631197f, -0.01736640f, -0.03579324f, 0.02268643f, -0.03511795f, 
    -0.02350203f, -0.03468863f, -0.01593531f, -0.01858019f, -0.04145056f, 0.02527262f, 0.01890997f, 0.00227954f, 
    -0.02434942f, 0.01056674f, -0.02679274f, -0.00288682f, -0.03392033f, -0.03187114f, -0.02274645f, 0.00925362f, 
    -0.02291362f, -0.03735486f, -0.02324940f, -0.01429123f, -0.02873046f, -0.01998920f, -0.02131881f, -0.02807685f, 
    0.01720251f, -0.00403021f, 0.01507271f, 0.02686888f, 0.03043167f, -0.02751472f, -0.01205716f, 0.00138196f, 
    0.01535437f, -0.02105590f, -0.03381883f, 0.01376471f, 0.02035141f, -0.01324265f, 0.02384388f, -0.01028496f, 
    -0.00517895f, -0.02186532f, 0.02045421f, 0.01148163f, -0.00881176f, 0.00815819f, 0.02671667f, -0.00055898f, 
    0.01398348f, -0.03758022f, 0.01276185f, -0.03716950f, -0.03012220f, -0.00308889f, 0.00204791f, 0.02911501f, 
    -0.01865654f, -0.01383359f, 0.03127576f, 0.02911611f, -0.03722940f, -0.02107710f, 0.01165103f, -0.00280441f, 
    -0.02679937f, -0.02556954f, 0.01290407f, -0.02135278f, 0.00584112f, -0.02622341f, -0.04005209f, 0.02327738f, 
    0.02550634f, 0.01236275f, -0.02925335f, -0.02284792f, -0.04073963f, -0.03795104f, 0.00931303f, 0.02901514f, 
    0.01248034f, -0.01606112f, -0.00451558f, 0.00543207f, -0.01578492f, -0.01550021f, -0.01650050f, 0.01488709f, 
    -0.02238979f, 0.01756967f, -0.03422482f, -0.01488129f, 0.01525934f, 0.01707908f, -0.03527566f, -0.00757172f, 
    -0.04093207f, 0.00945062f, 0.00482232f, 0.01522147f, -0.01415497f, 0.01986310f, 0.00422514f, -0.00408605f, 
    0.02792404f, 0.02667710f, -0.01254987f, 0.02154499f, -0.02361209f, -0.03545710f, -0.00544885f, 0.01735908f, 
    0.01909417f, 0.01963662f, 0.01940565f, -0.03935805f, 0.00539283f, 0.02060589f, 0.02924560f, -0.01176872f, 
    0.02503197f, -0.03450651f, -0.03823480f, 0.02509191f, -0.00190556f, -0.03326539f, -0.00772371f, 0.02848567f, 
    -0.00013892f, 0.00510947f, 0.00542509f, -0.02437639f, 0.00553583f, -0.01836465f, -0.03344024f, 0.02398985f, 
    0.01647460f, -0.00138067f, -0.02726083f, -0.03430412f, 0.00838329f, -0.03384547f, 0.00506337f, -0.01651822f, 
    -0.01370353f, -0.01811053f, 0.00365279f, -0.00344825f, -0.03577972f, -0.01345042f, 0.02495167f, 0.00690223f, 
    -0.01229335f, 0.01510829f, -0.01444503f, 0.01220706f, -0.02548982f, -0.00088174f, -0.03577767f, -0.00131948f, 
    0.00620450f, 0.00933055f, 0.02073295f, -0.01665255f, 0.03185266f, 0.01126997f, -0.00335999f, -0.00987095f, 
    0.00857916f, -0.01759549f, -0.01085698f, 0.03104063f, 0.02962733f, -0.04028380f, 0.01364093f, 0.01230813f, 
    0.00427080f, -0.01067920f, -0.01934964f, -0.02341349f, 0.02275858f, -0.03621998f, -0.03837717f, -0.00293174f, 
    0.00005849f, -0.01617728f, 0.02772256f, -0.02696097f, -0.02498830f, -0.03897250f, -0.00155521f, -0.03871637f, 
    -0.01438875f, -0.04178857f, 0.02719470f, -0.01513622f, 0.01814152f, 0.00749246f, 0.00273231f, 0.00609696f, 
    -0.03232371f, -0.03987021f, -0.03283186f, 0.00332356f, 0.00229149f, -0.01473735f, -0.00799790f, 0.01877358f, 
    -0.00228300f, 0.02655161f, -0.01875655f, -0.02505680f, -0.03510648f, -0.00475626f, -0.01842821f, -0.02974798f, 
    0.02405396f, 0.02987725f, 0.02363143f, -0.02348931f, -0.00290782f, 0.01506051f, -0.01694290f, -0.02557419f, 
    0.03044645f, -0.03904247f, -0.03023863f, -0.02399029f, -0.01916076f, 0.02913240f, -0.02246452f, -0.00675496f, 
    -0.03167896f, 0.02210534f, -0.02742181f, 0.01717594f, -0.01683526f, -0.01755552f, -0.01931383f, -0.00684156f, 
    0.00986341f, -0.00697420f, -0.02306069f, 0.02846805f, -0.00948788f, 0.00956447f, -0.00782443f, 0.02854059f, 
    -0.01446712f, -0.01739980f, -0.03510999f, -0.00245026f, 0.01202645f, 0.00815251f, -0.02519890f, -0.01144714f, 
    0.01630103f, -0.02417516f, -0.01365724f, 0.00326167f, 0.01492701f, -0.03870274f, -0.01740765f, -0.01985394f, 
    -0.01644079f, -0.02900642f, -0.02067437f, -0.02570795f, 0.01739889f, -0.02495268f, -0.00660171f, 0.01673761f, 
    0.02443123f, 0.01147800f, 0.00573520f, 0.00529675f, 0.00518516f, 0.00405263f, -0.00991223f, -0.00042244f, 
    -0.01240210f, -0.00394246f, 0.01498927f, -0.00944754f, -0.03269304f, 0.00042091f, 0.01947676f, -0.03246374f, 
    -0.02445771f, -0.02226895f, -0.03993513f, -0.01694280f, -0.02541718f, 0.00402240f, -0.02862907f, 0.02919894f, 
    -0.01540367f, -0.00797666f, -0.00113421f, 0.00559302f, 0.00597593f, -0.00757334f, -0.03135419f, -0.02180579f, 
    -0.01355280f, -0.00975835f, 0.02776065f, -0.03594675f, 0.00834972f, -0.02619871f, 0.02448318f, -0.03165437f, 
    -0.01368834f, -0.03393751f, -0.02180980f, -0.02460353f, 0.00710260f, 0.00822102f, 0.01393381f, -0.03463642f, 
    0.00891731f, 0.01110938f, 0.01343880f, -0.01853878f, -0.03275770f, -0.01883643f, 0.00336646f, 0.02233190f, 
    -0.00793880f, -0.00721055f, 0.01186093f, -0.01734329f, -0.02006424f, 0.02441604f, 0.00198797f, 0.01706316f, 
    0.01944416f, 0.01681762f, -0.02459071f, 0.03033523f, -0.02900839f, -0.01292282f, -0.02280342f, -0.01202938f, 
    0.00534001f, 0.02782241f, 0.01818063f, -0.00069736f, -0.01477702f, 0.02760440f, 0.00696317f, -0.01395864f, 
    -0.01629146f, -0.01092586f, 0.01928651f, -0.03432105f, 0.00648356f, 0.01488556f, -0.03863117f, -0.03457858f, 
    -0.03864733f, 0.01876899f, -0.00552713f, -0.01016994f, 0.00729357f, -0.01707731f, -0.02653439f, -0.03909665f, 
    -0.03040322f, -0.01517556f, 0.01359065f, 0.02453952f, -0.02484445f, -0.01023053f, -0.04221957f, -0.03281393f, 
    -0.03721604f, 0.00390760f, 0.02773316f, -0.00798079f, 0.00210317f, -0.01232458f, 0.02664053f, 0.02730106f, 
    0.00656361f, 0.02352285f, 0.03048065f, -0.00804803f, -0.00169715f, 0.02208659f, 0.02563819f, -0.01607627f, 
    -0.03240396f, -0.00344377f, -0.00021253f, 0.01692199f, -0.03702152f, -0.02327285f, -0.02082162f, 0.02166701f, 
    -0.02526615f, -0.00499512f, -0.04029196f, -0.02408762f, -0.02035041f, 0.00543573f, 0.01523294f, 0.03056170f, 
    -0.00783991f, -0.00660267f, 0.00733494f, 0.03052402f, -0.02210113f, -0.03282857f, -0.02293332f, -0.00224888f, 
    0.02230485f, 0.00663910f, -0.02029524f, -0.03908811f, 0.02061334f, -0.03123110f, 0.00112169f, 0.01737916f, 
    0.02977650f, -0.01985232f, 0.00596726f, -0.01222314f, 0.00730862f, 0.00929539f, 0.00764224f, 0.00998268f, 
    0.00849291f, -0.03554551f, -0.04157193f, 0.00164297f, 0.02253396f, 0.02006634f, -0.02404292f, 0.00888484f, 
    -0.02067816f, 0.01040277f, 0.00318013f, 0.01867751f, -0.02051269f, -0.03865467f, -0.02707039f, 0.00686728f, 
    0.00128779f, -0.00200764f, -0.03737557f, -0.01185236f, -0.02474182f, -0.03431245f, -0.03741285f, -0.03500946f, 
    -0.01182434f, -0.00335511f, -0.00998960f, 0.00598678f, -0.03254930f, -0.03114655f, 0.02252387f, -0.02578198f, 
    0.01255897f, 0.02893021f, -0.02611914f, -0.03741991f, 0.00315821f, 0.03058446f, 0.02547323f, -0.03153449f, 
    0.01392567f, 0.01908014f, -0.02889350f, -0.03752012f, -0.02689066f, -0.01898836f, -0.03557554f, -0.00260529f, 
    0.03101543f, 0.00320365f, -0.01269429f, 0.03011686f, 0.00961111f, 0.00173126f, 0.01478004f, -0.03725021f, 
    -0.02730336f, -0.03195625f, 0.01398067f, -0.00083068f, -0.02540278f, -0.01391141f, -0.00269277f, -0.00653244f, 
    0.02255554f, -0.00189210f, 0.01064239f, -0.03872315f, 0.01541908f, 0.02810180f, 0.00412605f, -0.04153259f, 
    0.01235947f, 0.01098541f, 0.01368481f, -0.01393520f, -0.03486348f, -0.00368147f, -0.03130434f, -0.00444405f, 
    0.00879514f, 0.01499325f, 0.00442005f, -0.03256616f, 0.01618233f, -0.03841707f, -0.03176223f, 0.00069860f, 
    -0.02220143f, 0.01666968f, 0.02519043f, -0.01189358f, -0.02942966f, 0.01084899f, -0.03296440f, -0.02351449f, 
    -0.00800427f, -0.04233582f, -0.00578139f, 0.01511360f, 0.01782280f, -0.02589698f, -0.02920728f, 0.01707958f, 
    0.01599797f, 0.02773544f, 0.01499950f, -0.01848555f, -0.03885782f, 0.02376863f, -0.02473214f, -0.02050968f, 
    -0.00142896f, -0.01579063f, -0.03401470f, -0.01062571f, -0.03672662f, 0.00222265f, -0.02759470f, -0.02641113f, 
    -0.00632637f, -0.01012069f, 0.01939080f, 0.02163651f, -0.03271450f, 0.01536199f, 0.02428414f, -0.02894660f, 
    0.03209950f, -0.02778027f, -0.00233602f, -0.02198797f, 0.02617878f, 0.00439348f, 0.02719907f, 0.01199473f, 
    -0.02271428f, 0.00735035f, 0.02828993f, -0.01842388f, -0.01873077f, -0.00275613f, -0.02433355f, 0.00501320f, 
    -0.03698257f, -0.01362306f, -0.02327154f, -0.00926301f, -0.01849134f, -0.02272286f, 0.01075840f, 0.02553810f, 
    -0.00612870f, 0.02934491f, -0.03222955f, 0.00591005f, -0.00157434f, -0.00221176f, -0.01417677f, -0.02609975f, 
    -0.03008353f, -0.00614519f, -0.00316714f, -0.03157970f, -0.00770431f, -0.00988826f, -0.02866037f, -0.03695560f, 
    -0.01405803f, 0.01080297f, -0.03925373f, -0.00117901f, 0.01890364f, -0.00972433f, 0.01681254f, -0.00400843f, 
    0.01661400f, -0.03444562f, -0.02337770f, 0.00299769f, -0.03273640f, -0.03143755f, -0.00712389f, 0.00455177f, 
    -0.01096953f, -0.02729796f, -0.02362383f, 0.01622683f, -0.01837958f, -0.04056850f, 0.00487495f, -0.00906505f, 
    -0.01382147f, 0.00250680f, -0.01210182f, -0.00953563f, -0.01698226f, 0.00790815f, -0.00784122f, 0.02521638f, 
    0.01703070f, -0.01108344f, -0.03929547f, -0.03886167f, 0.01453788f, 0.01202622f, -0.00692020f, 0.02487068f, 
    0.02396165f, -0.00652339f, -0.02264970f, 0.01451993f, -0.00368790f, -0.02108388f, -0.00634343f, -0.02928637f, 
    0.01520145f, -0.00486733f, -0.03237653f, 0.01413634f, 0.01079421f, 0.02029623f, -0.01678750f, -0.00697035f, 
    -0.02736663f, 0.01427840f, -0.02240113f, 0.00777800f, 0.00709744f, -0.00640129f, 0.00170920f, -0.01590047f, 
    0.01879617f, 0.01097605f, -0.02829443f, -0.00390024f, -0.00188305f, -0.02678789f, -0.03734135f, -0.00903291f, 
    -0.00384778f, 0.00056447f, -0.00505165f, 0.01132483f, 0.02964651f, 0.00676774f, -0.02338765f, -0.00357484f, 
    -0.01483021f, 0.00397517f, 0.01077167f, -0.01433811f, 0.02015654f, -0.02299744f, 0.01295215f, -0.01163023f, 
    -0.01888377f, 0.00595096f, 0.03309040f, -0.01642168f, -0.00955769f, -0.00454645f, 0.01690825f, 0.00498764f, 
    -0.03011324f, -0.03644321f, 0.00274992f, 0.01999357f, 0.00615392f, -0.01455673f, 0.02745179f, 0.01288223f, 
    -0.00322549f, 0.02852682f, 0.00192357f, -0.02911337f, -0.02969792f, -0.00702942f, -0.03303659f, -0.00056133f, 
    0.00043901f, 0.01446382f, -0.01047302f, 0.02138152f, 0.01389339f, -0.03273131f, -0.02284948f, 0.01275540f, 
    -0.03179589f, -0.03571995f, -0.03403874f, -0.03962670f, 0.01282954f, 0.02119440f, -0.02012064f, -0.01775741f, 
    0.02109168f, -0.00931645f, 0.01639261f, 0.01474771f, -0.01463931f, 0.02380598f, -0.03200931f, -0.01226026f, 
    -0.03734668f, -0.03667887f, -0.02974535f, -0.00048597f, -0.02485930f, -0.02861700f, 0.00257138f, -0.02796139f, 
    0.02337685f, 0.03213618f, -0.01103440f, 0.03275112f, 0.00068083f, 0.02810501f, -0.03647788f, -0.02187334f, 
    0.01893583f, 0.00499715f, 0.01269039f, -0.03213821f, -0.00538362f, 0.00632154f, -0.01744558f, 0.02203820f, 
    -0.01462621f, -0.03966521f, 0.02049701f, 0.01504787f, 0.02799367f, -0.00516238f, -0.01941019f, -0.01337340f, 
    0.00365681f, 0.02230213f, -0.01185160f, 0.00413061f, -0.01068177f, 0.00322044f, -0.02395941f, -0.00738193f, 
    0.02131512f, -0.00787670f, -0.01674350f, -0.03308481f, -0.02953769f, -0.01577201f, -0.03165198f, 0.00681856f, 
    -0.02529591f, -0.01807743f, -0.01983101f, 0.02415409f, -0.01336857f, -0.02141265f, 0.01003505f, -0.00118446f, 
    -0.03053601f, 0.02865381f, -0.00530247f, 0.02229701f, -0.01092457f, 0.00028611f, 0.00188133f, -0.00100412f, 
    -0.01803736f, -0.03496234f, -0.01098653f, 0.02598740f, 0.00085867f, -0.02719854f, -0.03620063f, 0.01562337f, 
    0.02417623f, 0.02079726f, 0.00404293f, -0.04102478f, -0.03299712f, 0.03322285f, -0.02108635f, 0.01867165f, 
    0.02315604f, -0.00400723f, 0.03252973f, 0.02989121f, 0.02122431f, 0.02481159f, -0.01274017f, -0.00605372f, 
    -0.02844947f, -0.00867022f, -0.01930283f, -0.00280028f, -0.00632948f, 0.01730823f, -0.00187488f, -0.01329335f, 
    -0.00664125f, -0.01993697f, 0.01299671f, -0.01736139f, 0.03243319f, -0.01268266f, 0.00077705f, 0.02199283f, 
    0.00613583f, -0.02100078f, 0.02990348f, 0.00861403f, -0.02851627f, 0.02417992f, -0.02460669f, -0.00560428f, 
    -0.02944548f, -0.00035464f, -0.02015013f, -0.00021064f, -0.02820394f, 0.01680977f, 0.02780440f, -0.03033622f, 
    -0.03054952f, 0.00528109f, 0.00046659f, -0.01620668f, -0.00311091f, -0.03768845f, -0.01411012f, 0.00882225f, 
    0.01673070f, -0.02332167f, 0.01797049f, -0.02941390f, -0.01338150f, -0.00751030f, 0.02237044f, 0.00264276f, 
    0.00314592f, 0.00207249f, -0.02114819f, 0.00830041f, 0.00490506f, 0.01970296f, -0.00472574f, 0.00686098f, 
    -0.00549139f, -0.00650468f, -0.03671183f, 0.01729181f, 0.00616605f, -0.02647749f, 0.01175545f, 0.00693222f, 
    0.01372838f, 0.01359001f, 0.02340209f, -0.01965122f, 0.01808790f, -0.02788118f, 0.00342801f, 0.02429014f, 
    -0.03423709f, 0.00743191f, 0.00153091f, -0.02184539f, -0.00622944f, 0.01728636f, -0.01483212f, -0.03885786f, 
    0.02440816f, 0.03008058f, 0.00393017f, -0.00307355f, -0.02155393f, -0.02972634f, -0.00782053f, -0.03253485f, 
    -0.00030022f, -0.03861285f, 0.00771415f, -0.03534909f, -0.04162360f, -0.00689402f, 0.02008158f, 0.00470816f, 
    -0.03614239f, -0.02529119f, -0.03238857f, -0.03338369f, -0.02619243f, -0.04226210f, -0.00137431f, -0.04030750f, 
    0.00620047f, -0.02021260f, -0.02623245f, -0.00780677f, -0.01863046f, -0.02513382f, 0.00637545f, 0.02351262f, 
    -0.00392928f, -0.00933003f, 0.01925452f, 0.01793591f, 0.00675049f, -0.00613120f, -0.01862014f, 0.00185851f, 
    0.01931121f, -0.03487661f, -0.03689392f, -0.01566853f, 0.02708487f, 0.00816933f, 0.01463897f, -0.00117641f, 
    -0.00765906f, -0.01656064f, 0.02500444f, -0.01865290f, 0.02209649f, -0.02911931f, -0.00725220f, -0.00637284f, 
    -0.00562100f, 0.00076464f, -0.01979133f, -0.04278958f, -0.02463087f, -0.02818329f, 0.00173885f, 0.00448932f, 
    0.02076337f, -0.02038857f, 0.03295432f, -0.00702811f, -0.01597984f, 0.01801729f, -0.00778872f, 0.00858189f, 
    -0.00642692f, 0.01168079f, 0.02036980f, 0.01738916f, -0.01694535f, -0.01819369f, -0.01970123f, -0.01996463f, 
    0.00382455f, -0.02101451f, -0.00053412f, -0.05000788f, 0.02700146f, -0.02936843f, 0.00131873f, -0.02162149f, 
    0.01500348f, 0.00235250f, -0.03401562f, 0.02167062f, -0.03652027f, -0.03248134f, 0.02541562f, 0.01306627f, 
    -0.00992827f, -0.02055687f, 0.00659965f, -0.00130816f, -0.03017110f, 0.01892711f, -0.00487829f, 0.00742656f, 
    0.01937754f, -0.00018873f, 0.01687616f, -0.01230770f, 0.00442206f, 0.01063952f, -0.02898161f, 0.01245670f, 
    -0.00689360f, -0.00090980f, -0.00265109f, 0.02763366f, -0.00341103f, -0.02717431f, -0.03988821f, -0.01778536f, 
    0.02641005f, -0.00813918f, 0.01657072f, -0.04578142f, 0.02377903f, -0.03277364f, -0.03418837f, 0.02267724f, 
    0.00947071f, -0.03537797f, -0.02231164f, -0.03944528f, -0.03087582f, 0.02004930f, -0.02572964f, -0.02763454f, 
    -0.01106809f, 0.02158628f, -0.02573217f, -0.02631491f, -0.00880258f, -0.00507295f, 0.02087679f, -0.03921442f, 
    -0.00827200f, 0.01479944f, 0.02542843f, 0.01668151f, 0.00950634f, -0.00462211f, 0.02565295f, 0.02670327f, 
    0.02832564f, 0.01350586f, 0.04258341f, 0.04119533f, -0.03427402f, 0.03573073f, 0.02668656f, 0.02392177f, 
    -0.02075461f, -0.02192014f, 0.01082775f, 0.02406320f, -0.02176649f, -0.02370894f, -0.02883527f, -0.00690730f, 
    -0.01940044f, -0.00268839f, -0.02383563f, -0.00044468f, 0.02322441f, -0.03751937f, -0.03528297f, -0.00017667f, 
    -0.02577673f, 0.02426990f, -0.03114982f, 0.00488714f, -0.02257317f, -0.01618312f, 0.02382484f, 0.01768159f, 
    -0.03868318f, -0.01233016f, -0.04290144f, -0.02414819f, 0.02456592f, -0.01290090f, 0.01020897f, -0.02557538f, 
    -0.01258782f, 0.01247981f, -0.04327231f, -0.01765574f, 0.00478110f, 0.00935066f, -0.00485198f, -0.04122824f, 
    -0.03120924f, -0.00484650f, -0.03587534f, 0.02657137f, 0.01903750f, -0.00981382f, 0.02418896f, 0.00398681f, 
    0.02046088f, -0.03129210f, 0.01149314f, -0.00255317f, -0.04131010f, -0.00102540f, -0.00467771f, -0.02197821f, 
    -0.02006221f, 0.03563151f, -0.02347272f, 0.01133737f, -0.01675814f, -0.03881003f, 0.00668069f, -0.00499199f, 
    0.02665900f, -0.01686189f, 0.02596403f, -0.02219639f, 0.01257479f, -0.02522630f, -0.03495973f, -0.02375706f, 
    0.02727921f, 0.01627253f, 0.01364354f, -0.02693945f, -0.00888940f, -0.03525379f, -0.03293479f, 0.01704310f, 
    0.00947384f, 0.01601451f, 0.01356123f, 0.02404885f, -0.02621320f, -0.00764444f, -0.00614747f, -0.01399097f, 
    -0.03144612f, -0.00512285f, 0.01628851f, -0.04325307f, -0.01654453f, 0.02371804f, -0.02502050f, 0.02442681f, 
    0.01536900f, 0.01213522f, 0.02965022f, 0.00196218f, -0.02969673f, 0.02109571f, -0.03952220f, -0.00849696f, 
    -0.00726996f, -0.00451433f, -0.00654701f, 0.01694765f, -0.03827671f, -0.02174372f, -0.00557257f, -0.00299111f, 
    0.00149533f, 0.03032700f, 0.00862942f, -0.02677596f, 0.01523575f, -0.02420364f, -0.03616666f, -0.02531223f, 
    -0.01417260f, -0.00834318f, -0.04577979f, 0.01400297f, 0.03630956f, -0.03755377f, 0.03445956f, 0.02994306f, 
    0.03192551f, -0.00884849f, 0.03100409f, 0.01044035f, 0.00671476f, 0.02609526f, 0.01729259f, -0.02893491f, 
    -0.03481667f, 0.01699563f, 0.03398847f, -0.03726270f, 0.00969012f, -0.01850148f, -0.01499151f, 0.00377932f, 
    -0.03211137f, -0.01723211f, 0.00633501f, -0.01456952f, 0.00270320f, 0.00564043f, -0.02594114f, 0.02968413f, 
    -0.00272230f, -0.01910616f, -0.02168383f, -0.02322453f, -0.04005796f, 0.01484911f, -0.00349462f, -0.03993000f, 
    -0.00777257f, -0.02601787f, -0.01233948f, 0.02369792f, -0.01787530f, -0.01903585f, 0.00192130f, -0.01984600f, 
    -0.04203044f, 0.02397040f, 0.00304918f, -0.03882069f, 0.03895087f, 0.01409276f, -0.01761833f, -0.00596755f, 
    -0.03493943f, 0.02062731f, 0.02915088f, 0.02671058f, 0.00095884f, -0.03125761f, 0.01741551f, -0.03396977f, 
    -0.02958066f, -0.03324737f, 0.01003959f, -0.01571769f, -0.01018543f, -0.00668874f, 0.02920821f, -0.00197596f, 
    0.01487192f, -0.00174187f, -0.02828775f, 0.01227465f, 0.03219860f, -0.02812516f, -0.03881897f, 0.01149007f, 
    -0.01630346f, -0.01899040f, 0.02569771f, -0.02382396f, 0.01405235f, -0.03713373f, 0.02415798f, -0.03366117f, 
    0.02791303f, 0.01388600f, 0.02849681f, 0.02369871f, -0.03945704f, 0.02866874f, 0.01013744f, 0.02254052f, 
    -0.01238288f, -0.00120520f, -0.00416065f, 0.01372491f, -0.01704645f, 0.03804350f, -0.02177977f, 0.00104608f, 
    -0.02864845f, -0.01976418f, -0.04218505f, 0.03341949f, 0.01311776f, -0.04148776f, -0.02735763f, -0.03107004f, 
    0.01518839f, -0.01273206f, -0.03923559f, -0.03540431f, -0.01328017f, -0.02768071f, -0.02354109f, 0.00538017f, 
    -0.00007734f, 0.02804602f, -0.01241032f, 0.00413739f, -0.02150966f, -0.02275907f, -0.01984248f, -0.02163968f, 
    0.01328503f, 0.00292998f, -0.01712295f, 0.00581972f, 0.00009453f, 0.02213580f, -0.01364656f, 0.02643171f, 
    -0.02439230f, 0.01738930f, -0.02699024f, -0.02132460f, 0.01375618f, 0.02373435f, -0.00089536f, -0.03737348f, 
    0.00604388f, -0.02468024f, -0.00074281f, 0.02830015f, 0.01879025f, -0.00656748f, -0.00735047f, -0.03634028f, 
    0.00091779f, -0.01295331f, 0.02302730f, 0.02285071f, -0.02435444f, -0.03541642f, -0.02936539f, -0.00245453f, 
    -0.03618450f, -0.02643148f, 0.02533318f, -0.00489623f, 0.02256512f, -0.01777047f, 0.01187146f, 0.03920830f, 
    0.01233608f, 0.01389248f, -0.04303162f, 0.02453613f, 0.02377991f, 0.03048270f, -0.01521426f, -0.01585904f, 
    -0.02887577f, 0.00094394f, 0.02739225f, -0.03442198f, -0.03201998f, -0.00002258f, -0.01089218f, -0.01374137f, 
    -0.04186161f, -0.01491149f, -0.00679895f, -0.01929518f, -0.01568618f, -0.01462441f, -0.03247538f, 0.02332352f, 
    -0.03292370f, -0.02895779f, 0.01782386f, -0.00367550f, -0.02494694f, -0.01286556f, 0.00197001f, 0.01675938f, 
    -0.01989716f, 0.02914009f, 0.00994054f, -0.02776021f, -0.00323871f, -0.01675295f, -0.01400162f, -0.00670127f, 
    0.00143769f, -0.00642504f, -0.03416600f, -0.03475205f, 0.00141490f, -0.00212472f, 0.01259826f, -0.03524917f, 
    0.00480952f, -0.01050059f, 0.00025388f, 0.01880562f, -0.00044239f, 0.02965413f, 0.00562299f, -0.02667660f, 
    0.01464593f, 0.01790292f, 0.00863546f, -0.01271265f, -0.02040807f, -0.02122046f, 0.00078342f, 0.00760819f, 
    0.01350898f, -0.03630455f, 0.00486349f, 0.02481604f, 0.02807151f, 0.01600384f, 0.00637377f, 0.01922370f, 
    0.01458090f, -0.00482292f, -0.02156099f, 0.00976751f, -0.00638818f, -0.01366186f, 0.01096097f, -0.00204758f, 
    0.00797825f, -0.01435375f, -0.01089863f, -0.00795358f, 0.02715562f, 0.00926724f, -0.02538443f, 0.01518637f, 
    0.03060290f, -0.00418922f, 0.00519425f, 0.02692322f, 0.00954087f, -0.02205355f, -0.03914331f, -0.01494953f, 
    -0.01236190f, -0.03981963f, -0.00030412f, -0.03033512f, 0.03170527f, 0.00251328f, 0.00921505f, -0.03621888f, 
    -0.00526105f, -0.00908707f, 0.02498616f, 0.01728107f, -0.00610014f, -0.01608755f, -0.03332207f, 0.00916083f, 
    0.01735796f, -0.00213200f, -0.01047258f, -0.03468572f, -0.01103241f, -0.02587193f, 0.01909966f, -0.01335252f, 
    -0.03116946f, -0.01857348f, -0.03565738f, 0.00985559f, 0.01539543f, 0.02430554f, -0.00493891f, -0.02364569f, 
    -0.01256230f, 0.00511433f, 0.00803220f, -0.00082804f, 0.02049642f, 0.00424920f, -0.01850866f, -0.02412854f, 
    -0.02949118f, -0.00072664f, 0.02871692f, 0.03827888f, -0.01454656f, 0.01665141f, 0.01276394f, 0.00471251f, 
    0.02162809f, 0.02154605f, 0.02439254f, 0.02482543f, -0.03257604f, -0.03220967f, 0.03186431f, -0.02180048f, 
    -0.04074473f, -0.02970345f, 0.00232373f, -0.01638737f, 0.01773950f, -0.02065611f, -0.04283743f, 0.00545662f, 
    0.01794109f, -0.01550284f, -0.02062636f, 0.00508830f, -0.01085256f, -0.01345600f, -0.03539979f, -0.01457149f, 
    0.03019041f, 0.00722172f, -0.01075520f, 0.01003166f, -0.00208558f, -0.02582240f, 0.00737664f, -0.01876149f, 
    0.00951276f, -0.02367783f, -0.00315440f, 0.01046350f, 0.02224970f, -0.00460590f, -0.00924261f, -0.00437364f, 
    0.02477809f, -0.02791278f, -0.00873924f, -0.02667534f, 0.02974687f, 0.00203486f, -0.03637572f, -0.02432978f, 
    0.01561393f, -0.02062228f, -0.03403372f, 0.02720149f, -0.03383495f, -0.00609677f, -0.00831473f, 0.01296207f, 
    -0.03210614f, 0.02182984f, 0.00213199f, -0.02960580f, 0.02286570f, -0.02861066f, -0.00641869f, -0.02199483f, 
    -0.01678695f, -0.01280920f, 0.01709173f, -0.04149852f, 0.00934621f, 0.02435561f, 0.02121840f, 0.00322658f, 
    -0.01928401f, -0.01840879f, -0.04268315f, -0.01081074f, 0.02017398f, -0.02548686f, -0.03999515f, 0.00501225f, 
    0.01790331f, -0.01230557f, 0.03107523f, -0.01057993f, -0.02014284f, 0.00768276f, -0.01334516f, 0.01522906f, 
    -0.03228383f, 0.02366837f, -0.00514411f, -0.04137984f, -0.02484944f, -0.02368016f, -0.03174727f, -0.03437837f, 
    -0.00755766f, 0.01759162f, -0.02064233f, -0.01502424f, 0.03329734f, -0.02544339f, 0.02868003f, -0.03443369f, 
    0.02400446f, 0.01362507f, -0.00367739f, 0.00535392f, -0.00112932f, -0.00588456f, 0.02039600f, -0.01904566f, 
    0.01982668f, -0.02525794f, -0.00067384f, 0.01108592f, -0.02599331f, -0.02999294f, 0.00300059f, -0.04469233f, 
    -0.03984710f, -0.02631855f, 0.02735997f, 0.01586854f, -0.01509766f, -0.03279341f, -0.02224939f, -0.02716516f, 
    0.00705813f, 0.02055549f, -0.01029141f, 0.00805971f, -0.04265519f, -0.00495929f, 0.01563661f, -0.02254779f, 
    -0.01439017f, -0.02858623f, -0.01465778f, -0.00972759f, -0.03991618f, -0.01771614f, -0.02837708f, -0.02643158f, 
    -0.00816570f, 0.02425947f, 0.04167376f, -0.01502689f, 0.01510818f, 0.03003889f, -0.01859866f, -0.01296864f, 
    -0.03098383f, 0.01640172f, -0.00116006f, -0.01527319f, -0.02458602f, 0.00274731f, 0.00810311f, 0.01817632f, 
    0.02420804f, -0.03146987f, -0.03490373f, 0.01724042f, -0.00058131f, 0.02745242f, -0.02610155f, -0.04195355f, 
    -0.00294156f, 0.02604227f, 0.00007993f, -0.03465323f, -0.02192207f, -0.02735547f, -0.03806188f, -0.02560165f, 
    0.01188028f, 0.00630717f, 0.00040806f, -0.03660147f, 0.00977547f, -0.00891358f, 0.02553745f, 0.02366207f, 
    -0.01022958f, -0.03091462f, -0.02040529f, -0.00102494f, -0.03032567f, -0.02647259f, 0.01218935f, -0.01254117f, 
    -0.04107890f, 0.01177973f, 0.00509103f, -0.01601872f, -0.01125693f, -0.03328136f, 0.02678079f, 0.00812851f, 
    -0.01388931f, 0.00535744f, 0.00930160f, -0.01124716f, -0.01114438f, -0.01966487f, -0.01794727f, -0.03523821f, 
    0.00564083f, -0.00944590f, -0.01195995f, -0.01883134f, 0.01146185f, -0.03452412f, -0.02015288f, 0.00471797f, 
    0.02475664f, 0.02184387f, -0.00300702f, 0.00418540f, 0.00901239f, 0.01266280f, -0.00711686f, -0.00570253f, 
    -0.03111984f, -0.02428455f, -0.03278696f, -0.01170618f, -0.03765142f, -0.03353275f, 0.00671912f, -0.03509427f, 
    -0.01041832f, 0.02993855f, 0.02162390f, -0.00455969f, -0.02666350f, -0.03421451f, 0.01858082f, 0.02719157f, 
    -0.02572487f, -0.04442639f, -0.04623437f, -0.03575916f, -0.02475289f, 0.00480889f, -0.03403234f, -0.00671782f, 
    0.01922587f, 0.00308782f, -0.01624971f, -0.02147589f, -0.04477855f, -0.03336920f, -0.00068894f, -0.01307651f, 
    0.01846691f, 0.01188283f, 0.01325622f, -0.03730614f, -0.01783043f, -0.01173920f, -0.04090178f, 0.02345564f, 
    -0.02443536f, -0.00782384f, 0.02437869f, -0.01189557f, 0.02378149f, -0.03649037f, 0.04214876f, 0.03119178f, 
    -0.01214528f, -0.00265827f, 0.02475697f, -0.01323388f, -0.02600699f, 0.00959267f, -0.00751202f, -0.00769053f, 
    0.01653899f, -0.01504698f, -0.01093130f, -0.02209498f, 0.01988162f, 0.02919145f, 0.00467309f, -0.01575902f, 
    0.02108694f, 0.01490987f, -0.04098749f, -0.00192005f, 0.00744671f, 0.00464755f, -0.04536239f, -0.02495410f, 
    0.02237771f, 0.00314721f, -0.00331517f, -0.01338399f, 0.01774707f, -0.01214364f, -0.01859941f, -0.02948128f, 
    -0.01991508f, 0.02093600f, 0.00634346f, -0.01065884f, -0.01389121f, -0.00519171f, 0.01022476f, -0.00024129f, 
    -0.02504624f, 0.02303487f, -0.03192069f, 0.02863376f, -0.01123345f, 0.02855162f, 0.00820648f, -0.03219527f, 
    0.00607394f, -0.00309210f, -0.04201871f, -0.01710609f, -0.03383445f, -0.01947370f, -0.04170136f, -0.03023456f, 
    0.02782002f, -0.01668646f, 0.00012138f, 0.00170499f, -0.03790511f, 0.02288974f, 0.00547671f, -0.00462693f, 
    -0.03419880f, -0.02284983f, -0.03323295f, -0.01731320f, -0.01021400f, -0.00251064f, 0.03552747f, 0.03156994f, 
    0.01752038f, -0.02685991f, 0.00326954f, -0.00877549f, -0.00081371f, -0.02884964f, -0.01637432f, -0.01770223f, 
    -0.03161623f, 0.03644187f, 0.03522392f, -0.03369913f, 0.01530490f, -0.00229072f, -0.02442792f, -0.01790623f, 
    -0.00308825f, 0.00867986f, 0.00459019f, 0.00578694f, 0.01811203f, -0.03681587f, -0.00294729f, -0.01813313f, 
    0.00781481f, 0.01812305f, -0.01988071f, 0.01499929f, 0.00998272f, -0.00115723f, 0.01954840f, -0.00687515f, 
    0.03381954f, 0.00983787f, -0.02084580f, -0.02270089f, 0.01944192f, -0.04010221f, 0.01250535f, -0.03535259f, 
    -0.02063771f, -0.00615053f, -0.03229936f, 0.01609843f, -0.04169068f, -0.00899593f, -0.01215166f, 0.01609645f, 
    0.01023172f, 0.03127734f, -0.00956697f, 0.01641218f, -0.02327704f, -0.01532591f, 0.00050419f, 0.02881548f, 
    -0.00747805f, -0.03792132f, 0.01108866f, 0.01894553f, 0.00966372f, 0.01156585f, -0.00013448f, 0.01604403f, 
    -0.02896291f, 0.02431919f, 0.01788672f, 0.02597818f, -0.00673985f, -0.01929656f, 0.01201930f, -0.03068824f, 
    0.01160357f, 0.00286072f, 0.01687751f, -0.02898404f, -0.00331997f, -0.01499184f, -0.01335410f, 0.01543170f, 
    -0.03111512f, 0.02791950f, -0.01855159f, -0.04445147f, 0.02513148f, 0.00052318f, 0.01075304f, 0.00727939f, 
    -0.00046375f, 0.02622846f, 0.00246529f, 0.02031024f, -0.00619641f, 0.01778842f, 0.02528000f, 0.01380433f, 
    -0.03977038f, -0.02237211f, 0.02447216f, -0.03095639f, 0.00543072f, 0.02715217f, 0.03029572f, -0.03386427f, 
    0.03036025f, -0.01434494f, 0.02808376f, 0.02375507f, -0.02682841f, -0.01595669f, 0.00857572f, -0.03425201f, 
    0.00871227f, -0.01857120f, -0.01372336f, -0.00178310f, 0.01762753f, 0.01917685f, -0.03569494f, -0.02476429f, 
    -0.04286591f, 0.00190265f, 0.00624540f, 0.00714541f, -0.03086133f, -0.00341876f, -0.00296335f, -0.00617169f, 
    0.02779914f, -0.00682972f, -0.02820318f, 0.00360173f, 0.01783654f, 0.03164682f, -0.02850046f, -0.01844113f, 
    0.00863453f, 0.03434549f, 0.01042914f, 0.00657376f, -0.02575674f, -0.02999635f, -0.01275344f, 0.00674008f, 
    0.00742293f, -0.03575128f, 0.02021166f, 0.02221516f, -0.02867844f, 0.01765388f, -0.00988929f, -0.00585949f, 
    0.02428602f, 0.02253302f, 0.03161049f, -0.03845955f, -0.00003682f, -0.01164021f, -0.00694781f, -0.01212480f, 
    -0.01011051f, -0.02067597f, 0.01755361f, -0.00543584f, 0.00514764f, 0.01430919f, 0.02783928f, -0.02322500f, 
    0.01735436f, -0.03208034f, -0.01604828f, 0.02756936f, -0.02583187f, -0.03476169f, 0.00987354f, -0.02172474f, 
    -0.00129025f, -0.02418869f, 0.00271995f, 0.00464833f, -0.00347419f, -0.01393772f, -0.04041481f, 0.02328042f, 
    -0.00687506f, -0.03833265f, 0.02387621f, 0.01668051f, 0.00082634f, 0.00514391f, -0.01998477f, -0.01729116f, 
    -0.00418162f, 0.03164233f, -0.02522790f, 0.01892449f, -0.01277467f, 0.02230284f, 0.00671819f, -0.02389736f, 
    -0.02045058f, -0.02540670f, -0.01907777f, -0.01356610f, 0.01257697f, -0.02232849f, 0.00805471f, 0.01181678f, 
    0.01916998f, -0.02867990f, 0.02130957f, 0.00711100f, -0.03994279f, -0.00898299f, 0.02438255f, -0.02805207f, 
    -0.02541898f, -0.00730853f, 0.02443997f, -0.00835242f, -0.00646645f, 0.01457764f, 0.01689943f, 0.00874644f, 
    0.01712200f, -0.01169361f, 0.01794615f, -0.02176546f, -0.00889179f, 0.01511779f, -0.02589178f, -0.04622414f, 
    0.00627724f, 0.01576518f, 0.02409814f, -0.04086083f, 0.01802857f, -0.03771703f, 0.02416472f, 0.00524779f, 
    -0.02766067f, -0.01768528f, -0.01156686f, 0.01968089f, -0.04283826f, 0.00001142f, 0.01220810f, 0.02273297f, 
    0.01123024f, 0.02638574f, 0.01139410f, -0.00900939f, -0.00577538f, -0.01088777f, 0.02670843f, -0.04082442f, 
    0.01175520f, -0.00598079f, -0.00275331f, 0.02845999f, 0.02274798f, -0.01087935f, -0.01779272f, 0.01862658f, 
    -0.01949658f, 0.02350586f, -0.02497017f, 0.00940179f, -0.01800462f, -0.03397220f, 0.01566015f, 0.02457184f, 
    -0.00660813f, 0.00816599f, -0.01893987f, -0.03519289f, -0.02996887f, -0.01641501f, 0.01633530f, 0.00257311f, 
    0.02487500f, -0.01549386f, 0.00919063f, 0.01621200f, -0.02155922f, -0.02694118f, 0.02362839f, 0.01687678f, 
    -0.03928969f, 0.00685607f, 0.01989875f, -0.02518103f, -0.01478831f, -0.03292864f, 0.01756295f, -0.02095674f, 
    0.02364445f, 0.02903734f, -0.03803863f, -0.03743026f, -0.01908917f, 0.00032703f, -0.01561992f, 0.02448569f, 
    -0.01620325f, 0.01318258f, 0.03014750f, -0.01872752f, 0.01113820f, 0.00505875f, -0.01033350f, -0.01924600f, 
    0.01494555f, -0.00218496f, 0.01315331f, -0.00840255f, -0.01740443f, 0.01135729f, 0.00142186f, -0.02280059f, 
    0.00320460f, -0.01925302f, 0.02840772f, -0.04166012f, 0.00506362f, 0.01203069f, -0.03131184f, -0.01660153f, 
    -0.01737510f, 0.00388257f, -0.02207659f, 0.00024984f, -0.01059145f, 0.01002324f, -0.03202273f, -0.01711764f, 
    -0.01111238f, 0.02491300f, -0.01979969f, 0.00996941f, -0.04439518f, -0.03133722f, -0.01946097f, -0.03418939f, 
    -0.02866754f, 0.01718544f, 0.01398407f, -0.04386422f, -0.01284528f, -0.02254586f, 0.00844557f, 0.01696893f, 
    0.00327916f, -0.00567501f, -0.01371436f, -0.00136477f, -0.03462986f, -0.00357345f, -0.00433319f, -0.03480617f, 
    -0.03512118f, 0.01374722f, 0.00174748f, -0.00397405f, 0.01490350f, -0.02194091f, -0.02345284f, -0.00040747f, 
    -0.00155069f, -0.00840261f, 0.03541501f, 0.00257849f, -0.01088448f, -0.02132436f, 0.01719794f, -0.01947360f, 
    -0.03194252f, -0.01744799f, -0.01151669f, 0.02083544f, 0.02311241f, 0.00229893f, 0.01204947f, -0.00103335f, 
    0.00273938f, -0.01029721f, -0.01752222f, -0.03382103f, -0.02481405f, 0.01832613f, 0.01676321f, 0.03155751f, 
    -0.00393800f, 0.01038207f, 0.02681469f, -0.04131257f, 0.02019854f, 0.02788915f, -0.01037796f, -0.03459514f, 
    -0.00027815f, 0.01045528f, -0.03048883f, 0.00491467f, -0.03519165f, -0.02410228f, -0.01868952f, -0.00356565f, 
    0.00351088f, 0.02032991f, -0.02100596f, 0.02242666f, 0.02266059f, -0.00452184f, 0.01631195f, 0.01406406f, 
    0.01460860f, -0.01899887f, -0.02874574f, 0.00209238f, 0.01967471f, 0.03163850f, 0.00746451f, -0.03313576f, 
    0.01913434f, 0.01775631f, -0.00739509f, -0.02742175f, 0.01918796f, -0.03350937f, 0.02209977f, 0.02604056f, 
    -0.02157838f, -0.02347798f, -0.00008413f, -0.01045221f, 0.02829975f, 0.00906493f, -0.01677850f, 0.00216727f, 
    -0.00239079f, 0.01335010f, -0.03259742f, -0.03784436f, 0.02314464f, -0.02324024f, -0.01510225f, -0.04058304f, 
    -0.03405279f, 0.00573212f, -0.00219465f, -0.01289271f, -0.02955010f, -0.01416694f, 0.00704579f, -0.01141642f, 
    0.01758536f, 0.01369163f, -0.02165906f, -0.01477933f, 0.02529838f, -0.03640275f, -0.03171560f, 0.02378672f, 
    0.02105463f, -0.00584278f, -0.04013556f, 0.00564714f, 0.02475783f, 0.02454577f, 0.02653897f, 0.01593165f, 
    0.00230155f, 0.01179848f, -0.00536652f, -0.02024093f, -0.00028300f, -0.01151935f, 0.02659455f, -0.00581288f, 
    -0.00495646f, 0.00689427f, -0.01235483f, -0.00520443f, -0.00266570f, -0.00782680f, 0.02158215f, -0.03845720f, 
    -0.00824848f, 0.02033898f, -0.03210676f, 0.01565959f, 0.00130989f, 0.01014312f, -0.04041804f, -0.03078156f, 
    -0.02155081f, 0.00234833f, -0.00419435f, -0.02268551f, -0.03197449f, -0.02547300f, 0.02723671f, -0.01840695f, 
    0.00507007f, -0.03996037f, 0.01468919f, 0.00096294f, -0.00174701f, -0.02520217f, 0.01463990f, -0.01367271f, 
    0.00792238f, 0.01158563f, -0.00697881f, -0.02936726f, 0.00328472f, 0.02036120f, -0.00210895f, -0.01380061f, 
    0.00051947f, 0.00220618f, -0.03239201f, -0.02319358f, 0.01857172f, 0.01716695f, 0.01228619f, -0.02824598f, 
    -0.01218093f, 0.02883585f, -0.00009752f, 0.01376551f, 0.00757566f, 0.02656258f, 0.00487446f, -0.03269600f, 
    0.00071135f, -0.01084996f, -0.02263772f, -0.02968610f, -0.03535502f, 0.02798743f, -0.00565584f, 0.00805913f, 
    -0.01082779f, -0.00413859f, -0.02056046f, 0.00154332f, 0.01566450f, 0.02721482f, -0.02848005f, 0.01676530f, 
    0.01480475f, 0.01117743f, -0.02214149f, 0.00901562f, 0.00348447f, -0.01069863f, -0.02277988f, -0.03443585f, 
    -0.03870755f, 0.01393291f, 0.00503313f, -0.03580080f, -0.00737842f, -0.03733407f, 0.02387087f, -0.00769059f, 
    -0.00050660f, -0.02162825f, 0.00191853f, -0.02959789f, -0.01156649f, 0.00826471f, -0.02495909f, -0.00550775f, 
    -0.04150263f, 0.00449886f, 0.02137620f, -0.02243657f, -0.01407974f, 0.03393717f, -0.03251112f, -0.01766096f, 
    -0.01769842f, -0.00594745f, 0.01532405f, 0.01810896f, 0.00427735f, -0.01999626f, 0.01477024f, -0.01104872f, 
    -0.02859968f, 0.01135206f, -0.01084485f, -0.02037769f, -0.01581089f, -0.00131717f, 0.00886742f, 0.02657634f, 
    0.03766509f, 0.01861963f, 0.02726093f, -0.03071912f, -0.02945659f, 0.00383969f, 0.01569972f, -0.03748947f, 
    -0.03930043f, 0.00143195f, 0.00698171f, -0.00834828f, 0.00135460f, 0.01742570f, -0.00671153f, -0.00636971f, 
    -0.00265086f, -0.00415883f, 0.02406771f, 0.01085366f, -0.01557278f, -0.02781386f, -0.02824534f, 0.00698521f, 
    -0.00963935f, -0.01808951f, -0.00889632f, -0.03704862f, -0.00196727f, -0.00476658f, 0.01947414f, 0.02287002f, 
    -0.00553552f, 0.01829369f, 0.00803937f, -0.02860541f, -0.01444804f, -0.00515506f, 0.00377124f, -0.01709090f, 
    -0.00659890f, -0.03558647f, 0.00663353f, -0.01077798f, -0.02876629f, -0.00369162f, 0.02457942f, -0.00351150f, 
    0.01541281f, 0.01407526f, -0.01968125f, -0.00620338f, 0.01972491f, 0.01990432f, -0.00119828f, 0.02724070f, 
    -0.00313113f, -0.02536091f, 0.02537237f, -0.00996450f, 0.02662176f, -0.01963094f, -0.01689489f, 0.00918699f, 
    0.00846997f, -0.00174314f, 0.00837876f, 0.02758552f, -0.02956778f, 0.01114651f, -0.01145238f, 0.02891119f, 
    -0.03423549f, -0.03705185f, -0.02038546f, 0.02447712f, -0.01520240f, 0.02020453f, -0.01444606f, 0.01417061f, 
    0.01187655f, -0.00183939f, -0.01373573f, 0.00472426f, 0.00612098f, 0.02630731f, -0.02174223f, -0.03278371f, 
    -0.02688299f, 0.00202966f, 0.01088180f, 0.01140107f, 0.02622290f, -0.02508349f, -0.01985333f, -0.04058412f, 
    -0.02049201f, 0.02549490f, 0.00075734f, 0.00418828f, -0.01218399f, -0.02764555f, -0.01465872f, 0.01809298f, 
    -0.00410414f, -0.01735411f, -0.02181927f, -0.00400249f, -0.01365514f, -0.00572731f, 0.00799927f, -0.00032170f, 
    0.00554319f, 0.01116875f, -0.01884785f, 0.03219010f, -0.01879757f, -0.02789122f, 0.00935393f, -0.00790815f, 
    -0.04108258f, -0.00952869f, 0.00283113f, -0.02727992f, -0.03931914f, 0.02222551f, -0.03085979f, 0.00555445f, 
    -0.00199374f, 0.01181577f, -0.01774913f, 0.00608503f, -0.00345040f, 0.00344869f, -0.01983474f, -0.00108914f, 
    0.00984285f, -0.00306877f, -0.03625458f, -0.01543253f, -0.00058356f, -0.03982528f, 0.00037748f, 0.01949555f, 
    -0.00170447f, -0.03494938f, 0.02364063f, 0.01680066f, 0.00811216f, -0.04160748f, 0.01091969f, -0.04143248f, 
    0.02421918f, 0.01587680f, 0.02617862f, -0.00980025f, 0.01621534f, -0.03617614f, -0.03249136f, -0.03563771f, 
    -0.00445457f, 0.01467188f, -0.01820648f, -0.01208152f, -0.00480219f, -0.02104448f, -0.01888015f, -0.02222540f, 
    0.00711313f, -0.01437580f, 0.01515588f, 0.01701021f, -0.04333484f, -0.02392090f, -0.03557916f, 0.00055676f, 
    0.02527870f, -0.02952989f, -0.01637612f, -0.00429730f, 0.00329885f, 0.01177435f, -0.04096485f, -0.02205186f, 
    -0.01899418f, 0.00848551f, -0.01482966f, -0.03396361f, -0.00892502f, -0.02733515f, 0.00017077f, -0.03543403f, 
    0.01943146f, -0.01433307f, 0.00531488f, 0.02682696f, -0.01481451f, -0.02468506f, 0.02033174f, -0.00605691f, 
    -0.00223320f, -0.00572592f, 0.00570833f, -0.01533710f, 0.02216570f, -0.02507458f, 0.00886361f, 0.02641091f, 
    -0.01531687f, 0.00540279f, -0.01020638f, -0.04050514f, -0.02716200f, 0.02102080f, -0.02570421f, -0.02681627f, 
    0.00093677f, 0.01896529f, 0.00488205f, -0.03487884f, 0.01730216f, 0.02723810f, -0.00799504f, -0.02005160f, 
    -0.01891767f, -0.00940111f, 0.03013823f, 0.00526460f, -0.01062390f, -0.00819783f, -0.01507690f, -0.03792793f, 
    -0.02158100f, 0.02117551f, 0.02011849f, 0.02865071f, 0.02244950f, -0.00506556f, -0.00259707f, 0.00923874f, 
    0.02648724f, -0.00538361f, 0.01882147f, -0.03030767f, -0.02124089f, -0.02431179f, -0.00067632f, 0.01439539f, 
    0.01798475f, -0.01429670f, -0.01881513f, -0.00611058f, 0.01758492f, 0.00457946f, 0.01735170f, -0.00519261f, 
    0.00596472f, 0.01279336f, -0.02491733f, 0.02984100f, -0.02484985f, -0.01392886f, -0.00821999f, 0.02687841f, 
    -0.00786435f, -0.00903901f, -0.03082596f, -0.01349212f, 0.01575754f, 0.01530388f, 0.01923239f, 0.02471069f, 
    -0.03668064f, -0.03063849f, -0.01064144f, -0.01991929f, 0.00990812f, -0.01834765f, 0.02817777f, 0.02908430f, 
    -0.00357081f, 0.03608143f, -0.00424534f, -0.00863821f, -0.01913865f, -0.01395489f, -0.02404043f, 0.00402599f, 
    -0.00807859f, -0.00324280f, -0.03371957f, -0.00045167f, -0.03155962f, -0.03611112f, -0.00099290f, -0.01832962f, 
    0.00411214f, -0.01731442f, -0.03267685f, 0.01620029f, -0.00166966f, -0.02398850f, 0.01732210f, -0.01472428f, 
    -0.03664656f, 0.02368298f, 0.00799019f, -0.00748084f, 0.01967842f, -0.03505485f, -0.04162104f, 0.00279397f, 
    0.01898272f, -0.00467311f, -0.01234814f, 0.01586961f, -0.00021838f, -0.00158440f, 0.01616562f, 0.01808105f, 
    -0.01929292f, 0.00269345f, -0.02662714f, -0.02048113f, -0.01271830f, 0.00343768f, 0.01113999f, -0.03690539f, 
    -0.00161186f, -0.01199970f, -0.02265275f, 0.00979132f, -0.00835329f, 0.02267041f, 0.02096936f, 0.02320486f, 
    -0.00261343f, -0.01677126f, -0.03468331f, -0.00500806f, -0.03583372f, -0.01692460f, -0.02233967f, 0.00350147f, 
    0.00635257f, -0.02749320f, 0.03548889f, -0.01165956f, 0.01917109f, -0.02563382f, -0.02783398f, 0.00486402f, 
    -0.00015203f, -0.02826565f, 0.00671751f, 0.00124287f, -0.02862687f, -0.00082296f, -0.00375499f, 0.01117498f, 
    -0.00540200f, -0.03607632f, 0.00559688f, -0.00347067f, -0.00107824f, -0.00558083f, -0.03797395f, 0.01383617f, 
    -0.01058256f, 0.01055195f, 0.00995741f, -0.02177024f, 0.03080280f, 0.01308105f, -0.00614651f, -0.00546190f, 
    -0.00475108f, -0.01206140f, -0.02574717f, 0.01235192f, 0.00428318f, 0.00006621f, -0.03978068f, 0.02071293f, 
    0.01136478f, 0.01196802f, 0.03242711f, 0.02633789f, 0.00273844f, -0.00010838f, -0.00170645f, -0.01314162f, 
    0.02767489f, -0.02419461f, -0.03607375f, 0.01292365f, 0.00814191f, 0.01090962f, -0.02110927f, 0.00192805f, 
    -0.01812788f, -0.03407548f, -0.00834277f, -0.00806219f, -0.01585812f, 0.01801445f, -0.00598987f, -0.03051700f, 
    -0.00156865f, 0.02872639f, 0.01234209f, 0.01878080f, 0.00757132f, 0.01195651f, 0.02733991f, -0.03837539f, 
    0.02057129f, 0.02611593f, -0.03767701f, -0.01658714f, 0.00617365f, -0.01212836f, 0.01292375f, -0.03687533f, 
    0.02366620f, -0.03170571f, 0.02720696f, 0.00652872f, 0.01828100f, -0.02461693f, 0.01808391f, -0.03210701f, 
    -0.00099026f, -0.04022637f, 0.01885977f, 0.01828632f, 0.01910025f, -0.01649934f, -0.02519476f, -0.02571180f, 
    0.02784085f, -0.02651315f, -0.00380673f, -0.03982956f, 0.02184420f, -0.01101991f, -0.00997732f, 0.01042989f, 
    -0.02275153f, -0.03037912f, -0.04038199f, -0.02373690f, 0.01933866f, 0.01779016f, 0.01526349f, 0.02158769f, 
    0.02104893f, 0.01871832f, -0.03048873f, -0.01974105f, 0.00095708f, -0.02445201f, -0.00619509f, -0.02893069f, 
    -0.02815266f, -0.02352196f, 0.01724432f, -0.03901419f, -0.04256562f, -0.03924832f, -0.00257654f, 0.00667056f, 
    -0.01422774f, 0.00804497f, -0.03790473f, -0.02185839f, -0.01577275f, -0.01350821f, -0.03298597f, 0.02226977f, 
    0.00315087f, -0.00348502f, -0.03244144f, 0.02926930f, -0.01589881f, 0.00661497f, 0.00161833f, -0.03599586f, 
    0.00288836f, 0.01249561f, 0.00676222f, -0.02104581f, -0.04074426f, -0.01959576f, 0.00844793f, -0.00940073f, 
    0.00666931f, -0.01710324f, 0.00889825f, -0.01515059f, -0.03375452f, -0.03984339f, -0.02338656f, 0.01986456f, 
    -0.01359655f, -0.01836120f, -0.02257986f, -0.00613866f, 0.00585131f, -0.01653105f, -0.00983424f, -0.00401266f, 
    0.03513869f, -0.01251579f, -0.03857662f, -0.02979760f, -0.00632501f, 0.00341696f, 0.00161253f, 0.03308453f, 
    -0.03445687f, -0.00944326f, -0.01362081f, -0.01178102f, 0.02736421f, -0.03640727f, -0.03095948f, 0.02195038f, 
    0.00900163f, -0.01976883f, -0.03007756f, -0.01673897f, 0.02205877f, 0.00437689f, 0.02129064f, -0.00159203f, 
    0.02318261f, 0.03227063f, -0.01129825f, 0.00460498f, -0.00323460f, 0.02546442f, 0.01387274f, -0.01037950f, 
    -0.03264444f, 0.00808756f, 0.00940149f, 0.02753586f, 0.00734729f, -0.00891549f, 0.00662098f, -0.04183659f, 
    -0.02954762f, -0.00977312f, 0.01060515f, 0.02039317f, -0.02438083f, -0.02648903f, 0.00601052f, -0.02344501f, 
    0.02209087f, 0.02621865f, 0.03249668f, 0.01944157f, 0.03290569f, 0.02385407f, -0.03380101f, -0.01216495f, 
    -0.03115854f, -0.00694200f, 0.01714933f, 0.00031317f, 0.01105635f, 0.01633785f, -0.02124842f, -0.00454314f, 
    0.00654852f, -0.01377307f, -0.00005329f, -0.02052617f, 0.02322718f, -0.02651195f, -0.00484726f, 0.00247580f, 
    0.01439488f, -0.01136434f, -0.03250722f, -0.03723228f, 0.02087680f, 0.02014153f, -0.00977030f, -0.03101137f, 
    0.03315678f, -0.02348528f, -0.00689437f, 0.00942111f, -0.01890731f, 0.03199712f, 0.01051819f, 0.00088210f, 
    -0.01347546f, -0.00205538f, 0.00460837f, 0.02961911f, 0.01136674f, 0.00464025f, -0.04141096f, -0.02735198f, 
    -0.01303338f, 0.02806970f, -0.02873066f, 0.03833358f, 0.03126508f, -0.00493365f, -0.00742980f, -0.02126464f, 
    -0.03424137f, 0.00883500f, 0.01988897f, 0.00915951f, -0.00183828f, 0.01808002f, 0.00237798f, -0.00290537f, 
    -0.01044190f, -0.00557720f, 0.02964303f, 0.01809028f, 0.00286254f, -0.00572328f, -0.02026759f, 0.03002302f, 
    0.02650785f, -0.03984225f, 0.00290593f, -0.01737389f, 0.02320451f, -0.01792743f, -0.02082039f, -0.02750766f, 
    -0.02326258f, 0.00448258f, -0.01780441f, 0.02237473f, 0.03081357f, -0.01568507f, -0.00590494f, 0.03476114f, 
    0.02056842f, -0.01200503f, -0.01302985f, -0.02044602f, -0.01181000f, 0.02350887f, -0.01081420f, 0.03136107f, 
    -0.00461255f, 0.02122567f, 0.02785773f, -0.01817780f, -0.02611374f, 0.02568273f, 0.02420380f, -0.03574557f, 
    -0.03481468f, 0.02391529f, 0.01625020f, -0.00687654f, -0.00451817f, 0.03401669f, 0.02509355f, -0.03599822f, 
    0.01470425f, -0.03219020f, -0.00435997f, -0.02805672f, -0.02479667f, -0.01489710f, -0.03572811f, 0.01239003f, 
    -0.02127165f, -0.03579576f, 0.02104185f, 0.02053765f, -0.02455609f, -0.03019317f, -0.01028380f, -0.01016181f, 
    -0.00767240f, 0.02116726f, -0.00512486f, -0.01347651f, -0.00883527f, -0.02835967f, 0.01331492f, -0.03174031f, 
    -0.00482807f, -0.01301371f, -0.02496776f, -0.00968890f, -0.03190617f, 0.00720358f, 0.01553671f, 0.03185603f, 
    0.01217605f, -0.00110334f, 0.03123167f, -0.03348291f, -0.03694006f, -0.02744489f, 0.03064488f, -0.01351919f, 
    -0.03256622f, 0.00692804f, 0.00237260f, 0.00803079f, -0.02898029f, -0.02693443f, -0.01552378f, 0.00659413f, 
    -0.02667309f, 0.03492503f, -0.02673703f, 0.00943844f, -0.00956359f, 0.03296139f, -0.03132101f, -0.03730100f, 
    -0.01329080f, -0.00120483f, -0.02598529f, -0.02867956f, 0.00500609f, 0.00612888f, -0.01133348f, 0.02837946f, 
    -0.01506122f, -0.00324100f, 0.00623423f, 0.02842211f, -0.00332463f, -0.02532979f, -0.02842334f, 0.01012530f, 
    0.01212814f, 0.01906270f, -0.03553624f, -0.02450997f, -0.02454231f, 0.00269149f, 0.02639278f, -0.01930105f, 
    -0.01683342f, -0.03708333f, 0.00996245f, -0.04012964f, 0.01545112f, -0.00352391f, -0.01247323f, -0.01843540f, 
    0.01417002f, 0.00130980f, -0.02600810f, -0.02258453f, 0.00107395f, 0.01200260f, 0.00170573f, 0.00623432f, 
    0.00190546f, -0.02939442f, -0.03390540f, 0.01839030f, 0.02776111f, 0.00733053f, -0.00337490f, 0.01836564f, 
    -0.03657502f, 0.02014307f, 0.00636702f, -0.02915767f, -0.03448481f, -0.01834523f, -0.00331433f, -0.02786464f, 
    0.03317515f, -0.02215120f, -0.02078421f, 0.00810398f, -0.02174744f, 0.00407803f, 0.00444335f, -0.03572853f, 
    -0.00149012f, -0.02585682f, -0.02667253f, 0.01295916f, -0.02361911f, -0.03604474f, 0.01797542f, 0.02770529f, 
    0.02221348f, -0.00228792f, -0.02239964f, 0.00894465f, -0.03096178f, 0.02101816f, -0.02384805f, 0.00151816f, 
    -0.02632295f, 0.00982901f, 0.00700038f, 0.00542006f, 0.00886271f, -0.01655203f, 0.01126104f, 0.00664770f, 
    0.02480596f, -0.01700383f, -0.01092793f, 0.00175380f, -0.03257396f, 0.02741058f, -0.03601324f, 0.01373286f, 
    -0.04083005f, -0.00773204f, 0.00931373f, 0.01617728f, 0.02282560f, -0.02074883f, 0.00613289f, 0.01648924f, 
    -0.01377453f, -0.02316303f, 0.00052122f, 0.01574284f, -0.00363804f, -0.03129965f, -0.01640716f, -0.01344209f, 
    -0.00741661f, 0.01345298f, 0.00070701f, 0.00955328f, -0.03512717f, -0.02006455f, 0.01086112f, -0.03421162f, 
    -0.02572984f, 0.00008899f, 0.01038230f, -0.03247333f, -0.03544992f, 0.02461244f, -0.01163126f, -0.00857889f, 
    0.01491364f, -0.03101634f, 0.00341640f, -0.03224516f, 0.00153479f, -0.02322671f, -0.01106997f, 0.03362291f, 
    0.00341942f, -0.02789183f, -0.02723934f, -0.01920943f, -0.00279388f, 0.01737327f, -0.01639893f, -0.00744698f, 
    -0.01206982f, -0.02026539f, 0.02490200f, 0.01961501f, 0.00798647f, -0.03179098f, -0.02200867f, 0.03964239f, 
    -0.00968302f, 0.04031559f, -0.00816694f, -0.03977043f, -0.02415316f, 0.01971542f, -0.00876543f, 0.00403090f, 
    0.01832269f, -0.01207491f, 0.01311670f, -0.00788369f, 0.03179415f, 0.02911069f, 0.02576800f, 0.03331929f, 
    -0.00742326f, -0.02554893f, 0.00720447f, 0.01963874f, 0.01422651f, -0.00934087f, 0.02310213f, 0.00057713f, 
    -0.01812008f, 0.02212195f, -0.01818574f, -0.03941234f, -0.00911225f, -0.00726484f, -0.02649685f, -0.00191077f, 
    0.01641737f, -0.02917190f, -0.04232163f, -0.01401555f, 0.02268973f, -0.01886402f, -0.01157220f, 0.02119804f, 
    -0.00214773f, 0.00111899f, -0.01055645f, -0.02944285f, 0.00549381f, 0.03497040f, 0.00323485f, 0.02257111f, 
    0.01016002f, 0.02842821f, 0.03989387f, -0.00413419f, 0.02560999f, -0.01273906f, 0.00131202f, 0.00417853f, 
    -0.00249132f, 0.01955072f, -0.00554656f, -0.03085128f, -0.02049125f, 0.00019013f, -0.02216457f, -0.02643305f, 
    0.02621196f, -0.02099213f, 0.02164660f, -0.03172801f, 0.00693633f, -0.03051331f, 0.02601692f, 0.02458621f, 
    0.01755809f, -0.03985075f, -0.04072908f, 0.03988042f, 0.00986386f, 0.02007848f, 0.00788543f, -0.01476218f, 
    0.00050269f, 0.03707049f, -0.02920336f, -0.01354984f, -0.00634481f, 0.00413409f, -0.03212263f, -0.03272974f, 
    0.02556144f, -0.04124494f, 0.00351803f, 0.00576322f, -0.03337639f, 0.01589342f, 0.01598895f, -0.00003651f, 
    -0.00225821f, -0.02051027f, -0.03668037f, 0.03220616f, -0.03857069f, 0.01401082f, -0.02653748f, 0.01347917f, 
    0.00720245f, 0.02642565f, 0.02050597f, -0.00206338f, -0.01533911f, 0.01262178f, 0.00878021f, 0.02008883f, 
    0.02431324f, -0.00214587f, 0.01280711f, -0.01489984f, 0.01824655f, 0.00831693f, -0.03370271f, -0.03429392f, 
    -0.01492245f, -0.02097212f, -0.02460916f, -0.00520300f, 0.01859504f, 0.02799737f, -0.00074573f, -0.00513229f, 
    -0.03637969f, 0.02133540f, -0.02370974f, -0.00166227f, -0.00327144f, -0.02650184f, 0.01611992f, 0.01587681f, 
    0.02459803f, -0.00817325f, -0.00196737f, -0.00785377f, -0.03555682f, 0.02001957f, 0.00629097f, -0.02327931f, 
    -0.02945325f, -0.03134380f, -0.01125241f, 0.00564996f, -0.03480117f, -0.03982234f, -0.02982232f, 0.02051502f, 
    0.02981562f, -0.00864557f, -0.00853320f, 0.02068488f, 0.01239724f, -0.01742261f, 0.00863997f, 0.00039741f, 
    -0.01764599f, -0.00030795f, -0.02585323f, 0.02843366f, -0.01864793f, 0.01030355f, -0.03518384f, 0.02711035f, 
    0.01639880f, -0.00944061f, -0.01560115f, -0.00140501f, -0.02880755f, -0.00472688f, 0.02793013f, 0.02006016f, 
    0.01030451f, 0.03185464f, -0.03006616f, 0.00612123f, -0.03721386f, -0.00963825f, 0.00162301f, 0.02239791f, 
    -0.01406264f, -0.01052573f, -0.03267660f, 0.00502271f, 0.02132381f, -0.00657693f, -0.03347908f, -0.02166319f, 
    -0.00226388f, 0.03204989f, -0.00467084f, -0.02770002f, 0.02939251f, -0.01136307f, 0.01885320f, 0.03060847f, 
    -0.00514785f, -0.01290451f, 0.00312998f, 0.00810931f, -0.01528570f, -0.02172305f, 0.00670746f, 0.00624469f, 
    -0.00562853f, -0.02077528f, -0.01938312f, 0.00827833f, -0.00526248f, 0.02040204f, 0.00484456f, 0.00864737f, 
    -0.03645084f, 0.00321912f, 0.00916038f, -0.00164226f, 0.01017040f, -0.00702813f, -0.01935313f, -0.03616434f, 
    -0.02458679f, -0.03168989f, 0.01987942f, -0.01841846f, -0.02083373f, 0.01248604f, 0.02429960f, 0.00509606f, 
    -0.00424402f, -0.00512026f, 0.00832647f, -0.00242268f, -0.00458657f, -0.02350999f, -0.01231107f, -0.00703806f, 
    -0.02274930f, -0.01381654f, -0.00729715f, -0.00651852f, -0.00270011f, -0.03101815f, -0.00672001f, 0.02879668f, 
    -0.00542018f, -0.02935262f, -0.02693942f, -0.03753503f, -0.01717220f, 0.03586229f, -0.03881690f, 0.01163938f, 
    -0.01169914f, 0.01694822f, 0.01922396f, -0.02613822f, -0.00252068f, -0.03902932f, 0.03104424f, 0.01415743f, 
    0.01514455f, 0.03108969f, -0.00937331f, 0.01405308f, -0.02380404f, 0.03769431f, 0.00031856f, 0.02075732f, 
    0.01853408f, 0.01375224f, -0.03312777f, 0.01514788f, 0.04273867f, 0.02197499f, 0.02875491f, 0.01033011f, 
    -0.02621339f, 0.02529332f, -0.01275797f, 0.01645143f, -0.00666283f, 0.00443320f, 0.02688122f, 0.02451099f, 
    0.02644086f, 0.01098632f, -0.01919821f, -0.01075369f, -0.02629046f, 0.01572177f, -0.01456612f, 0.00791522f, 
    0.00349044f, 0.03025504f, 0.02050883f, -0.02572142f, 0.01726191f, -0.01646119f, 0.02991903f, -0.01346639f, 
    -0.03440921f, -0.02895432f, 0.00481413f, -0.01135014f, -0.00026537f, 0.02851000f, -0.00614230f, 0.00893096f, 
    -0.00636061f, 0.02318860f, 0.03494536f, 0.02661200f, -0.01678622f, -0.03236440f, 0.02953601f, -0.01637903f, 
    -0.02549144f, -0.00461678f, -0.00133570f, 0.03406881f, -0.00315923f, -0.02056474f, -0.00034352f, 0.00795399f, 
    -0.03220360f, -0.02311803f, 0.01030838f, 0.01605135f, -0.01813370f, -0.02872274f, 0.01053534f, -0.02840988f, 
    -0.03084609f, 0.00284552f, 0.00032627f, -0.03845745f, 0.03452210f, 0.01535140f, -0.00856982f, 0.00552499f, 
    -0.03116072f, 0.01040101f, -0.02220927f, -0.01913451f, -0.01869564f, -0.03318593f, 0.01011359f, -0.00859006f, 
    -0.01928624f, -0.01030189f, 0.00663550f, 0.00492143f, -0.02409679f, 0.00096377f, -0.02530008f, -0.02423594f, 
    -0.01533467f, 0.02317042f, 0.03490615f, 0.03088688f, 0.02000150f, -0.01812679f, -0.00952342f, 0.01539570f, 
    0.00111128f, -0.01615079f, -0.01420816f, 0.02309407f, -0.01270137f, 0.01312855f, -0.02952049f, -0.00429482f, 
    0.00011054f, -0.01166595f, 0.02539979f, -0.03113292f, 0.01709914f, 0.00594746f, -0.03315848f, 0.00200833f, 
    -0.02066876f, 0.03207058f, 0.01191239f, 0.03397515f, 0.00876044f, 0.02185623f, -0.03231917f, -0.00734556f, 
    -0.01618476f, -0.01070582f, 0.00960967f, 0.00243529f, -0.02988453f, -0.02656308f, 0.02141508f, -0.01227589f, 
    -0.03396907f, 0.03146713f, 0.01657220f, 0.01104168f, 0.02846435f, 0.01909806f, 0.00618883f, -0.03862284f, 
    0.02081809f, 0.02648353f, 0.00403387f, 0.00831594f, -0.02414224f, 0.02456636f, -0.01763528f, 0.02180210f, 
    0.02190832f, 0.02979588f, -0.00719420f, -0.00064498f, -0.01865141f, 0.03070322f, 0.00260529f, 0.00760083f, 
    -0.03358177f, 0.02309651f, -0.00611370f, 0.00910776f, 0.01764266f, -0.01051325f, -0.03310290f, -0.03571169f, 
    -0.02369628f, -0.03109540f, 0.00692220f, 0.00575584f, -0.04051705f, 0.02325662f, -0.01397601f, 0.02178758f, 
    -0.00534093f, -0.01577633f, -0.04079368f, 0.01575764f, -0.01530861f, 0.00919521f, 0.02539215f, -0.02610187f, 
    0.02802139f, 0.01950150f, -0.02949318f, -0.02122639f, 0.02786934f, -0.01379095f, 0.02386201f, 0.03068640f, 
    -0.03526988f, 0.02914376f, -0.03412096f, -0.04192784f, -0.02536975f, 0.01892328f, 0.01654352f, -0.03718777f, 
    -0.02828711f, 0.00397001f, 0.02927437f, -0.03076912f, -0.00421615f, -0.00194340f, -0.02482702f, 0.00147346f, 
    -0.03670699f, 0.02922789f, -0.01113635f, -0.02441078f, -0.04169825f, -0.00165021f, -0.02825196f, -0.00943751f, 
    -0.01324618f, -0.03923952f, 0.00413686f, -0.02175076f, -0.02035587f, 0.01423341f, -0.04071628f, 0.01369900f, 
    0.02836511f, 0.01033899f, 0.01415197f, 0.00192197f, 0.00863248f, -0.04249945f, -0.04099275f, -0.03357572f, 
    -0.00010828f, -0.00189840f, -0.01709273f, -0.00137171f, 0.02451619f, 0.00521936f, 0.00851482f, -0.03822711f, 
    -0.02617897f, -0.01652957f, -0.00996813f, 0.02456032f, -0.02134689f, 0.01198986f, -0.00695974f, -0.02859992f, 
    0.00765327f, 0.01831968f, -0.00090545f, -0.01654155f, -0.02930880f, -0.02464434f, 0.02794691f, 0.01220678f, 
    0.00293397f, 0.02534902f, -0.02514752f, 0.00809210f, -0.01046914f, 0.02185653f, -0.01483732f, 0.02031714f, 
    -0.00506810f, -0.03396625f, -0.03770367f, 0.02701322f, 0.02326312f, -0.03359691f, -0.01186591f, -0.02339856f, 
    -0.03275093f, -0.01582690f, -0.03002406f, 0.00967369f, 0.00352299f, -0.00172305f, -0.01531384f, 0.00838002f, 
    0.02728873f, 0.00949346f, -0.03777665f, -0.01476391f, -0.00471783f, -0.03758415f, 0.02411913f, 0.02730691f, 
    -0.03520836f, -0.03888976f, -0.04443143f, -0.01195186f, -0.00020246f, 0.00726181f, -0.01360230f, 0.01842701f, 
    -0.00263148f, -0.00337378f, -0.00193950f, -0.02436290f, -0.00512741f, -0.01081871f, -0.04408763f, -0.01260343f, 
    0.00250356f, 0.02165668f, -0.00709530f, 0.02264661f, -0.01643668f, -0.03288437f, -0.00659919f, 0.00616322f, 
    -0.02639840f, 0.00637029f, -0.01471098f, 0.00617957f, -0.03652577f, -0.03539228f, 0.02259097f, 0.00830216f, 
    -0.01643549f, -0.03649136f, 0.02409889f, -0.00239786f, -0.03274339f, -0.02084541f, 0.01351523f, -0.00109698f, 
    0.02375357f, -0.00007127f, 0.00988782f, -0.02973136f, -0.03782557f, 0.01141948f, 0.01511387f, -0.04223694f, 
    -0.00440962f, 0.00948540f, 0.00830749f, -0.03376788f, 0.03383569f, -0.01520226f, -0.00590904f, -0.01398846f, 
    0.01312970f, 0.00305743f, -0.02917752f, -0.00985168f, -0.04257776f, -0.03262116f, -0.00581402f, 0.00228438f, 
    -0.04225793f, 0.01820095f, -0.00987343f, 0.00531968f, -0.03188921f, -0.01676897f, 0.00497236f, 0.01409225f, 
    -0.00899447f, -0.01800936f, -0.01955360f, 0.00191031f, 0.02558266f, 0.02516141f, -0.02221141f, -0.02005902f, 
    -0.02089238f, 0.01128800f, -0.02533452f, -0.04034587f, -0.02116368f, 0.00851127f, 0.01386081f, -0.01899845f, 
    -0.01010465f, -0.00713750f, -0.01766354f, -0.02935444f, 0.00404570f, -0.04219386f, -0.03761263f, 0.01170184f, 
    0.01180528f, 0.00457979f, 0.02247945f, -0.02460931f, -0.03677811f, -0.00327867f, 0.01851447f, -0.01577989f, 
    -0.00058821f, 0.00434426f, 0.00844028f, -0.00809308f, 0.01670930f, 0.00929644f, -0.03968862f, 0.02552500f, 
    -0.00998988f, 0.00250588f, 0.02278341f, -0.00358802f, -0.03183697f, -0.02656904f, 0.00602007f, -0.03331508f, 
    0.02264639f, -0.01867665f, -0.04277848f, -0.00881337f, 0.00128973f, 0.02130046f, 0.01316181f, -0.00479668f, 
    -0.02795721f, -0.03426919f, 0.00828602f, -0.02034851f, -0.02692150f, 0.02850467f, 0.01925041f, -0.03352961f, 
    -0.01193826f, 0.01378480f, 0.01820325f, -0.04227393f, -0.00067484f, -0.01807541f, -0.02015485f, -0.00973983f, 
    0.02508818f, -0.01771541f, -0.01451771f, -0.02203367f, -0.03169244f, -0.02189722f, 0.00544867f, 0.02761754f, 
    0.02689178f, 0.00745978f, -0.00444235f, -0.00656408f, -0.02802848f, 0.01938842f, 0.02572123f, -0.01942322f, 
    0.01247805f, 0.01362302f, 0.00114718f, -0.00502006f, -0.02110817f, -0.00959596f, -0.04022914f, -0.02231542f, 
    -0.04074055f, -0.02359878f, 0.02407082f, 0.01112705f, -0.03679445f, -0.01663684f, 0.01748417f, -0.03354735f, 
    -0.03966211f, -0.03534616f, 0.01724832f, 0.00552185f, 0.01544736f, 0.01992672f, -0.00236450f, -0.03763025f, 
    -0.01971580f, 0.01336293f, -0.02428989f, 0.01825656f, -0.03267366f, -0.02224597f, -0.03026686f, -0.03254422f, 
    0.00607445f, -0.03123639f, -0.00188638f, -0.01796224f, 0.01128785f, -0.01849695f, -0.03358612f, -0.04217159f, 
    -0.03107127f, 0.00439182f, 0.00785467f, -0.01791443f, -0.01968348f, 0.01355550f, -0.02770045f, 0.02152372f, 
    0.00635398f, 0.01083299f, 0.01721166f, -0.01300844f, 0.02906333f, 0.01883168f, -0.01331264f, 0.01784761f, 
    -0.03920309f, -0.03854972f, 0.00756012f, 0.01027239f, 0.02269671f, 0.00573336f, 0.01571481f, 0.01002741f, 
    -0.03989812f, -0.02715069f, 0.02715484f, -0.02407449f, 0.00209822f, -0.02927047f, -0.00124627f, -0.00660814f, 
    -0.01317551f, -0.00850659f, 0.00977892f, 0.01729652f, -0.00930229f, 0.00469438f, 0.01927538f, -0.00808123f, 
    -0.02622767f, -0.02052579f, 0.00701863f, 0.00243729f, -0.02197863f, 0.00985312f, -0.03002505f, -0.00916018f, 
    -0.00109708f, 0.01735378f, 0.02163033f, -0.04075925f, 0.01166810f, -0.01496113f, -0.04060096f, -0.03974396f, 
    -0.01572736f, 0.01342442f, -0.02253030f, -0.03232521f, -0.03726425f, -0.02087681f, 0.00771437f, 0.01363832f, 
    0.02435967f, 0.02611176f, -0.00184793f, 0.01851698f, 0.02256556f, 0.01887041f, -0.02610115f, -0.03997180f, 
    -0.03015048f, 0.00056184f, -0.01931745f, 0.00696830f, -0.00764469f, 0.00773735f, 0.02633012f, 0.00578888f, 
    0.01999406f, 0.02175433f, -0.01358608f, -0.02316803f, 0.02775347f, -0.03693077f, -0.03627577f, 0.00739767f, 
    0.02651553f, -0.02167138f, -0.02761582f, -0.00922151f, -0.03748356f, 0.01323000f, 0.02818848f, 0.00171423f, 
    -0.04317775f, 0.01180186f, -0.02641813f, -0.00844120f, 0.01186085f, -0.02655835f, -0.00018276f, 0.00018260f, 
    -0.02675503f, 0.00470178f, -0.01196730f, 0.01400408f, -0.00508801f, 0.02290049f, -0.00261057f, -0.00744656f, 
    0.01217390f, 0.02678600f, -0.02569142f, 0.01691195f, -0.00424655f, 0.02116226f, 0.01365594f, -0.00785084f, 
    -0.03819856f, 0.01033567f, -0.01089702f, -0.00025741f, -0.00319255f, -0.01684679f, -0.02059030f, 0.00252989f, 
    0.00089583f, -0.00174946f, -0.01697958f, 0.01697474f, -0.03837801f, 0.02664414f, -0.01354362f, 0.02506481f, 
    -0.03207737f, -0.03197214f, -0.01585248f, -0.02037918f, -0.00431956f, -0.01465920f, -0.02028994f, -0.02698228f, 
    -0.03124049f, -0.01776100f, -0.02796012f, -0.00053580f, -0.00920289f, 0.00731351f, -0.00531902f, 0.02777534f, 
    -0.00339447f, -0.01087802f, -0.04040692f, -0.02850144f, -0.02091194f, -0.03849505f, -0.02681541f, 0.00481178f, 
    -0.03579189f, 0.02864312f, 0.01146891f, -0.02984676f, -0.00656224f, -0.01514203f, -0.00953287f, -0.02345353f, 
    -0.00363734f, 0.00603950f, 0.00679563f, -0.04255569f, 0.01873586f, -0.03138617f, 0.02058979f, -0.01777446f, 
    0.00458270f, 0.02636266f, 0.01496459f, -0.02408256f, -0.00481069f, -0.03798452f, -0.01953138f, -0.01578502f, 
    -0.03187120f, -0.02259798f, 0.00541556f, -0.02564787f, -0.02945576f, 0.00156137f, -0.00263060f, 0.01655418f, 
    -0.01137326f, -0.03828239f, 0.00889216f, -0.01003231f, -0.02790856f, 0.00008472f, 0.02081818f, -0.02375688f, 
    -0.00293844f, -0.03972107f, 0.01220522f, 0.01264333f, -0.02399768f, -0.02446403f, 0.00459979f, -0.00407110f, 
    -0.00289626f, -0.02778882f, -0.00188081f, 0.02475720f, -0.04168561f, -0.01548949f, -0.02139112f, -0.01716559f, 
    -0.02510637f, -0.04016353f, -0.01542121f, -0.03444180f, 0.02520430f, 0.01021423f, 0.02688457f, 0.00789284f, 
    -0.03423906f, -0.01388526f, -0.03972286f, -0.03015967f, 0.02387261f, -0.01473236f, -0.01098742f, -0.00677946f, 
    0.01925451f, -0.02592233f, -0.00999610f, -0.03554211f, -0.00240724f, -0.00587831f, 0.02016964f, -0.01976159f, 
    0.02485111f, -0.04321261f, 0.01424497f, -0.00497647f, -0.02126891f, -0.02218420f, 0.01431761f, 0.02342123f, 
    0.01279424f, -0.03707071f, 0.01541638f, -0.01483441f, 0.02715307f, 0.00733229f, -0.00804351f, -0.02575557f, 
    0.01211981f, 0.01719455f, -0.03947625f, 0.01804470f, -0.03865715f, 0.01372473f, 0.01904389f, -0.04198890f, 
    -0.03987215f, 0.01836768f, 0.01598114f, 0.00131749f, -0.00299090f, -0.02133774f, 0.01224132f, 0.01521324f, 
    0.01289594f, -0.00684130f, -0.02176866f, 0.02122369f, -0.03974583f, -0.03020218f, 0.01029136f, -0.00397426f, 
    -0.03101918f, -0.00790301f, 0.01561399f, -0.00702173f, -0.03958650f, 0.01313441f, -0.03733063f, -0.02728634f, 
    0.02626178f, -0.00930895f, -0.03662633f, -0.02092018f, -0.01008483f, 0.00032441f, 0.01909391f, 0.00852469f, 
    -0.02650688f, 0.01980990f, -0.04271952f, -0.04293783f, 0.01944050f, 0.00036383f, -0.01185048f, -0.02472743f, 
    0.01404164f, -0.01992039f, -0.01187356f, 0.02504238f, 0.01561380f, 0.01033757f, -0.02576900f, 0.00949398f, 
    0.02035294f, -0.00312633f, 0.00202726f, 0.02103153f, -0.02074426f, 0.02736314f, -0.03454379f, -0.01420859f, 
    0.00676148f, -0.02784264f, -0.00638944f, 0.01217447f, -0.01362838f, 0.02267451f, -0.00991980f, -0.03779361f, 
    0.00681671f, 0.02570174f, 0.01461675f, 0.00192978f, 0.01252135f, 0.02726384f, 0.01896626f, 0.00620867f, 
    -0.00395725f, 0.01441463f, -0.03261651f, -0.04021910f, 0.02465302f, 0.02422719f, -0.03935900f, -0.03548071f, 
    0.02641691f, -0.01318093f, -0.00975028f, -0.02515686f, -0.04357859f, -0.00870133f, -0.01809902f, -0.00132626f, 
    -0.01161569f, -0.02535110f, -0.03063069f, 0.00573499f, 0.00893631f, -0.03459175f, 0.02514678f, -0.00863679f, 
    0.02441691f, -0.01691764f, -0.03036799f, -0.04276429f, 0.01796612f, -0.02819839f, 0.02349555f, -0.02389362f, 
    -0.01091629f, -0.00584058f, 0.00501136f, 0.01456871f, 0.01553581f, 0.00034785f, -0.01919936f, -0.01569920f, 
    -0.02500509f, -0.01954265f, 0.02289920f, -0.03677763f, -0.03658409f, -0.01386519f, -0.00665069f, -0.02610699f, 
    -0.01123283f, 0.02137778f, 0.01086016f, -0.03805152f, 0.01974249f, 0.01863771f, 0.00879987f, -0.03375486f, 
    -0.00132304f, -0.04106573f, -0.00829069f, 0.01758491f, -0.00860320f, -0.02774956f, -0.01492798f, 0.02056009f, 
    0.02761778f, 0.00503928f, 0.02908920f, 0.01405777f, -0.02888793f, -0.03270211f, 0.00729216f, 0.02019252f, 
    -0.02289880f, -0.03377131f, 0.00117759f, -0.04251854f, -0.01541136f, 0.02297674f, 0.00006920f, -0.01359210f, 
    0.02542231f, 0.02287189f, 0.02358733f, -0.03091275f, 0.02544359f, -0.03824580f, -0.03788307f, -0.02619322f, 
    -0.03194689f, 0.00159003f, -0.01750411f, 0.00704045f, 0.00047570f, -0.04045986f, -0.03698847f, -0.01346869f, 
    -0.03082006f, -0.04115932f, 0.00804288f, -0.02200685f, 0.00829585f, 0.00070369f, -0.03754669f, 0.02335258f, 
    0.01767805f, -0.02619765f, -0.01975029f, 0.00542212f, 0.02646992f, 0.01007158f, -0.03278743f, 0.01181507f, 
    0.00351907f, -0.00050212f, -0.01218874f, 0.02923494f, -0.03431155f, 0.01062644f, -0.02749689f, 0.00750348f, 
    0.01471769f, -0.01102747f, -0.00773342f, -0.00683005f, 0.02253024f, -0.03397711f, 0.02287236f, 0.00989258f, 
    -0.02863574f, -0.00074720f, -0.01437351f, -0.03971813f, -0.03033525f, -0.02070093f, 0.00545711f, 0.01012553f, 
    -0.00333289f, 0.00354264f, -0.04326051f, -0.03458418f, -0.01111071f, 0.01662626f, -0.00542628f, 0.00085445f, 
    0.01164155f, -0.01648229f, -0.03447518f, -0.03433007f, -0.00097536f, 0.01532847f, 0.02936541f, 0.02427840f, 
    0.25505257f, -0.02311219f, 0.03577537f, -0.30701533f, -0.25117341f, -0.01050403f, 0.00537762f, 0.06995491f, 
    -0.00570588f, 0.09012654f, -0.11551642f, 0.03010147f, -0.08736005f, 0.24043359f, -0.14980915f, 0.01146584f, 
    0.16901916f, -0.04182709f, -0.20013018f, -0.07571068f, 0.10001981f, 0.00586603f, -0.03439118f, -0.10482160f, 
    0.01323937f, -0.05241048f, -0.01598781f, -0.07433656f, 0.11718111f, -0.05206599f, 0.11683170f, 0.00268886f, 
    -0.03492466f, -0.01004994f, -0.06318632f, 0.02658518f, -0.38540876f, -0.21069634f, -0.07476629f, -0.22826470f, 
    0.03686026f, 0.02370510f, 0.06477739f, 0.05760177f, 0.02838399f, 0.07574155f, 0.01155863f, 0.01377346f, 
    0.23459421f, 0.18783139f, 0.48022631f, 0.08629469f, 0.04904503f, 0.12548135f, 0.07558500f, 0.00276271f, 
    0.06641103f, -0.06324019f, -0.01969355f, -0.10149598f, -0.30567446f, 0.06455480f, -0.00918157f, -0.06425358f, 
    -0.00290807f, 0.14759961f, 0.28113726f, 0.17502567f, 0.05618029f, 0.06202617f, 0.14243066f, 0.06112319f, 
    -0.11477383f, -0.23570219f, -0.19405939f, 0.10059805f, -0.05706667f, -0.14538996f, -0.07014513f, -0.13041607f, 
    -0.10712869f, -0.10784959f, 0.04093171f, 0.00506347f, 0.41346484f, -0.03082249f, 0.00248746f, -0.01814742f, 
    -0.26223370f, 0.03468481f, -0.00085512f, -0.02994968f, 0.03610303f, -0.04169511f, 0.09556834f, 0.04835596f, 
    0.07679540f, -0.13220917f, -0.02030599f, -0.07087204f, -0.09408496f, -0.10442683f, -0.04048099f, -0.01308466f, 
    -0.08463691f, 0.00176467f, 0.22565053f, 0.05303013f, 0.10522211f, 0.11819056f, 0.07670551f, 0.12710516f, 
    -0.06256194f, -0.04296806f, -0.02501676f, -0.05002635f, 0.01281083f, 0.04134659f, 0.01926457f, 0.06835330f, 
    -0.29674485f, 0.07147381f, 0.00856716f, 0.12046470f, 0.07744870f, 0.01408340f, -0.02704733f, -0.00330413f, 
    -0.05488260f, -0.07729682f, 0.01723336f, 0.07529107f, 0.03366582f, 0.36967096f, 0.09925617f, -0.08055102f, 
    -0.00848272f, 0.00292697f, -0.06857058f, 0.01149894f, -0.23197432f, 0.03112249f, 0.05584602f, -0.06430832f, 
    -0.05079122f, -0.21371178f, -0.05869311f, -0.07205417f, 0.04698712f, -0.01558428f, 0.26779100f, 0.06128288f, 
    -0.00983237f, -0.14774482f, -0.02819826f, 0.03114299f, 0.16276093f, 0.40726605f, 0.22930719f, 0.06566563f, 
    0.20596148f, 0.06342673f, 0.00782552f, -0.19317523f, 0.01099802f, -0.00396482f, -0.01621405f, -0.05787430f, 
    -0.03388771f, 0.11566101f, 0.01093688f, 0.05610235f, -0.04898631f, 0.04314977f, 0.06469873f, 0.05067277f, 
    -0.10310470f, -0.02779133f, -0.01341837f, 0.01051809f, -0.27101073f, 0.12785506f, -0.17462778f, -0.36575553f, 
    -0.14366110f, -0.21185359f, -0.15489733f, 0.05619558f, -0.07374275f, -0.05679341f, -0.06017452f, -0.06197364f, 
    0.05998285f, 0.00405130f, 0.13260210f, -0.20543435f, 0.02216110f, 0.20334844f, 0.13684852f, 0.13132311f, 
    0.06567951f, 0.10407322f, -0.13152991f, -0.07240936f, 0.14328432f, 0.06508567f, -0.08275396f, 0.04315764f, 
    0.07871934f, 0.05991790f, -0.01832516f, -0.06985290f, 0.24364012f, 0.11434695f, -0.04810528f, 0.13071397f, 
    0.02389740f, -0.05147392f, 0.12817475f, 0.28045940f, -0.04564310f, -0.07009795f, -0.02910997f, -0.08722480f, 
    0.11412968f, -0.00083214f, 0.08978455f, -0.29479650f, -0.00856887f, 0.10321987f, 0.29577169f, -0.05064358f, 
    0.07041252f, 0.07925656f, 0.07182732f, 0.00598257f, -0.04385233f, 0.08171336f, -0.16323715f, -0.21182293f, 
    0.03360873f, 0.32653490f, 0.13337085f, -0.06625443f, 0.00817332f, 0.03720570f, -0.04019344f, -0.30679223f, 
    0.00183787f, 0.00115708f, -0.01565712f, 0.01960045f, 0.43752828f, 0.14700709f, 0.32701755f, 0.06399446f, 
    -0.07096451f, 0.02226269f, 0.00201038f, 0.09927577f, 0.04738068f, 0.02374082f, 0.01118765f, 0.10382698f, 
    -0.22959487f, 0.28249654f, -0.13547809f, -0.25517714f, -0.05893527f, -0.07641586f, 0.05161246f, 0.08976430f, 
    0.00353033f, 0.08792718f, -0.05241375f, 0.00957163f, -0.11239265f, 0.04357642f, 0.06266690f, -0.03819720f, 
    0.09771536f, -0.00307157f, -0.06637499f, -0.00093566f, 0.10129628f, -0.12957896f, -0.10285262f, 0.02418519f, 
    -0.28447455f, -0.03160179f, -0.49970374f, 0.14935629f, -0.02808206f, 0.08386441f, 0.27332976f, 0.05135265f, 
    0.12078074f, -0.13784523f, 0.11753301f, 0.03437202f, 0.37911281f, 0.18343084f, -0.05540575f, 0.37488604f, 
    -0.13480923f, -0.09915407f, -0.03201688f, -0.07038861f, 0.08406298f, -0.07392138f, 0.03521628f, -0.03057087f, 
    0.08811417f, -0.23350272f, 0.02451807f, -0.16266786f, 0.12253579f, 0.00761238f, 0.13609000f, 0.20260248f, 
    0.05912013f, 0.00752333f, 0.17806765f, -0.01200244f, -0.09040377f, -0.40581477f, -0.13841128f, 0.16943955f, 
    0.08263632f, 0.13403243f, 0.21926481f, 0.22871661f, 0.01701029f, 0.22567423f, 0.01005920f, 0.03699008f, 
    -0.06230851f, 0.02155674f, 0.04858881f, 0.01543875f, -0.04012788f, -0.04637148f, -0.08550739f, -0.06898939f, 
    0.19593589f, 0.07393624f, 0.00207398f, -0.02499713f, -0.08956796f, -0.10246945f, 0.00167247f, 0.15505110f, 
    0.04738969f, 0.08406056f, -0.07719504f, 0.01559303f, 0.14293620f, 0.09539206f, 0.19123316f, 0.12625664f, 
    0.04683460f, 0.00075331f, 0.05332413f, 0.07211755f, -0.05358440f, -0.06378054f, -0.02190249f, -0.01313051f, 
    -0.03428474f, 0.06067158f, 0.16664910f, 0.09221874f, -0.26592004f, -0.27078211f, 0.12659954f, -0.10606458f, 
    -0.05366896f, 0.10266893f, 0.06788878f, -0.00177265f, 0.11302583f, 0.04595185f, -0.03653183f, -0.00550629f, 
    0.03009493f, 0.09930284f, 0.20588495f, 0.06259580f, 0.18603083f, 0.09777212f, -0.04731560f, 0.10211681f, 
    -0.11698298f, -0.07833915f, 0.12253614f, -0.12225889f, -0.38959143f, 0.19130339f, -0.15808444f, -0.26781282f, 
    -0.03026887f, -0.06317081f, -0.04066336f, -0.08677351f, -0.13085097f, 0.06357116f, 0.05367932f, 0.01717847f, 
    0.01464002f, -0.03116897f, 0.06341124f, 0.06021652f, 0.07217813f, 0.03249555f, 0.14869572f, 0.04791191f, 
    0.09093232f, -0.08503111f, 0.05724271f, 0.01546635f, -0.27764314f, -0.20209564f, -0.12574551f, 0.09067483f, 
    0.11577664f, -0.10312927f, -0.14106815f, -0.10904734f, 0.02425504f, 0.05753948f, -0.14640228f, 0.02085997f, 
    0.19688134f, 0.19163378f, 0.02043851f, 0.11979160f, -0.09107988f, -0.05156638f, -0.04506922f, -0.03186136f, 
    -0.05331793f, 0.06808112f, -0.03938837f, 0.00770897f, 0.34261215f, 0.27317330f, 0.46873122f, -0.42470837f, 
    0.14094877f, 0.02868496f, -0.26381099f, 0.14755799f, -0.07805087f, -0.03620403f, -0.08549324f, -0.08088858f, 
    -0.21208613f, -0.00880017f, 0.11837436f, -0.07998715f, -0.33657831f, -0.12358384f, -0.19610371f, -0.07399965f, 
    -0.14327399f, -0.03679750f, 0.03159436f, 0.05828923f, 0.03575600f, 0.03989372f, 0.01958034f, 0.20670830f, 
    -0.04848275f, 0.03581499f, -0.05026101f, -0.03743744f, 0.07705974f, 0.03869524f, 0.04009541f, -0.02200345f, 
    -0.20072778f, -0.02439452f, -0.09866551f, 0.47393709f, 0.10192985f, 0.06266561f, 0.25769171f, 0.10025933f, 
    0.08568561f, -0.15812004f, 0.11075501f, 0.05527248f, -0.22983834f, -0.48964822f, -0.30089438f, 0.37592301f, 
    -0.02401066f, -0.01722212f, 0.01063010f, 0.04962028f, -0.05114494f, 0.13875315f, -0.02452518f, 0.10212212f, 
    -0.08425001f, -0.05529540f, 0.45226389f, -0.09807633f, 0.25126684f, 0.06293843f, -0.02723918f, 0.09056788f, 
    -0.09786961f, 0.00129433f, -0.05036644f, 0.11171751f, 0.01139032f, -0.00711186f, 0.06979646f, 0.01680915f, 
    -0.12097293f, 0.05452064f, -0.03684136f, -0.03581929f, 0.00541158f, 0.17034200f, 0.09764586f, 0.07269208f, 
    0.19353332f, -0.03380700f, -0.04303808f, -0.17055500f, -0.18310092f, 0.08272124f, -0.02637604f, -0.13740323f, 
    -0.13130143f, 0.03097317f, 0.03955032f, 0.05331810f, 0.22923186f, -0.13544302f, 0.15911305f, -0.08035818f, 
    0.08334828f, 0.00322478f, -0.09988859f, -0.02179366f, 0.10538860f, 0.01492242f, -0.02800376f, -0.03806340f, 
    -0.04303968f, 0.04535560f, 0.06876849f, 0.05107564f, -0.03616759f, -0.12582792f, 0.02003293f, -0.01564715f, 
    0.01113957f, -0.01794085f, 0.01901324f, -0.00633932f, -0.09849121f, -0.11773323f, -0.20691225f, -0.03938766f, 
    0.01412384f, -0.00004496f, -0.05136612f, -0.08140565f, -0.02834303f, 0.05729980f, -0.00389281f, -0.09343704f, 
    0.02455042f, -0.06250238f, -0.17098430f, -0.08772285f, -0.11080011f, 0.21545619f, -0.10206352f, 0.11051367f, 
    0.08673019f, -0.01270446f, -0.05280186f, -0.00173699f, -0.01954417f, 0.08844749f, 0.10646633f, 0.02523024f, 
    -0.01902732f, 0.12167719f, -0.03853231f, -0.03056281f, 0.14506826f, 0.04666686f, -0.02563627f, 0.02390384f, 
    -0.17126216f, -0.26735333f, -0.18904372f, -0.09043645f, 0.12291993f, 0.30503333f, -0.13794260f, 0.19259934f, 
    -0.06333057f, 0.06566928f, -0.17279088f, -0.00468765f, 0.05777586f, 0.03747565f, -0.13997196f, -0.17149556f, 
    0.06357805f, 0.13487078f, -0.00307132f, 0.23049589f, 0.11713423f, -0.02844128f, 0.00839352f, 0.06611687f, 
    -0.07140177f, 0.03424868f, 0.03341283f, 0.02344997f, 0.04226175f, -0.03392890f, -0.06481070f, -0.07292154f, 
    0.00273464f, 0.02524859f, -0.08945888f, -0.06664888f, -0.08829700f, 0.03512669f, -0.02323183f, -0.11267024f, 
    -0.06155683f, -0.14516836f, -0.10769424f, -0.05924487f, -0.24774978f, -0.12571160f, -0.30500439f, -0.20120867f, 
    -0.21589796f, -0.10519738f, -0.06701002f, -0.00810353f, -0.04159199f, -0.14513992f, -0.11096840f, -0.03609854f, 
    -0.00660994f, 0.06616270f, 0.00154691f, 0.07148676f, -0.11576263f, 0.09372588f, -0.40533572f, 0.01998514f, 
    0.01561247f, -0.04598993f, 0.00568315f, -0.06188097f, 0.10033789f, -0.05850473f, -0.05056969f, 0.11062959f, 
    0.08078820f, 0.13481972f, -0.09249953f, 0.36175337f, 0.14748575f, 0.11645145f, 0.06274460f, 0.05599407f, 
    -0.09507900f, -0.06460103f, 0.16945675f, -0.02518442f, 0.08978690f, 0.02717713f, -0.14343645f, 0.17203540f, 
    0.16837177f, -0.07902519f, 0.04101270f, 0.10838699f, 0.20770299f, 0.07461654f, 0.19902632f, 0.15297675f, 
    -0.17114466f, 0.11767492f, -0.08957718f, 0.09061489f, 0.30432379f, -0.10143847f, 0.08870662f, -0.02787103f, 
    0.08898064f, 0.09407885f, 0.16340050f, 0.11821290f, -0.23581527f, 0.01168307f, -0.31950194f, 0.00392411f, 
    0.02789398f, 0.00090514f, 0.03979880f, 0.19170253f, 0.13022497f, 0.03036369f, 0.06136930f, 0.15594612f, 
    0.02066154f, 0.11703198f, 0.11195446f, 0.18832755f, -0.04626033f, 0.11230539f, -0.05583737f, 0.01950533f, 
    -0.00491201f, 0.08476449f, -0.02218989f, 0.14581993f, -0.02463566f, 0.00331946f, 0.17141466f, 0.30397555f, 
    0.13964725f, -0.10861978f, 0.01147648f, 0.10855343f, 0.05318195f, -0.08703084f, 0.08065753f, -0.03085587f, 
    -0.19603932f, -0.05268946f, -0.06636818f, 0.12846491f, -0.01832473f, 0.00251552f, -0.04255763f, 0.01415933f, 
    -0.01476122f, 0.01231985f, -0.22351374f, -0.04856033f, 0.05927337f, 0.18363310f, 0.01809683f, 0.03645210f, 
    -0.05169671f, -0.06488942f, -0.06607851f, 0.04920033f, 0.01199196f, -0.01749369f, -0.04069921f, -0.02915256f, 
    -0.25628176f, 0.37411788f, -0.12984806f, 0.05873005f, 0.25520170f, -0.06239993f, -0.05369435f, 0.03214571f, 
    -0.00422751f, 0.07201888f, 0.16251516f, 0.10874496f, 0.00786358f, -0.16154973f, -0.14169945f, 0.00304704f, 
    -0.06386515f, -0.03714759f, 0.04171214f, -0.12405527f, 0.11586542f, 0.05303896f, 0.05943790f, 0.18005918f, 
    -0.10075765f, 0.09410299f, -0.30102095f, 0.17701778f, 0.20536871f, -0.03047147f, -0.10000517f, -0.05333117f, 
    -0.23191772f, -0.16396296f, -0.47904223f, -0.39060655f, -0.09694432f, 0.00389702f, 0.15040618f, 0.31805313f, 
    -0.04289750f, 0.09365252f, 0.02063233f, -0.00701009f, 0.02435124f, -0.02565355f, -0.12357976f, -0.00600731f, 
    -0.07708675f, -0.07192751f, 0.09423520f, 0.26258695f, -0.03748988f, -0.09072329f, 0.03831976f, 0.05927792f, 
    -0.06052679f, 0.04250169f, 0.01405180f, 0.10438970f, 0.28294766f, 0.09070326f, 0.19702220f, 0.10726748f, 
    0.04452336f, 0.05428606f, -0.10583915f, 0.05199570f, -0.21393186f, -0.08632860f, -0.00597014f, 0.03364829f, 
    0.18898362f, -0.25517657f, -0.02892328f, 0.03590594f, -0.06823328f, 0.11040655f, 0.01849163f, 0.09027497f, 
    0.00809485f, 0.16296802f, 0.08779929f, 0.12616615f, -0.09924857f, -0.17194743f, 0.19018528f, -0.41716695f, 
    0.13770336f, 0.00397413f, 0.07522266f, -0.05933996f, -0.06433200f, 0.18639919f, -0.01763821f, 0.01387776f, 
    -0.35104960f, 0.05237480f, -0.11434369f, -0.10847621f, -0.12265306f, 0.06551709f, 0.16575411f, -0.18039821f, 
    0.01719773f, 0.00612127f, -0.14645059f, 0.20127983f, 0.10070547f, -0.05153850f, -0.18006513f, 0.02193841f, 
    0.02916664f, -0.02007549f, 0.06635322f, 0.11329912f, -0.09753528f, 0.03390049f, -0.04506727f, 0.08981876f, 
    0.07195996f, -0.05524791f, 0.00986840f, 0.04942893f, -0.09048472f, 0.08175962f, -0.10030117f, -0.03675803f, 
    -0.05953154f, -0.17721897f, -0.00895766f, -0.22641250f, -0.18356173f, 0.15277514f, -0.02623627f, 0.12611930f, 
    -0.00085765f, -0.01919239f, -0.06658875f, -0.17227140f, 0.15153667f, -0.03857999f, 0.09897866f, 0.26640260f, 
    0.11573243f, 0.09831813f, -0.14390948f, 0.02587923f, 0.12826891f, 0.02622039f, -0.13178785f, -0.02895851f, 
    -0.18083337f, -0.19328792f, -0.35130352f, -0.29635710f, -0.07263689f, -0.09711028f, 0.05996069f, 0.18347864f, 
    -0.09019790f, -0.02421165f, 0.05738528f, 0.10408561f, 0.02544694f, -0.07131743f, 0.02670864f, 0.18418820f, 
    -0.05175905f, -0.05160484f, 0.15985794f, 0.05308126f, -0.01637921f, 0.09900606f, 0.07462390f, 0.20918860f, 
    -0.11285049f, -0.13911791f, -0.06609480f, -0.02333077f, 0.42758739f, 0.29272357f, 0.46366706f, 0.33252054f, 
    0.16385327f, -0.03801572f, 0.08686098f, 0.26967108f, 0.06329060f, 0.00148874f, -0.01167924f, -0.07512040f, 
    -0.02759396f, 0.05308380f, 0.04409621f, 0.14404352f, -0.01510118f, -0.12674907f, 0.04910454f, -0.05361603f, 
    0.08661252f, 0.04954617f, -0.02347448f, 0.11220844f, 0.06339072f, 0.03362408f, -0.20080748f, 0.14200255f, 
    -0.07632124f, 0.14704928f, -0.01570890f, 0.01717434f, -0.13692103f, 0.13985364f, -0.15410762f, -0.28210467f, 
    0.15289883f, -0.12647492f, -0.27867091f, -0.04395606f, -0.07067315f, -0.12013645f, 0.16652124f, 0.04666924f, 
    -0.09230809f, 0.11511263f, -0.04701451f, 0.20467938f, 0.02891349f, 0.07841655f, 0.11507941f, 0.23137648f, 
    -0.05263194f, -0.06463819f, 0.07825178f, 0.11704318f, 0.07586768f, -0.05808945f, 0.06457332f, 0.21624815f, 
    0.00193366f, -0.03572757f, -0.11234409f, -0.01559107f, 0.02064381f, 0.02727251f, 0.01832404f, 0.10747635f, 
    0.08420105f, 0.12033530f, 0.12485579f, 0.13114889f, -0.17139751f, -0.13537416f, 0.18543600f, -0.18626037f, 
    0.00053096f, 0.07264098f, 0.00576370f, -0.00564182f, 0.05794225f, -0.01515143f, 0.05775980f, 0.10928905f, 
    0.21019156f, 0.22825366f, -0.13803537f, 0.11397842f, -0.00424306f, 0.07099275f, -0.07427114f, -0.12820385f, 
    0.03972583f, -0.17514873f, -0.08731372f, 0.04020017f, 0.10917901f, -0.05863740f, -0.15656807f, 0.08429530f, 
    0.09601676f, 0.00109035f, -0.12381123f, -0.12749992f, 0.15717603f, -0.03433434f, 0.16691428f, 0.21669419f, 
    -0.05006341f, -0.37110037f, 0.16104627f, -0.42639834f, 0.04625233f, 0.05352899f, -0.11945806f, 0.14505075f, 
    0.22257754f, -0.01332544f, 0.15073851f, -0.08696910f, 0.23903303f, -0.27326992f, 0.36099824f, -0.35949031f, 
    -0.07644104f, 0.24882728f, 0.10242478f, -0.10504226f, -0.18873397f, 0.13117604f, -0.21374334f, -0.22217888f, 
    -0.00038938f, 0.23282443f, -0.19594932f, 0.26007444f, 0.11241322f, 0.12030043f, -0.07360073f, -0.05175459f, 
    -0.26153052f, -0.50016159f, -0.00471683f, -0.32808426f, 0.14403935f, 0.10774823f, 0.12809533f, -0.02908803f, 
    0.03361219f, -0.03506050f, -0.09377938f, 0.07499795f, 0.08907513f, 0.03201404f, -0.23207547f, -0.00550830f, 
    -0.21841380f, -0.26614210f, -0.03884492f, 0.09446687f, -0.01513605f, 0.01943593f, 0.00735299f, 0.00683629f, 
    0.06029429f, 0.18689395f, 0.14798489f, 0.29312998f, 0.25021654f, 0.14091511f, -0.33734244f, -0.43540660f, 
    0.02087915f, -0.14078802f, -0.16177274f, -0.04627046f, -0.06315701f, 0.01965030f, -0.18506862f, -0.27032042f, 
    -0.10390658f, -0.25878122f, -0.08801075f, 0.00161911f, -0.05472589f, 0.01851200f, 0.06951566f, 0.26245663f, 
    0.24660681f, -0.03658201f, 0.07631270f, 0.15629591f, -0.18268564f, -0.05108855f, 0.08755781f, 0.21795592f, 
    -0.09119359f, 0.08513568f, 0.01449602f, -0.02243317f, 0.02358600f, 0.16713208f, -0.12388205f, 0.17575300f, 
    0.18523660f, 0.02657499f, -0.03787930f, 0.15129673f, 0.12592801f, -0.09644164f, -0.00072274f, 0.00442874f, 
    -0.00549814f, 0.19092846f, 0.01778983f, 0.15953095f, 0.29132101f, 0.21390618f, 0.00167740f, 0.21685250f, 
    0.00185450f, -0.03587907f, -0.05125995f, -0.08724087f, 0.08950844f, -0.26913068f, 0.04813686f, 0.12953553f, 
    -0.33675203f, -0.05451922f, 0.08157931f, -0.21254094f, -0.11846877f, 0.08603545f, 0.05311777f, -0.06880724f, 
    0.11740705f, -0.14631259f, 0.06691990f, 0.13052230f, 0.23486601f, -0.24894124f, -0.04593974f, 0.14062123f, 
    0.07338329f, 0.04056645f, 0.19859308f, 0.05002214f, 0.00859517f, 0.18626022f, 0.10136525f, 0.25781175f, 
    -0.02398009f, 0.14734396f, 0.07783652f, -0.05225570f, 0.15646473f, -0.20613007f, -0.13069455f, 0.13748838f, 
    -0.22428936f, -0.11672295f, -0.06946678f, -0.14492856f, -0.18851721f, 0.38281310f, 0.08591333f, 0.39327687f, 
    0.12846057f, 0.12142877f, -0.02081554f, -0.01221029f, -0.00192921f, -0.11460584f, 0.07802033f, -0.23158269f, 
    0.11416459f, 0.17135844f, 0.26619899f, 0.23663872f, 0.15576686f, 0.11374629f, 0.04991613f, 0.19443096f, 
    0.11868700f, -0.02566048f, 0.12172149f, -0.05039986f, -0.19262086f, -0.33408764f, -0.03508488f, -0.13662666f, 
    -0.09161659f, 0.07139891f, -0.17950168f, -0.15352143f, -0.18490845f, -0.17951775f, -0.14103730f, -0.17416716f, 
    0.07762633f, -0.15408020f, 0.18333213f, -0.01735323f, -0.08348029f, 0.09222154f, -0.00591674f, -0.04316187f, 
    -0.02352579f, -0.03187854f, 0.12933491f, 0.13414125f, 0.40400547f, 0.22958449f, -0.23035517f, -0.06968835f, 
    -0.06168948f, -0.15075389f, -0.32076535f, 0.04358640f, -0.08083651f, 0.02848713f, 0.02073903f, -0.13414247f, 
    0.07665205f, 0.47562668f, 0.10123178f, 0.23230876f, 0.08710328f, -0.02459140f, -0.08576230f, -0.05015780f, 
    0.11481821f, -0.05641760f, 0.09136751f, -0.02942067f, -0.17611656f, -0.13001150f, -0.06456202f, -0.20924065f, 
    -0.06635556f, -0.15373015f, 0.12128888f, -0.03530346f, 0.05014182f, 0.08637030f, 0.07438144f, 0.17399211f, 
    0.04169171f, 0.09732654f, 0.21858482f, 0.04557521f, 0.15509114f, -0.01359573f, -0.00737627f, 0.15410632f, 
    -0.17720120f, -0.44286001f, -0.21022977f, -0.43485865f, -0.17803973f, 0.44779345f, -0.11227405f, 0.16928971f, 
    0.26073122f, 0.11420519f, -0.06711822f, 0.18944460f, -0.18173276f, -0.00842892f, 0.09783803f, -0.23422368f, 
    0.00874581f, -0.00020367f, 0.12439948f, 0.08632352f, 0.04052788f, -0.02364800f, 0.00135340f, 0.18441285f, 
    0.15873632f, 0.00038441f, 0.03538979f, 0.16018987f, 0.52196938f, -0.03630464f, 0.05956772f, 0.12611565f, 
    -0.12864923f, 0.04281055f, 0.08118870f, -0.02721244f, 0.04236889f, 0.01465649f, -0.03099019f, 0.14250498f, 
    0.17715575f, 0.17815524f, 0.10398902f, 0.13164151f, 0.06139380f, -0.05425479f, 0.11385904f, 0.05989294f, 
    -0.10365123f, 0.06467900f, -0.00507927f, 0.18389896f, -0.05997416f, -0.07609318f, -0.25231487f, -0.14817747f, 
    -0.00267989f, -0.06914967f, -0.04378018f, -0.04301478f, -0.09487300f, -0.01676871f, -0.17534091f, -0.02517566f, 
    0.26725119f, 0.25088018f, 0.04141655f, 0.17839718f, -0.08277965f, -0.09451878f, 0.13882132f, 0.03340851f, 
    0.11987401f, 0.02409298f, -0.04370865f, -0.01755558f, -0.05913389f, 0.01835939f, 0.07664214f, 0.05750650f, 
    -0.13067779f, 0.10038948f, 0.10869005f, -0.02145995f, -0.11774387f, 0.08117814f, -0.17800066f, -0.11888448f, 
    -0.05072840f, 0.14443865f, -0.16245602f, -0.17231168f, 0.20547393f, -0.14465658f, -0.19367552f, -0.02475804f, 
    -0.24487010f, -0.30193800f, -0.22995830f, -0.40044916f, 0.20757355f, -0.05098448f, 0.08567106f, 0.28245142f, 
    0.06293719f, 0.02553590f, -0.01912448f, -0.08680947f, 0.11559734f, 0.16457263f, 0.32018039f, 0.43400115f, 
    0.12158192f, 0.06120426f, 0.07152758f, 0.15809463f, 0.05790782f, -0.04848900f, 0.09322390f, 0.02791473f, 
    0.05447322f, -0.04415983f, 0.08695571f, 0.02594219f, 0.38178515f, 0.19919644f, -0.10671207f, -0.17642680f, 
    0.02710779f, 0.01620876f, -0.01421030f, -0.01948571f, -0.05419413f, 0.01195564f, -0.09521605f, -0.18911189f, 
    0.06827544f, 0.11282432f, -0.00852725f, 0.13083692f, -0.05440384f, -0.10541645f, 0.00997958f, -0.06946992f, 
    0.05111822f, -0.10133766f, -0.01105694f, -0.02299501f, -0.06434922f, -0.13457754f, -0.00535536f, -0.21092460f, 
    -0.08734409f, -0.11978304f, -0.02421426f, -0.07467962f, -0.21407248f, 0.04924687f, -0.10936456f, -0.37430802f, 
    0.03233620f, -0.15726838f, 0.13948430f, 0.06662482f, -0.12382510f, 0.12240530f, -0.08634839f, -0.16649479f, 
    -0.10593545f, -0.14662267f, 0.02668222f, -0.03039976f, 0.09606338f, 0.03744205f, 0.21599914f, 0.14438932f, 
    0.02157038f, 0.05075756f, -0.02532621f, 0.03195047f, -0.01710848f, 0.00888774f, -0.00515773f, 0.06981912f, 
    -0.27560472f, 0.01321018f, -0.01970351f, -0.15101703f, 0.00800404f, -0.13820255f, -0.06811330f, -0.10959908f, 
    0.07275482f, -0.13880379f, -0.02818818f, 0.28224784f, -0.00840327f, -0.10757390f, 0.22508080f, 0.11727088f, 
    -0.11347131f, 0.02817758f, -0.02256759f, 0.14663886f, 0.08913804f, -0.03646088f, 0.07063001f, 0.00070612f, 
    0.08008018f, -0.14085342f, 0.13581280f, 0.14873640f, -0.03363051f, -0.03642654f, -0.04054069f, -0.10973421f, 
    0.22008719f, -0.00108116f, 0.21268845f, 0.27379110f, -0.10068577f, 0.04628335f, 0.22583236f, 0.19104621f, 
    0.14312024f, -0.19716084f, -0.16925479f, 0.06193671f, 0.06503895f, -0.00079308f, -0.10894717f, -0.03158568f, 
    0.40351385f, -0.14426126f, 0.16277467f, -0.07240968f, -0.02319895f, -0.08628921f, 0.04055873f, 0.11304305f, 
    0.08680888f, -0.04113282f, -0.02233564f, -0.07832851f, -0.12360506f, -0.01776505f, 0.02911638f, 0.18645416f, 
    0.18725017f, 0.03807304f, -0.03361298f, -0.05359794f, 0.05543232f, -0.02791136f, -0.11655118f, 0.10328249f, 
    -0.07416528f, -0.02684645f, -0.11744739f, -0.04295612f, 0.31124547f, 0.01657635f, 0.09133773f, 0.00894786f, 
    0.03209884f, -0.00183963f, -0.03123626f, 0.04342365f, 0.17606623f, 0.21682315f, -0.11052109f, -0.19543706f, 
    0.12505120f, -0.04612780f, 0.01682242f, 0.36244285f, 0.05908498f, -0.07459383f, 0.18866314f, -0.02614303f, 
    -0.12155436f, -0.06854963f, 0.07130760f, -0.14186648f, 0.17007551f, -0.00988735f, 0.10166448f, 0.19670591f, 
    0.11255836f, -0.06293739f, 0.03025288f, -0.05997901f, -0.12014287f, -0.09887356f, -0.17546673f, 0.01950391f, 
    0.17915027f, 0.00436975f, 0.21792620f, 0.09847631f, -0.01820194f, 0.18678451f, 0.01298347f, 0.04604855f, 
    0.10177343f, 0.00907957f, 0.12521866f, -0.01894756f, -0.04448349f, -0.04294985f, -0.02719861f, -0.02029373f, 
    -0.03949061f, -0.07369990f, -0.06055899f, 0.00160312f, 0.11086208f, 0.00741545f, 0.07135101f, 0.08320083f, 
    0.08135466f, -0.13679639f, 0.14096738f, -0.09891560f, 0.21830191f, 0.02701174f, -0.12393624f, 0.11274682f, 
    0.23226319f, -0.07461359f, 0.13486478f, -0.01716693f, -0.04283591f, 0.03791586f, -0.08366632f, -0.11547716f, 
    0.02210793f, -0.04075200f, 0.25134417f, -0.24709432f, -0.01594866f, -0.02037586f, 0.13761342f, -0.00069254f, 
    -0.05957078f, -0.08859993f, -0.08169676f, -0.07278419f, 0.03065384f, 0.02963791f, -0.15791252f, 0.03013581f, 
    -0.06519201f, 0.01417622f, 0.11988177f, -0.08728442f, 0.10229123f, -0.17642955f, 0.03522709f, 0.25439239f, 
    0.03293952f, 0.11905509f, 0.01318554f, 0.15260285f, -0.02132426f, -0.17432126f, 0.02209583f, -0.02572481f, 
    -0.10561369f, 0.09847320f, -0.20631872f, 0.18151602f, -0.04926672f, -0.08301716f, 0.13833141f, -0.08506303f, 
    -0.17233621f, -0.00371502f, -0.10273433f, -0.05788399f, -0.07976381f, 0.01476617f, -0.03355072f, -0.02104961f, 
    -0.00370875f, -0.07443973f, 0.13988073f, -0.00975103f, -0.15732995f, -0.02845630f, -0.00961710f, 0.04635744f, 
    0.10769643f, -0.02513889f, 0.04682832f, 0.02940151f, 0.04036212f, 0.05726493f, -0.09074165f, -0.08782063f, 
    -0.27807897f, -0.02605363f, 0.01106728f, 0.11235058f, 0.03354511f, -0.04706580f, 0.04998484f, -0.05774826f, 
    -0.00838251f, 0.04595478f, 0.02615788f, 0.01102411f, -0.29804462f, -0.30595255f, -0.32406455f, -0.03058601f, 
    0.16844954f, 0.18447503f, -0.12611136f, -0.14053918f, -0.02901420f, 0.06152315f, -0.01860377f, 0.01189281f, 
    -0.09299012f, -0.11128590f, 0.11920334f, -0.05145270f, 0.07218741f, 0.18675810f, -0.11517635f, 0.13967487f, 
    0.12660767f, -0.08978461f, 0.13142781f, -0.01866415f, -0.11293292f, -0.00990372f, -0.04156372f, -0.03317825f, 
    0.36508062f, -0.02629158f, -0.01791915f, -0.05094669f, 0.13653129f, -0.06640598f, -0.03463231f, 0.12099494f, 
    0.13822745f, 0.08171927f, 0.28278160f, 0.23634149f, -0.03491315f, -0.01727073f, -0.09023830f, 0.01785003f, 
    0.00617511f, 0.11896925f, 0.07584805f, -0.19040100f, -0.16845711f, 0.01802706f, 0.03197059f, -0.04356160f, 
    -0.01740104f, 0.09833849f, -0.01216878f, -0.06447913f, 0.04525319f, 0.00961915f, 0.11048701f, -0.06775955f, 
    -0.10658284f, -0.06575932f, 0.07070314f, 0.34283403f, -0.10791475f, -0.04673401f, 0.06408074f, 0.12292016f, 
    -0.07996354f, 0.02644568f, -0.05531226f, 0.06107511f, 0.24851856f, 0.17274946f, 0.34721088f, -0.08672263f, 
    0.09827640f, -0.16326275f, 0.18616721f, 0.08483687f, 0.20392434f, -0.04963399f, 0.09999548f, -0.05443804f, 
    -0.17327152f, 0.00885842f, 0.10952977f, -0.06328674f, -0.05195682f, -0.09965954f, -0.14760749f, 0.13298655f, 
    0.15896492f, 0.21428365f, 0.20937254f, 0.00184614f, 0.12678240f, 0.13963246f, -0.24953020f, 0.03753366f, 
    -0.03195009f, 0.01065210f, 0.09708311f, 0.05605244f, 0.16596584f, 0.27303222f, 0.05284772f, 0.12764871f, 
    -0.12985122f, 0.06537271f, -0.27773711f, -0.13970347f, 0.03270571f, 0.03527989f, -0.03859570f, 0.07539593f, 
    0.04234103f, 0.12215868f, 0.09856790f, 0.27759048f, 0.24797651f, 0.16743712f, -0.17951664f, -0.18366612f, 
    0.09441394f, -0.13166504f, 0.12297145f, -0.10035247f, 0.12607640f, 0.01080936f, 0.07724249f, 0.08066203f, 
    -0.11538316f, -0.05182969f, -0.08395502f, -0.18172938f, -0.01279775f, -0.02655303f, 0.05862742f, 0.15880780f, 
    0.02054972f, -0.02288713f, 0.05254858f, 0.08324615f, -0.16818696f, 0.02950702f, -0.16157553f, 0.11725442f, 
    0.00186672f, 0.03290771f, 0.18097943f, -0.04623648f, -0.10400725f, 0.09186246f, 0.07124797f, 0.06614592f, 
    -0.01698381f, -0.03976342f, -0.03982114f, 0.01381976f, -0.00089487f, 0.01828946f, 0.01786616f, -0.04951875f, 
    0.16628905f, -0.02663106f, -0.02052980f, -0.01976471f, 0.02093894f, -0.06314090f, 0.06097049f, 0.10468373f, 
    0.02052064f, 0.00348673f, 0.00359236f, 0.01207312f, 0.22431734f, 0.20717759f, -0.07729850f, 0.25974473f, 
    0.06990676f, 0.06418153f, -0.01712927f, 0.02826941f, -0.01394014f, -0.04973902f, 0.00746313f, -0.09949298f, 
    0.01153435f, 0.03308151f, -0.10796231f, 0.00304494f, 0.14018385f, 0.13730443f, -0.16611817f, -0.16996157f, 
    0.01670216f, -0.00422552f, 0.08341331f, 0.20852651f, 0.19820516f, -0.00847121f, -0.01497753f, -0.00319930f, 
    -0.21390426f, -0.29882583f, 0.06757069f, -0.06294776f, 0.02617338f, 0.19560063f, 0.05521524f, 0.18127514f, 
    0.00948942f, 0.06774228f, -0.01529991f, -0.09977195f, -0.11877690f, 0.24078068f, 0.09327057f, -0.08486629f, 
    -0.11272740f, -0.08932199f, -0.12208358f, -0.02166614f, 0.14859916f, 0.24191807f, 0.21974047f, 0.15701462f, 
    -0.03310740f, 0.08053372f, -0.19684909f, 0.10064996f, 0.02871776f, -0.26353502f, 0.17186220f, 0.16550721f, 
    0.07264235f, -0.07882516f, 0.03938567f, 0.04180424f, -0.18513432f, 0.07216800f, 0.01577315f, 0.05278030f, 
    -0.01868722f, -0.01490632f, -0.01192943f, -0.04513832f, 0.03908813f, -0.23375320f, -0.15388250f, -0.04995199f, 
    0.01690524f, -0.06993068f, 0.08161613f, 0.10559333f, 0.03370073f, -0.00770787f, -0.00172118f, -0.04366634f, 
    -0.01031984f, -0.02272429f, 0.02032477f, -0.08442227f, 0.20862837f, 0.05958207f, -0.56787026f, -0.08407128f, 
    -0.04707227f, 0.00058250f, 0.01918492f, 0.08096873f, 0.00435044f, 0.01964830f, -0.02495772f, 0.02477230f, 
    -0.31090510f, 0.02970113f, -0.04265382f, 0.00285337f, 0.01887478f, 0.11320858f, 0.05420316f, -0.03800226f, 
    -0.04964979f, 0.05652227f, 0.01214854f, 0.05047186f, 0.23803613f, -0.05735169f, 0.16097605f, 0.02175039f, 
    -0.00198795f, -0.09164127f, 0.07750767f, 0.04328050f, 0.12060045f, 0.37361673f, -0.08955019f, 0.17490077f, 
    -0.11527707f, -0.25655237f, 0.25406745f, -0.11479219f, -0.10818401f, 0.06147576f, 0.01078164f, 0.06944123f, 
    0.08639247f, -0.03981450f, -0.01006042f, 0.09646207f, -0.22654240f, -0.31833547f, 0.21620508f, -0.02955301f, 
    -0.09774952f, -0.05705895f, 0.04461554f, 0.04963552f, -0.12411860f, 0.03174106f, 0.17719562f, 0.11679436f, 
    0.10650382f, -0.14858633f, -0.36729857f, -0.06194168f, 0.09412027f, 0.19696382f, 0.30326492f, 0.21673200f, 
    -0.06105792f, 0.06135110f, -0.01091529f, 0.04337359f, 0.13676149f, -0.08805485f, 0.10077717f, -0.00967881f, 
    0.02520062f, 0.07507049f, 0.00552277f, -0.00546034f, 0.13421027f, 0.15542941f, 0.13703635f, -0.01278316f, 
    -0.16255607f, -0.11228991f, -0.09541359f, -0.10829517f, 0.04114532f, -0.20224331f, 0.26973805f, -0.09845074f, 
    -0.03630220f, -0.04221334f, -0.01892241f, -0.02639152f, -0.06402207f, -0.02002162f, -0.09099691f, -0.05100200f, 
    0.04799714f, 0.00703119f, 0.16705921f, 0.00447856f, 0.07619976f, -0.04281675f, -0.00085504f, 0.07443019f, 
    -0.13946150f, 0.02883896f, 0.12297764f, 0.17631331f, 0.04244012f, 0.05523952f, 0.00961608f, -0.02957360f, 
    0.01324840f, 0.00302710f, -0.04574231f, -0.11081096f, -0.08884734f, -0.03140762f, -0.07695669f, -0.07800408f, 
    -0.00494983f, -0.04018398f, -0.07929272f, -0.06319701f, -0.14322011f, 0.00804950f, 0.04778594f, -0.04986117f, 
    -0.18512486f, -0.29031789f, -0.08007894f, -0.12083107f, 0.22741517f, 0.16891624f, 0.17935872f, 0.06492242f, 
    0.05887982f, -0.09220533f, -0.07256885f, 0.11322708f, 0.26358780f, -0.15419757f, 0.23911703f, -0.07626715f, 
    0.08063651f, 0.04971845f, -0.07722809f, 0.17102236f, 0.16834974f, 0.13888682f, 0.00239625f, 0.04868665f, 
    -0.37896764f, -0.00746939f, -0.00884706f, -0.06630851f, 0.04187529f, -0.08100982f, -0.01093542f, 0.07808547f, 
    -0.13031150f, 0.15347652f, -0.04384721f, 0.11079518f, 0.01038863f, 0.03621838f, -0.08426915f, 0.00462411f, 
    -0.10011503f, 0.07686220f, 0.25265417f, 0.02680850f, 0.12246545f, 0.06412440f, -0.02777135f, 0.09922233f, 
    -0.08015140f, 0.01101670f, -0.15581796f, 0.20962432f, -0.09148031f, 0.01994796f, 0.00633697f, -0.03475138f, 
    0.03710129f, 0.07580601f, -0.00199969f, 0.12081294f, -0.02033078f, -0.13634335f, -0.04943849f, 0.00693905f, 
    0.00129345f, 0.04107810f, 0.05325744f, 0.07337195f, 0.05281924f, -0.04433212f, -0.01591500f, -0.22053228f, 
    -0.27493334f, 0.01595944f, 0.10019987f, 0.15003018f, 0.08187391f, 0.02332244f, -0.01886971f, 0.01719589f, 
    0.05090879f, 0.04778107f, -0.04903976f, -0.00285756f, -0.08806013f, 0.04484125f, -0.02388847f, 0.42501506f, 
    -0.01478819f, 0.01151749f, -0.11440052f, -0.02781521f, 0.08315869f, 0.15254624f, 0.11443239f, 0.30304202f, 
    -0.25868419f, -0.26288813f, 0.08198722f, 0.08796771f, 0.04595070f, 0.01122328f, -0.08800273f, 0.04729361f, 
    -0.01188676f, 0.02143998f, -0.06309412f, 0.06296920f, 0.22776827f, 0.05186982f, 0.29591715f, -0.15294053f, 
    -0.03494610f, -0.06316057f, 0.04015047f, 0.25008056f, 0.24596269f, 0.14319669f, -0.00167579f, 0.01576400f, 
    0.20680831f, -0.03183176f, -0.03413311f, 0.05263517f, 0.14266446f, 0.17442457f, -0.04927817f, 0.19748542f, 
    0.05091534f, 0.19030702f, 0.14477372f, 0.05604074f, -0.12930249f, -0.03503824f, -0.00267135f, 0.05148719f, 
    -0.14701273f, -0.18506061f, 0.15174770f, 0.18735202f, 0.04732762f, 0.10341740f, 0.04546833f, 0.01130022f, 
    0.21106651f, -0.16204773f, 0.00818092f, -0.05302553f, 0.06601577f, 0.01629862f, -0.03842991f, 0.07302222f, 
    0.17705081f, -0.03545012f, 0.05115930f, -0.08022808f, -0.13090613f, -0.10899819f, 0.05050542f, -0.20552400f, 
    0.17051011f, 0.12125105f, -0.20177950f, 0.20780948f, 0.10077754f, -0.09964845f, 0.01668104f, 0.08605144f, 
    0.30295357f, -0.12814748f, -0.18553475f, 0.16934767f, -0.01903387f, -0.01163068f, -0.03810842f, 0.09057818f, 
    0.06462467f, 0.08250304f, -0.06357487f, -0.06498900f, -0.11735749f, -0.08082886f, -0.10367363f, 0.04870623f, 
    0.03739380f, -0.05182950f, -0.03859747f, 0.03848055f, -0.14598398f, -0.05865415f, 0.03003780f, -0.00146490f, 
    -0.00403435f, 0.00106913f, 0.00899726f, 0.00410196f, -0.03377111f, 0.02994957f, -0.00902993f, 0.02248826f, 
    0.01732825f, -0.03406553f, -0.02892866f, 0.02744078f, 0.02889053f, -0.04155914f, -0.00155591f, -0.05328741f, 
    -0.00546358f, -0.04317161f, -0.01273935f, 0.02430379f, -0.02090102f, -0.01561468f, -0.03294019f, -0.03584267f, 
    -0.04117338f, -0.03544397f, -0.02044770f, -0.03441394f, 0.01618869f, -0.03549274f, -0.05103372f, -0.03973187f, 
    -0.04766779f, -0.04122172f, 0.01167132f, 0.01040434f, -0.01587369f, -0.01146434f, -0.01802528f, -0.02709911f, 
    0.00670713f, -0.04860270f, -0.05666363f, -0.04180178f, 0.01601215f, 0.01341235f, -0.04478335f, -0.02038272f, 
    -0.00469677f, -0.03434490f, -0.04011598f, 0.01197490f, -0.04353578f, 0.01505079f, -0.00929922f, 0.01791410f, 
    0.02981951f, -0.04102020f, -0.00821865f, -0.01082173f, -0.03347231f, -0.00261789f, 0.03403890f, -0.05332488f, 
    -0.00853928f, -0.01677150f, -0.00759052f, 0.01314510f, -0.01644965f, -0.03899474f, -0.00860209f, 0.02333096f, 
    -0.01669739f, -0.03426133f, -0.02008249f, -0.02197011f, 0.01937741f, -0.05019662f, -0.00602259f, -0.03937288f, 
    0.00434622f, -0.02279020f, -0.03664694f, -0.04445706f, 0.01743424f, -0.00039088f, -0.04613299f, 0.01392537f, 
    -0.03862572f, -0.00054300f, 0.00297664f, -0.02643036f, 0.00936553f, -0.00960442f, 0.00949340f, 0.01141924f, 
    -0.01004731f, 0.00223179f, -0.02340614f, 0.01194942f, -0.02047286f, -0.05577809f, -0.01545422f, -0.03002111f, 
    0.00348437f, -0.00394806f, -0.00731521f, -0.05396335f, -0.02430781f, -0.01418008f, -0.02191638f, -0.03247471f, 
    -0.04003811f, -0.01039973f, -0.04566082f, -0.03248155f, -0.01499067f, 0.00257173f, -0.05860154f, -0.05395228f, 
    -0.04237092f, -0.05489745f, -0.03069701f, -0.00917519f, -0.00238285f, -0.03883671f, 0.00963938f, 0.00219737f, 
    0.01415278f, -0.04334448f, -0.03058787f, -0.00008666f, 0.02054230f, -0.01934031f, -0.00832940f, -0.00746865f, 
    -0.03556522f, -0.02137294f, -0.01253425f, 0.00692737f, -0.02621247f, -0.02023667f, -0.02642507f, -0.04844343f, 
    0.01542220f, -0.02645144f, -0.04825952f, -0.00941209f, -0.00818712f, -0.02535749f, -0.03532041f, -0.05566017f, 
    0.00512544f, -0.04024741f, -0.01206430f, -0.01300573f, -0.01628349f, 0.02151466f, -0.02833467f, -0.05165827f, 
    0.00619641f, -0.02275415f, -0.02721539f, -0.01250021f, 0.00611502f, -0.02555223f, 0.02925382f, -0.01813281f, 
    -0.00620030f, -0.05670253f, -0.03993003f, -0.02307080f, -0.00326429f, -0.03951249f, -0.03251273f, -0.04980851f, 
    -0.02091369f, -0.00413453f, -0.03036802f, -0.00878427f, -0.00511482f, -0.04475533f, 0.00008510f, 0.00129952f, 
    -0.03392316f, -0.02800626f, 0.02363615f, -0.02313639f, -0.03510275f, -0.03362506f, 0.01508349f, -0.01664324f, 
    0.01440160f, 0.03188793f, -0.03871020f, -0.00557953f, 0.01010706f, 0.01181450f, 0.02454760f, -0.01920404f, 
    -0.01934428f, 0.00996692f, -0.02289940f, -0.00397014f, -0.00997517f, 0.01470613f, -0.00929885f, -0.04529301f, 
    -0.04358177f, 0.01680157f, -0.02186806f, -0.01641258f, -0.00615214f, -0.04855552f, -0.04831919f, -0.03831273f, 
    -0.01156369f, -0.02703317f, 0.01169513f, 0.02786741f, 0.00143663f, -0.00451858f, 0.03178117f, -0.00333656f, 
    0.00369894f, -0.03931573f, -0.02925692f, -0.03497754f, -0.02412322f, -0.00459479f, 0.02804906f, -0.00830828f, 
    0.00210149f, -0.03156629f, -0.02060008f, 0.01008243f, -0.03391808f, -0.00333415f, 0.01642816f, 0.00966458f, 
    -0.03699961f, -0.00352705f, -0.03673997f, -0.00245317f, -0.00291557f, 0.01547034f, -0.04958156f, -0.00743705f, 
    -0.04167855f, -0.02012802f, 0.02420519f, 0.00378284f, 0.00041928f, -0.04179562f, -0.03681467f, -0.01493000f, 
    0.01417486f, -0.04107470f, 0.01091874f, -0.02936695f, 0.00556281f, -0.02288408f, -0.02403468f, -0.01811341f, 
    0.01138636f, 0.00565770f, -0.00859909f, -0.01676971f, -0.03638808f, -0.00493792f, 0.01011012f, -0.02519974f, 
    -0.04555196f, 0.00871334f, -0.03336794f, -0.00359809f, -0.01627148f, 0.00678983f, -0.03283907f, 0.02448916f, 
    -0.03116941f, -0.02810028f, -0.03215404f, 0.00613108f, -0.00660532f, -0.03192117f, -0.04805147f, -0.00608223f, 
    -0.03614416f, 0.00500782f, 0.01469995f, -0.01060192f, -0.02581162f, 0.01325465f, -0.00465506f, -0.04267603f, 
    -0.00314270f, -0.05039881f, -0.01069821f, -0.02568997f, -0.03205076f, -0.02445027f, -0.03439485f, 0.00600362f, 
    -0.02337986f, -0.03244230f, -0.03264291f, -0.03984502f, 0.01589627f, -0.01002766f, -0.05016268f, 0.01925962f, 
    -0.01729886f, -0.04099520f, -0.01498774f, -0.03493847f, -0.01501995f, -0.01339488f, -0.02181108f, -0.05313551f, 
    -0.01432101f, -0.00514175f, -0.05234678f, 0.01263421f, -0.04339620f, -0.00334732f, -0.04049079f, -0.03057835f, 
    0.00017821f, -0.00550128f, -0.05263770f, -0.02598461f, -0.01027888f, 0.01056274f, 0.00321738f, -0.05365868f, 
    0.00485554f, -0.02978413f, 0.00025410f, -0.00447679f, 0.01152075f, -0.01173232f, -0.03752491f, -0.01904119f, 
    -0.00251064f, -0.01579428f, -0.03842698f, -0.02399038f, -0.01077898f, -0.04907985f, -0.04177474f, 0.00044002f, 
    -0.04443306f, -0.01318357f, 0.01572322f, 0.01469917f, -0.04812779f, -0.03657814f, -0.00275964f, -0.02517940f, 
    0.00790415f, 0.00523368f, 0.00552871f, 0.00147888f, 0.00307078f, -0.01189056f, -0.01929966f, 0.00481517f, 
    -0.05046600f, 0.00496512f, 0.00668827f, -0.04770324f, -0.00636735f, -0.00052145f, -0.02783801f, 0.01147968f, 
    0.01270770f, -0.03456794f, -0.03093398f, -0.00584614f, -0.03282096f, 0.00519174f, 0.02557937f, -0.00828295f, 
    0.01276155f, 0.01153824f, 0.01860313f, 0.00886502f, -0.03347709f, -0.01053384f, -0.03541577f, 0.00909529f, 
    -0.01233688f, -0.04320429f, -0.00912765f, 0.00509307f, -0.00174294f, -0.00259981f, 0.01060230f, -0.01827197f, 
    0.00272511f, 0.00401732f, -0.03914163f, -0.00274288f, -0.01433081f, -0.05510392f, -0.04070688f, -0.01610213f, 
    0.00315267f, -0.02072217f, -0.00667137f, 0.01032994f, -0.02659571f, -0.02449901f, -0.00492510f, -0.03322907f, 
    0.01111037f, -0.03743056f, -0.03991735f, -0.00148442f, -0.03436492f, 0.00583925f, 0.03462503f, 0.03091144f, 
    0.00341604f, -0.03348384f, -0.01217386f, -0.02028525f, -0.02572475f, 0.00016380f, 0.00162291f, 0.01898506f, 
    -0.02904646f, -0.01468808f, -0.05286481f, 0.00403708f, -0.01361697f, -0.04155516f, -0.03689468f, 0.01152084f, 
    -0.01028274f, -0.01867015f, 0.00745158f, -0.01197318f, -0.03728687f, -0.02605615f, 0.01073281f, -0.00216928f, 
    -0.05310764f, -0.04818130f, -0.00504355f, -0.00015453f, -0.01362094f, -0.01033948f, -0.02379477f, -0.01868662f, 
    0.01746789f, -0.01682042f, 0.01399959f, -0.04042057f, -0.02211028f, -0.00363725f, 0.00402490f, -0.03373514f, 
    -0.01750005f, 0.00262270f, -0.01935052f, -0.01711364f, -0.02024578f, -0.03977953f, 0.01752134f, -0.03171429f, 
    -0.02350089f, -0.00657514f, 0.00141855f, -0.00102472f, -0.02258984f, -0.02319822f, -0.05683398f, -0.01400893f, 
    0.00973061f, -0.02399433f, -0.03173460f, -0.03255602f, 0.01125622f, -0.05067727f, -0.00325582f, 0.01792287f, 
    -0.02922727f, -0.05090138f, -0.02866829f, -0.01368877f, -0.02582401f, -0.04797276f, -0.03284588f, 0.01141988f, 
    -0.00001060f, -0.00784082f, -0.03743278f, -0.04410649f, -0.02005305f, -0.02871064f, -0.02024917f, -0.00987871f, 
    0.02029293f, -0.03978282f, -0.04284314f, 0.01114385f, -0.02941207f, -0.01910915f, 0.02217890f, -0.02790932f, 
    -0.03635682f, 0.00632039f, -0.03177927f, 0.00236925f, -0.04223913f, -0.04846670f, -0.00737554f, 0.00282660f, 
    -0.03072513f, -0.02641525f, -0.00269914f, -0.03042713f, -0.02804447f, -0.04884494f, 0.01824800f, -0.03885762f, 
    -0.03670586f, -0.04546652f, -0.03511539f, -0.03436609f, -0.03522468f, -0.01841177f, 0.01004774f, -0.02435950f, 
    -0.00146663f, 0.01345376f, -0.02081745f, -0.01046524f, 0.02539528f, -0.04315513f, -0.04710519f, 0.01150185f, 
    -0.03400536f, 0.01185869f, -0.02465275f, -0.03987074f, -0.02030240f, -0.04608775f, -0.02375173f, -0.04171408f, 
    0.02105594f, -0.03118940f, 0.00927493f, -0.00435211f, 0.03474967f, -0.00663807f, -0.02136086f, -0.01680785f, 
    0.02582433f, -0.00359944f, 0.00069322f, -0.01180941f, 0.01185075f, 0.02282497f, -0.01570410f, -0.00000145f, 
    -0.04515684f, -0.04216370f, -0.02861140f, -0.04651002f, -0.01149821f, -0.03533679f, -0.02436617f, 0.01414587f, 
    -0.04909929f, 0.02436875f, -0.02682566f, 0.00007441f, -0.02737201f, 0.00675767f, 0.02111137f, -0.01582566f, 
    0.00986446f, 0.01786742f, -0.02033347f, -0.01811777f, -0.02019931f, -0.04408152f, -0.03884139f, -0.00637455f, 
    -0.00763517f, -0.02934702f, -0.03393886f, -0.04492007f, -0.01166083f, -0.05540522f, -0.00471631f, -0.02408953f, 
    -0.02470923f, -0.01370786f, 0.01294476f, 0.00011540f, 0.00171311f, -0.01496614f, -0.03246452f, -0.01300025f, 
    0.01734040f, 0.01618412f, -0.00555580f, -0.04775090f, -0.04567954f, -0.04255774f, -0.00252700f, -0.04818229f, 
    -0.04418138f, -0.05084980f, -0.00251744f, -0.01785495f, -0.00999640f, -0.03777237f, 0.00165992f, -0.01040683f, 
    -0.03937590f, -0.00353701f, -0.00621895f, -0.01243362f, -0.01437278f, -0.01542791f, -0.02231793f, -0.01519750f, 
    0.01083727f, -0.01642274f, -0.01169540f, -0.02317693f, -0.03229235f, -0.00114377f, -0.01323823f, 0.01076583f, 
    0.01728449f, -0.01105525f, 0.01294173f, 0.01361234f, 0.00587514f, -0.03186057f, -0.05355693f, -0.02796111f, 
    0.01252295f, 0.02781666f, 0.01405521f, -0.02931922f, 0.01527461f, -0.02379814f, -0.03373120f, 0.00818395f, 
    0.00572917f, -0.03222380f, 0.02186245f, 0.02510766f, -0.04059533f, -0.00065780f, -0.01622456f, -0.00839245f, 
    -0.00865114f, -0.05447211f, -0.00173386f, -0.02543886f, -0.05127620f, -0.03415596f, -0.02238505f, -0.04177470f, 
    -0.04314936f, -0.02875896f, -0.04206787f, 0.00076992f, 0.00634437f, -0.01085917f, -0.00424939f, -0.05136275f, 
    -0.00335849f, -0.00994189f, 0.01466151f, -0.00583429f, -0.02388911f, -0.00441758f, -0.04000460f, -0.00140575f, 
    -0.02140615f, -0.05626938f, 0.01592283f, 0.00836563f, 0.00034127f, -0.03043167f, -0.05043291f, -0.01242361f, 
    -0.02648888f, -0.05097269f, -0.00595492f, -0.01281562f, 0.00405952f, -0.04041132f, -0.00962285f, -0.04409147f, 
    -0.00972841f, -0.02936896f, -0.05110229f, -0.00367816f, -0.03261390f, -0.01371452f, -0.00253238f, 0.00160454f, 
    -0.01895240f, 0.01218091f, -0.02761976f, -0.01158154f, 0.02003960f, -0.03412841f, 0.02521978f, -0.00343315f, 
    -0.01963941f, -0.02184568f, -0.01516695f, -0.02157311f, -0.01512337f, -0.03046768f, -0.02373940f, -0.01696485f, 
    0.00220448f, -0.04916649f, -0.04121369f, 0.00733026f, -0.01456742f, 0.02264663f, -0.04596615f, -0.00855344f, 
    -0.03293662f, -0.04024355f, -0.03990552f, 0.02155672f, -0.01811430f, -0.04887586f, -0.00706642f, -0.01598571f, 
    -0.01469109f, -0.02128826f, -0.00322186f, -0.02887276f, -0.02273248f, 0.02974549f, 0.01551563f, -0.00334136f, 
    -0.02098254f, -0.03048915f, -0.05181745f, -0.01247383f, 0.01508641f, -0.00094000f, -0.03882708f, -0.04836046f, 
    -0.02966507f, -0.03589561f, 0.01771923f, -0.01906801f, 0.00672892f, -0.00696781f, -0.01237401f, -0.02066885f, 
    -0.29024899f, 0.10658814f, 0.03005889f, 0.08433872f, -0.00864408f, -0.00406008f, -0.11393417f, -0.02283963f, 
    0.14491183f, 0.05099420f, -0.11304451f, -0.05860350f, 0.19159438f, -0.19862895f, -0.03271160f, 0.02668858f, 
    0.05808070f, -0.13641310f, 0.15320826f, 0.09437960f, -0.24996023f, -0.01849487f, 0.05489886f, 0.02160473f, 
    -0.06620909f, -0.01154550f, 0.08866023f, 0.07503061f, 0.22421341f, 0.12215150f, -0.00728403f, 0.16746859f, 
    0.00078832f, 0.09859608f, 0.05347743f, 0.13062760f, -0.25396821f, -0.27365699f, 0.07425918f, 0.28565106f, 
    0.06215951f, 0.07322260f, -0.02860086f, 0.04267862f, -0.18336546f, 0.00783478f, -0.07190116f, 0.09929547f, 
    -0.30760559f, 0.02969606f, 0.19833945f, 0.34947872f, -0.07786970f, 0.01289918f, 0.01465050f, -0.12116782f, 
    -0.06228022f, 0.03092784f, 0.02384924f, 0.02990740f, 0.30733147f, 0.22387649f, -0.06863499f, 0.25855896f, 
    -0.09246003f, 0.05240199f, 0.02078473f, 0.03928899f, 0.11631972f, 0.07316436f, 0.24427867f, 0.13528368f, 
    -0.19211878f, -0.26152745f, -0.15138988f, -0.14273134f, 0.01637465f, -0.02725904f, -0.01931369f, 0.06013475f, 
    -0.10015112f, -0.08350723f, -0.09418170f, -0.15815164f, -0.03950039f, 0.21389219f, -0.03724754f, -0.09157326f, 
    -0.07819846f, 0.09225793f, -0.08793607f, 0.04753923f, 0.08189441f, -0.11761308f, 0.09525511f, -0.15568750f, 
    -0.18637803f, -0.06061180f, -0.17419057f, -0.04328514f, 0.03832949f, 0.06270479f, 0.17409302f, 0.08184676f, 
    0.03161198f, 0.07778545f, 0.12291934f, -0.05682761f, -0.01639807f, 0.05798799f, -0.09870647f, -0.09301043f, 
    -0.08348695f, -0.04970296f, 0.05657766f, 0.04217108f, -0.00977371f, 0.02570260f, 0.12729004f, 0.09483350f, 
    -0.23866183f, -0.10524915f, -0.03466126f, 0.20645916f, 0.03280034f, -0.02280067f, 0.10123191f, -0.09197613f, 
    0.10251369f, 0.14132804f, -0.03870940f, 0.11258125f, -0.23510261f, 0.02622883f, 0.05709032f, 0.12272690f, 
    0.14197864f, -0.03590573f, 0.11338460f, 0.08051234f, 0.05201595f, 0.11443470f, -0.01624995f, 0.09393289f, 
    0.04559239f, -0.10464154f, -0.13162290f, -0.06596603f, 0.19883060f, 0.11779916f, 0.02053241f, -0.00479132f, 
    0.00837566f, 0.14493896f, 0.02577870f, 0.04918792f, -0.15477628f, -0.20849192f, -0.02366933f, 0.28273079f, 
    -0.14771867f, -0.07861298f, -0.00386865f, -0.11802345f, -0.04013436f, -0.08167243f, 0.08226129f, 0.19056113f, 
    -0.20470192f, -0.13123237f, -0.00335353f, 0.17993833f, 0.02170384f, 0.06311110f, -0.00769343f, -0.05680180f, 
    0.02305917f, 0.07454049f, 0.02208235f, 0.09356151f, 0.05885382f, 0.19572149f, 0.34180230f, 0.19702873f, 
    0.07112274f, 0.00321919f, -0.06521820f, -0.06510594f, -0.01264026f, -0.00738984f, -0.05731184f, -0.07956249f, 
    -0.29305562f, 0.00276553f, 0.13131967f, 0.32083744f, -0.03472482f, 0.10202059f, 0.17086542f, -0.10381282f, 
    0.18946932f, 0.15587547f, 0.02625800f, 0.01242507f, 0.09267014f, 0.09661668f, 0.17654341f, 0.00759145f, 
    0.06847371f, -0.02918005f, -0.00323060f, 0.01323550f, 0.17636743f, -0.01145146f, 0.00053457f, 0.06367537f, 
    -0.08802853f, 0.11053308f, -0.26147348f, -0.24558508f, -0.01753881f, -0.03597385f, -0.01156938f, 0.09752353f, 
    0.02416301f, -0.04819341f, -0.13867824f, 0.00783501f, -0.00556045f, 0.00701816f, 0.07500821f, 0.02379212f, 
    -0.05937691f, -0.01236151f, 0.25469223f, 0.07892708f, -0.01908618f, 0.02688155f, -0.07683840f, -0.29027715f, 
    0.25502989f, -0.14080057f, 0.00707820f, 0.13477919f, 0.08894788f, -0.10798759f, 0.07348632f, 0.06344862f, 
    -0.04204768f, -0.01831865f, -0.02540471f, -0.02839329f, -0.34786198f, 0.36761290f, 0.08666181f, 0.12430083f, 
    -0.01708232f, 0.11475793f, -0.07380145f, 0.04485778f, -0.04078310f, -0.10887852f, 0.06352656f, 0.08118644f, 
    -0.28711379f, 0.08928126f, -0.21666825f, 0.49866149f, 0.04701760f, 0.04818722f, 0.18195052f, -0.04563737f, 
    0.05138144f, -0.00137823f, 0.05649943f, 0.07953142f, 0.08098235f, 0.06176303f, -0.04784930f, -0.02423325f, 
    -0.02016276f, -0.04234361f, -0.08916084f, -0.07065254f, -0.09269969f, -0.02581082f, 0.10528176f, -0.07668792f, 
    -0.20748353f, -0.01664803f, 0.02461664f, 0.20859432f, 0.17406879f, -0.10368318f, 0.21278977f, 0.11590212f, 
    0.12353171f, 0.04447456f, 0.14668325f, -0.07679556f, 0.16655329f, 0.27025706f, 0.31812820f, 0.04527026f, 
    -0.04183909f, 0.01947496f, -0.07125783f, 0.00264606f, -0.02232180f, 0.03160818f, -0.00309620f, -0.07338966f, 
    0.05359409f, -0.06822450f, -0.00080552f, -0.03198591f, 0.01369966f, -0.00079776f, -0.01257903f, 0.16013698f, 
    0.07033297f, 0.14446737f, 0.12030528f, 0.17317806f, -0.08216164f, -0.12034674f, 0.09231234f, 0.02615829f, 
    -0.01571837f, -0.01121191f, 0.06188652f, 0.02898324f, 0.03980106f, 0.05590513f, -0.02331583f, -0.09970962f, 
    -0.05534941f, -0.05076535f, -0.03914271f, -0.07816207f, -0.05061249f, -0.02609100f, -0.05397548f, 0.01206380f, 
    -0.07620750f, 0.01194019f, 0.07324239f, -0.03939370f, -0.13297342f, 0.00599731f, -0.07535298f, -0.03010282f, 
    0.04526616f, -0.03577847f, 0.08700951f, 0.08429618f, 0.00465793f, 0.10687196f, 0.15965766f, 0.14003801f, 
    -0.03895958f, -0.04364524f, -0.05883371f, -0.11952112f, -0.06316259f, -0.02036049f, -0.01720594f, 0.03122295f, 
    -0.05791841f, -0.02295556f, 0.17885457f, 0.01334849f, -0.13290052f, -0.06623556f, -0.07035121f, 0.08371297f, 
    -0.04074380f, 0.06363052f, 0.03584947f, 0.04315737f, -0.09100678f, -0.09551866f, -0.17886940f, -0.02506188f, 
    -0.00249781f, -0.05590053f, 0.31034663f, 0.19096921f, 0.10743544f, 0.14194570f, 0.07807145f, 0.00027945f, 
    0.13638569f, -0.01783934f, -0.08350080f, -0.23345917f, -0.18927935f, 0.08192376f, -0.03273732f, 0.24397448f, 
    0.01384787f, 0.08583906f, 0.13649598f, -0.02624517f, 0.11925876f, 0.05346036f, -0.01057341f, -0.06596629f, 
    -0.05811108f, 0.09931697f, 0.02813208f, -0.12168652f, 0.05263083f, 0.02657940f, 0.00458553f, -0.09455102f, 
    -0.01928328f, 0.04711717f, 0.02333763f, 0.03684038f, 0.17210352f, -0.11148428f, -0.14437173f, -0.11556932f, 
    -0.01949559f, -0.00819733f, 0.05611075f, 0.01497398f, -0.19396204f, -0.00954057f, -0.11237718f, -0.21410647f, 
    0.00035725f, 0.17794637f, 0.01103809f, -0.06718601f, 0.04691208f, -0.06349339f, -0.03255353f, 0.01867134f, 
    0.09822426f, 0.04676465f, -0.02055382f, 0.10832299f, -0.05532957f, 0.10105560f, 0.40309876f, 0.37966692f, 
    0.20202780f, -0.13953564f, -0.14222664f, 0.02553908f, -0.02516245f, -0.01731778f, 0.02544485f, 0.03204309f, 
    -0.19802782f, -0.26411954f, 0.23727030f, 0.12459660f, 0.17713520f, 0.08796623f, -0.12044719f, -0.21128429f, 
    -0.01470273f, -0.00189512f, -0.00124347f, -0.07537963f, -0.10284378f, -0.07955620f, -0.11891615f, -0.00633896f, 
    0.00590960f, 0.03828185f, 0.04898857f, -0.05432356f, 0.05296458f, 0.04592865f, 0.25808126f, 0.29936832f, 
    -0.28316531f, 0.09336429f, -0.00122444f, -0.07282709f, 0.04648992f, -0.01403354f, 0.08796868f, 0.19662918f, 
    -0.01633591f, 0.12224288f, 0.14077893f, 0.08466151f, -0.02531008f, -0.19977163f, -0.34328157f, -0.01730350f, 
    0.01151759f, -0.13007288f, 0.05394516f, 0.12267024f, -0.03155731f, 0.06858428f, 0.06264605f, -0.08924827f, 
    0.11108142f, 0.06303472f, 0.34189966f, 0.15865223f, 0.06398115f, 0.01482798f, -0.15477502f, 0.03906654f, 
    -0.04190993f, -0.02161936f, 0.07433975f, -0.07416386f, -0.09310874f, 0.02565112f, -0.10462721f, -0.06429587f, 
    -0.05869037f, 0.00843435f, 0.03162020f, 0.10693747f, -0.06059550f, -0.03361470f, -0.07572091f, -0.02142038f, 
    -0.06543943f, -0.02713198f, 0.06739184f, 0.09987465f, -0.06067749f, 0.09786542f, -0.13292192f, 0.04205881f, 
    0.06676430f, 0.05591211f, 0.09279457f, 0.13112572f, -0.16364922f, 0.06518010f, 0.35839766f, 0.02919349f, 
    0.06026025f, 0.23734881f, -0.10723635f, 0.12341874f, 0.03455367f, -0.04770460f, 0.10804530f, 0.08416072f, 
    -0.11108381f, -0.16770372f, 0.08824436f, 0.03309371f, -0.09946103f, -0.21341977f, -0.08998593f, -0.14987117f, 
    0.03401980f, 0.05163971f, 0.01374077f, 0.00686596f, -0.06431625f, -0.16306068f, -0.12938675f, -0.03252155f, 
    0.05602170f, -0.07079041f, 0.03230114f, 0.13821933f, 0.07869308f, -0.03806382f, -0.08929280f, 0.01967751f, 
    -0.16956934f, 0.06310814f, 0.15604116f, 0.36756796f, 0.09543005f, 0.09117532f, -0.02697567f, -0.06912000f, 
    -0.00435566f, 0.01061235f, 0.04044207f, -0.02892738f, -0.07947785f, 0.09171952f, -0.05666825f, 0.05281809f, 
    0.10186230f, -0.01482574f, 0.08274316f, 0.13443667f, -0.01122351f, 0.06707488f, 0.02426378f, 0.02543574f, 
    0.00373930f, -0.08972150f, -0.00773068f, 0.16251968f, -0.15200436f, 0.02030020f, 0.06611655f, 0.15018357f, 
    0.07025926f, 0.02708719f, 0.00381970f, 0.01066930f, -0.01026346f, 0.14168151f, 0.10304704f, 0.41429180f, 
    -0.04903876f, 0.12303771f, 0.21048440f, -0.00700149f, 0.11262990f, -0.02488228f, 0.06814005f, 0.07972138f, 
    -0.01158055f, -0.02066753f, -0.00381686f, -0.05479039f, 0.08885609f, -0.01150196f, -0.09139261f, -0.04848714f, 
    0.03655804f, 0.02642859f, 0.14853832f, 0.07853668f, 0.08146977f, -0.05943226f, -0.10949371f, -0.04294806f, 
    0.00016471f, -0.05830785f, -0.05804599f, -0.06121343f, 0.01659659f, 0.07025325f, -0.09052921f, -0.05362073f, 
    -0.01130117f, -0.33912423f, 0.13937694f, -0.08912729f, 0.04783439f, -0.19794156f, -0.05189150f, -0.11566370f, 
    -0.01687219f, 0.05552260f, 0.10940185f, 0.08891555f, 0.05873260f, -0.14135456f, -0.29582781f, -0.02176687f, 
    0.06854001f, -0.00756515f, 0.01874395f, 0.02051761f, 0.13485532f, -0.02288067f, 0.19774547f, -0.00737437f, 
    -0.07269088f, 0.01539977f, -0.04211400f, 0.25238389f, 0.18418452f, -0.08705982f, 0.13131337f, 0.02726549f, 
    0.01854149f, 0.04396082f, 0.02760020f, 0.00582370f, -0.23941424f, 0.03561474f, 0.08338047f, 0.03617521f, 
    0.05153932f, -0.13934655f, 0.10192383f, 0.10404611f, 0.10181639f, 0.03023280f, 0.15044728f, 0.07131463f, 
    0.44126192f, -0.20287275f, -0.06925318f, 0.24574152f, 0.07468464f, 0.09924558f, 0.03364500f, -0.01175371f, 
    0.02036658f, -0.07033580f, -0.02946264f, 0.17237851f, -0.11342961f, -0.10800988f, -0.03568913f, 0.07764283f, 
    -0.08553751f, -0.04671730f, -0.06877398f, -0.02507309f, 0.04967204f, 0.09870058f, 0.15355714f, 0.09965108f, 
    -0.13672829f, 0.10483716f, 0.09975676f, 0.06135172f, 0.03028058f, 0.00753876f, -0.01758310f, 0.05712622f, 
    -0.05463799f, 0.14373170f, 0.04570109f, 0.13046187f, -0.10184614f, 0.01725597f, 0.20492923f, 0.20954008f, 
    0.12011308f, -0.01583825f, 0.01536481f, 0.01179144f, 0.02012095f, 0.02529929f, -0.13590427f, -0.10909459f, 
    0.16540052f, 0.17639978f, -0.16864958f, -0.18331920f, 0.02066515f, -0.05693656f, 0.05851857f, 0.04346984f, 
    0.04620268f, 0.02632847f, 0.05877705f, 0.13239579f, -0.04517730f, 0.13505016f, 0.12219359f, -0.01760196f, 
    -0.00980777f, 0.00228633f, -0.01158524f, 0.09122181f, 0.01397114f, 0.00687127f, 0.04019963f, 0.02428209f, 
    -0.06554527f, -0.15682650f, -0.04619316f, -0.15042207f, -0.01507075f, -0.10445476f, -0.13659109f, 0.04596124f, 
    -0.09807843f, 0.14469196f, 0.01428576f, -0.02377938f, -0.28200394f, 0.04974509f, 0.12506144f, 0.16516788f, 
    0.15728360f, 0.16558644f, -0.23807435f, 0.06605843f, 0.08952204f, 0.17293711f, -0.07361913f, -0.05175402f, 
    -0.04598919f, -0.11857477f, -0.02292838f, -0.01477519f, -0.11484534f, -0.04844071f, -0.12142537f, 0.07446320f, 
    -0.04273927f, -0.13572475f, -0.01408857f, -0.00815793f, 0.03231378f, -0.28022510f, -0.31521255f, -0.09195656f, 
    -0.06204339f, 0.08172334f, -0.07555740f, 0.12648053f, -0.07499333f, -0.05618695f, 0.03622560f, 0.03388169f, 
    0.32727426f, 0.03017989f, 0.21530744f, -0.07061578f, 0.01269208f, 0.08141058f, 0.02018427f, -0.12633146f, 
    -0.03304910f, -0.04797378f, 0.03284769f, 0.11027601f, 0.25338468f, 0.00745108f, -0.05515599f, -0.34199154f, 
    -0.01957457f, -0.13752879f, 0.14893216f, 0.05443706f, 0.02990676f, 0.05086216f, -0.13697423f, 0.06855457f, 
    0.00930389f, -0.02062623f, -0.00829611f, 0.07914440f, -0.03181872f, 0.05103681f, 0.07111600f, 0.04568882f, 
    0.04130536f, 0.01840455f, 0.18358210f, -0.03161758f, 0.22554830f, -0.02726630f, -0.33237597f, 0.28565529f, 
    -0.11893115f, -0.04920677f, 0.12897152f, -0.11962308f, 0.02032836f, 0.03316132f, 0.05444947f, 0.01981161f, 
    -0.00783378f, 0.05231376f, -0.03217468f, 0.10995413f, 0.04171545f, 0.05959457f, 0.05181671f, -0.05021246f, 
    0.03707306f, 0.04019404f, 0.10070059f, 0.09097173f, 0.05809173f, -0.01408736f, 0.01539851f, -0.01448102f, 
    -0.04822355f, 0.00794681f, 0.03021980f, -0.01433051f, -0.04349592f, 0.05995123f, -0.01937398f, 0.07540947f, 
    -0.12704991f, 0.03397185f, 0.07480980f, -0.07044345f, -0.13400161f, 0.13042107f, -0.00535363f, -0.02628624f, 
    0.00810511f, -0.00347005f, -0.08707628f, -0.04945645f, 0.24940787f, 0.03482315f, 0.09945145f, 0.17869699f, 
    0.07792646f, 0.16949864f, -0.19172588f, 0.29199773f, -0.03637602f, 0.12213390f, 0.05828402f, 0.02270564f, 
    -0.07685636f, -0.25422412f, 0.02401724f, 0.02321715f, 0.00399320f, 0.08501018f, 0.00899496f, 0.05999136f, 
    -0.10287815f, -0.15435381f, 0.07980145f, -0.15119348f, 0.21103539f, 0.23603319f, 0.13537557f, -0.01829900f, 
    0.13310201f, 0.16370843f, -0.02898837f, -0.06894142f, -0.07513903f, 0.01448439f, 0.01830004f, 0.02107870f, 
    0.27495629f, 0.19488572f, -0.11268310f, -0.28278732f, 0.07470352f, -0.01233520f, 0.05628321f, 0.07863999f, 
    -0.03673116f, -0.02616476f, -0.08033302f, -0.03261320f, -0.13828070f, 0.29109541f, 0.02317680f, -0.35003212f, 
    -0.10957271f, -0.11279561f, -0.14954337f, -0.00464864f, -0.10062601f, -0.06220243f, -0.00371280f, 0.03538423f, 
    0.15951139f, -0.03202762f, -0.01159181f, 0.10700651f, 0.03623186f, 0.16280426f, 0.02552469f, 0.02600609f, 
    -0.00395616f, -0.04072434f, -0.07715672f, 0.02219458f, 0.05028708f, 0.05549991f, -0.16263524f, -0.09405623f, 
    0.05475393f, -0.17731854f, 0.04928840f, 0.06048675f, 0.03637064f, 0.11083781f, -0.06544435f, 0.09509613f, 
    0.37490612f, -0.10292550f, 0.12670955f, 0.00784771f, -0.03310500f, -0.12682000f, 0.04841104f, -0.04345510f, 
    0.11932427f, 0.15811421f, 0.18801844f, -0.09341699f, 0.03839768f, 0.11111747f, 0.14688857f, -0.06790271f, 
    0.04380986f, 0.15228742f, -0.10093912f, 0.14062166f, -0.06766688f, 0.06498273f, 0.01970254f, -0.05732645f, 
    0.17405163f, 0.26341015f, -0.07484444f, 0.12529314f, 0.01570796f, 0.15270226f, 0.13956891f, 0.13986975f, 
    0.14226861f, 0.07796690f, 0.04528507f, 0.02389787f, 0.26249495f, -0.08335568f, -0.01543862f, -0.13826320f, 
    -0.02428239f, -0.04554297f, 0.08937372f, -0.12485194f, 0.17638178f, 0.01857263f, -0.07219196f, 0.01641818f, 
    -0.01507227f, -0.00498744f, -0.16322646f, 0.02189765f, 0.05893703f, 0.12950182f, -0.11339661f, 0.19014670f, 
    0.06377735f, 0.06185412f, 0.07692266f, -0.10470095f, -0.29006684f, -0.23284017f, 0.19587608f, 0.05117269f, 
    -0.00492706f, 0.05291098f, -0.10959651f, 0.08550809f, 0.01945283f, -0.04656264f, -0.03477116f, 0.04682116f, 
    0.45094037f, 0.11283205f, -0.46380323f, -0.24940138f, -0.02363634f, -0.17159113f, 0.03506916f, 0.13074322f, 
    0.06655718f, -0.03068500f, 0.02914063f, -0.01434552f, 0.14700717f, 0.35025355f, -0.17644772f, 0.07259084f, 
    0.02143837f, 0.00130292f, 0.15422121f, -0.25372019f, 0.20249344f, -0.01050234f, 0.06903115f, 0.04475907f, 
    -0.06868039f, -0.25741935f, -0.11542455f, -0.07106753f, 0.07531433f, -0.08418230f, 0.16501932f, -0.08031086f, 
    -0.02465096f, 0.06602965f, 0.09326670f, -0.06134922f, 0.19174857f, 0.06598548f, -0.25628197f, 0.08564353f, 
    -0.01463703f, 0.12378077f, 0.04672003f, 0.15365528f, -0.02711154f, 0.01088668f, 0.03365661f, -0.01024809f, 
    -0.02558819f, -0.04944325f, 0.04055624f, 0.10246471f, -0.03067409f, -0.01398632f, -0.03495568f, -0.03465617f, 
    0.01180186f, -0.07107776f, -0.11906397f, 0.10598387f, 0.03037696f, 0.06258614f, -0.07878140f, 0.01320923f, 
    0.03123423f, -0.15873496f, -0.07603486f, 0.05932584f, 0.06424228f, 0.04759651f, -0.07341574f, 0.04437708f, 
    -0.11803181f, -0.02572343f, 0.02193745f, 0.03691957f, -0.05526659f, 0.00655372f, -0.00393260f, 0.03788216f, 
    -0.07240256f, -0.03965716f, -0.05232488f, 0.10679033f, 0.17204328f, -0.24437112f, -0.09910088f, 0.14358018f, 
    0.00401686f, 0.13824505f, -0.01786722f, -0.02588513f, 0.18110548f, -0.03913092f, -0.02428065f, 0.06868762f, 
    0.14900841f, 0.20041932f, -0.09028082f, -0.03212821f, 0.18242699f, -0.18982263f, -0.08836427f, 0.01506691f, 
    -0.06650782f, 0.05511932f, 0.09245473f, 0.06357779f, -0.19794457f, -0.05714110f, -0.06611001f, 0.28280753f, 
    -0.01308555f, 0.18313664f, -0.00501969f, 0.18056719f, 0.04647027f, 0.09405258f, -0.10190949f, 0.09078841f, 
    0.35046133f, -0.15322874f, -0.09151644f, -0.10179435f, 0.00235291f, -0.08615197f, 0.26085892f, 0.05230572f, 
    0.13065004f, -0.02714462f, 0.05797245f, -0.03505371f, -0.12582459f, -0.14171147f, 0.00858251f, 0.08868349f, 
    0.02014702f, 0.13242786f, 0.05696774f, 0.06831443f, -0.01696230f, 0.11927500f, -0.03803816f, -0.00079326f, 
    -0.10180008f, 0.09607733f, 0.01938741f, 0.05431071f, -0.02097424f, -0.10468388f, -0.00467531f, 0.08837774f, 
    -0.08453622f, 0.01791122f, 0.05860173f, -0.00557885f, 0.23255096f, -0.10732942f, 0.02525746f, -0.26783550f, 
    0.07370173f, 0.03504198f, -0.21999754f, 0.07887487f, -0.07852322f, -0.03487607f, 0.08168784f, -0.04352136f, 
    0.17226067f, 0.07218777f, -0.35329980f, -0.20485254f, -0.00285145f, -0.06849710f, -0.10991709f, 0.03481348f, 
    -0.03160724f, -0.05560349f, 0.08344056f, 0.05941604f, -0.05473559f, 0.03506457f, -0.20384407f, 0.16020381f, 
    0.05355282f, 0.04701225f, -0.04310136f, -0.05817498f, -0.05479445f, 0.16709685f, 0.00415136f, -0.12935129f, 
    0.35828295f, -0.04147355f, 0.02606271f, -0.16031110f, -0.01414102f, 0.03441162f, 0.23757729f, -0.06061646f, 
    0.09013704f, -0.20017152f, -0.02776953f, -0.06172651f, 0.30994758f, 0.22129503f, -0.12844832f, -0.04373610f, 
    0.03827820f, 0.06938601f, 0.06661849f, 0.19851869f, 0.05998005f, -0.01885805f, -0.01935978f, 0.00127853f, 
    -0.18830451f, -0.34486508f, 0.12480542f, 0.03495887f, -0.04215887f, 0.07774112f, -0.02631181f, 0.02311799f, 
    -0.08426540f, 0.07553012f, 0.02228715f, 0.11984155f, -0.09373014f, -0.01108623f, -0.01614344f, 0.00309644f, 
    -0.05308300f, 0.03994159f, -0.00225954f, -0.07946920f, 0.01145408f, -0.04088376f, 0.06090289f, 0.01488291f, 
    -0.08952929f, 0.03738799f, -0.08717556f, -0.08904370f, -0.10235542f, -0.05124552f, 0.15456624f, -0.26278391f, 
    -0.12910289f, 0.14358541f, -0.02277366f, -0.01747084f, -0.08401658f, -0.42924646f, -0.12144160f, 0.13457774f, 
    0.03850300f, -0.06118526f, -0.06394171f, -0.12054132f, 0.02802043f, 0.00949966f, 0.03206510f, -0.01235701f, 
    0.18060903f, 0.18408899f, -0.07651620f, -0.06937403f, 0.16505997f, 0.07751692f, 0.05993939f, 0.03069193f, 
    -0.07663333f, -0.09343963f, -0.07300132f, 0.01446495f, 0.02274774f, -0.07186378f, 0.00627565f, 0.02072303f, 
    0.04048460f, 0.13902903f, 0.11564875f, -0.04005663f, -0.05080255f, -0.02218160f, -0.06718353f, 0.02662249f, 
    0.11147228f, 0.05812269f, -0.18823305f, -0.31159219f, -0.10244453f, 0.04793951f, -0.08036257f, 0.03785532f, 
    0.08461197f, -0.03536941f, 0.03727722f, -0.01442966f, -0.08121388f, 0.01912094f, 0.10494183f, 0.05987237f, 
    0.00827003f, 0.03824719f, -0.09158956f, 0.04069172f, 0.15191133f, 0.08004967f, 0.05151490f, -0.03264240f, 
    0.02080606f, -0.03073242f, -0.25995734f, -0.13167115f, 0.11865934f, 0.20057578f, -0.11991302f, -0.02401173f, 
    -0.12728733f, -0.05364005f, -0.13119933f, -0.05093235f, 0.02628833f, -0.00198361f, -0.22964461f, -0.15202425f, 
    0.11586662f, 0.07040834f, 0.06314395f, -0.00137784f, 0.09449700f, -0.00515049f, -0.04804695f, 0.05793458f, 
    -0.09169320f, -0.01796563f, -0.07923400f, 0.06390961f, 0.00018086f, -0.02432548f, -0.00948800f, 0.03540481f, 
    -0.01870031f, 0.09632915f, -0.01245574f, 0.08598237f, 0.02171026f, 0.16128793f, -0.07427517f, -0.06642114f, 
    -0.04703008f, -0.05798818f, -0.00934924f, 0.04448859f, -0.13276917f, -0.06432480f, -0.04073988f, -0.00535366f, 
    0.06742353f, 0.33570811f, -0.14628419f, -0.02362296f, -0.01925240f, 0.16780773f, -0.07242135f, 0.08722314f, 
    -0.03921168f, 0.00283644f, -0.07802016f, -0.02485084f, 0.18819332f, -0.03238675f, -0.11975227f, -0.16611360f, 
    0.02901087f, 0.01969279f, 0.08964693f, 0.02095013f, 0.02088595f, 0.03000564f, 0.17054000f, 0.08692029f, 
    0.08256170f, 0.03989695f, -0.02283109f, 0.07930449f, -0.01493351f, 0.26897785f, -0.00124553f, 0.18131882f, 
    -0.07434838f, -0.03305073f, 0.03879189f, -0.01704117f, -0.01394663f, -0.02547017f, -0.15899649f, 0.01219236f, 
    0.04385283f, -0.11029386f, 0.07923619f, -0.01784849f, 0.27278906f, 0.02095439f, 0.07282165f, 0.04926189f, 
    0.08430199f, 0.30054823f, 0.10637121f, -0.33416903f, -0.01744790f, 0.05141217f, -0.04383308f, -0.03931595f, 
    0.05580825f, 0.07041457f, 0.16397211f, -0.08228838f, 0.18929715f, 0.14321299f, -0.01944160f, -0.31332183f, 
    0.14759767f, 0.01501643f, -0.09185567f, 0.05914678f, 0.00235705f, -0.09410811f, -0.12815058f, 0.05513121f, 
    -0.11151683f, -0.10958645f, 0.17185009f, 0.05994148f, 0.02947417f, -0.08382120f, 0.01043153f, 0.00681464f, 
    0.01302581f, -0.05289430f, 0.02945530f, 0.05385230f, 0.22565432f, -0.19059063f, 0.07787845f, 0.06069122f, 
    0.05756785f, 0.11448120f, 0.22669844f, 0.03598114f, -0.00812557f, -0.07922684f, 0.05940652f, 0.02926253f, 
    -0.09623893f, 0.08257487f, -0.00533885f, -0.03251678f, -0.01045551f, -0.00401801f, -0.06471349f, 0.01743521f, 
    -0.04234503f, 0.04641727f, -0.02834942f, 0.09027281f, -0.11575118f, 0.13349497f, 0.10884552f, 0.19658141f, 
    0.02866955f, -0.13942145f, -0.05107697f, -0.02400262f, -0.01368112f, -0.06297991f, 0.04451236f, 0.03831999f, 
    -0.21067077f, 0.08185893f, 0.21912035f, 0.44305795f, -0.07349651f, 0.03699114f, 0.10402270f, 0.17578322f, 
    0.03838016f, 0.08732177f, 0.23543128f, 0.24206078f, 0.21818295f, 0.07190134f, -0.01916807f, -0.04839738f, 
    0.01932317f, 0.13723275f, 0.16991292f, 0.16714387f, 0.15220648f, 0.10460645f, 0.07440190f, 0.08950116f, 
    -0.13525489f, -0.04769763f, 0.03215326f, -0.00471927f, -0.00942483f, 0.09226999f, 0.13589878f, 0.07676890f, 
    0.02295130f, 0.02769882f, 0.02283122f, 0.02830319f, -0.06360695f, 0.24950083f, 0.11184887f, 0.11191541f, 
    0.01479870f, 0.01738334f, 0.19210018f, 0.11134879f, 0.06045276f, 0.01745621f, 0.02585580f, 0.05707792f, 
    -0.07155871f, -0.06084433f, -0.34257966f, -0.01293676f, -0.10744449f, 0.14832531f, 0.13333906f, 0.29447755f, 
    -0.01349845f, -0.02732779f, -0.08323351f, 0.04322867f, 0.15470706f, 0.20145707f, -0.09366538f, 0.06685671f, 
    0.09220054f, 0.13873921f, 0.02793318f, 0.00792817f, 0.04497567f, 0.05920647f, -0.00653428f, -0.04960417f, 
    0.15339845f, 0.00989484f, -0.08330279f, -0.16036598f, 0.00135291f, -0.05645940f, -0.02484754f, -0.15045294f, 
    0.28566140f, 0.15180597f, 0.06681909f, 0.08046708f, -0.07095236f, 0.15896469f, 0.31036207f, 0.24196738f, 
    -0.03962177f, -0.00917571f, 0.10538434f, 0.14157204f, -0.01641298f, 0.05311528f, 0.16223891f, 0.12623453f, 
    -0.00399212f, -0.04947463f, -0.06460798f, -0.05200932f, 0.08925541f, -0.09167373f, 0.01067936f, 0.02756136f, 
    0.12718867f, 0.10691682f, 0.07489227f, 0.11280493f, 0.01108999f, 0.06637473f, -0.00012883f, -0.04260389f, 
    0.01211844f, 0.00390171f, -0.02699172f, -0.07705494f, 0.05044562f, 0.02178772f, -0.00080967f, -0.03137847f, 
    0.38330728f, -0.05543268f, -0.14325498f, 0.05767318f, 0.15200731f, 0.03392936f, 0.06975891f, 0.14253229f, 
    -0.05050761f, 0.02827026f, 0.02174356f, 0.06635684f, 0.08822734f, -0.00456264f, 0.01428259f, -0.06023826f, 
    -0.00325357f, 0.15209721f, 0.16060771f, -0.06869593f, 0.14686160f, 0.01990836f, 0.04150104f, 0.09494659f, 
    0.00597548f, -0.02523990f, 0.02926161f, 0.07610576f, 0.06428569f, 0.03792910f, 0.11979382f, 0.15987088f, 
    0.00939257f, 0.11426501f, 0.02741430f, 0.06137852f, 0.05362167f, -0.12156831f, -0.14627020f, -0.15833443f, 
    0.01872934f, 0.06183702f, 0.12683304f, 0.15379171f, 0.05165628f, 0.02993979f, 0.03474943f, 0.02188415f, 
    0.05287713f, -0.18368205f, -0.13494137f, -0.05879004f, 0.02012758f, -0.09821469f, -0.05955085f, 0.08018905f, 
    -0.00133646f, -0.08777878f, -0.02086055f, -0.02909509f, 0.10487263f, 0.20583020f, 0.11336781f, 0.07959333f, 
    -0.02222053f, -0.01910078f, 0.14500874f, 0.11856317f, -0.01925790f, 0.06547596f, -0.03691119f, -0.02196401f, 
    -0.12723066f, -0.16018213f, -0.08383229f, -0.09053691f, -0.03190222f, -0.12112967f, 0.21913739f, 0.17569143f, 
    -0.05281841f, 0.05724763f, 0.13566327f, 0.17837936f, -0.04742712f, 0.11062669f, 0.01949584f, 0.05925225f, 
    -0.04346951f, 0.10571817f, 0.03007353f, 0.08069462f, 0.00419667f, -0.00679691f, 0.04828766f, -0.06981813f, 
    -0.04736999f, 0.09279835f, -0.04014698f, -0.02003333f, 0.00291268f, -0.03222886f, -0.01473926f, -0.10442156f, 
    0.11993019f, 0.03945160f, 0.13052966f, 0.27491584f, 0.07497087f, -0.18052535f, -0.18902165f, -0.00171139f, 
    -0.01305940f, -0.06970993f, -0.04849831f, 0.01458623f, 0.16483949f, 0.18922451f, 0.18472004f, 0.21333407f, 
    0.24862809f, -0.08465900f, 0.07072775f, -0.28042912f, 0.16746293f, 0.00569374f, 0.06949279f, 0.03791151f, 
    0.07918220f, -0.00672717f, 0.23819180f, 0.22232759f, -0.07114239f, -0.00155136f, 0.01454298f, 0.21032530f, 
    -0.03445856f, 0.07296491f, 0.24973606f, 0.08165434f, -0.06690852f, 0.17081316f, 0.22928683f, 0.11487064f, 
    0.28399250f, -0.25871852f, 0.29852787f, 0.04227362f, -0.02370352f, -0.04086616f, 0.12966686f, -0.00888282f, 
    -0.04885695f, 0.11192708f, 0.03228135f, 0.05869402f, -0.07036886f, 0.14619626f, 0.04119385f, 0.01954854f, 
    -0.02968816f, 0.03887410f, 0.13133571f, 0.10175233f, -0.01740108f, 0.12165401f, 0.19916040f, 0.05604755f, 
    0.24866611f, -0.13035519f, -0.07556394f, -0.16409811f, 0.29830608f, 0.12816271f, 0.08195413f, 0.09608564f, 
    -0.00851495f, 0.00771652f, -0.06138700f, 0.09982292f, 0.11493705f, -0.14226882f, 0.13060236f, 0.15080842f, 
    0.13641904f, 0.02362262f, -0.05681324f, 0.07071264f, 0.05231111f, -0.01296034f, -0.02298637f, -0.03383691f, 
    -0.07490697f, 0.13420914f, 0.01373295f, 0.13858913f, 0.05628464f, -0.02668039f, 0.14683664f, 0.09947208f, 
    0.05039585f, 0.04965150f, -0.07498386f, 0.02157767f, 0.16477451f, -0.13979769f, 0.07300727f, -0.02780834f, 
    0.05091874f, -0.03463496f, 0.08497339f, 0.04004333f, -0.03787087f, -0.01007704f, 0.02597400f, -0.02081343f, 
    0.01228891f, 0.02950351f, -0.05163414f, -0.07010612f, 0.00584064f, -0.02526315f, -0.01322044f, -0.04813456f, 
    -0.06417014f, 0.11877977f, 0.01056482f, 0.05883262f, -0.00578679f, 0.04921402f, -0.07165150f, -0.06804176f, 
    -0.04036064f, 0.09434114f, 0.08434108f, -0.00639692f, 0.00820755f, -0.00064266f, 0.07449172f, 0.06582522f, 
    0.05071647f, 0.09618160f, 0.03063271f, -0.07386035f, -0.04077888f, 0.03758504f, -0.05067417f, -0.08436923f, 
    0.00499174f, 0.12433186f, 0.05215723f, 0.04377140f, -0.25933382f, 0.02447662f, 0.06608127f, -0.02907814f, 
    -0.05459066f, 0.00484001f, 0.06538824f, 0.20832729f, -0.09202157f, 0.09646879f, 0.20436698f, 0.00961902f, 
    -0.17508359f, 0.15744521f, -0.07673784f, 0.15053555f, -0.07969509f, 0.05460872f, 0.05543080f, 0.04648117f, 
    0.17108887f, 0.19665822f, 0.17282304f, 0.24715091f, 0.50850677f, -0.29106832f, 0.09558254f, -0.11364791f, 
    -0.01651550f, 0.00041717f, 0.03188699f, 0.00243374f, 0.01782475f, 0.13828249f, 0.22500555f, 0.10179263f, 
    0.31398442f, 0.08963491f, -0.18112281f, 0.02593243f, 0.08337218f, 0.17869253f, 0.17244406f, 0.08860615f, 
    0.06036188f, 0.00273287f, -0.12475352f, 0.11783810f, 0.30596483f, 0.02066467f, -0.06938226f, -0.06014598f, 
    0.03970595f, 0.00913921f, -0.10193462f, -0.03474969f, 0.32843620f, 0.09704282f, 0.20984706f, 0.26801419f, 
    0.08683606f, 0.06204325f, 0.04483470f, -0.02697322f, -0.07713691f, -0.00205228f, -0.03512265f, -0.07837791f, 
    -0.00711486f, 0.02530172f, 0.03606915f, -0.00061569f, -0.25721809f, 0.14206228f, 0.06921773f, 0.28691101f, 
    0.02462795f, 0.17387250f, 0.33278865f, 0.10982934f, -0.10336363f, 0.07247268f, 0.00615827f, 0.00614574f, 
    -0.15437233f, -0.14216284f, -0.16669790f, 0.04174968f, 0.07415796f, 0.13048789f, 0.18499368f, 0.28026232f, 
    0.01995752f, -0.00492749f, -0.05273075f, -0.06350475f, 0.18450449f, -0.11165339f, -0.01587229f, -0.05567494f, 
    0.15123808f, -0.04971207f, 0.04159271f, -0.05202429f, 0.08666819f, 0.00282137f, 0.04502843f, 0.05189834f, 
    0.25665942f, 0.15845285f, -0.27483505f, 0.08577306f, 0.19836499f, 0.14667173f, -0.09245976f, 0.19096577f, 
    0.07415441f, 0.12891237f, 0.04646750f, 0.15682143f, 0.61473870f, -0.16869329f, 0.04444685f, -0.00992021f, 
    0.12888803f, 0.02198551f, 0.11160918f, -0.16510202f, 0.10118572f, 0.07021535f, 0.00954647f, -0.03474328f, 
    -0.20014751f, 0.22595829f, 0.08811667f, 0.09634144f, 0.05273093f, 0.05504697f, 0.06010509f, 0.31064424f, 
    -0.04252290f, 0.12758999f, 0.22024648f, 0.10590106f, 0.01549687f, 0.07551935f, 0.06878015f, 0.02371990f, 
    -0.01693376f, -0.06485600f, 0.04385005f, -0.06209638f, 0.03145729f, 0.04922424f, 0.01858241f, 0.10659844f, 
    0.01183322f, 0.05852570f, 0.00396109f, 0.01752313f, 0.17269973f, 0.03154115f, -0.09895770f, 0.14093158f, 
    0.05804111f, -0.03751024f, -0.00092151f, -0.05286418f, -0.13332887f, 0.04540764f, 0.31845322f, 0.02370116f, 
    0.03467858f, -0.00786549f, 0.04069899f, 0.33055025f, -0.00278892f, 0.01777628f, 0.02106170f, -0.00986240f, 
    0.02297433f, -0.11082141f, -0.06860992f, -0.08906636f, 0.00165818f, 0.06247388f, 0.24790478f, 0.14963652f, 
    -0.03155713f, -0.03291706f, -0.02659694f, 0.01956281f, -0.03779702f, -0.04626150f, -0.04103896f, -0.06176135f, 
    -0.01468657f, -0.07376767f, -0.01453427f, -0.03570078f, 0.21988966f, 0.13291360f, -0.01116520f, -0.01944626f, 
    -0.04916042f, -0.19256544f, -0.12967776f, 0.23069257f, -0.00690217f, 0.04214014f, 0.24853374f, 0.19100319f, 
    0.01552518f, 0.01011230f, 0.06533892f, -0.02141767f, 0.01537995f, 0.00578161f, 0.02916032f, 0.02923105f, 
    0.00436760f, 0.03229527f, 0.12110163f, 0.04621348f, 0.02710800f, 0.10973103f, 0.15920281f, 0.10683288f, 
    -0.02152865f, -0.07069995f, -0.09761735f, 0.06327403f, -0.01403201f, -0.25252330f, 0.20532916f, 0.03135743f, 
    -0.06160058f, -0.03221071f, 0.13425772f, 0.01565192f, 0.19115369f, -0.08552998f, 0.00417051f, 0.11478405f, 
    0.05664042f, -0.15626119f, 0.05376748f, 0.20010006f, -0.00499590f, 0.00784382f, 0.11601574f, 0.00291411f, 
    0.09045777f, -0.03455092f, 0.00336936f, -0.03766211f, 0.03769381f, -0.00236081f, 0.02211011f, -0.05548970f, 
    0.03174081f, 0.09498687f, -0.03116990f, -0.04775728f, 0.14745291f, -0.10788196f, -0.02296385f, -0.06065310f, 
    0.03505317f, 0.01154078f, 0.02110856f, -0.04086507f, 0.18634488f, 0.18651254f, 0.11622420f, 0.09690511f, 
    0.14560154f, -0.10649439f, -0.01733251f, -0.03244833f, 0.07314385f, 0.11155499f, 0.14925145f, 0.17699754f, 
    -0.04789242f, -0.08986089f, -0.11649603f, 0.04065459f, 0.11092468f, 0.02243490f, 0.01076581f, -0.09932182f, 
    0.06544355f, 0.03918785f, -0.07032976f, -0.08864101f, 0.15505186f, 0.27010953f, -0.08552603f, 0.00187568f, 
    0.13639942f, -0.09444802f, -0.01128828f, -0.16286448f, -0.03608634f, 0.01216501f, -0.03973125f, 0.05648147f, 
    0.04415790f, 0.11551863f, 0.01569225f, -0.01104437f, 0.05528634f, 0.00299759f, 0.21143213f, 0.05666857f, 
    0.00699715f, 0.03314765f, 0.10165359f, 0.10601929f, 0.10160416f, 0.03447876f, 0.10685890f, 0.08282139f, 
    0.63272589f, 0.10868930f, -0.09818723f, -0.06951068f, 0.29864192f, -0.04819894f, 0.03434537f, -0.13763477f, 
    0.09607453f, 0.11672275f, 0.09962098f, -0.01872725f, 0.01426226f, -0.11900710f, -0.03476040f, 0.10478232f, 
    0.20123783f, 0.03820089f, 0.08450023f, 0.05768829f, -0.01652789f, -0.06414484f, -0.09715237f, 0.01444949f, 
    0.01098987f, 0.12051467f, 0.02378455f, 0.03192826f, -0.03273621f, 0.06132082f, 0.02458045f, 0.01100134f, 
    -0.00759849f, 0.08980355f, 0.03460117f, -0.00166920f, 0.10576125f, -0.03168284f, -0.27721083f, -0.03685950f, 
    -0.05572901f, 0.09915172f, 0.17484584f, 0.17018850f, -0.11410361f, 0.06519933f, 0.01393301f, 0.11587607f, 
    0.22670391f, 0.11266658f, 0.20560126f, 0.15396610f, -0.02822830f, -0.04039223f, 0.00072983f, -0.02868048f, 
    -0.00320883f, 0.09634452f, 0.12336785f, 0.11949336f, 0.10280126f, 0.02403376f, -0.01745445f, -0.10662939f, 
    -0.08334196f, 0.03388166f, 0.04049177f, -0.02061926f, 0.03743493f, 0.03565761f, -0.00338499f, -0.05920660f, 
    0.30775815f, -0.05559343f, -0.31763795f, -0.17191917f, 0.06141756f, -0.01968991f, 0.05737600f, 0.07302663f, 
    0.07159223f, -0.11329327f, -0.11678091f, -0.01157901f, -0.41994631f, 0.08954231f, -0.02597265f, -0.10670985f, 
    -0.01068721f, -0.05870234f, -0.03327623f, 0.01917791f, 0.05414854f, -0.01335837f, -0.04634483f, -0.02847979f, 
    -0.02644649f, 0.07732150f, -0.14192346f, 0.00838359f, 0.22596656f, 0.09647484f, 0.07497405f, -0.05788628f, 
    -0.03730211f, -0.04175853f, 0.01089703f, 0.01741086f, 0.10420923f, 0.18815610f, 0.03530992f, -0.20535360f, 
    0.04672354f, 0.02201378f, 0.02118826f, -0.02029607f, -0.09378528f, -0.02810645f, 0.05456131f, -0.04457441f, 
    0.13286151f, 0.12030874f, 0.00605231f, -0.14369737f, 0.04973480f, -0.00698655f, -0.00303763f, 0.13034923f, 
    0.07017665f, -0.00339911f, 0.06499181f, -0.05427299f, 0.02701751f, -0.16391651f, 0.29593065f, 0.00984791f, 
    0.16348776f, 0.09993365f, 0.18374582f, 0.06078325f, 0.11669193f, -0.02969637f, 0.04747115f, 0.00571006f, 
    0.03648637f, 0.00828929f, 0.14624551f, 0.08949984f, -0.02890248f, -0.05727243f, -0.00858906f, 0.04657573f, 
    0.05841112f, -0.04159866f, -0.00851463f, 0.14896263f, 0.29351920f, -0.34723485f, -0.10467626f, -0.17563888f, 
    -0.06780657f, 0.00236738f, -0.06520778f, 0.06370164f, 0.10545249f, 0.01917159f, -0.05199106f, -0.00660743f, 
    0.18458802f, -0.00812247f, 0.05830089f, -0.08287397f, -0.03245128f, -0.09631677f, -0.04867391f, 0.02761566f, 
    0.05776340f, 0.00257133f, -0.05413665f, -0.13499789f, 0.05158449f, 0.04304870f, 0.10588497f, 0.13588805f, 
    0.04095978f, -0.01510986f, 0.02950106f, -0.04539091f, 0.00668147f, -0.01036862f, 0.13703911f, 0.13554183f, 
    -0.14190018f, 0.12382567f, 0.03301570f, 0.08104723f, -0.10472280f, -0.04934016f, -0.04567953f, -0.02090584f, 
    0.03911987f, 0.03854766f, 0.12842891f, 0.02290760f, -0.34084240f, -0.04046420f, -0.14036326f, -0.24701031f, 
    -0.11449888f, -0.14554809f, -0.07687747f, 0.05946685f, -0.04479675f, 0.01475116f, -0.04146754f, -0.08464842f, 
    -0.12681459f, 0.13615817f, -0.09126227f, -0.17589511f, -0.06061647f, 0.05620718f, 0.07831990f, -0.11381742f, 
    -0.02413077f, -0.07654722f, -0.02436780f, -0.01029292f, -0.06663529f, 0.20446995f, 0.07694315f, -0.08923748f, 
    -0.00451286f, 0.05343607f, 0.07800753f, 0.12729600f, 0.04663204f, -0.04497204f, -0.05212824f, -0.01053658f, 
    0.04340989f, 0.10519291f, 0.08940724f, 0.01420056f, -0.01524488f, 0.08050410f, 0.07011069f, 0.03302485f, 
    -0.00014861f, 0.08163416f, 0.08784983f, 0.04534682f, -0.00484240f, -0.13560246f, -0.10307841f, -0.11629298f, 
    0.13827541f, 0.01967414f, -0.09805203f, 0.01845484f, 0.03432398f, 0.01645736f, 0.01984495f, -0.06481297f, 
    0.27127570f, 0.08624610f, -0.00289984f, -0.13428119f, 0.06726021f, 0.10866586f, -0.20076796f, 0.02622942f, 
    0.08333237f, -0.06075092f, 0.03936406f, -0.14160705f, -0.09261469f, 0.00294388f, 0.04894504f, 0.07080605f, 
    0.23315665f, 0.02858360f, -0.02010144f, -0.02437004f, 0.05264642f, -0.12127540f, 0.05002599f, -0.00577729f, 
    0.33032843f, -0.26180929f, 0.41375646f, 0.32648563f, -0.03126477f, -0.00462851f, -0.02170506f, 0.07760628f, 
    0.09757871f, 0.06217584f, -0.06417257f, -0.10622572f, -0.15020840f, 0.12297986f, -0.13515896f, -0.12697323f, 
    0.03790870f, 0.04701630f, -0.02094120f, 0.02073670f, 0.08435441f, -0.08636345f, -0.17295627f, -0.13783631f, 
    -0.27704039f, 0.04248811f, 0.04946380f, 0.01751106f, -0.11288357f, -0.03732064f, -0.07407462f, 0.02591202f, 
    -0.06031747f, 0.01879293f, -0.08537669f, -0.05859252f, 0.29395598f, -0.44037637f, 0.01385010f, -0.04267872f, 
    -0.02984339f, -0.06322334f, -0.08452783f, 0.11205460f, 0.15688981f, -0.04286287f, -0.13828181f, -0.00477899f, 
    -0.18762942f, 0.06186599f, 0.12756062f, -0.11945602f, -0.14112037f, -0.10050127f, 0.00511539f, 0.00266189f, 
    0.07693104f, -0.08103518f, 0.07766767f, -0.04061092f, -0.04828976f, 0.01881548f, -0.12478644f, 0.13962092f, 
    0.08910269f, -0.00779408f, 0.00246847f, -0.02380865f, 0.07360695f, -0.08807237f, -0.21288557f, 0.06596565f, 
    0.03861970f, -0.05848291f, 0.23592316f, 0.43307143f, -0.03792811f, 0.01381871f, -0.04257367f, -0.02278599f, 
    0.16004799f, 0.14473192f, 0.00988634f, 0.10112570f, 0.31061444f, -0.33986092f, -0.00717319f, -0.27934924f, 
    0.02284472f, 0.05769208f, -0.11579372f, 0.12267651f, -0.00214162f, 0.00068522f, 0.03324915f, -0.01776757f, 
    -0.07508987f, 0.05935661f, 0.06709702f, -0.11002591f, 0.05358341f, 0.22762011f, -0.11714307f, 0.17386033f, 
    -0.02169338f, -0.04204445f, -0.02953191f, 0.04603246f, -0.01801856f, 0.19573747f, 0.10930509f, -0.05363713f, 
    -0.00366756f, 0.01598686f, 0.06447604f, 0.02854710f, 0.05429865f, 0.07622132f, -0.01601808f, -0.04286592f, 
    0.01306548f, 0.00169688f, 0.07423501f, 0.02139824f, -0.00245628f, -0.01869149f, -0.00970191f, -0.04468297f, 
    0.04462447f, -0.08117293f, -0.02825127f, -0.10076822f, 0.05669178f, -0.03477206f, 0.11106854f, 0.11367738f, 
    -0.03473650f, -0.02270832f, -0.00254527f, 0.02736438f, 0.20945361f, 0.14243133f, -0.06063250f, 0.12988825f, 
    0.02028082f, 0.05135431f, 0.02976331f, 0.15214744f, -0.01358886f, 0.02325416f, 0.00089614f, -0.08655335f, 
    0.08545042f, -0.09279832f, 0.00155757f, 0.04552829f, 0.16046646f, 0.02059501f, -0.04519944f, -0.17277496f, 
    0.01873502f, -0.10374558f, -0.00443536f, 0.01375960f, 0.09039795f, -0.06768166f, -0.12338337f, -0.06564017f, 
    0.04091110f, -0.19147754f, 0.03015595f, -0.08599057f, -0.00053782f, 0.08508553f, -0.05268025f, 0.05609983f, 
    0.18050373f, -0.09455968f, -0.10985292f, -0.10911174f, -0.63331777f, 0.20558766f, 0.05953515f, -0.22001080f, 
    -0.08150709f, -0.12280936f, -0.01607230f, -0.08431998f, 0.12236652f, 0.07987957f, 0.07589675f, -0.08432513f, 
    -0.25921133f, -0.08609496f, 0.10081790f, 0.01654256f, -0.05660495f, -0.09209544f, -0.11005022f, 0.05057830f, 
    -0.03151915f, 0.09209921f, 0.01962230f, -0.07315811f, -0.44606960f, 0.05770592f, 0.12085599f, 0.09053381f, 
    -0.05608178f, -0.00931406f, -0.00959232f, 0.05683059f, 0.01692058f, -0.04831308f, -0.09205878f, -0.16958007f, 
    0.01963435f, -0.06556245f, 0.14748803f, 0.16950420f, 0.07279895f, -0.01605350f, 0.02647045f, 0.03909583f, 
    0.05713997f, 0.03470378f, -0.02014346f, 0.07112799f, -0.08637162f, 0.05973789f, -0.41418621f, 0.00314927f, 
    0.01448817f, -0.03686816f, 0.11538909f, 0.08379632f, 0.03950809f, 0.03380150f, -0.00736805f, 0.07309086f, 
    0.07795601f, 0.22596064f, 0.11749080f, -0.05465747f, -0.03927273f, -0.02568462f, 0.05402879f, 0.08919855f, 
    -0.05111244f, 0.03396547f, 0.02068779f, 0.03631905f, 0.00351631f, -0.00755787f, 0.15961434f, 0.07526990f, 
    -0.18164994f, -0.04312013f, -0.02468949f, 0.04087671f, 0.03917411f, 0.06826247f, -0.04518329f, 0.15094861f, 
    0.08199538f, 0.07351737f, 0.18484859f, 0.13887237f, -0.07762493f, -0.08788642f, 0.05358085f, -0.15375911f, 
    0.10511149f, 0.14652236f, -0.00503071f, 0.03382727f, -0.34282169f, 0.06644136f, 0.23632048f, 0.07763983f, 
    -0.19399098f, 0.01250859f, -0.00473227f, 0.08776158f, -0.03764036f, -0.05873584f, 0.07981446f, -0.00371592f, 
    0.06576054f, 0.05666854f, -0.24546598f, 0.17703167f, 0.11129484f, 0.07073781f, 0.14582138f, -0.00283470f, 
    0.03005168f, -0.16332781f, 0.05042663f, -0.06236678f, 0.11028105f, -0.09744368f, 0.08809017f, 0.04253888f, 
    0.00144814f, -0.00025935f, -0.06856188f, 0.05761277f, 0.04128320f, -0.11990219f, 0.06229511f, -0.05083692f, 
    0.02493751f, -0.11134280f, -0.07056936f, -0.09801486f, 0.04068613f, 0.08924584f, 0.00055711f, 0.07996843f, 
    -0.00090029f, -0.07071312f, -0.00899608f, 0.06287980f, 0.01390230f, 0.27014101f, -0.50212771f, -0.14592594f, 
    0.12466191f, 0.08141451f, 0.18775566f, 0.02828592f, 0.00616403f, -0.01614665f, -0.03161002f, 0.06447919f, 
    0.04929476f, 0.17295557f, 0.10393501f, -0.01450209f, -0.00214839f, -0.01851335f, -0.08862241f, -0.00449364f, 
    0.01200703f, 0.07633139f, 0.05447359f, 0.02413205f, -0.10464915f, 0.03658795f, -0.05750006f, -0.08452298f, 
    -0.01880666f, -0.01895020f, -0.00163064f, 0.04731580f, -0.11402321f, -0.07041991f, -0.04633973f, -0.05544673f, 
    0.09429661f, 0.23600139f, 0.22009902f, -0.12962745f, 0.04792140f, -0.02104275f, 0.01880698f, -0.04546413f, 
    0.06022135f, 0.09128822f, -0.00597196f, 0.05163139f, 0.15677400f, 0.14541717f, 0.16305305f, 0.00863862f, 
    0.05892225f, 0.06156377f, -0.09010668f, 0.10073898f, 0.07430262f, -0.11358859f, -0.02853280f, 0.08492455f, 
    -0.05272203f, 0.05311076f, 0.17514762f, -0.07696403f, -0.11774644f, 0.12936608f, 0.05273837f, -0.10102513f, 
    0.08332404f, -0.04730345f, -0.03002555f, -0.02913535f, 0.13069275f, 0.15862042f, 0.11783877f, -0.21532795f, 
    -0.02171358f, 0.17365904f, 0.04754761f, 0.04064398f, 0.14291926f, 0.01163219f, -0.00240299f, 0.04830188f, 
    -0.11034990f, 0.03896737f, 0.09743401f, 0.13853288f, -0.08365031f, -0.04147339f, -0.01419036f, -0.02832994f, 
    -0.02679995f, -0.09582418f, 0.01034451f, 0.10674405f, -0.11015588f, -0.01490388f, 0.05004432f, 0.06253514f, 
    0.00413862f, -0.01346152f, -0.01391689f, 0.00634954f, -0.04432676f, -0.15150477f, 0.02912793f, -0.10719205f, 
    -0.15282354f, 0.17330664f, 0.06574732f, 0.06684290f, -0.04471398f, -0.06719329f, 0.07066283f, 0.10277649f, 
    0.03494097f, 0.10274160f, 0.07456667f, -0.03815103f, -0.06614912f, -0.03336934f, 0.20178202f, 0.33644378f, 
    -0.13961087f, -0.09192424f, 0.03587695f, 0.05774838f, -0.03352036f, -0.15707849f, 0.10784467f, 0.09844268f, 
    -0.20058596f, 0.05773710f, 0.05095739f, -0.01702017f, -0.10632398f, 0.03623031f, 0.10392500f, -0.00554099f, 
    0.04642380f, -0.05961851f, -0.00785068f, -0.02122864f, 0.41178083f, -0.10635652f, -0.11894982f, 0.12188656f, 
    -0.01859413f, -0.00785547f, -0.04020153f, -0.11644903f, 0.11278271f, -0.07941368f, -0.08496371f, 0.15771778f, 
    -0.46221089f, -0.07138970f, 0.27650529f, 0.08519974f, 0.15902023f, 0.20645586f, -0.03848022f, 0.20138896f, 
    0.03525269f, -0.12463145f, -0.19005792f, 0.23483752f, 0.09331646f, 0.14220145f, 0.14525451f, -0.01464459f, 
    -0.05224364f, -0.06353424f, 0.02377600f, 0.06079480f, 0.10078384f, 0.08768137f, 0.05718741f, 0.10461234f, 
    0.05880646f, -0.00792298f, 0.04650565f, 0.07229098f, 0.11369827f, -0.01469550f, 0.03381436f, 0.00151579f, 
    0.00871797f, 0.04040240f, 0.11724178f, 0.02394288f, 0.06997333f, 0.13456188f, 0.02490137f, -0.09058530f, 
    0.01956486f, 0.05058780f, -0.06672388f, -0.01961867f, 0.03013352f, -0.00840199f, -0.00292174f, 0.00224877f, 
    0.06871679f, -0.10555651f, 0.17907497f, 0.22881792f, 0.01745343f, 0.01560840f, 0.04393847f, -0.00517082f, 
    0.07181931f, -0.08425951f, 0.05196279f, -0.01343681f, -0.07154170f, -0.05648273f, 0.08100498f, 0.10151093f, 
    0.12255419f, 0.02700436f, 0.00909440f, -0.03641104f, -0.04035823f, 0.00999300f, 0.03528522f, -0.01704104f, 
    0.03539975f, -0.00702505f, 0.00940236f, 0.02571500f, 0.00149047f, -0.01688996f, -0.02262045f, -0.03061498f, 
    -0.01077951f, -0.00814796f, 0.01093394f, -0.03304764f, 0.01048855f, -0.03164979f, 0.00110422f, 0.01726481f, 
    -0.00031428f, -0.02110600f, -0.02411260f, 0.00569463f, -0.02295682f, -0.04107741f, -0.02704702f, -0.03466971f, 
    0.02846101f, 0.00473295f, 0.01877668f, 0.00249135f, 0.02634847f, 0.01337938f, -0.02004315f, -0.03707482f, 
    0.01598102f, 0.00333182f, -0.03056800f, -0.01274852f, 0.01057055f, -0.03208231f, 0.00672024f, -0.02024448f, 
    -0.03828436f, -0.03585312f, -0.02020578f, 0.02051482f, -0.01091158f, -0.02499964f, -0.01924465f, -0.02632025f, 
    0.02073839f, -0.01940285f, -0.03372730f, 0.02174381f, -0.02755267f, 0.00024149f, -0.00900145f, -0.03353890f, 
    -0.04129848f, -0.01060736f, 0.00068769f, -0.02787227f, -0.02154542f, -0.00854601f, -0.02035584f, -0.02832318f, 
    -0.01505917f, 0.02755533f, -0.01801796f, 0.02894565f, 0.00381355f, -0.01539803f, 0.02588607f, -0.02893448f, 
    -0.02690941f, -0.03739800f, -0.01403254f, -0.00615640f, -0.02072627f, -0.00982502f, 0.00825225f, 0.00594274f, 
    -0.00512322f, 0.00323662f, -0.01921307f, -0.01316791f, 0.01999837f, 0.01063229f, -0.01542688f, 0.01377380f, 
    -0.02896024f, 0.02934903f, 0.02920674f, 0.00929480f, -0.00539715f, 0.02975226f, 0.00910769f, -0.00163989f, 
    0.00589996f, -0.03411874f, -0.02359104f, -0.02917498f, -0.02444118f, 0.02546883f, -0.00416884f, -0.02171965f, 
    -0.03771975f, -0.03403109f, 0.00203340f, -0.02071678f, 0.00378082f, -0.02319855f, -0.03152213f, -0.04070741f, 
    -0.01085430f, -0.00815502f, 0.00247179f, -0.01905393f, -0.04164573f, 0.01030839f, -0.04166487f, -0.01796637f, 
    -0.01774079f, -0.03364452f, -0.03404615f, 0.00951191f, 0.02781829f, -0.01313949f, -0.00466119f, -0.00417319f, 
    -0.01117610f, -0.02121420f, -0.01514757f, 0.02096977f, 0.00969200f, -0.02413139f, 0.02882080f, -0.02421531f, 
    -0.03892374f, 0.00448988f, -0.00992317f, 0.01064317f, -0.03000742f, -0.01388625f, -0.00151629f, -0.04099921f, 
    -0.01917198f, -0.02987263f, 0.01185112f, -0.00097922f, 0.00447727f, -0.03197468f, -0.01659869f, 0.02617307f, 
    -0.00525602f, -0.00612527f, -0.03532191f, -0.03295307f, -0.02457882f, 0.00479797f, -0.03175776f, 0.02887802f, 
    0.00003179f, -0.00465207f, -0.00063867f, -0.00837878f, -0.00642619f, -0.00983597f, -0.01976026f, -0.02389217f, 
    -0.03438220f, 0.02673197f, 0.02594606f, 0.02096929f, -0.02653260f, -0.00000435f, -0.01407891f, 0.01825003f, 
    -0.00027113f, 0.00556607f, 0.01771138f, 0.02228891f, 0.03027905f, -0.03510922f, -0.02808867f, -0.02819009f, 
    0.01160022f, -0.00138411f, -0.00688131f, -0.01856316f, 0.00945742f, -0.03942695f, -0.02059019f, -0.01642356f, 
    -0.03259228f, 0.02977183f, 0.01269744f, 0.02231741f, -0.00190744f, -0.01130017f, -0.01686110f, 0.00409204f, 
    0.00582799f, 0.00290285f, 0.02009095f, 0.00059410f, 0.00421590f, -0.00199456f, 0.02776318f, 0.02167278f, 
    0.00467085f, -0.01284954f, -0.01399982f, -0.00659153f, 0.01311133f, -0.02758490f, 0.02016335f, 0.00689434f, 
    -0.03080169f, 0.00145256f, 0.01465119f, -0.00409794f, -0.01409534f, 0.02894318f, -0.03634812f, -0.01573843f, 
    0.01446205f, 0.01306096f, 0.01733657f, 0.00112849f, -0.01015631f, 0.01691977f, -0.00682420f, 0.00581212f, 
    0.00960145f, 0.00074247f, -0.02676715f, 0.00255153f, 0.01518296f, 0.00887711f, -0.00805998f, -0.00498893f, 
    0.01558756f, -0.03308894f, -0.04058089f, 0.01394367f, -0.03236430f, 0.00807543f, 0.01155909f, -0.02126018f, 
    -0.00334916f, 0.00376282f, 0.01138480f, -0.02314145f, -0.02662676f, -0.00253069f, -0.03006290f, -0.04007756f, 
    0.01162817f, 0.02404380f, -0.03383781f, -0.02530920f, 0.02667383f, -0.00452480f, 0.00222018f, -0.01934458f, 
    -0.04115088f, 0.01476770f, 0.00006998f, -0.02957659f, -0.01776185f, -0.00927366f, 0.00291532f, -0.00796971f, 
    -0.02519852f, 0.02771071f, -0.03702920f, -0.01964498f, -0.01820606f, -0.02772769f, 0.00135836f, -0.01365693f, 
    0.00031730f, -0.00573145f, -0.02766637f, -0.02810163f, -0.02894037f, -0.02273962f, -0.01396604f, -0.02487625f, 
    -0.01805330f, 0.00610259f, -0.02776288f, -0.02293130f, 0.01815718f, 0.02788435f, -0.01262447f, 0.00135821f, 
    0.00876398f, -0.01007991f, -0.02547003f, 0.02993494f, -0.03792728f, 0.02671384f, 0.01965735f, -0.03617907f, 
    0.02242147f, 0.02365277f, -0.01193244f, -0.03826191f, -0.01482806f, -0.02782756f, 0.02538334f, -0.02082081f, 
    0.00054335f, -0.03568110f, -0.01193843f, -0.03644323f, 0.02569288f, -0.01806665f, 0.01407977f, -0.02240230f, 
    -0.03529824f, 0.00341292f, -0.01265406f, -0.02171863f, -0.01504855f, -0.01485784f, -0.01287747f, -0.01449494f, 
    -0.01813353f, 0.02815844f, -0.00666980f, -0.03329999f, 0.00544589f, -0.00252518f, -0.03888348f, -0.02518682f, 
    -0.02457206f, 0.01610258f, 0.01798763f, 0.00931917f, 0.01781054f, 0.01882578f, -0.03456846f, 0.02746383f, 
    -0.03457945f, -0.02857917f, -0.02019485f, -0.02053419f, -0.03798276f, -0.00963498f, -0.02646022f, 0.02336295f, 
    -0.01175030f, -0.03307392f, -0.00179467f, 0.00897526f, 0.00060689f, 0.02458317f, -0.00710762f, -0.00903881f, 
    0.01899468f, -0.02672122f, 0.01936787f, -0.00503753f, -0.03265955f, -0.03997085f, 0.01541352f, -0.03664634f, 
    0.00619933f, -0.01307330f, 0.01360970f, -0.02762154f, 0.02365442f, 0.00037108f, -0.01176825f, -0.03825941f, 
    -0.02062756f, -0.02064076f, 0.00311555f, 0.00574857f, -0.04005719f, -0.03862916f, 0.01793013f, 0.00982468f, 
    -0.03021974f, -0.00441807f, 0.02037219f, 0.02683314f, -0.01564778f, 0.02471988f, -0.04102973f, -0.02026010f, 
    -0.03400528f, 0.02709812f, -0.03707252f, -0.00019010f, 0.01092121f, 0.02286104f, 0.01784612f, 0.01316338f, 
    -0.00505111f, -0.03503651f, 0.01512606f, 0.00628442f, -0.02602717f, -0.01012327f, -0.02997752f, 0.00871654f, 
    0.00967038f, 0.00424307f, -0.03728515f, -0.04125683f, -0.00435863f, -0.01586607f, 0.01001512f, -0.03280845f, 
    0.00590911f, -0.02763722f, -0.03351976f, -0.02661416f, 0.01976647f, 0.01811901f, 0.01756873f, 0.02452509f, 
    -0.00327626f, 0.01348245f, -0.03899714f, -0.02331624f, -0.03646319f, 0.01523551f, -0.01155935f, -0.03620515f, 
    0.00640948f, 0.02063118f, -0.02601116f, -0.00460162f, -0.01380814f, -0.00545610f, -0.01333145f, -0.02146952f, 
    -0.02546457f, 0.00416071f, -0.03524129f, -0.03101519f, -0.01179933f, -0.00703545f, 0.00048818f, 0.00920675f, 
    0.01886320f, 0.00734743f, 0.00854522f, 0.02503467f, -0.02584748f, -0.02471849f, 0.01939382f, 0.00949946f, 
    0.03383427f, 0.00059021f, -0.02806462f, -0.02394836f, -0.00774341f, -0.03462050f, -0.00646228f, -0.00224260f, 
    -0.00889715f, 0.01362966f, 0.01272404f, -0.03459330f, 0.01997766f, -0.02416303f, 0.01559128f, 0.01287393f, 
    0.01840233f, 0.02338467f, 0.01537540f, -0.02716528f, 0.00413578f, -0.01479624f, -0.04027036f, 0.01785837f, 
    0.00942518f, -0.03051863f, -0.01917023f, -0.02486691f, -0.03350510f, -0.00148829f, -0.03095417f, 0.02711370f, 
    0.02282474f, 0.02879013f, -0.03421306f, -0.01251303f, -0.00448708f, -0.00559961f, -0.03905452f, 0.02355695f, 
    -0.00328217f, -0.03571252f, -0.00527609f, 0.00589909f, 0.00064050f, -0.03779804f, 0.00944002f, 0.01617754f, 
    -0.01998385f, -0.03896059f, -0.00998911f, -0.03041805f, 0.03045350f, -0.03984643f, 0.01037353f, -0.03946875f, 
    -0.00058181f, 0.02995937f, 0.02861259f, -0.02575633f, -0.00564487f, -0.02245707f, -0.03011310f, -0.03409103f, 
    0.00501429f, -0.00705200f, -0.00579172f, 0.01550912f, -0.01321879f, 0.01505064f, 0.00609299f, 0.02130273f, 
    -0.02967095f, -0.02560475f, 0.02427224f, 0.01292028f, -0.02569369f, -0.01421542f, 0.00984220f, 0.02319130f, 
    -0.04038533f, -0.01831507f, 0.01995682f, 0.01798495f, -0.02067108f, -0.02075233f, 0.02083315f, -0.00803692f, 
    -0.01623120f, -0.02548892f, -0.03638371f, -0.02963909f, -0.02210487f, -0.01507026f, 0.00081951f, -0.03229535f, 
    -0.02687799f, -0.03737209f, 0.01960795f, 0.01181861f, -0.00012236f, -0.03151143f, 0.00705679f, -0.01468112f, 
    0.00429096f, -0.03013510f, 0.01005305f, -0.03330518f, -0.03167524f, -0.00727849f, -0.00179034f, 0.02481178f, 
    -0.01392491f, -0.02712227f, -0.00061204f, 0.01909201f, -0.02030595f, -0.00013806f, -0.01154468f, -0.03632919f, 
    0.02438765f, -0.02810754f, -0.01633599f, -0.01401780f, -0.03315176f, 0.03008509f, 0.01057309f, 0.02043807f, 
    0.01493428f, 0.01020410f, -0.02560785f, -0.00337109f, 0.02777054f, 0.01607238f, 0.00241116f, -0.00898393f, 
    0.00759658f, 0.02212851f, 0.02821271f, -0.01607668f, 0.00846208f, 0.02929290f, -0.02890097f, 0.01348423f, 
    -0.01162201f, 0.00195888f, 0.01090549f, -0.01283036f, 0.02684328f, 0.00316368f, 0.01979405f, -0.02287701f, 
    -0.01401572f, 0.02928053f, -0.00338058f, 0.00049969f, -0.04185437f, -0.02654574f, -0.01668351f, -0.03520755f, 
    0.00381648f, -0.02764646f, -0.04144345f, -0.00175955f, 0.01581643f, -0.03731332f, -0.03324685f, -0.04032167f, 
    -0.03278669f, 0.01476502f, -0.03229381f, 0.02061358f, 0.01991775f, -0.02606833f, 0.00798429f, 0.00940850f, 
    0.02680370f, -0.02630834f, -0.02528610f, 0.02406376f, -0.03576569f, 0.00039785f, -0.01169212f, -0.00100209f, 
    0.00483369f, -0.01795960f, -0.00335528f, 0.00978850f, 0.01437519f, -0.01616499f, -0.04036606f, 0.01609196f, 
    0.02477772f, 0.00441214f, -0.01826707f, -0.00285028f, 0.02798901f, 0.03016661f, -0.03069068f, 0.02512468f, 
    0.02385722f, -0.01337926f, -0.02559649f, -0.02173632f, 0.01977221f, 0.00766994f, -0.03299237f, 0.00967096f, 
    0.02099599f, -0.00885526f, 0.00696498f, -0.01663752f, -0.04102414f, -0.00369033f, 0.01450952f, 0.01304799f, 
    0.02684130f, -0.03814412f, 0.01453611f, -0.02165626f, 0.01590772f, -0.03675832f, 0.02345726f, -0.00499727f, 
    -0.00642771f, -0.01453053f, -0.03815389f, 0.01233721f, 0.00072107f, 0.02099683f, -0.03059020f, -0.02037566f, 
    -0.03790450f, -0.02565217f, -0.03045125f, -0.00303545f, -0.00698575f, -0.04069157f, 0.02252830f, 0.00760915f, 
    -0.00464746f, -0.00781012f, -0.00706022f, -0.00426145f, 0.00308077f, 0.01765323f, -0.02359627f, -0.02399976f, 
    0.00959510f, 0.02979952f, -0.00038204f, -0.01089077f, -0.01230339f, 0.00786076f, -0.01088304f, 0.02251869f, 
    -0.02760261f, -0.00927192f, -0.00140411f, -0.01910127f, -0.00470633f, 0.02366119f, 0.00022721f, -0.01940079f, 
    -0.01974848f, 0.02293026f, -0.00809629f, 0.02842829f, -0.03684865f, -0.01742580f, 0.01332238f, -0.03254206f, 
    0.02487801f, 0.02151323f, 0.02909922f, -0.00987077f, -0.01641874f, 0.01679757f, 0.02670329f, 0.01539192f, 
    -0.03211604f, 0.00331599f, -0.02781984f, -0.00439301f, -0.00811503f, -0.02128128f, 0.00659287f, 0.01781484f, 
    0.00612507f, -0.03720231f, 0.00647366f, -0.02036244f, -0.00607985f, -0.02171344f, -0.03855347f, -0.02579354f, 
    0.00835076f, -0.03275498f, -0.03759455f, -0.03818118f, 0.01944120f, -0.00846223f, -0.00012042f, -0.03710635f, 
    -0.02518901f, 0.02318001f, 0.02318930f, -0.01054260f, 0.00100249f, -0.02810095f, 0.02851146f, -0.00629735f, 
    -0.02490741f, 0.02663179f, 0.02670203f, 0.03326418f, -0.02670971f, 0.01871274f, -0.00531750f, 0.01309690f, 
    -0.02959375f, -0.00689504f, -0.00189287f, -0.01867225f, -0.02253183f, 0.02786729f, -0.03774477f, 0.00249505f, 
    -0.00908098f, 0.01823245f, -0.00554905f, 0.00607169f, -0.01336973f, -0.01257551f, -0.03302376f, -0.00023523f, 
    -0.02127316f, 0.00246953f, 0.01883699f, -0.00933197f, 0.00376774f, -0.02270051f, 0.00412478f, 0.00695892f, 
    -0.03127958f, -0.03397969f, 0.00537204f, 0.01520516f, 0.02201854f, -0.01528011f, -0.02121854f, 0.01079889f, 
    0.02243431f, 0.00563218f, -0.01697308f, -0.00457483f, -0.03049758f, -0.01253732f, -0.02579834f, 0.00103218f, 
    0.00816296f, 0.00501624f, -0.00727307f, 0.02753577f, 0.02032841f, -0.00971558f, -0.01439650f, 0.02657912f, 
    -0.00337098f, 0.01056096f, 0.03429077f, 0.00867454f, -0.01702987f, -0.00097551f, 0.01737328f, -0.00326408f, 
    0.00179116f, -0.02667473f, 0.01867894f, 0.00014834f, -0.00290368f, 0.02168871f, 0.00126594f, -0.00468035f, 
    0.02016452f, 0.02301166f, -0.03056493f, 0.02333480f, -0.01123576f, 0.01686160f, 0.00433435f, 0.01110129f, 
    0.02867058f, -0.01758889f, -0.02206145f, -0.01904126f, 0.01918832f, -0.03650889f, 0.03139026f, 0.01723102f, 
    0.01988859f, -0.04037445f, 0.01181427f, -0.02977832f, 0.02362607f, -0.02835364f, -0.00013070f, -0.02624265f, 
    0.01369020f, 0.01382380f, -0.04084441f, -0.01056225f, 0.00511133f, -0.01228205f, 0.02454615f, -0.00537116f, 
    0.00212288f, 0.02285385f, 0.00163384f, 0.01847803f, -0.00163447f, 0.02803240f, -0.01075383f, -0.04315836f, 
    0.01976810f, 0.03488334f, -0.01055429f, 0.01932510f, 0.02107829f, -0.03386939f, 0.00570207f, 0.03655268f, 
    -0.01310898f, 0.03024925f, -0.03192769f, -0.02543420f, 0.02902220f, -0.02037671f, -0.01995073f, 0.00522652f, 
    0.00656782f, -0.04343509f, -0.03682705f, 0.00337851f, -0.00852607f, 0.01938255f, 0.02703611f, 0.00793438f, 
    0.00657771f, 0.01511142f, 0.01765709f, -0.00994136f, -0.00140525f, -0.01688479f, -0.04332517f, 0.02002711f, 
    0.00853072f, -0.01494694f, -0.02936134f, -0.02856912f, 0.00937501f, 0.00854733f, -0.00043545f, -0.00950893f, 
    0.01451401f, -0.00757011f, 0.02541659f, -0.01743201f, 0.00624179f, 0.01408506f, -0.00991635f, -0.00614775f, 
    -0.01798112f, 0.00060917f, -0.00091175f, -0.03246559f, -0.03465167f, 0.00824909f, -0.02116761f, -0.03466773f, 
    -0.00930694f, -0.01943980f, -0.02112375f, 0.00424664f, 0.02780050f, 0.00529103f, -0.01584918f, -0.03831794f, 
    -0.01198813f, -0.00041025f, 0.00098463f, -0.02292922f, -0.02328220f, 0.00432629f, -0.00686414f, 0.01313863f, 
    0.00547687f, -0.01680738f, 0.01235885f, 0.01618032f, -0.01312190f, -0.04049264f, -0.01519455f, -0.02572283f, 
    0.00216153f, -0.02098676f, -0.00441644f, -0.03753541f, 0.00880033f, -0.03731339f, -0.00675436f, -0.03314517f, 
    -0.00083792f, 0.01422924f, 0.00291482f, 0.01580360f, -0.02287389f, -0.03478666f, 0.00603525f, 0.02984204f, 
    -0.01781896f, 0.01432719f, 0.01758601f, 0.02172719f, 0.00614371f, 0.00083614f, -0.03011607f, 0.00572610f, 
    -0.00320130f, -0.00684447f, 0.03707987f, 0.00042417f, 0.00108101f, 0.00397741f, 0.02730568f, -0.02603939f, 
    -0.00461735f, 0.00129132f, -0.02891115f, -0.01993422f, 0.03249314f, 0.01828445f, 0.00939911f, -0.03416165f, 
    -0.02065646f, -0.00249045f, -0.00643679f, -0.02966544f, 0.01774975f, 0.00683386f, -0.03867402f, 0.00351126f, 
    0.01606183f, -0.00790288f, -0.02659277f, 0.01291534f, -0.02674827f, -0.01254119f, 0.02753259f, -0.03082581f, 
    -0.01445855f, -0.02091128f, 0.00074648f, 0.02095075f, -0.00133326f, -0.00591690f, 0.01882244f, 0.02879380f, 
    0.01029620f, 0.02127067f, 0.01481998f, 0.00749116f, 0.00651962f, -0.02563648f, -0.01384464f, 0.01030129f, 
    -0.01989002f, -0.03341959f, -0.01434224f, -0.00334532f, -0.02637715f, -0.02014625f, -0.00166750f, -0.01013792f, 
    0.00475043f, -0.00668642f, -0.01401367f, -0.02389492f, -0.01006115f, -0.04180562f, -0.00225738f, 0.00737646f, 
    -0.00905762f, 0.00889706f, 0.03128484f, -0.03205725f, -0.00717884f, 0.02045024f, -0.00617730f, 0.01105431f, 
    -0.03124553f, -0.02974286f, 0.00506114f, -0.02576454f, -0.01754050f, 0.02393894f, -0.03201314f, -0.04458148f, 
    0.02763036f, -0.02957390f, 0.01600481f, 0.01079171f, -0.03826403f, 0.01052233f, 0.00864132f, -0.02877610f, 
    0.01284090f, -0.01169326f, 0.00192233f, -0.00515405f, 0.01256655f, 0.00086997f, 0.00729041f, -0.00941005f, 
    -0.02074320f, 0.00661828f, -0.00731493f, -0.02327440f, -0.02005081f, -0.01167421f, 0.01957634f, 0.01429419f, 
    0.03013068f, 0.03664061f, 0.01068229f, 0.02652768f, -0.02630604f, -0.00487837f, -0.00194210f, 0.01428221f, 
    -0.00469522f, -0.01843386f, -0.01571874f, 0.03229430f, -0.01127865f, 0.01705673f, -0.01288131f, -0.04553115f, 
    -0.02787060f, -0.03424236f, -0.02026402f, -0.02021024f, 0.02751663f, -0.01888290f, 0.03783474f, -0.02224278f, 
    -0.01435172f, -0.00561915f, -0.03279685f, -0.01005695f, 0.01384320f, 0.03368295f, 0.01448578f, 0.01216827f, 
    0.00686271f, -0.02349957f, -0.01926411f, -0.00482788f, -0.00024216f, -0.02332868f, -0.02562186f, -0.00736665f, 
    0.02820783f, 0.03578813f, 0.02434575f, 0.00181428f, 0.02325388f, -0.01268290f, 0.01520802f, -0.00100105f, 
    -0.01333414f, -0.04601308f, -0.01632986f, -0.00017617f, -0.02744486f, 0.01645575f, -0.01366548f, 0.01732012f, 
    -0.00719721f, 0.00526233f, -0.01504425f, 0.02224098f, -0.01225828f, -0.03169770f, 0.00483418f, -0.00778877f, 
    0.02501251f, 0.02633380f, 0.01661919f, -0.01366510f, -0.02819454f, 0.00034885f, 0.01662556f, 0.01831055f, 
    0.01638852f, -0.02033940f, -0.01629899f, 0.02834753f, -0.02065699f, 0.02513192f, 0.01023158f, -0.02448878f, 
    -0.00305317f, 0.02523765f, 0.00378009f, -0.02840841f, -0.01509198f, -0.01493078f, -0.02476391f, -0.02819957f, 
    -0.03247354f, -0.03776794f, 0.01232282f, -0.02084436f, 0.00963036f, 0.00419680f, -0.04369487f, -0.00734617f, 
    -0.00757636f, 0.03425162f, 0.01221509f, -0.01102852f, 0.03422241f, 0.03951142f, -0.01072865f, -0.02350927f, 
    -0.00385507f, 0.00668193f, -0.00630047f, -0.01851442f, -0.01381377f, 0.02361673f, -0.03941021f, -0.01907940f, 
    -0.00282178f, 0.00499252f, 0.02645848f, 0.00997898f, -0.01869175f, -0.01750536f, -0.00768011f, -0.00126725f, 
    -0.02786086f, 0.00843189f, -0.00807199f, -0.00022804f, -0.00076073f, 0.00223299f, -0.02252749f, 0.01475521f, 
    -0.00966989f, 0.03222941f, 0.02055291f, -0.00087710f, -0.03175990f, -0.02643506f, -0.00656436f, 0.01146346f, 
    -0.02901852f, -0.04133358f, -0.01547883f, 0.00748365f, -0.02404846f, 0.00021729f, 0.02010033f, -0.04063284f, 
    -0.01341547f, 0.01796751f, -0.00067329f, 0.02396067f, -0.01532331f, 0.02882567f, -0.02271001f, -0.03929084f, 
    -0.01348725f, -0.01875152f, -0.02129540f, -0.00349383f, 0.02082588f, -0.04021229f, -0.00885065f, 0.01543121f, 
    -0.03228540f, -0.01208175f, -0.04400993f, -0.00608612f, -0.01504816f, 0.00830983f, -0.00471863f, 0.00894468f, 
    0.02667266f, 0.03377495f, -0.02281212f, 0.00711517f, 0.03191740f, -0.02598631f, 0.02280855f, -0.01897622f, 
    0.03380118f, 0.00073952f, -0.03010513f, 0.00022624f, -0.01451658f, -0.04518020f, 0.00425824f, 0.01179949f, 
    0.00036722f, 0.02447003f, 0.00520010f, 0.00014237f, 0.01213543f, 0.01044688f, -0.00497396f, -0.03632967f, 
    0.01304563f, -0.02403865f, 0.02446918f, -0.02788036f, 0.00371305f, -0.02086437f, -0.03119280f, -0.01242032f, 
    -0.01508990f, 0.01780748f, 0.00988481f, -0.03730749f, -0.01281695f, -0.02907162f, -0.03296160f, 0.02471863f, 
    -0.00143115f, -0.01622536f, -0.02530748f, 0.00665227f, 0.01174648f, -0.02747025f, -0.00178607f, -0.01176262f, 
    -0.01743456f, 0.00487619f, 0.00104489f, 0.02369061f, 0.00424530f, 0.03864190f, -0.01181851f, 0.00010701f, 
    0.02718260f, -0.00884556f, -0.03260479f, -0.01749535f, 0.02540852f, 0.00047125f, 0.02151325f, -0.00583315f, 
    -0.01089788f, -0.03142120f, -0.03882628f, 0.01109881f, 0.00049336f, -0.02259305f, -0.03905308f, 0.01808625f, 
    0.02773565f, -0.02101592f, 0.02111359f, 0.01969817f, 0.02791840f, 0.03776506f, -0.00901809f, -0.00696126f, 
    -0.03348735f, 0.02772648f, -0.00819498f, 0.00227741f, 0.00709507f, -0.04393737f, -0.03740083f, -0.01070447f, 
    -0.01108904f, 0.01616707f, 0.01938838f, -0.01815205f, -0.00348903f, -0.02612896f, -0.02732823f, 0.00013788f, 
    0.02408290f, 0.00819267f, -0.00766885f, -0.01926280f, -0.01868520f, -0.01270353f, 0.00754426f, -0.02305217f, 
    0.00694632f, 0.00900085f, 0.02281001f, -0.03107097f, 0.00436540f, 0.02771258f, -0.00710103f, 0.02379987f, 
    -0.01340860f, 0.02486770f, 0.03890582f, -0.03341766f, -0.01020180f, 0.00652148f, -0.00471078f, -0.04123059f, 
    0.03674986f, -0.02776570f, 0.03508703f, -0.04092005f, 0.00060442f, 0.02100686f, -0.03266944f, -0.00975466f, 
    -0.00519335f, -0.02436596f, -0.01632682f, -0.03771131f, 0.00879117f, -0.03883794f, -0.03793464f, -0.01716763f, 
    -0.02526747f, 0.00678716f, 0.03344437f, -0.02138508f, 0.00281982f, -0.02920741f, -0.02999883f, 0.00119383f, 
    0.00241080f, 0.00677002f, 0.00618813f, -0.02799534f, -0.03183365f, -0.00030201f, 0.02101686f, 0.01932633f, 
    -0.00872936f, 0.02546335f, -0.01949032f, 0.00158219f, 0.02621186f, -0.03453744f, -0.02125000f, -0.01933436f, 
    0.01936053f, -0.01603622f, 0.02405608f, 0.02032109f, -0.02000222f, -0.03010552f, -0.03008984f, 0.02268813f, 
    -0.01301178f, 0.00801109f, -0.03352918f, 0.01205255f, -0.02762173f, -0.03069218f, -0.02196121f, 0.02302039f, 
    -0.01120851f, -0.00862179f, -0.02869982f, -0.04317236f, 0.01425396f, -0.02334899f, -0.01593234f, 0.02101997f, 
    0.03148960f, -0.00969051f, 0.02836706f, 0.01082070f, -0.03187058f, 0.03368611f, -0.00222176f, 0.02800002f, 
    0.02486135f, 0.00490933f, 0.00340940f, 0.01660353f, 0.00890618f, 0.00059856f, -0.00938222f, 0.02312042f, 
    0.00382760f, -0.00665758f, -0.00635714f, 0.00402490f, 0.00011737f, 0.02850434f, -0.01062569f, 0.02724713f, 
    -0.03390004f, 0.00756026f, -0.01805986f, -0.02882203f, 0.03508287f, -0.00413998f, -0.01512763f, -0.01136300f, 
    0.03307270f, -0.00854228f, -0.01930358f, -0.01894882f, -0.02877544f, 0.01737755f, -0.03595706f, 0.01383510f, 
    0.01206306f, -0.01877036f, 0.02398815f, -0.02068827f, -0.03868876f, -0.02395278f, -0.03368768f, 0.01215487f, 
    -0.03931009f, -0.02081434f, -0.00714978f, 0.00208481f, 0.01864180f, 0.00310684f, -0.00440554f, -0.02510509f, 
    -0.00582692f, 0.00002206f, -0.01291647f, 0.01588541f, 0.00819850f, -0.02251972f, 0.02737166f, -0.03134710f, 
    -0.01478968f, -0.00483317f, -0.03807228f, -0.02542038f, -0.01670273f, 0.01986356f, 0.02081638f, -0.00497745f, 
    0.00129180f, 0.00180063f, -0.00336205f, -0.00518642f, 0.02483235f, 0.01613493f, 0.02013564f, 0.01760399f, 
    -0.01533075f, 0.02955828f, -0.03901771f, -0.00748246f, 0.01082014f, -0.02771736f, -0.01957347f, 0.02443136f, 
    0.00325971f, 0.01103612f, 0.02229972f, 0.02473812f, -0.04378824f, 0.00758627f, 0.02385562f, 0.01429296f, 
    -0.02511975f, -0.02531069f, 0.09452211f, -0.52238375f, 0.05274887f, 0.06626033f, 0.02836064f, -0.17120227f, 
    0.07018352f, 0.16092624f, 0.22452532f, 0.05711403f, 0.13819179f, 0.16098213f, 0.03338189f, 0.10084689f, 
    -0.07144395f, -0.06737985f, 0.10822459f, 0.04555475f, 0.05284653f, -0.03500165f, 0.15973470f, 0.28678107f, 
    0.06332042f, -0.07822742f, -0.03875012f, -0.10222888f, 0.04676963f, -0.03044792f, 0.08009031f, 0.08275446f, 
    0.02916078f, 0.04338904f, -0.12171870f, -0.09039199f, 0.31353289f, 0.26365134f, -0.00033223f, -0.05511613f, 
    0.00778892f, -0.11467707f, -0.04452316f, -0.21520607f, 0.15853313f, -0.00810269f, -0.03110899f, 0.00234836f, 
    -0.40884578f, -0.11270836f, 0.29873627f, 0.03551555f, 0.01535762f, -0.10401091f, -0.05117578f, -0.13505398f, 
    -0.01954469f, -0.04623038f, 0.01771758f, 0.01220133f, -0.19924241f, -0.27046683f, 0.00818926f, 0.19432966f, 
    0.07700095f, -0.17517848f, -0.00785245f, -0.02150050f, -0.02910780f, -0.09975974f, 0.01633955f, -0.02506901f, 
    -0.13045453f, 0.06400134f, 0.15218070f, 0.18258339f, 0.02538840f, -0.01522350f, 0.02268529f, 0.06428150f, 
    0.08718878f, 0.19654188f, 0.18419906f, 0.28656852f, -0.24904090f, -0.22548127f, 0.00194771f, -0.30371100f, 
    0.10093558f, 0.05964880f, -0.02069194f, 0.05047361f, -0.04678675f, 0.16128777f, -0.00311627f, -0.07363100f, 
    -0.00733261f, 0.12559199f, 0.09104608f, 0.17534249f, 0.00219613f, 0.06971058f, 0.07527214f, 0.08888970f, 
    0.09387991f, 0.16366538f, -0.03204490f, 0.29952344f, -0.07844970f, -0.03784571f, -0.11511016f, 0.00237270f, 
    0.03640095f, -0.01194456f, 0.00572089f, 0.05746309f, -0.00873150f, 0.00964757f, -0.08005769f, -0.17129472f, 
    -0.12979133f, -0.06459087f, 0.38984427f, 0.07457420f, 0.09444325f, -0.05364462f, 0.05418411f, 0.02065134f, 
    0.03316033f, -0.02986637f, -0.03965272f, -0.01096106f, 0.12527587f, 0.28121090f, 0.15348041f, 0.12887166f, 
    0.08770612f, -0.01160866f, 0.14722244f, 0.09722670f, 0.16498604f, 0.09875066f, 0.12550656f, 0.18387310f, 
    -0.03269204f, 0.01749858f, -0.07014705f, -0.08891041f, 0.19359769f, -0.17933501f, -0.25041783f, -0.07196504f, 
    -0.01730602f, -0.09994013f, -0.06427935f, -0.05790901f, -0.27763870f, -0.13286650f, 0.10239828f, 0.12565446f, 
    -0.14145476f, -0.13547418f, 0.05625469f, -0.09617715f, -0.03871158f, 0.05012224f, 0.01104596f, 0.07275626f, 
    -0.22410326f, -0.12202865f, 0.12925181f, -0.01869840f, -0.05786067f, 0.01817637f, -0.10043412f, -0.19660996f, 
    0.01833102f, -0.01101327f, -0.04240930f, -0.06844747f, -0.09410254f, -0.22673722f, -0.22013687f, 0.12297653f, 
    -0.03230720f, 0.13384184f, 0.11918906f, -0.06395128f, 0.07459977f, -0.03550809f, 0.01022206f, 0.06794815f, 
    0.00849486f, 0.32225791f, 0.17611554f, 0.01516954f, -0.02578323f, -0.09972324f, -0.06016808f, -0.05267546f, 
    -0.14593151f, -0.07488292f, 0.02307045f, 0.09984311f, 0.02527230f, -0.21818243f, -0.06248844f, 0.02103809f, 
    -0.05082021f, 0.10145173f, 0.07157129f, 0.19299315f, -0.04388423f, 0.01241732f, -0.07320512f, -0.03211547f, 
    -0.06220913f, -0.04450515f, -0.13968711f, 0.03397936f, 0.09461699f, 0.01985105f, -0.02318342f, 0.01833618f, 
    -0.14865211f, -0.09040496f, -0.00595595f, 0.20460491f, -0.26296428f, 0.08424778f, 0.22627184f, 0.10794593f, 
    -0.14708534f, -0.04146388f, 0.14871393f, -0.05623281f, 0.03244796f, -0.16213183f, 0.17980082f, 0.27096322f, 
    -0.16724353f, 0.03052321f, 0.07482810f, 0.33942994f, -0.02140584f, 0.03304848f, 0.00002245f, 0.19171824f, 
    0.01111436f, 0.07659712f, 0.16521233f, 0.01113337f, -0.42520532f, 0.22439772f, 0.38982022f, -0.13679650f, 
    0.11943074f, 0.09374177f, -0.16726881f, 0.11691881f, -0.07155987f, 0.01709133f, 0.16420075f, 0.01977193f, 
    0.11042010f, 0.37186477f, 0.15766603f, 0.21603794f, 0.07684565f, -0.03061901f, 0.02829727f, 0.00881438f, 
    0.09497242f, -0.11152007f, -0.10387767f, 0.11958288f, 0.19369771f, 0.05477706f, -0.17651089f, -0.14463209f, 
    -0.00529216f, -0.11132646f, 0.04030247f, -0.04560953f, 0.17415059f, 0.40649521f, 0.26218310f, 0.10153102f, 
    -0.02140425f, -0.34289482f, 0.07450536f, 0.21201588f, 0.00201251f, 0.03516266f, -0.02818021f, 0.06383837f, 
    0.05329280f, 0.11158995f, -0.08801857f, -0.00336010f, -0.30203709f, -0.15495919f, 0.14495924f, 0.11446542f, 
    0.00582121f, -0.00285847f, 0.11901088f, 0.12722485f, -0.04489331f, 0.03399556f, -0.02535766f, 0.03406156f, 
    0.08975597f, -0.21974416f, -0.02530713f, -0.10433258f, 0.08651648f, -0.08310947f, -0.05819224f, -0.01814231f, 
    0.02071412f, -0.13725267f, -0.01219890f, -0.11131908f, -0.06331988f, 0.20247820f, 0.26227611f, 0.04570178f, 
    0.06268166f, -0.01546141f, -0.23180145f, -0.11099643f, 0.17896804f, -0.04890932f, -0.01377455f, 0.00128238f, 
    0.00552543f, -0.08625047f, -0.06580196f, -0.00751424f, 0.02294444f, 0.02130720f, 0.07065118f, 0.01903084f, 
    0.05262258f, 0.03989992f, 0.03274294f, 0.09993429f, -0.04839046f, 0.03518001f, -0.03334230f, -0.08666717f, 
    0.09830011f, 0.03042836f, -0.02663230f, -0.01217632f, -0.04319600f, 0.03427446f, 0.06691090f, -0.05193907f, 
    0.03605101f, -0.08541751f, -0.12066919f, -0.04946544f, 0.06443983f, 0.05209642f, 0.04030479f, 0.06415469f, 
    0.04361311f, 0.00609587f, -0.04918101f, -0.18098466f, 0.28991279f, 0.36832896f, 0.07898767f, -0.04727182f, 
    -0.03932642f, -0.07440877f, -0.03481945f, -0.16588385f, 0.05639437f, 0.15393077f, 0.11454928f, 0.11101578f, 
    0.10435043f, -0.26244077f, -0.06216824f, 0.00997627f, -0.07231209f, -0.08747082f, 0.08976430f, -0.03263727f, 
    0.03758896f, 0.23245010f, 0.09534599f, 0.17189187f, 0.03714296f, 0.55247343f, 0.20450604f, 0.23714446f, 
    0.03872376f, -0.05253752f, -0.11492367f, 0.04687778f, 0.03133652f, -0.20850790f, -0.08596919f, 0.11152281f, 
    -0.27187610f, -0.10553363f, 0.22966982f, 0.10356474f, 0.15649898f, 0.15247715f, -0.15509148f, 0.13488862f, 
    0.10699003f, 0.08038054f, 0.06542119f, 0.03374512f, -0.13225889f, 0.02220558f, 0.12216835f, 0.13244352f, 
    0.05840759f, -0.03622353f, 0.06031299f, 0.01607004f, 0.08709588f, 0.12646726f, 0.24647780f, 0.33106652f, 
    -0.04039633f, -0.05131778f, -0.04342779f, 0.07989669f, 0.14524999f, 0.10737114f, 0.02926133f, 0.06941586f, 
    -0.01573936f, -0.02429671f, -0.06100618f, 0.00580741f, 0.10487770f, -0.18997435f, 0.03725255f, -0.26954609f, 
    0.13124141f, -0.02324846f, 0.03644399f, -0.08742973f, 0.07057655f, 0.06939313f, -0.07563401f, -0.01521522f, 
    -0.16079862f, 0.04531085f, 0.03991454f, -0.06208336f, -0.03472526f, -0.03189766f, 0.00868622f, -0.17671208f, 
    0.05029101f, -0.01206134f, 0.00336984f, 0.03460107f, -0.07129319f, 0.08044314f, -0.10844124f, -0.07190220f, 
    0.02814628f, -0.01611073f, -0.04263649f, 0.11980207f, -0.00693445f, -0.02488836f, -0.05119990f, -0.03943788f, 
    -0.10397953f, -0.43636155f, 0.49538904f, 0.23446450f, -0.00197820f, -0.03888476f, -0.08130909f, 0.02889544f, 
    0.03803565f, 0.02928255f, 0.11689947f, 0.07548145f, -0.36469287f, 0.03230923f, 0.24490087f, 0.24752337f, 
    0.11363883f, -0.06044229f, -0.12981394f, 0.04367037f, 0.28426638f, 0.09005498f, 0.09105341f, 0.07144052f, 
    0.31451398f, -0.02458945f, -0.17234042f, -0.32067949f, -0.11786146f, -0.02100775f, 0.03192438f, -0.09356722f, 
    0.18889655f, 0.07554585f, 0.01241584f, 0.03502654f, 0.06182476f, -0.19191833f, -0.07488924f, -0.02781786f, 
    0.06267643f, 0.09944267f, 0.09396574f, 0.05448971f, -0.07561243f, 0.15215571f, 0.06730963f, -0.06748383f, 
    -0.02076947f, -0.14038846f, -0.04906046f, -0.06342830f, 0.06657201f, 0.03271521f, 0.12264362f, 0.09746362f, 
    0.01347397f, -0.06879778f, -0.05462908f, -0.14286451f, 0.21496519f, -0.00875519f, -0.05794293f, -0.09520727f, 
    0.04575545f, 0.10623536f, -0.05371820f, -0.11182799f, 0.04251616f, -0.00032000f, -0.07750624f, -0.10697122f, 
    -0.32650325f, -0.17850378f, -0.06498753f, -0.07814158f, -0.02943360f, 0.04136175f, -0.01630601f, -0.07790657f, 
    0.02575457f, 0.05717888f, 0.03647530f, 0.06146780f, 0.09175002f, 0.15449506f, 0.08423711f, 0.16423541f, 
    -0.08020943f, 0.00327856f, 0.04311929f, -0.02086534f, 0.16687307f, 0.07411914f, 0.07764082f, 0.12378663f, 
    -0.15661120f, -0.10878909f, 0.15595816f, -0.07090252f, -0.03926553f, 0.05313268f, -0.16444208f, -0.13031861f, 
    -0.17095603f, -0.05338932f, 0.03138590f, -0.00674249f, -0.01914052f, -0.09602931f, -0.14561318f, 0.08643348f, 
    0.06175710f, 0.00634125f, 0.08526483f, 0.02157848f, 0.02694586f, 0.09025407f, -0.06620042f, -0.02563761f, 
    -0.02680394f, 0.37142733f, 0.24247429f, -0.19275652f, 0.00714418f, 0.00220440f, -0.11712172f, 0.07116041f, 
    0.04767837f, -0.03725647f, -0.03571898f, 0.00574984f, 0.14332834f, 0.17881566f, 0.18385948f, 0.21125259f, 
    0.03061003f, -0.08827560f, 0.06050197f, -0.00084839f, -0.07513773f, 0.13843378f, -0.18026258f, 0.00202455f, 
    -0.04195660f, -0.05529295f, -0.17672394f, -0.10447849f, 0.05845025f, 0.00234288f, 0.06497686f, 0.01170537f, 
    -0.01754019f, -0.07923302f, -0.08057564f, -0.16140117f, -0.09095715f, -0.08643018f, -0.05051602f, 0.21457841f, 
    -0.01912011f, 0.00335601f, 0.00619895f, 0.00294209f, 0.38492253f, 0.11913216f, 0.30841711f, 0.30884096f, 
    -0.28772563f, -0.22707194f, -0.12944755f, -0.23828590f, 0.00066061f, -0.14709012f, -0.00041480f, -0.28053579f, 
    -0.01938336f, -0.03656298f, 0.03778884f, 0.04185909f, -0.17061576f, -0.04237407f, 0.03010147f, 0.34551921f, 
    0.07496472f, 0.08341457f, -0.01471373f, -0.06310592f, 0.09214786f, -0.16704750f, -0.07514909f, -0.05739890f, 
    -0.08323299f, 0.33081049f, 0.45268697f, 0.34538952f, 0.10393094f, -0.13844508f, 0.12727480f, 0.06290412f, 
    0.04102026f, 0.00049251f, 0.02035366f, 0.04970327f, -0.21131113f, -0.02291931f, 0.16225740f, 0.01944881f, 
    0.11508597f, -0.03911423f, -0.02524431f, 0.11351865f, -0.20066841f, 0.05440955f, 0.07576463f, -0.02675642f, 
    -0.12851517f, -0.31865484f, -0.25178525f, 0.48028970f, -0.13417810f, -0.08200821f, -0.01386789f, 0.16713229f, 
    -0.04438040f, -0.05988353f, -0.04037096f, 0.00193682f, -0.28254813f, -0.22615899f, -0.13774930f, -0.15027548f, 
    -0.08211634f, -0.03671206f, -0.04619160f, -0.21074733f, -0.03361849f, -0.01572995f, 0.06888363f, -0.01320617f, 
    0.15765753f, -0.11266676f, -0.16683893f, -0.05175513f, 0.04532786f, 0.06508133f, 0.10887466f, 0.04477124f, 
    0.10697245f, 0.04272550f, 0.03874859f, 0.01474816f, -0.23379225f, 0.05802714f, 0.52775913f, -0.01197784f, 
    0.05696437f, 0.03345342f, -0.01351720f, 0.01598691f, 0.11307604f, 0.01093763f, 0.07834610f, 0.07965881f, 
    0.12671442f, -0.12231592f, -0.32116920f, -0.14598155f, -0.04945455f, -0.05393275f, 0.00560774f, 0.06129792f, 
    0.01732574f, -0.03748144f, 0.10620334f, 0.06414277f, -0.05666418f, -0.04563241f, -0.17826913f, 0.01407519f, 
    0.09365041f, 0.10209975f, 0.05670141f, 0.10631087f, 0.06139662f, -0.02900157f, -0.00859926f, -0.00069236f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.03470863f, -0.00928434f, 0.06554961f, 0.12548998f, 0.01124103f, -0.00095754f, 0.09182221f, 0.02984521f, 
    0.09493934f, -0.03161245f, -0.00358135f, -0.08216748f, 0.10630763f, 0.00533168f, 0.02225618f, -0.03646946f, 
    -0.03632154f, 0.01376665f, 0.02325853f, -0.02641536f, 0.00595582f, 0.20413187f, -0.06276394f, 0.15820409f, 
    -0.04782467f, 0.09051695f, 0.04001421f, 0.01221566f, 0.09861439f, -0.03642730f, -0.02995957f, 0.05240117f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.16279936f, 0.09314591f, -0.16420011f, 0.20744693f, -0.05557054f, 0.12543759f, -0.03960881f, 0.07507333f, 
    -0.21338250f, 0.31081378f, -0.17486311f, 0.22896887f, 0.14112195f, 0.03898601f, 0.00802646f, -0.06641062f, 
    0.16883102f, 0.13637021f, -0.17078474f, -0.15498489f, 0.00861891f, -0.41702631f, 0.02317225f, -0.41514742f, 
    0.02229483f, -0.44417867f, 0.40197030f, -0.10758613f, 0.02306218f, -0.11071606f, 0.06049521f, -0.12380097f, 
    0.17106661f, -0.11822675f, -0.29040903f, 0.15675136f, 0.08290730f, 0.03035566f, -0.27683651f, -0.01166948f, 
    0.35012877f, 0.08089499f, -0.02158462f, 0.13035561f, 0.15156399f, -0.13550565f, -0.13889866f, 0.04473483f, 
    0.06830025f, 0.06280438f, 0.11116675f, 0.15808350f, 0.15663216f, 0.58377093f, -0.48404896f, 0.13005832f, 
    -0.08234876f, -0.19945574f, 0.15025260f, -0.19947903f, 0.15711007f, 0.03992108f, -0.01645500f, -0.14481592f, 
    0.01558457f, -0.09710886f, 0.23574172f, 0.11649681f, 0.16560832f, -0.02459935f, -0.47485930f, -0.00372622f, 
    0.03859929f, 0.15148422f, -0.09688570f, -0.55048782f, -0.11195846f, 0.06635917f, -0.01931684f, -0.07954821f, 
    0.06127942f, 0.10574646f, -0.00012602f, 0.05898135f, 0.03793772f, 0.46138248f, 0.11730929f, -0.05949596f, 
    0.09698163f, 0.11105107f, 0.17848741f, -0.22301702f, -0.06317280f, 0.05705804f, -0.13559765f, 0.30850863f, 
    0.18656862f, -0.04254083f, 0.22268952f, -0.36167464f, -0.16370673f, 0.40091303f, -0.17543258f, 0.15978476f, 
    -0.29589495f, 0.17152400f, 0.07210153f, -0.03515798f, -0.22470139f, 0.11571294f, -0.13292651f, 0.12985246f, 
    -0.11354701f, 0.03456479f, -0.05848343f, -0.17027292f, -0.11860661f, -0.27185377f, 0.06293824f, -0.08633247f, 
    0.07223067f, 0.14618084f, -0.04884639f, 0.01754479f, -0.75641257f, 0.03704281f, -0.07334841f, -0.09376132f, 
    -0.03588275f, 0.08605167f, 0.05795483f, 0.23899792f, 0.15938234f, -0.14176545f, -0.20092642f, 0.13125105f, 
    0.20330471f, -0.12093128f, -0.14977908f, 0.22680275f, 0.11302258f, -0.17310730f, -0.15666790f, -0.10960329f, 
    -0.12178110f, -0.08217212f, -0.04903507f, -0.01903958f, 0.05601143f, -0.37860063f, 0.42292231f, -0.25112620f, 
    -0.01661015f, 0.05000855f, -0.23374650f, -0.19579157f, 0.13029628f, 0.04989107f, 0.08029123f, 0.17440443f, 
    0.06152836f, -0.04982597f, 0.09512281f, 0.34274095f, 0.06000209f, -0.10789844f, 0.43190923f, -0.13454108f, 
    -0.48909086f, -0.64008784f, -0.05869038f, 0.16046856f, -0.03822776f, 0.01029152f, -0.06075284f, 0.12557788f, 
    -0.06626192f, -0.13724189f, -0.15839796f, 0.02171788f, -0.02078169f, -0.09109620f, -0.15990956f, 0.10521187f, 
    -0.01825982f, 0.06457686f, -0.08332767f, -0.17895278f, 0.37113404f, -0.01302782f, 0.07589277f, -0.09235871f, 
    -0.46398455f, 0.09886932f, 0.11991959f, -0.51463848f, -0.06342103f, -0.59213209f, 0.33655593f, -0.08114184f, 
    0.28769630f, -0.03328041f, -0.15002501f, -0.65269256f, -0.29458451f, -0.01471618f, 0.10107926f, 0.01658210f, 
    0.05184940f, 0.12155683f, 0.11530048f, 0.01241422f, -0.09019417f, -0.37087721f, -0.46908471f, 0.27621821f, 
    -0.02043817f, -0.17208236f, -0.11448871f, -0.05785293f, -0.01615769f, 0.15617746f, 0.15195803f, 0.45992091f, 
    -0.32858440f, -0.01482319f, 0.06337816f, 0.00486303f, 0.16815160f, -0.08354604f, -0.34990293f, -0.08812993f, 
    -0.27638704f, -0.48066583f, -0.05764230f, -0.38454434f, 0.07718939f, 0.05616777f, -0.15064044f, 0.14255019f, 
    -0.05766450f, 0.12276542f, 0.08685896f, -0.02040118f, -0.01936889f, -0.47534645f, 0.24982244f, 0.12630938f, 
    0.14220066f, -0.09320565f, -0.15772244f, 0.29810047f, -0.11114153f, -0.07103277f, 0.15447219f, -0.27200285f, 
    -0.36312276f, 0.11666247f, -0.48769838f, -0.01496297f, -0.00777047f, 0.08857178f, 0.25915638f, 0.11846601f, 
    -0.54339260f, -0.64973307f, -0.05865525f, -0.39204681f, -0.31674767f, 0.00671526f, 0.04835281f, -0.13894832f, 
    0.02459416f, 0.16995427f, 0.04045736f, -0.15978806f, 0.09044784f, 0.20621082f, -0.23652023f, 0.04661417f, 
    -0.04111644f, 0.34804896f, 0.23597319f, 0.16036613f, 0.02320440f, 0.01736223f, 0.01430059f, -0.42476210f, 
    -0.62546420f, 0.01852120f, 0.20943525f, 0.35699043f, -0.14262381f, -0.37804917f, -0.44654250f, 0.07936132f, 
    -0.25956905f, 0.49295008f, -0.14528598f, 0.12197263f, -0.21837482f, 0.05429172f, -0.14824326f, -0.12664850f, 
    0.03490598f, -0.04283068f, -0.16467147f, -0.12351824f, -0.01598978f, 0.12567392f, -0.08872110f, 0.16405544f, 
    0.00629538f, -0.50022966f, -0.63282210f, 0.09434054f, 0.26468280f, 0.09363962f, -0.02247070f, 0.18828543f, 
    0.40449178f, -0.09248814f, 0.02588674f, 0.15146028f, -0.11288867f, 0.45544142f, 0.04544809f, 0.08530568f, 
    0.47311494f, -0.36969298f, 0.13481414f, -0.37645268f, -0.30484360f, -0.09273542f, 0.03663618f, 0.01225092f, 
    -0.05992901f, 0.10156522f, -0.14149922f, 0.08006397f, -0.11788666f, -0.06977313f, -0.67987281f, -0.32502022f, 
    -0.14839523f, 0.21027385f, -0.53261554f, -0.08485533f, 0.17783174f, -0.02593029f, 0.17894286f, -0.25497374f, 
    -0.04694078f, 0.03865958f, -0.51423532f, -0.72576040f, 0.10619483f, -0.18986696f, 0.44169405f, -0.06811564f, 
    0.37671787f, 0.13549311f, 0.13707928f, 0.11546332f, -0.11355046f, -0.09551083f, -0.11621989f, 0.13930459f, 
    -0.10946513f, -0.08946424f, 0.11108527f, -0.17046921f, -0.11668751f, 0.23748977f, -0.08391732f, -0.34349144f, 
    -0.07571850f, 0.14624482f, -0.40216258f, 0.16059160f, -0.22227873f, -0.02234738f, -0.05390446f, 0.13104999f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.21802178f, 0.09762976f, -0.09243221f, 0.02733778f, 0.05571612f, 0.01007966f, 0.02039881f, 0.17057891f, 
    0.08816257f, 0.09035254f, 0.03710880f, 0.10932099f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
