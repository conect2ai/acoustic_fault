#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.20936053f, -0.05444486f, -0.50634104f, -0.57734978f, -0.59883541f, 0.21164547f, -0.04037877f, -0.07442110f, 
    0.12835099f, 0.21802506f, -0.36969748f, -0.37879559f, -0.27702373f, -0.21630418f, 0.01566293f, 0.24070857f, 
    -0.02638720f, -0.00343246f, 0.22320278f, 0.02710182f, -0.12573971f, -0.05813595f, -0.02985440f, -0.21628937f, 
    -0.32108200f, 0.11696274f, -0.40723854f, -0.32778820f, 0.21953291f, 0.25214210f, 0.00221943f, -0.03551136f, 
    -0.33864996f, 0.03483754f, -0.60356545f, 0.32812169f, 0.06974100f, 0.45150456f, 0.08475747f, 0.06507240f, 
    -0.00173767f, -0.38746920f, 0.03943727f, 0.03236947f, 0.02598230f, -0.20274515f, 0.27482045f, 0.22900257f, 
    -0.11469701f, 0.13069157f, 0.52863133f, -0.79576439f, -0.03437670f, 0.02030063f, 0.22203922f, -0.05638117f, 
    0.10845758f, 0.27345258f, -0.13836414f, -0.18322225f, -0.06966205f, -0.27079976f, 0.49314919f, -0.56731337f, 
    0.29355943f, -0.10222261f, -0.12200434f, 0.13769934f, 0.08591929f, -0.03633243f, -0.19507609f, -0.10159445f, 
    -0.29361451f, 0.31284219f, 0.22678876f, -0.40216228f, -0.53069383f, -0.24285218f, -0.39141020f, -0.10236558f, 
    0.15951155f, -0.30310029f, -0.34238797f, -0.18422057f, -0.19618167f, 0.21568696f, 0.21100742f, 0.16107489f, 
    0.21263143f, -0.25554195f, 0.04862714f, -0.17713855f, 0.06062598f, 0.24572597f, -0.15121162f, -0.25854659f, 
    -0.03772882f, -0.12556292f, -0.02859166f, -0.37639502f, 0.49170226f, 0.61281431f, -0.41161415f, 0.10853918f, 
    -0.27923107f, -0.16016985f, 0.17081413f, -0.11573983f, 0.24578889f, 0.68704462f, 0.08342940f, -0.03602219f, 
    -0.34553710f, -0.31714272f, -0.15377970f, 0.01560675f, -0.11240196f, 0.05617424f, 0.22507322f, -0.26734641f, 
    -0.21061362f, 0.12163248f, 0.12870270f, -0.05913465f, -0.08141992f, -0.52168018f, -0.43403575f, 0.16380014f, 
    0.74754775f, 0.51106328f, 0.63126183f, -0.08892784f, -0.56673205f, -0.42706335f, -0.03129658f, -0.22888966f, 
    -0.06863328f, -0.36645415f, -0.05165039f, -0.34519938f, -0.09563278f, 0.11126544f, 0.20871815f, 0.19595288f, 
    0.12873867f, 0.07240187f, -0.00407219f, 0.04749688f, 0.15316266f, 0.08163378f, 0.53078353f, -0.08598296f, 
    0.01198349f, 0.24803814f, 0.35652021f, 0.31077147f, 0.28368726f, -0.14230072f, -0.19981275f, -0.09128102f, 
    0.26148623f, -0.29622510f, -0.04862544f, -0.38193396f, 0.10080050f, -0.09745872f, 0.01758240f, 0.14494324f, 
    -0.08403895f, -0.05615102f, -0.21013466f, -0.19325049f, -0.32309133f, -0.35102314f, -0.36339867f, 0.52325284f, 
    0.61950755f, 0.55982941f, -0.36404446f, -0.69418019f, 0.01874718f, 0.40431920f, 0.09933933f, -0.07322454f, 
    -0.14080200f, 0.13406980f, 0.14672440f, -0.19625479f, 0.26741442f, -0.34027696f, 0.29383457f, -0.13206455f, 
    -0.10067063f, -0.11546916f, 0.17497994f, 0.22141376f, -0.04578714f, -0.08609127f, -0.01434166f, 0.18628192f, 
    -0.39417416f, 0.48629367f, 0.14945747f, -0.51088804f, -0.26636568f, -0.44386491f, -0.29003626f, -0.13973717f, 
    0.47872466f, 0.48746377f, 0.05707968f, -0.10127973f, -0.17370509f, 0.25863340f, -0.00890075f, 0.04050901f, 
    -0.06760652f, -0.09262253f, 0.09154446f, -0.12274581f, -0.09155053f, -0.05730517f, -0.24358200f, -0.23252854f, 
    -0.39236259f, -0.19716053f, 0.01593324f, -0.54647917f, -0.40581855f, -0.24351291f, 0.09804814f, -0.28099990f, 
    -0.14245117f, -0.11519966f, -0.15396890f, -0.18653929f, -0.14064962f, -0.03845073f, -0.25730807f, 0.02278038f, 
    -0.13514203f, -0.33167627f, 0.01061311f, -0.28323358f, -0.11993838f, -0.00708183f, 0.53851503f, 0.21272044f, 
    -0.05944134f, 0.08772136f, -0.46357656f, -0.44318563f, -0.23466930f, -0.36002931f, 0.14189634f, -0.36904475f, 
    0.00293487f, 0.43820167f, 0.82354379f, -0.30044156f, -0.05792751f, 0.03722592f, -0.10363818f, -0.22451103f, 
    -0.13396932f, -0.20248728f, -0.19380215f, -0.17870745f, 0.09331542f, 0.04050230f, -0.05888510f, 0.15779886f, 
    0.02998816f, -0.15789039f, 0.34040976f, 0.40907729f, 0.64897662f, 0.60010344f, -0.26320577f, 0.27029645f, 
    -0.45655364f, -0.37415755f, -0.28307450f, -0.04772840f, -0.07151531f, 0.08829761f, -0.01227355f, 0.05470222f, 
    0.14438652f, -0.04569598f, 0.00187262f, -0.09499437f, -0.14404923f, 0.07892351f, -0.03521399f, -0.11365257f, 
    0.19283418f, -0.10036695f, 0.05450187f, 0.01471636f, 0.07789512f, -0.67109710f, 0.06393482f, 0.27638078f, 
    0.06538901f, -0.30403826f, -0.64163095f, -0.45196643f, -0.12413003f, -0.12601383f, 0.18617904f, -0.26747060f, 
    -0.15884404f, 0.10500214f, 0.38460383f, 0.01939100f, 0.11090931f, 0.10342995f, -0.12319071f, -0.03336198f, 
    0.12369517f, -0.07327139f, 0.02239596f, 0.25070071f, 0.15470289f, 0.35749233f, -0.25324452f, -0.19367872f, 
    0.19996689f, 0.06132830f, -0.47244310f, -0.15043578f, -0.11167762f, 0.37333614f, 0.37111023f, -0.05961079f, 
    0.28895211f, -0.20172559f, -0.02133525f, 0.17584650f, 0.30190447f, -0.29378417f, 0.14813305f, -0.02235132f, 
    -0.19736102f, -0.23850518f, 0.21297660f, -0.20884962f, 0.03124991f, 0.19803348f, -0.35921124f, -0.41789225f, 
    -0.17292731f, 0.60454011f, 0.22263293f, -0.37753394f, -0.52464789f, -0.54846764f, -0.32471672f, 0.42947584f, 
    0.19550855f, 0.30436775f, -0.07239002f, -0.03003125f, 0.31841192f, -0.04349899f, -0.20577648f, -0.05263642f, 
    -0.05791643f, -0.28160876f, -0.07017290f, -0.11931504f, -0.12476678f, 0.21891735f, -0.23632894f, -0.83518547f, 
    -0.49356875f, -0.59365362f, 0.18253340f, 0.00783789f, 0.58938479f, 0.56051362f, -0.02558728f, 0.09941233f, 
    0.64372391f, 0.25216666f, 0.14782286f, -0.02451277f, 0.02561903f, -0.12049615f, -0.20592229f, -0.06479810f, 
    0.08430297f, -0.16932844f, 0.23448341f, -0.17096251f, 0.07876927f, 0.08685717f, 0.00985022f, 0.19925095f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.02615419f, -0.04002041f, 0.22747704f, -0.22807889f, 0.24126133f, -0.14398375f, 0.00522570f, -0.04498461f, 
    0.09863334f, -0.17321809f, 0.30384067f, 0.16737412f, 0.12934101f, 0.23091593f, -0.08966958f, -0.01140861f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.01570841f, 0.11330137f, -0.22975452f, -0.10146258f, 0.02604871f, -0.23711240f, 0.08935273f, 0.05172019f, 
    0.08407338f, 0.11404630f, -0.12252684f, 0.02181225f, 0.09471733f, 0.03429079f, 0.23873709f, 0.03068643f, 
    -0.02182780f, 0.04363529f, -0.00081953f, -0.03451338f, 0.19930419f, -0.00541569f, -0.05209711f, 0.02507862f, 
    0.20289068f, -0.32834205f, 0.32166153f, -0.01373839f, 0.08130389f, 0.00988786f, 0.02685668f, 0.14335862f, 
    0.07824299f, 0.01023865f, 0.13049497f, 0.20511065f, 0.08165189f, 0.16956140f, 0.08740170f, -0.21216251f, 
    -0.00663538f, -0.13848640f, 0.06651774f, 0.06784584f, 0.01097052f, 0.05339091f, -0.12766027f, 0.00527796f, 
    0.49442878f, 0.11472540f, -0.03750869f, -0.06150685f, -0.07237085f, -0.06358813f, 0.07173512f, -0.16703263f, 
    -0.00471268f, 0.04940476f, 0.00758891f, -0.08964866f, -0.08206078f, -0.43436190f, -0.06787513f, 0.01237558f, 
    0.09229049f, 0.09367914f, 0.02489177f, 0.01515963f, 0.01175224f, -0.02101292f, -0.02859013f, -0.04200625f, 
    0.16481377f, -0.36792466f, 0.03520126f, -0.01233161f, -0.08556974f, -0.06970001f, -0.03761982f, -0.05430721f, 
    0.05467534f, -0.13236724f, -0.11071606f, -0.03349519f, -0.02270753f, -0.14456773f, -0.25180432f, -0.04140421f, 
    -0.09988151f, -0.07922087f, 0.20381819f, -0.02010484f, 0.13043571f, 0.18405822f, -0.08957110f, 0.20570013f, 
    -0.38079503f, 0.17402795f, -0.03755413f, -0.12333878f, 0.03720687f, -0.18612756f, 0.23529691f, -0.02677471f, 
    -0.09330959f, 0.06830387f, -0.11448611f, 0.01591281f, -0.01040478f, 0.01912552f, -0.05602668f, -0.19058761f, 
    0.02903992f, -0.04699541f, 0.19520551f, 0.01840878f, 0.13524547f, 0.20897923f, 0.13905007f, 0.25320283f, 
    -0.13919799f, -0.07724399f, 0.22087517f, 0.04287875f, -0.04042640f, -0.00439137f, 0.02715813f, 0.10168849f, 
    0.04548283f, -0.08598277f, -0.01718203f, 0.08161077f, 0.04810836f, 0.15642600f, -0.47082859f, 0.01518588f, 
    -0.02024774f, -0.06805162f, 0.26234952f, 0.02760972f, 0.06418172f, -0.00295465f, -0.13780934f, -0.01366706f, 
    0.04254535f, 0.16723308f, -0.05272412f, -0.06307739f, 0.17498149f, -0.02373869f, 0.12000001f, 0.16404155f, 
    -0.08470044f, 0.06215872f, 0.05899057f, -0.01599963f, -0.10010996f, 0.04783643f, 0.11268459f, -0.00862209f, 
    0.13239692f, 0.03180980f, 0.03235127f, 0.02768632f, 0.06402560f, -0.15420388f, -0.07392015f, 0.07703934f, 
    -0.11162888f, 0.15974504f, 0.22634360f, -0.12284722f, 0.05883903f, 0.09315448f, -0.05349244f, -0.03023076f, 
    -0.03886651f, 0.02386872f, -0.07182416f, -0.08417188f, -0.16891488f, -0.05852478f, 0.08550742f, -0.05356431f, 
    -0.13711810f, 0.03496567f, -0.10543442f, -0.14956304f, 0.04428454f, -0.01279555f, 0.10106357f, 0.16674326f, 
    -0.05930964f, 0.05606711f, -0.04875705f, -0.02797884f, 0.03675838f, -0.02769958f, -0.05908015f, -0.06213332f, 
    -0.05205910f, -0.00226239f, -0.04871240f, -0.04658279f, -0.05549002f, -0.07388627f, -0.00034248f, 0.06074077f, 
    -0.03859451f, -0.07090899f, -0.03508332f, 0.04522594f, 0.03365796f, 0.03795980f, 0.05707546f, -0.03531786f, 
    -0.01973297f, -0.08439444f, -0.07857540f, -0.00828731f, 0.01531892f, -0.07760113f, -0.01856898f, 0.01752721f, 
    -0.01827013f, -0.06254861f, -0.07332159f, 0.00790374f, -0.03282357f, 0.00578623f, 0.03055996f, 0.04386796f, 
    0.05897382f, 0.03081451f, -0.06476643f, -0.04177154f, 0.00880060f, 0.06599740f, -0.00145308f, 0.02049456f, 
    0.01216869f, -0.03000733f, -0.02316833f, 0.03447149f, 0.06373488f, -0.00156800f, 0.01562145f, 0.05025274f, 
    0.00071597f, -0.00428690f, -0.02291527f, -0.03943730f, 0.00170359f, 0.03842854f, 0.05673975f, 0.02988110f, 
    0.02997848f, -0.03737972f, -0.03749530f, -0.05971063f, -0.01815389f, -0.04393577f, 0.05281160f, -0.04158712f, 
    0.02317694f, -0.05410398f, -0.00480847f, -0.04707050f, -0.00955569f, -0.04000865f, -0.02955030f, -0.02668811f, 
    -0.05780561f, -0.00291370f, 0.00800802f, 0.04389642f, 0.05545014f, 0.00641642f, -0.00248117f, 0.04165705f, 
    0.05041373f, 0.04925362f, -0.01988954f, 0.01648102f, -0.07155445f, -0.05076530f, -0.04379339f, -0.07487149f, 
    -0.06876850f, -0.00338872f, -0.01096292f, -0.07265948f, -0.01168168f, -0.03090568f, 0.01933469f, 0.03006319f, 
    -0.02762392f, -0.02832178f, -0.01753210f, 0.00970498f, 0.03093497f, -0.00478289f, -0.06640186f, 0.00990553f, 
    -0.03804124f, -0.00495598f, -0.04084311f, -0.05240503f, -0.05901799f, 0.03873327f, 0.06439363f, -0.03606267f, 
    0.05532171f, 0.01250709f, 0.05465877f, 0.00104486f, -0.02294970f, -0.04799261f, 0.04967984f, -0.00201175f, 
    -0.05424996f, 0.02189995f, -0.07546434f, 0.00590337f, -0.05364715f, 0.02770610f, 0.03384357f, 0.02453220f, 
    0.00604424f, -0.00521225f, 0.02313399f, -0.02133621f, 0.04741773f, -0.07151255f, -0.05857394f, 0.05101082f, 
    -0.06850971f, -0.05770547f, -0.03310772f, -0.00726110f, -0.02835207f, -0.01034280f, -0.03788649f, 0.06368704f, 
    -0.03623349f, 0.04692646f, -0.07392468f, -0.03298408f, 0.04411754f, -0.00027641f, 0.03179584f, -0.02223581f, 
    -0.03838786f, -0.06138209f, -0.05354467f, 0.04663523f, 0.04255318f, 0.04591745f, -0.02304350f, 0.04726403f, 
    -0.06897490f, -0.01382304f, 0.05141613f, -0.04568815f, 0.05337340f, -0.04797747f, -0.02508916f, -0.06661787f, 
    -0.03919637f, 0.01544506f, 0.01149948f, -0.02443736f, -0.05908256f, -0.05197069f, -0.04214847f, -0.06863382f, 
    0.02938292f, -0.03301286f, 0.04588355f, -0.04613273f, -0.03767664f, 0.05518384f, -0.05706345f, -0.05256461f, 
    -0.07198050f, 0.01027540f, -0.11010958f, -0.17050849f, 0.04380694f, -0.05086594f, 0.07916970f, 0.09774332f, 
    0.07362913f, 0.04732060f, 0.06823005f, -0.00128137f, -0.19843198f, -0.00434773f, -0.09964899f, -0.09363929f, 
    0.01101496f, -0.12457070f, 0.07727014f, -0.06647881f, 0.06878827f, 0.02311736f, -0.15147609f, 0.13901876f, 
    0.28704292f, -0.15369712f, 0.06036103f, 0.22631195f, 0.02042159f, 0.05452036f, 0.14984794f, -0.04027098f, 
    0.12084666f, -0.04992466f, -0.03946567f, 0.30412084f, -0.06676270f, 0.08594353f, 0.11229702f, -0.25429654f, 
    -0.04964020f, 0.07257099f, -0.01069683f, 0.03410459f, 0.06913264f, -0.00639540f, -0.10318681f, -0.12627810f, 
    0.72834611f, -0.02101731f, -0.04144213f, -0.10386115f, -0.01796782f, -0.02062199f, -0.01786631f, 0.01434689f, 
    0.18281348f, 0.04599174f, 0.05356726f, 0.11164979f, -0.08626516f, -0.20667544f, 0.01966734f, -0.13389626f, 
    0.04906946f, -0.05662729f, -0.01390156f, 0.04249987f, 0.08079509f, 0.07143602f, -0.00776855f, 0.01322771f, 
    0.20920724f, -0.09201361f, 0.16619359f, 0.00201519f, -0.03887547f, -0.09971187f, 0.01164178f, 0.00355929f, 
    -0.02924191f, -0.04079590f, -0.07977651f, -0.20050065f, -0.17641802f, 0.15895766f, -0.39018670f, -0.00618433f, 
    -0.08082838f, -0.15143263f, -0.06191610f, -0.16514146f, 0.05115094f, -0.10107380f, -0.16281997f, 0.07794587f, 
    -0.03398235f, 0.00906073f, -0.02800081f, 0.04968138f, -0.08309967f, -0.01382577f, 0.02385148f, 0.14656144f, 
    -0.08482868f, 0.11251216f, -0.04827598f, -0.11094174f, -0.06303371f, -0.01955334f, -0.03553559f, -0.15859698f, 
    -0.00792695f, -0.07666362f, 0.20914565f, -0.10489774f, 0.00349842f, 0.12710448f, 0.06629574f, 0.02359777f, 
    -0.14577727f, -0.10303099f, 0.06382665f, 0.18659768f, -0.09387381f, -0.05980725f, 0.13010877f, 0.08953397f, 
    0.03770249f, -0.03497456f, 0.02478176f, 0.13908958f, -0.13815996f, 0.01843155f, -0.30737293f, 0.06945676f, 
    0.10668221f, 0.04163424f, 0.08630221f, -0.10037554f, -0.07731055f, -0.05989489f, -0.14743213f, -0.05077140f, 
    -0.04349139f, -0.15509507f, -0.05970386f, -0.05175992f, 0.15491661f, 0.23943895f, 0.10745478f, 0.08051820f, 
    -0.03032780f, -0.02131438f, 0.02098454f, 0.03766976f, 0.12024783f, -0.04123868f, 0.05583987f, 0.08856300f, 
    0.05336737f, -0.02962886f, 0.03629741f, -0.02213124f, 0.14105040f, 0.05509871f, -0.20151401f, 0.10615335f, 
    -0.02408365f, -0.24074654f, 0.26992595f, -0.12043037f, -0.01372621f, 0.04630713f, 0.18164778f, 0.08690712f, 
    0.17453954f, 0.00641891f, -0.02102269f, -0.11835424f, -0.07969365f, -0.32134196f, 0.28637248f, -0.09563082f, 
    -0.14248869f, -0.06734103f, -0.19752380f, -0.04955333f, 0.11868384f, 0.05059103f, 0.10502312f, 0.20407753f, 
    0.12457816f, 0.21339114f, -0.00093494f, 0.01497542f, 0.06862634f, 0.04939657f, -0.08217442f, -0.07799750f, 
    0.00681671f, -0.00944140f, -0.07034966f, -0.17632370f, 0.04824845f, -0.15413068f, -0.01760530f, -0.12097664f, 
    -0.17646037f, 0.11823812f, 0.24881755f, 0.17264636f, -0.03914731f, 0.00432074f, 0.16541705f, 0.24007910f, 
    0.56838411f, -0.13264020f, -0.00664965f, 0.20459145f, 0.10900658f, 0.08190025f, 0.26823452f, -0.26033133f, 
    0.31072968f, 0.16791975f, 0.05694339f, 0.07732807f, 0.10734006f, -0.02956995f, 0.05369161f, 0.16047233f, 
    -0.03691754f, -0.00100546f, 0.08448780f, 0.11112943f, -0.10521123f, -0.25046211f, -0.12841651f, 0.05891519f, 
    -0.01355830f, 0.22911569f, 0.43107682f, -0.10024602f, -0.08737335f, -0.03329021f, -0.01694075f, -0.13020290f, 
    0.00427993f, 0.06095317f, 0.20641991f, 0.12894528f, 0.04066714f, -0.01133510f, -0.09791046f, -0.23897013f, 
    0.01009866f, -0.20843993f, -0.08110089f, -0.05037758f, 0.13474929f, 0.01270905f, 0.05842605f, -0.05967602f, 
    0.06084992f, -0.01738882f, 0.05887042f, -0.03469571f, -0.04574947f, 0.02635243f, 0.03358043f, -0.02836915f, 
    0.04190233f, -0.11027914f, -0.05886377f, 0.03409172f, 0.14752944f, 0.02294805f, 0.04812956f, 0.06204171f, 
    -0.12957202f, -0.01241934f, 0.04455755f, 0.05501940f, -0.01692807f, -0.08837172f, 0.05438259f, 0.06708997f, 
    -0.26566231f, -0.16595331f, -0.00263086f, -0.08332723f, 0.13571936f, 0.05901202f, -0.10943823f, 0.12723459f, 
    -0.19367044f, -0.15268849f, -0.13382211f, -0.10377991f, -0.05970541f, 0.04868048f, -0.03275371f, -0.00368368f, 
    -0.02269633f, 0.04615805f, 0.14485730f, 0.27330917f, 0.00180369f, 0.02392029f, -0.00985177f, -0.04943982f, 
    -0.26196772f, 0.00459897f, -0.16628824f, 0.03400008f, 0.02525595f, 0.02508042f, -0.01327768f, -0.01767298f, 
    0.09096630f, 0.01768345f, -0.11191817f, 0.02092778f, 0.34529874f, 0.16639143f, 0.06116918f, -0.01327302f, 
    -0.10633129f, -0.22233126f, -0.07594523f, -0.07117806f, -0.08612999f, 0.01579302f, -0.00407865f, -0.00826941f, 
    -0.19424412f, 0.10117445f, 0.17722598f, -0.14348283f, 0.08693486f, -0.03114536f, -0.10088927f, 0.10552441f, 
    -0.09025616f, 0.10629678f, 0.02959714f, 0.00500965f, 0.05907963f, 0.03488142f, 0.03048344f, -0.08195645f, 
    0.11274078f, 0.22120243f, -0.10535842f, -0.11951244f, 0.04636271f, 0.04260471f, 0.08782291f, 0.19337754f, 
    -0.13050726f, -0.10446005f, 0.06910715f, -0.02725611f, -0.02820863f, -0.00703799f, 0.00578887f, 0.09740189f, 
    0.06825882f, -0.14012198f, -0.10008006f, -0.08323523f, 0.20121568f, 0.02239291f, -0.19911106f, -0.12133187f, 
    -0.10649110f, 0.00604028f, -0.00412671f, -0.11287916f, -0.12270263f, 0.00186432f, 0.03553937f, 0.03473191f, 
    0.19296902f, -0.15433325f, -0.04807194f, 0.00360804f, -0.02478990f, -0.11585581f, 0.15806684f, 0.15086269f, 
    -0.04052000f, -0.00054435f, 0.15093672f, 0.20025901f, 0.42575669f, -0.19065943f, -0.25402176f, -0.14086357f, 
    0.11121944f, 0.14098503f, 0.09117724f, 0.03046867f, 0.01816724f, 0.12173682f, -0.14132707f, -0.21794759f, 
    0.00084147f, -0.17801948f, -0.07018567f, -0.08547683f, 0.25578958f, -0.12459759f, -0.02707878f, -0.13485250f, 
    0.00764672f, 0.01911356f, -0.01240448f, -0.07602070f, -0.06886029f, -0.02892949f, -0.06789757f, -0.13519095f, 
    0.18005483f, 0.04188492f, -0.01085006f, 0.10766161f, -0.00582566f, -0.07259253f, 0.10250288f, -0.15948142f, 
    0.02409815f, -0.14543678f, -0.15385589f, 0.04585967f, -0.03888463f, 0.06208117f, 0.08338393f, -0.02795477f, 
    0.04032136f, -0.01764628f, -0.11516591f, 0.26414543f, 0.05421469f, 0.39416510f, 0.22332488f, -0.14168277f, 
    0.00147617f, -0.08679868f, -0.02341293f, -0.02209634f, -0.06881393f, 0.00133030f, -0.03028820f, 0.03345281f, 
    -0.04405640f, -0.12253230f, 0.11321896f, 0.08067744f, -0.12668280f, 0.11704537f, 0.10830704f, -0.10083272f, 
    0.12884231f, 0.29489666f, -0.04314503f, 0.13625045f, -0.64171392f, 0.20018023f, -0.04758473f, 0.31701958f, 
    0.04175640f, 0.07864036f, 0.03808281f, 0.04507311f, -0.08022881f, -0.19077232f, 0.00507625f, -0.03536507f, 
    -0.13838579f, -0.01528206f, 0.03415728f, 0.06477396f, 0.04295057f, -0.00197161f, 0.09376558f, -0.01461980f, 
    -0.00042197f, 0.11229282f, 0.03007513f, -0.01041085f, 0.32122916f, -0.04486730f, -0.01388128f, -0.00679192f, 
    0.03774790f, 0.05663875f, 0.04578389f, -0.01157628f, 0.14642511f, 0.11890242f, 0.02151781f, 0.16650143f, 
    0.29053947f, -0.34605536f, 0.05995996f, -0.11133329f, 0.25771737f, -0.08772378f, 0.03261838f, 0.10254921f, 
    0.03202375f, 0.03687263f, 0.19405249f, 0.10986045f, -0.33877987f, 0.30554372f, 0.26732504f, 0.06270871f, 
    0.16112904f, -0.05310873f, 0.02194965f, -0.07417811f, -0.03136095f, -0.07170191f, 0.11517289f, 0.06715257f, 
    0.55697954f, -0.09728701f, 0.08459368f, -0.18787615f, 0.14557730f, 0.10721610f, 0.14921284f, 0.08779514f, 
    0.04800820f, -0.02746512f, 0.04003191f, -0.03649392f, 0.01580495f, -0.27565083f, 0.19888413f, -0.10844746f, 
    0.01005841f, -0.10952129f, -0.08603070f, -0.08208140f, -0.08284034f, -0.00223848f, 0.04863637f, 0.05031546f, 
    0.52836770f, 0.02986904f, 0.11094190f, -0.08194287f, 0.16458261f, 0.02908994f, 0.00678418f, -0.14723809f, 
    0.01070829f, 0.00115021f, -0.02427640f, 0.02647090f, 0.01185716f, -0.18317035f, -0.26925898f, -0.10702589f, 
    0.11038391f, 0.00557373f, -0.03860461f, -0.16629305f, 0.08864965f, -0.07179278f, 0.18069430f, -0.02818631f, 
    0.16862451f, -0.08158777f, 0.02689292f, 0.14190656f, -0.03765179f, 0.04014534f, -0.09339688f, -0.01423905f, 
    0.10067322f, 0.13256976f, 0.14018846f, 0.02784190f, -0.05539234f, -0.12511581f, -0.27392414f, 0.09751591f, 
    0.00853109f, 0.02381937f, -0.21439007f, 0.04904915f, -0.10065457f, -0.08244670f, 0.06846430f, -0.07636233f, 
    -0.20070918f, 0.45098108f, 0.09103481f, 0.11795053f, 0.04985297f, -0.15519506f, -0.05607216f, 0.04192368f, 
    0.17237261f, 0.07346994f, 0.03837112f, -0.02302753f, -0.18538944f, 0.00440628f, -0.07228606f, 0.22290221f, 
    -0.05210076f, 0.01651969f, 0.02332253f, -0.06918468f, 0.06369492f, 0.15213005f, 0.16891141f, 0.11654993f, 
    -0.15842077f, 0.16430306f, -0.11534374f, 0.14909165f, -0.15158103f, -0.01889344f, -0.01417734f, 0.04572397f, 
    -0.09531953f, -0.02459426f, 0.01593771f, -0.05205650f, -0.45639402f, 0.29372776f, -0.16131540f, 0.10758350f, 
    0.05588670f, 0.03504011f, 0.06429504f, -0.09536078f, -0.02945732f, -0.00224777f, -0.00407743f, -0.01944862f, 
    -0.13654354f, 0.11070919f, -0.10352273f, -0.02029750f, 0.00735744f, -0.00872816f, 0.02867019f, 0.09027757f, 
    -0.09310970f, 0.14935488f, 0.17706171f, 0.06893311f, 0.13308287f, -0.19530176f, 0.24479268f, -0.18357652f, 
    -0.03389354f, -0.02622534f, -0.06297784f, -0.02506780f, -0.12419716f, -0.14437230f, 0.03318677f, -0.10005070f, 
    0.22299953f, -0.00769470f, 0.02396311f, 0.00656997f, 0.13682881f, 0.01879245f, -0.11940997f, 0.11295930f, 
    -0.04731831f, 0.12921847f, 0.10265113f, -0.07463216f, 0.02018187f, -0.24838281f, -0.05495021f, 0.03967309f, 
    -0.12468892f, 0.00067758f, -0.25679797f, 0.09332187f, 0.05493271f, -0.02055211f, -0.03695771f, -0.10461698f, 
    0.15673338f, -0.06963267f, 0.01258012f, 0.07006127f, 0.08926490f, -0.00386375f, 0.08961767f, 0.00217026f, 
    -0.04703360f, 0.04237454f, 0.09166995f, 0.00237391f, 0.29921234f, 0.01099735f, 0.38985863f, -0.19496471f, 
    0.11078486f, 0.03557067f, 0.01747490f, 0.03846198f, -0.14497615f, 0.05768316f, 0.08027525f, -0.05009999f, 
    -0.05778245f, -0.00832184f, -0.21835987f, 0.10916580f, -0.17369112f, -0.07173634f, 0.03461415f, -0.12193841f, 
    0.05640096f, -0.09841846f, 0.06567647f, 0.10110302f, -0.08846419f, 0.20686667f, -0.17331919f, 0.19154011f, 
    0.07551522f, -0.04443909f, 0.04468754f, 0.09189828f, 0.01065490f, 0.02942313f, 0.06594085f, -0.10048393f, 
    -0.11359966f, 0.04535035f, -0.45414764f, 0.11909155f, 0.01540741f, -0.01907879f, 0.10406843f, 0.15048099f, 
    0.04872746f, 0.10913250f, 0.09778544f, 0.12622298f, -0.44427806f, -0.03257455f, -0.23074248f, 0.10133980f, 
    0.05006836f, 0.05786230f, -0.00969066f, -0.03707591f, -0.06717734f, 0.09423812f, -0.01837964f, -0.01205813f, 
    0.00995054f, -0.03342125f, -0.02722597f, -0.03459981f, -0.05853141f, -0.01621271f, -0.06533236f, -0.02519590f, 
    0.02904603f, 0.06050571f, 0.01399522f, 0.05854804f, -0.06333017f, -0.07403038f, 0.03516748f, 0.03757033f, 
    0.03595833f, 0.01730717f, -0.03864831f, -0.02314025f, -0.06950157f, 0.06013807f, -0.01106272f, -0.01561202f, 
    -0.01145082f, -0.07741481f, -0.05346495f, -0.04379880f, 0.01680474f, -0.03622220f, 0.01016537f, -0.05205989f, 
    -0.02613348f, 0.05190686f, -0.01593798f, -0.07802270f, 0.02927534f, -0.01022683f, -0.01588556f, 0.04914365f, 
    0.01871862f, 0.06172941f, -0.06847332f, -0.06538636f, -0.03963816f, -0.03020047f, -0.01140662f, -0.02119161f, 
    0.03857241f, -0.03644473f, -0.05304646f, 0.00072822f, -0.07537516f, 0.00481371f, -0.00994361f, -0.00923212f, 
    0.06302088f, -0.07127199f, 0.04610632f, -0.03109178f, 0.05439112f, 0.03807727f, 0.04748303f, -0.02633707f, 
    0.05324480f, -0.00507005f, -0.07366925f, -0.00926389f, -0.00355393f, -0.07266854f, 0.00027608f, 0.03394130f, 
    -0.02269237f, -0.06524653f, -0.00027094f, -0.06949203f, -0.06733264f, -0.01413135f, -0.03552070f, -0.06268752f, 
    -0.06628168f, -0.00404457f, -0.00762049f, 0.04956283f, 0.02454725f, 0.04954012f, 0.05631414f, -0.03679992f, 
    -0.05768818f, 0.04420064f, 0.00968269f, -0.06294904f, 0.04579037f, -0.05125502f, 0.05137039f, -0.07068408f, 
    -0.04418288f, -0.06171239f, -0.03420002f, -0.03598498f, -0.06328963f, -0.07793141f, 0.04775538f, 0.05444889f, 
    -0.05447679f, 0.01977792f, -0.01911548f, -0.06566401f, -0.05359596f, -0.04850582f, -0.02997561f, -0.03636966f, 
    0.06171621f, 0.05075074f, -0.04870272f, -0.07154901f, 0.01066039f, 0.02329503f, -0.05755464f, 0.05311640f, 
    0.06207658f, -0.01216448f, -0.01062739f, -0.02894826f, -0.07116773f, 0.05697802f, 0.00039185f, -0.06345270f, 
    -0.05312421f, -0.06728557f, 0.04357588f, 0.01648470f, -0.03047642f, -0.01884860f, -0.06717224f, 0.04570705f, 
    0.00259660f, 0.01311169f, 0.05346105f, 0.02028920f, -0.05176080f, -0.04348738f, -0.01815279f, -0.06112133f, 
    0.05577225f, -0.07399857f, 0.00707219f, -0.02410603f, -0.06314009f, 0.04729628f, -0.01556163f, -0.03518447f, 
    -0.04733941f, -0.00254957f, -0.06942718f, 0.06147898f, -0.06702684f, 0.01427034f, -0.07447569f, -0.02904324f, 
    -0.06125231f, 0.05206336f, -0.07091269f, 0.05381615f, 0.01440180f, 0.05078634f, -0.02690521f, 0.00964982f, 
    -0.07081021f, -0.05575243f, 0.05033035f, 0.04568088f, -0.06025174f, -0.03190785f, 0.00944598f, -0.05950190f, 
    -0.04584571f, 0.02503403f, 0.00880155f, 0.06025794f, -0.05947484f, 0.00786230f, 0.04618554f, 0.04829383f, 
    0.00324951f, -0.03671884f, 0.04684047f, -0.04198300f, -0.01381907f, -0.06099656f, -0.03010838f, 0.00030071f, 
    0.10788573f, 0.06648527f, -0.11166286f, -0.10503635f, -0.01204272f, -0.17913115f, -0.23251343f, 0.03299022f, 
    -0.08135619f, 0.01023344f, -0.01936701f, -0.13082398f, 0.11378016f, 0.19123773f, -0.14800555f, -0.12360288f, 
    0.04927247f, 0.10263809f, 0.17614387f, -0.02940409f, 0.11142069f, -0.14117807f, -0.13033490f, -0.15195780f, 
    0.29448530f, -0.24439818f, 0.16063571f, -0.00742103f, 0.01832848f, -0.09498499f, -0.06412056f, -0.17781560f, 
    0.06164528f, -0.10067817f, -0.05302036f, -0.01986858f, -0.02924873f, 0.13028303f, 0.08218748f, -0.16487741f, 
    -0.03108421f, -0.13031815f, -0.10643458f, 0.00459714f, -0.12512119f, 0.18564554f, 0.03803769f, -0.05030421f, 
    0.46955797f, 0.07245072f, 0.02462093f, 0.13920249f, 0.03970300f, -0.06816257f, 0.01390793f, 0.08661744f, 
    0.19246115f, -0.05842985f, -0.15867248f, -0.07917477f, -0.13312675f, 0.08742136f, 0.07366318f, 0.18592256f, 
    -0.07606746f, 0.21939950f, 0.12940788f, -0.01138885f, -0.02478418f, -0.06280262f, -0.15200026f, -0.10156686f, 
    0.13123874f, 0.02267101f, 0.05666976f, 0.21729781f, -0.00637867f, 0.05646235f, 0.03009960f, -0.04436060f, 
    0.00037062f, 0.02058230f, -0.01292606f, 0.00032712f, 0.18924519f, 0.01432896f, -0.05771096f, 0.15735568f, 
    0.11542052f, -0.12584560f, 0.15113264f, 0.09187948f, 0.12609501f, 0.05497022f, 0.00168580f, 0.13017039f, 
    -0.50438404f, 0.10291728f, -0.04635977f, -0.00285083f, -0.36518967f, -0.31644514f, -0.04929630f, -0.10008197f, 
    -0.27808702f, 0.13905707f, -0.03087556f, -0.13076442f, 0.11339404f, 0.13208146f, -0.00049300f, 0.03678932f, 
    0.05590333f, 0.19570693f, 0.14801027f, 0.14687024f, -0.14689118f, 0.03154271f, -0.07676675f, 0.05539518f, 
    -0.14214808f, -0.13010523f, 0.07134356f, -0.01465652f, 0.01792925f, 0.08522305f, 0.14767691f, -0.13766252f, 
    -0.25874412f, -0.08610325f, -0.14590938f, -0.03205937f, 0.01696465f, 0.05606287f, 0.13871242f, 0.18920942f, 
    0.09403770f, -0.05773751f, 0.05203151f, -0.08824421f, 0.07904366f, 0.00512726f, 0.01025662f, 0.12918313f, 
    0.07892877f, -0.02581431f, -0.02204510f, -0.14745967f, 0.04241004f, 0.14053161f, 0.20032160f, -0.01629310f, 
    -0.06160288f, -0.13169992f, -0.12571751f, -0.25473762f, -0.02300714f, 0.07559016f, 0.17897050f, 0.22438720f, 
    0.06643115f, 0.05592275f, 0.05989394f, 0.02763360f, 0.22381680f, -0.02025323f, -0.06914074f, 0.03305305f, 
    -0.19939998f, 0.20930381f, 0.23140870f, 0.03784110f, 0.11175002f, -0.17553572f, -0.03768383f, -0.20324297f, 
    -0.08658234f, -0.12565795f, -0.28644317f, -0.24669942f, -0.07544035f, 0.00407662f, 0.04569976f, -0.03012339f, 
    -0.09514008f, -0.08026059f, -0.09363020f, -0.01059485f, 0.02445368f, 0.04082968f, 0.09473807f, 0.10960723f, 
    -0.02635696f, -0.16184768f, -0.08904420f, 0.00740429f, 0.00179025f, 0.01770004f, 0.00108703f, 0.00114436f, 
    -0.04577297f, 0.02459625f, 0.08354101f, -0.06567861f, -0.12450364f, -0.13852915f, -0.13566247f, -0.04181912f, 
    -0.14076841f, -0.00860657f, -0.14766723f, -0.08364933f, -0.11570686f, -0.03263975f, -0.08500176f, 0.00058808f, 
    0.05926230f, 0.20563690f, 0.00415070f, 0.19473416f, -0.05154763f, -0.07632919f, -0.04259489f, 0.00354132f, 
    0.14716670f, 0.11993793f, 0.03611754f, 0.19429636f, -0.13548610f, -0.06727091f, -0.06652296f, -0.01828508f, 
    -0.06572860f, -0.05454042f, 0.03864252f, 0.02631882f, -0.08397531f, -0.01303618f, -0.00329011f, -0.03332672f, 
    0.18961760f, 0.20824635f, -0.01173723f, 0.14448403f, -0.06078896f, -0.11876852f, -0.11737709f, 0.04027541f, 
    -0.04837503f, -0.00537355f, -0.01968377f, 0.00299999f, -0.18771060f, 0.28558549f, -0.07443660f, 0.09953940f, 
    0.03504676f, 0.05309479f, -0.00946602f, -0.09335588f, -0.07339345f, -0.07544102f, -0.01422840f, 0.08979956f, 
    -0.17249079f, 0.12923899f, 0.01791034f, -0.03362732f, -0.04845050f, -0.02042856f, -0.08593031f, -0.00876643f, 
    -0.07635045f, -0.03713931f, -0.00916453f, -0.21651126f, -0.05235304f, -0.01780885f, 0.11209786f, 0.07777921f, 
    0.01798897f, -0.08261395f, -0.05032994f, -0.09899713f, -0.10257991f, -0.10415964f, 0.09986838f, -0.03828125f, 
    0.09183940f, -0.11926249f, -0.03493846f, -0.11554755f, 0.01871136f, 0.03161063f, 0.02993024f, 0.16212209f, 
    -0.08004699f, 0.03887649f, -0.00339188f, -0.20056269f, -0.10903062f, -0.15779899f, 0.02526119f, 0.03188473f, 
    -0.04703375f, 0.03737375f, -0.02034034f, -0.05047759f, -0.04999203f, 0.04576275f, 0.02773444f, 0.01688024f, 
    0.13610223f, -0.21024410f, -0.00670264f, 0.07250470f, 0.09221677f, -0.03548947f, 0.05415564f, 0.03616532f, 
    -0.02787510f, 0.06764682f, 0.03017940f, 0.13605000f, 0.10507562f, 0.04691989f, 0.11169259f, -0.09776913f, 
    -0.05544395f, 0.04386363f, 0.04111457f, -0.01431697f, -0.08418308f, 0.04354534f, 0.01028901f, 0.00036039f, 
    0.02064819f, -0.12375464f, -0.14237991f, -0.00949906f, -0.07436256f, 0.07494768f, -0.06077907f, -0.00818148f, 
    0.03452357f, -0.06749201f, -0.04595643f, 0.00345648f, 0.14484012f, 0.06757624f, -0.17965119f, 0.08336294f, 
    0.12505718f, -0.01480725f, 0.10347225f, 0.08247244f, 0.05073704f, 0.02852892f, 0.04025136f, 0.13161126f, 
    0.09081599f, -0.10180397f, -0.08790942f, -0.04971642f, 0.01521666f, -0.01382064f, 0.15398607f, 0.03456881f, 
    -0.02039459f, 0.07379515f, 0.08658576f, -0.07095636f, -0.31073290f, -0.21421927f, -0.01226950f, -0.17705812f, 
    -0.09194989f, 0.03350523f, 0.02349453f, 0.05105907f, 0.07266097f, 0.09225886f, 0.09129021f, 0.07439312f, 
    0.24352090f, -0.10081914f, -0.05104231f, 0.01109997f, -0.07005712f, -0.24318185f, -0.02666968f, 0.15345836f, 
    -0.08558083f, 0.12613928f, -0.00104660f, -0.01542698f, 0.27612859f, -0.02764913f, -0.03303159f, 0.02291794f, 
    0.04796752f, 0.06408090f, -0.21706855f, 0.00803570f, 0.07412151f, 0.02927126f, -0.04764191f, -0.06597374f, 
    -0.23028150f, 0.10755756f, 0.23621969f, 0.06441437f, 0.12218397f, -0.05947900f, -0.02008482f, 0.20700827f, 
    -0.08867295f, -0.03833421f, 0.08459806f, 0.00187957f, -0.24045350f, -0.00211742f, -0.26016307f, 0.02262749f, 
    0.11155275f, -0.20791005f, -0.06345686f, 0.11396201f, -0.10740595f, 0.01110381f, 0.01834020f, -0.07368145f, 
    0.05266824f, 0.02685484f, -0.11210464f, 0.05559807f, -0.18395744f, 0.02251762f, -0.01904035f, -0.05069311f, 
    -0.01888493f, 0.06917688f, -0.01419366f, 0.07832664f, -0.49402305f, 0.22859535f, -0.09989362f, 0.20455892f, 
    0.15651008f, 0.15861975f, 0.08035891f, -0.18264945f, -0.10199177f, -0.04668552f, 0.01632984f, -0.02938651f, 
    -0.17783727f, -0.05513187f, -0.13520755f, -0.04393350f, -0.11514002f, -0.01596302f, -0.10887543f, -0.05022222f, 
    -0.09830864f, 0.03942184f, 0.05828885f, -0.07880233f, -0.20596102f, -0.09221441f, 0.05446491f, -0.04542911f, 
    0.06538191f, -0.03938448f, 0.04392009f, 0.14783931f, 0.04753347f, 0.07269502f, 0.15452728f, 0.04662976f, 
    0.05269919f, 0.15774202f, -0.12495895f, -0.26644567f, -0.01887549f, -0.12855515f, 0.04718800f, 0.14050491f, 
    -0.05916920f, 0.01269013f, 0.06469684f, -0.02966265f, 0.30460182f, -0.06640700f, -0.01753082f, 0.03785663f, 
    -0.06380644f, -0.00027088f, -0.04857231f, 0.14301357f, 0.06315882f, 0.19941258f, -0.04429561f, 0.11833989f, 
    0.23095056f, -0.08337019f, 0.09709839f, -0.03358206f, 0.31622252f, 0.07563596f, 0.07167160f, -0.03220824f, 
    -0.03673504f, -0.15259227f, 0.18134901f, 0.11940052f, 0.20232081f, 0.23246832f, 0.17247108f, -0.07749203f, 
    0.13545328f, 0.11827632f, 0.09385438f, 0.01132643f, -0.02283567f, 0.10234793f, 0.00455364f, -0.04611835f, 
    0.37005049f, 0.24118182f, -0.12507978f, -0.01984109f, -0.03035778f, -0.10228741f, 0.04529401f, 0.15627091f, 
    0.00618054f, 0.02575105f, -0.00543669f, -0.00905039f, -0.07481924f, 0.11744313f, -0.10374209f, 0.10194032f, 
    0.14108770f, -0.02021032f, 0.10646858f, 0.10711861f, 0.04766634f, 0.09232843f, 0.21783423f, 0.04573712f, 
    -0.01227621f, 0.27857268f, -0.25482652f, -0.07355007f, 0.08003250f, 0.10658997f, 0.02794801f, -0.03490556f, 
    -0.04766501f, -0.07299902f, 0.08533946f, -0.06540280f, -0.34540462f, 0.02508356f, -0.08504088f, 0.13585548f, 
    0.08553652f, 0.04363840f, 0.00328093f, -0.00533375f, 0.02441335f, 0.09566884f, 0.11367878f, 0.08246449f, 
    -0.14668098f, 0.01089303f, 0.08569174f, -0.02640194f, 0.17797661f, 0.01573619f, 0.06900682f, 0.13154280f, 
    0.02998588f, -0.06101720f, 0.00785536f, 0.22790071f, 0.09371692f, -0.01310870f, 0.22801964f, -0.17600179f, 
    0.05495444f, -0.03123543f, 0.11380347f, -0.03866113f, 0.10699125f, -0.03358331f, -0.03805004f, -0.28074145f, 
    -0.03997210f, -0.09014247f, -0.02564781f, -0.26567420f, 0.04164050f, 0.05113210f, -0.09642826f, 0.05472278f, 
    -0.15157010f, -0.00746492f, -0.14287007f, 0.03549266f, 0.17834961f, -0.02740713f, 0.09695259f, -0.00379900f, 
    0.12174924f, 0.11511886f, 0.01494901f, 0.00818737f, 0.20410122f, 0.14483424f, 0.07169916f, 0.11090741f, 
    0.29405177f, -0.11900378f, -0.22067197f, -0.10046636f, 0.03371922f, -0.10683030f, 0.06083998f, -0.02067360f, 
    -0.00698341f, 0.02480168f, 0.05612719f, -0.00098118f, 0.26152009f, -0.46477380f, 0.17422608f, -0.26757100f, 
    0.02740251f, 0.00353362f, -0.12970373f, -0.05032127f, -0.03013060f, 0.07518488f, -0.13423827f, -0.14690281f, 
    0.14196739f, -0.20489985f, 0.12815702f, -0.05651802f, -0.05032157f, -0.00708280f, 0.11538661f, 0.10013675f, 
    0.07314760f, 0.15063864f, 0.05544919f, 0.25431895f, -0.07464876f, 0.08669993f, -0.34371930f, 0.02607229f, 
    -0.09596634f, -0.05600378f, 0.07267299f, -0.06119128f, 0.04118332f, 0.02291869f, -0.05143228f, -0.06373862f, 
    -0.06572753f, 0.03247200f, -0.16105196f, 0.09246848f, -0.02083855f, 0.10581803f, 0.05380414f, -0.07413658f, 
    0.11172444f, 0.05349614f, 0.14575976f, 0.26128054f, -0.02755956f, 0.08394598f, 0.01059908f, -0.05001844f, 
    0.17470877f, 0.04893448f, 0.03635055f, 0.02880089f, 0.04290134f, -0.06365940f, 0.00009763f, 0.05315182f, 
    -0.07491827f, 0.00496508f, 0.11133454f, -0.05046825f, -0.10054196f, 0.06894523f, -0.05589574f, 0.02188657f, 
    0.06372995f, 0.06300790f, -0.06783427f, 0.01246813f, -0.29726887f, 0.02604910f, -0.19762665f, 0.12557094f, 
    0.04453743f, 0.10833747f, -0.05347278f, -0.05361253f, -0.06727824f, -0.15404807f, -0.04545826f, -0.05805719f, 
    0.13992104f, 0.02882041f, 0.10717105f, -0.02376606f, 0.13983802f, 0.02518374f, 0.14159584f, 0.05284695f, 
    -0.02944789f, -0.06931201f, -0.16188288f, -0.12191351f, -0.03727445f, -0.27040243f, 0.09391128f, -0.05330562f, 
    -0.08077028f, 0.01941803f, -0.15446661f, -0.06088451f, -0.01332707f, 0.03706266f, -0.08922367f, -0.01907627f, 
    0.10067242f, 0.07887512f, 0.16879411f, 0.08852153f, 0.11759739f, 0.02966489f, 0.05943411f, -0.00598348f, 
    0.15732677f, 0.12741284f, -0.02499772f, 0.18501714f, 0.36665228f, 0.16374087f, 0.33966351f, -0.00934937f, 
    -0.22197898f, -0.26634216f, -0.01372733f, -0.17508960f, 0.11987806f, -0.01450059f, -0.03805054f, -0.01261266f, 
    -0.04459771f, 0.24996808f, 0.11845222f, 0.17797911f, 0.10819622f, 0.10879957f, -0.11161505f, -0.05384936f, 
    0.07222851f, -0.02113736f, -0.13445053f, -0.12372841f, 0.22137547f, 0.09857558f, 0.22679093f, -0.01517426f, 
    0.10556563f, 0.08347918f, 0.14017947f, 0.15215987f, 0.11366014f, -0.04260181f, 0.17796880f, 0.06323122f, 
    0.08410756f, -0.00675010f, -0.13375266f, -0.14157534f, -0.17286596f, 0.14532904f, -0.03191683f, -0.02674418f, 
    -0.01795912f, -0.08741270f, -0.00095956f, -0.10403302f, 0.08861123f, 0.02705745f, 0.10587735f, 0.22772916f, 
    -0.00157746f, -0.08718737f, 0.08677138f, -0.00885564f, 0.03784312f, -0.13731986f, -0.03779876f, 0.08803324f, 
    -0.44547918f, 0.04502301f, 0.21740772f, -0.26022136f, 0.08523951f, 0.00708368f, 0.05214617f, -0.07038081f, 
    0.04181953f, 0.00857283f, -0.07226156f, -0.07585514f, 0.21366937f, -0.23689158f, 0.02525635f, 0.05412373f, 
    -0.00327265f, -0.02126756f, 0.00913269f, -0.07173622f, 0.01562454f, -0.01373561f, -0.14605968f, -0.04973789f, 
    0.13773932f, 0.12880962f, 0.06008997f, -0.04909207f, 0.10193298f, -0.13533962f, -0.10626215f, -0.10766154f, 
    -0.04406065f, -0.10670062f, 0.03142691f, 0.15989269f, 0.13904111f, -0.09459321f, -0.05051213f, -0.03932012f, 
    -0.08215301f, 0.08432408f, -0.10619970f, 0.10533269f, 0.20630705f, 0.16479345f, 0.00602122f, -0.05817585f, 
    -0.08722071f, -0.14019437f, -0.04438192f, -0.02242551f, -0.06172462f, -0.09450772f, -0.04875258f, -0.08226524f, 
    0.16823849f, -0.10239011f, -0.00980889f, 0.06147585f, -0.05287923f, 0.20787093f, 0.07655290f, 0.25952870f, 
    0.01322737f, 0.07395136f, -0.02336472f, 0.05281706f, -0.08821279f, -0.08379097f, -0.10654623f, -0.02152292f, 
    -0.08449482f, 0.37586027f, 0.03497487f, 0.00363347f, -0.03915809f, 0.18211944f, -0.11298442f, 0.03648188f, 
    0.07975675f, -0.02766764f, -0.21613380f, -0.03863995f, -0.08977232f, -0.13296466f, -0.11291026f, 0.09456266f, 
    -0.12547743f, 0.03574224f, -0.14255543f, -0.03824412f, 0.12946300f, 0.09314630f, -0.07121875f, -0.10271608f, 
    -0.12627393f, 0.27136549f, 0.16232996f, 0.11915150f, -0.03784779f, -0.01600064f, -0.17084900f, 0.03297335f, 
    -0.07781024f, 0.10332806f, -0.05871784f, 0.01412059f, -0.16504630f, -0.09019084f, 0.10469460f, -0.19727804f, 
    -0.08434421f, 0.08775020f, -0.08469103f, -0.06514997f, -0.11107926f, 0.06335521f, -0.03109236f, -0.00100829f, 
    -0.14204533f, 0.10926838f, -0.00432381f, 0.08216573f, 0.04430947f, 0.03101928f, -0.11277054f, 0.05946113f, 
    -0.02516355f, 0.01932400f, -0.04138198f, -0.01762042f, 0.53289860f, 0.31639051f, -0.15161715f, -0.14005108f, 
    -0.01246043f, 0.08907063f, 0.03465895f, -0.01450403f, -0.02775896f, -0.06285010f, -0.06687313f, 0.01214671f, 
    -0.06892964f, 0.18220955f, -0.02867168f, -0.04321255f, 0.16849294f, -0.07867143f, -0.02453015f, -0.01001537f, 
    0.07899415f, 0.10261417f, -0.04877050f, 0.00570723f, 0.03035362f, 0.22975174f, 0.21756835f, -0.01744704f, 
    -0.08479985f, -0.00515863f, 0.11884701f, 0.07362887f, 0.19880347f, -0.04121005f, 0.08481507f, 0.08654650f, 
    0.08530540f, -0.04675728f, 0.17669046f, 0.00481317f, -0.01990058f, 0.05447118f, -0.00040288f, 0.00305318f, 
    0.01885074f, 0.04710067f, 0.13019894f, 0.15528217f, 0.08776842f, 0.10826518f, 0.04057824f, 0.07596096f, 
    -0.04575273f, -0.01481205f, 0.02667331f, -0.02452200f, 0.10232451f, 0.03998891f, -0.03547784f, 0.07569230f, 
    0.08082140f, 0.00499579f, 0.05633188f, -0.18612808f, 0.03471965f, -0.07386743f, -0.02264274f, -0.14087656f, 
    0.06010383f, 0.02748811f, -0.01472480f, -0.03080332f, -0.00411503f, -0.39865884f, 0.08141001f, -0.06621686f, 
    0.00845206f, 0.18875526f, 0.01905392f, -0.03507547f, 0.10425520f, 0.06449375f, -0.03791633f, -0.02394518f, 
    0.22338378f, -0.18476610f, 0.02524462f, -0.07096435f, -0.00319432f, -0.10116214f, -0.08098137f, 0.04001290f, 
    -0.08723290f, -0.07145724f, -0.11368185f, 0.09883752f, 0.13743551f, -0.05640315f, -0.36887166f, -0.18472946f, 
    -0.14455305f, -0.13078192f, 0.02490485f, 0.04379325f, 0.20553479f, 0.10705566f, -0.09181513f, -0.01347818f, 
    -0.27076697f, 0.20743412f, -0.04861242f, -0.09204351f, 0.01338794f, -0.03662083f, 0.08788390f, 0.00337195f, 
    0.09249878f, 0.06603918f, -0.14577524f, 0.01835916f, 0.00788346f, 0.22532351f, -0.06985804f, 0.10065272f, 
    0.04693889f, 0.13715225f, 0.13023454f, 0.03612534f, 0.06029557f, 0.04278023f, 0.07058018f, 0.09014663f, 
    -0.30311754f, 0.27358061f, 0.05484477f, 0.08866212f, -0.06110523f, 0.05394955f, -0.07338689f, -0.04044984f, 
    -0.09515708f, 0.02501373f, -0.18686914f, -0.00815262f, -0.12326229f, -0.09588628f, -0.33571431f, 0.20809786f, 
    -0.00504294f, 0.08848978f, 0.12928496f, 0.01543966f, -0.09289339f, -0.04616070f, -0.10329635f, -0.07619785f, 
    -0.16513909f, 0.12136579f, 0.02549396f, -0.03277170f, 0.12571651f, 0.01838584f, 0.00577323f, 0.08752669f, 
    -0.12790601f, 0.09328765f, -0.07179501f, -0.05118953f, -0.15909520f, -0.01526575f, 0.04189060f, -0.20477647f, 
    0.00368792f, 0.10215257f, 0.01346258f, -0.01097623f, 0.06143337f, 0.05088089f, -0.02405184f, 0.06509013f, 
    -0.06708911f, 0.15797329f, 0.12398091f, -0.06896617f, 0.09376999f, 0.09135333f, 0.03482839f, 0.03463171f, 
    0.00480581f, -0.04972877f, -0.06596112f, 0.01901565f, 0.15964082f, 0.09723967f, 0.34597841f, 0.02901077f, 
    -0.06519799f, -0.07985339f, -0.16996315f, -0.13457280f, 0.05781311f, 0.02740145f, 0.07430487f, 0.07140522f, 
    0.21081570f, 0.24489149f, 0.11407851f, 0.12530237f, 0.07545593f, 0.06156013f, 0.03059919f, -0.06708331f, 
    -0.03412946f, 0.00195019f, -0.07355594f, 0.01341168f, 0.09580803f, 0.09928214f, -0.25976980f, -0.00991012f, 
    -0.06992733f, 0.08731980f, -0.08836570f, 0.13049832f, 0.01821951f, -0.02836238f, 0.16178636f, -0.02198947f, 
    0.06654058f, 0.28899691f, 0.07199287f, 0.21164374f, -0.03905077f, 0.02213923f, -0.00584368f, 0.07035745f, 
    0.05003976f, -0.01910977f, 0.12372101f, -0.04927620f, -0.05508458f, 0.02022585f, -0.18845072f, 0.13098907f, 
    -0.01562150f, -0.09949946f, 0.00928422f, -0.02690770f, -0.08148621f, -0.12412442f, 0.07607079f, -0.03552405f, 
    -0.16289081f, 0.27931243f, 0.23866692f, 0.11377978f, 0.02668952f, 0.03098650f, -0.03581074f, 0.07718606f, 
    -0.07556946f, -0.06821852f, -0.09482745f, -0.05605151f, -0.44367507f, 0.32162845f, -0.13176699f, 0.13280919f, 
    0.00581711f, -0.04278672f, 0.18103383f, -0.01982359f, -0.01518389f, -0.05466361f, 0.02909739f, -0.08618279f, 
    -0.09683961f, 0.13033606f, -0.19586159f, 0.00553118f, -0.08314491f, -0.01151326f, -0.25523895f, -0.05972636f, 
    -0.10034563f, -0.08716379f, -0.09646671f, -0.01698962f, 0.23644520f, -0.12639429f, 0.28222090f, -0.06861731f, 
    0.02016319f, -0.00368122f, -0.08768705f, 0.14088629f, -0.05315902f, -0.02519239f, 0.06815308f, 0.00499721f, 
    0.03174142f, -0.09293269f, 0.10512068f, -0.08658689f, 0.08922842f, -0.00493070f, 0.09019495f, 0.19343744f, 
    -0.05528416f, -0.01645477f, -0.07363961f, 0.01878089f, 0.10186290f, 0.12042437f, 0.09904237f, 0.24668373f, 
    -0.05620955f, 0.21955979f, -0.09247685f, 0.07562675f, 0.05379870f, 0.07097166f, -0.10417788f, -0.10987279f, 
    0.11931404f, 0.32394212f, 0.03660097f, 0.00813259f, 0.10709982f, 0.26234540f, 0.11100397f, -0.00756978f, 
    0.02780440f, -0.01203258f, -0.00236664f, 0.04436859f, 0.11276362f, 0.00980453f, 0.51111430f, -0.06452628f, 
    0.05961295f, -0.07417301f, -0.08165770f, -0.00388406f, -0.11213622f, -0.02295396f, 0.02467234f, -0.07318868f, 
    -0.19752508f, 0.24886112f, -0.01374406f, -0.02535461f, -0.10357003f, -0.03752267f, -0.05524132f, 0.10349199f, 
    -0.03063365f, 0.04657404f, 0.03927273f, 0.15865131f, -0.11300045f, 0.15354586f, -0.08421732f, -0.00946777f, 
    -0.13140351f, 0.06922103f, -0.03039425f, 0.01199429f, -0.07891246f, 0.01818837f, 0.21899439f, 0.10488502f, 
    -0.16888185f, 0.38456151f, -0.12512331f, 0.06659224f, -0.03304433f, 0.06658675f, 0.04742961f, 0.04644999f, 
    -0.03398985f, -0.01863799f, -0.06663922f, 0.14887048f, -0.27531755f, 0.11242849f, -0.25332916f, 0.07038262f, 
    0.11260997f, 0.03784216f, 0.01935939f, -0.05456153f, -0.06590247f, 0.10114591f, 0.02052713f, -0.12033235f, 
    0.23832449f, -0.15455937f, -0.26286685f, -0.19674307f, -0.06856591f, -0.01371276f, -0.10456742f, -0.03833681f, 
    -0.11480968f, 0.10231264f, 0.17434359f, 0.36632836f, 0.15572843f, -0.01871637f, -0.23186344f, 0.01397689f, 
    0.09104915f, -0.13380061f, 0.07281304f, 0.08889920f, -0.10097281f, 0.05795129f, 0.03566036f, -0.11052050f, 
    0.16332752f, -0.05462854f, 0.12857448f, -0.08758523f, 0.27000284f, -0.11520935f, 0.13238719f, -0.16762960f, 
    0.30505919f, 0.19135608f, -0.09176771f, 0.07316791f, 0.09887459f, -0.09207896f, -0.03047064f, -0.09331600f, 
    0.08580810f, 0.08568437f, 0.07277729f, 0.04317012f, 0.33913222f, 0.26155663f, 0.11660809f, 0.00420459f, 
    0.42526895f, 0.09182444f, 0.13830027f, 0.19429290f, -0.08602683f, -0.03069905f, 0.01988257f, 0.03109412f, 
    0.02313612f, -0.00367793f, 0.04728888f, -0.02561708f, 0.14310664f, 0.06689303f, -0.18984017f, 0.00313312f, 
    0.01563106f, 0.30188677f, -0.00016368f, -0.17544696f, -0.05462468f, -0.13350065f, -0.16778506f, -0.02977652f, 
    0.17403081f, 0.00279965f, 0.18544157f, 0.16143970f, -0.04268654f, -0.02911016f, 0.09960077f, 0.07941922f, 
    0.16207474f, 0.33808926f, 0.11033869f, 0.41694349f, 0.24585316f, 0.06610992f, 0.04562742f, 0.17229067f, 
    0.11795295f, -0.04193493f, 0.08997137f, 0.03582137f, -0.03325552f, -0.14067328f, -0.10888308f, -0.01724244f, 
    -0.28917649f, 0.01222328f, -0.02074490f, -0.10914350f, -0.08681918f, 0.09602100f, -0.00462238f, 0.03447949f, 
    -0.07661467f, -0.01536590f, 0.01661856f, -0.02817950f, 0.14583330f, -0.23541074f, -0.41776782f, -0.35994512f, 
    0.22189155f, 0.08973360f, 0.12751894f, 0.19276747f, -0.22314598f, -0.00010525f, -0.05866636f, -0.01469698f, 
    -0.24876934f, -0.48363805f, -0.08849823f, -0.35405388f, 0.13372113f, -0.08315900f, 0.11806033f, -0.06666744f, 
    -0.13404478f, 0.02900037f, 0.20477289f, -0.01941565f, 0.42780459f, 0.33097225f, 0.14235401f, 0.03098137f, 
    0.11304917f, 0.01821220f, -0.07013673f, 0.06569002f, -0.09431757f, -0.16254176f, 0.00684318f, 0.10444202f, 
    -0.05628181f, -0.05307030f, -0.23517920f, -0.29866117f, 0.05339259f, 0.11513014f, 0.21864398f, 0.08554893f, 
    -0.14062136f, -0.23093875f, -0.06816057f, -0.04465496f, 0.04439878f, 0.15217189f, 0.21178707f, 0.13294765f, 
    0.07092084f, 0.08187436f, 0.12491155f, -0.02033754f, 0.15587536f, 0.15092590f, 0.00810046f, -0.04791190f, 
    -0.02429958f, 0.35227329f, -0.10670327f, -0.02829020f, 0.08511403f, -0.04518070f, 0.09225472f, -0.07458487f, 
    0.07355027f, 0.12687218f, 0.08199460f, 0.11678696f, 0.01425175f, 0.05646282f, -0.14042442f, 0.12285347f, 
    -0.10763378f, -0.03368328f, -0.11662069f, 0.02268458f, -0.09909817f, 0.02459869f, -0.09968536f, -0.14147452f, 
    -0.00707996f, -0.07336591f, -0.02976557f, 0.09238618f, 0.10996593f, -0.10422627f, -0.09612151f, 0.19203830f, 
    0.06075313f, 0.06909431f, 0.01071376f, 0.05266002f, 0.15504631f, -0.11206302f, 0.20012602f, -0.01287849f, 
    0.10602016f, 0.00499725f, 0.12499193f, 0.13199283f, 0.22798532f, 0.06413206f, 0.15250002f, -0.02731068f, 
    -0.12093959f, 0.15849574f, 0.16323243f, -0.18610053f, 0.05628715f, 0.08333343f, -0.09713885f, 0.23444508f, 
    -0.02866020f, 0.01236009f, 0.14320582f, 0.10667199f, -0.07255580f, 0.16678008f, 0.15595457f, 0.24079105f, 
    0.19744349f, -0.08167361f, 0.08141052f, 0.22125599f, 0.11698409f, 0.07916620f, -0.08135650f, 0.05274916f, 
    0.10824075f, 0.00741891f, -0.17623526f, -0.32480550f, 0.03429884f, -0.05086328f, 0.08899050f, -0.11715723f, 
    0.00197303f, -0.05162783f, 0.07806878f, 0.01709852f, -0.24851733f, -0.41920081f, 0.21080399f, 0.08868676f, 
    -0.03766769f, 0.18137036f, -0.04443099f, -0.08878260f, 0.07960845f, -0.06542550f, -0.08103622f, 0.04253234f, 
    0.04378214f, -0.22745380f, -0.05645043f, -0.03517566f, 0.07268843f, 0.05197868f, -0.03363891f, 0.10084482f, 
    -0.02835430f, -0.13521364f, -0.11560244f, 0.00590917f, -0.16492546f, -0.24224587f, -0.27220711f, -0.22936065f, 
    -0.02273891f, -0.09908723f, -0.07878385f, 0.06077753f, 0.09569346f, 0.19309768f, -0.05363229f, 0.02046048f, 
    -0.02870893f, 0.15002790f, -0.14149162f, 0.06611372f, -0.04141863f, 0.00522358f, 0.03769220f, -0.05056224f, 
    -0.03239946f, -0.08520552f, -0.09495220f, 0.13372836f, 0.13264658f, 0.02921939f, 0.03170216f, 0.23598874f, 
    0.13013646f, 0.10121747f, 0.13159475f, 0.19300507f, 0.03975184f, 0.11079270f, 0.11854305f, 0.13609065f, 
    -0.07986582f, 0.28823426f, 0.14202371f, 0.14433187f, 0.06450947f, 0.02347540f, 0.03651039f, 0.18572307f, 
    0.08635844f, -0.03920424f, -0.20847788f, -0.03659636f, -0.36686981f, -0.11774625f, -0.22657521f, 0.13709061f, 
    -0.10836406f, 0.07278086f, 0.18239087f, -0.12227684f, 0.04831066f, 0.00219445f, 0.02862213f, -0.13886833f, 
    -0.05242822f, 0.10694057f, -0.07809526f, 0.16726947f, 0.09283912f, -0.04797531f, -0.06005149f, 0.12104296f, 
    -0.07598595f, 0.10018621f, -0.08446877f, 0.05624986f, -0.27938676f, -0.15028845f, 0.14327139f, -0.31783819f, 
    0.00265843f, 0.06808298f, 0.00881228f, -0.04948331f, 0.00420744f, -0.04469530f, 0.09172587f, -0.04429455f, 
    0.11400054f, 0.16676037f, 0.03697347f, 0.05000564f, 0.23682034f, 0.08856814f, 0.01850651f, -0.01221030f, 
    -0.08077676f, -0.02785221f, -0.00618112f, 0.05939292f, -0.00578777f, 0.17070867f, 0.21400286f, -0.05013364f, 
    -0.10881039f, -0.06748546f, 0.00802056f, -0.12445898f, -0.06958275f, -0.01826725f, -0.00089170f, 0.03615387f, 
    -0.01360285f, 0.05622534f, 0.19793729f, 0.15536563f, 0.03964975f, -0.05838976f, 0.13736299f, 0.12793717f, 
    -0.01504169f, 0.02261363f, 0.02215590f, -0.05047729f, 0.15352321f, -0.06039640f, -0.08581674f, -0.09546222f, 
    -0.07261530f, 0.05889443f, -0.10471109f, -0.06500744f, -0.00293883f, 0.15244995f, -0.06966520f, 0.01793268f, 
    0.40813965f, -0.15250859f, -0.22708476f, 0.12556498f, -0.11923127f, 0.06223873f, 0.07338389f, -0.03152430f, 
    0.02484322f, -0.06240748f, 0.03009474f, 0.01051559f, 0.03109537f, 0.00045907f, 0.00064492f, -0.15657128f, 
    0.01946055f, -0.19222762f, -0.02593409f, 0.01556700f, -0.11674817f, -0.14438748f, 0.11935049f, -0.16480337f, 
    -0.00631370f, 0.14431183f, 0.22543937f, 0.05038963f, -0.00473824f, -0.01816017f, -0.08927922f, 0.04665073f, 
    0.09663966f, 0.03637689f, -0.11764250f, 0.14413050f, -0.08335984f, 0.23647705f, 0.07975367f, -0.06499252f, 
    -0.01476221f, -0.30295423f, -0.02888278f, 0.05034398f, -0.06446974f, 0.02700168f, 0.04337197f, -0.00659239f, 
    -0.05807322f, -0.09824986f, -0.10906772f, -0.11507534f, -0.11561221f, -0.04489646f, -0.10293707f, -0.16874015f, 
    -0.13693075f, -0.19374013f, -0.27245677f, -0.22754142f, -0.40430325f, 0.16664580f, 0.06036654f, 0.07500190f, 
    -0.01313095f, 0.01374672f, -0.06351034f, 0.14010166f, -0.04689394f, -0.18639530f, 0.04165100f, 0.01832775f, 
    -0.05422113f, -0.14066315f, 0.08833687f, 0.06050599f, 0.06233024f, -0.06778353f, 0.12651318f, 0.05168487f, 
    -0.12944755f, 0.04231483f, -0.04942672f, -0.10564955f, -0.16195168f, -0.05656536f, 0.05899590f, -0.01735745f, 
    -0.06631932f, 0.08005436f, 0.07519065f, -0.05656265f, -0.01970606f, 0.07447208f, 0.06449516f, 0.21940663f, 
    0.03890716f, -0.01795407f, -0.07953059f, 0.05121929f, 0.05757654f, 0.11306362f, 0.07860733f, 0.00209847f, 
    0.00203186f, 0.07188961f, 0.06826119f, 0.17131956f, -0.30373582f, -0.00231396f, 0.26353663f, 0.06500921f, 
    0.12749217f, -0.00769982f, -0.02054496f, -0.05925453f, -0.03617196f, -0.11647853f, -0.02010069f, 0.04269059f, 
    0.16698372f, -0.17271191f, 0.07539486f, -0.12075997f, 0.00142369f, 0.10380979f, 0.01663469f, 0.01097256f, 
    0.05206502f, 0.03696514f, 0.03454069f, 0.06296092f, 0.11207583f, -0.04572248f, -0.02110410f, -0.00222214f, 
    -0.03552372f, 0.08062535f, -0.03054882f, 0.10048903f, -0.01240477f, 0.11353223f, 0.04860671f, 0.16472693f, 
    0.24322315f, -0.11136705f, 0.34898648f, -0.14114696f, 0.15816653f, -0.10356033f, 0.02388156f, -0.04487074f, 
    0.03859892f, 0.03821969f, -0.08994479f, -0.05626026f, -0.06934266f, -0.25641003f, -0.20598611f, -0.15414561f, 
    -0.07035629f, 0.01373845f, 0.09111936f, 0.01464135f, 0.24421519f, 0.09947394f, 0.19290152f, -0.06381653f, 
    -0.23034219f, -0.24088264f, -0.05261941f, -0.00995519f, -0.01197075f, -0.07915300f, -0.03328580f, 0.04033976f, 
    0.01723708f, -0.13553835f, -0.01941635f, 0.09516072f, -0.14702857f, -0.06879245f, 0.30455908f, 0.12917578f, 
    0.01023874f, 0.02068183f, -0.11796556f, 0.00421384f, 0.12030341f, -0.18622600f, -0.14534329f, 0.05044432f, 
    -0.14583336f, 0.09189156f, 0.29035380f, 0.00702114f, 0.00121173f, -0.00724919f, -0.11355745f, 0.20071898f, 
    -0.04114439f, 0.13848147f, 0.14804679f, 0.20640972f, -0.21066712f, -0.00001012f, 0.26614624f, 0.08270349f, 
    -0.03944449f, -0.01039191f, 0.04309507f, -0.02208492f, 0.03285975f, 0.21193776f, -0.00833467f, 0.11356782f, 
    0.47839743f, -0.01927190f, -0.46628523f, -0.00824090f, -0.06533698f, -0.06373269f, 0.00107027f, 0.07097359f, 
    0.10514437f, 0.17201722f, -0.07187480f, -0.02131760f, -0.25806552f, -0.26473704f, 0.18198512f, 0.27909845f, 
    0.19133228f, 0.15859941f, -0.00794814f, -0.06609334f, -0.02394163f, -0.01201007f, -0.11649479f, -0.08384699f, 
    -0.21551211f, -0.20756707f, -0.08274103f, -0.16215354f, 0.03975102f, -0.09538310f, 0.03700915f, 0.00841478f, 
    0.11689029f, 0.07018702f, 0.10355449f, 0.08522086f, 0.17415872f, -0.21759866f, -0.28574893f, -0.14837283f, 
    0.02652622f, -0.02741552f, 0.04130739f, -0.19845545f, 0.09251457f, 0.09297664f, 0.05310007f, -0.09995116f, 
    0.16699718f, 0.25420749f, -0.12564275f, -0.05258970f, -0.00573789f, -0.19203709f, 0.10537873f, 0.06565508f, 
    0.01545830f, 0.08469232f, -0.00460012f, -0.06047907f, -0.08981766f, -0.12029979f, -0.05593883f, -0.05719976f, 
    -0.08871478f, -0.07883054f, -0.08246478f, 0.10889064f, 0.02507949f, 0.04660267f, -0.01613745f, 0.10652624f, 
    -0.10534438f, 0.00624982f, 0.20838822f, 0.14006086f, 0.03530985f, -0.01037217f, -0.07359061f, 0.06188806f, 
    0.03903992f, -0.07258806f, -0.01293318f, 0.13039683f, 0.16300112f, 0.01225394f, -0.21210568f, 0.07323824f, 
    0.10204168f, 0.31382108f, 0.17530319f, -0.01642147f, -0.05984873f, -0.06846636f, -0.13015169f, -0.07095632f, 
    0.01374614f, 0.03359754f, -0.13202128f, 0.29685259f, -0.08343276f, 0.04030787f, -0.01525111f, 0.03937835f, 
    -0.08753882f, -0.01830702f, -0.07898908f, -0.04755720f, -0.09490620f, 0.08162056f, -0.28493553f, 0.13128044f, 
    0.04478063f, -0.02845270f, 0.07335284f, 0.13557965f, 0.17219648f, 0.04159632f, -0.10746399f, -0.02752142f, 
    -0.10884148f, -0.03007846f, -0.02780157f, 0.15194702f, -0.02063442f, 0.06573709f, 0.05779925f, 0.06624444f, 
    0.05087265f, 0.11898313f, 0.07156982f, -0.01619104f, -0.38267291f, -0.08152768f, 0.43006688f, 0.17976889f, 
    -0.04289789f, -0.04304501f, 0.02439102f, 0.05622216f, -0.02452116f, 0.13712515f, -0.02540698f, 0.10411036f, 
    0.06863596f, 0.05980778f, -0.06747102f, 0.32295701f, 0.11013737f, 0.12979430f, -0.02655808f, -0.09297370f, 
    -0.00678329f, -0.01705204f, -0.06774678f, -0.05573732f, -0.22444434f, 0.09428980f, -0.32970351f, 0.07786833f, 
    0.08465457f, 0.08571071f, 0.08049154f, 0.09731493f, -0.03077836f, 0.02916512f, 0.16629598f, 0.19844542f, 
    0.07905338f, 0.49593627f, -0.01526659f, 0.25945729f, -0.15047541f, 0.09334908f, 0.08641842f, -0.01605272f, 
    0.34299219f, 0.12142101f, 0.17960514f, 0.13864249f, -0.04004088f, 0.10567916f, -0.17211173f, 0.21139294f, 
    0.08928692f, 0.13871039f, 0.04415782f, -0.02859741f, -0.13194089f, -0.02029561f, 0.08595563f, 0.00341426f, 
    -0.37995079f, 0.26400664f, 0.40494922f, -0.01794137f, -0.04028020f, -0.03692468f, -0.06527332f, -0.04383980f, 
    0.10920980f, 0.05245049f, 0.16547792f, -0.07554232f, 0.04771172f, 0.15354639f, -0.23519872f, 0.06441823f, 
    0.04185648f, 0.00040067f, -0.07846619f, -0.05608096f, -0.10307465f, -0.00237990f, -0.09610883f, 0.12950176f, 
    0.05710419f, 0.33390316f, -0.02152649f, 0.09929620f, -0.03341839f, -0.17518874f, -0.12677173f, -0.13157761f, 
    0.13408200f, -0.07884969f, -0.00365738f, 0.08994684f, 0.34339997f, -0.12916793f, 0.07122471f, -0.15259460f, 
    -0.05417960f, -0.07837341f, -0.10567938f, -0.03409115f, 0.02229318f, -0.01026483f, -0.07623635f, -0.16439530f, 
    0.23462360f, -0.07633150f, -0.09558673f, 0.01587394f, 0.03228453f, 0.11736592f, -0.05205828f, 0.14103350f, 
    -0.04896161f, -0.04778180f, -0.12852591f, -0.03047818f, -0.14661980f, -0.10446858f, -0.21452457f, 0.23028491f, 
    -0.00538578f, 0.00268456f, 0.02587450f, 0.10147569f, -0.15897073f, -0.12099572f, -0.14151271f, 0.10231089f, 
    0.01761001f, 0.52430421f, -0.20100005f, 0.01225013f, -0.13261119f, 0.12612014f, 0.04222178f, 0.01254934f, 
    -0.00562742f, 0.05486134f, -0.05295604f, 0.03025724f, -0.18659417f, -0.30712143f, 0.00424286f, -0.02342778f, 
    -0.02174433f, -0.07228211f, -0.24800275f, 0.04217751f, -0.07105174f, 0.08331411f, 0.05970234f, 0.06683354f, 
    -0.56976748f, 0.02632748f, -0.17470936f, 0.07817269f, 0.04974329f, 0.10334852f, -0.11717797f, 0.00376854f, 
    -0.12592585f, -0.03135568f, 0.01858577f, -0.03425748f, -0.12983686f, 0.31370431f, -0.03126112f, -0.20574400f, 
    -0.04764287f, 0.11598499f, 0.20024239f, -0.18662179f, 0.01974436f, 0.04080703f, 0.18675344f, 0.12140276f, 
    -0.20384370f, 0.14598265f, -0.09632030f, -0.12424204f, -0.00013058f, 0.15731069f, 0.04165256f, 0.14581694f, 
    -0.00747643f, -0.01980746f, 0.03938016f, -0.00441844f, 0.32498306f, 0.12909950f, 0.23640285f, -0.15255095f, 
    -0.02227278f, 0.06164024f, -0.08423953f, 0.08676704f, -0.16079533f, 0.05865284f, -0.04042656f, -0.01698252f, 
    -0.07589266f, -0.07341896f, -0.05118308f, -0.01520114f, 0.02977286f, 0.05138678f, -0.02068030f, 0.05456457f, 
    0.03725388f, 0.00982421f, 0.03151470f, -0.06085404f, 0.05200392f, -0.02027414f, -0.01198238f, -0.00070870f, 
    0.04739530f, -0.05824592f, -0.05987205f, -0.03191742f, -0.06046326f, 0.03705446f, -0.06325996f, 0.02958379f, 
    0.00211865f, 0.03209513f, 0.00156915f, 0.06237776f, -0.04759122f, -0.01654095f, -0.07039893f, 0.06390747f, 
    -0.01406742f, 0.06103793f, 0.00485254f, 0.03517055f, -0.04343660f, 0.00667514f, 0.06623932f, -0.03214536f, 
    -0.05901061f, -0.04235464f, -0.06358285f, 0.06514248f, -0.00389176f, -0.02685696f, 0.03669059f, -0.00478200f, 
    -0.06159902f, -0.02467475f, -0.05781553f, -0.06026714f, 0.05339983f, -0.04144328f, -0.04052384f, -0.01765938f, 
    -0.02869224f, 0.03286802f, -0.01091029f, 0.02540886f, 0.06281830f, 0.05381939f, -0.04766538f, -0.02082356f, 
    -0.02013363f, 0.01339041f, -0.02330125f, -0.04820157f, 0.03175885f, -0.04290576f, 0.00832776f, -0.01046125f, 
    0.06540294f, -0.01929445f, -0.02844828f, -0.05887711f, 0.00713077f, -0.03297597f, 0.03089365f, -0.00422548f, 
    -0.04861178f, -0.00360135f, 0.04135165f, -0.01573134f, 0.04150175f, -0.07343765f, 0.00814990f, -0.00781617f, 
    -0.02431659f, -0.02970370f, 0.05742129f, 0.04340801f, -0.00815492f, 0.02187022f, 0.04212675f, -0.03384978f, 
    -0.00741267f, 0.01605693f, -0.07242883f, 0.00885225f, -0.00890961f, -0.00489902f, 0.00707021f, 0.04533657f, 
    -0.01977524f, -0.02234427f, 0.02273744f, -0.02045895f, -0.02969123f, -0.01656654f, -0.03274575f, 0.01647970f, 
    -0.00094387f, 0.03144807f, -0.05119315f, -0.06601555f, 0.03428053f, -0.02068059f, -0.07566398f, -0.06243662f, 
    -0.02254360f, -0.07001930f, -0.05266642f, -0.07422676f, -0.03089014f, -0.00628999f, -0.06062791f, -0.07546312f, 
    -0.01470698f, 0.04483333f, 0.03493709f, -0.01910113f, 0.02168180f, -0.05684739f, 0.03688016f, 0.01352598f, 
    0.04412319f, -0.02790317f, -0.02336897f, 0.05611823f, -0.04532535f, 0.01465693f, -0.02010685f, -0.05334337f, 
    -0.05044615f, -0.02431430f, 0.00844398f, -0.02005664f, 0.00317667f, 0.06472765f, -0.03102329f, -0.04702214f, 
    -0.05769433f, -0.00289126f, -0.06019094f, -0.05508436f, -0.01746426f, -0.04994756f, 0.01020689f, 0.02090290f, 
    -0.05543024f, 0.03876870f, 0.02210231f, 0.05556465f, 0.06652224f, 0.01040099f, 0.00821759f, -0.04084377f, 
    0.05296111f, -0.02641362f, -0.02007676f, 0.00732076f, 0.02747877f, 0.00618360f, 0.01153823f, 0.05147294f, 
    0.03892377f, 0.05725539f, -0.03260504f, -0.02342970f, 0.03569154f, -0.07616184f, -0.04770440f, 0.07127402f, 
    -0.07385704f, -0.00719331f, -0.06687754f, 0.01502571f, -0.07465748f, -0.00326998f, -0.05093002f, -0.06966220f, 
    -0.19641683f, -0.10562714f, -0.00507003f, 0.11011743f, 0.13129871f, -0.08426765f, 0.06181275f, 0.17201170f, 
    0.00200637f, -0.12241400f, 0.06959245f, 0.12461021f, -0.08601671f, -0.07500464f, -0.03325133f, 0.05098194f, 
    0.03242788f, -0.05859743f, -0.06202867f, -0.05791736f, 0.13760601f, -0.08538961f, -0.11972788f, -0.05580202f, 
    -0.17934610f, 0.22138606f, 0.17389132f, 0.06527662f, -0.05539443f, 0.17071964f, -0.01405263f, 0.16822425f, 
    -0.12169928f, 0.20824006f, 0.03492717f, 0.05475133f, -0.13763249f, 0.07781368f, 0.16135281f, 0.01037106f, 
    0.07149660f, -0.06855398f, -0.01729771f, -0.08927122f, 0.05821660f, 0.12527969f, 0.07837093f, 0.02338192f, 
    0.53130114f, -0.02578739f, -0.47682700f, -0.15900700f, 0.05461450f, -0.11452070f, 0.00141732f, 0.15818126f, 
    0.14277655f, 0.03711170f, -0.11251389f, 0.07442541f, -0.16029203f, -0.05821868f, 0.28723544f, 0.11783836f, 
    0.03430455f, 0.02995338f, 0.02189356f, 0.00453910f, -0.02974301f, 0.04618729f, -0.18106437f, -0.01584755f, 
    -0.19995253f, -0.27826735f, -0.20284186f, -0.20976646f, 0.07153445f, 0.01429258f, -0.04380659f, 0.02634278f, 
    0.17759840f, 0.18158811f, -0.00562168f, 0.03616240f, -0.09701862f, -0.03785034f, -0.36081496f, -0.21187288f, 
    0.17948583f, -0.03080489f, -0.17139368f, 0.00204171f, 0.08170518f, 0.08674666f, -0.10092302f, 0.01047336f, 
    0.13367842f, 0.17475148f, -0.16539456f, 0.10547137f, -0.03583833f, -0.02678618f, 0.07730329f, 0.08796401f, 
    -0.00827518f, 0.15916546f, 0.00985225f, 0.18040806f, -0.12187265f, -0.10357373f, 0.10265663f, 0.10605415f, 
    0.11244868f, 0.08434740f, -0.04517558f, 0.00134716f, 0.06493339f, -0.05202261f, 0.03391397f, -0.01351257f, 
    0.01004101f, 0.13203827f, 0.21248561f, 0.19181484f, -0.13611640f, 0.07063294f, 0.01351728f, -0.01478155f, 
    0.05558918f, -0.00806736f, -0.04554409f, -0.00976087f, -0.51663244f, -0.23460336f, 0.08048528f, 0.02670415f, 
    0.01740345f, 0.18227468f, -0.05090624f, -0.04753032f, 0.00930337f, -0.06669976f, -0.12729794f, -0.10002374f, 
    0.08554842f, -0.10146224f, -0.06381160f, 0.24926201f, -0.01697549f, 0.04281854f, 0.04582582f, 0.01422581f, 
    0.04231769f, 0.06986337f, -0.09125250f, 0.00048137f, -0.18576318f, -0.10399333f, -0.17789790f, 0.12474427f, 
    0.04804553f, -0.00048880f, 0.06830904f, 0.18890376f, 0.08645657f, 0.06189336f, -0.02682437f, 0.11036757f, 
    0.03448014f, 0.05250906f, 0.11910999f, 0.10832383f, 0.06035677f, -0.04342340f, 0.09703878f, -0.00264018f, 
    -0.02672114f, 0.14217444f, -0.06948821f, 0.17772366f, -0.36163071f, -0.07736859f, 0.73499322f, 0.24558564f, 
    -0.06207491f, -0.16639464f, -0.00578510f, -0.05500982f, -0.01706022f, 0.01843689f, -0.05978114f, 0.01677744f, 
    -0.08595213f, 0.15057628f, -0.00501612f, 0.01437903f, 0.04959717f, 0.00208460f, 0.00139827f, -0.09577187f, 
    -0.03087691f, -0.02014403f, 0.01390850f, 0.00968588f, 0.00564946f, -0.20916121f, 0.11563535f, -0.10465028f, 
    0.11622310f, -0.04247474f, -0.03617596f, 0.24049430f, 0.05457403f, 0.07049647f, 0.07721836f, -0.10404705f, 
    -0.04163794f, -0.03152902f, 0.07453477f, -0.05353846f, -0.05343087f, 0.14738427f, 0.02770217f, -0.00248328f, 
    -0.00211149f, -0.04710636f, 0.07647905f, -0.03121547f, 0.05369291f, -0.05080838f, 0.10722771f, 0.19591510f, 
    -0.01768944f, -0.04874530f, -0.03094091f, -0.01094694f, -0.00070553f, -0.20455579f, 0.16295202f, 0.03111253f, 
    -0.11082440f, -0.11061267f, 0.12288267f, -0.13116968f, 0.08509601f, -0.01445519f, 0.11411452f, -0.07315239f, 
    0.08248036f, -0.05180404f, 0.00487262f, -0.00190517f, 0.01516709f, -0.45737299f, -0.07183064f, -0.18183342f, 
    0.14301333f, 0.32412773f, 0.12814370f, 0.09670354f, -0.02820680f, 0.04478772f, 0.04539006f, -0.13988993f, 
    0.16864908f, -0.02125685f, 0.14265229f, 0.05662759f, 0.05909205f, -0.00116471f, -0.01152754f, 0.04823212f, 
    0.17121115f, 0.10580521f, 0.10764299f, 0.25833753f, 0.03042743f, -0.03847568f, 0.04074282f, -0.14957449f, 
    -0.16173859f, 0.07222302f, 0.02846232f, 0.20506801f, 0.05482341f, 0.20405675f, -0.05776997f, -0.03400834f, 
    -0.00019180f, 0.30811599f, -0.03000947f, 0.09734819f, -0.03204798f, -0.01656785f, 0.03726642f, -0.30771700f, 
    0.22202048f, 0.00936288f, -0.00453443f, 0.32648891f, -0.14640233f, -0.16330974f, 0.00612910f, -0.03663835f, 
    -0.05598450f, -0.01628712f, -0.09415523f, 0.07375516f, -0.01778629f, -0.08420076f, -0.13350464f, -0.04337029f, 
    -0.27764529f, 0.32847822f, 0.06137682f, 0.07796624f, -0.00728296f, -0.05476737f, -0.15822817f, 0.08402478f, 
    -0.03662062f, -0.13985021f, -0.10559561f, -0.10583452f, 0.20981181f, 0.18919528f, -0.07794211f, -0.01281832f, 
    -0.10475542f, 0.05039884f, 0.09415211f, 0.03194395f, 0.09909897f, 0.04734495f, 0.01387162f, -0.04040707f, 
    -0.09668115f, 0.04452696f, -0.14657865f, 0.06820331f, 0.03023334f, -0.16687825f, -0.08190987f, 0.03255105f, 
    -0.15382090f, 0.03616749f, 0.01647074f, -0.07391838f, -0.01976459f, 0.08345266f, 0.10124054f, -0.01935527f, 
    0.01034827f, 0.04361030f, -0.00820198f, -0.14642011f, 0.19441085f, 0.03340593f, 0.05499642f, -0.08774207f, 
    0.00557539f, -0.22438970f, -0.04612894f, 0.08584725f, 0.03629300f, 0.14611141f, -0.18849622f, -0.16850141f, 
    -0.09915063f, -0.17082244f, -0.13723266f, 0.09305206f, 0.32660288f, 0.07888383f, 0.36181206f, 0.12182117f, 
    0.04269914f, -0.00524913f, -0.03976938f, -0.12465945f, -0.15825497f, -0.07100733f, -0.04682006f, 0.17385896f, 
    -0.20974842f, -0.18570168f, -0.09601083f, -0.19656816f, 0.10163096f, -0.01805519f, 0.16116174f, 0.12739435f, 
    0.12724407f, 0.09084783f, 0.00169752f, 0.03355950f, -0.24530542f, 0.03817849f, 0.03829315f, -0.02596337f, 
    0.02017269f, 0.04661666f, -0.01468615f, -0.16427317f, 0.19493242f, 0.08535440f, -0.08508537f, -0.04339987f, 
    -0.02920434f, -0.00209788f, 0.04315952f, 0.09292656f, -0.11232048f, -0.02190718f, -0.02964029f, 0.18586963f, 
    -0.04625079f, 0.02068581f, 0.07667262f, 0.12425008f, -0.30719393f, -0.13915603f, 0.10184506f, -0.28655791f, 
    -0.01652557f, 0.12142041f, -0.11478934f, -0.02310365f, 0.00362140f, 0.09813648f, 0.00005531f, 0.01241920f, 
    0.28791726f, 0.00989549f, 0.23153868f, 0.16484074f, 0.05325794f, -0.04264396f, -0.06221670f, -0.13236770f, 
    0.02612877f, -0.04252066f, -0.11137727f, -0.00993956f, 0.00146933f, -0.18454425f, -0.13586827f, -0.27232474f, 
    0.34252161f, 0.05860511f, -0.01800548f, 0.13767746f, -0.06175356f, 0.02139124f, 0.11419008f, 0.04235510f, 
    0.14362679f, 0.11805514f, 0.32820627f, 0.09319261f, 0.05614774f, 0.02148049f, 0.12448282f, -0.01151666f, 
    -0.06344765f, -0.09426299f, 0.03595555f, -0.21387215f, -0.18839140f, 0.13440363f, -0.16762228f, -0.03920715f, 
    0.02397873f, 0.11255548f, 0.06692677f, -0.11160866f, -0.00514210f, -0.01430822f, -0.02767389f, 0.04076253f, 
    0.26350823f, 0.01678744f, -0.05787707f, 0.12074177f, -0.07867128f, -0.06053611f, 0.04714674f, -0.05952098f, 
    0.00457444f, 0.17108510f, 0.06395797f, -0.13009019f, -0.11791780f, -0.10573271f, -0.05191951f, -0.31280020f, 
    -0.10483477f, -0.16541982f, 0.14934796f, -0.05876330f, 0.07801469f, 0.00983405f, 0.00647348f, 0.11388724f, 
    -0.06114336f, -0.24428044f, 0.00653337f, 0.23784533f, 0.08810149f, -0.15578604f, 0.17425297f, 0.05988874f, 
    -0.00403239f, 0.04803780f, 0.08856093f, 0.06633695f, 0.08854175f, 0.16815919f, -0.24485122f, 0.02485179f, 
    0.11539634f, 0.09504515f, 0.10539776f, 0.12303761f, -0.01748990f, -0.05259704f, -0.04126582f, -0.02684852f, 
    -0.10821278f, -0.45782739f, -0.11887370f, -0.15245731f, 0.16952196f, 0.21820571f, 0.12921810f, 0.02675200f, 
    0.06755559f, -0.01369484f, -0.02252324f, 0.04528972f, 0.19549744f, -0.11425918f, 0.05884681f, 0.05104538f, 
    0.11812030f, -0.11586451f, 0.04154265f, 0.04312664f, 0.17497747f, 0.09286889f, -0.09589050f, 0.17424609f, 
    0.03549474f, -0.37787807f, 0.13924482f, -0.07306533f, 0.06512373f, 0.09824573f, 0.02316266f, 0.22422193f, 
    0.13241598f, 0.17850116f, 0.06692082f, -0.00217092f, 0.09990954f, -0.09607694f, 0.41362351f, -0.06643448f, 
    -0.03261494f, -0.12190671f, -0.09274898f, -0.04030854f, 0.13391516f, 0.10285506f, 0.05667135f, 0.23790094f, 
    -0.12970307f, -0.20836380f, -0.14628404f, 0.20694606f, 0.14038585f, -0.10965654f, -0.00958887f, 0.12402777f, 
    -0.05132488f, -0.01979853f, -0.07547161f, -0.00447127f, -0.17952780f, -0.26105630f, 0.23766264f, 0.06500310f, 
    -0.20447797f, 0.03665433f, -0.16271493f, 0.13426444f, -0.07150814f, -0.10522038f, 0.02084913f, -0.00658350f, 
    0.07058252f, 0.28884825f, 0.27115807f, 0.03976630f, -0.14697646f, 0.06099137f, -0.19453120f, 0.07521557f, 
    0.00941532f, 0.08191129f, 0.06784814f, 0.02224229f, -0.20396522f, -0.07232444f, 0.11603572f, 0.19023307f, 
    0.17773852f, -0.04438821f, 0.10057717f, 0.26966658f, 0.08374581f, 0.20875123f, 0.04465557f, -0.07447917f, 
    0.16011789f, 0.40549460f, 0.06779955f, 0.00631585f, -0.04578533f, -0.04129754f, -0.05103037f, 0.02353048f, 
    0.10302334f, 0.17236690f, 0.14810087f, 0.06560860f, -0.02961231f, -0.04315149f, 0.14249247f, 0.31174487f, 
    0.12495244f, 0.12695776f, -0.02710622f, -0.08429229f, -0.04836880f, 0.04005194f, -0.07990091f, -0.04297445f, 
    0.00038372f, 0.33243373f, 0.05055925f, -0.01598333f, 0.00592490f, -0.06700858f, -0.01835543f, -0.03167766f, 
    0.16264360f, -0.08049361f, -0.01513174f, -0.11478570f, 0.05424267f, 0.02153930f, 0.27079624f, 0.25488508f, 
    0.08224677f, 0.14511541f, -0.11773613f, 0.04880576f, -0.00098876f, 0.11855864f, 0.12324810f, -0.10471984f, 
    0.11816081f, -0.09307534f, -0.17332898f, 0.01371179f, -0.08640348f, 0.01607492f, 0.20023148f, 0.04922200f, 
    -0.14665443f, -0.06595974f, -0.02855841f, -0.08540556f, -0.20200731f, -0.25421593f, 0.06084082f, 0.36425832f, 
    -0.04479214f, -0.08433660f, 0.03635506f, 0.10647459f, 0.02643906f, -0.00831259f, 0.06273925f, 0.33696821f, 
    0.04885391f, -0.04391337f, -0.03379083f, 0.11725406f, 0.04588884f, 0.08808196f, -0.05874342f, 0.03599037f, 
    0.04754198f, -0.02644061f, -0.08348091f, 0.09721710f, 0.19802468f, 0.14838628f, 0.23772094f, 0.02248869f, 
    -0.05756377f, 0.06124728f, 0.00663064f, -0.02517316f, -0.05689591f, 0.12560925f, -0.09688266f, 0.06135568f, 
    -0.19151677f, -0.17201178f, -0.07610809f, 0.33501127f, 0.02601845f, 0.03237109f, -0.12003295f, 0.06941291f, 
    -0.10396904f, 0.07945827f, -0.05095486f, 0.03767753f, 0.06158650f, 0.05626486f, -0.12907308f, -0.06164336f, 
    0.13433966f, 0.00448088f, 0.05248222f, -0.04545067f, -0.01429631f, -0.13326232f, 0.07228318f, 0.11389334f, 
    -0.07513184f, -0.07578538f, -0.01838618f, 0.27176592f, 0.18138510f, 0.15454529f, 0.02473008f, -0.02826677f, 
    -0.02572073f, 0.08940437f, 0.10358850f, 0.10993385f, 0.04715188f, -0.07662059f, -0.16797744f, -0.26758599f, 
    -0.13711196f, -0.03865213f, 0.04096296f, 0.01075401f, 0.22059754f, 0.00263179f, -0.02011588f, -0.04718072f, 
    0.03297954f, 0.28242183f, 0.08487943f, -0.03924913f, 0.07506897f, 0.09147671f, -0.07057319f, -0.09443055f, 
    -0.06290910f, -0.04685935f, -0.13172027f, 0.08662806f, 0.11022938f, 0.05916909f, 0.34558362f, 0.05790725f, 
    -0.11897766f, -0.06561690f, 0.10306986f, 0.03763971f, 0.06951284f, -0.07167865f, 0.01210370f, 0.10616960f, 
    0.15398091f, -0.30832338f, 0.09955788f, -0.17375450f, -0.02047048f, 0.03951939f, -0.05943680f, 0.14892316f, 
    -0.00853365f, -0.06082730f, -0.07157253f, 0.04151186f, 0.26384088f, 0.23902129f, 0.08031470f, 0.06519701f, 
    -0.05749080f, -0.09166774f, 0.04378030f, 0.01211212f, 0.01117060f, 0.12335559f, -0.06535649f, -0.01292713f, 
    -0.14283630f, -0.13773626f, -0.30660716f, -0.24593724f, 0.12735505f, -0.02076906f, 0.09353814f, 0.07707339f, 
    0.03988133f, 0.08805567f, -0.02689941f, -0.05421291f, 0.19910581f, -0.34355769f, 0.11949395f, 0.12315804f, 
    -0.16414624f, 0.04062105f, -0.07817558f, -0.03984196f, -0.02746390f, -0.05202758f, -0.11927952f, 0.05308660f, 
    0.00216268f, -0.26970866f, -0.08463974f, -0.07201365f, 0.03982538f, -0.06742054f, 0.00886456f, 0.00303285f, 
    -0.20576219f, -0.17686775f, -0.02678080f, 0.05588138f, 0.18254758f, -0.08053763f, -0.07741023f, -0.12444463f, 
    0.03182266f, 0.03544698f, -0.00087691f, -0.11818478f, 0.04435939f, -0.09298595f, 0.04208080f, -0.00703125f, 
    -0.12119266f, 0.05129604f, -0.00483614f, -0.01172594f, -0.04295044f, 0.03338337f, -0.02768885f, 0.00453645f, 
    0.08729818f, 0.01669502f, 0.04365769f, 0.07319870f, -0.01447666f, 0.15635297f, 0.07855199f, -0.05675420f, 
    -0.01271467f, 0.05995124f, 0.10046250f, 0.04791978f, 0.06460758f, 0.02725878f, 0.07027146f, 0.07007869f, 
    -0.11325481f, 0.13411756f, 0.16569163f, 0.00573448f, -0.11299905f, 0.02752887f, -0.13113771f, 0.07872172f, 
    0.14855637f, -0.00411907f, -0.02546540f, -0.09855868f, 0.02608288f, -0.09164057f, -0.42514995f, 0.09027802f, 
    -0.00865320f, -0.10659232f, 0.06881864f, 0.04223213f, 0.06366034f, -0.04228127f, -0.03078092f, 0.00927039f, 
    0.00598833f, 0.26790246f, 0.03246105f, 0.08860637f, 0.03064827f, -0.01280494f, -0.05230254f, 0.06448890f, 
    -0.02139939f, -0.07230534f, -0.08817872f, 0.00175640f, -0.10223570f, -0.13684092f, -0.06210783f, -0.06822640f, 
    -0.15349019f, 0.05972383f, 0.00969022f, -0.00485962f, -0.00885261f, -0.02000767f, -0.04968494f, 0.06464629f, 
    0.02988769f, 0.21783128f, 0.10283460f, 0.05924727f, -0.13783416f, -0.10628794f, -0.03163407f, 0.09042393f, 
    -0.09032901f, 0.05866220f, 0.20811222f, 0.07177970f, 0.11173993f, 0.15705957f, -0.18911202f, 0.00892489f, 
    0.05029950f, 0.00207701f, 0.11579517f, 0.12322905f, -0.00814977f, -0.04592022f, -0.00752967f, -0.01836910f, 
    0.00942112f, -0.05089133f, -0.07026722f, 0.03874141f, 0.03226335f, -0.04188603f, 0.01760564f, 0.03693357f, 
    -0.05966859f, -0.03754785f, -0.02706525f, -0.08047985f, -0.02354445f, -0.01810483f, 0.04046795f, -0.03578788f, 
    -0.01809070f, -0.07875392f, -0.02592600f, 0.04571947f, -0.07927500f, -0.04891097f, -0.04449939f, 0.04036324f, 
    0.03918688f, -0.05298430f, 0.06378836f, -0.04772042f, 0.05797562f, -0.02268146f, 0.02483217f, -0.02095478f, 
    0.02122222f, -0.00168257f, 0.02876245f, -0.01888886f, 0.01512630f, -0.00092080f, 0.06289635f, -0.03670064f, 
    0.02279083f, -0.05699423f, 0.05023210f, 0.04345814f, 0.02861320f, -0.07150208f, 0.03647896f, -0.01374149f, 
    0.04420541f, -0.07074547f, -0.05752359f, -0.02692300f, 0.03048132f, 0.00688823f, 0.03399270f, -0.06436713f, 
    -0.04828734f, -0.04652847f, -0.04697461f, -0.00164687f, 0.00746450f, 0.01537563f, -0.01489150f, 0.00841201f, 
    -0.04768648f, -0.00181062f, 0.05136479f, -0.00638932f, -0.04428993f, -0.02086473f, -0.01235407f, -0.01605635f, 
    -0.02249861f, -0.07873543f, 0.05029628f, 0.03406958f, 0.05726150f, 0.00020432f, 0.03847041f, 0.00488413f, 
    -0.03986912f, -0.07494592f, 0.03760558f, 0.03285763f, 0.04602975f, -0.05263377f, -0.02309318f, 0.01000943f, 
    0.04357075f, -0.00963713f, -0.02250568f, -0.04255538f, -0.05811468f, 0.04725975f, 0.05673271f, -0.05940068f, 
    -0.07835540f, -0.05474080f, -0.05374170f, -0.08769678f, -0.07989938f, -0.02071372f, -0.03410216f, -0.02946044f, 
    -0.07790853f, 0.02240433f, -0.04863538f, 0.03005871f, -0.00584316f, -0.07776979f, 0.02903985f, 0.01441805f, 
    -0.02095032f, -0.01847915f, -0.00214204f, -0.06730960f, 0.03125552f, 0.03074571f, 0.04228183f, 0.04810755f, 
    -0.00089184f, 0.03739997f, 0.02633884f, 0.01544184f, -0.03475069f, 0.03188431f, -0.05794162f, -0.01941044f, 
    0.02390198f, -0.07127100f, 0.01439410f, -0.02567367f, -0.05056608f, -0.05618472f, -0.01490703f, -0.02927201f, 
    -0.08079468f, -0.05606969f, 0.01334365f, -0.04383243f, -0.00963518f, -0.06539202f, -0.05423426f, -0.00220349f, 
    0.02911728f, -0.05185670f, 0.02366693f, -0.05934436f, -0.04122458f, -0.04511725f, -0.00036833f, -0.06026619f, 
    -0.06387903f, 0.05206275f, 0.00304735f, -0.06682805f, -0.05734441f, 0.05788804f, -0.05185609f, 0.00291748f, 
    0.03478645f, 0.05392706f, -0.01132179f, -0.03418522f, -0.00386989f, 0.01224080f, -0.05292277f, 0.02519920f, 
    -0.03604960f, 0.01152256f, -0.05802035f, -0.01060996f, 0.04196396f, 0.05066832f, -0.05137606f, 0.02882423f, 
    -0.06852192f, -0.03353693f, 0.03960247f, -0.03425235f, -0.04651510f, 0.06404695f, -0.05050038f, -0.06934644f, 
    -0.03079938f, 0.03903003f, 0.01363564f, -0.07311021f, 0.01765459f, -0.03220443f, -0.01558768f, 0.02310093f, 
    0.10017932f, 0.39274856f, 0.19395311f, -0.03734200f, 0.08818081f, 0.25691316f, 0.03318120f, -0.01557324f, 
    0.10626948f, 0.07702779f, -0.07674413f, 0.05466474f, 0.10640650f, 0.23588975f, -0.13626876f, -0.25335088f, 
    0.06888985f, 0.07797929f, 0.24075173f, 0.06803296f, -0.07644231f, -0.04510302f, -0.03002420f, -0.11307253f, 
    0.27962825f, -0.12087244f, -0.11745579f, -0.04188117f, 0.03757275f, 0.01474113f, 0.09100079f, -0.14819100f, 
    0.03772658f, -0.12591240f, -0.04893934f, -0.10912362f, 0.22458735f, 0.08024122f, -0.09791727f, 0.10446931f, 
    0.04111897f, 0.10951375f, -0.03061084f, -0.10835379f, 0.05229193f, -0.06051236f, 0.25312385f, 0.00273903f, 
    -0.34290716f, -0.13258117f, 0.35227686f, -0.03527257f, 0.03981958f, 0.10196447f, -0.04918433f, -0.00131770f, 
    -0.03118213f, -0.01378761f, 0.07446627f, 0.07186342f, 0.14946665f, -0.01455847f, -0.12656693f, -0.32579041f, 
    0.01503506f, -0.04285226f, 0.00326807f, 0.14490016f, 0.09986301f, -0.04944650f, 0.01299879f, -0.16957405f, 
    0.20124109f, -0.12229373f, 0.04113944f, 0.09100506f, -0.11179683f, -0.08724292f, -0.04044664f, -0.13130434f, 
    -0.01792835f, 0.01310064f, 0.14134143f, 0.22637135f, 0.15104000f, -0.12671961f, -0.07575018f, -0.38679883f, 
    -0.13770144f, -0.01147076f, 0.01191699f, 0.21531186f, 0.00027467f, -0.02841157f, -0.17177026f, -0.00636283f, 
    -0.12016921f, 0.00769490f, 0.13600920f, 0.11353102f, 0.02210650f, 0.18852501f, 0.00789772f, -0.07789787f, 
    0.15156232f, 0.05053379f, 0.07251383f, 0.27531025f, 0.02935919f, 0.19582957f, 0.01350555f, -0.00030428f, 
    0.03910143f, 0.14837740f, -0.06093601f, -0.04306460f, -0.15640514f, -0.18963440f, -0.14050101f, -0.10408986f, 
    -0.01759949f, 0.32529411f, 0.07815181f, -0.08259938f, -0.04210383f, 0.07072207f, 0.02615454f, 0.05987305f, 
    -0.00448076f, 0.12057541f, -0.00006708f, -0.08936738f, -0.10791973f, -0.03048993f, 0.15191911f, 0.16991256f, 
    -0.01096470f, -0.18765916f, -0.04787581f, 0.19716868f, 0.04830552f, -0.19598314f, 0.06873848f, -0.01752999f, 
    -0.06270456f, 0.12054959f, 0.02923322f, -0.29336911f, 0.09780900f, 0.03703992f, -0.05658509f, -0.07284520f, 
    0.01545614f, -0.02520703f, 0.09807623f, 0.04191212f, -0.15270619f, -0.00132363f, 0.22304350f, -0.10194281f, 
    -0.21758200f, 0.05805457f, -0.20348962f, -0.18618101f, 0.07780951f, 0.22934553f, 0.03731077f, 0.03637763f, 
    -0.01189761f, 0.12831128f, 0.08199850f, -0.00891923f, -0.04514508f, -0.03292156f, -0.12023761f, 0.04637695f, 
    0.06879269f, -0.00827889f, 0.02762058f, -0.01811886f, 0.57452410f, 0.13348345f, -0.13523605f, 0.18015973f, 
    -0.08431514f, -0.10535531f, -0.12482014f, -0.06124416f, 0.02449666f, -0.01206466f, -0.01778176f, -0.03923137f, 
    0.04301412f, -0.06340447f, 0.00604254f, -0.04136370f, 0.11641115f, -0.02630557f, 0.02732141f, 0.03229005f, 
    0.09961620f, 0.14270625f, 0.12323245f, 0.22623809f, 0.35525310f, -0.15615122f, 0.25572622f, 0.05347918f, 
    0.00739222f, -0.05688949f, -0.20534854f, -0.10015117f, 0.06229404f, -0.07156589f, -0.09192687f, -0.21299516f, 
    -0.11007392f, -0.00274499f, 0.14169875f, -0.15281692f, 0.16915064f, 0.02443647f, -0.00514249f, 0.19150230f, 
    -0.16264401f, -0.08690535f, -0.09216205f, 0.08952247f, 0.32225722f, 0.07017042f, -0.20865735f, 0.00506601f, 
    -0.03017406f, -0.14951394f, -0.03830373f, 0.08933613f, 0.13882326f, -0.05158971f, -0.04001997f, 0.16731596f, 
    -0.28617615f, -0.11262165f, -0.13132364f, -0.07631534f, -0.09448952f, -0.02326950f, 0.04863497f, 0.01722451f, 
    -0.06135651f, 0.01310463f, -0.05092825f, 0.04786835f, 0.06312718f, -0.15156013f, 0.06478083f, 0.22133636f, 
    0.00193924f, 0.20863776f, 0.12230905f, -0.06475384f, 0.02365033f, -0.06172426f, -0.01866209f, 0.00761324f, 
    -0.26341447f, -0.27984211f, -0.16406816f, -0.01977685f, -0.03258272f, 0.01570514f, -0.02684476f, 0.06932854f, 
    -0.11857156f, 0.00838198f, 0.00989025f, 0.07015961f, -0.30950606f, -0.04355154f, -0.03491230f, -0.16394641f, 
    -0.00864823f, 0.03895930f, 0.02788021f, 0.14942832f, -0.03945582f, 0.02247332f, 0.04478969f, -0.06611512f, 
    -0.01126031f, 0.30767021f, 0.05896571f, -0.05937427f, 0.08333969f, -0.07089939f, 0.12470555f, -0.03364903f, 
    0.08096432f, 0.02067365f, 0.02729364f, 0.14701012f, 0.05358414f, -0.06510455f, 0.01031449f, -0.01196541f, 
    -0.06503405f, -0.03089619f, -0.12503175f, 0.08505014f, 0.01300428f, -0.01951035f, 0.01694954f, 0.15984215f, 
    0.16164218f, -0.03491621f, 0.13143231f, -0.03834341f, 0.11403441f, -0.16066001f, -0.04072236f, 0.06728662f, 
    0.10915830f, -0.02384527f, 0.13228931f, 0.02160028f, 0.01368133f, 0.14279523f, 0.08095212f, -0.04681851f, 
    0.13037069f, 0.17536165f, 0.21381532f, -0.04791522f, -0.07463935f, 0.09782354f, 0.08060460f, 0.01017472f, 
    0.36569333f, 0.33510798f, -0.09283081f, -0.03762239f, -0.07333416f, -0.24016039f, -0.07058349f, 0.08012932f, 
    -0.02362699f, 0.00451049f, -0.06355733f, -0.00112345f, -0.09755697f, 0.01417066f, 0.02267083f, -0.02288156f, 
    -0.06298561f, 0.02026409f, 0.03847306f, -0.00571615f, 0.12833868f, 0.02024918f, 0.14720632f, -0.14704911f, 
    0.15707126f, 0.29170135f, -0.26371866f, -0.10669915f, -0.01660497f, 0.13133767f, -0.09819528f, -0.09327961f, 
    0.05523224f, -0.04820678f, 0.10581847f, 0.18721557f, -0.06680406f, 0.18936875f, 0.03470150f, 0.21224439f, 
    0.02453285f, 0.13293065f, 0.13376793f, -0.04264075f, 0.11244903f, 0.01446094f, 0.09535996f, 0.15894090f, 
    0.19193761f, 0.22541936f, -0.02710481f, 0.04279284f, 0.06980395f, -0.00161637f, -0.10991893f, -0.15733628f, 
    0.09296446f, 0.22161567f, -0.07400744f, -0.09071115f, 0.27891651f, -0.06507417f, -0.15578511f, -0.18760918f, 
    0.10288441f, 0.03614926f, 0.12421025f, 0.26633796f, 0.06071423f, 0.09415870f, 0.15009847f, 0.03932963f, 
    0.20677783f, 0.05816630f, 0.05128729f, 0.06948854f, 0.09712102f, -0.09462483f, 0.07038323f, -0.09057228f, 
    0.24179757f, -0.17744270f, 0.09819204f, 0.02595877f, 0.13271272f, 0.05127594f, -0.18468906f, 0.21693946f, 
    0.04211270f, -0.01360381f, 0.00224630f, 0.04157432f, 0.10439709f, -0.05267810f, -0.03256969f, -0.00419246f, 
    -0.12581505f, 0.25408033f, 0.37872446f, -0.03575917f, -0.09153308f, -0.04007993f, -0.02164393f, -0.17099024f, 
    -0.03432442f, 0.03615272f, 0.02097209f, -0.03901852f, -0.01903326f, -0.14480565f, -0.18214983f, -0.07515321f, 
    -0.00728353f, 0.07114114f, -0.07624485f, -0.04141152f, 0.03826870f, -0.06912901f, 0.02707288f, -0.05447116f, 
    0.28285694f, 0.08431146f, 0.08294758f, 0.22795419f, -0.09730462f, -0.07157246f, -0.07270535f, -0.12106097f, 
    -0.18836549f, -0.11272080f, -0.01714985f, 0.03626370f, 0.07346152f, -0.00647956f, 0.05899597f, -0.02383612f, 
    -0.33185878f, 0.02524877f, 0.10315556f, 0.08889626f, 0.04558259f, -0.07140490f, 0.07493211f, 0.03796864f, 
    -0.21664537f, 0.03289863f, -0.06162069f, -0.27220231f, 0.15446711f, -0.02954440f, 0.03508487f, -0.05852865f, 
    0.00658358f, -0.11419576f, -0.13840009f, 0.06411423f, 0.10189106f, 0.00814365f, -0.11637221f, 0.19748466f, 
    0.01489348f, 0.03700515f, 0.00352722f, 0.21529560f, -0.09714876f, 0.07659005f, -0.01318028f, 0.14831525f, 
    -0.20712899f, 0.19857053f, -0.12757204f, -0.15703879f, 0.10938726f, 0.01252383f, 0.01559633f, -0.09767131f, 
    0.04886347f, -0.01784044f, -0.06551465f, 0.00398940f, 0.23908138f, 0.26377454f, 0.06855992f, 0.06400981f, 
    -0.03133698f, -0.21220882f, -0.05084385f, -0.04135548f, -0.07872605f, 0.09514850f, 0.08244830f, 0.04072366f, 
    -0.16484940f, 0.23271002f, -0.10994323f, -0.11887873f, 0.07214406f, -0.05702311f, -0.09543136f, 0.19987248f, 
    -0.13672049f, 0.05662034f, 0.14160353f, -0.09421307f, -0.10176975f, 0.17454217f, 0.14185932f, -0.27316269f, 
    -0.08669533f, 0.12312560f, -0.11435404f, -0.30502290f, 0.04107473f, 0.13481034f, 0.14486338f, 0.08880588f, 
    -0.13565429f, 0.27814189f, -0.08855160f, -0.17064087f, 0.07618045f, 0.01500075f, -0.14003254f, -0.05665001f, 
    -0.03270143f, -0.02372318f, -0.11606365f, -0.06057652f, 0.40161610f, 0.17914414f, -0.09698224f, -0.01165940f, 
    -0.02611838f, 0.04111724f, -0.20586881f, -0.16340238f, 0.09648658f, 0.05848168f, 0.04769304f, 0.00040838f, 
    0.18646185f, 0.11010925f, 0.29669139f, 0.30532146f, -0.06809793f, 0.18866155f, -0.03587759f, 0.05621000f, 
    0.01921629f, 0.05939313f, 0.13453527f, -0.04994142f, -0.05069883f, 0.02784974f, -0.32578400f, -0.10944154f, 
    0.18683967f, -0.06202929f, 0.12041684f, 0.00651553f, -0.04221648f, 0.01880154f, 0.03627631f, -0.01965856f, 
    -0.10585523f, 0.22884423f, -0.33471134f, 0.19588016f, -0.13089959f, -0.01234570f, 0.23745553f, -0.29666954f, 
    -0.04237191f, -0.01109550f, 0.07553745f, -0.21026307f, -0.08241213f, -0.15068869f, -0.01030407f, 0.16431005f, 
    0.06379989f, 0.04572690f, -0.09772272f, -0.07510474f, -0.06225757f, -0.10020170f, 0.23964241f, 0.04198529f, 
    -0.35030937f, -0.12176510f, 0.23949899f, -0.12892985f, -0.11659300f, 0.12427961f, -0.22665833f, 0.13019647f, 
    0.03899638f, 0.03500694f, 0.02963330f, 0.08731531f, -0.28073046f, 0.31346893f, -0.10438921f, -0.27324083f, 
    -0.08129207f, -0.03851881f, 0.01753812f, 0.23530236f, -0.13302206f, -0.02487593f, 0.01979738f, -0.03970047f, 
    -0.10324237f, 0.18646042f, -0.13362263f, -0.16427317f, 0.02091822f, -0.07997716f, -0.12019960f, -0.13843702f, 
    0.05817679f, 0.12907504f, 0.04502166f, 0.07376292f, -0.57069969f, 0.01082326f, 0.02894342f, -0.62971473f, 
    0.15293063f, 0.04374449f, -0.20795549f, 0.07355973f, 0.11957549f, 0.00906108f, -0.05730425f, -0.06399767f, 
    0.29319558f, 0.04125002f, 0.18334471f, 0.18245372f, 0.12370615f, 0.05309787f, -0.08279205f, -0.06455173f, 
    0.12725627f, -0.02093517f, 0.10672413f, 0.15927103f, -0.02441641f, 0.03502278f, 0.18770909f, 0.26427579f, 
    -0.07183892f, 0.17057687f, -0.04920809f, 0.05875217f, -0.06297025f, -0.15389518f, -0.07693664f, -0.20002754f, 
    0.03395320f, 0.20677298f, -0.00726656f, 0.13953857f, 0.15028253f, 0.07296481f, 0.07350386f, -0.00823305f, 
    -0.10935365f, 0.08809110f, -0.04306738f, -0.04723825f, -0.35546997f, -0.35605997f, 0.47785181f, 0.00445544f, 
    0.06096962f, -0.16265643f, -0.28177214f, 0.20808935f, 0.05315832f, -0.31738180f, 0.05018349f, -0.10909285f, 
    0.05593327f, -0.24789271f, 0.08100723f, 0.06420878f, -0.05532809f, -0.01293473f, 0.06348684f, -0.12184750f, 
    -0.03677220f, 0.02624871f, 0.07273012f, 0.09620871f, 0.05328843f, -0.14301576f, -0.01067319f, 0.10979815f, 
    -0.06572904f, -0.04756156f, -0.19906031f, 0.04481986f, 0.07699601f, 0.27047914f, 0.11005760f, -0.04551006f, 
    0.23040459f, -0.24216695f, -0.04254277f, 0.06409363f, 0.03351690f, -0.03519170f, 0.00780312f, 0.00405885f, 
    -0.04669923f, 0.02251714f, 0.01704098f, 0.04719229f, 0.27264768f, -0.13789219f, -0.01379287f, 0.04711429f, 
    0.20448072f, 0.00597299f, -0.11693174f, 0.03879721f, 0.00910041f, 0.07791030f, -0.01896405f, 0.03690693f, 
    -0.10820963f, -0.21711203f, 0.13612822f, 0.01302836f, -0.03545402f, 0.02486404f, 0.03918636f, 0.15844288f, 
    0.11876322f, -0.05327196f, 0.11971767f, 0.22848807f, -0.01093461f, -0.12360351f, 0.14096579f, -0.03092186f, 
    0.15545192f, -0.08298828f, -0.02087083f, -0.02797633f, 0.02569023f, -0.19737406f, -0.23162700f, -0.30413136f, 
    -0.09627961f, 0.06755154f, 0.01555841f, -0.05890809f, 0.07757091f, 0.01549133f, -0.07627412f, 0.06871776f, 
    -0.13541704f, 0.04283642f, -0.02618587f, 0.10419769f, -0.03253772f, 0.01204610f, 0.29825863f, -0.02373873f, 
    -0.05825201f, 0.00738151f, -0.01790783f, 0.00998444f, 0.17045216f, 0.18130182f, 0.12747978f, 0.08565568f, 
    0.42273569f, -0.14732254f, -0.35650462f, -0.02439982f, -0.00398233f, -0.02912134f, -0.09411038f, 0.06466766f, 
    0.16191913f, 0.13841376f, -0.02145788f, 0.04519667f, -0.17114796f, -0.19003536f, 0.32839555f, 0.13706297f, 
    0.11586811f, -0.02745285f, -0.13861261f, 0.11597054f, -0.08570810f, -0.03803988f, -0.22456852f, -0.06736498f, 
    -0.14529574f, -0.10736252f, -0.01270739f, -0.20873426f, -0.10529903f, 0.00588271f, 0.14933467f, 0.11125188f, 
    0.28293127f, 0.30025911f, 0.09284683f, 0.29910240f, -0.28320569f, 0.23552710f, -0.15918447f, -0.20826042f, 
    0.18076475f, 0.18407799f, -0.04008237f, -0.08287156f, 0.03031552f, 0.06135897f, 0.04308833f, -0.12032385f, 
    0.10891736f, 0.11025769f, -0.19852078f, 0.08499550f, 0.01519785f, 0.01514313f, 0.04558982f, -0.01501690f, 
    0.14230256f, 0.08287957f, 0.20600994f, 0.18485953f, -0.09589330f, -0.12223949f, 0.18458013f, 0.00756256f, 
    0.02450544f, -0.04335603f, -0.02777441f, -0.03010254f, 0.08500788f, -0.10463165f, 0.00513826f, -0.04192411f, 
    0.03906960f, -0.07460486f, 0.23677738f, 0.23140529f, 0.05074247f, -0.04933553f, -0.01785659f, 0.17531557f, 
    0.07234146f, 0.09615183f, 0.02383951f, 0.09323108f, -0.09779187f, 0.09580100f, 0.11556723f, 0.16756602f, 
    0.12547150f, 0.19000106f, -0.01777785f, -0.04482391f, 0.06513298f, -0.04234865f, -0.09034070f, -0.05463612f, 
    0.11384760f, -0.17063169f, 0.04780428f, 0.16043067f, -0.00330561f, 0.03735291f, 0.12221579f, -0.00864846f, 
    -0.01481789f, -0.13987194f, -0.23948614f, -0.14134082f, -0.02458575f, -0.19609493f, -0.13021937f, 0.20969656f, 
    0.05979422f, -0.07928947f, -0.11473759f, 0.15674882f, 0.07290121f, 0.03660347f, -0.06508156f, -0.07759460f, 
    0.21501963f, -0.18184611f, 0.02240850f, 0.32009697f, 0.00742005f, -0.02837672f, 0.00926406f, 0.07987558f, 
    0.02060533f, 0.11578429f, 0.01987544f, 0.20755164f, -0.11233902f, 0.06988712f, 0.30368242f, 0.07278673f, 
    -0.04195864f, -0.13087589f, -0.01344548f, -0.04764835f, -0.00510680f, 0.00814102f, 0.00828716f, -0.01605216f, 
    0.06819405f, -0.05570162f, -0.02297850f, -0.06829552f, -0.04706147f, -0.06750080f, -0.07368675f, 0.06027224f, 
    0.04987828f, -0.00521587f, 0.03645306f, 0.02337880f, 0.01737568f, -0.03923779f, -0.04329887f, 0.02631978f, 
    -0.00874854f, 0.06406906f, 0.06276392f, -0.02522597f, 0.06418606f, -0.06125699f, -0.01965913f, -0.03991480f, 
    0.01684708f, -0.03999165f, -0.01345607f, -0.07492006f, -0.06107469f, 0.05563974f, -0.04932240f, -0.07613327f, 
    0.06238313f, -0.04934439f, 0.02401047f, 0.00350774f, -0.05909149f, -0.01215097f, -0.06651548f, -0.03813031f, 
    -0.01852983f, -0.05071119f, 0.00375969f, 0.03295948f, 0.00674009f, 0.03253671f, -0.00564581f, 0.05421586f, 
    -0.07748483f, -0.04083679f, 0.05550837f, -0.00459831f, 0.04578457f, 0.00739834f, 0.00484859f, 0.05680484f, 
    -0.03096190f, -0.03465863f, 0.05630128f, -0.03394245f, -0.03663772f, -0.06784003f, 0.02247630f, -0.01724317f, 
    -0.05970692f, 0.03733392f, -0.00601645f, -0.05681127f, -0.03913014f, 0.01315840f, 0.02599881f, -0.07210141f, 
    -0.00392373f, 0.04891038f, 0.03592559f, 0.04610500f, 0.06095755f, -0.05761183f, -0.06882680f, 0.06050296f, 
    -0.04761159f, 0.00907231f, -0.06635223f, 0.06225095f, 0.00037759f, 0.04192216f, 0.02150791f, -0.02368050f, 
    0.03511226f, -0.00109312f, 0.06358293f, -0.07494379f, -0.01172189f, -0.05534355f, -0.07080752f, -0.06504818f, 
    0.04447928f, -0.01613661f, 0.04587679f, -0.04255693f, -0.03938939f, -0.06718063f, -0.03583967f, -0.02830980f, 
    0.06286664f, -0.03372524f, -0.01143067f, -0.04376465f, 0.04201500f, 0.05674669f, 0.02779391f, 0.02687033f, 
    -0.05902031f, 0.04737889f, -0.07259279f, 0.02597116f, -0.03335387f, 0.02967434f, 0.03270610f, -0.02625320f, 
    0.05434481f, -0.04286499f, -0.07685849f, -0.04383874f, -0.05367387f, 0.03963033f, -0.01783520f, -0.05417145f, 
    0.00411833f, -0.02692529f, -0.07111917f, -0.06896099f, -0.01102680f, -0.07419322f, -0.06808922f, 0.01409198f, 
    -0.05848799f, 0.01506703f, -0.04074648f, -0.01029856f, 0.06287940f, -0.03758582f, -0.07571629f, 0.03150140f, 
    -0.00656441f, -0.03389344f, 0.01716995f, 0.00562042f, -0.01999667f, -0.04607640f, 0.03853942f, -0.01125267f, 
    0.04158609f, -0.01117222f, -0.07315648f, -0.01727768f, 0.05824826f, 0.04207954f, -0.04708636f, -0.04004140f, 
    0.00965843f, 0.00687642f, 0.02853974f, -0.00730665f, -0.02137209f, -0.02914297f, 0.00317792f, 0.02827568f, 
    -0.02478761f, -0.06757176f, 0.06152600f, -0.06106534f, -0.02958233f, -0.07227370f, -0.01911203f, 0.01012174f, 
    0.04709642f, 0.03871776f, 0.05847612f, 0.05735624f, 0.04228774f, -0.01346317f, -0.04466223f, 0.01340874f, 
    0.02300213f, -0.04340927f, -0.01818805f, -0.07327625f, -0.03508160f, -0.05576394f, 0.04330511f, 0.00603110f, 
    -0.03596788f, -0.07052272f, -0.02287796f, 0.01352525f, 0.01449450f, 0.00724050f, -0.03243571f, 0.01984348f, 
    0.05770406f, 0.04614847f, -0.02757482f, 0.02885602f, 0.04878533f, -0.02178626f, 0.04075331f, 0.04611758f, 
    -0.04756204f, -0.05289808f, -0.04818577f, 0.03379286f, 0.03766512f, -0.02147406f, 0.00061186f, -0.04378673f, 
    -0.04439322f, -0.07666808f, -0.02827534f, 0.03754630f, -0.03055561f, -0.00393456f, -0.00250691f, 0.04619222f, 
    0.02949119f, -0.01631252f, 0.01269589f, 0.05105924f, -0.02561277f, 0.00334914f, 0.00479779f, -0.01011206f, 
    -0.03458644f, -0.03877838f, 0.00442420f, -0.06520785f, -0.04488322f, 0.04181128f, -0.03548060f, 0.03803188f, 
    -0.08382976f, -0.00177118f, 0.00154674f, 0.01284254f, -0.01388711f, -0.01375490f, 0.05996968f, -0.06504301f, 
    0.03222838f, -0.05339542f, -0.03451914f, -0.04696269f, 0.04575714f, 0.00992922f, 0.06129439f, -0.06085445f, 
    -0.04241939f, -0.05855971f, 0.04854852f, 0.02740634f, 0.01353904f, 0.02449427f, 0.04375666f, -0.07788534f, 
    -0.03359677f, 0.06712399f, 0.03948652f, -0.04312335f, -0.05460184f, -0.04313791f, -0.01086644f, -0.05932534f, 
    0.05450632f, 0.04094162f, 0.05768605f, -0.03673243f, 0.06193382f, -0.06812911f, -0.02737023f, -0.03617682f, 
    -0.01486403f, -0.02635265f, -0.06948650f, -0.06499729f, 0.00446470f, 0.02245837f, 0.00368211f, 0.01266114f, 
    0.00130530f, 0.01188718f, 0.00481587f, 0.02178939f, 0.04387453f, 0.01425249f, 0.03091983f, -0.02092938f, 
    0.05881381f, 0.02887130f, 0.04569425f, 0.04094179f, -0.05117004f, -0.07077792f, -0.04302595f, 0.04906073f, 
    -0.06165425f, 0.04107653f, -0.06024716f, -0.01225689f, -0.04816219f, -0.05649517f, 0.00284786f, 0.05500077f, 
    0.02412595f, -0.08414649f, 0.03851078f, -0.06677938f, -0.04295880f, -0.05379543f, -0.06496748f, -0.05727953f, 
    0.06185363f, -0.03205827f, -0.08466273f, 0.00574258f, 0.00436859f, 0.02920627f, 0.01240953f, -0.05001143f, 
    0.05161593f, -0.00178134f, 0.00186470f, -0.04718827f, -0.03593154f, -0.06308016f, -0.03627223f, -0.07554320f, 
    0.01158387f, -0.05773619f, 0.00553521f, 0.05263006f, 0.02018590f, -0.07679377f, -0.02006233f, -0.07120614f, 
    -0.01677987f, -0.02655871f, -0.02900274f, -0.07578102f, -0.00335739f, 0.04778922f, -0.05537925f, -0.06040632f, 
    -0.03719206f, 0.05623283f, -0.08437024f, 0.03896021f, 0.05881619f, -0.00745029f, 0.00677300f, 0.01060924f, 
    -0.05951914f, -0.04732363f, -0.06433801f, -0.00351265f, -0.00900255f, -0.00502609f, -0.07425273f, 0.01373603f, 
    -0.00826833f, 0.03364682f, -0.04679237f, 0.02304619f, -0.04950175f, -0.01299621f, 0.05373194f, -0.03625607f, 
    -0.01864567f, -0.06296181f, 0.03680639f, -0.02282702f, -0.03848830f, -0.00448974f, 0.00490503f, -0.04700413f, 
    0.23697506f, 0.39961636f, 0.18260323f, -0.17693108f, 0.00958063f, -0.09080310f, 0.02071294f, 0.01595162f, 
    0.05317207f, 0.09517494f, -0.03335741f, 0.02948918f, 0.26713371f, 0.11885311f, 0.06624685f, -0.11033077f, 
    -0.03504285f, 0.13626370f, 0.02049189f, 0.15248767f, 0.08645878f, -0.02653790f, 0.12736981f, 0.00266604f, 
    0.13690619f, -0.01203274f, 0.25038025f, 0.02751973f, 0.08942027f, -0.01397822f, -0.09321509f, 0.10698316f, 
    -0.06975143f, -0.09918099f, 0.13948849f, -0.06768751f, 0.00025854f, 0.02648039f, -0.02043747f, 0.02265404f, 
    -0.08162415f, -0.02976999f, 0.09568537f, 0.12797953f, -0.05857495f, -0.01403137f, 0.05391572f, -0.00237108f, 
    -0.00777023f, 0.01128482f, 0.02111043f, -0.07717626f, -0.10130151f, -0.03055570f, -0.13222645f, -0.11407814f, 
    -0.07207657f, 0.02560537f, 0.10117739f, 0.00040551f, -0.43557483f, -0.16870874f, -0.09250260f, 0.12868510f, 
    0.02586996f, 0.06318180f, 0.11692614f, 0.00335639f, -0.01502386f, -0.11819387f, -0.12401030f, -0.04366156f, 
    -0.03210751f, -0.16742653f, -0.14346801f, -0.06876595f, -0.11503503f, 0.00315823f, -0.00866432f, 0.06757504f, 
    -0.18479197f, -0.09938925f, 0.05084517f, 0.00418687f, 0.22312729f, -0.26356331f, -0.00925053f, -0.19105850f, 
    -0.00753713f, -0.11664551f, 0.06307113f, 0.00635725f, 0.12108133f, 0.18325140f, 0.04207781f, 0.11325963f, 
    -0.20224638f, 0.02982951f, 0.07060564f, -0.11642004f, 0.10078508f, -0.06432310f, 0.10181472f, 0.07350132f, 
    0.03154499f, 0.08109992f, -0.06027388f, 0.03218930f, 0.07583923f, 0.31233746f, 0.13879386f, -0.05814045f, 
    -0.05657010f, 0.15772907f, 0.05764400f, 0.11492553f, 0.05575341f, 0.04702083f, -0.03027466f, 0.00446400f, 
    -0.04344086f, 0.24310000f, 0.22204983f, -0.04750730f, 0.21681930f, 0.10234267f, 0.02839349f, 0.00945724f, 
    0.03653671f, 0.02903050f, -0.05087786f, -0.01492836f, 0.38135070f, 0.19780412f, 0.09252656f, 0.01918545f, 
    0.10555054f, -0.07038948f, 0.05499420f, 0.06764288f, -0.11367247f, 0.06141895f, 0.02431862f, -0.00635027f, 
    0.00845028f, 0.29756454f, 0.05186075f, -0.05391802f, -0.05102323f, -0.10243853f, -0.00693233f, 0.02311773f, 
    0.02087772f, -0.02696029f, 0.09410582f, 0.01449364f, -0.14913972f, 0.08227970f, 0.06193679f, 0.07145117f, 
    0.06064212f, 0.03322682f, -0.12542142f, -0.05305588f, 0.09680641f, 0.02881255f, 0.10958765f, 0.02274301f, 
    -0.22334312f, 0.27724096f, -0.05375177f, 0.04370720f, 0.01431186f, -0.02092485f, 0.00673418f, 0.14422140f, 
    -0.05350605f, -0.00557072f, 0.10230733f, 0.12853098f, -0.25302458f, 0.01574763f, -0.34664670f, 0.11266524f, 
    0.13210830f, 0.04075050f, -0.03339687f, -0.18842448f, -0.03093678f, 0.02817115f, 0.09304798f, 0.14229006f, 
    -0.16215344f, -0.16952281f, 0.05169592f, 0.01685291f, 0.07024698f, 0.02332453f, -0.03739077f, 0.20145114f, 
    0.06817747f, -0.00392097f, 0.16377167f, 0.07412880f, -0.03827017f, -0.10199457f, 0.39721653f, -0.00933156f, 
    0.15763712f, -0.05618078f, 0.05485691f, -0.03873238f, -0.07591294f, -0.17867373f, -0.08716637f, -0.15567347f, 
    -0.18487102f, 0.09374277f, -0.06106745f, -0.05988207f, 0.07740830f, -0.06673922f, -0.00834552f, 0.00544290f, 
    -0.24527954f, 0.09555323f, -0.12080268f, -0.07993700f, -0.13512930f, -0.09907231f, 0.30638096f, 0.18635267f, 
    0.04054393f, 0.07624815f, -0.11744345f, 0.09950986f, 0.25533426f, 0.07640328f, 0.19409084f, 0.09287936f, 
    0.24356084f, -0.29138958f, -0.10422220f, -0.09982558f, 0.03261869f, -0.00632207f, -0.07204966f, -0.06922009f, 
    0.02011621f, 0.14573388f, -0.01980388f, 0.05772714f, -0.19442357f, -0.31152156f, 0.07837322f, -0.07810268f, 
    0.01032711f, 0.07501401f, -0.15090314f, 0.02980625f, 0.12111420f, 0.02612255f, -0.06088390f, -0.01864027f, 
    -0.06390888f, -0.05115600f, 0.04860305f, -0.12041432f, -0.03684095f, -0.02421990f, 0.14426158f, 0.00796872f, 
    0.20268008f, 0.25790206f, 0.18624383f, 0.26808783f, 0.00739053f, -0.01862046f, -0.10347439f, -0.10446157f, 
    0.10201297f, -0.00681643f, 0.10839769f, -0.00464422f, 0.03640135f, 0.04052403f, -0.03935139f, -0.12093531f, 
    0.17406832f, 0.16021465f, -0.05472570f, 0.12010589f, 0.06342287f, 0.04611775f, -0.00044060f, -0.10659599f, 
    0.15882295f, 0.04023042f, 0.22463307f, 0.23715216f, -0.16872427f, -0.14226437f, 0.24661875f, 0.17295451f, 
    0.08028301f, -0.02925809f, -0.08221865f, 0.13330324f, -0.00545747f, -0.15146644f, 0.03521418f, -0.03358065f, 
    -0.13971925f, -0.06849318f, 0.15083987f, 0.11032174f, 0.05810941f, -0.13343975f, 0.00779728f, -0.00992607f, 
    0.03679511f, 0.03034556f, 0.00236320f, 0.07586323f, 0.12514417f, 0.09742090f, 0.06215520f, 0.10254215f, 
    0.04514985f, 0.11603463f, 0.00174972f, 0.00084052f, 0.03677204f, -0.14456542f, -0.00263094f, -0.05572251f, 
    0.00656964f, -0.14302258f, 0.05733029f, 0.30039036f, 0.02891223f, -0.06108072f, -0.00896901f, -0.12255006f, 
    -0.05936304f, -0.07390255f, -0.05495693f, -0.16781999f, 0.11293701f, -0.26218486f, -0.01206363f, -0.00105739f, 
    0.02206758f, -0.11041981f, -0.22018565f, -0.03370965f, 0.11854093f, 0.16974743f, -0.02955266f, -0.11684704f, 
    0.05751181f, -0.23943156f, -0.12922680f, 0.29258624f, -0.13532743f, 0.05638923f, 0.09699635f, 0.00616255f, 
    0.08087870f, 0.10271696f, 0.12077687f, 0.09164381f, 0.13056238f, 0.03789180f, 0.32669726f, 0.05200068f, 
    -0.07435846f, -0.10815702f, -0.09154495f, -0.09254840f, -0.03372020f, -0.01826971f, -0.00518893f, 0.07799801f, 
    -0.01497773f, 0.23079857f, 0.09634215f, -0.00829295f, -0.13995513f, 0.03891880f, 0.07769771f, 0.03937170f, 
    -0.00035341f, -0.00270790f, -0.03863353f, -0.10713232f, -0.09831725f, 0.14208478f, -0.09130263f, 0.06304786f, 
    -0.16982281f, -0.04059689f, 0.02366621f, -0.14866398f, -0.13055375f, 0.02097797f, -0.04196245f, 0.03791668f, 
    0.51879364f, -0.03292077f, -0.07663736f, 0.35785955f, 0.02994392f, 0.06896460f, 0.21687241f, -0.13187933f, 
    0.35537252f, 0.03884748f, 0.11979370f, 0.19289303f, 0.04433903f, 0.07171179f, 0.18513788f, -0.12959626f, 
    -0.19415930f, 0.00907008f, -0.02129902f, -0.09872209f, 0.05912542f, -0.07186736f, 0.01919453f, -0.10532656f, 
    0.16516696f, 0.06417806f, 0.11764215f, 0.20181537f, -0.11141590f, 0.00600067f, -0.01719247f, 0.11466084f, 
    0.11513226f, 0.12625782f, 0.13708703f, 0.06110600f, -0.16184108f, 0.08535368f, -0.18563767f, -0.12856109f, 
    -0.03507141f, -0.21832465f, 0.07766055f, 0.07655696f, 0.14351179f, 0.02965175f, 0.04189652f, 0.00707548f, 
    -0.03836931f, 0.00095387f, -0.10004463f, -0.00840579f, -0.00551364f, 0.01887872f, -0.04921351f, -0.05462994f, 
    -0.10241908f, -0.10318531f, -0.07155970f, -0.18612146f, 0.01632133f, -0.05071715f, 0.00650612f, -0.05323967f, 
    -0.05156409f, -0.22640398f, 0.01169190f, 0.00466564f, -0.13935782f, -0.23272412f, -0.01065605f, 0.03933230f, 
    -0.04151565f, -0.11205864f, 0.10093960f, 0.05620759f, 0.14886557f, 0.04435500f, -0.05973816f, 0.22356030f, 
    -0.14630949f, 0.12635027f, -0.03318801f, -0.15746832f, -0.11842323f, 0.06718192f, 0.00736503f, -0.28153071f, 
    -0.05305985f, -0.01693683f, 0.05871805f, -0.03291801f, -0.06362240f, 0.04063858f, -0.04588448f, -0.08361033f, 
    -0.06428158f, -0.00675142f, -0.01874916f, 0.11486156f, -0.02434111f, 0.06605172f, 0.07842188f, 0.01766610f, 
    0.04151544f, 0.05703063f, 0.04056326f, 0.04302505f, 0.17132890f, 0.01976593f, 0.11297069f, -0.19620545f, 
    -0.00181200f, -0.14746901f, -0.12967891f, 0.05255934f, -0.08656242f, -0.08625019f, -0.04473212f, 0.11859002f, 
    -0.07571935f, -0.12841620f, 0.04982492f, -0.04459167f, 0.03182485f, 0.18957146f, 0.03628703f, -0.09208385f, 
    0.07632157f, -0.01431412f, 0.11952861f, 0.17702949f, 0.24535739f, 0.03537343f, -0.12273040f, 0.14036940f, 
    0.09098893f, 0.15828146f, 0.00312193f, 0.06956802f, 0.01853513f, 0.11251994f, 0.03526050f, 0.21161769f, 
    -0.02759013f, -0.11642475f, 0.10606626f, -0.08287112f, -0.02350166f, -0.14123075f, 0.27436176f, 0.24415199f, 
    0.26633304f, 0.03974563f, 0.03804291f, -0.12146480f, -0.26851174f, -0.22909863f, -0.07129472f, 0.10556436f, 
    -0.05587537f, 0.01819946f, 0.02301140f, 0.06800101f, 0.11621132f, 0.18001564f, 0.11918695f, -0.07365809f, 
    0.15965989f, 0.11842756f, 0.04702640f, 0.06185166f, -0.05869251f, 0.22355562f, 0.08032724f, 0.02942263f, 
    0.04960111f, 0.01693471f, 0.21345106f, 0.20238817f, 0.00103164f, -0.06461255f, -0.12972970f, -0.10241081f, 
    0.26828608f, -0.02132731f, 0.13093117f, 0.05852983f, -0.14219506f, 0.18524925f, 0.00307261f, -0.34772840f, 
    -0.07393248f, 0.09105814f, -0.29996815f, -0.00977947f, 0.03568126f, -0.25389951f, 0.12272812f, -0.14305073f, 
    -0.05025030f, -0.02948235f, -0.06343928f, -0.08556777f, -0.02228781f, -0.08661809f, -0.14006804f, 0.02656581f, 
    0.04116588f, 0.23167729f, -0.03073817f, 0.07513422f, -0.07815979f, -0.03559350f, 0.15469714f, 0.08623759f, 
    -0.29147881f, -0.09812652f, 0.22018735f, 0.01241032f, -0.22267242f, 0.11846924f, -0.08313235f, -0.06461190f, 
    -0.06234109f, -0.02011084f, 0.08146475f, 0.04103413f, 0.05062508f, 0.02645495f, -0.00784232f, -0.31398833f, 
    -0.05091183f, 0.05941806f, -0.16913848f, 0.20857207f, -0.02291430f, 0.02266017f, 0.05932550f, 0.01634062f, 
    -0.01410947f, 0.02130159f, 0.11029094f, 0.05115478f, -0.23942682f, 0.03467524f, 0.16431436f, -0.05445966f, 
    0.00482121f, 0.21201654f, 0.07457764f, 0.11036152f, -0.42042553f, 0.19662023f, 0.05099965f, -0.12290516f, 
    -0.16442372f, 0.08432364f, 0.22698468f, 0.10626394f, 0.05914306f, -0.00990497f, 0.05048304f, -0.08269349f, 
    0.16597289f, -0.04541630f, 0.15493163f, -0.00982880f, 0.00825286f, 0.10746998f, -0.04684472f, -0.08423804f, 
    0.13809118f, -0.03274268f, 0.12580441f, 0.17144839f, 0.14269735f, 0.00940338f, -0.07391429f, 0.06321450f, 
    0.02877948f, -0.07119683f, -0.07117469f, -0.06106619f, -0.20568953f, -0.10567053f, 0.09539358f, -0.09390256f, 
    0.14528662f, 0.09329779f, -0.11004782f, -0.07834774f, 0.16507281f, 0.00056700f, 0.06014915f, 0.14090437f, 
    -0.11576262f, 0.07427773f, 0.11749339f, 0.04306262f, -0.14528729f, 0.07100278f, 0.09220760f, -0.03347849f, 
    -0.07044320f, -0.18026367f, -0.06695957f, 0.02454435f, 0.13751666f, -0.17007484f, 0.08115347f, -0.10438219f, 
    -0.02258412f, -0.08259037f, 0.12710582f, -0.08583433f, 0.09317004f, -0.01945611f, 0.08002610f, -0.06009242f, 
    0.01449207f, -0.02699351f, 0.03969079f, 0.05174623f, 0.12174290f, -0.24602199f, 0.17457049f, -0.30419728f, 
    -0.08517818f, -0.09339739f, -0.09680439f, -0.30107155f, -0.07829139f, 0.19726847f, 0.14958553f, -0.14642105f, 
    0.25045544f, -0.22337414f, 0.00188701f, 0.02743128f, 0.05821962f, 0.03258872f, 0.01098027f, 0.03210048f, 
    0.10294683f, -0.06307924f, 0.09107801f, 0.04016452f, 0.34930137f, -0.04061402f, -0.12192953f, -0.04800902f, 
    -0.02880608f, 0.03163427f, -0.04328418f, 0.02813501f, 0.07343846f, -0.00832751f, 0.09348609f, 0.00774745f, 
    0.23980594f, 0.30565858f, 0.23183976f, -0.01418748f, 0.13091004f, 0.13624573f, 0.01463532f, 0.20633471f, 
    0.11252977f, -0.10607490f, -0.03952099f, -0.13362399f, 0.28705218f, 0.15123983f, 0.35259497f, -0.06862199f, 
    0.04533858f, 0.04338907f, 0.22376150f, 0.17925575f, 0.10162241f, -0.02931676f, 0.20596425f, 0.04235864f, 
    0.16555515f, -0.22482814f, 0.02922701f, -0.01899529f, -0.03957589f, -0.01661539f, 0.13405709f, -0.17661767f, 
    -0.03816519f, -0.14192845f, -0.03092710f, 0.07819310f, 0.00522176f, 0.06790589f, 0.16986465f, 0.24050355f, 
    -0.17569126f, -0.00463043f, 0.19340873f, 0.26465034f, 0.00177322f, 0.08371671f, -0.06953151f, -0.00663623f, 
    -0.03496721f, -0.30617231f, -0.07070955f, -0.25686079f, -0.05280308f, -0.04812229f, -0.08050907f, -0.00943185f, 
    -0.04252385f, 0.12969565f, 0.09584008f, -0.07890346f, -0.15514058f, -0.41769415f, 0.14685710f, -0.08657420f, 
    0.00871644f, 0.07855640f, 0.01926722f, 0.09202652f, 0.17704150f, 0.00144790f, -0.10018241f, -0.07591746f, 
    -0.07697913f, -0.33477840f, -0.09431332f, -0.25839585f, 0.01547095f, 0.10109465f, -0.02767044f, -0.04149351f, 
    -0.27544552f, -0.07989466f, 0.08145434f, 0.07080314f, 0.08619777f, -0.25083998f, -0.09432390f, -0.11121020f, 
    0.00028994f, 0.05808163f, 0.23986207f, 0.04265044f, 0.18303023f, 0.16770975f, 0.00847334f, 0.14355597f, 
    -0.27883443f, -0.07100371f, 0.08682706f, -0.28541446f, -0.01402567f, -0.15512829f, -0.03340344f, 0.08496000f, 
    0.02578458f, -0.02301747f, -0.02960564f, -0.03212710f, -0.01695665f, 0.34701172f, 0.25402385f, 0.26675898f, 
    -0.02009118f, -0.00934519f, 0.19551620f, 0.22794934f, -0.01635094f, 0.11809699f, 0.10895555f, 0.08552005f, 
    -0.07372555f, 0.09385839f, 0.12344715f, 0.20608282f, 0.17451128f, -0.01907115f, 0.05393706f, 0.03594668f, 
    0.09214869f, 0.07997221f, -0.11814535f, 0.02202272f, 0.43201986f, 0.12574773f, -0.23519051f, -0.20025675f, 
    -0.00392672f, -0.16545181f, 0.03789876f, -0.00593863f, -0.00787727f, 0.00002146f, 0.01712208f, 0.06093496f, 
    0.08742505f, 0.37448388f, 0.34282842f, 0.11265230f, -0.07782440f, -0.14599052f, 0.00573397f, 0.00819209f, 
    -0.12916398f, -0.01600359f, 0.01946650f, -0.06523283f, 0.02036293f, -0.29355514f, 0.13774067f, -0.00895513f, 
    -0.08818791f, 0.06013019f, -0.18322711f, -0.13542731f, 0.14744689f, 0.11407679f, 0.09647115f, 0.03653031f, 
    0.08778496f, 0.07254004f, 0.16864811f, 0.04659665f, -0.06780596f, -0.16457388f, -0.02176664f, 0.09895521f, 
    0.12894629f, -0.03323428f, 0.03940031f, 0.02952308f, -0.10450170f, -0.02020023f, -0.44328696f, -0.18927771f, 
    0.15952185f, 0.10030805f, 0.00692587f, -0.16957237f, 0.17091696f, 0.02237706f, 0.00663686f, 0.15778604f, 
    -0.05051739f, 0.12868015f, 0.09166149f, 0.20627943f, 0.12161569f, 0.03434113f, -0.07547955f, -0.06245312f, 
    -0.07467150f, 0.10711475f, -0.08599892f, -0.14668888f, -0.22598036f, -0.03063086f, -0.33360586f, -0.16071591f, 
    -0.07061073f, 0.11102922f, 0.16263299f, 0.03829468f, -0.05655823f, 0.13586324f, 0.06860879f, 0.27641940f, 
    0.40316477f, 0.19899271f, -0.05036077f, 0.38912323f, -0.20315927f, 0.13797390f, 0.15660490f, -0.20796408f, 
    0.31248185f, 0.04746340f, 0.23770148f, 0.19693999f, -0.11433256f, -0.03699245f, -0.10571116f, -0.09299120f, 
    0.08229295f, 0.16665785f, 0.01748146f, 0.07832865f, -0.07885012f, -0.10778126f, -0.02653871f, -0.14311361f, 
    0.12428723f, 0.25382385f, 0.37906447f, -0.04430122f, -0.02979554f, -0.16815946f, -0.06679884f, -0.04618204f, 
    0.16273986f, -0.02068083f, 0.07097354f, 0.16267590f, 0.13160731f, 0.16882475f, -0.16836858f, -0.05978717f, 
    0.02280205f, -0.11725813f, 0.10008259f, 0.03623143f, 0.10009336f, -0.10504670f, 0.06766049f, 0.03959269f, 
    -0.04051145f, -0.04214831f, -0.06241283f, -0.10919976f, -0.03977112f, -0.17038992f, -0.22367010f, -0.22695392f, 
    -0.17399292f, -0.26605561f, -0.05461164f, -0.16089271f, -0.05235717f, 0.09431796f, -0.02494271f, 0.00748603f, 
    0.05812609f, 0.00588346f, -0.15894586f, 0.13734566f, 0.06757736f, -0.11553577f, 0.01595776f, 0.06116996f, 
    0.09453156f, -0.18436457f, 0.06565721f, 0.02446841f, 0.03190668f, 0.02043949f, 0.01885438f, 0.14088868f, 
    -0.08322457f, -0.00455321f, -0.01181869f, -0.10535786f, -0.11798339f, 0.00965162f, -0.04227225f, 0.06379859f, 
    -0.10499558f, 0.15764715f, 0.13838136f, -0.06614631f, -0.02764767f, 0.00721064f, -0.14152493f, -0.03313848f, 
    -0.02490166f, 0.21061336f, -0.20426176f, 0.15393494f, -0.11059894f, 0.08654415f, 0.13245641f, 0.12123471f, 
    0.04526431f, -0.03595506f, -0.06797735f, 0.13176894f, -0.37056109f, -0.26978317f, -0.04886641f, -0.06980354f, 
    -0.04295599f, -0.25105584f, -0.14866337f, -0.07227531f, 0.01348120f, 0.07299160f, -0.04249708f, 0.11105688f, 
    -0.21229303f, -0.21319470f, 0.08786804f, 0.04767792f, 0.07954736f, 0.07776090f, -0.04038458f, -0.01663731f, 
    0.06609587f, 0.00771765f, 0.04341555f, 0.16340768f, 0.14063556f, 0.11128761f, 0.04464275f, -0.09248663f, 
    0.03949251f, 0.07429157f, 0.05559587f, 0.03311369f, -0.01448206f, 0.13574111f, -0.08863005f, 0.34310645f, 
    -0.09417657f, -0.19521457f, 0.12300319f, -0.10243098f, -0.02586522f, -0.01064290f, 0.10766988f, 0.13068473f, 
    0.13471648f, -0.06856802f, 0.01283790f, -0.11686744f, 0.18483147f, -0.24593113f, 0.04421885f, -0.12212727f, 
    -0.23695639f, -0.05511168f, -0.22295672f, -0.00834355f, 0.11725298f, 0.11022244f, 0.11324395f, 0.08284473f, 
    0.09218145f, -0.16029765f, -0.01722915f, 0.19264664f, -0.05577774f, -0.19634056f, -0.00937299f, 0.13826565f, 
    -0.08916865f, 0.01318062f, -0.09771493f, -0.09790894f, -0.01183958f, 0.06734974f, -0.15172860f, 0.13585187f, 
    -0.01647416f, 0.03396159f, -0.07068607f, 0.13102059f, 0.00304660f, -0.00643068f, -0.03044152f, -0.00743662f, 
    0.00393820f, 0.21256229f, 0.19108924f, 0.27311277f, 0.08132610f, -0.03108441f, -0.06134980f, 0.32892904f, 
    0.06659202f, 0.11464813f, 0.11260055f, 0.14822495f, -0.27121371f, 0.11877003f, -0.07519957f, 0.08214109f, 
    0.07727637f, -0.20959920f, -0.00959267f, 0.11116092f, -0.11125433f, 0.00774190f, -0.14590764f, -0.17414255f, 
    0.07763457f, 0.23779361f, -0.08273487f, 0.01966510f, -0.01659350f, 0.06724358f, -0.12707093f, 0.06592423f, 
    0.11900639f, 0.04666826f, -0.08123393f, 0.10648026f, -0.25443932f, 0.34481141f, 0.00524628f, 0.23360464f, 
    0.12164664f, 0.01461197f, 0.10298546f, 0.03635013f, -0.04608117f, 0.02344831f, -0.00213710f, 0.01789585f, 
    -0.20423079f, 0.10851379f, -0.22083087f, -0.12581316f, -0.02160263f, 0.06149717f, -0.12322474f, 0.02532268f, 
    0.10001349f, 0.08415209f, -0.07667162f, -0.11381716f, -0.32842940f, -0.04559948f, -0.00790291f, 0.05437927f, 
    -0.09752849f, -0.11182921f, -0.17116208f, -0.00966175f, 0.06177225f, -0.07172315f, 0.03445170f, -0.10736810f, 
    0.05148431f, -0.04308050f, -0.16872703f, -0.01851007f, 0.05216804f, -0.09578194f, 0.06313325f, -0.01518315f, 
    -0.12602344f, -0.04489182f, -0.13276583f, -0.04256868f, 0.05600784f, -0.09804428f, 0.04729886f, 0.22290306f, 
    -0.08105493f, -0.02305634f, -0.04432381f, -0.05822762f, 0.15858649f, 0.19168584f, 0.07474525f, 0.12050683f, 
    0.23599881f, 0.10814306f, 0.07424169f, 0.04768626f, 0.00161827f, 0.20263338f, 0.11996595f, 0.07978557f, 
    0.13278875f, 0.02427827f, 0.02712365f, 0.09792996f, -0.38111523f, 0.00398267f, 0.30303210f, -0.06667369f, 
    0.13781694f, 0.14821632f, 0.05566603f, -0.08413973f, -0.02601401f, 0.06970938f, -0.03892983f, -0.04552915f, 
    0.09621583f, 0.07091629f, 0.00585530f, 0.26099098f, -0.04021443f, -0.04651095f, 0.03224167f, 0.14567718f, 
    -0.10183013f, 0.07183664f, -0.02959513f, 0.05997683f, -0.20038339f, 0.06637682f, -0.08751122f, -0.08017573f, 
    -0.01007133f, 0.07922423f, 0.07755220f, 0.10200267f, 0.03315983f, -0.18601634f, 0.14377527f, 0.20267695f, 
    -0.00847644f, 0.14950658f, -0.03665998f, 0.10062331f, 0.14143069f, 0.17589672f, 0.10808957f, 0.02497515f, 
    -0.18913081f, -0.02804031f, -0.12126506f, -0.08268337f, -0.28867748f, -0.09615459f, -0.09175291f, -0.11193820f, 
    0.06666235f, 0.04859620f, -0.02569898f, -0.05494405f, -0.04114939f, -0.02515417f, 0.06350844f, -0.10080348f, 
    -0.10727550f, -0.13715380f, 0.12737596f, 0.15154082f, 0.04840256f, -0.05300039f, -0.01291527f, 0.08661626f, 
    -0.09156686f, 0.00055273f, 0.00182485f, 0.05794518f, -0.16170943f, -0.10231435f, 0.00030736f, 0.05588386f, 
    -0.02962082f, -0.04314708f, -0.26379591f, -0.04830503f, -0.07679702f, -0.01544649f, -0.14290415f, -0.10284694f, 
    0.07576095f, 0.07148437f, 0.06915256f, 0.11306783f, 0.05933690f, -0.04272638f, -0.02510075f, 0.02848216f, 
    0.16225274f, 0.05677970f, 0.13818626f, -0.01913868f, -0.28208140f, -0.13749196f, 0.04679975f, 0.02387011f, 
    0.10244166f, -0.11294574f, -0.11747494f, 0.01767516f, -0.05147162f, 0.11747366f, 0.11315455f, -0.06114895f, 
    0.19221364f, 0.15551767f, -0.04998172f, 0.20570523f, 0.05381510f, 0.02657168f, -0.02019015f, 0.06920788f, 
    0.06246259f, 0.04141074f, 0.06997714f, 0.11779746f, -0.14308985f, 0.26218829f, -0.03895338f, 0.09921837f, 
    0.04049725f, 0.10791525f, 0.01737297f, -0.12943737f, -0.12126680f, -0.06975871f, -0.08677460f, -0.11697403f, 
    -0.06520875f, 0.15654907f, -0.15531793f, -0.00004807f, -0.04009878f, 0.05490804f, 0.05710745f, -0.01223966f, 
    0.09952562f, 0.10500652f, 0.05857442f, -0.05791514f, 0.10867129f, 0.05927374f, 0.26238033f, 0.05087864f, 
    0.10551163f, 0.03794543f, -0.07429036f, 0.16926953f, -0.09221500f, 0.08066945f, 0.01981066f, 0.08778189f, 
    0.24503651f, -0.14769600f, -0.04811589f, 0.04290295f, -0.02821213f, -0.02880790f, -0.04222086f, -0.04304850f, 
    0.05807716f, 0.16804832f, 0.08924261f, -0.09071267f, -0.17718056f, -0.21399626f, 0.13132647f, -0.05002735f, 
    0.00714452f, -0.02032439f, 0.01603894f, -0.16878808f, 0.02755564f, -0.18029255f, -0.09568899f, -0.08282712f, 
    0.01746203f, -0.20589659f, 0.09274350f, 0.05964467f, 0.08671272f, -0.01660474f, 0.03328140f, -0.07342312f, 
    0.08479850f, 0.00370675f, 0.11263324f, -0.03662995f, 0.27947408f, 0.09712891f, 0.44636360f, -0.12370772f, 
    -0.02902409f, 0.05558418f, -0.00224358f, 0.07048161f, -0.02732335f, -0.06108240f, -0.00284978f, 0.08140191f, 
    0.00907203f, -0.25049874f, -0.05145532f, 0.19283646f, -0.11361300f, 0.05018359f, 0.04977529f, -0.05271388f, 
    0.10241412f, -0.13256428f, -0.04045175f, -0.00904743f, 0.19943738f, 0.07292432f, -0.12651326f, 0.28134060f, 
    0.02433611f, -0.08238999f, 0.14193624f, 0.13090938f, 0.19255222f, 0.08003280f, 0.10359218f, 0.09476162f, 
    0.10183148f, -0.27005339f, -0.14170827f, 0.22061473f, 0.07011899f, -0.09570085f, -0.07744320f, 0.06744890f, 
    0.05693907f, 0.08105330f, 0.04738478f, 0.04956476f, -0.23905580f, -0.08003677f, -0.00300839f, 0.13621221f, 
    0.02157192f, 0.02225855f, 0.08400110f, 0.05784875f, 0.17580646f, 0.16144240f, 0.07794331f, 0.08452450f, 
    -0.03722744f, -0.07622003f, 0.12492796f, 0.24562527f, 0.01069716f, 0.06411495f, -0.04591400f, 0.00592382f, 
    0.03430913f, 0.03069527f, 0.07782454f, 0.11625353f, -0.13201235f, -0.05704549f, 0.01385614f, 0.17998479f, 
    -0.08391073f, 0.06213887f, -0.29778919f, 0.02021508f, -0.11897128f, -0.06631137f, 0.09686835f, 0.01689065f, 
    -0.17312910f, 0.51387042f, 0.09260470f, 0.02374967f, 0.01441612f, 0.00121963f, 0.00836483f, 0.02109044f, 
    -0.01846263f, 0.06189292f, 0.15364000f, -0.11638424f, -0.14237955f, -0.22340856f, 0.02546186f, 0.36821362f, 
    -0.02925722f, -0.09610336f, -0.04020822f, -0.04645550f, 0.01664048f, 0.08021401f, 0.14857827f, 0.09350707f, 
    -0.12632051f, 0.09390499f, -0.00319167f, 0.04606922f, -0.13412233f, -0.04254088f, -0.09972659f, 0.06799076f, 
    -0.08727767f, -0.02601089f, 0.01597511f, -0.04723011f, -0.39046708f, 0.19719121f, -0.02188540f, 0.19465441f, 
    0.06130021f, 0.13467987f, 0.15268789f, -0.08944542f, -0.04480940f, -0.03652677f, -0.05735068f, 0.02130528f, 
    -0.08971012f, 0.23462340f, -0.15917803f, -0.06155078f, -0.02167181f, 0.05408080f, 0.01036472f, 0.05010369f, 
    0.01594480f, 0.16314784f, 0.12456951f, 0.06283629f, 0.12289898f, -0.24285451f, 0.29353547f, -0.02502179f, 
    -0.01987945f, -0.00763437f, -0.07865847f, -0.03621735f, -0.30527294f, -0.04630038f, -0.02367255f, -0.10568208f, 
    0.44338152f, 0.08053288f, -0.04356914f, -0.06025461f, 0.11370625f, -0.00044520f, 0.03131963f, -0.01136412f, 
    0.16099757f, 0.13536629f, 0.05342990f, 0.13585976f, -0.13003191f, -0.27736890f, 0.17032516f, 0.18319081f, 
    0.01819362f, -0.08163931f, -0.21141814f, 0.05422138f, -0.00541154f, -0.08070155f, -0.06818111f, -0.08069123f, 
    0.03252886f, -0.05436946f, 0.06422724f, 0.09357900f, 0.17151845f, 0.08235176f, -0.10760550f, -0.02091989f, 
    -0.05905868f, 0.10328132f, 0.04499777f, 0.00054016f, 0.31560761f, -0.02873870f, 0.41827580f, -0.13848391f, 
    -0.04983527f, 0.14240190f, -0.06168302f, 0.06716385f, -0.12641288f, 0.06897308f, -0.01963018f, -0.11566092f, 
    -0.08223306f, -0.12643509f, -0.04511834f, 0.27961341f, -0.07990496f, -0.13257806f, -0.08687782f, -0.09660496f, 
    -0.03939431f, 0.01689653f, -0.01618984f, -0.04868869f, -0.00967131f, 0.11626373f, -0.20065990f, 0.07100575f, 
    -0.06126289f, -0.12520789f, -0.13990076f, 0.11384968f, 0.01773205f, 0.12256949f, 0.13536535f, 0.00377236f, 
    -0.15023407f, -0.14195471f, -0.38580504f, 0.35130930f, 0.01874953f, 0.11647836f, 0.06874002f, 0.06174121f, 
    0.11220776f, 0.00007466f, 0.19648887f, 0.14371400f, -0.41997197f, -0.03572253f, -0.25306129f, 0.07351112f, 
    -0.02831087f, -0.00062093f, 0.00719460f, -0.00375410f, -0.07459261f, 0.15796603f, 0.04761178f, 0.03395821f, 
    -0.10552085f, 0.11133511f, 0.03134624f, 0.03188132f, -0.08893128f, 0.07030854f, -0.20765570f, -0.18962820f, 
    -0.04512326f, -0.08951364f, 0.06773387f, 0.08474790f, 0.16202551f, -0.00027177f, -0.06621404f, 0.00268246f, 
    0.13460216f, -0.03556396f, 0.20342706f, -0.09964110f, 0.02279957f, 0.12726746f, 0.16536500f, -0.04582087f, 
    0.10120061f, -0.04571203f, -0.17477012f, -0.34908193f, 0.01385679f, 0.07445177f, 0.06224676f, -0.13512708f, 
    -0.01804870f, 0.08588801f, -0.09106929f, -0.16096306f, 0.09444182f, 0.14481033f, -0.03961662f, -0.13660203f, 
    0.05934932f, 0.07240352f, 0.20081672f, -0.20212646f, 0.00412393f, -0.20681414f, -0.03804622f, -0.02310750f, 
    0.10519250f, 0.07908317f, -0.19977060f, -0.02691089f, 0.08742778f, 0.03944029f, 0.17978576f, 0.08286943f, 
    0.10351750f, -0.09248170f, -0.04211178f, 0.06576344f, 0.24402419f, 0.18290836f, 0.13163140f, 0.24550034f, 
    -0.41958639f, -0.22110340f, -0.19213556f, -0.00530426f, 0.12408185f, 0.04574608f, 0.03741036f, 0.14630555f, 
    0.06622981f, 0.04033116f, -0.01970497f, 0.14839220f, 0.00241984f, 0.06067435f, 0.00730144f, 0.11504269f, 
    0.12464665f, 0.03434923f, -0.05525874f, 0.15658766f, 0.16816910f, 0.15620972f, -0.07712157f, 0.09221301f, 
    -0.01462709f, 0.05441895f, -0.05201572f, -0.15468954f, 0.12232792f, -0.02481955f, 0.05036674f, -0.00927364f, 
    -0.36314011f, -0.06191040f, -0.08887718f, -0.03923402f, -0.00981923f, 0.11682708f, -0.15787652f, -0.04540997f, 
    -0.10373344f, -0.05750491f, 0.06735454f, 0.20612523f, 0.17116593f, 0.18445018f, 0.05492135f, 0.15227631f, 
    -0.01852139f, 0.02192915f, 0.01528644f, -0.25233322f, 0.00546506f, -0.00547324f, 0.04933893f, -0.09372272f, 
    -0.01924008f, -0.01775349f, 0.05039049f, -0.21643010f, -0.27950469f, 0.05482074f, -0.08113881f, -0.01565448f, 
    0.00594326f, 0.00828762f, -0.05219298f, -0.18446688f, -0.08035832f, 0.05314500f, -0.00696718f, 0.30139789f, 
    -0.10458445f, -0.04921756f, -0.02961141f, -0.04097938f, 0.06896888f, 0.02446719f, 0.07874355f, 0.12232811f, 
    0.17470184f, 0.17800294f, 0.10587937f, 0.13357194f, 0.09739431f, -0.06434155f, -0.01255102f, 0.08283986f, 
    0.01722231f, -0.08439356f, 0.05264699f, 0.06370752f, -0.20285273f, 0.08191088f, 0.12466016f, 0.01874105f, 
    0.01974891f, 0.09791933f, 0.02055986f, 0.05696820f, -0.07269476f, -0.14566852f, -0.19424014f, -0.04666056f, 
    0.04079998f, 0.18771946f, -0.01573323f, -0.24489257f, -0.13213040f, 0.01047755f, -0.03126559f, -0.06724852f, 
    -0.03997612f, -0.03829314f, -0.02373682f, -0.14627294f, 0.10689052f, 0.07283127f, 0.07093889f, 0.19734661f, 
    0.00471661f, 0.06850459f, 0.01146329f, 0.12868902f, 0.05977557f, -0.16829640f, -0.13490604f, -0.30414769f, 
    0.09943939f, -0.11483536f, 0.05467563f, 0.19281209f, -0.01181827f, -0.04558766f, 0.05987729f, 0.14285503f, 
    -0.10141893f, -0.07256931f, 0.01605577f, -0.03619861f, -0.18801066f, 0.00186968f, 0.03245784f, 0.10361482f, 
    0.27029112f, 0.24615324f, 0.05613627f, 0.09906410f, -0.05056207f, 0.13672850f, 0.13394266f, 0.18335316f, 
    -0.01893554f, 0.28440991f, -0.21361460f, 0.05260055f, -0.04957579f, 0.13398480f, 0.06142882f, -0.25718340f, 
    -0.00049388f, 0.21824425f, 0.07570814f, 0.03622901f, -0.31245008f, -0.07951781f, 0.05052697f, 0.12348674f, 
    0.16195516f, 0.12451342f, 0.04972340f, 0.21655823f, -0.01437837f, 0.01152478f, 0.10476063f, -0.08551822f, 
    0.13653509f, 0.09661380f, 0.18643582f, -0.03014651f, -0.14340000f, 0.04691591f, -0.14675111f, -0.13875219f, 
    0.01751680f, -0.05327298f, 0.02259823f, -0.03981546f, -0.11629927f, 0.37795520f, 0.11724806f, -0.20109586f, 
    0.06844876f, 0.18091564f, -0.06179001f, -0.04812645f, -0.00890627f, 0.02953966f, 0.02195826f, 0.10091271f, 
    0.15752684f, 0.24545284f, 0.03437389f, -0.06493136f, 0.00499088f, 0.01635276f, -0.11608911f, -0.17783891f, 
    -0.04327368f, -0.05148545f, -0.05238280f, -0.15939984f, -0.27700302f, 0.12962116f, -0.19316782f, 0.33571276f, 
    0.02939118f, -0.07578782f, 0.09200393f, 0.03004670f, 0.19217876f, 0.03083153f, -0.03197482f, -0.03980092f, 
    0.15845056f, -0.20266375f, 0.12210429f, -0.03140131f, -0.12208774f, 0.01053781f, 0.06160342f, 0.05805595f, 
    -0.12194815f, -0.15072165f, -0.08495598f, -0.06870055f, 0.03897062f, 0.00520725f, 0.13203464f, 0.37891215f, 
    0.06980656f, -0.08846274f, 0.11219429f, 0.18207243f, 0.00521919f, -0.07317273f, 0.00604985f, 0.09479518f, 
    0.09119219f, -0.14539073f, -0.18034439f, -0.03291584f, 0.08465475f, 0.10758737f, 0.02798296f, 0.08651236f, 
    -0.04825647f, 0.13222371f, -0.08974969f, 0.05441928f, -0.36008847f, -0.11029667f, 0.06582925f, -0.02892650f, 
    -0.11207335f, -0.08918052f, 0.00780420f, -0.13024795f, 0.15396747f, -0.12746717f, -0.05152089f, -0.04125369f, 
    -0.12713987f, -0.15455966f, 0.14093602f, 0.20418096f, -0.01150320f, 0.08194635f, 0.04368708f, -0.04618805f, 
    0.01733176f, 0.18041830f, 0.03057737f, -0.03119613f, 0.16748749f, -0.20223190f, 0.15692940f, -0.35821083f, 
    -0.10225770f, -0.04296828f, -0.08018276f, -0.18749295f, 0.08662728f, 0.14402293f, 0.12742481f, 0.13769476f, 
    0.12819318f, -0.10581920f, 0.11163485f, 0.17777653f, 0.15896629f, 0.13343860f, 0.13741148f, -0.00478902f, 
    0.03760139f, 0.04211386f, -0.22614780f, -0.04502525f, 0.20429318f, -0.30208263f, -0.34881601f, -0.49360621f, 
    -0.02931403f, 0.06766784f, -0.08933899f, 0.01806880f, 0.14790992f, 0.04615696f, 0.11631887f, 0.13085219f, 
    0.21974511f, 0.20187962f, 0.11840025f, 0.27505076f, 0.03346216f, 0.08121250f, -0.04606185f, -0.04085330f, 
    0.00830378f, 0.06668624f, 0.11031920f, -0.00545749f, 0.05984219f, 0.24464305f, -0.22589613f, 0.01524833f, 
    0.23762555f, 0.16427970f, 0.04180463f, 0.08685223f, -0.11219314f, -0.13050523f, 0.26465675f, -0.08235220f, 
    -0.33831403f, 0.45105740f, -0.13762361f, 0.04099519f, -0.06661203f, -0.07144737f, 0.08820796f, -0.17556563f, 
    -0.03102364f, -0.06759311f, 0.06004955f, -0.15984291f, 0.02963632f, 0.10007822f, -0.14308913f, 0.29642197f, 
    0.07712536f, 0.02496421f, -0.02653839f, 0.03358602f, -0.02655288f, -0.10626970f, 0.25479504f, 0.12433837f, 
    -0.67367876f, -0.02806092f, 0.15681420f, -0.03944299f, -0.03049691f, 0.03825046f, -0.04566360f, -0.04393689f, 
    -0.01486849f, -0.04696953f, -0.04599380f, -0.04066527f, -0.27639166f, 0.32155758f, -0.12407714f, 0.11467917f, 
    -0.07579866f, 0.04147127f, 0.00869487f, -0.00129372f, -0.07045989f, -0.00661273f, 0.10313991f, 0.02510834f, 
    -0.15700351f, 0.23953304f, -0.16978502f, 0.04322053f, -0.00477592f, 0.06724108f, -0.15319686f, -0.00963563f, 
    -0.14196599f, 0.23186830f, 0.08683596f, 0.16290732f, -0.07762573f, -0.26325145f, 0.02985912f, -0.47826570f, 
    -0.05347384f, -0.01731733f, -0.08159699f, 0.11364245f, 0.06786499f, 0.03484853f, -0.07634825f, -0.07896252f, 
    0.24603568f, 0.04986934f, 0.12827598f, 0.09655093f, 0.11070950f, -0.00436813f, -0.08296221f, -0.09176400f, 
    0.14995831f, -0.12114305f, 0.04501690f, 0.16260016f, 0.08846429f, 0.09563973f, 0.00237934f, 0.38300771f, 
    -0.02029289f, 0.05531063f, -0.09866214f, 0.04878804f, -0.02072090f, -0.14120482f, -0.11568806f, -0.04527791f, 
    0.16994518f, 0.41278207f, -0.00471363f, -0.01989480f, 0.07226228f, 0.11105873f, -0.02612578f, 0.01556249f, 
    -0.10346422f, 0.07578062f, -0.04554349f, -0.00899491f, -0.38820001f, -0.27230558f, 0.40330556f, -0.09337262f, 
    -0.06871979f, -0.02184549f, -0.04582983f, -0.03828582f, 0.09687399f, -0.09655533f, 0.15575266f, -0.12381946f, 
    -0.02953144f, 0.13737127f, -0.00517410f, 0.11397870f, -0.00822459f, 0.01709165f, -0.11116312f, -0.07200465f, 
    -0.07269928f, 0.04485852f, 0.04029962f, 0.04377591f, -0.41978690f, 0.06443646f, -0.05963072f, -0.19358851f, 
    -0.19897544f, 0.07204144f, -0.14033365f, -0.12252341f, -0.03691180f, 0.12980475f, 0.08431641f, -0.04709947f, 
    -0.10258544f, 0.22085404f, -0.17881723f, 0.13104786f, 0.02085883f, 0.12000719f, 0.00770704f, 0.05659326f, 
    -0.03546842f, -0.11951591f, -0.10036556f, 0.06585059f, 0.25921857f, 0.17748389f, -0.02536917f, 0.00035282f, 
    0.10987046f, 0.08177220f, 0.05316690f, 0.07269960f, -0.03076689f, -0.01090261f, -0.08437395f, -0.01303795f, 
    -0.00250900f, 0.09633051f, -0.00206193f, 0.06640586f, 0.05238131f, 0.00106250f, -0.02804335f, -0.20619681f, 
    -0.01595598f, 0.11156673f, -0.13815767f, -0.06033127f, 0.06702404f, -0.11049037f, -0.18268257f, 0.00032745f, 
    0.02649217f, -0.08360072f, -0.02324966f, -0.04116232f, -0.10930292f, 0.07448304f, 0.13885482f, 0.09428463f, 
    0.28565800f, 0.11660933f, 0.05383463f, 0.34999305f, 0.03511386f, -0.00331244f, 0.05445342f, 0.05790835f, 
    0.24010980f, -0.00253449f, 0.24261455f, 0.25290012f, 0.05686038f, -0.04938140f, -0.12937057f, 0.14143920f, 
    -0.17201200f, 0.01776086f, -0.04454780f, -0.01129075f, -0.07399191f, -0.04703438f, -0.02854258f, 0.00209918f, 
    -0.42371756f, 0.14962524f, 0.45411822f, -0.06695829f, -0.00339010f, -0.02276133f, 0.03825881f, -0.10255934f, 
    -0.00248734f, 0.13191043f, 0.05749398f, -0.06624963f, -0.04045977f, -0.13231257f, -0.22338332f, 0.08327240f, 
    0.06737060f, -0.04590488f, 0.01684490f, 0.03848653f, 0.15562280f, -0.01138328f, -0.00721439f, -0.06490194f, 
    -0.12822109f, -0.16625464f, 0.01574447f, 0.06664528f, -0.05065794f, -0.11152905f, -0.06670099f, -0.03335250f, 
    -0.03277932f, -0.09268266f, 0.03090255f, -0.15491383f, -0.02695456f, -0.19055562f, -0.03010235f, -0.42616853f, 
    -0.23314264f, -0.13124368f, -0.12282778f, 0.12245188f, -0.09458197f, -0.14431891f, 0.07426145f, 0.00672337f, 
    0.04417177f, 0.03759668f, -0.04958320f, -0.00120299f, 0.13493998f, 0.04826501f, 0.03956758f, 0.02361656f, 
    0.11555317f, -0.01906217f, 0.09267858f, 0.07887376f, -0.16410212f, -0.02233123f, -0.16765958f, -0.07154068f, 
    -0.11537997f, 0.00841509f, -0.04552837f, 0.16064505f, -0.10144220f, -0.02708505f, -0.02564969f, 0.12074390f, 
    -0.04255201f, 0.43226850f, -0.05079970f, 0.15590453f, 0.01451271f, -0.08532908f, 0.10085784f, 0.11657520f, 
    -0.03609953f, 0.01774140f, 0.05011764f, 0.02132670f, 0.14683467f, -0.02141736f, -0.15544756f, -0.02006563f, 
    0.15068753f, -0.07544641f, 0.03069483f, 0.05828862f, -0.11435778f, -0.00205025f, -0.07049041f, 0.04584927f, 
    -0.28787124f, 0.08185114f, -0.18494286f, -0.06056725f, -0.03821458f, -0.13191415f, 0.02606688f, 0.00092905f, 
    0.01559093f, -0.01238300f, 0.12278736f, 0.01126990f, -0.01803310f, 0.21982826f, -0.11401772f, -0.11745204f, 
    -0.02356283f, 0.00313214f, 0.14693378f, -0.06490247f, 0.06396537f, 0.09712391f, 0.04929413f, 0.13437794f, 
    -0.13798635f, -0.12462588f, -0.26642054f, -0.24732538f, -0.08602166f, 0.09349167f, 0.07836643f, 0.12099863f, 
    0.05471711f, -0.03205087f, 0.19700830f, -0.06568613f, 0.03338656f, 0.01115349f, 0.17891647f, 0.05221132f, 
    -0.16084273f, 0.03160577f, -0.03359571f, 0.01930232f, -0.00951835f, 0.05122758f, -0.02047539f, -0.01260182f, 
    -0.18042691f, 0.14349392f, -0.01409505f, -0.07224077f, -0.01857466f, 0.17810535f, 0.00137153f, 0.04074166f, 
    0.04190608f, -0.02204585f, -0.05570368f, 0.02065971f, -0.25391528f, 0.24913366f, -0.09748174f, 0.01283514f, 
    -0.00658943f, -0.16632167f, -0.07855937f, -0.13193575f, 0.08067737f, -0.05663966f, -0.03815806f, 0.03953515f, 
    0.08193627f, 0.13032483f, 0.21709375f, 0.27609101f, 0.04354655f, -0.07071409f, 0.03509905f, 0.26574171f, 
    0.17201482f, 0.11063806f, 0.20083988f, 0.23562247f, -0.11299512f, 0.06449962f, 0.03878335f, -0.07494158f, 
    -0.13590899f, 0.07774082f, 0.08368871f, -0.07592282f, -0.06214611f, 0.06912743f, -0.13564423f, 0.12213968f, 
    0.29587030f, -0.01488578f, -0.11057504f, 0.05832977f, 0.00939799f, -0.12878101f, -0.01390972f, 0.11775923f, 
    0.01431204f, 0.17571564f, 0.08482286f, -0.07753458f, -0.22647971f, -0.29163042f, -0.09822479f, 0.18574949f, 
    0.17028387f, 0.04184265f, 0.00676359f, 0.07713216f, 0.01803552f, -0.07399730f, -0.08758976f, -0.06612591f, 
    0.00054127f, -0.19822764f, -0.03124992f, 0.07767154f, 0.03531581f, 0.04015705f, 0.00823494f, 0.05250323f, 
    0.12644762f, 0.08135778f, 0.11363735f, 0.10119716f, 0.36092570f, -0.10978395f, -0.12356704f, -0.23556297f, 
    -0.10002419f, 0.00526515f, 0.02556999f, -0.16238864f, -0.03381544f, 0.06093532f, -0.05543931f, 0.07763244f, 
    -0.03755928f, 0.19466129f, -0.20480834f, -0.04494986f, -0.04266495f, 0.02479704f, -0.00992643f, 0.05997724f, 
    0.06911098f, 0.11729119f, 0.10449620f, -0.05108534f, -0.21207662f, 0.03616790f, -0.03214743f, -0.37794453f, 
    -0.08987366f, -0.10277566f, -0.13824651f, -0.04504712f, -0.04016069f, -0.07069214f, 0.00329325f, -0.07432367f, 
    -0.11561665f, 0.34946227f, 0.20571722f, 0.28741562f, -0.04762690f, -0.03487036f, -0.02175862f, 0.11493564f, 
    0.07423425f, 0.03689328f, 0.09254137f, 0.08825856f, 0.18379995f, 0.04704518f, -0.08439115f, 0.10218646f, 
    0.10813978f, 0.25112146f, 0.12940912f, 0.05591892f, -0.13059962f, 0.04482412f, -0.02080720f, -0.00511125f, 
    -0.31859234f, -0.09139073f, -0.24830627f, 0.04698245f, 0.00087930f, -0.02023947f, -0.10734802f, -0.14037766f, 
    0.00519778f, -0.19838157f, 0.05760907f, -0.05864225f, 0.03523051f, 0.19033527f, -0.10602653f, 0.23253521f, 
    0.07993999f, 0.06176621f, 0.22783658f, 0.22784863f, 0.17654529f, 0.05307515f, -0.05254077f, 0.06094915f, 
    -0.38485560f, -0.08694893f, -0.20108452f, -0.04460088f, -0.00775633f, -0.06279497f, -0.06718186f, 0.24153139f, 
    0.00517689f, 0.06554309f, 0.20519271f, -0.01675254f, -0.32257286f, 0.05756270f, 0.52497464f, 0.29645902f, 
    0.00771839f, -0.12797366f, -0.07923511f, 0.12985840f, -0.09035194f, 0.14357093f, 0.00278408f, 0.07512244f, 
    -0.21884982f, -0.11464253f, -0.05058411f, -0.16797045f, 0.03134743f, 0.00169870f, 0.06440809f, 0.10496738f, 
    0.11706401f, -0.01000082f, 0.12589765f, 0.08151784f, 0.01814255f, -0.25418678f, 0.30697253f, -0.05867669f, 
    0.05120745f, -0.08931067f, 0.10739665f, -0.00559408f, 0.03265974f, -0.04394028f, -0.09767016f, -0.24395627f, 
    0.15545602f, -0.15319550f, 0.16915882f, -0.13558309f, 0.10054154f, -0.03323008f, 0.07419375f, 0.03752122f, 
    -0.23392625f, 0.00547454f, -0.05259367f, -0.10669877f, -0.01985517f, 0.05945817f, 0.22637603f, -0.00273736f, 
    0.00554880f, -0.05710459f, -0.00608485f, 0.14325233f, 0.25159854f, 0.17066611f, -0.00955559f, 0.06335054f, 
    0.09918997f, -0.12124626f, -0.03304814f, -0.23407133f, 0.05442782f, 0.07899418f, 0.01531951f, -0.20164260f, 
    -0.06397825f, 0.07936140f, 0.05706995f, 0.17284428f, 0.25200513f, -0.50227350f, 0.23392978f, -0.22437085f, 
    -0.06283117f, 0.07675149f, -0.10792661f, 0.02973555f, -0.03137566f, 0.02440687f, -0.07149377f, -0.35895336f, 
    0.14002486f, -0.15109763f, 0.18194707f, -0.16990562f, -0.03121833f, 0.04450782f, 0.02007448f, 0.04776143f, 
    0.08842305f, 0.08808367f, -0.02633639f, 0.21267228f, -0.42006302f, 0.09371778f, -0.20858672f, -0.09162489f, 
    0.00097119f, 0.09953780f, 0.19610389f, 0.04153369f, 0.16398756f, -0.03632457f, 0.07896660f, 0.10547883f, 
    0.06780966f, 0.13130553f, 0.01278588f, 0.18828340f, -0.02905256f, -0.04787185f, 0.00938758f, -0.25492966f, 
    0.18069024f, 0.01238349f, 0.03466302f, 0.14130615f, -0.08113700f, -0.04901766f, 0.01732465f, -0.08400661f, 
    0.03516408f, -0.00992793f, 0.12062095f, 0.08106068f, 0.06450903f, -0.04626736f, 0.17722175f, 0.10573104f, 
    -0.09007929f, 0.05979792f, 0.23792447f, 0.16607550f, 0.00154169f, -0.15092604f, 0.01974316f, 0.00203986f, 
    0.08549033f, 0.08456370f, -0.06489130f, -0.09905956f, -0.26288915f, 0.10319478f, -0.18322971f, 0.08362653f, 
    0.11072169f, 0.07626905f, 0.06420860f, -0.18510219f, 0.00992608f, -0.17294303f, -0.03991745f, -0.08708539f, 
    0.00640954f, -0.00272561f, 0.06631131f, 0.06111860f, 0.07482517f, 0.06528026f, 0.07045935f, 0.10517927f, 
    -0.02627558f, -0.07489142f, -0.13552417f, -0.13834944f, 0.06818520f, -0.32842356f, 0.13398366f, -0.12853795f, 
    0.03402153f, 0.05444143f, -0.22179924f, -0.14801091f, 0.08153853f, 0.11387202f, 0.02461753f, -0.11828941f, 
    0.18281990f, -0.28328839f, 0.27863768f, 0.01016500f, -0.01321192f, -0.01281965f, -0.12133439f, -0.07968427f, 
    0.06521059f, 0.10785072f, 0.10589200f, -0.00491905f, 0.25502583f, 0.04639396f, 0.35419354f, 0.08702854f, 
    -0.14481403f, -0.14828110f, -0.03065271f, -0.05947640f, 0.09654393f, -0.12486929f, 0.04310980f, 0.00174934f, 
    -0.13827452f, -0.24901907f, -0.03828230f, 0.15265141f, 0.03873396f, 0.04128281f, 0.18118729f, 0.18485178f, 
    0.06314725f, 0.03176119f, 0.16760036f, 0.12081459f, -0.16203043f, -0.33102670f, 0.06327795f, 0.13626297f, 
    -0.04787008f, 0.04021623f, -0.12810862f, 0.20573324f, -0.06138248f, 0.06470789f, -0.01517200f, -0.23197332f, 
    -0.07222912f, 0.44724122f, 0.10782319f, 0.08244328f, 0.03999285f, -0.20126030f, -0.02904655f, 0.05270126f, 
    -0.07292034f, 0.10571024f, 0.17604001f, -0.05504589f, -0.21034443f, -0.31334874f, 0.03240328f, 0.06024985f, 
    0.05902038f, -0.04381347f, -0.08434859f, 0.21650049f, 0.04867656f, 0.01186433f, 0.03585699f, -0.06234311f, 
    -0.06284437f, 0.18240164f, 0.10203449f, 0.00257584f, -0.16615316f, -0.03742147f, -0.12737428f, -0.07868728f, 
    0.00119047f, 0.11327913f, 0.09269335f, 0.08880547f, -0.16394740f, 0.16370262f, -0.06679446f, 0.16466039f, 
    0.00132048f, 0.03641852f, 0.02651422f, 0.04545333f, -0.16667525f, 0.05624961f, 0.02420859f, -0.00133626f, 
    -0.17255630f, 0.33433944f, -0.06595528f, -0.03787656f, -0.15350007f, 0.08379596f, 0.07539286f, 0.03552001f, 
    0.12595421f, 0.20464444f, 0.06497482f, -0.00494849f, -0.31856620f, 0.03322361f, 0.38384080f, 0.04866249f, 
    0.05732459f, 0.09221436f, -0.07130148f, -0.15229623f, -0.07388739f, -0.07444088f, 0.06759579f, -0.08668066f, 
    0.45656300f, -0.10050511f, 0.01812416f, 0.02595161f, 0.07207866f, 0.10855925f, 0.11684323f, 0.03174692f, 
    0.03439883f, 0.10178677f, 0.08695180f, 0.20740898f, -0.15156591f, -0.31762961f, 0.00623649f, 0.11934155f, 
    -0.01047674f, -0.11122977f, 0.02966353f, -0.01269301f, 0.02945747f, -0.05437430f, -0.05687602f, -0.08995576f, 
    0.10746082f, -0.14939038f, 0.00758107f, 0.09515937f, 0.18046714f, 0.06181106f, -0.02697257f, 0.05332441f, 
    0.10568947f, 0.12308419f, 0.00092201f, -0.01544784f, 0.19050305f, 0.15264539f, 0.31113848f, -0.08841696f, 
    -0.08809755f, 0.06087941f, -0.09249952f, -0.08397398f, -0.08140714f, -0.08324795f, -0.05622840f, 0.00460728f, 
    -0.04314289f, -0.17074801f, -0.01856519f, 0.31616127f, 0.02402681f, -0.03990816f, 0.00885308f, 0.03151403f, 
    -0.05273329f, -0.05549516f, -0.15278190f, -0.15991120f, 0.19309446f, 0.00947529f, -0.13732865f, 0.01113936f, 
    0.04034172f, 0.03593007f, -0.08884517f, -0.02561794f, -0.11097383f, -0.02704319f, 0.20171265f, -0.03347426f, 
    0.10864252f, -0.18719345f, -0.20943163f, 0.22343747f, 0.12704445f, 0.04982492f, 0.05298293f, -0.04479297f, 
    0.05115207f, 0.19645591f, 0.03746798f, 0.19327167f, 0.09753391f, 0.02112545f, -0.17398258f, -0.17101236f, 
    -0.02625442f, 0.00998107f, 0.01386405f, -0.16301681f, 0.11127648f, 0.07622930f, 0.02640156f, -0.12336376f, 
    -0.16717030f, 0.02841300f, -0.09105928f, -0.01244561f, 0.04103975f, -0.24803431f, -0.02917512f, 0.01639823f, 
    -0.08883097f, 0.05457039f, -0.11796697f, -0.05845166f, -0.30755898f, 0.10834864f, -0.01648372f, 0.01463531f, 
    -0.14104898f, 0.01841139f, 0.20968381f, 0.11800077f, -0.10012763f, -0.12969479f, 0.01504641f, 0.04753639f, 
    0.25243962f, -0.01316966f, 0.12262157f, 0.22165431f, -0.04707510f, 0.15127249f, 0.00925552f, -0.13191357f, 
    0.12137235f, 0.11815079f, 0.22098754f, 0.21494792f, -0.16743477f, 0.01796729f, 0.05670104f, -0.08804789f, 
    0.16109562f, -0.05413597f, 0.01095780f, 0.07804459f, 0.10470057f, 0.13460281f, 0.10144769f, -0.07558566f, 
    0.57173753f, 0.12857559f, 0.05574644f, -0.03126080f, 0.04928353f, -0.19851577f, -0.06170667f, -0.00440304f, 
    0.20686355f, -0.11827572f, -0.00664150f, -0.08862083f, -0.36501774f, -0.04805082f, 0.10796419f, -0.14740492f, 
    0.02982405f, 0.02210228f, 0.10119314f, -0.00995492f, -0.09353521f, 0.08353536f, -0.04784172f, -0.05855746f, 
    0.23373462f, -0.10938638f, -0.13581915f, -0.02805342f, -0.08695477f, -0.05731123f, -0.17326501f, -0.11938520f, 
    0.05800699f, -0.31889477f, -0.22509612f, -0.04766360f, 0.29546094f, -0.20288686f, -0.30510056f, -0.06388059f, 
    -0.06907684f, -0.16573766f, -0.05965588f, 0.02822423f, 0.09013333f, 0.16946699f, -0.22826648f, 0.05700928f, 
    -0.21912584f, 0.07869738f, -0.03138585f, -0.05885340f, -0.02256935f, -0.10049392f, 0.01042013f, 0.03627337f, 
    -0.11607253f, 0.04469771f, -0.11292292f, 0.04308201f, -0.07706185f, 0.04859208f, -0.01191921f, 0.02394076f, 
    0.06197972f, 0.08871236f, 0.21307930f, -0.02134591f, 0.13288407f, 0.11235289f, -0.09787931f, -0.03943195f, 
    -0.19801043f, 0.18129505f, 0.00860175f, 0.06655003f, -0.08806374f, 0.07861938f, 0.10633510f, -0.05209466f, 
    0.12480988f, -0.07193878f, -0.23058623f, -0.03299526f, -0.22180055f, -0.08773605f, 0.02750388f, 0.16868101f, 
    -0.17220306f, -0.11658760f, -0.01177589f, -0.04488720f, -0.01851735f, -0.04561249f, -0.19455138f, -0.04681122f, 
    -0.33722878f, -0.06515956f, 0.00157762f, 0.24895646f, 0.18108273f, 0.18895720f, 0.08048748f, 0.03924582f, 
    -0.05678282f, 0.06351360f, 0.02828111f, -0.01823922f, -0.04457235f, 0.06022717f, 0.04841348f, 0.02437151f, 
    0.01967237f, 0.01114098f, 0.03493399f, -0.04595704f, 0.10621021f, -0.04077271f, -0.04556175f, 0.18439946f, 
    -0.35612994f, 0.00348313f, 0.37219208f, 0.08986803f, 0.21738330f, 0.10472914f, -0.01868844f, 0.04368605f, 
    -0.07466037f, -0.11117435f, -0.15093854f, -0.05692354f, 0.02002036f, -0.19481170f, 0.04950420f, -0.19318312f, 
    -0.37520829f, -0.15678434f, -0.17321092f, -0.01619993f, 0.09536555f, -0.03465768f, 0.05365917f, -0.04348874f, 
    -0.00377448f, 0.03200117f, -0.00910825f, 0.06403282f, -0.03921429f, -0.05206880f, -0.06502597f, -0.04123564f, 
    -0.04432481f, -0.01182668f, 0.00221466f, -0.06429329f, -0.04564421f, 0.02062165f, -0.00117024f, 0.03646461f, 
    -0.06688054f, -0.04498298f, -0.00487255f, 0.02843495f, 0.01246561f, 0.03770090f, -0.04163923f, 0.06202365f, 
    0.02237380f, -0.06727458f, 0.00281958f, -0.03232000f, 0.03695823f, -0.02901609f, -0.07287975f, -0.07271544f, 
    -0.00552812f, 0.02935189f, -0.07252640f, -0.06425358f, 0.04618983f, 0.00387380f, 0.00941870f, 0.01159167f, 
    -0.05596741f, 0.06112664f, 0.02482744f, -0.02471727f, -0.02283767f, -0.07161860f, 0.00169973f, -0.02963796f, 
    0.04923112f, -0.03279730f, -0.04875385f, 0.04764854f, 0.05687667f, -0.05491527f, -0.04992260f, -0.03458330f, 
    0.03229215f, 0.02779344f, -0.07602721f, -0.02864724f, 0.05933183f, -0.03124937f, -0.05261480f, -0.06780359f, 
    0.01960506f, 0.06225980f, -0.06607347f, 0.04481405f, -0.01763010f, -0.03854388f, -0.01390730f, -0.07136837f, 
    -0.03114757f, -0.04181794f, -0.03242689f, -0.01801879f, -0.01975348f, 0.00951011f, -0.06671382f, 0.00873343f, 
    -0.01517430f, -0.06099300f, -0.00960575f, 0.00771256f, 0.03161075f, 0.04527493f, -0.06698287f, 0.05059145f, 
    -0.02556528f, -0.05451903f, 0.05152801f, -0.04464907f, 0.00710919f, 0.02519622f, 0.04602962f, -0.05057757f, 
    -0.01071861f, -0.02180821f, -0.03306584f, -0.06531163f, -0.05972067f, 0.03124868f, -0.02604285f, 0.05604516f, 
    0.06614929f, -0.05121323f, 0.04653579f, -0.04038918f, 0.04137662f, 0.06044196f, -0.04151134f, -0.03517081f, 
    0.05598976f, 0.01865951f, -0.02464802f, 0.03839383f, 0.05680855f, -0.03033242f, -0.04134665f, -0.01300973f, 
    -0.04446283f, 0.00900571f, 0.05543499f, -0.06169941f, 0.03540556f, -0.04341285f, -0.06961844f, 0.05040466f, 
    -0.02475824f, -0.01079325f, -0.02899922f, -0.05478319f, -0.06938656f, 0.04485196f, 0.03730932f, 0.01635788f, 
    -0.03008417f, -0.05457591f, 0.04822557f, 0.02989210f, -0.01028497f, 0.03048189f, 0.01703231f, -0.06270774f, 
    -0.07310872f, -0.04805791f, -0.07219563f, -0.02621936f, -0.06721674f, 0.03603160f, -0.07295282f, -0.07713317f, 
    0.05504681f, -0.05297959f, -0.04500229f, 0.03272382f, 0.01613478f, 0.01500782f, 0.05503944f, 0.05337776f, 
    -0.02475381f, -0.04723035f, -0.05671167f, -0.06284570f, 0.06576382f, -0.00087433f, 0.00055906f, -0.02243123f, 
    0.05265204f, -0.01410303f, 0.00463907f, -0.02485707f, -0.04875964f, 0.05529763f, -0.04531823f, -0.05887893f, 
    -0.00522898f, 0.04445454f, -0.02451839f, -0.00754900f, 0.03102666f, -0.01217266f, 0.00552532f, -0.07713376f, 
    0.00935050f, -0.07037391f, -0.06482822f, 0.01192016f, -0.04261804f, -0.00083256f, -0.07579978f, -0.03268598f, 
    0.04852646f, 0.23194352f, 0.05109845f, -0.01987339f, 0.08195094f, 0.01922669f, 0.05198717f, 0.05742122f, 
    -0.06876793f, 0.05732234f, -0.10796232f, -0.15212663f, -0.04492747f, 0.35937059f, -0.15617214f, -0.12564941f, 
    -0.06736840f, 0.07874867f, 0.19865954f, 0.03736450f, -0.04388339f, 0.00437936f, 0.14460644f, 0.09164850f, 
    0.20641819f, -0.15613069f, 0.08437159f, 0.15966490f, -0.08162221f, 0.15600683f, 0.04864416f, 0.01450330f, 
    0.11468371f, 0.03706393f, 0.09644736f, 0.23595874f, 0.04797255f, 0.24156441f, 0.07163800f, -0.12748699f, 
    -0.06903798f, -0.02645468f, 0.06465235f, 0.06018019f, -0.19465755f, 0.04151257f, -0.10314149f, -0.15743853f, 
    0.47497323f, 0.07437743f, -0.12430772f, 0.03318414f, -0.04899202f, -0.05002416f, -0.17082630f, 0.08821853f, 
    0.04422494f, -0.11697291f, -0.09838789f, -0.07521242f, -0.15540545f, 0.04929850f, 0.03618164f, -0.12083308f, 
    0.05181630f, -0.15949032f, -0.07463679f, -0.05502321f, -0.01139592f, 0.04315405f, 0.01250835f, 0.00303769f, 
    -0.14730018f, -0.33120635f, -0.18149498f, -0.24297132f, -0.04989810f, -0.16443679f, -0.13248464f, 0.00627543f, 
    -0.17246874f, -0.30310860f, -0.14132042f, -0.26033929f, 0.00015737f, 0.00700508f, -0.24807063f, 0.15984187f, 
    0.05449965f, -0.08864737f, 0.04845052f, -0.16725346f, 0.11616407f, 0.03001967f, -0.04793980f, 0.06551761f, 
    -0.27493334f, -0.09102333f, 0.01956570f, -0.04031565f, -0.01762048f, -0.02113298f, 0.07608067f, 0.14314587f, 
    -0.03688534f, 0.04357968f, -0.15395339f, -0.16894870f, 0.09057882f, 0.20472331f, 0.09690768f, 0.06165521f, 
    -0.03025983f, 0.09313325f, 0.27550223f, -0.10929819f, 0.04344447f, 0.10412744f, -0.02322397f, 0.07533032f, 
    -0.03523294f, 0.14807251f, -0.01343288f, 0.09386443f, -0.08185235f, 0.21074556f, 0.13362080f, 0.08228955f, 
    0.00240074f, 0.09969740f, -0.09030077f, 0.10683666f, -0.34798583f, -0.21871947f, -0.21413258f, 0.00939174f, 
    -0.02929063f, -0.10996457f, -0.07631559f, -0.11040212f, 0.00604175f, 0.00288676f, -0.04736307f, 0.13830324f, 
    -0.08378823f, -0.03371979f, 0.22640823f, 0.10131508f, -0.00911755f, 0.18383655f, 0.09071721f, 0.07911459f, 
    -0.00923000f, 0.09275505f, 0.06662150f, 0.05087213f, -0.08251364f, -0.07686369f, -0.10591002f, -0.03889120f, 
    -0.09289954f, 0.16081259f, 0.03029417f, 0.07906874f, 0.09096412f, -0.14860681f, -0.07260226f, 0.25024030f, 
    -0.15533696f, 0.07892960f, 0.27937195f, -0.03376524f, 0.16436766f, -0.03809314f, -0.02150061f, 0.22637577f, 
    0.05074771f, -0.09126481f, -0.14695306f, -0.02723260f, -0.37674367f, -0.18066733f, -0.17842260f, -0.28360221f, 
    -0.02652230f, -0.06587290f, -0.09070624f, 0.09617955f, 0.16467801f, 0.11964293f, 0.11366602f, 0.06406742f, 
    0.07728279f, 0.17001028f, 0.01919810f, -0.19780962f, 0.05910019f, 0.18772656f, 0.17875150f, 0.08858894f, 
    0.00487040f, -0.02224029f, 0.00466562f, 0.09628318f, 0.11650548f, 0.55589736f, -0.09726740f, -0.03789048f, 
    -0.12121799f, 0.08993765f, 0.22315288f, -0.07252802f, 0.14886555f, -0.05287913f, -0.07424729f, -0.11395498f, 
    0.19859095f, -0.24342863f, -0.06828323f, -0.06038398f, 0.07646570f, 0.06482662f, -0.08509214f, 0.10707061f, 
    0.06956711f, 0.13734001f, -0.02891708f, 0.13997342f, 0.34328040f, 0.22120494f, -0.09058066f, -0.25750288f, 
    0.10666320f, 0.09116831f, 0.16266209f, -0.07206508f, 0.01609945f, 0.07536220f, 0.03851371f, 0.03305416f, 
    0.25437549f, -0.14190511f, -0.25072783f, 0.24857703f, 0.00760346f, -0.10972606f, 0.00361740f, -0.00026180f, 
    0.08980115f, -0.10582107f, -0.00342765f, 0.01654050f, 0.43745294f, -0.06494400f, 0.16859238f, -0.15209848f, 
    0.02074795f, -0.04962454f, 0.05335680f, -0.08493641f, 0.02111526f, 0.01972548f, -0.05401158f, 0.02374361f, 
    -0.01574505f, -0.27394867f, -0.01259413f, 0.01020523f, 0.04720239f, -0.14697942f, 0.05236651f, 0.01008557f, 
    -0.01252822f, -0.07078545f, -0.01970350f, 0.01771319f, 0.12717228f, -0.15900633f, -0.69093418f, 0.47461322f, 
    -0.05446263f, -0.12037061f, 0.09207651f, -0.17350884f, -0.20920680f, -0.01670551f, -0.14632881f, 0.02886313f, 
    -0.30813849f, -0.04604686f, 0.02070530f, 0.01459833f, -0.06446988f, 0.12233547f, 0.13770717f, 0.12223773f, 
    0.06003832f, 0.16425946f, -0.02375516f, -0.00903076f, 0.13667381f, 0.16703375f, 0.00731888f, -0.15033989f, 
    0.11498034f, 0.09020422f, 0.17988777f, 0.00825553f, -0.05392464f, 0.04666042f, -0.01761315f, -0.11078653f, 
    0.12299316f, -0.16568989f, 0.11152149f, -0.11022267f, -0.00380806f, 0.09955982f, 0.00087674f, 0.02576389f, 
    0.04684735f, -0.03771621f, 0.08259558f, 0.08165779f, -0.20416470f, 0.13766712f, -0.25335294f, 0.08400752f, 
    0.12561834f, 0.06163846f, 0.14193034f, -0.04406627f, -0.03042762f, -0.14135781f, -0.03251392f, -0.00719964f, 
    0.23560517f, 0.07345903f, 0.15611145f, -0.27832040f, 0.09511244f, 0.20712131f, 0.23207557f, 0.02173074f, 
    0.06544328f, 0.02434538f, -0.07707019f, -0.00275449f, -0.05304833f, -0.16645342f, 0.20874073f, -0.02744748f, 
    -0.11988840f, 0.04542898f, 0.11071729f, 0.00520834f, -0.06591321f, -0.05627210f, -0.15751001f, 0.09596066f, 
    0.03909354f, 0.34303728f, 0.33010897f, -0.13752051f, 0.11178139f, -0.01035130f, -0.01193503f, -0.03895545f, 
    0.11126895f, -0.02610287f, 0.13467188f, 0.07901677f, -0.28785628f, -0.12722771f, -0.39148483f, -0.22360890f, 
    -0.11789115f, -0.18909948f, 0.04384460f, 0.00796410f, 0.16230074f, 0.06426981f, 0.02620634f, -0.07827806f, 
    0.24598601f, -0.03118671f, 0.08470651f, 0.05661321f, -0.10643965f, -0.03727350f, 0.03702813f, -0.00302929f, 
    -0.15014553f, 0.04236633f, 0.09509643f, 0.01020123f, 0.09053662f, -0.05228699f, -0.38423631f, -0.05350285f, 
    0.10813683f, 0.15966761f, -0.04488099f, 0.09123684f, -0.05128664f, 0.12895060f, 0.01832904f, -0.11354165f, 
    0.11938249f, -0.15206449f, -0.15877166f, 0.09695021f, 0.07792357f, -0.05123256f, 0.19808936f, -0.08499057f, 
    0.18485959f, -0.05342754f, -0.07635451f, -0.05578443f, 0.04137729f, 0.04172866f, -0.11219185f, -0.09712519f, 
    0.12504588f, 0.18872991f, 0.10477655f, -0.05604353f, -0.09445428f, -0.00838942f, 0.09622576f, -0.08879272f, 
    0.13348827f, 0.11466238f, 0.05917478f, 0.09935702f, -0.22549467f, -0.06620027f, -0.00585166f, 0.04666876f, 
    -0.01504938f, -0.12150266f, 0.01855404f, 0.10700685f, -0.02866644f, 0.34613547f, -0.14309818f, -0.00370488f, 
    -0.03089115f, -0.06989606f, 0.08773386f, -0.06144450f, -0.04509670f, -0.12593979f, 0.04173720f, -0.05278311f, 
    0.04457837f, 0.03453859f, 0.08768497f, 0.05644716f, -0.06107610f, 0.00280867f, 0.03170079f, -0.09724085f, 
    -0.05801246f, 0.12948045f, -0.08683263f, 0.02174749f, -0.11214419f, 0.15785781f, 0.04477512f, 0.15118067f, 
    -0.03551654f, -0.05978703f, 0.04393512f, 0.11058144f, 0.04780266f, -0.01859985f, 0.02511463f, 0.02859739f, 
    -0.15330394f, -0.17980887f, 0.13518217f, -0.16100149f, 0.04920787f, -0.07096794f, -0.01544833f, 0.04443241f, 
    -0.13566919f, -0.04468617f, 0.02071453f, -0.15707330f, 0.12044395f, 0.09895682f, 0.02877170f, -0.01786589f, 
    0.00812406f, 0.08963677f, 0.05993043f, 0.02063496f, -0.07293037f, 0.09374546f, 0.02796412f, 0.00396265f, 
    0.16577506f, -0.33938503f, -0.13882644f, -0.15610434f, 0.19721459f, 0.02015806f, 0.19933930f, 0.04727047f, 
    -0.15638016f, -0.06432752f, 0.20948273f, 0.05713603f, 0.16639273f, 0.17317595f, 0.13242406f, -0.08542478f, 
    -0.08168105f, -0.18944722f, -0.12950873f, -0.11020045f, -0.07195912f, -0.08501112f, 0.07739846f, -0.00117512f, 
    0.28360444f, -0.06196861f, 0.09561881f, -0.07814811f, -0.03488467f, 0.02630693f, 0.03372730f, 0.10319486f, 
    0.06102362f, -0.00413745f, 0.14832336f, 0.01757530f, 0.20698582f, 0.04591079f, 0.11970557f, 0.10638264f, 
    0.06389031f, -0.01864291f, 0.08667947f, -0.07446977f, 0.07562161f, 0.01638828f, 0.04227615f, 0.02865649f, 
    0.14927991f, -0.06839254f, 0.07579231f, -0.11821602f, 0.08432757f, 0.02560412f, 0.10461980f, -0.00193461f, 
    0.02398803f, -0.10006924f, -0.08205621f, -0.01666164f, -0.10911003f, -0.18630919f, -0.34180242f, -0.05511957f, 
    -0.09482562f, -0.05654206f, -0.06683151f, 0.05418269f, 0.19250986f, 0.00494425f, 0.04929807f, -0.02302347f, 
    -0.03546638f, -0.28146186f, -0.02157447f, 0.05146737f, -0.04348273f, -0.09760565f, 0.11361019f, 0.11733596f, 
    -0.12088305f, -0.04865456f, 0.02343366f, -0.03526198f, -0.04949824f, -0.14115360f, -0.06274919f, 0.09317844f, 
    -0.16551751f, 0.23363954f, -0.08677800f, 0.05779392f, -0.02629014f, -0.02517566f, -0.00644313f, -0.04117586f, 
    -0.01496399f, 0.19007547f, 0.25745708f, 0.20081484f, 0.16817260f, 0.05045165f, -0.13815562f, 0.24414232f, 
    0.14919783f, 0.03253450f, 0.20303194f, 0.13114138f, -0.06665067f, -0.01668900f, -0.09914558f, -0.04323709f, 
    -0.02920271f, -0.07402934f, 0.03168440f, 0.18146205f, -0.07319829f, -0.07414798f, -0.15260959f, -0.05841586f, 
    0.12317141f, 0.23862770f, -0.01332654f, 0.25745913f, -0.05586574f, -0.08161356f, -0.08378113f, -0.07644217f, 
    0.03786819f, -0.01696702f, 0.03136827f, -0.03424339f, -0.27473366f, 0.20018378f, -0.10824228f, 0.22521299f, 
    0.07612619f, -0.02770829f, 0.09012304f, -0.17962761f, -0.06983562f, 0.04448954f, 0.06556621f, 0.02533363f, 
    -0.29392844f, 0.21714924f, -0.23598959f, 0.04320434f, -0.08736283f, 0.00646070f, 0.00372834f, 0.00056395f, 
    0.04730521f, 0.03884539f, -0.00582880f, -0.12577632f, -0.05709922f, -0.12793687f, 0.23636855f, 0.16080917f, 
    0.03073422f, 0.02382829f, -0.16386361f, -0.17236750f, -0.09928722f, -0.07122199f, 0.08396705f, 0.00594931f, 
    0.09589189f, -0.15102449f, -0.03840954f, -0.21953017f, 0.01568208f, -0.08006587f, -0.00193179f, 0.22581862f, 
    -0.07928888f, 0.05206431f, -0.08180661f, -0.10927302f, -0.03344425f, -0.16423261f, 0.04587610f, 0.04917704f, 
    -0.01738351f, -0.07832170f, 0.02357437f, -0.08971994f, 0.09169519f, 0.13060622f, -0.08582227f, 0.00798144f, 
    0.22240560f, -0.21979536f, 0.02394826f, 0.01848999f, 0.10505700f, 0.12095561f, 0.09343883f, 0.10233182f, 
    0.03894340f, 0.01576219f, 0.08969090f, 0.04307648f, 0.16593765f, 0.10955773f, 0.21037969f, -0.16605945f, 
    0.09654090f, 0.05721941f, -0.01148773f, -0.04771404f, -0.08820318f, 0.03463356f, -0.00115690f, 0.07397218f, 
    0.08809648f, 0.07981774f, 0.01872147f, 0.13630810f, 0.06270855f, 0.05848965f, 0.04550834f, 0.15797848f, 
    0.00055045f, 0.10152692f, -0.00373176f, -0.04637664f, 0.04341613f, 0.15093265f, -0.17352201f, 0.09239702f, 
    0.08224110f, -0.08427417f, 0.09186938f, 0.12053031f, 0.04313710f, -0.10344504f, 0.06881396f, 0.06902727f, 
    -0.13116989f, 0.08574466f, -0.03113847f, 0.10220170f, 0.06347124f, 0.15291944f, 0.03595031f, 0.01206752f, 
    -0.03850859f, 0.05556360f, -0.02017290f, 0.01410665f, -0.57580268f, -0.01745655f, -0.33835816f, -0.10543393f, 
    0.01906458f, -0.04271051f, 0.00172197f, -0.16708978f, -0.00260452f, 0.07067779f, 0.11113009f, -0.07728819f, 
    -0.09688856f, 0.03008193f, 0.10896060f, 0.03287776f, 0.04760503f, 0.15683582f, 0.09509274f, 0.02810279f, 
    -0.09118614f, -0.03962041f, 0.03578600f, 0.16317515f, -0.24521077f, 0.01165374f, -0.07793397f, -0.06693097f, 
    -0.01370193f, -0.02468812f, 0.08480547f, 0.16074960f, -0.02543813f, 0.06837369f, -0.03875269f, -0.04316799f, 
    0.23809071f, 0.19484337f, 0.10538386f, 0.09244639f, 0.06183726f, -0.05138461f, 0.10540712f, -0.16824074f, 
    0.23927188f, 0.16950102f, 0.11215553f, -0.10023455f, -0.15561633f, -0.28686205f, 0.11933316f, -0.03025038f, 
    -0.04602785f, 0.20968173f, 0.03098886f, -0.09684730f, 0.00399059f, -0.06571950f, 0.10643893f, -0.06378704f, 
    0.10415905f, 0.01918891f, 0.23756106f, 0.10684393f, -0.02091838f, 0.00649820f, -0.01018922f, 0.11064928f, 
    0.10187673f, 0.07215425f, 0.21124797f, -0.02597440f, -0.04045173f, -0.00055430f, -0.22495389f, -0.30171335f, 
    0.18430772f, -0.04178091f, 0.01583463f, 0.02847590f, -0.00503962f, -0.04915523f, 0.04176469f, -0.19884919f, 
    0.04269961f, 0.05280592f, -0.08393925f, 0.03083734f, 0.01192952f, 0.05463204f, -0.03365257f, 0.06526358f, 
    0.28173223f, 0.11315251f, 0.13225546f, 0.13643339f, 0.27043784f, 0.00417096f, 0.11429133f, -0.07964715f, 
    0.02700885f, 0.06509139f, -0.02297188f, -0.00363991f, -0.12732758f, 0.08167470f, -0.07414406f, 0.09581315f, 
    0.12646727f, -0.10513980f, 0.00458857f, 0.10004953f, 0.08707883f, 0.10846797f, -0.12987894f, -0.10996445f, 
    0.01698157f, 0.08909928f, 0.08741681f, 0.10676464f, -0.39039904f, -0.10767225f, 0.00774491f, -0.13924812f, 
    0.00823833f, 0.02737717f, 0.06401940f, -0.03258188f, -0.12997273f, -0.28418884f, -0.25347808f, -0.29926413f, 
    -0.11442219f, 0.01134330f, -0.00645614f, 0.02478958f, -0.02237012f, 0.01398870f, -0.01713935f, -0.10329861f, 
    0.01381754f, 0.04246753f, -0.04592524f, -0.10231773f, 0.49866337f, 0.09573639f, 0.19430856f, -0.11230845f, 
    0.02131313f, -0.06162958f, -0.09807959f, 0.18907578f, -0.08456687f, -0.01678813f, 0.03438369f, 0.10566998f, 
    -0.37766936f, -0.11492994f, -0.04071565f, 0.06553383f, -0.07946716f, -0.02794592f, -0.09190644f, -0.18437149f, 
    -0.07882061f, -0.06478184f, 0.09406181f, -0.05843156f, 0.13877012f, 0.07111938f, 0.01576889f, 0.28898147f, 
    0.00506188f, 0.15082251f, -0.01119197f, -0.00853678f, 0.07086524f, 0.11451729f, 0.00827631f, 0.03769989f, 
    -0.21774524f, -0.24328233f, -0.14836402f, 0.10694941f, -0.07921788f, -0.00804117f, -0.14206646f, -0.01080416f, 
    0.11811880f, 0.00172999f, 0.07149366f, -0.02787859f, 0.04834377f, 0.11196448f, -0.00200431f, 0.13581333f, 
    -0.04629964f, 0.04092028f, -0.01121535f, 0.05446115f, -0.09483203f, 0.02016651f, -0.16729364f, -0.01666565f, 
    0.16036485f, 0.01184561f, 0.04976083f, 0.13035388f, -0.04190195f, 0.02397525f, 0.08027357f, 0.06988017f, 
    -0.06196115f, -0.07835831f, -0.08942021f, 0.00111898f, 0.17658284f, 0.20521177f, -0.24985416f, 0.02620707f, 
    0.04897590f, 0.08574160f, -0.05229233f, -0.15211152f, 0.00228265f, 0.06341002f, 0.11297896f, -0.02614407f, 
    -0.00171059f, 0.15686606f, -0.30157453f, 0.07055809f, -0.03733958f, 0.07113722f, 0.08197903f, -0.13594578f, 
    0.20729302f, 0.09247007f, -0.03691014f, 0.06904884f, 0.06264275f, 0.05952932f, -0.30998892f, -0.12291914f, 
    0.10055900f, -0.02495227f, -0.04707173f, -0.19511823f, -0.07390436f, -0.23001067f, 0.02966538f, -0.07452177f, 
    -0.19039920f, 0.08721700f, 0.00151685f, -0.00092449f, 0.01179114f, 0.00229061f, -0.04489513f, -0.03153798f, 
    0.06433418f, -0.06873363f, -0.07458652f, 0.01488797f, 0.09811210f, 0.46201271f, -0.02679693f, -0.00509033f, 
    -0.08969641f, -0.20088606f, 0.04123870f, -0.11791445f, 0.00656784f, 0.01624587f, 0.08720282f, 0.03741673f, 
    -0.21162896f, -0.04015889f, -0.16042344f, -0.12574361f, -0.02100864f, -0.05001098f, -0.12613831f, 0.02473875f, 
    -0.13432804f, -0.01979938f, -0.09543571f, -0.10153598f, -0.31349769f, 0.00093761f, -0.14504127f, 0.09193898f, 
    -0.06577505f, -0.02312932f, -0.17605942f, 0.05534083f, -0.06546529f, -0.05437073f, 0.05009945f, -0.06554437f, 
    -0.02071458f, -0.01492714f, 0.02446008f, 0.10164336f, 0.12561776f, 0.05009142f, 0.08242710f, 0.04812430f, 
    -0.00277536f, 0.00544188f, -0.00191444f, -0.09387066f, 0.03611392f, 0.02948283f, -0.12275327f, 0.05279839f, 
    0.06244772f, 0.14945088f, -0.03015768f, -0.10222415f, -0.05938055f, -0.03590519f, -0.01061016f, -0.06565417f, 
    0.19670112f, 0.17362909f, -0.04930974f, -0.03579298f, -0.01514011f, 0.18222606f, 0.06563926f, 0.03097265f, 
    -0.14155409f, -0.08837108f, 0.00379967f, 0.08839062f, -0.50538468f, -0.27809969f, 0.08723423f, 0.03686969f, 
    0.08269881f, -0.00427970f, -0.12875614f, 0.02024804f, 0.03384418f, -0.05204285f, -0.04442622f, 0.02524878f, 
    0.13442026f, 0.06991936f, 0.00982356f, -0.09834290f, -0.00910645f, 0.22578359f, -0.02424487f, 0.06239960f, 
    0.03922365f, 0.06533445f, -0.00093365f, 0.03109444f, -0.15300734f, 0.13154903f, 0.05213533f, -0.01433105f, 
    -0.06246704f, 0.07496811f, 0.06423636f, 0.13159673f, -0.00017203f, 0.02486014f, 0.04991559f, 0.05925998f, 
    0.11389813f, 0.20839332f, 0.06604040f, -0.05542099f, 0.07909254f, 0.01261926f, -0.03558325f, -0.02763023f, 
    -0.02976430f, -0.14197047f, -0.10120903f, -0.07244530f, 0.05251810f, -0.00933828f, -0.04793948f, 0.08322994f, 
    0.02281735f, 0.05411921f, 0.10359362f, 0.04068279f, -0.01486162f, 0.11501928f, 0.14220934f, -0.04076231f, 
    0.19033739f, 0.11834549f, 0.08680919f, -0.00007202f, 0.02909115f, 0.21520004f, 0.00367703f, -0.00542795f, 
    0.02701123f, -0.07904672f, 0.07579456f, 0.25553113f, 0.17457029f, 0.14127842f, -0.18209526f, -0.08485778f, 
    0.03749100f, 0.03198297f, 0.02528111f, 0.17497049f, 0.04807106f, 0.01078662f, 0.16373320f, -0.25171185f, 
    -0.22196442f, 0.01308827f, -0.10608734f, -0.11960940f, 0.24494022f, -0.08377830f, -0.07468026f, -0.13045742f, 
    0.02450847f, 0.08549946f, -0.14860211f, -0.15070917f, 0.18015669f, 0.01936343f, -0.15958457f, 0.10399310f, 
    0.07404198f, 0.12873712f, 0.11893918f, -0.12236293f, 0.20922475f, 0.15888000f, 0.09497110f, 0.22442076f, 
    -0.65835905f, -0.08628481f, -0.17178835f, 0.29292202f, -0.14199892f, -0.05600187f, -0.06087624f, -0.18300404f, 
    -0.07600592f, -0.07073864f, 0.01495483f, 0.05564198f, 0.58578658f, 0.11881096f, -0.31526360f, -0.26508102f, 
    0.18286373f, 0.28300959f, 0.19586308f, -0.02247153f, -0.18182883f, -0.10358320f, -0.12473513f, -0.12648863f, 
    -0.07572736f, 0.09562109f, -0.00347140f, 0.33277628f, -0.32173648f, -0.28176224f, -0.11687192f, -0.15998520f, 
    0.02671966f, 0.22179332f, 0.13425831f, 0.21685138f, -0.04970058f, -0.04000127f, -0.15320440f, 0.23408619f, 
    -0.02791873f, -0.27840325f, -0.29984900f, -0.20841305f, -0.34790492f, -0.28704360f, -0.17460673f, 0.00559912f, 
    0.21262410f, -0.00153269f, 0.03481550f, 0.05988386f, -0.19170426f, 0.07557080f, -0.05757917f, -0.04794369f, 
    0.17757384f, 0.12444586f, 0.26864254f, 0.18855312f, 0.12751830f, 0.01995432f, -0.03114842f, 0.04139826f, 
    0.28847292f, 0.18811889f, -0.06164390f, 0.03823530f, -0.23009591f, -0.29593459f, -0.13939966f, -0.22932854f, 
    0.15951853f, 0.02100670f, 0.07261612f, -0.14429273f, 0.11131047f, 0.12756146f, 0.03672273f, 0.00598332f, 
    -0.16357340f, 0.02309475f, 0.06573247f, -0.10896342f, 0.11015169f, 0.29864606f, 0.02199499f, 0.20661992f, 
    0.07587613f, 0.07298063f, -0.05504345f, 0.02733385f, -0.28127003f, -0.33240783f, -0.13373540f, -0.14686453f, 
    0.13355516f, 0.15179998f, -0.02449876f, -0.34174922f, 0.07668275f, 0.08003656f, 0.13803320f, 0.07515574f, 
    0.05269150f, -0.13365948f, 0.01322239f, -0.07823578f, -0.36455905f, 0.05406453f, 0.11035772f, -0.30338472f, 
    -0.15772273f, -0.00788970f, -0.08553456f, -0.16081816f, -0.12568283f, -0.02078508f, 0.07466184f, -0.13847606f, 
    0.19382189f, 0.36938679f, 0.08601171f, 0.08638448f, -0.01444292f, 0.01880709f, -0.13490503f, -0.13254045f, 
    -0.05839665f, 0.10258588f, 0.08372030f, 0.27145615f, 0.03414269f, 0.20867270f, -0.17703503f, -0.04543028f, 
    0.17158423f, -0.16034998f, 0.05036416f, -0.21325180f, -0.18500003f, -0.07337148f, -0.07798255f, 0.01688458f, 
    0.07138350f, 0.01704154f, -0.09583691f, -0.14673600f, 0.10130265f, 0.03232057f, 0.09844932f, 0.03665757f, 
    -0.06271131f, -0.12317678f, -0.04299871f, 0.06948045f, 0.23908186f, 0.06043451f, 0.15404457f, -0.01291877f, 
    0.00771978f, 0.18973450f, 0.38274035f, 0.05862696f, 0.05896985f, 0.09827993f, 0.03636009f, -0.02729801f, 
    0.17162137f, -0.16789705f, -0.06885646f, -0.08665586f, 0.07689845f, 0.10536160f, -0.03156190f, -0.09548698f, 
    -0.08357256f, 0.11758006f, -0.07164449f, 0.07891387f, 0.06099966f, 0.09300701f, 0.04884339f, -0.29907641f, 
    0.06074758f, 0.18984684f, 0.15204692f, 0.15690504f, 0.04646462f, 0.04256202f, -0.11714128f, -0.03382929f, 
    0.04774107f, 0.03575754f, 0.09344058f, -0.06572730f, 0.02972245f, 0.05724864f, -0.02250630f, -0.12095658f, 
    0.09382488f, -0.02447355f, 0.05990358f, 0.17468014f, 0.34220621f, -0.02835885f, 0.22661319f, -0.18739846f, 
    0.05135340f, -0.18938260f, -0.10714242f, 0.04062652f, 0.03007332f, 0.17180161f, -0.03080870f, -0.02234350f, 
    0.14474007f, 0.00793769f, 0.19560519f, -0.02782065f, -0.03843432f, -0.08511949f, 0.10764106f, -0.00912892f, 
    0.07487202f, -0.00235665f, -0.01292485f, -0.01517531f, -0.17956592f, 0.18002047f, -0.19459638f, 0.24051930f, 
    0.05371867f, 0.17192328f, 0.04971933f, -0.04417820f, 0.09855191f, -0.04084866f, 0.03041065f, 0.00655190f, 
    -0.24962305f, -0.21569410f, -0.00696917f, -0.06952888f, -0.06368113f, -0.00196506f, 0.06442503f, 0.06775307f, 
    -0.10105810f, -0.07967605f, -0.07078586f, -0.06933521f, 0.21172620f, 0.20708942f, -0.11516250f, 0.00706238f, 
    0.14665943f, 0.04259012f, 0.26785651f, -0.04450948f, -0.00576150f, -0.02754680f, 0.11453042f, 0.08622908f, 
    0.05170877f, -0.28100535f, -0.05377684f, -0.15288442f, -0.03144892f, 0.03587078f, 0.03992959f, 0.04708261f, 
    -0.09406898f, 0.02957436f, 0.00663102f, 0.08692861f, -0.28612384f, 0.10491555f, -0.25818062f, 0.12620623f, 
    -0.02960387f, -0.05371831f, -0.04420976f, 0.01585227f, 0.10299879f, 0.08939970f, 0.05858460f, 0.11611578f, 
    0.15261085f, 0.07912152f, 0.25699678f, -0.06700156f, 0.19399555f, 0.08386758f, 0.15298149f, 0.03359236f, 
    -0.02923310f, 0.04510113f, -0.05719160f, -0.09167994f, -0.00444107f, -0.19848041f, 0.17790711f, -0.23606189f, 
    0.04238953f, 0.03293389f, -0.04117434f, -0.06708317f, -0.02699751f, -0.13627614f, 0.01283500f, 0.14054987f, 
    0.23255447f, 0.06984578f, 0.49061927f, -0.05270952f, 0.14619401f, -0.01991912f, 0.02425813f, -0.05401609f, 
    0.01895092f, -0.00982257f, -0.02736892f, -0.11754971f, 0.41615304f, -0.03869405f, -0.03118295f, -0.18875390f, 
    -0.04073592f, 0.05192596f, -0.04016839f, 0.03753059f, 0.00484267f, -0.11869254f, 0.07788009f, -0.02139632f, 
    -0.18139227f, 0.03114338f, 0.03325688f, 0.04742251f, 0.04745329f, 0.03427054f, -0.01507476f, 0.11058401f, 
    -0.01612247f, -0.10319864f, -0.08204915f, 0.09802997f, -0.12282868f, -0.27930593f, 0.35300937f, -0.09515178f, 
    -0.02203670f, 0.09788891f, 0.18474166f, 0.10079003f, -0.01166686f, -0.04309712f, 0.00368257f, 0.04144267f, 
    0.18834490f, -0.24373551f, 0.00322657f, 0.04898475f, -0.08045791f, 0.15454412f, 0.00199997f, 0.05360430f, 
    -0.13466834f, 0.00082327f, 0.11499932f, -0.08491559f, -0.03911656f, -0.04322284f, 0.39516521f, 0.02600162f, 
    0.05738291f, 0.08193734f, -0.00180040f, 0.05802506f, 0.03251934f, 0.12740575f, 0.07712344f, 0.01818786f, 
    0.19079866f, -0.03538228f, 0.17182209f, -0.10415678f, 0.06009936f, -0.02064926f, -0.03777410f, -0.07922958f, 
    0.19133323f, 0.09193554f, 0.14435074f, 0.06176660f, -0.01066275f, -0.42191413f, 0.24140881f, -0.08020035f, 
    0.08282395f, -0.13423008f, -0.00045992f, 0.04185553f, -0.04200243f, 0.03328294f, -0.11101997f, -0.02446428f, 
    0.14567532f, 0.09198768f, 0.20495182f, -0.11611794f, 0.04111907f, -0.04431027f, 0.06994279f, -0.07790907f, 
    0.21948250f, -0.08358370f, 0.11371209f, 0.03544871f, 0.07705048f, 0.16155326f, -0.02517008f, 0.06192399f, 
    0.05448164f, 0.18897873f, 0.04996840f, -0.02239447f, 0.02323974f, 0.17401700f, 0.05930179f, 0.04659958f, 
    0.02807509f, -0.11623459f, -0.08196525f, 0.06475841f, 0.03176792f, -0.17465709f, 0.18320945f, -0.02160478f, 
    -0.03316103f, -0.07932905f, 0.01791281f, 0.14076693f, -0.14402007f, -0.01277377f, 0.16891050f, -0.00884225f, 
    -0.04042844f, -0.13943207f, 0.22566149f, 0.05419049f, 0.00606534f, -0.02934987f, 0.03212987f, 0.14972569f, 
    -0.25661093f, -0.02978852f, -0.03358636f, 0.09453776f, -0.00374765f, -0.05303907f, -0.03740607f, -0.02694450f, 
    0.08822136f, 0.04007439f, -0.19484738f, 0.08202835f, 0.25311196f, 0.10267646f, -0.01177455f, 0.08594593f, 
    -0.00344323f, -0.04140275f, -0.09867720f, 0.01322588f, 0.07717200f, 0.01740595f, -0.07711976f, 0.01353455f, 
    -0.10773065f, -0.18577854f, 0.07929164f, 0.16959701f, -0.00855676f, 0.02692911f, 0.04399700f, 0.02391865f, 
    -0.07818574f, 0.06028463f, 0.01907508f, -0.10490830f, 0.21356806f, -0.15727888f, 0.04598444f, -0.02497720f, 
    0.05172846f, 0.02362865f, -0.06913785f, -0.09222367f, 0.05021656f, -0.01693698f, 0.02803419f, 0.09389302f, 
    -0.03444174f, -0.32440025f, 0.23763297f, 0.24982412f, 0.07328751f, -0.02058684f, 0.04390528f, 0.09026216f, 
    -0.01224543f, 0.09639010f, 0.15070565f, 0.02005106f, 0.35452649f, 0.00030056f, -0.12521487f, -0.25564104f, 
    -0.07131143f, -0.07751029f, -0.13450399f, -0.00434026f, 0.09502778f, -0.13789190f, -0.05698919f, 0.04591420f, 
    0.15458739f, -0.02451396f, -0.00355271f, 0.06627089f, 0.00028279f, -0.09628892f, 0.11579803f, -0.05920997f, 
    -0.14087358f, 0.00036035f, -0.10705334f, -0.02591247f, 0.06031101f, -0.12885331f, -0.05946914f, 0.11826096f, 
    -0.10072204f, 0.10655798f, -0.22710507f, 0.06714585f, -0.07724856f, 0.17262571f, 0.00026989f, -0.04501464f, 
    -0.02088585f, 0.21326581f, 0.22647847f, 0.14641438f, 0.12302272f, -0.13592859f, -0.10000582f, 0.25283626f, 
    0.12134975f, 0.00273453f, 0.10374545f, -0.01040953f, 0.03637842f, -0.14873402f, -0.35080367f, 0.04881608f, 
    0.10301553f, -0.00731847f, -0.01997776f, 0.14375408f, -0.20186011f, -0.14519948f, -0.04826805f, 0.01511474f, 
    -0.44692826f, 0.23638268f, 0.15045182f, 0.14952032f, -0.16559464f, 0.03729207f, -0.02973183f, -0.03628919f, 
    -0.11979827f, 0.06302879f, -0.02480688f, 0.10135874f, -0.26226878f, 0.37126467f, -0.12876734f, 0.09881937f, 
    0.04361229f, 0.08094903f, 0.04847274f, -0.08538830f, -0.02965501f, 0.01578981f, 0.02225342f, -0.06534814f, 
    -0.16360410f, 0.14606403f, -0.12702489f, -0.06572647f, -0.14456193f, 0.00627942f, -0.03031672f, 0.01017519f, 
    -0.16400459f, -0.04649194f, -0.08805125f, -0.18001494f, -0.16022637f, -0.11596449f, 0.29069078f, -0.04453986f, 
    -0.05832508f, -0.04226512f, -0.05013216f, 0.06211428f, -0.00431520f, 0.02182710f, 0.12304118f, 0.04042370f, 
    0.09003033f, -0.05382366f, 0.00263402f, -0.18557140f, 0.05505021f, 0.06138034f, 0.13746998f, 0.10881291f, 
    -0.06913595f, -0.03305543f, -0.14417228f, -0.01004679f, 0.17414790f, -0.14046417f, -0.07933328f, 0.05048013f, 
    -0.12764046f, 0.07228153f, 0.02091966f, -0.04600188f, 0.03968280f, 0.12259665f, 0.00646290f, 0.04705119f, 
    0.33274466f, -0.06077083f, 0.06365240f, -0.01707147f, 0.09982539f, 0.05360885f, 0.02408464f, -0.00714914f, 
    0.06353410f, 0.00190130f, 0.07746647f, 0.01213509f, 0.14667438f, 0.12738043f, 0.35102776f, -0.13240740f, 
    -0.01905299f, -0.10913301f, 0.03824582f, -0.03109637f, -0.06064657f, 0.15819070f, 0.10310042f, -0.01012735f, 
    0.14079863f, 0.15567534f, -0.13966872f, -0.11779077f, -0.07137828f, -0.00183754f, 0.02699792f, 0.10623414f, 
    0.03522831f, -0.02583926f, 0.03022360f, 0.05383842f, 0.01804131f, 0.12768482f, -0.17158812f, -0.01434811f, 
    0.09564053f, -0.04213712f, -0.00736841f, 0.07622329f, 0.01589909f, 0.00499525f, 0.14689226f, 0.10320290f, 
    -0.00509167f, 0.25511923f, -0.34360629f, -0.05938987f, 0.05271139f, 0.11141123f, -0.02294509f, 0.04003641f, 
    -0.01181382f, -0.06339775f, 0.14101502f, -0.01778929f, -0.30108041f, 0.04662612f, -0.27639177f, -0.00204597f, 
    0.09372162f, 0.09119627f, 0.13868721f, -0.00668097f, 0.12991196f, 0.02830823f, 0.11263779f, -0.03471143f, 
    -0.02825117f, 0.21782047f, 0.28624916f, 0.06770217f, 0.02149762f, -0.10532016f, 0.07460984f, 0.29462382f, 
    0.09244969f, -0.05668171f, 0.09050638f, 0.13891247f, 0.11691672f, 0.29354453f, -0.16345075f, -0.16833580f, 
    -0.11179727f, 0.09310137f, 0.05424844f, 0.00521009f, -0.01625934f, -0.17668721f, -0.11332643f, -0.07725059f, 
    0.20429859f, -0.25555936f, 0.00335243f, -0.03316135f, -0.08740266f, 0.13257857f, 0.03969481f, -0.15845403f, 
    -0.08812055f, 0.13286074f, -0.02826572f, -0.12505707f, 0.04921323f, 0.20843236f, 0.14860025f, -0.23291834f, 
    0.05469117f, -0.04104595f, 0.10267004f, -0.00976476f, -0.07925383f, -0.02485476f, 0.29687172f, -0.06800418f, 
    0.54860318f, -0.14602987f, -0.12818050f, 0.04143944f, 0.10325748f, 0.06768738f, -0.15053320f, 0.01009662f, 
    0.15828703f, -0.04406494f, 0.00427499f, 0.12098201f, -0.12268987f, 0.22649293f, 0.19152257f, -0.17851909f, 
    -0.12223938f, -0.18767357f, 0.06435115f, 0.08115895f, 0.07172697f, -0.03915249f, -0.08556332f, -0.21895847f, 
    -0.07875535f, -0.25211808f, -0.27878550f, -0.26807353f, 0.03788528f, 0.02745748f, 0.03502865f, 0.04744724f, 
    0.19184271f, 0.04477084f, -0.10828314f, 0.06819206f, -0.17714748f, 0.03888861f, -0.41872492f, -0.24426238f, 
    0.20136435f, -0.03242095f, -0.05297947f, 0.07972151f, 0.07677083f, 0.06996644f, -0.14609650f, 0.15040703f, 
    -0.02995845f, -0.06541376f, 0.16377759f, 0.19203900f, 0.01566841f, -0.13888769f, -0.00117331f, -0.00864660f, 
    0.02583443f, 0.23126356f, 0.02925188f, 0.10493147f, 0.05818012f, 0.28761384f, 0.26891416f, -0.04233725f, 
    0.06527046f, 0.20883584f, 0.18405859f, -0.02601143f, 0.15409467f, 0.09455071f, -0.07330809f, -0.10744607f, 
    0.05846868f, -0.06840099f, 0.23852910f, 0.16712242f, 0.03526756f, 0.06151495f, 0.04196879f, -0.01744594f, 
    0.01149323f, 0.02474222f, 0.02189052f, 0.07750181f, -0.33687723f, -0.16814388f, 0.39125830f, 0.13143757f, 
    0.12720084f, -0.13346756f, -0.23604251f, 0.06848139f, 0.02395255f, -0.20870125f, -0.06609815f, -0.06784490f, 
    0.24602281f, -0.20274954f, 0.28178915f, 0.07130491f, -0.06335678f, 0.16119660f, 0.16582143f, -0.03091784f, 
    -0.02406215f, 0.04493888f, 0.05467647f, -0.00198715f, -0.06023720f, -0.25548911f, 0.22619694f, 0.41547921f, 
    -0.12551641f, 0.02948768f, -0.16986805f, 0.22613351f, 0.10689225f, 0.03474224f, -0.18968597f, 0.14362888f, 
    0.07239313f, -0.08966717f, 0.38088197f, 0.12815310f, 0.06845563f, -0.19672789f, 0.06497022f, -0.03599679f, 
    0.06388032f, -0.07751352f, -0.01418933f, 0.19409370f, -0.44127223f, -0.40802249f, -0.12645936f, 0.03307713f, 
    0.03356050f, -0.01986148f, -0.10143816f, -0.02618336f, -0.07705322f, -0.06431343f, -0.06033433f, 0.03534953f, 
    0.02613430f, 0.01598272f, -0.00026905f, 0.03863980f, -0.06408875f, 0.02796357f, 0.06136901f, -0.01872724f, 
    -0.07492428f, -0.03796089f, 0.00817142f, -0.00359425f, -0.05306423f, -0.07794911f, 0.04115736f, 0.03491247f, 
    -0.04390580f, -0.06173364f, 0.05743773f, -0.03980547f, 0.02172038f, 0.02981789f, -0.07664579f, 0.04836488f, 
    0.03639011f, -0.01373625f, -0.05336143f, -0.05700431f, -0.07282405f, 0.06276271f, -0.01221131f, -0.06330021f, 
    -0.07618828f, 0.01371195f, -0.04929685f, -0.00842009f, -0.00218076f, -0.07050098f, 0.04842809f, 0.02400520f, 
    0.03731950f, -0.06521668f, -0.01245037f, 0.05896907f, -0.05496787f, -0.01923182f, -0.06257752f, -0.03012474f, 
    0.06126889f, 0.05779994f, 0.06383488f, -0.03572077f, -0.07827894f, 0.02006153f, -0.06649705f, 0.02024763f, 
    -0.05149367f, 0.05483819f, -0.05159263f, -0.06811655f, -0.01986167f, 0.02886735f, 0.00446566f, -0.06968534f, 
    0.03080518f, -0.03993547f, -0.01073727f, 0.01191020f, 0.01961817f, -0.03911484f, -0.01164456f, -0.07753853f, 
    0.03310230f, -0.05641383f, -0.07208946f, 0.04359042f, -0.06776401f, -0.05249063f, 0.05598200f, -0.06928811f, 
    -0.00755638f, -0.04759014f, -0.02212451f, -0.04719139f, -0.06410004f, -0.01920720f, 0.00489120f, -0.02941285f, 
    0.06139167f, 0.01453676f, -0.01220361f, -0.02466126f, 0.00441322f, -0.06350965f, 0.06058338f, 0.00925656f, 
    0.02288216f, -0.02334620f, -0.04825627f, 0.00302087f, 0.03986777f, -0.05425110f, -0.04132000f, 0.05864480f, 
    -0.05030615f, -0.04505101f, -0.04042257f, 0.05295658f, -0.03207700f, 0.00095321f, -0.07875688f, 0.01356477f, 
    0.00031045f, -0.06731252f, -0.03675113f, 0.06308092f, -0.04368074f, -0.01951779f, 0.01830168f, 0.00529596f, 
    -0.02281376f, -0.01154447f, -0.01563153f, 0.04182007f, 0.00958061f, -0.02029420f, -0.01693719f, -0.04021725f, 
    0.05474683f, -0.02353789f, -0.07344317f, -0.06819163f, -0.07480942f, 0.05277848f, 0.03092310f, -0.05193339f, 
    -0.00501476f, 0.02482419f, -0.03080474f, 0.03300368f, 0.05767481f, -0.00413813f, -0.06049278f, -0.05769596f, 
    0.04658192f, -0.02575405f, 0.01568259f, -0.06465225f, -0.00244229f, -0.04499245f, -0.06316610f, 0.06203108f, 
    0.06285097f, -0.05006825f, -0.07079236f, -0.00038014f, 0.00573498f, 0.00764184f, -0.04664971f, -0.05769610f, 
    0.04544489f, -0.01674742f, -0.02728901f, 0.02502896f, 0.00494133f, -0.03932014f, -0.07884413f, 0.03949249f, 
    0.01772927f, 0.05794107f, 0.00832041f, 0.00366588f, -0.03577141f, -0.04490413f, 0.04613796f, 0.05568823f, 
    0.03278481f, 0.03592089f, 0.00425828f, -0.03563939f, 0.02520459f, 0.05495576f, -0.03482777f, -0.00235442f, 
    -0.05228655f, 0.02524937f, 0.05192233f, 0.01871878f, 0.00757742f, -0.00678078f, 0.00730737f, 0.00691688f, 
    0.22457206f, 0.10864346f, -0.04001598f, 0.00597714f, 0.04617382f, 0.06844371f, 0.09201469f, -0.08943514f, 
    -0.13128398f, 0.10598043f, -0.11083785f, -0.10253335f, -0.01840778f, 0.13236579f, -0.45968556f, -0.08457404f, 
    -0.05864261f, 0.10939641f, 0.03029794f, 0.01174274f, 0.02240070f, 0.16456451f, 0.03570836f, 0.12301076f, 
    0.28348953f, 0.00108509f, -0.05221881f, 0.36645418f, 0.04667776f, 0.14257348f, 0.16828011f, -0.00191060f, 
    0.28586656f, 0.03315819f, 0.18855093f, 0.25521317f, 0.06345000f, 0.10057575f, -0.19121021f, -0.16492338f, 
    0.08225156f, 0.18306892f, 0.09249755f, 0.02243030f, -0.10921390f, -0.09371477f, -0.12659948f, -0.18995354f, 
    -0.06843907f, 0.26446122f, 0.31873453f, 0.15979710f, -0.11201823f, -0.12817055f, -0.02880793f, 0.08791813f, 
    0.12577167f, 0.05883161f, 0.12443721f, 0.00321438f, 0.08986846f, 0.24898028f, -0.31390294f, -0.13385451f, 
    -0.00098359f, -0.05692369f, -0.03394974f, -0.01582744f, -0.05023827f, -0.05637947f, 0.07514106f, 0.01648396f, 
    -0.05922030f, -0.01554711f, 0.03198705f, 0.11036923f, 0.01602329f, -0.12028606f, -0.16001026f, -0.15778106f, 
    -0.12719479f, -0.21963176f, -0.07554936f, -0.19709928f, -0.31246015f, 0.04157197f, -0.22788353f, 0.05769871f, 
    -0.08432703f, -0.23727091f, -0.17253879f, 0.05575351f, -0.01812918f, -0.08076701f, -0.11902026f, 0.08495386f, 
    -0.16070822f, -0.10969427f, 0.01770213f, 0.00678491f, -0.00832157f, -0.01819471f, 0.04652081f, 0.28118110f, 
    -0.06048599f, 0.07178853f, -0.13972180f, -0.23294492f, 0.15493250f, 0.12834543f, -0.25887388f, -0.12218437f, 
    0.09810787f, 0.08810978f, 0.04867102f, -0.04249311f, -0.03177293f, 0.10387020f, -0.13276587f, 0.09242609f, 
    0.19101845f, 0.14339368f, -0.10174297f, -0.02351246f, 0.01630641f, 0.12504989f, 0.12596603f, 0.03338493f, 
    -0.11446104f, -0.07336310f, 0.14918165f, 0.15694098f, -0.33676156f, -0.05790099f, -0.13284418f, 0.06937923f, 
    -0.05676110f, -0.20771153f, -0.06135297f, 0.01008498f, -0.03298177f, 0.13558365f, -0.02131292f, 0.02544478f, 
    0.03462102f, -0.03231301f, 0.00816635f, -0.25785178f, 0.11628687f, 0.13508086f, 0.07809688f, 0.00077997f, 
    0.12955251f, -0.00592964f, 0.08381284f, 0.05954320f, 0.04962308f, 0.25504333f, 0.03673210f, -0.15521717f, 
    0.08237550f, 0.12549470f, 0.32999095f, -0.01957199f, -0.06104912f, -0.00375079f, 0.00388123f, 0.31889191f, 
    -0.01934368f, 0.13105458f, 0.04584567f, -0.26423699f, 0.10870670f, 0.13957836f, 0.02289498f, 0.15445957f, 
    0.02476970f, -0.03876569f, -0.04545370f, -0.20448144f, -0.07033903f, -0.27265635f, -0.00448205f, 0.00965846f, 
    -0.09157715f, -0.04159650f, -0.16116823f, -0.00769350f, 0.01673998f, 0.05636424f, 0.12099223f, 0.07748358f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.09993131f, -0.02912118f, 0.13775630f, 0.20102684f, 0.05203320f, 0.00951624f, -0.00721728f, 0.09841616f, 
    0.08577164f, 0.03098644f, -0.03617204f, -0.13538240f, 0.05825811f, 0.08769914f, 0.14074504f, 0.00748852f, 
    0.03540097f, 0.17551433f, 0.15591848f, -0.05869843f, 0.12122771f, 0.15146823f, 0.04630171f, 0.06578463f, 
    -0.03521895f, -0.02080492f, -0.06183590f, -0.13133983f, 0.08323520f, 0.09754403f, 0.13176462f, -0.07241784f, 
    -0.06565676f, 0.17379582f, 0.01881984f, 0.10481928f, -0.09166528f, 0.02417031f, 0.18491425f, 0.17330545f, 
    0.06302513f, -0.01882618f, -0.13175906f, 0.05224935f, -0.03614007f, 0.21263482f, 0.28072312f, 0.10825139f, 
    0.10682469f, 0.20874473f, 0.02163450f, 0.09587140f, -0.09065680f, 0.06053703f, 0.00258033f, 0.13104640f, 
    -0.12548207f, -0.14482133f, -0.04240414f, 0.10989671f, -0.05773260f, 0.17263566f, -0.04756493f, 0.07019807f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.18462877f, -0.09728022f, 0.13863708f, 0.15165375f, 0.31920362f, -0.04534997f, 0.04547863f, -0.05381246f, 
    0.13054334f, 0.05639700f, -0.12364890f, -0.04583042f, -0.05978756f, 0.01393110f, 0.13189942f, -0.15155385f, 
    0.24795561f, -0.32026500f, 0.31050253f, -0.10436090f, -0.18464908f, -0.20911306f, 0.07117749f, -0.00845602f, 
    -0.27420822f, -0.03754519f, 0.04821305f, -0.14499684f, 0.14034261f, 0.29469660f, -0.09484531f, 0.09373797f, 
    -0.10142760f, -0.02011246f, -0.06525376f, 0.13863787f, 0.13029431f, -0.06461258f, 0.38158312f, 0.04464510f, 
    0.01583382f, -0.12090518f, -0.02372177f, 0.45221394f, 0.26549816f, -0.05912285f, -0.29769886f, -0.13389228f, 
    0.09897327f, 0.12631743f, 0.06436360f, 0.09356074f, 0.00316074f, 0.37150636f, 0.06756436f, 0.08244846f, 
    0.23906928f, 0.17663597f, 0.16928479f, 0.01976681f, 0.09526280f, 0.09545664f, -0.03718647f, 0.36780229f, 
    0.35164830f, -0.00747675f, 0.15733431f, -0.07565153f, -0.06016337f, -0.10863699f, -0.03112526f, 0.40290645f, 
    0.05099472f, -0.00081968f, -0.13136412f, -0.19045666f, 0.00370948f, 0.06427461f, 0.30315524f, -0.00471584f, 
    0.06843400f, 0.10743099f, -0.01343324f, -0.00385001f, 0.02779278f, -0.05200715f, -0.04906715f, 0.00741162f, 
    -0.09954456f, -0.02703789f, -0.08228780f, 0.08026038f, -0.08245946f, -0.13846776f, -0.15809709f, -0.03869328f, 
    0.08186718f, 0.04690124f, -0.21524790f, 0.22053061f, -0.06816773f, 0.14282519f, 0.13430129f, 0.02441702f, 
    0.13306038f, -0.19361889f, -0.25789982f, 0.02633777f, -0.14269972f, -0.04716958f, 0.14953245f, -0.02086097f, 
    -0.24339779f, 0.26450792f, -0.00044268f, 0.19846456f, 0.32702112f, 0.16640784f, 0.19711824f, -0.01732480f, 
    0.02131952f, -0.48468783f, 0.07044714f, -0.00351416f, -0.06905682f, 0.04112911f, 0.02322068f, 0.39853466f, 
    -0.12375666f, -0.04431550f, -0.23327197f, -0.02796128f, -0.05789502f, -0.18610340f, 0.08578585f, 0.19564186f, 
    -0.19752108f, 0.11722139f, 0.17257173f, 0.18644257f, 0.05757744f, 0.11918133f, -0.40034366f, -0.01313913f, 
    -0.00269898f, -0.11552551f, -0.10002284f, 0.05605730f, 0.06566568f, -0.15988155f, -0.28350553f, -0.29513824f, 
    0.22026905f, 0.02177589f, 0.27664155f, 0.05011316f, -0.17005531f, 0.23527810f, 0.06093537f, 0.10673684f, 
    0.08966154f, 0.17369018f, 0.03988914f, -0.13773236f, 0.03696200f, 0.42070201f, 0.06809561f, 0.14958358f, 
    -0.25438341f, 0.03846595f, -0.03266500f, 0.17704068f, 0.00258811f, -0.20070823f, -0.13558812f, -0.26318714f, 
    -0.16915630f, 0.11645345f, 0.07732040f, 0.41770113f, 0.33401006f, 0.04986159f, 0.04603430f, -0.32010984f, 
    0.11048050f, 0.26706639f, 0.18748355f, -0.19448955f, -0.15849979f, 0.33355039f, -0.08198456f, -0.10619067f, 
    0.00323543f, 0.07055505f, -0.04336018f, -0.18619525f, 0.03548612f, -0.03636600f, -0.00058794f, -0.00948385f, 
    -0.00011558f, -0.00088082f, -0.03860182f, -0.09092514f, -0.10240655f, 0.02352802f, -0.06411499f, 0.10841244f, 
    -0.09328904f, -0.05300675f, 0.02175318f, 0.04184875f, 0.01638464f, 0.01255618f, -0.07823778f, -0.07169598f, 
    0.03598828f, -0.03385271f, -0.00846747f, -0.14472960f, 0.02040794f, -0.12414186f, -0.00160306f, 0.06820180f, 
    -0.10577437f, -0.04292554f, -0.06603400f, -0.12846752f, 0.07518635f, -0.12286898f, 0.06537197f, 0.13272040f, 
    0.00347400f, 0.08787397f, 0.00215129f, 0.03511247f, -0.10193432f, -0.11269759f, 0.01636436f, 0.12287122f, 
    -0.10662027f, 0.03886452f, 0.12483528f, -0.02276968f, -0.08900815f, -0.11615223f, -0.05741142f, -0.03643798f, 
    -0.11021171f, 0.10089421f, -0.03816504f, -0.06691280f, 0.08033051f, 0.07597565f, 0.03718911f, -0.04491005f, 
    0.21971287f, 0.00944033f, 0.15729216f, 0.03212633f, -0.02965354f, 0.26602566f, -0.12195209f, 0.11970312f, 
    0.03894519f, -0.00164179f, -0.03690831f, -0.43122855f, -0.02773548f, -0.16890034f, 0.49680644f, -0.24001221f, 
    -0.35794950f, 0.26674464f, 0.10835920f, 0.06547849f, -0.23793863f, 0.00490779f, 0.02995530f, 0.08890321f, 
    -0.27804592f, -0.07713518f, -0.29228228f, -0.07484026f, 0.07415027f, -0.45614582f, -0.07433576f, 0.04246810f, 
    0.02905735f, 0.01087566f, 0.17283204f, 0.03389342f, -0.12175579f, -0.08954828f, -0.07528120f, -0.31720778f, 
    0.13121924f, 0.12023495f, -0.19459666f, 0.01455400f, -0.55906856f, 0.11225914f, 0.08446165f, -0.29839021f, 
    0.07044615f, 0.18794757f, -0.02580072f, -0.22768958f, 0.45059860f, 0.24379797f, 0.14413579f, 0.24310407f, 
    -0.26897928f, -0.17535597f, 0.06281421f, 0.04604099f, -0.07192464f, -0.51056719f, 0.05458292f, -0.15622562f, 
    0.03353751f, -0.06877226f, -0.12078483f, -0.11901127f, -0.22959021f, 0.40262258f, -0.05290507f, 0.01133741f, 
    0.17774984f, 0.25309169f, -0.16735335f, -0.08756862f, 0.00964256f, 0.28770685f, 0.07797192f, -0.14022586f, 
    -0.12799984f, 0.34476608f, 0.15849280f, 0.05390853f, 0.00746824f, 0.16633239f, -0.02386015f, -0.05912697f, 
    0.02515067f, -0.06589135f, 0.12132736f, -0.00260027f, 0.15777603f, -0.12918656f, 0.12813108f, -0.08171293f, 
    -0.09934662f, 0.23064002f, 0.06195770f, -0.05149237f, -0.08132702f, -0.08450013f, -0.11902165f, 0.13141255f, 
    0.19057979f, 0.35509175f, -0.09296642f, -0.46310678f, 0.11350673f, 0.22249570f, 0.42208323f, -0.03642590f, 
    0.16356130f, 0.03673111f, -0.04832883f, -0.20770644f, -0.23425736f, -0.14556977f, 0.12144306f, 0.03615655f, 
    -0.11486211f, -0.08493456f, -0.27263415f, -0.03816262f, 0.25516826f, 0.02233831f, 0.10164918f, 0.07266872f, 
    -0.11215395f, 0.09530839f, 0.03529660f, 0.09458060f, 0.10784809f, -0.01143908f, 0.06291775f, -0.10261080f, 
    0.11450655f, 0.07578837f, 0.04080656f, 0.01344266f, -0.00073166f, -0.05187827f, 0.01712018f, 0.04679686f, 
    0.01093441f, 0.01154137f, -0.09199309f, -0.07577883f, 0.04329738f, 0.03217442f, -0.06154022f, -0.06992330f, 
    -0.06447343f, 0.08163899f, 0.01090951f, -0.01729239f, 0.06290302f, -0.06997120f, -0.09280708f, -0.12225466f, 
    0.01148264f, -0.07335483f, -0.05760910f, 0.06179170f, -0.03423579f, -0.10539605f, 0.07501008f, 0.04770050f, 
    -0.10881999f, -0.04311202f, -0.13757917f, 0.06389405f, 0.05522715f, -0.05125546f, 0.09026501f, 0.05085982f, 
    -0.10049104f, 0.04189371f, 0.05027141f, -0.11455252f, -0.02945725f, 0.05164597f, 0.11117629f, -0.12293968f, 
    -0.07586512f, -0.01719046f, -0.13519821f, -0.11627032f, -0.00739171f, -0.07596727f, 0.05321845f, -0.11862050f, 
    -0.04374821f, 0.02984244f, 0.04121652f, -0.02984679f, -0.00457832f, -0.00497680f, -0.11662318f, -0.02895116f, 
    -0.13002914f, -0.04587619f, 0.05551371f, -0.15948747f, 0.03182085f, -0.04671495f, 0.08474004f, -0.09794031f, 
    -0.13037547f, -0.07303040f, -0.02069125f, -0.04071561f, -0.04868362f, -0.19987372f, -0.10869084f, -0.02626264f, 
    -0.03133406f, 0.01718744f, 0.02121044f, 0.01792487f, 0.04769088f, -0.01956553f, 0.01205717f, -0.03249130f, 
    0.11432269f, 0.01714770f, -0.03362745f, -0.01100431f, 0.05867138f, 0.06556672f, -0.11383158f, 0.01295481f, 
    -0.13485037f, -0.08806130f, -0.01211684f, 0.02710966f, 0.04667073f, -0.01474672f, -0.05843625f, -0.06139086f, 
    -0.09559558f, 0.03787120f, 0.10196450f, -0.05506613f, 0.06979399f, 0.07187511f, -0.12675464f, -0.02122314f, 
    -0.15140617f, -0.11029612f, -0.10811656f, -0.08641092f, -0.12405282f, -0.08087416f, -0.01896775f, 0.04652611f, 
    -0.19359368f, 0.09946953f, 0.05587452f, -0.24229392f, 0.25655821f, 0.28831559f, -0.01198013f, -0.25111267f, 
    0.17780060f, 0.12100767f, -0.18601425f, -0.22353552f, -0.07720269f, -0.05937577f, -0.06371559f, 0.04187386f, 
    0.10043655f, -0.01659101f, 0.29400235f, -0.03911250f, 0.04314999f, -0.03321118f, 0.23263550f, -0.11938279f, 
    -0.29333991f, -0.03833329f, -0.09045591f, -0.05347561f, -0.28428674f, 0.07157364f, 0.08218278f, 0.05403439f, 
    0.04877109f, -0.05695948f, 0.10492679f, -0.02107833f, 0.15317291f, -0.10057689f, 0.22559242f, 0.20873055f, 
    0.10050829f, 0.11284190f, -0.03469893f, 0.10358429f, 0.01693633f, 0.25629479f, 0.03257890f, -0.06146382f, 
    0.13573335f, -0.06924068f, 0.02072181f, -0.13055950f, -0.03169030f, 0.18641031f, 0.03373458f, -0.07005984f, 
    0.08803484f, -0.02716386f, 0.07556874f, -0.18263277f, 0.27339223f, -0.05194303f, -0.12649612f, 0.39789429f, 
    -0.16669674f, 0.08629997f, -0.01042771f, -0.14394411f, -0.02372167f, 0.11658251f, 0.06108967f, -0.13334028f, 
    0.15225033f, 0.01860072f, -0.12659845f, -0.07416856f, -0.14284813f, 0.02570195f, -0.12803078f, -0.08994112f, 
    0.20890395f, -0.07039323f, 0.22474532f, -0.04597121f, -0.00012036f, 0.00927316f, 0.09659953f, 0.04389879f, 
    -0.28800100f, 0.02602408f, -0.01570122f, -0.03938095f, -0.24434343f, 0.31802508f, 0.15023708f, -0.01399814f, 
    -0.11827476f, 0.06751175f, 0.04932874f, 0.17748143f, 0.30495209f, -0.11997350f, 0.38912380f, 0.06206452f, 
    0.15152501f, 0.18436387f, -0.27385455f, 0.30124852f, -0.02017027f, 0.21243821f, -0.01259731f, 0.10163853f, 
    0.18756095f, 0.08506453f, 0.03736453f, -0.03754815f, -0.32053149f, -0.00887916f, -0.06077977f, 0.06206498f, 
    0.05989442f, -0.32415187f, 0.16527285f, 0.16032808f, -0.01665956f, -0.07806274f, 0.03176942f, 0.10761295f, 
    0.02397068f, 0.05841540f, 0.15073103f, -0.01874855f, 0.22397652f, 0.05675234f, 0.11652948f, -0.10986464f, 
    0.20764130f, 0.22624160f, -0.18692550f, -0.19066234f, -0.17438751f, 0.07179440f, 0.05443477f, -0.08239272f, 
    0.10544758f, 0.24023263f, 0.05860430f, -0.04725423f, 0.01761567f, -0.23922001f, 0.01627201f, 0.14301082f, 
    -0.09186672f, -0.07904280f, -0.22605340f, 0.18365914f, -0.08418861f, -0.14636816f, -0.11847136f, 0.09900089f, 
    0.01938262f, 0.06328120f, -0.24029279f, 0.17929770f, -0.17268354f, -0.23767860f, 0.12744218f, 0.16770746f, 
    0.10872048f, -0.03926025f, -0.24794589f, -0.12620951f, -0.31317651f, 0.08410320f, 0.11912347f, -0.00049194f, 
    -0.04921552f, 0.08000918f, 0.03339075f, -0.03775321f, 0.21730909f, -0.05170031f, 0.31057629f, -0.03273451f, 
    0.08708582f, -0.20063972f, -0.05569233f, -0.08893000f, 0.45189956f, -0.00238193f, 0.04836281f, 0.37381938f, 
    0.24594563f, -0.10337378f, -0.03618253f, -0.08015513f, 0.22367401f, -0.03805156f, 0.00541920f, 0.36228609f, 
    -0.03083444f, 0.13647167f, 0.20496953f, 0.01137802f, 0.02949998f, -0.01748690f, 0.14167684f, 0.01704146f, 
    0.07862758f, -0.07967906f, -0.27817047f, -0.05346921f, -0.07018990f, -0.15652640f, -0.08369819f, 0.22981440f, 
    0.11536491f, 0.10763606f, -0.02298792f, -0.07613019f, 0.26035786f, -0.19494174f, 0.06668346f, 0.08356363f, 
    0.08647919f, 0.14666080f, 0.03226116f, -0.02491194f, -0.11375489f, 0.00767074f, -0.08689290f, -0.07094210f, 
    0.01639876f, -0.05867726f, 0.15041387f, 0.08676753f, -0.26666123f, -0.32413059f, -0.17766570f, 0.12009515f, 
    0.10738037f, 0.21190034f, 0.08529754f, 0.16433507f, 0.37601870f, 0.08097842f, -0.00547505f, -0.00439579f, 
    -0.00069506f, 0.19628112f, 0.20680772f, 0.22768687f, 0.06033107f, 0.20959778f, 0.00660703f, -0.11965130f, 
    0.18903244f, -0.03730654f, 0.11677547f, 0.11806139f, 0.09178805f, -0.29425260f, -0.08786628f, 0.19235370f, 
    0.03057315f, -0.00144179f, 0.27373987f, -0.09499574f, 0.30497602f, -0.19530948f, 0.14266951f, 0.02559723f, 
    0.03308319f, -0.01200673f, 0.08847667f, -0.00636581f, 0.09015021f, 0.16881789f, 0.19301440f, -0.05129424f, 
    0.09157189f, -0.09542861f, 0.11720999f, 0.05626449f, 0.01792945f, -0.05668477f, -0.01361863f, 0.05234214f, 
    -0.05147111f, -0.08290514f, 0.05631947f, 0.21068609f, 0.07058819f, -0.02113898f, 0.14306439f, -0.02861573f, 
    0.04029141f, -0.18308564f, 0.02372874f, -0.00322606f, -0.32816538f, 0.12841372f, 0.10155985f, 0.36442935f, 
    -0.16000704f, -0.02823585f, 0.01413167f, 0.05235938f, 0.40458861f, 0.14482513f, -0.19986235f, 0.00254844f, 
    0.05371515f, -0.04729117f, 0.11278623f, 0.08688024f, -0.23232850f, 0.13804144f, 0.09329647f, 0.04559899f, 
    -0.14606890f, -0.09637859f, -0.08306730f, -0.08707547f, -0.03169128f, 0.26034185f, 0.02122186f, -0.13323113f, 
    0.15071833f, 0.16333182f, 0.06544551f, -0.14192355f, -0.19272768f, 0.04711295f, 0.05695027f, 0.04516178f, 
    -0.20923951f, 0.18750711f, 0.04562493f, 0.00707285f, -0.01237686f, 0.13548645f, -0.08211824f, 0.00216538f, 
    -0.25031155f, -0.05393657f, -0.03671023f, 0.02665890f, -0.12093477f, 0.06090328f, 0.19345595f, -0.10614730f, 
    -0.05231573f, 0.14353916f, 0.23800324f, 0.11839579f, 0.09026518f, 0.02857583f, -0.21284811f, -0.12342069f, 
    0.14386094f, 0.27185476f, -0.38241372f, -0.10616850f, 0.12576878f, 0.00723018f, 0.12147678f, 0.02393142f, 
    0.34660500f, -0.08660965f, 0.07833149f, -0.26446420f, -0.02733564f, 0.11735595f, 0.08881328f, 0.27250940f, 
    -0.02897427f, 0.12989371f, -0.18318334f, -0.03363663f, 0.08244607f, -0.13187142f, -0.08521552f, -0.05260463f, 
    -0.00203170f, 0.01305272f, 0.15027098f, -0.16075024f, -0.05515264f, -0.03350256f, -0.12074937f, 0.18083404f, 
    -0.19756354f, 0.02570918f, -0.08023826f, -0.03197373f, -0.00639805f, 0.02276821f, -0.08738657f, -0.03365194f, 
    -0.03687751f, 0.00962484f, -0.05905474f, 0.11406094f, -0.12318321f, -0.01403125f, 0.08043142f, -0.16660541f, 
    -0.07241667f, -0.02145197f, 0.02168049f, 0.09756471f, 0.00068977f, -0.09267969f, 0.02968397f, 0.10952322f, 
    0.08541425f, -0.08093339f, 0.01054094f, -0.08853921f, 0.06565250f, 0.05186464f, -0.01477427f, -0.21260497f, 
    0.09815998f, -0.07682088f, -0.12514567f, -0.10531072f, -0.04544348f, 0.01243745f, 0.10205697f, -0.02162421f, 
    0.02834477f, -0.02407225f, 0.03835933f, -0.19733831f, -0.17583133f, -0.07292358f, -0.12632500f, 0.13558465f, 
    0.03834596f, 0.07798120f, -0.16380651f, -0.21160415f, 0.04462791f, 0.08412376f, 0.10740805f, -0.26084679f, 
    -0.13546586f, -0.00616225f, -0.06509465f, 0.09932696f, 0.12624413f, 0.23993483f, -0.02583233f, 0.21259052f, 
    0.12475477f, 0.04109905f, -0.27125680f, -0.06045735f, -0.23090005f, 0.04739305f, 0.17850487f, -0.20810150f, 
    0.11995134f, 0.00376701f, -0.16361746f, 0.01309454f, -0.28437492f, -0.19566850f, -0.10707119f, 0.16873837f, 
    0.07375708f, -0.12729146f, -0.07219106f, 0.08766536f, -0.01881098f, -0.00952115f, -0.06090543f, 0.06161835f, 
    0.00090487f, 0.12425733f, -0.03312432f, 0.18271245f, 0.02119529f, 0.06470650f, 0.13075365f, 0.01471430f, 
    0.10732593f, 0.21727785f, 0.13612632f, 0.06314639f, -0.00808954f, -0.00147432f, -0.15606132f, -0.27814797f, 
    0.09527059f, -0.19321574f, 0.04840849f, 0.05832043f, 0.14160223f, 0.24787998f, 0.17969994f, -0.08695300f, 
    -0.01547228f, 0.14092010f, -0.02230096f, 0.14662850f, 0.13532871f, 0.09217953f, 0.10734075f, 0.06376921f, 
    0.11634166f, -0.11763866f, 0.09116124f, 0.07830474f, 0.11370194f, 0.03114681f, -0.04229842f, -0.09423270f, 
    -0.08937863f, -0.06496590f, 0.03561888f, -0.03921531f, -0.05523890f, 0.24028212f, 0.24950531f, -0.17533447f, 
    0.24847120f, -0.32882199f, -0.12448196f, 0.07461570f, -0.04679311f, 0.15064228f, -0.17980441f, 0.04958788f, 
    0.05331346f, 0.01365119f, 0.32459909f, 0.20497338f, 0.18591677f, 0.19810516f, -0.18767217f, -0.00106818f, 
    -0.05189691f, 0.08244786f, -0.21019737f, 0.11399319f, 0.12573913f, -0.05140951f, 0.28111085f, 0.00586987f, 
    0.05390833f, -0.16330567f, 0.02804032f, -0.25126612f, 0.06276489f, 0.18894646f, 0.08935253f, 0.01556593f, 
    -0.01550282f, 0.14521439f, -0.07101312f, 0.06782924f, 0.20761253f, 0.21322085f, -0.04646838f, 0.14170890f, 
    0.12799434f, 0.20466854f, -0.03794877f, 0.00906728f, 0.06543978f, 0.12236264f, 0.00418856f, 0.39556810f, 
    0.24033409f, -0.10576690f, 0.13441879f, 0.18833187f, -0.26111540f, -0.19311410f, -0.04418281f, 0.16416720f, 
    0.08572286f, -0.06982531f, 0.03837645f, -0.06611730f, 0.08157621f, 0.12897193f, 0.13570309f, 0.10455748f, 
    -0.07209317f, 0.07737859f, 0.22008881f, -0.01667483f, -0.03385273f, -0.16182639f, 0.02144774f, 0.09524103f, 
    0.08354029f, -0.09910376f, 0.16310553f, -0.23125198f, 0.07376987f, -0.12991589f, -0.27355406f, 0.06048688f, 
    -0.13061933f, 0.12866633f, -0.09753627f, 0.05265250f, -0.10877939f, 0.10400255f, 0.18161808f, -0.02717545f, 
    -0.07586551f, -0.26314908f, 0.06302527f, 0.23260202f, -0.15405139f, -0.15439910f, 0.20044526f, -0.13522412f, 
    -0.17081282f, 0.21422486f, 0.09857614f, 0.26330543f, 0.47503680f, -0.06749666f, 0.01981372f, -0.05005182f, 
    0.02086164f, -0.20108013f, 0.10732279f, 0.12640019f, -0.13742147f, 0.14221194f, -0.06684851f, 0.27854893f, 
    0.08243962f, -0.08653355f, 0.25996032f, -0.23884892f, -0.18730168f, 0.16705796f, -0.10466567f, 0.24716446f, 
    -0.06490251f, 0.12348471f, 0.19544117f, 0.00382864f, 0.37577668f, 0.03306254f, 0.03702188f, 0.33047393f, 
    -0.15532762f, 0.49585116f, 0.01768391f, -0.09739782f, 0.56449276f, 0.09278361f, 0.14028245f, 0.07474738f, 
    0.16174933f, 0.07338119f, -0.04278680f, 0.01138956f, -0.15797897f, 0.16321690f, 0.20435832f, -0.05920969f, 
    0.06983474f, 0.14921048f, 0.24316034f, 0.08540339f, -0.10533637f, -0.07456782f, 0.08125963f, 0.08610412f, 
    0.06308103f, -0.02990415f, 0.04948733f, -0.30353487f, -0.01568221f, 0.20594765f, 0.37297091f, -0.07459110f, 
    -0.20451339f, 0.14192270f, -0.00770644f, 0.17965899f, -0.23307535f, -0.11207405f, -0.15036790f, -0.02851012f, 
    0.03450845f, -0.09887508f, -0.08425666f, 0.03341968f, -0.29995590f, 0.09849081f, 0.04712887f, -0.06815289f, 
    0.07982022f, 0.08732244f, 0.00473130f, 0.01945845f, 0.10503671f, 0.13019900f, 0.03047401f, -0.07375478f, 
    0.05747311f, 0.27138692f, -0.11113922f, -0.15818866f, -0.19481339f, -0.09376075f, -0.19296521f, 0.09941411f, 
    0.01805823f, 0.38079631f, -0.24276651f, -0.03863365f, 0.21887355f, 0.10670823f, 0.09642035f, 0.15523495f, 
    0.04033545f, -0.05458557f, -0.14973718f, 0.24772003f, 0.03903355f, 0.08668647f, 0.26646248f, 0.09347823f, 
    -0.09263060f, 0.12670255f, 0.26316407f, -0.12954007f, 0.09389756f, -0.07272630f, -0.20646665f, 0.18242228f, 
    0.21067676f, 0.12586276f, -0.02226803f, -0.24686047f, -0.12302629f, 0.21764460f, 0.16993278f, 0.07081383f, 
    0.18041235f, -0.12347196f, 0.02995831f, -0.25270486f, -0.37529242f, -0.06748302f, 0.20389737f, -0.04596518f, 
    -0.23709266f, -0.22180036f, -0.15986794f, -0.04404182f, 0.16822703f, -0.04346285f, 0.07365099f, -0.21475229f, 
    0.10536265f, 0.10846974f, 0.11363747f, 0.02102371f, 0.12181967f, -0.29610991f, 0.12718707f, 0.05586362f, 
    -0.11018810f, -0.16263774f, 0.13462907f, 0.16931905f, 0.32810369f, -0.16261877f, 0.21469945f, 0.18900712f, 
    0.10991403f, -0.11246917f, -0.05204346f, 0.09565237f, 0.11817387f, 0.21805860f, 0.05252237f, 0.07204174f, 
    -0.04977967f, 0.10271011f, 0.29144347f, -0.08371317f, 0.27708936f, 0.10744345f, 0.13513018f, -0.01069866f, 
    0.00170845f, 0.01756285f, 0.03686350f, -0.01514947f, 0.26262853f, 0.24695893f, 0.20423661f, -0.11356337f, 
    -0.00957812f, -0.19531292f, -0.11572710f, 0.46696573f, -0.16691139f, -0.08682407f, -0.12766325f, 0.20727699f, 
    -0.02164268f, 0.32675290f, -0.06435110f, 0.26156753f, 0.38877881f, 0.11464729f, -0.30277216f, -0.07671416f, 
    0.07522853f, 0.11455674f, 0.36144596f, 0.09135404f, -0.35432073f, 0.14542915f, -0.07127000f, -0.12115372f, 
    0.22887398f, 0.07916759f, -0.04686770f, -0.12886868f, 0.03766261f, -0.08792548f, 0.02095644f, 0.11028119f, 
    -0.17002295f, -0.03885426f, 0.26549137f, -0.04923955f, 0.15900646f, -0.05052194f, 0.12006830f, 0.14843360f, 
    0.12446880f, -0.04291321f, -0.39971182f, 0.04351304f, -0.01259115f, 0.05415807f, -0.16023742f, -0.22502433f, 
    0.15712413f, 0.02321345f, 0.07739316f, 0.16025767f, -0.08482201f, 0.11651190f, 0.18411188f, 0.08823791f, 
    0.07913636f, 0.22174999f, 0.04145907f, -0.18464594f, 0.10171367f, 0.08597445f, -0.19389823f, 0.05509575f, 
    -0.27234125f, -0.32530749f, -0.00076894f, -0.17600107f, -0.01678525f, 0.15135781f, 0.07254976f, 0.26232734f, 
    -0.22281109f, 0.01941366f, 0.10233273f, 0.05289280f, 0.22799064f, 0.06695236f, -0.02190009f, -0.23056260f, 
    -0.07978096f, 0.20484482f, 0.20449007f, 0.09172662f, -0.25039423f, 0.24348448f, -0.02616225f, -0.14425866f, 
    -0.16735268f, -0.08293945f, 0.10111000f, -0.05002054f, -0.31568593f, -0.04204881f, 0.08359694f, -0.14615980f, 
    -0.04541397f, -0.29260650f, -0.08717688f, 0.01290544f, -0.39957729f, -0.11468972f, -0.10880889f, -0.32596895f, 
    0.11662384f, -0.12056828f, -0.22837164f, 0.07927127f, 0.01929338f, -0.06874614f, 0.14197648f, -0.17517249f, 
    0.06287392f, 0.08583854f, 0.07490353f, 0.06416332f, -0.21841356f, -0.14036484f, 0.02257384f, -0.00541627f, 
    0.04103102f, -0.21294639f, 0.03208843f, 0.04093820f, -0.11559140f, -0.28722793f, -0.07094831f, -0.01848517f, 
    -0.16967061f, 0.00000187f, 0.12121603f, -0.23107502f, -0.05764733f, -0.40717351f, 0.06107876f, 0.09018674f, 
    0.11490653f, -0.10359909f, -0.03550671f, -0.04216604f, -0.09351932f, -0.07827968f, -0.12689261f, -0.18648778f, 
    0.01351966f, -0.01017680f, -0.12142883f, -0.15825723f, 0.19827215f, -0.00057178f, 0.09559323f, 0.00979302f, 
    -0.04301578f, -0.05087427f, 0.01981561f, 0.07394666f, -0.30239692f, 0.12131180f, 0.07036196f, 0.16548941f, 
    0.07334921f, 0.14172807f, -0.22665702f, -0.11712171f, 0.13334116f, 0.21108975f, -0.01483775f, -0.12666561f, 
    0.00571980f, 0.17289411f, 0.03877639f, -0.03547164f, 0.23445684f, -0.15375747f, -0.07743350f, 0.09789030f, 
    -0.10253563f, -0.06734431f, 0.08521955f, 0.05352900f, -0.27681065f, 0.01124008f, 0.10116510f, 0.09003939f, 
    0.08747566f, -0.03425788f, 0.06117896f, 0.16639347f, -0.11501759f, 0.15812767f, 0.28652257f, 0.14441165f, 
    0.11210373f, 0.23672469f, -0.23248522f, 0.05702748f, 0.11389445f, 0.12299865f, 0.13223207f, -0.31944212f, 
    -0.01478284f, 0.23644444f, 0.06934753f, 0.24632268f, -0.10962358f, -0.08066672f, 0.24640588f, 0.19583075f, 
    -0.03315552f, -0.61290061f, -0.13800284f, -0.09219679f, -0.05514455f, 0.18290815f, 0.01211082f, 0.00894474f, 
    -0.02794166f, 0.10036632f, 0.10046814f, -0.07681953f, -0.11868883f, 0.09239949f, 0.08892809f, -0.23157406f, 
    0.04000900f, 0.14008194f, -0.05253806f, -0.18346524f, -0.21305001f, 0.09371162f, -0.19128411f, -0.15437862f, 
    0.12420896f, 0.25822777f, 0.06937719f, 0.11505006f, 0.17327513f, -0.08447932f, -0.00728720f, 0.03402811f, 
    -0.24097534f, 0.08296169f, -0.32856056f, -0.03513467f, -0.43645543f, 0.01309429f, 0.19215423f, 0.06784391f, 
    -0.11288783f, 0.02076646f, -0.15868090f, 0.21998467f, -0.10569558f, -0.06663833f, 0.12196325f, 0.15835238f, 
    0.10868995f, -0.03226063f, -0.18621831f, -0.18527399f, -0.37658083f, 0.24533978f, 0.37986574f, -0.20750016f, 
    0.14530346f, -0.08368172f, -0.11273293f, 0.17296311f, 0.04434491f, -0.02600151f, 0.24856147f, 0.06542941f, 
    0.04261873f, -0.57145715f, -0.08180030f, 0.04583243f, 0.28298131f, -0.09443436f, 0.05655235f, 0.30515632f, 
    -0.08443975f, 0.08752356f, -0.00241997f, 0.02293735f, 0.13171041f, -0.10766508f, 0.09365074f, 0.14468998f, 
    -0.21092576f, 0.05516582f, 0.17118809f, 0.16977869f, 0.05828872f, 0.20515446f, -0.29466355f, 0.19702840f, 
    0.27213210f, -0.00090721f, -0.03415046f, 0.01877454f, 0.13955985f, 0.10430238f, -0.25412115f, -0.21487790f, 
    0.15863615f, 0.02394088f, 0.41537899f, -0.04721886f, -0.16638556f, 0.37805930f, 0.23376369f, 0.11212690f, 
    -0.08375024f, 0.24936374f, 0.17867970f, 0.11002113f, -0.04791158f, 0.19182919f, 0.04182138f, 0.05551712f, 
    -0.03713129f, 0.00156361f, -0.04126061f, 0.10801140f, 0.06333351f, -0.06665832f, -0.02187691f, 0.03134502f, 
    -0.13643537f, 0.18020438f, -0.06543737f, 0.23133536f, 0.16692302f, -0.02798947f, -0.18870346f, 0.04565291f, 
    0.09214129f, -0.08218458f, 0.03879619f, 0.04269288f, -0.25196683f, 0.59194094f, -0.04929710f, -0.26332021f, 
    0.38862422f, -0.09748481f, 0.21771839f, 0.17068541f, -0.14950423f, -0.12462890f, -0.07498399f, -0.10486969f, 
    -0.02855740f, -0.11432145f, 0.12247997f, 0.11202382f, 0.13087362f, -0.18404193f, -0.03254201f, -0.04464148f, 
    0.03831316f, 0.21280022f, -0.30638617f, -0.03539170f, -0.12724213f, -0.02344814f, 0.21108086f, 0.03274154f, 
    0.04089225f, -0.11048747f, -0.04136764f, -0.14987163f, -0.26122522f, -0.06189449f, 0.09520465f, -0.00574979f, 
    -0.00256636f, 0.09698008f, 0.24391107f, 0.20032051f, 0.19558458f, 0.19519424f, 0.20080714f, -0.01846181f, 
    -0.11012952f, 0.01931286f, -0.08241612f, 0.03342574f, -0.34490231f, 0.04814944f, 0.14100227f, 0.24545026f, 
    0.05314921f, 0.15546454f, -0.11911790f, 0.21081601f, 0.37464431f, -0.04660352f, 0.08181401f, 0.08380638f, 
    -0.15964194f, -0.34376395f, 0.22538693f, 0.30844611f, -0.18679519f, 0.01377758f, 0.07169844f, -0.18531615f, 
    0.32875836f, 0.02798452f, 0.05423469f, 0.17326078f, -0.31590319f, -0.04452574f, 0.12119903f, 0.14670762f, 
    0.00199353f, 0.06416740f, -0.04826234f, 0.14151677f, 0.35488400f, 0.03087090f, -0.05126430f, 0.21290587f, 
    0.01709498f, 0.07563367f, 0.21649110f, -0.09437800f, -0.08780509f, -0.14218062f, -0.03868565f, -0.00345781f, 
    0.10726883f, 0.04847372f, -0.11829589f, -0.16295916f, 0.21138847f, -0.08441415f, -0.04623529f, -0.03461847f, 
    -0.12761149f, 0.18731283f, -0.21879998f, -0.05005715f, -0.15562968f, 0.23358251f, 0.29289520f, 0.16014983f, 
    -0.07114842f, -0.23315568f, -0.39754653f, 0.17825773f, -0.02790623f, 0.17582497f, 0.17050658f, -0.20885865f, 
    -0.08142952f, 0.29738548f, 0.02916546f, 0.38446733f, -0.00413559f, -0.09075983f, 0.03114528f, -0.08371467f, 
    -0.14027843f, -0.46798226f, -0.05850454f, 0.00864998f, -0.08769556f, -0.02920415f, -0.04633493f, 0.28205028f, 
    -0.11180285f, -0.00271430f, -0.32811514f, -0.14122663f, -0.01550639f, 0.17498708f, -0.00218331f, -0.09080419f, 
    -0.05270023f, 0.15461694f, 0.02437436f, 0.15997656f, 0.17342322f, 0.21094044f, -0.12887672f, 0.16590738f, 
    -0.07590511f, -0.03265236f, 0.41888681f, -0.01318136f, 0.02549004f, -0.10600096f, -0.34033781f, 0.07239365f, 
    0.16054264f, -0.01210402f, 0.02152552f, 0.17443031f, 0.33840913f, -0.01806054f, -0.03899526f, -0.02468187f, 
    0.03668498f, 0.07990379f, -0.03223085f, -0.26421082f, 0.15034179f, 0.22912194f, -0.23444197f, 0.21522689f, 
    -0.23441830f, 0.32007059f, 0.10630849f, 0.23300220f, 0.29552263f, 0.06545817f, -0.06964225f, -0.37002164f, 
    0.10656694f, -0.04154970f, -0.05903095f, -0.05498118f, 0.18506005f, -0.05518224f, 0.10356473f, -0.29515669f, 
    0.06535497f, 0.66990882f, 0.14221728f, -0.16076814f, 0.35206312f, -0.26055744f, -0.09547248f, -0.17652461f, 
    0.14558007f, -0.09418887f, -0.24926637f, 0.02017022f, -0.32409510f, -0.04758348f, 0.10971939f, -0.01629426f, 
    -0.10100682f, 0.12462521f, -0.06963056f, 0.28443009f, 0.24762110f, 0.16181962f, -0.32749507f, 0.25742337f, 
    0.01289787f, -0.00116677f, 0.33875114f, 0.01859176f, -0.22304186f, 0.02883459f, -0.32377580f, 0.16609423f, 
    0.18602355f, 0.07898769f, -0.02055133f, 0.13675366f, 0.27055112f, -0.09665117f, -0.27904433f, 0.10927241f, 
    -0.01087061f, 0.22751878f, 0.03539062f, -0.01331325f, 0.01749416f, 0.24803287f, 0.15904050f, 0.02768243f, 
    -0.23577599f, 0.16854914f, -0.14074062f, 0.03003812f, 0.04810415f, 0.20871772f, -0.01930858f, -0.19112737f, 
    -0.09036746f, -0.07838129f, 0.05579394f, 0.22099645f, -0.06393814f, -0.19711541f, 0.08059294f, -0.25724036f, 
    -0.08880456f, 0.09998336f, 0.05034249f, 0.02225588f, 0.23660949f, -0.22990973f, 0.02066253f, 0.08210229f, 
    -0.06288499f, 0.10236612f, -0.13497752f, -0.00002060f, -0.22633183f, 0.31255430f, -0.06753787f, -0.01965229f, 
    0.06119502f, -0.05601611f, -0.16048385f, -0.02513699f, 0.04255575f, 0.09790085f, 0.10477956f, 0.03364239f, 
    -0.08030755f, 0.25527418f, 0.22634126f, 0.09681682f, 0.13395967f, -0.02094946f, -0.06822969f, 0.11850289f, 
    -0.22123088f, -0.08900236f, -0.10952459f, -0.13390963f, -0.09278956f, 0.21704586f, 0.13956967f, -0.06587133f, 
    -0.08274534f, 0.11543909f, 0.20664537f, 0.07520780f, 0.00021158f, 0.05578357f, -0.00917380f, 0.04888732f, 
    0.04905396f, 0.39204344f, -0.23538607f, 0.31881705f, 0.18943834f, -0.12402149f, 0.11555694f, -0.12268607f, 
    0.11913213f, 0.26948324f, -0.09519320f, 0.08074007f, -0.26748461f, -0.15274270f, -0.01476014f, 0.17526492f, 
    -0.14846353f, -0.34340820f, -0.04801944f, 0.18486635f, -0.11467826f, 0.15411253f, -0.03684005f, -0.21323542f, 
    0.27870801f, 0.07600524f, 0.13573435f, 0.32110158f, -0.24422765f, -0.11551283f, 0.08490764f, -0.21345997f, 
    -0.11356124f, -0.02343775f, -0.16680130f, 0.09621812f, 0.10908444f, 0.05378471f, 0.14232437f, 0.13410208f, 
    -0.03834775f, -0.11363195f, 0.52605170f, -0.04687469f, -0.10290311f, 0.22400647f, -0.08668034f, 0.15655065f, 
    -0.04839909f, 0.02837525f, 0.03948953f, -0.03905673f, 0.25122947f, 0.02135606f, -0.18226352f, -0.05249194f, 
    -0.02322233f, 0.11376564f, -0.07751032f, -0.00644653f, 0.09123704f, -0.09416281f, 0.30200431f, 0.05602297f, 
    -0.14310028f, -0.15776409f, -0.10218013f, 0.11620175f, 0.07017037f, 0.27961910f, 0.24279232f, 0.09797260f, 
    0.11526064f, 0.21240757f, -0.11749789f, 0.08387759f, -0.24959430f, -0.01909775f, -0.00381242f, 0.17076710f, 
    0.02864495f, -0.45011124f, 0.09207743f, 0.13115104f, 0.11223357f, -0.09883337f, -0.11272325f, 0.34778759f, 
    -0.04358985f, -0.12205459f, -0.00528297f, -0.13991536f, -0.16409241f, -0.15736797f, 0.09900947f, 0.08053244f, 
    -0.09986926f, -0.14622094f, -0.10260353f, 0.08755107f, -0.01469042f, -0.04765297f, 0.01151865f, -0.02318428f, 
    -0.01165247f, 0.17702927f, 0.10741375f, -0.12427709f, 0.01064659f, -0.05506586f, -0.03176863f, 0.05042950f, 
    -0.07229619f, -0.06649376f, -0.15726434f, -0.00551197f, -0.19137269f, -0.14931667f, -0.05118097f, 0.01695896f, 
    -0.06685153f, -0.05463842f, 0.01411479f, -0.17592527f, -0.11459856f, -0.09219041f, -0.17256603f, 0.06253700f, 
    0.09312853f, -0.16701865f, -0.09219430f, -0.04383531f, -0.14025146f, -0.09410380f, 0.17559168f, 0.13462766f, 
    -0.06549625f, -0.07666183f, -0.11934522f, 0.10066563f, 0.01476234f, -0.11483020f, 0.07053838f, 0.02460177f, 
    -0.03340923f, -0.03732832f, -0.05428842f, 0.14141713f, -0.05652393f, -0.01910562f, -0.08176544f, -0.18701378f, 
    -0.36492130f, 0.00860207f, -0.29509380f, -0.33904773f, 0.23984644f, 0.07781786f, 0.07485674f, -0.18809837f, 
    -0.00576773f, 0.17383179f, 0.17559323f, 0.13180113f, -0.08964614f, 0.03389914f, 0.30951005f, 0.13808864f, 
    0.03073534f, -0.02510586f, 0.19323546f, -0.02076828f, 0.04161469f, -0.08334547f, -0.16201934f, 0.13499635f, 
    -0.14166592f, -0.04121680f, -0.03250130f, -0.01656341f, -0.07709667f, 0.17169963f, 0.11886555f, 0.06127162f, 
    0.03886861f, 0.00008675f, 0.08977361f, -0.36908215f, 0.12511751f, -0.07001320f, -0.32482094f, 0.09220282f, 
    -0.14789140f, 0.01187331f, 0.09947343f, 0.38322255f, 0.21973273f, -0.42991057f, -0.44988149f, -0.01588179f, 
    0.32491356f, 0.06559744f, -0.07627796f, 0.02996311f, 0.00384201f, 0.07612590f, 0.02347402f, -0.17850894f, 
    0.09329637f, 0.48806977f, 0.05829188f, -0.08656493f, 0.11602083f, -0.06927378f, -0.01441397f, 0.03338477f, 
    -0.11507414f, 0.08488998f, -0.15418991f, 0.00092514f, -0.19009341f, 0.26743618f, 0.03327477f, -0.10551143f, 
    0.03514405f, 0.12504800f, -0.19683635f, -0.04063341f, -0.00945102f, 0.18021664f, 0.11126792f, -0.10641547f, 
    0.10184526f, 0.06497784f, 0.19753459f, 0.02116120f, -0.05995522f, 0.24493003f, -0.09269633f, 0.01897698f, 
    -0.02128271f, 0.06503120f, 0.02215442f, -0.08308674f, 0.21280028f, 0.20725845f, 0.00771408f, 0.04823128f, 
    -0.00530757f, 0.12290135f, 0.04350325f, 0.08162756f, 0.08843549f, 0.11211381f, -0.01331297f, -0.09888916f, 
    0.20381074f, 0.17999689f, -0.20580041f, -0.09956128f, 0.17191078f, 0.39273304f, 0.27824342f, -0.02485523f, 
    0.09811579f, 0.02869549f, -0.02901992f, -0.01183964f, -0.46737444f, -0.09847724f, 0.06735788f, 0.21002430f, 
    -0.17453384f, -0.45821917f, -0.21479858f, 0.09191024f, 0.24374817f, -0.00789993f, 0.09423544f, -0.06920242f, 
    0.12328137f, 0.01738582f, -0.09159158f, -0.02923757f, -0.13974489f, -0.13378909f, -0.07089975f, -0.16746022f, 
    -0.07390614f, -0.11354742f, 0.21053845f, 0.20518205f, 0.18474594f, 0.02109096f, -0.26328561f, 0.25750500f, 
    -0.12565528f, 0.39088917f, 0.23597531f, 0.07196683f, 0.23163565f, 0.22248827f, 0.12970735f, 0.24680942f, 
    0.06027170f, -0.11463721f, -0.18813281f, 0.10757285f, -0.06828912f, -0.26722395f, 0.22650397f, -0.01882277f, 
    0.06223558f, -0.02033497f, 0.24937646f, -0.21185069f, 0.00074061f, -0.04400651f, -0.16380903f, 0.07609408f, 
    -0.03727788f, 0.07240482f, -0.04131008f, 0.07962577f, -0.02222976f, -0.08717587f, -0.02031134f, 0.43496913f, 
    0.23697551f, 0.16134731f, 0.00317450f, -0.02148829f, -0.00255703f, -0.36999959f, 0.11483926f, -0.07097155f, 
    -0.02911362f, -0.03808548f, 0.11401661f, 0.23851669f, -0.16009197f, -0.14814249f, -0.01867193f, -0.25023636f, 
    0.04686623f, 0.05732720f, -0.08781201f, -0.05121773f, 0.28510991f, -0.08398280f, 0.06662348f, 0.15651733f, 
    -0.11213069f, 0.30190971f, 0.10327425f, 0.12444694f, 0.18975723f, 0.15545277f, -0.08270679f, 0.18194664f, 
    -0.19966534f, 0.12866358f, -0.03776634f, -0.04339050f, 0.04847628f, 0.22423428f, -0.15384868f, -0.15187736f, 
    0.05942322f, 0.03626408f, 0.24517773f, 0.26689497f, 0.23393279f, 0.08799437f, 0.14663397f, -0.12881348f, 
    0.03207409f, 0.23448659f, 0.00954164f, -0.22805184f, 0.11124063f, 0.21627732f, -0.31241783f, 0.14757036f, 
    -0.21921159f, -0.01249315f, -0.05869020f, -0.17825629f, 0.12036937f, -0.09761337f, -0.15030362f, 0.05510382f, 
    -0.05490694f, 0.06056795f, 0.06931797f, -0.14847501f, 0.19738409f, 0.03063032f, 0.13413794f, -0.17735122f, 
    0.04365281f, 0.47797027f, -0.03224076f, 0.03160601f, 0.16541846f, -0.01570265f, -0.07964584f, -0.22123504f, 
    0.02190815f, -0.08728617f, 0.19503185f, 0.14255981f, -0.18630499f, -0.20174362f, 0.08669535f, -0.18004863f, 
    -0.11271355f, -0.12407762f, 0.16750892f, 0.19177730f, 0.20656803f, 0.02213552f, 0.14988591f, -0.04224803f, 
    -0.03769575f, -0.16478592f, 0.34745914f, -0.12107439f, 0.02412401f, 0.35354164f, -0.12303717f, -0.24011947f, 
    -0.00193417f, -0.00264912f, 0.31416425f, 0.10718410f, 0.32559323f, 0.08710893f, -0.03590483f, 0.05683560f, 
    -0.02769298f, 0.12176365f, 0.00849975f, 0.05704421f, 0.11867495f, -0.09049095f, 0.02852308f, -0.18697512f, 
    -0.05428040f, -0.05499885f, 0.11190121f, -0.28946537f, 0.15868072f, 0.30182311f, 0.29005983f, 0.14897442f, 
    -0.04202399f, 0.09480589f, -0.03082100f, -0.11090565f, 0.06681385f, -0.11725996f, -0.27976772f, 0.13240081f, 
    0.03602165f, 0.15621720f, 0.08399861f, -0.11517236f, -0.06667615f, -0.08371971f, 0.11830477f, 0.20102431f, 
    0.24963130f, 0.03345556f, 0.08997325f, 0.21623911f, -0.00040433f, 0.00464231f, 0.01229659f, 0.15459906f, 
    -0.01037467f, 0.06132719f, 0.09559967f, -0.27046633f, 0.06464940f, -0.14222227f, 0.46334729f, -0.10371084f, 
    -0.23473011f, 0.18208824f, 0.11747791f, 0.03317180f, -0.22289549f, -0.02645970f, -0.02625221f, 0.18141799f, 
    -0.06294148f, -0.11795761f, -0.08620839f, -0.27954069f, 0.36299449f, -0.17872000f, -0.05505143f, 0.01351233f, 
    0.03926545f, -0.07352075f, 0.09470198f, -0.08550985f, 0.10059697f, 0.23716836f, -0.19697498f, -0.18402930f, 
    0.02024072f, -0.03729793f, 0.09874941f, -0.18145588f, -0.19066451f, 0.06481379f, 0.01401772f, -0.13198577f, 
    0.00377779f, 0.03954847f, -0.03171214f, -0.03528603f, 0.02979953f, 0.23540139f, -0.02503446f, 0.08658481f, 
    -0.15136617f, -0.15667377f, 0.21691261f, 0.09866457f, -0.07554600f, -0.29885784f, 0.11497165f, -0.00560762f, 
    -0.37637413f, 0.00522416f, -0.03743127f, -0.08267958f, -0.06872926f, -0.04307383f, 0.12498260f, -0.02737119f, 
    0.06325995f, -0.17563231f, 0.13759799f, 0.20587288f, -0.11227446f, -0.02928701f, -0.20647776f, 0.12149307f, 
    0.10424837f, 0.05960668f, 0.21996734f, -0.11824203f, 0.19430344f, 0.04518698f, 0.09370735f, -0.01908372f, 
    -0.00990123f, 0.12117139f, -0.04356210f, -0.13635975f, -0.03187526f, 0.30118841f, 0.11571689f, 0.01226252f, 
    0.12092032f, -0.05386029f, 0.29872209f, -0.02824170f, 0.15766545f, 0.03855734f, 0.06208747f, 0.03529772f, 
    -0.06633059f, 0.13790207f, 0.05448487f, 0.41486558f, 0.14819874f, -0.25959769f, -0.30260587f, 0.12737204f, 
    0.09541176f, 0.01474728f, 0.11461627f, 0.09171832f, -0.15934160f, 0.05707636f, -0.00397011f, 0.13581483f, 
    0.05074168f, 0.07128935f, -0.11100360f, 0.13715501f, -0.37160471f, 0.28764910f, 0.07208275f, -0.38155973f, 
    0.25021586f, 0.05238767f, -0.09473371f, 0.04365756f, 0.27921829f, -0.19404072f, -0.06340633f, 0.12899439f, 
    -0.21681049f, 0.19329715f, 0.12479306f, 0.09855335f, 0.00702183f, -0.01411291f, 0.00317811f, 0.12397053f, 
    -0.00107666f, -0.02178952f, -0.45679709f, 0.00538096f, -0.07271989f, 0.03244764f, -0.13619946f, -0.24605863f, 
    0.10726432f, -0.03805882f, 0.36790299f, 0.23483036f, 0.31457448f, 0.00886262f, 0.12306057f, 0.04985882f, 
    0.11548301f, 0.02981065f, 0.20331478f, -0.09652993f, 0.17044355f, 0.36113074f, -0.30207345f, -0.11636870f, 
    -0.11476779f, -0.14176811f, 0.04628836f, -0.24688016f, -0.10494943f, 0.17348054f, 0.07626794f, 0.23895831f, 
    -0.07149080f, 0.03954002f, 0.00071000f, -0.02251353f, 0.05557406f, 0.01967373f, -0.10827367f, -0.17533241f, 
    -0.12957582f, 0.27391315f, 0.01118045f, 0.11078078f, -0.07034465f, 0.15203157f, 0.08528864f, -0.31687230f, 
    -0.44494438f, 0.01713580f, -0.27008104f, -0.25024819f, -0.00920425f, 0.16794747f, -0.07358346f, -0.28608707f, 
    -0.10375325f, -0.03189325f, -0.06532371f, 0.16717087f, 0.09347019f, 0.26636377f, -0.34333196f, 0.11664498f, 
    0.03168350f, -0.05184529f, 0.40549278f, 0.12026899f, 0.17267719f, 0.08960930f, -0.08976027f, 0.00756049f, 
    0.02440884f, 0.03630291f, 0.26546529f, 0.12593226f, 0.14602649f, 0.26773134f, 0.07017244f, 0.11734361f, 
    -0.06173297f, -0.05720136f, 0.03731714f, -0.08681944f, 0.00362323f, -0.12362424f, 0.05249031f, 0.07150448f, 
    0.00612278f, 0.22174820f, 0.01314316f, -0.03177137f, 0.44903550f, 0.07426419f, -0.01527233f, -0.10076231f, 
    0.11090647f, -0.00582540f, -0.02862903f, -0.07281292f, -0.17839286f, -0.19597895f, 0.03045536f, 0.03962513f, 
    -0.01253386f, 0.54888815f, 0.04259560f, -0.10737809f, -0.01127875f, -0.04620633f, 0.02194299f, -0.05231063f, 
    0.16691782f, 0.10372554f, 0.06652289f, -0.08727305f, 0.38092035f, -0.01396103f, -0.04367888f, 0.17037548f, 
    0.12854612f, 0.19391005f, -0.01645428f, -0.20722626f, -0.03686238f, 0.08130441f, 0.24703765f, -0.11492853f, 
    0.15342091f, -0.02551233f, -0.43820685f, 0.03463379f, 0.14452617f, -0.23860025f, 0.15488359f, -0.11982620f, 
    0.01933453f, -0.02952016f, -0.10918305f, -0.03364672f, -0.20234260f, 0.02053516f, 0.10004410f, 0.09810138f, 
    -0.02847295f, 0.11628282f, -0.07531638f, 0.16283228f, 0.09437086f, 0.14655720f, -0.19961971f, -0.08133011f, 
    0.05233226f, -0.02330109f, -0.05443291f, -0.12984927f, -0.23155959f, -0.24071768f, -0.02005162f, -0.03764118f, 
    -0.09526391f, -0.13890663f, 0.07669157f, 0.19645466f, 0.35779989f, 0.31888038f, 0.04550358f, -0.00085407f, 
    -0.04904662f, 0.04041233f, 0.17101036f, -0.05884569f, 0.16622370f, 0.32925865f, -0.03788541f, 0.18560185f, 
    0.22574951f, -0.03275662f, 0.11977381f, 0.23617515f, 0.05806883f, -0.35571909f, 0.09603740f, -0.03788324f, 
    0.01730860f, -0.06442514f, 0.24619214f, -0.13754603f, 0.17398271f, -0.34159476f, 0.22267376f, -0.18772674f, 
    -0.09607223f, -0.00531243f, 0.28359091f, -0.09886215f, -0.00067683f, 0.25531414f, 0.04398894f, -0.03762095f, 
    -0.18821596f, 0.08578579f, 0.11754761f, -0.23498070f, 0.13376342f, -0.12077376f, 0.12802601f, 0.05698399f, 
    0.00755182f, -0.14253962f, 0.10729842f, -0.08177939f, 0.05481705f, -0.07631484f, -0.03412492f, -0.16336057f, 
    0.09494069f, -0.20846392f, 0.01805952f, 0.10227995f, -0.16756277f, -0.00591793f, 0.21779978f, 0.06627668f, 
    0.09799059f, 0.15603487f, -0.02684305f, -0.25868648f, -0.39094076f, 0.02287631f, -0.22026852f, 0.23325539f, 
    -0.09385385f, -0.51293933f, 0.14730304f, 0.10710916f, -0.22501311f, -0.20070417f, -0.02390909f, 0.10743058f, 
    0.31027910f, 0.07141507f, 0.25087157f, 0.17131755f, 0.13485108f, 0.17624728f, -0.08084508f, 0.24413174f, 
    0.11808546f, 0.13862516f, -0.16417024f, -0.10541955f, 0.13803850f, -0.14499982f, -0.00566442f, 0.24123323f, 
    0.05897682f, 0.09339608f, -0.31298760f, 0.09546383f, -0.10633075f, 0.00848273f, 0.14295702f, 0.08133607f, 
    0.08260796f, -0.00720152f, -0.18844469f, 0.15139934f, 0.34316933f, 0.01334947f, -0.02432408f, -0.05841293f, 
    0.09759030f, 0.11493871f, -0.03234515f, 0.00603327f, -0.08017278f, 0.12818225f, 0.00000084f, 0.06607158f, 
    -0.06654344f, -0.10962734f, -0.06848381f, -0.15991277f, 0.05389048f, 0.21267577f, 0.11333526f, 0.24569941f, 
    0.05500739f, 0.03606968f, -0.10820477f, -0.04839719f, -0.33787754f, 0.03781644f, -0.01063700f, -0.18105176f, 
    -0.15238233f, -0.27967569f, 0.06555763f, 0.01337075f, 0.02856852f, -0.02840973f, 0.04900237f, 0.01146499f, 
    -0.03987756f, 0.09367430f, -0.06799355f, -0.10331780f, -0.08586594f, 0.06666680f, -0.11113159f, -0.04039477f, 
    -0.11013123f, -0.04305849f, -0.02196556f, 0.08731605f, -0.10692231f, -0.08145477f, -0.01208809f, -0.06760592f, 
    -0.10440551f, 0.05934775f, -0.12776354f, -0.09271951f, -0.03560086f, -0.04601509f, -0.14335856f, -0.09235844f, 
    0.04061347f, -0.12081194f, -0.00165495f, -0.13205847f, -0.08411358f, 0.09108055f, -0.12298902f, 0.03875163f, 
    0.08591200f, -0.02986917f, 0.04633915f, 0.08602346f, -0.04652852f, 0.08926839f, -0.03682559f, -0.08994821f, 
    -0.08463121f, 0.00537781f, -0.12022428f, 0.06721571f, 0.00760304f, -0.01968853f, -0.06183143f, -0.06726182f, 
    -0.10049784f, 0.08766136f, 0.05115619f, -0.07742175f, -0.12937853f, -0.00452639f, -0.13447684f, -0.10112165f, 
    -0.12153932f, -0.12145846f, 0.09427121f, -0.03390225f, 0.03845262f, -0.05825667f, -0.07639620f, 0.01990585f, 
    0.01933244f, -0.10047778f, -0.03761050f, 0.05640071f, 0.10731453f, -0.08719715f, 0.01521052f, -0.00411712f, 
    -0.03462695f, -0.12343131f, -0.01540038f, -0.11171237f, -0.14933792f, 0.05381159f, -0.05661685f, -0.14898951f, 
    -0.02584101f, 0.08671508f, -0.22661297f, -0.07617287f, 0.01005322f, -0.05980011f, -0.05922805f, -0.12975132f, 
    -0.04457746f, -0.07287313f, -0.14884295f, -0.02551099f, -0.25875732f, 0.01174641f, -0.05196299f, -0.01716791f, 
    -0.11412016f, 0.01043784f, -0.03545459f, 0.16721119f, -0.04895752f, 0.10485017f, 0.12960657f, 0.03799892f, 
    0.03328716f, -0.04480200f, -0.08691730f, -0.01010828f, -0.24666061f, -0.04064593f, 0.10745898f, -0.12153734f, 
    0.01517195f, -0.07536867f, -0.11119135f, -0.03870534f, -0.09357307f, 0.14082471f, 0.12903962f, 0.04570696f, 
    0.03600701f, -0.24189034f, 0.12713049f, -0.15839581f, 0.01381610f, 0.32644191f, -0.03751004f, 0.05307268f, 
    0.14938311f, 0.08254107f, 0.15757905f, 0.11183637f, 0.35041857f, 0.10014422f, -0.06228977f, 0.20681886f, 
    0.09783375f, 0.19071355f, -0.05773020f, -0.20564412f, -0.08787455f, 0.12681501f, 0.04594449f, 0.04490852f, 
    0.12135354f, -0.11006779f, -0.19349185f, -0.04459553f, -0.00039443f, -0.19305189f, 0.01969949f, 0.17555335f, 
    -0.15985757f, 0.07797841f, -0.30082977f, 0.18915755f, 0.21887511f, 0.12252637f, -0.11838036f, -0.10243442f, 
    0.00867369f, -0.10030285f, -0.14152235f, -0.08043438f, -0.08084069f, -0.00136237f, -0.11019767f, 0.21233748f, 
    0.10051946f, 0.05690020f, -0.10826360f, 0.32256594f, -0.03075508f, -0.05844152f, -0.22187643f, 0.03345046f, 
    0.08018959f, -0.01543573f, -0.07729127f, 0.19122304f, -0.06684522f, 0.26037785f, 0.05705748f, -0.03762255f, 
    0.00839710f, -0.21845143f, 0.08617774f, -0.07622599f, 0.27863833f, 0.13629499f, -0.04214138f, 0.07558064f, 
    -0.21724004f, 0.02960419f, 0.03553973f, 0.18598278f, 0.10608050f, 0.16702051f, 0.05066948f, 0.11716615f, 
    -0.09771258f, 0.16410515f, -0.29402301f, 0.20400362f, 0.00050815f, 0.08338304f, -0.13694358f, -0.05864517f, 
    0.03385250f, -0.28575593f, 0.21337426f, -0.09551230f, -0.30747053f, -0.06904088f, -0.11965697f, -0.03939277f, 
    0.00825655f, 0.06974985f, 0.07108618f, 0.17368864f, 0.32956350f, 0.12677209f, -0.29215792f, -0.11456994f, 
    0.11318019f, 0.06009203f, -0.20507544f, 0.08597738f, 0.04479581f, 0.07669459f, 0.07200908f, -0.00267682f, 
    -0.12695950f, 0.23792367f, -0.10266360f, 0.16476770f, 0.21551044f, 0.29252753f, -0.19823271f, -0.52075547f, 
    -0.12588574f, -0.16941617f, 0.04061233f, 0.08192231f, -0.24182148f, 0.10122399f, -0.10794880f, -0.06255136f, 
    0.08053900f, -0.27511880f, 0.06323820f, 0.10491352f, 0.19384807f, -0.23609500f, 0.09308359f, 0.02782261f, 
    0.29384369f, 0.00274868f, -0.00644722f, -0.20182404f, 0.01295233f, -0.01422353f, 0.12837198f, 0.14270620f, 
    0.00213045f, 0.20329157f, 0.12697208f, -0.03367735f, 0.29371127f, 0.03518324f, -0.11395380f, 0.27355665f, 
    0.13120055f, 0.20786859f, 0.32913765f, -0.01726415f, 0.37844414f, -0.06740484f, -0.14929536f, 0.08299612f, 
    -0.08023602f, -0.08790927f, -0.07464314f, -0.07753409f, 0.18454036f, -0.05512631f, 0.04300454f, 0.04191908f, 
    -0.07567167f, -0.01031421f, -0.15168998f, -0.13162485f, -0.11620002f, -0.12035145f, 0.14486907f, 0.27046064f, 
    -0.12690729f, 0.02839442f, -0.17314813f, 0.01910778f, 0.12866743f, 0.05648597f, 0.01694013f, 0.03014861f, 
    -0.05687845f, 0.35725525f, -0.08917821f, 0.26531678f, 0.20430380f, -0.11882041f, 0.14722218f, -0.18075648f, 
    0.09764394f, 0.13665944f, 0.08862805f, -0.13435170f, 0.05855218f, 0.00776423f, 0.05376661f, 0.10023183f, 
    -0.13308382f, -0.06568054f, 0.15490696f, -0.14310724f, -0.24269339f, 0.37250984f, -0.11971961f, 0.31616214f, 
    0.09145232f, 0.07982318f, -0.05449684f, -0.02546919f, 0.24376552f, 0.02384308f, 0.18383969f, 0.03210233f, 
    -0.09850720f, 0.36479133f, 0.04775391f, -0.00584570f, 0.28228870f, -0.10808088f, -0.00240911f, -0.02229516f, 
    -0.00465358f, 0.07051088f, -0.03493768f, -0.02117506f, -0.09177902f, -0.07338623f, 0.04558790f, 0.10534168f, 
    -0.08157260f, 0.18029964f, 0.00157418f, 0.06147982f, -0.05773793f, 0.16275926f, 0.10665729f, 0.06885414f, 
    0.03577769f, 0.18582536f, 0.07278905f, -0.04824663f, 0.09258946f, 0.02387533f, 0.43581775f, -0.22470097f, 
    -0.18603396f, 0.17704791f, -0.05181797f, 0.17845382f, -0.02448337f, -0.02400973f, -0.06908184f, 0.13482699f, 
    -0.13914958f, -0.52297252f, -0.15371054f, -0.09396192f, -0.16258024f, 0.25102693f, -0.12053613f, 0.10792771f, 
    0.14488457f, 0.00407158f, 0.14453340f, -0.06099976f, 0.27108344f, -0.07668817f, 0.10036279f, 0.09711957f, 
    0.16012609f, 0.19722077f, -0.15746206f, -0.20060274f, -0.01728925f, -0.02269288f, 0.08663286f, 0.02221740f, 
    0.02263976f, 0.10792802f, -0.05165434f, -0.03743312f, -0.06572897f, 0.05051116f, 0.29828420f, 0.04559518f, 
    -0.08769261f, -0.08189290f, -0.18792944f, 0.01280571f, -0.00243808f, 0.00261673f, 0.10100007f, 0.06832962f, 
    0.03542270f, 0.02703466f, 0.11711069f, 0.04845627f, 0.16830170f, 0.07169045f, 0.17319743f, 0.16494486f, 
    0.07069305f, -0.14774798f, -0.17601776f, 0.38083825f, -0.04210533f, 0.11074992f, -0.17364326f, 0.28248593f, 
    0.27382776f, -0.10651740f, 0.06695978f, -0.02296499f, -0.18153620f, 0.06262291f, 0.12356064f, 0.02109980f, 
    0.03982716f, -0.23474689f, 0.05771103f, 0.06968156f, 0.03049820f, -0.07872676f, -0.10654362f, 0.20941770f, 
    -0.09967771f, -0.00586233f, 0.13364169f, 0.03263290f, -0.04068876f, -0.01206584f, -0.07279656f, 0.33583120f, 
    0.16723768f, -0.06887328f, -0.04286202f, -0.02087778f, -0.03423887f, 0.15110503f, 0.01552031f, 0.11319187f, 
    0.27490836f, 0.08385194f, 0.00747765f, 0.03559927f, 0.13288359f, -0.12121009f, -0.14005414f, 0.20932457f, 
    0.06937414f, 0.01536760f, -0.15719442f, -0.03666208f, 0.04121878f, -0.14480338f, -0.05877513f, -0.01832427f, 
    0.10840383f, -0.02115418f, -0.07432817f, 0.18299301f, -0.22568998f, -0.02019450f, 0.32842001f, 0.13193999f, 
    0.18351728f, -0.03973471f, 0.17371725f, -0.05354872f, -0.05860765f, 0.10412803f, -0.06666099f, -0.22740890f, 
    -0.11737278f, 0.15639904f, -0.05564235f, -0.03119437f, 0.07460082f, -0.02871927f, -0.04137877f, -0.01991846f, 
    0.06095043f, -0.28487822f, 0.18994628f, 0.21176846f, 0.12823816f, 0.00049098f, -0.05457316f, -0.04169118f, 
    -0.33740458f, -0.08865513f, -0.11059625f, -0.02390243f, -0.11084669f, 0.07557566f, 0.05330084f, -0.32933697f, 
    -0.18457143f, -0.26175675f, 0.03528754f, -0.03639475f, -0.17578574f, -0.01443020f, 0.02688599f, -0.10223801f, 
    0.08035450f, -0.23163667f, -0.08585256f, -0.01951455f, -0.02962401f, 0.07267032f, 0.00055519f, -0.22678179f, 
    0.10693329f, -0.06808615f, -0.02932521f, 0.29619446f, -0.15510058f, 0.08351566f, -0.20126368f, 0.03325109f, 
    -0.04376550f, -0.19172098f, -0.09329021f, -0.01137643f, 0.09406006f, -0.29653394f, -0.03570096f, 0.07370680f, 
    0.04187085f, 0.01788574f, 0.10436094f, -0.33786711f, 0.13746229f, -0.11465797f, 0.19711727f, 0.04571249f, 
    0.05467254f, -0.23633234f, 0.10450307f, -0.27063671f, -0.26452893f, -0.14084254f, -0.04708179f, -0.03945033f, 
    -0.00992725f, -0.10202532f, 0.17370960f, -0.10397089f, 0.12493511f, -0.01226263f, 0.08145179f, 0.02269182f, 
    -0.10364269f, -0.00460579f, -0.24939252f, 0.09079359f, 0.03546910f, 0.35980466f, -0.10456286f, -0.05264140f, 
    0.07104655f, 0.09190389f, -0.16025788f, 0.11777527f, -0.26203954f, 0.25703272f, 0.11014410f, -0.09135646f, 
    -0.08669546f, -0.21606614f, -0.09885997f, 0.08766548f, -0.21785009f, -0.16093171f, 0.02399075f, -0.00532176f, 
    -0.10403987f, 0.05458375f, 0.10540150f, 0.08641101f, 0.08507217f, -0.06039888f, -0.13598967f, 0.12590097f, 
    0.08715631f, 0.20644623f, -0.08404514f, -0.00883332f, 0.06257915f, 0.13580181f, -0.09217846f, 0.12195437f, 
    0.14173219f, 0.36427364f, -0.12688455f, 0.19910955f, 0.09093420f, -0.05707511f, -0.15249479f, -0.35887805f, 
    0.21734785f, -0.04387431f, -0.05538870f, -0.09469829f, 0.18173987f, 0.19521481f, 0.35395131f, 0.01564644f, 
    -0.09508973f, 0.07306155f, 0.07406295f, 0.03911784f, 0.36878419f, -0.11623168f, 0.06550281f, -0.01641127f, 
    -0.34272841f, -0.04074534f, -0.02003747f, 0.05746803f, -0.14742120f, 0.25090423f, 0.05514439f, -0.28140473f, 
    0.10764568f, 0.02198791f, 0.00643521f, -0.03372947f, -0.11422765f, 0.02796555f, -0.09719950f, 0.06979621f, 
    0.06987484f, -0.02387208f, 0.26860410f, -0.06213138f, 0.10228680f, 0.08568610f, -0.09061606f, 0.18451811f, 
    -0.20154604f, 0.05047116f, -0.03780297f, 0.08251072f, -0.08890241f, 0.22144152f, 0.07819371f, 0.08776484f, 
    0.04745285f, -0.08029608f, 0.18240197f, 0.09811657f, 0.10492446f, 0.09097300f, 0.20386903f, -0.02531967f, 
    0.27107799f, 0.32661912f, -0.14040563f, 0.23638792f, -0.00177855f, 0.16725449f, 0.19685134f, -0.17656067f, 
    0.10037076f, -0.11354675f, -0.05833398f, -0.08134974f, -0.24389078f, 0.08548671f, 0.05366876f, 0.22817762f, 
    -0.01866359f, -0.07803898f, -0.15677275f, -0.06317069f, -0.03512970f, -0.13733090f, -0.01992503f, 0.02412453f, 
    -0.01072829f, -0.00912560f, -0.00830919f, 0.11046697f, 0.21122989f, 0.03343530f, -0.04788403f, 0.10496024f, 
    0.03318464f, 0.01531198f, 0.04932835f, 0.03258851f, -0.03863447f, 0.30643639f, 0.00459676f, -0.03359249f, 
    0.23421285f, -0.23652381f, 0.19545943f, -0.02803926f, 0.19249043f, -0.22715212f, -0.14715549f, 0.26922154f, 
    -0.09307030f, -0.02396637f, -0.15460579f, -0.10277746f, 0.07213277f, -0.00437504f, -0.03171828f, 0.06876744f, 
    -0.09432489f, 0.08663253f, -0.16907203f, -0.03154985f, 0.06489632f, -0.11896393f, 0.13880178f, 0.33020744f, 
    0.07448155f, 0.06915590f, -0.01692462f, 0.37558740f, 0.23668383f, -0.21116029f, -0.16077867f, -0.08901048f, 
    0.22106256f, 0.12720034f, -0.06096170f, 0.24201140f, -0.09092406f, 0.16687931f, 0.26890019f, -0.04933989f, 
    0.26903069f, -0.08005305f, 0.06983906f, 0.09130806f, 0.38268426f, 0.26863655f, -0.04935617f, 0.20787321f, 
    0.05933852f, -0.10629605f, 0.00876834f, -0.04203334f, -0.14720537f, 0.00733044f, -0.05184421f, -0.14582889f, 
    -0.05901674f, 0.05430695f, 0.04667315f, -0.16727643f, 0.01354654f, 0.04126393f, -0.11362622f, -0.09826925f, 
    -0.10912094f, -0.10487495f, -0.09212427f, -0.06904021f, -0.04040090f, -0.08979344f, -0.01717389f, 0.00440665f, 
    -0.12709597f, 0.00529657f, -0.12727381f, -0.07443190f, -0.04280863f, -0.12877397f, -0.11508709f, 0.09460802f, 
    0.04558656f, 0.01310443f, -0.14420415f, 0.04252572f, 0.03829799f, -0.05388316f, -0.06340780f, -0.01260056f, 
    -0.08867691f, -0.12570494f, -0.08115765f, -0.17516018f, 0.05916801f, -0.13324665f, -0.04911700f, -0.03859634f, 
    -0.11432850f, -0.09345317f, 0.02566366f, -0.13200104f, -0.07020953f, -0.01290554f, -0.01743313f, 0.04701920f, 
    0.04946455f, -0.10422187f, -0.01851424f, -0.14825422f, 0.01470311f, 0.05520752f, 0.10991813f, 0.01659618f, 
    -0.12996948f, -0.07879759f, 0.08949037f, 0.04760863f, -0.07936113f, 0.17688784f, 0.12206891f, -0.17438337f, 
    0.03690952f, -0.16506504f, -0.15592018f, -0.22421736f, -0.00832407f, -0.12420118f, 0.20114811f, -0.08993910f, 
    0.07126008f, -0.21038583f, -0.10959091f, -0.12289967f, -0.05549703f, -0.15439665f, 0.20803097f, -0.06532561f, 
    0.08236712f, 0.09221890f, -0.12509218f, 0.06489512f, 0.01994864f, -0.06424926f, 0.06114314f, 0.04828542f, 
    -0.10207459f, -0.13098527f, 0.06096803f, 0.22318609f, -0.02107584f, -0.00866672f, -0.04511451f, -0.19193017f, 
    -0.23578520f, 0.03002106f, 0.03797800f, -0.16792078f, 0.04276406f, 0.16228740f, -0.02908415f, -0.23352575f, 
    -0.15481900f, -0.16661258f, -0.02752152f, -0.18755236f, 0.15311399f, -0.13204028f, 0.01244341f, -0.06706731f, 
    -0.07353032f, -0.11370148f, -0.09671095f, -0.00144156f, -0.12825961f, -0.16171525f, 0.09741557f, 0.06014019f, 
    0.10721134f, -0.11376540f, 0.07220397f, -0.05002905f, 0.02091138f, 0.00164786f, -0.11208539f, 0.31989875f, 
    0.01598164f, 0.05951304f, 0.12703037f, 0.10791035f, 0.10892742f, -0.00292984f, -0.09548646f, 0.04619114f, 
    0.01253313f, 0.24094786f, -0.44395873f, -0.08483065f, 0.10850737f, 0.09932451f, -0.06506892f, 0.27953932f, 
    0.11512020f, -0.08657838f, -0.17958251f, -0.05470870f, -0.10590504f, 0.01774860f, 0.23596446f, -0.02042301f, 
    -0.01485330f, 0.11242940f, 0.25956437f, 0.00160622f, -0.08726221f, 0.12882829f, -0.21753348f, 0.02145269f, 
    0.23263983f, 0.21812560f, 0.00121620f, 0.02274176f, -0.07365526f, -0.18661629f, -0.28416795f, 0.34309125f, 
    0.24589352f, 0.04829466f, -0.06299119f, -0.12749787f, -0.22246104f, -0.08713026f, 0.04925250f, 0.14736040f, 
    -0.18572466f, -0.24677810f, -0.07845596f, 0.26359275f, -0.08601058f, 0.21328157f, 0.06939292f, -0.64939290f, 
    0.11284410f, -0.09869815f, -0.16912253f, -0.16537046f, 0.20678179f, 0.26696384f, 0.03347024f, -0.14191706f, 
    0.00062522f, 0.18079023f, -0.03972260f, -0.21637999f, -0.07222093f, 0.22278371f, 0.00140156f, -0.05079761f, 
    -0.09381127f, -0.06752796f, -0.20067722f, -0.06338255f, -0.05651157f, 0.20859729f, -0.20558031f, 0.09930424f, 
    -0.07374026f, -0.01541343f, 0.03598854f, 0.13699281f, 0.18701109f, -0.02954859f, -0.01480161f, -0.03346356f, 
    -0.04318763f, 0.24217395f, 0.05995915f, -0.15684079f, 0.04410946f, 0.05275064f, -0.37722319f, 0.15425308f, 
    0.01150424f, 0.24528821f, 0.06212830f, -0.02760965f, 0.19339070f, -0.14256370f, -0.07463459f, -0.00882318f, 
    0.10073792f, 0.07669152f, 0.08896533f, -0.05804056f, -0.05235325f, 0.10059810f, 0.25600305f, 0.09569331f, 
    -0.00343818f, 0.10864995f, 0.03466714f, -0.13461061f, 0.24827074f, 0.14756401f, -0.00700144f, -0.30763549f, 
    -0.19001918f, 0.06825593f, -0.03235890f, -0.14284396f, 0.13580696f, 0.08812237f, 0.01839453f, -0.32003865f, 
    -0.03541639f, -0.15926717f, -0.04501201f, -0.19936931f, -0.31507704f, -0.25589183f, 0.08004621f, -0.19752595f, 
    0.01778875f, 0.05464669f, 0.02422752f, -0.09942438f, -0.12498908f, -0.00446740f, 0.13498881f, -0.04757982f, 
    0.06571239f, -0.04414913f, 0.16635132f, -0.12588450f, 0.00598710f, 0.00116871f, -0.14740527f, 0.01300339f, 
    0.01407965f, -0.04095001f, -0.08548725f, -0.05253667f, 0.02553184f, -0.07585505f, -0.03320096f, -0.03150627f, 
    0.05091186f, -0.09248953f, 0.14843298f, -0.19601162f, -0.01726218f, -0.19160062f, -0.11101646f, -0.17205679f, 
    -0.11906467f, -0.01065488f, 0.03003195f, -0.02076092f, 0.07437039f, 0.07402319f, -0.10391998f, -0.09161840f, 
    0.03082622f, -0.07923434f, 0.06929967f, -0.01526529f, 0.01377349f, 0.12304529f, 0.03185822f, -0.20403738f, 
    -0.11193520f, -0.03940789f, 0.07026257f, -0.16958338f, 0.13817017f, -0.06185667f, -0.02226975f, -0.16184236f, 
    -0.13555542f, -0.11540095f, 0.40362477f, -0.10743780f, 0.02008671f, -0.18102966f, -0.10574269f, 0.15451650f, 
    -0.09553374f, 0.31088066f, -0.17586383f, 0.09591168f, 0.42004979f, 0.06124808f, 0.09576998f, 0.17946002f, 
    -0.06629155f, 0.04381631f, -0.05284408f, 0.26356301f, -0.32103136f, 0.10753298f, 0.43497011f, 0.08213949f, 
    -0.03924631f, -0.09556803f, 0.36682993f, -0.13050176f, 0.14411159f, 0.04348703f, -0.02478627f, -0.10356694f, 
    0.18550825f, 0.06314299f, -0.17949347f, 0.05241432f, -0.00254586f, -0.06811380f, 0.15349586f, 0.63348341f, 
    0.33347648f, -0.09254607f, -0.10965723f, -0.17887411f, -0.11940710f, -0.24410973f, -0.07017054f, 0.22970454f, 
    -0.20166582f, 0.09974793f, 0.18490300f, 0.22135049f, -0.13708797f, -0.01357881f, 0.02393186f, -0.35088909f, 
    0.01096875f, 0.04425852f, -0.16014455f, 0.30261928f, -0.14336005f, -0.13965844f, 0.11679401f, -0.27050024f, 
    -0.05753939f, -0.14370933f, 0.06347901f, 0.22564113f, -0.00205988f, 0.09989934f, -0.10424273f, -0.01691856f, 
    0.05026384f, -0.14264829f, 0.25961986f, 0.08371019f, -0.13521056f, 0.31034052f, -0.08852337f, 0.18549345f, 
    0.08990929f, 0.11956719f, 0.20024329f, -0.10386877f, 0.29895878f, 0.16846062f, -0.12546971f, -0.11596002f, 
    0.07453157f, 0.02087384f, 0.04036429f, 0.06085071f, 0.04215394f, 0.10982033f, 0.07495366f, -0.00878524f, 
    0.21511221f, 0.12765385f, -0.14710453f, 0.02412409f, -0.04006160f, 0.04625039f, -0.29345903f, 0.06613539f, 
    0.25349167f, 0.20124136f, -0.03008799f, 0.01499395f, -0.37217852f, 0.02931571f, -0.05821403f, 0.29737911f, 
    -0.04349351f, -0.12430920f, -0.08777577f, 0.17738281f, 0.14507294f, 0.02080175f, 0.03130718f, -0.06419534f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.01335980f, 0.10608091f, -0.05972550f, -0.01396479f, 0.06718230f, 0.11680525f, -0.13355818f, -0.19075540f, 
    0.20250525f, 0.03241454f, 0.02953740f, -0.15414999f, 0.09064583f, 0.04983463f, -0.08755615f, 0.10579665f, 
    0.19124766f, 0.08877783f, 0.16968060f, 0.15389399f, -0.07893676f, 0.12072675f, -0.17014414f, 0.18179379f, 
    0.13756301f, 0.22083689f, 0.06702930f, 0.04068520f, -0.10703614f, 0.01229215f, 0.14066663f, 0.13415873f, 
    -0.13480432f, -0.19961467f, 0.06047822f, -0.03207520f, 0.02712614f, -0.00791089f, 0.28075808f, 0.06896888f, 
    0.15238304f, -0.06811795f, -0.02380179f, 0.17270128f, 0.27623391f, -0.13207854f, -0.05666436f, 0.14079322f, 
    0.00396078f, 0.03363606f, 0.26073492f, 0.07280538f, 0.01900192f, -0.05639809f, -0.13411950f, 0.13772732f, 
    0.04552422f, -0.16183902f, -0.01081154f, 0.14501204f, -0.01709762f, -0.12979864f, 0.16582744f, -0.02781328f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    0.08702297f, -0.04962499f, 0.15673156f, -0.10777111f, -0.15493478f, -0.00603583f, -0.05221593f, -0.12115888f, 
    -0.05256097f, -0.36920962f, -0.11536661f, 0.04217887f, 0.18238039f, -0.08671758f, -0.06341817f, -0.01946183f, 
    0.21963248f, 0.07352810f, -0.05878435f, -0.29905221f, 0.08424922f, 0.18747459f, 0.04015982f, -0.40720969f, 
    -0.10001432f, 0.05877422f, -0.27897570f, -0.09378669f, 0.20853364f, 0.03879703f, -0.42952034f, -0.15741579f, 
    0.06623051f, 0.05574817f, -0.26858297f, -0.15673909f, 0.18617073f, 0.26969671f, -0.57981491f, -0.06460857f, 
    0.12680179f, 0.12548019f, 0.12056718f, -0.10066840f, -0.36848155f, 0.07475294f, -0.16409147f, -0.24426237f, 
    -0.28466198f, 0.01798729f, -0.11888389f, -0.36683401f, -0.15353143f, 0.00115245f, -0.00350801f, -0.33287314f, 
    -0.03726200f, 0.00661247f, -0.28914550f, -0.53607374f, 0.02820542f, -0.05005422f, -0.12368166f, -0.37240678f, 
    0.08683995f, 0.06040093f, 0.12839405f, -0.02816231f, 0.46700284f, -0.00399419f, 0.04469991f, -0.05015882f, 
    -0.25804338f, -0.08151510f, -0.23778860f, -0.05891698f, 0.05167786f, -0.16509600f, -0.00532024f, 0.09201918f, 
    0.09462591f, 0.19425800f, -0.02199026f, -0.27384841f, 0.06971513f, -0.06869346f, 0.08686267f, 0.16704762f, 
    -0.55611157f, 0.04430677f, 0.01380700f, 0.22683650f, 0.06499969f, 0.25958765f, 0.14536381f, 0.12417399f, 
    -0.00773019f, -0.50682580f, 0.09904057f, -0.46775925f, -0.05341448f, 0.05109804f, 0.18009679f, -0.00968992f, 
    -0.03039254f, 0.02301561f, -0.17528327f, 0.19082643f, 0.03549057f, 0.09307352f, -0.25372967f, -0.03219602f, 
    0.16968445f, -0.04960930f, 0.16408525f, -0.06382221f, 0.12888399f, 0.07715121f, -0.04037258f, 0.00504275f, 
    -0.02822420f, 0.06443517f, -0.06303187f, 0.00434078f, -0.04793030f, -0.00164934f, -0.53433979f, 0.09995460f, 
    0.14727281f, -0.21711974f, -0.35191980f, -0.04626077f, -0.78778982f, 0.15756178f, -0.11269091f, -0.06386179f, 
    0.15424344f, 0.13183330f, -0.10976253f, -0.34213242f, 0.01676084f, 0.02994604f, 0.00811735f, -0.15568022f, 
    0.16581412f, -0.16562806f, 0.17739001f, 0.10616244f, -0.08763349f, -0.39492527f, -0.02412811f, 0.20424925f, 
    0.19356130f, 0.16862397f, -0.11244311f, -0.12960470f, -0.54012620f, -0.66169053f, 0.19906154f, 0.09823414f, 
    -0.14295164f, -0.32049501f, 0.24636425f, -0.09421442f, -0.16797833f, 0.22128697f, -0.93693513f, 0.12644760f, 
    -0.18035258f, 0.26378092f, -0.28758520f, 0.04998995f, -0.00885356f, 0.12183008f, -0.04614833f, -0.16020426f, 
    -0.02362408f, -0.03007241f, 0.08578130f, -0.10176729f, 0.00426934f, 0.07694721f, -0.49685019f, 0.14223018f, 
    0.05480390f, 0.06308216f, -0.10318054f, 0.05477827f, -0.02858375f, -0.09440409f, 0.04783791f, 0.15469401f, 
    0.19104460f, -0.34884378f, 0.07556610f, 0.08557860f, -0.29817942f, -0.00543941f, -0.04901301f, -0.02572401f, 
    0.20497979f, 0.00630512f, -0.13556504f, -0.06948625f, -0.39213330f, 0.19408745f, -0.14496197f, 0.11181391f, 
    -0.14368664f, -0.17769812f, -0.02875988f, -0.03348904f, -0.01071542f, -0.15182096f, -0.69170237f, -0.04023330f, 
    -0.32169390f, -0.05460322f, -0.48309022f, -0.14865765f, 0.21778181f, -0.10843041f, 0.16955939f, -0.21490222f, 
    0.01127440f, 0.28751236f, -0.16509771f, -0.08865171f, 0.07342907f, -0.16410077f, -0.22097242f, 0.15826274f, 
    -0.10880931f, 0.19263615f, -0.00029133f, -0.42040697f, -0.22095944f, -0.10348630f, -0.02813669f, 0.16491675f, 
    0.14953367f, -0.01897915f, -0.01197905f, 0.09453120f, -0.16416745f, -0.51555181f, 0.12599036f, 0.13439263f, 
    0.19297062f, 0.02645387f, -0.53147513f, -0.02721165f, 0.15197074f, -0.53055733f, -0.03223442f, -0.09892899f, 
    -0.29510337f, -0.46296513f, 0.08998318f, -0.14442992f, -0.11600415f, -0.01022332f, 0.10700718f, -0.05369816f, 
    -0.33899033f, -0.42081788f, -0.30235240f, 0.12317243f, 0.04769953f, -0.09516609f, -0.09545998f, 0.06548650f, 
    -0.15092920f, -0.06851231f, 0.13044855f, 0.15042281f, 0.03580508f, 0.13491520f, -0.27441189f, -0.16683039f, 
    -0.11724260f, 0.14916299f, -0.09196537f, -0.13729236f, 0.13183852f, -0.07389269f, -0.10405598f, -0.36759084f, 
    -0.11415508f, 0.03352726f, -0.34470415f, 0.24327008f, 0.12643109f, -0.08458577f, 0.14248671f, 0.09020775f, 
    0.16023380f, 0.08058164f, -0.06213399f, -0.01723434f, -0.10632908f, 0.06689028f, -0.20044565f, -0.15189275f, 
    -0.29101780f, 0.02662661f, -0.00343624f, -0.32683408f, 0.14213262f, -0.32872334f, -0.23698239f, -0.16279170f, 
    0.00085501f, -0.10703585f, -0.28617263f, 0.32200363f, -0.01126089f, -0.05269841f, 0.15957932f, 0.10073629f, 
    0.03305977f, 0.23255482f, 0.13115090f, 0.04235204f, -0.14318584f, -0.11232469f, -0.01690467f, 0.04686943f, 
    0.00119656f, -0.12295530f, 0.17528585f, 0.12426260f, 0.14190799f, -0.42758092f, -0.03432969f, 0.04961337f, 
    -0.00937457f, 0.22313742f, 0.06880631f, -0.17568438f, 0.11783020f, 0.04014654f, -0.04872652f, 0.17901517f, 
    0.27399141f, 0.09177351f, 0.15308699f, 0.16680901f, -0.25330704f, -0.16505349f, 0.02447270f, -0.10798738f, 
    -0.09343000f, -0.14398000f, -0.39583609f, -0.03130159f, -0.06329884f, -0.21606597f, -0.18325366f, 0.00975771f, 
    -0.07024214f, -0.33125994f, 0.35805711f, -0.23473048f, 0.00006371f, -0.05550614f, 0.26866904f, 0.14949559f, 
    -0.44702399f, 0.11337262f, 0.17114237f, 0.07714136f, 0.08972811f, -0.15029451f, -0.20925686f, -0.26206180f, 
    0.09723917f, 0.04387468f, -0.06025334f, 0.07022305f, -0.08225111f, 0.05813344f, -0.16117780f, -0.32960334f, 
    -0.45764354f, 0.03266393f, -0.30693701f, -0.07706752f, 0.12560177f, 0.12089377f, 0.00063714f, -0.00222064f, 
    0.28843227f, 0.13673516f, 0.07704800f, -0.47850576f, 0.04881684f, 0.22543328f, -0.09515070f, -0.03096197f, 
    -0.53489125f, 0.00509105f, 0.18527117f, 0.15650417f, -0.30045044f, -0.59354377f, 0.11479581f, 0.17937231f, 
    0.34710354f, -0.91583043f, 0.11303150f, -0.30294776f, -0.19455643f, -0.32702962f, 0.18358171f, -0.07244460f, 
    0.02664110f, -0.30230153f, 0.06050188f, 0.07818039f, -0.59158218f, -0.06242363f, -0.08570439f, 0.06638200f, 
    -0.62392300f, -0.15615116f, -0.19965577f, 0.09741678f, -0.06167786f, 0.11630669f, -0.25551590f, -0.45583683f, 
    0.08163197f, -0.16901426f, 0.20507412f, 0.01449733f, -0.15162101f, 0.04055056f, -0.20352845f, 0.21689598f, 
    -0.67527753f, -0.01317958f, 0.06975111f, 0.00952625f, -0.43104360f, 0.13795860f, 0.22168329f, -0.37546337f, 
    0.17658405f, -0.15065593f, -0.14187154f, 0.07579128f, -0.07169990f, -0.73336262f, -0.08416517f, 0.03993880f, 
    -0.08697823f, 0.16522078f, -0.19168663f, 0.01812346f, 0.10938512f, -0.04325337f, -0.08516812f, -0.15134241f, 
    -0.13196598f, 0.12304997f, -0.44998714f, -0.22024775f, 0.34496012f, 0.05994990f, -0.23540962f, -0.25102970f, 
    -0.36786684f, -0.12734582f, 0.18131158f, -0.23166595f, 0.04661291f, -0.13017425f, 0.05225031f, 0.16736716f, 
    0.01105641f, 0.14263523f, -0.20436637f, 0.31917575f, -0.55926102f, -0.00081599f, -0.05651699f, 0.19218923f, 
    -0.04277105f, 0.00153021f, -0.25141829f, 0.22188264f, -0.18829714f, -0.05514764f, -0.39685765f, -0.12065345f, 
    0.34065026f, -0.43973595f, -0.56599200f, 0.12553807f, -0.13708529f, -0.08818901f, -0.09434188f, -0.01822869f, 
    0.02075108f, 0.03248358f, -0.48000428f, 0.12165798f, -0.47319824f, -0.03835598f, 0.28226990f, 0.28576431f, 
    0.28098670f, 0.11016811f, -0.57446152f, 0.00973771f, -0.26453114f, -0.12037862f, -0.05643523f, -0.06389309f, 
    0.33622488f, 0.11705840f, 0.24541990f, -0.08275597f, 0.04984418f, -0.14779402f, 0.01922546f, 0.22317372f, 
    0.17712727f, -0.20931555f, -0.32282653f, 0.18343726f, -0.17841974f, -0.23649696f, -0.32330978f, -0.07676338f, 
    0.15978551f, -0.55236822f, -0.09854306f, -0.13410351f, -0.16925856f, -0.16639853f, -0.31044152f, -0.00577616f, 
    -0.02163715f, -0.22900513f, -0.02200966f, -0.46327895f, -0.33340886f, -0.20659824f, -0.27986637f, -0.21565308f, 
    -0.49123710f, -0.24698702f, 0.16659647f, -0.08957823f, 0.22398056f, 0.07597792f, 0.14276917f, 0.32032600f, 
    0.40654215f, -0.23164128f, -0.30721128f, 0.25655928f, 0.17558771f, -0.25202897f, -0.02731467f, 0.13114211f, 
    0.16597818f, -0.07466054f, -0.05177891f, -0.10842508f, -0.15954439f, -0.35046831f, -0.23320195f, -0.01558388f, 
    -0.46924829f, -0.14471558f, -0.22063762f, -0.07659181f, -0.16422975f, -0.05463782f, -0.04272411f, 0.10985265f, 
    -0.04292658f, -0.14037223f, -0.24262790f, -0.08570223f, 0.15076120f, 0.10170899f, 0.07399870f, -0.51090139f, 
    -0.21058400f, -0.29989013f, 0.15482838f, 0.21245363f, 0.21375950f, 0.23979644f, -0.14309293f, -0.27273649f, 
    -0.41098189f, 0.03568635f, 0.06474672f, -0.13024931f, -0.77138525f, -0.51496154f, 0.00218114f, -0.03393881f, 
    -0.11418553f, -0.34559941f, -0.01763519f, 0.00348605f, 0.13272581f, 0.11995954f, 0.10097320f, 0.02712883f, 
    0.38314211f, -0.26599947f, 0.14456584f, 0.08625158f, 0.29708189f, 0.10584795f, -0.10416128f, -0.03463047f, 
    -0.07129107f, -0.13076016f, 0.00774604f, 0.19156326f, -0.46802270f, -0.57702833f, -0.41333771f, -0.08440804f, 
    -0.43804780f, -0.12719396f, -0.17866606f, 0.16198581f, 0.04589552f, -0.46530080f, 0.16548397f, -0.11458607f, 
    -0.18882248f, 0.02674718f, -0.25675675f, 0.05049210f, -0.33646220f, 0.20399441f, -0.09583223f, -0.06036919f, 
    0.10801975f, -0.15129843f, 0.19678774f, -0.16004558f, -0.28473520f, -0.12116300f, -0.22116996f, -0.19330317f, 
    -0.19597770f, 0.14159948f, 0.04350666f, 0.05865069f, -0.22687259f, -0.53930140f, -0.72941250f, 0.04845497f, 
    0.15056147f, -0.42258471f, -0.12878814f, 0.27595496f, 0.32662019f, 0.35326198f, 0.02812390f, 0.24985477f, 
    0.15462177f, -0.14475624f, 0.01087889f, 0.25669032f, 0.07975917f, -0.06174247f, -0.38721970f, -0.36664250f, 
    -0.51825398f, 0.13753381f, -0.66747683f, -0.08749206f, 0.17514962f, -0.15244243f, -0.41858807f, 0.11840004f, 
    -0.03026001f, 0.29904541f, 0.02803535f, 0.06729878f, 0.13672273f, -0.74062133f, -0.10555406f, -0.05860575f, 
    0.17233720f, -0.01906687f, -0.36924657f, -0.18686019f, 0.05435840f, -0.50954831f, -0.29676250f, -0.04098222f, 
    -0.14153530f, 0.00625790f, -0.11525336f, -0.05322872f, 0.02539805f, 0.28608280f, 0.05293482f, -0.10627972f, 
    0.04468645f, -0.05206997f, 0.09162944f, -0.05557162f, -0.31983924f, 0.25035608f, 0.00162859f, 0.22964554f, 
    -0.04851959f, -0.44754428f, -0.33157173f, 0.25871226f, -0.51857722f, -0.13392206f, -0.20776013f, 0.18258293f, 
    0.10154930f, -0.16109861f, 0.00662635f, -0.39567956f, -0.06141366f, -0.13477644f, 0.15165831f, -0.16149810f, 
    -0.08563001f, -0.30778372f, 0.27866438f, -0.23230317f, 0.08107474f, -0.31192589f, -0.09015346f, -0.11529696f, 
    0.21131441f, -0.35622281f, 0.19976565f, -0.24511527f, -0.00132193f, 0.06348418f, -0.13522592f, 0.05586704f, 
    -0.00482912f, -0.44163200f, -0.07617172f, -0.05411426f, -0.15506276f, -0.37962097f, 0.39812115f, 0.04656093f, 
    -0.07962050f, 0.03718205f, -0.18302570f, 0.21597376f, 0.33233470f, -0.23065008f, -0.08530983f, 0.04726155f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.10028245f, 0.16242373f, 0.03213859f, -0.04480560f, 0.02961075f, 0.04793863f, 0.13833746f, -0.08480813f, 
    0.09718826f, 0.11719716f, -0.09294575f, 0.04282184f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
