#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.47531256f, -0.13415660f, -0.45461109f, -0.19355068f, -0.26614395f, 0.15676379f, -0.31168261f, 0.22340316f, 
    0.44691271f, -0.54690170f, 0.08169731f, -0.11839353f, -0.21149942f, -0.01516633f, 0.21808551f, 0.13113473f, 
    0.03930556f, -0.46907729f, -0.17787865f, 0.04222959f, -0.34446204f, 0.15517746f, 0.33716902f, 0.13543686f, 
    -0.02995432f, 0.66356903f, 0.56322360f, 0.60895580f, -0.46840388f, -0.69386822f, -0.28778934f, 0.29295108f, 
    -0.44253117f, -0.31848553f, 0.23542996f, 0.26730487f, 0.35271060f, -0.25523975f, 0.08998951f, 0.04245219f, 
    -0.02102580f, -0.10022450f, 0.13143931f, -0.19794087f, -0.07418106f, 0.18254006f, 0.19272660f, -0.14992288f, 
    -0.19327371f, 0.21224947f, 0.11900352f, -0.36448017f, -0.62973958f, -0.42153963f, 0.24508530f, 0.40405959f, 
    -0.55229402f, 0.19073755f, 0.46820462f, -0.02002505f, -0.20349988f, -0.10329608f, 0.04786800f, -0.02970209f, 
    -0.38393152f, -0.11066899f, 0.11202441f, 0.29621202f, 0.07821435f, -0.01315644f, 0.11140683f, 0.03145644f, 
    0.10502801f, 0.01394597f, -0.06641357f, 0.74837965f, 0.27705181f, -0.46539155f, 0.23949870f, -0.11820859f, 
    0.17799638f, 0.36941019f, 0.11295819f, 0.00096958f, 0.28717655f, 0.10567117f, 0.22560604f, 0.13653824f, 
    0.12160106f, 0.04999543f, 0.06015458f, -0.24648412f, -0.01206297f, -0.14187424f, -0.14988950f, -0.09723876f, 
    -0.17171580f, -0.03836125f, 0.31485334f, -0.06260361f, -0.47003508f, -1.04859591f, -0.49001199f, 0.12455986f, 
    0.14200108f, -0.39596909f, 0.30997923f, -0.44328052f, 0.01068576f, 0.19837596f, 0.27790025f, 0.13398799f, 
    0.09286139f, 0.20879751f, 0.18150061f, 0.11004154f, -0.02926652f, 0.14012317f, 0.22056219f, -0.17014901f, 
    0.06941850f, 0.11383228f, -0.21759857f, 0.09860761f, -0.05457022f, -0.12166143f, 0.80741984f, 0.14736398f, 
    -0.22343233f, 0.65912217f, -0.40019351f, 0.51899362f, 0.62556845f, -0.38591519f, 0.14568244f, -0.17511202f, 
    0.17070055f, 0.08291897f, 0.02555208f, 0.05451235f, 0.25007120f, -0.18603373f, -0.02509119f, 0.25656959f, 
    0.12361330f, -0.21095993f, -0.02200616f, 0.07298798f, -0.01159357f, -0.05591923f, -0.40316579f, 0.67370099f, 
    0.60867262f, 0.38042495f, -0.15594576f, -0.29966924f, 0.30827010f, -0.20877095f, 0.37140185f, -0.12099754f, 
    -0.22863711f, -0.23403460f, 0.06054267f, -0.04432696f, 0.07037099f, 0.21268837f, 0.12721863f, 0.19083337f, 
    0.12893255f, -0.06885712f, 0.44881189f, 0.21462668f, -0.28790635f, -0.06465977f, 0.26239762f, 0.21573901f, 
    -0.13905007f, -0.58741790f, -0.71734345f, -0.51963019f, 0.36890814f, 0.25950769f, -0.20024766f, -0.25264296f, 
    0.26477724f, -0.15710762f, -0.32181543f, -0.23950841f, -0.21742271f, -0.11744947f, -0.28696796f, 0.19464411f, 
    0.07891097f, 0.08822279f, 0.13124111f, -0.18459624f, -0.18100494f, -0.32334858f, -0.11319284f, 0.17126699f, 
    -0.29551467f, 0.59194791f, 0.64349598f, 0.61091650f, -0.04471388f, -0.00256504f, 0.02091078f, -0.21955508f, 
    0.30845648f, -0.20965624f, 0.16643062f, -0.25244993f, 0.16144261f, 0.25862014f, -0.10595642f, -0.32860216f, 
    -0.11395150f, -0.16032700f, -0.40985131f, -0.11369028f, -0.31157038f, 0.00812369f, -0.10509287f, 0.27904403f, 
    0.12625104f, -0.19818349f, 0.18919893f, 0.46951497f, -0.50449479f, -0.16468088f, -0.22745210f, 0.07429776f, 
    0.06864692f, -0.09179096f, -0.52605182f, -0.11160395f, -0.05944733f, -0.44328982f, -0.22016363f, -0.39273599f, 
    0.15235487f, -0.31182462f, 0.38916916f, 0.27721003f, -0.16802543f, -0.35633722f, -0.09665305f, -0.28974810f, 
    -0.30571684f, -0.12429352f, 0.44366670f, -0.60271209f, -0.68094361f, 0.40060663f, 0.04823212f, -0.69309479f, 
    -0.53030163f, 0.04474519f, -0.06428175f, 0.09247638f, 0.07839130f, 0.12545791f, -0.01081678f, 0.05506475f, 
    0.04113300f, -0.11496344f, 0.20411769f, -0.14547177f, -0.17967026f, -0.07259277f, 0.09882050f, -0.08704803f, 
    0.24347620f, 0.25558746f, -0.07841491f, 0.00494679f, 0.23879220f, 0.47717515f, 0.54399353f, -0.08467562f, 
    -0.11523260f, 0.33392334f, -0.24211605f, -0.06290777f, 0.22208621f, 0.10326047f, 0.39553711f, -0.31048986f, 
    -0.05445110f, 0.11737559f, -0.06034946f, -0.41825995f, -0.02901699f, 0.18719570f, 0.21739832f, 0.27921781f, 
    0.23493828f, 0.38470733f, -0.13231711f, -0.23017262f, -0.65606362f, 0.12978315f, -0.46868828f, -0.40116364f, 
    -0.03373515f, 0.44028541f, -0.13950202f, -0.60046035f, -0.03566112f, -0.11780312f, 0.15439841f, 0.06146764f, 
    0.47568628f, 0.02848617f, -0.10372234f, -0.38956246f, -0.08349688f, 0.32020369f, -0.29164642f, -0.25547916f, 
    0.23829237f, -0.27880201f, -0.13629267f, 0.00970444f, -0.16657491f, -0.58762711f, -0.28298864f, 0.57444465f, 
    -0.33595735f, -0.50592625f, -0.10199499f, -0.21994211f, -0.35765532f, 0.07129083f, 0.17952669f, 0.20923607f, 
    -0.02154421f, -0.17556569f, -0.31063721f, -0.07084329f, -0.07511141f, 0.16199759f, -0.13157752f, -0.15277314f, 
    0.15462331f, 0.11045906f, 0.23164091f, 0.11773051f, 0.10271781f, -0.08986672f, 0.39451522f, 0.14724818f, 
    0.34272349f, 0.48724782f, 0.43893224f, 0.42781901f, 0.41488612f, -0.02212392f, 0.18257739f, 0.11728887f, 
    -0.06315799f, -0.08414730f, -0.33661839f, -0.23869237f, -0.36011037f, -0.23611943f, -0.25954714f, -0.12663770f, 
    -0.15797214f, -0.47056276f, 0.07453243f, 0.20748539f, -0.02792284f, -0.03421476f, 0.15815510f, 0.80867261f, 
    -0.01779917f, -0.04053652f, 0.57512975f, -0.28575620f, -0.02264501f, 0.31918395f, -0.08018717f, -0.14464249f, 
    0.18840617f, -0.23176810f, -0.21982834f, -0.11422618f, -0.42065865f, -0.21336488f, -0.18745844f, -0.10360803f, 
    -0.22334352f, -0.19612020f, 0.07113008f, -0.18883039f, 0.16153437f, 0.04347980f, -0.07073017f, -0.13423344f, 
    0.67362869f, 0.64763939f, 0.44852954f, 0.26567987f, -0.57283616f, -0.16580991f, -0.44558603f, 0.00379894f, 
    0.34315139f, 0.46631268f, 0.31213549f, 0.03025776f, -0.36451027f, -0.00215073f, -0.02124170f, 0.09947889f, 
    0.16661233f, 0.10862837f, -0.05796477f, 0.19252557f, -0.00682604f, 0.00002595f, 0.30676615f, -0.03754753f, 
    -0.30515784f, 0.53298515f, 0.83087909f, 0.47728392f, 0.41033670f, 0.45928729f, 0.31769314f, -0.16148384f, 
    -0.55379486f, -0.12849204f, -0.22393017f, -0.16315280f, 0.03043539f, -0.02675017f, 0.49224377f, -0.26153162f, 
    -0.07375431f, -0.04240787f, 0.35933381f, 0.17618985f, 0.02243786f, -0.02672180f, -0.13387050f, -0.30321926f, 
    -0.14055268f, -0.20900844f, 0.41504556f, 0.48669943f, -0.46229854f, -0.72678530f, -0.06759586f, 0.19379428f, 
    0.04134303f, 0.07721815f, -0.03674325f, 0.31581491f, -0.06216782f, 0.15154842f, 0.08519866f, -0.23759174f, 
    0.12874879f, 0.32535619f, -0.31796548f, -0.26565436f, 0.14806151f, 0.31815165f, 0.33378631f, -0.13452981f, 
    0.03327138f, -0.26283810f, -0.40323579f, -0.11712442f, -0.10000727f, 0.39995363f, 0.48683575f, 0.66019124f, 
    -0.63415110f, -0.44083109f, -0.37864318f, -0.20706615f, -0.38500357f, 0.31255969f, 0.25542203f, -0.13964479f, 
    0.07318388f, 0.01517844f, -0.58415091f, 0.18193750f, -0.07009027f, -0.18594930f, 0.12204158f, -0.18266723f, 
    -0.06157319f, -0.25300732f, 0.08471621f, -0.08443907f, 0.16556251f, 0.20419748f, -0.34213841f, 0.27921388f, 
    -0.20060325f, -0.41295275f, -0.60076708f, 0.34782869f, 0.43547148f, -0.39144760f, -0.45391282f, -0.24124275f, 
    0.43704423f, -0.05327885f, -0.28818130f, 0.19055501f, -0.25999469f, -0.00702135f, -0.07279910f, 0.27709404f, 
    0.01378989f, 0.08620598f, 0.01770349f, -0.17398074f, -0.23331572f, 0.89019614f, -0.56561583f, 0.41024378f, 
    -0.23338780f, -0.01897797f, -0.30149332f, -0.27541438f, -0.23853438f, -0.12430321f, -0.58353251f, 0.12881495f, 
    0.11039061f, 0.13732922f, 0.01448119f, -0.02595782f, -0.18123336f, -0.07429343f, 0.06444831f, 0.08928685f, 
    0.07343853f, 0.10168578f, 0.30394837f, 0.00472772f, 0.11259529f, 0.22003931f, -0.46181715f, 0.20333873f, 
    -0.31652737f, -0.34092516f, 0.00237705f, -0.06126750f, -0.45580134f, -0.44804585f, -0.17460366f, -0.25732216f, 
    0.06696871f, 0.30482572f, 0.11044337f, -0.07828374f, -0.12187916f, 0.23331913f, 0.09726549f, 0.20366946f, 
    0.17022598f, -0.06886636f, -0.00169683f, 0.31165731f, 0.30094948f, -0.23841849f, 0.07862715f, -0.26647964f, 
    0.05231772f, 0.06106944f, 0.27082619f, 0.56321907f, -0.27823752f, -0.79052120f, -0.44856066f, -0.35881609f, 
    -0.00018405f, -0.30977696f, -0.03262881f, 0.43790740f, 0.33419448f, -0.04817975f, 0.26696005f, 0.05781563f, 
    -0.03011547f, 0.14149043f, -0.04039768f, -0.13927627f, 0.13786396f, 0.09742985f, -0.02867288f, -0.23898856f, 
    -1.01182139f, 0.06714181f, 0.19314702f, -0.20853981f, -0.41598839f, 0.30002290f, 0.32769781f, 0.20733592f, 
    0.10021693f, -0.10764700f, -0.24915636f, 0.22108403f, 0.06502593f, 0.01420891f, 0.22193834f, -0.05660262f, 
    0.12792841f, -0.01628830f, -0.10698382f, -0.22807725f, -0.00628522f, 0.04623824f, 0.11728698f, -0.07365437f, 
    0.01415956f, -0.22934213f, -0.62858927f, 0.69753504f, 0.54320371f, 0.11047930f, 0.25499979f, -0.15184017f, 
    0.42910299f, 0.21255989f, -0.29930496f, -0.00952604f, -0.31354105f, -0.29674706f, 0.03180479f, -0.20001337f, 
    0.23600014f, 0.13400528f, -0.25735450f, 0.31078950f, -0.01063358f, -0.36062953f, -0.20325927f, -0.04588189f, 
    0.07937804f, -0.28826082f, -0.40822628f, -0.47989818f, -0.14431854f, 0.17371997f, -0.00355290f, -0.43770084f, 
    0.74197870f, 0.20796683f, -0.54582274f, 0.38883632f, -0.03180527f, 0.25348103f, -0.06518859f, -0.10765078f, 
    -0.03900842f, -0.55949640f, -0.06155225f, 0.01382502f, -0.08530753f, -0.36768520f, 0.25265276f, 0.00209532f, 
    0.19053140f, -0.23547179f, -0.12339124f, 0.89136523f, 0.57922393f, 0.23210105f, 0.42324653f, 0.84205872f, 
    0.01401019f, -0.27489999f, -0.32971814f, 0.09124862f, 0.02222298f, 0.06925276f, 0.32693180f, -0.07520146f, 
    -0.11472394f, 0.03868767f, 0.33082530f, -0.11609074f, -0.07246593f, 0.05972267f, 0.11730576f, 0.30354363f, 
    -0.04568746f, 0.17937571f, -0.16957495f, 0.44626728f, -0.95744771f, -0.20052935f, -0.46448821f, -0.30470172f, 
    -0.17077014f, 0.56851155f, 0.65852571f, 0.28063676f, 0.53365231f, 0.54925144f, 0.15042493f, -0.28110442f, 
    0.25929129f, -0.02178269f, 0.39059156f, 0.02769093f, -0.05655532f, -0.05754863f, 0.09760369f, 0.01689352f, 
    -0.10006324f, -0.11423028f, 0.02209037f, 0.02161871f, 0.02632945f, -0.44608110f, -0.72456086f, -0.64278144f, 
    -0.34567413f, -0.15524340f, 0.05496959f, 0.20983003f, 0.12800407f, 0.12210827f, 0.24321903f, -0.24471429f, 
    0.05498897f, -0.23517342f, -0.18282573f, -0.40717837f, -0.06730630f, 0.24292813f, 0.04802029f, -0.05726448f, 
    0.07111318f, -0.16953707f, -0.01822979f, -0.17237358f, 0.12950334f, 0.15937674f, -0.23994105f, 0.40190551f, 
    -0.32798606f, 0.20265675f, -0.50062948f, -0.08142325f, -0.28297719f, 0.02808184f, -0.14122275f, -0.22195283f, 
    -0.22481257f, 0.26311481f, -0.43332005f, -0.07513817f, -0.24540266f, -0.00955247f, 0.11310066f, -0.18261752f, 
    0.28573847f, 0.20330158f, -0.27280611f, -0.33631963f, -0.28018308f, -0.09040044f, -0.03274575f, -0.33628336f, 
    -0.19954015f, -0.07563709f, 0.17996611f, 0.29416764f, -0.21658801f, 0.60343367f, 0.57092208f, -0.16129507f, 
    0.49223199f, 0.23172054f, 0.05006514f, 0.26603222f, -0.32749298f, 0.16011876f, -0.18683261f, 0.14933026f, 
    -0.21327507f, 0.05680668f, -0.11466405f, -0.04137339f, 0.07134542f, 0.12810937f, 0.20982587f, 0.39189523f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.04171059f, 0.09254715f, 0.08014333f, 0.24409917f, 0.07598979f, 0.12987131f, 0.32873011f, -0.04156694f, 
    0.03296384f, 0.02175547f, 0.25807324f, 0.13152780f, 0.18133454f, 0.08833759f, 0.12800398f, 0.04826559f, 
    0.29083565f, 0.04165182f, 0.05102171f, 0.09246083f, -0.05325978f, 0.07564532f, 0.06423724f, 0.27291781f, 
    -0.06841786f, 0.03831241f, 0.10050312f, 0.20395704f, -0.13168968f, -0.21094352f, 0.02386079f, 0.17393056f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.32235906f, -0.06731401f, -0.08414462f, -0.03329223f, -0.03861560f, -0.02142087f, 0.10842223f, 0.13630164f, 
    0.06884808f, 0.04217798f, -0.01309952f, -0.08076504f, 0.09411650f, 0.17224085f, -0.07973053f, -0.29975823f, 
    0.02751682f, 0.09472688f, -0.01932577f, 0.02182893f, -0.09952220f, 0.03414023f, 0.01068852f, 0.06097921f, 
    -0.02897288f, -0.01531546f, 0.15757395f, -0.13632104f, 0.01169399f, 0.07099897f, 0.02721821f, 0.08652056f, 
    0.04747293f, 0.03664402f, 0.04483423f, 0.09063857f, 0.28709200f, 0.23661205f, -0.00455427f, -0.02737563f, 
    -0.08914653f, 0.08620582f, -0.00828829f, -0.05814480f, -0.03550021f, 0.08669921f, 0.08941457f, -0.01062901f, 
    -0.28866777f, -0.04665078f, -0.04957864f, 0.11440492f, 0.05921435f, -0.08574720f, 0.06828520f, 0.07071960f, 
    0.10229338f, 0.10718066f, 0.03983641f, 0.04522468f, 0.34314331f, -0.06700183f, 0.11109147f, -0.09606438f, 
    0.09745613f, 0.08212283f, 0.06468900f, -0.04542265f, 0.16820398f, 0.02326513f, 0.05881561f, 0.15174663f, 
    0.21111473f, -0.10866234f, 0.19491655f, 0.22860384f, -0.03891410f, -0.10662233f, 0.11844140f, 0.02163959f, 
    0.12590264f, 0.11415267f, -0.04100078f, -0.06824004f, -0.00304226f, 0.08389802f, 0.12775685f, -0.36637655f, 
    0.17330797f, 0.06676766f, -0.04514695f, 0.18360958f, 0.04793270f, 0.01402646f, -0.02096710f, 0.03841468f, 
    -0.06168150f, -0.02585611f, 0.11403503f, 0.24829942f, -0.06133343f, -0.00901474f, 0.01382428f, 0.03203620f, 
    -0.12661941f, -0.06588092f, 0.13145091f, -0.06447631f, 0.00402172f, -0.08411745f, -0.03842866f, -0.10639415f, 
    0.07431623f, -0.09416992f, -0.08856205f, 0.16036507f, -0.04355660f, 0.03973159f, 0.05509978f, 0.03974959f, 
    -0.39298901f, -0.16308582f, 0.24532224f, 0.23950940f, -0.10407184f, -0.14364296f, 0.00242703f, 0.01051997f, 
    -0.14049636f, 0.03960511f, 0.00681915f, 0.06555163f, -0.13305876f, -0.03635051f, 0.16053706f, 0.24887638f, 
    -0.03477278f, -0.03231790f, 0.07828216f, -0.00478233f, 0.04959150f, 0.03103758f, -0.15047596f, -0.00155532f, 
    -0.29634124f, -0.20321502f, 0.13472170f, -0.16418377f, 0.07644080f, 0.07317787f, 0.16017596f, -0.00710204f, 
    0.06729904f, -0.09411614f, 0.08583325f, -0.01783900f, -0.30275917f, -0.28570753f, -0.06902548f, -0.08181424f, 
    0.02708114f, -0.20697145f, 0.01141850f, 0.04728328f, 0.03893071f, 0.10193556f, -0.02128411f, 0.01347511f, 
    0.06421319f, 0.30790105f, 0.16475894f, 0.34340233f, 0.00457999f, -0.03922958f, 0.03817418f, 0.01383050f, 
    -0.09264860f, 0.05757219f, -0.06772079f, -0.03065864f, 0.23740348f, 0.21564589f, -0.10540151f, 0.38035122f, 
    -0.15601844f, -0.07525098f, 0.01755514f, -0.04115476f, -0.11064702f, 0.04355673f, 0.03465454f, -0.07018459f, 
    0.19665587f, 0.05786026f, -0.02656772f, 0.07727610f, -0.12504694f, -0.00577178f, 0.01904653f, 0.03085817f, 
    0.03388542f, 0.01775042f, -0.04798149f, -0.08189308f, 0.15599144f, 0.19062842f, 0.11932518f, 0.00253898f, 
    -0.05147172f, -0.00425906f, -0.02179273f, 0.06644944f, -0.06790922f, -0.01764145f, 0.12696865f, 0.02702256f, 
    0.19192563f, 0.19427148f, 0.13246413f, -0.30211183f, 0.01392181f, -0.00101728f, 0.09865989f, -0.09261072f, 
    -0.01483564f, 0.09626446f, 0.08653041f, -0.01396028f, -0.21905699f, -0.06428277f, -0.00000054f, -0.02227560f, 
    -0.08397065f, -0.09885423f, 0.05408652f, -0.00378959f, 0.03027687f, 0.03494625f, 0.13576831f, 0.05569521f, 
    0.02834873f, -0.28113574f, -0.02440137f, 0.07729858f, 0.01952499f, -0.09788753f, -0.07913805f, 0.04454322f, 
    -0.03995700f, 0.00568360f, 0.11084408f, -0.00631679f, 0.41383803f, -0.15162630f, -0.08388760f, -0.09495138f, 
    -0.13294190f, 0.04252334f, -0.13094315f, -0.07521467f, 0.01070245f, -0.01456086f, 0.03230690f, 0.03111130f, 
    -0.24219546f, -0.12389845f, 0.02643518f, -0.11497735f, -0.01161027f, 0.05138726f, 0.06579436f, 0.07169235f, 
    0.22121957f, 0.07693078f, 0.03802107f, 0.01843883f, -0.03238996f, -0.04373904f, 0.07032964f, -0.24700800f, 
    -0.06934563f, -0.13176511f, 0.08178999f, 0.00542696f, 0.00040020f, -0.00567417f, -0.02901675f, 0.01857276f, 
    -0.13130242f, -0.18737240f, 0.17349234f, 0.07369850f, 0.24111207f, 0.09968062f, 0.05450953f, -0.08316500f, 
    0.13329975f, 0.02153111f, 0.00971082f, 0.15786119f, 0.16415370f, 0.09332774f, -0.01070260f, 0.32095540f, 
    0.11473749f, -0.13686338f, 0.10528072f, -0.12216412f, 0.04539678f, 0.06493533f, 0.12342945f, 0.01051605f, 
    -0.29784983f, -0.14592960f, -0.10754106f, 0.07406541f, 0.05968690f, 0.01150296f, 0.00018558f, 0.12056170f, 
    0.14233430f, -0.01795580f, -0.00320428f, -0.02636890f, -0.04561601f, 0.13924900f, 0.34878930f, 0.01129881f, 
    -0.05688599f, 0.07536245f, -0.07283357f, 0.06455884f, 0.00060763f, -0.06754354f, 0.01036457f, 0.00999390f, 
    0.03053809f, -0.09266624f, 0.01966873f, -0.01406000f, 0.07160839f, 0.08044086f, 0.00091505f, -0.10944783f, 
    0.09878816f, 0.02790143f, 0.06317132f, 0.06895301f, -0.10310653f, -0.04782394f, -0.05948132f, -0.24114554f, 
    0.26775014f, 0.14718205f, -0.07051574f, 0.08482754f, 0.14055477f, 0.00985050f, -0.03238194f, 0.19165815f, 
    -0.27208966f, -0.13861611f, -0.14088419f, -0.20783694f, 0.02719854f, -0.03876896f, -0.10775903f, -0.14978462f, 
    0.01921729f, 0.10606792f, -0.03555059f, 0.05595064f, 0.01535077f, 0.03802336f, -0.05542823f, -0.01264683f, 
    0.09904920f, 0.03824902f, -0.03480448f, -0.05440734f, 0.01491974f, -0.09636535f, 0.03385700f, 0.05643713f, 
    -0.00067875f, 0.09423822f, 0.08758685f, 0.11550953f, 0.07293800f, 0.09140506f, 0.14666267f, 0.04510845f, 
    0.01171589f, 0.15994813f, -0.05124229f, 0.03200476f, -0.05560500f, -0.06799194f, -0.12756960f, 0.02623259f, 
    0.01946769f, -0.00296732f, 0.01216822f, 0.07221761f, -0.04945705f, 0.02886080f, -0.01397663f, 0.02217980f, 
    0.09555028f, -0.12728412f, -0.03601046f, -0.01121574f, 0.00107710f, -0.01036622f, -0.03939298f, 0.12738490f, 
    0.11053099f, -0.01212854f, 0.05748101f, 0.08864725f, 0.06224181f, 0.09645378f, 0.12606528f, -0.09612294f, 
    0.04735073f, -0.01877229f, 0.14397343f, -0.05293597f, 0.08995067f, -0.11657856f, 0.03177376f, 0.06377922f, 
    -0.00237962f, 0.01908918f, 0.00312628f, 0.07968715f, -0.01484029f, -0.02801993f, -0.02297195f, 0.05820394f, 
    -0.02198902f, 0.10725345f, 0.17225643f, 0.11133534f, 0.17767796f, -0.02633964f, 0.10418610f, -0.04254008f, 
    0.04074749f, 0.02139516f, -0.02449864f, -0.11611770f, -0.00992420f, 0.19234769f, 0.02197592f, 0.22989987f, 
    -0.19034272f, -0.06096535f, -0.03302284f, 0.02306755f, 0.07333127f, 0.04781675f, -0.01440025f, 0.13740149f, 
    0.14576486f, 0.01480901f, 0.17820928f, 0.07698404f, 0.13612716f, 0.10031445f, -0.04095714f, 0.06381080f, 
    0.09541427f, 0.04216820f, -0.12226754f, 0.01429359f, 0.00216726f, -0.02143165f, -0.02909778f, 0.00881711f, 
    -0.34814665f, -0.01193853f, 0.07006346f, 0.08679120f, 0.01772758f, 0.05731344f, 0.04103858f, -0.04306898f, 
    -0.17033625f, -0.04346077f, -0.12808870f, -0.08776424f, 0.08317947f, 0.02552242f, 0.10707308f, 0.15202683f, 
    0.05685127f, 0.10249678f, -0.06868319f, 0.06264737f, -0.02050855f, -0.05750012f, -0.03376166f, 0.09862491f, 
    0.05984048f, -0.08617247f, 0.10865472f, 0.03598168f, 0.05033333f, 0.08202173f, -0.01384089f, 0.04949336f, 
    0.07183251f, -0.03907316f, -0.07971150f, 0.12801713f, -0.10933963f, 0.07332263f, 0.04224462f, -0.05780610f, 
    -0.06512040f, -0.08604246f, 0.07528675f, 0.04800634f, -0.01244017f, 0.06259945f, -0.04355123f, 0.08512074f, 
    -0.24602038f, 0.20796894f, 0.04967644f, 0.05270125f, 0.04830301f, 0.00322245f, 0.10420083f, 0.07808615f, 
    -0.03376209f, -0.04224402f, 0.14706692f, -0.09636640f, -0.13024975f, 0.11279909f, 0.14075404f, 0.40861604f, 
    0.06963895f, -0.01200809f, 0.09945242f, -0.00880012f, 0.07226008f, 0.01610371f, -0.08407969f, 0.04702355f, 
    -0.07412759f, 0.01359799f, 0.09679163f, 0.08703376f, 0.00516476f, 0.07876068f, -0.01238472f, 0.03844788f, 
    0.11900326f, -0.04788721f, -0.06075459f, -0.14037605f, 0.19153933f, -0.09160520f, 0.03771736f, 0.09132116f, 
    -0.10091662f, -0.01089455f, 0.17401384f, 0.03757531f, 0.09596922f, 0.05195419f, -0.15921432f, -0.14395611f, 
    0.05471339f, -0.01446822f, -0.01143059f, 0.06274231f, 0.08899632f, -0.04618521f, -0.03937355f, 0.00320450f, 
    0.05184731f, 0.06626354f, -0.01596946f, 0.05770104f, -0.12739916f, -0.10147625f, 0.05988713f, 0.11266892f, 
    0.14525098f, -0.00115080f, 0.04567443f, 0.01434614f, -0.15139292f, -0.06769062f, 0.15126067f, 0.02939386f, 
    0.04685066f, -0.05930935f, 0.10717129f, -0.01097510f, 0.00256792f, -0.16170381f, -0.14245591f, -0.03217712f, 
    -0.00929485f, 0.16013451f, -0.10789590f, 0.00693514f, 0.00469526f, -0.06193103f, 0.07726821f, -0.00118028f, 
    0.12235069f, 0.03777610f, -0.04443806f, 0.08558280f, -0.11251955f, -0.06051500f, 0.02906079f, 0.01116021f, 
    0.19210450f, -0.09124313f, -0.06449702f, 0.00074270f, 0.06040162f, -0.17656793f, 0.11355623f, -0.08826489f, 
    -0.03924894f, -0.02653189f, -0.10635839f, 0.06657296f, 0.09532534f, -0.12893029f, 0.19797641f, 0.28221926f, 
    -0.06650042f, 0.01203228f, -0.00378269f, 0.06040357f, 0.03494028f, 0.01160601f, -0.00204375f, 0.16359383f, 
    0.16319779f, 0.20540540f, -0.03042573f, 0.07466238f, 0.08540946f, 0.02548798f, 0.03677206f, 0.12272495f, 
    0.07102186f, 0.11698750f, 0.11537010f, 0.12173613f, 0.22987922f, -0.09372257f, -0.06261912f, 0.03928778f, 
    0.05712081f, -0.05703560f, 0.05583894f, 0.02438089f, 0.00508824f, 0.07291323f, 0.10927808f, 0.14803961f, 
    -0.28977600f, -0.03756041f, -0.03148153f, 0.04497141f, 0.01099736f, -0.03530272f, 0.04806285f, -0.04807869f, 
    0.06390156f, 0.00290702f, -0.00289516f, 0.02908501f, -0.07909190f, 0.20978704f, 0.03596655f, -0.05845997f, 
    0.11169957f, 0.08667006f, -0.00376830f, -0.10344607f, -0.03518836f, 0.02864113f, -0.12138803f, 0.00837468f, 
    0.08518068f, -0.00949416f, -0.06504009f, -0.01010519f, -0.06585659f, -0.00766028f, 0.05729400f, 0.08435743f, 
    0.02755038f, 0.01399065f, -0.05146258f, -0.19907048f, -0.01074322f, -0.03779230f, 0.02283969f, 0.03912047f, 
    0.02181168f, 0.01224604f, 0.02524157f, 0.00785521f, -0.02519983f, 0.03225647f, -0.08162916f, 0.22884639f, 
    -0.30835244f, 0.23336695f, -0.09988476f, -0.13725570f, 0.05151346f, -0.14152244f, 0.14441621f, -0.13440727f, 
    0.04728144f, 0.08102578f, -0.02502893f, -0.00774726f, 0.33345672f, 0.24975294f, -0.01484887f, 0.17461355f, 
    0.10443616f, 0.14025228f, 0.15636204f, -0.04321751f, 0.09036499f, 0.05788407f, -0.04977774f, -0.03705597f, 
    -0.03938701f, -0.04347457f, -0.17224681f, 0.06405932f, 0.08533175f, 0.06527885f, -0.06594104f, -0.07274069f, 
    -0.00901841f, 0.10288621f, -0.05059573f, 0.09036263f, 0.06848784f, 0.02722932f, -0.05362873f, -0.13689183f, 
    -0.03769970f, 0.08646721f, 0.04439072f, 0.04028619f, -0.04507828f, 0.07681724f, 0.00885634f, 0.01024988f, 
    0.26682982f, 0.01197274f, 0.09221850f, 0.18506725f, 0.11196785f, 0.16695821f, 0.05554035f, 0.22648856f, 
    -0.05212882f, -0.03435348f, -0.02089341f, -0.06101198f, -0.46137494f, -0.12067800f, 0.40949962f, -0.05970468f, 
    0.00679853f, -0.00436494f, -0.03826373f, -0.06451447f, -0.05129831f, 0.04105949f, 0.00611315f, 0.05651409f, 
    0.27065456f, 0.17605811f, -0.15285744f, 0.23563433f, 0.07239871f, 0.16280486f, 0.13210131f, 0.06451674f, 
    0.02917811f, 0.04879812f, -0.01803188f, 0.05298555f, -0.15674204f, -0.10981385f, -0.14295617f, -0.12892786f, 
    -0.05694379f, 0.03538424f, 0.02379774f, 0.08030353f, 0.01388502f, 0.05407557f, 0.04187826f, 0.00425798f, 
    -0.24073440f, -0.01864160f, 0.02947931f, 0.10271938f, 0.11383461f, 0.03052295f, 0.11658409f, 0.07040701f, 
    0.03177714f, 0.14985618f, -0.07312941f, 0.01055272f, 0.12692356f, -0.20006415f, -0.09612608f, 0.03102616f, 
    -0.13619347f, 0.01124489f, 0.01230089f, 0.02861930f, -0.00084043f, -0.03464768f, 0.07405053f, -0.00933645f, 
    -0.14029393f, 0.17355987f, 0.02581373f, 0.12051892f, -0.02737705f, 0.13673639f, -0.00422399f, -0.02926257f, 
    0.05273049f, 0.12312219f, -0.00959566f, 0.19159527f, -0.05737881f, -0.01392416f, 0.24880980f, 0.22444850f, 
    0.05470970f, -0.08524272f, 0.13705033f, 0.07346649f, 0.02319868f, -0.03705329f, 0.00296555f, 0.07997873f, 
    -0.20859891f, 0.05356777f, -0.04347818f, -0.05618751f, -0.02543303f, 0.11894829f, -0.04922497f, -0.00441345f, 
    0.02923184f, -0.07419305f, -0.02823726f, 0.10086893f, 0.02557888f, 0.24820748f, 0.31580657f, -0.01009385f, 
    -0.08697996f, 0.10136169f, 0.10089351f, -0.06192096f, 0.07498527f, 0.06481391f, 0.07331702f, -0.08930034f, 
    0.10786603f, 0.01936082f, -0.00902777f, 0.42436606f, 0.10352065f, 0.13051426f, -0.03276850f, -0.02773434f, 
    0.08696780f, 0.06608886f, -0.00666917f, -0.03423364f, -0.24687661f, 0.15872331f, -0.02785457f, -0.15818578f, 
    0.07629720f, 0.14383331f, -0.01735089f, 0.03341770f, 0.11655616f, 0.07590530f, 0.10264250f, 0.07083725f, 
    0.03296933f, 0.11448533f, 0.01276177f, 0.01226047f, 0.11178353f, -0.00933848f, 0.11863594f, 0.05890716f, 
    -0.00443397f, -0.00514001f, 0.10233007f, -0.00251464f, 0.23638719f, 0.15701494f, 0.03481769f, 0.19037351f, 
    0.14654970f, 0.13409024f, 0.00636766f, 0.03918906f, 0.12287223f, 0.11756517f, 0.07304678f, 0.10930336f, 
    -0.18471462f, -0.10888197f, -0.08481152f, -0.12902603f, 0.07267653f, -0.05548639f, -0.08187057f, -0.04083972f, 
    0.03960011f, 0.04422437f, -0.04776826f, 0.08638054f, -0.05440087f, 0.14180100f, -0.03224307f, -0.04729067f, 
    0.00443242f, 0.08098792f, 0.01253364f, -0.06110759f, 0.11630345f, 0.01246765f, 0.13345772f, 0.02206214f, 
    -0.12070844f, -0.12426589f, -0.01040073f, -0.02286023f, 0.01313122f, 0.07047818f, 0.02127166f, -0.05943359f, 
    0.04203590f, -0.00295039f, 0.05572751f, 0.11919615f, -0.12754767f, 0.20560211f, -0.01818817f, -0.10070167f, 
    0.02084313f, 0.03307392f, 0.02343932f, 0.04170189f, -0.02056293f, 0.04267509f, -0.10174279f, 0.14660740f, 
    0.08127894f, -0.07009251f, 0.07322782f, -0.07381873f, -0.05569737f, 0.04631234f, 0.14990304f, -0.02816231f, 
    0.04526695f, -0.09082937f, 0.09524410f, 0.10227967f, -0.01384470f, -0.00567856f, 0.05503874f, 0.07698333f, 
    -0.03801380f, -0.13215588f, -0.04865154f, -0.06909820f, 0.02306409f, -0.00420747f, 0.03948547f, 0.13375190f, 
    0.37079018f, 0.03310091f, -0.05846362f, 0.15910709f, -0.00846761f, 0.21290144f, -0.04385156f, -0.19217777f, 
    0.05906795f, 0.18124577f, -0.01383581f, -0.04376306f, -0.03123876f, 0.18676345f, 0.29196662f, 0.06620157f, 
    -0.09328749f, 0.07116695f, 0.10935702f, 0.03158337f, 0.04801148f, 0.03451956f, -0.05129797f, 0.11105803f, 
    0.12602927f, 0.11676820f, 0.20296024f, 0.16375600f, 0.07681488f, -0.03517691f, 0.13804406f, 0.11897454f, 
    0.08447144f, 0.12393951f, 0.03258591f, 0.01281218f, 0.10434489f, -0.03658129f, 0.12104889f, 0.27131221f, 
    0.01137324f, 0.11517102f, -0.13469470f, 0.08660834f, 0.10829665f, 0.09130664f, 0.03262019f, 0.00285993f, 
    0.32879460f, 0.27734187f, 0.01431584f, 0.08250424f, 0.12715867f, 0.02852177f, 0.00118638f, 0.07298899f, 
    0.08844710f, 0.01909805f, -0.00731023f, 0.08241068f, 0.01250385f, 0.00884789f, 0.00035051f, 0.15526982f, 
    0.08814537f, -0.00781938f, -0.04431226f, 0.14441080f, 0.10533537f, 0.05745524f, 0.10924818f, 0.01759551f, 
    -0.27487314f, 0.16354233f, 0.18354920f, -0.05128344f, 0.04950917f, -0.09030088f, -0.05195979f, 0.00001499f, 
    -0.08304390f, 0.21155715f, 0.01251504f, 0.10027947f, -0.04111676f, -0.15698566f, -0.05757669f, -0.11526760f, 
    0.00027637f, -0.06672033f, 0.01470701f, 0.05747842f, 0.07078965f, 0.05549216f, 0.10781938f, -0.03195165f, 
    0.25243512f, 0.23847541f, 0.04966109f, -0.01093757f, 0.05271523f, -0.01510791f, 0.08534014f, 0.10798185f, 
    0.10338443f, -0.01192017f, 0.01817142f, 0.01985073f, 0.02647030f, 0.14373903f, 0.23264752f, 0.27687070f, 
    0.15118434f, 0.01672000f, 0.13744430f, 0.17707530f, -0.12989692f, 0.15266776f, 0.04045323f, -0.14861239f, 
    0.23996836f, 0.09326480f, 0.14210045f, 0.05700438f, -0.00351184f, 0.07712430f, 0.12180547f, 0.27118999f, 
    0.00070728f, 0.00046516f, -0.00767929f, -0.00359848f, -0.24964449f, 0.21007052f, -0.06727381f, -0.08288674f, 
    0.07025606f, -0.01318757f, 0.02006155f, 0.17303833f, -0.00345495f, 0.11628015f, -0.01261378f, 0.08004874f, 
    -0.01247555f, -0.17677352f, 0.02859201f, -0.07551432f, -0.00108799f, -0.06851634f, -0.10657049f, 0.03109787f, 
    0.06462593f, 0.04187239f, 0.16709389f, 0.08318442f, 0.33580628f, 0.12103181f, 0.09228119f, 0.02576543f, 
    -0.01512603f, 0.03649570f, 0.07891040f, 0.04128399f, 0.20885201f, 0.06615611f, 0.10291529f, -0.03713779f, 
    -0.16007234f, -0.03356606f, 0.01803476f, 0.22687657f, 0.00712438f, -0.05503851f, -0.07476417f, 0.04896642f, 
    0.04384682f, 0.07908820f, 0.00371659f, 0.00873486f, -0.03997284f, -0.13214657f, -0.03054179f, 0.15972899f, 
    0.18188536f, 0.04427249f, 0.00074366f, 0.04821004f, 0.12961902f, 0.10489049f, 0.03621322f, 0.05249465f, 
    0.56171799f, 0.09702354f, -0.02236996f, -0.00489310f, -0.06277549f, 0.01640403f, 0.05270219f, 0.08787485f, 
    -0.03459891f, -0.03348529f, -0.00725274f, -0.01512812f, -0.18450631f, 0.11995903f, -0.21270519f, 0.07180285f, 
    0.13121739f, 0.04848057f, -0.04111746f, 0.12391193f, -0.00931739f, -0.00930923f, -0.05048319f, -0.03762419f, 
    0.05064850f, -0.06972400f, -0.05229678f, -0.08719557f, -0.07293582f, 0.08226086f, -0.03852291f, 0.04092323f, 
    0.02544063f, -0.11129790f, 0.05042985f, -0.04176942f, -0.00347935f, -0.07072935f, -0.05358348f, 0.02642743f, 
    -0.03467156f, 0.10378397f, 0.16162764f, -0.08631434f, 0.03504762f, 0.03782471f, 0.06541747f, 0.00037560f, 
    0.21610366f, -0.01540344f, -0.03097687f, -0.08341145f, 0.09772363f, -0.02301347f, 0.02822588f, 0.04089120f, 
    0.15660229f, 0.08892995f, 0.03317537f, 0.05610166f, 0.00164409f, 0.00921464f, -0.19630137f, -0.06503163f, 
    0.06236148f, 0.09782699f, 0.03180765f, -0.01557184f, -0.01105971f, 0.13240369f, -0.03755618f, 0.08275391f, 
    0.06168524f, 0.09924310f, -0.12277082f, -0.19485667f, 0.08149904f, -0.03601458f, 0.07798697f, 0.06097419f, 
    0.16054890f, 0.06087074f, 0.16383967f, 0.09764019f, 0.27995661f, -0.07552748f, -0.07919957f, -0.00046099f, 
    0.01876670f, 0.11277819f, 0.01670876f, 0.02602769f, -0.00076676f, 0.06255483f, 0.06361391f, 0.05826181f, 
    0.22946723f, 0.02588893f, -0.12694165f, 0.03972498f, -0.00584635f, 0.11894301f, -0.11532737f, -0.05848706f, 
    0.09353528f, 0.00336200f, -0.00257245f, 0.05650630f, -0.10332870f, -0.12412307f, 0.09184738f, -0.30025691f, 
    -0.10623242f, 0.00691729f, 0.12760431f, 0.04073734f, -0.00771019f, -0.04491060f, 0.11658696f, 0.00651540f, 
    0.15881853f, -0.17375556f, -0.13302957f, -0.18727081f, 0.13854946f, 0.14571910f, 0.01969710f, -0.00252556f, 
    0.09026284f, 0.09651691f, 0.11145671f, 0.01710228f, -0.16451678f, -0.14547500f, 0.08329296f, -0.11333958f, 
    0.26990521f, 0.14687416f, 0.05742719f, -0.01080933f, 0.01292801f, -0.01436967f, 0.04436640f, 0.08310712f, 
    0.16731673f, 0.06126316f, 0.22686437f, -0.05170717f, 0.09076624f, -0.03396371f, 0.06355207f, -0.05110125f, 
    0.00795562f, -0.02656439f, 0.04398354f, 0.03110373f, 0.02684029f, -0.33935246f, -0.10161012f, 0.03885391f, 
    0.05073266f, -0.06531761f, -0.06415516f, -0.06793305f, 0.12130443f, 0.02364024f, -0.02451951f, -0.03157643f, 
    -0.08314291f, 0.07149640f, -0.04527231f, 0.18846390f, 0.03006721f, 0.10058714f, -0.04737896f, -0.00678824f, 
    0.07375193f, -0.01238437f, -0.00879530f, 0.08008431f, 0.20980258f, 0.25581622f, -0.07924765f, 0.00162569f, 
    0.13732405f, 0.01603580f, -0.00837434f, 0.22355101f, 0.08093468f, 0.14397182f, 0.06285851f, -0.09325385f, 
    -0.47532621f, 0.06437970f, 0.06352551f, -0.09702215f, 0.01622173f, -0.01025821f, 0.04687377f, 0.13864434f, 
    0.11853427f, 0.00287018f, 0.06578904f, 0.06125468f, -0.19577540f, 0.23727700f, -0.03916670f, -0.27531287f, 
    0.27268773f, 0.04323829f, 0.00555470f, 0.05062497f, 0.06171224f, 0.19919400f, 0.05715749f, -0.12404053f, 
    0.10818896f, 0.04306436f, -0.09612221f, -0.09821709f, -0.07033307f, 0.04349808f, 0.02522136f, -0.13458540f, 
    -0.01270361f, -0.12683553f, 0.11151417f, -0.07649243f, 0.04706896f, 0.18941619f, -0.00246031f, -0.10874027f, 
    0.02855754f, -0.00012195f, 0.05911993f, 0.11948799f, 0.02588736f, -0.04278617f, -0.02475972f, 0.07195988f, 
    -0.18109068f, -0.02842214f, -0.14314017f, -0.18921891f, -0.16339225f, -0.03644514f, 0.00378485f, 0.11251484f, 
    -0.05649765f, 0.12881897f, 0.03518117f, -0.06657657f, -0.11357096f, -0.03387328f, 0.09883279f, -0.16302955f, 
    -0.07387824f, -0.02333825f, -0.05703352f, 0.07586079f, -0.01388660f, -0.05386322f, 0.00296399f, -0.02381457f, 
    0.21746172f, 0.12974538f, -0.15327470f, 0.19070411f, 0.00673053f, 0.08666055f, 0.14811361f, 0.07126975f, 
    -0.01403389f, -0.10522711f, 0.07210521f, -0.02443463f, 0.15163338f, 0.00778088f, -0.17716497f, 0.10542835f, 
    0.13174827f, 0.02336822f, 0.01534230f, 0.00398830f, 0.07269894f, 0.06990822f, 0.07643658f, -0.07885598f, 
    0.14546420f, -0.10057533f, 0.08972090f, 0.11749475f, -0.09177180f, -0.01568014f, -0.02588380f, 0.26305792f, 
    -0.16441882f, 0.04621455f, -0.02163859f, -0.00733281f, -0.05612569f, -0.16841720f, -0.06245666f, -0.03379155f, 
    -0.25165495f, -0.12530740f, -0.01736375f, -0.06271429f, 0.05161857f, -0.15635344f, -0.01836882f, 0.00614375f, 
    -0.08034242f, 0.00335493f, 0.05965612f, -0.07457233f, -0.00556959f, 0.07892691f, -0.00935581f, -0.06906817f, 
    0.01341791f, -0.07867561f, 0.03746106f, 0.07552627f, 0.14860843f, -0.10509099f, -0.00691381f, 0.27661723f, 
    0.10209284f, 0.01228531f, -0.02758312f, 0.08753262f, 0.00145381f, -0.01000314f, 0.08604936f, -0.07818049f, 
    0.02868269f, -0.01799611f, -0.01494140f, -0.03296917f, 0.00026326f, 0.03515583f, -0.00026318f, -0.04946884f, 
    -0.05707486f, -0.05701244f, -0.04633506f, 0.03360787f, -0.04021648f, -0.04314072f, -0.02585480f, -0.05203329f, 
    0.03891382f, 0.03623238f, -0.02523916f, 0.01094683f, 0.00786448f, 0.01140983f, 0.02271313f, -0.02397526f, 
    -0.04400601f, 0.02187151f, -0.01128528f, -0.01607681f, -0.04622637f, -0.02249956f, -0.01994335f, -0.00355906f, 
    0.00828673f, -0.02372066f, 0.01031848f, -0.03413631f, -0.03614566f, -0.01678716f, 0.03235535f, -0.01311102f, 
    -0.03198535f, -0.05816939f, 0.02928659f, 0.01396948f, 0.03550474f, -0.02607279f, 0.01887709f, -0.00506715f, 
    -0.00660160f, 0.01256446f, 0.00469677f, -0.02586706f, 0.03877883f, -0.05045730f, -0.05194912f, -0.02681831f, 
    -0.02233457f, -0.01422338f, -0.04264336f, 0.02075047f, 0.02575009f, -0.05368464f, 0.00540688f, 0.01142290f, 
    0.02904849f, -0.04843628f, 0.02453752f, 0.04115456f, -0.01616815f, 0.03329616f, -0.02559472f, 0.02873757f, 
    -0.00714572f, -0.00172535f, 0.04277225f, -0.04163982f, -0.05197018f, -0.00355771f, 0.00229040f, 0.02204286f, 
    -0.01437120f, 0.02877948f, -0.05409479f, 0.00768179f, -0.04346737f, -0.01268843f, -0.05348337f, 0.03808414f, 
    0.00131130f, 0.02228572f, -0.03690886f, -0.05835116f, 0.02018135f, -0.00644112f, -0.02541404f, 0.01595868f, 
    0.01211658f, 0.02595456f, 0.02676796f, -0.00872845f, -0.00210936f, 0.02370429f, -0.00595420f, -0.00472504f, 
    0.03800400f, -0.05160374f, -0.03057694f, 0.01599770f, 0.01625272f, 0.02553995f, -0.05862457f, -0.02415876f, 
    0.04103326f, -0.04379800f, 0.04522046f, 0.01003259f, 0.02272997f, -0.04621827f, 0.01288043f, 0.03130726f, 
    0.01101275f, -0.02477413f, -0.02271986f, -0.04390518f, -0.00351889f, 0.03672703f, -0.00505679f, -0.02406784f, 
    0.01230665f, 0.04138254f, -0.00265476f, -0.00835612f, -0.05579148f, -0.00433470f, -0.01584912f, 0.04142130f, 
    0.04061659f, 0.00645050f, -0.04705196f, -0.03997193f, 0.01794399f, -0.00272417f, -0.01485404f, 0.03170143f, 
    -0.01919901f, 0.03544529f, -0.03034760f, 0.02087068f, -0.03224478f, -0.04228871f, -0.02597366f, -0.02866801f, 
    -0.01027882f, -0.02430800f, -0.01714549f, 0.03101616f, -0.01108614f, 0.02304516f, 0.02124864f, 0.03397280f, 
    0.02202758f, -0.02027139f, -0.05078338f, 0.00409990f, -0.02551325f, -0.01705521f, -0.04864614f, -0.04011839f, 
    0.03649395f, 0.01579960f, -0.00943081f, -0.05581737f, -0.00188964f, -0.01476899f, -0.02664527f, -0.04992471f, 
    -0.02328767f, 0.03561796f, -0.04691113f, -0.02870340f, -0.00579264f, -0.00233046f, 0.02324772f, 0.03525814f, 
    0.00721824f, 0.00325495f, -0.02440814f, -0.02139265f, 0.00080066f, -0.05345713f, -0.02019529f, -0.03846553f, 
    0.02335391f, -0.03335723f, -0.00148160f, -0.00260108f, -0.04681540f, -0.04783540f, -0.05156121f, -0.02445100f, 
    -0.04208125f, 0.02279883f, 0.02020185f, 0.00665224f, 0.03701006f, 0.01267980f, -0.04873304f, -0.04278137f, 
    0.01132174f, -0.02861521f, 0.01897729f, 0.02059282f, 0.01304253f, 0.02552636f, -0.02364402f, 0.00523403f, 
    -0.02704783f, -0.02583622f, -0.01993317f, -0.06066659f, 0.04021761f, -0.04372869f, 0.01266584f, -0.00967526f, 
    -0.04418124f, 0.02895141f, -0.04160859f, 0.01860704f, -0.01004421f, -0.02074051f, -0.03862620f, 0.00710184f, 
    0.00334968f, 0.01990799f, -0.02332558f, 0.00593812f, -0.01135863f, 0.02956734f, -0.04111186f, -0.05073500f, 
    -0.04053779f, -0.03602168f, 0.02484801f, 0.02872197f, 0.03010548f, -0.05048835f, -0.04837982f, -0.02541103f, 
    -0.03987110f, -0.00652765f, -0.02395227f, 0.01118783f, 0.03332350f, 0.04052518f, 0.00099251f, -0.02986175f, 
    -0.01909208f, -0.00849410f, 0.04311601f, 0.02821579f, 0.01122536f, -0.02946536f, -0.00696083f, -0.02166091f, 
    0.03352159f, -0.03635035f, -0.05594065f, 0.02301342f, 0.00425895f, -0.03333749f, -0.03750201f, -0.03931153f, 
    -0.01379863f, -0.01937029f, -0.00372391f, 0.02447969f, 0.02545159f, 0.03419995f, 0.01030005f, 0.00390619f, 
    -0.02608126f, -0.01058970f, -0.01594222f, -0.05011300f, -0.04656898f, -0.03608975f, -0.02912768f, -0.04441177f, 
    0.04036717f, -0.05355190f, 0.02944271f, 0.02340180f, -0.04697579f, -0.01042341f, 0.02769491f, -0.01827220f, 
    0.03817748f, -0.03783834f, 0.00163020f, -0.03354632f, 0.01629533f, 0.04586079f, -0.00649989f, 0.01353830f, 
    -0.01043323f, -0.02928805f, 0.00190241f, -0.03223252f, 0.03941240f, -0.05670725f, -0.03665391f, 0.03244074f, 
    -0.02791777f, 0.04024829f, 0.04015131f, -0.03100922f, 0.03208691f, -0.03280670f, 0.02058233f, 0.03468084f, 
    0.01620412f, -0.03006286f, 0.02645859f, -0.01165069f, 0.04191175f, 0.00933858f, 0.00117689f, -0.01658477f, 
    -0.01759751f, -0.04148172f, 0.01426051f, -0.02804429f, -0.03043646f, 0.02148527f, -0.01278843f, 0.02798639f, 
    0.01357295f, -0.01798452f, 0.00192122f, -0.03811849f, 0.02307199f, -0.00706616f, 0.00886166f, -0.03088582f, 
    -0.00378881f, -0.01473965f, 0.03523589f, -0.05056684f, -0.02545818f, 0.01877904f, 0.03377561f, 0.02946086f, 
    -0.04454590f, -0.03735159f, 0.01876336f, -0.00491894f, 0.00497310f, 0.02581998f, 0.01118916f, 0.03310335f, 
    0.03251324f, 0.02586843f, 0.02451381f, -0.02605397f, -0.05638527f, 0.01371239f, -0.01658279f, -0.01020078f, 
    0.04034474f, 0.00338012f, -0.01545425f, -0.05289141f, -0.04939985f, 0.00166291f, 0.01207050f, -0.02062809f, 
    0.01318207f, 0.03173969f, 0.00387965f, 0.01789497f, -0.01460939f, -0.00482027f, -0.00899081f, 0.00305088f, 
    0.02700286f, -0.00559541f, 0.02357928f, 0.02091963f, -0.05817044f, 0.03897148f, -0.03741407f, -0.00742198f, 
    0.01457729f, 0.02306790f, -0.04026539f, 0.01643333f, -0.00570804f, -0.02625044f, 0.02479739f, 0.01974920f, 
    -0.05438928f, -0.04320613f, 0.04064889f, 0.04583859f, 0.00019944f, -0.04984055f, 0.01898768f, -0.00184730f, 
    0.03459932f, -0.03499388f, -0.00165501f, -0.02879181f, -0.04648342f, 0.03292634f, -0.04818280f, -0.00345961f, 
    0.03315586f, -0.00800606f, -0.05679612f, -0.01085078f, -0.03379071f, -0.00297462f, -0.05016258f, 0.04042023f, 
    -0.03348789f, -0.01208608f, -0.02675701f, -0.03658914f, 0.02393682f, -0.05279994f, 0.00817125f, 0.00909766f, 
    0.03535850f, -0.04991941f, 0.02397243f, 0.03814062f, -0.01843397f, 0.01150789f, -0.03616529f, -0.02147830f, 
    -0.05585621f, -0.04076279f, 0.00743333f, -0.02183950f, 0.00490463f, -0.04792453f, 0.03389345f, -0.02940736f, 
    0.04046170f, -0.03386884f, -0.03551294f, -0.00516658f, -0.02489508f, -0.01387291f, 0.01679145f, 0.03069689f, 
    -0.05051251f, 0.03273076f, -0.04645561f, 0.03502079f, -0.04572144f, -0.01118999f, -0.03635201f, 0.02677127f, 
    0.03700257f, 0.03167736f, -0.02217866f, -0.03319989f, 0.01477027f, -0.00914025f, -0.01338416f, 0.01621672f, 
    0.03571967f, -0.04203175f, -0.04405140f, 0.01545114f, -0.02538629f, 0.00968564f, 0.01539085f, 0.01250282f, 
    -0.00360830f, 0.01918159f, 0.03876358f, -0.01514910f, -0.05411984f, -0.03660613f, -0.03177600f, 0.00666654f, 
    -0.00561913f, 0.01974337f, 0.03987966f, -0.01824326f, -0.00123296f, 0.01565650f, -0.01885934f, 0.02611924f, 
    -0.04531361f, -0.03264647f, 0.01036185f, 0.04522680f, 0.02529463f, -0.02426393f, -0.02800609f, -0.00269818f, 
    -0.03421703f, -0.03174885f, -0.02195197f, 0.01485549f, -0.05499607f, 0.01359087f, -0.05128352f, -0.02035136f, 
    -0.02493033f, 0.01212198f, 0.01757208f, 0.02238119f, 0.01897073f, -0.03382810f, 0.01914325f, -0.01356828f, 
    -0.02737976f, 0.04195846f, -0.02668518f, 0.04602263f, 0.02162033f, -0.04121365f, -0.05614055f, 0.01686707f, 
    0.04509149f, -0.05995937f, 0.03986132f, -0.02376305f, 0.01505960f, -0.01944607f, -0.01379394f, 0.04170174f, 
    0.03598422f, -0.05107786f, 0.00657280f, 0.01563728f, -0.05434394f, 0.01383743f, -0.05383007f, 0.01581936f, 
    -0.02792731f, 0.01212833f, 0.04461183f, -0.04948478f, 0.01830812f, -0.03576937f, -0.04495718f, -0.01231594f, 
    0.00881219f, 0.00948933f, 0.03871565f, -0.04552718f, 0.03473203f, -0.03034936f, -0.02651439f, -0.01233280f, 
    0.03884397f, 0.03288680f, 0.04593527f, 0.03877001f, 0.02254494f, 0.02722515f, 0.02868763f, 0.05425370f, 
    -0.01308644f, 0.02991672f, -0.04923964f, 0.02016199f, -0.03811765f, -0.00000325f, -0.01825521f, 0.02971925f, 
    0.00526797f, -0.00395666f, -0.02951464f, -0.01141643f, -0.02973148f, -0.05426713f, 0.00549528f, 0.03432961f, 
    -0.00071853f, -0.04673161f, 0.03190972f, -0.02861058f, -0.03218568f, -0.03483288f, -0.05324897f, -0.03707743f, 
    -0.05428662f, 0.01742932f, 0.00182892f, 0.04163774f, 0.02756231f, -0.03632121f, -0.04110849f, 0.01510266f, 
    0.00538495f, -0.04798565f, -0.02701864f, 0.03618841f, -0.03231131f, -0.03451746f, -0.03213431f, 0.01986025f, 
    -0.00705503f, -0.00033222f, -0.02066384f, -0.04575863f, 0.02443474f, -0.05196059f, -0.03114997f, 0.02977640f, 
    0.02315763f, -0.01667089f, -0.01796877f, -0.02616267f, -0.02627919f, -0.01535968f, 0.02412045f, 0.03711501f, 
    0.02302812f, -0.01011263f, -0.04936749f, 0.04380992f, -0.02809381f, -0.00732593f, -0.02794530f, -0.04237359f, 
    0.04283767f, 0.00400834f, -0.04238088f, -0.04806622f, 0.03542042f, -0.04020077f, 0.02665991f, -0.01820571f, 
    0.00969679f, -0.05066971f, -0.01454819f, -0.02344090f, 0.03168565f, -0.05405155f, 0.04281682f, 0.02650980f, 
    -0.02011624f, -0.04506282f, 0.01294871f, -0.00342615f, -0.00007384f, 0.03107145f, -0.03067343f, 0.04243303f, 
    -0.01020087f, -0.02308765f, -0.00131041f, -0.03670921f, 0.00254093f, -0.00772789f, -0.03956397f, -0.05833787f, 
    -0.01826054f, 0.01270864f, 0.00778268f, -0.01167333f, 0.03251507f, -0.04218503f, 0.00058091f, -0.01638355f, 
    -0.02449690f, 0.01735177f, -0.02045191f, -0.05759924f, -0.04539051f, -0.03459915f, -0.03394935f, -0.00157597f, 
    -0.04218655f, -0.01699752f, 0.03061705f, -0.00134318f, -0.03303925f, 0.01157423f, -0.04982297f, 0.01364129f, 
    0.02152014f, -0.03344606f, 0.02007280f, -0.05914143f, 0.00875637f, 0.02693093f, -0.00696305f, -0.02762962f, 
    -0.04619979f, 0.04779597f, 0.00203328f, -0.01550876f, -0.04226518f, -0.03679446f, -0.04326852f, 0.02357376f, 
    0.00716857f, -0.04462728f, 0.04113256f, 0.02377947f, 0.00084022f, 0.03222140f, 0.04798678f, 0.04641365f, 
    -0.01262293f, -0.01545945f, 0.03763230f, -0.00758692f, -0.02883842f, -0.01597664f, -0.00665817f, -0.00944345f, 
    -0.02324120f, -0.01394164f, -0.01759135f, -0.03079840f, -0.03547974f, -0.04852711f, -0.01975791f, -0.01555122f, 
    0.03888050f, 0.04467430f, -0.00140230f, 0.04433228f, -0.03807125f, -0.00748151f, -0.02183305f, -0.04485536f, 
    -0.05368587f, -0.04750279f, 0.03648461f, -0.05386212f, -0.01937099f, 0.02681439f, 0.01738042f, 0.01629833f, 
    -0.00938742f, -0.02182078f, -0.01509973f, -0.00682433f, 0.00951846f, -0.02762234f, 0.04195676f, 0.03588234f, 
    0.00347708f, 0.03067787f, 0.03334095f, 0.04269434f, -0.00127141f, 0.01599414f, 0.04371444f, -0.04418224f, 
    -0.02863124f, -0.04211272f, 0.02673267f, -0.02582472f, -0.00376204f, -0.04960461f, -0.00915301f, -0.05019934f, 
    -0.03628480f, -0.05792969f, 0.00832416f, -0.01511296f, 0.00723329f, -0.03861791f, -0.04156027f, -0.04424737f, 
    -0.00680836f, 0.03282984f, -0.02609128f, -0.00118548f, -0.04190432f, 0.02522268f, 0.02903041f, 0.00168793f, 
    -0.00370590f, -0.02004640f, -0.02007071f, -0.04357095f, 0.00302193f, -0.02427619f, -0.00344998f, 0.03317834f, 
    -0.01441442f, -0.02786524f, 0.03605231f, 0.01596900f, -0.03567733f, -0.00989015f, -0.02610003f, 0.01337570f, 
    -0.03464483f, -0.02555162f, -0.00141890f, -0.05572725f, -0.00422947f, -0.05490190f, -0.05196226f, 0.00832555f, 
    0.03634290f, -0.04404863f, -0.05622625f, -0.02773842f, -0.00072423f, -0.00190737f, 0.02664354f, 0.00767329f, 
    -0.04396675f, 0.04095426f, -0.02335500f, 0.03151826f, 0.00323907f, -0.01222513f, 0.03079710f, -0.03800772f, 
    0.03076644f, -0.05860043f, 0.03806154f, 0.04100445f, -0.03776452f, -0.05710305f, -0.02010383f, -0.00309043f, 
    -0.01028142f, -0.06031689f, 0.04186697f, 0.00613611f, 0.00183235f, -0.04214383f, -0.02298873f, -0.04474738f, 
    -0.01714896f, 0.00187305f, -0.05906240f, -0.02706352f, -0.01308015f, -0.02631539f, 0.00253383f, -0.00814824f, 
    0.01286268f, -0.03904465f, -0.02234929f, 0.02234080f, -0.05578861f, 0.03855498f, 0.02765829f, 0.03511665f, 
    -0.01067541f, -0.05291694f, 0.03585998f, -0.05934713f, -0.01913785f, -0.03869766f, -0.02228122f, -0.04312025f, 
    -0.00091080f, -0.00221122f, 0.02339086f, -0.02038592f, -0.05180324f, -0.05573447f, -0.01852395f, 0.03933565f, 
    -0.00432588f, -0.02806260f, -0.03436916f, -0.02756258f, -0.05731783f, -0.00752868f, -0.05133720f, -0.03159499f, 
    0.00330428f, -0.01973453f, 0.01173350f, 0.00170136f, -0.00843550f, -0.02352253f, 0.01622413f, 0.03132459f, 
    0.01755462f, 0.01776623f, -0.05173677f, -0.04228731f, -0.01071396f, -0.04387230f, -0.04260268f, -0.05986421f, 
    -0.02455697f, -0.04606844f, -0.03865651f, -0.04315637f, -0.03588830f, -0.02510809f, -0.01026419f, -0.05676078f, 
    0.03681156f, 0.02878449f, -0.01576805f, 0.00332497f, -0.03085639f, 0.03318219f, -0.05131883f, -0.05762919f, 
    -0.04022060f, 0.02703056f, -0.05044822f, -0.00253414f, -0.01600989f, 0.02693951f, 0.03650970f, 0.01779713f, 
    -0.00081362f, -0.01777191f, -0.01913872f, -0.05652310f, 0.02982300f, -0.02540853f, -0.04206550f, -0.03952082f, 
    0.00572367f, 0.04094497f, -0.01604513f, 0.03365090f, -0.02745672f, 0.04135516f, 0.00460416f, -0.01867650f, 
    0.04663477f, -0.05789552f, 0.03569625f, -0.05742940f, 0.04087983f, 0.00083264f, 0.02080380f, -0.04638155f, 
    -0.03261097f, -0.01950293f, 0.01308260f, -0.01605014f, 0.02676333f, 0.01944245f, -0.03209275f, -0.00450127f, 
    0.01859177f, 0.00580694f, -0.01908148f, -0.03919721f, 0.02351129f, -0.02095191f, 0.02887124f, -0.00674089f, 
    -0.01850591f, -0.05310388f, -0.03887623f, 0.02963083f, -0.00782987f, -0.02932486f, -0.01357428f, -0.05363930f, 
    -0.04381044f, -0.00550305f, -0.05931969f, -0.03604103f, 0.03946864f, -0.04050027f, -0.02257961f, -0.03440325f, 
    0.00394743f, -0.03779599f, -0.04372343f, -0.01400590f, -0.01134037f, -0.02005916f, -0.05200594f, -0.00429810f, 
    -0.00559056f, -0.00418930f, 0.00146850f, -0.00170511f, 0.00554107f, 0.02067539f, 0.02922383f, 0.01732893f, 
    -0.03615431f, -0.05388357f, -0.04691524f, 0.01846526f, -0.05298820f, 0.03411208f, -0.05211828f, -0.00378612f, 
    -0.04098354f, -0.02238225f, -0.05445128f, -0.00133897f, 0.02442807f, 0.00019680f, -0.05727656f, 0.02337481f, 
    -0.03598579f, -0.00335987f, 0.03076415f, -0.03283391f, 0.03784119f, 0.03677076f, -0.00298698f, 0.02458170f, 
    0.01599856f, 0.00960232f, -0.04661731f, -0.03102130f, 0.01638636f, 0.03249492f, -0.03810649f, 0.02849664f, 
    -0.01401879f, 0.03111361f, -0.00408854f, 0.03499668f, -0.05023490f, -0.05810492f, -0.02613988f, 0.00709091f, 
    -0.03373045f, 0.01006539f, 0.00210529f, 0.02105649f, -0.00410744f, -0.01707471f, -0.04594228f, -0.04972637f, 
    -0.00685051f, 0.02691723f, -0.01646248f, 0.02662420f, -0.01665419f, -0.03000931f, 0.02423083f, -0.05659363f, 
    0.02217665f, 0.01437617f, 0.01125769f, -0.05982639f, -0.00141772f, -0.00094992f, 0.02950361f, -0.01954388f, 
    -0.05166144f, 0.04019639f, -0.01042561f, 0.01047386f, -0.01988365f, 0.02424458f, -0.00937442f, -0.02448695f, 
    -0.00450164f, 0.01414940f, -0.04601698f, -0.02919221f, -0.04523698f, 0.04816269f, 0.02158237f, 0.02258120f, 
    -0.05801228f, 0.00271867f, -0.02904711f, -0.00233470f, 0.02058662f, -0.03368756f, -0.00663298f, -0.04972817f, 
    0.01455471f, -0.05166292f, 0.02612081f, -0.04672486f, -0.01834485f, -0.02499534f, 0.01869090f, 0.02901878f, 
    -0.01069448f, 0.02212813f, -0.01152677f, -0.00468798f, -0.05616998f, 0.03538586f, 0.03281109f, -0.02042612f, 
    0.02636965f, -0.04037207f, -0.01247471f, 0.03590649f, -0.03251297f, 0.04019837f, -0.05032469f, 0.03831674f, 
    0.01910533f, -0.04459704f, 0.03909500f, -0.05831008f, -0.02462496f, -0.00591995f, -0.00838127f, 0.02957267f, 
    -0.00678033f, -0.03010174f, -0.01358567f, -0.04917085f, 0.01472159f, -0.02000259f, 0.00559257f, -0.04426660f, 
    0.00079161f, -0.02436196f, -0.02401772f, 0.03232096f, -0.05320020f, -0.03665463f, -0.01075547f, -0.04361894f, 
    -0.01363572f, 0.00496985f, -0.00767605f, 0.02184585f, 0.02958704f, -0.05213590f, 0.02196438f, -0.05899093f, 
    -0.01955559f, -0.03779238f, -0.05319410f, -0.01230294f, 0.00473180f, -0.03428172f, -0.05102225f, 0.02846449f, 
    0.03845021f, -0.05197934f, 0.03832233f, -0.03866852f, 0.00100366f, 0.01206357f, -0.01470069f, -0.03468888f, 
    0.20270053f, 0.01833328f, -0.03803819f, 0.04895658f, 0.06514972f, -0.02645100f, -0.04506703f, -0.01124338f, 
    -0.04009311f, -0.00868248f, -0.01647026f, 0.10626625f, -0.20658639f, -0.21577211f, 0.06594240f, 0.31407666f, 
    0.10485034f, 0.01577794f, -0.02190502f, 0.00161190f, 0.06504656f, 0.01973955f, -0.04191623f, 0.02833126f, 
    0.04986367f, 0.12535301f, -0.12603424f, 0.04516241f, -0.13596413f, 0.01487556f, 0.08943839f, -0.11633211f, 
    -0.06799097f, 0.04887248f, 0.03457968f, -0.06691872f, -0.23069951f, -0.08504314f, -0.08164798f, -0.02346835f, 
    -0.01800301f, 0.03293083f, 0.06808551f, -0.07059135f, 0.00417941f, 0.03869550f, -0.00600839f, -0.00768176f, 
    -0.31237301f, 0.15477113f, 0.16210604f, -0.08288901f, 0.00088425f, -0.02995090f, -0.02590670f, -0.05421980f, 
    0.06585587f, 0.01152396f, -0.01773012f, -0.03751160f, -0.18303083f, -0.05322355f, -0.00390453f, 0.27157691f, 
    -0.13051730f, -0.09374332f, -0.01744844f, 0.04480623f, -0.04105669f, -0.03884448f, -0.02724380f, -0.10107551f, 
    -0.05133689f, 0.04602730f, 0.02834592f, -0.04300487f, 0.11470917f, 0.03592601f, 0.06883325f, 0.05793853f, 
    0.02165003f, 0.09660827f, -0.09628256f, 0.04890576f, -0.13156447f, -0.02006283f, -0.10900357f, 0.39001513f, 
    -0.17281651f, 0.02154633f, 0.05506304f, -0.03848347f, 0.04823168f, -0.00532240f, 0.03552797f, 0.08592487f, 
    -0.05544353f, -0.03506459f, 0.13789748f, -0.25440457f, 0.06301218f, 0.00985805f, 0.04249248f, 0.02611677f, 
    0.16322431f, 0.02187432f, 0.01218865f, 0.08371687f, 0.11658768f, 0.05623405f, 0.18645604f, 0.03396999f, 
    -0.08446556f, 0.03747704f, 0.21101317f, 0.01985866f, 0.12034556f, 0.07822797f, 0.09078435f, 0.04927899f, 
    0.02860312f, 0.24419600f, -0.10252675f, -0.01350792f, -0.00134949f, 0.04963928f, -0.01055303f, -0.03177122f, 
    0.05903410f, 0.01349294f, -0.01312826f, -0.08119907f, -0.02710713f, 0.13086700f, -0.00845747f, -0.13368419f, 
    0.07064267f, 0.05121803f, -0.02789454f, 0.09233712f, 0.03224728f, -0.06703909f, 0.04614127f, -0.02454782f, 
    0.21164258f, 0.19736852f, -0.02428107f, 0.05582957f, -0.07661553f, 0.02791683f, -0.05690554f, 0.01786574f, 
    -0.00692661f, 0.18056887f, -0.03796424f, 0.18099996f, 0.40608606f, 0.29879516f, -0.02908334f, -0.00474953f, 
    0.06047294f, -0.03863668f, -0.09891522f, 0.02054728f, -0.03964930f, 0.05040911f, 0.01413429f, 0.12504175f, 
    -0.18984140f, -0.06751566f, -0.18468846f, -0.17626552f, 0.03183186f, -0.05837161f, 0.00818645f, -0.03597573f, 
    0.08212686f, -0.03678460f, 0.15481722f, 0.13036057f, -0.23389918f, 0.00965579f, 0.05417881f, -0.19635209f, 
    0.07985173f, 0.03525550f, -0.01927694f, 0.00803832f, 0.10482346f, -0.03469463f, 0.12178093f, 0.14137420f, 
    -0.28361401f, -0.09007525f, -0.04807896f, 0.00893008f, 0.08311331f, 0.20670465f, 0.02862097f, -0.02774383f, 
    0.11330371f, -0.02750001f, 0.04972895f, 0.04063455f, -0.04127179f, 0.12155855f, -0.00744748f, -0.00733691f, 
    0.03609358f, 0.11432610f, 0.04530498f, 0.02373752f, 0.03165462f, 0.00486209f, -0.03146182f, 0.08674522f, 
    -0.19974346f, -0.04521247f, -0.14090660f, 0.31407237f, 0.04173896f, 0.18340367f, -0.03254027f, 0.12074281f, 
    0.08589635f, -0.08159966f, 0.08608326f, -0.04278619f, -0.13997322f, -0.02545269f, 0.11284468f, -0.04942451f, 
    0.02356067f, 0.02102045f, 0.08023337f, -0.03976051f, 0.02865852f, -0.02153208f, -0.10199756f, 0.07584758f, 
    0.30120242f, 0.12161113f, 0.12571613f, 0.04500865f, 0.05435025f, 0.02161903f, 0.04605317f, -0.01330304f, 
    0.05732450f, 0.15164021f, -0.09855608f, -0.01728952f, -0.11651251f, -0.12545243f, 0.05608819f, 0.14171301f, 
    -0.05947106f, 0.07934641f, 0.09150868f, 0.05493596f, -0.01454800f, -0.03830419f, 0.03370508f, 0.03932235f, 
    0.20586705f, 0.16134623f, 0.06217637f, 0.17507809f, -0.02318157f, 0.02981004f, 0.00594367f, 0.11192185f, 
    -0.11328397f, 0.00436527f, -0.03673181f, 0.02714971f, -0.05604555f, -0.01773671f, -0.03526985f, 0.23695365f, 
    -0.01042526f, 0.08425049f, -0.06903230f, 0.09031360f, 0.07070706f, 0.04290648f, 0.02173231f, -0.00692889f, 
    0.25125045f, -0.04639081f, 0.05654289f, 0.05691980f, -0.01869445f, -0.00747438f, -0.01154464f, -0.06367677f, 
    -0.04674083f, 0.03225369f, 0.03362046f, 0.01176051f, 0.04899963f, -0.06070015f, 0.09453344f, -0.19896103f, 
    0.05237730f, -0.03802189f, 0.06077795f, 0.18996941f, 0.05966067f, 0.04754851f, 0.05241424f, 0.10938497f, 
    -0.14687496f, 0.01396508f, 0.13308080f, -0.12188211f, 0.01249026f, 0.01328369f, -0.09630774f, -0.08980401f, 
    -0.02736194f, 0.12791197f, -0.00273737f, 0.14254223f, -0.16074708f, 0.02463753f, -0.09260526f, -0.14387979f, 
    0.01160206f, 0.02375917f, 0.02988393f, 0.00409496f, 0.05892581f, -0.01792248f, -0.00674385f, 0.02222645f, 
    -0.33719590f, -0.12054399f, -0.04821686f, 0.11222365f, -0.01770477f, 0.02280754f, 0.04657171f, -0.09563229f, 
    0.03337450f, -0.11936160f, 0.03889843f, -0.03622890f, -0.14185621f, -0.07805994f, 0.08138256f, 0.12636153f, 
    -0.13145581f, -0.10080628f, 0.02448160f, -0.00326769f, -0.15189356f, 0.09979191f, 0.10730399f, -0.02190580f, 
    0.35377440f, 0.10065548f, 0.18261610f, 0.17615156f, -0.08085756f, 0.01689973f, 0.15024848f, 0.23859608f, 
    0.09021083f, -0.05684324f, 0.10585687f, 0.02562356f, -0.26115295f, -0.03196726f, -0.03899353f, 0.00731149f, 
    0.03828299f, -0.04717202f, 0.17790093f, 0.06203823f, -0.03227713f, -0.03912371f, -0.07377816f, 0.04322512f, 
    0.00936216f, 0.02263093f, 0.00686202f, -0.01934155f, -0.04713240f, 0.02658327f, 0.00958351f, -0.03442559f, 
    -0.03590991f, 0.02538422f, -0.01472025f, 0.03177966f, -0.02019747f, 0.03183397f, -0.02376445f, 0.00097399f, 
    -0.04640609f, 0.03007346f, -0.04851149f, -0.04869813f, -0.04590724f, -0.01189901f, 0.00994232f, -0.03111236f, 
    0.01866491f, 0.00501690f, 0.04120405f, -0.00183036f, -0.00135221f, -0.02843025f, 0.03019394f, -0.04681739f, 
    0.00682152f, 0.04745451f, -0.02353678f, -0.01538494f, 0.00002691f, 0.00956754f, -0.05473092f, -0.05039736f, 
    -0.04082026f, -0.01919255f, 0.02906931f, -0.03755678f, 0.01526367f, 0.04530312f, -0.02145476f, -0.03262271f, 
    0.03195433f, 0.03205779f, -0.01231581f, -0.00824426f, 0.00844175f, -0.02027354f, 0.04443994f, -0.00266682f, 
    0.00850649f, -0.04202424f, 0.02186416f, -0.02353118f, 0.00263238f, 0.01861835f, -0.02487269f, -0.04362489f, 
    0.00691721f, 0.04066428f, 0.02299450f, 0.01990911f, 0.04516540f, -0.05203647f, -0.05015060f, -0.04239823f, 
    -0.03278680f, 0.03341774f, 0.02413832f, -0.02466829f, 0.02247713f, -0.02451471f, 0.04336291f, -0.03757352f, 
    -0.02825837f, -0.03408613f, 0.00962527f, 0.00004618f, -0.04678131f, -0.04735989f, 0.03870310f, -0.01196686f, 
    0.02785298f, 0.01860007f, -0.04254866f, -0.05041912f, -0.01807072f, 0.01870917f, 0.02725634f, -0.00741837f, 
    -0.04435766f, -0.00871408f, -0.02609459f, 0.02554762f, -0.02375893f, -0.05150431f, 0.04663557f, -0.02717580f, 
    0.01703523f, -0.03422673f, 0.00877881f, -0.01022152f, 0.01256002f, 0.00512879f, 0.01410074f, 0.03175475f, 
    0.00719352f, -0.02788751f, -0.01724905f, -0.04168455f, 0.01303588f, 0.01912800f, -0.04881797f, -0.02968565f, 
    0.02623777f, 0.02415070f, 0.03479643f, -0.04861105f, -0.02956595f, 0.02261262f, 0.02619702f, 0.01796193f, 
    -0.05642349f, 0.03532908f, -0.02452955f, 0.00968171f, 0.03476072f, -0.02909546f, 0.02633338f, -0.02459181f, 
    -0.01317022f, 0.04509095f, 0.04013032f, 0.01648250f, -0.01772670f, -0.05232555f, -0.05186894f, -0.00602905f, 
    -0.01057941f, 0.00024411f, -0.02169904f, 0.02915637f, 0.01570667f, 0.00319424f, 0.02437758f, 0.03224555f, 
    0.02098115f, -0.01684460f, -0.01706124f, 0.03672777f, -0.00898200f, -0.04167143f, 0.02860130f, -0.05863096f, 
    -0.01498599f, -0.04418685f, -0.05244798f, 0.02273991f, 0.03085610f, -0.05422593f, 0.00639429f, 0.04149918f, 
    -0.01985954f, -0.03452891f, 0.02342626f, -0.05143575f, -0.03811025f, 0.00814900f, -0.03915029f, -0.04243748f, 
    -0.02690209f, 0.05027335f, -0.01542542f, -0.00376032f, 0.03631874f, -0.03708251f, 0.03251781f, 0.00702616f, 
    -0.03680781f, 0.00389567f, 0.03821958f, -0.01026707f, -0.00713122f, -0.03628754f, 0.01977031f, 0.05045182f, 
    0.01027394f, 0.02039713f, -0.00357198f, -0.05450414f, -0.00878890f, -0.00800636f, -0.03792353f, -0.01438077f, 
    -0.05026232f, -0.03786027f, -0.00760646f, 0.01126854f, 0.03718037f, -0.01893203f, -0.04783671f, 0.03024342f, 
    -0.02678490f, -0.01855580f, -0.01204015f, 0.01979741f, 0.04997784f, 0.01191405f, -0.03819718f, 0.00586826f, 
    0.02724249f, -0.00303727f, 0.04697098f, -0.04182287f, -0.03452363f, -0.01698703f, -0.00210926f, -0.02683375f, 
    -0.02309547f, -0.03064396f, -0.02615467f, -0.04869534f, 0.03726372f, -0.03967306f, 0.01519676f, -0.04768250f, 
    0.03373777f, -0.03427828f, -0.03484664f, 0.03496577f, 0.05220729f, -0.02325523f, -0.04584466f, 0.01305461f, 
    -0.02302438f, -0.00280415f, 0.00993488f, -0.02284585f, -0.02176774f, -0.04568396f, -0.03789073f, 0.01218805f, 
    0.03133910f, -0.00879140f, -0.03928582f, 0.01098153f, 0.01409722f, 0.00579050f, -0.02893854f, -0.00064890f, 
    -0.05317369f, -0.04588435f, 0.03160331f, -0.00870140f, -0.01942768f, 0.01554812f, -0.00719200f, 0.04698726f, 
    -0.01501317f, -0.01405850f, -0.01806319f, -0.01020582f, -0.00607995f, 0.01275875f, 0.01709717f, -0.01754020f, 
    -0.00934711f, -0.02942988f, -0.00562768f, 0.02691359f, 0.00655027f, 0.01276883f, -0.01810500f, -0.04445698f, 
    -0.02322511f, 0.01310374f, 0.02899332f, -0.02719990f, 0.02306051f, 0.04666028f, -0.01435118f, 0.00799323f, 
    -0.00384171f, -0.04966133f, -0.02006357f, 0.03387310f, -0.00960737f, -0.01840301f, 0.02232075f, 0.00293572f, 
    -0.03432498f, 0.03989434f, 0.00759926f, 0.02375366f, 0.01920924f, 0.00799784f, -0.02967099f, -0.05060084f, 
    0.04037293f, -0.03197412f, -0.00995992f, -0.03992696f, 0.03593795f, 0.05138026f, 0.02299231f, -0.01999275f, 
    0.02759210f, -0.01973497f, -0.01089321f, -0.03813695f, -0.04173052f, 0.03883998f, 0.01427692f, -0.00971290f, 
    0.00231970f, -0.03906789f, 0.02628908f, 0.02264427f, -0.00273189f, -0.02216454f, -0.03234556f, 0.01971023f, 
    -0.04150001f, -0.03832899f, -0.01397049f, -0.02417556f, -0.03943469f, -0.04864092f, 0.03384992f, 0.00568417f, 
    0.00905657f, 0.03640409f, -0.04636402f, 0.01057503f, 0.03542050f, 0.03862635f, 0.00197044f, -0.01052600f, 
    -0.02153477f, 0.04312177f, 0.02050338f, 0.00385868f, -0.05581718f, -0.04171461f, -0.00406239f, 0.01603990f, 
    0.00237904f, 0.03653809f, 0.00625912f, 0.04311662f, 0.00190599f, -0.02562842f, 0.03220996f, -0.02917376f, 
    -0.01526486f, -0.03046761f, -0.04130666f, 0.02665043f, -0.02655637f, -0.03622325f, -0.01250690f, -0.01710679f, 
    -0.00504376f, 0.04635844f, 0.00029212f, -0.00165441f, -0.00837888f, 0.00190069f, 0.01255213f, 0.01780903f, 
    0.03076362f, -0.00850044f, 0.00947592f, 0.02197008f, 0.02661391f, 0.00008717f, 0.02793149f, -0.02442318f, 
    -0.12180245f, -0.08442425f, 0.09346433f, 0.11530467f, 0.01482632f, -0.03599213f, 0.03304224f, -0.00002218f, 
    0.14385219f, 0.07215629f, 0.09718508f, 0.08552331f, 0.43848008f, 0.15396731f, -0.15263827f, 0.21991859f, 
    0.02078748f, 0.07810285f, 0.06089508f, 0.15544796f, -0.06734873f, 0.08576229f, -0.00599094f, 0.00444556f, 
    -0.13959573f, -0.23263371f, 0.17920379f, -0.18484023f, 0.11963722f, 0.02865985f, 0.00012997f, 0.07410553f, 
    0.04248865f, 0.02040848f, 0.01403542f, 0.06775673f, 0.11848566f, 0.21451981f, 0.22109459f, 0.10160735f, 
    0.00655474f, 0.02065209f, -0.01106688f, -0.02548419f, 0.07500340f, 0.04650559f, 0.01295609f, -0.03711889f, 
    0.12497095f, -0.01280448f, -0.06048351f, -0.04572682f, -0.05366036f, -0.04000913f, 0.00085234f, -0.05886225f, 
    -0.04097189f, 0.02160419f, 0.06722994f, -0.01410065f, 0.02525235f, 0.08213818f, 0.16505246f, -0.04087094f, 
    0.11698070f, 0.03733867f, 0.02973559f, 0.00757083f, -0.02418295f, -0.02003117f, -0.02075668f, 0.01923436f, 
    0.28955775f, -0.13155632f, 0.25282839f, 0.08413337f, 0.05289730f, -0.01893425f, 0.02028336f, 0.05196591f, 
    0.05273363f, -0.06186477f, 0.03642252f, -0.18737787f, 0.19071333f, 0.07909666f, -0.17111571f, -0.12811457f, 
    0.04056009f, 0.10606183f, -0.07992515f, 0.10107946f, 0.00276443f, 0.05578892f, 0.01753458f, -0.06612407f, 
    0.29288658f, 0.07012821f, 0.09691141f, 0.12250549f, 0.07072698f, -0.02375087f, 0.09874879f, 0.10259266f, 
    -0.05500223f, 0.02220303f, 0.03634317f, -0.06577121f, 0.12081317f, -0.30104503f, -0.16174458f, 0.25425932f, 
    0.13402781f, -0.05877519f, 0.01368125f, 0.16895373f, 0.18204823f, -0.00188163f, 0.05842551f, 0.13811223f, 
    -0.16941686f, -0.09026106f, 0.04123563f, -0.24634846f, -0.02333934f, -0.06081607f, 0.09860203f, 0.01071352f, 
    0.04322802f, 0.04377603f, 0.07049256f, 0.06253317f, 0.28254864f, -0.14242882f, 0.03235135f, 0.04292338f, 
    -0.05483197f, 0.03686529f, 0.04572039f, -0.05423430f, 0.00518782f, 0.11162414f, -0.15612943f, 0.01756450f, 
    -0.10320672f, -0.25412545f, 0.08993437f, 0.11331633f, -0.01457698f, 0.09555001f, -0.06266981f, -0.06041830f, 
    0.04498196f, 0.13711153f, -0.01156084f, 0.02971285f, -0.25042751f, -0.17283778f, -0.05900019f, -0.06057082f, 
    0.10023238f, -0.06451032f, 0.02204768f, 0.03867136f, 0.03246817f, 0.00551379f, 0.11953676f, -0.11761933f, 
    0.07952216f, 0.13691507f, 0.24925701f, -0.01063603f, 0.07248963f, -0.05767791f, -0.00358120f, 0.10750155f, 
    -0.01494698f, 0.04091248f, 0.06210077f, 0.04160139f, 0.00142932f, -0.04176274f, 0.13956696f, 0.04946458f, 
    0.03839170f, -0.07243671f, -0.00099722f, 0.05398116f, -0.12069060f, 0.04722242f, 0.08893920f, 0.06499716f, 
    0.29058838f, 0.36576128f, 0.18494314f, 0.07721378f, 0.07023570f, 0.00535465f, 0.00445515f, 0.06230049f, 
    -0.03965006f, -0.01267634f, -0.03019010f, -0.10832676f, 0.08822976f, -0.05507692f, 0.03666678f, -0.04797059f, 
    0.05276189f, 0.04783718f, 0.06061067f, 0.02838014f, 0.05464835f, 0.02909617f, 0.00337806f, 0.00655065f, 
    -0.08139632f, 0.03552027f, 0.00222509f, -0.01084033f, 0.14193654f, -0.06825622f, 0.00672543f, 0.11797652f, 
    0.05443567f, 0.01146652f, 0.03233982f, -0.03906630f, 0.16447024f, 0.19130740f, -0.02574965f, -0.19109195f, 
    0.06017549f, 0.07042085f, 0.15863802f, 0.21332453f, 0.12262749f, 0.02988866f, 0.11141414f, 0.07457999f, 
    -0.37769580f, 0.08547188f, 0.19995753f, -0.03926593f, 0.01403171f, -0.03185279f, 0.19422947f, 0.18529938f, 
    0.03448073f, -0.10146569f, 0.02556710f, 0.00030556f, 0.19322316f, -0.16181019f, -0.25954375f, 0.07371393f, 
    0.11872628f, 0.03384392f, 0.09187236f, -0.01279350f, -0.12297281f, -0.04650579f, 0.04731132f, 0.05203046f, 
    -0.09226312f, -0.18952732f, -0.08873856f, -0.00264985f, -0.00431127f, 0.12096271f, -0.03596694f, -0.03225621f, 
    -0.13366188f, -0.05947775f, -0.08232907f, -0.03252013f, -0.00454440f, 0.14470498f, -0.06676900f, -0.35249329f, 
    0.05182404f, 0.05294448f, 0.14564408f, -0.01197807f, -0.08978882f, 0.02986558f, 0.02151102f, 0.05026356f, 
    -0.22366083f, -0.29329681f, -0.02457588f, 0.05823970f, 0.05969974f, -0.02445504f, -0.05268071f, -0.04057376f, 
    -0.05477551f, 0.07735775f, 0.14296281f, 0.10604825f, 0.22348787f, 0.07516019f, 0.06770051f, -0.14803028f, 
    0.09149578f, 0.02153460f, 0.01412985f, -0.02198467f, -0.00766850f, -0.00614570f, -0.01045543f, 0.06772311f, 
    0.19609368f, -0.20550960f, -0.24861382f, 0.11239775f, -0.04352919f, 0.00652364f, 0.03119270f, 0.03727292f, 
    0.11007820f, -0.10442793f, -0.00137948f, -0.10115373f, -0.11538675f, 0.42258403f, 0.16826941f, -0.23371464f, 
    0.01338833f, 0.09405699f, -0.02385879f, -0.02700882f, -0.01752171f, -0.02587477f, 0.02366669f, 0.04732761f, 
    -0.19960326f, -0.29091513f, -0.13738705f, -0.07623082f, -0.03561531f, 0.00130130f, -0.00443551f, 0.01752981f, 
    -0.08540785f, 0.08606041f, -0.01090608f, 0.03935940f, 0.06970122f, -0.03852376f, -0.35548392f, -0.34474641f, 
    0.02891782f, 0.03268136f, -0.04060921f, 0.01089147f, 0.08612636f, 0.04564834f, -0.10944822f, 0.20123389f, 
    -0.19049639f, 0.08548231f, 0.00035930f, 0.03561791f, -0.11138872f, -0.04118682f, -0.03667936f, -0.04640858f, 
    0.17794406f, 0.05651934f, 0.09209305f, 0.03045463f, 0.22186941f, -0.23626399f, 0.06675217f, 0.07650656f, 
    0.03029304f, -0.02996255f, 0.03630692f, -0.08896604f, 0.09607418f, 0.03560632f, 0.11404616f, 0.07068185f, 
    0.01670768f, -0.02253128f, -0.00186104f, -0.01668683f, -0.03368388f, -0.00562315f, -0.02300327f, -0.00061037f, 
    -0.03774938f, -0.01572503f, 0.02312723f, 0.03782968f, -0.03993621f, 0.01396861f, -0.04300892f, 0.01589083f, 
    -0.04812287f, 0.00897349f, 0.03348864f, 0.03874570f, -0.04923541f, -0.01522643f, 0.00410760f, 0.02348155f, 
    -0.04438515f, 0.04546809f, 0.02774227f, -0.00899377f, 0.02754484f, -0.02665810f, 0.04249279f, 0.01099163f, 
    -0.00416851f, -0.03839351f, -0.05336365f, -0.03223336f, 0.01687158f, -0.00804920f, 0.02219979f, -0.01572834f, 
    0.01982901f, -0.03905014f, 0.02088241f, 0.01289184f, 0.03493274f, 0.04489895f, -0.00258334f, 0.03527388f, 
    -0.02975720f, -0.01758116f, 0.01307889f, -0.03004575f, 0.02551531f, -0.05059443f, 0.03586711f, -0.05002566f, 
    0.05372442f, 0.02303126f, 0.03951717f, -0.03270316f, -0.03882292f, -0.04183500f, -0.05792318f, 0.01532374f, 
    0.02373045f, 0.01676175f, -0.04355473f, -0.03152191f, 0.00452171f, -0.02859475f, 0.01701317f, -0.04262787f, 
    -0.01601866f, 0.03161547f, -0.03316393f, -0.03814694f, 0.01455969f, 0.00926760f, -0.03893530f, 0.01482068f, 
    -0.03457324f, 0.02147704f, -0.05327211f, 0.01617639f, -0.03401542f, 0.02698056f, -0.00027092f, -0.05057859f, 
    0.04224630f, -0.02170479f, 0.03053105f, 0.00537355f, 0.03640512f, -0.05059056f, 0.03485220f, -0.03663018f, 
    -0.00894665f, 0.01235117f, -0.03181250f, -0.00314183f, 0.02188002f, 0.01952256f, -0.03131149f, -0.00184697f, 
    -0.04964988f, -0.02930896f, 0.03433548f, -0.01822223f, 0.03191448f, -0.03203551f, -0.01786975f, 0.00844461f, 
    -0.03529038f, 0.03356077f, -0.01363718f, 0.03173044f, -0.01573141f, -0.01670060f, 0.00945108f, -0.00377722f, 
    -0.04037063f, -0.05595817f, -0.01197977f, 0.01458498f, 0.04592580f, -0.04072086f, -0.03271628f, -0.01168182f, 
    -0.04171613f, 0.03033633f, 0.03098575f, 0.03116912f, 0.03112180f, 0.00882386f, 0.02341783f, -0.05281891f, 
    0.00746364f, -0.04957501f, -0.02580084f, -0.00704306f, -0.04924529f, 0.02860565f, -0.03042518f, -0.03807876f, 
    -0.03926393f, -0.04370429f, 0.02093436f, 0.03665894f, -0.01044956f, 0.04890788f, 0.02269901f, -0.04125276f, 
    0.00418199f, -0.02418365f, -0.02581465f, -0.01642171f, -0.03495077f, 0.01655096f, 0.03013032f, 0.01080823f, 
    0.02436646f, -0.02393038f, 0.03119528f, 0.04060826f, 0.02352995f, -0.00714018f, 0.01419893f, -0.02122908f, 
    -0.00480116f, -0.00499892f, -0.03597800f, -0.00679775f, 0.04068997f, -0.04803877f, 0.04187013f, 0.02509139f, 
    -0.04446902f, 0.03255206f, 0.01065570f, -0.02230285f, -0.00445372f, 0.00140513f, -0.00310195f, -0.02274824f, 
    0.03328425f, -0.04813887f, -0.04850568f, -0.05042721f, 0.02522528f, -0.02391196f, 0.00231422f, -0.02805543f, 
    0.02969249f, -0.01144016f, 0.00987582f, 0.03026269f, 0.04648941f, -0.03425862f, -0.05097808f, -0.04748904f, 
    -0.05023107f, 0.00069765f, 0.03104993f, -0.01233687f, -0.04535123f, 0.02317165f, -0.00350386f, 0.02124618f, 
    -0.00278263f, -0.05091831f, -0.04327191f, -0.00386755f, 0.01755805f, 0.03306179f, -0.02766200f, -0.04087679f, 
    0.00992378f, 0.01188732f, 0.01383558f, 0.00888473f, -0.01085338f, 0.04087486f, 0.00921480f, -0.02402236f, 
    -0.05424928f, -0.02209023f, -0.01964319f, -0.00576155f, -0.02125039f, -0.05160391f, -0.01524545f, 0.00289982f, 
    -0.00955199f, 0.00358463f, -0.01657537f, -0.06008997f, 0.00993550f, -0.03601680f, -0.02109865f, 0.04389185f, 
    -0.01677873f, 0.00090571f, 0.00480983f, -0.05419066f, 0.03206965f, -0.02281781f, 0.03809078f, -0.01620372f, 
    -0.02647856f, 0.00123364f, 0.01151441f, -0.01789233f, 0.03472179f, 0.04041213f, -0.02438792f, 0.03071068f, 
    -0.02979526f, -0.02276996f, -0.01972595f, -0.00012813f, 0.03160957f, 0.03781201f, -0.00262623f, -0.03776294f, 
    0.03641092f, 0.00419443f, 0.03660134f, 0.03607372f, 0.03077907f, 0.03816867f, 0.02987626f, 0.02755716f, 
    -0.00310780f, -0.01385383f, -0.03201635f, 0.04249698f, 0.02545213f, -0.02659026f, 0.03910339f, -0.01505680f, 
    0.03106965f, -0.02618680f, -0.03395095f, -0.01106062f, 0.00022441f, 0.05023072f, -0.05213727f, 0.02885934f, 
    0.02145855f, 0.02390649f, -0.01500019f, 0.02661214f, 0.04248287f, -0.01935044f, -0.05065974f, 0.03777831f, 
    0.00531492f, -0.02242182f, -0.05514725f, -0.03722620f, 0.05136747f, 0.00447506f, -0.05861352f, -0.00312517f, 
    -0.00982541f, 0.03926183f, 0.02510073f, -0.02357564f, 0.02301163f, -0.04439804f, 0.00700426f, -0.03422843f, 
    -0.03410279f, 0.02235869f, -0.02753040f, 0.00049156f, 0.02199220f, -0.03828682f, -0.04755615f, -0.04375853f, 
    0.03901291f, -0.01848966f, -0.00269046f, -0.00714180f, 0.02256463f, -0.01115388f, 0.03943832f, -0.00648624f, 
    -0.01268627f, -0.03762585f, -0.04223262f, -0.01101398f, -0.03393621f, -0.04833850f, -0.03300725f, 0.01020676f, 
    0.04753264f, -0.05253614f, -0.04564091f, 0.04223702f, -0.00150626f, -0.04785158f, -0.04802788f, 0.00696977f, 
    0.03750189f, 0.02863643f, 0.03590531f, 0.03329996f, 0.03317421f, 0.03313298f, 0.00055307f, 0.01080652f, 
    -0.05633494f, -0.02606305f, -0.05051160f, 0.03758069f, -0.04529824f, 0.01180036f, 0.01437557f, -0.04867344f, 
    -0.01438528f, 0.02815797f, -0.04156113f, 0.00315656f, 0.02835512f, 0.00151188f, 0.01132177f, -0.05134317f, 
    -0.03959466f, 0.03112904f, -0.03199569f, -0.03784428f, -0.00218444f, 0.04422630f, -0.01139117f, -0.00123615f, 
    0.04218300f, -0.02795776f, -0.01144373f, 0.03850575f, 0.03472985f, 0.05246728f, -0.00369278f, 0.03169617f, 
    -0.04053213f, -0.14076294f, 0.19615304f, -0.06927138f, 0.10764568f, 0.09328809f, 0.13214912f, 0.04081290f, 
    0.02932845f, 0.03399535f, -0.00291035f, -0.05924525f, 0.33718303f, 0.28043693f, -0.02888704f, -0.05273919f, 
    -0.04468504f, -0.04516134f, -0.00447280f, 0.09249721f, -0.00412993f, 0.09410872f, 0.07323924f, 0.12572730f, 
    0.21881711f, -0.08159483f, -0.05755895f, -0.02794064f, 0.06730289f, -0.00533710f, -0.04412355f, 0.08119066f, 
    0.07660514f, 0.00733468f, 0.07702153f, 0.05069421f, 0.06432125f, -0.05846731f, 0.01579699f, -0.01957432f, 
    0.15573312f, -0.11071407f, 0.10187060f, -0.03472703f, 0.01548794f, -0.10245271f, -0.03480984f, -0.01765565f, 
    -0.12790550f, 0.06166662f, -0.09374459f, -0.03598589f, 0.03361095f, -0.07014845f, 0.00041104f, 0.06330995f, 
    -0.02066574f, 0.00835609f, 0.13054466f, 0.03310999f, -0.06803993f, 0.08446714f, 0.08483580f, -0.12976858f, 
    0.07012753f, 0.03704512f, -0.02396594f, -0.02744375f, 0.07458858f, 0.09684842f, 0.05593633f, 0.07841177f, 
    -0.01148028f, 0.03701331f, 0.01026984f, 0.02077036f, -0.12063981f, -0.01211677f, -0.10821804f, 0.09107280f, 
    0.06300000f, 0.04248570f, 0.12015290f, 0.08331588f, 0.29756936f, -0.01621490f, 0.03430674f, -0.17041010f, 
    0.03418261f, 0.00404315f, -0.14178345f, 0.02569857f, -0.03497411f, 0.01017404f, -0.04323856f, -0.03668787f, 
    -0.12370154f, -0.14678222f, -0.01079098f, 0.25379032f, -0.01664563f, -0.00340160f, 0.01613978f, -0.01278852f, 
    -0.16780861f, -0.03127831f, -0.11891433f, 0.05163730f, -0.09284674f, 0.17960998f, 0.00651471f, 0.13440481f, 
    -0.11161835f, 0.06159235f, -0.14169842f, 0.11615412f, 0.07386206f, -0.13021465f, 0.03695514f, -0.03125566f, 
    -0.12775068f, -0.02364308f, 0.04890454f, 0.05476792f, 0.14233091f, -0.02264941f, -0.04175208f, 0.12616779f, 
    0.07943822f, -0.09251995f, 0.02246369f, 0.17502905f, 0.05671773f, 0.03961450f, 0.01773723f, 0.08209419f, 
    0.00465890f, -0.07671607f, -0.06221800f, 0.02419966f, 0.06189156f, 0.03308390f, 0.01485108f, 0.07570556f, 
    -0.05847156f, -0.22815815f, 0.02357096f, 0.03770470f, 0.06882519f, 0.12771881f, 0.05860947f, 0.01345158f, 
    0.02106196f, -0.00984895f, 0.05704186f, -0.02176738f, -0.37837219f, -0.14894518f, 0.11104030f, 0.32720554f, 
    0.03957560f, 0.12520662f, 0.05238546f, -0.01449985f, 0.18508828f, -0.05984127f, -0.07060391f, -0.04443342f, 
    0.00057087f, -0.15716508f, -0.01224952f, 0.04667744f, -0.05049477f, 0.09249509f, -0.02452807f, -0.02780237f, 
    0.07707959f, -0.04455671f, -0.12267796f, -0.21972214f, 0.17564487f, -0.14506476f, -0.03290709f, 0.10300265f, 
    0.03000515f, -0.01909940f, 0.00574695f, -0.03023184f, 0.06584927f, 0.08700990f, -0.10806216f, -0.21093774f, 
    0.54012167f, -0.03256539f, -0.13043119f, 0.00507492f, 0.11479143f, -0.11581439f, -0.06956404f, 0.02617739f, 
    0.03072938f, -0.04204436f, 0.03370011f, 0.04337259f, 0.30688086f, -0.13239419f, 0.00185323f, 0.24760507f, 
    0.09363367f, -0.01819374f, -0.02274622f, -0.09495419f, -0.05912567f, -0.00548351f, 0.10647892f, 0.03776540f, 
    0.08473539f, 0.02457054f, 0.02610183f, -0.12373263f, 0.06016842f, -0.19615693f, -0.19666114f, -0.12889241f, 
    0.00795881f, 0.11073192f, -0.12928578f, 0.02477518f, 0.07670098f, -0.07086241f, -0.04613674f, 0.17208004f, 
    0.13524529f, 0.03301569f, -0.00130767f, 0.10396253f, -0.04621569f, 0.07989465f, 0.06222453f, 0.09778173f, 
    0.17282984f, 0.14965183f, -0.16113466f, -0.05689285f, -0.04154900f, -0.09480110f, 0.07111287f, -0.04129503f, 
    0.02132537f, -0.12511259f, 0.01941392f, 0.03564184f, 0.05051471f, 0.05833239f, 0.20746213f, 0.16048628f, 
    0.01120032f, -0.06094450f, -0.06146870f, 0.10278767f, 0.01481835f, -0.06569012f, -0.05029935f, 0.00830272f, 
    0.01463945f, 0.08968638f, -0.09802517f, 0.18165709f, -0.03550172f, -0.04117423f, 0.01705059f, 0.02624804f, 
    0.06385213f, -0.05156152f, 0.03545039f, 0.02640356f, 0.19866936f, -0.08484973f, -0.03780773f, 0.09094559f, 
    -0.00325087f, -0.00033750f, 0.06343812f, 0.03366328f, 0.09128704f, 0.02517715f, 0.01928939f, 0.15970850f, 
    -0.79127216f, -0.04176102f, 0.06330863f, -0.02667968f, 0.00850423f, 0.02764528f, -0.06045153f, 0.02426328f, 
    0.10864515f, 0.00273148f, 0.10805360f, 0.03465415f, -0.28991589f, 0.10903759f, 0.07100434f, 0.13196354f, 
    0.03981011f, -0.02393753f, -0.10617787f, -0.14972807f, 0.02059938f, -0.02271227f, 0.02367516f, -0.04434912f, 
    -0.19953763f, 0.12465744f, -0.19709300f, -0.04395328f, 0.07661399f, -0.07657611f, 0.02397264f, 0.12957191f, 
    0.11911877f, -0.07246025f, 0.02415985f, -0.16202499f, 0.25489604f, -0.15844427f, -0.15024419f, 0.16915044f, 
    0.04262812f, -0.00644608f, -0.00762875f, 0.02090370f, -0.05083556f, 0.06285249f, -0.02310692f, 0.13629258f, 
    -0.23796538f, 0.03532080f, -0.00926750f, -0.25823557f, 0.03370876f, -0.04255829f, 0.09107085f, -0.04961793f, 
    0.01210783f, 0.03183331f, 0.06262033f, -0.11545829f, 0.22432272f, 0.27984938f, -0.24790809f, -0.10615594f, 
    0.07466126f, 0.13701887f, 0.17756185f, -0.06769796f, 0.04107570f, -0.01289232f, -0.15866657f, -0.15997702f, 
    -0.13817824f, 0.07052251f, -0.13659799f, 0.01948522f, 0.07069194f, -0.00483641f, -0.09098578f, -0.07179567f, 
    -0.08190385f, 0.10245819f, -0.06697078f, -0.00682423f, -0.17890461f, 0.12847534f, -0.02147036f, -0.10419664f, 
    0.04085518f, 0.01471111f, 0.06885140f, 0.00518485f, -0.01848551f, 0.06938607f, 0.06509724f, -0.07838356f, 
    0.01043284f, -0.00906215f, -0.04297187f, -0.03191311f, -0.00379158f, -0.01459623f, 0.01497560f, -0.04505849f, 
    0.00915431f, 0.00280697f, -0.04166561f, 0.01328932f, -0.01975504f, -0.00495655f, 0.02976114f, -0.00474449f, 
    -0.04395447f, -0.00126264f, -0.02355512f, 0.04976736f, 0.04309792f, -0.03022998f, 0.00666624f, 0.00669739f, 
    0.04577273f, -0.03556353f, 0.03209290f, 0.01964049f, -0.03594319f, 0.04487862f, -0.00553018f, 0.00763003f, 
    0.01528283f, 0.03524315f, 0.01821177f, -0.00937984f, -0.00119513f, 0.02970762f, -0.03958941f, -0.02624097f, 
    -0.00051009f, -0.01312098f, 0.03396357f, -0.03991934f, 0.04018890f, -0.00865257f, -0.00017533f, -0.01672887f, 
    -0.03254417f, 0.01672284f, -0.02267082f, -0.00766041f, -0.01585300f, -0.00428755f, -0.02877467f, -0.01334719f, 
    0.00638083f, -0.03625918f, 0.03701826f, -0.00605483f, 0.02223924f, -0.05304167f, 0.00295716f, 0.03012244f, 
    -0.03288639f, -0.01388404f, -0.03910394f, -0.01510502f, -0.01943115f, 0.01162766f, -0.00195578f, -0.00827800f, 
    -0.01952540f, -0.05125559f, -0.02325608f, 0.02617751f, 0.01677673f, -0.04738153f, -0.03743308f, 0.00990893f, 
    0.01504577f, -0.01414592f, -0.02214650f, -0.04101467f, 0.00705495f, 0.04447982f, 0.02917889f, -0.03371361f, 
    -0.04286393f, -0.05532983f, -0.02874077f, -0.01809389f, -0.02072349f, -0.01551721f, 0.03537573f, 0.01469498f, 
    0.02074040f, -0.00747065f, 0.05417280f, 0.01031802f, -0.02085402f, -0.05709443f, -0.05333585f, -0.01467047f, 
    -0.02239461f, -0.02428367f, -0.01435662f, 0.03476638f, -0.00491525f, -0.00575614f, -0.00524679f, -0.00239832f, 
    -0.03116539f, 0.02474240f, -0.00325538f, -0.02656067f, 0.03006544f, -0.02678966f, -0.00951704f, -0.03917253f, 
    0.00208512f, -0.00782663f, 0.02978116f, 0.03602562f, -0.00606311f, 0.02985990f, -0.04469137f, 0.03398154f, 
    -0.01249302f, 0.03853037f, -0.05073421f, 0.01919624f, 0.01642122f, -0.04485649f, 0.04376522f, -0.03750544f, 
    0.03234145f, -0.04211315f, -0.03731769f, 0.03239740f, 0.02443540f, 0.01751125f, 0.04203086f, 0.01358675f, 
    -0.02534334f, 0.00219606f, -0.05179838f, 0.00784217f, 0.03310661f, -0.01987916f, -0.04045022f, 0.04040763f, 
    -0.05329474f, -0.04030335f, 0.01993764f, 0.04198245f, -0.03443139f, -0.00924855f, 0.05343359f, 0.04401376f, 
    -0.03203031f, -0.04756488f, 0.02556153f, -0.01807250f, -0.00848418f, -0.03697543f, -0.01333673f, -0.04518469f, 
    0.00903106f, -0.00154002f, -0.01298606f, -0.00917675f, -0.04048185f, -0.03533172f, -0.03308180f, 0.00345952f, 
    -0.03442542f, -0.01073934f, -0.00532936f, -0.01818445f, -0.00487636f, 0.02710242f, 0.02177600f, -0.04272430f, 
    0.04015174f, -0.01847222f, -0.05129868f, -0.00781986f, 0.02794496f, -0.04564310f, 0.03094935f, 0.03786131f, 
    -0.03711725f, 0.02841386f, 0.03023515f, 0.00165583f, -0.02097847f, -0.00750869f, -0.00998416f, 0.00532561f, 
    -0.02705294f, 0.00602368f, 0.00610184f, 0.02011548f, -0.02368958f, 0.02125656f, 0.03729068f, -0.03556301f, 
    0.03019839f, 0.02785997f, -0.02316215f, 0.02626952f, -0.04491857f, -0.04659216f, 0.04978848f, -0.03884276f, 
    0.03129726f, -0.03869941f, -0.02073432f, 0.02618339f, -0.02207260f, -0.01137079f, -0.04783586f, -0.00325625f, 
    0.01630264f, -0.02636286f, 0.04561342f, -0.01539477f, -0.04673716f, 0.00874160f, -0.01083573f, 0.02922633f, 
    -0.03725903f, 0.03403739f, -0.04076929f, -0.00628832f, -0.00195721f, -0.00750146f, -0.03719971f, -0.02580282f, 
    0.01627285f, -0.05372781f, -0.03241822f, -0.04344103f, -0.03456104f, -0.04170400f, -0.03250725f, 0.00101591f, 
    -0.04645363f, -0.04047662f, -0.02347183f, 0.03030001f, 0.01862024f, -0.00287207f, 0.02191178f, -0.01964774f, 
    0.04344369f, 0.04248144f, 0.01252485f, -0.05498319f, 0.00336920f, -0.00798002f, 0.05109585f, -0.05429232f, 
    -0.03048730f, 0.04302100f, 0.05095852f, -0.02186920f, 0.03876960f, 0.03923342f, 0.00063186f, 0.01274064f, 
    -0.01843722f, -0.05262302f, -0.04448733f, -0.04519840f, -0.03886611f, -0.03244814f, 0.04602758f, 0.02302691f, 
    -0.01880538f, -0.04927098f, -0.04955626f, 0.01448096f, -0.02947739f, 0.00584977f, 0.01741890f, 0.02541267f, 
    -0.02376600f, -0.03767177f, 0.05444603f, -0.02769569f, 0.02067574f, -0.00541335f, -0.04741914f, 0.01885103f, 
    -0.02571899f, -0.00318611f, -0.03138100f, -0.02745401f, 0.03410595f, -0.02401663f, 0.03016241f, 0.03035845f, 
    0.00321899f, -0.02357554f, -0.01377934f, 0.05160021f, -0.04527769f, -0.04827914f, -0.00837513f, -0.05084814f, 
    0.00904821f, -0.04463942f, -0.03365756f, 0.04166693f, 0.02351925f, 0.01857828f, 0.02567287f, 0.01874022f, 
    0.00535443f, 0.03614222f, 0.03886456f, -0.05454537f, 0.03823653f, 0.02986734f, -0.00829206f, -0.02273898f, 
    -0.01046588f, -0.03486273f, -0.01248399f, -0.00839053f, 0.01658465f, -0.05389523f, -0.04372343f, -0.03184226f, 
    0.01323011f, 0.01251528f, 0.00447811f, -0.03407720f, -0.03379479f, -0.03039468f, 0.01288364f, 0.02909696f, 
    -0.00666276f, 0.03199573f, 0.02813043f, 0.03891420f, -0.02975214f, 0.00395013f, -0.04960326f, 0.00430398f, 
    -0.01094554f, 0.01851422f, 0.00423287f, -0.05855527f, -0.03052052f, 0.00156907f, 0.00078893f, 0.02316113f, 
    0.00177881f, -0.01067288f, 0.02754849f, -0.02984225f, 0.03326742f, -0.03356028f, -0.00891874f, 0.03357774f, 
    -0.05447049f, 0.03315969f, -0.03264350f, 0.01949429f, -0.02054066f, 0.03831449f, 0.03702560f, -0.04417186f, 
    0.02824214f, 0.04217489f, 0.02216382f, -0.03577632f, 0.01035452f, -0.02048521f, 0.04115727f, -0.03359856f, 
    0.06216365f, 0.03972681f, -0.16944775f, 0.08064488f, 0.02524966f, -0.06965839f, -0.11000453f, 0.21071064f, 
    -0.05560378f, -0.10321572f, 0.11222177f, -0.11464826f, 0.31974030f, -0.15265928f, 0.14403391f, -0.06067929f, 
    -0.07345961f, 0.05316470f, 0.02361183f, 0.00144531f, 0.08055913f, 0.03639839f, 0.03987567f, 0.07968544f, 
    0.09482338f, 0.09552415f, -0.15234584f, 0.29193598f, -0.08487678f, -0.05384166f, -0.01268723f, -0.06400385f, 
    -0.07697933f, -0.08047944f, 0.00378983f, 0.02307092f, -0.19912958f, -0.02594123f, -0.07539327f, 0.04599959f, 
    0.05651988f, -0.00195606f, -0.00781533f, 0.01155332f, -0.03263708f, 0.12085294f, 0.06621975f, -0.00622119f, 
    -0.02679612f, 0.04092093f, 0.10382268f, -0.05265580f, -0.04057368f, 0.00238026f, 0.00554750f, -0.14105129f, 
    0.04652483f, -0.04166147f, -0.09363841f, -0.00247885f, 0.09417886f, -0.15037000f, -0.15800649f, 0.27972296f, 
    -0.02511016f, -0.10114169f, 0.03390643f, 0.12964465f, -0.05782595f, -0.01500891f, 0.05754682f, -0.17321257f, 
    0.12017141f, -0.02983948f, 0.04847492f, -0.02668094f, -0.03363071f, -0.02058199f, 0.03934930f, -0.02732140f, 
    0.03000088f, -0.03095625f, -0.10823350f, -0.01076451f, -0.08993891f, -0.17675669f, 0.11495317f, 0.30543229f, 
    -0.11510448f, -0.03045861f, 0.08514627f, 0.01088086f, -0.03672820f, 0.06920926f, 0.06301165f, 0.09321386f, 
    0.24256864f, 0.09537794f, -0.06793221f, -0.01250812f, -0.01356932f, 0.01253188f, -0.03941445f, -0.04988901f, 
    0.21336852f, -0.00432536f, -0.01416687f, 0.02835784f, 0.09212385f, -0.02745998f, -0.01420003f, 0.06829892f, 
    0.01653746f, 0.08997422f, 0.14785095f, -0.02661908f, 0.12407783f, 0.20163603f, 0.06404533f, -0.06046260f, 
    -0.10339648f, 0.33672026f, -0.13177106f, -0.02238864f, 0.00113631f, -0.02919096f, 0.03297137f, -0.00437333f, 
    0.06302276f, 0.06545652f, 0.02101441f, -0.04583391f, 0.08016873f, 0.03473143f, 0.03665163f, -0.01458302f, 
    0.05879851f, 0.01102512f, -0.03670557f, 0.06023478f, -0.02556119f, -0.13795841f, 0.05155202f, -0.01673418f, 
    0.21561131f, -0.13356952f, 0.07865127f, -0.03179990f, -0.00366700f, 0.11569951f, -0.11851723f, -0.04931961f, 
    0.15178585f, 0.05020702f, -0.04632809f, 0.17878011f, 0.35075659f, 0.01739427f, -0.17691678f, -0.30174214f, 
    0.03836004f, 0.04333714f, -0.03286363f, 0.01795146f, -0.02229248f, -0.04262597f, 0.08432546f, 0.12487186f, 
    -0.11090495f, -0.06404639f, -0.14243041f, -0.10862812f, 0.17634749f, -0.11574680f, -0.04903301f, -0.10674582f, 
    -0.02147942f, 0.09529366f, 0.03161186f, 0.09867878f, -0.17241764f, 0.08154897f, -0.05236341f, -0.08831935f, 
    0.23169740f, 0.13764778f, 0.02679721f, 0.04585107f, 0.05536805f, 0.06473421f, 0.17899252f, 0.15576412f, 
    0.23396599f, 0.02241748f, 0.01937107f, -0.18046579f, -0.02041243f, 0.23815130f, 0.05873296f, 0.06256965f, 
    0.11826692f, -0.03788050f, -0.01755127f, -0.02834952f, 0.15118831f, 0.19892398f, -0.08015939f, 0.19351695f, 
    0.01295987f, 0.09694821f, -0.03761064f, -0.06203168f, 0.01686345f, 0.08396685f, -0.06891745f, 0.09811238f, 
    0.04106031f, 0.11919354f, -0.14264767f, 0.25512099f, -0.01211170f, 0.04067717f, -0.02483233f, 0.04594233f, 
    0.00386892f, -0.06329202f, -0.04913394f, 0.00295744f, -0.17498943f, -0.00926328f, -0.05644637f, 0.04878289f, 
    -0.02817890f, -0.04808790f, -0.00849902f, -0.11660136f, 0.08511750f, 0.07210055f, -0.00411069f, -0.01640180f, 
    0.05307250f, 0.20689777f, -0.10645760f, 0.09320438f, -0.00730486f, 0.08272172f, -0.04599005f, -0.00030045f, 
    0.12648669f, 0.06355328f, -0.01687239f, -0.13996777f, -0.10227657f, 0.08960066f, -0.10808958f, -0.05307677f, 
    0.01761638f, -0.01246660f, 0.01455056f, -0.03383995f, -0.07221305f, -0.13736969f, -0.02781399f, -0.03987934f, 
    -0.09770598f, -0.09803875f, 0.07922858f, 0.15262896f, -0.07376032f, 0.01083828f, 0.02658430f, 0.03178553f, 
    0.02044872f, -0.21333343f, -0.04979094f, -0.06756116f, -0.23062567f, 0.01383528f, -0.03243848f, 0.16883534f, 
    -0.04672227f, 0.12463440f, -0.16263939f, 0.02547000f, 0.06776386f, -0.00720057f, -0.08598001f, 0.03998211f, 
    0.09825723f, 0.09823947f, 0.06428927f, -0.07164975f, -0.01894919f, -0.16331673f, -0.02005727f, 0.07882563f, 
    -0.01662368f, -0.00970605f, 0.01019885f, 0.06221175f, 0.10950211f, -0.00412591f, 0.02515748f, -0.13474184f, 
    0.01507556f, -0.02090918f, -0.01019366f, 0.09825595f, 0.06698529f, -0.06932335f, 0.17807746f, 0.08621071f, 
    -0.27672729f, 0.14275786f, 0.13706672f, 0.01392357f, 0.07464479f, 0.02590539f, -0.00434782f, -0.08740166f, 
    -0.07350774f, 0.03188547f, 0.00343058f, 0.18788391f, 0.14617273f, 0.09170694f, -0.11448893f, 0.07673646f, 
    0.12464282f, 0.00829189f, 0.04698323f, -0.11288228f, -0.06469629f, -0.07699998f, 0.04437438f, -0.21407752f, 
    -0.07110690f, -0.11183457f, 0.09031837f, 0.17490476f, 0.05295773f, -0.01025572f, -0.02663235f, 0.24331309f, 
    -0.00065562f, -0.00148554f, 0.05234959f, -0.08597011f, -0.12621208f, -0.16850074f, 0.05110858f, 0.21386108f, 
    -0.07118749f, -0.07167852f, -0.05423418f, 0.17145644f, -0.04447249f, 0.06934265f, 0.12444647f, -0.07473911f, 
    0.08374729f, 0.09280279f, 0.07725909f, -0.12404086f, -0.05929369f, -0.00820123f, 0.03222970f, 0.13853052f, 
    -0.01624017f, -0.05255245f, 0.13777457f, -0.01292298f, -0.22008485f, 0.06427713f, 0.00997581f, -0.01327124f, 
    -0.02841180f, -0.11037795f, -0.00044691f, -0.04426323f, -0.07244710f, -0.00324788f, -0.07977162f, -0.03644517f, 
    -0.05606878f, 0.25850618f, -0.17004971f, 0.21724503f, -0.04371708f, -0.12239491f, -0.08609831f, 0.18763840f, 
    0.04022898f, -0.07812154f, 0.18880433f, -0.02080166f, 0.11711872f, -0.11943172f, 0.09566648f, -0.00025673f, 
    -0.01079628f, 0.16284794f, 0.07758532f, -0.05567484f, -0.06432397f, -0.00593016f, -0.06043981f, 0.04868742f, 
    0.07909614f, 0.26462972f, 0.10754739f, 0.14125119f, -0.02655889f, 0.09181530f, 0.03868538f, -0.08423882f, 
    -0.09397757f, -0.00734382f, -0.00053331f, 0.01708415f, -0.07183379f, 0.20084566f, 0.03996773f, -0.03632953f, 
    -0.11176459f, 0.07298522f, -0.00577695f, 0.02405405f, -0.04420456f, 0.10603175f, 0.05946602f, -0.06440102f, 
    -0.07818517f, -0.12232326f, 0.25009462f, -0.00831768f, 0.04816991f, 0.00992874f, -0.06449486f, -0.11915140f, 
    0.08208506f, 0.07183474f, -0.07624064f, -0.11793506f, 0.32341224f, -0.26133588f, -0.06543314f, 0.22950634f, 
    0.00324532f, 0.02028912f, 0.05489972f, 0.04711401f, -0.06067626f, -0.05450586f, -0.09938391f, -0.15045363f, 
    0.17097855f, -0.19159141f, 0.05389400f, -0.00396258f, 0.11137731f, -0.06489854f, 0.09150495f, -0.06484820f, 
    -0.03181387f, -0.05169914f, -0.15125787f, -0.05991951f, -0.14050053f, 0.07944474f, 0.12905802f, 0.13459928f, 
    -0.01261123f, -0.01530304f, 0.07306973f, 0.11840736f, 0.00918183f, -0.01954675f, -0.02950308f, 0.08275844f, 
    0.15240084f, 0.07794549f, -0.01373736f, -0.06616149f, 0.05000156f, 0.06859549f, 0.02780410f, -0.00766023f, 
    0.09088320f, 0.00131184f, 0.18215403f, -0.02155743f, 0.13817407f, -0.20633540f, 0.01660389f, 0.08611847f, 
    0.08620436f, -0.04467105f, 0.13075970f, -0.00360985f, 0.11963224f, 0.17859215f, 0.14852127f, -0.07261435f, 
    -0.16104899f, 0.17279695f, 0.05459347f, -0.02602286f, -0.16543521f, -0.01146967f, -0.05518658f, -0.09506574f, 
    -0.02856711f, 0.05575528f, 0.01686230f, -0.12395478f, -0.04635714f, -0.11676145f, 0.02420565f, 0.00294918f, 
    0.04279490f, 0.09110573f, -0.01130307f, -0.01857815f, -0.00043173f, -0.06473142f, 0.00598890f, -0.04558761f, 
    -0.02890286f, -0.02530014f, 0.17871043f, -0.04612677f, 0.04296074f, 0.04284422f, -0.04754799f, 0.02196803f, 
    0.04291944f, -0.02698028f, -0.01721241f, 0.13432641f, 0.34240919f, -0.03327676f, -0.02697663f, -0.23884441f, 
    0.08624130f, -0.00197354f, -0.00734328f, 0.05643745f, -0.07084975f, -0.01412317f, 0.11740857f, 0.06478940f, 
    -0.21720307f, 0.23347700f, -0.07872184f, -0.09078199f, 0.16957097f, -0.05808388f, -0.03460430f, -0.06118986f, 
    -0.10335173f, 0.08453833f, 0.06990366f, 0.07136991f, -0.19144414f, 0.22190517f, -0.15489456f, -0.04838137f, 
    0.05915829f, 0.01584123f, -0.02109001f, 0.00354488f, -0.08496025f, 0.06431524f, 0.15012559f, 0.18751620f, 
    -0.04936223f, 0.10238748f, 0.11653078f, -0.15579747f, -0.13171361f, 0.17741863f, 0.11035065f, 0.05007821f, 
    0.04339543f, -0.07267032f, 0.00825101f, -0.13406542f, -0.08327415f, 0.33361626f, -0.00348746f, -0.06148343f, 
    0.04620660f, 0.08582366f, 0.01355422f, 0.04098418f, 0.03379052f, 0.02514658f, -0.12047030f, 0.09083018f, 
    0.03894656f, 0.15201217f, -0.02845597f, 0.12690867f, -0.02906197f, 0.02094668f, 0.14629257f, 0.10415985f, 
    -0.02661277f, -0.06698021f, 0.08651515f, -0.08354902f, -0.18511052f, -0.08488067f, -0.08440324f, -0.07103994f, 
    -0.09433272f, -0.04267724f, 0.06100397f, -0.14769205f, 0.09520803f, -0.02931911f, -0.02077650f, -0.02104283f, 
    0.09409274f, 0.04603307f, 0.07804231f, 0.09833600f, -0.01948574f, 0.04588781f, 0.01710900f, 0.01340972f, 
    0.02074997f, 0.13956456f, -0.01475149f, -0.00830286f, 0.22399117f, -0.05337371f, -0.29745784f, -0.04760556f, 
    -0.14041783f, 0.02736813f, 0.03587669f, -0.09885237f, -0.13538608f, -0.12262924f, -0.02471002f, 0.03285797f, 
    -0.17024942f, -0.21725854f, 0.11081441f, 0.09565261f, -0.00540001f, 0.14261727f, -0.04389612f, 0.09192431f, 
    0.03741610f, -0.07873297f, -0.16825601f, -0.14960261f, -0.23343040f, -0.03213511f, -0.02626053f, -0.06590839f, 
    0.00768273f, 0.15962304f, -0.10900664f, -0.04199783f, 0.02881783f, 0.01396609f, -0.06896971f, -0.09673086f, 
    0.47211847f, 0.08082890f, 0.10201502f, 0.16079877f, 0.16805591f, -0.09270112f, 0.05252815f, -0.00320254f, 
    -0.06943481f, -0.00005795f, -0.03237054f, 0.20798862f, 0.51015323f, 0.02787201f, -0.01657953f, -0.04721581f, 
    0.07334346f, 0.00630652f, 0.06693042f, 0.08700423f, 0.07945763f, -0.09979442f, 0.20815592f, 0.10302191f, 
    0.00461814f, -0.09676373f, 0.21015096f, -0.00043067f, -0.00597136f, 0.08012003f, -0.12374189f, -0.16098052f, 
    -0.08713651f, 0.12658833f, 0.00678712f, 0.19875513f, -0.25289860f, 0.30139908f, 0.11917723f, -0.08335851f, 
    0.01369397f, 0.02567619f, 0.01089412f, -0.09300666f, -0.05832935f, -0.09681405f, 0.09532111f, -0.17191908f, 
    0.04919802f, -0.13088581f, 0.09385712f, 0.13736403f, 0.07990811f, 0.06439177f, 0.00995751f, 0.10398052f, 
    0.07575193f, -0.09372353f, 0.05791628f, -0.04490274f, -0.03933340f, -0.15479566f, 0.12801605f, 0.15034103f, 
    0.12940796f, 0.08652978f, -0.02804153f, 0.16965742f, -0.06023455f, 0.14375749f, 0.13087450f, 0.06046771f, 
    0.06304324f, -0.02949523f, -0.00739078f, 0.08093323f, -0.04848606f, 0.00342597f, 0.04272606f, 0.12113947f, 
    0.07770166f, 0.03095402f, 0.08193596f, -0.02843653f, 0.11730935f, -0.13229394f, 0.07349399f, -0.01730894f, 
    0.03906202f, -0.09518518f, -0.02024142f, -0.04649048f, 0.01595605f, -0.01924128f, -0.03406918f, 0.02958434f, 
    -0.02637226f, 0.00905972f, -0.04639522f, -0.02760831f, 0.04019961f, 0.00224799f, 0.03077905f, -0.04417701f, 
    0.03602383f, 0.01444055f, -0.00801435f, -0.05543229f, 0.02094819f, -0.03539224f, 0.00602300f, 0.03057522f, 
    -0.02560886f, 0.02915070f, 0.00223584f, 0.03986291f, -0.00083017f, -0.01452584f, -0.01513708f, 0.02880142f, 
    -0.04506973f, -0.01753414f, 0.03505336f, 0.00100407f, 0.01540155f, 0.03513340f, -0.01172140f, -0.00222491f, 
    0.01847371f, -0.05106322f, 0.03832605f, -0.04514236f, 0.03213764f, -0.04591703f, 0.03160396f, -0.00729016f, 
    -0.04932262f, -0.01670473f, 0.04168728f, -0.03384787f, 0.03874446f, -0.05276068f, 0.01844104f, 0.03351790f, 
    0.00186878f, -0.02871195f, 0.01419414f, 0.00727103f, 0.02061464f, 0.03570697f, 0.01467631f, -0.02329547f, 
    0.01995487f, 0.02447077f, -0.05258876f, -0.01331846f, 0.00404348f, -0.03845659f, 0.02280653f, -0.00166297f, 
    0.00249059f, 0.00221985f, 0.03089213f, 0.03258740f, 0.02011004f, 0.00605792f, -0.05181488f, -0.03041655f, 
    -0.03377783f, 0.01451829f, -0.05160365f, -0.03331570f, -0.01324317f, 0.01758457f, -0.02309217f, 0.04210303f, 
    -0.03876479f, 0.01441136f, 0.01527413f, 0.00005066f, 0.00222536f, 0.02516540f, -0.00794942f, -0.05545902f, 
    0.01421949f, -0.00054450f, 0.00842016f, 0.03738829f, 0.01263068f, 0.00617442f, -0.02216476f, -0.01996838f, 
    -0.03782599f, -0.01764254f, 0.03530103f, 0.04494076f, 0.02459773f, -0.03657847f, -0.02470781f, -0.03732208f, 
    -0.05227471f, 0.01901371f, -0.01485848f, -0.02791550f, 0.02662134f, -0.05423843f, -0.04667257f, -0.01686877f, 
    0.01361796f, 0.00783391f, 0.00474523f, -0.03866612f, -0.05458242f, -0.04384488f, 0.03698505f, -0.01419651f, 
    -0.03509830f, -0.04619706f, 0.01146409f, -0.02524582f, 0.00050952f, 0.03271575f, -0.02253823f, -0.02028801f, 
    0.02830254f, 0.00403510f, -0.03743773f, -0.04058607f, -0.04085561f, 0.04282280f, 0.03272701f, 0.02257028f, 
    -0.00468506f, -0.04895951f, -0.03056802f, 0.01904235f, -0.03005677f, -0.05780239f, -0.04500207f, 0.01769429f, 
    -0.02258901f, -0.03634931f, 0.04172121f, -0.00006581f, 0.03245847f, 0.00467912f, 0.00267289f, -0.03444079f, 
    -0.02740762f, -0.05915153f, -0.00131968f, 0.03566352f, 0.00930866f, -0.03200283f, -0.03141125f, -0.05301745f, 
    0.04288925f, -0.00138128f, 0.04124944f, 0.01279329f, -0.02112920f, 0.04237407f, 0.02453814f, 0.00278165f, 
    -0.00222684f, -0.03161803f, 0.02363207f, 0.03265325f, 0.01453367f, -0.00754030f, -0.03907742f, -0.04527573f, 
    -0.01155469f, -0.04895024f, 0.03782747f, 0.01495497f, -0.03078047f, -0.04612242f, -0.05559423f, -0.03695391f, 
    0.02735804f, 0.04600437f, 0.01163470f, 0.01582755f, 0.02027383f, 0.02870775f, -0.02143776f, -0.00779753f, 
    -0.04791412f, -0.00117135f, 0.00743212f, 0.04207821f, 0.01961932f, 0.00920097f, 0.03298474f, 0.02335954f, 
    -0.01338492f, -0.05144802f, 0.01822456f, 0.02865057f, -0.05077315f, 0.01818107f, -0.04164521f, 0.02181227f, 
    0.04559764f, 0.00490946f, -0.03911956f, -0.02220651f, 0.02986397f, 0.00702510f, -0.02295210f, 0.00466290f, 
    0.02765308f, -0.04227211f, -0.04317493f, -0.03716375f, -0.01624661f, -0.04495081f, 0.02068543f, -0.04356463f, 
    0.01752339f, -0.00783490f, -0.02171464f, -0.04429084f, -0.05540508f, -0.00895245f, 0.03348180f, 0.00355624f, 
    -0.01379402f, -0.05708487f, -0.05612469f, 0.01479901f, 0.02922640f, -0.05437227f, -0.04897056f, 0.01124986f, 
    -0.00707152f, 0.03860582f, -0.05688234f, 0.00847830f, -0.03590867f, -0.04112138f, -0.04954167f, 0.02526744f, 
    0.03808140f, -0.01038844f, 0.02677115f, -0.00613148f, 0.03959806f, -0.05856149f, 0.02944057f, 0.03707043f, 
    -0.00852521f, -0.04188266f, -0.00919494f, -0.01738489f, 0.04110286f, 0.04178734f, -0.04247445f, 0.03491994f, 
    0.04029778f, -0.03722752f, 0.02677728f, -0.01700595f, 0.03594781f, -0.03156780f, 0.00522013f, 0.04332161f, 
    0.03222647f, -0.03110579f, -0.04092239f, 0.03168258f, -0.03138207f, 0.02773648f, 0.02185955f, 0.00876837f, 
    0.02539485f, -0.02529840f, -0.02342172f, -0.02593141f, -0.00077638f, 0.01646264f, -0.04232138f, -0.05342841f, 
    -0.02212588f, 0.02029378f, 0.01724384f, -0.03449620f, 0.04047967f, 0.03326447f, 0.01855287f, 0.03897906f, 
    -0.02864239f, -0.02171451f, -0.03356821f, 0.01248057f, 0.00545743f, 0.00054923f, -0.02921402f, -0.03953137f, 
    -0.00090187f, -0.01374944f, 0.03637217f, -0.02788030f, -0.00261492f, 0.03726946f, -0.04848715f, -0.04356359f, 
    0.02698212f, 0.02217367f, -0.01785573f, -0.05596655f, -0.02938590f, -0.00720801f, -0.04425668f, 0.00994790f, 
    -0.02945714f, 0.00442496f, -0.00975005f, -0.03606580f, -0.03043366f, -0.02408823f, -0.04500175f, -0.03827207f, 
    -0.03001783f, -0.04568972f, 0.03630823f, -0.00400870f, 0.02352472f, -0.01901796f, 0.00800421f, -0.02720354f, 
    0.03296951f, -0.00950722f, 0.01851945f, -0.03216741f, 0.04842480f, 0.03985840f, -0.01586210f, 0.01315185f, 
    0.03499656f, 0.01032502f, -0.05317074f, 0.03819386f, -0.02758083f, -0.03594902f, -0.02176746f, 0.01797393f, 
    -0.00076645f, -0.03287243f, 0.00779893f, 0.02458625f, -0.04048730f, -0.00497332f, 0.00167648f, -0.03041164f, 
    0.02134212f, 0.01656011f, 0.03865108f, -0.04980141f, 0.03345551f, 0.02883524f, -0.04178330f, 0.00859253f, 
    -0.02257627f, -0.02025223f, -0.05399085f, -0.03081273f, -0.05388445f, -0.00500116f, 0.03548863f, -0.04962090f, 
    -0.03225704f, -0.01646313f, -0.00197478f, -0.02684711f, 0.02923261f, -0.00884692f, 0.03032456f, 0.03056957f, 
    0.25337762f, 0.01755017f, 0.10032701f, -0.16480272f, 0.22649419f, 0.13753331f, 0.13940105f, -0.09685443f, 
    0.01221216f, 0.13081019f, -0.08435420f, 0.08508678f, 0.30330005f, 0.03777080f, -0.09742701f, 0.26149833f, 
    0.14548138f, -0.18667036f, 0.04190541f, 0.00600875f, 0.00722181f, 0.09416973f, 0.03180115f, 0.10285621f, 
    0.28657079f, -0.04077892f, 0.00909318f, -0.15088043f, 0.04734931f, -0.01425129f, 0.05698417f, 0.01574814f, 
    -0.02773282f, -0.02265675f, 0.13572155f, -0.04979637f, 0.01579449f, -0.01191032f, -0.01470579f, -0.04749952f, 
    0.10963783f, -0.03301988f, 0.04728066f, -0.01661164f, -0.02984378f, -0.00209766f, -0.01592350f, 0.07970483f, 
    -0.35306406f, 0.29164147f, 0.09410764f, -0.07330625f, 0.23312065f, -0.05531448f, -0.01179057f, 0.04307694f, 
    0.01350668f, 0.07286254f, 0.10432995f, 0.00953969f, -0.10392676f, 0.21313810f, 0.21230261f, 0.10637020f, 
    -0.01787047f, -0.06434850f, -0.00578175f, 0.00652011f, 0.09079893f, -0.01630137f, 0.00281846f, 0.00636925f, 
    0.04494585f, 0.24384235f, 0.12920992f, -0.02373384f, -0.00813601f, 0.11512982f, 0.01223057f, 0.01520468f, 
    0.13795952f, 0.08578926f, -0.00084162f, 0.00800302f, 0.26183009f, 0.05711975f, -0.26978821f, 0.09416708f, 
    -0.04220781f, -0.04447762f, -0.07844049f, -0.08107821f, 0.14018221f, 0.06215683f, 0.02124624f, -0.00551356f, 
    0.11129962f, -0.13277803f, 0.22139934f, 0.15257637f, -0.06019035f, -0.01419898f, 0.02274561f, 0.08007751f, 
    0.06249009f, 0.07004487f, -0.07002883f, 0.02134405f, 0.08887487f, 0.05566601f, 0.13160844f, 0.10880098f, 
    -0.11041651f, 0.03004076f, 0.06163258f, -0.00938669f, 0.10231074f, 0.00654604f, 0.03184054f, 0.01488953f, 
    -0.01399766f, 0.08503031f, -0.09780631f, -0.06940915f, 0.18070568f, -0.01299809f, 0.07923253f, 0.13274196f, 
    0.00221474f, 0.04992751f, 0.04251128f, 0.06142674f, 0.31213832f, 0.13853577f, -0.01282168f, 0.03144716f, 
    0.09169046f, 0.10622439f, 0.00398839f, 0.11800007f, 0.05835214f, 0.00570121f, -0.01537837f, -0.00238701f, 
    0.07545880f, -0.03178696f, 0.01059521f, 0.09859338f, 0.00220233f, 0.04685417f, 0.13554187f, 0.01635065f, 
    -0.01105724f, 0.15408206f, 0.10326196f, 0.05534315f, 0.03489284f, 0.10252752f, -0.12951833f, 0.40859339f, 
    0.09658117f, 0.05914173f, -0.01694052f, 0.05048956f, -0.04851960f, 0.02454431f, -0.09350035f, 0.04194136f, 
    0.25397354f, 0.01982592f, 0.08636211f, 0.04067710f, -0.14543273f, 0.02844583f, 0.13934118f, 0.10994264f, 
    0.05816878f, -0.09186015f, 0.10647146f, 0.02630403f, 0.29180816f, 0.06091527f, 0.17855835f, 0.04592680f, 
    -0.03328752f, -0.08310974f, 0.07533210f, -0.01452725f, 0.03640341f, -0.02436749f, 0.00368992f, -0.03138512f, 
    0.14308748f, 0.11242260f, -0.02849649f, -0.01390340f, 0.20321858f, -0.04070777f, -0.12245002f, 0.04068120f, 
    0.09396546f, 0.09953694f, 0.08607418f, 0.08130114f, 0.18847911f, 0.12482359f, 0.09809269f, 0.13118421f, 
    -0.10574310f, 0.04443726f, -0.00330767f, 0.02735141f, 0.03464505f, 0.01142295f, 0.06590160f, 0.09042755f, 
    -0.02026037f, -0.02996129f, -0.04934055f, 0.14878324f, 0.12829448f, -0.00810358f, -0.09278508f, -0.00639075f, 
    0.07856127f, 0.00520490f, 0.02389101f, 0.00224489f, 0.11207686f, -0.06560587f, 0.08985451f, 0.05273596f, 
    0.03348354f, 0.03745183f, 0.06205139f, 0.06181196f, 0.08040538f, 0.03632005f, -0.10302232f, 0.15166683f, 
    0.26526415f, 0.25422809f, 0.06595945f, -0.08104989f, 0.14491402f, 0.05335520f, 0.06401432f, 0.02748897f, 
    0.01935484f, -0.03130113f, 0.03551415f, -0.08410256f, -0.01703123f, -0.11438642f, 0.20868567f, 0.29862133f, 
    -0.00739942f, 0.00260700f, 0.01732916f, 0.04079039f, 0.03106567f, -0.04281853f, 0.06442625f, 0.01693521f, 
    0.13286489f, 0.14296934f, -0.01443871f, 0.14343752f, 0.03759282f, 0.00526585f, -0.06182673f, 0.03165936f, 
    -0.12589027f, 0.03610479f, 0.06689278f, 0.05597920f, 0.06879159f, -0.03754705f, -0.08538984f, 0.06620945f, 
    0.08744539f, -0.01127412f, 0.03111307f, 0.16516928f, 0.06469232f, 0.01994094f, 0.10278765f, 0.04344252f, 
    -0.17184785f, -0.07104314f, 0.07331224f, 0.14299642f, -0.00826180f, 0.14752233f, -0.03861616f, -0.02726348f, 
    0.05970147f, 0.06891288f, 0.03949941f, -0.07702379f, -0.26965874f, 0.06533204f, 0.04174606f, -0.04892950f, 
    -0.04228633f, 0.10791561f, -0.02073761f, 0.02600346f, -0.09111483f, 0.04433920f, -0.01047491f, 0.02155835f, 
    -0.20633636f, 0.12770054f, -0.01286879f, -0.16569196f, 0.12123747f, 0.05759460f, 0.04794687f, 0.06020812f, 
    0.14345095f, -0.07469635f, 0.00411107f, -0.03156935f, 0.16321127f, 0.00741866f, 0.13424459f, 0.03543077f, 
    0.01952132f, 0.09320245f, 0.03702077f, 0.10077122f, 0.05558376f, 0.03196685f, 0.04466847f, 0.17760177f, 
    -0.29653427f, -0.08165989f, 0.04362038f, 0.03415198f, -0.00421460f, 0.07046817f, 0.04803465f, -0.08517815f, 
    0.02814582f, 0.03421400f, 0.06017333f, -0.04544652f, 0.07029884f, 0.36759657f, 0.03037001f, -0.08065080f, 
    0.02205297f, -0.00726308f, 0.07726806f, -0.11767363f, 0.01605191f, -0.03832837f, -0.07125410f, -0.05086630f, 
    0.26415959f, 0.11323988f, 0.06977591f, 0.15716188f, 0.09263655f, -0.09297432f, 0.07261895f, 0.06746411f, 
    0.04052797f, 0.04746521f, 0.03083589f, 0.10555658f, -0.21826874f, 0.15338385f, 0.00606628f, -0.09518891f, 
    0.02643643f, 0.10795401f, 0.25906953f, 0.06838677f, 0.08759256f, -0.01657115f, 0.07736527f, -0.01520184f, 
    -0.05219409f, -0.03843800f, 0.01164786f, 0.01186259f, -0.05588757f, 0.00658483f, -0.00303943f, 0.01544845f, 
    0.02605130f, 0.02833043f, -0.03908945f, -0.03673200f, 0.04228656f, -0.02282431f, -0.03856931f, -0.03686562f, 
    0.00719169f, 0.02671563f, 0.01552845f, 0.02940611f, -0.02012931f, -0.04351922f, -0.02075820f, 0.01981782f, 
    -0.03089744f, 0.02919137f, -0.05117759f, 0.02619843f, -0.00676145f, -0.03657773f, -0.03146116f, -0.00082759f, 
    -0.04278345f, 0.01144517f, -0.00904423f, -0.05517629f, 0.02344904f, 0.00135997f, -0.00852214f, 0.02110294f, 
    0.03314912f, -0.05399769f, -0.00513556f, 0.02957609f, 0.00227516f, -0.01223933f, -0.05680076f, -0.03645535f, 
    -0.05496261f, -0.04464499f, 0.02747952f, -0.02841116f, -0.05733790f, 0.01442524f, -0.01488549f, 0.00394885f, 
    0.00027828f, 0.04406174f, 0.02178210f, -0.05388813f, -0.01936533f, -0.03370383f, -0.00366004f, -0.00999879f, 
    -0.00783531f, -0.00475750f, 0.03145692f, -0.05691618f, -0.02320407f, 0.02624114f, 0.01354930f, -0.01354205f, 
    0.03433122f, 0.00568816f, -0.02634763f, -0.05525349f, -0.04133379f, -0.01697544f, 0.02001791f, 0.03077064f, 
    0.00076815f, 0.03598078f, -0.02250007f, 0.00953305f, 0.02563220f, -0.00340850f, 0.02312660f, 0.00151151f, 
    -0.00768886f, 0.02007266f, -0.02605307f, -0.00788804f, -0.01993947f, 0.03213062f, -0.05179732f, 0.02782875f, 
    0.02626196f, 0.03708717f, 0.03579620f, -0.04437459f, -0.03284615f, -0.06026821f, 0.01430898f, -0.00452840f, 
    -0.03662622f, 0.01352102f, -0.00672144f, -0.04999866f, 0.00074889f, -0.04140979f, 0.01716785f, 0.02175691f, 
    -0.01645343f, -0.04288787f, 0.01518872f, 0.02713897f, -0.02033855f, -0.01557273f, -0.05008192f, -0.03908677f, 
    -0.03129218f, 0.00402584f, -0.00198835f, -0.05864179f, -0.02712462f, 0.01991576f, -0.01391378f, 0.00846235f, 
    -0.04189960f, -0.05138704f, 0.02539840f, 0.04068654f, -0.04693441f, 0.03579637f, -0.02484586f, 0.00042965f, 
    -0.03093295f, -0.00922776f, 0.02196806f, -0.05163710f, -0.05459947f, -0.01628782f, -0.00697918f, 0.03602455f, 
    -0.03567439f, -0.02947029f, -0.06080276f, -0.03471601f, -0.03241580f, -0.05505048f, -0.05495929f, 0.02551440f, 
    0.02277723f, -0.00276652f, -0.00066929f, 0.02156710f, 0.00475744f, -0.01643156f, 0.02047413f, 0.00121066f, 
    -0.01245852f, 0.01058192f, 0.03631173f, -0.00001354f, 0.02368928f, -0.05553321f, 0.00637601f, 0.01874743f, 
    0.04107150f, 0.00341637f, -0.05083161f, 0.00524604f, -0.01070646f, 0.02200465f, 0.02550933f, -0.03044183f, 
    0.01368906f, 0.02790443f, 0.00325381f, -0.00960794f, 0.01830117f, 0.01165786f, -0.00281318f, -0.03023423f, 
    -0.02070499f, 0.02294916f, -0.01071615f, -0.05274875f, 0.02907372f, -0.03519284f, 0.01745324f, -0.04105812f, 
    -0.02105835f, -0.00483091f, -0.05939830f, 0.00098480f, -0.02733762f, 0.02915774f, -0.01849923f, 0.01546901f, 
    0.00109158f, -0.04834663f, 0.02873280f, 0.02015173f, 0.02628081f, 0.02310916f, -0.04270852f, 0.03205806f, 
    -0.05476647f, -0.03734869f, 0.03220236f, -0.02584045f, 0.00980740f, 0.02216050f, 0.00751703f, -0.02748144f, 
    0.00651528f, -0.04715201f, 0.01208386f, 0.03332521f, -0.03104923f, 0.03708113f, -0.01770845f, -0.05559165f, 
    0.04189105f, 0.00928657f, 0.00545283f, 0.00647663f, -0.04510690f, 0.02615914f, -0.03890469f, 0.00561690f, 
    -0.04622090f, -0.04364095f, -0.00443030f, -0.04323862f, -0.00517771f, 0.01747154f, 0.03608413f, 0.00877803f, 
    0.03448785f, -0.01550582f, -0.02092630f, 0.03729907f, 0.01871077f, 0.01687815f, 0.00428828f, -0.01808387f, 
    0.01736225f, 0.00818237f, -0.00533217f, 0.04527932f, 0.03852142f, -0.02576033f, -0.03814660f, -0.00955249f, 
    0.01322629f, -0.02426538f, -0.03207191f, 0.02733609f, -0.02248917f, -0.05150774f, -0.02005075f, -0.05331776f, 
    0.02400940f, -0.05192531f, -0.04704410f, 0.02253816f, -0.03286462f, 0.01442171f, 0.01593060f, -0.05284869f, 
    -0.06022107f, -0.05123113f, -0.02873288f, -0.00687096f, 0.01688143f, 0.02506298f, -0.00218822f, 0.01665060f, 
    0.02760198f, -0.01452058f, 0.02130770f, -0.00564138f, -0.03372822f, -0.02841840f, -0.03580032f, 0.02233750f, 
    0.03713874f, -0.00679542f, 0.02264014f, -0.05001594f, -0.01199513f, 0.03548117f, 0.02509249f, 0.01937360f, 
    -0.03582777f, -0.03620249f, 0.01350266f, 0.04294250f, -0.03495075f, -0.01719550f, 0.03204994f, 0.01734627f, 
    0.00488095f, -0.05025879f, 0.02344094f, -0.03347370f, -0.04984078f, -0.04871705f, -0.01176257f, 0.03606583f, 
    0.03734182f, 0.01217464f, -0.00383364f, 0.02062329f, -0.00536103f, -0.03021384f, 0.03089356f, -0.03110658f, 
    -0.02792701f, 0.01201048f, -0.04969848f, 0.01780957f, 0.03895334f, 0.00433609f, 0.00247226f, -0.03552182f, 
    -0.03824266f, 0.02826213f, 0.02745824f, -0.00026548f, -0.04449138f, -0.05492209f, -0.03904488f, -0.05107335f, 
    0.00337864f, 0.02769916f, 0.03750959f, -0.02717670f, -0.04751020f, 0.03760834f, 0.02112743f, -0.05416006f, 
    -0.00758778f, -0.04122516f, -0.02769784f, -0.04510994f, 0.02253812f, -0.00550989f, 0.02880711f, -0.00685385f, 
    -0.01915581f, -0.03461859f, 0.01459452f, 0.03191079f, 0.04949484f, -0.02585569f, -0.04794441f, -0.01008559f, 
    -0.04285096f, 0.03749468f, -0.06342298f, -0.00822528f, -0.04942239f, -0.01608353f, -0.04401471f, -0.04558258f, 
    -0.03185589f, -0.04336487f, 0.02023198f, -0.01078095f, -0.03003772f, -0.00674239f, 0.03613609f, 0.03192772f, 
    0.00342581f, 0.02467086f, -0.05264878f, -0.01683456f, -0.01064778f, 0.02932034f, 0.01899440f, 0.00731162f, 
    -0.00320442f, 0.00648937f, -0.00556014f, -0.01509809f, -0.00260130f, -0.03220448f, 0.00278143f, 0.02762809f, 
    -0.01720326f, -0.05038783f, -0.02933213f, -0.03063933f, -0.05111622f, 0.00244101f, -0.03233108f, -0.00408178f, 
    -0.05984444f, -0.00657681f, -0.05097621f, -0.04541910f, -0.04185915f, -0.00079948f, 0.00204997f, -0.04681649f, 
    0.01976744f, 0.04430498f, 0.00621017f, 0.02581055f, 0.00165253f, 0.00994906f, -0.03881646f, 0.00945566f, 
    0.00478071f, 0.04093435f, 0.00054320f, 0.00694307f, 0.02167205f, 0.00904671f, -0.05884821f, -0.06455427f, 
    0.01757576f, 0.02515457f, -0.05920474f, 0.01555321f, -0.04675137f, 0.03589600f, -0.00045677f, -0.05830276f, 
    -0.04305531f, -0.02275116f, -0.04675582f, -0.04695399f, 0.02270004f, 0.00977396f, -0.02320774f, -0.01353164f, 
    -0.06262939f, -0.06148805f, -0.02802960f, -0.00259667f, -0.01179498f, 0.02292426f, 0.01642097f, -0.03659488f, 
    -0.04536435f, -0.01359200f, -0.03171870f, -0.02418232f, -0.02287758f, -0.05517003f, -0.01708165f, 0.00698896f, 
    -0.03742113f, 0.02513722f, -0.06106562f, 0.01746276f, 0.02748769f, -0.03420519f, 0.02871937f, 0.00180343f, 
    -0.01249979f, 0.00580108f, -0.04651785f, -0.02549104f, -0.03645340f, 0.00044871f, -0.04074627f, 0.01760069f, 
    -0.00530360f, -0.05425347f, -0.00285992f, -0.00136208f, 0.03698338f, 0.00581819f, -0.02062619f, -0.05313762f, 
    0.01158599f, -0.05331533f, -0.05260997f, 0.02931197f, -0.01661358f, -0.06636623f, 0.01899119f, -0.01471066f, 
    0.03031484f, -0.03066851f, -0.00850639f, -0.03655242f, 0.02140607f, 0.00981503f, 0.01182559f, 0.05927632f, 
    -0.00671119f, -0.00972134f, -0.01766500f, 0.05434613f, 0.03873596f, -0.03488432f, -0.04766541f, 0.04466988f, 
    0.01562911f, -0.00380662f, -0.04821714f, 0.03355614f, 0.02420546f, -0.04719701f, -0.03515288f, -0.01360110f, 
    0.04015045f, -0.05805013f, -0.04967697f, -0.03149159f, -0.01048474f, -0.04785984f, -0.03231781f, -0.02976812f, 
    -0.01671840f, 0.03430427f, 0.03771915f, -0.04166513f, 0.04400798f, 0.04294806f, -0.01832439f, -0.00568606f, 
    0.03328283f, 0.00228061f, 0.03140378f, 0.02239893f, -0.06617170f, 0.02957678f, -0.00286784f, 0.02586410f, 
    -0.02722431f, -0.04184022f, 0.02242835f, -0.03893258f, 0.00815646f, 0.00764974f, -0.00660517f, -0.02145299f, 
    -0.01630366f, -0.05639779f, 0.03609568f, 0.02385969f, 0.02152918f, 0.01001528f, -0.05000014f, 0.02486212f, 
    -0.04270308f, -0.01430880f, 0.02205258f, 0.01729937f, 0.01248543f, -0.05351168f, -0.03384366f, 0.00203819f, 
    -0.03344555f, 0.03684248f, 0.00924977f, -0.02100680f, 0.00942696f, -0.03402732f, 0.00721998f, -0.04871195f, 
    -0.05281033f, -0.03022514f, 0.01012257f, 0.04558316f, -0.02007621f, 0.04252158f, 0.03782626f, -0.02224202f, 
    -0.01077117f, 0.01513757f, -0.01759531f, -0.00209795f, -0.05213882f, -0.03347639f, -0.00870421f, 0.02844096f, 
    -0.03733027f, 0.04142859f, -0.00884268f, -0.06975916f, -0.04766634f, -0.04180578f, -0.00289648f, -0.01668332f, 
    -0.01662151f, -0.01217364f, 0.02910284f, 0.02904984f, -0.00797309f, 0.00281375f, 0.02286017f, -0.04073935f, 
    -0.01198040f, -0.05499662f, 0.04512736f, -0.04416657f, -0.00827541f, 0.00650777f, 0.04658112f, 0.02756802f, 
    -0.04659845f, 0.05125193f, 0.01936463f, -0.05239707f, 0.02653484f, -0.03119893f, 0.00544775f, 0.01453590f, 
    0.05556498f, -0.01315212f, -0.03763535f, -0.00803430f, 0.03546952f, -0.02980839f, -0.04801248f, -0.02376821f, 
    -0.04691199f, -0.02160867f, -0.03495710f, -0.03818647f, -0.04766744f, -0.04735000f, 0.00439263f, -0.01304820f, 
    -0.02700644f, 0.00780203f, 0.02698502f, -0.05709433f, -0.01366044f, 0.00360211f, 0.01999845f, 0.04037635f, 
    -0.05240804f, -0.02821225f, 0.01673082f, 0.02876266f, -0.01630105f, -0.05012982f, -0.00634876f, -0.04905817f, 
    -0.01731530f, 0.02807702f, 0.01765183f, -0.00505761f, -0.02897404f, -0.03181733f, 0.04252166f, -0.04963621f, 
    -0.03760055f, -0.02881561f, -0.03463583f, -0.00094333f, 0.00241947f, 0.00239006f, -0.01689121f, -0.03925287f, 
    0.01842448f, 0.01856248f, 0.01043600f, 0.02073271f, -0.05549162f, 0.00566737f, -0.05091940f, -0.06531849f, 
    0.04043464f, 0.02205866f, -0.03596729f, -0.02236255f, 0.00794097f, 0.00577182f, -0.04146725f, 0.00795836f, 
    0.02131934f, 0.03503444f, 0.01442796f, -0.00395195f, -0.00706759f, -0.04995629f, -0.01164061f, 0.03799592f, 
    0.03383978f, -0.00339744f, -0.02690269f, -0.02518232f, -0.04540682f, -0.00034472f, -0.04799828f, -0.01905442f, 
    -0.01236524f, -0.05794304f, -0.06198192f, -0.05519170f, 0.03070565f, -0.05329063f, -0.04289840f, 0.03045895f, 
    -0.01745586f, 0.03159430f, -0.02763430f, -0.04572517f, 0.04148813f, 0.02209197f, 0.05158716f, -0.01523605f, 
    -0.04592021f, -0.02276654f, -0.01005494f, -0.03361724f, -0.00738545f, -0.03903234f, -0.03419787f, -0.01784552f, 
    -0.02602254f, -0.05322767f, -0.03507969f, -0.00977744f, 0.02275613f, -0.03961898f, -0.04299953f, -0.01934806f, 
    -0.00890352f, -0.01163448f, -0.05780151f, -0.01459851f, -0.00861058f, -0.02726099f, -0.04043814f, 0.01001709f, 
    0.02323548f, 0.04964002f, 0.03077718f, 0.00260423f, -0.02142044f, -0.04903970f, -0.01394888f, -0.03597802f, 
    0.00588099f, -0.00457885f, -0.02192542f, 0.00826810f, 0.02729739f, 0.01820820f, -0.00397335f, 0.01206229f, 
    0.01926464f, -0.02797181f, -0.01124853f, 0.05088620f, 0.00198408f, -0.03706251f, 0.04149173f, -0.07135274f, 
    -0.03287736f, 0.02315477f, -0.00183777f, -0.03850985f, -0.00356945f, -0.04350765f, -0.02669143f, 0.00240309f, 
    -0.05297266f, -0.08563929f, 0.03818453f, -0.27487555f, 0.03778073f, -0.03694800f, -0.01749166f, -0.15357623f, 
    -0.00634759f, 0.03876665f, -0.02035997f, 0.18344119f, 0.08291039f, 0.09080526f, -0.26977971f, -0.10294378f, 
    0.00702338f, -0.02096740f, 0.06473176f, 0.04100655f, 0.17955872f, -0.11299218f, 0.04110054f, -0.08430848f, 
    -0.44647470f, -0.09848975f, 0.19784111f, 0.01743225f, -0.09036902f, -0.09295283f, -0.09183792f, 0.11065614f, 
    0.04523670f, 0.00761970f, 0.01329095f, -0.02258054f, 0.21157807f, -0.07933092f, -0.08546651f, 0.18801083f, 
    0.04052943f, 0.01833366f, 0.00602019f, -0.00286607f, 0.04409849f, 0.01602970f, 0.03127670f, 0.09064676f, 
    0.48089918f, 0.06097950f, 0.02803761f, -0.08585970f, -0.10482447f, -0.02120453f, 0.00050515f, 0.17896543f, 
    -0.03306198f, -0.15998654f, -0.00649737f, 0.04430237f, -0.10208639f, 0.44057190f, -0.02784503f, 0.06240242f, 
    0.13720623f, 0.05838264f, -0.02761170f, -0.06221758f, 0.03180865f, 0.10790453f, -0.00732257f, 0.08258566f, 
    -0.08265414f, 0.01099349f, -0.23537746f, -0.01179391f, 0.01933390f, 0.06490599f, 0.07100313f, 0.06399617f, 
    0.04589323f, 0.00983313f, 0.10262432f, -0.03424393f, -0.11037435f, 0.04726109f, 0.01882093f, -0.07342314f, 
    0.01781427f, 0.08722364f, 0.01943976f, -0.11817591f, 0.04901357f, -0.02768021f, 0.02784897f, -0.11921542f, 
    0.17457810f, 0.03417227f, -0.08286802f, 0.06823019f, 0.03694126f, 0.04712149f, -0.00504113f, 0.05727438f, 
    0.03500086f, 0.05962727f, 0.02653838f, -0.09399172f, -0.13965110f, 0.09522800f, -0.17317182f, -0.11179598f, 
    0.17879811f, -0.00077751f, -0.01411108f, -0.06763246f, -0.14235961f, -0.02421648f, -0.10491824f, 0.08828932f, 
    0.23887160f, 0.03303835f, -0.05917334f, -0.27651322f, 0.06275392f, 0.01672529f, 0.06978092f, 0.05490052f, 
    0.09379486f, 0.03757035f, 0.04526589f, 0.14419264f, 0.21912302f, -0.06128937f, -0.04505192f, 0.15528041f, 
    0.01159669f, -0.04613796f, 0.03744328f, 0.06646137f, 0.03579852f, 0.05489002f, 0.07577942f, 0.03891100f, 
    0.13089913f, 0.23407319f, -0.16356327f, -0.08102882f, -0.02007183f, 0.03154149f, -0.03986014f, 0.07093114f, 
    -0.01849212f, -0.05305987f, 0.02248265f, -0.04376936f, -0.13494253f, -0.06616281f, 0.19171633f, -0.20721009f, 
    -0.08096661f, -0.04639985f, 0.10201432f, 0.04221902f, 0.02189154f, -0.00636533f, -0.00995181f, 0.05410304f, 
    0.44949314f, -0.13817872f, 0.07074427f, 0.16192143f, 0.03408612f, 0.12767237f, 0.05678267f, 0.03639270f, 
    0.07875917f, -0.01708772f, 0.06727426f, 0.02724882f, 0.19371849f, -0.14330713f, 0.15696561f, 0.07051090f, 
    0.11990185f, 0.13340549f, 0.07364627f, -0.01021912f, 0.01454846f, 0.06206864f, -0.04879653f, -0.03039315f, 
    -0.07953928f, -0.09611221f, 0.05948228f, 0.08996735f, 0.00409526f, -0.05109443f, 0.05641048f, 0.01157618f, 
    -0.11029146f, 0.06412113f, -0.00512205f, 0.15975712f, 0.08200970f, -0.34258533f, 0.08009020f, 0.27440298f, 
    0.02627347f, -0.03236059f, -0.03137748f, -0.08752647f, 0.09189412f, 0.00124225f, 0.15921193f, -0.14314058f, 
    0.02951147f, 0.17329426f, -0.04920068f, 0.12016323f, -0.00882046f, 0.06320128f, -0.06221680f, 0.00763374f, 
    0.08615296f, 0.03015631f, -0.06088902f, -0.01387276f, 0.12326925f, 0.11651482f, 0.10612734f, 0.19577894f, 
    0.18673466f, 0.08829673f, -0.08423683f, 0.10184147f, 0.04416988f, 0.11160579f, -0.05704651f, -0.12483282f, 
    -0.29279301f, -0.19901977f, 0.02444761f, -0.09701703f, 0.11148279f, -0.00032761f, 0.03366556f, 0.11355716f, 
    0.06024521f, -0.06577895f, 0.14401700f, 0.07882868f, -0.27252746f, 0.18431821f, 0.16166775f, -0.17121416f, 
    0.21708781f, 0.06196063f, -0.08298714f, 0.08077092f, 0.16227166f, 0.17230739f, 0.12652542f, -0.13108192f, 
    0.04278881f, 0.15885726f, -0.15848379f, -0.28229326f, 0.03642482f, -0.07691590f, 0.03870775f, -0.06799048f, 
    0.03318072f, -0.00142901f, 0.19363920f, 0.09507356f, 0.00077721f, 0.09546251f, 0.04065495f, -0.00076139f, 
    0.13539052f, -0.10947814f, 0.05177195f, 0.05315264f, 0.03736508f, -0.04837810f, 0.08843125f, -0.09538047f, 
    0.01670485f, -0.01113683f, -0.05331567f, -0.31193095f, -0.15833840f, 0.03074774f, 0.12385167f, 0.01942896f, 
    -0.02872767f, 0.08815340f, -0.02130261f, -0.15206675f, -0.29056701f, -0.09473803f, 0.07930980f, 0.03030695f, 
    -0.18451853f, -0.00135369f, -0.04842014f, -0.00729962f, -0.11879938f, 0.10983980f, -0.10696937f, -0.03482644f, 
    0.38310131f, 0.16083801f, -0.01398264f, 0.11905230f, 0.03414064f, 0.14118002f, 0.15031169f, 0.16594821f, 
    0.09067841f, -0.12748618f, 0.02120312f, -0.06671733f, 0.19388449f, -0.18124089f, 0.03030576f, 0.37555906f, 
    0.01018358f, 0.01859683f, -0.01783342f, -0.01526491f, 0.14444476f, 0.04954869f, 0.05007182f, 0.09053481f, 
    0.19906536f, 0.16198157f, 0.13498171f, 0.20201178f, -0.04853177f, 0.04194639f, 0.01542402f, 0.12817255f, 
    -0.08357701f, 0.11037912f, -0.02631824f, 0.02708357f, -0.03124900f, -0.08130921f, 0.17817983f, 0.06465006f, 
    -0.15823330f, -0.14691089f, 0.03638834f, -0.16706389f, 0.12154718f, -0.21572761f, -0.04899728f, 0.04429502f, 
    0.03976814f, -0.09768865f, -0.04360189f, -0.11422002f, 0.06422879f, 0.01086065f, -0.05088287f, -0.18728253f, 
    -0.09691132f, 0.00358446f, -0.08449638f, 0.04534445f, 0.32795495f, -0.01843869f, 0.14856006f, 0.25154066f, 
    0.00586275f, 0.09852750f, -0.09938402f, -0.05653096f, 0.03260786f, -0.00982644f, 0.11580547f, -0.05070354f, 
    -0.07878108f, -0.01978800f, 0.00872059f, 0.07093419f, -0.11181271f, -0.02673088f, -0.10256166f, 0.19987160f, 
    -0.02519179f, -0.14925238f, 0.19009392f, -0.15517342f, 0.17710301f, 0.06733162f, 0.18551043f, -0.26171985f, 
    -0.06915673f, 0.09855741f, 0.02819541f, -0.03184606f, 0.08106090f, 0.00377880f, 0.05539084f, -0.03934289f, 
    0.05187423f, 0.17242417f, 0.11317877f, 0.15153804f, 0.08125823f, 0.01170081f, 0.04314071f, 0.04360578f, 
    -0.06350254f, 0.02807441f, -0.03554185f, 0.05531924f, -0.07161611f, -0.05451840f, -0.01071036f, 0.06574118f, 
    0.04481288f, 0.03826600f, -0.09868994f, 0.09248451f, 0.08394711f, 0.17681547f, 0.00235042f, 0.07767793f, 
    0.29602334f, -0.08844131f, 0.00644033f, 0.16282576f, -0.02179283f, 0.08371459f, 0.05965739f, 0.00107047f, 
    0.01553361f, -0.06783598f, -0.13961811f, -0.01734425f, 0.13321142f, -0.15270145f, -0.25201830f, 0.00044959f, 
    0.02784578f, 0.08675322f, -0.02695841f, 0.07977781f, 0.06548054f, -0.07209069f, 0.03198111f, -0.18909793f, 
    0.24455586f, 0.00385277f, -0.07148046f, 0.03066552f, -0.19356367f, -0.05934687f, 0.11195806f, -0.07818423f, 
    -0.11450720f, -0.12087631f, -0.08793215f, -0.07385838f, -0.02302418f, -0.03961661f, 0.30222014f, -0.03157818f, 
    0.09973466f, -0.08358234f, 0.17907156f, 0.09620374f, -0.04899447f, 0.01465824f, -0.02205446f, 0.07184436f, 
    0.14469533f, 0.06423508f, -0.11743851f, -0.10156128f, -0.01696873f, -0.05778381f, -0.03331621f, -0.00014134f, 
    0.06256359f, -0.01959784f, 0.13049352f, 0.11411691f, -0.08595346f, 0.06645948f, -0.07214307f, -0.19767478f, 
    0.09588008f, -0.08754995f, -0.02843883f, -0.06203621f, -0.10330237f, 0.11715461f, 0.02634249f, -0.05483752f, 
    -0.02750968f, 0.09208572f, -0.04646184f, 0.16049071f, -0.07020513f, 0.04011471f, 0.00544287f, 0.00886896f, 
    0.00050634f, 0.11312474f, 0.06635986f, 0.01659296f, 0.05973125f, -0.08260857f, -0.01630100f, 0.06558353f, 
    -0.03645799f, 0.06296112f, -0.03043667f, -0.07689757f, -0.01568506f, -0.02236892f, 0.05327574f, 0.04707180f, 
    0.08410422f, -0.18312897f, 0.09006347f, -0.04736846f, 0.16394910f, 0.05960592f, -0.00986761f, -0.03872116f, 
    0.02744325f, -0.11331425f, -0.06549215f, -0.00516772f, 0.10278604f, -0.14909257f, -0.00105537f, -0.26194194f, 
    -0.00528041f, 0.00817855f, 0.02252415f, 0.05935993f, -0.00630021f, -0.01127129f, 0.21632680f, 0.04753663f, 
    0.09365506f, 0.04608383f, -0.06208755f, -0.03715675f, 0.07713640f, 0.00470178f, -0.06877338f, -0.09453454f, 
    -0.08439576f, 0.17461200f, 0.00675807f, 0.05611560f, -0.10941064f, 0.20287473f, -0.04517588f, 0.07031886f, 
    0.07031687f, 0.09914673f, -0.02065862f, 0.02345590f, -0.12206806f, -0.00956116f, 0.11397931f, 0.18691912f, 
    0.12826505f, 0.07547744f, 0.15260193f, -0.05308590f, -0.22216423f, -0.05270192f, 0.13382101f, 0.00979402f, 
    -0.06291392f, -0.05082432f, 0.03854887f, -0.02662798f, 0.01065293f, 0.06734926f, -0.05912217f, -0.12308599f, 
    -0.04251047f, -0.07827415f, 0.00383708f, -0.05430884f, 0.11261993f, 0.02713143f, -0.14263310f, -0.02986935f, 
    0.16519412f, 0.04647845f, 0.01036473f, -0.08644115f, -0.00747997f, 0.10334937f, 0.22896607f, 0.01994939f, 
    0.00797179f, -0.03058825f, 0.06121033f, 0.05874250f, 0.03193133f, 0.07366031f, -0.11662316f, 0.01793659f, 
    -0.09601590f, -0.07536928f, -0.07170632f, -0.06884453f, 0.08627078f, 0.01242735f, 0.06761017f, -0.02663556f, 
    -0.22518028f, 0.01264001f, 0.05837602f, 0.03795482f, -0.09350698f, 0.15478405f, -0.10373089f, 0.05132136f, 
    0.05294553f, 0.01226366f, 0.09230925f, -0.02622199f, 0.08451135f, 0.22841921f, -0.11186238f, -0.34236044f, 
    -0.00602538f, -0.00900201f, -0.04952399f, -0.08277383f, -0.00964118f, 0.15151894f, -0.04973267f, -0.10992559f, 
    -0.12776913f, -0.16816446f, 0.12958242f, -0.08746585f, 0.00707272f, 0.03231057f, 0.11450157f, -0.04165370f, 
    0.11696006f, -0.08288616f, -0.04860473f, -0.20318423f, -0.07063888f, 0.08574050f, 0.18644929f, -0.14924465f, 
    -0.07335031f, -0.02715617f, -0.03553884f, 0.01882762f, 0.06194628f, -0.04989098f, -0.16260435f, -0.10315190f, 
    0.25086075f, 0.20588464f, -0.01415475f, 0.04890568f, 0.03156450f, -0.01026091f, 0.03122020f, 0.02766608f, 
    0.06782961f, -0.00505730f, -0.08086137f, 0.10224673f, 0.26302350f, 0.00034234f, -0.14567353f, 0.11256819f, 
    -0.06256175f, 0.03996431f, 0.08004154f, 0.07519951f, 0.11998130f, -0.05776646f, 0.12535806f, -0.01270774f, 
    0.03198584f, 0.07782372f, 0.04722800f, 0.17329009f, 0.06773707f, 0.09351668f, 0.00953585f, -0.05765485f, 
    -0.03338828f, 0.08079058f, 0.06040928f, 0.12714224f, 0.16115439f, 0.07341817f, 0.02181623f, 0.00226078f, 
    -0.02915104f, -0.08868390f, -0.07554214f, -0.00170025f, -0.02267711f, 0.01185042f, 0.09687293f, -0.19596939f, 
    0.48316529f, 0.00164477f, 0.19484971f, 0.15625930f, 0.08921445f, 0.14437598f, -0.08101640f, 0.28204393f, 
    -0.06030646f, -0.01982949f, 0.05111502f, 0.13631299f, -0.03091311f, -0.07810394f, 0.13257766f, -0.01330020f, 
    0.01718877f, 0.02946987f, -0.05521098f, 0.08512944f, 0.03590183f, 0.05521990f, 0.06992872f, 0.05530572f, 
    -0.08648507f, 0.01837558f, 0.12859602f, -0.07487947f, -0.03649985f, 0.03303960f, 0.01888407f, -0.00471288f, 
    0.04570537f, -0.09999517f, 0.02235109f, 0.00289500f, 0.03900304f, 0.05731118f, 0.05706033f, 0.21639377f, 
    0.11806188f, -0.06032350f, -0.21837518f, 0.04422482f, 0.00617265f, 0.01100305f, 0.02908894f, -0.00809248f, 
    -0.09159972f, -0.05059296f, 0.03689728f, 0.21350300f, -0.09092208f, -0.03330030f, -0.01845842f, -0.07847729f, 
    0.08658864f, 0.02777330f, 0.12698509f, 0.13750251f, -0.18632013f, 0.04683248f, 0.01398326f, -0.01452558f, 
    -0.04006056f, 0.10070409f, 0.06247560f, 0.06365276f, -0.02541568f, -0.04597267f, -0.07265887f, -0.07385267f, 
    -0.20229286f, 0.04233420f, 0.14595821f, -0.02653368f, 0.05340955f, 0.08304705f, 0.07940700f, 0.08923037f, 
    0.14922957f, 0.09877019f, -0.11045395f, 0.02694628f, 0.05861324f, 0.12039149f, 0.15884599f, 0.08232302f, 
    -0.00710216f, 0.03458630f, -0.00849255f, 0.05115595f, 0.08840451f, 0.02044649f, 0.06389067f, -0.02407380f, 
    0.50365824f, -0.16414149f, -0.02278926f, 0.01948332f, -0.15758380f, 0.06978902f, 0.05724847f, 0.03292146f, 
    0.01558153f, 0.06704170f, -0.01030753f, -0.00401140f, 0.03234685f, -0.09115309f, -0.01184953f, -0.15422319f, 
    0.14954525f, 0.15577383f, -0.01747366f, -0.01512801f, 0.01975800f, 0.01376202f, 0.01705821f, 0.16465545f, 
    0.03144506f, -0.16013208f, -0.02486893f, 0.03616301f, 0.00479436f, -0.02036413f, -0.04117868f, -0.03144465f, 
    -0.10710134f, -0.04895008f, 0.06821439f, -0.07152652f, -0.10627629f, 0.16192763f, 0.03510339f, -0.25332573f, 
    0.15499929f, 0.08384171f, 0.06607357f, 0.06885011f, -0.01450161f, -0.02718744f, 0.01907074f, -0.06343887f, 
    -0.04392369f, 0.06810284f, -0.10853431f, -0.00262878f, 0.05877011f, 0.03590301f, 0.04450584f, -0.05585342f, 
    -0.09387975f, 0.04748317f, 0.01651633f, -0.07462283f, -0.14135660f, -0.01244909f, -0.11930297f, 0.05458277f, 
    0.17237872f, -0.00974860f, -0.10491487f, 0.04151220f, 0.02063722f, 0.02512873f, -0.08861911f, 0.04682573f, 
    0.26738456f, -0.11006942f, 0.09747261f, -0.01528195f, -0.02994759f, 0.07476906f, 0.04472107f, -0.10953810f, 
    0.05025639f, -0.06454003f, 0.07223152f, 0.05257720f, -0.05882304f, -0.10206732f, 0.02384392f, -0.06380928f, 
    -0.00743715f, -0.00896996f, 0.00189565f, -0.10204402f, -0.04610398f, 0.12241799f, 0.01976292f, 0.04430417f, 
    -0.02972432f, 0.21561582f, -0.03749068f, -0.01502229f, 0.07564530f, -0.03942350f, 0.02230978f, 0.11978140f, 
    -0.00656304f, -0.04105110f, -0.02749337f, -0.11091413f, -0.13548169f, 0.01715569f, 0.23520978f, -0.11678682f, 
    0.02838115f, -0.00281562f, 0.11083679f, -0.01521154f, 0.03711440f, -0.01157227f, 0.07194846f, -0.05667375f, 
    -0.02379570f, 0.04662346f, 0.03771394f, -0.04820770f, 0.04498485f, 0.02943349f, 0.00496499f, 0.01296697f, 
    -0.05864702f, 0.04818919f, 0.05840083f, 0.08246972f, -0.19675986f, -0.14358693f, -0.02948523f, 0.02272769f, 
    -0.04457396f, 0.00628245f, -0.00358784f, 0.03969537f, 0.01170734f, -0.02792964f, -0.06934775f, -0.00266437f, 
    -0.29308975f, 0.07546785f, 0.16361041f, 0.24363884f, -0.09449250f, -0.02619653f, 0.11002403f, -0.03712213f, 
    -0.06356069f, -0.04866706f, 0.00512816f, -0.07306449f, -0.21211065f, -0.20165938f, 0.05973411f, -0.15412724f, 
    0.12460897f, -0.06156972f, -0.05409577f, -0.01788006f, 0.02309506f, 0.01005762f, -0.10323685f, -0.04862734f, 
    -0.09064782f, -0.03208002f, 0.10491057f, -0.13497247f, -0.04798919f, 0.02766289f, 0.15650846f, 0.13357729f, 
    0.00951000f, 0.10992407f, 0.01650741f, 0.12970679f, 0.30883643f, 0.25751853f, -0.05680824f, -0.04315627f, 
    0.13662863f, 0.13470784f, 0.06050842f, 0.02969829f, 0.02737880f, 0.02509658f, 0.12592545f, -0.06679676f, 
    -0.36954591f, -0.15414955f, 0.26869762f, -0.00567021f, 0.01996509f, 0.05629170f, 0.07771391f, 0.06844926f, 
    -0.03195886f, 0.01318351f, 0.00355173f, 0.12206232f, 0.05960734f, 0.08856045f, -0.08880170f, -0.13437724f, 
    0.13100976f, 0.07761532f, 0.00601513f, 0.00976163f, 0.02298691f, 0.16754112f, 0.06993116f, 0.09439428f, 
    0.04494304f, 0.02351676f, -0.02848266f, -0.19457006f, 0.17333359f, -0.03567023f, 0.09513011f, -0.08874980f, 
    -0.04754460f, 0.05619916f, -0.03546494f, -0.02495924f, 0.18950075f, 0.18932007f, 0.02648282f, -0.25849447f, 
    0.14480482f, -0.05099825f, 0.12082490f, -0.10128059f, -0.12716651f, 0.01839369f, 0.00433320f, -0.02949195f, 
    0.30491850f, 0.01596311f, -0.14971341f, -0.01770778f, 0.01869832f, 0.03035149f, 0.00369676f, 0.05525092f, 
    -0.06396597f, 0.00237865f, 0.06615510f, -0.05195062f, 0.20391469f, 0.00076038f, 0.00332770f, 0.07236929f, 
    -0.00799942f, 0.01798261f, 0.05994771f, 0.00499091f, -0.06143119f, 0.00789716f, -0.04573539f, -0.05433472f, 
    0.59829462f, -0.22404355f, -0.06643003f, 0.17812783f, -0.04380244f, 0.09927764f, 0.07178150f, 0.09315755f, 
    0.08242932f, 0.00756250f, 0.03638999f, -0.09578688f, -0.21239363f, 0.14861231f, -0.01484799f, -0.16821590f, 
    0.01608003f, 0.00705213f, -0.01838386f, 0.00446915f, 0.05159936f, 0.05608537f, 0.12018415f, 0.01561858f, 
    0.34985030f, 0.12900914f, -0.05908579f, -0.12612036f, -0.07970018f, -0.02638475f, -0.08638203f, 0.11443236f, 
    0.01048646f, 0.07098822f, -0.08914335f, 0.12646623f, 0.16578223f, -0.10065481f, 0.00847745f, -0.15057895f, 
    0.05169913f, 0.03060325f, -0.02666353f, 0.08343400f, 0.14820354f, -0.02606341f, 0.03030560f, 0.19256173f, 
    -0.17327188f, -0.05550328f, 0.16767991f, 0.09921095f, -0.03781036f, 0.09280991f, -0.01851205f, -0.02527356f, 
    0.05665100f, -0.03745739f, 0.05531816f, -0.02956108f, 0.53656965f, -0.19950275f, 0.06112970f, 0.17728405f, 
    0.02116614f, 0.01938959f, -0.17393878f, 0.00810580f, 0.07361449f, 0.03457657f, 0.03748862f, 0.11267716f, 
    0.28715351f, -0.10604059f, 0.10590075f, 0.01643509f, 0.11076257f, 0.04304073f, 0.00372084f, -0.00899736f, 
    -0.11639486f, -0.00512096f, 0.05620409f, 0.04798905f, -0.22750629f, -0.03018883f, 0.18562885f, 0.54779518f, 
    0.08963672f, -0.06356471f, -0.05051416f, 0.02023469f, -0.10994260f, 0.10211054f, -0.03954833f, 0.01831090f, 
    0.07840656f, 0.04898673f, -0.03847677f, -0.05380024f, 0.07201789f, 0.01761339f, 0.21314000f, -0.09053932f, 
    -0.04239701f, 0.10839935f, -0.01686233f, -0.09327996f, -0.24125022f, -0.02259135f, -0.01975195f, 0.04928089f, 
    0.02428006f, 0.12956946f, 0.08369552f, 0.00560414f, -0.03445410f, 0.07521413f, -0.00963024f, -0.06550376f, 
    -0.34256428f, 0.12678389f, 0.06142637f, -0.07294504f, 0.01595964f, 0.04209958f, 0.02891215f, -0.10647628f, 
    0.02986111f, 0.04190201f, -0.03601575f, -0.11299728f, -0.28575334f, -0.12228911f, 0.14149167f, 0.08437826f, 
    -0.09817315f, -0.01523741f, 0.02894456f, 0.15140504f, -0.03830827f, -0.13746552f, -0.01969289f, -0.11582002f, 
    0.08541980f, 0.11005362f, 0.22595167f, 0.03277200f, 0.09347287f, 0.04442735f, -0.02580554f, 0.00455825f, 
    0.02011059f, 0.06848720f, -0.05632981f, 0.00517951f, -0.07573403f, -0.05280034f, -0.32668966f, 0.21500263f, 
    -0.05518864f, 0.00318148f, 0.05526797f, 0.03016829f, 0.06718254f, 0.00007904f, 0.05597752f, 0.13263994f, 
    0.21698000f, -0.07990532f, 0.23855613f, -0.08202267f, 0.08451314f, -0.02761056f, -0.04289485f, 0.06714846f, 
    0.12672541f, 0.03569769f, 0.01320918f, 0.16319034f, 0.09764344f, 0.11520598f, 0.28797212f, 0.21433251f, 
    -0.07174982f, -0.05036182f, 0.18932801f, 0.02237220f, 0.26311737f, 0.09405591f, 0.10403278f, 0.03051723f, 
    0.01550793f, 0.10035437f, -0.02288409f, -0.01109039f, 0.01949494f, 0.01784620f, 0.06633595f, -0.05490932f, 
    0.10775793f, -0.07398666f, 0.03367607f, -0.15534912f, 0.08637001f, 0.10883650f, -0.00867776f, -0.13084483f, 
    0.14726783f, 0.07123187f, -0.02428476f, 0.13712531f, 0.09170414f, 0.01412730f, 0.10946660f, -0.07614487f, 
    0.27476212f, -0.08211897f, -0.03625593f, 0.12894353f, -0.05040104f, 0.03485151f, -0.01147288f, 0.02524120f, 
    -0.00635952f, 0.31845829f, 0.02336266f, 0.13255534f, 0.25376579f, 0.22142902f, -0.14568052f, 0.05661985f, 
    0.03204873f, 0.07257815f, -0.04658411f, -0.00607291f, -0.06675715f, 0.01981249f, 0.07883263f, -0.02525347f, 
    -0.14212938f, -0.02727220f, -0.08042321f, -0.22157742f, 0.04394823f, -0.16937938f, 0.02947894f, 0.02202336f, 
    0.02172772f, 0.01779066f, 0.21830513f, 0.08978380f, -0.25940946f, -0.05205989f, 0.09003276f, -0.27625448f, 
    0.06712523f, 0.03429171f, -0.12598501f, 0.01245967f, 0.02869674f, -0.04205505f, 0.16712402f, 0.11675731f, 
    -0.18033046f, 0.16005228f, -0.02190847f, 0.16258076f, 0.13965182f, 0.18683632f, 0.03625852f, -0.01033307f, 
    0.12964189f, 0.06860042f, 0.11657432f, -0.01672002f, -0.03287379f, 0.21451581f, -0.01342605f, -0.17952712f, 
    -0.00506706f, 0.10234241f, 0.07256044f, 0.01576372f, 0.11683831f, 0.01982540f, -0.10378060f, 0.12861297f, 
    -0.27515712f, -0.11959101f, -0.16258289f, 0.19931476f, 0.11786530f, 0.22197789f, 0.19013502f, 0.16145955f, 
    0.08702561f, -0.10180525f, 0.11702492f, 0.08984967f, 0.18687406f, 0.12952548f, 0.12549993f, -0.05049360f, 
    -0.09901650f, 0.02148862f, 0.11876492f, -0.00801687f, 0.08927113f, -0.03445848f, -0.02708969f, 0.18338399f, 
    0.07250297f, 0.30297428f, 0.26616552f, -0.01127363f, 0.08851118f, 0.17314067f, 0.09597749f, -0.01821628f, 
    0.07220163f, 0.14254750f, -0.00881900f, -0.06704716f, -0.01595038f, -0.01686310f, 0.07149288f, 0.17719890f, 
    0.00002414f, 0.03868144f, 0.14283332f, 0.05423014f, -0.01410288f, -0.06531883f, -0.02555155f, 0.08369243f, 
    0.15159687f, 0.04717520f, 0.11887310f, 0.21372183f, -0.05233501f, 0.00203833f, -0.00675108f, 0.03829705f, 
    -0.23040760f, 0.00603849f, -0.08432064f, 0.03087722f, 0.04844797f, 0.03813490f, -0.00953020f, 0.15537016f, 
    0.13158171f, 0.15897553f, 0.08057388f, 0.09912345f, 0.02528346f, 0.13034494f, 0.12263827f, 0.03358668f, 
    0.29715192f, -0.12010409f, 0.02016051f, 0.06613611f, 0.01607776f, 0.00832600f, -0.14191195f, 0.02981858f, 
    -0.01987787f, 0.00464908f, 0.06417565f, 0.05103100f, 0.05952228f, -0.13603525f, 0.08646715f, -0.18686782f, 
    0.05327626f, -0.06355562f, -0.00273695f, 0.13215025f, 0.06612936f, -0.00502022f, -0.01004760f, 0.09254112f, 
    -0.07749803f, -0.05554425f, 0.06613124f, -0.12441090f, 0.04642875f, -0.03828480f, -0.01989973f, -0.05362668f, 
    -0.03449659f, 0.05732767f, -0.02210794f, 0.11000521f, -0.14113598f, 0.23666893f, -0.07228528f, -0.28659824f, 
    -0.01230172f, 0.06257518f, 0.05365109f, 0.03279486f, 0.05178909f, -0.04580525f, 0.13330436f, -0.07788327f, 
    -0.18881026f, -0.28437397f, -0.15439016f, -0.09174497f, -0.08927353f, 0.03087353f, -0.01544998f, 0.00044174f, 
    0.01643192f, -0.02588903f, 0.01040502f, 0.00333784f, -0.16666324f, -0.04597569f, -0.17890243f, -0.20225836f, 
    -0.16521488f, -0.00639805f, 0.04525371f, 0.04489869f, -0.14129405f, 0.10569342f, 0.03533687f, -0.03768881f, 
    0.21800731f, 0.29701671f, 0.35968882f, 0.31079820f, -0.13623798f, -0.07515807f, 0.19239710f, 0.35824269f, 
    0.14205138f, 0.01898917f, 0.13333343f, 0.01445036f, -0.24250044f, -0.01090598f, -0.00816996f, -0.12338437f, 
    0.10011204f, -0.00448843f, 0.17671771f, 0.12127008f, 0.04103479f, -0.00350195f, -0.04895256f, 0.11124623f, 
    -0.14819953f, 0.19406119f, -0.13879070f, 0.11490922f, 0.03568644f, -0.00595685f, -0.02331919f, 0.06671815f, 
    0.02837088f, 0.00091403f, -0.03366940f, 0.05673203f, 0.21096146f, -0.25109914f, -0.17253038f, -0.27919185f, 
    0.02472357f, 0.09025121f, -0.04282048f, 0.02643327f, 0.12495045f, 0.00332004f, -0.01503184f, 0.13857834f, 
    0.02508610f, 0.10919717f, 0.06136834f, 0.21264893f, -0.12924574f, -0.03036105f, -0.09892578f, 0.09498692f, 
    0.10833211f, -0.06903942f, 0.07078400f, 0.07609116f, 0.10641825f, 0.10255321f, 0.04693913f, 0.05307155f, 
    0.01202140f, -0.04235129f, 0.05788738f, -0.04675258f, 0.08217812f, -0.02185793f, 0.00458659f, 0.04149194f, 
    0.07932454f, 0.05102183f, 0.16822618f, 0.05906009f, 0.00656908f, 0.02810197f, -0.03200858f, 0.07614473f, 
    -0.00958856f, 0.08366870f, 0.09743480f, 0.06816298f, 0.35494089f, 0.00575598f, -0.04502062f, 0.28146425f, 
    0.04758997f, 0.00385012f, -0.02532594f, -0.08096574f, 0.03717531f, 0.19377126f, -0.13851061f, 0.06131645f, 
    -0.22279817f, -0.20255080f, -0.16566473f, -0.05033197f, 0.18035416f, -0.06329028f, -0.04965079f, 0.11303642f, 
    0.08078440f, 0.03769553f, 0.06475575f, 0.07361216f, -0.11374366f, 0.08370618f, 0.10068540f, 0.22073381f, 
    0.01053141f, 0.13344072f, -0.01176681f, 0.00400227f, 0.02400300f, -0.01233835f, -0.03385980f, 0.04846815f, 
    -0.36324814f, -0.03254334f, 0.04248276f, -0.04041776f, 0.10377894f, 0.12925041f, -0.01437002f, -0.01936120f, 
    -0.01936222f, 0.04840028f, 0.08918403f, -0.16215557f, 0.09252286f, -0.14892156f, -0.03129784f, -0.03248363f, 
    0.15287241f, 0.16777997f, 0.02941268f, 0.04957432f, -0.05796096f, 0.06667943f, -0.01010875f, 0.05159840f, 
    -0.14129633f, 0.13739312f, -0.01340026f, -0.05921223f, 0.09923179f, -0.01209253f, 0.01690056f, 0.07436278f, 
    0.00077496f, 0.06118218f, -0.07032309f, 0.19956993f, -0.07428142f, -0.06390749f, 0.08513143f, -0.01480537f, 
    -0.06674583f, -0.02763285f, 0.05220122f, -0.01170906f, -0.00775525f, -0.10065666f, -0.09819861f, 0.10379336f, 
    -0.31938565f, 0.29371354f, 0.09995522f, -0.03228731f, 0.10696796f, -0.05891969f, 0.12601744f, 0.07227708f, 
    0.00724440f, -0.14943083f, 0.10428317f, -0.01432327f, 0.14566800f, 0.13801691f, 0.07855806f, -0.02095164f, 
    0.10272180f, -0.03650610f, 0.10744534f, 0.06420817f, -0.05199979f, -0.01514601f, -0.06573737f, 0.16565049f, 
    -0.03127833f, 0.20899071f, 0.08725602f, 0.12706301f, 0.08946292f, 0.11288480f, 0.01641543f, -0.02890442f, 
    0.07583632f, -0.07674755f, -0.04924531f, 0.00156042f, 0.09991816f, 0.12957519f, 0.02460623f, 0.09908296f, 
    -0.00809152f, 0.00779111f, 0.17157541f, -0.03718322f, 0.15195741f, -0.02997933f, -0.12050184f, 0.02961379f, 
    -0.06783935f, -0.16167374f, 0.08444838f, -0.05984086f, 0.00447759f, 0.13929868f, -0.03053807f, -0.03726001f, 
    -0.03340990f, -0.03125146f, 0.01548589f, 0.01339310f, -0.24879122f, -0.09356768f, -0.00096305f, 0.20773529f, 
    0.10590459f, -0.01621760f, 0.00699093f, 0.03326054f, -0.18474641f, -0.00478552f, 0.20255575f, -0.04297539f, 
    0.05914053f, 0.19120167f, 0.02073749f, 0.26607195f, -0.12585737f, 0.02699316f, -0.23840976f, -0.11290289f, 
    -0.04372461f, 0.08812218f, -0.07140709f, -0.11984074f, -0.33259332f, -0.26818132f, 0.09613491f, -0.06527839f, 
    0.15234156f, -0.00102718f, -0.17992799f, 0.04258356f, -0.05639698f, 0.03034470f, 0.05861095f, -0.16512728f, 
    0.28033528f, -0.21594706f, -0.13680984f, 0.01738771f, -0.08638244f, -0.19494551f, -0.05981135f, 0.06329130f, 
    0.03899156f, -0.00653616f, -0.06407989f, 0.00465975f, 0.03850627f, -0.20313577f, -0.01211150f, -0.01920804f, 
    -0.02549211f, 0.02802295f, -0.03461314f, -0.02176574f, 0.00800750f, 0.08672771f, 0.11736464f, 0.10495743f, 
    0.12467342f, 0.17010669f, -0.05105051f, -0.01855605f, 0.16271432f, 0.10688441f, 0.08559978f, 0.12195340f, 
    0.14822738f, 0.12287241f, 0.19079673f, 0.06212843f, -0.08979555f, -0.21218665f, -0.18718190f, 0.12509920f, 
    -0.08097149f, -0.01175438f, 0.04213507f, 0.04172022f, 0.06806280f, 0.04001085f, 0.01704694f, -0.02258235f, 
    -0.07045010f, -0.01726589f, -0.03955517f, 0.04551743f, 0.05269076f, -0.08340426f, 0.24095854f, -0.07205915f, 
    -0.05173739f, -0.01680592f, -0.03927005f, 0.02492289f, 0.14123733f, 0.19919389f, 0.08157256f, -0.09656364f, 
    0.07307404f, 0.01932592f, -0.09134322f, -0.04798215f, 0.03420689f, 0.08132023f, 0.07266061f, 0.07878676f, 
    0.02488754f, 0.01382078f, 0.03499419f, 0.00729439f, -0.05732522f, 0.10271866f, -0.03865604f, 0.02890405f, 
    -0.03196277f, 0.06111707f, -0.01263162f, -0.06285948f, -0.15150674f, -0.07246429f, 0.03317979f, 0.23393163f, 
    0.05747211f, 0.01171777f, 0.03150271f, -0.08194517f, -0.06365369f, 0.02228756f, -0.12194574f, 0.08615163f, 
    -0.34909442f, 0.23266909f, 0.04153207f, 0.09641252f, 0.12997065f, -0.08044428f, 0.04430367f, -0.06288145f, 
    -0.02666133f, 0.01520954f, 0.06609859f, -0.06640252f, 0.07223462f, -0.08871444f, 0.26877037f, 0.46088639f, 
    0.16245471f, 0.05928574f, 0.07420819f, 0.07316514f, 0.08467855f, 0.06254941f, 0.02645551f, 0.06546869f, 
    0.04376411f, -0.30271313f, -0.30808911f, -0.16728944f, 0.16056775f, 0.05615101f, -0.01652197f, -0.05764890f, 
    -0.05792953f, 0.07078340f, -0.13463794f, 0.14987239f, 0.21036926f, 0.00479682f, -0.06489603f, 0.08387309f, 
    0.00466930f, 0.01151296f, -0.01414181f, -0.00827336f, -0.07591802f, 0.06092526f, -0.02368620f, -0.12525009f, 
    0.03366485f, 0.03666882f, 0.02302713f, 0.01068098f, -0.02438197f, 0.04076168f, 0.01941741f, -0.01515322f, 
    0.02921365f, -0.04565884f, 0.01559707f, -0.05222255f, -0.00749705f, -0.00412772f, -0.04363854f, -0.05475846f, 
    0.00926238f, -0.04770649f, -0.05875234f, 0.04495147f, -0.04187177f, 0.00904647f, 0.02106643f, 0.02859269f, 
    -0.04252454f, -0.01930023f, -0.00665937f, -0.00360923f, -0.04244834f, 0.01302029f, -0.05215703f, 0.03426955f, 
    0.00203994f, 0.01028631f, 0.01410232f, -0.05980076f, 0.02380609f, 0.00285782f, 0.01661767f, 0.00318765f, 
    -0.01218756f, 0.03776776f, -0.01114144f, -0.02413890f, 0.04529684f, -0.02351391f, 0.00067440f, 0.02647494f, 
    0.04068146f, -0.00024428f, -0.04355060f, 0.00901186f, -0.01139997f, -0.03884749f, -0.05234753f, 0.00809359f, 
    -0.04976888f, 0.00461218f, 0.00139133f, -0.04695573f, -0.04996904f, 0.01835249f, 0.03179275f, -0.03128964f, 
    -0.00275255f, 0.03008512f, -0.04011525f, 0.02990738f, 0.01248995f, -0.01994600f, 0.00992514f, -0.03507683f, 
    -0.00147609f, -0.03918250f, 0.04397738f, 0.04400089f, 0.04101497f, -0.00609941f, -0.01752138f, 0.04964003f, 
    -0.03869726f, -0.02289993f, 0.03552153f, 0.01112017f, -0.00704683f, 0.05525552f, -0.03118302f, 0.03602294f, 
    -0.03329473f, 0.05247783f, -0.04610319f, 0.03161717f, 0.02842170f, 0.02709559f, 0.00179555f, -0.06314623f, 
    0.01602643f, -0.00684088f, 0.00238606f, 0.02835856f, -0.01563522f, 0.03649132f, -0.00741877f, -0.02580383f, 
    -0.01275908f, -0.04147560f, -0.02609243f, 0.01049261f, 0.00845685f, 0.00365097f, -0.04251645f, 0.01538869f, 
    0.04146997f, -0.01925675f, 0.03990921f, -0.00388177f, 0.02265366f, -0.04952109f, -0.00073999f, -0.03809968f, 
    0.00701364f, 0.03152865f, 0.03684901f, 0.02717669f, -0.01382803f, 0.01612237f, -0.04927315f, -0.02321645f, 
    0.03654448f, -0.04193573f, -0.01861733f, -0.02367252f, -0.03380318f, -0.05629977f, 0.00747645f, 0.03339236f, 
    -0.03182708f, -0.05605251f, 0.02173139f, -0.02544879f, 0.02392282f, -0.00379793f, 0.05085521f, 0.03757153f, 
    -0.01128105f, -0.03407215f, -0.04423046f, -0.00150565f, -0.04308014f, 0.00924600f, 0.04894920f, 0.01155185f, 
    -0.01323355f, 0.02502566f, -0.01182047f, -0.05677290f, -0.04631962f, 0.06173715f, -0.02011706f, -0.02588475f, 
    -0.04764247f, -0.01417146f, 0.04162319f, 0.00669250f, -0.01598130f, -0.01771795f, -0.04287960f, -0.04306308f, 
    -0.00907650f, 0.01234764f, -0.00968783f, 0.00141274f, -0.05863120f, -0.00132993f, -0.01070296f, 0.02259496f, 
    0.03138186f, 0.01360266f, -0.01640721f, 0.03220618f, 0.02367905f, 0.03414469f, 0.01515627f, 0.00391830f, 
    0.02849221f, -0.01897043f, -0.04676490f, -0.04990886f, 0.00840199f, -0.05649147f, 0.03681668f, -0.05921679f, 
    -0.02982634f, -0.02139002f, -0.03762447f, -0.03805279f, -0.01874347f, 0.02663951f, 0.01172065f, 0.03206666f, 
    -0.01211374f, 0.02287808f, 0.03470981f, -0.04515630f, 0.00489556f, 0.02961723f, 0.01283131f, -0.04195191f, 
    -0.00808313f, 0.01282740f, -0.02499445f, -0.05783832f, -0.02721327f, -0.00972553f, 0.04325757f, -0.02387195f, 
    0.02726537f, -0.03349039f, -0.05974181f, -0.02451958f, 0.00519655f, 0.01744614f, 0.03719007f, -0.03784693f, 
    -0.03017090f, -0.00063704f, -0.02224922f, -0.04380866f, -0.03422623f, -0.03711863f, -0.05068377f, 0.01476046f, 
    -0.03599794f, 0.04009349f, 0.01341647f, 0.02882915f, 0.01330029f, -0.01335282f, -0.00234309f, -0.02383482f, 
    0.02572401f, 0.00291534f, 0.02291437f, -0.01515623f, -0.02710065f, -0.03957413f, -0.02685495f, 0.01203668f, 
    -0.04331797f, 0.02296117f, 0.02268392f, -0.03827657f, 0.02612897f, -0.03049889f, 0.04863891f, 0.00092607f, 
    -0.01784137f, -0.05335776f, -0.03775623f, -0.00885208f, -0.02894920f, 0.02328647f, -0.00064194f, 0.00231437f, 
    -0.02571187f, -0.00238387f, 0.04821980f, 0.02886762f, 0.01226517f, 0.03512304f, 0.00536617f, -0.03331079f, 
    0.04832637f, -0.03285890f, 0.00675003f, 0.01148853f, -0.01341670f, -0.04181430f, 0.05344478f, 0.01350382f, 
    -0.04785256f, -0.04999363f, -0.02858355f, -0.04228232f, -0.05817124f, -0.05340706f, -0.04517490f, 0.01064219f, 
    0.00998638f, -0.05206877f, 0.05057616f, -0.00134729f, 0.03377526f, 0.02507150f, -0.01903269f, -0.00028151f, 
    0.01175580f, 0.01943395f, -0.03257639f, 0.00130249f, -0.01526077f, -0.03103597f, 0.01769740f, -0.05674370f, 
    0.02861312f, -0.03372663f, -0.01418034f, -0.01006513f, 0.04047891f, 0.00286846f, -0.04508751f, -0.04298852f, 
    0.01822002f, -0.03238289f, -0.01150681f, -0.00219448f, 0.00919805f, -0.04138235f, 0.04328818f, 0.00767520f, 
    -0.01604110f, -0.00372806f, -0.03175834f, -0.02206349f, 0.01278115f, -0.03830094f, 0.01956943f, 0.00850489f, 
    0.02131564f, 0.00730980f, 0.03530945f, 0.01804494f, 0.02749636f, 0.02915152f, 0.03298831f, -0.01494639f, 
    -0.02876333f, -0.03613679f, -0.04844320f, 0.03100470f, -0.03275197f, 0.02182297f, -0.01432500f, -0.00403839f, 
    -0.01114253f, 0.00137756f, -0.05560226f, -0.01834489f, 0.01959680f, -0.02614204f, 0.03409571f, -0.00674135f, 
    -0.03898961f, -0.01770892f, 0.05000998f, -0.02866584f, 0.02271964f, -0.04600137f, 0.02218933f, -0.02592025f, 
    0.03137730f, 0.05945067f, 0.03119036f, 0.04035344f, -0.04027868f, -0.03553507f, -0.01285299f, -0.02432203f, 
    0.01529309f, -0.04116750f, 0.02948941f, -0.00256953f, 0.01293437f, -0.04138947f, 0.02797618f, -0.05432104f, 
    -0.01061954f, 0.03818861f, -0.00219332f, 0.01713242f, -0.04328368f, 0.00513289f, 0.01094589f, -0.02876099f, 
    0.14012849f, 0.12183550f, -0.03254465f, -0.17214359f, -0.05698695f, -0.05360102f, -0.02435582f, -0.11254314f, 
    0.14190966f, -0.04815402f, 0.07683687f, -0.00249631f, -0.03744963f, 0.22515345f, -0.18740019f, -0.01789349f, 
    0.04989062f, 0.03763023f, -0.06619053f, 0.02264391f, 0.09866639f, 0.03296160f, 0.02480352f, -0.05357328f, 
    0.17973544f, -0.05992701f, -0.03393044f, -0.18490747f, -0.09152692f, -0.02886880f, 0.13029838f, 0.03123834f, 
    -0.05582211f, 0.02563726f, -0.06008179f, 0.02561042f, 0.33055919f, -0.11602357f, -0.21907996f, 0.04979529f, 
    0.00966017f, -0.01959537f, -0.06672038f, 0.13216704f, -0.03583595f, 0.15767252f, 0.01546345f, 0.02566313f, 
    -0.33822063f, 0.23711519f, -0.10278534f, 0.04079031f, -0.01432725f, 0.01379760f, 0.03927736f, -0.00995459f, 
    0.07360598f, -0.08384259f, -0.14054495f, -0.08881460f, -0.30857632f, 0.22854105f, 0.16163936f, -0.06381645f, 
    0.03792520f, 0.01368495f, 0.07527201f, 0.14444295f, 0.11474607f, -0.02432291f, -0.03119280f, -0.00342690f, 
    0.02515014f, 0.22537722f, -0.22064741f, 0.03663978f, -0.03008218f, 0.02158687f, 0.21185820f, 0.03058088f, 
    -0.08554935f, 0.01590235f, -0.04359667f, -0.02953205f, 0.08877320f, -0.09956773f, 0.19103667f, -0.02231797f, 
    -0.09807829f, -0.06841810f, 0.06572520f, 0.08939435f, 0.04047020f, 0.04058535f, 0.08917746f, 0.08536230f, 
    0.13659640f, 0.07033791f, -0.05544924f, 0.07955030f, -0.03363140f, -0.07029460f, 0.10402463f, 0.02946731f, 
    0.04506809f, 0.08146530f, 0.10337058f, 0.10311219f, -0.14578058f, 0.20007260f, 0.08481228f, -0.04020666f, 
    0.11820406f, -0.00437396f, -0.00607202f, 0.08449842f, -0.04101382f, 0.07055427f, 0.14544617f, 0.05164000f, 
    0.13546433f, 0.10976624f, 0.01213397f, 0.24771518f, -0.06541057f, -0.09479148f, -0.04160486f, 0.07049660f, 
    -0.04577572f, 0.05305345f, -0.03114094f, -0.16125035f, -0.11106060f, 0.07917514f, 0.08133592f, 0.26897991f, 
    0.06419533f, 0.09347764f, -0.14808369f, 0.06742862f, 0.02771839f, -0.12359579f, 0.04079646f, -0.02874022f, 
    0.38589391f, 0.15627712f, -0.01011969f, -0.09976529f, -0.14732343f, -0.10602166f, -0.02671232f, 0.03899185f, 
    0.01133134f, -0.00195615f, -0.00537401f, 0.16788445f, 0.01087340f, 0.14976038f, 0.13205674f, -0.00512385f, 
    -0.26616040f, 0.02373187f, -0.12606864f, 0.12672672f, -0.00658813f, -0.00486926f, -0.04125050f, 0.03664094f, 
    0.20066036f, -0.14191514f, -0.06437820f, 0.24498735f, -0.26143774f, -0.00615634f, 0.04527200f, 0.00716763f, 
    -0.00299969f, 0.07749800f, 0.10518424f, 0.06908531f, 0.27824616f, -0.03979126f, -0.06304187f, 0.24403833f, 
    -0.02733960f, 0.13625628f, -0.01600288f, 0.03812220f, 0.02698421f, 0.07233144f, 0.10510640f, 0.06944440f, 
    0.08086418f, -0.19176383f, -0.30438119f, 0.07009289f, -0.10902196f, 0.01665261f, -0.04429108f, 0.02086438f, 
    -0.00123437f, 0.04802418f, -0.00863582f, 0.01117897f, 0.62752795f, -0.02806834f, 0.06484555f, 0.29742366f, 
    -0.12273873f, 0.06730100f, 0.09240865f, 0.06255675f, 0.13290203f, -0.13489789f, -0.01961713f, 0.04805956f, 
    0.02658067f, 0.07005256f, -0.08111016f, -0.22896716f, -0.02250665f, 0.06253549f, -0.00267903f, 0.05730231f, 
    -0.00235018f, -0.13134615f, 0.06157131f, -0.04636410f, -0.27474859f, -0.17046477f, 0.16189750f, 0.19995895f, 
    -0.00580823f, 0.06944472f, 0.06970422f, -0.17494327f, 0.00136070f, 0.05521596f, -0.10723678f, -0.07983238f, 
    0.36053637f, 0.05616560f, -0.06365367f, 0.03625857f, -0.04314786f, 0.03785212f, -0.05775565f, -0.01218039f, 
    0.05717847f, 0.00112644f, 0.05167765f, 0.18264712f, -0.03514478f, -0.01248434f, 0.11569088f, 0.09165771f, 
    0.02128905f, 0.00339736f, -0.03688917f, 0.06056501f, 0.04474514f, -0.03256484f, -0.00420541f, -0.06859079f, 
    0.11682557f, 0.18368366f, 0.09514860f, -0.00784182f, -0.14409694f, -0.00453560f, -0.00886043f, 0.12816809f, 
    0.13076594f, 0.03707933f, 0.06674796f, -0.00663670f, -0.10950179f, -0.05786000f, 0.16018182f, 0.27781329f, 
    0.01476916f, 0.08465976f, -0.01064365f, 0.02889589f, 0.11984003f, -0.15490724f, -0.06266031f, -0.05770883f, 
    0.05493021f, 0.22834203f, 0.22495671f, -0.25925082f, -0.08823658f, -0.00755520f, -0.21525219f, -0.01052691f, 
    0.05956039f, 0.03205848f, -0.04665155f, 0.06974067f, -0.25032017f, -0.24631523f, 0.03162509f, 0.28631431f, 
    -0.13208784f, 0.03526188f, 0.16736422f, 0.04288929f, 0.10207395f, 0.10328795f, 0.15123005f, -0.04684195f, 
    -0.28140852f, 0.28413925f, 0.15591827f, -0.08921117f, 0.05623361f, 0.08926675f, -0.13050549f, 0.01535292f, 
    0.04050633f, 0.07349471f, -0.05247965f, 0.21722578f, 0.32481703f, -0.26299962f, -0.00759413f, 0.29886034f, 
    -0.11568537f, 0.03988638f, 0.02369852f, -0.00413708f, -0.02154528f, 0.02687553f, -0.11315950f, -0.08741800f, 
    0.13987283f, 0.17616932f, 0.03016402f, -0.23081943f, 0.12129108f, 0.09318306f, -0.11731361f, -0.06622471f, 
    0.05905683f, 0.01817805f, 0.07113923f, -0.07594407f, -0.18467663f, 0.00815662f, -0.09158227f, -0.18073308f, 
    -0.22448707f, -0.12563461f, -0.03217012f, 0.09451143f, 0.02604152f, -0.00406536f, 0.19146615f, 0.03013802f, 
    0.18772233f, 0.00506233f, -0.03339109f, 0.11656649f, 0.07408720f, -0.03635506f, 0.12735511f, 0.07563125f, 
    -0.04908859f, 0.07154412f, 0.15201907f, 0.02534817f, -0.22384503f, 0.26975599f, 0.06699090f, 0.02053663f, 
    0.11301817f, -0.04882034f, -0.07530358f, -0.03342255f, -0.06014333f, -0.11199857f, -0.05614199f, -0.00212746f, 
    0.09029028f, -0.06845230f, 0.00581215f, 0.02403827f, -0.10604990f, 0.00631275f, 0.05017764f, 0.02224752f, 
    0.07149776f, 0.12987532f, -0.01774900f, -0.07918096f, -0.37781933f, 0.09295100f, 0.24455503f, -0.21779417f, 
    -0.05624701f, 0.06514197f, 0.12494180f, 0.07345465f, -0.00102319f, -0.04241126f, 0.04106550f, -0.05101679f, 
    0.03440702f, -0.19929834f, -0.10356871f, -0.08913937f, 0.14626749f, -0.00758282f, 0.02483249f, 0.13571766f, 
    0.05238662f, 0.09156264f, -0.04268844f, 0.04718846f, 0.21793240f, -0.08433917f, 0.07704113f, 0.02983512f, 
    0.02706156f, -0.05045243f, -0.08519555f, 0.06383126f, 0.10590003f, 0.08964054f, -0.00447762f, 0.02037893f, 
    0.26429904f, -0.04973268f, -0.31708339f, 0.21094888f, 0.03930784f, 0.03954021f, 0.07914545f, 0.09431777f, 
    0.05124389f, 0.00419841f, -0.09983342f, 0.09841222f, -0.09241137f, 0.05056288f, 0.01149603f, -0.34152287f, 
    0.05388195f, 0.11598962f, 0.05953245f, 0.03176299f, 0.11514894f, 0.02541192f, 0.08804167f, 0.10850205f, 
    -0.11507206f, 0.17993365f, -0.11058222f, 0.07175478f, -0.10238658f, 0.10381887f, 0.06219458f, 0.09127799f, 
    -0.03380241f, -0.02740247f, 0.03587883f, 0.07693703f, 0.03236729f, -0.17607200f, 0.32418969f, -0.15079093f, 
    0.10219959f, -0.10881969f, 0.16921362f, 0.16056508f, 0.02762904f, 0.05274483f, 0.11692634f, 0.04049189f, 
    -0.12862949f, 0.27605805f, -0.20101966f, 0.08136795f, -0.08877175f, 0.11742508f, 0.12052362f, 0.04445943f, 
    -0.07762033f, -0.00337385f, 0.06227488f, 0.10304821f, -0.22014578f, 0.18578914f, 0.04490850f, -0.14341260f, 
    0.09632852f, 0.03015556f, -0.03166790f, 0.08030338f, -0.13962306f, -0.07321994f, -0.06465782f, 0.12861665f, 
    0.24752036f, -0.30456281f, 0.05042587f, 0.34652287f, -0.01201350f, 0.01942105f, 0.05871558f, -0.08557521f, 
    -0.01347436f, 0.01407818f, 0.04393391f, 0.04048808f, -0.30645880f, 0.11551570f, 0.12765023f, 0.06912182f, 
    -0.03159625f, 0.08120304f, 0.01549349f, -0.07316396f, -0.02911711f, 0.10324582f, 0.00854438f, 0.08793961f, 
    0.09559502f, 0.08685254f, 0.04681750f, -0.07104722f, 0.01043335f, -0.06581514f, -0.01924820f, 0.07080751f, 
    -0.04582565f, -0.07583784f, 0.03365453f, 0.00642181f, -0.22272129f, 0.00630668f, 0.02941851f, 0.07389487f, 
    -0.15540598f, -0.02690452f, -0.02938901f, 0.02748970f, 0.10518165f, -0.00662494f, 0.05874702f, -0.01214414f, 
    0.04492940f, -0.03944520f, 0.13791116f, 0.14461641f, -0.13143763f, 0.15105003f, 0.02427697f, 0.10321946f, 
    0.01906556f, 0.03223511f, -0.05617107f, -0.01824873f, 0.07345663f, -0.02199427f, 0.03905556f, 0.16394369f, 
    -0.09920761f, 0.16249135f, 0.00501262f, 0.08556412f, -0.04627730f, -0.00809941f, -0.05077185f, -0.04091622f, 
    0.00197168f, -0.13524152f, 0.00045929f, 0.08823559f, -0.08692966f, -0.11127058f, 0.17578049f, -0.04839965f, 
    -0.07154573f, 0.03695254f, -0.04890180f, 0.07330870f, 0.19115007f, -0.07249413f, 0.10914457f, -0.09351429f, 
    -0.06473268f, 0.02354997f, 0.08376686f, 0.02283578f, 0.08243152f, 0.00446589f, -0.10733940f, 0.06084531f, 
    0.18376501f, -0.25750601f, 0.23553778f, -0.38355055f, -0.01539476f, -0.07042261f, 0.18053254f, -0.02069316f, 
    0.00125922f, -0.02830701f, 0.05575817f, 0.10754190f, 0.05157823f, 0.07722900f, -0.00595570f, 0.06026535f, 
    0.04298946f, 0.00537235f, 0.04433379f, -0.04162800f, -0.04648634f, 0.05131846f, 0.11053915f, -0.03763207f, 
    -0.15471098f, -0.13020819f, -0.06273434f, 0.08891923f, 0.01163164f, 0.11081653f, -0.04532095f, -0.06984935f, 
    0.01196744f, -0.03153954f, -0.00559474f, 0.13642256f, -0.09355709f, 0.05993803f, 0.10845703f, -0.12670988f, 
    0.05948550f, 0.13533682f, -0.02526401f, 0.06271446f, 0.08448292f, 0.16849865f, -0.00660379f, 0.07424869f, 
    0.01440162f, 0.05691004f, 0.00310410f, -0.17228314f, 0.05390396f, -0.05535140f, 0.10285644f, 0.00815246f, 
    0.06809516f, 0.16540515f, 0.13416632f, 0.02547972f, 0.19571091f, 0.09532972f, 0.14198016f, -0.00708029f, 
    0.09183961f, 0.01795410f, 0.02673131f, -0.00387304f, 0.08091396f, -0.02523065f, 0.00955940f, 0.10378062f, 
    -0.00159282f, 0.30536440f, -0.07819894f, -0.14566615f, -0.06445616f, 0.07366747f, -0.14994574f, 0.09058701f, 
    0.14816731f, 0.00246394f, -0.07533747f, 0.02923856f, -0.10060143f, 0.03497485f, -0.13942420f, 0.27286223f, 
    0.10094792f, 0.08722183f, 0.08707356f, -0.00401293f, 0.06153173f, -0.00197052f, -0.02303733f, -0.11212784f, 
    0.00851927f, 0.07536308f, -0.04034089f, 0.10107109f, 0.00260958f, -0.01262489f, 0.03182323f, 0.03226878f, 
    0.01194359f, 0.00382225f, 0.03651641f, -0.07027092f, 0.25055820f, -0.26875660f, 0.03063469f, 0.02514432f, 
    -0.01327270f, -0.07196167f, 0.06061973f, 0.05401570f, 0.10543191f, 0.07018519f, 0.04058358f, 0.03869092f, 
    0.46126294f, 0.24962647f, -0.02484569f, -0.14623053f, 0.07553250f, -0.03499314f, -0.06848058f, 0.05281442f, 
    0.10408570f, 0.09052394f, -0.02563263f, 0.10708831f, 0.08163041f, 0.02763365f, -0.13080797f, -0.06673452f, 
    -0.02611596f, -0.04030581f, -0.01075585f, 0.13073614f, 0.05820754f, 0.01755111f, 0.10303860f, -0.05159093f, 
    -0.18625583f, 0.01584112f, 0.00662169f, -0.06406722f, 0.06314848f, 0.10864884f, 0.07853777f, -0.05350825f, 
    -0.06487674f, 0.00921613f, 0.02575613f, 0.01252114f, 0.19369274f, 0.18876012f, -0.02136812f, 0.09389978f, 
    0.07825349f, 0.04467754f, -0.16697282f, 0.10077368f, 0.10159787f, 0.02955512f, 0.10463424f, -0.01844312f, 
    -0.08675987f, 0.07989009f, 0.18746869f, 0.12663069f, 0.07657100f, -0.04088952f, 0.01266746f, 0.05812407f, 
    -0.03165369f, -0.02773780f, 0.00224966f, 0.08093935f, 0.51513910f, -0.04139130f, 0.00414225f, -0.16633011f, 
    0.07001350f, 0.05445626f, 0.05387542f, 0.01489311f, 0.03264603f, 0.15415408f, 0.08560124f, 0.09344706f, 
    0.05477779f, 0.14034380f, 0.18521871f, 0.21188585f, -0.02800626f, -0.19059622f, -0.05158945f, 0.11033231f, 
    0.05803550f, -0.03269721f, 0.14320730f, 0.05370582f, -0.08588523f, 0.06567413f, 0.02415119f, 0.02667395f, 
    0.13274071f, -0.03230533f, 0.11922259f, -0.06339422f, 0.01619027f, 0.02942086f, 0.05112467f, 0.08592588f, 
    0.16400687f, 0.02070491f, 0.17035177f, -0.00534433f, -0.00259668f, -0.01449892f, -0.08300202f, -0.01423660f, 
    -0.01819047f, 0.08782165f, 0.04244075f, 0.02799369f, 0.21237524f, -0.16630857f, -0.09051847f, 0.07600690f, 
    0.07508315f, 0.04073377f, -0.07158541f, 0.01405001f, -0.08428257f, 0.18110278f, 0.04164397f, 0.04472386f, 
    0.05470968f, -0.30937874f, 0.01434469f, -0.14418134f, -0.03752315f, 0.05985576f, -0.17253971f, 0.01028528f, 
    0.06647541f, 0.01924498f, 0.00783240f, 0.03422497f, 0.10710107f, 0.18543629f, -0.09883810f, -0.08684979f, 
    -0.05969070f, 0.00543841f, -0.12537567f, 0.02168375f, 0.02026092f, -0.01939514f, -0.06431524f, -0.08524606f, 
    0.03694092f, -0.29249129f, -0.06004386f, -0.09725881f, 0.20257661f, -0.00171999f, -0.15791194f, -0.03479950f, 
    0.03338883f, 0.00104162f, 0.00909576f, 0.00242371f, 0.00739867f, -0.12207748f, 0.03952254f, 0.13318905f, 
    -0.04127341f, 0.10002523f, -0.06271262f, -0.02322721f, 0.09478891f, 0.08566532f, 0.02682803f, -0.03262408f, 
    -0.33610937f, 0.04254182f, 0.00018711f, -0.09326796f, 0.12234870f, -0.01967058f, 0.03495465f, 0.10583154f, 
    0.09077431f, 0.03578731f, 0.06634236f, 0.15283780f, 0.37883782f, -0.17603900f, -0.17008621f, -0.16769029f, 
    0.02904752f, 0.01768379f, 0.07584936f, 0.00620164f, 0.00142022f, 0.10301182f, 0.07515620f, 0.14159358f, 
    -0.12120787f, -0.02724104f, 0.13679028f, 0.17006998f, 0.01564923f, 0.06365754f, -0.03012902f, -0.01270597f, 
    0.08008978f, 0.04247514f, 0.12354357f, 0.00779821f, -0.14580497f, -0.10585259f, 0.10779418f, 0.08083779f, 
    0.17178151f, 0.00198179f, 0.19331259f, -0.03049087f, 0.03038967f, -0.01595750f, -0.04091900f, -0.06078408f, 
    0.00297104f, -0.05103786f, -0.21925241f, -0.14556889f, 0.21694982f, 0.10274126f, -0.06945302f, -0.08184270f, 
    0.14648673f, -0.03774751f, -0.05846408f, -0.07117714f, -0.16683924f, -0.14316602f, -0.05930103f, -0.10640785f, 
    0.15009603f, -0.06797419f, 0.07155161f, -0.12017942f, 0.13732612f, 0.07551632f, 0.07486618f, -0.07955393f, 
    0.36228523f, 0.16988024f, 0.09822582f, -0.26082963f, 0.09049749f, 0.08852557f, -0.04399628f, 0.00829123f, 
    -0.03697657f, 0.03443981f, 0.12196185f, 0.04318145f, -0.27238870f, -0.13274850f, -0.25619313f, -0.08751836f, 
    0.16943869f, -0.01418271f, -0.10387941f, -0.06553403f, 0.00419505f, 0.04335214f, 0.12395809f, -0.03473705f, 
    0.07950751f, 0.18483435f, -0.02681529f, 0.15825388f, -0.02634967f, -0.06717538f, -0.17592484f, 0.01229660f, 
    -0.09240105f, 0.09496042f, -0.04420974f, 0.01663629f, -0.05804548f, -0.09213055f, -0.23717690f, -0.03131558f, 
    0.20438810f, 0.00713359f, -0.11142411f, 0.15575613f, 0.09390230f, -0.03066470f, 0.01986831f, 0.01724535f, 
    -0.21648091f, 0.01915537f, -0.07088073f, 0.09082998f, -0.02054407f, -0.08396176f, -0.07799233f, 0.06831025f, 
    -0.04447577f, 0.00179818f, 0.03925276f, -0.01274920f, -0.12304728f, 0.05940455f, -0.12848110f, -0.11113361f, 
    0.04986381f, -0.02306214f, 0.00075340f, -0.04411975f, -0.01799368f, -0.04870164f, -0.00248212f, 0.07534233f, 
    -0.08274825f, -0.00825234f, -0.01766638f, 0.13853817f, 0.07971814f, -0.01054858f, -0.02134911f, 0.01917667f, 
    -0.04115884f, -0.12923004f, 0.07479672f, -0.00048417f, -0.06986695f, -0.07390124f, -0.32315505f, -0.09202126f, 
    0.06269488f, 0.02023157f, -0.00924640f, 0.03638278f, 0.03435403f, 0.06725529f, 0.03923227f, 0.09217525f, 
    -0.17043592f, -0.06197494f, 0.08489938f, 0.14828177f, -0.07477180f, -0.06461110f, 0.13739960f, -0.02500804f, 
    0.01294197f, -0.02975704f, 0.10594450f, -0.00672788f, -0.01280946f, 0.04704831f, 0.12479828f, -0.05442089f, 
    0.06068641f, -0.07804076f, -0.21175157f, -0.14926113f, -0.06955884f, -0.02954206f, 0.17937225f, 0.14743905f, 
    0.21820933f, 0.01375274f, -0.17345324f, 0.11746285f, -0.06561011f, -0.11629964f, 0.06443690f, 0.05858701f, 
    0.04926322f, -0.04175195f, 0.05488833f, -0.10564416f, -0.03453100f, 0.16038297f, -0.20449594f, 0.01667352f, 
    0.22323440f, 0.01373429f, 0.00433917f, -0.04220194f, -0.12586729f, 0.06953868f, 0.06671268f, 0.04143881f, 
    -0.15821820f, -0.02966691f, 0.04414326f, 0.07749642f, -0.05634056f, -0.03918914f, 0.03096567f, 0.14950831f, 
    -0.02506996f, 0.05485848f, 0.02641489f, -0.08106967f, 0.23701774f, 0.11418556f, 0.15986639f, 0.09502999f, 
    -0.02382458f, -0.03612954f, -0.05971258f, -0.08549077f, 0.01607658f, -0.13419668f, -0.15361589f, 0.00531965f, 
    -0.12752251f, -0.10193148f, -0.08301196f, -0.05372753f, 0.00300973f, -0.00903565f, -0.03716416f, -0.12690449f, 
    0.01235462f, 0.03597245f, -0.10053311f, -0.05501724f, 0.11967067f, -0.03455755f, -0.03625761f, 0.07891490f, 
    -0.01739554f, 0.02982707f, 0.02780740f, 0.03849895f, 0.05270921f, 0.11646583f, 0.07156467f, 0.01447836f, 
    -0.22269814f, -0.21997261f, -0.13616669f, 0.10142886f, 0.12358439f, 0.04996265f, 0.07340363f, 0.21414340f, 
    -0.01673573f, 0.06630820f, -0.09080721f, -0.03980772f, -0.16852012f, -0.08492745f, 0.27148649f, -0.02403268f, 
    0.00782798f, 0.00010746f, 0.21179610f, 0.03078287f, 0.07895818f, -0.01430699f, -0.04423355f, -0.00092767f, 
    -0.33237320f, -0.33162412f, -0.25081047f, 0.01926100f, 0.07123119f, -0.01504946f, -0.05156417f, -0.01081718f, 
    0.07473695f, -0.15590580f, 0.00416893f, 0.07384439f, 0.09038427f, 0.08550558f, 0.22788024f, -0.14973590f, 
    0.03601277f, -0.00245302f, 0.12226068f, -0.03540851f, 0.03794841f, 0.03241656f, 0.02241751f, -0.03405852f, 
    -0.18236712f, -0.22303833f, -0.24579976f, -0.00843444f, 0.19012465f, 0.13538952f, 0.01045148f, 0.12082715f, 
    0.01000381f, 0.06023994f, 0.04752685f, 0.09077428f, 0.39295927f, 0.16269056f, 0.02928482f, -0.00978651f, 
    -0.06499047f, 0.04695785f, 0.16974698f, -0.06506596f, -0.05560169f, 0.00303061f, 0.10684831f, -0.01258532f, 
    0.29439461f, 0.15903507f, 0.18582901f, 0.12410415f, -0.05029429f, -0.02791756f, 0.09938165f, -0.04640862f, 
    0.18408237f, 0.09939503f, 0.02443237f, -0.04627190f, -0.11460870f, -0.23458010f, 0.12397964f, 0.33675289f, 
    0.09531169f, -0.04273093f, 0.09122553f, 0.06648975f, -0.05263088f, 0.05051655f, 0.00871918f, 0.08948412f, 
    0.31085306f, 0.36857444f, 0.13512769f, 0.07518710f, -0.21430138f, 0.20667262f, 0.07193988f, -0.01741709f, 
    0.06199534f, -0.02467225f, 0.04624782f, -0.04245114f, 0.23049358f, -0.08635447f, -0.06083013f, -0.01641197f, 
    0.00347362f, -0.09569228f, 0.06269238f, 0.11619134f, 0.01900417f, -0.04858323f, 0.00023696f, 0.10119344f, 
    -0.31334633f, -0.24464585f, -0.08964013f, -0.11111868f, 0.12225004f, -0.12549163f, 0.08562821f, 0.00164669f, 
    0.03333250f, 0.14831464f, -0.03413889f, -0.02784921f, -0.05442722f, 0.22857490f, 0.25304931f, -0.10269583f, 
    -0.06929927f, 0.07045554f, 0.01723391f, 0.05671182f, -0.01135894f, -0.01444991f, -0.18023339f, 0.00051672f, 
    -0.39392105f, -0.32531857f, 0.07438575f, -0.07939352f, 0.12247729f, 0.25014248f, -0.02565821f, -0.01097212f, 
    0.09104186f, 0.03886889f, -0.03664790f, -0.00334092f, -0.09840964f, -0.21386527f, -0.32365811f, -0.24168563f, 
    0.05646458f, -0.06913580f, -0.01894488f, -0.02728597f, 0.03334187f, 0.04437002f, 0.03723382f, -0.02917269f, 
    0.15061562f, 0.25632685f, 0.25392416f, -0.02580945f, 0.13399538f, 0.05760701f, 0.08156180f, 0.11813792f, 
    0.12363002f, 0.14780316f, 0.05214236f, 0.12317213f, -0.02053587f, 0.18960875f, 0.13103597f, -0.03203656f, 
    -0.05097042f, -0.00453114f, 0.13598339f, 0.04867771f, -0.03771156f, 0.05772988f, 0.09238108f, 0.15490311f, 
    0.18614939f, 0.19125205f, 0.29640183f, 0.14457856f, -0.07155969f, 0.10181198f, 0.11510868f, 0.11189404f, 
    0.08002947f, -0.04992022f, 0.01299002f, -0.01781319f, 0.14385375f, 0.26707074f, 0.36815244f, 0.03726982f, 
    0.00309036f, 0.09882058f, 0.09166582f, 0.12425859f, -0.03075067f, 0.12984751f, 0.04113540f, 0.17075655f, 
    0.08255667f, -0.20329787f, 0.13285351f, 0.01943440f, 0.01841493f, -0.04492228f, 0.14033684f, 0.01967106f, 
    0.04077459f, -0.09969705f, -0.01798565f, -0.10333044f, 0.15050294f, 0.25458631f, 0.33449760f, -0.06682757f, 
    -0.07663374f, -0.04604734f, 0.02097055f, 0.01871916f, 0.02584359f, 0.10478725f, 0.14786953f, 0.18591532f, 
    -0.25708708f, -0.07079802f, -0.00425452f, 0.11740528f, -0.13976046f, 0.02581923f, -0.05352791f, -0.07092570f, 
    -0.00484726f, -0.00461924f, -0.07288226f, -0.09285985f, -0.14735238f, -0.06593250f, 0.18355091f, 0.19035627f, 
    -0.13522048f, 0.08420700f, 0.00922900f, -0.12789895f, -0.01587288f, -0.02632304f, 0.04010678f, 0.05203776f, 
    -0.21271487f, -0.29748496f, 0.04554706f, -0.03001685f, 0.00238772f, 0.11232249f, -0.03356619f, 0.02947204f, 
    0.07460672f, 0.06314311f, -0.11337991f, 0.03842497f, 0.06259681f, 0.17766684f, 0.13620339f, 0.09211605f, 
    -0.13486186f, 0.03408244f, 0.03706852f, 0.01183571f, 0.10884309f, 0.00995689f, 0.06893242f, 0.15525883f, 
    -0.36264098f, -0.21717481f, -0.32572451f, -0.06690338f, 0.14561115f, -0.01603706f, -0.04560515f, -0.02404661f, 
    -0.09317873f, -0.05709025f, -0.10012208f, 0.08536831f, 0.17741291f, 0.34019551f, -0.21322900f, -0.25970203f, 
    0.18312785f, 0.21865283f, 0.00292430f, 0.08592916f, 0.13632663f, -0.00974924f, -0.12502237f, 0.08897647f, 
    -0.39200944f, -0.13309644f, -0.12131808f, -0.10778940f, 0.07356048f, -0.00350709f, 0.08144285f, 0.05372865f, 
    -0.09646716f, -0.12300684f, 0.08745707f, -0.09127941f, 0.17023627f, 0.30471241f, 0.38406956f, -0.03358218f, 
    -0.07398218f, -0.01350796f, 0.01334045f, 0.01082922f, 0.11514197f, 0.05728821f, -0.03365804f, 0.06942977f, 
    -0.41475031f, -0.30262601f, -0.22574724f, 0.10501602f, 0.12141608f, -0.00871066f, 0.08298292f, 0.18738173f, 
    -0.06154903f, 0.00683715f, 0.04791510f, -0.05315427f, -0.31124398f, -0.14128746f, -0.17493813f, 0.19423084f, 
    0.13022520f, -0.01237935f, -0.12973474f, 0.12359323f, -0.04322596f, 0.11195384f, 0.08736217f, 0.01425731f, 
    -0.26967782f, -0.09680478f, -0.02966295f, -0.16553049f, -0.04241006f, 0.14072743f, 0.02803551f, -0.04547872f, 
    0.06386167f, 0.04224598f, 0.01346695f, 0.10433971f, -0.14066382f, -0.14009702f, -0.11276400f, -0.05902649f, 
    0.13777605f, -0.06512386f, 0.16155200f, 0.14514022f, -0.07983080f, -0.01746138f, 0.10284950f, -0.02851829f, 
    0.02646200f, -0.05132313f, 0.00769989f, -0.05225089f, 0.02509814f, 0.01818453f, 0.03517403f, -0.04506113f, 
    0.00368833f, 0.03532211f, 0.00418631f, -0.06085837f, -0.01077019f, 0.02393091f, 0.01627585f, 0.03125280f, 
    -0.05334167f, 0.03311924f, -0.02616222f, -0.04110518f, 0.00555192f, -0.04226907f, -0.00934823f, 0.01727293f, 
    -0.04085923f, 0.03452245f, -0.05961120f, -0.00819524f, 0.04004252f, 0.03768428f, -0.02067921f, -0.02926128f, 
    -0.01921868f, 0.03292008f, -0.00394184f, -0.05020135f, 0.00370894f, -0.00941311f, -0.00293694f, -0.03523432f, 
    -0.05175123f, 0.02866789f, 0.01852088f, -0.05454367f, -0.03393454f, -0.04386555f, -0.04975062f, 0.02631468f, 
    -0.05141816f, -0.00776226f, -0.03368661f, -0.03380536f, 0.00828847f, -0.02036011f, 0.02682033f, -0.03685559f, 
    -0.05850488f, 0.01111085f, -0.00039574f, -0.04564887f, -0.05479010f, 0.03509334f, -0.01429336f, 0.00985399f, 
    -0.02831753f, 0.03719983f, 0.03376992f, -0.04865972f, 0.01290272f, 0.02907141f, -0.00261692f, 0.01726702f, 
    -0.05201292f, -0.01881335f, -0.05442121f, 0.02746899f, -0.05187408f, -0.00034367f, 0.03354998f, 0.02667379f, 
    -0.01941716f, 0.03516806f, -0.02449041f, -0.02766622f, 0.02167058f, -0.01270005f, -0.05984586f, -0.02540964f, 
    0.01954775f, -0.03946847f, -0.04782690f, -0.03494684f, -0.05033345f, -0.05583231f, -0.04764074f, -0.04008929f, 
    0.04706177f, 0.00136744f, -0.00674208f, -0.02999367f, -0.00338146f, -0.05488626f, 0.03504395f, -0.03958409f, 
    -0.04913550f, -0.03934649f, -0.01992855f, 0.00734982f, -0.04523456f, -0.04996922f, 0.04167017f, -0.00702770f, 
    0.03398910f, 0.01833885f, 0.02046837f, -0.00433664f, -0.04465729f, -0.00044212f, -0.03232591f, 0.02562341f, 
    0.02127845f, 0.03497265f, -0.00436212f, 0.00774316f, 0.01690396f, 0.01010182f, -0.05726328f, -0.02157331f, 
    -0.01071064f, 0.00300818f, 0.03052781f, -0.04534818f, 0.00137803f, 0.03870185f, -0.02782327f, 0.03591915f, 
    -0.02934300f, -0.01095995f, 0.00153802f, 0.01726226f, -0.01146166f, 0.02311878f, -0.01825567f, -0.05757865f, 
    0.03363528f, 0.02308448f, -0.03697139f, -0.03242547f, -0.05627703f, -0.00836251f, 0.03826994f, -0.03079423f, 
    0.00180452f, -0.03402407f, -0.00522341f, 0.00876352f, -0.03271759f, -0.01598066f, -0.05581954f, 0.00758001f, 
    0.00407210f, 0.02428823f, -0.02160780f, 0.01308792f, -0.04817867f, 0.03967596f, 0.01894511f, -0.04666185f, 
    -0.02607391f, 0.01237457f, 0.01596612f, -0.00190050f, -0.04646708f, -0.02319695f, -0.00397396f, 0.01691033f, 
    -0.00827053f, -0.03497745f, -0.00105231f, 0.03270360f, -0.00098591f, 0.00060114f, 0.00923544f, 0.02065623f, 
    0.03982569f, 0.04017529f, 0.02571850f, -0.04905287f, -0.00201406f, 0.02255866f, 0.00336964f, -0.05499358f, 
    0.01181375f, -0.00413749f, -0.04529938f, -0.02389173f, -0.02542591f, -0.04252940f, 0.02594958f, -0.01593198f, 
    0.02981321f, 0.00061390f, -0.03894982f, -0.00180781f, -0.00648768f, -0.00934106f, 0.02082123f, -0.03240712f, 
    0.04197145f, 0.00190923f, 0.00518388f, 0.02738867f, -0.00661219f, -0.00561581f, 0.02411807f, -0.03185184f, 
    -0.02177123f, -0.00594444f, -0.00993945f, -0.01308254f, 0.01619414f, 0.00444819f, -0.01986973f, -0.05176767f, 
    0.03476290f, -0.00296719f, 0.03883863f, 0.01367141f, -0.00392177f, -0.03071477f, -0.03470588f, 0.02073938f, 
    -0.03565312f, 0.02708236f, -0.00109098f, -0.01276265f, -0.04673911f, -0.01184662f, -0.02528348f, -0.04756869f, 
    -0.01836089f, 0.03252374f, -0.05640201f, 0.03282520f, -0.00740269f, 0.02514937f, -0.03235472f, -0.00988357f, 
    -0.00192991f, -0.04706549f, 0.00400726f, -0.04041928f, -0.00130770f, 0.00324072f, -0.05700402f, 0.00834009f, 
    -0.00330581f, -0.03102281f, -0.01859356f, 0.03416456f, -0.00482070f, -0.00957415f, -0.00248750f, -0.02893597f, 
    0.01270303f, 0.00758979f, -0.03378211f, -0.01551523f, -0.02245476f, 0.01377107f, 0.02917868f, 0.02679098f, 
    0.00058400f, -0.05131395f, -0.01071785f, 0.01719594f, -0.02000239f, 0.02043873f, 0.00294709f, 0.02788793f, 
    -0.01347360f, -0.05800990f, -0.05271231f, -0.03842336f, -0.04356303f, 0.01651308f, 0.04165919f, 0.01909804f, 
    -0.01630002f, 0.03583164f, -0.01175916f, -0.02020212f, -0.05058647f, -0.02150350f, 0.00734480f, 0.02746295f, 
    -0.02403461f, -0.00733560f, 0.01021567f, -0.04812794f, -0.04774691f, -0.05653684f, -0.03264958f, 0.01793272f, 
    -0.04812778f, -0.03956021f, 0.00272121f, -0.00332422f, 0.04034248f, 0.02868277f, -0.00555944f, -0.02518358f, 
    0.01040591f, 0.01500192f, -0.01980949f, -0.03987950f, -0.04922972f, -0.05170580f, -0.05712057f, 0.03926206f, 
    0.01151270f, 0.01323500f, -0.05550096f, 0.00640829f, -0.01883343f, 0.02943798f, -0.01384407f, -0.03379236f, 
    -0.03106860f, 0.00121366f, 0.03978755f, 0.02591127f, -0.01877376f, 0.00175922f, 0.02585733f, -0.01754416f, 
    -0.05761459f, 0.00881952f, -0.04401019f, -0.01263172f, -0.03049649f, -0.00796893f, -0.00503867f, -0.00952335f, 
    -0.01192765f, -0.05869017f, 0.00151364f, 0.00863217f, -0.00567545f, -0.04603629f, 0.01486344f, 0.03066953f, 
    -0.05303377f, -0.01967873f, -0.04845607f, 0.01318385f, -0.01503007f, -0.04663369f, -0.03547681f, -0.00097903f, 
    -0.00780682f, 0.03310882f, -0.01530266f, 0.04211839f, -0.00921993f, 0.02278768f, -0.02298709f, 0.01735966f, 
    -0.02765154f, -0.03951051f, -0.02908724f, -0.02054184f, -0.03442892f, -0.04595304f, 0.01611911f, -0.03278095f, 
    -0.01748068f, 0.02669320f, 0.00287001f, 0.02894464f, -0.01244005f, 0.02276103f, -0.03403786f, 0.01148146f, 
    -0.04480975f, 0.02108060f, -0.00834811f, 0.00979854f, -0.00141727f, 0.03691695f, -0.02699545f, 0.01521993f, 
    0.02630995f, 0.00389096f, -0.05256034f, 0.01246905f, 0.01182644f, -0.04898821f, -0.05403719f, 0.04180202f, 
    -0.00574638f, 0.00653575f, -0.00291606f, -0.05653404f, -0.05015616f, 0.00027077f, -0.03632656f, -0.01551311f, 
    -0.01948781f, 0.01469630f, 0.03297506f, -0.00912775f, -0.00636980f, 0.02578263f, -0.04289334f, -0.00684410f, 
    -0.01936878f, -0.00532013f, 0.03207843f, 0.01568997f, 0.03952280f, 0.02266005f, 0.00946456f, 0.01732398f, 
    0.03592532f, -0.04519145f, -0.03519356f, -0.00615332f, -0.01994705f, -0.01238281f, -0.04647602f, -0.02448265f, 
    -0.03802950f, 0.02551488f, 0.01775521f, -0.00116638f, -0.02656112f, -0.04119294f, -0.02802541f, 0.03717227f, 
    0.03441254f, -0.04189444f, -0.03210181f, -0.05513785f, -0.05140810f, 0.03231112f, -0.05381763f, 0.03725911f, 
    0.02208011f, -0.00543493f, 0.03235491f, 0.02107116f, -0.00231273f, -0.04739949f, -0.00774591f, 0.03493817f, 
    -0.02166511f, -0.00203900f, -0.04405157f, -0.00142871f, -0.00588499f, -0.05650258f, 0.00336285f, -0.00123528f, 
    0.01713156f, -0.01359375f, -0.05339563f, -0.00178466f, 0.00818415f, -0.00259097f, 0.00846086f, -0.03120668f, 
    0.03802374f, 0.02994699f, -0.00192920f, -0.04643799f, -0.02935126f, -0.05463979f, -0.00785718f, -0.02457549f, 
    -0.04555709f, 0.04039611f, -0.05046852f, 0.02772015f, 0.03050214f, -0.03545123f, -0.04571582f, -0.01887413f, 
    0.02623789f, 0.01599921f, -0.00129419f, 0.04259220f, -0.03363739f, 0.02516204f, -0.02198506f, -0.04183492f, 
    -0.00625316f, -0.00681604f, 0.04178670f, 0.00361347f, -0.05791926f, 0.04174883f, 0.04098020f, -0.04714366f, 
    0.00425425f, -0.00259221f, 0.02555627f, -0.01599592f, -0.03050794f, 0.00820955f, 0.00943005f, -0.02137366f, 
    -0.01707073f, -0.05188140f, -0.02907682f, -0.04065964f, -0.03229843f, 0.01584270f, 0.03011188f, -0.03639081f, 
    0.03683614f, -0.00827578f, 0.03867975f, -0.02927692f, 0.03139061f, -0.00834709f, -0.02146425f, -0.01793438f, 
    0.01091679f, 0.02977149f, 0.02692797f, 0.00302604f, 0.00501162f, -0.01258885f, 0.02480536f, -0.05222924f, 
    0.01800612f, -0.00444564f, -0.02436954f, -0.02389509f, 0.01180957f, -0.03010425f, 0.01969502f, -0.01675714f, 
    -0.05427324f, -0.01719710f, -0.01226699f, 0.02700746f, -0.02118056f, 0.02382497f, -0.02669959f, -0.00017197f, 
    -0.03183828f, -0.03834466f, -0.04083818f, -0.00226530f, 0.02366991f, -0.04498042f, -0.05715333f, -0.05309954f, 
    -0.05455373f, -0.03067967f, -0.03135263f, 0.00283125f, -0.01796815f, -0.01804910f, -0.03805206f, 0.00986040f, 
    -0.01325823f, -0.03384497f, 0.01989063f, -0.03245957f, 0.03177309f, -0.00908292f, 0.02676239f, 0.03935288f, 
    0.04220500f, -0.05583701f, 0.00370113f, 0.02578181f, -0.05558169f, 0.01314771f, -0.04402333f, -0.03598082f, 
    -0.03663428f, 0.04250473f, -0.04748469f, 0.03750239f, -0.01975135f, -0.00438952f, 0.03182619f, 0.01904911f, 
    0.03245597f, -0.00384248f, 0.03497060f, 0.00604292f, -0.01155864f, -0.03673726f, 0.01923257f, -0.01633062f, 
    -0.05790547f, -0.01636798f, -0.03444989f, -0.00820018f, 0.00171170f, 0.01929962f, 0.02133401f, 0.01741136f, 
    0.01864827f, -0.05050302f, -0.02714081f, -0.02573553f, -0.05268768f, -0.00569947f, 0.00450956f, -0.04362386f, 
    -0.01654513f, 0.02185372f, 0.01612405f, 0.03916479f, -0.00291149f, 0.03750277f, -0.03029836f, 0.04180891f, 
    0.04016329f, -0.00599593f, -0.01710833f, 0.01073424f, -0.05062725f, -0.04027479f, -0.03774881f, 0.02734862f, 
    0.01887035f, 0.04141625f, -0.00384778f, 0.04356900f, -0.04592321f, -0.05066015f, -0.01005280f, -0.03573246f, 
    -0.04159826f, -0.02481521f, -0.02992980f, -0.00815382f, 0.02746835f, 0.02768505f, -0.04505080f, -0.03010294f, 
    0.00587293f, -0.03484756f, -0.05566046f, -0.01720765f, -0.05488848f, -0.01894941f, -0.00445115f, 0.04157982f, 
    -0.02159175f, -0.04236457f, -0.04601483f, -0.01683677f, 0.00441502f, 0.00773964f, 0.00566076f, -0.04958199f, 
    -0.01799701f, -0.02301639f, -0.03852224f, -0.02897238f, -0.01064706f, -0.03342338f, 0.01108636f, -0.00151195f, 
    0.00636307f, -0.04866537f, -0.05316292f, -0.01649269f, -0.03513641f, 0.03448209f, 0.00142714f, -0.02751484f, 
    0.04143422f, -0.02431602f, -0.00246297f, -0.05208972f, -0.03356477f, 0.04292202f, 0.00745402f, -0.04412584f, 
    0.02923309f, 0.01923020f, -0.04565491f, 0.03780247f, -0.02159927f, -0.02707572f, -0.01402824f, -0.01531859f, 
    0.03223776f, 0.01734632f, 0.01029539f, 0.00438910f, -0.00980620f, -0.02066562f, -0.04762048f, 0.02419103f, 
    -0.05468515f, 0.01209050f, 0.00240248f, 0.00599354f, -0.00025139f, -0.02848381f, -0.05827617f, -0.00803962f, 
    -0.03847961f, 0.00003382f, -0.02871545f, 0.02347301f, -0.04613493f, 0.00942715f, -0.01175565f, 0.02608277f, 
    -0.02050214f, 0.00708013f, -0.03097388f, -0.00685838f, -0.04617850f, 0.01275505f, 0.01156233f, 0.03456489f, 
    0.01604377f, -0.02301148f, -0.01265241f, -0.05812162f, -0.04658750f, -0.04476507f, -0.04537238f, -0.02680596f, 
    -0.04344467f, 0.03243325f, -0.03852752f, -0.04424989f, -0.02093279f, -0.04718044f, -0.01536202f, -0.05658446f, 
    -0.00203454f, 0.03893442f, -0.01495686f, -0.01386721f, 0.03985158f, 0.04124894f, -0.01291850f, -0.04648435f, 
    -0.01556034f, -0.02363075f, 0.01633630f, -0.01226251f, 0.03875040f, 0.00488072f, 0.02058847f, -0.03386508f, 
    -0.05003481f, 0.01957212f, 0.04134787f, -0.03519373f, 0.01811179f, -0.05784680f, -0.03877916f, -0.01649811f, 
    0.03107966f, 0.04108597f, 0.02576008f, -0.01308311f, -0.04636983f, 0.03232620f, -0.03448130f, -0.04505352f, 
    -0.04445302f, 0.00735310f, 0.00935683f, -0.00700141f, 0.02535590f, -0.04608642f, 0.04235401f, 0.01327776f, 
    0.00731673f, 0.01589605f, 0.01521727f, 0.02521036f, -0.05342145f, -0.03115651f, -0.00862266f, 0.00824264f, 
    0.00884624f, -0.02749662f, -0.01497138f, 0.03619366f, 0.00027708f, 0.01776579f, 0.04349233f, -0.00814321f, 
    0.01718054f, 0.01496969f, -0.05308679f, 0.04135429f, 0.04067378f, -0.05845469f, 0.04029777f, 0.03385347f, 
    0.02078239f, -0.00765418f, 0.00336264f, 0.02278246f, -0.05638754f, -0.02076460f, 0.01589585f, -0.03062767f, 
    -0.02787756f, -0.00686444f, -0.00667792f, -0.02833835f, -0.04584949f, 0.03592067f, -0.01857996f, 0.00860824f, 
    -0.01139921f, 0.01040265f, -0.03358864f, -0.04034314f, -0.04243345f, -0.05060829f, 0.00651227f, -0.03931521f, 
    -0.01272757f, 0.04414297f, 0.01615554f, -0.04660825f, 0.02085591f, -0.04874783f, 0.00078583f, 0.01388331f, 
    -0.00983822f, 0.03796178f, -0.01117283f, 0.04305984f, 0.00728468f, 0.00218522f, 0.00634572f, -0.05673758f, 
    -0.00653643f, -0.03431224f, -0.04269053f, -0.00883220f, -0.02463677f, 0.01336392f, -0.02934526f, 0.03615065f, 
    -0.02857862f, 0.04756695f, -0.04042452f, -0.02728505f, -0.04694878f, -0.05654391f, 0.02101065f, -0.04320228f, 
    -0.04943825f, 0.00429439f, -0.00020010f, -0.00466031f, 0.03629987f, -0.00078722f, -0.00836763f, -0.03387493f, 
    -0.02985884f, -0.01445632f, 0.02613435f, 0.02173772f, 0.03127646f, -0.02394421f, -0.01744839f, 0.02618247f, 
    -0.01087237f, -0.02293616f, 0.04658930f, -0.02735517f, -0.03173946f, 0.02140183f, 0.01752108f, 0.00005461f, 
    -0.04190950f, -0.04584503f, -0.04964888f, 0.02643908f, 0.04594763f, 0.00664494f, -0.01724910f, -0.01012965f, 
    -0.01859804f, 0.04727573f, -0.02527568f, -0.01940922f, 0.02962595f, -0.00128417f, -0.03038828f, -0.02709433f, 
    0.04003437f, -0.03561781f, 0.03077660f, -0.02368584f, 0.00996380f, 0.01230935f, -0.01797208f, 0.01184456f, 
    -0.03773407f, 0.01410514f, 0.02757424f, -0.00952101f, 0.02392203f, 0.00699596f, -0.01159840f, -0.04010421f, 
    -0.02820553f, 0.03763748f, -0.04757095f, 0.02053278f, 0.01014822f, -0.03194419f, 0.03638081f, -0.04285769f, 
    0.00042167f, -0.04782081f, 0.00641098f, 0.01166845f, 0.00412525f, 0.04015495f, -0.00040070f, -0.00979576f, 
    -0.05565124f, 0.00463331f, -0.02108756f, 0.02902134f, -0.01650202f, 0.03261962f, 0.04166269f, 0.02280779f, 
    -0.02198010f, 0.03825094f, -0.00185342f, 0.04220110f, -0.04564018f, -0.01074270f, 0.04800323f, -0.02146531f, 
    0.03695858f, -0.01614394f, 0.01152493f, -0.03931196f, -0.03162449f, -0.03495489f, -0.04398219f, -0.01486253f, 
    -0.00782860f, -0.05349365f, 0.02902002f, -0.05290015f, -0.01686985f, -0.04565262f, 0.00764465f, 0.03122462f, 
    -0.01736161f, 0.00636434f, -0.03179818f, -0.04225297f, 0.01949538f, 0.00221357f, 0.02484191f, -0.01241069f, 
    0.03849500f, 0.02401485f, -0.00143375f, -0.00563279f, -0.04384219f, -0.00254708f, 0.03324310f, 0.01456680f, 
    -0.04944420f, -0.04750103f, -0.01759758f, 0.03534986f, -0.01923905f, -0.00070995f, 0.03833518f, -0.05444912f, 
    0.01362171f, -0.00865838f, 0.02177845f, -0.00449506f, -0.04861093f, -0.00649905f, -0.04207007f, -0.00348928f, 
    -0.00315692f, 0.04358435f, 0.00164890f, -0.00796432f, 0.04502087f, -0.00086742f, 0.00815790f, 0.01359414f, 
    -0.00438431f, -0.02959785f, -0.04103630f, -0.03979468f, -0.02715339f, -0.02328397f, 0.04351239f, -0.01931812f, 
    0.04611829f, 0.04284897f, -0.01666719f, -0.04658395f, 0.03823792f, 0.02690210f, 0.02254010f, -0.00695195f, 
    0.02461657f, -0.00822345f, 0.00337090f, 0.03025119f, 0.00845264f, 0.00125469f, -0.04183423f, -0.00032778f, 
    0.04355299f, 0.01950571f, -0.02824159f, -0.02850430f, -0.00296959f, 0.03412878f, -0.01060025f, -0.05842595f, 
    0.00565148f, 0.02429589f, 0.01218384f, 0.02779224f, -0.02528215f, -0.01035330f, -0.04071505f, -0.01335952f, 
    -0.05338621f, -0.00872942f, -0.01153738f, -0.01162346f, -0.04240634f, -0.04812910f, 0.03967611f, 0.00059478f, 
    -0.01063283f, 0.03546225f, -0.04324425f, 0.00166916f, 0.04414687f, 0.00027115f, 0.02000361f, -0.02079795f, 
    0.03295348f, -0.00305187f, 0.02573986f, -0.02950056f, 0.01540633f, -0.02764892f, -0.04433266f, -0.03612633f, 
    -0.03385608f, -0.02913649f, -0.04889068f, 0.01455393f, 0.03861468f, 0.04027435f, 0.02725345f, -0.03321264f, 
    0.03618689f, -0.02471726f, -0.01182655f, -0.00746065f, -0.04568913f, -0.02097939f, 0.03395858f, 0.01737066f, 
    -0.01987699f, 0.03605117f, 0.03494958f, 0.03696158f, -0.01002832f, -0.01121559f, -0.03414768f, -0.02453530f, 
    -0.04371946f, -0.03743577f, -0.05658853f, -0.02959791f, -0.01487569f, -0.04637561f, -0.01934065f, -0.00689390f, 
    -0.02660530f, -0.01174175f, 0.02016818f, -0.01833891f, -0.00032906f, -0.02973252f, -0.03012646f, 0.01427386f, 
    -0.04033101f, -0.00536061f, -0.00601208f, -0.03784806f, -0.02049066f, 0.03455378f, 0.01625581f, 0.01539602f, 
    0.00979768f, -0.05601010f, -0.03715351f, -0.00866269f, 0.04248628f, -0.00130745f, 0.01795932f, 0.01463630f, 
    0.00179374f, -0.01079193f, -0.04948810f, -0.03314536f, -0.02979057f, 0.03345024f, 0.04578621f, 0.04825047f, 
    -0.00957470f, -0.02248774f, -0.00182724f, -0.02853454f, 0.03722740f, 0.02139595f, 0.03895999f, 0.03317343f, 
    -0.01901622f, -0.04803118f, 0.02350891f, 0.02643648f, 0.03569552f, -0.05508314f, -0.03629792f, 0.00245869f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.00664485f, 0.09154511f, 0.00858123f, 0.04878561f, -0.00323279f, 0.01957478f, -0.05298572f, -0.00173363f, 
    0.03746386f, 0.07613745f, 0.00715162f, 0.01433889f, 0.02552368f, 0.02123671f, -0.00222811f, 0.00125552f, 
    0.03313833f, 0.03156120f, 0.00866011f, 0.09428364f, -0.03439194f, 0.08721727f, 0.02872535f, 0.05367531f, 
    -0.05810383f, -0.00901641f, 0.06561593f, 0.07075676f, 0.04276561f, 0.03594543f, -0.00127992f, 0.03224065f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.12774526f, -0.07521338f, 0.24248111f, 0.12721321f, -0.15598404f, 0.02764356f, -0.15554485f, -0.04406676f, 
    0.11358625f, 0.06802366f, 0.13556200f, -0.16551936f, 0.04172936f, 0.16696189f, -0.01624617f, 0.16105250f, 
    -0.07367904f, -0.16997637f, 0.07173221f, 0.05374984f, 0.40513611f, 0.25218621f, 0.07567436f, -0.24831744f, 
    -0.03034330f, 0.20779799f, 0.43383282f, -0.61625725f, 0.28754202f, -0.00503604f, -0.10481653f, 0.01293491f, 
    0.36227033f, -0.36341202f, 0.15709184f, 0.15883625f, 0.05608011f, 0.01003313f, 0.09232125f, 0.11714140f, 
    0.03081735f, 0.02035322f, 0.04675987f, -0.17181033f, -0.12757929f, 0.40009248f, 0.04856641f, -0.17504312f, 
    -0.02101333f, 0.08593532f, -0.05776598f, 0.04080205f, 0.37857121f, -0.35296193f, 0.10317446f, -0.21117711f, 
    -0.12266988f, 0.14243114f, -0.02934070f, -0.20500569f, 0.26748782f, 0.10195562f, 0.12104914f, 0.06110157f, 
    -0.08239491f, 0.07330646f, -0.18282761f, -0.13163210f, -0.18229061f, -0.12521009f, -0.15611427f, 0.13617378f, 
    0.13959822f, -0.15536499f, 0.03789723f, 0.05549108f, 0.09841466f, 0.06083725f, 0.11278424f, 0.08260068f, 
    -0.15298541f, 0.05673898f, -0.02323790f, 0.06899218f, -0.05316355f, -0.01243840f, -0.10593187f, -0.13657086f, 
    -0.14149952f, 0.15361261f, 0.09468464f, -0.07995271f, -0.09835992f, -0.11021971f, 0.14473070f, -0.10713439f, 
    -0.00444836f, 0.25296620f, 0.35291883f, -0.21445172f, -0.01342794f, -0.08339748f, -0.08208077f, 0.16383047f, 
    -0.07452153f, -0.29243287f, 0.07755172f, -0.20818444f, -0.00761607f, 0.00421407f, 0.11760650f, 0.12316813f, 
    -0.08034891f, -0.10796629f, -0.16339752f, -0.27725488f, 0.25201243f, -0.08956308f, -0.01701435f, 0.45789224f, 
    0.14275043f, -0.27545002f, -0.09235403f, 0.21146159f, 0.09170518f, -0.06610558f, -0.16533446f, 0.15423569f, 
    0.29584935f, 0.35323957f, 0.25168666f, -0.22109859f, -0.11288916f, -0.14798912f, -0.02230472f, -0.12889440f, 
    0.02814662f, -0.14192419f, -0.16484030f, 0.57870591f, 0.11316708f, -0.08251075f, -0.11844251f, 0.16224676f, 
    0.12768254f, -0.06363446f, 0.15943608f, -0.15968561f, -0.13728362f, -0.23349027f, -0.13713436f, 0.07801151f, 
    0.01481727f, 0.38803849f, 0.00355876f, 0.12903720f, -0.04060041f, 0.13225128f, 0.15910611f, -0.16240114f, 
    -0.05001485f, 0.24535966f, 0.01758659f, 0.15738447f, -0.12784076f, 0.08344823f, -0.14512169f, -0.19789702f, 
    -0.09820036f, 0.04752596f, -0.10141163f, 0.12323929f, -0.10399945f, -0.41784063f, -0.39995894f, 0.15932974f, 
    0.08836171f, 0.08214718f, 0.01168210f, 0.34960634f, -0.17484909f, 0.33905080f, -0.01380571f, -0.04620765f, 
    -0.16021194f, 0.10614578f, 0.21067299f, -0.22835293f, 0.22081879f, -0.07867316f, 0.05072065f, 0.02168412f, 
    0.27408084f, 0.19540811f, 0.05703505f, 0.09470132f, -0.04378058f, -0.11134042f, 0.00753382f, -0.29290321f, 
    0.09189299f, -0.02658629f, 0.08971538f, 0.33339369f, -0.10167497f, -0.19252814f, -0.33944160f, -0.04266327f, 
    0.06238044f, -0.16646884f, 0.15832432f, 0.46083227f, 0.12377819f, 0.15226884f, -0.29099473f, -0.00317071f, 
    -0.14878222f, 0.15554483f, 0.43357480f, -0.26758593f, 0.38241342f, 0.11880722f, 0.16369481f, -0.15232807f, 
    -0.20458303f, 0.14617509f, -0.05752575f, 0.00109287f, 0.00080614f, 0.03533369f, -0.07349438f, 0.24678366f, 
    0.12344953f, 0.24847069f, 0.08406136f, 0.06221409f, 0.00468701f, 0.20535098f, 0.19258548f, -0.10988910f, 
    0.20313136f, 0.11610096f, -0.16927497f, -0.35261583f, -0.12498946f, -0.23954149f, 0.15578246f, 0.04391285f, 
    0.06755589f, -0.24783228f, -0.18276885f, 0.61296940f, 0.18975832f, 0.14680994f, -0.11167345f, -0.04256883f, 
    0.33559668f, 0.19651312f, -0.13666561f, 0.13037561f, 0.11597623f, -0.15752868f, -0.04539605f, -0.27380088f, 
    -0.00208465f, 0.09584613f, -0.10429507f, 0.37866899f, 0.10303289f, 0.18774244f, 0.02794174f, 0.17018898f, 
    0.09315718f, 0.00169527f, 0.07848255f, -0.18175851f, -0.05179969f, -0.17416632f, -0.20924839f, 0.45435926f, 
    -0.05338779f, -0.16370295f, -0.02651061f, 0.57917017f, 0.21212263f, -0.03653568f, -0.14801791f, -0.10989181f, 
    0.33535430f, 0.01007236f, -0.19658436f, -0.11966819f, -0.10476368f, 0.02517012f, 0.11233936f, 0.15708932f, 
    0.14992750f, 0.26586670f, -0.10154825f, 0.21339773f, -0.01287778f, 0.02006135f, 0.05733687f, 0.12814383f, 
    0.20454586f, 0.15341209f, -0.12999727f, 0.07221094f, -0.42023781f, -0.07719309f, 0.22011757f, 0.23137306f, 
    -0.05659955f, 0.34461391f, -0.26078561f, -0.05376816f, -0.06686516f, -0.16128863f, -0.03762986f, 0.01284658f, 
    -0.04080927f, 0.20530041f, 0.37514016f, -0.07629831f, -0.05621857f, 0.04469198f, 0.09397121f, 0.22407974f, 
    -0.14612290f, 0.11538528f, 0.08592056f, -0.20122452f, 0.03722064f, -0.21856096f, 0.03867774f, 0.06117462f, 
    -0.06114242f, -0.17080493f, -0.10685315f, -0.22516988f, -0.11839025f, 0.36824840f, 0.39059159f, -0.13567315f, 
    0.11215596f, -0.13371897f, 0.32980362f, -0.12156774f, -0.14846891f, 0.16805762f, -0.07255059f, 0.03840730f, 
    0.05842836f, 0.14947665f, 0.35447022f, -0.13204359f, 0.07036120f, 0.08803405f, -0.00471332f, 0.18774265f, 
    -0.03176591f, -0.12151226f, -0.16932735f, -0.08801871f, 0.04271461f, 0.02245814f, 0.45518559f, -0.12663925f, 
    -0.12368052f, -0.00785682f, 0.12037733f, -0.41559732f, 0.09230914f, 0.32434744f, 0.08828977f, 0.34619069f, 
    -0.02774573f, -0.25912327f, 0.14697735f, 0.17496498f, -0.13086401f, -0.00319041f, -0.11387918f, 0.08997215f, 
    -0.36817345f, -0.15824105f, 0.04825056f, 0.27644193f, -0.12748909f, -0.12157489f, 0.16401310f, 0.33382696f, 
    -0.15052642f, 0.03925120f, -0.08895618f, -0.12167367f, -0.04325839f, 0.51743960f, 0.37650153f, 0.15089987f, 
    -0.01461761f, -0.08762085f, 0.08112270f, 0.21050899f, 0.27276185f, -0.01757697f, -0.00797116f, 0.31143042f, 
    -0.13314925f, 0.06917808f, -0.27472791f, 0.35221207f, -0.02910682f, 0.16672897f, 0.14383009f, 0.01815402f, 
    0.15101640f, 0.12993136f, -0.19223063f, 0.25705990f, 0.00489158f, 0.13590115f, -0.15774243f, -0.23572186f, 
    -0.00504145f, 0.35752404f, 0.07551386f, 0.39506370f, -0.05879635f, -0.07369632f, 0.04416829f, -0.00871946f, 
    0.15930355f, 0.09502368f, 0.04886255f, 0.27459913f, 0.31503770f, 0.44216865f, -0.17198996f, -0.07217251f, 
    0.14604546f, -0.12905009f, -0.10665424f, 0.60542917f, -0.13982239f, 0.18089986f, -0.07153031f, -0.05817991f, 
    -0.05498453f, 0.07565694f, 0.06081621f, 0.23881277f, -0.11435968f, -0.09271247f, 0.13242242f, 0.03717828f, 
    0.06651332f, 0.31043893f, 0.05265888f, -0.00670373f, -0.05812231f, -0.00676246f, -0.18031159f, -0.03299855f, 
    0.06016014f, 0.12963320f, 0.10797951f, 0.00009720f, -0.18802880f, 0.06160007f, 0.29929695f, -0.10673998f, 
    0.11979017f, -0.42968440f, -0.22854529f, 0.68067813f, 0.10789745f, -0.14785893f, 0.13334575f, -0.12640901f, 
    0.20071812f, -0.13472308f, -0.10731184f, 0.27871746f, 0.13166209f, -0.08967990f, 0.16069959f, -0.02137048f, 
    0.02947600f, 0.06950826f, 0.06325001f, -0.19410108f, 0.02005469f, -0.28330082f, -0.04965505f, -0.01848193f, 
    0.00379551f, 0.14068894f, 0.10348719f, 0.42934838f, 0.21515626f, 0.41510659f, -0.12654527f, 0.47346681f, 
    -0.08693090f, -0.33452863f, -0.01190744f, 0.29923990f, -0.03407520f, 0.16925336f, -0.11146121f, -0.15131217f, 
    0.28960517f, -0.13948825f, 0.23306888f, -0.30115035f, 0.18305530f, 0.07933056f, -0.16002639f, -0.00583631f, 
    0.03510932f, -0.30697516f, -0.10537074f, -0.09748315f, -0.09941027f, 0.14245892f, 0.37156376f, 0.04797460f, 
    0.20979229f, -0.03252747f, 0.05198606f, -0.07115185f, 0.33352402f, -0.30444688f, -0.01758917f, 0.14051443f, 
    0.05201331f, 0.42398483f, 0.01815480f, -0.35461417f, -0.17596585f, -0.03149004f, 0.01170001f, -0.11401193f, 
    0.18397795f, 0.03082138f, 0.00125046f, -0.24688296f, -0.15278940f, -0.08623926f, 0.09740220f, 0.40137652f, 
    -0.12319995f, 0.08998346f, 0.14279653f, 0.03931185f, -0.09421983f, 0.09459294f, 0.30646396f, -0.03078233f, 
    0.22816731f, -0.07966600f, 0.09567700f, -0.33332047f, -0.24679229f, -0.08881282f, 0.37770855f, -0.25076666f, 
    -0.10180739f, -0.08850498f, -0.06819377f, -0.32170016f, 0.23810731f, 0.04120027f, -0.09811801f, -0.05608859f, 
    0.21745735f, 0.21363817f, 0.03346660f, -0.02025864f, -0.15948085f, 0.14147224f, -0.06077430f, 0.08377770f, 
    -0.11514625f, -0.15228310f, 0.05901246f, 0.03915450f, -0.04567761f, 0.16925682f, -0.05278160f, -0.16885144f, 
    -0.09346490f, 0.00861407f, -0.02804715f, -0.04400175f, -0.21518815f, -0.37876046f, -0.25696602f, 0.52712202f, 
    0.06010505f, 0.09076979f, 0.02468439f, -0.08649464f, 0.50988615f, 0.00754586f, 0.15487243f, 0.16336308f, 
    -0.13283914f, -0.22780490f, 0.22681105f, 0.29573768f, 0.15995911f, -0.15241113f, 0.09830577f, 0.20882000f, 
    0.15803766f, -0.20275527f, 0.06878415f, -0.33213615f, 0.03995513f, 0.38089758f, 0.34309593f, 0.09595549f, 
    -0.09930585f, 0.13600804f, 0.15169612f, -0.05801363f, 0.36022341f, 0.16857980f, 0.17981099f, -0.11608145f, 
    -0.01968142f, 0.27277625f, 0.02841487f, -0.14679047f, -0.17765087f, 0.02883806f, 0.11842079f, 0.00427891f, 
    0.16745850f, -0.18595102f, -0.06498127f, 0.24743606f, 0.06930650f, 0.18013619f, -0.16864413f, -0.12920700f, 
    0.16812301f, 0.24408187f, -0.10233720f, 0.23285501f, -0.13187268f, 0.10635127f, 0.17558955f, 0.04598102f, 
    -0.04164494f, -0.02341836f, 0.16152017f, -0.22254576f, 0.52098626f, -0.10604880f, 0.15613498f, -0.46703959f, 
    -0.15963005f, 0.09494719f, 0.25994161f, -0.12187860f, 0.35298267f, 0.16637990f, 0.10931841f, -0.03224013f, 
    0.05011743f, -0.02011852f, 0.03856431f, 0.14690146f, -0.04984625f, 0.04727556f, 0.05743332f, -0.21903029f, 
    0.15633115f, -0.04480695f, 0.12190501f, 0.26482120f, 0.01875036f, 0.56291151f, 0.28783011f, 0.06039840f, 
    0.12985690f, 0.10052954f, 0.07755671f, -0.09566243f, 0.27050355f, -0.34556568f, -0.26608181f, 0.34820226f, 
    0.03269766f, 0.03426077f, -0.13571189f, 0.32382840f, 0.05025509f, -0.02881992f, -0.17004924f, 0.13045132f, 
    0.10564318f, 0.14516425f, -0.06901243f, -0.21346228f, -0.06959134f, 0.16154529f, 0.10354064f, 0.25955746f, 
    0.13396694f, 0.14218943f, -0.08229677f, -0.31256399f, 0.06723007f, -0.16379146f, 0.15180680f, 0.08360990f, 
    0.20450857f, -0.04383126f, -0.16079497f, -0.12540312f, -0.31637055f, -0.18911055f, 0.02458829f, 0.28722748f, 
    0.02352276f, 0.01348940f, -0.08892222f, -0.28943470f, 0.47559443f, 0.05509927f, -0.04994448f, 0.03291578f, 
    0.15706003f, -0.14174499f, 0.14811786f, -0.12990630f, 0.04574514f, -0.05951178f, 0.07762247f, 0.16577511f, 
    0.03012370f, 0.31137279f, -0.13126804f, -0.07571715f, -0.02844154f, 0.28381687f, 0.53707379f, -0.12637639f, 
    0.03086422f, 0.12125787f, 0.10079885f, -0.50342739f, 0.14336088f, 0.07437531f, 0.40407440f, -0.27941924f, 
    -0.09900931f, -0.10083635f, -0.30026186f, 0.15979792f, 0.33547485f, 0.11460370f, -0.03976704f, -0.13819082f, 
    -0.08739778f, -0.01712329f, 0.00252690f, 0.09170216f, -0.03893160f, 0.00089206f, 0.06426336f, 0.24602987f, 
    0.02292077f, 0.17844684f, -0.08972228f, 0.25852174f, 0.03486752f, -0.18072632f, -0.31216425f, 0.04153508f, 
    0.25674492f, -0.09292782f, -0.00786810f, -0.09314739f, -0.13463031f, -0.05788335f, 0.26127598f, -0.14422455f, 
    0.10644701f, 0.56493503f, 0.15509878f, -0.21488465f, -0.28389981f, 0.13700509f, -0.05509092f, -0.13045208f, 
    -0.16497079f, -0.00606141f, 0.10544878f, 0.04883161f, -0.01664204f, 0.13415082f, 0.01268496f, -0.06830388f, 
    0.00829591f, -0.13173664f, -0.12289680f, -0.00368597f, 0.13731284f, -0.14701526f, -0.13964170f, 0.06639713f, 
    -0.16853920f, -0.01275309f, 0.16690378f, -0.15395766f, 0.15345621f, 0.15203255f, -0.15453477f, -0.06395084f, 
    0.13747573f, -0.14127763f, -0.06667359f, 0.07103255f, 0.11090039f, -0.12363797f, 0.09924607f, 0.09975187f, 
    -0.43016505f, -0.04142256f, 0.09810763f, 0.24453497f, -0.02820612f, 0.10215012f, 0.10754760f, 0.43274981f, 
    0.10211626f, -0.31196502f, 0.16527264f, 0.10215147f, 0.14678481f, 0.44057047f, -0.05508354f, 0.03096331f, 
    0.07389189f, -0.06751660f, 0.05649341f, 0.35147232f, -0.15077984f, -0.21975854f, 0.33676469f, -0.05110316f, 
    0.11052044f, 0.17940263f, -0.05418706f, 0.10340869f, -0.03637469f, -0.12086198f, -0.14622641f, 0.04961991f, 
    -0.37685654f, 0.32597175f, 0.19493072f, 0.20811875f, -0.03961461f, 0.01888428f, -0.13385050f, 0.37176234f, 
    0.02194719f, -0.22581653f, 0.12956266f, 0.24946555f, -0.17213699f, 0.07648242f, -0.42044941f, 0.14681584f, 
    0.31268778f, 0.07392365f, -0.06917612f, 0.31254619f, -0.45706558f, -0.29242477f, 0.29290810f, 0.15719230f, 
    0.17232846f, 0.26059860f, -0.14001967f, -0.03225850f, -0.22029768f, 0.00653080f, 0.11037044f, -0.05128606f, 
    -0.06728721f, -0.03232997f, 0.12383050f, 0.07971440f, -0.10304812f, -0.13491459f, -0.02567909f, -0.17125018f, 
    0.05647323f, 0.20800819f, 0.16730849f, 0.39727518f, -0.09288457f, -0.10339480f, -0.41140938f, -0.16881530f, 
    0.25879747f, -0.00996082f, 0.15098588f, -0.03449629f, 0.08373977f, 0.04267182f, 0.08876004f, -0.30546090f, 
    -0.14079510f, -0.26495752f, 0.05851788f, 0.35532117f, 0.09367340f, -0.10154410f, 0.11816538f, -0.06342419f, 
    -0.14040059f, 0.13124400f, 0.08265691f, -0.00027199f, 0.01002658f, 0.11674504f, -0.05505856f, 0.03465260f, 
    0.15392949f, -0.01462886f, -0.04585692f, 0.10558286f, -0.03394268f, 0.03585026f, -0.17342502f, -0.09851144f, 
    -0.13268560f, 0.02400779f, 0.10662883f, 0.07608780f, -0.01612530f, 0.10337088f, -0.07008665f, 0.07846277f, 
    -0.12113187f, -0.09062254f, -0.17496511f, -0.12010476f, -0.14871100f, -0.03996267f, -0.06581873f, 0.12685587f, 
    0.14839464f, 0.28545010f, 0.03323328f, -0.00158189f, -0.10967124f, 0.05512805f, -0.01000191f, -0.01631935f, 
    0.01756552f, 0.12356950f, -0.11524712f, 0.47540459f, 0.01680971f, 0.10752025f, -0.22509523f, 0.13269080f, 
    -0.21134426f, 0.06790640f, -0.18909626f, -0.10070309f, -0.10470778f, -0.12138738f, -0.21532196f, 0.33585468f, 
    -0.04402177f, 0.23059794f, 0.17485851f, 0.25556976f, 0.18286420f, -0.01104635f, 0.03133667f, 0.07833616f, 
    0.32040879f, 0.14014931f, -0.19885214f, 0.11883692f, -0.11863149f, -0.01114085f, 0.12760197f, -0.32839575f, 
    0.06299707f, 0.50504440f, 0.15161161f, -0.34452710f, -0.03969715f, 0.00994741f, 0.50207162f, -0.04168940f, 
    -0.11792979f, -0.03855473f, -0.00736123f, 0.30426678f, 0.12787114f, 0.31000090f, -0.10909225f, 0.11893488f, 
    -0.07955360f, -0.03173114f, -0.08083591f, 0.19205567f, 0.12041475f, -0.15769599f, -0.05073633f, -0.08424385f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.07289984f, 0.01617606f, -0.08370681f, 0.06617264f, 0.12262229f, -0.01003009f, -0.04000178f, 0.24278536f, 
    0.07257587f, -0.00378053f, -0.01463902f, -0.05984249f, 0.01135591f, -0.06978300f, -0.02854318f, -0.05483779f, 
    -0.19418798f, 0.11302923f, -0.03692259f, 0.18145725f, 0.13924372f, -0.02757012f, 0.07505039f, 0.13611051f, 
    -0.09464753f, -0.16585037f, 0.05902914f, 0.19758248f, 0.01818946f, -0.16538884f, 0.02004383f, -0.08841327f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    0.20117021f, 0.28238583f, 0.02232709f, -0.37027431f, 0.33990908f, -0.03856071f, 0.25146222f, -0.68224519f, 
    -0.25870007f, -0.03320552f, 0.09634259f, -0.13461982f, -0.58395630f, 0.00140762f, -0.60929888f, -0.31716290f, 
    0.46477744f, -0.03138388f, -0.32787362f, 0.16085224f, 0.29047728f, -0.14683029f, -0.29371342f, -0.03970517f, 
    0.21197367f, 0.00427641f, -0.26761442f, -0.26729369f, 0.16621870f, 0.04064439f, -0.10759031f, -0.19728351f, 
    0.16381627f, -0.24244995f, 0.04091014f, -0.02053654f, 0.10304761f, 0.33533320f, 0.31245473f, -0.28223988f, 
    0.24529080f, 0.04926482f, -0.18595886f, -0.36057881f, -0.36421326f, 0.14962402f, -0.25905529f, 0.18972649f, 
    -0.03482993f, -0.42388114f, 0.19884329f, -0.23943305f, 0.02988629f, 0.01573350f, 0.03643036f, -0.43635342f, 
    0.05508021f, 0.11727767f, -0.36352271f, -0.16960374f, -0.09587596f, 0.02821924f, 0.35271096f, 0.13093947f, 
    0.35959828f, -0.03180123f, -0.08642820f, -0.43564382f, -0.57360578f, 0.12050974f, 0.30447033f, -0.54901147f, 
    -0.15636194f, -0.47670466f, 0.05394885f, -0.05981453f, 0.40479088f, 0.07115722f, -0.18953718f, 0.25258979f, 
    -0.10585853f, -0.49676052f, -0.32634339f, 0.24443507f, 0.05027235f, 0.01804034f, -0.50262284f, -0.16982479f, 
    -0.54683441f, 0.13182059f, 0.10833987f, -0.38774100f, -0.03141908f, -0.12920704f, -0.19149615f, 0.28246352f, 
    0.14837874f, -0.17021875f, -0.02098050f, -0.37458363f, 0.23562957f, 0.08202364f, -0.08236450f, -0.30018416f, 
    -0.62034345f, 0.29361433f, 0.13856915f, 0.01842569f, 0.12721209f, -0.28166449f, -0.63564283f, -0.52871168f, 
    0.16633980f, -0.03503878f, -0.37022623f, 0.24224462f, -0.33326495f, -0.16716053f, -0.27397618f, -0.23849796f, 
    0.36955857f, 0.11020967f, 0.24380079f, 0.24377686f, -0.48074535f, 0.03543501f, 0.25785989f, -0.70055515f, 
    0.18355849f, 0.23966168f, -0.08539940f, 0.14128879f, -0.06260695f, -0.13344993f, 0.03808248f, -0.06321143f, 
    -0.08020170f, -0.03147642f, -0.06071256f, -0.06840536f, 0.10793129f, -0.51999938f, -0.33961132f, -0.06333841f, 
    0.22392315f, 0.09658862f, 0.43958318f, 0.08377023f, -0.07667578f, 0.07857334f, 0.34968606f, -0.00336035f, 
    -0.13456100f, -0.06741441f, 0.12077892f, 0.04582818f, -0.30900061f, -0.05654186f, -0.05612164f, -0.27854505f, 
    -0.21350999f, -0.24016815f, -0.02392581f, -0.26766378f, 0.29438677f, 0.14073765f, 0.05538397f, 0.13603984f, 
    0.28567132f, 0.13183135f, 0.13746318f, -0.04550851f, -0.41224101f, -0.10840917f, 0.22197340f, -0.35328019f, 
    -0.31841701f, 0.18930119f, 0.17711276f, -0.62626481f, -0.14238119f, -0.10020463f, 0.19351108f, 0.15561645f, 
    -0.16560246f, 0.16706736f, -0.07074507f, 0.09115521f, 0.28826711f, 0.09340379f, 0.20067988f, -0.10365118f, 
    0.11023984f, 0.06786028f, 0.11131908f, -0.98006344f, -0.55322456f, 0.03601125f, -0.21044654f, -0.04110033f, 
    -0.41864362f, 0.28474909f, 0.12766966f, -0.34784359f, -0.03856379f, 0.02328671f, 0.16307296f, 0.05143495f, 
    -0.20992109f, 0.22889033f, -0.67647749f, 0.15885800f, 0.13465877f, -0.43911064f, 0.25587445f, 0.26897067f, 
    0.16983157f, 0.17205922f, -0.00414682f, -0.12516211f, -0.04759908f, 0.15780842f, -0.52462000f, 0.18851623f, 
    -0.25483012f, -0.45620859f, 0.12766184f, 0.31607199f, 0.24692005f, -0.37803069f, -0.45862946f, 0.18607207f, 
    -0.01872397f, 0.02332123f, 0.13828357f, 0.38903409f, 0.18627311f, -0.09906843f, -0.34820035f, -0.08271907f, 
    0.39723989f, 0.10138385f, -0.49221325f, -0.01098709f, -0.64187211f, 0.05536206f, 0.08657131f, 0.00759970f, 
    -0.04633985f, -0.01858971f, 0.00377304f, 0.11145301f, -0.31346560f, -0.01503799f, -0.27433702f, 0.13694851f, 
    -0.59708941f, 0.04477756f, 0.13145094f, -0.12945159f, 0.14259408f, -0.11844075f, 0.07381086f, -0.15126500f, 
    0.36761230f, 0.34017646f, -0.53449357f, -0.34634212f, 0.19244957f, 0.29139683f, 0.17178175f, 0.41223416f, 
    0.02410115f, -0.46737325f, 0.18102828f, -0.31855699f, -0.41273463f, 0.24852164f, -0.17563215f, -0.24088745f, 
    -0.33517471f, 0.09363285f, -0.01001645f, -0.04366147f, -0.12777278f, 0.05138200f, 0.10641257f, 0.33813190f, 
    -0.03209503f, 0.02184794f, -0.06808409f, 0.12368835f, -0.21316728f, -0.31982046f, -0.25750211f, 0.20482196f, 
    0.19586520f, -0.07694556f, 0.06990546f, 0.43068007f, 0.02526329f, 0.01316679f, 0.07808094f, 0.03926772f, 
    -0.07991369f, 0.04380672f, -0.04216745f, 0.17122146f, 0.19737826f, 0.15840913f, -0.08852752f, 0.31690940f, 
    -0.32089981f, 0.00748499f, -0.30674973f, -0.61427546f, -0.22293137f, 0.10667541f, 0.05080652f, 0.12712537f, 
    -0.00916276f, -0.34552962f, -0.01723979f, 0.30265960f, -0.15996452f, 0.26511133f, 0.08039802f, -0.14781454f, 
    -0.36666843f, -0.33695370f, 0.30125710f, 0.15471470f, -0.11652526f, 0.08260600f, 0.37993965f, 0.27909791f, 
    -0.43574247f, -0.34189758f, -0.67182148f, 0.08308239f, -0.37980711f, -0.71790063f, -0.38225561f, -0.42285833f, 
    0.11332086f, 0.16820098f, 0.17276351f, 0.31146291f, 0.34012827f, -0.08274183f, -0.20781811f, -0.32487926f, 
    -0.11329121f, 0.05233907f, 0.03500651f, -0.52744067f, -0.04015507f, -0.23089926f, -0.13960110f, 0.18883021f, 
    0.00704006f, -0.02104962f, -0.26850691f, -0.50652063f, 0.31864992f, 0.09955486f, 0.29473385f, -0.28272352f, 
    -0.12130507f, -0.16457322f, -0.43516561f, 0.12334310f, 0.21707095f, 0.27056020f, -0.46009180f, -0.07157987f, 
    0.20653874f, -0.15627661f, 0.25659856f, 0.20254198f, 0.34778729f, -0.06924371f, -0.09143122f, -0.43487471f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    0.01540318f, -0.16367590f, -0.11394493f, -0.00662635f, 0.02423982f, 0.08909436f, 0.02036874f, 0.05822830f, 
    -0.08379841f, -0.08677344f, 0.14273801f, -0.07022902f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
