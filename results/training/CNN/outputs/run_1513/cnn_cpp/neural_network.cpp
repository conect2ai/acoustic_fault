#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.17521898f, 1.02188838f, 0.38979933f, 0.44301921f, 0.05679541f, 0.11468987f, 0.53403139f, 0.60732079f, 
    0.39303622f, -1.97386217f, -1.40606880f, -1.80978000f, 0.37545222f, 0.63329393f, 0.14017496f, 0.26277721f, 
    0.38101393f, -0.28617442f, -0.40668342f, -0.57821167f, -0.76043540f, -0.23882155f, 1.71451354f, -1.57236254f, 
    -0.46873617f, -0.44881067f, -0.18652892f, -0.01822033f, -0.76728874f, -0.73278058f, -1.46234000f, -0.83783340f, 
    -0.72585726f, -0.27380440f, -0.50689846f, 0.42462942f, -0.07328377f, 0.65491831f, -0.05837744f, 0.66210085f, 
    0.82517356f, 0.21476184f, -0.16867293f, 1.06140268f, -0.69689757f, -0.98417282f, 0.84054887f, 0.19227280f, 
    -1.02003253f, -1.07371831f, -0.73994720f, -0.01983519f, -0.50807369f, -1.09709787f, 0.04666218f, 0.11451858f, 
    0.05457236f, 0.09561127f, 0.31522608f, 0.03134901f, 0.30476543f, 0.32703653f, -0.98638719f, -0.59250534f, 
    -0.29921329f, -0.02409798f, -1.08034980f, -1.10788870f, -1.10288239f, 0.78744769f, -0.13518980f, 0.76760972f, 
    0.54776621f, 0.14993180f, -0.05896450f, 1.19277573f, -0.76166475f, -0.81372815f, -0.14551584f, -0.20377868f, 
    -0.08006956f, -0.36041778f, -0.35999706f, 1.22034824f, 1.46732450f, -1.31934845f, -0.50774908f, -0.05850065f, 
    0.18595868f, -0.17577310f, 0.01770502f, 0.22687717f, 0.34033880f, -0.24705695f, -0.25533837f, 0.60150743f, 
    -0.34907159f, -0.31060544f, 1.27366590f, 0.94642895f, 0.25612882f, -0.52022123f, -1.26343727f, -0.24021347f, 
    -1.15814245f, 0.54358047f, 0.57258296f, 0.93188393f, 0.88943058f, 0.08746686f, 1.10966706f, -1.19622481f, 
    -0.65943962f, 0.41483706f, 0.08892509f, 0.71484232f, -0.34256008f, -0.77544284f, 0.54652250f, 0.43297392f, 
    -0.52298337f, -0.46021143f, 1.24712539f, -0.17988737f, 0.29726478f, -0.39085498f, -0.94470900f, 0.30670747f, 
    0.00689758f, 0.75098419f, 1.29184163f, 0.93387359f, -0.32735625f, 0.13205542f, 0.21378934f, -0.05808520f, 
    0.98438847f, 0.69397616f, 0.22075309f, -0.53528804f, -0.03163638f, 0.17398416f, -0.78255403f, -0.30124864f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.26952279f, 0.72698122f, 0.00763861f, -0.00414223f, 0.12596415f, -0.02716598f, 1.22636807f, 0.16433583f, 
    0.83417737f, -0.29455388f, 0.26941308f, 0.27066445f, 0.01961858f, 0.88114756f, 0.52010435f, 0.82275486f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.30508566f, 0.14153360f, 0.24316300f, 0.41054747f, -0.07065533f, -0.10544867f, 0.16374852f, 0.19746435f, 
    0.14077756f, 0.37913859f, 0.25832054f, 0.25106329f, -0.15253124f, -0.16654320f, -0.02503951f, 0.20463365f, 
    -0.08030546f, 0.03813750f, 0.27440545f, 0.43157712f, 0.23419444f, -0.08602029f, 0.00270296f, -0.17284867f, 
    -0.10306711f, -0.42595032f, 0.05651350f, 0.16824520f, 0.86031628f, 0.47061029f, 0.05221320f, 0.03542014f, 
    0.18266448f, 0.18788072f, -0.11745135f, -0.11454353f, 0.16975570f, -0.03315155f, 0.00629307f, -0.00874027f, 
    0.29479176f, 0.09170316f, -0.05432440f, -0.14795060f, -0.06151658f, 0.21025205f, -0.13576768f, 0.47915187f, 
    0.21193054f, 0.20033427f, -0.06935599f, -0.06167819f, -0.13450436f, -0.30522299f, -0.00929019f, 0.06825025f, 
    0.01160496f, 0.07654289f, -0.15548825f, 0.17555569f, -0.28209922f, -0.27005190f, -0.15573035f, 0.43287057f, 
    0.45465472f, 0.69989836f, -0.11669642f, 0.03369163f, -0.06766468f, 0.14167075f, 0.06842086f, 0.18604839f, 
    -0.08495037f, -0.31252444f, -0.18966056f, 0.14648339f, 0.06985369f, -0.01208046f, -0.04887661f, -0.32593673f, 
    -0.18883570f, -0.69783419f, -0.55659044f, -0.02333962f, -0.01553464f, 0.25213212f, -0.11782261f, 0.23536853f, 
    0.26527286f, -0.20628253f, 0.07155286f, -0.14451900f, -0.09644563f, 0.03856434f, 0.17739961f, -0.24622892f, 
    0.23642561f, -0.12163579f, 0.37917373f, -0.38654053f, -0.51150739f, -0.30351940f, 0.06787248f, 0.04514784f, 
    0.21856809f, 0.08570068f, 0.17085516f, 0.36631638f, -0.57653630f, -0.37181583f, -0.19507131f, 0.29014528f, 
    0.05773219f, 0.19781852f, -0.14959009f, 0.35010844f, 0.09856938f, -0.41507143f, 0.21153568f, 0.23885308f, 
    -0.07715216f, -0.07040201f, -0.11930975f, -0.26768631f, -0.19017626f, 0.21451871f, 0.06501801f, -0.00745345f, 
    0.22784297f, 0.18189590f, 0.26141432f, 0.02103212f, -0.04086893f, -0.12368611f, -0.08836684f, -0.16999693f, 
    -0.73609281f, 0.14826816f, 0.19238666f, -0.05593476f, -0.04453876f, -0.35359970f, -0.38322759f, -0.05034542f, 
    -0.01511512f, -0.03933825f, 0.06323374f, -0.08663260f, -0.18132780f, -0.29706600f, 0.18427892f, -0.05854521f, 
    -0.07177254f, -0.39227811f, -0.91427600f, -0.92322820f, -0.20651972f, -0.06113581f, -0.15245394f, 0.04674881f, 
    -0.09534217f, -0.06967066f, -0.22053306f, -0.47003374f, -1.46736407f, -0.10600074f, -0.11130467f, -0.47310591f, 
    -0.10789118f, -0.16445069f, 0.00617263f, -0.27997127f, 0.05699627f, -0.33414078f, -0.06162964f, -0.22526848f, 
    -0.32469001f, -0.18945533f, 0.04360818f, 0.13654125f, 0.10251882f, 0.11425550f, 0.09048495f, -0.21432349f, 
    -0.12708093f, -0.19915305f, -0.07035118f, -0.04900130f, -0.15894984f, 0.01494860f, 0.37761083f, 0.13663946f, 
    -0.07481597f, 0.02657468f, -0.10485366f, 0.00585442f, 0.05480215f, 0.22855902f, 0.21067685f, 0.29285422f, 
    0.16965298f, 0.21391833f, 0.24498791f, 0.06551071f, 0.05858051f, 0.19357710f, 0.11140288f, 0.37691566f, 
    0.62786674f, -0.59475863f, 0.06462090f, 0.07047563f, -0.14270402f, -0.10951837f, -0.02650293f, -0.05091588f, 
    0.39784062f, -0.08797510f, 0.25147694f, 0.13369443f, 0.42092648f, 0.16692138f, 0.39441574f, 0.19465958f, 
    -0.00952858f, 0.14993000f, -0.44538355f, 0.11420769f, -0.08791365f, 0.09481260f, -0.18161507f, 0.10704853f, 
    -0.49250391f, -0.30249280f, 0.17036441f, 0.07072282f, 0.20530765f, 0.00898216f, -0.11082876f, -0.18348090f, 
    -0.00760255f, 0.06167955f, -0.27074584f, -0.33365521f, -0.12428564f, -0.28862786f, 0.10816669f, -0.10580235f, 
    -0.05742220f, 0.05079175f, -0.11505800f, -0.15228346f, 0.10104150f, 0.36067632f, 0.55726486f, 0.04473737f, 
    -0.13788058f, -0.03285637f, 0.15747885f, -0.16885321f, -0.05529368f, -0.01099590f, 0.09746097f, 0.34270290f, 
    0.17936347f, 0.09412373f, 0.19182056f, 0.33648670f, -0.01259618f, 0.13874993f, 0.11391895f, -0.02855845f, 
    0.14734574f, -0.24333534f, -0.09667151f, -0.17539261f, -0.07002886f, -0.13838987f, -0.05728126f, 0.42283812f, 
    0.30068564f, 0.25022292f, -0.03769303f, 0.02581357f, -0.01205490f, 0.02828136f, 0.14546052f, 0.02282471f, 
    -0.08498207f, 0.05476713f, 0.01615492f, -0.01942470f, -0.03987430f, -0.06180704f, 0.01162922f, 0.06584226f, 
    -0.05802352f, -0.06299570f, -0.04571274f, 0.05339309f, 0.03692216f, -0.07677257f, -0.03659938f, 0.03237213f, 
    -0.05674128f, -0.09085533f, -0.08161455f, 0.01864050f, 0.01807382f, 0.05513952f, -0.06978277f, -0.06012443f, 
    -0.01807221f, 0.01637408f, 0.01315874f, -0.07191289f, -0.04481046f, 0.03770998f, 0.05644645f, 0.02616184f, 
    -0.08288432f, -0.00320814f, 0.04346775f, -0.05430336f, 0.04185734f, -0.00484437f, -0.00259613f, -0.04476784f, 
    -0.04061419f, -0.01217062f, -0.01047651f, -0.02884171f, -0.04675299f, 0.04201660f, -0.00257876f, 0.02800556f, 
    0.02274692f, -0.07274193f, -0.06728890f, 0.06325459f, -0.07905766f, -0.08790909f, 0.07042747f, 0.03823133f, 
    -0.02333109f, -0.04664344f, -0.05134755f, 0.01180194f, -0.08978973f, 0.00381608f, -0.07268274f, 0.01946429f, 
    0.06635030f, 0.03687021f, 0.05940132f, 0.03435810f, -0.03472469f, -0.04861867f, -0.00440462f, -0.06357739f, 
    0.05622901f, -0.06205399f, 0.07019465f, 0.02280121f, 0.06889919f, -0.03026925f, -0.04570483f, 0.06136237f, 
    -0.00513079f, -0.07016828f, -0.05562535f, -0.05653287f, -0.06216222f, -0.01555838f, 0.04245741f, 0.06484659f, 
    0.05089815f, -0.07728100f, 0.02772056f, 0.06202074f, 0.06600706f, -0.01872886f, 0.03884725f, 0.05046521f, 
    -0.02699153f, 0.00651188f, 0.01271481f, -0.03864101f, 0.04541608f, -0.03904947f, -0.08032362f, -0.01315461f, 
    0.01407378f, 0.03761075f, 0.04762975f, -0.03601017f, -0.00862320f, 0.04077775f, 0.06898730f, -0.06999322f, 
    -0.05211129f, -0.00146357f, -0.01610769f, 0.05339138f, -0.02072415f, -0.01096075f, -0.03708326f, -0.00355476f, 
    -0.05247087f, 0.00000212f, 0.03016056f, 0.01227752f, -0.07353467f, 0.05072811f, 0.06063302f, -0.04941902f, 
    0.02667013f, -0.06456282f, -0.08445225f, -0.07818723f, -0.09462676f, -0.04389126f, -0.00737856f, -0.04112816f, 
    -0.07054620f, -0.07856698f, -0.06102731f, -0.06836945f, -0.05105804f, 0.04413088f, 0.03068713f, 0.05522615f, 
    -0.03689343f, -0.06285138f, 0.02880510f, -0.05894355f, -0.05089637f, 0.06429622f, 0.04489865f, -0.01485737f, 
    0.07090418f, 0.03448784f, -0.04391477f, -0.03509931f, 0.03431385f, -0.02167229f, -0.00081587f, -0.00211168f, 
    -0.00984749f, 0.05735510f, 0.02533596f, -0.03521617f, -0.05501835f, 0.04444319f, 0.06604896f, -0.01844457f, 
    -0.06902306f, 0.04506458f, -0.04287127f, -0.05035975f, -0.05463178f, 0.03606302f, -0.07060596f, -0.03212558f, 
    0.02624421f, -0.03210180f, -0.06668971f, -0.09138224f, -0.03216516f, -0.05767277f, -0.02729290f, 0.03771126f, 
    -0.02665247f, 0.01455349f, -0.01521210f, -0.05062251f, -0.03267320f, -0.06779039f, 0.02163100f, -0.05468486f, 
    0.00250812f, 0.03172287f, 0.02996841f, 0.03570503f, -0.00496539f, -0.06647295f, -0.02739717f, 0.03893495f, 
    0.03509144f, 0.00299691f, -0.05705721f, -0.03714043f, -0.05642185f, -0.07562125f, -0.04867939f, 0.04748036f, 
    0.00090197f, -0.04396294f, -0.02616637f, 0.01023920f, -0.09335620f, 0.01142132f, 0.04165675f, -0.09744384f, 
    -0.06039987f, -0.05635099f, -0.02107083f, -0.01194731f, 0.03853479f, -0.01060584f, -0.03628828f, -0.01304805f, 
    0.03076122f, 0.05666959f, 0.04248048f, 0.00523596f, 0.01001751f, -0.01216398f, -0.07129366f, 0.04137644f, 
    0.06057129f, 0.06902196f, 0.01521245f, 0.05278780f, 0.03316547f, 0.00379466f, 0.00479757f, 0.06702450f, 
    0.01339193f, -0.05749477f, -0.02171999f, 0.06933370f, 0.03399500f, 0.04209072f, -0.08592335f, -0.02456186f, 
    0.03556452f, 0.07403652f, -0.04196131f, 0.02104600f, 0.08092943f, 0.02011193f, -0.00313445f, -0.04270204f, 
    -0.02923814f, -0.04909623f, 0.06633667f, -0.07674874f, -0.08668739f, -0.06409537f, -0.01362925f, -0.02710574f, 
    0.05802355f, -0.04256076f, -0.08033418f, 0.05500362f, 0.03729946f, 0.00547255f, 0.01057151f, -0.04939493f, 
    -0.03648610f, -0.07986274f, -0.03344614f, 0.06243306f, -0.00351246f, -0.02937278f, 0.02015601f, -0.07658209f, 
    -0.07828326f, -0.07738894f, -0.02859012f, 0.00312447f, -0.04067031f, -0.02239348f, -0.01202782f, -0.02282231f, 
    0.00219501f, 0.01258918f, 0.00886695f, -0.37502995f, -0.08415217f, 0.01469204f, 0.12485971f, -0.03065684f, 
    -0.14400457f, -0.23610891f, 0.04166483f, -0.24414781f, -0.14419575f, 0.17341733f, 0.43090618f, -0.00931712f, 
    -0.12573229f, 0.05709921f, -0.56618625f, -0.35858786f, -0.53412610f, -0.34429681f, 0.28216732f, 0.00962102f, 
    0.25148991f, -0.17185855f, -0.20692354f, 0.20279421f, -0.41387862f, -0.23180388f, 0.18028313f, 0.12969069f, 
    0.15682645f, -0.04456220f, -0.06737305f, -0.02841058f, -0.32956192f, 0.01030596f, 0.13088934f, -0.03591020f, 
    0.22093457f, 0.19565186f, 0.15056288f, 0.13171998f, 0.03847275f, 0.41307530f, -0.01103747f, -0.06448573f, 
    -0.20482284f, -0.85025311f, -0.12670103f, 0.13994163f, 0.06873029f, 0.14796080f, -0.09198409f, 0.07206219f, 
    0.18568847f, 0.27293101f, 0.04413831f, 0.27501541f, -0.00151269f, 0.27952239f, 0.17404346f, -0.21080302f, 
    -0.75172192f, -0.10897174f, 0.14253028f, 0.12455823f, -0.25597358f, -0.07396606f, -0.09317230f, -0.06574149f, 
    -0.95933288f, -0.21730378f, 0.22599415f, -0.00170136f, 0.03828808f, 0.17884555f, 0.19059806f, 0.02966080f, 
    0.14479543f, -0.70241320f, -1.00198328f, -0.37010217f, -0.43466952f, -0.43049508f, -0.11045563f, 0.11768205f, 
    0.12782443f, -0.12956926f, 0.10736159f, 0.11418382f, 0.17189246f, -0.07551932f, 0.20691387f, 0.08053877f, 
    -0.07258431f, -0.14555527f, -0.00185243f, 0.32254189f, -0.20789115f, -0.43232930f, -0.04698934f, 0.08523457f, 
    -0.02990809f, 0.19196340f, 0.00527334f, -0.13660391f, 0.63510442f, 0.28110889f, -0.67293453f, -0.05421052f, 
    -0.01493193f, 0.02331827f, -0.08704630f, -0.05682104f, -0.04905063f, 0.60668516f, 0.11667412f, -0.01477174f, 
    0.11124326f, 0.19338402f, 0.31408834f, 0.14781925f, -0.13895799f, 0.01432118f, -0.38552818f, -0.11706322f, 
    0.29389572f, -0.01928282f, 0.30574286f, 0.10911424f, -0.05137600f, 0.14490648f, 0.07554889f, 0.01828619f, 
    0.36527190f, 0.37162748f, 0.19666977f, -0.17603587f, 0.09746663f, -0.08575365f, -0.04460161f, 0.12046342f, 
    0.27523988f, -0.21234523f, 0.00798188f, -0.17038484f, -0.22001979f, 0.17003605f, -0.03529372f, 0.01246883f, 
    -0.05692701f, -1.06497204f, 0.69294637f, 0.63349885f, 0.05389167f, 0.03194094f, 0.00415698f, 0.02937235f, 
    0.02174686f, 0.08356892f, -0.97998708f, 0.04935007f, -0.52507132f, -0.26999992f, -0.01963224f, 0.00897424f, 
    -0.10996687f, 0.05258416f, 0.08298372f, 0.20101599f, -0.17530541f, 0.17352819f, -0.37129539f, 0.10345285f, 
    -0.23444003f, 0.03053414f, -0.03739491f, -0.09537078f, 0.21917038f, 0.08885032f, 0.04745043f, -0.37976426f, 
    -0.52888644f, -0.37187025f, 0.12255625f, 0.02751013f, 0.22932288f, 0.15208222f, -0.16985455f, 0.55195707f, 
    -0.22520304f, 0.13350295f, 0.00710832f, 0.00796182f, 0.02830910f, 0.23988678f, 0.18183604f, 0.24872456f, 
    -0.08090815f, 0.17164488f, 0.10006987f, -0.23697467f, 0.22381215f, 0.29190010f, 0.25172535f, 0.22214213f, 
    -0.09537525f, 0.40867263f, -0.11079865f, -0.09948500f, -0.27704731f, 0.16689256f, 0.01461750f, -0.02321708f, 
    -0.09970369f, 0.40189761f, 0.41647044f, -0.10497720f, 0.13563187f, -0.03563172f, 0.20288657f, 0.11300711f, 
    0.09696487f, -0.33652496f, 0.13555090f, 0.00760091f, -0.16106984f, -0.15818274f, -0.25703397f, 0.08875173f, 
    -0.06782600f, -0.18904053f, 0.28472042f, -0.27448228f, -0.07127529f, -0.19975713f, -0.30474681f, -0.09334975f, 
    -0.05712179f, 0.24759288f, -0.17052259f, 0.37850416f, 0.39597774f, 0.09487402f, 0.06195313f, -0.05084713f, 
    0.00039086f, 0.01162117f, -0.12265395f, -0.11902678f, -0.65208662f, -0.95883149f, 0.28361401f, 0.01470171f, 
    0.06281056f, -0.16065200f, -0.10666355f, -0.13080588f, -0.39881533f, 0.41151389f, -0.21914633f, -0.13899846f, 
    -0.11811700f, 0.12003408f, -0.44632864f, 0.07316044f, 0.02494975f, 0.01878767f, 0.35357183f, -0.02947243f, 
    0.20137601f, -0.43028551f, -0.50203133f, -0.56074309f, -0.04919598f, 0.18342310f, 0.12810867f, 0.26008439f, 
    0.14028430f, 0.09115133f, 0.11223885f, 0.32410786f, -0.12231423f, 0.27309775f, 0.41428703f, 0.17105548f, 
    0.16155370f, -0.03206904f, 0.03994313f, 0.00438295f, 0.07849569f, -0.12688829f, 0.42806649f, -0.01242296f, 
    -0.09185052f, 0.34643382f, -0.22987098f, 0.30639097f, 0.09907103f, -0.05031066f, 0.02946261f, 0.15492441f, 
    -0.05796218f, 0.12129431f, -0.12766522f, 0.12836170f, 0.10323302f, -0.15981348f, -0.33373606f, -0.44457218f, 
    -0.03379725f, -0.00262057f, -0.05287544f, -0.07092769f, 0.46734822f, 0.22915213f, -0.12714311f, -0.34060183f, 
    -0.08464243f, 0.04621206f, 0.01906543f, -0.04750732f, 0.10785852f, 0.26061243f, 0.01791298f, -0.55032504f, 
    -0.20466979f, -0.11076655f, 0.04263734f, 0.16590473f, -0.04017112f, -0.03132447f, -0.04888595f, -0.06104865f, 
    0.07578045f, -0.08994209f, -0.05163426f, 0.09585292f, 0.04234020f, 0.18113755f, 0.17624110f, 0.06182813f, 
    0.11520922f, -0.04392406f, 0.08415180f, 0.08684584f, 0.24258046f, 0.13104863f, 0.11578275f, 0.42315856f, 
    0.49428287f, 0.28754741f, 0.11423276f, -0.27788600f, -0.12190847f, -0.04835844f, -0.04298266f, 0.01504141f, 
    -0.23458014f, -0.46825117f, 0.26150927f, 0.03960731f, -0.00232994f, -0.11370735f, 0.09136212f, -0.06538767f, 
    0.14844319f, -0.64825541f, -1.31968451f, -0.01375233f, -0.71368271f, 0.19618811f, -0.23030286f, -0.15067020f, 
    0.01067748f, -0.13296914f, -0.48827705f, 0.07567069f, -0.09327317f, -0.01459196f, -0.19020751f, -0.21550089f, 
    -0.18891875f, 0.09809393f, -0.15175317f, 0.33236629f, 0.35384348f, 0.39272335f, 0.05561092f, -0.04591449f, 
    0.07935688f, -0.09924544f, 0.02014551f, -0.12970605f, -0.72285599f, 0.25898293f, -0.08135956f, -0.32413545f, 
    0.30527002f, 0.07197684f, 0.12403789f, 0.04952133f, -0.05653645f, -0.67563415f, 0.29421565f, -0.33091560f, 
    -0.05868445f, -0.08822094f, -0.06687561f, 0.06428574f, 0.36016724f, 0.35654384f, 0.18224916f, 0.39176273f, 
    0.09043322f, -0.36062565f, -0.09163036f, -0.34433323f, 0.08979074f, 0.05776583f, 0.22678359f, -0.35839751f, 
    -0.16016342f, 0.17821829f, -0.05181785f, 0.02040927f, 0.08725471f, -0.00860952f, -0.22488263f, 0.03806523f, 
    -0.05720207f, 0.22146881f, -0.15723377f, -0.38787299f, -0.02736004f, -0.06130071f, -0.05804503f, -0.25092015f, 
    -0.07701989f, 0.75093466f, -0.92718339f, -0.60156268f, 0.19679511f, 0.03932748f, -0.03572347f, -0.03993273f, 
    0.14544268f, -0.02809753f, 0.02937096f, -0.33935559f, 0.44557485f, -0.07046429f, -0.07835042f, 0.07380264f, 
    -0.04934146f, 0.22648972f, 0.44605124f, 0.16346747f, -0.11925845f, 0.12415235f, -0.00917957f, -0.27041727f, 
    0.06188496f, -0.12888919f, -0.03773575f, 0.00038033f, -0.18271893f, 0.18903930f, -0.01996386f, -0.15179341f, 
    0.06214595f, -0.04462155f, 0.09767441f, 0.08146864f, 0.01410171f, 0.52106816f, 0.09397458f, 0.03286692f, 
    -0.19556193f, 0.01006240f, -0.15185350f, 0.20302877f, 0.05222470f, 0.12232844f, -0.13149485f, 0.07124154f, 
    -0.01403816f, -0.16198029f, 0.20851870f, -0.12476678f, 0.09115008f, 0.33535355f, 0.11594591f, 0.04154712f, 
    -0.38358280f, 0.21232906f, -0.16679011f, -0.05578732f, -0.35550743f, 0.10340694f, -0.11502131f, -0.11922453f, 
    -0.24941507f, 0.00170503f, 0.58794475f, -0.01090734f, -0.04649692f, -0.05220542f, 0.00531798f, 0.04605875f, 
    -0.02249058f, -0.14152181f, 0.19862784f, 0.11313727f, -0.20936367f, 0.09816340f, -0.00404756f, 0.19910370f, 
    0.17570472f, -0.24264327f, -0.14121288f, 0.19505279f, -0.16711099f, -0.05923502f, 0.04429822f, 0.01783923f, 
    -0.06463669f, -0.21614705f, -0.12563023f, -0.28198868f, -0.21952686f, 0.26724201f, -0.05884904f, 0.33935371f, 
    -0.09815603f, 0.05658393f, 0.05880290f, -0.07417826f, 0.01964552f, 0.40542096f, 0.17284052f, 0.03791397f, 
    0.18040667f, 0.28267276f, 0.29208711f, -0.01375663f, -0.15885207f, 0.30001959f, 0.28296712f, -0.08530071f, 
    -0.25516972f, 0.06973772f, 0.12592253f, -0.03130778f, 0.05057438f, 0.10034749f, -0.06134617f, 0.16281837f, 
    -0.30539995f, -0.10375834f, -0.18770275f, -0.06582413f, 0.07900465f, -0.03023269f, 0.12935917f, 0.00996912f, 
    0.19068143f, 0.27994412f, -0.12910876f, 0.07226630f, -0.03147690f, 0.24574532f, -0.04194536f, -0.03371586f, 
    -0.43012446f, -0.19793679f, -0.38992164f, -0.17641276f, -0.01799759f, -0.14039305f, 0.21926793f, 0.33896571f, 
    0.00110988f, -0.22678912f, -0.03610560f, 0.40874997f, -0.06783634f, -0.06438204f, -0.07755175f, -0.13941525f, 
    0.02931260f, -0.01819627f, -0.54235703f, -0.28298831f, -0.06097029f, -0.11512498f, -0.21107318f, -0.23073311f, 
    -0.08816871f, -0.05975850f, 0.24694172f, -0.07857896f, -0.35768548f, 0.02039801f, 0.07683150f, 0.00204271f, 
    -0.18742323f, 0.19135337f, -0.00605282f, 0.20002809f, -0.07001480f, 0.02697122f, -0.17287001f, 0.21936208f, 
    0.21071824f, 0.10070450f, 0.32050940f, 0.26344860f, 0.25894147f, -0.67683554f, -0.28641579f, -0.20364860f, 
    0.08685690f, 0.02190250f, 0.16335247f, -0.09093069f, -0.03624272f, 0.09284631f, 0.39086324f, 0.13412972f, 
    0.03678332f, 0.42769232f, 0.26261112f, 0.31638902f, 0.42415866f, 0.31332171f, 0.59567851f, -0.16224432f, 
    -0.25771865f, -0.23992664f, 0.25103140f, 0.01412777f, 0.05652677f, 0.16144353f, 0.19143546f, 0.12173258f, 
    -0.04272933f, -0.00849534f, 0.18421407f, 0.30628553f, 0.15291342f, -0.17971350f, 0.44741210f, 0.32957599f, 
    0.16472948f, -0.67409503f, -0.24665615f, -0.18812333f, 0.31181547f, 0.00992722f, -0.27724874f, 0.49016055f, 
    -0.17712496f, 0.05818510f, 0.07968149f, -0.15340728f, 0.38359827f, -0.02332200f, -0.00361787f, -0.09891891f, 
    0.42627391f, 0.28338954f, 0.31388539f, 0.29746202f, 0.17245460f, -0.29909128f, -0.00119294f, 0.10610085f, 
    0.12877683f, 0.41290885f, 0.30858696f, 0.13994321f, -0.50102198f, -0.18010063f, -0.51207298f, -0.04533892f, 
    0.06623900f, 0.08916726f, 0.05119835f, -0.15401176f, 0.24285150f, -0.04587373f, -0.05229605f, -0.05352134f, 
    0.22014531f, 0.21037632f, 0.06062356f, 0.50579196f, 0.41891512f, 0.66573280f, 0.15353702f, 0.17022391f, 
    -0.06062411f, 0.06901456f, -0.09483410f, 0.14583613f, 0.15373644f, 0.07429830f, 0.22991471f, -0.13365078f, 
    0.05114496f, 0.15758465f, -0.02507100f, 0.00053018f, 0.28284687f, 0.10581598f, 0.07059515f, 0.23323162f, 
    -0.09517615f, 0.04892264f, 0.32255796f, 0.00098083f, -0.01067384f, -0.23483075f, 0.28604957f, 0.00589411f, 
    0.18489997f, 0.66876185f, 0.07406153f, 0.03295005f, -0.32525247f, -0.34093577f, 0.00577706f, 0.08461857f, 
    0.04558458f, -0.00096663f, -0.88346267f, -0.60643929f, 0.06659307f, 0.14527579f, -0.22948010f, -0.05382581f, 
    -0.12580238f, -0.16965216f, -0.12358122f, -0.51586914f, -0.06165246f, -0.74665898f, -0.07304068f, -0.00866443f, 
    -0.03607914f, 0.04039347f, -0.11050996f, 0.06180571f, 0.29214984f, 0.12965274f, 0.19410206f, -0.31859466f, 
    -0.19115061f, -0.44717181f, 0.23267944f, -0.13543387f, -0.06687978f, -0.10618907f, -0.06708056f, -0.16020918f, 
    0.20070879f, 0.04811490f, -0.21359253f, -0.25680086f, -0.04483870f, 0.01156742f, 0.17616895f, 0.12376994f, 
    0.21888907f, -0.11544987f, 0.18469559f, 0.02735594f, 0.12993008f, 0.08569992f, -0.00325167f, -0.29909614f, 
    -0.51746690f, -0.07014178f, 0.14563759f, -0.03771109f, 0.17033780f, -0.03103122f, -0.02825982f, -0.07981734f, 
    0.06324352f, -0.38467708f, 0.08042680f, 0.00401537f, -0.02611122f, 0.04920618f, 0.05070430f, -0.02118741f, 
    0.00460596f, 0.12513162f, 0.26708370f, 0.29538035f, 0.05330780f, 0.28028944f, -0.35386878f, 0.31341261f, 
    0.15639447f, 0.10570136f, -0.31073293f, -0.06506090f, -0.30501717f, -0.41826403f, 0.31149447f, 0.07211695f, 
    -0.27718890f, 0.05399382f, 0.36476249f, -0.66565818f, -0.49281475f, 0.55145460f, 0.33974248f, 0.12663256f, 
    0.06502537f, 0.23334929f, -0.09782088f, 0.16526477f, -0.30098343f, -0.74726677f, -0.27667454f, 0.10942335f, 
    0.14633198f, 0.14323951f, 0.05818234f, 0.31023151f, 0.10085627f, 0.01356457f, 0.06314489f, 0.01503212f, 
    -0.04060348f, 0.20739540f, -0.14753659f, 0.03171714f, 0.26667762f, 0.21559076f, 0.25402939f, 0.19792645f, 
    -0.16578630f, -0.30650434f, -0.05657915f, -0.24608739f, 0.22592448f, -0.06127177f, 0.01398795f, -0.05895310f, 
    0.20265540f, 0.28007472f, 0.06064528f, 0.04793317f, -0.02218705f, 0.04644998f, 0.10896461f, 0.19401725f, 
    0.25798455f, -0.23069148f, -0.01842053f, -0.05690036f, -0.08090972f, 0.18650404f, -0.24910428f, -0.10500027f, 
    -0.27811888f, -0.75667793f, 0.28984106f, 0.43025637f, 0.04264989f, 0.10788050f, -0.19042130f, -0.00787655f, 
    -0.03817874f, -0.01942449f, -0.04892768f, -0.33202040f, 0.34600291f, 0.09983529f, 0.04914922f, -0.18368846f, 
    -0.28397259f, -0.22864875f, 0.06799764f, -0.09720761f, 0.03250644f, -0.53026044f, 0.05188817f, -0.13230339f, 
    -0.11886068f, 0.23705718f, -0.02412399f, -0.21129534f, -0.12343448f, -0.09539520f, 0.17140421f, 0.08386543f, 
    0.01299158f, -0.25545940f, -0.00802171f, -0.03505435f, -0.02865637f, -0.45885074f, -0.41276872f, -0.56250018f, 
    -0.00992440f, 0.16342807f, 0.39147875f, 0.07739307f, -0.01256410f, -0.07310091f, 0.20950063f, 0.19379766f, 
    0.15968204f, 0.11230591f, -0.04185356f, -0.02592086f, 0.00167012f, 0.28829911f, 0.26020163f, -0.89266735f, 
    0.32493952f, -0.04603823f, -0.13856764f, -0.03595087f, -0.26488939f, 0.11322405f, 0.09863830f, -0.06831514f, 
    -0.03319333f, 0.04794852f, 0.08473063f, -0.11977588f, 0.16662274f, 0.12896124f, 0.20674928f, 0.36693493f, 
    0.21913083f, -1.06072176f, -0.35993800f, 0.41584423f, 0.18942812f, 0.17839338f, -0.11536416f, 0.20930886f, 
    0.13859208f, -0.11764668f, 0.11785407f, 0.42324907f, 0.07145876f, 0.15979902f, -0.02126893f, 0.23345307f, 
    0.13052413f, 0.03495176f, -0.24575019f, 0.49011749f, -0.00609457f, -0.85610229f, 0.14774293f, 0.09449951f, 
    0.09368677f, 0.16176242f, 0.05488304f, 0.07740395f, 0.91125464f, -0.67132419f, -0.10120601f, 0.01458034f, 
    0.29067418f, 0.17813329f, 0.06429870f, -0.01761798f, 0.20866580f, -0.05786068f, 0.10382262f, 0.04810936f, 
    -0.14708556f, -0.04825398f, 0.36921057f, 0.04610468f, 0.13495764f, 0.12466012f, -0.24883577f, -0.01721841f, 
    -0.24203640f, -0.09192922f, -0.07922762f, -0.06522816f, 0.07527523f, -0.01504386f, 0.20771566f, 0.07029258f, 
    -0.09355162f, 0.12755445f, -0.11952636f, 0.07577756f, 0.03991190f, 0.03634540f, 0.17923053f, 0.12547614f, 
    0.48132950f, 0.36920267f, -0.43987983f, -0.33825630f, -0.51952374f, 0.06033764f, -0.11898731f, -0.01071746f, 
    0.08036481f, 0.45658973f, -0.04290016f, -0.59177595f, 0.39563990f, 0.28271061f, 0.32810715f, 0.21262623f, 
    0.03091105f, -0.03302337f, 0.84147257f, -0.03809189f, -0.37260899f, 0.00954621f, 0.03345893f, 0.28994069f, 
    0.09300774f, -0.00658961f, -0.33033931f, 0.48573434f, 0.26750419f, 0.16612713f, 0.15363729f, -0.10547622f, 
    -0.18853141f, -0.05439034f, -0.23598628f, 0.05222619f, 0.12196288f, -0.18886578f, -0.72485965f, -0.20116253f, 
    -0.16416508f, -0.31657991f, 0.09596114f, 0.10308365f, 0.17327833f, -0.38848320f, 0.34116891f, 0.14273037f, 
    0.02705799f, -0.03485889f, -0.07638802f, 0.14157721f, 0.02563623f, 0.07609820f, -0.21910842f, -0.20775524f, 
    0.02771353f, 0.17043036f, 0.02490110f, -0.19860354f, 0.15077366f, -0.08129542f, 0.24045029f, 0.36160603f, 
    0.23109072f, 0.29950944f, -0.09499354f, -0.06437441f, -0.26434836f, -0.06398177f, 0.01996993f, 0.13434041f, 
    -0.17491943f, 0.11016987f, -0.80145234f, 0.11749705f, 0.05153285f, -0.25385904f, -0.04914219f, 0.20000374f, 
    0.42258582f, -0.42757639f, 0.04138799f, -0.44445533f, -0.23828349f, 0.00666143f, 0.09307668f, 0.27361876f, 
    -0.03710322f, 0.16090956f, -0.15367560f, -0.33197144f, 0.06920621f, 0.30302432f, 0.19105844f, -0.25634548f, 
    0.18632406f, 0.29549783f, -0.03860315f, 0.30939764f, 0.36180535f, -0.07321730f, -0.06025586f, -0.23295525f, 
    -0.02109648f, -0.05400077f, 0.06432858f, 0.09930866f, -0.27337575f, -0.88795382f, -0.12304503f, 0.05652839f, 
    -0.19496407f, -0.10173711f, -0.18934599f, 0.14774963f, 0.14348826f, -0.79480940f, -0.54113096f, 0.43749872f, 
    -0.01870432f, -0.29924375f, -0.08071029f, 0.11207059f, 0.06434379f, -0.05033992f, -0.12976515f, -0.13680817f, 
    -0.50475103f, 0.02425618f, -0.31799996f, -0.19252853f, 0.18365365f, 0.09376821f, 0.19615787f, -0.97899169f, 
    0.24705894f, -0.01356402f, -0.12489635f, 0.11608500f, 0.02168061f, 0.16963202f, 0.26733404f, 0.14311333f, 
    -0.09120879f, 0.07170303f, 0.01265263f, -0.06595509f, -0.05940666f, 0.08530629f, 0.02152593f, -0.01177974f, 
    -0.07800285f, 0.05740892f, 0.02648493f, 0.06204735f, -0.03671523f, -0.07395642f, 0.03982077f, -0.05322619f, 
    0.00717569f, -0.09710219f, 0.04634748f, -0.08688569f, 0.01552225f, 0.05928651f, 0.01281680f, -0.00945096f, 
    0.04479408f, -0.06085995f, -0.09262405f, -0.02911550f, 0.01300563f, 0.02605911f, 0.02608131f, 0.01050944f, 
    -0.06399521f, -0.03915261f, -0.01847037f, -0.05890406f, 0.01519646f, -0.02399397f, -0.02518472f, -0.08024903f, 
    0.04223773f, -0.06943862f, 0.02098398f, 0.04261493f, -0.04472071f, 0.03127684f, 0.00884704f, -0.08471968f, 
    0.06276751f, -0.03455799f, 0.05706040f, 0.04197134f, 0.03564815f, 0.04268729f, -0.06472322f, -0.07752925f, 
    0.05003674f, 0.06920072f, -0.05473722f, 0.03698509f, -0.00354611f, -0.05863829f, 0.01076768f, 0.04702174f, 
    0.06192167f, -0.04456552f, -0.06211588f, -0.04464423f, -0.08356516f, 0.03348812f, -0.00760572f, 0.05599687f, 
    0.02548373f, -0.04947630f, -0.00392105f, -0.02619724f, 0.04462227f, -0.08922567f, 0.03875348f, 0.06403749f, 
    -0.03112310f, 0.00773171f, 0.00204989f, -0.02416602f, 0.00572285f, -0.02627853f, 0.02112278f, -0.09220611f, 
    0.03997270f, -0.03470377f, -0.08904310f, -0.06954010f, 0.03532769f, -0.02827204f, 0.02134258f, -0.03748608f, 
    -0.07024699f, 0.06413050f, -0.01491352f, -0.02182257f, -0.06591214f, -0.09535769f, 0.00549407f, -0.00138769f, 
    0.06381837f, -0.04670512f, -0.06671654f, -0.07129719f, -0.07634402f, -0.08938524f, -0.05155645f, -0.06659680f, 
    -0.03345664f, 0.05530490f, -0.02453197f, -0.01186599f, -0.06704319f, 0.06744083f, 0.02485370f, 0.06549404f, 
    -0.02447793f, 0.02211748f, -0.08386558f, -0.00221279f, -0.05557064f, 0.01434974f, -0.02307393f, -0.00222934f, 
    -0.00243747f, 0.02779049f, 0.04975230f, -0.06354328f, -0.06509935f, 0.04082205f, -0.02082325f, 0.04781328f, 
    0.05158267f, -0.07432783f, -0.07315185f, -0.02204265f, 0.02884302f, -0.04299462f, -0.03555617f, -0.01079006f, 
    -0.45777640f, 0.36113942f, -0.29694656f, -0.43933171f, -0.27631456f, 0.06309312f, 0.04364523f, 0.20691541f, 
    -0.04840389f, -0.13633734f, 0.91512662f, 0.04665824f, 0.09081469f, 0.16688146f, 0.14536193f, -0.06503183f, 
    0.09178589f, 0.05876204f, -0.93749422f, 0.47889501f, 0.84956300f, 0.14238569f, 0.17468140f, 0.19138008f, 
    0.15104908f, -0.05998035f, -0.39059201f, -0.41096282f, -0.29548347f, 0.17384559f, -0.06749062f, 0.00817231f, 
    -0.27207577f, -0.02318618f, -0.14331737f, 0.16763382f, -0.14833649f, 0.03816915f, 0.15648016f, -0.35232511f, 
    -0.08430084f, -0.06334427f, -0.10172892f, -0.17072397f, 0.20592530f, -0.33865437f, 0.27423537f, -0.30984277f, 
    0.23027259f, -0.20783684f, -0.03634252f, 0.10503744f, 0.04658649f, -0.03666154f, 0.09434605f, 0.36777449f, 
    0.42133698f, 0.09274825f, 0.11339522f, 0.01469830f, 0.20646752f, -0.01811699f, 0.39389348f, -0.59837228f, 
    -0.16394179f, 0.02331602f, -0.10884207f, -0.19060637f, -0.22886382f, 0.14246771f, -0.02076574f, 0.15068094f, 
    0.47351950f, 0.24344522f, -0.26786816f, -0.12657501f, -0.08482290f, 0.01105047f, 0.16506489f, 0.12206766f, 
    -0.11391477f, -0.35101417f, -1.66415191f, -0.57602781f, -0.26264137f, -0.24216381f, -0.02922361f, 0.04824515f, 
    -0.15483175f, 0.15199417f, 0.23867051f, -0.09857216f, 0.26483208f, -0.30932534f, 0.01995056f, -0.38266146f, 
    -0.01746758f, 0.27970797f, -0.02068643f, -0.07125793f, -0.00779260f, -0.27981955f, 0.10957985f, 0.00583520f, 
    -0.39070526f, -0.08211355f, -0.02072078f, -0.11123203f, -0.33874908f, -0.35011423f, 0.48539838f, -0.15210693f, 
    -0.27998671f, -0.14402848f, -0.06764212f, -0.10340703f, 0.24373138f, -0.29270917f, -0.11550580f, 0.42704776f, 
    0.04167480f, 0.11760025f, 0.00045518f, 0.09710833f, 0.10799251f, 0.17863069f, -0.24434742f, -0.04623250f, 
    0.08800389f, -0.04556328f, -0.14867908f, 0.05284397f, 0.20670651f, 0.21927367f, -0.00247362f, 0.13302840f, 
    -0.08443779f, -0.69631290f, -0.06787059f, -0.24452862f, 0.07456947f, 0.18820617f, 0.20732126f, 0.19082834f, 
    0.23118977f, 0.25238371f, -0.11384101f, 0.17847934f, -0.07479443f, 0.22715780f, 0.04130221f, 0.11791547f, 
    -0.18192255f, 0.25808698f, -0.27401811f, -0.15922077f, 0.17664005f, -0.14023620f, 0.07943244f, 0.09401061f, 
    0.09867314f, -0.10331862f, -0.07905447f, -0.48036927f, 0.76942599f, -0.07590565f, 0.11462831f, 0.08267269f, 
    -0.08308301f, -0.15534574f, -0.19249852f, 0.26950300f, 0.54445696f, -0.38439065f, -0.42252702f, -0.12940033f, 
    -0.22557615f, 0.05770499f, 0.08093657f, 0.01173053f, 0.21195590f, -0.10737553f, -0.09880144f, 0.16612941f, 
    -0.11442828f, -0.02410036f, -0.21591406f, 0.12318404f, -0.04434656f, -0.43923768f, 0.06748003f, 0.15780108f, 
    -0.16599427f, -0.15921973f, 0.14566579f, 0.01303249f, 0.03991638f, -0.10813734f, 0.11132292f, -0.21382344f, 
    0.14525166f, 0.03990160f, -0.11341926f, -0.14238849f, -0.23502970f, 0.21982110f, 0.05533884f, -0.52386284f, 
    0.22947602f, 0.39983210f, -0.05384535f, -0.10651260f, -0.07642772f, 0.02096159f, 0.05267242f, 0.08790856f, 
    0.46303716f, 0.23819399f, 0.55264521f, 0.03359540f, -0.19287455f, 0.09709038f, 0.16194314f, 0.20280141f, 
    0.07032707f, -0.51528203f, 0.02406104f, 0.64104968f, -0.48242038f, 0.19353330f, -0.44871476f, -0.20481429f, 
    0.10350724f, -0.08851541f, -0.10596196f, 0.87969166f, -0.38061979f, 0.21704739f, -0.02759617f, 0.01614638f, 
    0.25588048f, 0.06396226f, 0.02900858f, -0.43216246f, -0.50279123f, -0.01538662f, 0.07084895f, 0.04415385f, 
    -0.05461401f, -0.02856362f, 0.02508222f, 0.13416311f, -0.18013319f, 0.46892893f, 0.57312131f, -0.21188906f, 
    -0.12424445f, -0.20826350f, 0.10888089f, -0.00675812f, 0.12854256f, -0.47016999f, 0.56657052f, -0.20448789f, 
    0.07208794f, -0.21202716f, 0.00011373f, -0.05937899f, 0.09963354f, 0.13182566f, -0.19358441f, -0.12531102f, 
    -0.19141038f, -0.01118108f, -0.15362251f, -0.21907488f, -0.05617646f, -0.05381343f, 0.11194900f, -0.09900014f, 
    0.43232870f, 0.05966833f, -0.07719520f, 0.08314596f, 0.05282822f, 0.32538164f, 0.18929417f, 0.12401806f, 
    -0.01325309f, 0.09407946f, 0.03000387f, 0.01114624f, -0.18431863f, -0.16282429f, 0.13962176f, -0.18406276f, 
    0.21344103f, 0.57807094f, -0.20251501f, -0.64853835f, -0.19184983f, 0.05124386f, -0.06339233f, 0.02522544f, 
    -0.10002436f, -0.05807542f, 0.18109162f, 0.05643659f, 0.20223369f, 0.22526492f, -0.05837741f, -0.12791574f, 
    -0.14988719f, -0.34743926f, -0.32437330f, 0.16025245f, -0.01190175f, -0.58781207f, -0.05066106f, -0.08219388f, 
    -0.06004876f, 0.01252052f, 0.09736067f, -0.10495963f, -0.18760815f, 0.07991136f, -0.07241764f, -0.18273047f, 
    -0.03544724f, -0.09398946f, 0.07223552f, -0.24286743f, 0.23749395f, 0.36749381f, -0.23584989f, -0.20224573f, 
    0.20897582f, 0.10564854f, 0.12646416f, -0.05461315f, -0.01872159f, -0.12839574f, -0.10031692f, 0.11255625f, 
    0.34004512f, 0.15509334f, 0.16750570f, 0.11821818f, -0.01902239f, 0.09900399f, 0.53331029f, 0.01284038f, 
    0.16136059f, 0.12827569f, -0.10088420f, -0.09501773f, 0.01841498f, -0.15997398f, 0.26018491f, 0.09640920f, 
    -0.54740238f, -0.12749009f, 0.17196909f, -0.09090129f, -0.08916651f, 0.02784958f, 0.24892972f, 0.02497248f, 
    0.06014600f, -0.23528287f, -0.01334519f, 0.02085107f, -0.36862472f, -0.00144719f, -0.11047954f, -0.01915129f, 
    0.27464736f, -0.08248069f, -0.10319906f, 0.07148777f, -0.05301224f, 0.01487251f, 0.44268206f, -0.16258296f, 
    0.51755148f, 0.15424459f, 0.12618877f, -0.55312192f, -0.34491023f, 0.42012683f, 0.28168076f, 0.01778679f, 
    0.36868167f, 0.00979181f, 0.20925504f, 0.45921525f, 0.17085007f, -0.11984346f, 0.10912782f, 0.05271149f, 
    -0.01606319f, 0.05089238f, 0.25558734f, -0.01692952f, 0.17195228f, 0.59259236f, 0.06996566f, 0.38390490f, 
    0.35003108f, -0.01856847f, 0.16085093f, -0.07272641f, 0.04602336f, 0.10103994f, -0.00679880f, -0.12400036f, 
    -0.42369196f, -0.08507149f, -0.03195642f, -0.24082124f, -0.00561893f, -0.44970962f, -0.19518460f, -0.60617799f, 
    0.16298187f, 0.26448223f, -0.03890489f, -0.11982438f, -0.05750467f, 0.04673738f, 0.10398918f, 0.07112767f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    -0.13745426f, 0.46659130f, -0.03767386f, -0.00346553f, 0.24865797f, 0.25513551f, 0.13939261f, -0.01121061f, 
    0.58839524f, 0.24032456f, 0.25873977f, 0.15204272f, -0.04550986f, 0.34304336f, -0.08483890f, 0.31329864f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.37530079f, -0.30600202f, -0.23420060f, -0.09746319f, 0.22960074f, -0.65061718f, 0.25328100f, -0.09871135f, 
    -0.46240169f, 0.33373562f, -0.13907127f, 0.82599229f, -0.05331830f, -0.78731072f, 0.21694386f, -0.07623637f, 
    0.23972452f, 0.99232948f, -0.23890643f, -0.10907708f, -0.34753662f, -0.72500598f, -0.21035573f, -1.01855457f, 
    -0.09726468f, 0.10459593f, 0.17360234f, 0.42664164f, 0.20333394f, 0.25646657f, 0.10334749f, 0.42310137f, 
    -0.38482738f, -0.27632841f, 0.06556525f, -0.01237574f, 0.03713802f, 0.37150648f, -0.55319059f, -0.09944335f, 
    0.25165680f, 0.28329995f, -0.31544113f, -0.36918348f, 0.12375527f, 1.28517699f, -0.73287696f, -0.60614765f, 
    0.00705992f, -2.08368254f, -0.03367922f, -0.20479633f, -0.06289119f, 0.47395521f, 0.00874044f, 0.37492731f, 
    0.18630621f, -0.24503478f, -1.28787112f, 0.21676372f, -0.07179709f, -1.32946801f, -0.02763132f, 0.46212301f, 
    0.62686771f, -0.13470587f, -0.21911222f, -0.15301009f, -0.52735186f, 0.16243501f, 0.49868363f, 0.13956621f, 
    -0.18680944f, -0.13718660f, -0.34808463f, -0.16675106f, -0.03336840f, -0.61184967f, 0.24315313f, -0.73564523f, 
    0.11100283f, 0.24327070f, 0.15742508f, -0.24798901f, -0.19489092f, -0.00323780f, -0.39074221f, -0.40748560f, 
    0.28592485f, -0.28153175f, -0.22830796f, 0.39267856f, 0.22898959f, -0.08794083f, -0.01744988f, -0.09670909f, 
    -1.18423259f, -0.85834455f, 0.15964212f, 0.04978079f, 0.32051596f, 0.34928185f, -0.68646789f, 0.13750818f, 
    0.27373508f, 0.09191886f, 0.93167776f, -1.17563355f, -0.13368279f, -0.19170901f, -0.60471135f, -0.87294281f, 
    -0.10949247f, -0.49552795f, -0.13916044f, 0.07804243f, -0.38131985f, 0.51588356f, -0.34342703f, 0.59296733f, 
    -0.49847820f, 0.44322872f, -0.10387801f, -0.33362430f, 0.02441180f, -0.48515239f, 0.40136096f, 0.51927108f, 
    0.26574123f, -0.07326207f, -0.07396426f, 0.15151842f, 1.12910509f, -0.64607048f, -1.07933247f, 0.25820136f, 
    0.07092036f, -0.40504500f, -0.11803511f, -0.49984461f, -0.07056801f, -0.37266642f, -0.60115314f, 0.64583588f, 
    -0.44998556f, -0.38266364f, 0.17507920f, 0.21998002f, -0.27313590f, 0.86777169f, 0.56307369f, 0.35461003f, 
    0.54454273f, -0.31199059f, -0.19937529f, -0.67700821f, 0.14275029f, -0.98964143f, -0.69428873f, -0.83625907f, 
    0.11995222f, -0.77434886f, -0.24632263f, 0.05893687f, -0.93171012f, -1.00765193f, 0.49431220f, 0.02818781f, 
    0.08981998f, 0.12859821f, -0.26155230f, -1.10017693f, 0.17885751f, 0.94498092f, 0.17820762f, -0.17575070f, 
    -0.49390444f, -0.40139949f, -0.01838073f, -0.07199124f, 0.46692348f, -0.43606809f, -0.42100456f, 0.15588652f, 
    0.10048799f, -0.82962263f, 0.22666752f, -0.16634357f, -0.00445132f, -0.48574486f, 1.14743853f, -0.34867015f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.70389599f, 0.04599004f, 0.31088299f, 0.60890973f, 0.10566740f, -0.05077108f, -0.34272790f, -0.43531835f, 
    -0.32343221f, -0.11950757f, -0.00324276f, 0.24841808f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
