#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.86265272f, 0.37906536f, 0.46152249f, -0.15992349f, 0.32179561f, -0.48890197f, -0.02267659f, 0.09395929f, 
    0.73889965f, 0.01665962f, -0.23115198f, -0.23533070f, 0.43890873f, -0.56213641f, -0.06484758f, 0.34576264f, 
    -0.10857262f, 0.14412698f, -0.27627736f, -0.21537361f, 0.08851115f, -0.20502850f, 0.15290989f, 0.02451323f, 
    0.23905450f, -0.03410111f, -0.51938093f, -0.06845021f, 0.37406501f, 0.21768607f, -0.44003054f, -0.40877333f, 
    -0.01386441f, 0.59145343f, 0.07606933f, 0.19266590f, -0.05758282f, -0.14733326f, 0.11656997f, -0.24080060f, 
    -0.35320792f, 0.15544325f, -0.29715437f, -0.32140329f, -0.37945130f, -0.58728218f, -0.31806663f, -0.29303485f, 
    -0.60521299f, -0.43289235f, 0.63242823f, 0.64426196f, 0.45213231f, 0.52674663f, -0.68777645f, -0.21384948f, 
    -0.15361699f, -0.18595277f, -0.49278763f, -0.50400716f, 0.46217763f, 0.21108814f, 0.28104901f, -0.04376559f, 
    -0.49561328f, -0.31308165f, -0.23951228f, 0.14600486f, -0.13023108f, 0.16612940f, 0.11392174f, -0.15296420f, 
    -0.06947426f, -0.02729749f, 0.25418940f, -0.51665711f, -0.08175253f, -0.42980981f, -0.14987059f, -0.32970446f, 
    -0.58033842f, -0.81939542f, -0.50892961f, -0.53738403f, -1.03128409f, 0.40967789f, 0.28911448f, 0.61250353f, 
    0.11850262f, 0.34037405f, -0.05261311f, -0.24434157f, -0.10106352f, -0.00722662f, -0.23126762f, -0.22677608f, 
    0.19380473f, -0.22841385f, -0.23121440f, 0.49015859f, 0.22922358f, -0.35991544f, -0.19679123f, 0.52071494f, 
    0.12168881f, -0.75372845f, -0.59850955f, -0.31742248f, 0.11669287f, 0.07631245f, 0.14571190f, -0.54213470f, 
    -0.21527456f, 0.21841770f, -0.35258302f, -0.15871930f, -0.20048945f, 0.07719028f, 0.18896705f, -0.30121705f, 
    0.09641235f, -0.11778519f, -0.35908756f, 0.11587124f, 0.40331706f, 0.47384426f, 0.16990304f, 0.31515205f, 
    -0.16833758f, -0.27766192f, 0.39313653f, 0.29214212f, 0.23547861f, 0.45038673f, 0.03011000f, 0.34785929f, 
    -0.19162831f, 0.43717852f, -0.26289228f, 0.19807991f, 0.15045655f, 0.19602524f, 0.01223321f, -0.23440827f, 
    0.23854622f, -0.04393868f, 0.28625113f, -0.04989779f, -0.11655950f, 0.15694995f, -0.99932951f, -0.50559133f, 
    -0.50474274f, -0.50558126f, -0.21294916f, -0.27859026f, 0.06155197f, 0.02825951f, 0.20165896f, -0.24261525f, 
    0.46359029f, 0.11331101f, -0.07348815f, -0.03512171f, 0.18383847f, -0.23114096f, -0.09944470f, -0.19526261f, 
    0.23826659f, -0.30682567f, -0.26270667f, -0.22434549f, -0.06432905f, -0.25623694f, -0.36632422f, -0.47301948f, 
    -1.46539474f, 0.38691103f, 0.79773337f, 1.11444950f, -0.31862691f, -0.42718804f, 0.47944677f, -0.50483209f, 
    -0.05557205f, -0.19645579f, -0.40089718f, 0.35537425f, -0.49580997f, -0.14543061f, -0.17726246f, 0.28025758f, 
    0.10921614f, 0.25528955f, 0.00205317f, 0.16850990f, 0.00731937f, -0.15077914f, 0.01735579f, 0.19921385f, 
    0.16580954f, 0.15839356f, 0.27726817f, 0.29904956f, 0.49136400f, 0.28831306f, -0.20817198f, -0.26215589f, 
    0.30626446f, -0.07002645f, 0.13456644f, 0.30091619f, 0.00144908f, -0.31030986f, 0.08454852f, -0.44466880f, 
    -0.04749496f, 0.14370586f, -0.17973839f, -0.00253415f, 0.00938883f, -0.08147255f, 0.25473493f, 0.00591606f, 
    -0.13689829f, 0.23483013f, 0.30148917f, -0.19656883f, 0.18564245f, 0.13769475f, 0.08817214f, 0.00661173f, 
    -0.10460185f, 0.12730096f, 0.22933720f, -0.19373535f, 0.40005866f, -0.09579195f, -0.11400042f, 0.19040415f, 
    0.13909864f, 0.03695012f, 0.11512350f, 0.07664659f, -0.25748742f, 0.22704720f, 0.37291706f, 0.33210102f, 
    0.18707931f, 0.24133249f, -1.04655731f, -0.13678659f, 0.46926248f, 0.00936955f, -0.20052508f, -0.09083002f, 
    -0.36531806f, 0.07378194f, 0.82197613f, -0.36644021f, 0.27442381f, -0.01667888f, -0.03876073f, 0.63147813f, 
    -0.21406995f, -0.13574979f, -0.09710501f, -0.14640704f, -0.45163083f, 0.18621729f, 0.26927957f, 0.24502872f, 
    0.34589756f, -0.08976230f, -0.03446367f, 0.59646475f, 0.41469648f, 0.22825465f, 0.08411757f, 0.24254026f, 
    -0.09057697f, -0.27574420f, -0.15364905f, -0.30831230f, -0.50539315f, 0.09881918f, 0.08654167f, 0.07559019f, 
    0.25801495f, -0.08731169f, 0.14304912f, 0.06295829f, -0.08595688f, -0.29459050f, 0.25732699f, -0.25611091f, 
    0.05272724f, -0.25169793f, -0.15442526f, 0.14539748f, 1.12086332f, 0.50534809f, 0.19811657f, -0.37957305f, 
    -0.52768666f, 0.19577089f, -0.00760235f, -0.09640677f, 0.08822942f, -0.31889287f, -0.13135505f, -0.20127472f, 
    -0.21936211f, -0.10061537f, 0.32695001f, 0.16148385f, 0.28519934f, 0.11034521f, -0.27045116f, -0.38385993f, 
    -0.13257076f, -0.07169930f, 0.00960842f, 0.06373800f, 0.10165372f, -1.05480778f, -0.31670219f, -0.17736724f, 
    0.17205730f, 0.04159553f, 0.31828901f, 0.15610294f, 0.34331310f, 0.16355047f, 0.94949538f, -0.13777129f, 
    -0.30202675f, -0.02834474f, -0.41692713f, -0.06609437f, -0.15538585f, 0.31754363f, -0.15636635f, 0.34626877f, 
    0.35184360f, 0.04869241f, -0.25852659f, -0.32390547f, -0.16871671f, 0.07751869f, -0.76394826f, 0.20777358f, 
    -0.33257195f, 0.22968298f, 0.28983578f, -0.24088487f, 0.16101864f, -0.25835770f, 0.33657387f, 0.52634227f, 
    0.13069610f, -0.23881994f, -0.56166947f, 0.22019009f, -0.04850094f, 0.30504501f, -0.12294680f, 0.07360366f, 
    0.27188361f, -0.26609749f, -0.36883071f, -0.18571161f, 0.30131724f, -0.25374332f, -0.21818402f, -0.79324150f, 
    -0.34767529f, 0.03781748f, 0.57435948f, -0.11324070f, 0.20376718f, 0.53526413f, 0.25233167f, 0.03372019f, 
    0.06496794f, 0.39557451f, -0.37113696f, -0.11158866f, 0.39978024f, -0.08847286f, -0.07569573f, -0.15538892f, 
    -0.45065406f, 0.34259927f, -0.07449026f, 0.21573807f, -0.27407077f, 0.45436078f, 0.12835358f, -0.29854771f, 
    0.41116583f, -0.28193116f, -0.85396051f, -0.56590617f, -0.92365575f, 0.65057564f, 0.23040518f, 0.48198342f, 
    0.28209269f, 0.10355914f, 0.48105827f, 0.04295844f, -0.03816821f, 0.19874889f, -0.28463683f, -0.39755681f, 
    0.04503355f, 0.24924462f, -0.24662253f, -0.35934737f, -0.17429619f, 0.07582738f, 0.28739458f, 0.42125931f, 
    -0.06539031f, -1.33932090f, 0.02187852f, 0.18970893f, -0.86499381f, -0.34313819f, -0.11383953f, -0.33731267f, 
    -0.38523272f, 0.09094814f, 0.05449788f, -0.50077844f, -0.54189634f, -0.27947024f, -0.62954164f, -0.45288166f, 
    0.27476531f, 0.14086758f, -0.15282071f, -0.16736592f, -0.24302801f, -0.21122326f, 0.00658817f, -0.42636910f, 
    -0.11090560f, -0.34409404f, 0.81810385f, -0.32647014f, -0.36766353f, 0.01579981f, 0.32289946f, 0.22420758f, 
    1.06226814f, -0.44408283f, -0.71479023f, -0.61212265f, 0.59316039f, -0.28388792f, -0.22146057f, -0.11438062f, 
    -0.19081143f, -0.22663756f, -0.16686790f, 0.35002077f, 0.39519662f, -0.13875820f, -0.21831307f, -0.10098206f, 
    0.09182841f, -0.00905536f, -0.08013768f, -0.60386938f, -0.62635851f, -0.59286898f, -0.41673672f, 0.03494113f, 
    0.00813648f, -0.41737616f, -0.21235788f, -0.61975837f, -0.34458655f, -0.18276997f, -0.07179008f, -0.00543220f, 
    0.23629345f, -0.78834486f, 0.23439097f, -0.39031130f, -0.24524574f, 0.08871628f, -0.16100256f, -0.41088960f, 
    -0.15190305f, -0.32395902f, -0.21769492f, -0.19117287f, 0.57361883f, -0.02860876f, -0.10874057f, 0.44494215f, 
    -0.12237329f, 0.35104039f, -0.37844849f, -0.28011316f, 0.08291578f, -0.45697063f, 0.00184672f, 0.06795391f, 
    0.37176940f, -0.48941714f, -0.06585460f, -0.25148016f, 0.18866991f, -0.05205815f, -0.29152927f, 0.41390032f, 
    -0.19407490f, -0.13552281f, 0.01745323f, 0.40989771f, 0.18809797f, 0.48138359f, 0.97449845f, 0.67163086f, 
    -0.89108962f, -0.73395860f, -0.58852917f, -0.24040876f, 0.25058639f, -0.42850450f, -0.35285720f, 0.03776067f, 
    0.40453771f, 0.41856936f, 0.04223237f, -0.25663349f, 0.29260331f, -0.20310211f, -0.19326280f, 0.18444552f, 
    -0.45968422f, 0.28921771f, -0.14925943f, -0.18626982f, -0.25335279f, 0.00894522f, -0.63898885f, -0.52083582f, 
    -0.27637419f, -0.42986104f, -0.01729938f, 0.45645285f, -0.01331221f, -0.17823593f, -0.08373106f, 0.29150325f, 
    0.27590233f, 0.12400696f, 0.27993935f, -0.18822536f, 0.43105984f, -0.22662155f, -0.14362638f, -0.29301721f, 
    -0.10467187f, 0.39378464f, 0.12696244f, -0.31397784f, -0.09521418f, 0.40835741f, 0.52815127f, 0.03156693f, 
    0.56376004f, 0.31912073f, 0.07864875f, 0.21047281f, -0.00260661f, 0.06082722f, 0.09677334f, 0.03478539f, 
    -0.42961410f, -0.31235906f, -0.33388576f, -0.04162207f, -0.30328467f, -0.10212609f, 0.25543132f, -0.11933570f, 
    0.32093301f, 0.15814984f, 0.10936082f, 0.01920628f, -0.09811664f, -0.19999507f, -0.26610228f, -0.10512014f, 
    -0.53237927f, -0.41257894f, -0.34395087f, -0.51773542f, -0.36547756f, -0.52834255f, -0.56896359f, -0.72659856f, 
    -0.35351852f, -0.38192186f, 0.17558049f, 0.00076818f, 0.38067412f, 0.52933943f, 0.16572370f, 0.14052275f, 
    -0.02791211f, -0.17401530f, 0.21086784f, 0.06783003f, 0.14639524f, 0.35680896f, 0.46339357f, 0.03721649f, 
    0.24311717f, -0.99136257f, -0.58164608f, -0.65089947f, -0.73635048f, -0.91072416f, 0.53437644f, 0.28879359f, 
    -0.20626910f, 0.50107294f, 0.43433157f, -0.36356843f, -0.14814827f, 0.10202380f, 0.37622830f, -0.01116044f, 
    -0.09307823f, -0.24064092f, -0.08791389f, -0.00282205f, -0.35692793f, -0.24473271f, 0.15601332f, 0.30465430f, 
    -0.21450305f, 0.11212979f, -0.18365683f, 0.08290598f, 0.19833441f, -0.01493005f, 0.09705855f, 0.19161493f, 
    0.52393490f, -0.19672051f, 0.26103345f, -0.56498134f, -0.30555403f, 0.13327427f, -0.28027773f, 0.09038834f, 
    0.34419680f, 0.31354749f, -0.15765588f, -0.38908479f, -0.10970193f, 0.19963594f, -0.17406419f, -0.12694462f, 
    -0.08077401f, 0.16201748f, 0.20690331f, 0.38583389f, -0.14454448f, -0.20748626f, 0.41003448f, 0.17854065f, 
    -0.37200460f, -0.24585544f, -0.47479650f, -0.42702043f, 0.61511678f, 0.00977470f, 0.15882762f, 0.08240116f, 
    0.30286980f, 0.01976464f, -0.55000627f, -0.02793843f, 0.49286509f, 0.32462370f, -0.30511156f, 0.16784692f, 
    -0.19310525f, 0.23584107f, 0.05816231f, -0.27685407f, 0.11077411f, -0.23128597f, -0.17047949f, -0.22615838f, 
    0.07733060f, 0.16209206f, -0.31637380f, 0.06763117f, 0.10123246f, -0.04220455f, 0.02442165f, 0.06049190f, 
    0.15525690f, -0.21687567f, -0.09707402f, -0.25952196f, -0.29519525f, 0.42595309f, -0.20006900f, -0.56037295f, 
    0.14373431f, 0.30942440f, 0.32589239f, 0.35547668f, 0.49937403f, 0.27068430f, 0.47395679f, 0.43547535f, 
    -0.18824932f, -0.07025532f, -0.47696286f, -0.55062616f, -0.31178865f, 0.43159369f, 0.42907780f, -0.13803065f, 
    -0.06100643f, -0.04694409f, -0.29911080f, -0.29351205f, 0.13907945f, -0.00288948f, -0.04954479f, 0.18644659f, 
    0.16165867f, 0.13926043f, -0.29466024f, -0.42011309f, -0.19486468f, -0.34538254f, -1.49098122f, 0.28892064f, 
    -0.15822826f, 0.04023245f, 0.60859883f, 0.60984206f, 0.81505454f, 0.61746931f, -0.30546638f, -0.38223135f, 
    -0.14852329f, 0.03786207f, -0.25741658f, 0.12241914f, 0.25431329f, 0.10975361f, -0.07600351f, -0.32879487f, 
    -0.39723665f, -0.16533086f, 0.07188024f, 0.03395732f, 0.01419148f, -0.12744169f, -0.06320147f, 0.27916518f, 
    0.89874417f, 1.25913119f, -1.44931412f, -1.41927326f, -0.69556350f, 0.24797229f, 0.31843981f, 0.12278925f, 
    0.13126564f, -0.23829487f, 0.03573230f, 0.35875031f, 0.45743853f, 0.26989895f, -0.04373924f, -0.19765234f, 
    0.21461995f, -0.37759012f, -0.00505389f, 0.17699860f, -0.06688440f, 0.02993757f, -0.01683582f, -0.16382268f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.19371279f, 0.21739525f, 0.06954997f, 0.16307856f, 0.28026107f, 0.07153277f, 0.13256469f, 0.29303879f, 
    -0.12091258f, -0.06838448f, 0.15866278f, -0.20710720f, 0.24583869f, 0.19256179f, 0.21434803f, 0.34963879f, 
    0.29779738f, -0.02038535f, 0.36460894f, 0.09222478f, 0.32418767f, 0.29147220f, 0.49669343f, 0.03029556f, 
    -0.03254431f, -0.08718897f, 0.48773611f, 0.21125433f, 0.20756525f, 0.05453711f, 0.44994411f, 0.20744033f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.24717760f, 0.02878089f, 0.13451849f, 0.04189338f, -0.16427554f, 0.10860870f, 0.02958119f, 0.02312717f, 
    -0.14146972f, 0.10413758f, -0.04594049f, -0.17934637f, -0.02813271f, 0.15876479f, 0.08978612f, -0.05397594f, 
    -0.02664482f, 0.06121683f, 0.00178917f, 0.07420923f, -0.07850707f, 0.05097278f, -0.06705581f, 0.10276008f, 
    0.53469110f, -0.05081967f, 0.29638124f, 0.14985773f, 0.06687555f, -0.16743799f, 0.24918005f, -0.12132049f, 
    -0.01775452f, -0.03130589f, -0.07339262f, 0.08752377f, -0.41086352f, -0.22572787f, -0.18005751f, 0.21167304f, 
    -0.03504751f, -0.05671361f, -0.17965113f, -0.13021752f, -0.08104415f, -0.10351444f, -0.06497139f, 0.01167296f, 
    0.20743455f, 0.10381001f, -0.26052526f, -0.25848317f, 0.06367941f, 0.16820845f, 0.03743827f, 0.01878364f, 
    -0.03821732f, -0.01396066f, -0.09132383f, 0.08519360f, 0.19729488f, 0.06705926f, 0.12691061f, 0.14463729f, 
    -0.03433655f, 0.00954433f, -0.08799573f, 0.00579082f, 0.14464575f, -0.00696567f, -0.03550922f, -0.10199864f, 
    -0.39634347f, -0.22423697f, -0.12085176f, -0.24017069f, -0.05286501f, 0.13830142f, 0.04301291f, 0.00776729f, 
    0.15945265f, 0.07720495f, 0.07581943f, 0.02782552f, -0.24061322f, 0.05939964f, 0.21820503f, 0.04690764f, 
    0.30299848f, 0.13411453f, -0.17615990f, -0.04099689f, -0.06495491f, 0.04845937f, 0.00354147f, -0.01581576f, 
    0.20050831f, 0.13975576f, 0.16505833f, 0.27722365f, -0.02331726f, 0.09020693f, -0.11507903f, 0.00896276f, 
    -0.06152144f, -0.00900334f, 0.03092621f, 0.03456591f, 0.09245711f, 0.06622736f, 0.01899503f, 0.11806502f, 
    -0.07806106f, -0.01318347f, 0.00029086f, 0.00897078f, -0.17166372f, -0.11920711f, -0.12120791f, -0.10180771f, 
    -0.44863445f, 0.07893135f, 0.40079901f, -0.01663289f, -0.07647585f, 0.02501306f, -0.04702230f, -0.05325677f, 
    0.08669593f, -0.16874269f, 0.18593682f, -0.15992136f, 0.11545280f, 0.01639326f, 0.06783831f, 0.03477921f, 
    0.06978448f, 0.00991131f, -0.00374313f, 0.10113313f, 0.01894872f, 0.04224472f, -0.02537157f, 0.05374127f, 
    0.71928948f, 0.20619413f, 0.13729687f, -0.06309299f, -0.08053270f, -0.02304413f, 0.09420670f, -0.00968881f, 
    -0.00146656f, 0.08010901f, -0.13958994f, 0.01440546f, -0.11522757f, 0.21640508f, 0.05143600f, 0.03834443f, 
    -0.07932299f, 0.05772916f, -0.00263869f, 0.14097136f, -0.16529636f, 0.12164888f, 0.04549842f, 0.24066147f, 
    0.03685569f, -0.02350830f, -0.07312805f, 0.00355228f, -0.04658155f, 0.14370587f, -0.05265998f, 0.22288501f, 
    -0.06100116f, 0.27559093f, 0.11064491f, 0.04741124f, 0.02318451f, 0.07518335f, -0.01092546f, -0.07440280f, 
    -0.06662663f, 0.00964747f, 0.00589798f, 0.03533009f, -0.04449667f, 0.22454299f, -0.01930156f, 0.06266550f, 
    -0.00634856f, -0.32853270f, -0.33551031f, -0.17624174f, -0.08954720f, -0.13298787f, -0.06187417f, 0.37237304f, 
    0.26265246f, 0.17190702f, 0.15527847f, -0.23334645f, -0.61827677f, -1.19275320f, -0.56762666f, -0.32315278f, 
    -0.14208348f, 0.10305788f, 0.12609528f, -0.00971248f, -0.03112707f, 0.09441473f, 0.09803716f, 0.04144467f, 
    0.16450197f, -0.02927366f, 0.00300485f, 0.50545418f, 0.24297388f, 0.06865557f, -0.00558424f, -0.05784450f, 
    0.03329595f, 0.10650180f, 0.01888213f, 0.13095461f, -0.27293307f, -1.03557396f, -0.22515583f, -0.11682701f, 
    -0.08306494f, -0.11614352f, -0.01209114f, 0.04271730f, -0.02409160f, 0.05140895f, -0.11216591f, 0.19310185f, 
    0.41693315f, 0.22588491f, 0.08913066f, 0.10751530f, -0.01712853f, 0.08880835f, 0.01971159f, 0.05770825f, 
    -0.09732611f, 0.05017507f, -0.08088727f, 0.04409175f, 0.35290995f, -0.33978879f, -0.02991308f, -0.26908863f, 
    0.13962598f, 0.25015914f, 0.26533642f, -0.10572916f, 0.03797181f, -0.11341613f, -0.03804511f, 0.12938093f, 
    -0.30840531f, 0.14562698f, -0.06744444f, 0.00964870f, -0.07385373f, -0.07723977f, 0.03736233f, 0.04429184f, 
    -0.05992082f, 0.08626998f, -0.11021131f, 0.02234002f, 0.19332385f, 0.21996278f, 0.10957278f, 0.26810119f, 
    -0.02534035f, 0.05318389f, 0.01593702f, -0.09332981f, -0.01269210f, 0.09648831f, 0.07165931f, 0.09927168f, 
    -0.42723092f, -0.45757633f, -0.40735459f, -0.35296869f, 0.33612099f, 0.00624938f, -0.12563561f, -0.15461873f, 
    0.02307600f, -0.09269558f, -0.02407267f, -0.02093515f, -0.44104308f, -0.62079495f, -0.44860810f, -0.77615958f, 
    0.00185708f, -0.20760481f, 0.00186981f, 0.00659268f, 0.00561599f, 0.11453074f, 0.06692224f, -0.03112155f, 
    0.17157534f, 0.10911943f, 0.08730482f, 0.14369841f, 0.03418679f, -0.01083035f, 0.00177851f, -0.14084102f, 
    0.04318456f, 0.02300430f, 0.18413961f, 0.01575953f, 0.08030193f, 0.06674825f, -0.03632456f, 0.11092639f, 
    0.04248149f, 0.23628668f, 0.22386605f, 0.07707714f, -0.07245974f, -0.05776953f, -0.05156863f, 0.06604669f, 
    0.00370830f, 0.07994477f, 0.02373184f, -0.06566753f, 0.00867637f, -0.14980623f, -0.03037247f, 0.02200681f, 
    -0.10654619f, 0.00258278f, -0.08751779f, -0.12613267f, 0.34668612f, -0.01290880f, 0.04961623f, 0.09287944f, 
    -0.02603883f, 0.09912175f, 0.12196501f, 0.06167943f, 0.13881180f, -0.02936354f, 0.10898930f, 0.12246832f, 
    0.04725862f, 0.20517546f, 0.12489464f, -0.02587925f, -0.03117721f, -0.05824869f, -0.04112074f, -0.05094940f, 
    0.07954589f, 0.00825885f, -0.01336157f, 0.19635907f, 0.38840923f, -0.31727117f, -0.02658811f, -0.04263426f, 
    -0.03341957f, 0.06679693f, -0.00570283f, 0.13271485f, 0.26148579f, -0.01917485f, -0.11989058f, -0.00855326f, 
    0.28742358f, 0.05225391f, 0.41791078f, 0.02832561f, -0.13121021f, 0.09421609f, 0.01959898f, 0.03874999f, 
    0.03364953f, 0.07177401f, 0.14141607f, 0.14812796f, -0.06964602f, 0.25462955f, -0.10838756f, -0.26536518f, 
    -0.03143732f, -0.00923262f, 0.01143813f, 0.04186229f, 0.03672492f, -0.06752075f, -0.05305021f, -0.04215193f, 
    -0.07941493f, -0.10983375f, 0.12791339f, -0.20624912f, 0.03055513f, -0.07097356f, -0.05099751f, -0.20788901f, 
    -0.10064724f, -0.08665567f, 0.10020126f, 0.08292699f, 0.03362506f, -0.01861806f, -0.29633388f, -0.26505208f, 
    -0.01475103f, 0.08605041f, 0.00383700f, -0.04941140f, -0.03393556f, -0.01598916f, 0.03526586f, 0.14909893f, 
    -0.02960938f, 0.33619118f, 0.08191636f, -0.21233979f, 0.29711941f, -0.01583436f, -0.07674797f, 0.03472969f, 
    -0.00919663f, -0.01067267f, -0.05200074f, 0.00244974f, -0.17321010f, 0.02861180f, 0.02654629f, 0.15019019f, 
    -0.10939094f, -0.16287951f, -0.11758930f, -0.01716254f, -0.08557630f, 0.00807656f, -0.07130612f, 0.06032274f, 
    0.06365336f, 0.12434338f, -0.31524101f, -0.33622369f, -0.02560089f, 0.20386456f, 0.06342564f, 0.24995293f, 
    0.01304402f, -0.00202545f, -0.03849149f, -0.03722368f, 0.45483157f, 0.59541488f, 0.15051456f, -0.03280998f, 
    0.18182594f, -0.16071135f, 0.14636882f, -0.00463339f, -0.01528404f, 0.05013888f, -0.00598186f, 0.00510254f, 
    -0.18703806f, 0.08096742f, 0.00851103f, -0.07418074f, -0.07705877f, -0.10302552f, -0.03410120f, 0.02239353f, 
    -0.01567108f, 0.05945892f, 0.07423714f, 0.06698677f, -0.15744284f, -0.01458856f, -0.02179605f, -0.06142651f, 
    -0.19807227f, -0.06413367f, -0.08061177f, -0.07999849f, -0.14322442f, 0.06645285f, 0.04636056f, 0.00002687f, 
    0.08049408f, 0.24862202f, 0.15766187f, -0.20222564f, 0.03230445f, 0.15916663f, 0.13523042f, 0.14126712f, 
    -0.15375382f, 0.16764300f, 0.01696331f, -0.05026070f, -0.24695319f, -0.04614022f, -0.04707216f, -0.12245578f, 
    -0.15840468f, -0.07427731f, -0.09223229f, -0.14761907f, -0.16639556f, 0.05011506f, -0.03381542f, -0.04500002f, 
    -0.29544368f, -0.07773621f, 0.16516966f, -0.03889676f, 0.04860140f, 0.01366787f, -0.08564051f, 0.00348458f, 
    -0.00252048f, 0.00569914f, -0.00070859f, 0.02975416f, 0.07720091f, 0.12869169f, 0.10212608f, -0.06660902f, 
    -0.01524145f, -0.03027065f, -0.09204382f, 0.01880381f, 0.18110147f, 0.20949857f, 0.14621058f, -0.16132973f, 
    -0.20905806f, 0.19823651f, 0.13446896f, -0.12780134f, -0.00038068f, -0.01959208f, 0.02306033f, 0.06153210f, 
    0.08213115f, 0.25953540f, 0.06312288f, 0.12428331f, 0.03187499f, -0.28348541f, -0.05967454f, -0.15921369f, 
    -0.09589613f, -0.05116523f, 0.02571391f, 0.06752780f, 0.27986535f, 0.31837302f, 0.04899758f, 0.12455186f, 
    -0.05042451f, -0.16371468f, -0.23460580f, 0.21380934f, 0.02308190f, 0.21677397f, -0.00695848f, -0.13549361f, 
    0.22183786f, 0.22985715f, -0.00136849f, 0.12594494f, 0.31045416f, 0.28070909f, 0.06077969f, -0.04713895f, 
    0.09517235f, 0.37452564f, 0.05644559f, 0.22239375f, -0.03651933f, -0.02184041f, -0.13475588f, -0.04981960f, 
    0.10442536f, 0.09036523f, -0.06480382f, 0.47427708f, 0.09374604f, -0.05314847f, 0.06271114f, 0.02296159f, 
    -0.15874042f, -0.01317723f, 0.03380156f, 0.14979264f, 0.35962066f, 0.15194230f, -0.25939372f, 0.04733758f, 
    0.08415460f, 0.23278244f, 0.21281543f, -0.03560258f, -0.03731950f, -0.09348860f, -0.13167934f, -0.09121073f, 
    -0.24047388f, 0.07839140f, -0.08589754f, 0.12244382f, 0.02987657f, 0.13525751f, -0.02999673f, -0.00653934f, 
    0.07703491f, 0.10129589f, 0.00229174f, 0.07884230f, 0.09372762f, -0.33894905f, 0.15237531f, -0.03802328f, 
    0.05820467f, 0.15950906f, 0.10476188f, 0.14959200f, -0.12007812f, 0.03689117f, -0.00805508f, 0.03852965f, 
    -0.13494684f, 0.00403651f, -0.07894131f, 0.03060954f, 0.01148189f, 0.12289348f, 0.24811566f, 0.18492909f, 
    0.22127382f, -0.03010281f, 0.03832075f, -0.02884362f, -0.32992089f, -0.07714993f, -0.05628169f, -0.16337045f, 
    -0.04650747f, 0.00865052f, -0.13633676f, -0.15399700f, -0.15587999f, -0.05408937f, -0.08244435f, -0.03620715f, 
    0.16038965f, 0.03437682f, -0.03646048f, -0.11359901f, 0.13024154f, 0.07613315f, -0.03164623f, 0.09637450f, 
    -0.11470903f, -0.02401458f, -0.03751390f, 0.03676256f, -0.12085422f, 0.05302005f, 0.11936999f, -0.12730841f, 
    0.21097921f, 0.32575360f, 0.10044839f, 0.02871058f, -0.03927279f, 0.08944156f, -0.02574747f, 0.03063331f, 
    0.07838050f, -0.07817042f, 0.22825436f, 0.12842479f, -0.05357531f, 0.00120370f, -0.00315425f, 0.11042873f, 
    0.13780528f, 0.18665828f, 0.15835235f, 0.07163920f, -0.05485749f, 0.35493767f, -0.06453969f, -0.15469715f, 
    0.03104880f, 0.02407209f, -0.00322525f, 0.09173418f, 0.06247115f, 0.00122865f, 0.07026316f, 0.08187467f, 
    -0.11032427f, 0.02567825f, -0.03927106f, -0.02149080f, 0.07960795f, 0.13763353f, -0.02624122f, -0.08866616f, 
    0.05314838f, 0.03741755f, 0.12436975f, 0.16110560f, -0.35685489f, 0.20772858f, 0.14576015f, 0.08500978f, 
    0.03333490f, -0.05989468f, -0.23566757f, 0.05691896f, -0.11627071f, -0.10700268f, -0.00195386f, -0.08220590f, 
    0.45607311f, -0.04349536f, -0.04324042f, -0.24049364f, -0.01199022f, -0.00394027f, 0.08345830f, 0.03877249f, 
    0.04861999f, 0.16367415f, 0.03396670f, 0.10813949f, 0.38653371f, -0.80939764f, 0.40035477f, 0.18038560f, 
    0.04395619f, -0.01931676f, 0.02438080f, 0.04627885f, 0.07912444f, -0.09669099f, -0.03474173f, 0.00330591f, 
    0.01953404f, 0.03365006f, -0.04430206f, 0.04342312f, 0.00545597f, 0.01827163f, 0.01858849f, 0.04014316f, 
    0.02136918f, -0.01427540f, 0.04492710f, 0.00364779f, 0.03137287f, -0.03550832f, -0.04048032f, -0.02305829f, 
    0.02580573f, -0.01039108f, -0.00948527f, 0.01592534f, -0.00576540f, -0.04741376f, -0.03869979f, -0.04511032f, 
    -0.03420829f, -0.03069743f, 0.00968331f, 0.02097275f, -0.04675551f, -0.03471607f, 0.03067359f, -0.01151650f, 
    0.02825804f, 0.00638621f, -0.01044157f, 0.03998848f, -0.02516160f, -0.01218982f, 0.01438838f, -0.05621896f, 
    -0.02942044f, -0.01780961f, -0.02038079f, 0.02467735f, 0.03259366f, -0.01960267f, -0.01034997f, -0.02354705f, 
    -0.03107102f, 0.01717421f, -0.05004283f, 0.03954192f, 0.03712348f, 0.01252296f, -0.05189876f, -0.03486030f, 
    -0.05184053f, 0.01469186f, -0.03092001f, 0.00375114f, -0.04112019f, -0.02641341f, -0.05441297f, -0.04249164f, 
    -0.01337349f, -0.03517033f, -0.04376360f, 0.02254834f, -0.02063671f, 0.04042225f, -0.01842277f, -0.02991213f, 
    -0.03108072f, 0.02861423f, -0.02668425f, 0.02529044f, -0.01091903f, -0.02537007f, -0.04739133f, -0.01667659f, 
    0.04487110f, -0.04296682f, 0.01913632f, 0.00886533f, -0.02272214f, -0.02175165f, -0.03611756f, -0.01411304f, 
    -0.03722780f, -0.03699806f, 0.00810412f, -0.03141608f, 0.03101672f, 0.04149267f, -0.02545874f, -0.04324709f, 
    -0.03029072f, -0.03333875f, 0.02858191f, -0.04055287f, -0.01539118f, -0.02345848f, -0.02610017f, 0.03742706f, 
    0.03337140f, -0.04763748f, -0.03075483f, 0.00625738f, -0.04774397f, 0.04382697f, 0.02277256f, 0.01656925f, 
    -0.03888161f, -0.05117071f, -0.04856677f, -0.03424006f, -0.02391526f, -0.01578193f, -0.03651734f, 0.04215555f, 
    0.01114980f, 0.04225751f, -0.01080587f, -0.04477677f, 0.00429820f, -0.02982862f, 0.00159873f, -0.04044601f, 
    0.00048487f, -0.00056366f, -0.01246273f, 0.00873819f, -0.04078574f, -0.00344612f, -0.01696322f, -0.03105354f, 
    0.00314116f, -0.02237180f, -0.01915740f, 0.03194267f, 0.01393235f, -0.00281368f, -0.02470096f, -0.03294699f, 
    0.04477293f, -0.05561538f, -0.03909181f, -0.05280926f, -0.03973682f, -0.03439939f, -0.04523089f, 0.02320902f, 
    0.00662781f, -0.04765576f, -0.02362402f, -0.03861935f, 0.02640680f, 0.04317017f, -0.04535796f, -0.00932903f, 
    0.03670906f, 0.00191901f, -0.01645313f, -0.03340789f, 0.03326383f, 0.04283233f, -0.01518380f, 0.01857072f, 
    -0.01859074f, -0.03738476f, -0.02370974f, -0.02206375f, 0.00012709f, -0.02944427f, 0.00484096f, 0.00056495f, 
    0.04170829f, -0.02712749f, -0.05346556f, -0.04080940f, 0.01667535f, -0.04806725f, 0.02841950f, 0.01837941f, 
    -0.01156123f, 0.04441294f, -0.00951073f, 0.01574327f, -0.05639462f, -0.03720946f, -0.05511912f, -0.01705853f, 
    0.01506931f, 0.01502524f, -0.01303376f, -0.05134559f, 0.01939635f, -0.01318866f, -0.02932341f, -0.03857135f, 
    -0.01771395f, -0.03203066f, 0.01861473f, 0.00449184f, -0.04879846f, -0.03052062f, -0.02642296f, 0.00724526f, 
    -0.04688025f, -0.03872217f, -0.03966780f, 0.00646357f, -0.01770422f, 0.02405826f, -0.01257092f, 0.04348597f, 
    0.04457837f, -0.04208281f, -0.04217745f, 0.00289274f, -0.03568301f, -0.00359545f, -0.04806911f, 0.00459117f, 
    0.00867159f, -0.03239829f, -0.03943976f, -0.00381357f, 0.01322086f, -0.00695826f, 0.00880054f, -0.04747307f, 
    0.01558973f, 0.01874157f, 0.03667490f, -0.00155958f, 0.02293233f, -0.05029118f, -0.02849128f, -0.01780292f, 
    0.03866365f, 0.02529899f, 0.02809051f, -0.02499356f, -0.03086053f, 0.00609110f, -0.02015580f, -0.04890087f, 
    0.00488162f, -0.00709362f, -0.03786735f, -0.00062322f, -0.01298962f, -0.00489759f, 0.02106130f, -0.01461936f, 
    0.01337685f, 0.00226065f, 0.03222995f, -0.01319391f, 0.00735181f, 0.00790239f, -0.03823376f, -0.00590510f, 
    0.02638107f, 0.02180424f, -0.05158344f, 0.03950382f, -0.02754656f, 0.04030793f, 0.03460221f, -0.04650088f, 
    0.00283820f, -0.03729128f, -0.01811344f, -0.02287763f, 0.00141713f, 0.04111001f, 0.00420087f, 0.03865525f, 
    0.03245817f, -0.05279223f, 0.00113880f, 0.01433817f, -0.02076245f, -0.02771637f, -0.03967013f, 0.00154331f, 
    -0.00974740f, -0.02954879f, 0.01019729f, 0.02605127f, 0.00801001f, 0.02609263f, -0.00471481f, -0.01766171f, 
    -0.04372083f, 0.04217616f, -0.04401297f, -0.01820672f, 0.02506197f, 0.00765475f, 0.03963003f, -0.01753705f, 
    -0.05383739f, 0.03559491f, -0.00967466f, 0.00238741f, -0.03424499f, -0.02308876f, -0.00529745f, -0.05654150f, 
    0.02543423f, -0.03100492f, 0.01998448f, -0.01908175f, 0.01014383f, 0.02837764f, -0.01612781f, -0.04491406f, 
    0.02346494f, 0.00163072f, -0.01197559f, 0.01240759f, 0.03483786f, 0.01824864f, 0.03498254f, -0.00823912f, 
    -0.02843385f, 0.02424522f, -0.01468047f, -0.04098336f, 0.00796877f, 0.04394810f, -0.01851263f, 0.02521146f, 
    -0.00117757f, -0.00765499f, 0.02563496f, -0.03668929f, 0.03968070f, 0.00096205f, 0.03041845f, -0.00342341f, 
    0.04322664f, -0.05421944f, -0.02272366f, -0.04792177f, -0.04610491f, -0.00280494f, -0.04628105f, 0.01409606f, 
    0.01994767f, 0.03743035f, -0.05010608f, 0.00984332f, -0.04930992f, 0.04534775f, 0.01302183f, 0.01797892f, 
    -0.00883557f, -0.02319487f, 0.00246093f, 0.03333243f, -0.04718231f, -0.03663332f, 0.03579653f, -0.00596950f, 
    -0.02945105f, 0.00555973f, 0.03211802f, -0.01153594f, 0.01092966f, 0.02542160f, -0.01584108f, 0.02148274f, 
    0.00071929f, -0.02962806f, 0.04540901f, -0.02240900f, -0.02491996f, -0.03550749f, 0.03813601f, 0.03134608f, 
    0.44613513f, -0.04971672f, -0.28228450f, -0.24003777f, -0.01268359f, -0.00590811f, -0.03614077f, -0.09666239f, 
    -0.22230005f, -0.24014300f, -0.07248054f, -0.20423387f, 0.18359901f, -0.10670110f, 0.10413191f, 0.21266930f, 
    -0.04804356f, 0.04571939f, -0.15838115f, -0.16128038f, 0.22902164f, 0.40476754f, 0.24361111f, 0.49322814f, 
    -0.43159959f, 0.38815799f, 0.36713380f, 0.14993134f, 0.22751831f, -0.07221282f, -0.14418051f, 0.31872687f, 
    -0.07192220f, 0.03958477f, 0.05531752f, -0.22834419f, 0.11174484f, -0.07507826f, 0.27616990f, 0.33649167f, 
    0.21719310f, 0.05124289f, -0.06884009f, 0.19931629f, 0.16400068f, -0.03763013f, -0.01441231f, -0.17963392f, 
    0.07702962f, -0.05780824f, 0.39225042f, 0.41970876f, -0.06141374f, 0.05012313f, -0.08666291f, 0.18810871f, 
    -0.21507873f, 0.03122017f, 0.00197283f, -0.04591421f, -0.29349554f, -0.30264059f, -0.41030428f, -0.59810394f, 
    0.09860498f, 0.25332102f, 0.02875691f, 0.14386268f, 0.12695356f, -0.02425463f, -0.06785928f, -0.08034660f, 
    0.21600279f, 0.02586590f, 0.11928862f, 0.40386066f, 0.12762754f, 0.01026174f, 0.04293026f, 0.08721460f, 
    0.15351482f, 0.03696422f, 0.05657475f, 0.32121795f, -0.25012878f, -0.08598661f, -0.03091218f, 0.14787139f, 
    -0.05068687f, 0.17676041f, -0.19341643f, 0.02644937f, -0.20234661f, -0.04936481f, -0.02676559f, -0.05480141f, 
    -0.02119232f, 0.00161175f, 0.00134970f, -0.37530395f, 0.00400992f, -0.33460250f, -0.06582274f, -0.05088679f, 
    -0.00356317f, -0.09742427f, -0.19582862f, 0.13332765f, -0.06341645f, -0.27086550f, -0.22931585f, -0.05866966f, 
    0.20640287f, -0.03267031f, 0.01489588f, 0.02725444f, -0.15830247f, -0.44308138f, -0.34390497f, -0.57253760f, 
    0.43320861f, 0.04871657f, 0.02776160f, 0.13865229f, 0.00064295f, 0.28649962f, -0.11731242f, -0.20535927f, 
    0.03639669f, 0.03112729f, -0.27998167f, -0.10837299f, -0.31233111f, -0.09623662f, -0.05270558f, -0.11227797f, 
    0.14426745f, 0.21406360f, -0.26239040f, 0.09469638f, 0.08866154f, -0.01938335f, 0.11866938f, -0.08800938f, 
    -0.24168912f, 0.27526957f, -0.07657398f, 0.10172386f, 0.12387059f, 0.01531666f, -0.07442293f, 0.11941588f, 
    -0.07616112f, -0.00044531f, 0.00340938f, -0.09910119f, -0.02353004f, -0.18053991f, -0.07123769f, 0.00866457f, 
    -0.02109681f, 0.06194798f, 0.11709177f, 0.19549416f, 0.14282535f, 0.30193877f, 0.14872195f, 0.09963015f, 
    0.26016381f, -0.17635240f, -0.11539192f, 0.00173308f, -0.28358847f, 0.10538589f, 0.12670666f, -0.01429776f, 
    0.00170654f, 0.11560730f, 0.24095824f, 0.25725982f, 0.09178217f, 0.29174903f, 0.10549713f, -0.40910152f, 
    -0.23605131f, -0.04976666f, 0.12626116f, -0.08284318f, -0.21907307f, -0.06321499f, 0.08048157f, 0.08230330f, 
    -0.03613330f, 0.43747538f, 0.32331058f, 0.20535624f, -0.12347259f, -0.19041643f, -0.04186457f, -0.12254044f, 
    -0.04617279f, -0.10681324f, 0.10605440f, 0.10098769f, -0.13208449f, -0.37690189f, -0.13434812f, 0.14524257f, 
    -0.04406539f, -0.08529303f, 0.09835029f, 0.03066819f, 0.14431213f, 0.06602438f, 0.06958296f, 0.23054875f, 
    -0.26806656f, 0.15886182f, 0.29322976f, 0.09882470f, 0.19795580f, 0.08743890f, 0.00774731f, 0.11870790f, 
    0.10880229f, -0.01170835f, -0.07897750f, -0.08360232f, -0.25396544f, -0.18083191f, 0.13379753f, 0.05772644f, 
    0.06728869f, -0.05815959f, -0.18117742f, 0.25886875f, 0.04455389f, 0.02072999f, 0.12080487f, 0.27705386f, 
    -0.17090632f, 0.23689672f, 0.44659892f, -0.17964292f, 0.09547916f, -0.08322970f, -0.06098846f, 0.02574130f, 
    -0.39258379f, -0.00962331f, -0.21354029f, -0.51450735f, -0.04314557f, 0.38288713f, 0.03983262f, 0.35205123f, 
    0.19327036f, 0.06129635f, -0.04281652f, -0.15515354f, 0.08803251f, -0.09117317f, 0.28453329f, 0.01744467f, 
    0.28104737f, 0.14857842f, -0.07361515f, 0.27121866f, 0.08380207f, -0.08146701f, -0.09757266f, -0.15325694f, 
    -0.29193446f, 0.07890856f, -0.43124801f, -0.11672631f, 0.33961883f, 0.10264926f, -0.11407340f, 0.12042398f, 
    0.05227292f, -0.17170075f, 0.11251984f, 0.25258636f, 0.20581916f, 0.16901197f, 0.21065147f, 0.07646576f, 
    0.11051746f, -0.12199955f, -0.00955531f, 0.13051529f, -0.05230441f, -0.00038699f, -0.05338662f, 0.05416203f, 
    0.14480300f, -0.05440274f, -0.05707588f, -0.15329599f, 0.34112743f, 0.20944323f, 0.29943463f, 0.47688821f, 
    -0.26291436f, -0.04468106f, -0.02931159f, -0.04824696f, 0.10415852f, -0.23388785f, -0.06277381f, 0.32731375f, 
    0.03771002f, 0.11656595f, -0.54845554f, -0.19462691f, -0.11133932f, -0.15772314f, -0.00310358f, -0.23711953f, 
    -0.12177491f, -0.03723082f, -0.14612755f, -0.08390529f, -0.26928556f, -0.37754044f, 0.21654570f, 0.35931581f, 
    0.04259704f, 0.15338910f, -0.05174836f, -0.27545702f, 0.02041036f, 0.08755827f, -0.15124567f, -0.03493381f, 
    0.02601939f, 0.01599943f, 0.06425324f, 0.11915909f, 0.07234453f, 0.00005891f, -0.14221650f, -0.08901400f, 
    -0.53522485f, -0.34096175f, -0.33188289f, -0.64558709f, 0.23892277f, -0.06156562f, -0.15743434f, 0.04696768f, 
    -0.02652136f, 0.14211313f, 0.03418850f, -0.00250286f, 0.45729014f, 0.13819757f, 0.20106702f, 0.29210705f, 
    0.42974180f, -0.11495347f, -0.16866621f, -0.06139338f, -0.12319765f, -0.06233200f, 0.10049858f, 0.01913534f, 
    -0.00542877f, 0.14181346f, 0.11747423f, 0.08255577f, -0.37126133f, 0.42916831f, -0.08004200f, 0.30609044f, 
    0.01463909f, 0.18800557f, -0.09913089f, -0.19722332f, 0.14252767f, -0.00408254f, 0.12126396f, 0.04783812f, 
    -0.30074519f, 0.26782200f, -0.27368513f, 0.32324171f, -0.07345133f, 0.10453804f, 0.11347155f, 0.06679834f, 
    0.01397978f, -0.20211275f, 0.04788418f, -0.06122074f, 0.18668805f, 0.18077490f, 0.15131192f, 0.06701086f, 
    -0.06733076f, -0.07027330f, -0.03564981f, -0.07126830f, 0.06039547f, 0.02918541f, 0.09993285f, 0.10079262f, 
    -0.25265086f, -0.04572288f, -0.52035409f, -0.29417184f, -0.04621654f, 0.00690301f, -0.16805255f, 0.20606621f, 
    0.11060365f, 0.00011790f, 0.00147670f, -0.06886476f, -0.15603383f, 0.17349684f, 0.15363595f, 0.10266275f, 
    -0.09221844f, -0.10381977f, 0.10234712f, -0.01825618f, -0.04650449f, -0.01908084f, -0.05613898f, -0.07392512f, 
    -0.04991430f, 0.01280459f, 0.15412153f, -0.02549663f, 0.05477188f, 0.21327344f, 0.04257916f, 0.05801883f, 
    0.05976244f, -0.00635771f, 0.00374736f, -0.02488757f, 0.05495527f, 0.07428703f, -0.02329365f, -0.02702596f, 
    0.06179729f, 0.01483273f, 0.07735018f, -0.08555923f, -0.08645144f, -0.20871863f, 0.11543725f, 0.24208644f, 
    -0.09270421f, 0.26451343f, 0.22505914f, 0.15298292f, -0.10531375f, -0.05220250f, 0.10472574f, 0.13084570f, 
    0.00306464f, -0.05670748f, 0.00987771f, 0.03754501f, 0.46988356f, -0.88876379f, 0.00609953f, 0.25909501f, 
    -0.10430651f, 0.08451559f, 0.05231025f, 0.11411463f, -0.04315259f, -0.02177207f, 0.09495459f, -0.07359509f, 
    0.07264673f, -0.02639096f, 0.10524213f, 0.03693319f, 0.06363625f, -0.11773672f, 0.04314798f, 0.04341802f, 
    0.08321232f, -0.09160611f, 0.18573622f, -0.00016850f, 0.10126503f, -0.02698247f, 0.04538810f, -0.03437112f, 
    0.09402835f, -0.02100950f, 0.05115419f, -0.05431394f, 0.10253154f, -0.04548630f, 0.07486844f, -0.00587014f, 
    0.05034259f, 0.40154973f, -0.56901103f, 0.13042340f, -0.01703338f, 0.09944671f, -0.07706288f, -0.10537007f, 
    0.07859794f, -0.12542239f, -0.01046487f, 0.17107330f, -0.06197419f, -0.00113035f, -0.14770232f, 0.01347640f, 
    0.00494297f, -0.08151492f, 0.08072779f, -0.02218359f, 0.05857879f, 0.00601688f, 0.00966816f, -0.00877288f, 
    0.13223568f, 0.29537323f, -0.10271399f, 0.00593545f, 0.09740671f, 0.00270747f, -0.01556055f, 0.09968583f, 
    0.15513010f, -0.06357281f, -0.03337925f, -0.03494222f, 0.23952837f, -0.18775906f, 0.05303476f, 0.35269549f, 
    -0.28056037f, -0.02781714f, -0.01359660f, 0.02652763f, 0.23474681f, 0.12340136f, -0.18350729f, 0.17372888f, 
    0.12057833f, -0.23205684f, 0.27095056f, -0.08459858f, -0.01079419f, -0.17053017f, 0.05121393f, -0.10111181f, 
    0.23494819f, -0.00272125f, -0.00830965f, 0.04645043f, 0.60237551f, 0.08489967f, 0.05190202f, -0.03445251f, 
    -0.08732107f, -0.03681923f, 0.08247995f, 0.06345077f, 0.00754052f, 0.11991625f, -0.10858991f, -0.00601008f, 
    0.21147124f, 0.38361880f, 0.15740372f, -0.30096042f, -0.09031614f, -0.01043448f, 0.09631781f, -0.04228560f, 
    0.01919045f, -0.18688396f, 0.06192955f, 0.12806433f, -0.42613488f, -0.00239401f, -0.19753157f, 0.08436184f, 
    -0.02443925f, -0.06078421f, -0.03537515f, -0.00881556f, -0.04857465f, -0.12311401f, -0.04873174f, -0.04435541f, 
    0.37294507f, -0.47426376f, 0.50384825f, -0.57438439f, 0.26244619f, 0.04014980f, 0.09831009f, 0.15263024f, 
    0.09842967f, 0.03734921f, -0.00957139f, -0.01905346f, -0.09611910f, 0.15682799f, 0.10884330f, -0.14229141f, 
    -0.04331230f, 0.01392205f, -0.05402914f, 0.01415421f, -0.02527231f, -0.04051223f, -0.02961276f, 0.00363466f, 
    0.12704295f, -0.05708820f, 0.04766902f, -0.31095684f, 0.12423796f, 0.14664978f, 0.00533708f, 0.04566878f, 
    0.14069211f, -0.10922591f, 0.24225262f, -0.12132917f, -0.13930413f, -0.04257531f, -0.34390932f, 0.20427978f, 
    0.03176662f, -0.09911319f, 0.02679203f, -0.12242925f, 0.22409138f, 0.13798892f, -0.19816118f, -0.00049049f, 
    0.42506969f, -0.07727517f, 0.17896385f, -0.02252640f, -0.16269168f, 0.10417160f, -0.02037922f, 0.01278009f, 
    0.06674226f, 0.00213301f, 0.19819573f, 0.09250700f, -0.07273266f, 0.18719122f, -0.11437711f, 0.22592221f, 
    0.21597686f, 0.02386125f, 0.05506932f, 0.04374166f, 0.04940771f, -0.08356739f, 0.02208921f, 0.01893445f, 
    -0.18872172f, 0.01502468f, -0.05174969f, 0.03556216f, -0.08563114f, -0.03201251f, 0.05562077f, 0.12274636f, 
    0.10425946f, 0.07320560f, -0.00697330f, 0.01453585f, -0.13448906f, 0.18104865f, 0.14972822f, 0.02039414f, 
    -0.10857910f, -0.17566189f, 0.20032026f, -0.05793585f, 0.05019219f, -0.09575551f, -0.00339896f, 0.00557891f, 
    0.06124580f, 0.00424676f, 0.06248836f, 0.23839162f, 0.08627687f, 0.05936440f, 0.09189774f, 0.01123813f, 
    0.16569029f, 0.27220982f, -0.09306759f, 0.01241711f, -0.16832280f, -0.22120115f, 0.18372148f, -0.07833015f, 
    -0.03999846f, -0.04976912f, 0.02244649f, 0.05918809f, 0.13081853f, -0.04055039f, 0.11094151f, -0.04307326f, 
    0.11673825f, -0.09874231f, 0.03244315f, 0.05715057f, -0.04132221f, 0.01827608f, 0.06699788f, 0.06602780f, 
    -0.00562186f, -0.20160735f, 0.00578465f, 0.02633109f, -0.04215147f, 0.24894983f, -0.22477241f, 0.20341478f, 
    0.06519955f, -0.05384430f, -0.05545983f, -0.03431014f, 0.03478660f, -0.00166979f, 0.01949182f, 0.07375664f, 
    0.36261371f, -0.40193149f, 0.31803772f, 0.22814733f, -0.17316729f, -0.05574013f, 0.00184832f, 0.02607601f, 
    0.35376000f, 0.27740273f, 0.14576165f, 0.04881620f, -0.28822213f, 0.36277729f, -0.57546312f, 0.00636569f, 
    -0.07802527f, 0.01335117f, -0.05217924f, -0.02848331f, 0.13061666f, 0.04113838f, 0.11921573f, -0.00620476f, 
    -0.28113514f, 0.02577694f, 0.11701856f, 0.12972972f, 0.06069921f, 0.11820922f, 0.04200232f, -0.07913384f, 
    0.04001122f, -0.02152743f, 0.03383096f, -0.06569333f, -0.19166033f, 0.33456782f, 0.07844014f, 0.15648763f, 
    -0.00311598f, -0.06234756f, -0.02341487f, -0.05238432f, -0.02979261f, -0.06781302f, 0.15601639f, 0.10996637f, 
    -0.00807893f, -0.08403410f, -0.06674930f, 0.14814758f, -0.17671013f, 0.03054936f, -0.13044672f, -0.09962205f, 
    0.08281817f, -0.20731865f, -0.12212194f, 0.11501309f, 0.11818861f, 0.30889243f, 0.32348672f, 0.20194839f, 
    -0.05603910f, 0.15105186f, 0.18751967f, 0.19078436f, -0.02750502f, 0.07882904f, 0.08249221f, 0.02378406f, 
    -0.27967858f, 0.06670190f, -0.40326604f, -0.07951329f, -0.02611947f, 0.12008809f, 0.00343586f, -0.07204537f, 
    0.01288205f, -0.09465693f, -0.10837251f, -0.13356520f, -0.04907119f, -0.13083610f, -0.03559948f, -0.11222876f, 
    -0.05296730f, -0.02841353f, -0.03464686f, -0.00495366f, 0.10392144f, 0.20325445f, 0.15649401f, 0.05603057f, 
    -0.11046205f, 0.23699301f, 0.38888201f, 0.16287699f, 0.09126834f, 0.05511858f, -0.06178061f, 0.07526872f, 
    0.13966163f, 0.25683942f, 0.18297739f, 0.08152147f, -0.49134082f, -0.40419826f, 0.30042163f, 0.41284657f, 
    0.03451820f, 0.21729042f, 0.19953072f, 0.01261101f, -0.00098430f, -0.07689175f, -0.04208125f, 0.01721775f, 
    -0.16695419f, -0.18728667f, -0.19980478f, 0.22191985f, -0.06796434f, 0.03355302f, -0.00469409f, -0.06754333f, 
    -0.03149656f, -0.00859432f, -0.03137868f, 0.14091589f, -0.09933117f, -0.10715017f, -0.11142389f, -0.02081286f, 
    0.11771730f, 0.04796382f, 0.01210573f, 0.05750352f, 0.11495534f, 0.04819177f, 0.03417231f, 0.04036675f, 
    -0.27642137f, 0.33264336f, -0.16025400f, 0.00879435f, -0.09750759f, -0.15147631f, 0.28804463f, 0.15147191f, 
    0.16031237f, -0.14502288f, 0.18338224f, -0.03144091f, -0.13940363f, -0.12980147f, -0.17546827f, 0.02821505f, 
    -0.08623526f, 0.03003530f, -0.08709113f, -0.09340615f, 0.00661026f, -0.00112639f, -0.06808835f, -0.05331774f, 
    0.23022902f, -0.19891803f, -0.22327705f, -0.11403930f, -0.11269501f, -0.09465844f, -0.03216622f, -0.14899579f, 
    -0.07529303f, 0.09463871f, -0.14934175f, -0.00038019f, 0.09104263f, 0.06436198f, 0.15587817f, 0.17329963f, 
    -0.21763042f, -0.07944261f, -0.07845910f, -0.21457924f, 0.07505991f, 0.04924700f, -0.05746335f, 0.06271750f, 
    -0.25937682f, 0.14048204f, 0.04981187f, 0.09276845f, 0.08158309f, -0.15623908f, -0.02313648f, -0.03932660f, 
    0.03936821f, -0.06791236f, -0.07883608f, 0.30502334f, -0.03067004f, 0.02043823f, 0.22180039f, 0.26102567f, 
    0.03504954f, -0.07487863f, 0.02782406f, -0.05368172f, -0.15940168f, 0.06849156f, -0.09180555f, 0.02810038f, 
    0.73202604f, 0.41104713f, 0.41915551f, -0.12564084f, 0.00340421f, -0.10341667f, 0.01847604f, 0.13266835f, 
    0.03849996f, 0.10319497f, 0.02263655f, 0.13737072f, 0.10134888f, 0.14390026f, -0.07600587f, 0.09616953f, 
    0.28416908f, -0.14583696f, -0.07644350f, -0.06309778f, 0.14018221f, 0.17016026f, 0.06847470f, 0.13860075f, 
    0.11572719f, -0.24422631f, -0.10064900f, -0.03642127f, -0.11346485f, 0.03809176f, -0.06117518f, 0.05338512f, 
    0.00681854f, -0.08233240f, -0.07312681f, -0.09555846f, 0.06432238f, 0.27924639f, 0.25097212f, 0.44872591f, 
    0.17847319f, -0.01233703f, 0.04022059f, 0.08505479f, 0.03588752f, 0.13582569f, 0.06399576f, 0.09137538f, 
    0.06833206f, -0.24291889f, -0.30802909f, 0.14545104f, -0.00322689f, 0.00116863f, 0.06515717f, -0.05619175f, 
    -0.06598653f, -0.12340145f, -0.07310409f, 0.03721493f, 0.41178587f, -0.14613800f, 0.09834207f, -0.33131498f, 
    0.07150666f, -0.03973489f, 0.22699724f, 0.21944939f, 0.00429411f, -0.14661005f, 0.02372186f, 0.01258622f, 
    0.03739113f, 0.42702374f, 0.08169538f, 0.12627891f, -0.05489327f, 0.10124426f, 0.01095067f, -0.03975730f, 
    0.03046421f, 0.02221858f, 0.13173647f, 0.03396688f, -0.06414665f, -0.22198169f, -0.13910609f, -0.07230444f, 
    -0.13779995f, 0.00135161f, -0.01412410f, -0.03893093f, 0.05934643f, -0.06079127f, 0.02263834f, 0.03110482f, 
    0.10250085f, 0.38842386f, 0.41417390f, 0.32780150f, -0.02657768f, 0.02373530f, 0.18319957f, 0.14538999f, 
    0.03245248f, 0.05397981f, 0.04168986f, -0.01957073f, 0.45666200f, 0.67585373f, 0.36294305f, 0.26081690f, 
    0.02355591f, -0.01859024f, 0.02324327f, 0.06425302f, -0.02100932f, -0.00509633f, 0.12484518f, -0.07708012f, 
    -0.00656704f, 0.02061344f, 0.20111190f, 0.01268518f, 0.15836133f, 0.00334216f, 0.02863218f, -0.01816816f, 
    -0.04127102f, 0.08315971f, -0.00654298f, -0.07561937f, -0.09749570f, 0.12139180f, -0.13914591f, -0.05177071f, 
    0.12539721f, -0.06226713f, 0.08914223f, -0.02264404f, 0.00288406f, -0.03587716f, 0.00066578f, 0.02516196f, 
    0.19952023f, 0.15363881f, 0.08896193f, 0.08630560f, 0.10911501f, 0.09388361f, 0.14103240f, 0.05096302f, 
    -0.08246417f, -0.04717854f, -0.04116534f, -0.04302881f, -0.05335880f, -0.01715511f, -0.29903990f, -0.01295543f, 
    -0.02028207f, -0.01741378f, -0.06783418f, 0.00440236f, -0.01029386f, -0.08579530f, 0.09743121f, -0.06441668f, 
    -0.01584489f, -0.11191176f, 0.87981576f, 0.28461424f, 0.13883947f, -0.02166367f, -0.15471964f, -0.06202743f, 
    -0.04930921f, -0.02030740f, 0.05387818f, -0.08792888f, 0.39615753f, 0.09223877f, -0.19468617f, -0.56969196f, 
    0.04289815f, -0.26526201f, -0.04301328f, 0.15066953f, 0.14235859f, 0.13059728f, 0.03712698f, 0.02715043f, 
    -0.05144295f, -0.02579257f, -0.03558428f, -0.01322473f, 0.01437052f, -0.03126050f, -0.04521120f, -0.01628136f, 
    -0.01294051f, -0.02229534f, 0.00435727f, 0.01420152f, -0.05383731f, -0.01611947f, 0.02811567f, 0.03718276f, 
    -0.03277459f, -0.02034131f, -0.04688245f, -0.03732616f, -0.04052966f, -0.01332091f, 0.00432583f, -0.01257847f, 
    0.02306488f, 0.00483104f, 0.01181767f, 0.01754190f, 0.02639330f, 0.02735839f, 0.03964144f, 0.01029723f, 
    -0.05085043f, -0.02277610f, 0.00821171f, 0.01051119f, -0.02029500f, 0.03426297f, 0.04239316f, 0.03968280f, 
    0.02557979f, -0.02639794f, 0.01086659f, -0.03870258f, 0.02532165f, 0.00594031f, -0.00267773f, -0.05427400f, 
    0.02102653f, -0.05936261f, -0.05261564f, -0.03467547f, 0.03494522f, -0.04887133f, -0.00444022f, -0.03441392f, 
    0.03129764f, -0.03963397f, -0.01810461f, -0.03522050f, 0.03712618f, -0.04215520f, -0.04752670f, 0.03385018f, 
    0.03973313f, -0.00911837f, -0.02231094f, -0.05738157f, -0.01242986f, 0.00138304f, 0.00322122f, -0.03537846f, 
    -0.04888023f, -0.01986896f, -0.02358509f, 0.02059163f, -0.00345805f, 0.03437386f, -0.01054061f, -0.05328990f, 
    0.02274151f, 0.02034767f, 0.03920471f, -0.01917616f, 0.01616516f, -0.02264849f, 0.01514381f, -0.03900570f, 
    0.04372488f, 0.03659735f, -0.04947213f, 0.03681648f, -0.02798054f, -0.04200139f, 0.02107390f, 0.02030677f, 
    -0.02731919f, -0.04502944f, 0.02067905f, -0.01884355f, -0.03393561f, 0.03373690f, 0.03060114f, 0.03195230f, 
    0.01922930f, 0.00358269f, 0.04112028f, 0.02175712f, -0.02252284f, 0.00104722f, 0.04172440f, 0.00650337f, 
    -0.01788778f, 0.02260077f, 0.04441559f, -0.05268875f, -0.02862619f, -0.05342382f, -0.00792619f, 0.03359695f, 
    0.01579279f, -0.03526942f, -0.00506301f, -0.01817537f, -0.04533087f, -0.02160767f, 0.00582399f, 0.01192137f, 
    0.01945123f, -0.03954739f, 0.00550094f, -0.05766726f, 0.03091556f, -0.00624626f, -0.01030488f, 0.01812783f, 
    -0.05197364f, -0.02981853f, -0.01750972f, 0.03942923f, 0.02601831f, -0.05487604f, -0.04519895f, -0.04875859f, 
    0.03391155f, -0.04836387f, 0.00255674f, 0.03282561f, 0.00377747f, 0.03781852f, -0.05476297f, 0.03933406f, 
    0.01320170f, -0.05224238f, -0.04951898f, -0.02139644f, -0.04709148f, 0.04002439f, -0.04939039f, -0.00309768f, 
    -0.04008206f, 0.03302765f, -0.03565089f, 0.00714590f, -0.01500652f, 0.03804790f, 0.02922504f, -0.00928716f, 
    0.00728573f, -0.01303526f, -0.05391436f, 0.02354779f, -0.03929502f, -0.02726208f, 0.02110086f, 0.01956163f, 
    -0.05619094f, 0.01639980f, 0.03008780f, 0.02896800f, -0.04339185f, -0.04986551f, 0.00129139f, 0.00857108f, 
    0.01093015f, -0.02711852f, 0.02465338f, -0.02308637f, -0.02981427f, 0.04348207f, 0.03601995f, -0.03155882f, 
    0.04210591f, 0.00464997f, -0.01703453f, 0.00354575f, -0.02026181f, 0.00181888f, -0.02421991f, -0.04579360f, 
    -0.02394887f, -0.04245839f, -0.00814606f, 0.01077460f, -0.00185844f, 0.01235471f, 0.00627115f, 0.01511286f, 
    0.01805494f, 0.03279333f, -0.01800325f, -0.04946086f, -0.03286262f, -0.02835740f, 0.02178819f, 0.01397883f, 
    -0.01754149f, -0.00298412f, -0.00251227f, -0.05635249f, -0.02621747f, -0.00621562f, 0.04113564f, -0.05565714f, 
    -0.04068053f, -0.03234113f, -0.00551403f, 0.01331596f, -0.02098191f, 0.03173976f, -0.00720803f, 0.00976690f, 
    0.00144230f, -0.05873280f, -0.00367057f, -0.01010764f, 0.00866911f, -0.02715139f, -0.01755578f, 0.03772496f, 
    0.01673734f, -0.02581904f, -0.04152721f, 0.02501753f, -0.03332847f, -0.03091904f, 0.02481837f, 0.02102307f, 
    0.01672260f, -0.00462510f, 0.01319906f, 0.01079126f, -0.03740518f, -0.01215524f, 0.01260850f, -0.04273681f, 
    -0.03901846f, -0.05649685f, -0.03629968f, -0.05217216f, -0.04036014f, -0.02362474f, -0.01245844f, 0.01291013f, 
    0.01480760f, -0.01268571f, -0.03574350f, 0.02754989f, 0.03856653f, -0.00303495f, -0.02161907f, 0.03816649f, 
    0.00587453f, 0.02310931f, -0.02755413f, -0.04259628f, -0.04919639f, 0.01532073f, 0.02249411f, 0.01089238f, 
    0.01124570f, -0.03233537f, -0.04901874f, -0.02874245f, 0.03070555f, 0.00708257f, -0.01827041f, -0.00004506f, 
    -0.01307476f, 0.01616376f, -0.05449022f, 0.00028308f, -0.03335311f, 0.01312227f, 0.01754036f, 0.03981728f, 
    0.00233139f, -0.00908026f, -0.02288616f, 0.04296390f, 0.01465132f, 0.04272306f, -0.03714180f, 0.00667548f, 
    -0.04719486f, -0.05602401f, 0.03763705f, -0.03070163f, 0.01366225f, -0.02510615f, -0.00625277f, -0.01493679f, 
    -0.01572359f, -0.00011572f, -0.02170570f, 0.03109969f, 0.03225382f, -0.01899508f, -0.02150321f, 0.04457998f, 
    -0.04546048f, 0.04277965f, 0.02249398f, -0.00192512f, 0.01809913f, -0.01040795f, -0.00092627f, -0.03605696f, 
    0.00822316f, 0.02654438f, -0.04545384f, -0.05038954f, 0.01404364f, -0.00760097f, -0.04140547f, -0.04698829f, 
    -0.03252012f, 0.02506631f, -0.05079900f, -0.05598583f, -0.04030975f, -0.03437198f, -0.01125446f, -0.03186198f, 
    0.01326575f, -0.00046952f, 0.00617344f, -0.01738717f, -0.05055330f, -0.04208435f, 0.02891240f, 0.01444262f, 
    0.00631652f, -0.03413719f, -0.02622256f, 0.02994280f, -0.04796696f, -0.03468278f, 0.03799192f, -0.05486123f, 
    -0.05367051f, -0.03553440f, 0.03503736f, 0.02825812f, -0.04676301f, 0.02988549f, -0.03555746f, 0.01064683f, 
    0.03660966f, -0.01408875f, -0.01623623f, -0.03378821f, -0.00475370f, 0.02748277f, -0.05874535f, -0.05261919f, 
    -0.00317282f, -0.04861505f, -0.03203077f, -0.01534784f, 0.00758444f, 0.02259340f, 0.03610718f, -0.01709479f, 
    0.49516457f, -0.07053552f, -0.09962618f, -0.10205191f, -0.08233618f, 0.00153466f, 0.02319455f, -0.22580877f, 
    -0.00460975f, 0.18505496f, 0.00469131f, 0.01343638f, -0.29819992f, 0.26504365f, -0.16241866f, -0.10299571f, 
    -0.07598879f, 0.01357249f, -0.08420814f, 0.08125153f, 0.09853542f, 0.12224115f, -0.11416803f, -0.02985147f, 
    -0.20553356f, 0.07240831f, 0.23305199f, -0.15056196f, -0.03370290f, -0.03121552f, 0.02631698f, -0.10569974f, 
    -0.04601899f, -0.05272079f, -0.05516177f, 0.03913837f, -0.27665430f, -0.44749093f, -0.24002461f, 0.04213936f, 
    0.04135912f, 0.02284230f, -0.07276421f, 0.00257443f, -0.04017237f, -0.03344376f, -0.02237229f, -0.09394560f, 
    -0.17854676f, 0.24854247f, -0.43508583f, -0.19219124f, -0.02751373f, -0.12449316f, -0.02326619f, -0.02154433f, 
    -0.03158142f, -0.07743063f, 0.05711766f, -0.11354501f, -0.01872926f, 0.10146508f, 0.09121853f, 0.04655583f, 
    0.03940666f, 0.00097229f, 0.00236519f, 0.02936704f, 0.04238473f, 0.24225193f, 0.04962193f, -0.01998427f, 
    -0.14461587f, 0.15727131f, 0.05610716f, 0.06034485f, -0.06949843f, 0.10421795f, 0.09820276f, 0.14437112f, 
    -0.13736109f, 0.10259516f, 0.09449010f, 0.04563284f, -0.47030947f, 0.68015212f, -0.47959182f, 0.35283649f, 
    -0.15404052f, -0.03550409f, -0.10267029f, -0.05664348f, 0.06050338f, 0.00050619f, -0.03287840f, 0.08985204f, 
    -0.03566247f, 0.03886103f, 0.15664588f, 0.15908310f, -0.06948240f, -0.03525386f, -0.03616019f, -0.00173624f, 
    0.03400527f, 0.07338702f, -0.18053642f, 0.04583283f, -0.03226101f, 0.03471322f, 0.05902578f, -0.05863899f, 
    0.21243860f, -0.02801029f, -0.11035781f, -0.08869562f, -0.08192227f, 0.04617416f, -0.08938056f, 0.01313659f, 
    -0.13893045f, 0.21046180f, -0.31853306f, -0.21304573f, 0.08796189f, 0.02182610f, 0.06147917f, 0.05760609f, 
    -0.00244291f, 0.04101472f, 0.09789386f, -0.01706095f, -0.23957932f, 0.00615714f, 0.09623038f, 0.07715654f, 
    -0.07709660f, -0.01396918f, 0.09182725f, -0.15665993f, 0.11069487f, -0.04258491f, -0.17727901f, -0.03826550f, 
    -0.04014229f, -0.06930692f, 0.33588505f, -0.16734789f, 0.00407623f, -0.16472171f, -0.04456054f, -0.13888143f, 
    -0.17161837f, 0.17693593f, -0.08441730f, -0.01496009f, 0.23358795f, 0.05876321f, -0.04154808f, 0.16106004f, 
    -0.04145754f, 0.08827223f, 0.05162358f, 0.05261311f, 0.06739134f, 0.07757835f, 0.19025512f, -0.03986666f, 
    0.05195509f, 0.13227491f, -0.09985758f, -0.23163664f, -0.01548443f, 0.01555604f, 0.05723760f, 0.16188116f, 
    0.01498109f, -0.05259723f, -0.01261548f, -0.06527559f, -0.00510130f, 0.13422281f, 0.24381076f, -0.15829943f, 
    -0.03194166f, 0.03189816f, 0.03845539f, 0.00882808f, -0.01776237f, -0.05902288f, 0.25446469f, 0.11599304f, 
    -0.02781118f, 0.41024032f, 0.33352050f, 0.24771813f, 0.02602633f, -0.10183308f, 0.20387267f, 0.13348259f, 
    0.15662557f, 0.18257704f, 0.10786686f, 0.09430836f, 0.29059672f, -0.23988758f, -0.14987367f, 0.12079635f, 
    0.11139791f, 0.02776522f, -0.09400225f, -0.11309753f, -0.06493574f, 0.07918657f, 0.08696288f, 0.19285426f, 
    -0.21811512f, 0.15865029f, 0.08145352f, 0.45836282f, 0.06493128f, 0.03960603f, -0.00922538f, 0.00478240f, 
    -0.12593089f, -0.08818833f, 0.00805195f, -0.14333150f, -0.17943679f, -0.21387102f, -0.05854237f, 0.30256104f, 
    -0.11152364f, -0.02142262f, 0.12504458f, 0.01092382f, -0.01197743f, 0.05270358f, 0.08954038f, 0.01816615f, 
    -0.32841825f, 0.13008906f, 0.04227301f, 0.12746559f, 0.06809001f, -0.15949473f, 0.08925559f, -0.12417505f, 
    -0.02631929f, -0.01428982f, -0.15668799f, 0.08513644f, 0.32314399f, -0.23991010f, 0.25705066f, -0.38480836f, 
    0.12340453f, 0.10534023f, 0.17055151f, 0.04116597f, -0.04877714f, -0.07558795f, 0.10423681f, 0.04414931f, 
    -0.13451974f, 0.02899219f, 0.02853626f, 0.18051891f, 0.01330936f, -0.11978592f, 0.26414588f, 0.14058648f, 
    -0.01210022f, 0.03074989f, 0.07529478f, -0.06902073f, 0.02947373f, -0.01991107f, 0.17299721f, -0.04231855f, 
    -0.07835109f, -0.05261495f, -0.02882819f, -0.11788237f, -0.03398309f, 0.05930830f, 0.02323119f, -0.10940021f, 
    -0.23083831f, -0.33489671f, -0.08660731f, 0.16445947f, -0.08626057f, -0.07236262f, -0.18894444f, -0.07449787f, 
    -0.13574132f, -0.16486624f, -0.06050470f, -0.16139029f, 0.08427040f, 0.40332767f, 0.40853512f, 0.53418863f, 
    -0.05264064f, 0.12703180f, 0.09313022f, 0.07878857f, -0.06187895f, -0.01120065f, 0.03518993f, 0.02454627f, 
    0.16490819f, 0.09955140f, 0.15224059f, 0.16880837f, 0.06293255f, -0.06427974f, 0.02354358f, 0.04812645f, 
    0.05533151f, 0.02833235f, 0.21690309f, 0.04363958f, 0.01185049f, 0.02335184f, -0.13671575f, 0.17455374f, 
    0.07987983f, 0.13723224f, -0.02989999f, -0.09319092f, 0.04829636f, -0.08037891f, 0.13022728f, 0.16749363f, 
    -0.06131956f, 0.17542878f, 0.05142768f, -0.04763079f, 0.12428796f, -0.14609824f, -0.15707214f, 0.00426282f, 
    -0.16418384f, 0.15214239f, 0.06719615f, 0.05632533f, 0.16700046f, -0.03612672f, -0.07747670f, -0.11245263f, 
    -0.05123082f, 0.06505659f, -0.05243777f, -0.11200291f, 0.13951419f, 0.06465998f, 0.01711780f, -0.02621186f, 
    0.11740986f, -0.15942071f, 0.29669309f, -0.10420379f, 0.02133327f, -0.02282779f, 0.07595333f, 0.09923065f, 
    -0.01762438f, 0.07435239f, -0.02138459f, -0.00107187f, 0.73601687f, -0.21955982f, -0.05245530f, -0.03947912f, 
    0.03013412f, -0.06313202f, -0.10649596f, 0.12877159f, 0.03216400f, 0.13526127f, -0.00774685f, 0.00004695f, 
    -0.01299038f, -0.08997834f, 0.36807147f, -0.12745795f, -0.04326396f, 0.11317120f, 0.19383797f, 0.08667028f, 
    -0.02959307f, 0.07217265f, 0.18509458f, -0.00634872f, -0.17282820f, -0.04262948f, -0.16152300f, -0.07569275f, 
    -0.04397883f, -0.07454181f, -0.05959083f, -0.05472653f, -0.00970632f, -0.03834912f, 0.00255640f, 0.15615050f, 
    -0.05524154f, 0.22475716f, 0.55858618f, -0.23625833f, -0.09309498f, -0.13222209f, -0.18486786f, -0.10346610f, 
    0.02017269f, -0.10958376f, 0.12441574f, 0.15237468f, 0.08445527f, 0.09225143f, 0.12336020f, 0.09196395f, 
    0.06587902f, 0.21476698f, -0.17061837f, 0.01556674f, -0.01837495f, -0.05501840f, -0.02516685f, -0.08773434f, 
    -0.20631342f, 0.26735759f, 0.45187524f, -0.04692232f, 0.06140410f, 0.08656568f, -0.09705639f, 0.06092682f, 
    -0.06104870f, -0.17057922f, -0.03948609f, -0.11774906f, 0.00009977f, -0.06600899f, 0.18156217f, -0.02190820f, 
    -0.12768595f, -0.01003533f, -0.09639286f, 0.10675757f, 0.00575870f, 0.04459594f, -0.05305535f, -0.03423088f, 
    0.27355999f, -0.05852031f, -0.19958086f, -0.07684465f, -0.05704788f, 0.01236846f, -0.15742113f, 0.12769325f, 
    -0.11120729f, 0.06800188f, 0.03537855f, 0.11280692f, -0.23638968f, 0.17317979f, 0.26172236f, -0.10196275f, 
    -0.06865682f, 0.04870024f, 0.18967098f, -0.00773796f, -0.01572785f, -0.06915398f, -0.05541991f, -0.02555076f, 
    0.01019813f, 0.23222955f, -0.08036667f, 0.06138484f, -0.08579002f, -0.08245433f, 0.01043323f, 0.01830890f, 
    -0.05148980f, 0.12283877f, -0.01283941f, 0.04942732f, -0.00055439f, 0.01594328f, -0.01089732f, 0.09543552f, 
    -0.07624026f, -0.03131148f, 0.02680618f, 0.05981397f, -0.17672125f, -0.08708496f, -0.02194855f, -0.06853210f, 
    -0.04596889f, -0.17727233f, 0.16346925f, 0.17043458f, 0.03705828f, -0.06896311f, 0.37206453f, 0.16868851f, 
    0.04702129f, -0.00525121f, -0.07592507f, -0.15576272f, 0.14437182f, 0.05268606f, 0.01590221f, -0.06711211f, 
    -0.17531875f, -0.08677880f, -0.31199485f, 0.11613321f, -0.02409586f, 0.13404049f, -0.09074430f, 0.09452824f, 
    0.24968059f, 0.02360751f, -0.04992611f, -0.05970064f, -0.03678711f, -0.05773047f, -0.07599851f, -0.08850268f, 
    -0.08950461f, 0.16161244f, -0.09453309f, 0.06272627f, 0.05837709f, 0.20654671f, 0.06672849f, 0.00286547f, 
    -0.00086947f, 0.21840784f, 0.09736181f, -0.01045836f, 0.02915690f, 0.11364999f, -0.11085613f, 0.02371777f, 
    -0.18541563f, 0.18891311f, -0.04858707f, 0.07269651f, 0.03872582f, 0.00444700f, 0.07381184f, -0.09121485f, 
    -0.01321069f, 0.10141616f, 0.01185291f, 0.23555200f, -0.01390858f, -0.23536777f, -0.02927684f, 0.17332889f, 
    0.01260332f, -0.03964279f, 0.26159021f, 0.07533714f, -0.14608386f, 0.14456423f, -0.07654922f, 0.16705523f, 
    0.06619526f, -0.16625570f, -0.06956136f, 0.01433098f, -0.06283224f, 0.01742972f, 0.02207018f, -0.13685252f, 
    -0.15690161f, -0.09360069f, -0.04431407f, 0.01809796f, 0.34896815f, 0.31106651f, 0.01047303f, 0.15680939f, 
    0.16708103f, 0.19970344f, -0.05785430f, 0.09900133f, -0.00197350f, -0.01754495f, -0.13243851f, 0.03104427f, 
    0.16239476f, 0.27561021f, -0.22748199f, 0.15057760f, -0.05357064f, -0.00770160f, 0.13186133f, -0.04959952f, 
    -0.02137646f, -0.01728877f, 0.05588636f, 0.06969327f, 0.29254085f, 0.18127701f, 0.14545299f, 0.23270549f, 
    0.20035218f, 0.13191406f, -0.02285278f, 0.14896858f, -0.08464544f, -0.18692581f, 0.02509753f, 0.03339972f, 
    0.14379561f, 0.29175591f, -0.04476453f, -0.02986300f, -0.06216063f, 0.00494360f, 0.01179842f, -0.00542719f, 
    0.02260201f, 0.09088042f, -0.15690620f, 0.04558563f, 0.14153726f, -0.38714793f, 0.66171920f, -0.11665217f, 
    0.11860543f, 0.10936276f, -0.14651731f, -0.13888273f, -0.00382013f, -0.13538083f, 0.16406836f, 0.03918901f, 
    -0.02316623f, 0.12173126f, -0.25841969f, 0.18772618f, 0.11091768f, 0.12421142f, 0.12375379f, -0.06404325f, 
    -0.06664190f, 0.11288410f, -0.14360310f, -0.06023947f, 0.15667477f, -0.08347483f, -0.25408861f, -0.19551091f, 
    -0.11921722f, -0.09802487f, -0.07491553f, 0.09508377f, 0.07168434f, 0.06208866f, 0.01744347f, -0.02302205f, 
    0.39645925f, 0.30501452f, 0.35575482f, 0.29440892f, 0.05493436f, -0.06247414f, -0.01540422f, 0.07498288f, 
    0.02072044f, -0.05144221f, -0.00084739f, -0.04548567f, 0.43393543f, 0.44101322f, 0.52232182f, 0.28057829f, 
    0.05985114f, 0.11544827f, 0.03104461f, -0.03169943f, -0.09924268f, -0.23405124f, 0.08921901f, -0.17415577f, 
    0.16772839f, -0.10639143f, -0.06759090f, 0.11537272f, -0.06958858f, 0.00464185f, 0.13368934f, -0.06038293f, 
    0.10150291f, 0.17465238f, -0.04069792f, 0.07389609f, -0.03328030f, 0.40413445f, 0.02121027f, -0.00299959f, 
    -0.03626025f, -0.11454893f, -0.14883062f, -0.07717835f, -0.07266626f, -0.12614763f, 0.23727150f, -0.09831800f, 
    -0.00140810f, 0.15045759f, 0.01777006f, 0.05615484f, -0.03080280f, 0.27152532f, -0.04092908f, 0.06235569f, 
    -0.15793923f, -0.11871468f, 0.05580762f, -0.22545384f, -0.14300866f, 0.05246010f, 0.31633121f, -0.04135751f, 
    -0.06601917f, -0.11698943f, -0.21853028f, 0.00899761f, 0.23987658f, -0.11138243f, 0.02115486f, 0.08704656f, 
    0.38979095f, -0.33607191f, 0.30156288f, 0.10908774f, 0.01514858f, 0.09459224f, 0.09660615f, 0.08059663f, 
    0.00099106f, -0.04893539f, -0.02116435f, 0.00046655f, 0.03618094f, -0.77543455f, 0.68375868f, -0.07165352f, 
    0.04399632f, 0.07463047f, -0.24930796f, -0.06853500f, 0.19191881f, 0.28470820f, -0.06652100f, 0.02255025f, 
    -0.15219606f, 0.02984604f, 0.17429379f, 0.12165712f, -0.01304459f, -0.11086246f, -0.08147673f, -0.14941704f, 
    0.07367492f, 0.02899721f, 0.00557443f, -0.08489615f, 0.01113638f, 0.19938709f, 0.05622065f, -0.06145122f, 
    0.10685227f, -0.02879088f, 0.11597569f, 0.09558982f, 0.03376027f, 0.00577078f, 0.03078342f, -0.24591070f, 
    0.24328358f, -0.02767588f, 0.40013954f, -0.05865156f, -0.24555857f, 0.05355581f, 0.13829182f, -0.10454579f, 
    -0.00963631f, 0.07890699f, -0.06375939f, 0.03206106f, -0.27181038f, -0.24440268f, -0.03957649f, -0.15616189f, 
    -0.10351308f, -0.16906406f, -0.06419344f, -0.03643942f, 0.04126994f, 0.07769097f, 0.11069509f, 0.05841165f, 
    0.27205604f, -0.13768858f, -0.37573302f, 0.06434754f, 0.18595214f, -0.06604413f, 0.07364053f, -0.05219262f, 
    -0.01345473f, 0.05756157f, 0.04210005f, 0.09264905f, 0.00227675f, 0.00510918f, 0.06988887f, -0.00870400f, 
    -0.14561097f, 0.01206008f, 0.05051378f, -0.03071333f, 0.12392130f, 0.25627002f, 0.19058025f, 0.01187198f, 
    -0.29846287f, -0.17444225f, 0.02320107f, -0.11765592f, 0.09373878f, 0.10498094f, -0.01036400f, 0.17353374f, 
    0.19161920f, 0.16872139f, 0.10996667f, -0.01692321f, -0.08008197f, -0.36383590f, 0.19006428f, 0.10132144f, 
    0.14277178f, 0.18156914f, 0.09586658f, 0.02249803f, 0.11796138f, 0.03883960f, 0.04510683f, 0.14677417f, 
    0.22370394f, 0.15152679f, -0.08233222f, 0.03682590f, -0.04408802f, 0.11161552f, 0.02871577f, -0.13036479f, 
    -0.10312220f, 0.00788289f, -0.02232127f, -0.02735998f, -0.03659486f, -0.00262458f, -0.15714376f, -0.06355649f, 
    0.10276351f, 0.00849903f, -0.00618134f, 0.00008825f, -0.01376297f, 0.05903471f, -0.02752103f, -0.05195783f, 
    -0.19485220f, 0.24131778f, 0.27395919f, 0.12266811f, 0.07535834f, -0.04335526f, 0.14374915f, -0.07762712f, 
    0.10629045f, -0.28501475f, 0.27192178f, 0.07965174f, 0.09517338f, 0.01418696f, 0.03195191f, -0.13988200f, 
    -0.03291474f, -0.04187142f, 0.01320507f, 0.09829408f, -0.17937028f, -0.03194816f, -0.07500990f, -0.16660686f, 
    0.38479075f, 0.19701824f, 0.13667028f, 0.11858799f, -0.06513659f, -0.05321444f, 0.03415435f, -0.14598660f, 
    -0.11476618f, -0.08493222f, -0.06300595f, -0.03553297f, -0.23068194f, -0.08911251f, 0.00169678f, -0.01276935f, 
    0.00242317f, 0.00105099f, -0.05723106f, -0.24196503f, 0.27898994f, -0.06673704f, 0.20904452f, -0.01985758f, 
    -0.05182838f, 0.12761112f, 0.01678449f, 0.17708391f, 0.03898929f, 0.07317878f, -0.15492676f, 0.01968441f, 
    0.25608572f, 0.24006256f, 0.18167002f, 0.05506970f, -0.10791057f, 0.02823312f, 0.01113537f, 0.33861336f, 
    -0.06213655f, 0.09141297f, -0.17800641f, -0.04974571f, 0.20673703f, 0.04353481f, 0.12374686f, 0.23199970f, 
    0.14563531f, 0.19820534f, 0.24127746f, 0.20688327f, -0.02573406f, -0.02638137f, 0.13058957f, 0.29093269f, 
    -0.06254701f, 0.25479850f, 0.04903544f, -0.07846551f, -0.15558094f, -0.02367827f, -0.08873148f, -0.13757208f, 
    0.05117907f, 0.07088145f, 0.03089195f, -0.08230825f, 0.18213022f, 0.13895714f, 0.18156940f, 0.04382933f, 
    -0.06213991f, -0.12872550f, 0.53322506f, 0.38683790f, -0.18619597f, 0.29618004f, -0.19992554f, -0.02815202f, 
    -0.13263865f, 0.03363046f, 0.08934328f, 0.04625656f, 0.09765692f, -0.12330442f, -0.05414897f, -0.08394909f, 
    -0.04559612f, -0.06349409f, -0.05564969f, -0.01118297f, 0.11546277f, 0.11638300f, 0.03741586f, -0.06035138f, 
    0.24196617f, -0.04294410f, 0.17868453f, 0.24727458f, -0.05749390f, -0.03499224f, 0.00400743f, 0.09694013f, 
    -0.04936340f, -0.00719265f, 0.00481929f, 0.08219567f, 0.00704904f, -0.35948232f, 0.21207078f, -0.13727216f, 
    0.01183984f, 0.16336930f, 0.19836567f, 0.30632758f, -0.10502677f, 0.06890216f, 0.05511790f, 0.17499943f, 
    -0.09696233f, 0.03461652f, 0.24191342f, -0.04245163f, -0.02282692f, -0.12720808f, 0.06906589f, -0.00128487f, 
    0.02903066f, -0.14801212f, 0.06870699f, -0.17339215f, 0.01132271f, 0.08291643f, 0.14334472f, -0.07681765f, 
    -0.12559322f, -0.01900723f, -0.02717307f, -0.07462724f, -0.17307544f, -0.07542355f, -0.18667513f, 0.01766879f, 
    -0.19721338f, 0.00994042f, 0.02406712f, -0.09025344f, -0.03923920f, -0.18636492f, -0.21589194f, -0.21393906f, 
    -0.18622531f, -0.07954761f, -0.13803506f, 0.01841790f, -0.18536606f, 0.04589158f, -0.10736557f, -0.35174990f, 
    0.00145606f, -0.17330016f, -0.03340315f, 0.08372244f, -0.04110412f, 0.19255029f, -0.07577536f, -0.11071528f, 
    -0.10258115f, 0.16824438f, 0.34139699f, 0.01264639f, 0.07843549f, 0.06331063f, 0.00924389f, -0.01006354f, 
    0.23594569f, 0.00101880f, 0.32704636f, 0.09406088f, 0.17758264f, 0.13096790f, -0.09514076f, 0.08390082f, 
    0.20025744f, 0.11188194f, 0.15093262f, 0.00419024f, -0.05020789f, 0.08394901f, -0.14577046f, 0.05590674f, 
    -0.03078017f, -0.07923729f, -0.02958160f, -0.04438756f, 0.19072360f, -0.07086793f, -0.03456235f, 0.12642430f, 
    0.00794351f, 0.09489159f, 0.01784160f, 0.01094646f, 0.33055139f, 0.06965620f, 0.06294150f, 0.02382962f, 
    -0.00252085f, 0.00886269f, 0.17024130f, -0.07459993f, -0.25762886f, 0.04943626f, -0.09912116f, 0.00983617f, 
    -0.39831677f, 0.13860464f, 0.32300007f, 0.14466819f, -0.10312802f, 0.08394922f, -0.10297904f, -0.06015976f, 
    0.23837648f, 0.17357205f, 0.22556208f, 0.03639002f, 0.12845109f, 0.05483152f, 0.24199505f, -0.42562613f, 
    -0.02591976f, 0.01948445f, 0.32726625f, 0.16805665f, -0.00851093f, -0.10282132f, -0.04095456f, 0.20618844f, 
    0.03693695f, -0.02933905f, -0.00901620f, 0.01432767f, -0.02604241f, -0.01478974f, -0.01778764f, -0.04642515f, 
    0.03003686f, 0.00747584f, 0.03005844f, -0.03807212f, -0.04590296f, -0.00661319f, -0.03262348f, -0.03025846f, 
    0.03659900f, 0.01402720f, 0.03422473f, 0.01884934f, -0.03923015f, 0.03294944f, -0.03719378f, -0.02902327f, 
    -0.01302036f, -0.04685800f, 0.02575393f, -0.01830930f, 0.02160776f, -0.05659210f, -0.04633939f, 0.01230722f, 
    -0.03855108f, 0.00967113f, -0.04256532f, -0.01309845f, 0.01916426f, 0.01635189f, 0.02848244f, -0.01766373f, 
    -0.05823499f, -0.03318576f, 0.00697547f, -0.00425081f, -0.02965985f, -0.00881101f, -0.00545885f, -0.04690484f, 
    0.03036298f, -0.03499800f, 0.01166212f, -0.02305269f, -0.02388691f, 0.01423400f, -0.02265213f, 0.00296748f, 
    0.00690598f, 0.03942079f, 0.03735950f, -0.04630377f, 0.01469157f, -0.04845618f, -0.00371016f, -0.03451657f, 
    0.03702613f, 0.00751385f, -0.04835433f, -0.05034271f, 0.02059207f, 0.02889946f, 0.00855971f, -0.04637987f, 
    0.03368845f, 0.03184081f, -0.02490360f, -0.02144697f, -0.00084707f, 0.00150192f, 0.02760140f, -0.05356056f, 
    -0.00539243f, -0.03994320f, -0.02586536f, 0.00903327f, -0.04965605f, -0.02011108f, -0.03542613f, -0.01241903f, 
    -0.05273718f, -0.04911791f, 0.02010291f, -0.05280217f, -0.03575465f, -0.02568431f, -0.03356878f, -0.04126186f, 
    -0.04199371f, 0.02111718f, -0.05010260f, 0.03336290f, 0.03433451f, -0.02245768f, -0.04491059f, -0.03539125f, 
    -0.00659704f, -0.04645957f, 0.03128302f, -0.00526461f, 0.00045403f, -0.00421619f, 0.02353566f, 0.02948138f, 
    -0.00704527f, -0.01812867f, 0.02929181f, -0.01264325f, -0.05082894f, -0.00646240f, 0.04112218f, -0.01122644f, 
    0.03906001f, -0.05008211f, -0.01718907f, 0.02999853f, 0.02467599f, -0.04039880f, 0.00869725f, -0.04556262f, 
    -0.02907040f, -0.04020848f, -0.04902414f, 0.01884911f, -0.02070155f, -0.04326951f, 0.03422451f, -0.03224460f, 
    -0.01971309f, 0.02715027f, 0.02933811f, -0.04335128f, -0.00598244f, 0.03640547f, -0.00949778f, 0.01635845f, 
    0.04047467f, -0.01479003f, -0.02066552f, -0.03172890f, -0.04315365f, 0.00346110f, -0.00579304f, -0.01033530f, 
    0.03946089f, -0.01684788f, -0.01189893f, 0.02810939f, -0.00375483f, -0.03153227f, 0.01256427f, -0.03004406f, 
    -0.03425712f, 0.04550312f, -0.04335302f, -0.00121257f, -0.00279118f, -0.03990061f, 0.01932514f, -0.04125842f, 
    -0.01760339f, 0.03422173f, -0.02802691f, 0.03673086f, 0.01095283f, 0.04136323f, -0.01780469f, 0.01465356f, 
    -0.01297726f, -0.01439048f, -0.00422461f, -0.04906040f, 0.00564940f, -0.01488983f, -0.01268067f, -0.05563396f, 
    -0.01096629f, -0.00569584f, -0.05318315f, -0.04144105f, 0.02117894f, -0.05125875f, -0.03287795f, 0.00267575f, 
    0.03333952f, 0.00022182f, 0.04241799f, -0.04017733f, -0.04129226f, -0.01157487f, 0.00806439f, -0.03679086f, 
    -0.01140442f, -0.04331744f, -0.01638608f, -0.05791102f, -0.04905667f, 0.01672928f, 0.00182338f, 0.03886452f, 
    -0.05527971f, -0.03719335f, -0.03944522f, 0.01280331f, -0.00512096f, -0.01839075f, 0.02563653f, -0.02421193f, 
    -0.01159211f, 0.00226466f, 0.01855375f, 0.03524882f, 0.03819824f, 0.01508965f, -0.00739861f, -0.04276072f, 
    0.00260134f, -0.00732382f, -0.05491073f, 0.00534715f, 0.02180067f, 0.00183013f, -0.02428763f, -0.00811185f, 
    -0.00183650f, 0.03969407f, -0.05046510f, -0.01064369f, -0.04711628f, -0.02774765f, -0.02600914f, -0.05362643f, 
    -0.01204948f, -0.01860617f, -0.03741826f, -0.01621841f, 0.02014662f, -0.00278050f, 0.00044652f, -0.02995489f, 
    0.04013030f, -0.00223226f, -0.02341174f, -0.03146965f, -0.00394343f, 0.03477987f, -0.04772430f, -0.03025328f, 
    -0.01250071f, -0.00713045f, 0.03968995f, -0.00140034f, -0.05855205f, 0.02914015f, -0.00124012f, -0.03067615f, 
    0.00867489f, -0.03552706f, 0.00149014f, -0.05097368f, -0.03159628f, -0.05455377f, 0.04282065f, 0.01099464f, 
    0.02837128f, 0.00957900f, -0.00921768f, -0.05827240f, -0.02626465f, 0.02595155f, 0.01996330f, 0.03834363f, 
    -0.01156889f, 0.04188697f, 0.03836656f, -0.04028083f, 0.00799158f, -0.02634943f, -0.02211411f, 0.03412765f, 
    -0.01470620f, -0.00971343f, 0.03694285f, -0.02023561f, -0.00624560f, -0.00039444f, 0.00331572f, -0.03530817f, 
    -0.00822765f, 0.00297930f, 0.02268890f, -0.04030306f, 0.04069648f, -0.03063067f, 0.01285208f, -0.03600131f, 
    -0.04586387f, -0.02348622f, -0.05507815f, -0.01494073f, 0.00516598f, -0.05516145f, 0.00777182f, -0.00017926f, 
    0.00743688f, 0.00699240f, -0.03061894f, -0.01780642f, 0.00001953f, -0.00925633f, -0.04473958f, -0.02768258f, 
    0.02423627f, 0.03133122f, 0.01889737f, -0.02278214f, 0.01650104f, 0.04159143f, -0.03880692f, -0.00914254f, 
    -0.05005407f, 0.02916190f, -0.05025015f, -0.00660892f, -0.02990567f, 0.01406808f, 0.04024495f, -0.02001056f, 
    0.02988306f, -0.03507734f, 0.03921559f, -0.04362836f, -0.02036889f, 0.02589102f, 0.00973377f, -0.02718749f, 
    -0.01635521f, 0.03060406f, 0.03758183f, 0.02010757f, 0.02290004f, -0.00720898f, 0.01573624f, -0.01411484f, 
    -0.02543272f, -0.03981859f, 0.00235502f, -0.00556860f, -0.03682097f, -0.01829058f, 0.01810465f, -0.03475058f, 
    0.02032083f, -0.00023670f, 0.02122231f, 0.00381432f, 0.03587909f, -0.03960239f, -0.02807135f, -0.02138255f, 
    -0.04847873f, -0.05665472f, -0.02223611f, -0.00061540f, 0.00415400f, 0.00134046f, -0.00887434f, -0.00394126f, 
    -0.01041128f, -0.02024337f, 0.00940688f, -0.05149674f, 0.03325567f, -0.03029150f, -0.03717631f, 0.00765521f, 
    0.00841528f, -0.03787134f, -0.02121164f, -0.03072557f, 0.03988117f, 0.04905744f, 0.01701855f, -0.03499046f, 
    0.04489817f, -0.01754927f, 0.03014250f, -0.04275425f, -0.02273616f, -0.02947650f, -0.03242342f, -0.01594809f, 
    -0.03049476f, -0.03402759f, -0.03771402f, -0.04427594f, -0.01340361f, -0.04059475f, -0.02287637f, 0.01035118f, 
    0.02702776f, -0.01429902f, -0.04477621f, 0.04116090f, -0.03771505f, 0.00414641f, -0.00599803f, -0.04033747f, 
    -0.04451151f, -0.03810706f, 0.01408495f, 0.01082551f, 0.03473008f, -0.03743944f, 0.00691216f, -0.00870430f, 
    -0.04258589f, -0.03892771f, 0.01312428f, -0.01555418f, 0.01910696f, -0.03518585f, -0.05984238f, -0.04058556f, 
    0.03246007f, -0.02972469f, -0.05766035f, 0.01490888f, -0.05035613f, 0.00667619f, -0.05414810f, -0.01414190f, 
    0.01967950f, -0.03160287f, 0.01667500f, -0.03238921f, 0.03108851f, 0.02753370f, -0.03981385f, 0.01855898f, 
    -0.04495541f, 0.01137755f, -0.04693321f, 0.01694656f, 0.03367613f, -0.00590680f, 0.03157051f, -0.05017856f, 
    0.00208244f, 0.03883892f, 0.02842120f, -0.01236047f, -0.06154692f, 0.01493952f, 0.02767525f, 0.02957859f, 
    0.03489823f, -0.00930798f, -0.03297656f, -0.02143469f, -0.01214394f, 0.03622535f, -0.05170628f, -0.01308999f, 
    -0.02204500f, 0.03553800f, 0.03613335f, -0.05236907f, 0.00548776f, -0.06051418f, -0.05596204f, 0.02732782f, 
    0.01512800f, 0.02354452f, 0.03705239f, 0.01949502f, 0.03114572f, -0.01538576f, -0.03557590f, -0.01722661f, 
    0.02608884f, -0.05634145f, -0.04638019f, 0.02339951f, 0.03549952f, 0.02589303f, -0.02467263f, 0.00121761f, 
    -0.01037105f, -0.05348787f, -0.04449020f, 0.03364823f, -0.00501869f, 0.01967852f, -0.02679820f, 0.02046468f, 
    0.01416776f, -0.04613111f, -0.02979691f, 0.03901234f, -0.02369273f, 0.03793028f, -0.02744963f, -0.00658744f, 
    -0.01064182f, 0.00852653f, -0.00178793f, 0.04016842f, 0.00106400f, -0.00600936f, 0.04043806f, -0.01237584f, 
    -0.01064348f, 0.02269951f, -0.03014032f, -0.02929785f, 0.01800593f, 0.03632938f, 0.01314481f, 0.03062640f, 
    -0.00056526f, 0.00829367f, -0.02808979f, 0.03415776f, 0.02214385f, 0.03239941f, -0.05649651f, -0.01610302f, 
    -0.02651447f, 0.03280975f, 0.00972656f, 0.02346569f, 0.00510675f, -0.01753201f, -0.00966857f, -0.05208923f, 
    0.02267471f, 0.03259217f, -0.05937620f, -0.01761973f, 0.03432886f, -0.04923489f, 0.01559032f, -0.00154825f, 
    -0.04824416f, 0.00621674f, 0.00606294f, -0.00784961f, 0.02788003f, 0.00532149f, -0.02838538f, -0.02841104f, 
    0.03379953f, -0.02916054f, 0.03159539f, -0.00925916f, 0.02814942f, -0.02667513f, 0.01843649f, -0.01172728f, 
    -0.01360025f, 0.00218582f, 0.02392351f, 0.00669730f, 0.02381169f, -0.00200642f, -0.01555037f, 0.00943628f, 
    -0.04540446f, -0.03960557f, -0.03162926f, -0.00924620f, -0.02885467f, 0.02938732f, -0.02938659f, 0.01271503f, 
    -0.04485359f, -0.02398502f, -0.00509497f, -0.04080807f, -0.01062238f, -0.04400198f, -0.00870949f, -0.02847818f, 
    -0.05615124f, -0.00538883f, -0.02589846f, 0.03243497f, 0.03439326f, 0.01171275f, 0.00099406f, 0.00440099f, 
    0.01395148f, 0.02515127f, 0.02499998f, -0.03265235f, 0.02427545f, -0.05191882f, -0.01883418f, -0.01868395f, 
    -0.01424102f, 0.02723183f, 0.00591045f, -0.01398314f, 0.03549989f, 0.02583750f, -0.02384736f, -0.02355691f, 
    0.03326878f, -0.04003598f, -0.02889717f, -0.04453924f, 0.03702421f, 0.00845313f, -0.03330340f, -0.01439754f, 
    0.03702699f, 0.01185065f, -0.04160461f, -0.05595244f, 0.01387252f, -0.01848722f, 0.01130134f, 0.00197084f, 
    0.02421027f, -0.05643781f, 0.00537718f, 0.02123179f, 0.02000709f, -0.00352177f, 0.01072066f, -0.05587382f, 
    -0.03435329f, 0.01935291f, -0.03423732f, 0.00095901f, -0.04549276f, -0.04015660f, -0.00987528f, -0.04672439f, 
    -0.03443357f, -0.03243468f, 0.00645579f, -0.03792767f, -0.03118647f, 0.00390502f, 0.03381008f, -0.04615337f, 
    0.01469447f, -0.04937284f, 0.01576451f, 0.01196914f, -0.02714927f, -0.00362285f, -0.04192465f, 0.00542910f, 
    0.00949894f, -0.01178703f, 0.02469232f, 0.00473985f, -0.04079715f, -0.04808773f, -0.01137970f, -0.00084503f, 
    0.04124449f, 0.04122654f, -0.01623116f, -0.02269639f, 0.01057429f, -0.05172761f, -0.05300279f, 0.02087523f, 
    0.02240839f, -0.03910100f, -0.00494569f, 0.02244910f, -0.03507754f, 0.00976350f, -0.00537512f, -0.02294526f, 
    -0.05019847f, -0.05956888f, 0.00495721f, 0.04786122f, -0.00665333f, -0.03649288f, -0.02513795f, -0.01709320f, 
    -0.04904075f, -0.05274275f, -0.02605679f, -0.03922006f, 0.01564328f, 0.03439074f, -0.03358699f, 0.02511051f, 
    -0.05498888f, -0.04441078f, 0.02446909f, -0.02996759f, -0.01972739f, -0.02254509f, -0.05549677f, 0.02427157f, 
    -0.00816892f, 0.01726169f, -0.03795248f, -0.03755784f, -0.03889231f, -0.00812114f, 0.02549158f, -0.05659762f, 
    0.03755311f, 0.03483366f, -0.02244928f, -0.02016083f, 0.01408745f, -0.00112864f, -0.03418262f, 0.03816972f, 
    -0.00471122f, -0.03630056f, -0.04572159f, -0.01306780f, -0.02681058f, -0.02217745f, -0.02166562f, 0.00582722f, 
    0.02790647f, -0.04661026f, -0.05314230f, -0.05263786f, 0.01519452f, 0.00462172f, 0.01322722f, -0.01200263f, 
    -0.05872937f, -0.05184222f, -0.01886237f, -0.00678895f, 0.01487650f, -0.03215566f, 0.03067644f, 0.01119002f, 
    -0.04123915f, -0.03907840f, -0.02979770f, -0.00769459f, 0.02194370f, -0.02677852f, 0.01292906f, 0.00634873f, 
    -0.05449486f, -0.02898573f, -0.02211000f, 0.04067009f, 0.00285243f, 0.03807286f, 0.01286462f, -0.04847930f, 
    -0.33285397f, 0.07603313f, -0.19196171f, 0.35270730f, 0.03845267f, 0.07477882f, -0.03681865f, -0.10266037f, 
    0.05955109f, 0.11752700f, 0.26172295f, 0.29952991f, -0.08523767f, -0.16431952f, -0.16209555f, -0.13168803f, 
    0.09631554f, 0.05267625f, -0.00482596f, 0.08104240f, 0.00186995f, -0.34699520f, -0.41273078f, -0.33445451f, 
    0.40566820f, 0.21627848f, -0.20582741f, 0.26038501f, 0.17997552f, -0.10384402f, -0.14158517f, -0.17152321f, 
    -0.06419494f, -0.13163841f, -0.03325299f, -0.03641214f, 0.19575854f, 0.35287896f, 0.35261968f, 0.39589655f, 
    -0.02411292f, 0.23940548f, 0.02644690f, -0.08391013f, 0.09210641f, 0.16137373f, 0.02381767f, 0.12275273f, 
    0.13923770f, 0.20646709f, 0.12268777f, 0.04075869f, 0.03149382f, -0.00260504f, -0.22079422f, -0.05509630f, 
    0.10662603f, 0.03615496f, -0.03289859f, 0.00191255f, 0.06301305f, 0.08085699f, -0.00052178f, 0.06653578f, 
    0.09942473f, -0.07047756f, -0.05845434f, -0.09335023f, 0.13442710f, 0.02001447f, 0.06903873f, 0.24874057f, 
    -0.14843570f, 0.16465423f, -0.06750745f, 0.08987356f, 0.04870069f, 0.08105250f, 0.18890096f, -0.01189188f, 
    0.12614736f, -0.03217225f, -0.19107030f, -0.31583914f, -0.22336341f, -0.06709433f, 0.14242215f, 0.01432292f, 
    0.06595703f, -0.00377947f, -0.03819599f, -0.05927208f, 0.14871770f, 0.14327991f, -0.11756381f, -0.01313909f, 
    0.08620647f, 0.06983721f, 0.14715725f, 0.15594500f, -0.00029607f, -0.02438720f, -0.10793797f, -0.07322340f, 
    -0.00814292f, -0.04139029f, 0.05866072f, 0.09700140f, -0.05989699f, 0.02807292f, 0.09492302f, 0.01986395f, 
    -0.02131944f, 0.02421695f, -0.11226679f, -0.09039329f, -0.02827373f, 0.01567719f, 0.08118538f, 0.04674772f, 
    -0.24391592f, -0.13309810f, -0.24255992f, -0.15385331f, -0.16915199f, -0.13921651f, 0.03198786f, 0.06939144f, 
    -0.03289946f, 0.31041414f, 0.10840804f, -0.04723577f, -0.05341086f, 0.07842617f, 0.02695321f, 0.19766083f, 
    0.03239629f, -0.09659790f, 0.10763700f, -0.12020623f, -0.02931097f, -0.08917063f, 0.02734119f, 0.05382310f, 
    0.22205713f, 0.03708368f, 0.09162985f, 0.22924925f, 0.05959723f, 0.00403700f, -0.06959908f, -0.03318526f, 
    0.03525299f, -0.04973537f, 0.05743789f, 0.04081717f, -0.19144790f, 0.01485390f, -0.08233450f, -0.11068627f, 
    -0.07381030f, -0.10936297f, -0.15111081f, 0.06367008f, -0.30915684f, -0.19875661f, -0.17821613f, -0.07049671f, 
    -0.22936568f, -0.16204438f, 0.03518222f, -0.11953408f, -0.03680910f, 0.02558807f, -0.05324167f, 0.06228084f, 
    -0.29384607f, -0.11673937f, -0.32112890f, -0.14078526f, 0.01274611f, -0.08631930f, 0.01823262f, -0.14611688f, 
    -0.09377604f, -0.07068895f, 0.04897563f, 0.00562925f, 0.21871009f, 0.35417643f, -0.00389867f, -0.10770135f, 
    0.16953653f, -0.27462772f, -0.21343376f, -0.31281608f, -0.08375208f, 0.09865450f, 0.05516861f, 0.26252201f, 
    0.21228129f, 0.05146898f, 0.12855051f, -0.32160121f, 0.01131117f, 0.08106375f, 0.26372924f, 0.17535193f, 
    0.30496755f, -0.17030223f, 0.08046605f, 0.08706428f, 0.02860823f, -0.00508840f, 0.02039967f, 0.00272485f, 
    0.46699920f, 0.56384856f, -0.27486089f, -0.32269743f, 0.17730001f, -0.27388722f, 0.01418661f, 0.12738426f, 
    0.08430170f, -0.04641767f, -0.10532238f, -0.00775928f, 0.07571036f, 0.24244703f, 0.22088461f, 0.22580916f, 
    0.12143705f, 0.06881600f, 0.05024054f, -0.11640143f, 0.12495113f, -0.01620366f, -0.00305368f, -0.01484376f, 
    0.21749268f, 0.09904451f, -0.18706915f, 0.00987072f, -0.04057237f, -0.12323725f, -0.03646155f, -0.14950377f, 
    0.12314791f, -0.01631577f, 0.05923549f, 0.11194400f, 0.25115055f, -0.02138344f, -0.06190563f, 0.43450260f, 
    0.20820746f, 0.04134143f, 0.02958375f, 0.02021507f, -0.11885063f, -0.18053694f, -0.03071785f, 0.09310291f, 
    -0.10707370f, 0.01863535f, -0.33787966f, -0.01435570f, -0.05893829f, 0.15868764f, 0.11994707f, 0.22370036f, 
    0.28191918f, 0.18801884f, -0.04797453f, 0.01614104f, 0.14209878f, 0.14165956f, 0.06142792f, 0.14802533f, 
    -0.03361321f, -0.04151465f, -0.06393836f, -0.18953496f, -0.01537563f, -0.04856431f, -0.00222407f, -0.06030636f, 
    -0.09612209f, 0.00747586f, 0.29096448f, 0.19092552f, 0.24435359f, 0.10046809f, 0.20003329f, 0.24265464f, 
    -0.08968519f, 0.07115563f, 0.08835363f, 0.02649743f, -0.29618850f, -0.10962504f, -0.03929755f, -0.05012374f, 
    0.01161501f, 0.12326755f, 0.07823444f, 0.13730781f, 0.13664553f, -0.05306849f, -0.08217411f, -0.26582536f, 
    0.18360278f, 0.03145621f, 0.03319476f, 0.22372277f, 0.09794690f, -0.04328253f, 0.04137807f, 0.02317433f, 
    0.19931559f, 0.12848006f, -0.10683129f, 0.28260723f, -0.06236058f, 0.04581012f, 0.19127555f, -0.22202402f, 
    0.06243204f, -0.05726123f, 0.03167769f, 0.29082978f, -0.08977050f, -0.01854217f, 0.03465205f, -0.06885463f, 
    -0.03395198f, 0.05712956f, -0.00898065f, -0.00033505f, -0.06508371f, 0.16012615f, -0.05759492f, -0.10043993f, 
    0.00433988f, 0.07535479f, 0.14948717f, 0.19573247f, 0.13139693f, -0.07256125f, 0.06116321f, 0.07870086f, 
    -0.03742095f, -0.06098383f, -0.17279162f, 0.16290438f, 0.10880020f, -0.03579528f, 0.03707082f, -0.16553190f, 
    -0.00756362f, 0.15664899f, 0.11808044f, -0.09320347f, 0.02042601f, -0.12384204f, -0.05135327f, -0.01637658f, 
    0.25580570f, -0.07215407f, -0.08945119f, -0.00088798f, -0.15251546f, -0.31317067f, -0.42545339f, 0.15320942f, 
    0.10347779f, 0.07860580f, -0.27440304f, 0.13490880f, -0.00156646f, 0.05426365f, -0.08600930f, -0.02266086f, 
    -0.25439075f, -0.27211028f, 0.08398440f, 0.14105558f, 0.10252432f, -0.18238761f, -0.11493098f, 0.13428748f, 
    -0.00760556f, -0.06991588f, -0.03176346f, -0.15775290f, 0.02898694f, -0.18554968f, 0.21739830f, 0.14768702f, 
    0.01772015f, -0.00477231f, -0.01336516f, 0.02022844f, 0.27884871f, 0.31110382f, 0.39651212f, 0.45973179f, 
    0.50624269f, -0.11424050f, 0.16024157f, 0.09297821f, 0.21155187f, 0.15302257f, 0.37098950f, 0.05234993f, 
    -0.04364371f, -0.01717979f, -0.10709569f, -0.03977009f, 0.18310587f, 0.22630601f, -0.01838463f, -0.11171073f, 
    0.00751819f, -0.06897786f, -0.07277485f, -0.06092039f, 0.05990342f, -0.11325517f, -0.14680630f, -0.05006279f, 
    0.38838929f, -0.22652328f, 0.25154123f, 0.09181175f, 0.06281321f, 0.00779717f, 0.10699541f, 0.15873384f, 
    0.01008308f, -0.04086241f, -0.02819394f, 0.09327655f, 0.05288905f, -0.17328863f, -0.19490677f, -0.14098659f, 
    0.02504246f, 0.13989511f, 0.14484592f, 0.11992286f, 0.07630447f, -0.07889445f, -0.09340066f, -0.06368329f, 
    -0.09030116f, 0.13081229f, 0.26805818f, -0.02275424f, -0.08328183f, -0.09038260f, -0.07987785f, 0.00263596f, 
    0.05548810f, -0.00595801f, 0.03462402f, 0.09795322f, 0.40817767f, -0.29000512f, 0.48179132f, 0.13118933f, 
    0.13027248f, 0.12936619f, 0.12157056f, 0.04305565f, -0.11165919f, 0.01439261f, -0.04699940f, -0.11524717f, 
    -0.21935938f, -0.07687584f, -0.28292337f, 0.15111050f, 0.12695596f, 0.12362706f, -0.03961140f, -0.03762086f, 
    -0.08535687f, -0.15761711f, 0.00852682f, 0.03031091f, 0.00265525f, -0.04779259f, -0.18154377f, 0.08709250f, 
    -0.09536461f, 0.10638450f, 0.03166936f, 0.08247882f, 0.08804627f, -0.12153983f, -0.19903310f, -0.24336255f, 
    -0.17616670f, -0.38864109f, 0.60844517f, 0.35629785f, 0.06332935f, 0.07701776f, -0.07964142f, -0.27002895f, 
    0.11391726f, -0.08998796f, -0.15783143f, -0.18176895f, 0.17688303f, -0.18297836f, 0.07428996f, -0.00113534f, 
    0.24550423f, 0.37166616f, -0.01928968f, 0.08815020f, 0.02584947f, -0.03051099f, 0.09215218f, -0.00663230f, 
    0.25694939f, -0.06920072f, -0.14712363f, -0.22634642f, -0.01733312f, 0.02711691f, 0.04206628f, 0.04340268f, 
    0.05137907f, 0.08721817f, 0.20790149f, -0.10852311f, -0.31768090f, -0.06140963f, 0.06384014f, 0.07322577f, 
    0.08609181f, -0.03161247f, 0.32296619f, 0.30394977f, -0.02239998f, 0.06093312f, 0.19938213f, 0.35870656f, 
    -0.09564464f, -0.13219449f, -0.14505953f, 0.27466050f, -0.04697959f, -0.04020215f, 0.04835781f, 0.26554990f, 
    0.24024093f, 0.27145740f, 0.32354718f, 0.23773950f, -0.32596081f, 0.00124801f, -0.20030406f, 0.25409061f, 
    0.11884405f, -0.11426625f, -0.03148864f, 0.05137420f, -0.02868447f, 0.06444373f, 0.08392468f, -0.00126013f, 
    0.07022998f, 0.33220366f, 0.16275050f, 0.17189129f, 0.08340573f, -0.06671274f, -0.19822180f, 0.24369034f, 
    -0.06582291f, -0.00355428f, 0.06079297f, -0.08829337f, -0.27348644f, 0.11832866f, 0.07190166f, -0.09403931f, 
    -0.24852575f, -0.06812356f, 0.14859520f, 0.09883817f, -0.07143715f, -0.02699066f, 0.18847665f, 0.00706200f, 
    -0.26282850f, -0.11251999f, -0.28449219f, -0.10911869f, 0.08683956f, 0.26164731f, 0.04749041f, -0.07880230f, 
    0.05448163f, 0.06690856f, -0.08226387f, 0.11216629f, -0.00508608f, 0.03926027f, 0.29766044f, -0.26343489f, 
    0.00485332f, 0.03518490f, -0.12616152f, 0.04113375f, 0.00471006f, 0.05371897f, 0.08441170f, 0.11350280f, 
    0.27241734f, -0.08916611f, 0.17580889f, -0.01956275f, 0.18430772f, 0.22765875f, 0.05397762f, 0.06988570f, 
    -0.09733696f, -0.05947278f, -0.09190683f, -0.17923853f, 0.16556534f, 0.12135750f, -0.06101770f, -0.15406828f, 
    0.21271457f, 0.16866061f, 0.09518439f, -0.09324033f, -0.08153228f, 0.06866887f, -0.00790361f, -0.15889689f, 
    0.14862375f, 0.25466698f, 0.41733140f, 0.06365798f, 0.08018290f, -0.10528818f, -0.09213361f, 0.08509222f, 
    -0.02817436f, -0.11131149f, -0.29724362f, -0.11450078f, -0.05701555f, -0.03476680f, 0.02967224f, 0.16125135f, 
    -0.01590792f, -0.01190770f, 0.03502018f, 0.15134741f, 0.00040411f, 0.11602440f, -0.00213526f, -0.02917062f, 
    0.15160787f, 0.12999037f, 0.00654270f, -0.24395478f, 0.08360530f, 0.08163176f, 0.01534969f, -0.21293460f, 
    -0.02083074f, -0.17441908f, -0.14794861f, -0.08683755f, -0.13715625f, 0.01274790f, 0.00388889f, -0.16177572f, 
    -0.04229587f, -0.14545955f, 0.06920192f, 0.02513892f, 0.06956135f, -0.05148287f, -0.04891763f, 0.13736248f, 
    -0.12316657f, -0.15390974f, 0.01576406f, -0.00353299f, 0.17273527f, 0.09482402f, -0.07888207f, 0.03146201f, 
    -0.05502934f, -0.10527866f, -0.00736779f, 0.08889636f, 0.27839616f, -0.17348513f, -0.02421153f, 0.37468094f, 
    0.18683837f, 0.15107338f, 0.33554259f, 0.05495326f, 0.10753094f, 0.23236200f, -0.30639392f, -0.17036870f, 
    -0.01328844f, -0.12302631f, -0.10551704f, -0.05420943f, 0.06449513f, -0.00134814f, -0.13577299f, -0.11229416f, 
    0.00007646f, -0.18824105f, -0.24414320f, -0.27778983f, 0.21209204f, -0.30731234f, -0.23076187f, 0.13069299f, 
    0.03954867f, 0.07449190f, 0.26839909f, 0.12475485f, 0.03979775f, -0.07114139f, 0.01246155f, 0.03026412f, 
    -0.71727604f, 0.03012321f, 0.05302797f, -0.06257734f, 0.00273782f, 0.04093305f, -0.07987162f, 0.02137118f, 
    0.14013456f, 0.09315339f, 0.25664654f, 0.24937047f, 0.04988675f, 0.21523023f, -0.10015934f, -0.13457997f, 
    -0.05564857f, 0.01785754f, 0.23483711f, -0.12812796f, 0.16064098f, -0.00561484f, -0.18478431f, -0.08406172f, 
    0.01450815f, 0.01184725f, -0.01789537f, -0.05552317f, 0.01020184f, -0.01390587f, -0.03847700f, -0.02968546f, 
    0.02988670f, -0.03645961f, 0.01944106f, -0.03940507f, -0.04362198f, -0.02495229f, -0.00408350f, -0.01052907f, 
    0.01900184f, -0.04996650f, 0.04016743f, 0.02774206f, 0.03842881f, -0.03620715f, 0.04884456f, -0.01851921f, 
    0.04124272f, -0.01583856f, 0.04265917f, 0.01501797f, -0.03215624f, 0.03614685f, 0.00775020f, -0.01647035f, 
    0.01250661f, 0.02166860f, -0.05378373f, 0.03070395f, 0.01328508f, 0.02627112f, 0.04476112f, -0.02315047f, 
    -0.02693319f, -0.00645482f, -0.03011718f, -0.04090683f, 0.01600786f, 0.00626480f, -0.02692001f, -0.04657439f, 
    0.04350866f, -0.00890983f, 0.02886906f, -0.02278886f, 0.04414075f, -0.03782373f, -0.04849854f, -0.04230047f, 
    0.02664536f, 0.01583577f, -0.04605732f, -0.01721118f, -0.02307390f, 0.00432741f, -0.00960364f, 0.00263072f, 
    0.03187803f, -0.01765750f, 0.03312039f, -0.03246801f, 0.03996964f, -0.03378090f, 0.03136804f, -0.01638951f, 
    -0.03188787f, 0.02809934f, 0.00139033f, -0.02901030f, 0.01841678f, 0.02739877f, 0.03202355f, -0.02562201f, 
    0.01634136f, -0.02729893f, 0.01547566f, -0.03870110f, 0.01480968f, 0.00120425f, -0.00552788f, 0.00031257f, 
    0.01487163f, 0.04245500f, 0.02432802f, 0.01813153f, -0.01796675f, -0.01002546f, 0.00777808f, -0.03179104f, 
    0.02253329f, -0.00539629f, -0.01523808f, 0.02977194f, -0.02458427f, 0.01654162f, -0.01086307f, 0.00646885f, 
    -0.02712335f, 0.02843129f, 0.03332376f, -0.00216779f, 0.02185724f, -0.03703044f, 0.04115506f, -0.01122950f, 
    0.00751478f, 0.00311535f, -0.00036018f, -0.01384180f, -0.01698820f, 0.02029369f, 0.02524344f, -0.00243310f, 
    -0.02080603f, 0.03364825f, -0.01754263f, -0.03138066f, 0.04064354f, -0.03358360f, -0.04929542f, -0.04527029f, 
    0.01952596f, 0.04065866f, 0.00138057f, -0.02651354f, -0.04560473f, -0.03729146f, 0.02343081f, 0.02593175f, 
    0.00982387f, 0.00040078f, -0.00968659f, -0.05636336f, -0.05370594f, 0.03832239f, 0.04241849f, -0.03428774f, 
    -0.04231010f, -0.00960826f, 0.00461541f, -0.05383610f, -0.04697709f, -0.04556807f, -0.05149925f, 0.00159063f, 
    -0.02927159f, -0.02507935f, -0.05356233f, -0.05222198f, 0.03468384f, -0.01736565f, -0.02333156f, -0.04276289f, 
    -0.03653438f, -0.05014577f, -0.01694033f, -0.01470479f, -0.04976341f, -0.00872895f, 0.03035760f, -0.04047044f, 
    0.00590328f, 0.02611370f, 0.02366185f, -0.04372150f, -0.03109470f, -0.02276435f, -0.01650993f, 0.00567609f, 
    -0.00930186f, -0.02573840f, -0.00104150f, 0.00036069f, 0.01808899f, -0.03697399f, -0.04913740f, 0.04333496f, 
    -0.03938834f, -0.02584299f, 0.01074253f, 0.03051482f, -0.04675700f, -0.01778041f, -0.04227979f, -0.02123095f, 
    0.03890114f, 0.02101577f, -0.01888360f, -0.04385894f, -0.00839874f, 0.01358335f, 0.03664307f, -0.01392964f, 
    0.03443044f, 0.00416794f, 0.03098640f, 0.04272304f, -0.04372671f, -0.02013375f, -0.02884513f, 0.02447311f, 
    -0.05058460f, 0.00984197f, -0.01157006f, -0.02504518f, 0.00458843f, -0.04624041f, -0.01962070f, -0.04424031f, 
    -0.04622572f, -0.02513226f, -0.01302690f, 0.00335116f, 0.04179861f, -0.03650520f, -0.05048259f, -0.02597425f, 
    -0.02938641f, 0.01266460f, 0.04179359f, -0.02109365f, 0.04584741f, -0.04741542f, -0.00888900f, -0.04270275f, 
    -0.04274055f, 0.04866910f, -0.02433328f, -0.00374005f, 0.03695692f, -0.00369422f, -0.03619175f, 0.04185760f, 
    0.03730582f, -0.02147830f, -0.03666407f, -0.03969390f, 0.03359701f, 0.00139923f, 0.03306736f, -0.01067278f, 
    0.01918431f, -0.05086171f, -0.02252029f, -0.04214821f, 0.03723763f, 0.03165236f, -0.04835168f, 0.03451815f, 
    -0.04873613f, 0.03916273f, 0.04328657f, 0.03805076f, -0.02025947f, -0.03911217f, -0.04357984f, -0.02894508f, 
    -0.02882371f, -0.00584757f, 0.01029913f, -0.04777901f, 0.03256855f, -0.04596356f, -0.05552315f, 0.03055030f, 
    -0.05517374f, -0.03625990f, -0.00018155f, -0.03767672f, -0.01222088f, -0.03519098f, 0.00305688f, 0.01720431f, 
    0.04418811f, 0.04203820f, 0.03937024f, -0.03572799f, 0.01234054f, 0.04000342f, -0.05640205f, -0.03454187f, 
    -0.01798181f, 0.03314618f, -0.03263157f, 0.01627658f, -0.02431204f, -0.03275273f, 0.03725782f, -0.00935220f, 
    -0.02120170f, 0.00843480f, -0.00781672f, -0.01779805f, 0.02367266f, 0.01203663f, -0.00041310f, 0.00356703f, 
    0.00992144f, 0.00684207f, 0.02328780f, 0.03610365f, 0.04077264f, 0.00860972f, 0.03572123f, -0.02773181f, 
    0.01887963f, -0.04185930f, 0.02532183f, -0.01696355f, -0.03865547f, -0.00995081f, -0.01012263f, -0.03043211f, 
    0.01365017f, 0.01709154f, 0.00225803f, -0.00289614f, -0.02688906f, 0.01127592f, 0.00331747f, 0.02074875f, 
    -0.01130832f, -0.04246642f, -0.04043774f, 0.02532124f, -0.01722181f, -0.00108602f, -0.00600171f, -0.00767472f, 
    -0.04604642f, -0.01702260f, -0.02753538f, 0.01107873f, -0.04412507f, -0.03567797f, 0.04276223f, -0.05251244f, 
    0.04108041f, -0.03992584f, 0.01304754f, 0.00054885f, -0.03265966f, 0.00961694f, -0.04383764f, 0.04152366f, 
    -0.02847094f, -0.01074643f, 0.01983038f, 0.00872763f, -0.04549525f, -0.02492208f, -0.00969591f, -0.05671398f, 
    -0.01175218f, 0.00206030f, 0.00446090f, -0.02810941f, -0.05566037f, 0.04276098f, 0.00076203f, 0.01628104f, 
    -0.05036786f, -0.01666235f, 0.00670312f, 0.01934841f, 0.00337589f, -0.02260612f, -0.02853180f, -0.01840851f, 
    0.04217223f, -0.04228184f, -0.03335088f, 0.02783545f, -0.03752626f, -0.05454105f, -0.04597073f, -0.04685337f, 
    -0.01498710f, 0.01159495f, 0.04351624f, 0.01276312f, -0.00592942f, 0.03115910f, 0.02499777f, 0.03524283f, 
    0.02524506f, -0.03520768f, -0.04362736f, 0.00117122f, -0.04357354f, -0.00722503f, -0.03851649f, 0.03231588f, 
    -0.03732697f, -0.00708809f, -0.03261102f, -0.04130543f, -0.05232233f, 0.00118721f, 0.00536624f, 0.03497871f, 
    -0.03061579f, 0.01694036f, -0.01546983f, -0.02669729f, -0.01821925f, 0.00626899f, -0.03610463f, 0.02736825f, 
    0.02096504f, -0.03571393f, -0.03986705f, -0.00537706f, 0.00813035f, -0.02784192f, 0.03493795f, -0.05397510f, 
    -0.00735772f, 0.02502685f, 0.03654436f, 0.04205833f, 0.02346026f, 0.03964323f, 0.02693058f, -0.04805828f, 
    -0.00288564f, 0.03877887f, -0.05308402f, 0.00696359f, 0.00584179f, -0.01330373f, -0.02036449f, -0.03390494f, 
    -0.00160536f, 0.02354015f, 0.01877349f, -0.04182440f, -0.00187865f, -0.01027311f, -0.00228280f, -0.01335565f, 
    0.03054721f, -0.01179931f, 0.03378502f, -0.05288124f, -0.02562411f, 0.01954279f, -0.04664531f, -0.02051373f, 
    0.01250028f, 0.03903231f, 0.03904979f, 0.00645171f, 0.01113025f, 0.02775161f, -0.01181857f, 0.02822347f, 
    0.02329269f, 0.01127293f, 0.01086443f, 0.02596650f, 0.02051168f, -0.02537516f, -0.05410182f, -0.02100153f, 
    -0.02482629f, -0.02554775f, -0.02807320f, -0.00802541f, 0.00331481f, 0.02429971f, 0.04006337f, -0.00851887f, 
    0.03531548f, 0.00257877f, 0.01251865f, -0.05075419f, -0.04232574f, 0.03769962f, -0.00372622f, 0.02658588f, 
    0.00206819f, -0.03802096f, -0.01551497f, 0.01658012f, 0.04196704f, -0.04101603f, -0.02226585f, -0.00209402f, 
    0.01826232f, -0.02785393f, -0.01710371f, 0.04736981f, 0.02932025f, -0.01186958f, -0.02674377f, -0.03290952f, 
    -0.04102989f, -0.04543561f, 0.02218741f, 0.02587620f, 0.01312394f, -0.04284055f, 0.04234862f, -0.03893621f, 
    -0.04855645f, -0.04233526f, 0.03338173f, 0.03342362f, -0.02188827f, 0.00258290f, 0.04115022f, -0.01542922f, 
    0.02544309f, 0.01985030f, -0.04435520f, -0.00960433f, -0.02751504f, -0.01120569f, -0.00041245f, -0.02483139f, 
    0.04543978f, -0.02751444f, -0.02247184f, -0.05164120f, -0.03042396f, -0.03354817f, 0.02012586f, -0.00591601f, 
    0.01054932f, 0.00307043f, -0.01955635f, -0.01480380f, -0.04149648f, -0.04979766f, -0.04138849f, -0.01165858f, 
    0.03331231f, -0.04618639f, -0.05363580f, 0.03189830f, 0.02177037f, -0.01191520f, 0.00608392f, 0.01325784f, 
    -0.04851121f, 0.03620932f, 0.00101709f, -0.03002442f, -0.03481174f, -0.00287385f, -0.02388362f, -0.04169048f, 
    -0.04989589f, 0.02786506f, 0.03032948f, 0.02261610f, 0.01157466f, 0.02497869f, 0.01124806f, 0.03027590f, 
    -0.02497837f, 0.02679228f, 0.01771525f, 0.02458923f, -0.04873270f, 0.04340842f, -0.02266871f, 0.02399546f, 
    0.01093394f, -0.04136433f, -0.05538957f, 0.00461955f, 0.00593476f, -0.01261035f, -0.00632927f, -0.04137024f, 
    0.00800652f, -0.02329951f, -0.01042578f, 0.02379012f, -0.03129413f, -0.05620157f, -0.02591940f, -0.03452782f, 
    0.02212179f, -0.02364130f, -0.05352179f, -0.03993940f, 0.02210347f, -0.03689019f, -0.02060929f, -0.05316950f, 
    -0.01648311f, 0.01573117f, -0.04027999f, -0.02730583f, 0.00809938f, -0.02284919f, -0.01949953f, 0.00282842f, 
    -0.02328971f, -0.05772538f, 0.00958447f, -0.02836936f, -0.00446910f, -0.01998418f, -0.03745848f, 0.02720776f, 
    -0.00003511f, -0.03004703f, -0.02352910f, -0.00422408f, -0.00532928f, -0.02350420f, 0.01230181f, 0.02141847f, 
    -0.01023402f, -0.04823289f, 0.01628310f, -0.05213837f, 0.03109205f, 0.03327257f, 0.01520029f, -0.01061014f, 
    0.03446366f, -0.03637008f, 0.00643278f, -0.00161387f, -0.04348136f, -0.02593508f, 0.01943737f, 0.03603574f, 
    0.02948539f, -0.00453353f, -0.03512087f, -0.02680296f, -0.01937251f, -0.05691011f, -0.04631222f, 0.02252735f, 
    -0.05484528f, -0.05314093f, 0.01640803f, -0.00372890f, -0.03260252f, -0.04092158f, -0.01529400f, -0.00781377f, 
    0.00120399f, -0.01009441f, -0.05263211f, 0.00611593f, -0.04054970f, 0.02423033f, 0.00414695f, -0.04791609f, 
    0.01217254f, 0.02810301f, -0.00412373f, 0.02124854f, 0.02953559f, 0.02862549f, -0.02769679f, -0.00862145f, 
    -0.05047007f, -0.02251090f, -0.00451026f, -0.04695118f, -0.05252075f, -0.01923984f, 0.03404067f, 0.00498568f, 
    -0.02850689f, -0.03061448f, 0.03620840f, 0.02755888f, 0.00896250f, 0.02783918f, -0.01657686f, 0.02926745f, 
    -0.03903582f, 0.03102905f, 0.02528132f, -0.00243475f, 0.00465321f, 0.02518797f, 0.03171648f, 0.03954080f, 
    -0.02779632f, 0.01069826f, -0.05596330f, -0.01092948f, -0.00723411f, 0.02938244f, -0.02362542f, 0.01523069f, 
    -0.02825930f, 0.04346064f, -0.00340423f, 0.02547890f, -0.04815406f, 0.03413386f, -0.02573578f, 0.03827612f, 
    -0.03932356f, -0.00242610f, -0.00235562f, -0.03516266f, 0.00265720f, -0.04244228f, 0.03920592f, -0.05287275f, 
    -0.00620872f, 0.00508563f, 0.02528562f, -0.03147232f, 0.00175676f, 0.00316548f, -0.00861127f, -0.01824364f, 
    -0.03947759f, -0.00726395f, -0.03526190f, 0.03376041f, 0.03242381f, -0.03823120f, -0.04091566f, 0.00778897f, 
    0.03538894f, 0.04303834f, -0.04904760f, -0.00211531f, -0.03389795f, -0.04019054f, -0.03623883f, -0.05215667f, 
    -0.00426563f, 0.02195282f, -0.00493136f, 0.00217789f, 0.02653338f, -0.03504636f, 0.00853935f, 0.00840159f, 
    0.00916372f, 0.01948800f, -0.03222159f, 0.02170689f, -0.03052630f, 0.00488864f, -0.00912315f, -0.05920414f, 
    0.03518242f, 0.03789590f, 0.04394705f, 0.02200905f, 0.01014075f, 0.03929770f, 0.00506612f, 0.03529218f, 
    0.15030198f, 0.16278300f, 0.07001206f, -0.04224348f, 0.08125833f, 0.12252069f, 0.06470214f, -0.09587681f, 
    0.03246450f, 0.08341069f, 0.09693103f, 0.06570912f, 0.05912241f, -0.13833773f, -0.14496388f, -0.09439413f, 
    0.07136724f, -0.02889822f, -0.03661346f, 0.02801942f, 0.08315424f, 0.07027099f, -0.10026512f, -0.16539618f, 
    0.11690839f, 0.49132383f, 0.39483008f, 0.01453669f, -0.25710097f, -0.07324567f, -0.12822884f, 0.09609140f, 
    0.06218518f, -0.02439165f, 0.06514718f, 0.00202283f, -0.26749972f, -0.23792836f, 0.04548270f, 0.08381610f, 
    0.01357239f, 0.07025222f, 0.03488926f, 0.18606895f, 0.00097303f, 0.00624142f, 0.06892682f, -0.07277773f, 
    -0.10870796f, 0.09927846f, -0.07598860f, 0.21861261f, 0.07722579f, -0.07372519f, -0.02416019f, -0.15174128f, 
    -0.07250416f, 0.01161256f, -0.05174520f, -0.13667609f, -0.01475934f, 0.06908051f, 0.08648429f, -0.04381268f, 
    -0.12048444f, 0.02027601f, -0.04144556f, -0.06951264f, 0.06563612f, 0.16077729f, 0.17154939f, -0.11392147f, 
    0.11479429f, -0.34250930f, -0.21211110f, -0.06265425f, 0.10968703f, 0.05036516f, 0.10894702f, 0.19332637f, 
    0.10628020f, 0.06240139f, 0.01399781f, -0.00286331f, -0.10679782f, 0.06677439f, -0.21377885f, -0.10368311f, 
    0.05937705f, 0.19468626f, 0.15385759f, -0.00222968f, 0.09918374f, 0.01224898f, -0.04760488f, 0.09252520f, 
    0.26117447f, 0.16155237f, 0.09833068f, -0.08044002f, -0.11438629f, -0.06477346f, -0.00578716f, -0.11145136f, 
    -0.02159874f, 0.03101083f, -0.05380592f, -0.08102461f, 0.06501233f, -0.00176057f, 0.00257267f, -0.07823354f, 
    0.13605654f, 0.04905283f, 0.01146431f, -0.05631360f, -0.01668515f, -0.00007685f, 0.03394407f, 0.01694952f, 
    0.27550057f, 0.26951993f, 0.07985441f, 0.08326993f, 0.14584763f, -0.12170355f, 0.04699488f, 0.22328839f, 
    -0.10250574f, -0.01478672f, 0.28031296f, 0.00384326f, 0.03408298f, 0.04526770f, 0.02046407f, -0.03619150f, 
    -0.03947495f, -0.13888021f, -0.03346279f, 0.03699443f, -0.11562252f, 0.03001603f, -0.02357130f, -0.08219165f, 
    0.23837835f, 0.16785735f, 0.16359729f, 0.10336430f, -0.10676797f, 0.00596804f, -0.00622946f, -0.05485956f, 
    -0.06042194f, -0.09385920f, -0.00711078f, 0.04323513f, 0.47091988f, 0.08921131f, -0.11882499f, -0.29932436f, 
    0.07968763f, 0.13897131f, -0.18673149f, -0.34577665f, 0.15290967f, -0.11522420f, -0.01592392f, -0.00087335f, 
    0.29394823f, 0.15935966f, -0.01569460f, -0.01138309f, 0.07811998f, 0.02590986f, -0.13772056f, -0.13343002f, 
    0.17844297f, 0.02859207f, 0.05504611f, 0.07292504f, 0.24835977f, 0.13820487f, -0.08575834f, 0.25262272f, 
    -0.06132508f, 0.00105480f, -0.09097642f, -0.05358138f, 0.06868531f, -0.02588585f, 0.23308069f, 0.18513076f, 
    0.07061482f, -0.14565799f, 0.06149055f, -0.20461071f, -0.20056531f, -0.11498594f, 0.33811235f, 0.31176156f, 
    -0.21572618f, 0.26066330f, 0.09671262f, 0.12230331f, 0.20533039f, 0.01870377f, -0.02116310f, 0.04613887f, 
    0.23467159f, 0.08735396f, -0.00345584f, 0.02066699f, 0.07375079f, 0.04098516f, -0.18448487f, 0.11004218f, 
    0.08899839f, 0.30815119f, 0.53624022f, 0.12090606f, -0.22808638f, 0.03222790f, 0.01020125f, 0.09335440f, 
    0.01519722f, 0.02418437f, 0.20557180f, 0.02060211f, 0.04079067f, -0.10275643f, -0.15579097f, 0.16289350f, 
    0.06785128f, -0.01581563f, 0.15087429f, 0.16323881f, -0.01923352f, -0.10628366f, -0.04979866f, 0.05401492f, 
    0.17091674f, 0.27607745f, 0.14392421f, 0.17502411f, -0.05088923f, -0.11186478f, -0.01834054f, 0.05704410f, 
    -0.01058576f, 0.05137867f, -0.05863223f, -0.01918890f, -0.20995872f, 0.11803351f, 0.36372039f, 0.09901294f, 
    -0.05856847f, 0.18768767f, -0.00422018f, 0.32315171f, -0.05455205f, -0.08962261f, 0.22785194f, 0.36790180f, 
    0.23542593f, -0.10101548f, -0.16988924f, -0.14309411f, -0.04436893f, -0.03874684f, 0.17225410f, -0.12874168f, 
    -0.02141388f, 0.13762005f, 0.03972385f, -0.05971177f, 0.21599151f, 0.10117225f, 0.01821737f, 0.02253347f, 
    -0.10964476f, -0.07415224f, -0.10874300f, -0.05466490f, 0.02516649f, 0.08846758f, -0.01879369f, 0.00777420f, 
    -0.17680904f, -0.16392936f, -0.05475067f, 0.01865530f, -0.03435307f, -0.12020197f, -0.06525026f, 0.09106874f, 
    -0.16961136f, 0.00042461f, -0.04949845f, -0.01586514f, 0.28088582f, -0.02568320f, -0.17138097f, -0.12959896f, 
    -0.02924807f, -0.14062326f, 0.05633650f, 0.18680580f, -0.16133815f, 0.04425684f, -0.00773183f, -0.23004183f, 
    0.10704947f, 0.24707201f, -0.11174204f, -0.01831272f, -0.15067294f, 0.11162044f, 0.10564979f, -0.12000262f, 
    0.13660735f, 0.15593210f, 0.19054511f, 0.09806515f, -0.02934072f, 0.21406767f, 0.10093094f, -0.16031794f, 
    0.11128423f, 0.15317377f, 0.01408662f, 0.01338934f, -0.06489655f, -0.09958675f, 0.07795976f, 0.00739066f, 
    0.10318946f, 0.10379931f, 0.05507472f, 0.01679901f, 0.09648470f, 0.12368265f, 0.13440847f, 0.01845299f, 
    -0.11292140f, 0.04912459f, 0.01139430f, -0.01776109f, 0.02596394f, 0.22134680f, 0.18442568f, -0.08735593f, 
    0.07929695f, 0.01354213f, -0.21203335f, -0.02254343f, -0.09959165f, 0.06219133f, 0.12444819f, 0.15438911f, 
    0.34973294f, 0.30937847f, -0.06112266f, 0.31928465f, -0.01543888f, 0.00569815f, -0.02350928f, -0.14081074f, 
    0.04051561f, 0.08345599f, 0.14972995f, 0.00269232f, -0.14703213f, 0.21723072f, 0.17620809f, -0.16601001f, 
    -0.03227383f, 0.21158059f, 0.38364938f, 0.19747432f, 0.15443532f, 0.17670318f, 0.04282487f, 0.26562199f, 
    0.04037613f, -0.02697597f, 0.03643119f, -0.03846592f, 0.01511742f, -0.02789472f, -0.00205537f, -0.04981157f, 
    -0.05182588f, 0.01483823f, 0.02418087f, -0.04384435f, -0.04839589f, -0.00909532f, 0.02160875f, -0.03487547f, 
    -0.01447642f, 0.02541544f, -0.01667080f, -0.02008480f, 0.04152356f, -0.04076899f, -0.04975502f, 0.00271794f, 
    -0.03266910f, -0.03949344f, 0.02506137f, -0.04344634f, -0.03615604f, -0.04140536f, -0.01260544f, 0.00478858f, 
    0.03560073f, -0.04370747f, 0.01868238f, -0.02833302f, 0.00824497f, 0.01542206f, -0.00300267f, -0.04420642f, 
    -0.02201016f, 0.00687539f, 0.00917601f, -0.04114602f, -0.00989070f, -0.05434778f, 0.04103180f, -0.01189269f, 
    -0.02283849f, -0.00829126f, -0.01509769f, -0.01329742f, 0.01046353f, 0.00883167f, -0.04001329f, -0.00996421f, 
    -0.01364808f, -0.04144168f, -0.01605821f, 0.04291846f, 0.03041188f, 0.00446987f, 0.04418724f, -0.03142114f, 
    0.01861742f, -0.03817130f, -0.01574581f, 0.00461592f, -0.04174585f, 0.03303540f, -0.02940586f, 0.02575910f, 
    -0.01860978f, -0.00854751f, 0.03194910f, -0.02059221f, -0.00004148f, 0.01010818f, 0.02102787f, -0.00970457f, 
    -0.03727759f, 0.04029937f, -0.02385062f, -0.04898031f, 0.01690653f, 0.02288504f, 0.02210632f, -0.03035863f, 
    0.01053949f, 0.02412815f, -0.02743230f, 0.00978370f, -0.00291312f, -0.04408835f, -0.04505798f, 0.01135175f, 
    -0.01805822f, -0.01015086f, -0.03831176f, -0.01904632f, 0.04384514f, 0.02487538f, -0.01433207f, 0.02065891f, 
    0.02421958f, -0.04565461f, 0.01448257f, 0.00374555f, 0.04279898f, -0.03286874f, -0.04176326f, 0.03713162f, 
    -0.00077903f, -0.01819966f, 0.02676266f, 0.00627088f, -0.01186504f, -0.03887359f, -0.01383819f, -0.04760844f, 
    -0.00148772f, 0.01155511f, -0.03636739f, -0.00206697f, -0.02800563f, 0.02159649f, 0.01529220f, -0.04654270f, 
    -0.05135130f, 0.04236395f, 0.02488609f, -0.04384787f, -0.04105883f, 0.00700868f, -0.03005400f, -0.02223041f, 
    0.00709385f, 0.01979231f, 0.02706223f, -0.05368141f, -0.00004985f, 0.03509795f, 0.01900162f, -0.03057182f, 
    -0.04710481f, -0.02223106f, 0.02405325f, -0.04605850f, 0.00393887f, 0.03890634f, -0.03381537f, -0.03598526f, 
    -0.03503808f, 0.03632728f, -0.04546040f, -0.04247022f, 0.00649798f, 0.00048275f, 0.04416012f, -0.04340162f, 
    -0.01343786f, 0.01538733f, -0.02911214f, -0.05541535f, 0.03386496f, -0.03203783f, -0.03790615f, 0.04210462f, 
    0.03846156f, -0.05489240f, -0.02098422f, 0.02150227f, -0.00430461f, -0.00378642f, 0.01703692f, 0.03176449f, 
    -0.03318620f, -0.04195677f, -0.01390923f, -0.02671238f, 0.04162174f, -0.03186021f, -0.02006625f, -0.05093780f, 
    0.01812764f, 0.04318680f, -0.00748969f, -0.05297644f, 0.02901710f, -0.01691825f, -0.02062110f, 0.01906951f, 
    -0.04521197f, -0.01597251f, 0.04565156f, -0.01978054f, 0.03234747f, -0.05612645f, 0.04248154f, 0.03980331f, 
    -0.03562523f, -0.02848127f, -0.00763822f, -0.02646649f, 0.00445019f, 0.00422988f, 0.02000937f, -0.00464771f, 
    0.03564706f, 0.00473822f, 0.03145523f, -0.00869653f, -0.04871619f, 0.03322044f, -0.02374624f, -0.05308310f, 
    0.01668746f, 0.02636452f, -0.01023345f, -0.05260156f, -0.05069853f, -0.02882049f, -0.02461500f, -0.01447775f, 
    -0.01601784f, -0.01211538f, -0.02317256f, 0.03986093f, -0.00163413f, 0.03934848f, -0.03123739f, 0.04511285f, 
    0.00774952f, -0.05297242f, 0.00932284f, 0.01300601f, -0.00930477f, -0.04404922f, -0.02422168f, -0.02765503f, 
    0.02772512f, -0.04309755f, 0.00209805f, 0.02250474f, -0.03860690f, -0.01845344f, -0.03638040f, 0.01320196f, 
    0.02810046f, -0.03160139f, -0.03274465f, -0.04460643f, 0.00478334f, -0.00425060f, 0.01705202f, 0.02405392f, 
    0.02414979f, -0.03885766f, -0.00620138f, -0.04871947f, -0.03003285f, 0.01489895f, 0.00853558f, -0.05194162f, 
    -0.03793641f, -0.03123822f, 0.03034940f, -0.04334078f, -0.04187753f, -0.02534216f, -0.03124303f, -0.01280631f, 
    -0.00117890f, -0.04745542f, 0.03471682f, 0.00942979f, -0.05527308f, 0.01369486f, 0.01127896f, -0.00673241f, 
    0.02579672f, -0.04219687f, 0.02448521f, -0.01201232f, 0.02129443f, -0.02488547f, 0.02645517f, -0.04424277f, 
    -0.04344012f, -0.00902414f, 0.00718559f, 0.01975490f, -0.01555836f, -0.02218704f, 0.00109637f, -0.03379049f, 
    0.04016555f, -0.00196063f, 0.02186761f, -0.04774972f, 0.02545721f, 0.01806229f, 0.01968198f, 0.03474637f, 
    -0.03897138f, 0.02251568f, 0.04298613f, 0.00980203f, -0.00895989f, 0.01744719f, 0.03564242f, -0.00967142f, 
    -0.01250606f, 0.04129834f, 0.03635408f, -0.00514271f, -0.04894770f, 0.00925048f, -0.03026628f, 0.00628482f, 
    -0.00019067f, -0.03661751f, 0.01470242f, -0.03082372f, 0.03388898f, -0.03097860f, -0.02638060f, 0.03729353f, 
    -0.05089272f, 0.02434000f, -0.00977389f, -0.02050432f, 0.02116924f, -0.04293455f, -0.02151322f, 0.02538724f, 
    -0.05451570f, -0.03188509f, 0.04700756f, -0.03152348f, 0.03368531f, -0.04069728f, -0.01739920f, 0.03445010f, 
    0.01261924f, 0.04508880f, 0.02503549f, -0.02929943f, 0.04153510f, -0.00903330f, 0.00731400f, -0.03458334f, 
    0.01213182f, 0.02733994f, -0.04172225f, -0.03115681f, 0.00611815f, -0.01106794f, 0.02276598f, 0.00720750f, 
    -0.00303877f, 0.00691049f, 0.00779358f, -0.00722194f, -0.02387802f, -0.03915646f, -0.00932759f, -0.03354590f, 
    -0.04973108f, -0.03951154f, 0.00802675f, 0.00976680f, -0.02576033f, -0.00624150f, 0.00603357f, 0.02869488f, 
    -0.02681156f, 0.01082820f, -0.01343489f, -0.02687400f, -0.01895345f, -0.01297250f, 0.01277668f, 0.01035555f, 
    -0.02288754f, -0.01346866f, 0.02478637f, 0.04718913f, 0.01078450f, -0.01563722f, -0.00041246f, -0.05632054f, 
    -0.03396497f, -0.00266760f, -0.05447551f, 0.02125399f, 0.01549772f, -0.03138234f, 0.04317781f, -0.00958601f, 
    0.03734479f, -0.03939910f, 0.01962871f, -0.02470250f, -0.03444500f, -0.05516574f, 0.02746602f, 0.02018934f, 
    -0.04603067f, 0.03087749f, -0.02764143f, 0.01860725f, 0.00112665f, 0.03594764f, 0.02892587f, 0.00802354f, 
    -0.03192988f, -0.02141519f, 0.03610219f, 0.03470001f, 0.01293834f, -0.01053046f, 0.04482443f, 0.02195429f, 
    -0.01099150f, -0.00471524f, -0.05522722f, 0.00756469f, 0.02035625f, -0.00255571f, 0.02781059f, 0.02514109f, 
    0.04066839f, -0.05050755f, -0.02830124f, -0.03588915f, -0.04078190f, -0.00189252f, -0.01830604f, -0.03890261f, 
    -0.01025812f, -0.04692724f, -0.04913345f, -0.00493811f, 0.00335070f, 0.01195635f, -0.00109036f, -0.04397338f, 
    -0.04590038f, 0.03389636f, 0.02507420f, 0.00412875f, 0.02515422f, -0.00660532f, -0.00801851f, -0.00701334f, 
    -0.04037746f, 0.03861118f, -0.00075777f, 0.00517744f, -0.04427095f, -0.02125637f, -0.05102009f, 0.00498311f, 
    -0.05344144f, 0.01606970f, -0.04328868f, -0.01365678f, 0.01895759f, 0.03046469f, 0.00027053f, -0.03790885f, 
    -0.02322867f, 0.03291932f, -0.04297414f, -0.00897284f, -0.01379976f, 0.03232627f, -0.01834999f, -0.03030638f, 
    -0.00892479f, -0.03865305f, -0.04595799f, -0.01235380f, 0.03785594f, 0.02873502f, 0.05050618f, 0.03703033f, 
    -0.03276521f, 0.02679756f, -0.05455263f, -0.00655548f, 0.00788895f, 0.05012704f, -0.01703529f, 0.03255817f, 
    0.01439380f, 0.01189801f, 0.03743121f, -0.04436540f, -0.04536586f, -0.03999837f, 0.02176386f, -0.01669844f, 
    0.02050831f, 0.00628992f, -0.04198423f, 0.01733213f, -0.01317880f, 0.01184351f, 0.00000107f, 0.01846050f, 
    0.01858336f, 0.01217830f, -0.04858746f, -0.02545421f, 0.03272950f, 0.04463145f, -0.04474251f, -0.00507853f, 
    0.01975480f, -0.03692324f, 0.00773740f, 0.01331080f, 0.03653735f, 0.03437254f, -0.02778969f, 0.00799300f, 
    -0.05433854f, -0.02264322f, -0.05330968f, -0.02588857f, -0.05425394f, -0.03578093f, -0.03537429f, 0.02726281f, 
    0.02485775f, -0.00541460f, -0.03375444f, -0.03672501f, 0.00863983f, -0.01953281f, 0.00185953f, -0.03666431f, 
    0.01025990f, 0.01017301f, -0.04087035f, 0.00322163f, -0.04072973f, 0.03071708f, 0.01798462f, 0.01138658f, 
    -0.01932996f, -0.00411533f, -0.05691839f, -0.04703765f, 0.03522955f, 0.02990040f, 0.03700124f, 0.00193177f, 
    -0.04519129f, -0.02043825f, -0.03279508f, -0.03236352f, -0.03596654f, 0.01431310f, -0.05066094f, -0.03026263f, 
    0.04214482f, 0.02358197f, 0.02029676f, -0.05049913f, 0.03153628f, 0.00601120f, 0.00073874f, -0.03002764f, 
    -0.04400899f, -0.02829161f, -0.04195563f, 0.00742410f, 0.01894007f, -0.03002304f, 0.00013152f, -0.04629775f, 
    -0.05569879f, -0.05159491f, 0.02370744f, 0.01086378f, -0.01446298f, -0.04384380f, 0.03918083f, 0.01940700f, 
    -0.00415368f, 0.02474026f, 0.03996263f, -0.02299955f, -0.05024891f, 0.02881465f, 0.00973048f, -0.05239222f, 
    -0.04355997f, -0.02047377f, -0.04427341f, 0.04180460f, -0.04855397f, -0.03988088f, -0.00542951f, 0.01125658f, 
    -0.00490293f, 0.01791926f, 0.00837233f, -0.02898488f, -0.01084172f, 0.03462763f, 0.03406661f, -0.05547880f, 
    -0.01063147f, 0.04121300f, -0.01956298f, 0.00517163f, -0.02388868f, -0.04378270f, 0.03282713f, -0.00858169f, 
    0.01095581f, 0.03686631f, 0.02763411f, -0.01354737f, -0.03997703f, -0.04980716f, 0.01762936f, -0.01927443f, 
    -0.01945847f, -0.05200518f, 0.02305183f, -0.02357326f, -0.00909810f, 0.03113580f, -0.01140340f, -0.05121273f, 
    -0.04427022f, -0.04369132f, -0.02868556f, 0.03261690f, -0.00972378f, -0.03127959f, 0.01854646f, -0.00895588f, 
    -0.03460866f, 0.03527106f, -0.01213599f, 0.02923547f, 0.02715239f, 0.04261719f, -0.03160336f, 0.00234442f, 
    0.02394007f, 0.01826384f, -0.05162540f, -0.03255514f, 0.02591104f, -0.05103742f, -0.03372449f, -0.04275134f, 
    0.02555380f, -0.05058987f, -0.00924650f, -0.03793954f, 0.01191101f, 0.03569680f, -0.01965020f, 0.00327754f, 
    0.00482531f, 0.00137166f, 0.01554649f, -0.02835575f, -0.05327225f, 0.03857289f, -0.01928896f, -0.01258519f, 
    0.03061453f, 0.00430323f, -0.05124490f, -0.03760151f, 0.02777106f, -0.01488370f, 0.03215881f, -0.04667895f, 
    -0.05100912f, -0.03702551f, 0.02063986f, -0.00721283f, -0.04349038f, 0.01128166f, -0.00618052f, -0.00703077f, 
    -0.02714848f, 0.01462398f, -0.02290797f, 0.01377268f, 0.03064999f, -0.03879414f, -0.02870579f, 0.02959956f, 
    -0.01929789f, 0.00325683f, -0.00353967f, -0.02283355f, 0.00195491f, -0.00803431f, 0.02701496f, -0.03024804f, 
    -0.04336115f, 0.03159508f, -0.00438455f, 0.00730525f, -0.03940193f, 0.01796815f, 0.03280533f, -0.01032081f, 
    -0.03711256f, -0.00996896f, -0.00573550f, 0.03644670f, -0.04772277f, 0.03040979f, -0.03288788f, -0.01799870f, 
    -0.01223620f, -0.03250507f, -0.05085303f, 0.01858001f, -0.01300149f, -0.05138499f, 0.01372102f, -0.03622932f, 
    0.03483750f, -0.00567046f, -0.02074932f, -0.04107391f, 0.00954019f, -0.04912790f, -0.02796503f, -0.01786618f, 
    0.01800345f, 0.04101664f, 0.01133789f, -0.01630879f, -0.01042621f, 0.00218903f, 0.03018627f, -0.02757585f, 
    0.03720529f, -0.01133414f, -0.02254933f, -0.03657090f, -0.04251691f, -0.05200218f, -0.00145519f, -0.01832871f, 
    0.02625057f, 0.03847738f, 0.01679409f, 0.00046276f, -0.02645183f, -0.00327707f, -0.03555945f, 0.02726027f, 
    0.03572817f, -0.01333194f, -0.04460628f, -0.03984068f, 0.03485725f, 0.02573612f, 0.02364733f, -0.05086498f, 
    -0.03339563f, -0.01719153f, 0.02519500f, 0.03176897f, -0.03433589f, -0.01873253f, -0.05181437f, 0.01340712f, 
    0.00963674f, -0.03129431f, 0.04290550f, 0.04178695f, -0.00145570f, -0.01601700f, 0.02014823f, 0.01036369f, 
    -0.01304636f, -0.02511008f, 0.04019252f, -0.04422710f, 0.04178352f, -0.00105272f, 0.01441482f, -0.03757299f, 
    -0.05374197f, 0.01969023f, -0.04242113f, -0.03907547f, -0.04435385f, -0.02320842f, -0.00575740f, -0.02019284f, 
    0.01238126f, -0.00216771f, -0.01042002f, 0.02383076f, 0.00121476f, -0.02670105f, -0.03084405f, 0.00766700f, 
    -0.03846716f, -0.04151070f, -0.03224651f, -0.05452223f, 0.01694887f, -0.02032880f, 0.01080469f, 0.04452214f, 
    -0.00281540f, -0.03738378f, -0.01398247f, 0.04288105f, 0.02718608f, 0.00037785f, -0.03334561f, 0.03612025f, 
    0.03186977f, -0.01588264f, 0.02515214f, -0.03553193f, 0.02741743f, -0.05011332f, 0.02477641f, -0.04735834f, 
    -0.03553978f, -0.04675061f, -0.01752773f, -0.04958951f, -0.03957763f, -0.03682150f, 0.03461809f, 0.02493054f, 
    0.03439685f, 0.01608187f, 0.04082594f, 0.04444344f, -0.02642127f, 0.02693825f, -0.03059766f, 0.03108484f, 
    -0.04215275f, -0.04961263f, 0.03174388f, -0.04814560f, -0.05308466f, 0.00284857f, -0.02385442f, -0.01318602f, 
    -0.00864455f, -0.05501944f, -0.00109809f, -0.01668976f, 0.01204586f, -0.05419387f, -0.02871207f, -0.05686673f, 
    -0.02949763f, 0.00539087f, 0.02277433f, -0.02481679f, -0.04506166f, -0.02180667f, 0.00465135f, 0.01979971f, 
    -0.04139614f, -0.03779570f, 0.00288929f, -0.00320259f, -0.02089098f, 0.02196533f, 0.00403490f, 0.00577203f, 
    -0.01093629f, -0.03443744f, -0.01580329f, -0.02768246f, -0.00082826f, 0.00146984f, -0.03058859f, -0.02013674f, 
    -0.05245097f, 0.04088722f, 0.00275942f, -0.05645088f, -0.04490482f, -0.01939923f, -0.02617527f, -0.02929680f, 
    0.00227186f, -0.02808569f, -0.02941838f, 0.00667985f, -0.04555485f, 0.01482620f, -0.00933930f, 0.03365725f, 
    0.04147181f, 0.02519260f, -0.03257953f, -0.02724828f, 0.03880177f, 0.02835161f, 0.03872081f, -0.03606945f, 
    -0.03224814f, 0.02858882f, -0.01494180f, -0.01785550f, -0.04572326f, -0.05305759f, 0.01580810f, -0.01317785f, 
    -0.02932567f, 0.02451057f, -0.04347562f, -0.05472510f, 0.03123682f, 0.00961465f, 0.04448509f, 0.02962851f, 
    0.03740662f, -0.04955773f, 0.00284374f, -0.02952946f, 0.03002702f, -0.01176347f, -0.05063859f, 0.02982011f, 
    0.01673482f, 0.03562692f, 0.02387602f, -0.04315164f, 0.02513712f, -0.03230006f, -0.01243470f, -0.05431654f, 
    0.03638978f, -0.04817315f, -0.05283175f, 0.01655355f, -0.03378010f, -0.03984237f, 0.01433561f, -0.03401196f, 
    0.00261386f, 0.00420013f, -0.04610199f, 0.04385078f, -0.02452810f, -0.01309448f, -0.05219635f, 0.00232991f, 
    -0.00996872f, 0.02357364f, 0.03758815f, -0.02015977f, -0.04816118f, -0.03103199f, -0.05471737f, 0.02701170f, 
    -0.01090269f, -0.02443118f, -0.04460876f, -0.00968643f, 0.03144679f, -0.05605945f, -0.03999009f, 0.00612687f, 
    -0.01875922f, 0.00629162f, -0.05312208f, 0.01936492f, -0.01514040f, 0.01597828f, -0.02664446f, -0.02425403f, 
    0.01326079f, 0.01150586f, 0.01376627f, 0.03042153f, 0.01468577f, -0.01141974f, 0.03985879f, -0.00143709f, 
    0.01779403f, -0.02427189f, -0.02391828f, -0.01708539f, 0.00430266f, -0.01472851f, 0.03934516f, -0.03828308f, 
    0.00915754f, 0.03879410f, 0.03101197f, -0.04114825f, -0.05076818f, -0.04262868f, 0.04401367f, -0.03484750f, 
    -0.02201202f, -0.01066939f, -0.05507975f, 0.01514653f, 0.03297472f, 0.04452569f, -0.02490612f, -0.02488138f, 
    -0.04942269f, 0.02726993f, -0.00590334f, 0.02557880f, 0.02011184f, 0.03268628f, -0.01912359f, -0.04612750f, 
    -0.03493986f, -0.05324406f, -0.01517281f, -0.03125263f, -0.00391276f, -0.02923077f, -0.00880025f, 0.04076387f, 
    0.02755383f, -0.03711712f, -0.04682060f, 0.01614299f, -0.00711247f, -0.01299724f, -0.02353510f, 0.04253012f, 
    -0.02265858f, 0.03330816f, 0.03717650f, -0.05410524f, -0.05131484f, -0.02639323f, -0.04897036f, -0.04845621f, 
    0.01350485f, -0.05261663f, -0.03967935f, -0.04106372f, 0.02124943f, -0.01673791f, -0.01402929f, -0.00497438f, 
    -0.02682645f, -0.04156880f, -0.03326517f, -0.05360644f, 0.02700130f, 0.00265700f, 0.02607735f, -0.00945616f, 
    0.00061163f, -0.00349090f, -0.02900832f, -0.03701013f, -0.04376010f, 0.04405143f, 0.02839669f, -0.00980634f, 
    0.00453998f, 0.03319012f, -0.02282715f, 0.03518120f, 0.04201785f, 0.00750624f, -0.04297072f, 0.03650106f, 
    -0.00110309f, -0.03947886f, 0.02170636f, -0.04745086f, 0.01514034f, 0.03712885f, 0.04122170f, 0.02177033f, 
    -0.04928966f, -0.02973846f, -0.03341765f, -0.04385768f, -0.00945145f, -0.05099881f, 0.01603319f, -0.01249850f, 
    -0.03169993f, -0.01040509f, -0.04809462f, -0.01280283f, -0.02389972f, -0.01647870f, -0.04902912f, 0.04422820f, 
    -0.00868861f, -0.00126112f, -0.01684319f, 0.00709876f, 0.03240922f, -0.01935074f, -0.03780543f, -0.02045402f, 
    0.01495702f, 0.02031043f, 0.01422806f, 0.01419620f, -0.02457507f, 0.03012331f, -0.00138146f, -0.02296826f, 
    0.00392906f, 0.03370108f, -0.02009084f, -0.02605215f, 0.04268862f, 0.04603344f, -0.05675237f, 0.02406525f, 
    -0.01115474f, 0.04178054f, -0.03543682f, 0.03261802f, -0.01448257f, -0.03607240f, -0.03241841f, 0.00885673f, 
    0.04277555f, -0.02576635f, 0.00162953f, -0.04313679f, 0.00422854f, 0.01451967f, 0.00457182f, 0.01528614f, 
    0.11281163f, 0.31205621f, 0.19388141f, -0.02274160f, -0.07640301f, 0.00289082f, 0.03412750f, 0.05782874f, 
    -0.10116085f, -0.20410419f, 0.05189566f, -0.11511555f, 0.07835120f, 0.04808404f, 0.20542146f, 0.14378251f, 
    -0.16147247f, 0.00883387f, -0.09438653f, -0.12259998f, -0.10924986f, 0.07340840f, 0.15765674f, 0.00822742f, 
    -0.26681700f, -0.21811457f, -0.01250191f, 0.61189455f, 0.01549210f, 0.13968268f, 0.03443150f, 0.47720650f, 
    0.16726699f, -0.02998141f, 0.00340391f, -0.10444432f, 0.33815587f, 0.21459386f, 0.17490411f, 0.22254677f, 
    0.20869359f, 0.24791637f, 0.31008983f, 0.23571479f, 0.10909920f, 0.08584510f, 0.04561043f, -0.15915404f, 
    -0.35201946f, -0.02906732f, -0.09250061f, 0.15978102f, -0.11801786f, 0.04779382f, 0.05582197f, -0.01652892f, 
    -0.16240576f, 0.02689270f, -0.22973520f, -0.11830242f, 0.02949542f, -0.10102513f, -0.10915004f, -0.15973175f, 
    -0.03167581f, 0.03443475f, 0.08514398f, 0.02758517f, 0.02224793f, -0.12182169f, 0.06932577f, -0.00638543f, 
    0.21606116f, -0.08861537f, 0.02197545f, 0.25249663f, 0.23931703f, -0.05261519f, 0.04710383f, 0.06211339f, 
    0.01635688f, -0.00228538f, 0.07988338f, -0.00895137f, -0.25554591f, -0.15621269f, 0.32376802f, -0.04420783f, 
    0.10863501f, 0.11847272f, -0.01753615f, 0.08893282f, -0.13868158f, -0.15029751f, -0.09602030f, -0.07109284f, 
    -0.13042910f, -0.22116108f, -0.10300661f, -0.13671650f, 0.09908580f, 0.12717353f, -0.00884048f, -0.06197628f, 
    0.04918465f, 0.05346207f, 0.02004435f, -0.02671089f, 0.03184790f, 0.10762557f, -0.01861077f, -0.15466937f, 
    0.03903027f, 0.00871054f, 0.03116168f, -0.22126822f, 0.16749249f, -0.05841408f, 0.18714681f, -0.04419349f, 
    0.56913394f, 0.50845319f, 0.09943059f, -0.19052120f, -0.21248883f, 0.15050659f, -0.15016960f, 0.14436151f, 
    -0.00358495f, 0.17112909f, -0.20057158f, -0.00991795f, -0.06962536f, -0.19354802f, -0.35812223f, 0.20271680f, 
    0.07256102f, -0.07119700f, 0.30444330f, 0.26201251f, 0.05673719f, 0.03537648f, 0.12482367f, -0.18024848f, 
    -0.26601866f, -0.05976729f, -0.21635939f, 0.28284156f, -0.21221171f, 0.06589784f, 0.00153817f, 0.11701646f, 
    -0.09931254f, 0.01299686f, 0.08902108f, -0.07950651f, 0.17631577f, -0.08582573f, 0.30596960f, -0.22861145f, 
    0.17618106f, 0.02174510f, -0.15822665f, -0.06338011f, -0.14146423f, 0.13428470f, 0.04519016f, -0.03006904f, 
    0.06464927f, 0.00516239f, 0.05308681f, -0.00123250f, 0.02631338f, 0.00688432f, -0.09526692f, -0.10337493f, 
    0.04640702f, -0.16656515f, 0.01192975f, 0.03538560f, 0.24285193f, 0.26548794f, 0.23988724f, -0.08876960f, 
    0.05785141f, 0.06453636f, -0.30030197f, -0.04917590f, 0.01642684f, -0.00986814f, -0.16832164f, -0.06925821f, 
    0.27372125f, -0.25742581f, -0.14187798f, 0.17188421f, 0.09653310f, 0.03268562f, -0.11958223f, -0.10039773f, 
    0.04262170f, -0.04057721f, 0.03625389f, 0.12785506f, 0.21833238f, -0.09485789f, -0.06007641f, -0.04642822f, 
    -0.04777015f, -0.02970960f, 0.03827908f, 0.13634141f, -0.07415684f, 0.08601748f, -0.00750203f, 0.03073831f, 
    0.17481261f, -0.35384443f, 0.15163694f, 0.31814644f, 0.05008211f, -0.07148258f, -0.05797378f, 0.06800451f, 
    0.07921337f, 0.06773940f, -0.25037453f, 0.06785882f, -0.00977605f, 0.10581182f, -0.21594715f, -0.09326023f, 
    0.13658997f, 0.14257796f, -0.06412844f, 0.17507006f, 0.00315862f, 0.14535025f, 0.02579650f, 0.01759869f, 
    -0.12236515f, -0.07133343f, -0.14608693f, 0.17187950f, -0.00290789f, -0.05061130f, -0.24470496f, 0.25419694f, 
    -0.25192201f, -0.16923361f, -0.00153100f, -0.20432435f, -0.24836710f, 0.53928232f, -0.19837587f, 0.43144250f, 
    -0.17768148f, -0.12398622f, 0.08466725f, 0.08144812f, 0.08808062f, -0.02373470f, 0.04760505f, 0.02218377f, 
    0.19646086f, 0.22217582f, -0.04011306f, -0.26005596f, -0.07346153f, -0.11162509f, -0.15110146f, -0.09729283f, 
    -0.10681511f, 0.01660954f, 0.00616533f, -0.04405119f, 0.13610815f, 0.01297543f, 0.06494257f, 0.24295612f, 
    -0.07921328f, 0.13169220f, 0.18036313f, 0.09773321f, 0.20129274f, -0.09554075f, 0.05114439f, 0.12900072f, 
    0.38165236f, 0.35778669f, -0.05014769f, 0.13346353f, 0.05624487f, 0.13078685f, 0.10662202f, 0.35040978f, 
    0.10419968f, 0.11645709f, 0.03186347f, 0.10435834f, 0.26982552f, -0.13707022f, -0.32087716f, -0.08228356f, 
    0.04534480f, -0.14361098f, 0.02933761f, 0.10974889f, 0.05273414f, 0.05296040f, -0.06866580f, 0.11167028f, 
    0.03171157f, 0.18235533f, -0.12629491f, -0.31676549f, -0.10057643f, -0.13318728f, -0.06299359f, -0.11205436f, 
    -0.15876868f, -0.08248615f, -0.02527224f, 0.01192522f, -0.47325167f, -0.06965828f, -0.07124113f, -0.13726552f, 
    0.11255234f, 0.14109564f, 0.00972331f, -0.04615405f, 0.11448061f, 0.03290309f, -0.21968521f, 0.05905047f, 
    0.14240299f, -0.00516121f, 0.05067085f, 0.35075799f, 0.08875285f, 0.05730817f, -0.03514670f, -0.14143762f, 
    0.18661602f, -0.02946830f, -0.00604309f, 0.29988906f, -0.30136213f, 0.12219682f, -0.46207014f, -0.02524605f, 
    -0.19623630f, -0.03352940f, 0.18640204f, -0.20716508f, 0.25433141f, -0.00742393f, 0.08207020f, 0.11598028f, 
    0.76244420f, 0.40458667f, -0.20875934f, 0.14589126f, 0.07288874f, 0.04080108f, -0.09766245f, -0.01768579f, 
    -0.11488784f, -0.13892382f, 0.05200173f, 0.04827856f, -0.26616478f, 0.58481371f, 0.05917931f, 0.33900341f, 
    -0.28261337f, -0.06399228f, -0.11192475f, -0.24278089f, 0.06893865f, -0.13014899f, 0.02684303f, 0.04773716f, 
    0.11524563f, -0.07755279f, 0.05405671f, 0.34562349f, -0.02257344f, -0.06142593f, -0.19471490f, 0.09486792f, 
    0.05231782f, -0.23052998f, 0.03392336f, 0.28556889f, 0.06262799f, 0.06008732f, 0.05049508f, 0.04640650f, 
    0.15141039f, 0.03736028f, 0.08043195f, 0.04311208f, 0.02210550f, -0.16624248f, 0.02615858f, -0.28348291f, 
    0.27873433f, -0.21246007f, -0.32600817f, 0.26312390f, 0.11603437f, 0.21494450f, 0.06538057f, -0.02564136f, 
    -0.08648549f, -0.00384765f, -0.10723311f, -0.30777833f, -0.09712932f, 0.04624698f, 0.24963461f, 0.07055597f, 
    0.08309899f, 0.12181892f, 0.00802108f, -0.04374707f, 0.00024085f, -0.00350637f, -0.00165437f, 0.15540318f, 
    0.23297003f, -0.06810420f, 0.05345609f, 0.30144611f, -0.08553169f, 0.14314216f, 0.08191799f, 0.16438702f, 
    0.07734120f, 0.20390131f, 0.04807985f, 0.27591857f, -0.10725470f, -0.11569326f, -0.13671039f, -0.02148482f, 
    0.00418019f, -0.11832986f, 0.08857337f, 0.03989376f, -0.01433117f, -0.04980066f, 0.10905271f, 0.25161958f, 
    -0.25946820f, 0.18504277f, 0.11218198f, 0.09707063f, -0.07012699f, -0.14804867f, -0.01659754f, 0.13408142f, 
    -0.05426651f, -0.10943312f, -0.17378290f, -0.22219475f, -0.01824464f, -0.52722609f, 0.47056094f, 0.26540276f, 
    0.12375227f, 0.15137124f, 0.02275094f, 0.16751224f, 0.03504307f, 0.08169088f, 0.12268320f, 0.16401458f, 
    -0.29235414f, -0.07802819f, -0.25316414f, -0.25662744f, -0.02841315f, 0.02462495f, 0.12636611f, 0.02897331f, 
    0.09183596f, 0.00957379f, 0.23704955f, 0.07573296f, -0.20404738f, -0.09590153f, -0.16823502f, -0.11099627f, 
    -0.07351246f, 0.09058261f, -0.00316097f, -0.05988448f, 0.18197578f, -0.01700218f, 0.20991126f, 0.13276307f, 
    0.29942164f, 0.39736065f, 0.00006996f, 0.14371812f, 0.01542796f, 0.01698292f, 0.02610422f, -0.16008304f, 
    -0.06018409f, 0.21740171f, -0.05435504f, 0.13936283f, -0.23072886f, -0.32342076f, -0.15708436f, -0.13986290f, 
    0.20212890f, -0.02692449f, 0.04966646f, -0.04985116f, -0.25314528f, -0.08921251f, 0.13647395f, -0.11494845f, 
    -0.10095613f, 0.12928076f, -0.28591961f, 0.04021790f, -0.06308886f, 0.11168533f, -0.06623418f, 0.08436134f, 
    0.14203268f, -0.21668482f, 0.26129270f, -0.01618895f, -0.71472114f, -0.19225840f, 0.10834099f, -0.04903192f, 
    0.04152289f, -0.19423561f, -0.15476623f, 0.08994983f, -0.07245248f, -0.02974875f, -0.00017185f, 0.01854924f, 
    -0.10969653f, -0.01482532f, 0.13416705f, 0.06080914f, -0.11442651f, 0.10300536f, -0.09739698f, 0.08879586f, 
    0.06741910f, 0.10963906f, 0.05655668f, -0.02962593f, -0.09707222f, 0.20753109f, -0.00843390f, 0.07009767f, 
    -0.04783726f, 0.01640765f, -0.09358422f, 0.10419468f, 0.22524352f, 0.28593853f, -0.01590266f, 0.04121311f, 
    -0.08464975f, 0.20704871f, -0.01445019f, 0.08261681f, -0.01772274f, 0.05384484f, -0.00989018f, -0.06350853f, 
    0.08687799f, 0.03014442f, 0.08579425f, -0.09670632f, -0.35160568f, -0.06643638f, 0.13516106f, 0.00034068f, 
    -0.01755455f, -0.12367663f, 0.26563832f, 0.11258858f, 0.08470774f, -0.13032427f, -0.02985874f, -0.04288168f, 
    0.08951613f, 0.05354154f, 0.38471159f, -0.01141049f, 0.13144813f, 0.23315535f, 0.10106573f, 0.02939896f, 
    0.08293287f, 0.06834355f, -0.10334852f, -0.01129133f, -0.14885475f, 0.23904443f, 0.10119100f, -0.13452318f, 
    0.10719598f, 0.01481158f, 0.03628919f, 0.09411120f, 0.04999960f, -0.03964097f, -0.04234976f, -0.10551205f, 
    0.10252412f, -0.11532202f, 0.07726208f, 0.08272034f, -0.04718856f, 0.23122327f, -0.06216553f, 0.05909602f, 
    0.04083739f, 0.03091211f, 0.30814126f, -0.01193746f, -0.07993660f, 0.05510439f, -0.09197877f, 0.34144780f, 
    0.09232178f, 0.12322915f, 0.16486357f, 0.12746984f, -0.06253189f, -0.02936290f, -0.12396736f, -0.08537105f, 
    0.01560064f, 0.06978559f, 0.19864611f, 0.13172907f, -0.06272025f, -0.01714649f, -0.17789195f, -0.01062448f, 
    0.02096005f, 0.01210502f, 0.04373049f, 0.02820239f, -0.02873962f, -0.05818638f, 0.01426293f, -0.16788922f, 
    -0.02111213f, -0.02530988f, -0.01184870f, -0.18578158f, -0.11361574f, -0.18392475f, -0.14821821f, -0.03546006f, 
    -0.23162419f, 0.07637536f, 0.05281210f, -0.07727581f, 0.07245775f, 0.00232479f, 0.06860755f, 0.03938250f, 
    -0.17878257f, 0.02982362f, -0.08956411f, 0.10489132f, -0.44635820f, -0.19138384f, -0.08467327f, -0.28578645f, 
    -0.06849962f, -0.29570341f, 0.11487802f, 0.23240690f, -0.01519093f, 0.05575414f, -0.06776448f, -0.12415833f, 
    -0.03976489f, 0.14089243f, 0.16584262f, -0.01713770f, -0.00656482f, 0.07831739f, 0.02265681f, 0.01350422f, 
    0.11297815f, 0.21928999f, -0.10480884f, 0.28488418f, -0.10245737f, -0.16602612f, 0.01996127f, -0.08591030f, 
    0.12903339f, 0.10646196f, 0.12510866f, 0.24011873f, -0.02304808f, 0.20784958f, 0.00103890f, -0.26353580f, 
    -0.04186114f, -0.17336060f, -0.13351548f, 0.06016828f, -0.15818956f, 0.00465060f, -0.09384877f, -0.01529750f, 
    0.23151359f, 0.00416536f, 0.17617001f, 0.20515835f, 0.16231722f, 0.02489904f, -0.35868520f, 0.04542078f, 
    -0.06592014f, -0.11506463f, 0.06339970f, 0.32276043f, -0.31820810f, 0.06240705f, -0.19813177f, -0.19466713f, 
    -0.07113488f, 0.36052617f, 0.09016573f, -0.22244151f, -0.16644542f, -0.11520606f, -0.08305492f, 0.07897776f, 
    0.29603398f, 0.15294054f, 0.14043647f, 0.16822168f, -0.26126581f, 0.32397863f, -0.22302237f, 0.12241911f, 
    -0.06679426f, -0.06434955f, 0.26218876f, 0.07096792f, -0.14251262f, -0.24629374f, -0.10689098f, -0.05001209f, 
    -0.74381435f, 0.16079374f, -0.06487057f, 0.37659112f, 0.22283255f, -0.00567097f, -0.12479517f, 0.05009466f, 
    0.13198765f, 0.12213285f, -0.29978573f, 0.04917304f, 0.15144461f, -0.31544694f, 0.19598214f, 0.12479652f, 
    0.04481344f, 0.05612730f, -0.03715030f, -0.09704250f, 0.15420970f, 0.04203818f, 0.10265785f, 0.02316626f, 
    0.18948770f, -0.14768282f, -0.40537608f, 0.39861917f, 0.06582038f, -0.02217367f, 0.01799350f, -0.05134295f, 
    -0.10581631f, 0.03063158f, -0.04587283f, 0.08506530f, 0.57750195f, 0.51904488f, -0.11377539f, -0.15840203f, 
    0.08848844f, 0.13929646f, 0.23849709f, 0.07050535f, -0.01750964f, -0.04661494f, 0.01476136f, -0.01005032f, 
    0.09010261f, 0.00624232f, 0.39944252f, -0.04073466f, 0.03409109f, -0.06084068f, 0.03015986f, -0.08445499f, 
    0.01703701f, -0.07588705f, -0.06425364f, 0.01665659f, 0.01278831f, -0.18244869f, -0.15600094f, 0.01812244f, 
    0.09526987f, 0.04270025f, 0.03373424f, -0.03532363f, 0.14369039f, -0.15873060f, -0.13171099f, 0.01248373f, 
    0.27379695f, 0.09897957f, 0.02737956f, -0.12547737f, 0.13559036f, 0.05965935f, -0.02778185f, -0.06825761f, 
    0.16253388f, -0.06038482f, 0.01716115f, 0.02451533f, 0.41997623f, 0.11850738f, 0.18458356f, -0.32335719f, 
    0.15391791f, -0.08923469f, 0.09613041f, 0.08592396f, 0.08395626f, -0.04835966f, -0.19309829f, -0.12421662f, 
    0.07118090f, -0.26490477f, 0.01100832f, 0.18381797f, 0.02549281f, 0.12642738f, -0.09365008f, -0.04301088f, 
    -0.00889231f, -0.06035320f, 0.11675005f, 0.00059045f, -0.02312572f, -0.05992129f, -0.03060058f, 0.10849607f, 
    0.02052850f, 0.03509538f, -0.00090737f, -0.05535901f, 0.12865065f, 0.08220212f, -0.09230734f, -0.01573233f, 
    -0.13769980f, -0.29315248f, 0.21771514f, 0.16058432f, -0.13661987f, -0.04369614f, -0.04398241f, 0.16683361f, 
    0.14195022f, -0.01879619f, -0.01774837f, -0.05755608f, 0.19114004f, 0.03491434f, -0.19331229f, 0.11248226f, 
    0.16050644f, -0.02627855f, 0.22099617f, -0.12246718f, 0.03150832f, -0.05263886f, 0.06914918f, -0.00005690f, 
    0.04084989f, -0.33033118f, -0.32509434f, 0.33280259f, -0.07593503f, -0.01989083f, -0.03785610f, -0.00752609f, 
    -0.01323693f, 0.02124741f, 0.06506928f, 0.05961776f, -0.09532408f, -0.14930791f, -0.17084695f, -0.16703400f, 
    0.05171039f, -0.09253534f, -0.03272638f, 0.05059985f, -0.02663490f, -0.06182843f, -0.00799520f, 0.18333073f, 
    -0.14984725f, -0.08493479f, 0.01619218f, 0.11605309f, -0.03967711f, -0.06049198f, -0.00115894f, -0.08824053f, 
    0.09316130f, 0.09449554f, 0.06549800f, 0.16282937f, -0.13036877f, -0.15852013f, -0.18198849f, 0.22748946f, 
    0.18520272f, -0.05106740f, -0.09062766f, -0.05891109f, 0.06871270f, 0.02718464f, 0.08986534f, -0.10852984f, 
    0.28127635f, -0.46483311f, -0.26337194f, -0.25719449f, 0.13772579f, 0.03788253f, -0.21166497f, -0.07211744f, 
    0.15606007f, 0.09881318f, 0.03807062f, -0.11448151f, 0.09749282f, 0.57254690f, 0.30136719f, -0.06338977f, 
    0.13681376f, 0.22636673f, 0.07645290f, 0.21007298f, 0.02113697f, -0.05774419f, -0.01109954f, 0.13279514f, 
    0.40827724f, -0.21022408f, -0.35367882f, -0.52367103f, -0.07083227f, -0.13237688f, 0.17862391f, 0.01713145f, 
    0.00611134f, 0.04770692f, -0.09011848f, 0.00695791f, 0.40303639f, 0.16897109f, 0.10213392f, -0.11717911f, 
    0.16815645f, 0.34092858f, 0.10579844f, 0.09075976f, 0.03892394f, -0.00775162f, -0.00954893f, 0.03470072f, 
    0.47584495f, -0.21027021f, -0.23039527f, 0.07173446f, 0.00153920f, -0.04940279f, 0.01247269f, -0.04318342f, 
    -0.02674210f, -0.16924044f, -0.05169063f, -0.08259913f, -0.11771188f, 0.48675451f, -0.37459579f, 0.30878893f, 
    -0.02066099f, -0.00682496f, -0.03089284f, 0.04605193f, -0.06960880f, 0.06289220f, -0.11065620f, 0.03647802f, 
    0.21982986f, -0.04665829f, -0.05974951f, -0.44947127f, 0.02966149f, -0.00658128f, 0.02266876f, 0.00367329f, 
    0.20909788f, -0.07298944f, -0.13823213f, -0.05337445f, -0.44961452f, -0.14167945f, -0.01907928f, 0.26548931f, 
    0.05237875f, -0.03653309f, -0.08890954f, 0.09901481f, -0.00019248f, 0.03503874f, 0.03770288f, 0.05144699f, 
    0.40387943f, 0.43662062f, -0.00526651f, -0.19996929f, 0.13804008f, 0.22977002f, 0.18094009f, 0.20999458f, 
    0.02581540f, -0.02028928f, -0.02886751f, 0.02417739f, 0.09530623f, -0.21570465f, -0.25150004f, -0.32741591f, 
    0.17777959f, 0.18581060f, -0.09483658f, 0.07408664f, 0.13427764f, 0.08890244f, 0.02888779f, 0.03347513f, 
    -0.12089846f, -0.11542091f, -0.30793798f, -0.01448125f, -0.01660042f, -0.05424045f, -0.03083212f, -0.07534888f, 
    -0.02326607f, 0.01151737f, -0.03727024f, -0.00124265f, 0.05187559f, 0.00339519f, 0.10020268f, -0.22770336f, 
    0.09421656f, -0.01563136f, -0.03919410f, 0.12240353f, -0.01787146f, 0.00392233f, 0.00567393f, 0.05846692f, 
    0.10157672f, -0.10905366f, 0.04257147f, 0.00811979f, 0.15214612f, 0.18623482f, 0.10741233f, -0.16371328f, 
    0.06158881f, -0.01847140f, -0.10908931f, -0.06906757f, -0.52684742f, -0.25046417f, 0.08078696f, 0.07763641f, 
    0.10138911f, -0.01840699f, 0.04261706f, -0.04455242f, 0.08837910f, -0.08248580f, 0.07338023f, 0.14325316f, 
    -0.24786767f, 0.47098657f, -0.29716048f, 0.36790928f, 0.01388635f, -0.04392447f, -0.08162393f, -0.14793360f, 
    -0.03219304f, -0.01049373f, 0.01385778f, 0.10418738f, -0.47558999f, 0.19625710f, -0.20489611f, 0.10381891f, 
    -0.02920427f, 0.10870482f, 0.04282049f, 0.02721919f, 0.10534617f, 0.12314962f, -0.00071439f, 0.01543113f, 
    0.02567176f, -0.01210125f, -0.00244629f, -0.05141437f, 0.02870646f, 0.01908039f, -0.01879513f, 0.02108725f, 
    0.01318743f, 0.01097790f, -0.00352762f, -0.02361128f, -0.02313137f, -0.04210380f, 0.02451798f, 0.03752301f, 
    -0.00406100f, -0.05085696f, 0.01140716f, -0.01116141f, -0.04288389f, 0.02270610f, 0.03612771f, -0.03921465f, 
    -0.02390975f, -0.02150799f, -0.03778248f, 0.00999372f, 0.02022622f, -0.01094510f, -0.00000288f, 0.00386228f, 
    -0.02976221f, -0.01485295f, -0.02339716f, -0.04763291f, -0.03820893f, -0.01730697f, -0.05477376f, 0.01911327f, 
    -0.05903466f, 0.00471167f, -0.02659494f, -0.02675626f, -0.02930256f, -0.01627536f, 0.00887210f, -0.01205900f, 
    -0.04779438f, 0.02033546f, -0.03647505f, -0.01517406f, -0.01691157f, -0.03718530f, -0.03713780f, -0.05030534f, 
    -0.01287562f, 0.02031041f, -0.03651318f, -0.03375588f, 0.01600934f, -0.05886815f, 0.01300399f, 0.02169494f, 
    0.02161296f, 0.00570965f, -0.02027392f, 0.00637213f, -0.05597843f, -0.05900509f, -0.04161053f, -0.04763239f, 
    -0.05635080f, -0.00527278f, 0.03330432f, -0.02501095f, -0.03336959f, 0.03278322f, -0.01151028f, -0.01170580f, 
    -0.04961256f, -0.04063676f, -0.05565033f, 0.01458390f, -0.02115877f, -0.00552653f, -0.03385081f, -0.05624296f, 
    0.00252860f, 0.01031775f, -0.00057060f, -0.01594933f, 0.01586516f, -0.04452439f, 0.02779443f, -0.02353642f, 
    -0.03842914f, 0.03740667f, 0.00162376f, -0.02685607f, 0.01906888f, -0.03850952f, -0.00435103f, -0.04561353f, 
    0.03478343f, -0.00403105f, 0.03850090f, 0.03605144f, -0.05521707f, 0.03271345f, 0.03981365f, -0.05976178f, 
    -0.04184129f, 0.00036405f, -0.02842855f, 0.04116864f, -0.03722553f, -0.01311659f, -0.04370093f, -0.01081003f, 
    -0.04777246f, -0.02767531f, -0.01957909f, -0.01538383f, -0.00450931f, -0.01377577f, -0.05335658f, -0.05655815f, 
    -0.04452869f, 0.00005751f, 0.01550863f, 0.01305978f, -0.02337065f, 0.02046619f, -0.06140345f, -0.01421547f, 
    0.01786982f, 0.00336727f, -0.03246982f, -0.05178632f, -0.02592673f, 0.03242455f, 0.01653086f, -0.03142829f, 
    -0.01037584f, -0.02859606f, -0.00615080f, 0.02141813f, -0.03364685f, 0.03665560f, 0.03724003f, 0.00135562f, 
    0.00492890f, -0.02877842f, -0.00138916f, 0.01726327f, -0.03684787f, 0.02363268f, 0.02890872f, -0.02753888f, 
    -0.04837331f, 0.01166238f, -0.00982186f, 0.01405326f, 0.00199183f, -0.01205576f, 0.04234507f, 0.01390248f, 
    0.03327770f, -0.00990122f, 0.02572091f, 0.03266773f, -0.03415036f, -0.00538117f, -0.00236936f, -0.05597331f, 
    0.02158578f, -0.00600728f, 0.03024172f, -0.05650005f, -0.02038526f, -0.05848711f, -0.01392439f, -0.01629760f, 
    0.03684787f, -0.01556101f, -0.04424699f, -0.00537161f, -0.02520369f, -0.05495426f, 0.02683531f, -0.05934484f, 
    -0.03852347f, -0.00990819f, -0.01235504f, -0.01370049f, -0.03639926f, -0.01802529f, 0.03915500f, -0.02033078f, 
    0.03502050f, 0.04000172f, 0.02744834f, 0.01076277f, -0.04472200f, -0.00314853f, 0.02350852f, -0.01305399f, 
    -0.02455043f, -0.00116074f, -0.03038082f, -0.01527082f, -0.05860607f, -0.00533382f, 0.04087509f, 0.03049522f, 
    0.00408845f, 0.02959853f, -0.00786051f, 0.00258096f, 0.03620248f, 0.00711382f, -0.05484916f, 0.01334362f, 
    -0.04015107f, 0.03876645f, -0.02264297f, -0.03844696f, 0.00091063f, -0.05783670f, -0.02911712f, 0.02512177f, 
    -0.03143081f, -0.04116731f, -0.02921703f, -0.01330509f, -0.01871952f, -0.01494870f, -0.02109913f, -0.00512350f, 
    -0.06079932f, 0.01408222f, -0.05152668f, 0.00259880f, -0.05719193f, 0.03549781f, -0.05840103f, 0.02731327f, 
    0.03682513f, -0.03144281f, -0.04055713f, -0.03908758f, -0.04200318f, 0.00005096f, -0.00289212f, -0.05834268f, 
    -0.03467765f, 0.01890059f, -0.01301319f, -0.04177530f, 0.03692623f, 0.01332421f, -0.02252788f, -0.00582803f, 
    -0.01968537f, -0.05974153f, -0.02035608f, 0.04072179f, -0.03734518f, -0.03834592f, -0.03942220f, 0.01457309f, 
    0.00242825f, 0.02450378f, -0.04287203f, -0.02726903f, 0.03413226f, -0.03515124f, -0.03811728f, -0.01308822f, 
    -0.01076990f, -0.00188761f, -0.00506130f, 0.01602970f, -0.04711819f, 0.01258596f, 0.00978932f, 0.02782950f, 
    -0.05273020f, -0.04152850f, 0.01318723f, -0.05389683f, 0.01013652f, -0.00704314f, -0.00534861f, -0.05472637f, 
    -0.04170912f, 0.01218896f, 0.00083237f, -0.01212118f, -0.04156094f, 0.04659873f, -0.00665571f, -0.03609899f, 
    0.03175764f, 0.02300121f, -0.01354233f, 0.02786890f, -0.01425303f, -0.03162306f, -0.04108665f, 0.02670097f, 
    0.01103858f, 0.00118653f, 0.02717796f, -0.00889882f, -0.01411910f, -0.01884124f, -0.00259517f, -0.01828948f, 
    0.01806741f, 0.02850399f, 0.02022115f, 0.02707973f, -0.03528867f, -0.03008707f, 0.00689021f, 0.03216146f, 
    -0.05924778f, -0.05407527f, 0.03142224f, 0.03888137f, -0.02672425f, 0.03859803f, 0.02431049f, -0.05797189f, 
    0.02169359f, 0.03524282f, -0.00153754f, 0.03489890f, -0.04536491f, -0.01714103f, 0.02236003f, 0.03004620f, 
    0.01768365f, 0.02473124f, 0.04083054f, -0.04115344f, -0.00888921f, 0.03650230f, -0.04117287f, -0.01380236f, 
    0.02318427f, -0.01294014f, -0.00370824f, -0.00051932f, 0.00031577f, -0.02960480f, 0.02429664f, 0.03127256f, 
    -0.03693555f, 0.02153903f, -0.03275547f, 0.00013588f, -0.03280828f, -0.00737237f, 0.03374746f, 0.01902775f, 
    -0.00825653f, -0.05505312f, 0.03854840f, 0.03718289f, -0.03529253f, 0.00736209f, -0.01344442f, -0.00265300f, 
    -0.02999301f, -0.01468852f, -0.02722187f, -0.01742031f, -0.04956657f, -0.01049799f, 0.02550290f, -0.01473483f, 
    0.01954235f, -0.03669181f, -0.02303495f, -0.00630068f, -0.01586034f, 0.03113754f, -0.03878144f, -0.02440789f, 
    -0.01328051f, -0.00855200f, 0.03797979f, -0.01991343f, 0.02363338f, -0.04359777f, -0.03607211f, 0.01627427f, 
    0.01694852f, 0.01253773f, -0.03199719f, -0.04344095f, -0.05841976f, -0.00648530f, -0.05135009f, -0.05837910f, 
    -0.01781536f, -0.02740888f, -0.05756652f, 0.04750722f, -0.02858610f, 0.02876476f, -0.05763291f, -0.01801928f, 
    0.03392444f, -0.05149952f, -0.04556732f, -0.04154284f, -0.03590905f, -0.02874883f, -0.02093128f, 0.03188511f, 
    0.02858649f, -0.00283734f, -0.04198448f, 0.01440524f, 0.01628319f, 0.01079812f, -0.02368152f, -0.03816293f, 
    0.02240686f, 0.00895298f, 0.00103719f, -0.03447845f, 0.00171815f, 0.01468531f, -0.00943154f, 0.02527314f, 
    -0.03801750f, -0.00180756f, 0.00127772f, -0.05123310f, -0.02756330f, -0.01934250f, -0.03249989f, 0.04463496f, 
    0.00733307f, -0.04746255f, 0.03303104f, 0.02569471f, -0.03691988f, 0.02398864f, 0.00372023f, 0.04277162f, 
    0.01294883f, 0.01822386f, 0.01196009f, 0.03570582f, 0.02587144f, 0.00703944f, -0.01508260f, 0.00348538f, 
    0.03881598f, 0.03077043f, 0.00461284f, 0.01701771f, -0.00403599f, -0.00294946f, -0.02299287f, -0.05286096f, 
    -0.00699707f, 0.01680506f, -0.02638683f, -0.03032253f, -0.02868798f, 0.01099985f, -0.02326838f, 0.03162461f, 
    0.03743941f, -0.00410358f, -0.05536653f, 0.02576729f, -0.02617570f, 0.01965639f, -0.03224935f, -0.03761416f, 
    -0.00672547f, 0.00421915f, -0.00419781f, 0.03375270f, 0.03961950f, 0.00637686f, 0.01942690f, -0.00990603f, 
    -0.05151461f, -0.01610247f, 0.00069779f, -0.01059693f, 0.04080044f, -0.01959059f, 0.00577129f, 0.01236070f, 
    -0.03169496f, -0.04249727f, -0.04852204f, -0.02586775f, 0.00192280f, -0.04708869f, 0.02439780f, -0.04068583f, 
    -0.00818921f, -0.03895899f, -0.00773066f, -0.02726393f, 0.04452382f, 0.00109602f, -0.04300811f, -0.03380895f, 
    -0.02200351f, -0.03024829f, 0.00545416f, 0.02931998f, 0.02823219f, 0.01496902f, -0.04926778f, -0.05386385f, 
    -0.04619242f, -0.03203550f, -0.04235172f, -0.02899173f, -0.00869701f, 0.03477262f, 0.04126784f, 0.03996597f, 
    0.01132393f, -0.02139982f, -0.00152041f, 0.02868523f, -0.03528046f, 0.03515199f, 0.03470425f, -0.05684866f, 
    0.00222687f, -0.03535429f, 0.00914866f, -0.00829424f, -0.05468653f, -0.03513408f, 0.01626487f, -0.04438535f, 
    -0.03861332f, 0.01151377f, 0.03510560f, 0.04186918f, -0.01077197f, 0.02116819f, -0.01209413f, 0.00201687f, 
    -0.03677284f, 0.04393032f, -0.01775302f, -0.05979609f, -0.02577875f, -0.04472470f, 0.00250883f, -0.01181145f, 
    0.02462260f, -0.03285050f, 0.03028461f, -0.04346639f, -0.02719001f, -0.03028838f, -0.02028077f, -0.02866347f, 
    -0.05493039f, 0.01005503f, -0.05368708f, -0.01717312f, -0.00240787f, 0.01352441f, 0.02445051f, 0.00417356f, 
    0.02980640f, -0.03593142f, -0.03288122f, -0.01656778f, -0.03614531f, -0.03729014f, -0.04669130f, 0.01599859f, 
    -0.00167850f, -0.05726602f, -0.00908855f, -0.00728586f, -0.04418943f, -0.04231275f, -0.05792183f, -0.03804102f, 
    0.00719286f, -0.05326717f, -0.05674043f, 0.00223310f, 0.03420407f, -0.01009673f, -0.02609615f, 0.01264834f, 
    0.01798320f, 0.00121956f, 0.00954151f, -0.01227764f, 0.04438499f, -0.03338868f, -0.01214221f, -0.04376726f, 
    -0.01340140f, -0.02868037f, -0.02988709f, 0.02887075f, -0.00082614f, -0.03830719f, 0.02072098f, 0.01840719f, 
    -0.01505949f, 0.02033798f, -0.02430555f, 0.00965332f, -0.02137799f, -0.00095296f, 0.02079424f, -0.03773723f, 
    0.00321216f, -0.05786688f, -0.04900555f, 0.00380340f, 0.03083070f, 0.01345877f, -0.04260829f, 0.02575361f, 
    0.03557468f, -0.01432801f, -0.02396532f, 0.02820381f, -0.02439101f, 0.00282790f, -0.01192023f, -0.00822539f, 
    -0.05779566f, 0.03808574f, 0.00063382f, 0.00096142f, -0.03557999f, -0.00047972f, 0.00336464f, -0.05651763f, 
    0.02233620f, -0.04468537f, -0.04089966f, 0.02216220f, -0.00814718f, 0.01541376f, -0.00417519f, 0.01196169f, 
    -0.03531114f, 0.03711472f, -0.04329284f, -0.03429976f, -0.02586495f, 0.04155742f, 0.02343659f, -0.00311618f, 
    -0.05185769f, 0.01939472f, -0.05013584f, 0.00473305f, -0.04233645f, 0.01890395f, -0.02133603f, 0.03211310f, 
    0.02870655f, -0.00681908f, -0.04451383f, 0.03797636f, 0.02691769f, 0.03570284f, 0.02752856f, 0.03311836f, 
    0.01573109f, 0.01217995f, -0.01442757f, -0.05345492f, 0.03156301f, -0.03762004f, 0.01763145f, 0.02298697f, 
    0.03244871f, 0.00470075f, 0.00202259f, -0.02104055f, -0.00999298f, 0.02281181f, -0.03964635f, -0.04257264f, 
    0.00581707f, -0.00388561f, 0.00369673f, 0.02523244f, -0.01046184f, 0.03230958f, -0.01128026f, -0.04281896f, 
    -0.03616717f, 0.03048943f, -0.05537889f, -0.02996087f, 0.00203833f, -0.05249064f, 0.01476775f, -0.00917684f, 
    -0.02261143f, -0.05045703f, -0.04269459f, -0.01816400f, -0.03604034f, -0.03703197f, -0.01034591f, 0.03341435f, 
    0.00235363f, -0.03657831f, -0.00896873f, -0.02133578f, -0.02607959f, -0.04779112f, 0.02724941f, 0.01620499f, 
    -0.05115264f, -0.01411235f, -0.02612355f, -0.02469385f, -0.01280240f, 0.03302138f, -0.01319982f, 0.03373727f, 
    0.03271386f, -0.02101415f, -0.01088389f, 0.04172723f, 0.04023582f, -0.03808689f, 0.01937792f, 0.00224633f, 
    0.02645473f, 0.00543429f, -0.02335022f, -0.00786199f, -0.05467556f, -0.01606171f, 0.02291487f, -0.02924793f, 
    0.00672823f, -0.02026930f, 0.01998952f, 0.01598967f, 0.00777917f, 0.02243404f, 0.04347304f, 0.03454993f, 
    -0.00628650f, -0.04082431f, 0.02049956f, 0.01061965f, 0.01797043f, 0.03508953f, 0.02401900f, -0.04255135f, 
    0.00215142f, -0.03889140f, 0.01768525f, -0.04234798f, -0.00789710f, 0.03183825f, 0.02292215f, 0.02049031f, 
    0.03892693f, -0.03804157f, 0.03058020f, -0.03068073f, -0.03767421f, -0.04377849f, 0.03196306f, -0.04590481f, 
    -0.02965160f, 0.02804842f, 0.03941799f, 0.01844308f, -0.04998200f, -0.03081020f, -0.04675259f, -0.01747545f, 
    -0.02323394f, -0.00359120f, -0.02976492f, 0.03581423f, 0.02772672f, -0.00331803f, -0.01367440f, 0.01432630f, 
    -0.00871037f, 0.03174053f, 0.03335812f, -0.02515759f, 0.01488419f, -0.05427427f, 0.00030658f, -0.01389016f, 
    -0.02525989f, 0.03888192f, 0.01349589f, -0.03422260f, -0.03659308f, -0.01924977f, 0.03071587f, 0.02700701f, 
    0.01351864f, -0.01072312f, 0.00440152f, -0.04986989f, 0.04374084f, -0.02052227f, 0.01071500f, 0.01717469f, 
    -0.03945953f, -0.03830691f, 0.02196118f, 0.00408420f, -0.00918933f, -0.05323114f, 0.00882269f, 0.00181391f, 
    0.00360228f, -0.01593455f, 0.02950059f, -0.01872775f, -0.02255183f, -0.05273838f, 0.02102240f, -0.00835685f, 
    -0.02274890f, 0.02629541f, 0.02610284f, -0.02710977f, 0.00423954f, 0.03477289f, -0.05431292f, -0.05048842f, 
    -0.03222372f, -0.02829040f, -0.02244380f, 0.01395829f, -0.02857073f, -0.05555389f, -0.01114344f, 0.04738661f, 
    -0.03405311f, 0.04847846f, -0.02988748f, -0.04178133f, -0.00035117f, -0.05222772f, -0.02118435f, -0.01497262f, 
    0.03732553f, -0.00657291f, -0.05337603f, 0.02279090f, -0.01584725f, -0.03918000f, 0.01216110f, 0.03276165f, 
    0.00979336f, 0.02892248f, 0.00604595f, 0.04868526f, 0.03149308f, -0.02629370f, 0.01376969f, 0.00600477f, 
    -0.02018807f, -0.02785816f, -0.01091951f, 0.02599847f, 0.03601001f, 0.03366038f, -0.01618912f, -0.02042243f, 
    -0.05046492f, 0.05042620f, -0.03512195f, 0.03693098f, -0.04132653f, -0.01304176f, -0.02608180f, -0.02435116f, 
    -0.05046492f, -0.05704370f, -0.01433630f, 0.03668827f, 0.02489545f, 0.00560193f, -0.02265162f, -0.05138944f, 
    0.04846141f, -0.01454755f, 0.01651561f, 0.03379738f, -0.01360061f, -0.02224099f, -0.02643960f, -0.02794295f, 
    0.01723813f, 0.03160903f, 0.03243840f, 0.03928553f, -0.02632368f, -0.01984864f, 0.02797036f, -0.03439311f, 
    -0.01560055f, -0.00218899f, 0.03483117f, -0.01998627f, -0.04807615f, 0.00425051f, -0.02356630f, -0.02627762f, 
    -0.03132248f, 0.01848939f, -0.00118088f, -0.00130550f, -0.00023787f, -0.01389016f, -0.04688348f, 0.01110815f, 
    0.00029367f, -0.00386649f, 0.03026254f, -0.03945735f, -0.01072169f, 0.00591520f, 0.02024277f, 0.00730878f, 
    -0.04882413f, 0.02182969f, 0.03053963f, 0.04086211f, 0.01086431f, -0.03243933f, 0.01714195f, -0.05957446f, 
    -0.00058671f, -0.04221619f, -0.01426494f, -0.00704260f, -0.04090148f, -0.03337656f, -0.01311932f, -0.01071961f, 
    -0.03083564f, 0.04386235f, -0.05237072f, 0.03021524f, 0.00656438f, -0.04367627f, -0.03153701f, 0.01962595f, 
    0.02578765f, -0.05500916f, -0.03777099f, 0.01980259f, -0.00846223f, 0.04242692f, 0.01141832f, 0.02544793f, 
    0.03848435f, 0.01199939f, 0.03057605f, -0.05388292f, -0.00654526f, -0.02900925f, 0.00192841f, -0.04279227f, 
    -0.06132586f, 0.00202374f, -0.03704329f, -0.05087407f, -0.03339459f, -0.01280347f, 0.01113380f, -0.01985085f, 
    -0.04253326f, 0.03338275f, 0.00653272f, 0.03996049f, 0.03516328f, 0.03405070f, -0.01460419f, -0.00006416f, 
    -0.03965592f, -0.03827889f, -0.02664203f, 0.00848179f, 0.00691961f, -0.03740267f, -0.05520977f, 0.01162001f, 
    -0.02232310f, -0.05462089f, -0.00170101f, -0.00522192f, -0.02398668f, -0.01879142f, -0.00477543f, 0.02895578f, 
    0.03744498f, -0.02380400f, -0.04198506f, 0.00960463f, 0.00068241f, -0.02085739f, -0.02524417f, -0.04675189f, 
    0.02342708f, 0.03744686f, -0.05321356f, 0.01551260f, 0.00439674f, 0.02069352f, 0.00278326f, -0.03849583f, 
    -0.00952740f, 0.03033382f, -0.03823512f, 0.04304250f, 0.00002489f, -0.02408326f, -0.01547774f, 0.02358634f, 
    -0.00762924f, -0.06031778f, 0.00294967f, -0.01017708f, 0.02855818f, 0.01489506f, -0.04140952f, -0.05862718f, 
    0.03292847f, -0.05334732f, 0.02619247f, -0.05256459f, 0.00841507f, -0.01973472f, -0.05355607f, 0.03427754f, 
    0.03807037f, -0.04596502f, 0.00144061f, 0.01294421f, -0.03494393f, 0.01262199f, -0.04043680f, -0.02810230f, 
    -0.01243312f, -0.04881074f, 0.02447641f, -0.01486301f, 0.03388619f, -0.00801165f, 0.02389852f, -0.01876288f, 
    -0.02437837f, 0.04019459f, 0.01035666f, -0.00637562f, 0.00997949f, -0.01894572f, -0.03179339f, -0.01495561f, 
    0.03502950f, -0.04239804f, -0.00323260f, -0.04960091f, -0.01214350f, 0.00814988f, -0.01859008f, -0.01778379f, 
    0.02475537f, -0.04596692f, -0.00143243f, -0.05540877f, -0.05491043f, -0.00878251f, -0.02152155f, -0.05169060f, 
    0.03951593f, -0.01995867f, -0.00982151f, 0.00021945f, 0.03878502f, -0.00598670f, 0.03724249f, 0.00848430f, 
    -0.05300593f, -0.04286345f, -0.01262297f, -0.03899525f, 0.03910822f, 0.00031258f, -0.04755678f, 0.04976398f, 
    0.01579974f, 0.01727374f, -0.00325736f, -0.05332026f, -0.00854594f, 0.01893838f, -0.00396689f, 0.00488537f, 
    0.03993603f, -0.00886741f, 0.04083800f, 0.01425535f, -0.01074316f, 0.03310961f, 0.02358640f, -0.00222094f, 
    -0.01439791f, -0.01897684f, -0.05550157f, 0.02070766f, 0.01289005f, 0.02504762f, -0.04987631f, 0.01957752f, 
    0.03340167f, 0.03639911f, 0.00543266f, 0.01332286f, 0.01858071f, -0.04968672f, -0.01547314f, -0.00267251f, 
    0.03916746f, -0.04088381f, -0.00673529f, -0.03256831f, -0.04236495f, -0.00500016f, 0.01954171f, 0.02939170f, 
    0.00238480f, -0.01332293f, -0.02329726f, 0.03077563f, 0.02053242f, -0.03682252f, 0.03460693f, 0.01236685f, 
    -0.00177504f, -0.01994380f, -0.02484614f, 0.01071058f, -0.04002394f, -0.04009311f, -0.04769779f, 0.01501460f, 
    0.00175808f, 0.02815954f, -0.03324858f, -0.01198193f, -0.02626668f, 0.00745115f, -0.02827138f, 0.01197458f, 
    0.02384776f, 0.02492462f, 0.02556762f, -0.01016045f, 0.01193611f, -0.04626983f, -0.03836598f, 0.00251453f, 
    -0.05704399f, -0.02028229f, -0.01897692f, 0.00098726f, -0.05749555f, 0.01231844f, 0.01014393f, 0.00517153f, 
    0.01740294f, 0.02928114f, -0.02184738f, 0.01955218f, -0.05653261f, 0.01477968f, -0.00292312f, 0.00995242f, 
    0.02360369f, 0.00880594f, 0.03332589f, -0.04465090f, -0.04459285f, -0.01591451f, -0.02269401f, -0.00480549f, 
    -0.04074762f, -0.02148064f, -0.03536432f, -0.04115100f, -0.05088506f, 0.03931777f, -0.03130122f, -0.05507755f, 
    -0.04648430f, -0.04142618f, -0.03746374f, 0.03565468f, -0.05892077f, -0.04617805f, 0.00840108f, 0.04096944f, 
    0.01335380f, 0.00481039f, 0.00096645f, -0.01732084f, 0.01981614f, -0.03576734f, -0.02705576f, -0.02276139f, 
    -0.03028584f, 0.00595686f, 0.01005800f, 0.01920178f, 0.03833897f, -0.04489975f, -0.00872819f, 0.03839190f, 
    -0.01319044f, 0.02632931f, -0.01915686f, -0.05743636f, -0.04344291f, -0.02252629f, 0.02761547f, -0.02751077f, 
    -0.00227248f, 0.02262787f, 0.00299183f, 0.02127659f, 0.02787151f, -0.01706562f, -0.05472495f, 0.02945269f, 
    0.00537106f, 0.01998202f, -0.00075723f, 0.03708537f, 0.03088441f, -0.00433479f, 0.04928011f, -0.04561659f, 
    -0.04745255f, 0.04124705f, -0.03274066f, 0.01329839f, -0.04441691f, 0.03265843f, -0.01856192f, -0.02081950f, 
    -0.03922273f, 0.03004163f, -0.01247932f, -0.01861357f, 0.00932398f, 0.03438877f, 0.01195904f, 0.03469057f, 
    -0.04321013f, -0.04406919f, -0.03770021f, 0.00515716f, 0.01294841f, 0.02624581f, 0.01228922f, -0.04615304f, 
    0.04013992f, -0.02502575f, 0.00085971f, -0.05517963f, -0.00948816f, -0.05229299f, 0.01851116f, -0.04372032f, 
    0.01096856f, -0.05132525f, 0.03235768f, 0.04224901f, 0.02926054f, -0.03671222f, 0.01343613f, 0.02598985f, 
    -0.04088072f, 0.04069071f, -0.00002506f, 0.02540294f, 0.01924812f, -0.01566945f, 0.00342835f, 0.01944986f, 
    -0.03509375f, -0.00232371f, 0.01018871f, -0.01040307f, 0.03247174f, -0.04087237f, 0.05464561f, 0.02621854f, 
    -0.01618636f, -0.01532079f, 0.01665981f, -0.03931769f, 0.00913968f, -0.03123986f, -0.03200239f, 0.01225881f, 
    -0.03476781f, 0.01097294f, -0.05622435f, 0.03044838f, -0.03802942f, -0.01004116f, -0.01361183f, -0.02858803f, 
    -0.05229108f, -0.03624742f, -0.03925589f, -0.02344244f, -0.04489636f, -0.00643119f, 0.03910565f, -0.02806209f, 
    -0.00117561f, -0.05881974f, -0.00479937f, 0.02059382f, -0.04013615f, 0.04270231f, -0.04671920f, 0.00349502f, 
    -0.02942722f, 0.03972291f, -0.02401495f, 0.02638145f, -0.00951736f, 0.04234298f, -0.00928262f, -0.04481288f, 
    -0.03289896f, -0.00450014f, -0.00144105f, 0.00278116f, 0.02731287f, 0.03517446f, -0.04968788f, 0.00366091f, 
    0.00434144f, -0.04998457f, -0.02285078f, -0.03049874f, -0.05346027f, 0.04490982f, -0.01056946f, -0.04464196f, 
    0.00651964f, -0.01899186f, -0.00056618f, -0.05248554f, 0.02741785f, 0.00923053f, -0.01742416f, -0.03846661f, 
    -0.01717729f, 0.02574089f, -0.05870258f, 0.02898916f, -0.00879731f, -0.03226510f, -0.03299036f, 0.04355925f, 
    -0.04061724f, -0.01511027f, -0.05870619f, -0.01222282f, 0.00555624f, -0.02012672f, -0.03634686f, 0.00940308f, 
    -0.02687756f, -0.00958403f, -0.03193738f, 0.01684337f, -0.02146224f, -0.03935599f, 0.01759246f, -0.03049779f, 
    -0.01252736f, 0.03279827f, 0.04217014f, 0.01847000f, -0.00873251f, 0.00426456f, 0.02521638f, 0.02256749f, 
    0.00067623f, 0.00464310f, -0.05319518f, -0.01925723f, -0.01578481f, -0.02447359f, 0.03634931f, 0.03621247f, 
    -0.03180666f, -0.01179061f, 0.03771491f, 0.02794756f, -0.02224495f, 0.00418768f, -0.02390454f, -0.00632900f, 
    0.02707498f, -0.03215425f, 0.03310204f, -0.01102166f, -0.03862778f, -0.01697334f, -0.00834173f, 0.00539628f, 
    -0.04437078f, -0.05631749f, 0.04143709f, 0.01262873f, 0.01519201f, -0.03966570f, -0.01272087f, 0.00384009f, 
    0.04261922f, -0.01260834f, 0.04413388f, 0.00863351f, 0.03661918f, -0.04463709f, -0.00456275f, -0.03399514f, 
    0.02048118f, 0.03560308f, -0.04625859f, -0.00971355f, 0.04049895f, -0.01192185f, -0.02939711f, 0.00641887f, 
    -0.05388416f, -0.04236446f, 0.02709775f, 0.03435852f, -0.00997949f, -0.03962464f, -0.00710001f, 0.00411186f, 
    0.01893496f, -0.05198986f, -0.00404711f, 0.01855977f, -0.02522964f, -0.01819969f, -0.01799436f, 0.00682711f, 
    -0.00751810f, 0.04689353f, 0.00390000f, -0.00085804f, -0.03314473f, 0.04000926f, 0.05176259f, 0.04081012f, 
    -0.03308065f, 0.02021698f, -0.00955976f, -0.00806639f, -0.00381453f, -0.04636664f, 0.05064498f, -0.00596713f, 
    0.01671991f, -0.05073212f, 0.04422544f, -0.02340858f, -0.00112240f, -0.03004250f, 0.01796573f, 0.03293619f, 
    -0.02928697f, -0.00322169f, 0.01453020f, -0.03182199f, -0.01423692f, 0.00361149f, -0.01429554f, 0.00701321f, 
    -0.02926133f, 0.03583500f, 0.01212523f, 0.00473246f, 0.01006763f, -0.00169472f, 0.00951277f, -0.00948475f, 
    -0.04036118f, -0.00043242f, 0.02530360f, 0.01598836f, -0.03106963f, 0.01319788f, -0.00527203f, -0.05540941f, 
    -0.04914295f, -0.04294560f, 0.05882334f, 0.06482797f, -0.01754322f, -0.05332397f, -0.05363850f, -0.04040047f, 
    -0.03539290f, 0.02694835f, 0.04563484f, -0.01887511f, -0.05922635f, 0.00360722f, -0.02124585f, 0.05319181f, 
    0.04310171f, -0.04657319f, -0.05259763f, -0.00056015f, 0.01636944f, -0.05516225f, 0.02034955f, -0.02181858f, 
    0.01940345f, 0.00957602f, 0.03720998f, -0.03897214f, 0.02960874f, 0.00706664f, 0.02849591f, 0.01967409f, 
    0.03552305f, 0.01645979f, 0.01434838f, -0.03729927f, 0.02567256f, 0.00882956f, 0.00152618f, 0.00467592f, 
    -0.03078141f, 0.02877902f, 0.04817405f, 0.03701322f, 0.00182599f, 0.00363966f, 0.00391551f, 0.01960883f, 
    0.00839655f, 0.03519509f, -0.01304720f, 0.03663976f, 0.04795090f, 0.02880639f, -0.01296230f, -0.03089841f, 
    0.03982285f, 0.01937207f, 0.01648048f, 0.03204071f, -0.00535711f, 0.03609756f, -0.03293875f, -0.00336829f, 
    -0.02703733f, 0.02144668f, 0.00412562f, 0.01038762f, 0.04684594f, 0.00669377f, -0.03657429f, 0.02408035f, 
    -0.06320743f, 0.02296033f, -0.00217835f, -0.04395796f, 0.00038178f, -0.01941061f, 0.03211248f, -0.03242958f, 
    -0.00221536f, -0.05123486f, 0.01958762f, 0.01120208f, -0.01876502f, -0.00515824f, 0.02943750f, 0.05187884f, 
    0.00014480f, 0.01985065f, 0.01785589f, 0.00682590f, -0.01679934f, 0.03831525f, 0.01239021f, -0.02289099f, 
    0.01504946f, -0.05619584f, 0.00044756f, 0.07054827f, 0.01179515f, -0.01499650f, -0.02318545f, -0.02183481f, 
    0.03096773f, -0.02305563f, -0.01576283f, 0.02313938f, -0.00527579f, 0.04835311f, -0.04323441f, -0.02384474f, 
    -0.01788484f, 0.04313870f, -0.03627369f, -0.00832343f, 0.00692073f, -0.02537923f, 0.03231845f, -0.01783592f, 
    -0.07363208f, 0.05228128f, -0.01638254f, 0.06241895f, -0.00926444f, -0.00881654f, 0.04370143f, -0.00377125f, 
    -0.01973816f, 0.01180327f, -0.04343446f, -0.01462785f, 0.05666664f, -0.00598113f, -0.01303767f, -0.01499480f, 
    0.00342119f, 0.00632385f, -0.03657097f, -0.04237130f, -0.05300788f, 0.00234945f, 0.00220927f, 0.04457135f, 
    0.02317359f, 0.02389740f, -0.00986134f, -0.00019752f, -0.01168390f, -0.03773375f, 0.05838379f, 0.01799536f, 
    0.01377163f, -0.01426682f, 0.02177477f, -0.03967088f, -0.01195600f, 0.03286054f, -0.03267203f, -0.01499796f, 
    0.00706412f, -0.05382555f, -0.01905002f, 0.00062956f, -0.04502018f, -0.02567812f, 0.02395709f, -0.05473268f, 
    -0.05008630f, 0.03636998f, -0.02469302f, -0.02351695f, 0.02005485f, 0.00736142f, -0.02195038f, -0.01112056f, 
    -0.03338487f, 0.03978006f, 0.01587884f, 0.00614902f, -0.02458467f, 0.03606787f, -0.03925969f, -0.01664357f, 
    -0.02969626f, -0.04484363f, 0.01007510f, -0.04723598f, 0.00302892f, -0.04762963f, -0.07075004f, -0.02049216f, 
    -0.02078412f, -0.03485528f, 0.03258717f, 0.04037550f, -0.01461711f, 0.03908841f, 0.04055763f, 0.00544529f, 
    0.01294308f, 0.03327613f, 0.01679869f, -0.02705641f, -0.01294750f, -0.04171187f, 0.02435196f, 0.04093591f, 
    0.03224051f, -0.04700999f, -0.03484734f, -0.02694476f, 0.01646388f, -0.05713129f, 0.01730493f, -0.01085253f, 
    0.03103965f, 0.00193476f, 0.03218873f, 0.04486817f, -0.02387431f, 0.03654992f, 0.03355056f, -0.00773701f, 
    0.02490813f, -0.02512280f, -0.05390492f, 0.00630471f, -0.03955471f, -0.02884354f, -0.05332502f, -0.00234564f, 
    0.02770005f, 0.00421404f, -0.03700904f, 0.03895449f, -0.02807089f, -0.00405877f, 0.00710189f, -0.01390686f, 
    0.01313392f, 0.03655412f, 0.03687510f, 0.00178365f, 0.03409259f, -0.01747504f, -0.02018499f, 0.03133933f, 
    -0.00096450f, 0.03509381f, -0.04629469f, -0.03006586f, -0.02581958f, -0.02809939f, -0.02350625f, 0.01350217f, 
    0.01325376f, -0.05891457f, 0.00649523f, -0.03881941f, -0.02734296f, -0.03099798f, -0.02490487f, 0.00401215f, 
    -0.05046735f, -0.00912353f, 0.03919549f, -0.05488715f, -0.00437097f, -0.01693313f, -0.04284865f, 0.04099810f, 
    0.02871008f, 0.01285950f, -0.00892700f, -0.03320927f, 0.02988060f, 0.00528243f, 0.02110618f, 0.01734448f, 
    0.03875483f, -0.01053755f, -0.04174378f, -0.02050274f, 0.00945477f, -0.03112007f, 0.04063781f, -0.04355001f, 
    -0.06288049f, 0.02405882f, -0.05867612f, 0.03126121f, -0.05567998f, -0.01895251f, -0.02571984f, -0.03921419f, 
    -0.01418477f, -0.04077893f, 0.01442263f, -0.04989481f, -0.01860633f, 0.03032765f, 0.03310275f, -0.02078177f, 
    -0.00673167f, -0.00315700f, 0.03139411f, 0.02503206f, 0.03273387f, -0.00415419f, 0.00544982f, 0.04332696f, 
    -0.02559666f, -0.03096057f, -0.00261082f, -0.04616578f, -0.04259080f, 0.00086986f, -0.02882608f, -0.00592896f, 
    0.00991711f, -0.04385061f, -0.00091620f, -0.02809407f, -0.00708010f, -0.01992951f, 0.04804763f, 0.02605584f, 
    -0.01656417f, -0.05224688f, -0.04808590f, 0.02948138f, -0.04007589f, 0.03384161f, 0.00420042f, 0.00768982f, 
    -0.03358139f, -0.04494858f, -0.03393993f, -0.05513127f, -0.02571102f, 0.00966514f, 0.03139010f, -0.00523400f, 
    -0.02914565f, -0.04052021f, 0.01351450f, 0.02347288f, -0.01736539f, -0.00207353f, 0.01070320f, 0.00633351f, 
    -0.02510833f, 0.02144866f, 0.01953552f, -0.04054590f, 0.02379534f, 0.01879999f, -0.01343615f, -0.03707192f, 
    -0.03229608f, -0.03483475f, 0.00770702f, -0.02254286f, -0.03636913f, 0.00588462f, -0.03546594f, 0.00094159f, 
    0.02412321f, 0.03069079f, 0.02394819f, 0.00079446f, -0.01850957f, 0.02744889f, -0.00682602f, 0.03804849f, 
    -0.05821279f, -0.03965482f, -0.02847157f, -0.03921871f, 0.01739927f, -0.02771425f, -0.00785006f, -0.04815562f, 
    0.65461695f, -0.26273870f, -0.20776528f, -0.26679406f, 0.40531197f, -0.22443947f, -0.23307173f, -0.04211716f, 
    0.11069608f, 0.02839503f, 0.00017375f, 0.17456096f, 0.21196502f, -0.30507967f, -0.04630150f, 0.07075343f, 
    0.08541083f, -0.04516514f, -0.08509890f, -0.02186445f, 0.18857715f, 0.03705253f, 0.02322674f, 0.06886983f, 
    0.07134013f, 0.56712031f, 0.25480872f, 0.38524714f, 0.01413707f, -0.08831238f, -0.02134004f, 0.08912410f, 
    -0.01074771f, 0.03319300f, 0.04763698f, -0.12508403f, 0.13318610f, 0.01782401f, 0.23619874f, 0.23374945f, 
    0.18723883f, 0.12611584f, -0.11624204f, 0.19898267f, 0.08398561f, 0.02424948f, -0.04184693f, 0.00000596f, 
    0.30290657f, -0.09850473f, 0.29399735f, 0.46641698f, -0.04258914f, -0.19767661f, 0.04797804f, 0.17088678f, 
    -0.00073823f, 0.03819773f, 0.13159865f, 0.01670838f, -0.20102064f, -0.03595706f, -0.11640376f, -0.18384266f, 
    0.15281232f, 0.05377523f, -0.04564879f, -0.06084213f, 0.22243191f, 0.27941883f, 0.12528589f, 0.11579093f, 
    0.19605552f, -0.05971596f, -0.04764120f, 0.21512541f, 0.12614883f, -0.11834963f, 0.15374012f, -0.09958023f, 
    -0.04450661f, -0.01646903f, 0.02747266f, -0.01471096f, -0.13844791f, 0.32500809f, -0.16078070f, 0.04902392f, 
    0.06285439f, 0.09575270f, -0.02894125f, -0.06374034f, 0.05264891f, 0.06197666f, 0.11518054f, -0.00633285f, 
    0.15128060f, 0.25437281f, 0.07185029f, -0.21948940f, -0.10105240f, -0.08556435f, -0.00486741f, -0.02059644f, 
    0.01597276f, 0.06484994f, -0.12367636f, -0.03147677f, -0.08650326f, -0.00565509f, -0.00047804f, 0.01465046f, 
    0.09623902f, 0.17472433f, -0.13597628f, 0.03239923f, 0.12897632f, 0.16446294f, -0.01736368f, 0.05410070f, 
    0.57880616f, -0.42904595f, 0.00829952f, 0.06712049f, 0.26040614f, 0.00387129f, 0.02688779f, -0.06324118f, 
    0.18510941f, 0.30510372f, -0.01824876f, 0.10894974f, 0.03785284f, 0.12583108f, 0.22902192f, 0.05439789f, 
    -0.05095619f, 0.08097075f, -0.02873710f, -0.02287157f, 0.02950187f, -0.01917809f, 0.13471903f, 0.06477378f, 
    -0.41603923f, -0.00560324f, 0.23417208f, 0.30641910f, -0.00781874f, 0.00718911f, -0.07988925f, -0.02118525f, 
    0.03338538f, 0.02408179f, 0.05810908f, -0.05362440f, -0.11519838f, -0.23746973f, -0.39203840f, -0.33919093f, 
    0.22655138f, -0.09398376f, 0.00445696f, 0.25164464f, -0.08516257f, -0.06516490f, 0.27249554f, 0.10351738f, 
    0.38294250f, -0.23189768f, -0.24689224f, -0.13526282f, -0.02117042f, -0.05941294f, 0.12863833f, -0.10152478f, 
    -0.09244967f, 0.04129050f, 0.12254557f, 0.08593392f, -0.04247460f, 0.19429491f, -0.09026586f, -0.16343133f, 
    0.09997953f, 0.02593779f, -0.00277030f, -0.13205130f, 0.06125933f, 0.06173867f, 0.21762429f, 0.04782993f, 
    -0.58906889f, 0.01232043f, 0.19683361f, 0.25873324f, -0.01970899f, 0.04530161f, 0.13745081f, 0.06703056f, 
    -0.02595885f, 0.04475296f, 0.06249696f, 0.18802072f, 0.00220164f, -0.31234369f, 0.06751551f, 0.02568772f, 
    -0.03374586f, -0.28094006f, 0.00934293f, -0.02016569f, -0.03321454f, -0.03907240f, 0.13620986f, 0.11145424f, 
    -0.23039897f, 0.83924538f, -0.05850384f, -0.03247968f, -0.13781939f, 0.22253202f, 0.00409594f, 0.11773371f, 
    0.08447874f, -0.02272822f, -0.02382990f, -0.05705180f, -0.24739228f, -0.14507014f, 0.04617266f, 0.01632936f, 
    -0.03187467f, -0.12331243f, -0.13061433f, -0.03280533f, -0.01462067f, 0.14756326f, 0.22015174f, 0.08531304f, 
    -0.06914136f, 0.06349635f, 0.52215374f, 0.33861077f, 0.01258369f, -0.14665686f, 0.08663201f, -0.04038003f, 
    0.01394494f, 0.03153230f, 0.03003022f, -0.02512177f, -0.05179458f, 0.32018504f, 0.30271363f, 0.19874662f, 
    0.16823335f, 0.02167769f, -0.19432347f, 0.10150377f, 0.03619119f, 0.13469371f, 0.12131856f, 0.00980344f, 
    -0.03509138f, -0.38029084f, -0.25123274f, -0.04928467f, 0.12541360f, -0.01862263f, -0.01052825f, 0.17518176f, 
    0.08794457f, 0.13529897f, -0.12685016f, 0.04711185f, 0.47972405f, 0.15053177f, 0.29346964f, 0.07243523f, 
    -0.05267077f, -0.08774056f, -0.01548993f, 0.12369419f, 0.06476242f, 0.01357312f, -0.07862914f, -0.05255722f, 
    0.03385033f, -0.26062706f, -0.01469673f, 0.09275300f, 0.14411898f, 0.09621678f, 0.09142279f, 0.02426003f, 
    0.09176920f, -0.05061721f, -0.04361862f, -0.04044621f, -0.07941233f, -0.28140971f, -0.11441369f, 0.31254676f, 
    -0.05886147f, -0.02992164f, 0.09199607f, 0.14652435f, 0.05960860f, -0.00416759f, 0.01155353f, 0.00314613f, 
    0.01224839f, 0.01708276f, -0.22777240f, -0.16498972f, 0.07111455f, 0.07456976f, -0.09802368f, 0.11468771f, 
    0.03694670f, -0.17266317f, -0.01155314f, 0.10217579f, 0.33453953f, -0.20678777f, 0.04963129f, 0.10238244f, 
    0.19938284f, -0.02192844f, 0.07017463f, 0.19512023f, -0.04269828f, 0.20184356f, -0.07785480f, -0.08937697f, 
    -0.07907553f, 0.01467152f, -0.04372777f, 0.04064426f, 0.01509323f, -0.04234017f, -0.07746793f, -0.07390477f, 
    0.10512366f, 0.14148438f, 0.16373335f, 0.03668927f, 0.34604618f, -0.15611677f, 0.27958190f, -0.06291047f, 
    -0.06301721f, -0.19845450f, 0.10770684f, 0.05020482f, 0.02656880f, 0.05486332f, -0.05847747f, -0.05575855f, 
    -0.34407726f, 0.21885602f, -0.46494925f, -0.38661170f, 0.03779102f, -0.01925212f, -0.10543431f, 0.02200726f, 
    0.01946279f, -0.13822073f, -0.03581882f, 0.05413985f, -0.30846706f, 0.41998193f, -0.03348541f, 0.10835210f, 
    0.13169627f, 0.09194949f, 0.15141435f, 0.12164854f, -0.13792148f, 0.17635463f, 0.05261980f, -0.00309439f, 
    -0.18572327f, -0.12033302f, -0.36080229f, 0.30829468f, 0.02802473f, 0.06754403f, -0.05369548f, -0.11347235f, 
    -0.08430555f, 0.14127012f, -0.18648395f, -0.10206601f, -0.09746010f, 0.05182024f, 0.03589612f, 0.22290960f, 
    -0.05847047f, 0.02454192f, -0.03195421f, 0.01250566f, 0.23754752f, 0.11997581f, -0.03862701f, 0.02496587f, 
    0.12794548f, 0.12446081f, -0.14752467f, -0.35685787f, 0.09075024f, 0.00451014f, 0.17272304f, 0.03830364f, 
    -0.01849736f, -0.07141497f, -0.12404572f, 0.12014446f, -0.42905182f, -0.25512412f, -0.14924471f, -0.01601887f, 
    0.08006758f, -0.00993947f, 0.00255780f, -0.00691737f, -0.13281271f, -0.07289948f, -0.06918683f, -0.02437765f, 
    -0.13385890f, 0.14814152f, -0.30563244f, 0.05994177f, -0.00853722f, 0.11840693f, 0.24601479f, -0.03923206f, 
    -0.03833052f, -0.02342238f, 0.05138331f, -0.01380934f, -0.02513501f, -0.02677119f, -0.11814853f, 0.00043285f, 
    0.02842790f, -0.01819037f, -0.03415201f, -0.04822754f, 0.17049657f, 0.15275523f, 0.00442150f, 0.02025406f, 
    -0.31515250f, 0.07376927f, 0.12478021f, 0.04038424f, -0.05971233f, -0.00496636f, -0.04057006f, -0.04674668f, 
    -0.08827208f, 0.09266098f, 0.13041364f, 0.06618462f, -0.53910530f, 0.27517152f, -0.61761642f, 0.33469227f, 
    -0.01052838f, 0.06604576f, 0.02618029f, 0.19261339f, 0.05952680f, 0.00648233f, -0.05515354f, 0.02050660f, 
    0.06917937f, -0.14823453f, 0.19668470f, 0.17732544f, -0.00257752f, 0.05251802f, -0.06815595f, 0.04419701f, 
    -0.04457233f, -0.08243711f, -0.10866635f, -0.09847789f, -0.05233091f, -0.15144204f, 0.03880690f, -0.08123044f, 
    0.11159823f, 0.00876416f, -0.08286615f, -0.00886832f, 0.03186970f, 0.06295684f, -0.13712588f, -0.06824248f, 
    -0.45678326f, 0.02611731f, -0.39193353f, 0.41744608f, 0.05793924f, -0.02410571f, -0.19064035f, -0.02212973f, 
    0.03208089f, -0.20481214f, 0.20571998f, -0.02280923f, -0.15128419f, -0.07577457f, -0.04814691f, -0.08217855f, 
    0.11704238f, -0.01896843f, 0.16910903f, -0.00805460f, 0.00906505f, -0.14495979f, -0.09681872f, 0.05667472f, 
    0.30039474f, -0.20324002f, 0.13235448f, -0.31654623f, -0.06200872f, -0.02192938f, 0.09876269f, -0.08262744f, 
    -0.01454356f, 0.04536665f, -0.17544438f, 0.00799239f, 0.13746770f, 0.05516887f, -0.05504171f, 0.23183142f, 
    -0.03057481f, 0.02545376f, -0.12615079f, -0.12509766f, 0.18795876f, 0.09033068f, 0.16170062f, 0.26844293f, 
    0.19875011f, -0.06083469f, 0.15317629f, 0.13685045f, -0.03543868f, 0.03321369f, -0.13126922f, -0.04103146f, 
    0.10779079f, -0.02789550f, 0.14976126f, -0.10559355f, -0.18747328f, 0.12432016f, 0.11523694f, 0.21848571f, 
    0.01036676f, 0.02622479f, -0.01453120f, -0.08685184f, 0.13002111f, -0.01095971f, 0.46838087f, -0.06599089f, 
    0.22466384f, 0.48567411f, 0.33327594f, -0.32184955f, -0.08256923f, -0.17032085f, 0.05164760f, 0.14987199f, 
    0.12157420f, 0.14292774f, 0.26866487f, 0.04319934f, -0.03235536f, -0.02553298f, 0.04136981f, 0.18122351f, 
    0.14199898f, -0.02518146f, -0.10391704f, 0.02260395f, -0.00416447f, 0.03456100f, 0.00487522f, 0.01781516f, 
    0.12206272f, 0.04021532f, 0.04368604f, -0.48237029f, 0.11744508f, 0.09670597f, 0.10898610f, 0.08792584f, 
    0.10636664f, -0.05669615f, 0.09046563f, -0.09439170f, -0.20738427f, -0.12550581f, 0.09336430f, 0.20847012f, 
    0.04111233f, 0.04533806f, 0.16344638f, 0.03099585f, -0.02528734f, -0.03363345f, 0.02532762f, 0.00425786f, 
    0.09813929f, -0.00276888f, -0.20561835f, -0.15562694f, 0.16559614f, -0.00582341f, 0.08460809f, -0.06265762f, 
    0.02188186f, -0.05697307f, -0.10352381f, 0.03484212f, 0.08267752f, 0.19555068f, -0.04712995f, -0.39685324f, 
    0.08746669f, 0.06641500f, 0.15192328f, 0.08713761f, 0.08823720f, -0.06039242f, -0.08594309f, 0.15101230f, 
    -0.03222016f, -0.07687268f, 0.25456497f, 0.06429821f, 0.01696252f, -0.02234927f, -0.04680800f, -0.03453109f, 
    0.07817066f, 0.11552161f, -0.00712804f, 0.09113911f, -0.09396264f, 0.08439483f, -0.06048975f, 0.10401921f, 
    0.00365430f, 0.03121674f, -0.00677923f, -0.08433109f, -0.06096204f, 0.01558198f, 0.03743123f, -0.09770687f, 
    -0.36621201f, -0.29097483f, -0.11757569f, 0.00318578f, 0.14981917f, -0.00969803f, 0.07671181f, -0.13889626f, 
    -0.03537365f, -0.11292832f, -0.02109264f, -0.07724050f, -0.00847061f, 0.10339598f, 0.21720922f, 0.19517832f, 
    -0.06656122f, -0.01621242f, -0.02095537f, 0.03732685f, -0.07686821f, 0.00357347f, 0.09060320f, 0.06531273f, 
    0.10563096f, 0.08297229f, -0.01581123f, 0.22206855f, 0.07661345f, 0.01253577f, 0.00792080f, -0.12010478f, 
    0.07154304f, 0.06904206f, 0.18677557f, 0.04740488f, 0.12719063f, -0.22312994f, -0.01464953f, 0.02039294f, 
    0.04580111f, 0.20943697f, -0.08013733f, 0.04121597f, 0.04464264f, -0.12161341f, 0.08538742f, -0.01132143f, 
    -0.04404585f, 0.02017921f, 0.02147002f, -0.12295277f, 0.06933962f, -0.15361172f, 0.12808974f, 0.02573055f, 
    -0.08925495f, 0.14594105f, -0.14018476f, -0.14523464f, 0.12632190f, -0.03347067f, -0.01022432f, 0.02067867f, 
    -0.02807155f, 0.12147706f, 0.11778908f, -0.01280471f, -0.11561040f, -0.01764677f, 0.03551626f, -0.03908281f, 
    -0.44866645f, 0.41433144f, 0.37523967f, 0.46911812f, 0.06947599f, -0.12922859f, -0.07282262f, -0.04609584f, 
    0.18161961f, 0.11786866f, 0.13322601f, 0.05454489f, 0.39640594f, 0.39104611f, -0.47083238f, -0.24519198f, 
    -0.01710385f, -0.09595880f, 0.09171212f, 0.04234269f, 0.28405321f, 0.25841880f, -0.03587997f, 0.15104686f, 
    -0.04335654f, -0.03716261f, -0.03076763f, 0.02305859f, -0.00931892f, 0.04448086f, 0.02476565f, 0.04158891f, 
    0.01838891f, -0.01340418f, -0.01021753f, -0.00916095f, -0.01985182f, 0.04917365f, 0.03619125f, -0.02435425f, 
    -0.01102769f, 0.02867579f, -0.03401400f, 0.02861546f, -0.04566487f, -0.05377126f, 0.00859924f, -0.00280514f, 
    -0.00448450f, -0.05050126f, -0.04926509f, -0.04571428f, -0.01717175f, -0.02702273f, -0.00469557f, 0.01830237f, 
    -0.00608443f, -0.05675363f, 0.02072566f, -0.04598289f, -0.00618392f, -0.02241003f, 0.00281908f, -0.01519892f, 
    -0.01383083f, -0.03494235f, 0.01612188f, -0.00076289f, -0.00632970f, -0.01496487f, 0.00214011f, -0.03789792f, 
    -0.00914575f, -0.05661904f, 0.00162821f, 0.01341558f, 0.00818755f, -0.02832423f, -0.04270062f, -0.02931547f, 
    -0.01476699f, 0.02776121f, -0.01553505f, -0.04374602f, -0.01392966f, 0.00991040f, -0.04088577f, -0.03370939f, 
    0.00128022f, 0.01779879f, 0.04245934f, 0.03261069f, 0.03865368f, -0.05608185f, -0.02513339f, -0.04404097f, 
    0.04162156f, -0.01799238f, -0.05511446f, 0.01724753f, 0.00616872f, 0.04188109f, -0.00738996f, -0.04525559f, 
    -0.02734783f, 0.00534461f, -0.04555394f, -0.00114450f, -0.01013585f, -0.02252452f, -0.00545031f, 0.00151433f, 
    0.00810342f, 0.02634360f, 0.02104917f, 0.01000191f, 0.02778365f, -0.02781233f, -0.02097692f, -0.00934303f, 
    -0.04881913f, -0.04080550f, -0.04967455f, 0.03285462f, -0.00920038f, -0.04102861f, -0.05630291f, -0.05251995f, 
    -0.00825244f, -0.02484599f, 0.01583902f, 0.04304111f, 0.01573532f, -0.03497899f, 0.01885090f, 0.00802994f, 
    0.01875077f, -0.03611436f, -0.00205785f, 0.02816912f, -0.00938249f, -0.00889596f, -0.01069172f, 0.01998537f, 
    -0.02600023f, 0.04584394f, -0.03956429f, -0.02632151f, 0.00297996f, -0.00342503f, -0.03440570f, 0.03546224f, 
    0.03170822f, -0.00013564f, -0.00034223f, -0.00263685f, -0.00566093f, 0.00128483f, -0.01582925f, -0.02213076f, 
    0.02723112f, 0.03690899f, 0.00943829f, 0.03332977f, 0.00283697f, -0.04871218f, 0.00872964f, -0.03299868f, 
    -0.04247347f, 0.00211190f, 0.03212684f, -0.05621787f, 0.04290338f, 0.02549885f, 0.04103350f, 0.01678465f, 
    -0.03552983f, -0.00729073f, -0.03979373f, -0.03250576f, -0.03456208f, -0.05196002f, 0.00296341f, 0.03432028f, 
    -0.01320270f, -0.01572395f, -0.01205932f, -0.02746380f, -0.01312203f, -0.01758255f, 0.01409590f, -0.05054383f, 
    -0.04639513f, 0.00389503f, -0.04674095f, 0.01728805f, -0.03486519f, -0.00114295f, -0.03460156f, -0.02611683f, 
    0.04458113f, -0.02076424f, -0.03316057f, -0.03195874f, 0.04478601f, -0.03536049f, -0.02976880f, 0.04171277f, 
    -0.00250290f, -0.03013167f, -0.00054547f, -0.04606845f, 0.01152164f, 0.00922300f, 0.02732162f, -0.01436782f, 
    -0.02474816f, -0.04686968f, 0.00813743f, -0.02258423f, -0.05493962f, -0.01093671f, -0.01081375f, -0.00811809f, 
    0.03647813f, -0.02713427f, 0.00909718f, -0.05098942f, 0.02317949f, 0.03346428f, -0.03832731f, -0.05526575f, 
    0.01796153f, -0.04088889f, -0.03926576f, -0.02301183f, -0.02746872f, 0.01097790f, 0.00643076f, -0.02801714f, 
    -0.01787411f, -0.04798568f, -0.05532442f, 0.03963570f, 0.03179284f, 0.04102668f, -0.04590107f, 0.01074667f, 
    -0.01983939f, -0.03264149f, -0.03390157f, 0.02721675f, -0.02214729f, -0.03540535f, -0.03455979f, 0.03691285f, 
    -0.03878355f, 0.01771537f, 0.04412438f, -0.04614723f, 0.01612624f, -0.01540416f, -0.03182882f, 0.02007403f, 
    -0.04883419f, -0.00697856f, -0.00571030f, -0.00141867f, 0.00468653f, 0.04335018f, -0.03384069f, -0.02187945f, 
    0.03144859f, 0.03468376f, 0.04110126f, -0.03953983f, -0.04756481f, -0.03577686f, -0.05282168f, -0.02735047f, 
    0.03922994f, 0.03115901f, 0.04071225f, -0.02526264f, 0.00827280f, -0.05463152f, 0.02659441f, -0.02566601f, 
    -0.04558581f, 0.01089805f, -0.03308524f, -0.01177281f, 0.02267653f, 0.02762372f, -0.00181631f, 0.02839513f, 
    0.01577334f, 0.00795678f, 0.00952323f, 0.01176925f, -0.01706595f, 0.04373107f, -0.02223421f, 0.03228528f, 
    0.02611918f, -0.02406396f, 0.02259900f, -0.04881868f, -0.01833978f, -0.03745268f, -0.05161814f, -0.03700794f, 
    0.02528754f, -0.04328969f, -0.01680658f, 0.03808672f, 0.03622751f, 0.02137161f, -0.01067927f, -0.01260913f, 
    -0.01931704f, -0.02051457f, -0.03018108f, -0.04348020f, -0.04083626f, -0.02689826f, -0.02643510f, 0.03470793f, 
    -0.05174900f, -0.01867358f, -0.04084045f, 0.00925357f, 0.00568902f, -0.00780067f, -0.03190949f, -0.03519508f, 
    0.02610419f, 0.03051416f, -0.04881223f, -0.04871678f, -0.00027778f, 0.04496257f, 0.04090092f, 0.04277548f, 
    0.03872247f, 0.01826734f, -0.02273415f, -0.05206037f, 0.04066847f, 0.00744497f, 0.03356635f, -0.02324967f, 
    0.02547267f, 0.00436213f, 0.00124022f, -0.02582816f, -0.00964411f, 0.02534872f, -0.03264474f, -0.04043033f, 
    0.01225492f, 0.00554800f, -0.03089890f, 0.01090053f, -0.04928774f, -0.02579285f, 0.02548194f, -0.02907251f, 
    -0.04588025f, -0.05233997f, 0.00713668f, -0.01493661f, -0.03589626f, -0.02063842f, 0.02316923f, 0.01318430f, 
    -0.04083204f, 0.03226693f, 0.00850124f, 0.02544047f, 0.02826898f, -0.01245577f, -0.00822096f, 0.02111091f, 
    -0.02997896f, -0.02566362f, -0.03044938f, -0.01037529f, -0.04814798f, 0.03628282f, -0.03763415f, 0.01178285f, 
    0.00925952f, -0.03002826f, 0.01796430f, -0.02744281f, -0.02356711f, -0.04305726f, -0.05269815f, 0.00022814f, 
    -0.02120650f, -0.04121831f, 0.00221688f, -0.03145367f, -0.02890662f, -0.01895101f, -0.04486424f, 0.04419165f, 
    0.66427112f, -0.20911117f, -0.17486501f, 0.00960248f, 0.02881852f, -0.07782976f, -0.11975143f, 0.05262027f, 
    0.11388804f, 0.13774925f, -0.24219821f, 0.33559066f, 0.10741623f, -0.01710374f, -0.10396204f, 0.03350332f, 
    0.09617008f, 0.05653977f, -0.00594538f, -0.02125351f, 0.10371741f, 0.04217545f, -0.00812865f, -0.18752436f, 
    -0.23281613f, -0.22705030f, -0.37521997f, 0.16302659f, 0.12613350f, -0.08457866f, 0.03498296f, -0.20862654f, 
    -0.08277491f, -0.02732365f, -0.01153956f, 0.01132247f, -0.20434675f, -0.29620370f, -0.31477314f, -0.01552877f, 
    0.22292139f, 0.22111291f, 0.05222774f, -0.13697739f, -0.02897297f, -0.04684751f, 0.03627521f, 0.05634980f, 
    0.15097484f, 0.10033290f, -0.01560947f, 0.10442311f, 0.05220752f, 0.02852734f, 0.19606009f, 0.07168526f, 
    0.14346325f, 0.08941296f, 0.18860611f, 0.12860407f, -0.41193509f, -0.07174250f, -0.25187629f, -0.02910063f, 
    0.04733717f, -0.17366576f, -0.07955984f, -0.07142525f, 0.14092587f, 0.13006124f, 0.04405111f, 0.18597493f, 
    -0.05711688f, 0.09804750f, -0.03747627f, -0.02460214f, 0.08499849f, -0.07185823f, 0.13395153f, -0.01810881f, 
    -0.08052032f, -0.06541926f, -0.04094716f, -0.09156813f, 0.01934852f, 0.73974752f, -0.35828960f, 0.25564295f, 
    0.02188201f, 0.01093753f, -0.00818376f, 0.05324481f, 0.07459637f, 0.10966977f, 0.04748804f, 0.08527982f, 
    -0.30605355f, -0.18764511f, 0.11564875f, -0.34594569f, -0.07412485f, -0.03511604f, -0.05386319f, 0.06980096f, 
    0.07434824f, 0.05258102f, -0.04903569f, -0.04421511f, -0.36143282f, -0.15756212f, -0.06506006f, -0.16588154f, 
    -0.01829526f, 0.01923764f, -0.25561664f, -0.10716332f, 0.08476826f, -0.00038097f, 0.08003101f, 0.14668339f, 
    0.40684575f, 0.06026455f, -0.16454315f, 0.00298308f, 0.01509512f, 0.01819948f, -0.13255875f, -0.00770961f, 
    -0.00074443f, 0.30029842f, 0.03994188f, 0.00416524f, -0.52224052f, -0.17264171f, -0.03756966f, -0.08813965f, 
    -0.02392070f, -0.17239684f, -0.01736723f, -0.23648818f, -0.02989893f, -0.23300073f, 0.04630445f, 0.05735019f, 
    -0.67884761f, -0.32101315f, 0.30135921f, -0.15223816f, -0.04221073f, -0.06509684f, -0.17547810f, 0.09578785f, 
    0.12021727f, -0.09605591f, 0.06502993f, -0.00192857f, -0.05991602f, -0.10857808f, 0.01204159f, 0.04061768f, 
    0.22739454f, -0.01890492f, -0.16336124f, 0.04297972f, -0.08640993f, 0.14102395f, 0.31470427f, 0.13385145f, 
    0.19246615f, -0.06258669f, 0.13393298f, -0.13278086f, 0.04990941f, 0.15819673f, 0.04164601f, 0.03689563f, 
    -0.01612210f, 0.03768833f, 0.14342496f, -0.14666978f, -0.16469221f, 0.14058839f, 0.16888854f, -0.17591181f, 
    0.13303725f, 0.03601297f, -0.08495123f, 0.03284328f, 0.17698357f, 0.01076021f, 0.36691025f, -0.10199771f, 
    -0.21483567f, 0.17897911f, 0.16574475f, 0.07498016f, 0.00769445f, 0.01278615f, -0.13033442f, -0.01957046f, 
    0.08521151f, 0.04590616f, 0.10313799f, 0.10477266f, 0.09291770f, -0.09887875f, 0.12807891f, -0.06643706f, 
    0.04612577f, 0.07093868f, -0.09275830f, 0.10838985f, -0.05297562f, 0.01104539f, -0.06397153f, -0.02486786f, 
    -0.08099981f, 0.29348794f, -0.06624403f, 0.04151875f, 0.06997910f, -0.09985613f, 0.19618714f, -0.11660507f, 
    0.03950885f, 0.08474228f, 0.07566635f, 0.12034547f, -0.09849814f, -0.06780963f, -0.13930179f, -0.07573323f, 
    0.10632041f, 0.02485274f, 0.11649825f, -0.14525276f, 0.10875899f, -0.03350833f, 0.09888422f, -0.08453798f, 
    -0.28381267f, -0.08324376f, -0.00898409f, 0.08665632f, -0.04378342f, -0.03737636f, 0.03307584f, -0.08997586f, 
    0.01747022f, 0.04071861f, 0.07703923f, 0.18537198f, -0.12462365f, 0.22301416f, -0.11517656f, 0.18199065f, 
    0.13974038f, 0.05988221f, -0.11963875f, 0.08988965f, 0.04940579f, 0.03856474f, 0.00679666f, -0.01215942f, 
    -0.02378043f, -0.15052859f, 0.17114861f, -0.01036662f, 0.14794938f, 0.11881763f, -0.07734832f, 0.14774039f, 
    0.04299448f, 0.04717609f, -0.04711980f, 0.12831022f, -0.21172400f, -0.13716322f, -0.02830506f, -0.07214350f, 
    -0.01552741f, -0.02755681f, -0.06373849f, -0.01596805f, -0.19746672f, -0.01899477f, -0.04968771f, -0.08714650f, 
    -0.12029617f, -0.32972234f, -0.22738628f, -0.02919414f, 0.21253242f, 0.14777887f, 0.11093730f, -0.06054150f, 
    -0.15082154f, -0.06990729f, 0.02766280f, -0.01318917f, -0.23231286f, -0.24035063f, 0.01318324f, 0.09259355f, 
    0.06413294f, 0.02182634f, -0.11632977f, 0.15309423f, -0.04638768f, 0.08885416f, -0.09380524f, 0.09946823f, 
    0.02849755f, 0.18086703f, -0.04669898f, 0.01566217f, -0.08806701f, -0.02026978f, -0.11939949f, 0.17427146f, 
    -0.02653817f, -0.03131591f, 0.11392912f, 0.21885405f, 0.06541037f, -0.25586534f, 0.00143256f, -0.05346661f, 
    0.08498740f, 0.10221890f, -0.00552043f, 0.15021421f, 0.01893704f, 0.01647282f, 0.09149676f, 0.07035980f, 
    -0.16320419f, -0.13124299f, -0.04218280f, -0.07288344f, 0.07434632f, 0.00984639f, 0.02896615f, -0.13922921f, 
    0.17218278f, 0.20214424f, 0.14355555f, 0.34166697f, -0.15763411f, -0.15667418f, 0.01875012f, -0.06866068f, 
    -0.03731976f, -0.00107875f, 0.06181214f, 0.15509985f, -0.13733496f, 0.01399993f, -0.14155643f, -0.12092102f, 
    -0.01758068f, 0.84617764f, -0.25338718f, -0.11155134f, 0.00350594f, -0.15747465f, -0.03194075f, -0.01589161f, 
    0.03472572f, 0.04832008f, -0.03267822f, 0.16343726f, 0.05664404f, 0.26813814f, -0.15803427f, 0.31486380f, 
    0.01610243f, -0.01471340f, 0.12020589f, 0.08852120f, 0.03941296f, 0.10491034f, 0.10668877f, 0.00950180f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.13704227f, 0.09246906f, 0.04456614f, -0.08753943f, 0.17129345f, 0.18618222f, -0.04518889f, 0.12411715f, 
    0.01559448f, 0.09243959f, 0.02751979f, -0.01524090f, 0.21622542f, 0.03298568f, 0.02726695f, 0.01828683f, 
    0.09709891f, -0.02901163f, -0.05200008f, -0.05460951f, -0.10887607f, 0.17939751f, -0.02865480f, 0.00707629f, 
    0.03759788f, -0.02067235f, -0.00553146f, 0.02484123f, 0.08746199f, 0.22269343f, 0.03798394f, 0.11604717f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.03960728f, 0.42542708f, -0.06001351f, -0.24956761f, -0.00950893f, -0.00107873f, 0.09787311f, -0.53220558f, 
    0.37475368f, -0.19804776f, -0.15299127f, 0.14310788f, -0.16554493f, 0.17535545f, -0.02576033f, 0.11102621f, 
    -0.22425784f, 0.01739671f, 0.14313221f, 0.09664890f, 0.24704614f, -0.65399265f, 0.38406116f, -0.15234038f, 
    -0.10654874f, -0.17737892f, 0.11054319f, -0.03179313f, -0.45229235f, -0.48881727f, 0.08884242f, -0.39109260f, 
    0.22302595f, 0.11808588f, 0.06686567f, -0.88586944f, 0.06949838f, 0.33013695f, -0.16061021f, 0.20978048f, 
    0.22695373f, 0.04448281f, -0.04843091f, 0.05297833f, 0.30926448f, -0.33956850f, -0.09076968f, -0.16742049f, 
    0.12634993f, -0.03862138f, -0.10333625f, -0.16511095f, -0.37435490f, -0.38212702f, 0.07647642f, -0.11254741f, 
    -0.06156456f, 0.07892811f, -0.06943165f, 0.04712003f, -0.18171336f, 0.12147082f, -0.11438771f, -0.30533877f, 
    -0.51780403f, -0.03386468f, -0.07025930f, 0.30732724f, 0.38077766f, 0.08171239f, 0.10750373f, 0.46664917f, 
    0.11922700f, -0.11765569f, -0.12252359f, 0.12386128f, -0.21256074f, 0.02385804f, -0.00028512f, 0.13683994f, 
    -0.12327377f, -0.07394657f, 0.13275754f, -0.12080313f, -0.63890296f, -0.10205531f, -0.69443148f, -0.09607094f, 
    -0.08132547f, 0.01640695f, 0.08333897f, -0.05423059f, 0.00445477f, 0.23540787f, -0.15690185f, 0.35714829f, 
    -0.30045763f, -0.08930527f, 0.11950041f, 0.21200581f, -0.93304545f, 0.05814297f, -0.04907816f, 0.54353338f, 
    0.05119108f, -0.45290607f, 0.04764007f, 0.10884128f, -0.02757277f, -0.09984427f, -0.03977138f, -0.01882557f, 
    -0.05153567f, 0.11950019f, -0.06809601f, 0.15414496f, 0.31820941f, -0.47408170f, -0.04322468f, 0.14739394f, 
    0.08266383f, -0.10020361f, 0.01996837f, -0.13098906f, 0.41427797f, -0.01570412f, -0.07948714f, 0.34826502f, 
    0.09425520f, -0.35281664f, 0.00454443f, 0.40487632f, 0.22769383f, 0.21236418f, 0.14183392f, -0.25866210f, 
    0.06239093f, -0.27098027f, 0.16369085f, -0.09738979f, 0.06344569f, 0.28526989f, 0.09170585f, 0.03723104f, 
    -0.23373263f, 0.06124677f, -0.10668102f, 0.08720877f, 0.12965775f, -0.00888382f, -0.04540638f, -0.07436301f, 
    0.07018801f, -0.06688270f, -0.18135630f, 0.09057754f, 0.15483016f, -0.37539500f, 0.00871187f, -0.83422893f, 
    0.06831492f, 0.03895811f, -0.03935675f, -0.43571398f, 0.07508691f, -0.01810601f, 0.11279099f, -0.75349516f, 
    -0.11956030f, -0.11638042f, 0.05195892f, 0.10475839f, 0.41236755f, 0.30182850f, 0.10049587f, -0.10305865f, 
    -0.34573916f, 0.11818282f, -0.02680174f, 0.06896662f, -0.02896233f, 0.54002196f, 0.34180039f, -0.05037697f, 
    -0.14697841f, -0.17668925f, 0.04974845f, 0.11253111f, 0.08736423f, -0.08316555f, 0.02574029f, 0.31663692f, 
    0.27175710f, -0.01601164f, 0.04597491f, -0.23363893f, 0.20844463f, 0.13693482f, -0.05299999f, 0.60394984f, 
    -0.70748621f, 0.27468425f, 0.05140787f, -0.03418177f, -0.33326083f, 0.50232697f, -0.11705366f, 0.15194631f, 
    -0.30541709f, 0.00914303f, 0.04345552f, -0.09925760f, -0.65087938f, -0.01552657f, -0.86749810f, 0.07086218f, 
    -0.09482373f, -0.06695661f, -0.16085814f, 0.01904076f, -0.38018975f, 0.30174178f, 0.15014552f, 0.13253520f, 
    -0.02763363f, -0.21697982f, 0.06643143f, 0.41023889f, 0.27351746f, -0.93870950f, -0.15633033f, -0.52414721f, 
    -0.16675334f, -0.07835755f, -0.07248858f, -0.11925378f, -0.05653642f, -0.19996431f, 0.13732202f, 0.06973986f, 
    0.27851617f, 0.16123064f, 0.07099026f, -0.01110878f, 0.27829778f, 0.15425357f, 0.26237002f, 0.03411071f, 
    -0.01937692f, -0.06423200f, 0.01076407f, 0.03693451f, 0.08490113f, -0.12546901f, 0.11581914f, 0.11604693f, 
    -0.37836957f, 0.38608089f, 0.00167986f, -0.32781258f, -0.04901221f, -0.59302902f, -0.00824169f, 0.21872336f, 
    -0.43149066f, 0.18137962f, -0.11395504f, -0.03499354f, 0.07851927f, -0.52854586f, 0.04758419f, 0.14461905f, 
    0.08976084f, -0.11974105f, 0.10777596f, 0.01683822f, -0.38896739f, 0.25075769f, -0.22111458f, 0.01181826f, 
    0.15506771f, 0.13547641f, 0.06446528f, -0.05503409f, 0.38866523f, -0.25609761f, 0.04805071f, 0.61244094f, 
    -0.19481730f, -1.01539052f, 0.15468787f, -0.06976958f, 0.29898399f, 0.31706542f, -0.13051824f, -0.27859777f, 
    -0.60259026f, 0.23175552f, 0.13731857f, -0.00117809f, -0.51078981f, 0.22883248f, 0.09286714f, -0.07006907f, 
    0.12967220f, -0.01864267f, -0.09939785f, -0.03419182f, 0.33732340f, 0.03662563f, 0.26887721f, -0.05907261f, 
    -0.08445896f, 0.02314320f, 0.11665318f, 0.14600468f, -0.21888968f, 0.21586941f, -0.01051266f, -0.08335531f, 
    -0.56099635f, 0.29767635f, 0.13548797f, -0.59169424f, -0.07364515f, 0.25177479f, -0.01040359f, 0.16758668f, 
    0.07532609f, 0.27190921f, 0.10195700f, 0.01800453f, -0.01641886f, -0.44239634f, 0.08779468f, 0.04659734f, 
    0.09595535f, -0.00388899f, 0.11516736f, 0.13971856f, 0.34006658f, 0.51110768f, -0.89058429f, -0.01172225f, 
    0.04504375f, -0.03308566f, -0.13375001f, 0.04303950f, -0.34393179f, -0.29964292f, -0.17184365f, -0.13030449f, 
    0.02235232f, -0.08432605f, 0.11271332f, -0.17139325f, -0.64657450f, -0.08038102f, -0.14736031f, -0.11531573f, 
    0.31183302f, 0.42584112f, 0.13225248f, -0.09958591f, -0.48992932f, 0.47806010f, 0.14342026f, 0.08631404f, 
    0.26629472f, 0.12582214f, -0.13253291f, 0.14279695f, -0.85039395f, -0.13388784f, -0.17077820f, -0.16733241f, 
    0.12940651f, -0.01288394f, -0.08279826f, 0.06446458f, 0.38763502f, -0.13765173f, -0.06439098f, -0.46752208f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.19948338f, 0.06802029f, 0.01293650f, 0.01484983f, 0.05576277f, 0.20378608f, 0.10623439f, -0.16547717f, 
    0.02841701f, -0.15391260f, -0.05917947f, 0.04354267f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
