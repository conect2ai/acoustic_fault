#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.26387525f, 0.39725271f, -0.03431900f, 0.38972506f, 0.35907996f, -0.34776321f, 0.23124084f, 0.17890222f, 
    0.18236123f, 0.15784718f, 0.23044677f, 0.14433469f, -0.13741849f, 0.30039546f, -0.16337234f, -0.25525737f, 
    -0.28667769f, 0.46492937f, -0.09073482f, -0.44728994f, 0.03490504f, -0.00253099f, -0.26668066f, -0.30381781f, 
    0.35849753f, 0.39187297f, -0.64075166f, -0.71264297f, -0.17911951f, -0.38735536f, -0.53680158f, 0.70857072f, 
    0.56828260f, -0.12527873f, 0.39258561f, 0.23507695f, 0.01943238f, 0.29345429f, -0.16501820f, 0.17008187f, 
    -0.16501001f, 0.17944472f, -0.00517365f, -0.04089735f, -0.12549333f, 0.17017239f, -0.22489730f, 0.16540492f, 
    0.08435243f, 0.19308190f, -0.00939415f, -0.02909148f, -0.10544714f, 0.48156977f, -0.00623240f, -0.51730204f, 
    -0.77291876f, -0.54585147f, -0.11751233f, -0.15692461f, 0.24893357f, 0.42897472f, 0.45709154f, -0.02470092f, 
    -0.13537599f, -0.17261298f, -0.08777845f, 0.34937087f, -0.31985503f, 0.30565163f, 0.08067996f, -0.16098665f, 
    -0.04456823f, -0.20274086f, 0.21779886f, -0.15509105f, -0.31896776f, -0.40928924f, -0.53802580f, -0.30002445f, 
    -0.14247286f, 0.05057266f, 0.41324806f, 0.40090221f, 0.21986969f, -0.40327400f, -0.20677191f, -0.19536398f, 
    -0.14526173f, 0.01133291f, -0.15775537f, -0.08405801f, -0.02023174f, 0.03228052f, 0.25679877f, 0.19712286f, 
    -0.13826753f, -0.18067476f, -0.18167798f, -0.38781512f, 0.44426250f, 0.45695964f, -0.05340142f, 0.21601968f, 
    -0.44223431f, -0.36656654f, -0.56224185f, -0.26190275f, -0.33497864f, -0.48155016f, -0.13161193f, -0.10545326f, 
    -0.12552017f, -0.04376921f, -0.26923865f, -0.20351291f, 0.14028926f, -0.32727978f, -0.20588383f, -0.05965289f, 
    -0.33092511f, 0.17491087f, 0.02284962f, 0.08541179f, 0.02727846f, -0.80781627f, 0.22650044f, 0.71476173f, 
    -0.57652032f, 0.49069160f, -0.19969884f, 0.27353233f, -0.22981127f, -0.23395407f, -0.57580060f, 0.04334759f, 
    0.25436041f, 0.15067816f, 0.05818913f, -0.19368777f, 0.42551860f, 0.07653558f, 0.16399908f, 0.15699176f, 
    0.25452065f, -0.14890927f, -0.16554268f, -0.18530902f, -0.13476577f, 0.34018397f, 0.36795652f, 0.40502715f, 
    -0.47184542f, 0.06853800f, -0.44715437f, 0.54790080f, 0.26039597f, 0.23575725f, 0.47278905f, 0.52458078f, 
    0.16452232f, 0.02343886f, 0.12311444f, -0.05162658f, 0.14519952f, -0.16627818f, -0.32816914f, -0.02123441f, 
    -0.31193829f, -0.05136003f, -0.11812884f, -0.18859561f, 0.12880382f, -0.09736960f, 0.25270140f, 0.13986850f, 
    -0.07556273f, -0.70922619f, -0.52104354f, 0.33257014f, 0.32467642f, 0.17175339f, 0.32657987f, -0.07659548f, 
    -0.05046994f, -0.27127925f, 0.21371368f, 0.09660996f, -0.10395119f, -0.22553027f, -0.04818370f, -0.17155246f, 
    0.27592692f, 0.43320122f, -0.42823064f, 0.04587558f, -0.12833050f, -0.03590672f, -0.22920167f, 0.19377553f, 
    -0.57347560f, -0.23019929f, 0.26443365f, 0.18044053f, -0.23892473f, -0.55059946f, -0.11615563f, -0.28744048f, 
    -0.08007671f, -0.45088229f, -0.19912747f, 0.33682436f, -0.07047676f, 0.35378763f, 0.25493166f, -0.04146829f, 
    0.28373784f, 0.25014299f, 0.22675288f, 0.16258939f, 0.15929136f, -0.21805432f, 0.25287735f, -0.19040179f, 
    -0.42644513f, -0.69423884f, -0.08637389f, 0.37129134f, -0.04917127f, 0.11181874f, -0.32647869f, 0.22995038f, 
    -0.45916790f, -0.35753742f, -0.45665210f, -0.00547127f, 0.07056657f, 0.43508571f, 0.34344774f, 0.32899916f, 
    0.06045243f, -0.48550320f, 0.01888612f, -0.41544241f, -0.17850620f, -0.37339914f, 0.28330362f, 0.02044502f, 
    0.03195013f, 0.01608885f, 1.04970050f, 0.23777582f, -0.58962554f, -0.56861597f, -0.40307245f, -0.32051611f, 
    0.13231882f, 0.07988513f, -0.01403330f, -0.38732934f, -0.02581777f, -0.01350953f, 0.41715121f, 0.30581269f, 
    0.02941176f, 0.02397203f, -0.18826649f, -0.05340753f, 0.00490514f, 0.21665417f, 0.00898451f, 0.05786835f, 
    0.07287136f, 0.07178575f, 0.09628431f, -0.09242074f, -0.18949525f, 0.64775711f, -0.01481534f, -0.78242296f, 
    -0.74428844f, 0.06226435f, 0.06160928f, -0.44575870f, -0.01592635f, 0.23904876f, 0.46556702f, -0.15537140f, 
    -0.06663325f, -0.05785725f, -0.10320073f, -0.02721186f, 0.17600535f, 0.20058179f, -0.12932554f, 0.00419325f, 
    0.07540172f, -0.16590068f, -0.11425107f, -0.14940980f, 0.56873369f, -0.04862731f, -0.81112039f, 0.52245706f, 
    0.53511143f, -0.31087556f, 0.25235966f, 0.26746926f, 0.49689829f, 0.01622892f, 0.17111290f, -0.03303099f, 
    -0.18865040f, -0.26073959f, -0.31387517f, -0.03943688f, -0.26870233f, -0.29379618f, -0.22498561f, -0.13829829f, 
    0.06532137f, 0.05213673f, 0.07103951f, 0.18253893f, 0.23637959f, 0.97333300f, 0.47034591f, -0.25566766f, 
    0.61665261f, 0.75546819f, 0.30105710f, 0.27050003f, 0.26913810f, 0.39890486f, 0.37300804f, -0.53646028f, 
    0.06891713f, -0.25589317f, -0.39724320f, -0.00235705f, -0.24138162f, -0.27027512f, -0.12665075f, 0.16414012f, 
    0.25882122f, -0.03018340f, 0.07449169f, 0.08301394f, -0.17095864f, -0.15994819f, 0.08398174f, -0.41737321f, 
    -0.33997819f, -0.33968854f, 0.47336769f, -0.38390580f, -0.54994076f, 0.06291761f, -0.03035350f, -0.27951124f, 
    -0.38164821f, -0.05855085f, -0.11347216f, -0.42454106f, -0.15214562f, 0.30354980f, -0.19978003f, 0.32446194f, 
    0.11718085f, -0.40454486f, -0.17270869f, -0.23468952f, 0.16149254f, 0.24500555f, 0.28209516f, -0.18890357f, 
    0.11386270f, 0.47443521f, 0.23180996f, 0.07701722f, 0.00607321f, 0.41206351f, -0.21058515f, -0.70088726f, 
    -0.22788620f, -0.44943142f, 0.22553891f, 0.26885089f, 0.41139352f, -0.13772605f, 0.18225296f, -0.05951785f, 
    -0.20122635f, 0.25172448f, -0.30600253f, 0.09563066f, -0.17719956f, -0.01744296f, -0.21770978f, 0.05324791f, 
    -0.10499838f, 0.38915804f, 0.66023898f, 0.25035733f, 0.49738181f, -1.00620413f, 0.31233117f, -0.18329099f, 
    -0.62363678f, -0.14537355f, 0.46833020f, 0.29545397f, -0.11696303f, 0.05773990f, -0.12458842f, 0.18283382f, 
    -0.28038567f, 0.02185514f, -0.03818966f, 0.11352837f, 0.02962458f, -0.03391206f, 0.24688496f, 0.06393631f, 
    -0.31261623f, -0.89582056f, 0.02321112f, -0.46338323f, -0.31922999f, -0.21277204f, 0.35236567f, 0.77283061f, 
    -0.15271741f, 0.23948412f, 0.35399601f, -0.35687965f, -0.03586992f, 0.30520386f, -0.27208611f, 0.21621056f, 
    0.15283868f, 0.07157870f, -0.13266116f, -0.18573822f, -0.12415458f, -0.08239468f, -0.07427082f, 0.05190029f, 
    0.05830215f, 0.10430317f, 0.55155981f, -0.24062689f, 0.48824763f, 0.29925138f, -0.85069418f, 0.14541987f, 
    -0.98079926f, 0.53335887f, 0.14035557f, 0.26874998f, 0.39119184f, -0.22340398f, -0.30786133f, -0.11101989f, 
    -0.09945393f, 0.05296533f, -0.01402433f, -0.06432111f, -0.27263537f, 0.00069682f, 0.13088982f, 0.22327890f, 
    0.05968456f, -0.00752041f, -0.18919413f, -0.55487049f, -0.64134300f, -0.34300858f, -0.22107935f, -0.28437096f, 
    0.30077916f, 0.27231261f, 0.40444040f, 0.51244664f, 0.21314248f, 0.17257580f, 0.04856294f, -0.04420840f, 
    0.08734194f, 0.09610360f, 0.00720491f, 0.21214882f, 0.19669496f, 0.17938638f, -0.07716547f, 0.00175041f, 
    0.13273343f, 0.01140599f, -0.23363563f, 0.25164261f, 1.04196262f, -0.36191982f, -0.37347701f, -0.06174258f, 
    -0.13531905f, -0.16889197f, 0.39689928f, -0.14863363f, 0.07366305f, -0.00205157f, -0.32056653f, 0.15997055f, 
    -0.08552235f, 0.18722297f, -0.25603515f, -0.06580577f, -0.13323542f, -0.03009064f, 0.10165081f, 0.15364067f, 
    0.09494299f, 0.29834545f, -0.05913962f, -0.01229838f, -0.12454458f, -0.53132564f, 0.52090311f, 0.54097170f, 
    0.37679970f, -0.40710646f, -0.77466601f, 0.05774052f, -0.15406486f, -0.02452413f, 0.32012886f, -0.25180954f, 
    0.49828327f, -0.41994265f, 0.01402676f, 0.08931786f, -0.17857081f, 0.13829641f, -0.00371621f, 0.14596383f, 
    -0.00998433f, 0.13760790f, -0.00432243f, -0.24263461f, -0.16664135f, -0.14129508f, 0.78024966f, 0.42274275f, 
    -0.00287411f, -0.27883676f, -0.14747298f, 0.22555189f, 0.38498956f, -0.08666206f, -0.32829422f, 0.24325600f, 
    -0.18788140f, 0.36130059f, 0.16450758f, 0.33642370f, 0.08294867f, -0.05634908f, 0.11434580f, 0.27495092f, 
    0.36947215f, 0.02667776f, -0.01130618f, 0.00611653f, 0.21778442f, -0.07689332f, 0.21952941f, 0.27393824f, 
    -0.39742532f, -0.63146818f, 0.22998230f, -0.24024215f, 0.20054533f, 0.08488844f, 0.16265137f, 0.31858546f, 
    0.25152415f, -0.50795174f, 0.17999788f, 0.34229529f, -0.47512707f, -0.38704881f, -0.54596025f, -0.03399071f, 
    0.05963515f, 0.01332863f, -0.25737345f, -0.08126104f, 0.17995939f, -0.36642066f, -0.22776797f, 0.35498807f, 
    -0.30323225f, -0.00906471f, -0.42539334f, -0.12199859f, -0.42997319f, 0.55914074f, 0.21410766f, -0.56597799f, 
    -0.02319455f, 0.31882787f, 0.34367889f, -0.23579700f, 0.11045486f, -0.30674797f, -0.30639157f, 0.17903718f, 
    0.28733829f, 0.50419039f, 0.46686387f, -0.11720098f, -0.16211347f, -0.32430691f, -0.04763389f, 0.17339355f, 
    0.44448492f, 0.19997236f, 0.35441452f, 0.58274138f, 0.27169523f, 0.21030930f, 0.23747368f, -0.34621081f, 
    -0.36216486f, -0.36270615f, -0.05551639f, 0.16145337f, 0.46001241f, -0.12211370f, -0.04456336f, 0.29743960f, 
    0.03331393f, 0.10150765f, 0.31467617f, 0.04999092f, 0.46019822f, 0.06017445f, -0.00008291f, -0.08274741f, 
    -0.01508663f, 0.11572024f, -0.80927777f, -0.32344800f, -0.62321705f, -0.22258398f, -0.44172797f, 0.02011220f, 
    -0.33065975f, 0.01290042f, 0.20887035f, -0.13543744f, -0.21284471f, 0.19901420f, -0.14612727f, 0.46274579f, 
    0.07658743f, -0.09383846f, 0.06314448f, -0.16530801f, 0.03466285f, 0.02317260f, -0.19483355f, 0.11577541f, 
    0.23498677f, -0.22081523f, 0.15528013f, -0.12563407f, -0.48342875f, 0.53644598f, 0.47099459f, 0.33774108f, 
    0.70209658f, 0.29655024f, 0.06381945f, -0.15399815f, -0.12805328f, -0.05339723f, -0.17177661f, -0.34031516f, 
    0.46023825f, 0.16997442f, 0.26269791f, 0.04844660f, -0.32964179f, 0.20461373f, 0.16920441f, 0.15567707f, 
    0.22449458f, -0.12908727f, 0.20913230f, 0.16618204f, 0.46020910f, -0.03292174f, -0.45337948f, -0.63149422f, 
    -0.41808298f, -0.21251328f, 0.53296846f, 0.41216484f, -0.09891933f, -0.04701601f, 0.01002032f, -0.08596324f, 
    -0.31813249f, -0.29503879f, 0.08731742f, 0.16298574f, 0.05958086f, -0.19641660f, 0.10364917f, 0.01811478f, 
    -0.11386523f, 0.04678792f, 0.21706533f, -0.26524407f, 0.20234257f, -0.17728002f, 0.24601629f, 0.03147899f, 
    -0.46797630f, 0.20809281f, -0.68983924f, 0.58150703f, -0.21937963f, -0.64291644f, -0.13044444f, -0.04618159f, 
    0.34979239f, 0.27694041f, 0.20000190f, -0.07496028f, -0.49016023f, 0.15151855f, -0.27386063f, -0.24615175f, 
    0.03568830f, 0.17925464f, -0.17961541f, -0.17136043f, 0.03248745f, 0.09040292f, 0.76805633f, 0.56133246f, 
    0.03208439f, -0.62550730f, -0.54147255f, 0.31951612f, 0.28407669f, 0.35298949f, 0.44660830f, 0.37096071f, 
    -0.13584563f, 0.40688995f, -0.13164835f, -0.06999141f, -0.02386204f, 0.06274348f, 0.34325662f, 0.26462296f, 
    0.23809128f, -0.07673179f, -0.01642046f, -0.07329679f, 0.17137671f, -0.18286203f, -0.19389519f, -0.73658925f, 
    0.26892981f, -0.05861943f, -0.24218072f, -0.11298629f, 0.39079359f, 0.57051098f, 0.33952048f, 0.60092777f, 
    0.53086424f, -0.16992763f, -0.14853799f, -0.03078108f, -0.31316084f, -0.22997075f, 0.31463885f, 0.15985198f, 
    0.13546742f, 0.19516467f, -0.08444565f, 0.15924792f, -0.38523886f, -0.29862699f, -0.33600461f, -0.07356091f, 
    -0.45121527f, 0.04632181f, -0.49719489f, -0.30953190f, 0.12885116f, -0.51573706f, 0.01347191f, 0.34037831f, 
    -0.29219404f, 0.28630608f, 0.06075779f, -0.10873877f, -0.16616409f, -0.59532964f, -0.31012172f, 0.27400360f, 
    -0.13154571f, 0.18502297f, 0.33213502f, 0.07278681f, 0.27324948f, 0.15943266f, -0.13856411f, -0.15051778f, 
    0.28695840f, -0.31362638f, -0.62176853f, -0.55091518f, -0.40216237f, 0.07705292f, -0.25186005f, 0.14440170f, 
    0.21709812f, 0.15402368f, 0.50348383f, 0.37067056f, 0.01852099f, -0.16669741f, -0.05814876f, -0.24044092f, 
    0.14327011f, 0.03519704f, -0.08229189f, 0.18119414f, 0.30928385f, 0.02222180f, 0.07884743f, -0.20090523f, 
    0.31305543f, 0.23790577f, -0.15079062f, -0.94482762f, -0.54556924f, 0.62041771f, 0.70029116f, -0.76511461f, 
    0.40777275f, 0.63225508f, -0.34434357f, 0.03564372f, 0.15051323f, -0.06199859f, -0.18837744f, -0.11041021f, 
    0.37843207f, 0.05036178f, 0.21626927f, -0.05000140f, -0.06158728f, -0.06581081f, -0.14046143f, -0.29379404f, 
    -0.00902397f, -0.05444908f, -0.05490332f, -0.25774658f, -0.34685615f, 0.06500267f, -0.34353128f, 0.10503828f, 
    0.01346927f, 0.31739056f, -0.15728645f, -0.68377423f, -0.40265515f, -0.23515730f, 0.16860679f, -0.15279458f, 
    -0.28997728f, -0.49679396f, -0.55732524f, -0.20327041f, -0.37459591f, 0.02422540f, -0.53525126f, 0.01847630f, 
    -0.28386033f, 0.22404380f, 0.28183612f, 0.27712840f, -0.20458739f, 0.81996906f, -0.39795086f, -0.68433601f, 
    0.52229041f, 0.65572900f, -0.86299390f, 0.07682207f, -0.14880976f, -0.23769146f, 0.17220914f, -0.22968355f, 
    0.22156622f, 0.08556485f, -0.19076297f, 0.15655214f, 0.08168513f, 0.00383650f, 0.02359731f, 0.19375992f, 
    0.18424352f, -0.07080512f, 0.20922311f, -0.10202450f, -0.25898209f, 0.54261976f, 0.51351321f, 0.65451461f, 
    0.19583607f, 0.56610560f, -0.53895897f, -0.57441616f, -0.46086192f, -0.05777467f, -0.10666482f, 0.02994832f, 
    -0.03478802f, 0.28442451f, 0.19618265f, -0.01069624f, 0.13578901f, -0.03221376f, 0.03528624f, 0.12223173f, 
    0.09933200f, 0.01166262f, -0.05123364f, 0.19647741f, 0.07799317f, -0.18919300f, 0.44771048f, 0.86186427f, 
    0.47551265f, 0.27372256f, 0.17339061f, -0.55815393f, 0.31423634f, -0.01356772f, -0.50649792f, -0.04621178f, 
    0.06592496f, 0.10773022f, -0.34144756f, 0.35867527f, 0.12129756f, -0.30863950f, 0.21353488f, 0.09106044f, 
    -0.04952708f, -0.17067394f, 0.10278646f, -0.06834113f, 0.14425816f, -0.07465742f, 0.16142952f, -0.41085181f, 
    -1.03118551f, -0.26476109f, 0.20584558f, -0.26754668f, 0.24226861f, 0.87152767f, 0.37620559f, -0.40505058f, 
    0.35762084f, -0.20442417f, -0.11072464f, -0.34500134f, -0.29390466f, 0.05066558f, -0.19939063f, 0.11471856f, 
    -0.13350455f, 0.13571058f, -0.05782533f, 0.27487752f, 0.10599131f, -0.16821843f, 0.26439652f, -0.15222861f, 
    0.25982314f, -0.07359724f, -0.21324341f, -0.22102329f, 0.41189194f, 0.80820209f, 0.15490809f, -0.67313939f, 
    -0.01276784f, -0.09820964f, -0.12753321f, 0.36024749f, -0.18969880f, 0.26398444f, 0.40867719f, -0.39169505f, 
    -0.26629841f, -0.34537575f, -0.02397750f, -0.14875032f, 0.08921587f, 0.27133176f, -0.32802132f, -0.42018056f, 
    -0.03026697f, -0.03779093f, -0.44561377f, -0.59267092f, -0.65313500f, 0.45012200f, 0.12484286f, -0.28993717f, 
    -0.59380084f, -0.28440961f, -0.10950890f, -0.27015480f, 0.24381448f, 0.39899981f, -0.02162350f, 0.17492400f, 
    0.33970922f, 0.16671818f, -0.04403709f, 0.04257290f, 0.21135421f, 0.07191820f, 0.18322314f, 0.21761586f, 
    0.15315636f, -0.07603500f, -0.69120055f, -0.52199811f, 0.52209264f, 0.54399884f, 0.58792067f, 0.42248297f, 
    0.45841977f, 0.50237817f, -0.25120917f, 0.46537489f, -0.16282298f, 0.06159806f, 0.35823256f, 0.29553160f, 
    -0.22831999f, -0.17962031f, -0.13461758f, -0.19367732f, -0.11096774f, 0.04013510f, 0.09120313f, -0.07892464f, 
    -0.15987317f, 0.08575287f, -0.22713187f, -0.07523496f, -0.45736420f, -0.09669743f, 0.30988595f, 0.05528149f, 
    -0.46388993f, -0.54556948f, 0.02119635f, 0.29517457f, 0.13503662f, 0.25815710f, 0.10206409f, 0.24608757f, 
    -0.09876379f, -0.25959772f, -0.30123597f, 0.35745296f, -0.27699363f, 0.27226815f, 0.12425371f, -0.41562197f, 
    -0.23864102f, 0.47399762f, 0.01365481f, -0.15098447f, 0.27936867f, 0.00596667f, 0.00800468f, 0.59243703f, 
    -0.10583324f, -0.49222150f, -0.01754651f, 0.48159224f, -0.00586423f, 0.21423076f, 0.22664762f, 0.15638132f, 
    -0.08033928f, -0.01124442f, 0.33643252f, -0.11150979f, 0.16404766f, 0.02941651f, -0.03879609f, -0.06505099f, 
    0.34290159f, 0.33314276f, -0.39209443f, 0.26538846f, -0.15647355f, -0.26816103f, 0.20225850f, 0.43187889f, 
    0.66647249f, 0.31201106f, 0.28234643f, 0.67115527f, 0.29467669f, 0.21970093f, 0.36344430f, -0.35960352f, 
    -0.05809925f, 0.18113644f, -0.21279804f, 0.00197172f, -0.34900129f, -0.09055360f, 0.11331002f, 0.06079363f, 
    -0.09382273f, -0.07562440f, 0.19260055f, -0.24809802f, 0.16132233f, 0.13212223f, 0.45913738f, 0.70797503f, 
    0.10156972f, -0.38478813f, -0.72782451f, 0.26937202f, 0.19844528f, -0.42811438f, -0.37584874f, 0.19816145f, 
    0.38115096f, 0.32601210f, 0.24952476f, 0.12797570f, -0.20522907f, 0.16965514f, -0.44664881f, 0.14531602f, 
    0.25811574f, -0.26792261f, -0.06261116f, 0.05943748f, -0.07585913f, -0.14474694f, 0.40077150f, -0.92495018f, 
    -0.30207908f, -0.20023841f, 0.11520045f, 0.21049996f, -0.78037947f, -0.18416157f, 0.08400196f, -0.61967468f, 
    -0.21380232f, 0.05817228f, 0.25161666f, 0.46262458f, 0.03874904f, 0.09756310f, 0.21023484f, 0.00005056f, 
    0.15405637f, 0.17838226f, -0.15120518f, -0.25664270f, 0.00959630f, -0.07176805f, 0.05622346f, 0.05372127f, 
    0.33795238f, 0.68052083f, 0.38523000f, 0.52209109f, 0.65811646f, -0.47612739f, 0.43304962f, 0.34584120f, 
    -0.36037204f, 0.17824174f, -0.45895880f, -0.50837266f, -0.00860620f, 0.17265522f, 0.24848178f, -0.15828314f, 
    0.15579464f, 0.11782537f, 0.08051649f, 0.00001051f, 0.08278718f, -0.10564006f, -0.15259907f, 0.25311378f, 
    0.00480159f, -0.40731257f, 0.06302273f, -0.21626689f, -0.56409246f, -0.52207237f, 0.55859661f, 0.54305387f, 
    0.17993815f, 0.29508135f, 0.27506796f, 0.17217542f, -0.21047315f, 0.00951425f, -0.00292648f, -0.31364274f, 
    -0.01342273f, -0.37200597f, 0.00371452f, -0.13879120f, 0.24441932f, -0.16572937f, -0.02596211f, -0.07325606f, 
    -0.35203314f, 0.22104414f, 0.70351928f, 0.09167469f, 0.75566709f, 0.69157165f, 0.69719386f, 0.39532360f, 
    -0.19002436f, -0.38780090f, 0.00246992f, -0.00182249f, 0.17597245f, 0.31874713f, -0.23152150f, 0.04922858f, 
    -0.09188765f, -0.04562484f, -0.01393304f, -0.29489636f, -0.12324282f, 0.22383009f, 0.24624719f, 0.07816705f, 
    0.27313161f, -0.28538236f, 0.20186831f, -0.20853029f, -0.19879381f, -0.22423904f, 0.60355246f, -0.62066305f, 
    0.37620741f, 0.15949617f, -0.46196482f, 0.00805824f, 0.36371940f, 0.21541500f, -0.07449702f, 0.07526147f, 
    -0.24364926f, 0.39217958f, -0.46250373f, -0.65906513f, 0.28430307f, -0.07005526f, -0.30427092f, -0.00097925f, 
    0.36367813f, 0.10706069f, 0.30355626f, -0.38063115f, 0.57570261f, 0.22188367f, 0.09194655f, -0.42316583f, 
    0.16981737f, 0.50699717f, 0.01743839f, -0.46053660f, -0.19387299f, -0.00675944f, -0.37650549f, -0.30992278f, 
    -0.42303619f, -0.39808199f, -0.04360991f, -0.27900112f, 0.24684511f, -0.16306612f, -0.46150959f, -0.39357916f, 
    0.03343474f, -0.29961514f, 0.00875085f, 0.01176575f, -0.01238476f, 0.00540566f, 0.59242302f, 0.41329539f, 
    -0.69765836f, -0.24969515f, -0.05331681f, 0.04657410f, -0.65810245f, -0.43008626f, -0.46031338f, -0.14394961f, 
    -0.03283398f, -0.44478917f, 0.25333783f, -0.21616636f, -0.27774301f, -0.30746460f, -0.16201699f, -0.34262750f, 
    0.06936683f, 0.04349448f, 0.08701550f, 0.24793707f, -0.06948920f, 0.01306821f, 0.39184475f, 0.47816682f, 
    -0.16367690f, 0.68825567f, 0.26265532f, -0.57810992f, -0.41000420f, -0.55865014f, -0.19628771f, 0.19329298f, 
    0.35429212f, -0.15056920f, 0.19487286f, -0.13490596f, 0.14083719f, 0.30789301f, 0.31280598f, 0.22172546f, 
    -0.31964037f, 0.25917524f, 0.24281506f, -0.14816006f, -0.19852999f, 0.25208795f, 0.08007219f, 0.16851211f, 
    0.78855985f, -0.01606992f, -0.28032625f, 0.21516281f, -0.69611901f, 0.64242190f, -0.25458020f, -0.46360806f, 
    -0.15976833f, 0.36166167f, 0.35186714f, 0.07949355f, -0.04895080f, 0.38417089f, 0.15017620f, 0.04029870f, 
    -0.15098098f, 0.16946992f, -0.10766388f, -0.24504459f, 0.03605421f, 0.19081876f, 0.50888342f, 0.24994712f, 
    0.61019409f, 0.69253761f, 0.63899612f, 0.52768266f, -0.60089332f, -0.21129383f, -0.63491189f, 0.05460978f, 
    -0.10551634f, 0.62617862f, 0.08271494f, 0.00660865f, -0.22492345f, 0.34475338f, -0.33420759f, -0.21879581f, 
    -0.04804499f, 0.07699341f, -0.28176010f, -0.13617583f, 0.16503994f, -0.12004540f, -0.00640844f, 0.01026464f, 
    -0.15042953f, -0.28988701f, -0.36063004f, -0.47266293f, -0.46839726f, -0.17676553f, 0.29094312f, 0.49048290f, 
    -0.27746424f, 0.21296889f, 0.22280119f, 0.20857918f, -0.22925469f, -0.09844179f, -0.16581246f, 0.00393566f, 
    -0.28256208f, 0.17832573f, -0.08188432f, 0.03276741f, -0.36995602f, 0.01803670f, -0.00824394f, 0.31111583f, 
    0.18092084f, -0.17274520f, 0.91848350f, 0.49937752f, 0.38769099f, 0.74168730f, 0.85615796f, 0.46131924f, 
    0.12773755f, 0.00750156f, 0.14605728f, -0.15740271f, -0.12973580f, 0.37587994f, 0.00364310f, 0.16327655f, 
    -0.06983332f, 0.16635996f, -0.15309146f, 0.14133209f, 0.21328586f, -0.21763422f, 0.04383953f, -0.04100342f, 
    0.00910002f, -0.00160627f, 0.14212182f, 0.10670398f, -0.12265357f, 0.52240777f, 0.70281762f, -0.36680624f, 
    -0.23318297f, -0.70885664f, 0.54943603f, 0.21946846f, 0.12294500f, 0.19207980f, -0.14213501f, -0.41748208f, 
    -0.35051796f, -0.17165838f, -0.29560837f, -0.38573819f, -0.11458328f, -0.09384941f, 0.08055642f, 0.08033364f, 
    0.16089456f, -0.03840320f, 0.14853980f, -0.05325577f, 0.51605695f, 0.24641451f, 0.05400328f, -0.37149739f, 
    0.37667084f, -0.01222283f, -0.25858098f, 0.37293231f, 0.56183511f, 0.43255672f, -0.06522492f, -0.31489673f, 
    0.01828837f, 0.21811309f, -0.10566327f, 0.30024135f, -0.05225170f, -0.21606986f, 0.18268782f, 0.13070725f, 
    0.28786752f, -0.05767655f, 0.21473330f, 0.09923728f, 0.14728107f, -0.09368671f, -0.07887458f, 0.02170564f, 
    -0.49591172f, -0.47136453f, 0.24266514f, -0.39122665f, -0.45999825f, -0.62400109f, -0.15642011f, 0.38251612f, 
    0.13794693f, -0.17338291f, 0.29157269f, 0.22046441f, 0.04471271f, 0.31940949f, -0.24393477f, 0.02621762f, 
    0.34455889f, 0.24284348f, 0.13854864f, 0.18423566f, 0.61800653f, 0.00899682f, -0.08975708f, 0.10153049f, 
    -0.65030932f, -0.48878315f, 0.19752046f, 0.71088469f, 0.04086690f, -0.43556768f, 0.41287464f, -0.23780735f, 
    0.12060145f, -0.25594258f, -0.12917663f, 0.39670649f, -0.16771042f, 0.11758634f, -0.08500163f, 0.09089568f, 
    -0.03342585f, 0.28295878f, 0.20781392f, -0.01772504f, -0.19608557f, -0.03627720f, 0.31848070f, -0.71293986f, 
    0.49031469f, 0.23578347f, -0.03173903f, 0.56563282f, 0.36402455f, -0.43173793f, -0.02543822f, -0.39376462f, 
    -0.03023854f, -0.52777570f, -0.25059742f, -0.37976196f, -0.15234573f, -0.26619214f, -0.07102464f, -0.34533900f, 
    0.29852188f, -0.27740663f, -0.34805691f, 0.11035089f, 0.09868819f, -0.35964984f, 0.04739204f, 0.33347756f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.01068179f, 0.04816344f, 0.09548926f, 0.06405698f, 0.22970596f, 0.05177160f, 0.18502524f, 0.04267117f, 
    0.33145186f, 0.16300958f, 0.02234292f, 0.17688054f, 0.07091823f, 0.09520201f, 0.04538750f, -0.10858093f, 
    0.00413576f, 0.05277892f, 0.19924775f, -0.05442648f, 0.04470150f, 0.06644270f, 0.19978434f, 0.06308816f, 
    -0.01095985f, 0.03338470f, 0.26489887f, 0.18792275f, 0.02394385f, 0.05368933f, 0.11870945f, 0.13284768f, 
    0.04039469f, 0.06460666f, 0.03665628f, -0.03585490f, -0.02567429f, 0.12067732f, 0.10739622f, 0.09268734f, 
    0.07065830f, 0.04972223f, 0.27766594f, 0.15319204f, 0.05376426f, 0.11337870f, 0.18780364f, 0.13841583f, 
    0.08405487f, 0.24725765f, 0.09107797f, 0.05815063f, 0.10745271f, -0.10956062f, 0.14557950f, 0.11345803f, 
    0.16656804f, -0.13349421f, 0.03427055f, 0.08268645f, 0.10371698f, 0.04120276f, 0.01509718f, 0.08138967f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.02418457f, -0.02517567f, 0.01524036f, 0.00899083f, 0.02530600f, -0.03828012f, 0.03211728f, -0.01290285f, 
    0.00732103f, 0.00086040f, 0.01264332f, -0.02687899f, 0.00123204f, -0.01620282f, -0.02299069f, 0.02486640f, 
    0.01899945f, -0.02996110f, 0.03257839f, 0.03041622f, 0.00095166f, -0.04259175f, 0.01660299f, -0.02641721f, 
    -0.03596802f, -0.03244286f, 0.01109435f, 0.03057571f, -0.00904141f, -0.02625669f, -0.00397783f, 0.02053257f, 
    -0.03099245f, -0.02837464f, 0.01257229f, 0.01305080f, -0.00933091f, 0.02558674f, -0.03517953f, 0.01843254f, 
    -0.01691510f, -0.00386141f, -0.01132349f, -0.00638377f, -0.00398504f, -0.01560528f, -0.00627780f, 0.02527496f, 
    -0.00086637f, 0.00905562f, -0.03965684f, -0.00129697f, 0.02286443f, -0.01275821f, -0.03862993f, 0.00022017f, 
    -0.01705034f, -0.00134262f, 0.03642231f, -0.02708709f, 0.01097585f, -0.01192075f, -0.01885758f, -0.01314852f, 
    -0.01885360f, -0.01687190f, 0.00189793f, 0.02626809f, -0.00367557f, 0.02183816f, -0.00025231f, 0.00484685f, 
    0.01722932f, 0.01168596f, -0.03237410f, -0.01345927f, 0.02440786f, -0.00096234f, -0.03027756f, 0.00649265f, 
    -0.01688542f, -0.01515367f, -0.00815401f, 0.00407932f, -0.03071317f, -0.03647258f, 0.00810723f, -0.02090755f, 
    -0.01461889f, -0.01177119f, 0.02622186f, -0.02971138f, -0.02063860f, -0.00640821f, -0.00119739f, -0.01839735f, 
    0.01662520f, 0.00479317f, -0.04611746f, -0.02216822f, -0.02143684f, 0.01897486f, -0.00388984f, 0.01654034f, 
    0.00159007f, 0.00605600f, -0.01964839f, -0.03423429f, -0.00470043f, -0.03323186f, -0.01560124f, -0.02236881f, 
    0.00136309f, -0.01825904f, -0.01072362f, -0.02567023f, -0.00547229f, -0.00187858f, -0.03213871f, -0.00978957f, 
    -0.01407711f, -0.00676727f, 0.02800436f, 0.02159511f, -0.03073781f, 0.01115620f, 0.02402054f, 0.03039022f, 
    -0.01042781f, 0.02616868f, 0.02787088f, -0.03766128f, -0.03073362f, 0.03269758f, 0.01973340f, 0.03403474f, 
    0.00609918f, -0.01794008f, -0.01058365f, 0.01663286f, 0.01600661f, -0.03210254f, -0.03661120f, -0.04039376f, 
    0.02607406f, -0.03401254f, 0.00008122f, 0.02215506f, 0.02810415f, -0.00762819f, 0.01781558f, -0.00643318f, 
    -0.03425557f, 0.02737866f, 0.02484158f, 0.00784840f, -0.00458798f, 0.01816438f, 0.00437910f, -0.02124834f, 
    -0.01265238f, 0.01344013f, 0.00292271f, -0.01631225f, 0.02252664f, 0.01693558f, -0.00929588f, -0.02195783f, 
    -0.01825153f, -0.02937424f, -0.00895467f, 0.01580286f, 0.01271686f, -0.03359709f, -0.01603913f, 0.01400553f, 
    -0.01408898f, -0.03473509f, 0.00298046f, -0.03285512f, 0.02072150f, 0.02796826f, 0.02213492f, -0.00445845f, 
    -0.03242277f, 0.01726090f, 0.02612471f, -0.01274721f, -0.03620392f, -0.00236857f, 0.01831010f, -0.04386544f, 
    0.01255901f, -0.00824841f, -0.03121344f, 0.01734817f, -0.01322626f, 0.00198442f, 0.01290465f, 0.02859655f, 
    -0.03491135f, -0.02253626f, 0.02975246f, 0.00018372f, 0.01461430f, 0.03218255f, -0.01399830f, -0.03229658f, 
    0.00906154f, -0.00872094f, -0.02417853f, 0.01895631f, -0.01750000f, 0.01827621f, 0.00591421f, -0.02779485f, 
    -0.03405415f, 0.02955526f, -0.00222839f, -0.00324002f, 0.01381023f, -0.02637420f, -0.02575491f, 0.01445032f, 
    -0.02440601f, 0.03258855f, -0.02092584f, -0.02119705f, 0.01485058f, -0.02667308f, -0.00729257f, 0.01585662f, 
    -0.03339908f, 0.00743451f, -0.00511775f, -0.00617791f, 0.01496530f, 0.02386520f, 0.00936636f, 0.01346803f, 
    0.02794654f, 0.03051114f, -0.02278338f, 0.00140149f, -0.00770353f, -0.00964998f, -0.01260099f, 0.02654843f, 
    -0.03473470f, 0.03230799f, 0.01118737f, -0.02029627f, 0.00756824f, -0.02305759f, -0.01325880f, 0.00809315f, 
    -0.02260224f, -0.01297799f, -0.04204620f, -0.00023065f, 0.02417353f, -0.04026141f, -0.02673683f, -0.01812853f, 
    0.03724296f, -0.00414626f, -0.01692556f, -0.00716094f, 0.02423932f, -0.03385586f, -0.01128205f, 0.02013277f, 
    0.01357785f, 0.01935841f, -0.04050829f, 0.02524326f, -0.03252703f, -0.01354844f, -0.03060504f, -0.01699324f, 
    -0.02656417f, 0.01145313f, -0.03198696f, 0.00446595f, -0.00708141f, 0.02933597f, 0.02050502f, -0.02900951f, 
    -0.00882890f, 0.02180844f, 0.00105541f, 0.02427421f, 0.02610140f, -0.00876758f, -0.01126037f, 0.00274304f, 
    -0.02851038f, 0.02103658f, -0.03419365f, -0.02709299f, 0.02216354f, 0.01777004f, -0.02227288f, -0.00699659f, 
    0.00225388f, -0.03573843f, -0.03387649f, 0.02809156f, 0.00297724f, 0.00464724f, -0.02429524f, -0.00592680f, 
    -0.00778280f, 0.01274058f, 0.01873265f, 0.01327257f, 0.00123819f, 0.01599015f, -0.02749326f, -0.01230655f, 
    0.01680713f, -0.01587358f, -0.01529612f, -0.01984670f, -0.02056491f, -0.02584354f, -0.02864409f, 0.01526399f, 
    -0.02247313f, -0.02314849f, -0.02397508f, -0.03875379f, -0.03472511f, 0.01431899f, 0.01409081f, -0.02785668f, 
    -0.00274341f, 0.03844068f, 0.02192221f, -0.00561719f, -0.01018714f, 0.01030888f, 0.01753856f, 0.01278115f, 
    -0.01584262f, -0.00413323f, 0.00886724f, 0.02708696f, 0.00803953f, -0.01812370f, -0.00113462f, -0.03249146f, 
    0.01310148f, -0.00208866f, -0.00573701f, -0.02694632f, 0.02770559f, 0.01763183f, 0.02792511f, 0.00295268f, 
    -0.01218109f, 0.01469485f, 0.01507747f, -0.03779447f, -0.01426525f, -0.02383466f, -0.03014460f, 0.00418350f, 
    0.01223171f, 0.02206410f, 0.02069812f, 0.01933917f, -0.00314983f, 0.03076768f, 0.00216867f, 0.00992055f, 
    -0.02506713f, 0.02417228f, 0.00487641f, -0.03173510f, 0.01896278f, 0.00820981f, 0.00269417f, 0.01734550f, 
    -0.01731422f, 0.02386484f, 0.00602491f, 0.00762121f, -0.01238467f, 0.02336186f, -0.00321544f, 0.02191755f, 
    -0.02684580f, -0.03511965f, -0.02695603f, -0.00941307f, 0.02359755f, -0.02116447f, 0.00011241f, 0.00343150f, 
    0.00040207f, -0.02547071f, 0.00117259f, -0.00638517f, -0.03167483f, 0.02918264f, 0.02058720f, -0.02863348f, 
    0.03595799f, -0.00544255f, 0.02139023f, -0.02335402f, 0.01381962f, -0.00656673f, -0.02056304f, -0.03053429f, 
    -0.00411518f, -0.04262529f, 0.01097735f, 0.02907310f, -0.02723710f, -0.00963436f, -0.02123240f, -0.00505284f, 
    0.01943174f, -0.04361806f, -0.01918471f, -0.02373263f, 0.01787738f, 0.02199619f, -0.01663603f, 0.00259495f, 
    0.00188088f, 0.00453326f, 0.03960601f, 0.01400483f, 0.02333367f, 0.00044020f, -0.01411750f, -0.00244622f, 
    0.02077367f, -0.01142192f, 0.00789684f, 0.02443301f, 0.00994598f, 0.00938586f, -0.01232557f, 0.03203473f, 
    -0.03426234f, 0.03043222f, -0.01556577f, 0.01382578f, -0.01856974f, -0.00245706f, -0.01919353f, -0.03307679f, 
    -0.00218450f, -0.00541676f, -0.02690606f, -0.04469400f, -0.02835364f, -0.01946776f, 0.02450650f, -0.03096247f, 
    -0.01753988f, 0.01987640f, -0.00154844f, 0.00588784f, -0.01865560f, -0.03187406f, 0.01972478f, -0.03317885f, 
    0.00184770f, -0.01562902f, 0.00543058f, -0.02570016f, 0.02820444f, 0.00386928f, -0.03366686f, 0.00696023f, 
    0.02757072f, 0.00997943f, -0.02246386f, -0.03512916f, 0.01396855f, 0.02206018f, 0.02441744f, -0.01810700f, 
    -0.03540188f, -0.03732051f, -0.03844072f, 0.00120778f, 0.01066740f, -0.04769770f, 0.02875534f, -0.02197850f, 
    -0.01725090f, -0.03074564f, -0.01858589f, 0.01512518f, 0.00859645f, -0.02541287f, 0.01153196f, -0.03645600f, 
    -0.00234774f, 0.03214874f, -0.04372736f, 0.02178732f, 0.01467822f, 0.00034249f, -0.01728547f, 0.00634480f, 
    0.01075577f, 0.03250002f, -0.03256861f, -0.01185991f, -0.01406386f, 0.00560357f, 0.02918064f, -0.02009951f, 
    0.01091550f, 0.03164365f, 0.01750335f, -0.01299712f, -0.03059572f, -0.01554819f, -0.01458447f, 0.00106429f, 
    0.01442391f, -0.01444558f, -0.00436560f, 0.02535718f, -0.03090048f, -0.00208840f, -0.02629929f, -0.02830228f, 
    -0.02717039f, -0.03353090f, -0.00228332f, -0.01803402f, 0.00437954f, 0.00064274f, 0.00454876f, 0.00092978f, 
    0.02933852f, -0.01266820f, -0.00572497f, -0.02889405f, -0.03876734f, -0.02882144f, -0.03480764f, 0.00191989f, 
    -0.03110683f, 0.01699859f, -0.00182293f, -0.03631452f, -0.02011219f, -0.00106618f, 0.01889312f, 0.00564044f, 
    -0.01680172f, 0.03204507f, -0.03506306f, -0.03131850f, -0.03518516f, 0.01983288f, 0.02381950f, -0.01722209f, 
    0.01906405f, 0.00089297f, 0.02593122f, -0.00413069f, -0.01199397f, 0.01109186f, 0.00185587f, -0.01220239f, 
    0.00041649f, 0.00477488f, -0.02021230f, 0.01931253f, -0.02808316f, -0.01572158f, -0.01426462f, -0.02580967f, 
    -0.01415827f, -0.02412497f, 0.00225423f, 0.00007824f, 0.00212570f, 0.00675071f, -0.03587058f, 0.03236679f, 
    0.01195472f, 0.03235499f, 0.02304978f, -0.03098893f, -0.01846176f, -0.02610794f, 0.02343524f, -0.02861080f, 
    -0.00429150f, -0.01194522f, 0.02827535f, 0.01342461f, -0.01736838f, -0.00223443f, 0.00086696f, -0.02979136f, 
    -0.03488128f, -0.01685150f, 0.00660497f, 0.00427918f, -0.00873145f, -0.03381941f, -0.01737637f, 0.00294262f, 
    -0.03226192f, 0.00948935f, 0.01920924f, -0.03369079f, -0.01423821f, 0.01845215f, 0.00544618f, 0.02965923f, 
    0.00331970f, 0.02664481f, -0.01677335f, 0.01055177f, -0.01960679f, -0.02999717f, -0.02751209f, -0.03877259f, 
    0.00089658f, 0.02304060f, 0.00020807f, -0.00520523f, -0.01970953f, 0.02381512f, 0.00789560f, 0.03508185f, 
    -0.01876198f, 0.02344744f, 0.02536602f, -0.02056494f, 0.01698215f, 0.01684047f, -0.01411318f, -0.01345247f, 
    -0.02833236f, 0.03077722f, 0.02052945f, -0.00850431f, -0.02314704f, -0.02496489f, -0.03813452f, -0.03359583f, 
    -0.03478066f, -0.00483724f, -0.01409598f, -0.01920097f, 0.01599078f, -0.00889178f, -0.01572696f, 0.01753321f, 
    -0.01858547f, -0.02611370f, 0.02538639f, 0.01233121f, -0.02126659f, 0.02843492f, 0.01174025f, -0.04242182f, 
    -0.00024253f, -0.02801657f, -0.01192436f, -0.00417652f, 0.01746087f, 0.01532451f, 0.00837941f, -0.02298845f, 
    -0.02611589f, -0.02215972f, 0.02350722f, -0.00658391f, -0.01993775f, 0.00937848f, 0.01068804f, -0.03869444f, 
    -0.00998526f, -0.00218788f, -0.01505186f, -0.01006228f, -0.01636366f, 0.02610814f, 0.02280840f, 0.01664934f, 
    -0.00289299f, -0.00959993f, -0.01053047f, -0.03522030f, -0.01036726f, 0.00710299f, 0.02325165f, 0.01711705f, 
    0.02517957f, -0.02722867f, -0.01474514f, -0.01140947f, -0.00333041f, 0.00858176f, 0.01258275f, 0.01720034f, 
    -0.03381384f, 0.03199156f, 0.00756647f, -0.00011362f, -0.02514487f, -0.01290529f, -0.01491024f, 0.03368298f, 
    0.02893581f, 0.02825346f, 0.01344663f, -0.02431341f, -0.00079362f, 0.02353765f, -0.01340436f, 0.01711342f, 
    -0.00182585f, 0.00301145f, -0.02712520f, 0.01339332f, -0.01862488f, -0.01334905f, -0.03363806f, 0.01789666f, 
    0.01900104f, -0.03610827f, -0.01362345f, 0.00333067f, 0.02636967f, 0.02388747f, -0.03202740f, 0.01275234f, 
    -0.00572590f, 0.00982603f, 0.03127500f, 0.01972957f, -0.01325491f, -0.03678801f, 0.00282596f, -0.03166097f, 
    0.02738136f, -0.01011309f, -0.04157659f, 0.01315464f, 0.00888125f, -0.01782525f, -0.02633130f, 0.00742591f, 
    -0.02193420f, -0.00937334f, -0.02515348f, 0.00761256f, 0.00309101f, 0.00034029f, -0.01366356f, -0.01207980f, 
    0.00004801f, 0.01854007f, -0.00730149f, 0.02389031f, 0.01512460f, 0.02864661f, -0.02333914f, -0.03720798f, 
    -0.03309821f, -0.01268301f, 0.03716917f, 0.02878601f, 0.01979174f, 0.00946559f, 0.01852367f, 0.01249819f, 
    -0.01725555f, 0.00506923f, 0.01904589f, -0.00581879f, -0.00999056f, 0.00957456f, -0.01565001f, -0.00512751f, 
    -0.02849960f, -0.01553780f, 0.01476677f, -0.01308724f, 0.00033945f, 0.02023157f, -0.00149106f, -0.02026319f, 
    -0.02597673f, -0.01620609f, 0.01499225f, -0.01100118f, 0.03417991f, 0.02270251f, 0.00932026f, 0.02978669f, 
    0.03224392f, 0.01944141f, -0.01918279f, 0.01648048f, -0.00061677f, -0.01152712f, -0.03767979f, -0.01445243f, 
    -0.00096684f, 0.01136689f, 0.00201034f, -0.01686140f, 0.00060724f, -0.02279668f, -0.02606745f, -0.03026684f, 
    -0.03645473f, 0.02375193f, -0.03019558f, -0.03696093f, -0.02452337f, -0.03122876f, -0.02680516f, -0.02479871f, 
    -0.01912729f, 0.00940808f, 0.00488792f, 0.03187837f, -0.00051107f, -0.02899211f, -0.02507224f, -0.00585588f, 
    -0.02979248f, -0.02144431f, 0.03385306f, 0.03038193f, 0.01047880f, 0.00945851f, 0.01775386f, 0.03148004f, 
    -0.03340684f, -0.02913624f, 0.01271912f, 0.00930783f, -0.01831916f, 0.02065615f, -0.00924268f, -0.03385945f, 
    -0.01408040f, -0.03576074f, 0.00350434f, -0.01686182f, 0.03124976f, -0.01711613f, -0.00861130f, 0.01499187f, 
    -0.03654776f, 0.01287630f, -0.01822839f, -0.03168651f, -0.02733867f, -0.01225229f, 0.02150532f, -0.00652656f, 
    0.02847462f, 0.00736650f, 0.03130249f, -0.02383978f, 0.01105851f, 0.02259095f, -0.00218083f, -0.02437179f, 
    0.00813610f, 0.01954518f, -0.00430769f, -0.01849439f, 0.00970740f, -0.01722717f, -0.01823276f, 0.01268073f, 
    0.01534544f, -0.03249515f, -0.00919775f, -0.00777108f, -0.01332310f, 0.02093506f, 0.02997428f, 0.01184198f, 
    0.01661838f, -0.02370259f, -0.01523239f, -0.01053491f, 0.03277140f, -0.02356675f, -0.03370719f, -0.00186078f, 
    0.02538195f, 0.01280788f, -0.01224065f, 0.00276857f, -0.01817636f, 0.01588460f, 0.03265079f, -0.00414000f, 
    -0.01993029f, -0.01175375f, 0.01780909f, 0.01748198f, -0.03766734f, 0.02455009f, 0.01577933f, -0.00846241f, 
    -0.03834997f, 0.01565108f, -0.02825562f, 0.01160368f, 0.01376103f, 0.00757316f, -0.01778055f, 0.01188761f, 
    0.01053369f, -0.00015642f, 0.01390996f, -0.01902699f, -0.02358909f, -0.01741170f, -0.02871713f, -0.01183802f, 
    0.01377152f, -0.03684439f, -0.01548759f, -0.03970322f, 0.00081203f, 0.03473670f, 0.00234682f, 0.01350968f, 
    -0.02917909f, 0.01232555f, 0.01859516f, 0.01279072f, -0.02747115f, -0.01731725f, 0.01501747f, -0.02508590f, 
    -0.01654422f, 0.01927100f, -0.00494661f, 0.00991183f, -0.02875947f, -0.02596752f, 0.00805285f, -0.03622389f, 
    -0.02370341f, -0.01106841f, 0.03322346f, -0.02466051f, -0.01230680f, -0.00286953f, -0.02962780f, -0.02574209f, 
    -0.00611239f, -0.03240917f, -0.00539065f, 0.01487929f, 0.01098048f, 0.02279522f, -0.00910175f, 0.02687787f, 
    0.01992010f, -0.01320152f, -0.01041527f, -0.03340819f, -0.01130310f, -0.02367095f, 0.00648063f, -0.00900241f, 
    -0.00886108f, -0.00747558f, -0.01973521f, 0.01216577f, -0.01523305f, 0.02234548f, 0.01361588f, -0.02051207f, 
    0.00321974f, -0.02903417f, 0.00546850f, 0.01309799f, 0.02922559f, -0.00124562f, -0.00347336f, -0.02738171f, 
    -0.03184194f, 0.02697382f, -0.00895296f, 0.02497634f, -0.02082372f, -0.00034163f, -0.02595638f, 0.01967919f, 
    0.01437129f, 0.03150751f, 0.01138559f, 0.02684538f, -0.02128864f, -0.02364134f, -0.02005215f, -0.02338536f, 
    -0.01157301f, -0.00058120f, 0.02171669f, 0.02715370f, -0.00041175f, -0.03587761f, 0.02735427f, 0.02985945f, 
    -0.02479066f, -0.00388028f, -0.01263998f, 0.02662266f, 0.00275345f, 0.02948324f, -0.01457539f, -0.00519280f, 
    -0.01642721f, 0.01697109f, -0.01520836f, 0.01604182f, 0.00778775f, 0.00803375f, -0.00804879f, 0.01040907f, 
    -0.00507714f, 0.01824428f, -0.02203299f, 0.00057643f, -0.01351900f, -0.02745251f, -0.02083816f, 0.00699709f, 
    0.00206964f, -0.02420313f, 0.01739816f, 0.01846069f, -0.02975210f, -0.00845958f, 0.03112991f, -0.03468083f, 
    -0.03630456f, -0.02743825f, 0.00439487f, 0.02758659f, 0.00127808f, 0.01823775f, 0.03557498f, 0.01896879f, 
    -0.03381988f, 0.02961568f, -0.03236428f, -0.01936485f, 0.03056820f, -0.02079271f, -0.03583529f, -0.02996241f, 
    0.01412443f, 0.00792800f, 0.02550302f, -0.01244276f, 0.02628067f, -0.03142094f, -0.00331833f, 0.01946054f, 
    -0.02055135f, -0.00564713f, 0.00653550f, 0.00575300f, -0.00176334f, 0.02493076f, -0.00583895f, -0.03629826f, 
    -0.02933978f, -0.02066032f, 0.02072995f, -0.01028334f, 0.00277348f, -0.02177574f, -0.03026200f, -0.02201314f, 
    0.01901623f, 0.00480001f, 0.01928151f, -0.03146778f, -0.02076492f, 0.00134483f, 0.03467204f, -0.00247423f, 
    -0.03249976f, 0.03388995f, -0.01241382f, -0.00003983f, 0.00677727f, 0.00721213f, 0.01547468f, -0.00973473f, 
    -0.03140628f, 0.03091142f, -0.00020995f, 0.03368263f, 0.02868456f, -0.00910679f, -0.02986355f, -0.03664456f, 
    -0.00067625f, -0.01717362f, -0.02284774f, 0.02292881f, 0.02635002f, 0.03040642f, 0.03113077f, -0.00388906f, 
    0.03699939f, -0.02927471f, -0.03270343f, -0.01787453f, 0.02213723f, 0.02950822f, -0.00772558f, -0.03670156f, 
    0.02703273f, -0.01519546f, 0.02784361f, 0.01373905f, 0.00887704f, 0.00677599f, -0.03280427f, -0.01478181f, 
    0.00358003f, -0.02041863f, -0.03218120f, -0.01911498f, -0.00759605f, -0.01973053f, -0.01529566f, -0.00211859f, 
    0.02572718f, 0.03346262f, 0.00339065f, -0.01815864f, 0.01366526f, 0.00524457f, 0.00217271f, -0.00624544f, 
    0.01709726f, -0.02431411f, 0.00154029f, 0.02481706f, -0.00182536f, 0.02197491f, -0.01497477f, -0.02646449f, 
    0.00803465f, 0.02941464f, 0.02437222f, -0.00447792f, -0.03559354f, 0.03519552f, 0.01830399f, -0.00548051f, 
    -0.02141204f, -0.01542871f, -0.01225863f, -0.00653156f, -0.03472342f, 0.00216749f, -0.00940932f, -0.03070371f, 
    0.00972481f, 0.00533414f, 0.00624825f, 0.03621083f, 0.01999745f, 0.01354736f, -0.00120674f, -0.03915538f, 
    -0.02588704f, -0.01677321f, 0.01276037f, 0.02892535f, -0.03340919f, 0.03093433f, 0.02585323f, 0.00964061f, 
    -0.00657723f, -0.02949408f, -0.00179322f, 0.01115927f, -0.01979064f, -0.03491205f, -0.01537463f, -0.02400312f, 
    -0.02291352f, 0.03247442f, 0.01888029f, 0.01686976f, -0.02311109f, 0.00444942f, 0.01224953f, -0.01591466f, 
    -0.02074202f, -0.02054439f, 0.03261860f, 0.01524313f, -0.02100963f, -0.00456608f, -0.00334322f, -0.03248266f, 
    -0.01007529f, -0.01840353f, 0.01945243f, -0.02175214f, 0.02607120f, -0.02124084f, -0.01725785f, 0.02968743f, 
    -0.02809138f, 0.01680362f, -0.01058254f, -0.01770594f, 0.01348633f, 0.01617285f, -0.01105543f, 0.02477971f, 
    -0.00966718f, 0.01806595f, 0.02488639f, 0.00657967f, 0.01637292f, -0.00668254f, 0.00308494f, -0.03590016f, 
    -0.01869383f, 0.02896403f, -0.01898044f, -0.02542054f, 0.02422471f, -0.02433458f, -0.02557918f, -0.00241342f, 
    0.00605584f, 0.02491198f, -0.00671612f, -0.01661441f, -0.03836082f, -0.01437305f, -0.03430164f, 0.01815849f, 
    0.00341837f, -0.01032249f, 0.02489530f, -0.03294063f, -0.01357723f, -0.02996896f, -0.00832217f, 0.02589521f, 
    0.00218216f, -0.01578628f, 0.02700471f, 0.03148989f, 0.00373204f, 0.02090518f, 0.01962430f, 0.00245887f, 
    -0.02812748f, -0.02058040f, -0.02034657f, -0.03392345f, 0.02124349f, 0.00168308f, 0.00835244f, 0.01995152f, 
    0.02177349f, 0.02816593f, 0.01141944f, 0.00033593f, 0.01928904f, -0.01251044f, -0.02255052f, -0.00581393f, 
    -0.03036420f, 0.01832468f, -0.01353005f, -0.00241460f, -0.03774216f, -0.01994807f, 0.01670628f, -0.00794421f, 
    0.02235759f, 0.02468165f, 0.03251773f, -0.02379952f, 0.01919329f, 0.00600187f, -0.03086248f, 0.00215704f, 
    0.01723041f, -0.01447504f, -0.00040295f, -0.00027335f, -0.01952211f, 0.01697160f, 0.02320565f, 0.00527974f, 
    0.02612849f, -0.01608202f, -0.03238023f, -0.02823430f, 0.02262334f, 0.02096827f, -0.03695811f, 0.02626552f, 
    -0.02088661f, -0.00672336f, -0.02589898f, -0.01075603f, -0.03166652f, -0.02164443f, 0.00473302f, -0.01866795f, 
    0.03135174f, 0.01666564f, -0.02631140f, -0.01011125f, 0.00084662f, 0.01824396f, 0.02260459f, -0.01252690f, 
    -0.01913901f, -0.03784946f, -0.03474273f, 0.01762816f, -0.01016630f, -0.02241781f, -0.02615939f, -0.02354124f, 
    0.01084482f, -0.00950025f, 0.02162210f, 0.02110235f, 0.00134932f, -0.01303570f, 0.01465783f, 0.02472783f, 
    0.00066485f, -0.02774241f, -0.02159197f, -0.01749185f, -0.00075878f, -0.02465201f, -0.01090715f, 0.00357658f, 
    -0.01548573f, 0.01610126f, -0.03677495f, -0.01785629f, 0.01313350f, -0.01518007f, -0.00752556f, -0.02175636f, 
    -0.00323232f, -0.02181824f, -0.03083907f, -0.02448475f, -0.02147699f, 0.00671741f, 0.02838394f, -0.01795940f, 
    -0.01669679f, -0.03657032f, 0.01206805f, -0.00581180f, -0.02723057f, -0.00432973f, 0.01670779f, 0.00395795f, 
    -0.03698187f, -0.02740132f, 0.00222921f, 0.01035442f, -0.01182090f, -0.00229092f, -0.01217141f, -0.00106434f, 
    -0.02858742f, -0.01548239f, -0.01752202f, 0.01111133f, -0.03255784f, -0.02043248f, -0.03154591f, -0.00590825f, 
    0.00358544f, -0.01860435f, 0.01586592f, 0.01568885f, -0.00773102f, -0.00062376f, -0.03808785f, -0.03574172f, 
    -0.01657978f, -0.03620942f, -0.01306694f, -0.00015044f, -0.02222692f, 0.03210139f, -0.00612969f, 0.03203920f, 
    0.01908324f, -0.02353803f, -0.03597615f, 0.02442073f, 0.00766548f, 0.02032368f, -0.02962395f, -0.03235962f, 
    -0.02269810f, 0.00807881f, 0.02763356f, 0.02125137f, 0.02722690f, 0.02821912f, -0.02434784f, -0.00168985f, 
    -0.03232536f, -0.02100295f, 0.02547326f, -0.03020721f, 0.01945973f, 0.01524245f, -0.03689823f, -0.01005468f, 
    0.03242264f, -0.02761368f, -0.00966008f, -0.03668948f, 0.01481871f, -0.00656093f, 0.03142958f, -0.00606411f, 
    -0.00559684f, 0.00603575f, 0.02627823f, -0.02046611f, -0.00810290f, 0.02554199f, 0.01410729f, 0.03538128f, 
    -0.00256573f, 0.03492135f, 0.00929277f, -0.00730002f, 0.02390945f, 0.01465523f, 0.01896572f, -0.01017906f, 
    0.00313818f, 0.01417696f, -0.00259262f, -0.01041847f, 0.03331005f, 0.02470141f, 0.03397038f, 0.01572585f, 
    -0.03633902f, -0.00152541f, -0.02386208f, 0.03204783f, -0.01945902f, -0.01100652f, -0.01767706f, 0.00653593f, 
    0.00713879f, -0.02921112f, 0.02263245f, 0.01877651f, -0.01451692f, 0.01889340f, 0.00911187f, -0.00177756f, 
    -0.00779249f, 0.02218433f, -0.02338775f, 0.00561174f, -0.02562402f, 0.01455679f, 0.01563815f, -0.00677572f, 
    -0.03718092f, -0.00195176f, -0.03521772f, 0.03543574f, -0.02649607f, -0.00121625f, -0.02653644f, -0.01622766f, 
    0.03129395f, -0.00168445f, 0.00122085f, 0.02636487f, -0.02291058f, -0.00706067f, 0.00386091f, -0.00035876f, 
    -0.00518747f, -0.00607616f, -0.02943923f, 0.00036803f, -0.03355397f, -0.02088577f, -0.03022608f, 0.00395791f, 
    0.02953181f, -0.03182506f, -0.02618046f, -0.00637194f, 0.03489777f, 0.01669896f, -0.00854815f, 0.01350109f, 
    -0.01743148f, 0.00232726f, 0.01065477f, -0.02748135f, -0.00514943f, 0.03142434f, -0.04178985f, 0.00337633f, 
    -0.00770492f, -0.01318953f, -0.02343993f, -0.00835524f, 0.01224770f, 0.00194096f, -0.01877488f, 0.01678949f, 
    -0.00427360f, -0.00770245f, 0.01705709f, -0.01646441f, -0.03568932f, 0.00865581f, -0.03252884f, 0.02541074f, 
    0.00593618f, -0.01088311f, 0.00808781f, -0.02934511f, -0.02023558f, 0.01002270f, -0.03641343f, 0.02198196f, 
    -0.03799886f, -0.01586825f, -0.00999003f, 0.03308501f, -0.02241953f, 0.01738037f, -0.03594541f, -0.02181870f, 
    0.01678427f, 0.01828032f, 0.02145439f, -0.02559019f, -0.00822691f, -0.01659811f, 0.01665856f, -0.03064892f, 
    -0.04024482f, -0.03187435f, -0.00598733f, 0.02657844f, 0.01073175f, 0.02113201f, -0.01561064f, -0.03218788f, 
    0.02224009f, -0.01905342f, 0.00710495f, 0.01049217f, -0.02425978f, -0.00095257f, -0.01585013f, 0.00015955f, 
    -0.03278394f, 0.00188762f, -0.01275145f, -0.03926494f, 0.00331201f, -0.00274570f, -0.01131053f, -0.00722911f, 
    0.00722305f, -0.03127240f, -0.01208267f, 0.01939750f, -0.02585969f, -0.00327800f, -0.02757652f, -0.02646079f, 
    0.01355675f, 0.00816669f, -0.03013693f, -0.02428913f, -0.04122205f, 0.01806969f, 0.02949463f, 0.02040110f, 
    -0.00867008f, -0.00881659f, -0.04041641f, -0.00992642f, 0.00253911f, -0.02635281f, 0.01278109f, 0.01699501f, 
    -0.02631342f, -0.00442920f, 0.00953994f, -0.03133923f, -0.01721817f, 0.00377343f, -0.01184579f, -0.00552654f, 
    0.00011035f, -0.02768825f, -0.01746793f, 0.00667110f, 0.02429820f, 0.01981812f, -0.02711297f, 0.02531518f, 
    -0.00278597f, 0.00802766f, -0.03906045f, -0.02852588f, 0.01768198f, -0.00933040f, 0.01519185f, 0.00006213f, 
    0.00288254f, -0.00222027f, -0.00752491f, -0.00616175f, 0.02869211f, -0.01229744f, 0.01674727f, -0.03903363f, 
    -0.03122061f, 0.02691564f, 0.01274281f, -0.00246719f, -0.03518931f, 0.00489360f, -0.00411761f, -0.02938104f, 
    -0.01640519f, 0.02870893f, -0.04105310f, -0.00557280f, 0.01473336f, -0.02488996f, -0.03276921f, -0.01054934f, 
    -0.02695524f, -0.01979637f, 0.02186607f, 0.00366611f, 0.02054843f, -0.00118959f, -0.01627486f, 0.01627430f, 
    0.03291275f, -0.00505804f, -0.03378259f, 0.02077672f, -0.00824306f, -0.03683484f, 0.01181676f, 0.01028043f, 
    -0.01053738f, -0.02610600f, 0.01703905f, -0.02541644f, 0.01927459f, -0.01133945f, -0.00618951f, 0.02458904f, 
    0.02375958f, -0.03290093f, 0.01787044f, -0.02700832f, 0.02549724f, -0.00704268f, -0.00889492f, -0.02911695f, 
    0.00657703f, -0.00460406f, 0.00515987f, -0.02321305f, -0.03730897f, 0.01394491f, 0.01191783f, -0.01014464f, 
    -0.02988901f, 0.00462506f, -0.02036100f, 0.00972096f, 0.01645885f, -0.03703203f, 0.00693452f, 0.01387550f, 
    0.02218471f, 0.02172128f, -0.01530783f, -0.00163311f, 0.03250525f, 0.03471971f, 0.00355891f, -0.04097780f, 
    -0.01475471f, 0.01748213f, -0.03562916f, 0.02134290f, -0.01891423f, -0.02553521f, -0.00195517f, -0.01306048f, 
    -0.01051204f, -0.03027284f, 0.01579866f, -0.01525437f, -0.02412817f, -0.00343090f, 0.01528508f, 0.02339896f, 
    -0.00783416f, 0.00401107f, 0.03793675f, -0.02507871f, 0.00943874f, 0.01489201f, -0.00936893f, 0.02030028f, 
    -0.01144450f, 0.01901296f, 0.02647877f, -0.03665578f, 0.00461322f, -0.01777006f, 0.02394833f, 0.01803560f, 
    -0.00590970f, -0.00814191f, 0.00270166f, -0.02552442f, -0.02440108f, 0.00246976f, -0.00512567f, -0.03232925f, 
    -0.03453894f, -0.03670223f, -0.02254062f, 0.00287695f, -0.01105627f, 0.02838703f, 0.01671846f, -0.02412562f, 
    -0.01411248f, -0.00132385f, 0.00234192f, -0.00776622f, 0.01120182f, 0.02852036f, -0.02634949f, -0.01348678f, 
    -0.02118733f, -0.02600807f, 0.02545172f, -0.02593982f, -0.00606402f, -0.03132078f, 0.02184331f, -0.00079491f, 
    0.02593103f, -0.02911383f, 0.02215716f, -0.01046817f, -0.01622568f, 0.00417875f, 0.02001133f, -0.01078094f, 
    0.00230372f, 0.00936306f, 0.02039686f, 0.00695236f, 0.00631367f, 0.00968040f, 0.02247976f, -0.01698100f, 
    -0.02823727f, -0.00814968f, 0.01666950f, -0.00602499f, 0.01622674f, -0.01269945f, 0.02090312f, -0.02169379f, 
    -0.02064038f, 0.01768495f, -0.02457910f, 0.00947901f, -0.01196569f, 0.01590328f, 0.00404754f, -0.00745103f, 
    -0.02731834f, -0.03424903f, -0.03132156f, -0.00386808f, -0.04027014f, -0.03551855f, -0.02195984f, -0.03965888f, 
    -0.01002354f, 0.02052028f, -0.01993668f, -0.01605947f, 0.01944257f, -0.02989782f, -0.04152638f, -0.00548176f, 
    0.02267697f, 0.00652937f, 0.00501629f, 0.00037907f, -0.00845163f, -0.01653942f, -0.01975432f, 0.00595324f, 
    0.00302026f, 0.02961045f, -0.04510115f, 0.01746886f, 0.02683995f, -0.04095098f, -0.02650318f, 0.02161893f, 
    -0.01205189f, -0.02588725f, -0.01602627f, -0.02942328f, 0.01631437f, 0.00215893f, -0.02026178f, 0.01648483f, 
    -0.03344177f, 0.01602588f, 0.00925219f, 0.01220830f, 0.02451718f, 0.00898956f, 0.02322292f, 0.01558279f, 
    0.00577460f, -0.01434063f, -0.03708690f, 0.03210071f, -0.01507126f, -0.02075436f, 0.00087218f, -0.02446722f, 
    -0.00308491f, 0.01729129f, -0.00801400f, 0.00219537f, -0.04278989f, 0.01316891f, 0.02907527f, -0.02621126f, 
    -0.00523761f, -0.02703623f, -0.00483679f, -0.00490914f, -0.03482385f, 0.00387419f, 0.03052670f, -0.01231117f, 
    0.02906335f, -0.00330410f, -0.03583883f, -0.02262253f, -0.03339835f, 0.01693556f, -0.03181909f, -0.02079659f, 
    -0.02222181f, -0.02031603f, 0.01636154f, -0.01669475f, -0.02728631f, 0.00473687f, -0.02626138f, 0.00887893f, 
    0.01196272f, -0.00313777f, -0.01322655f, 0.02487093f, 0.00961880f, -0.03831236f, -0.01796352f, 0.01445623f, 
    0.01854161f, -0.01193497f, -0.02103619f, 0.00266816f, -0.03150537f, 0.01707136f, 0.00479131f, 0.01660220f, 
    -0.01016306f, -0.01605040f, -0.01330332f, -0.00752266f, -0.02998420f, 0.01232552f, -0.00217030f, 0.00753904f, 
    -0.00747742f, 0.01282190f, 0.00523876f, -0.02295583f, 0.01733033f, -0.04111972f, -0.03343720f, -0.03858469f, 
    0.01377137f, 0.01053945f, -0.01007376f, -0.02799820f, 0.00665046f, -0.04042076f, 0.01513730f, -0.00980260f, 
    0.01802434f, 0.02181636f, 0.02371461f, 0.00321749f, 0.00481110f, -0.02293365f, 0.02206402f, -0.02665532f, 
    -0.02075549f, -0.01827614f, 0.02139352f, -0.03548950f, 0.00955385f, -0.01446422f, -0.01190857f, 0.00471578f, 
    0.02722871f, -0.04011266f, -0.01966728f, 0.01290512f, -0.03703701f, 0.02695562f, 0.01225567f, -0.01481838f, 
    -0.00812367f, -0.02385765f, 0.02016905f, -0.01581408f, 0.00949899f, 0.01591321f, 0.00640428f, -0.02569145f, 
    0.01326418f, -0.03719257f, -0.02922505f, 0.02297798f, 0.01852920f, 0.02223031f, -0.03313569f, -0.01499399f, 
    -0.01599416f, 0.00478141f, -0.00965434f, -0.01015505f, 0.01525744f, 0.01824053f, -0.01862179f, 0.02094530f, 
    -0.02233608f, -0.03158794f, -0.03897537f, 0.02696547f, -0.01919070f, 0.00643739f, -0.04293088f, -0.02170626f, 
    0.01620702f, -0.01292460f, -0.00743635f, 0.00547315f, 0.01015814f, 0.00630323f, 0.01501599f, 0.02258493f, 
    0.00061797f, 0.02952170f, -0.03417682f, -0.01981154f, 0.00303672f, 0.01227850f, -0.01895630f, -0.01773044f, 
    -0.00839604f, -0.02081119f, -0.02932568f, 0.00743187f, -0.02838664f, -0.00025290f, -0.03323064f, -0.02524984f, 
    -0.03516175f, 0.00540848f, -0.02477755f, 0.02547642f, 0.00915718f, 0.03014654f, -0.01272934f, 0.03044795f, 
    -0.01291190f, -0.03190652f, -0.01742842f, -0.03921346f, -0.01439941f, -0.00779399f, 0.01678231f, 0.00790815f, 
    0.01595004f, 0.00796458f, -0.02027705f, 0.01833258f, 0.01229160f, 0.02420521f, -0.02330435f, -0.00675860f, 
    0.01609963f, 0.03350172f, 0.01541146f, 0.00223497f, -0.02007543f, 0.00028449f, 0.01393177f, -0.00448881f, 
    -0.02810357f, -0.02159615f, -0.02079691f, -0.03388550f, -0.01289139f, -0.02839703f, -0.00029704f, 0.02917785f, 
    0.01632407f, -0.01708932f, -0.00031928f, -0.00575605f, -0.03386029f, -0.02071560f, -0.00792376f, -0.03441864f, 
    0.01147020f, -0.01158593f, -0.00817508f, 0.02040436f, -0.03637845f, -0.02187473f, 0.00764832f, -0.00748778f, 
    -0.00876271f, -0.01312765f, -0.00156299f, -0.00801052f, 0.02690005f, 0.00938105f, -0.00293594f, -0.02971440f, 
    0.01724841f, 0.01572318f, 0.01403569f, -0.01430886f, 0.01537260f, -0.03511297f, -0.00359604f, 0.01181203f, 
    0.02081253f, 0.01819552f, -0.00117117f, -0.01066203f, 0.02681420f, -0.01214627f, -0.01666781f, -0.01120977f, 
    -0.00532246f, -0.00518947f, -0.00136799f, -0.00204183f, 0.02041152f, 0.01996204f, -0.04227810f, -0.02490920f, 
    0.00358405f, -0.03926960f, -0.02779884f, -0.02002173f, 0.02002746f, -0.01268946f, -0.00442414f, -0.01535686f, 
    0.01918877f, -0.02256215f, -0.00554694f, -0.00818567f, -0.03244886f, 0.01331553f, 0.00306661f, 0.03176587f, 
    0.00284647f, -0.02971872f, -0.02770020f, 0.01946922f, 0.01057260f, -0.02456560f, 0.01465040f, -0.03337689f, 
    0.00213563f, -0.01030852f, -0.03891732f, 0.00298168f, -0.01134541f, 0.02748686f, -0.02996439f, -0.01402277f, 
    -0.00403575f, -0.03652524f, 0.00239022f, -0.03504819f, -0.00313102f, 0.00998841f, 0.02639901f, -0.03206313f, 
    0.01935702f, 0.03114478f, -0.03471757f, 0.02437380f, -0.03122308f, -0.00624810f, -0.02000885f, -0.03161860f, 
    0.00665518f, 0.00541073f, -0.01587306f, 0.01402695f, 0.02835473f, -0.03105873f, -0.01790197f, -0.01598578f, 
    -0.00240336f, -0.00035361f, -0.02830249f, 0.01599630f, 0.00253508f, -0.00062959f, 0.02328173f, -0.01413885f, 
    -0.02309769f, -0.01209053f, -0.03902287f, 0.01010777f, 0.00838418f, 0.03214045f, 0.00832861f, 0.02268599f, 
    0.01014525f, -0.00976040f, 0.00984634f, -0.04239113f, 0.02599519f, 0.00968972f, 0.02535699f, -0.01644222f, 
    0.00691157f, -0.02747121f, -0.03318877f, 0.02341712f, 0.00756246f, 0.01341191f, -0.03018567f, -0.03221698f, 
    -0.00167022f, -0.02350320f, 0.00421775f, -0.00642852f, 0.00681090f, 0.00920572f, -0.03071609f, 0.02385762f, 
    0.02200555f, 0.02243786f, 0.02107784f, -0.04019350f, 0.02978011f, 0.00873167f, -0.02561953f, -0.01720769f, 
    -0.01734383f, -0.02460351f, 0.03173326f, -0.01745580f, -0.03786226f, -0.00790545f, -0.02987472f, 0.01243777f, 
    -0.00835445f, 0.00154302f, -0.03025151f, -0.01807755f, 0.00362124f, 0.00507819f, -0.02104047f, -0.01380077f, 
    -0.03021642f, -0.04099595f, -0.04111749f, 0.02958345f, -0.00286564f, 0.01902669f, 0.02186432f, 0.00639083f, 
    -0.02698990f, -0.00675507f, 0.02125236f, -0.00560493f, -0.00653510f, 0.01716292f, 0.00585443f, -0.02671298f, 
    0.00544440f, -0.00226548f, -0.00127827f, 0.02628827f, -0.01555149f, 0.00718853f, -0.02670519f, -0.04230709f, 
    -0.00152682f, 0.01178581f, 0.00434772f, -0.01019357f, 0.02555463f, -0.00450771f, -0.01530689f, 0.00474991f, 
    -0.03693031f, -0.00046160f, -0.01448808f, 0.01654106f, 0.01913205f, 0.00885702f, 0.00049311f, -0.00749420f, 
    0.00237611f, -0.01238968f, -0.01653138f, -0.02424235f, 0.02033699f, 0.00034841f, -0.03344636f, 0.01056988f, 
    -0.03697830f, -0.03242173f, 0.01120048f, 0.01891915f, 0.01310451f, -0.03511592f, -0.04179570f, 0.01719859f, 
    0.09008440f, 0.08514131f, 0.06823286f, -0.08330770f, 0.03387614f, 0.11398352f, 0.04880729f, 0.00417867f, 
    -0.09795829f, -0.11052557f, 0.09489267f, 0.00176081f, 0.35985368f, -0.18290913f, 0.03508745f, -0.03748601f, 
    -0.10304445f, -0.01288213f, 0.04287793f, 0.03831355f, 0.00042047f, -0.05438520f, 0.06408950f, 0.03440729f, 
    0.12141378f, 0.06108126f, 0.02219061f, 0.00525095f, -0.05512852f, 0.02031286f, -0.03429415f, -0.07872333f, 
    -0.03944374f, 0.04586780f, 0.08268647f, 0.05848466f, 0.12207012f, -0.00186877f, -0.10736702f, -0.04930275f, 
    0.12487368f, -0.06644718f, 0.02734151f, 0.05971345f, 0.00689225f, 0.00967842f, -0.08152271f, -0.03614163f, 
    -0.15700844f, 0.05784174f, -0.10824284f, 0.00531055f, -0.00228725f, -0.06743022f, 0.00821973f, 0.07826870f, 
    -0.01902264f, -0.00140041f, -0.01954742f, 0.01803742f, 0.10076903f, -0.19988407f, -0.10587583f, 0.02774534f, 
    -0.02301808f, 0.03370363f, 0.02746887f, -0.03712182f, 0.00130623f, -0.04573876f, -0.01925221f, 0.02321501f, 
    0.30123425f, 0.01112687f, -0.06311437f, 0.01528595f, -0.11565734f, -0.04652908f, 0.02076006f, -0.02245414f, 
    -0.02631725f, -0.05864853f, -0.03359976f, 0.02398068f, 0.06318172f, -0.05741333f, 0.09744799f, -0.25273433f, 
    0.02702426f, 0.02571204f, -0.04221738f, 0.04968005f, -0.10751546f, -0.09879977f, 0.02417305f, 0.08177974f, 
    0.14759858f, 0.00453955f, -0.14694592f, -0.08364339f, 0.04131123f, -0.00316641f, 0.00213298f, 0.02656057f, 
    -0.03978911f, 0.12837966f, 0.05250193f, 0.09956693f, 0.19296512f, 0.06422540f, -0.02599879f, -0.08000553f, 
    0.01708484f, 0.06144102f, 0.00486973f, 0.01478857f, -0.01100040f, 0.01735502f, -0.09793370f, -0.14781947f, 
    -0.09662778f, -0.07931858f, -0.04700232f, -0.12667203f, 0.02131771f, -0.16430393f, 0.12263302f, 0.01866422f, 
    -0.08163000f, 0.05537114f, 0.01363415f, 0.07045286f, -0.13737349f, 0.00316064f, -0.15162839f, 0.14679576f, 
    -0.07914571f, -0.01743776f, 0.04082734f, 0.05525502f, 0.01078169f, -0.04613990f, -0.05775437f, -0.05219011f, 
    0.17397073f, -0.04649748f, 0.00864603f, 0.10739711f, -0.01420314f, -0.01181635f, 0.03801748f, 0.01973531f, 
    0.11528300f, -0.07408141f, -0.03823263f, -0.02543814f, 0.23402666f, -0.03928875f, 0.19919056f, -0.03391469f, 
    -0.10024478f, -0.06768382f, -0.00802736f, -0.03152814f, -0.05855891f, 0.04377711f, -0.07982788f, 0.03993262f, 
    -0.10112741f, -0.08226591f, 0.10514773f, -0.29468647f, 0.03021771f, 0.15943211f, -0.12564407f, 0.00441094f, 
    0.09061036f, -0.03243153f, -0.03222357f, 0.11697941f, 0.08194224f, 0.06465732f, -0.14667790f, 0.04154654f, 
    -0.04278250f, 0.16924639f, 0.04949474f, -0.04120674f, 0.07296705f, -0.06862754f, -0.03311146f, -0.12657799f, 
    0.34707865f, 0.18141015f, -0.05584088f, -0.02393319f, 0.03051991f, 0.10718149f, 0.03369822f, -0.06013740f, 
    0.02006837f, -0.06151752f, 0.04488110f, 0.09568844f, 0.21204945f, 0.09755773f, 0.04694103f, -0.11811996f, 
    -0.00903743f, 0.03501840f, -0.00900965f, -0.00267278f, 0.00198608f, 0.05724740f, -0.01559752f, 0.00026142f, 
    -0.38678578f, 0.01556116f, -0.01374138f, 0.28900290f, -0.01887267f, 0.02271300f, 0.02960468f, 0.03833251f, 
    0.04506492f, -0.12748314f, 0.09642414f, 0.06614676f, 0.06200008f, 0.04859746f, -0.03653323f, 0.04290836f, 
    -0.01075677f, 0.03498167f, 0.03286021f, 0.13421738f, 0.00078506f, 0.03477595f, -0.03385815f, 0.09376036f, 
    0.15628780f, -0.30153513f, 0.05204730f, -0.10041919f, 0.03898263f, -0.17988768f, 0.00268387f, -0.01427737f, 
    0.08229502f, 0.02077522f, 0.00315311f, 0.01615004f, -0.06811684f, 0.09432843f, -0.25838122f, -0.01732173f, 
    0.10102542f, 0.06661672f, 0.03151803f, -0.05379082f, -0.05302225f, -0.02944285f, 0.02909838f, -0.06650738f, 
    0.10398921f, 0.10623845f, 0.03028260f, -0.17253524f, -0.11220859f, -0.03390190f, 0.06066213f, -0.01717202f, 
    -0.05971023f, 0.05078390f, 0.06830780f, -0.04168347f, 0.21746027f, -0.04162044f, -0.04080939f, 0.00068966f, 
    0.04085021f, 0.01561244f, -0.02828808f, 0.01358812f, -0.08660883f, -0.10229193f, 0.00986575f, -0.05691525f, 
    0.01496289f, -0.04317823f, 0.05151296f, 0.06077457f, 0.11975839f, 0.01193305f, 0.02470405f, -0.05655810f, 
    0.05135198f, -0.09707926f, 0.04268010f, -0.03887705f, -0.02266637f, 0.03190598f, 0.09406257f, -0.03814677f, 
    -0.13425539f, 0.10975882f, 0.07077571f, -0.02993126f, -0.02215626f, 0.00858571f, 0.09548157f, 0.14421691f, 
    -0.21456970f, 0.06262749f, -0.02720024f, -0.07104080f, 0.02197402f, 0.02927982f, 0.09153777f, 0.05041143f, 
    -0.02602297f, 0.09934212f, 0.03201723f, -0.03710895f, 0.10683554f, -0.07999270f, 0.06873057f, 0.15163583f, 
    -0.07042171f, 0.08226541f, 0.00697461f, -0.02281647f, 0.06407057f, 0.18158433f, -0.07623895f, -0.06257805f, 
    0.18611063f, -0.05269637f, -0.06118463f, -0.11367617f, -0.06023740f, -0.17707437f, 0.04172038f, 0.09151918f, 
    -0.01789580f, 0.02937863f, -0.09397117f, 0.03355912f, 0.16313230f, 0.14516404f, -0.11999904f, -0.08292846f, 
    0.03795820f, 0.01559489f, -0.04576727f, -0.02345107f, -0.01816067f, -0.02377728f, 0.11621162f, -0.04230348f, 
    0.18811624f, 0.14615901f, -0.04692646f, -0.07976431f, 0.06574279f, -0.18780734f, 0.15287067f, -0.05875346f, 
    -0.06320150f, -0.03943285f, 0.03304757f, -0.07754796f, 0.20291461f, 0.13498224f, -0.05596695f, 0.05577992f, 
    0.11157053f, -0.03550135f, -0.02651602f, -0.10460071f, 0.07249332f, -0.02475140f, -0.10840946f, -0.05628230f, 
    0.02844739f, -0.01610964f, -0.01127672f, -0.11693862f, 0.11206462f, 0.06867614f, 0.01482069f, 0.03792024f, 
    0.05013927f, 0.00298094f, -0.00273857f, 0.09589706f, 0.13486537f, -0.04714519f, 0.08680215f, -0.15105630f, 
    -0.00537067f, -0.00414517f, 0.05837111f, -0.04540049f, 0.06677045f, 0.05026628f, -0.05018143f, 0.20837313f, 
    0.39148605f, -0.09771761f, 0.10034478f, -0.08404376f, -0.12149164f, 0.08743765f, -0.16142659f, 0.00382724f, 
    0.03098508f, 0.07222316f, 0.07340357f, 0.02065850f, 0.11976101f, -0.02516408f, -0.07900605f, -0.07652070f, 
    -0.07453018f, 0.16844887f, -0.03580729f, 0.05576685f, 0.14626256f, 0.04138062f, -0.05889788f, -0.12915558f, 
    -0.28144133f, -0.01766398f, 0.31820759f, -0.13374023f, 0.11525701f, -0.10616734f, 0.15035912f, -0.08974750f, 
    -0.00060724f, 0.11616150f, -0.01416594f, 0.00780552f, 0.00974495f, 0.22055981f, 0.12371561f, 0.00442205f, 
    0.00825733f, -0.08211868f, 0.08257392f, -0.00138334f, -0.08572951f, 0.00633677f, 0.00565159f, 0.06203913f, 
    0.03740996f, 0.28229216f, -0.10144494f, -0.05663902f, -0.00458760f, 0.03444586f, 0.03514078f, 0.04943053f, 
    0.01062670f, 0.00136974f, -0.04333627f, 0.07839762f, 0.43830529f, 0.03683114f, 0.01030425f, -0.05738780f, 
    -0.02255741f, -0.06783236f, 0.02523055f, 0.15343355f, 0.16553806f, 0.00841541f, -0.03333728f, 0.04673085f, 
    0.07827970f, -0.24891345f, 0.14346249f, -0.19969521f, -0.06672122f, -0.05239562f, 0.00662940f, 0.04098377f, 
    -0.13211428f, 0.01183195f, -0.03899939f, -0.09028682f, -0.12014508f, -0.09927826f, 0.12251668f, -0.39586082f, 
    0.02957619f, -0.00066523f, 0.08240163f, -0.10504027f, -0.05359550f, 0.11687629f, 0.17500818f, 0.09635365f, 
    0.20816892f, -0.02924533f, 0.10733745f, 0.12734886f, -0.05878657f, -0.03756231f, -0.02720770f, -0.01928573f, 
    -0.03645319f, -0.01122915f, 0.00027724f, -0.10365353f, 0.06154640f, -0.01204655f, 0.06194570f, -0.00565525f, 
    -0.05234832f, 0.05650349f, 0.07036667f, -0.02478850f, -0.07192838f, -0.04806712f, 0.05603240f, 0.01182366f, 
    0.22773699f, 0.03143270f, 0.01722548f, 0.14574879f, 0.02999889f, -0.06033932f, -0.06022513f, 0.01397773f, 
    -0.04271781f, 0.09840907f, 0.04238003f, 0.10131446f, 0.21265775f, 0.05479065f, 0.11996465f, 0.06428148f, 
    -0.08514462f, 0.06996007f, -0.00731892f, -0.05013730f, -0.03478819f, 0.02867232f, 0.08905289f, -0.10146266f, 
    -0.17206891f, 0.10471617f, -0.01820385f, 0.00173987f, -0.05986866f, -0.00251896f, 0.06669222f, 0.06066259f, 
    -0.01232998f, -0.06213189f, -0.02112418f, 0.00228618f, 0.32997641f, -0.06953897f, -0.06196122f, -0.07809301f, 
    0.05355957f, 0.09173387f, -0.01559723f, -0.00965858f, -0.06265862f, 0.03623526f, 0.10027190f, 0.00458522f, 
    0.06135763f, 0.20891781f, 0.04199151f, 0.08718024f, -0.03201622f, 0.02796666f, -0.05943096f, -0.05688656f, 
    0.01533710f, 0.06915808f, -0.01354890f, 0.00441668f, 0.22687405f, -0.00497019f, -0.08625502f, -0.01504880f, 
    -0.08202201f, -0.05928027f, 0.07163208f, 0.00567003f, -0.06381702f, -0.01350496f, -0.03598316f, 0.03433361f, 
    0.03233977f, -0.01412145f, 0.22822526f, 0.12517887f, -0.10708068f, 0.04321616f, -0.02365368f, 0.00436484f, 
    0.00202074f, 0.03184014f, 0.08491116f, 0.00657575f, 0.28028643f, 0.04280112f, 0.05970172f, 0.17617574f, 
    0.00074121f, -0.01655863f, 0.02015466f, 0.04866703f, -0.04326718f, 0.01368049f, 0.03848257f, -0.05905323f, 
    -0.03312621f, -0.11543015f, 0.13248171f, -0.10142282f, 0.02268733f, 0.04463241f, 0.06872196f, 0.04368992f, 
    0.05113988f, -0.10100647f, -0.10972854f, -0.07338798f, -0.26390123f, 0.09643087f, -0.17139818f, -0.06097588f, 
    0.12005235f, -0.01529083f, 0.13260446f, 0.04908432f, -0.15573731f, 0.06484409f, -0.06485951f, -0.11149755f, 
    0.21374588f, -0.01581357f, -0.01036505f, 0.07534407f, -0.05803037f, -0.01638759f, 0.00359829f, 0.02518416f, 
    -0.08175620f, 0.04492036f, 0.00015239f, 0.10520416f, 0.08032090f, 0.15072818f, -0.11418194f, -0.05437193f, 
    0.03719189f, 0.03730294f, 0.01483035f, 0.00763004f, 0.05210955f, 0.04584586f, -0.01525467f, 0.02523932f, 
    -0.19209406f, 0.24228737f, -0.07994886f, 0.15440550f, -0.05112398f, -0.06385785f, 0.03331431f, 0.02666517f, 
    -0.07523802f, -0.06231823f, 0.00265775f, -0.10400198f, 0.23547202f, 0.04220590f, 0.04736735f, -0.13050428f, 
    0.06289817f, 0.05989927f, -0.00420408f, -0.08702150f, 0.07334720f, -0.02405505f, -0.05488120f, 0.06100833f, 
    0.10560325f, -0.03532754f, 0.27536929f, 0.11732329f, 0.01665967f, 0.06675670f, -0.02542970f, -0.02329694f, 
    -0.04902337f, 0.02450363f, -0.00629559f, 0.07980627f, -0.24983342f, 0.14675209f, -0.02339350f, 0.16379899f, 
    -0.15024260f, -0.03091634f, 0.03753804f, 0.03265388f, -0.03683942f, 0.01558752f, -0.02169860f, 0.08279821f, 
    -0.04032028f, 0.14120851f, 0.13838862f, 0.02038899f, 0.02400002f, -0.02892143f, 0.03682770f, -0.01268449f, 
    -0.06268636f, 0.00349056f, -0.02257274f, 0.06981502f, -0.24268943f, 0.12287617f, -0.06280656f, -0.09571380f, 
    0.13148563f, 0.00344134f, 0.05620970f, -0.07368139f, 0.07728429f, 0.02546613f, 0.10038909f, 0.02770147f, 
    -0.12480091f, -0.15168288f, -0.02784511f, -0.09400211f, 0.00985175f, 0.14452754f, -0.01171545f, 0.04054132f, 
    -0.02726269f, 0.15939245f, -0.06355900f, 0.07187756f, 0.02227354f, -0.09761525f, 0.06209876f, -0.06063323f, 
    0.06639957f, 0.07872037f, -0.01141316f, -0.01339218f, 0.03363796f, 0.06443147f, -0.00704983f, -0.10947316f, 
    0.03170352f, 0.01286226f, -0.04747583f, 0.10743527f, 0.05112605f, 0.02597352f, -0.05254734f, 0.06847201f, 
    0.02126822f, -0.03086150f, 0.11736421f, 0.05923028f, -0.14379342f, 0.25302434f, 0.01361630f, 0.10746934f, 
    -0.07388557f, 0.02837418f, 0.03265179f, 0.07550687f, 0.05983489f, 0.02005062f, 0.02959368f, 0.06526572f, 
    0.07472195f, 0.10739601f, 0.17343839f, -0.05053544f, 0.03649289f, -0.00331787f, -0.00546035f, 0.00879022f, 
    -0.02830415f, -0.05627546f, 0.00114469f, 0.07363341f, 0.05797246f, -0.07000878f, 0.00799598f, 0.21346807f, 
    0.02339579f, 0.04447799f, 0.00360654f, -0.00656721f, -0.09781074f, -0.03443619f, 0.02808549f, -0.04536738f, 
    -0.22196305f, 0.05683821f, 0.20265581f, -0.03239906f, 0.01987671f, -0.00452056f, 0.12850405f, -0.05482592f, 
    0.05847321f, -0.00891137f, -0.05647016f, 0.10091373f, 0.21560916f, 0.05594639f, -0.17513502f, -0.15517969f, 
    0.04355052f, -0.07731506f, -0.02198585f, -0.09976715f, -0.04824289f, 0.04887650f, 0.09548315f, 0.06871407f, 
    -0.05586975f, 0.07914161f, 0.03508950f, 0.11110931f, -0.01735750f, 0.11092210f, 0.07457768f, -0.04522198f, 
    -0.02523977f, -0.00616187f, 0.00449723f, -0.03528622f, -0.03608671f, 0.09648820f, -0.11235210f, 0.20412959f, 
    -0.08575355f, 0.02966275f, -0.07200774f, 0.06690922f, 0.08570605f, 0.00073101f, 0.10644592f, -0.07256604f, 
    0.19206768f, -0.11324205f, 0.02011378f, -0.12457787f, 0.04365965f, -0.03093382f, 0.04728825f, -0.00581273f, 
    0.07398805f, 0.07602076f, 0.05694481f, 0.05691525f, 0.15126792f, -0.06512728f, -0.05671598f, -0.04617692f, 
    0.03231987f, 0.02214782f, 0.07551815f, 0.03857988f, -0.03509332f, 0.00342640f, 0.07400060f, 0.07110956f, 
    -0.17163020f, 0.14514527f, -0.04414810f, 0.19097412f, -0.01672458f, 0.07558312f, 0.07025782f, -0.15349720f, 
    0.13982637f, 0.03088214f, 0.08115023f, -0.00393734f, 0.24557790f, -0.20226291f, 0.12441269f, -0.18106404f, 
    0.05061167f, 0.05123017f, 0.03732902f, 0.12556823f, 0.06098200f, 0.07289036f, 0.07225385f, 0.00550639f, 
    -0.11880668f, -0.13382505f, 0.01488761f, -0.16916069f, 0.01957988f, -0.02669207f, 0.05856187f, -0.03204228f, 
    0.01914625f, -0.11109482f, -0.02598270f, 0.09599046f, 0.02588423f, 0.09520277f, 0.00056231f, -0.15539649f, 
    0.03949438f, 0.00281502f, 0.02223219f, -0.02986364f, 0.01482118f, 0.02902102f, 0.03587220f, -0.09412133f, 
    -0.03971294f, 0.01223612f, -0.08534981f, 0.01272844f, 0.01407971f, 0.05067248f, 0.02147390f, -0.04365718f, 
    0.03396326f, -0.00898535f, 0.19446208f, 0.02435327f, 0.04543160f, -0.05270001f, -0.09496363f, -0.14659218f, 
    0.08124647f, -0.06184985f, -0.09027468f, 0.05201370f, -0.15643242f, -0.01492444f, 0.09594761f, -0.08437815f, 
    0.03355089f, 0.01986510f, 0.10118392f, -0.10105959f, 0.01929344f, -0.05526507f, -0.00417128f, -0.00643915f, 
    -0.00564645f, 0.06033489f, -0.05536469f, 0.08355770f, -0.23070012f, -0.15578306f, -0.04527922f, 0.23109886f, 
    -0.04148886f, 0.01261371f, 0.10653237f, -0.02799405f, 0.02230332f, -0.04125260f, 0.01419004f, 0.00176444f, 
    -0.07356025f, 0.00569716f, 0.08937848f, -0.05085571f, 0.16188663f, -0.01890030f, -0.04170416f, -0.03868824f, 
    0.08544226f, 0.07222427f, -0.07552042f, 0.00478289f, -0.12888560f, -0.06683223f, 0.03113151f, 0.11792230f, 
    0.03149798f, 0.07469635f, 0.05636138f, -0.04743183f, -0.06482122f, 0.03535992f, 0.04989447f, 0.07090481f, 
    -0.29100531f, 0.20048249f, 0.02202277f, 0.16653676f, -0.07661777f, 0.05787733f, 0.05796667f, 0.06830239f, 
    0.14158796f, -0.05353865f, 0.08795512f, -0.07116992f, 0.11107423f, -0.13860710f, 0.17642854f, -0.00383915f, 
    0.04363020f, -0.03665457f, -0.00825829f, 0.14077698f, 0.08732001f, 0.05613856f, 0.00596968f, 0.01743864f, 
    -0.15819626f, -0.09315098f, -0.01707275f, 0.20460878f, 0.14171663f, 0.12650025f, 0.07484619f, 0.03562663f, 
    0.10139686f, 0.03594555f, 0.11442260f, -0.00728304f, -0.17531501f, 0.10815665f, 0.09408000f, -0.07132556f, 
    -0.00242440f, 0.10098866f, 0.00160099f, 0.09645795f, 0.07568707f, 0.01093691f, 0.04569292f, 0.01112504f, 
    -0.25971931f, 0.02358251f, 0.13017641f, 0.05697196f, 0.04744769f, 0.07539266f, -0.04143238f, -0.02119356f, 
    -0.01468181f, -0.04744322f, 0.15040782f, 0.06573308f, -0.11639516f, 0.00039440f, 0.03497504f, -0.11990801f, 
    0.05556411f, 0.08244289f, -0.10316277f, 0.04987102f, -0.02551581f, 0.05775269f, 0.02672010f, 0.10638434f, 
    -0.05428912f, -0.11336640f, 0.02733614f, 0.00371517f, 0.08483969f, 0.08728825f, -0.01176651f, -0.01503395f, 
    -0.02805771f, 0.06439411f, 0.03346468f, 0.05301833f, -0.02704729f, 0.12695172f, 0.00669103f, -0.06057800f, 
    0.06016848f, 0.01239384f, -0.01438894f, 0.10246277f, 0.16246007f, -0.00718621f, 0.01905856f, 0.07677797f, 
    -0.14652607f, 0.03552786f, -0.06607267f, 0.21520662f, 0.03532591f, 0.15090984f, 0.02437001f, -0.03019208f, 
    0.15115114f, -0.00337797f, -0.07619713f, 0.09074145f, 0.18233979f, -0.05481174f, -0.11894191f, 0.07428282f, 
    0.05055123f, 0.07379221f, -0.01553665f, 0.02198379f, -0.05585181f, 0.14395688f, -0.01788532f, -0.07898843f, 
    -0.05277451f, 0.01046700f, -0.05136230f, 0.26274663f, 0.03063872f, 0.05476516f, 0.10317242f, 0.00759347f, 
    0.11992355f, -0.08960117f, 0.10277991f, 0.09393473f, 0.09010614f, -0.07109603f, 0.07806031f, 0.08760624f, 
    -0.08232510f, 0.07056978f, -0.02085944f, -0.00447723f, -0.07529835f, 0.00508480f, 0.06070923f, 0.08384191f, 
    -0.04968692f, -0.05551467f, 0.05897005f, 0.17712091f, 0.00281151f, 0.02042593f, 0.01343907f, 0.03032394f, 
    -0.04675404f, 0.04668935f, 0.05508804f, -0.03018302f, -0.12798233f, -0.04992785f, 0.07032479f, 0.17893656f, 
    0.07228056f, 0.02117990f, -0.02253467f, -0.03853732f, -0.02441664f, 0.00297635f, 0.02738015f, 0.00049835f, 
    -0.14537424f, 0.01129845f, -0.14141773f, -0.06227349f, 0.12588005f, -0.09839911f, 0.08248881f, 0.03496263f, 
    0.01672686f, -0.06706780f, -0.12745343f, 0.07570586f, 0.05921289f, 0.00410885f, 0.03473718f, -0.01607176f, 
    0.02508754f, 0.04057457f, 0.04975586f, -0.06293494f, 0.03429773f, -0.04940791f, 0.02755312f, -0.01137951f, 
    -0.16770528f, 0.01426423f, -0.14092092f, 0.12725443f, 0.03602871f, -0.07850517f, -0.06869388f, 0.03946682f, 
    -0.08211713f, 0.02087068f, 0.07469379f, 0.00039272f, -0.20967010f, 0.01814822f, 0.11846092f, -0.03939437f, 
    0.00656685f, 0.00442492f, -0.03655915f, -0.07905427f, 0.02495557f, 0.10085204f, 0.07556561f, 0.02083447f, 
    -0.13883008f, -0.10090451f, 0.09634119f, 0.11847456f, 0.08527933f, 0.05144779f, -0.03030973f, 0.00700424f, 
    -0.01378723f, 0.04583401f, 0.04255893f, 0.01173614f, -0.18428405f, 0.01488102f, -0.11863093f, -0.06727152f, 
    -0.05626598f, 0.05552864f, 0.03524458f, 0.07176553f, -0.07862182f, -0.01613808f, -0.00747939f, -0.05152778f, 
    -0.17477717f, 0.17173910f, -0.16192265f, -0.02280479f, 0.22057644f, 0.05525159f, 0.08074378f, 0.25226545f, 
    0.16788922f, 0.01275043f, -0.10189378f, 0.05931457f, 0.07583641f, 0.06111289f, -0.18937507f, 0.12093327f, 
    0.13312000f, 0.00502754f, -0.06659174f, 0.10185114f, 0.09831609f, 0.00161328f, -0.01177425f, 0.02554203f, 
    0.14847958f, -0.03688279f, 0.06385477f, -0.11445417f, -0.00395101f, -0.07230461f, 0.02031446f, 0.06098466f, 
    0.02510092f, 0.01062205f, 0.01776079f, 0.01153963f, -0.02441150f, 0.03312090f, 0.15625980f, -0.10861091f, 
    0.08326629f, 0.16152500f, -0.05149195f, -0.13384674f, 0.12783055f, -0.05545849f, 0.01989362f, 0.11763688f, 
    -0.01987843f, -0.04177328f, 0.05887917f, -0.08876577f, 0.04133745f, -0.00582490f, 0.03413296f, 0.13140894f, 
    0.14845015f, 0.06656326f, 0.05202921f, -0.06117750f, 0.15305698f, -0.03764639f, 0.09287331f, -0.12277506f, 
    0.10398347f, 0.01167066f, -0.02604725f, -0.00400442f, 0.04125334f, -0.00083981f, 0.01097387f, -0.04487952f, 
    -0.05595714f, -0.08457946f, -0.08016625f, 0.08841618f, 0.14287336f, 0.00864793f, 0.01381940f, 0.00524432f, 
    0.05904675f, 0.03200369f, 0.14772810f, 0.05824665f, 0.23017183f, -0.03513495f, -0.02360588f, -0.00846780f, 
    0.06922657f, 0.07611427f, 0.00899002f, 0.00499637f, 0.06518184f, -0.02196106f, 0.08255982f, 0.04591927f, 
    -0.00675396f, 0.01326400f, 0.02192122f, 0.00412371f, 0.14656496f, -0.00862921f, -0.01776755f, 0.04325224f, 
    -0.01499011f, 0.08306772f, 0.05174391f, 0.01931012f, 0.12383863f, 0.07017690f, -0.03498194f, 0.11673351f, 
    0.00573902f, 0.05357261f, -0.02357343f, 0.00395228f, 0.05151322f, 0.01352531f, 0.03847473f, -0.05511405f, 
    -0.25447327f, 0.16232033f, 0.04900438f, -0.15947114f, 0.21653658f, 0.02297347f, 0.03134323f, -0.05105045f, 
    0.06669229f, -0.00796238f, -0.08799066f, 0.04857948f, -0.16290291f, -0.00935408f, 0.09343035f, -0.13153467f, 
    -0.00285340f, -0.09773303f, -0.03420497f, 0.11487431f, 0.06426404f, 0.06865463f, 0.02861948f, -0.05715730f, 
    -0.13903116f, 0.02331775f, -0.01064472f, 0.12420816f, 0.07606283f, 0.08772457f, 0.00085488f, -0.03432083f, 
    0.10863789f, 0.10476268f, 0.00163693f, -0.04356000f, -0.11632474f, -0.08631525f, 0.05377884f, 0.01389554f, 
    0.06492626f, 0.01727501f, 0.02956416f, 0.01356784f, 0.09003505f, 0.08015087f, -0.06041704f, -0.05692696f, 
    -0.15360351f, 0.04969110f, 0.20734443f, -0.05397542f, 0.08116604f, 0.10162836f, -0.04720433f, 0.06907512f, 
    0.14513801f, 0.02038439f, 0.03892682f, 0.09035894f, 0.03006754f, -0.01124059f, -0.00420792f, 0.07647380f, 
    -0.03230687f, 0.01239497f, 0.01947069f, -0.05968549f, 0.00225630f, -0.00713842f, 0.10429131f, 0.10734303f, 
    -0.22997776f, -0.09258294f, 0.21072309f, -0.00986004f, 0.17373332f, 0.11054664f, -0.05171418f, 0.04436965f, 
    0.01668894f, 0.00507595f, -0.00492832f, -0.03486548f, -0.22687492f, -0.17730081f, 0.00345643f, 0.05465439f, 
    0.00376039f, -0.03113001f, 0.09440338f, 0.09179845f, -0.01069964f, 0.00075929f, -0.04231150f, -0.03678279f, 
    -0.15617688f, 0.12755387f, 0.00271293f, -0.14736331f, 0.08989180f, 0.05011587f, 0.07772075f, -0.06504069f, 
    0.01388493f, 0.05584897f, 0.09039692f, 0.02387723f, 0.07169742f, -0.01168802f, 0.05007198f, -0.20771012f, 
    0.04553479f, -0.00705319f, -0.05372836f, 0.09647565f, 0.02544501f, 0.09332176f, -0.04148106f, 0.00760477f, 
    -0.01639633f, -0.09622956f, 0.00738985f, 0.24083991f, -0.00482259f, 0.06145436f, 0.06546590f, 0.00095566f, 
    0.13378569f, 0.04129733f, 0.02312383f, 0.08697231f, 0.14008947f, -0.03737739f, 0.04601332f, 0.03324519f, 
    0.05296401f, 0.00089476f, 0.00301660f, 0.04676298f, 0.02948993f, 0.05087608f, -0.06611598f, 0.06016066f, 
    -0.09404857f, 0.05163317f, 0.01483630f, 0.05609584f, -0.01292336f, 0.08154774f, -0.05709268f, 0.02407008f, 
    0.07869154f, -0.05143379f, 0.03406200f, 0.01605426f, 0.04524752f, 0.11327070f, 0.05264024f, 0.17344642f, 
    -0.02965518f, 0.05250131f, -0.05375990f, 0.08192029f, 0.06887635f, 0.00880424f, 0.09626661f, -0.02404974f, 
    0.00187077f, -0.03725309f, 0.04706216f, -0.07744280f, -0.02345818f, -0.09924375f, 0.11218692f, -0.03183455f, 
    0.06234593f, 0.06620812f, -0.10444388f, 0.08522404f, -0.18076824f, 0.14445135f, 0.13954850f, -0.03011971f, 
    0.04974763f, -0.05032999f, 0.09205947f, -0.12612756f, -0.03687917f, -0.01229448f, 0.03469171f, 0.02614040f, 
    -0.15935600f, -0.07167866f, -0.06719096f, 0.00852316f, 0.08014821f, 0.05084965f, 0.00278039f, -0.08662627f, 
    0.09743518f, 0.04541291f, -0.09809317f, -0.04963035f, -0.09908757f, 0.18773639f, -0.06170702f, 0.02499057f, 
    -0.06205120f, 0.00681233f, 0.05820044f, 0.04061356f, -0.00755872f, -0.03750850f, 0.15484133f, 0.15522403f, 
    0.03556886f, 0.03041017f, -0.05704308f, 0.02280552f, -0.00857046f, -0.00318122f, -0.00613199f, -0.00568653f, 
    0.02187358f, -0.00111162f, 0.08464906f, -0.03355082f, 0.05505894f, 0.04149388f, 0.05131914f, 0.18112372f, 
    -0.05729384f, -0.03247617f, 0.06185266f, -0.00464248f, -0.04109903f, -0.07035673f, -0.09361535f, -0.12206545f, 
    -0.11269446f, -0.01924372f, -0.01913920f, 0.04299837f, 0.04786691f, 0.03253645f, -0.08597115f, 0.00341243f, 
    -0.05370917f, 0.02349505f, 0.04585975f, -0.01741300f, -0.08897708f, -0.03623398f, -0.04455617f, 0.16090795f, 
    -0.04865426f, -0.09674476f, 0.16398750f, -0.07977881f, -0.05750770f, 0.14218926f, -0.16272575f, 0.08974349f, 
    -0.01350943f, 0.09890899f, 0.11275609f, 0.00055081f, 0.06281311f, 0.07320088f, 0.00477237f, -0.05192476f, 
    -0.03191951f, -0.09994318f, -0.05501734f, -0.15153678f, -0.09673853f, 0.04449261f, 0.02719614f, 0.00422213f, 
    0.09025870f, -0.08996769f, 0.03480858f, -0.05248651f, 0.07737155f, 0.06450692f, 0.00064202f, -0.01997650f, 
    -0.13369432f, 0.08525261f, -0.12631761f, -0.03299122f, -0.04012633f, 0.05698621f, -0.04719648f, 0.01440099f, 
    0.00886570f, 0.01758336f, 0.03786938f, -0.00304227f, 0.15541314f, -0.00321186f, 0.18955179f, -0.02654126f, 
    0.12455235f, 0.11272729f, 0.09815901f, -0.09831201f, -0.01958274f, 0.02744735f, 0.04489445f, -0.00169239f, 
    0.06163177f, 0.14413281f, -0.01098741f, 0.02443796f, 0.06665461f, -0.02674254f, 0.04875990f, 0.10598493f, 
    -0.07056974f, 0.17109179f, 0.25706327f, -0.04358956f, -0.03053956f, 0.03047240f, -0.10734525f, 0.06923904f, 
    0.05700327f, 0.13748589f, 0.10265999f, 0.08925486f, 0.00960593f, -0.03651252f, 0.13744441f, 0.09126718f, 
    0.03058742f, -0.12034941f, -0.12203067f, 0.15722914f, -0.13211578f, -0.06429018f, -0.00641454f, 0.01961722f, 
    -0.04603768f, 0.04444748f, -0.06667383f, -0.01357070f, -0.02598775f, 0.00099093f, 0.07564829f, -0.00603324f, 
    0.01545540f, 0.01279042f, 0.06049853f, -0.01889374f, 0.09620854f, 0.10303143f, -0.08708854f, 0.04844973f, 
    0.03170565f, -0.06413554f, -0.03346691f, 0.16067286f, 0.00990131f, 0.07361181f, -0.04294099f, -0.01291091f, 
    -0.02753537f, -0.02905513f, 0.05080993f, -0.11567209f, 0.32291692f, 0.06272940f, 0.07755168f, 0.05631871f, 
    0.01161210f, -0.05661330f, -0.02712021f, 0.14139341f, -0.05311085f, -0.01623150f, -0.05227377f, 0.09449814f, 
    -0.00296767f, -0.19530953f, 0.01710159f, -0.07652873f, -0.07271951f, 0.05492620f, -0.02551536f, 0.02498055f, 
    -0.15063792f, 0.00345740f, -0.07383905f, -0.00807587f, 0.00400777f, 0.06779912f, 0.07477540f, -0.02571676f, 
    -0.03613294f, -0.03322039f, 0.04205490f, 0.07399736f, -0.13616741f, 0.03812559f, 0.05896224f, -0.06175264f, 
    -0.11153264f, 0.24962641f, 0.04557006f, -0.09737290f, -0.03301243f, 0.10903249f, 0.08182435f, 0.05214548f, 
    -0.10802126f, 0.03829974f, 0.00442016f, 0.00664191f, 0.16686845f, 0.06752649f, 0.13529111f, 0.06974910f, 
    -0.03507302f, 0.02673947f, 0.02781467f, -0.04860010f, -0.01894377f, 0.02495718f, -0.00169405f, 0.07232201f, 
    -0.01700327f, -0.09220678f, 0.04828430f, -0.05236810f, -0.05218276f, 0.07610083f, -0.03855561f, 0.00804277f, 
    -0.04459723f, 0.01341795f, -0.05264037f, -0.00127756f, -0.09347229f, 0.05734224f, -0.03964897f, 0.05337149f, 
    -0.03063298f, -0.03870995f, 0.13691726f, -0.01426826f, -0.00414390f, 0.24657880f, -0.07216708f, 0.17191613f, 
    0.17406043f, -0.13907039f, -0.05629155f, -0.00812079f, -0.18409050f, -0.03058278f, -0.05596599f, 0.02300701f, 
    -0.06697989f, 0.18421376f, -0.03901172f, -0.00706097f, 0.07661376f, 0.02801553f, 0.02927523f, 0.01962878f, 
    0.03082950f, -0.09924830f, 0.05392428f, 0.02262833f, 0.12845637f, -0.09787671f, -0.12786111f, -0.13531138f, 
    0.29447675f, 0.08692460f, -0.04158786f, -0.07260442f, -0.06966255f, -0.07508106f, -0.05793048f, -0.06342722f, 
    -0.00831048f, -0.10361360f, -0.05186546f, -0.08486768f, -0.06286267f, -0.11688976f, 0.05769987f, -0.06947627f, 
    0.07444292f, -0.06538061f, -0.01453842f, -0.05071287f, -0.02524253f, -0.16168503f, 0.06529061f, -0.10014113f, 
    -0.20928268f, 0.11517170f, 0.12731957f, 0.10168815f, -0.00405939f, 0.05058238f, 0.10195327f, -0.05779151f, 
    0.01792196f, -0.02612351f, 0.16185306f, -0.02066826f, 0.02214062f, -0.03269520f, 0.10457611f, -0.06538970f, 
    0.01527814f, 0.02505324f, -0.16050932f, -0.09029417f, 0.02973936f, -0.10082702f, -0.11196127f, 0.12748507f, 
    -0.20528130f, -0.04604210f, 0.07344102f, 0.02940364f, -0.06099408f, 0.08963769f, 0.05564665f, 0.03503245f, 
    -0.00538162f, 0.03459540f, 0.04862100f, -0.00534113f, 0.07993397f, 0.03327432f, 0.06195363f, 0.05390181f, 
    -0.09007123f, 0.02452874f, 0.19017336f, 0.12972812f, -0.06763643f, 0.02969164f, 0.01205968f, 0.07940643f, 
    0.01976253f, 0.01631786f, 0.00617465f, -0.00073294f, -0.05222078f, -0.16890021f, 0.01717129f, -0.04382919f, 
    -0.10425334f, -0.04074373f, 0.09564804f, -0.02880913f, -0.08540029f, 0.22709228f, -0.09030320f, 0.07215537f, 
    -0.00481546f, -0.00653159f, 0.02610254f, -0.00433754f, 0.01173829f, 0.00943517f, 0.06871463f, -0.16617621f, 
    0.20902795f, 0.15773442f, 0.00929330f, 0.08554612f, 0.03185663f, 0.01588607f, 0.00419458f, 0.02167932f, 
    0.05170268f, -0.05330991f, 0.08362106f, -0.00788402f, -0.23276100f, -0.01016666f, 0.07859292f, -0.12255272f, 
    0.08684534f, -0.10982347f, 0.03283699f, -0.07132928f, 0.03686690f, 0.06665064f, 0.05153803f, 0.22319081f, 
    0.32967940f, 0.02090232f, -0.11951724f, 0.13331255f, -0.01065211f, 0.16332062f, -0.04664558f, -0.05360212f, 
    -0.03890686f, -0.13561325f, 0.03425300f, -0.06759161f, 0.02559338f, 0.05568551f, -0.01148605f, 0.03804733f, 
    -0.01120616f, 0.08215476f, -0.03123519f, 0.02059631f, 0.00369548f, -0.00445392f, -0.01030476f, -0.09078171f, 
    0.09897939f, 0.07422403f, 0.13477507f, -0.09118641f, 0.03518154f, -0.05431153f, 0.06065505f, -0.02390168f, 
    -0.04150338f, 0.00077233f, -0.07517841f, -0.14195994f, -0.11903857f, -0.04411849f, 0.25576550f, -0.05132392f, 
    -0.01963724f, 0.06604269f, 0.04998394f, 0.00323317f, -0.00381155f, 0.06682072f, 0.14072460f, 0.04364679f, 
    0.03772608f, -0.05656440f, 0.05565792f, 0.04644364f, -0.02558373f, -0.03540245f, 0.00893323f, -0.02428965f, 
    0.05281284f, 0.00710405f, 0.03779384f, 0.08490027f, -0.10835693f, -0.19344406f, 0.00213111f, 0.07802138f, 
    0.07506258f, 0.00200514f, -0.01053571f, 0.03847377f, 0.04293078f, -0.15593755f, -0.13562380f, -0.06559949f, 
    -0.07633791f, -0.07313137f, 0.02756608f, -0.02980335f, -0.09554434f, 0.03494457f, 0.05059181f, 0.02678028f, 
    0.07252181f, -0.03298981f, -0.02326417f, 0.13351427f, 0.04764679f, 0.04131732f, -0.11006944f, 0.09757829f, 
    -0.00512043f, -0.00910379f, 0.03555245f, 0.01671492f, 0.01715428f, 0.12235628f, 0.03294308f, -0.08419513f, 
    0.01475996f, 0.01010591f, 0.05622441f, 0.04547906f, 0.01280956f, 0.03291897f, 0.15513314f, -0.06593610f, 
    -0.01963628f, 0.00044651f, -0.02098639f, -0.06229522f, -0.06699925f, -0.06228488f, 0.00792496f, -0.01607285f, 
    -0.00785170f, -0.03220627f, 0.08024857f, 0.07013363f, 0.00300730f, -0.07245773f, -0.12673554f, 0.14480385f, 
    0.08765703f, -0.02447319f, 0.05102702f, 0.05222897f, 0.01249362f, 0.02502101f, -0.03121005f, -0.04244337f, 
    0.02280775f, 0.06372827f, -0.13307963f, -0.07902364f, -0.21827954f, 0.03557232f, 0.00564436f, 0.05745673f, 
    0.04598982f, -0.10133418f, 0.04615939f, 0.03861809f, 0.09781835f, 0.01452582f, -0.12810469f, -0.03129127f, 
    0.04805769f, 0.06499781f, -0.02675797f, -0.00506628f, 0.05600466f, -0.00671120f, 0.05424571f, 0.05682872f, 
    0.07269322f, -0.07348445f, -0.03565458f, 0.00251197f, 0.07259940f, 0.13359122f, 0.05332422f, 0.09925590f, 
    0.03515905f, 0.07272626f, 0.02713648f, 0.08250514f, -0.00745535f, 0.04587138f, 0.08798093f, 0.04645440f, 
    0.15936235f, 0.07392699f, -0.12197248f, 0.02940403f, -0.07946289f, -0.04563941f, 0.00934872f, 0.03042384f, 
    0.01738011f, -0.06149955f, 0.01803449f, -0.08433092f, 0.05000911f, 0.02678598f, -0.03570583f, -0.12999530f, 
    -0.01570936f, 0.15352231f, -0.05304418f, -0.14009883f, -0.02196106f, 0.07992166f, 0.05549373f, 0.10341883f, 
    0.02434670f, 0.01462871f, -0.06553713f, -0.01455521f, -0.00794839f, -0.07688917f, 0.05177303f, 0.02984379f, 
    -0.10517199f, 0.18078516f, 0.11036436f, 0.24905592f, 0.24822785f, -0.00058448f, -0.00337291f, -0.02876763f, 
    -0.02488126f, 0.07638606f, -0.05764887f, -0.13230641f, 0.09081016f, -0.02850175f, 0.12517689f, 0.08136636f, 
    -0.03001206f, 0.06119951f, -0.01214143f, 0.06440389f, 0.04469911f, 0.04103565f, 0.00808045f, -0.02604993f, 
    0.07662273f, -0.00777948f, -0.02956799f, -0.10991981f, -0.00026795f, -0.04981956f, 0.03778259f, 0.03247100f, 
    0.06425496f, -0.00446924f, -0.07858405f, 0.02241965f, -0.04765688f, -0.00833467f, -0.04220662f, -0.14951521f, 
    0.04726190f, -0.02007648f, -0.02162452f, -0.04952588f, -0.12327622f, -0.04821924f, 0.00461223f, 0.04078000f, 
    0.01179579f, 0.18878654f, -0.12741131f, 0.05196815f, 0.02616150f, 0.06130954f, 0.14940290f, 0.01898804f, 
    -0.01522092f, 0.04244284f, 0.05795998f, 0.11445890f, -0.16283089f, 0.06518088f, 0.11823286f, 0.05822751f, 
    0.08681227f, -0.01674577f, -0.13158056f, 0.01496876f, -0.03787366f, -0.06990817f, 0.00345216f, 0.13641541f, 
    0.04209833f, -0.02907710f, 0.01770756f, -0.11761928f, 0.02139581f, -0.02966599f, 0.03117062f, -0.09391341f, 
    -0.00592677f, 0.07283218f, 0.00478194f, -0.04910139f, -0.06925913f, -0.05862535f, 0.10885983f, -0.00420295f, 
    -0.02944546f, 0.02305531f, -0.05377948f, 0.01736177f, 0.01461053f, -0.03537400f, 0.06130612f, 0.02933779f, 
    -0.11170816f, -0.01111938f, 0.01729776f, -0.10726719f, 0.05418601f, -0.08595816f, -0.01434889f, -0.13125519f, 
    -0.06062661f, 0.16452706f, 0.04984334f, 0.11927164f, -0.01172163f, -0.15574433f, 0.09551687f, 0.01412288f, 
    0.10796954f, 0.01628491f, -0.04423457f, 0.06133822f, 0.05094236f, -0.10999817f, -0.01881981f, -0.03070085f, 
    -0.01294879f, -0.09278327f, 0.10856608f, 0.03837720f, 0.09882394f, -0.04293048f, -0.00561632f, -0.08428509f, 
    0.03434395f, -0.10965328f, 0.11187480f, -0.07837833f, 0.05886028f, -0.04116981f, -0.03518496f, 0.20920776f, 
    0.00468915f, 0.16129614f, -0.02613252f, -0.00865566f, 0.03711993f, 0.01340765f, -0.03360592f, 0.12834454f, 
    0.05305820f, 0.03915329f, 0.03362220f, 0.08311500f, 0.00177011f, 0.04206182f, 0.01085239f, -0.14116065f, 
    0.04365864f, -0.04002354f, 0.01317393f, 0.00231292f, 0.02700456f, 0.07225649f, 0.09385844f, 0.04303489f, 
    0.10480598f, -0.01118563f, -0.01386412f, -0.07208930f, 0.10114586f, 0.09023392f, -0.04268568f, 0.01882904f, 
    0.13856615f, 0.04977054f, 0.06216739f, 0.04206884f, -0.20512132f, -0.01396802f, 0.00601862f, -0.14610925f, 
    -0.06804491f, -0.12920636f, 0.03245686f, 0.02578325f, 0.08660513f, 0.07106029f, 0.01362555f, 0.01673910f, 
    0.11713754f, -0.06677569f, -0.02011039f, 0.02485337f, 0.00862818f, 0.03994408f, 0.02139572f, 0.06921849f, 
    0.16454969f, 0.02710596f, -0.05747773f, -0.10405733f, -0.15234429f, 0.12215775f, 0.08988006f, 0.09749717f, 
    -0.15425265f, 0.08544441f, -0.01109118f, 0.05284777f, 0.07003267f, 0.01456121f, -0.05450397f, -0.03832398f, 
    -0.03772042f, 0.00468842f, -0.14502780f, 0.14511679f, 0.11369393f, 0.04738737f, -0.11463395f, 0.06096451f, 
    -0.02247290f, 0.02286340f, 0.02907896f, 0.10439431f, 0.00218761f, 0.02891173f, -0.25259703f, -0.07511549f, 
    -0.01932368f, 0.04792927f, 0.03621735f, -0.02515157f, -0.01992264f, -0.06996256f, 0.04433701f, -0.04742202f, 
    -0.08887278f, -0.00118903f, 0.04792979f, -0.09649847f, 0.07612997f, -0.05922192f, 0.05802443f, 0.03542445f, 
    -0.01950063f, 0.11548971f, 0.11531149f, 0.14037701f, -0.09601603f, 0.01717876f, 0.22506131f, -0.17021863f, 
    0.06673039f, -0.06217878f, 0.05173703f, -0.10005440f, 0.04548909f, 0.02673513f, 0.05576688f, -0.03345859f, 
    0.03885193f, -0.16901813f, -0.19407231f, -0.06545781f, 0.12567925f, 0.04047780f, -0.10066750f, 0.03682188f, 
    0.09173459f, -0.03242338f, 0.00930044f, -0.00415089f, -0.11487732f, 0.01569562f, 0.02757538f, 0.00466000f, 
    0.14206584f, 0.06249268f, 0.03231569f, -0.04187810f, 0.00223836f, 0.04429549f, -0.03564971f, 0.04770799f, 
    0.03212936f, -0.05104547f, -0.06073442f, 0.18425232f, 0.06389794f, 0.00186749f, 0.13114436f, 0.07312803f, 
    0.10344411f, 0.03242945f, -0.03358631f, 0.00577217f, -0.08794551f, -0.12367646f, -0.09898389f, 0.08309054f, 
    -0.01838305f, -0.02290535f, -0.05042194f, 0.05164050f, 0.02630722f, 0.00786032f, -0.01375407f, 0.13809632f, 
    -0.04651149f, 0.07173739f, 0.04443886f, -0.25511909f, -0.10283420f, 0.02805579f, 0.09051368f, -0.02437730f, 
    0.00898836f, -0.08439510f, -0.06682158f, 0.08802126f, -0.16338368f, -0.04040924f, -0.04907262f, 0.08999737f, 
    0.06006984f, -0.01734881f, 0.03127769f, -0.07350477f, 0.13828717f, -0.09908839f, 0.10809650f, -0.02587871f, 
    -0.12360744f, 0.06330274f, -0.10280172f, 0.03212786f, 0.04253080f, 0.10631271f, 0.03749387f, 0.10179456f, 
    -0.02076035f, 0.08927239f, 0.02981514f, 0.03085421f, -0.04220393f, 0.16793448f, -0.07337318f, -0.03432964f, 
    -0.15985855f, -0.00623439f, -0.07903464f, -0.05406282f, -0.20570739f, -0.01074718f, -0.05566264f, 0.00729163f, 
    -0.23383015f, -0.14518408f, 0.09368593f, 0.08347017f, 0.10686726f, -0.02705431f, 0.01236629f, 0.01539529f, 
    0.00780879f, 0.00131364f, -0.06217034f, 0.01708098f, -0.03953438f, -0.07040699f, 0.15662464f, -0.18073362f, 
    -0.18133323f, -0.03536321f, -0.05520895f, 0.05724413f, -0.01239460f, 0.07658859f, 0.01811281f, -0.06396060f, 
    0.17138357f, -0.10243252f, 0.04408990f, -0.03424011f, 0.06523088f, 0.03899804f, -0.04864620f, -0.00893471f, 
    0.09638025f, 0.04211809f, 0.00875120f, 0.00722399f, -0.06238236f, 0.13316968f, 0.00624449f, 0.01154044f, 
    0.08037561f, -0.09205369f, -0.00779284f, -0.10312267f, 0.01570055f, 0.07430325f, 0.02468422f, 0.10849652f, 
    0.12284727f, -0.02653355f, -0.24047728f, 0.09638274f, 0.02720819f, -0.04863384f, -0.11473957f, -0.04279830f, 
    0.02447558f, 0.02555889f, 0.06338963f, -0.03042404f, 0.06664449f, 0.03437682f, 0.08767319f, -0.06004337f, 
    0.00828782f, -0.02388165f, -0.04850377f, 0.05382764f, 0.12737404f, 0.06587453f, 0.06866288f, 0.00513271f, 
    0.18583298f, 0.10198839f, -0.18040806f, 0.06721234f, -0.23454317f, 0.08624104f, -0.01286584f, -0.12960552f, 
    0.04748890f, -0.05447860f, -0.04840920f, 0.07068738f, 0.07262945f, 0.03332667f, -0.06697728f, 0.03870024f, 
    0.02861067f, 0.02234427f, 0.04194475f, -0.03608276f, 0.09514080f, -0.03458083f, -0.07077303f, 0.07742994f, 
    0.22744389f, 0.06548995f, 0.12661895f, -0.21820660f, -0.18917339f, 0.00432495f, 0.04604353f, -0.04293698f, 
    0.01795911f, 0.03072382f, 0.16037409f, 0.03907322f, -0.01735098f, -0.13977520f, 0.02073137f, 0.11526012f, 
    -0.03595066f, -0.09045412f, -0.01735047f, 0.00328293f, -0.02948116f, 0.07324678f, 0.05387536f, 0.01903238f, 
    0.07071941f, 0.14831689f, -0.08520219f, -0.14019823f, 0.03793054f, 0.00944623f, 0.04822652f, -0.03126961f, 
    0.13292065f, 0.07498403f, -0.00485559f, -0.09860355f, -0.05561309f, 0.16701715f, 0.03461790f, 0.01114909f, 
    0.02480705f, 0.05981929f, -0.10521217f, 0.05440608f, 0.15119943f, -0.05155785f, -0.03833501f, 0.12121946f, 
    -0.08804210f, 0.12777531f, -0.23981036f, 0.14302632f, 0.09201469f, 0.08642497f, -0.03851605f, -0.09000408f, 
    0.04188052f, 0.02508888f, -0.07835755f, 0.01437153f, -0.10637234f, -0.05498453f, -0.03548450f, -0.06431377f, 
    -0.08020090f, -0.02278181f, -0.02895278f, -0.00869399f, 0.01835760f, -0.04275998f, 0.02076635f, 0.03347841f, 
    -0.16379753f, 0.31983683f, 0.00345293f, -0.20086278f, -0.00088777f, -0.01372870f, -0.00046730f, -0.03824289f, 
    0.02714933f, -0.03365260f, 0.07505581f, -0.00613182f, -0.06748254f, 0.25359589f, 0.01871662f, -0.08508155f, 
    0.00531107f, -0.13162026f, -0.02607811f, 0.01492311f, 0.08529609f, -0.10835231f, 0.07526642f, 0.03553903f, 
    -0.16766152f, -0.06851495f, 0.25047687f, 0.19686967f, -0.07758736f, -0.04631871f, 0.05362977f, 0.00509031f, 
    -0.03740118f, 0.08968970f, -0.00605994f, 0.01819715f, 0.09018369f, 0.06232281f, -0.00854738f, -0.04629409f, 
    -0.12428427f, 0.07141371f, 0.13957281f, -0.06308416f, 0.03497885f, -0.02554765f, -0.16799863f, -0.04482935f, 
    0.22503290f, 0.11340534f, -0.14146642f, 0.04880511f, 0.11362553f, -0.09059966f, -0.10359969f, 0.07545179f, 
    0.15349962f, 0.00963791f, 0.07902143f, -0.02035408f, 0.02802227f, 0.01842299f, 0.07910466f, 0.01512502f, 
    0.05842815f, -0.02610138f, 0.03238354f, 0.05522062f, 0.10653531f, 0.03128399f, 0.00152227f, -0.02927448f, 
    -0.05096575f, 0.08745522f, -0.07851513f, 0.00770137f, 0.04580966f, -0.05436621f, -0.05318538f, 0.05667259f, 
    0.10166971f, 0.00810759f, -0.06750260f, 0.09192098f, -0.01433381f, -0.18135194f, 0.00123164f, 0.06089805f, 
    -0.01186388f, 0.03913706f, 0.09674200f, -0.00209408f, 0.00502483f, 0.00334547f, -0.04679139f, 0.12285198f, 
    0.22977863f, -0.06594269f, -0.13987711f, 0.13286577f, -0.10891066f, 0.01713268f, -0.07039405f, 0.06329530f, 
    -0.00884626f, -0.01737956f, 0.03318768f, -0.01002511f, 0.07694685f, 0.17843547f, 0.09624355f, -0.15223356f, 
    -0.06983521f, -0.10973947f, 0.10985094f, 0.03490607f, -0.03801632f, 0.01224712f, 0.04189156f, -0.07008457f, 
    0.01460344f, -0.15755038f, 0.14031778f, 0.19858328f, -0.08552031f, -0.07435232f, 0.08379701f, -0.02654183f, 
    0.02234820f, -0.04111928f, 0.05062270f, 0.02925015f, 0.08850781f, 0.04105769f, 0.19078346f, -0.01376375f, 
    0.05700110f, -0.05565521f, 0.12788659f, 0.04422590f, -0.09793643f, 0.04675224f, 0.02320441f, 0.09662275f, 
    0.04290104f, -0.11954732f, -0.00876723f, 0.07905929f, 0.08039976f, -0.02535498f, -0.00655249f, 0.00255704f, 
    -0.00857682f, 0.08215985f, -0.01042273f, 0.19634280f, 0.07330994f, -0.08277369f, -0.15155771f, 0.02479157f, 
    -0.00194041f, -0.04491940f, 0.01771591f, 0.02674227f, 0.02487530f, -0.02905123f, 0.07811721f, 0.02534913f, 
    0.20904517f, 0.10697892f, -0.31826398f, 0.16805533f, 0.13957347f, -0.02102020f, 0.00223548f, 0.05290072f, 
    0.02182104f, -0.04264437f, -0.05420737f, 0.09982547f, -0.31012803f, 0.13044299f, 0.18843737f, -0.15932165f, 
    -0.03310953f, -0.03381144f, 0.12894194f, 0.02113472f, -0.03797972f, -0.04879778f, 0.00135381f, 0.07454373f, 
    -0.15806164f, 0.11083699f, 0.05830139f, 0.08912557f, 0.00771629f, -0.08699221f, -0.10550050f, 0.07673835f, 
    0.02584615f, 0.02002540f, -0.04988223f, 0.03441370f, 0.05275325f, -0.11684054f, -0.11014042f, 0.00316478f, 
    -0.12205078f, 0.01066823f, 0.01472426f, -0.03222560f, -0.07860646f, -0.05273789f, 0.02631171f, 0.13966107f, 
    0.12110586f, -0.11681912f, 0.06789984f, 0.05206657f, -0.13057265f, -0.06606607f, -0.02906776f, 0.01392990f, 
    0.05273268f, 0.03523788f, 0.00781888f, 0.02946545f, 0.27103385f, 0.10129509f, 0.04831680f, 0.23643003f, 
    0.07460930f, -0.01910857f, 0.01375728f, -0.04522081f, -0.00887305f, 0.04842318f, 0.06773423f, -0.01067655f, 
    0.02919733f, 0.01531125f, -0.09340977f, 0.02745285f, -0.12603866f, 0.03660529f, 0.07216387f, 0.05452425f, 
    -0.02301179f, -0.00545831f, -0.02756955f, 0.09276120f, 0.07349811f, 0.17580681f, -0.05687299f, 0.06042900f, 
    0.00937250f, -0.01272201f, 0.04789197f, -0.00140866f, 0.03996579f, 0.04303891f, -0.03802466f, -0.10268108f, 
    0.05084220f, 0.01380945f, -0.22606984f, 0.08558158f, 0.02500419f, 0.04210461f, 0.06481531f, 0.03946758f, 
    -0.03618320f, -0.00794301f, -0.00133476f, 0.04545901f, -0.08597396f, 0.03086073f, -0.15768984f, 0.22555813f, 
    0.09881127f, -0.03548054f, -0.02890146f, 0.09137936f, 0.05333435f, 0.16144902f, -0.12291409f, 0.07550686f, 
    0.02444767f, -0.03934968f, -0.09249503f, 0.17525311f, -0.00327344f, -0.07970368f, -0.07021299f, 0.00851609f, 
    0.07474755f, -0.04918901f, 0.06330040f, 0.06098079f, 0.24852949f, 0.23805100f, -0.11152580f, -0.06866942f, 
    -0.17195915f, -0.06757481f, 0.04536457f, -0.17436330f, -0.10299738f, -0.01206282f, -0.05705900f, 0.00877408f, 
    0.04399499f, -0.23981377f, 0.03947933f, 0.01928773f, -0.08079375f, -0.03121787f, -0.10781321f, 0.04764600f, 
    0.02636985f, -0.04276666f, -0.02116357f, 0.00700031f, -0.11302491f, -0.19524710f, 0.11116806f, -0.05283289f, 
    0.17207073f, -0.03259225f, 0.11424546f, -0.03964119f, -0.02795644f, -0.00060736f, -0.12993979f, -0.00466152f, 
    -0.30898201f, -0.02298150f, 0.03747344f, 0.01723052f, -0.01405752f, 0.03939316f, 0.06940793f, 0.05308738f, 
    -0.03174134f, 0.01161785f, 0.02871179f, -0.00175524f, 0.12969017f, 0.10216529f, -0.03437551f, -0.08966280f, 
    -0.02838634f, 0.04955973f, 0.13960584f, -0.04764074f, 0.05118027f, 0.12371269f, 0.00070212f, 0.03321302f, 
    0.12989198f, -0.13740839f, -0.05850113f, -0.04759103f, -0.11960722f, 0.02323535f, -0.03080040f, -0.01734313f, 
    -0.02968707f, 0.07695410f, -0.02005937f, -0.00401326f, 0.02974399f, 0.15256096f, -0.02585858f, -0.10184956f, 
    0.03436030f, 0.03046116f, -0.06619908f, 0.07943209f, 0.03121933f, -0.01610196f, 0.08136252f, -0.01109020f, 
    0.09326693f, 0.07501901f, -0.05716613f, 0.01316598f, -0.01383970f, -0.04672112f, -0.05717184f, -0.07101879f, 
    -0.03858534f, 0.01126090f, -0.03967090f, -0.02095429f, -0.26303613f, 0.36445868f, 0.07603089f, 0.05690034f, 
    0.09995733f, -0.05322429f, 0.05031481f, -0.00825583f, -0.04599472f, 0.06877163f, -0.07063191f, 0.05552471f, 
    -0.25280738f, -0.04187439f, -0.00216505f, -0.08681565f, -0.05103927f, -0.00775384f, -0.00311824f, 0.02078108f, 
    -0.05293058f, 0.02522778f, -0.06473733f, 0.00223992f, -0.00269593f, 0.17326960f, -0.09233815f, 0.13454123f, 
    -0.01035608f, 0.10069121f, -0.04967915f, -0.07967962f, -0.12106024f, -0.06332110f, 0.00784599f, 0.05774702f, 
    -0.03761828f, 0.19822820f, 0.06777757f, -0.00657959f, -0.03076153f, -0.09773834f, -0.06926333f, -0.04908068f, 
    -0.09996330f, -0.10683433f, -0.03365228f, 0.03588798f, -0.03249175f, -0.26802903f, 0.13928284f, 0.15541269f, 
    -0.04794845f, -0.00094934f, -0.00030297f, 0.02633875f, -0.05758136f, -0.09388457f, 0.08085185f, -0.00172286f, 
    0.06049823f, 0.05878289f, 0.07317146f, -0.01085490f, -0.00376159f, 0.00424494f, 0.03395674f, -0.04906419f, 
    -0.03390048f, 0.04693785f, -0.03977637f, -0.04409152f, -0.02163523f, 0.04160497f, -0.02022298f, 0.15269643f, 
    -0.00948778f, 0.09227296f, 0.00239889f, -0.04631919f, 0.06203312f, 0.04645445f, 0.02111144f, -0.05426555f, 
    0.03162719f, -0.18044665f, 0.03070830f, -0.03146991f, 0.09592471f, -0.04757393f, 0.00986208f, 0.00289619f, 
    0.03794066f, 0.01736929f, -0.06717399f, -0.14276314f, 0.00789662f, -0.15343003f, -0.06636287f, 0.16596816f, 
    -0.04553189f, 0.02318280f, 0.00892288f, 0.11611982f, -0.02080138f, 0.11044747f, 0.07069463f, -0.03910023f, 
    -0.12838443f, 0.46148065f, -0.04088302f, 0.05962900f, -0.02020775f, 0.05767781f, 0.00073935f, -0.03895644f, 
    0.07212728f, -0.02347288f, 0.04808964f, -0.02423322f, 0.30642888f, -0.11455178f, 0.02908329f, -0.01746094f, 
    -0.06005669f, -0.01029446f, 0.01440022f, 0.00576008f, 0.05622572f, -0.00420260f, 0.00656024f, -0.02598773f, 
    -0.26125345f, 0.25633058f, 0.06002109f, -0.16855234f, -0.00077677f, 0.01784029f, -0.03931273f, -0.03076608f, 
    0.00419914f, 0.03048087f, 0.11506252f, -0.02976079f, 0.01098355f, 0.16746224f, 0.06440932f, 0.01246000f, 
    0.03823037f, -0.01644309f, -0.01280962f, 0.01454055f, -0.06465905f, 0.02882501f, 0.02681626f, -0.06892757f, 
    -0.05938366f, 0.02652667f, -0.12900734f, 0.14472929f, 0.01493389f, 0.01118705f, -0.01634454f, 0.03912459f, 
    -0.06508586f, 0.05995369f, 0.14343147f, -0.06902172f, 0.07035130f, -0.06688027f, 0.06441621f, 0.01632118f, 
    -0.04811695f, 0.05751615f, 0.00443666f, -0.00857541f, -0.08295138f, 0.03790743f, 0.07531636f, 0.00644191f, 
    0.38859427f, -0.19597481f, -0.15025701f, 0.07206994f, -0.05072796f, -0.11678900f, -0.03299685f, 0.03189952f, 
    0.05497955f, 0.01158062f, 0.00307256f, 0.01853816f, 0.14740242f, -0.03455815f, 0.14617400f, 0.04629218f, 
    0.04598078f, 0.08126874f, 0.05116168f, -0.03138755f, 0.07872616f, -0.00016539f, -0.02821242f, 0.03222420f, 
    0.24859573f, 0.01180732f, -0.13311009f, -0.15925416f, 0.04884313f, -0.02377372f, -0.06889298f, 0.04034430f, 
    0.02263501f, 0.09799692f, 0.02817472f, -0.08009045f, -0.13366580f, 0.05876541f, 0.07234604f, 0.09323491f, 
    0.15332793f, 0.04627970f, -0.01538285f, 0.03009014f, -0.04959597f, -0.09778563f, 0.00442384f, 0.03033762f, 
    -0.14040314f, 0.19415092f, -0.17259385f, 0.01461392f, -0.01797888f, -0.05836758f, 0.00791880f, 0.05179549f, 
    -0.04834425f, -0.00998429f, 0.04486304f, -0.09624276f, 0.28074068f, -0.15801696f, 0.04671402f, -0.01729571f, 
    -0.01557154f, -0.06662070f, -0.02959144f, 0.05561012f, 0.11119708f, -0.06476908f, -0.02961143f, 0.01038487f, 
    0.06478813f, 0.05282735f, -0.02792770f, -0.00041185f, 0.03457109f, 0.03214443f, 0.06320341f, -0.00321409f, 
    -0.04275500f, 0.02619195f, 0.00478673f, 0.02728482f, 0.00706252f, 0.10683630f, -0.05742821f, -0.00586142f, 
    0.03149427f, 0.04467102f, 0.06877835f, 0.02022906f, 0.11327514f, 0.08854795f, -0.08549213f, 0.07797150f, 
    0.05018997f, -0.06259118f, 0.03391577f, -0.09938487f, 0.04807723f, 0.00404747f, -0.03111457f, 0.10336115f, 
    0.09607437f, 0.00212248f, 0.03579683f, 0.02378543f, 0.13995421f, 0.00479126f, -0.01139810f, -0.04968212f, 
    0.00284662f, -0.05697370f, 0.05115049f, 0.03580400f, -0.02250733f, 0.07629719f, -0.05514596f, 0.06701173f, 
    -0.09296617f, -0.03242321f, 0.00582649f, 0.05720229f, 0.14365244f, 0.00895452f, -0.00396841f, -0.06462497f, 
    0.00036424f, -0.04674171f, -0.07019027f, -0.02397875f, -0.06390046f, -0.02582649f, 0.11854924f, 0.01120572f, 
    0.00207542f, 0.04422035f, 0.00005432f, -0.03146112f, 0.06058483f, -0.05175579f, 0.02682051f, 0.08368206f, 
    -0.21825205f, 0.24762155f, -0.03392771f, 0.03185326f, 0.06911103f, 0.06284837f, 0.00742177f, -0.10718895f, 
    0.02094719f, 0.01096203f, -0.08760797f, 0.01093635f, 0.02340629f, -0.16257867f, -0.07792225f, 0.10135353f, 
    -0.02718685f, 0.08892985f, -0.06024209f, 0.01136690f, -0.03190268f, 0.03564411f, -0.01619501f, 0.04636164f, 
    0.20002000f, 0.13613108f, -0.11468999f, 0.00838928f, -0.04319954f, -0.00499403f, -0.00288702f, -0.03807355f, 
    -0.02679363f, -0.04407984f, 0.02402646f, 0.02809652f, 0.22008425f, 0.03489818f, 0.14252879f, 0.11198196f, 
    -0.02208309f, 0.04628657f, 0.00796330f, -0.10699377f, -0.03293646f, -0.03934012f, 0.00139038f, 0.02812441f, 
    0.02718864f, -0.09877368f, 0.04464196f, -0.00881108f, -0.04300689f, 0.03258672f, -0.00517046f, -0.06191187f, 
    -0.04623624f, 0.01816005f, 0.04452471f, -0.05436504f, -0.21399578f, 0.05764157f, 0.06668757f, 0.07506752f, 
    0.04977519f, 0.07694715f, 0.08601848f, -0.04540930f, -0.03707588f, 0.09514404f, -0.03063696f, -0.01920884f, 
    -0.11172035f, 0.30403259f, -0.02165587f, -0.21210505f, 0.09037651f, 0.00348340f, 0.03633590f, -0.12689267f, 
    0.07904746f, -0.00121325f, -0.04583300f, 0.06138264f, -0.34355333f, -0.03432064f, 0.02294402f, 0.10346337f, 
    0.07481225f, 0.04996323f, 0.07667805f, -0.06960022f, 0.02067382f, 0.09507161f, 0.06930970f, 0.02839733f, 
    -0.16935170f, -0.01468093f, 0.14763573f, 0.18500696f, -0.02236939f, 0.03439841f, 0.00413423f, 0.00516183f, 
    0.08120003f, -0.02903111f, 0.06902873f, -0.01412357f, 0.07154740f, 0.05837779f, -0.10362368f, -0.09365379f, 
    -0.13604851f, -0.05127978f, -0.08013797f, 0.00010047f, 0.01688844f, -0.04175070f, 0.03768133f, 0.04593054f, 
    0.33081663f, -0.02123206f, -0.04162863f, -0.01959514f, -0.08182368f, -0.00672218f, 0.02910366f, -0.00309943f, 
    -0.01735490f, -0.04340247f, -0.01331704f, -0.06034801f, -0.26012489f, 0.24391602f, 0.08437204f, -0.04546505f, 
    0.05493930f, 0.01842056f, -0.01370457f, 0.14029670f, -0.04162046f, -0.01873032f, 0.06270865f, -0.08654802f, 
    -0.13497610f, 0.09997623f, 0.03648249f, 0.07438359f, 0.03338465f, 0.08215825f, 0.04938346f, -0.04173872f, 
    0.17125420f, 0.12667306f, 0.12067790f, 0.03747249f, -0.16832986f, -0.06725636f, -0.02196033f, 0.15625870f, 
    0.09929961f, -0.00491854f, -0.08625692f, 0.04000419f, 0.07394639f, -0.01923891f, -0.01394145f, 0.05434779f, 
    -0.11448181f, -0.03705394f, 0.03182648f, -0.11714694f, 0.02781297f, 0.06363220f, -0.00628282f, -0.03369501f, 
    -0.03828941f, 0.00906122f, -0.00248372f, 0.06268307f, -0.05899556f, -0.12166133f, -0.03475536f, -0.05371350f, 
    -0.04884857f, 0.11452945f, -0.10410146f, -0.06020765f, 0.05777992f, -0.01389234f, 0.09494282f, 0.02778405f, 
    0.06472792f, 0.13820054f, 0.00453420f, -0.09710003f, 0.01328286f, -0.05995748f, -0.00235668f, 0.07747053f, 
    0.03392302f, -0.06334400f, -0.01196233f, -0.12004341f, -0.00967860f, -0.03437115f, 0.16810490f, 0.05493942f, 
    0.05085083f, -0.05576083f, 0.01078176f, -0.03838741f, 0.06434263f, -0.07437757f, -0.08943924f, -0.04877528f, 
    0.19387588f, 0.15192157f, -0.00137371f, 0.07106154f, 0.02158104f, 0.02924784f, -0.01173131f, -0.06708767f, 
    0.02598331f, 0.00337282f, 0.06657364f, 0.01038151f, -0.10581480f, -0.10846436f, -0.13942249f, -0.05107677f, 
    0.06424425f, -0.00842166f, -0.05699610f, 0.02911929f, 0.05148097f, -0.01104473f, 0.01115693f, -0.00042293f, 
    0.22573848f, -0.07193162f, 0.01342597f, 0.06786753f, 0.12248959f, 0.00796198f, 0.01912370f, -0.02354904f, 
    0.04726729f, -0.09268343f, 0.04716930f, -0.03119742f, 0.13378158f, 0.03141977f, 0.05034001f, 0.04625233f, 
    0.04008703f, 0.07261921f, -0.00687973f, -0.01188056f, 0.07521650f, 0.00790739f, 0.03065846f, -0.09295310f, 
    0.14516598f, 0.01100412f, -0.01795712f, 0.02748666f, 0.08437222f, 0.01908720f, -0.02980904f, 0.00136670f, 
    0.02455484f, 0.05956244f, -0.03976896f, 0.00610262f, -0.07451838f, -0.05881169f, -0.01243779f, -0.07278261f, 
    -0.04781217f, 0.03748525f, -0.01646122f, 0.05260720f, 0.00185051f, 0.08063946f, 0.04743281f, -0.15677121f, 
    0.17995916f, 0.03526608f, -0.04116507f, 0.07400242f, 0.00690662f, -0.07835709f, 0.06597229f, 0.01016259f, 
    0.01512418f, 0.07020275f, 0.08894559f, -0.04392290f, 0.03773090f, -0.15180884f, -0.03818911f, 0.14198600f, 
    -0.03555558f, 0.04345729f, -0.09437587f, -0.05066358f, 0.07386217f, -0.07080450f, 0.02115582f, -0.02169601f, 
    -0.14672658f, 0.07731368f, 0.17842856f, -0.13747579f, 0.08673909f, -0.07673197f, 0.01380624f, 0.10289402f, 
    0.11410724f, 0.01301247f, -0.00342112f, 0.00655703f, 0.30920392f, -0.00526411f, -0.00397885f, 0.10858425f, 
    -0.00056411f, -0.02644123f, -0.01518597f, -0.00279827f, -0.16543140f, -0.12124416f, 0.07695395f, 0.01955596f, 
    0.32261094f, 0.08247301f, 0.03405126f, -0.19806971f, 0.01535779f, -0.02610234f, -0.08789843f, 0.01835736f, 
    -0.06363349f, 0.08609531f, 0.03740802f, -0.05243609f, -0.13944347f, -0.05247792f, 0.15038303f, 0.00343263f, 
    0.11038562f, 0.12342437f, 0.14611213f, 0.02879150f, -0.02933207f, 0.05464721f, -0.01717512f, 0.00391793f, 
    0.14674073f, 0.10432294f, 0.05430065f, 0.06219940f, 0.11812848f, 0.07574575f, 0.06553947f, -0.02288449f, 
    -0.01906957f, 0.04397200f, 0.07036585f, -0.02676419f, 0.20797004f, -0.05167362f, -0.09835666f, -0.08087958f, 
    -0.00113153f, 0.01862335f, -0.02773787f, 0.06798062f, 0.02094604f, 0.00699094f, 0.10859030f, 0.06237610f, 
    0.20739408f, 0.04823348f, -0.05686923f, 0.03772827f, -0.00970983f, 0.02056184f, -0.05035268f, 0.03776856f, 
    0.05441805f, 0.03677364f, 0.09215697f, -0.01305267f, -0.11513757f, -0.06153980f, -0.04727649f, 0.05844953f, 
    -0.14790633f, -0.09422664f, 0.02982264f, 0.04277834f, 0.02499104f, -0.05248837f, -0.03644819f, 0.08466505f, 
    0.00031105f, 0.13685535f, 0.08897707f, 0.10965355f, -0.00632832f, 0.04417200f, 0.04977238f, -0.02083214f, 
    0.06186636f, -0.02924616f, 0.00869205f, 0.12887010f, -0.19281624f, -0.08794455f, 0.29379222f, 0.14652532f, 
    -0.01450680f, 0.02417779f, 0.01539048f, -0.02159233f, 0.03230187f, -0.04080327f, 0.02008705f, -0.01017842f, 
    0.01820273f, -0.12736717f, 0.10015868f, 0.12127826f, -0.00097930f, -0.05135112f, 0.13542250f, -0.00993374f, 
    0.02647705f, 0.02550806f, -0.07926670f, 0.06816053f, 0.13108282f, -0.13256577f, 0.02761741f, 0.00225891f, 
    -0.02380565f, 0.02664335f, 0.02392113f, -0.03405498f, -0.03734063f, -0.06277653f, 0.05724932f, -0.01993303f, 
    -0.12392340f, -0.16638002f, -0.02881134f, 0.13222848f, 0.07847095f, 0.05112016f, 0.05441883f, -0.04914494f, 
    0.15849887f, -0.02990604f, -0.12142479f, -0.07521664f, -0.09851006f, -0.02456107f, 0.18290675f, 0.06868817f, 
    -0.03229567f, 0.04966836f, 0.09569526f, 0.11103325f, 0.06437033f, -0.03863807f, 0.14429978f, 0.11410662f, 
    0.01118426f, -0.14158440f, -0.09663092f, -0.03329349f, -0.02182742f, 0.18871196f, 0.09936808f, -0.01205825f, 
    0.05455088f, 0.10746596f, 0.16690843f, 0.00628144f, 0.09754878f, 0.27631363f, 0.00693101f, -0.09849211f, 
    0.11348801f, -0.03434461f, 0.11423679f, 0.05997854f, 0.03355138f, 0.00694363f, -0.10633709f, -0.16123949f, 
    -0.03845323f, -0.10966805f, 0.07067877f, 0.08981781f, 0.09285119f, 0.04571768f, -0.04678911f, 0.01059783f, 
    0.04032192f, 0.01945137f, 0.05062236f, 0.00667328f, -0.04451283f, -0.03839864f, 0.03299775f, -0.01616369f, 
    0.03034162f, -0.14372976f, 0.16836916f, -0.03860988f, -0.07370735f, 0.07152466f, -0.14604600f, 0.16494949f, 
    -0.02728216f, 0.18509260f, 0.11952334f, 0.11772998f, -0.00650446f, 0.08518329f, -0.05076072f, -0.03865090f, 
    -0.02968451f, -0.13768652f, -0.07127025f, 0.04255944f, -0.11183061f, 0.10477746f, 0.15562201f, -0.15671590f, 
    0.09669879f, 0.00240694f, -0.00001938f, -0.04327792f, 0.06234018f, -0.10569707f, -0.03194179f, 0.11668571f, 
    0.30521572f, -0.12917836f, -0.00630529f, -0.16696806f, -0.09751444f, -0.02842133f, 0.03605815f, 0.08893339f, 
    -0.06788493f, 0.04576286f, -0.01617312f, -0.03200591f, -0.04389179f, -0.02119181f, 0.11342245f, -0.02715713f, 
    0.10825816f, 0.08047423f, 0.09121979f, -0.09366741f, -0.04320277f, 0.05004344f, -0.00324613f, 0.05927793f, 
    0.30591536f, 0.01638071f, -0.04744118f, 0.18766968f, 0.10377157f, -0.02232475f, -0.03917741f, 0.04944132f, 
    -0.10469028f, 0.13378799f, 0.12303660f, 0.02745938f, 0.09608878f, -0.01121420f, -0.18259197f, 0.23624699f, 
    0.07318268f, 0.15406056f, 0.09900633f, 0.05906569f, 0.02136423f, -0.06135925f, 0.11129148f, 0.07555593f, 
    0.02260563f, -0.10095582f, 0.07173648f, 0.14710025f, -0.06499746f, -0.10351176f, 0.00777428f, 0.11317182f, 
    -0.01020070f, 0.02465355f, -0.02247585f, -0.02254687f, 0.04000675f, 0.24036554f, 0.03465730f, 0.00728478f, 
    0.03331590f, -0.00879760f, -0.01882249f, 0.11385499f, 0.13782464f, 0.17034818f, -0.17170826f, 0.12091386f, 
    -0.47487578f, -0.01299211f, 0.23601788f, 0.14498484f, 0.03227574f, 0.10036253f, -0.04531068f, -0.07008941f, 
    -0.07015962f, 0.00896423f, 0.02079615f, -0.20521949f, 0.06024878f, 0.09134421f, 0.08304354f, 0.06476484f, 
    0.13209751f, -0.11214712f, -0.04217323f, 0.21152316f, 0.01497244f, 0.07618330f, 0.02813766f, 0.11709403f, 
    0.12249926f, -0.00033287f, 0.06091264f, -0.07054190f, -0.16308770f, 0.13389319f, 0.05824827f, -0.03656468f, 
    -0.02743951f, -0.01591514f, -0.06821781f, 0.02855409f, 0.12488417f, 0.07693907f, 0.00041852f, 0.00394354f, 
    -0.02603067f, -0.08532395f, 0.00540211f, 0.07946173f, 0.00312474f, -0.04658240f, 0.06950181f, -0.06083742f, 
    0.16034314f, 0.24523376f, 0.12965886f, -0.02302337f, -0.03607937f, 0.13125335f, 0.06128794f, -0.00867012f, 
    -0.11984137f, 0.02685711f, 0.00745886f, 0.10879604f, -0.17348114f, -0.04020408f, 0.01988026f, 0.08948910f, 
    -0.00283327f, 0.17370750f, 0.06802247f, -0.04381557f, -0.03142650f, 0.06357216f, -0.00578654f, 0.07127567f, 
    0.00599151f, -0.01206446f, 0.08979922f, -0.11004901f, -0.05693814f, -0.03230769f, -0.08420320f, -0.04889824f, 
    -0.04529539f, -0.04485806f, -0.15258452f, 0.01766706f, -0.09599923f, -0.02505055f, 0.06079594f, 0.15013210f, 
    -0.04312904f, -0.05039078f, 0.07042465f, -0.10863269f, -0.14432904f, 0.18955541f, 0.04274603f, 0.13522226f, 
    0.00202905f, -0.03948084f, 0.11518732f, -0.00169156f, -0.00558274f, -0.07241952f, 0.02753170f, 0.07931195f, 
    -0.05688190f, 0.22445820f, -0.06672468f, -0.04339093f, -0.16209044f, -0.02559931f, 0.11115780f, 0.00797989f, 
    0.00932880f, -0.06917382f, -0.00538684f, -0.02353235f, 0.05466089f, -0.16902322f, -0.11165478f, -0.14775673f, 
    0.28776336f, 0.19742790f, -0.03524512f, 0.00161884f, -0.14819227f, -0.04384191f, -0.07036412f, 0.16331628f, 
    0.05654880f, -0.09443481f, -0.01357692f, 0.06697372f, 0.06084322f, 0.08341593f, -0.18525209f, -0.11946631f, 
    0.02284823f, -0.07326216f, -0.00414820f, 0.01463557f, -0.10266731f, -0.21161684f, 0.01555702f, -0.13826887f, 
    0.00157999f, -0.07189311f, 0.17393352f, 0.06891396f, -0.05128128f, 0.00729996f, 0.04483093f, 0.12146664f, 
    -0.08628777f, -0.01670531f, 0.17939353f, 0.00921838f, -0.07437038f, 0.08055703f, 0.20551457f, -0.16556309f, 
    0.06986064f, -0.07587932f, 0.02142769f, -0.04348407f, 0.14048289f, -0.03272845f, -0.14358315f, 0.04595653f, 
    -0.16093509f, -0.08956535f, 0.23708063f, -0.13958523f, -0.05583629f, 0.05839048f, 0.06391499f, 0.13300078f, 
    0.03875026f, 0.03655591f, -0.00602658f, 0.02143141f, -0.10553023f, -0.06605869f, 0.02050267f, 0.05092272f, 
    0.06727402f, -0.03890081f, 0.15766707f, 0.15236704f, -0.01014521f, 0.09838531f, 0.07766218f, 0.03401069f, 
    0.07363956f, -0.02642316f, 0.02857749f, 0.10034594f, -0.01737847f, -0.11538157f, 0.05521000f, 0.10583435f, 
    0.00816049f, 0.02304780f, 0.05366599f, 0.04788766f, 0.01260991f, 0.03294567f, 0.00933906f, 0.18286285f, 
    -0.00589603f, 0.01623029f, -0.04183358f, 0.11754120f, -0.06254122f, -0.07684644f, 0.13290232f, -0.14020112f, 
    0.21590714f, -0.14677426f, -0.04406704f, 0.23243424f, 0.00242163f, 0.03984679f, 0.01096162f, 0.05032817f, 
    0.01052935f, -0.01829843f, 0.15721245f, 0.00462021f, 0.05159343f, 0.04337144f, 0.12227588f, -0.14588287f, 
    0.16078712f, -0.18879081f, -0.01498948f, 0.04830613f, -0.01658376f, 0.13068350f, 0.13665381f, 0.17520839f, 
    0.34815189f, 0.23418231f, -0.25423676f, -0.09936976f, -0.02441690f, 0.16712050f, 0.04108833f, -0.03670023f, 
    -0.03434355f, -0.15311219f, -0.03006225f, -0.07322776f, -0.04914644f, -0.15721677f, 0.03743093f, 0.17949240f, 
    0.11020880f, 0.12413174f, 0.01905611f, -0.07137719f, 0.05548820f, -0.10080325f, -0.03964285f, -0.07140292f, 
    -0.10021306f, -0.05238122f, 0.15984364f, -0.01091684f, 0.09942624f, 0.01641616f, -0.01071255f, -0.01058582f, 
    0.00674190f, -0.06399876f, -0.10703469f, -0.03103273f, -0.11741536f, -0.06316365f, 0.15717472f, 0.03130581f, 
    0.01526988f, -0.05281550f, -0.00138080f, -0.15550900f, 0.04280710f, 0.09222406f, 0.04244049f, 0.10199609f, 
    0.08974601f, 0.09256925f, -0.02760147f, -0.09814920f, -0.08637694f, -0.06644967f, -0.00892683f, -0.08556856f, 
    -0.13495113f, -0.05704840f, -0.01206962f, 0.10486139f, -0.10526940f, -0.10682974f, 0.13150775f, 0.08224579f, 
    -0.02043745f, 0.04939274f, 0.06204622f, 0.03353689f, 0.07751236f, -0.11200847f, -0.15909030f, -0.07368057f, 
    -0.02221443f, 0.06104375f, -0.06432234f, 0.04293688f, 0.01023980f, 0.05349600f, 0.02407595f, -0.00547659f, 
    0.01252044f, 0.01467767f, -0.00330170f, 0.02976619f, -0.01536943f, 0.09389362f, -0.07969172f, 0.22439779f, 
    0.05754383f, -0.15196262f, 0.00333721f, 0.08256797f, -0.02377698f, 0.14106148f, -0.12814672f, -0.06359294f, 
    0.00400854f, -0.20156173f, 0.06522653f, 0.14154126f, -0.03391237f, 0.03813418f, 0.09919780f, -0.14584960f, 
    -0.06123601f, -0.00694554f, -0.04227814f, 0.03782189f, -0.06737890f, 0.01431128f, -0.16737024f, 0.09771308f, 
    -0.04286534f, 0.09137487f, 0.12156513f, 0.07659459f, -0.01648107f, 0.00603297f, -0.04480281f, 0.16814727f, 
    -0.08011875f, -0.06247690f, 0.23222320f, -0.22312616f, -0.00520202f, 0.09000323f, 0.01316078f, -0.00575639f, 
    -0.00163475f, 0.06864397f, -0.18199737f, -0.13386546f, -0.05642223f, 0.02788521f, 0.26370010f, 0.20155938f, 
    -0.03070141f, -0.03796378f, -0.01218001f, 0.11501373f, 0.02254153f, 0.13037658f, -0.18117531f, -0.03959622f, 
    0.06989118f, -0.00126676f, -0.05253371f, 0.15523954f, -0.01342856f, 0.05566036f, 0.11383663f, 0.05929262f, 
    -0.02309401f, 0.01924111f, -0.06144559f, 0.07542121f, -0.22203718f, 0.14821407f, 0.17106596f, 0.01073863f, 
    0.12427077f, -0.01565909f, 0.05633999f, 0.07765504f, -0.01764469f, 0.06178795f, 0.11919244f, 0.07987394f, 
    -0.03527130f, 0.05080453f, -0.05907709f, 0.07978933f, -0.06003881f, 0.04455229f, 0.05536158f, 0.01122435f, 
    -0.06648910f, -0.07934577f, 0.02035587f, -0.09952571f, -0.10107936f, 0.06109508f, -0.03646157f, -0.23875923f, 
    -0.02305710f, 0.23224281f, 0.02556772f, -0.07364988f, -0.03062906f, -0.05513237f, 0.03340155f, 0.24247023f, 
    -0.04506258f, 0.01531704f, 0.10635054f, -0.09757002f, 0.06264373f, -0.02471432f, 0.00294766f, 0.03919758f, 
    -0.09710564f, 0.06459584f, 0.11841621f, 0.24088626f, 0.12808627f, 0.11394162f, 0.12845363f, -0.18376699f, 
    0.03478923f, 0.10946541f, 0.03045949f, -0.09499641f, 0.04874049f, 0.05880057f, 0.17547104f, 0.19434020f, 
    0.04084836f, -0.11294428f, -0.00130421f, 0.16183978f, -0.04810290f, 0.00209247f, -0.02447533f, -0.14907442f, 
    0.01304175f, 0.01621654f, -0.07519488f, -0.20581390f, -0.23544702f, 0.00884615f, 0.04003264f, -0.22584733f, 
    -0.04566875f, -0.01117882f, -0.02979713f, -0.06589598f, 0.10212613f, 0.04829831f, -0.01371246f, -0.19526787f, 
    -0.22274233f, -0.23055352f, 0.04681781f, 0.10299172f, -0.12649533f, 0.18858978f, 0.13582741f, -0.01914534f, 
    0.08239216f, 0.12464911f, -0.03622268f, 0.11758549f, -0.02218541f, 0.19178584f, 0.07434404f, 0.09182040f, 
    -0.03313338f, -0.02988022f, -0.08079389f, 0.17268384f, -0.01873903f, 0.04222306f, 0.08782917f, 0.06974468f, 
    0.15113074f, 0.06760006f, -0.18577041f, 0.06213270f, -0.01401156f, -0.11461996f, 0.04896081f, 0.09281159f, 
    0.06546409f, -0.02326159f, -0.10745489f, -0.05215879f, -0.05293864f, 0.02340470f, 0.17178857f, 0.15740284f, 
    0.04691377f, 0.10626078f, 0.03693632f, -0.02295700f, -0.00711004f, -0.00062578f, 0.06665368f, 0.01118810f, 
    0.01764401f, -0.09235878f, -0.04693376f, -0.00842496f, 0.00649721f, -0.03712035f, -0.02810055f, 0.00425056f, 
    -0.07699598f, -0.04009119f, -0.02590206f, -0.12658651f, 0.03313945f, 0.10152608f, 0.15702638f, -0.15304607f, 
    0.00591350f, 0.15162462f, 0.01106116f, 0.07424224f, -0.07444315f, -0.11663242f, 0.05021466f, -0.08283028f, 
    -0.04003704f, 0.08163982f, -0.02067963f, -0.01668230f, 0.10729232f, -0.13932863f, -0.00591081f, -0.03610286f, 
    0.01478529f, -0.12200329f, 0.16986358f, -0.14299408f, 0.19979526f, 0.02502626f, -0.19612820f, -0.07170518f, 
    -0.00037831f, -0.13720955f, 0.11847671f, -0.10504246f, 0.00326518f, 0.10936640f, -0.08421662f, 0.20359512f, 
    -0.01700418f, -0.00983756f, -0.00258695f, 0.06633969f, -0.07015482f, -0.02016055f, -0.02834960f, 0.07570534f, 
    0.03571078f, 0.02600782f, -0.10269936f, -0.01574459f, -0.08718915f, -0.23550533f, -0.11662067f, -0.03435225f, 
    0.11703270f, 0.02572674f, 0.01709779f, 0.08739050f, 0.02722287f, -0.05160370f, 0.05025907f, 0.02133963f, 
    0.05930772f, -0.04460174f, 0.06401208f, 0.07437751f, 0.01446510f, 0.07268774f, 0.05473703f, 0.06942856f, 
    0.11279129f, -0.03813926f, 0.06985802f, 0.03263904f, 0.02428753f, -0.17665321f, -0.04686247f, -0.22353578f, 
    0.08484713f, 0.01390118f, -0.07443313f, 0.04400107f, 0.12127507f, 0.05162012f, -0.04220901f, -0.03736611f, 
    -0.00518954f, 0.04424670f, 0.06290762f, -0.06360133f, 0.12595966f, 0.06257431f, -0.01878523f, -0.03420975f, 
    0.04319900f, 0.00467847f, -0.03247252f, 0.01757336f, -0.36448088f, 0.14890194f, -0.04464409f, -0.25232247f, 
    -0.02913675f, 0.12107790f, -0.06314466f, 0.07767343f, 0.09661886f, 0.09466404f, 0.01120635f, 0.09763704f, 
    0.09401558f, -0.06480569f, -0.02288171f, -0.03350602f, 0.02532214f, -0.03483738f, 0.04342348f, 0.03584968f, 
    0.05678836f, 0.01165752f, 0.01387250f, 0.05720523f, 0.04965390f, -0.07813278f, 0.09809540f, -0.18534040f, 
    0.13433796f, 0.03097979f, -0.05915453f, 0.02820829f, 0.05123923f, -0.04287622f, 0.05144858f, 0.00305908f, 
    -0.14089701f, 0.09635392f, -0.04620055f, 0.10028350f, 0.02153272f, 0.01225708f, 0.03605735f, 0.06629627f, 
    0.05460232f, 0.11555723f, 0.06916732f, 0.10972553f, -0.20684797f, 0.10032424f, -0.01747057f, 0.04648711f, 
    0.01538556f, 0.09295058f, 0.09439395f, 0.08478498f, 0.07711536f, -0.02437823f, 0.02740768f, 0.01084968f, 
    0.04462854f, -0.17974465f, 0.34038776f, -0.14807099f, 0.01460485f, 0.02856502f, 0.00833474f, 0.02935182f, 
    -0.10084668f, 0.00979071f, -0.01689308f, 0.03229999f, -0.40206966f, 0.06541757f, -0.16215369f, 0.13607952f, 
    -0.00632752f, -0.00960325f, -0.03606742f, 0.01301981f, 0.03926568f, 0.05666444f, 0.05517198f, 0.00536802f, 
    -0.03274514f, 0.07661846f, 0.05001667f, 0.25392297f, -0.01024102f, 0.04616613f, 0.04595820f, 0.04381510f, 
    0.11416014f, -0.06471682f, -0.15541159f, 0.08719365f, 0.04351470f, -0.05727270f, 0.01972331f, 0.13231389f, 
    -0.04613588f, 0.00679791f, 0.03649973f, 0.04103592f, 0.09150406f, 0.02658671f, -0.06315199f, 0.09971026f, 
    0.01273026f, -0.06419358f, 0.05478999f, -0.05035381f, 0.08540241f, 0.03457358f, 0.06082447f, 0.07123314f, 
    0.01451702f, 0.01661439f, 0.03556599f, -0.00525749f, -0.14868635f, 0.27632472f, -0.11094926f, -0.03647661f, 
    -0.06594665f, 0.07360379f, -0.07354488f, 0.02065379f, 0.12821345f, -0.07785968f, 0.03047209f, 0.02985398f, 
    -0.11432232f, 0.17087969f, 0.02690372f, -0.13580997f, -0.05544995f, -0.04495431f, -0.01294307f, 0.01009456f, 
    0.12386238f, 0.03125158f, 0.05005381f, 0.08445621f, 0.13046438f, -0.05687894f, -0.02297751f, -0.16250202f, 
    0.00808726f, 0.06890034f, -0.01424306f, -0.04516007f, 0.03389310f, 0.03329521f, 0.09698123f, 0.02091634f, 
    -0.01586680f, -0.01373441f, 0.04920148f, 0.14752296f, 0.09673543f, -0.05694962f, 0.08039083f, -0.07938515f, 
    0.06198601f, -0.04473025f, 0.03257969f, 0.03358001f, 0.10583256f, -0.00805815f, -0.17709035f, -0.15819383f, 
    0.09186971f, 0.02082816f, 0.00086123f, 0.14876007f, 0.13925530f, 0.07190866f, -0.03147583f, 0.06216606f, 
    0.07627989f, -0.22762258f, 0.12860847f, 0.05997563f, 0.16093570f, -0.04400608f, -0.10752946f, -0.03296415f, 
    0.04788049f, 0.06371307f, 0.09281973f, 0.04283954f, -0.17795491f, 0.01255667f, -0.07579038f, 0.05839839f, 
    -0.08969592f, 0.03066755f, -0.05732336f, -0.01072556f, -0.04198430f, 0.09202628f, 0.06125697f, 0.00562074f, 
    0.09534131f, 0.05949344f, 0.11021065f, 0.01593381f, 0.00595303f, 0.04238699f, -0.02168882f, 0.06146027f, 
    0.06215009f, 0.03055425f, 0.08268190f, 0.03003039f, -0.07273363f, -0.09192664f, -0.06783708f, -0.02071734f, 
    0.16431928f, -0.02279388f, -0.05349870f, -0.01537265f, 0.01556079f, -0.22210759f, 0.07740065f, 0.00110985f, 
    0.11354963f, -0.12197932f, 0.02948508f, -0.00733202f, 0.00307267f, 0.02732032f, 0.06736749f, -0.04555649f, 
    0.10749158f, 0.04345106f, -0.01890391f, 0.06064950f, 0.03654713f, 0.16596815f, 0.16830474f, -0.04510553f, 
    -0.04086486f, 0.06330875f, 0.01108665f, 0.01753237f, 0.07042197f, 0.02130605f, 0.11949933f, 0.13268749f, 
    -0.05988004f, -0.10185347f, -0.15272902f, -0.04156094f, -0.02613035f, 0.04920194f, 0.11301052f, 0.12433114f, 
    0.04919348f, 0.08596826f, 0.07932550f, 0.01823627f, 0.07389830f, 0.17088674f, 0.01333749f, 0.09725979f, 
    0.03214095f, 0.09040056f, 0.09182253f, 0.07433798f, -0.04736301f, 0.08499452f, 0.04151737f, 0.14365675f, 
    0.03753543f, -0.14356588f, 0.01951922f, -0.25086865f, 0.03774472f, -0.08118355f, 0.01675984f, 0.00932404f, 
    -0.01387374f, 0.02652399f, 0.04564418f, -0.03893197f, -0.22097006f, 0.03407928f, -0.00205069f, -0.13860916f, 
    -0.01711606f, -0.00855965f, 0.11017811f, 0.02288484f, 0.02095042f, 0.00274455f, 0.06809675f, -0.03092540f, 
    0.08963319f, -0.09225581f, 0.15566120f, -0.11618688f, 0.04806535f, -0.00859797f, -0.08164181f, -0.06651838f, 
    0.01952235f, 0.05978424f, 0.02055076f, 0.00141314f, 0.13059351f, -0.03258673f, 0.00149527f, -0.06134727f, 
    0.10445930f, 0.08804003f, -0.02626958f, 0.06895628f, 0.07222963f, 0.05803164f, -0.04888424f, -0.01454557f, 
    -0.07001664f, 0.01721692f, -0.11851506f, -0.08260640f, -0.03932383f, 0.08055906f, 0.03214319f, 0.13768397f, 
    0.16247778f, 0.04987119f, -0.00520753f, 0.06772000f, 0.16112001f, -0.18524913f, -0.18989801f, -0.13940862f, 
    0.04628117f, -0.02763297f, 0.04334868f, 0.10829738f, 0.07641897f, 0.02359902f, -0.00464309f, 0.06168322f, 
    -0.33194637f, 0.06527109f, -0.13620849f, 0.27338761f, 0.02350823f, -0.03180900f, -0.06688810f, 0.04904709f, 
    0.00889138f, 0.01855316f, 0.07708205f, 0.02278648f, -0.02704423f, -0.00585581f, -0.09067522f, 0.00013729f, 
    0.01079352f, 0.02041793f, -0.01900218f, 0.05529358f, 0.00563542f, -0.08724482f, -0.03746590f, -0.01905612f, 
    -0.18865375f, -0.31539243f, 0.22932512f, -0.31050923f, -0.16513753f, -0.01606483f, 0.15743281f, -0.07110793f, 
    0.06181676f, 0.10101393f, -0.00931793f, 0.11597334f, 0.22357057f, 0.10815972f, 0.13116391f, -0.01768709f, 
    0.00487844f, -0.03795307f, -0.00009598f, 0.07797352f, 0.07700875f, -0.00359126f, -0.04991011f, 0.19992106f, 
    0.01267566f, 0.23327097f, 0.00974021f, -0.00139174f, -0.08760680f, 0.04928022f, 0.01714594f, 0.00499586f, 
    0.01649332f, 0.04734769f, 0.06236348f, 0.02436563f, -0.03288357f, 0.03363127f, -0.15041547f, 0.01257314f, 
    0.10983400f, 0.00304234f, -0.15376742f, -0.11764202f, 0.09757802f, -0.00654963f, -0.08590578f, 0.06266501f, 
    -0.02247248f, -0.05809803f, 0.15185694f, -0.03654668f, 0.08036168f, -0.06617122f, 0.04649988f, -0.05915327f, 
    -0.07155512f, 0.05706503f, 0.02147438f, 0.01098278f, 0.13762265f, -0.06966537f, 0.00808463f, -0.06994378f, 
    0.01633167f, -0.01283539f, 0.16938661f, 0.02826583f, 0.00424103f, 0.07389550f, 0.06200580f, 0.07041549f, 
    -0.08194256f, 0.26994675f, -0.08654632f, 0.03801104f, 0.15597211f, 0.05562501f, -0.03654017f, 0.10123985f, 
    -0.01246736f, 0.04126118f, 0.03000463f, 0.02104409f, 0.03455148f, -0.04531169f, -0.01156720f, 0.10043462f, 
    0.03066612f, -0.06334516f, 0.06898471f, 0.11821285f, 0.05809843f, 0.01706039f, 0.02373152f, 0.03195920f, 
    -0.20046335f, -0.07277124f, -0.03622023f, 0.11123547f, 0.07315631f, 0.01508325f, -0.13956355f, -0.03571923f, 
    0.02167833f, 0.04387979f, -0.03091649f, 0.10899418f, -0.00470915f, 0.15507729f, 0.02350270f, 0.07359482f, 
    0.00610205f, 0.10729816f, 0.03837248f, 0.06214877f, -0.04708366f, 0.05780243f, 0.09636275f, 0.07361067f, 
    -0.13501953f, 0.02364584f, 0.16287956f, -0.14427693f, -0.03377862f, 0.04010963f, 0.02209181f, 0.04805226f, 
    0.04622433f, 0.04895583f, -0.00233184f, 0.03796733f, -0.13338619f, 0.10013056f, -0.14144944f, 0.06464861f, 
    -0.02217514f, 0.03550311f, 0.02611581f, 0.13863559f, 0.00412790f, 0.08575182f, 0.07598344f, 0.09595309f, 
    0.03188558f, 0.11678039f, -0.03339648f, 0.03720405f, -0.07463998f, 0.04522405f, -0.01041052f, 0.09620108f, 
    0.03548997f, 0.06670822f, 0.07721532f, 0.02392493f, 0.03104505f, -0.17657100f, 0.04610246f, -0.17389663f, 
    0.00983624f, 0.01616591f, 0.03116859f, 0.03926218f, 0.01430277f, 0.08235868f, -0.05538844f, 0.05479491f, 
    0.17382695f, 0.02147450f, 0.18237999f, 0.01481234f, 0.02003283f, -0.02746307f, 0.06788268f, 0.08784898f, 
    0.10701505f, 0.05446380f, 0.01940754f, 0.07242455f, -0.03615689f, -0.00440109f, -0.08623574f, 0.22903053f, 
    0.07267700f, -0.02635276f, 0.15121447f, -0.07400269f, 0.10349034f, -0.06317125f, 0.01463809f, 0.12204987f, 
    -0.01123462f, 0.07461334f, 0.13332802f, -0.14012997f, 0.00918152f, 0.05354153f, 0.04451260f, 0.04414709f, 
    -0.01646082f, -0.12941465f, 0.00361380f, -0.11533095f, -0.25384071f, 0.06556731f, 0.06887735f, -0.21524474f, 
    0.03952565f, 0.06708816f, 0.06765689f, 0.07128229f, -0.02180924f, -0.04657639f, -0.01832475f, -0.01265195f, 
    0.15609096f, 0.04057281f, 0.09230320f, 0.14528699f, -0.01131650f, 0.06151117f, 0.04893572f, 0.03217952f, 
    -0.05280120f, 0.08426871f, 0.02571533f, 0.12237158f, -0.09644473f, 0.04519483f, -0.02419442f, 0.00104145f, 
    0.05160601f, 0.06929280f, -0.00769153f, 0.00289397f, 0.13141789f, 0.09753641f, 0.03568297f, 0.08035897f, 
    0.11928396f, 0.19908491f, 0.06995454f, 0.19616421f, 0.06475776f, -0.04468998f, 0.04304302f, 0.00871059f, 
    0.00960107f, -0.05726423f, 0.01168033f, 0.05220280f, 0.11173715f, -0.13943288f, -0.13557102f, -0.11377230f, 
    0.08974374f, -0.01390708f, -0.12619774f, -0.01693125f, 0.07374586f, 0.01631184f, 0.00179724f, -0.03442583f, 
    0.14568587f, 0.02360621f, 0.04187297f, 0.01596497f, -0.07214458f, 0.03242603f, -0.02904585f, 0.06974551f, 
    0.07993639f, 0.00968204f, -0.02091705f, 0.07766122f, -0.14637502f, 0.13436019f, 0.06202097f, 0.25610268f, 
    0.00202474f, -0.02149146f, 0.01026466f, -0.01258004f, 0.06449454f, 0.00397690f, -0.10965107f, 0.06582981f, 
    0.23195469f, -0.01309144f, 0.14831631f, -0.06515362f, 0.10231122f, 0.00485695f, 0.04194659f, 0.07748108f, 
    0.11073551f, 0.05705449f, 0.05213736f, 0.09554573f, -0.24214408f, -0.11478597f, 0.01413795f, -0.00697001f, 
    0.10466500f, 0.09592555f, 0.06565247f, 0.00323608f, 0.02143087f, 0.08801140f, -0.00036015f, 0.13454306f, 
    -0.01313652f, -0.26597995f, 0.03702578f, -0.07049425f, 0.06739902f, -0.03619162f, 0.07876475f, 0.17058332f, 
    0.07966769f, 0.09498226f, -0.00441785f, 0.02550873f, -0.09031804f, 0.05903872f, -0.03963705f, -0.15105230f, 
    0.08406666f, 0.09823687f, 0.05159108f, 0.02206512f, -0.04009480f, -0.00021380f, -0.04212319f, -0.00420281f, 
    0.05045634f, -0.05336788f, 0.04542299f, 0.15036345f, -0.07666036f, 0.10130214f, -0.04925075f, 0.04586732f, 
    -0.02506266f, -0.06969023f, 0.09405468f, 0.03275161f, -0.22804309f, -0.04672489f, -0.05967708f, -0.02727626f, 
    -0.03400347f, 0.01738779f, -0.05908005f, 0.06577501f, 0.05803759f, 0.00890847f, 0.04993845f, 0.02721779f, 
    -0.07606744f, -0.21648489f, 0.15936404f, 0.06058676f, -0.11144373f, -0.00019193f, 0.01944628f, -0.09148204f, 
    0.06976539f, -0.09975924f, -0.04866458f, 0.13707650f, -0.06290720f, -0.20702146f, 0.01424232f, 0.07977884f, 
    0.11095221f, 0.05404465f, 0.07663903f, 0.10416491f, -0.01097675f, -0.03673792f, 0.09022824f, 0.04354889f, 
    -0.00644917f, -0.11533854f, 0.05410159f, 0.12955107f, -0.06643272f, 0.03856533f, 0.08885901f, 0.06526171f, 
    0.04113166f, 0.05079044f, 0.01004049f, 0.07479077f, -0.04266251f, 0.07518244f, 0.05755137f, -0.30984172f, 
    0.20807177f, -0.03419349f, 0.02613732f, -0.02240576f, 0.03166624f, 0.09934603f, 0.09750478f, 0.05986287f, 
    0.08610710f, 0.05906208f, -0.13316913f, 0.03565304f, -0.00610713f, 0.10798289f, 0.00924588f, -0.10279752f, 
    -0.12882139f, 0.02966882f, 0.06005629f, 0.02760844f, -0.08088773f, -0.06534842f, -0.19605339f, -0.15121530f, 
    -0.00373909f, 0.07567231f, 0.01768594f, 0.00353935f, 0.10442194f, -0.00316949f, 0.06262437f, -0.03001872f, 
    -0.08461830f, -0.10815334f, 0.01936756f, -0.04981107f, 0.08155150f, 0.05752159f, -0.05984489f, -0.00234805f, 
    0.03948837f, 0.03062116f, 0.07299857f, 0.08524775f, -0.18132421f, -0.00894789f, 0.17371978f, -0.10398698f, 
    0.08154425f, 0.07854993f, -0.04577505f, 0.07097428f, -0.10676572f, 0.00364577f, 0.03835020f, 0.12841660f, 
    0.39078504f, 0.01439275f, -0.02376135f, -0.06187620f, -0.05549082f, -0.02602293f, 0.08979713f, 0.05564765f, 
    0.04432710f, 0.09270696f, 0.10680354f, -0.07057673f, -0.03040053f, -0.20009549f, 0.05683800f, -0.14475000f, 
    -0.01940380f, -0.01412189f, 0.01050503f, 0.00425390f, 0.02154188f, -0.00963321f, 0.05165018f, 0.08341365f, 
    0.24170041f, 0.06250314f, 0.05803819f, -0.04408046f, -0.03029088f, -0.00677437f, 0.03411915f, -0.07478156f, 
    -0.15828517f, -0.07683872f, -0.07545086f, 0.03369130f, 0.38738045f, 0.12445290f, 0.18150100f, 0.17335369f, 
    -0.04875164f, 0.02979811f, -0.00711074f, 0.06139050f, -0.06047226f, 0.00150612f, 0.01579385f, -0.11449347f, 
    0.00304385f, -0.15028460f, 0.07095812f, 0.05161190f, -0.03939478f, 0.02462626f, 0.02429696f, -0.03721911f, 
    -0.00197409f, -0.07114647f, 0.15858126f, -0.03581494f, -0.08783097f, 0.22079675f, -0.00834659f, 0.09107614f, 
    0.21164213f, 0.05174357f, -0.03912246f, 0.11305374f, -0.04178147f, -0.01962140f, 0.05356246f, 0.10432999f, 
    -0.43594971f, -0.02485999f, 0.34611261f, 0.14027137f, -0.04094072f, -0.15877843f, 0.10058021f, -0.04492626f, 
    0.06151211f, 0.11901575f, -0.04904477f, 0.07453225f, -0.43039924f, -0.06985757f, 0.00889730f, -0.02519825f, 
    0.07470762f, 0.01573060f, 0.03885546f, -0.01528842f, 0.13487786f, 0.03479188f, -0.04336932f, 0.06930615f, 
    0.18739131f, -0.13071065f, -0.01098845f, -0.05683196f, -0.03258932f, 0.08707076f, 0.01503870f, -0.05399977f, 
    0.10405678f, 0.07036036f, -0.08633477f, 0.07081223f, -0.16661444f, -0.08669813f, -0.07814375f, 0.07751434f, 
    0.08181765f, 0.06119736f, 0.02730834f, -0.00694184f, 0.07092468f, -0.00158262f, 0.01343808f, 0.12513344f, 
    0.21442568f, 0.09451611f, 0.05185829f, 0.08845264f, -0.06551363f, 0.03626367f, -0.03765452f, 0.09992204f, 
    0.06473827f, -0.01664277f, 0.05346159f, -0.03910125f, -0.14120290f, -0.02973699f, -0.01528956f, 0.03802254f, 
    0.08539113f, 0.10257476f, 0.02249784f, 0.10869828f, 0.08697461f, 0.06029637f, -0.01815946f, 0.04021324f, 
    -0.01216665f, 0.01023244f, 0.09278966f, -0.04469336f, 0.02989252f, 0.04206931f, -0.08074635f, 0.01391454f, 
    0.06820296f, -0.02216116f, 0.04659005f, 0.02020500f, 0.02943439f, -0.00472783f, -0.00339043f, 0.07401089f, 
    -0.06170641f, 0.10531871f, 0.04641755f, 0.00223612f, -0.20680435f, -0.02267053f, 0.16379055f, -0.06987938f, 
    -0.21005891f, 0.14168879f, 0.01335852f, -0.00820511f, 0.17463604f, 0.16382267f, 0.01305020f, 0.04312803f, 
    0.09908104f, 0.00435949f, 0.13196544f, 0.12794675f, -0.18714999f, 0.01625879f, 0.01363443f, 0.03456961f, 
    0.02229668f, 0.08671922f, -0.01953836f, -0.01134123f, 0.01816924f, -0.00090450f, -0.03123094f, 0.03063811f, 
    -0.17173909f, -0.07222788f, -0.04408503f, -0.02595212f, 0.04048584f, 0.11401064f, 0.05733346f, 0.16043293f, 
    0.03325808f, -0.06340592f, 0.05620473f, 0.10300388f, -0.14618987f, 0.36099848f, -0.06776600f, -0.04734431f, 
    -0.04386894f, -0.02828884f, 0.05935857f, 0.05226629f, 0.02750798f, -0.04263747f, 0.02042593f, -0.05658606f, 
    -0.06787631f, -0.06972170f, 0.01419707f, -0.03899414f, 0.02750931f, 0.14107139f, 0.03838429f, 0.05047208f, 
    -0.00350814f, 0.07337637f, -0.01274973f, 0.04292389f, -0.12831625f, 0.09581026f, 0.16790625f, 0.04598802f, 
    0.10681931f, 0.05804455f, -0.02861298f, 0.04569415f, 0.06341951f, 0.08988013f, -0.03304590f, -0.01685602f, 
    0.20706876f, -0.02966552f, -0.00877151f, -0.05000474f, -0.05541787f, 0.02576842f, -0.05166835f, 0.02076072f, 
    0.03612740f, 0.06096506f, 0.04383760f, 0.17592157f, 0.02412319f, 0.05671474f, 0.12781259f, 0.10089560f, 
    0.11424923f, -0.00600228f, -0.03279689f, -0.00100341f, 0.07575104f, 0.11386995f, 0.07877085f, 0.10341042f, 
    -0.07410669f, -0.15137209f, -0.02216948f, -0.03535422f, 0.06467503f, 0.10255469f, 0.00429968f, 0.21388707f, 
    0.12470091f, 0.01615997f, 0.03566139f, -0.06130404f, -0.21146606f, -0.08152883f, -0.09167384f, 0.04108072f, 
    0.08311282f, 0.05555614f, -0.02585440f, 0.10240754f, -0.04088648f, 0.02413052f, 0.04189030f, 0.01052119f, 
    -0.43440080f, 0.04719402f, -0.07009994f, 0.07398342f, 0.01587541f, -0.03261729f, 0.09559896f, 0.00567357f, 
    0.05960143f, -0.02779238f, -0.01638144f, 0.04554826f, 0.04128613f, 0.04489426f, 0.09057672f, -0.13039571f, 
    0.17817910f, 0.03855455f, 0.15732448f, 0.19156407f, -0.03392010f, 0.01046688f, 0.03319055f, 0.00374402f, 
    0.09566301f, 0.19203998f, -0.11103249f, -0.03523387f, -0.14606835f, -0.06113696f, 0.07178639f, -0.02809893f, 
    0.03119931f, -0.01513397f, 0.05772217f, -0.00439792f, -0.09336986f, -0.07693113f, 0.18694623f, 0.16161142f, 
    -0.03823870f, 0.00215127f, 0.01040641f, -0.03354389f, 0.06011475f, -0.03293980f, -0.02094191f, 0.02521892f, 
    -0.08645449f, -0.16153333f, 0.28839600f, 0.27634576f, 0.01563656f, 0.09029174f, -0.05691107f, 0.05030374f, 
    0.01922853f, -0.04952140f, 0.03044149f, -0.03608350f, -0.47578442f, 0.20062599f, -0.07976440f, -0.08470619f, 
    0.08084792f, -0.01220489f, 0.01121736f, 0.03124023f, -0.02605177f, 0.02240480f, 0.04910589f, -0.00478002f, 
    -0.08598844f, 0.09775105f, -0.16660331f, -0.09484366f, -0.05707654f, -0.05205714f, -0.06880251f, 0.11602394f, 
    -0.07387321f, 0.02421797f, 0.00256549f, 0.06373210f, -0.20396683f, -0.04901931f, 0.01452339f, 0.01956009f, 
    0.01776839f, 0.04844305f, -0.03827054f, 0.07267477f, 0.15341847f, 0.01240592f, 0.01175729f, 0.07172014f, 
    -0.16726334f, 0.07015171f, 0.11199807f, -0.00309945f, 0.07760471f, 0.03453023f, 0.02052881f, 0.04101329f, 
    0.02389154f, -0.00500842f, 0.02145210f, -0.08089358f, -0.16848144f, -0.04664084f, -0.01937805f, 0.09618111f, 
    0.07180787f, 0.01562240f, 0.06658129f, -0.10477781f, 0.05102729f, 0.01322248f, -0.06070236f, 0.05632061f, 
    0.00994547f, -0.25504375f, 0.09685971f, 0.04355226f, -0.13026769f, -0.07933807f, -0.04810230f, 0.05876533f, 
    0.03905642f, 0.06648351f, 0.02052231f, -0.11522162f, 0.08765022f, 0.26910731f, 0.07357834f, 0.20624802f, 
    0.00800460f, -0.00411132f, 0.08786076f, 0.00996527f, 0.02622899f, -0.04890376f, 0.13021773f, -0.03047195f, 
    -0.11222898f, 0.08583877f, 0.07408503f, -0.07242619f, -0.01575805f, 0.10199813f, 0.05991590f, 0.05749516f, 
    -0.06927490f, -0.05280976f, 0.06299705f, 0.02957004f, -0.17812289f, -0.16557045f, 0.18435590f, 0.14882825f, 
    0.07842803f, 0.02895391f, -0.04472004f, 0.02318125f, 0.11553492f, 0.10554195f, 0.05838798f, 0.09450301f, 
    0.26723459f, 0.17579797f, 0.32358557f, 0.24987921f, -0.08510710f, 0.06297144f, 0.05949354f, 0.02562745f, 
    -0.04352812f, 0.12731409f, 0.12045273f, -0.06342737f, -0.13588558f, 0.04946408f, 0.02025686f, 0.01053353f, 
    0.10448837f, 0.04713017f, 0.03805721f, -0.05743861f, -0.01967212f, 0.04786201f, 0.10811052f, 0.06625974f, 
    -0.16445038f, 0.17445466f, 0.24306235f, 0.31201184f, 0.06200580f, 0.09064540f, 0.00821843f, -0.05158762f, 
    -0.02918193f, 0.01307397f, -0.11217158f, -0.00435843f, -0.29919708f, 0.08246551f, -0.06839298f, -0.25279140f, 
    -0.09167454f, -0.03046639f, -0.02349525f, 0.17346436f, -0.07625459f, -0.08183488f, 0.01547310f, -0.07603114f, 
    0.09462451f, 0.11375609f, 0.20242164f, 0.13295515f, 0.04599907f, 0.04544138f, -0.01309681f, 0.10273564f, 
    0.04265599f, -0.01161704f, -0.03405454f, 0.05736305f, -0.03607783f, 0.10298724f, 0.17758040f, -0.00067419f, 
    0.00521752f, 0.06333088f, 0.04489820f, 0.08379500f, -0.04785372f, 0.07955893f, 0.02366784f, -0.01380446f, 
    0.00071366f, -0.00903751f, 0.12051181f, 0.13444330f, -0.09233753f, 0.04256654f, -0.04652905f, -0.09803842f, 
    0.13826559f, 0.05450960f, -0.00664319f, -0.03761175f, -0.21563856f, 0.08781280f, 0.17333722f, -0.05231565f, 
    -0.05207986f, -0.06073824f, 0.05540990f, -0.06085667f, 0.08619682f, -0.01677818f, 0.03451096f, 0.03839679f, 
    -0.15190144f, -0.19109461f, 0.13043898f, 0.22594984f, -0.05569428f, 0.08488342f, 0.01884448f, 0.03988864f, 
    0.05025972f, -0.03645215f, 0.04541587f, 0.01001429f, -0.31771895f, 0.08399239f, -0.09184515f, 0.00290042f, 
    0.07312018f, 0.07773027f, 0.12368548f, 0.19127335f, 0.04107102f, -0.05252432f, -0.05896584f, 0.15554908f, 
    0.33850491f, 0.14626966f, 0.23009409f, 0.22153147f, -0.02378149f, 0.04254140f, 0.05595950f, 0.08958248f, 
    0.02023656f, -0.00410241f, 0.06935094f, 0.07146649f, 0.06637407f, -0.19918153f, 0.21367078f, 0.24908543f, 
    0.00046694f, -0.04856698f, 0.01954841f, 0.01652446f, 0.04909094f, -0.00834541f, 0.01366022f, -0.04972539f, 
    0.10657386f, -0.02752390f, 0.04222641f, -0.06795385f, 0.04901999f, 0.08773296f, -0.03293026f, -0.10954824f, 
    0.07258754f, 0.03725868f, 0.07780909f, 0.01346801f, -0.06167859f, 0.01212730f, 0.14112161f, -0.04480854f, 
    0.06373991f, 0.02895257f, 0.18159994f, 0.07559950f, -0.05001707f, 0.05120131f, -0.07142606f, -0.00522978f, 
    -0.20168401f, 0.03416267f, 0.02560696f, -0.15457129f, 0.08787973f, -0.03156899f, 0.03450374f, -0.09216914f, 
    0.13946746f, -0.05752704f, 0.18302836f, -0.03768300f, 0.23181494f, 0.02405153f, 0.03551948f, 0.17389204f, 
    -0.00311947f, -0.07746156f, 0.00723975f, 0.09861330f, -0.05258264f, 0.03660398f, 0.01309520f, -0.01904043f, 
    -0.03874362f, -0.00644526f, 0.01884918f, 0.00304497f, 0.00648436f, -0.00544871f, -0.02395008f, -0.01157472f, 
    -0.03332123f, -0.03111018f, -0.03656382f, -0.02986942f, -0.01109816f, 0.02828888f, 0.01083295f, 0.02664227f, 
    -0.02238479f, -0.02597424f, -0.02184586f, 0.00776207f, -0.03563026f, 0.02678062f, 0.00809825f, 0.00071041f, 
    0.01847950f, -0.03653431f, -0.00361769f, -0.03933177f, 0.00487146f, 0.00942603f, 0.00539013f, -0.02741233f, 
    -0.03630310f, 0.02655501f, 0.00703094f, 0.02004642f, -0.03007715f, 0.00166251f, 0.02801970f, -0.03725756f, 
    0.02500434f, 0.02075330f, 0.01978704f, -0.01922454f, -0.02297175f, -0.03749715f, 0.01197086f, -0.04286840f, 
    0.01277422f, 0.00811505f, -0.03258889f, 0.02514440f, 0.01020004f, 0.01859535f, -0.02610566f, 0.00142517f, 
    -0.03036795f, 0.01336453f, 0.00848522f, 0.01154306f, 0.00425347f, -0.01979125f, -0.00842034f, 0.02632218f, 
    0.01412071f, 0.00061429f, 0.00406598f, -0.01542972f, 0.01199090f, -0.04196353f, -0.02144184f, 0.02311847f, 
    0.01138041f, -0.01253881f, 0.02545969f, 0.00014420f, -0.01464687f, -0.02762419f, -0.03957371f, -0.01707614f, 
    0.01521532f, -0.01146518f, 0.00422627f, 0.02085223f, -0.04347789f, 0.00620225f, -0.02687934f, -0.00153480f, 
    0.01909687f, 0.02227661f, 0.00073810f, 0.01013600f, -0.01044942f, 0.02413088f, 0.02537602f, -0.02874896f, 
    0.02311225f, 0.02154420f, 0.02832953f, -0.03559245f, -0.02613708f, 0.00912393f, -0.01748233f, -0.03052345f, 
    0.01011241f, 0.02354640f, -0.03471106f, -0.00976991f, -0.00261895f, 0.02257957f, -0.02095450f, -0.00259520f, 
    0.01146019f, 0.00316409f, 0.00546338f, -0.03720081f, -0.02932547f, -0.01600286f, -0.02394858f, 0.02408421f, 
    -0.02971495f, -0.03547358f, 0.02381661f, 0.02678080f, -0.00907566f, -0.00544478f, -0.00345028f, 0.00214853f, 
    0.00260080f, 0.02044825f, -0.02479174f, -0.03165541f, 0.01087790f, -0.01570370f, -0.00063027f, 0.01845778f, 
    0.01355875f, -0.04148977f, -0.00147612f, -0.01465342f, 0.02078497f, 0.01390635f, -0.03504807f, 0.02129934f, 
    -0.03579272f, 0.00380887f, -0.01521050f, 0.02612619f, -0.02203966f, 0.02776753f, -0.03507994f, 0.00641951f, 
    0.02102084f, 0.01507909f, 0.02547546f, -0.00171599f, -0.01597240f, -0.02638150f, -0.01125721f, -0.03154733f, 
    0.00517082f, 0.01859538f, -0.03108211f, 0.00389088f, 0.01295620f, 0.00125819f, 0.01332824f, -0.01228333f, 
    -0.02630965f, -0.01883238f, 0.00367159f, -0.03534796f, 0.00668945f, -0.03847227f, 0.01930125f, -0.00713102f, 
    -0.02038707f, 0.02635668f, 0.01421511f, 0.00490898f, 0.01966781f, -0.01702767f, 0.00393485f, -0.03306551f, 
    -0.02750466f, -0.00477244f, -0.03686911f, -0.03459838f, -0.04199452f, -0.00090702f, 0.02193786f, -0.03230675f, 
    -0.04102827f, -0.03397283f, 0.02840972f, 0.01200095f, 0.01460413f, 0.02077715f, -0.03046808f, -0.03328198f, 
    -0.01172345f, 0.01477311f, 0.01336501f, 0.01097920f, 0.02302698f, -0.00223813f, 0.02368970f, -0.00599666f, 
    0.02120868f, 0.00928389f, -0.03733133f, 0.02586309f, -0.00520539f, -0.01931571f, -0.00440890f, -0.02119906f, 
    0.02552957f, 0.00212034f, -0.02520990f, -0.03283811f, -0.02970197f, 0.01867650f, 0.01816939f, -0.02658440f, 
    -0.01852070f, 0.01137033f, -0.02411807f, 0.00015206f, 0.00255268f, -0.02138648f, 0.02020287f, -0.03459972f, 
    0.01686527f, 0.02574079f, -0.01683843f, 0.01347670f, -0.01345986f, -0.03133566f, 0.00252634f, 0.02279903f, 
    -0.01207317f, 0.02019645f, -0.02278651f, -0.01274196f, -0.02591310f, -0.02379069f, -0.00174665f, 0.02179927f, 
    -0.01713249f, -0.04191964f, -0.04159676f, -0.03033980f, -0.03947899f, -0.00431206f, -0.01936745f, -0.01171647f, 
    -0.03856387f, -0.03805159f, 0.00183753f, -0.01971497f, -0.00351152f, 0.00111266f, 0.01798991f, -0.01878555f, 
    -0.03829454f, 0.00806868f, -0.03180683f, -0.00208425f, -0.00399346f, -0.03404186f, 0.00194940f, -0.02394363f, 
    -0.00169774f, -0.01636390f, -0.03360801f, -0.03153875f, 0.01778767f, -0.00376105f, -0.04231481f, 0.02650017f, 
    -0.01854717f, -0.01502430f, -0.04249933f, -0.03941957f, -0.02062479f, -0.04126922f, -0.04225802f, -0.02163495f, 
    0.01987685f, 0.00235120f, 0.00196330f, -0.02260883f, 0.02062970f, -0.02121359f, -0.00230045f, -0.02914027f, 
    0.01471797f, 0.00610070f, 0.02472444f, -0.03163771f, -0.02028355f, 0.02074511f, 0.02692508f, 0.01352847f, 
    -0.00338561f, -0.01167554f, -0.03205528f, -0.02840805f, 0.00680313f, -0.00054586f, 0.01968518f, -0.02830899f, 
    0.01576566f, -0.03031741f, 0.02370832f, 0.00309628f, -0.01541096f, -0.01809394f, -0.03670705f, -0.03395692f, 
    -0.03732026f, -0.00871105f, -0.01366983f, -0.02855303f, -0.02201108f, 0.00003267f, 0.01172008f, 0.01022416f, 
    -0.03864473f, 0.02217635f, -0.03411813f, 0.00528022f, 0.01984485f, -0.03333008f, -0.00332996f, 0.00441217f, 
    -0.00133986f, 0.00441184f, -0.03880066f, -0.04222240f, -0.02048466f, -0.00952282f, -0.01273687f, -0.03378518f, 
    0.02442309f, 0.00469515f, -0.03699382f, 0.01215342f, 0.02434779f, 0.00880300f, -0.02295301f, 0.02403997f, 
    -0.01815038f, -0.02875188f, -0.03434084f, -0.04013029f, 0.00751976f, 0.02345276f, 0.02627232f, 0.01880363f, 
    0.01182016f, 0.01785275f, -0.03871902f, -0.03162087f, -0.03467284f, 0.00022298f, 0.01925593f, -0.02782467f, 
    0.02527499f, 0.01851281f, -0.03498996f, 0.01054375f, -0.00400303f, 0.01853237f, 0.00312694f, -0.00465404f, 
    -0.02813038f, -0.03886914f, -0.02814535f, 0.00558304f, -0.00131446f, -0.01192657f, -0.00846889f, 0.01745094f, 
    0.02485898f, -0.01720757f, 0.01476637f, -0.04038137f, -0.04375555f, -0.00399475f, 0.02193890f, -0.03124313f, 
    0.00996414f, -0.01836634f, -0.02560441f, -0.01581959f, 0.01017106f, 0.01990637f, 0.01055463f, 0.00935359f, 
    0.02328540f, 0.00985316f, -0.02592769f, -0.04244260f, 0.02794720f, 0.00619563f, 0.00336696f, 0.01324216f, 
    -0.00442127f, 0.00485048f, -0.00937502f, 0.00432245f, 0.00537510f, 0.00397424f, -0.04228535f, -0.01903948f, 
    -0.00142054f, -0.02125396f, -0.02090194f, 0.01688166f, -0.02122577f, -0.01467414f, -0.01706898f, -0.01081842f, 
    -0.02480958f, -0.03640483f, -0.01841524f, -0.03734132f, -0.00671660f, -0.00689606f, 0.01584896f, -0.02854626f, 
    -0.03251574f, 0.00577629f, -0.00087626f, -0.04009276f, 0.00849140f, -0.02017524f, -0.01779112f, -0.02270127f, 
    -0.02198649f, 0.00514707f, 0.02659642f, -0.03231481f, -0.00069414f, -0.00589134f, 0.00532155f, -0.00690540f, 
    -0.03793556f, -0.01554184f, -0.03432089f, 0.02690036f, 0.00184391f, -0.02296155f, 0.01912004f, 0.00582612f, 
    -0.00195981f, 0.01520627f, -0.01796328f, -0.02939967f, 0.00769087f, -0.03621575f, 0.02084295f, 0.00823885f, 
    -0.00658767f, -0.01517443f, -0.02081256f, -0.00314754f, 0.01936329f, -0.02559233f, -0.00064542f, -0.00633045f, 
    -0.04196645f, -0.03726246f, 0.01367346f, -0.03307035f, -0.02727826f, 0.00430159f, 0.00893734f, -0.02645780f, 
    0.00911393f, -0.03364001f, 0.02387970f, 0.01053178f, -0.02105211f, 0.01224314f, 0.00352598f, -0.03173367f, 
    0.02761666f, 0.02105322f, -0.01366038f, 0.00067773f, 0.00854482f, -0.04316318f, 0.01400967f, 0.02443160f, 
    -0.01547426f, 0.00268407f, -0.04044535f, -0.02261516f, -0.04105758f, 0.01429619f, -0.02680288f, 0.00996300f, 
    0.00206119f, -0.03625972f, 0.02443879f, 0.00020484f, -0.02888665f, -0.03829087f, -0.01806737f, -0.00377877f, 
    -0.00772981f, 0.01737933f, -0.03214123f, -0.03423484f, -0.02460665f, 0.01214661f, -0.02061492f, 0.02064224f, 
    -0.03282040f, 0.01948586f, -0.00044629f, 0.02254159f, -0.00915599f, -0.00894719f, -0.00530349f, 0.02649103f, 
    0.01514179f, -0.03199627f, -0.00496578f, 0.01127298f, 0.01116103f, 0.00813626f, -0.03829752f, -0.02386908f, 
    -0.01279386f, -0.02723601f, -0.04101988f, 0.00213625f, -0.04124008f, -0.02776059f, 0.01116942f, 0.01608453f, 
    0.01747032f, 0.00889814f, -0.01739789f, -0.01618722f, 0.00929443f, -0.01282680f, -0.03160068f, -0.00983845f, 
    -0.03249414f, -0.01760163f, 0.00188555f, 0.02603382f, -0.03119691f, -0.01514225f, 0.00323942f, -0.02925950f, 
    0.00547308f, -0.03418798f, -0.02490775f, -0.01703635f, -0.01546408f, -0.02949047f, 0.00757348f, -0.03155507f, 
    0.02342211f, 0.01642280f, -0.02713205f, 0.01096262f, -0.00423070f, -0.01028662f, -0.02283116f, 0.02160881f, 
    -0.01096728f, -0.04382363f, -0.01970329f, -0.02877619f, -0.03308992f, 0.00496585f, -0.00818309f, 0.00333264f, 
    -0.02300223f, 0.01507966f, 0.00609089f, -0.01771029f, 0.00858106f, -0.01121709f, -0.03573937f, 0.00360089f, 
    -0.01240873f, 0.01872578f, 0.00483680f, -0.02857117f, 0.01022737f, 0.00281414f, 0.01547558f, -0.03610003f, 
    0.02454522f, -0.00547611f, -0.03626087f, -0.00908225f, -0.03568025f, -0.01483283f, -0.03655631f, 0.02798609f, 
    0.00870984f, -0.02009997f, 0.00574917f, 0.02470577f, -0.01149173f, -0.01393553f, 0.01935289f, 0.01975361f, 
    0.01295391f, -0.02330753f, 0.02284128f, -0.02001283f, 0.01662208f, 0.01520971f, -0.04262698f, 0.01365188f, 
    -0.02268166f, -0.03759865f, -0.02554365f, 0.01279344f, 0.02136848f, 0.00405631f, -0.02077680f, -0.03149710f, 
    -0.01391535f, 0.02029132f, 0.00874305f, -0.00169827f, -0.00722070f, -0.01374708f, -0.00049391f, -0.03702186f, 
    0.02196177f, 0.01489355f, -0.00852055f, 0.02629355f, -0.01352928f, 0.00349079f, -0.04183021f, -0.01744065f, 
    0.00318457f, -0.04065847f, -0.02504229f, -0.01792816f, -0.01698620f, 0.00950290f, 0.01546884f, 0.01074688f, 
    0.02160473f, -0.00412941f, -0.00823463f, -0.00400323f, -0.02433407f, -0.00647170f, 0.01976161f, -0.03328740f, 
    -0.00191899f, 0.00645269f, -0.01843660f, 0.02626977f, -0.00264158f, -0.01933422f, 0.00330907f, 0.00291906f, 
    -0.01753095f, -0.01378002f, 0.01563857f, 0.02406678f, 0.01143052f, -0.02086782f, -0.00522341f, -0.01383540f, 
    0.01553413f, 0.00973823f, 0.01228267f, -0.00392663f, 0.00513750f, 0.02626617f, -0.01750408f, -0.03269820f, 
    0.01740025f, -0.02680726f, -0.00841151f, 0.01542819f, -0.03731122f, -0.02907674f, -0.01420397f, 0.02148081f, 
    0.00686637f, -0.02732425f, -0.04321308f, 0.02160251f, 0.02327234f, -0.04051270f, 0.01437479f, -0.02903545f, 
    -0.02494439f, -0.00744513f, -0.00160732f, 0.00245006f, -0.02111334f, -0.03815166f, -0.00493625f, -0.02086410f, 
    -0.03771333f, -0.02559469f, 0.02490376f, 0.00032194f, 0.01837747f, -0.00510468f, -0.01828627f, 0.00324596f, 
    0.02366562f, 0.00026476f, -0.01011448f, 0.00559611f, -0.01066249f, -0.02938903f, 0.00300280f, -0.03105887f, 
    -0.02653486f, -0.03592997f, -0.04406447f, -0.03311094f, -0.02836282f, -0.00963376f, -0.00295681f, -0.03393741f, 
    0.00123123f, 0.02647915f, -0.00680908f, 0.01196723f, -0.01506502f, -0.04079401f, 0.02456821f, 0.02119253f, 
    -0.02738952f, 0.02129215f, 0.02741444f, 0.00306962f, -0.01063017f, -0.03112925f, 0.01310431f, -0.03088896f, 
    0.02465727f, -0.02880898f, 0.02345711f, -0.01083694f, -0.03034019f, -0.02824723f, -0.02470765f, -0.02521024f, 
    0.01766560f, 0.00193951f, -0.02220528f, -0.00945297f, 0.01107164f, 0.01483861f, 0.00521874f, 0.00615003f, 
    -0.01948914f, -0.00520313f, 0.00472826f, 0.01268604f, -0.04152685f, -0.02475635f, -0.01115366f, -0.03570221f, 
    -0.00407855f, -0.00333865f, -0.03598698f, 0.02412469f, -0.03621988f, -0.02877813f, 0.00478280f, -0.00946952f, 
    0.02690104f, -0.01494367f, -0.01122102f, 0.02448525f, -0.00125501f, -0.02262257f, -0.00102713f, -0.01409058f, 
    0.02669547f, -0.01284025f, -0.02965446f, 0.02933981f, 0.02951314f, -0.00819580f, 0.01319434f, 0.02594938f, 
    -0.02490132f, 0.01636105f, 0.00342257f, -0.00251675f, -0.03882479f, 0.02915265f, -0.02754610f, 0.01742723f, 
    -0.01914052f, -0.03843935f, -0.00459401f, 0.01894781f, -0.01472654f, 0.02351210f, -0.01321305f, 0.00203126f, 
    -0.01013001f, -0.02815387f, 0.02850369f, -0.02891812f, -0.03415712f, -0.00466718f, -0.02601757f, -0.02743853f, 
    0.02161103f, 0.00037163f, 0.01788617f, 0.02745881f, -0.00292819f, -0.03533485f, -0.00143807f, -0.01916769f, 
    -0.00885961f, -0.03022397f, 0.00479400f, 0.02830314f, 0.00837601f, -0.00048212f, 0.01510237f, 0.00953158f, 
    -0.02941824f, -0.01521749f, 0.00515439f, -0.01391235f, 0.00633123f, -0.03646433f, -0.00754413f, -0.02874309f, 
    0.02158039f, -0.00773851f, 0.01015487f, -0.01052500f, 0.02171938f, 0.02323836f, -0.02199943f, 0.01702304f, 
    0.01850593f, -0.00184673f, -0.01752463f, -0.01989346f, 0.02700978f, -0.02804772f, -0.00887240f, -0.00012742f, 
    -0.04100920f, 0.01765058f, 0.01226007f, 0.02974610f, -0.02251278f, -0.01311876f, 0.01521099f, -0.00773414f, 
    -0.03924529f, -0.01793301f, -0.01712729f, 0.02825710f, -0.03318692f, -0.00302977f, 0.00040845f, -0.01422558f, 
    0.01208068f, -0.00104278f, -0.00974116f, -0.00600005f, 0.00169821f, 0.02207246f, 0.02079614f, -0.01360895f, 
    0.02127217f, 0.01437649f, 0.00261163f, 0.03326623f, -0.03639756f, 0.00773915f, -0.01053669f, -0.00719371f, 
    -0.01636184f, -0.01060627f, -0.00287198f, 0.01093587f, 0.01238863f, -0.01802686f, 0.02830968f, 0.00772468f, 
    -0.02879524f, -0.00474760f, 0.02985142f, -0.00079266f, 0.00411884f, -0.01779415f, -0.01182050f, -0.00044261f, 
    -0.02113898f, -0.02038323f, -0.01867017f, -0.00587635f, -0.03573625f, -0.02160811f, 0.01907724f, 0.00722708f, 
    0.02189176f, 0.01413994f, -0.01353560f, -0.00855024f, -0.01205075f, 0.00681235f, -0.02492429f, -0.02482133f, 
    -0.00986219f, 0.02492195f, 0.01592051f, -0.03892296f, 0.00764544f, -0.04131912f, -0.01446131f, -0.01425991f, 
    -0.01943462f, 0.03113995f, 0.01326989f, -0.02749177f, -0.00047354f, 0.00708418f, 0.00357895f, -0.03715687f, 
    0.00240972f, -0.01224830f, 0.02345536f, -0.03377073f, -0.01061222f, 0.00657840f, -0.00230381f, 0.02476376f, 
    -0.04025879f, 0.02705295f, -0.00378494f, 0.03009580f, 0.00378617f, -0.02797315f, -0.03137695f, -0.00122562f, 
    0.00363212f, -0.00052049f, -0.02064570f, -0.02942173f, 0.00433874f, -0.03772304f, -0.04056184f, -0.03813354f, 
    0.00459471f, 0.01187114f, -0.03607577f, 0.00195780f, 0.02260868f, -0.00684328f, 0.02079728f, 0.02543697f, 
    -0.00488635f, 0.00040813f, -0.01359249f, -0.02894579f, -0.00252471f, -0.03248002f, -0.00310696f, -0.01663474f, 
    0.02301591f, -0.00514554f, 0.00542012f, -0.02333677f, -0.01254580f, -0.00350540f, -0.00211131f, -0.02466903f, 
    0.01463180f, -0.00369572f, -0.02355114f, -0.02456002f, 0.02224821f, -0.02080497f, -0.02795309f, -0.02954554f, 
    0.00631664f, 0.00176323f, 0.01658939f, -0.01911006f, 0.01165904f, 0.00605684f, -0.01441691f, 0.02923268f, 
    -0.01297961f, -0.02667990f, 0.02966408f, -0.02956443f, -0.00811241f, 0.02352741f, -0.02335257f, -0.03325900f, 
    0.02173738f, 0.00934655f, -0.03614172f, 0.00852825f, -0.02119075f, 0.01260875f, 0.00046346f, 0.00771155f, 
    0.02549149f, -0.00116345f, -0.00517920f, 0.02349523f, -0.03492674f, -0.00067584f, 0.02905830f, -0.03877819f, 
    0.01163473f, -0.03215479f, -0.01279853f, -0.02582169f, 0.00902826f, 0.00516772f, 0.01586460f, -0.02937008f, 
    0.01320033f, -0.00905652f, 0.02348037f, -0.00995760f, -0.02218290f, -0.02669012f, -0.01440167f, 0.01019920f, 
    -0.01678021f, -0.01208085f, -0.03749878f, 0.01149812f, 0.00072950f, 0.01705856f, -0.00202194f, -0.00935931f, 
    -0.02395264f, -0.03919329f, -0.00321179f, 0.01985058f, 0.00819860f, -0.02224287f, -0.03088174f, 0.03002505f, 
    -0.01954478f, -0.00289330f, -0.00301084f, -0.00767038f, -0.03530979f, -0.03319831f, 0.02102443f, -0.02534511f, 
    0.01236613f, 0.01575176f, 0.01762076f, 0.02928083f, -0.00563062f, -0.01072016f, 0.02105967f, 0.02824946f, 
    0.00560618f, -0.03899591f, -0.00289579f, -0.03528838f, -0.03653097f, 0.02699240f, 0.00209935f, 0.02397231f, 
    -0.02188112f, 0.02751628f, -0.00209086f, 0.01195279f, -0.01183912f, 0.02298728f, -0.01923689f, -0.01057565f, 
    -0.00539165f, 0.02079069f, -0.01626481f, 0.01565357f, -0.00314408f, -0.00864691f, -0.00403809f, -0.00951374f, 
    -0.01280193f, 0.00738559f, -0.03576132f, 0.02334162f, -0.02990053f, -0.00244896f, -0.03856058f, -0.02352467f, 
    -0.03887211f, 0.02732151f, 0.01539043f, -0.03861024f, -0.00546130f, -0.02123039f, -0.03498577f, 0.00860116f, 
    -0.03676390f, -0.02948256f, 0.02439286f, -0.01634146f, 0.02294300f, 0.02625451f, 0.00883334f, -0.00320641f, 
    -0.02774599f, -0.03322157f, -0.01346850f, -0.02295933f, 0.00101067f, 0.00227370f, 0.02812729f, -0.00310704f, 
    -0.01653888f, -0.01364587f, 0.01437196f, -0.02581281f, -0.01330249f, -0.02785936f, -0.02091739f, -0.03839666f, 
    -0.03414058f, -0.02590247f, -0.02958047f, 0.01181954f, -0.02370248f, 0.02524982f, -0.02883330f, 0.02367336f, 
    -0.00744197f, -0.03384594f, 0.02376916f, -0.01001702f, 0.02063698f, 0.00215029f, 0.02856896f, -0.03879993f, 
    0.00354856f, -0.02200931f, -0.04048099f, 0.01398030f, -0.01560733f, 0.00389608f, 0.01357676f, 0.00072601f, 
    -0.02799847f, -0.03411610f, -0.01286189f, -0.00629506f, -0.01078263f, -0.03484229f, 0.02232477f, 0.00588017f, 
    -0.03559397f, -0.00587009f, 0.01894551f, -0.02861577f, -0.02332324f, -0.04163416f, 0.02918555f, 0.03007681f, 
    0.02731593f, 0.02458493f, 0.00257345f, 0.02341823f, 0.01594451f, 0.00247242f, -0.03287981f, -0.01816301f, 
    -0.01548905f, -0.01237566f, -0.00678800f, -0.02346196f, -0.01172944f, -0.00037279f, 0.01936121f, 0.00001577f, 
    -0.01960969f, 0.00790600f, 0.01798854f, 0.00681161f, -0.00673866f, 0.00852716f, 0.02298025f, -0.00357521f, 
    0.02092886f, -0.01833428f, 0.01727406f, -0.02940867f, -0.03222853f, -0.00429539f, -0.03167718f, 0.01430326f, 
    -0.01181450f, -0.02757464f, -0.02803992f, -0.02818219f, 0.02176344f, -0.00628575f, 0.00172518f, -0.02349134f, 
    -0.03907263f, -0.01601962f, -0.00642802f, -0.01187638f, -0.00599592f, -0.02410440f, 0.02892921f, -0.00747106f, 
    -0.01746678f, -0.00563129f, -0.00717904f, 0.01437343f, -0.02513801f, 0.01479376f, 0.00746441f, 0.02483043f, 
    0.01859957f, 0.00191310f, 0.02575385f, 0.02812043f, -0.02630832f, 0.01508040f, -0.00710324f, -0.01081398f, 
    -0.00571368f, -0.02900725f, -0.03245221f, 0.00924370f, -0.00610993f, -0.00241157f, -0.03477285f, -0.04167489f, 
    -0.03286145f, 0.01953370f, -0.03329995f, -0.02266621f, -0.01226474f, 0.02736924f, -0.03348928f, -0.02928912f, 
    0.01582925f, -0.03260274f, -0.01568620f, 0.02703908f, 0.01134522f, -0.02838789f, -0.02894964f, -0.02978127f, 
    0.01267779f, -0.03194033f, 0.01040267f, -0.03603841f, 0.02264456f, 0.01670265f, 0.00873835f, 0.01326113f, 
    -0.02841249f, -0.01235730f, 0.02649044f, -0.02506111f, -0.03024418f, -0.04011828f, -0.03640900f, -0.03874258f, 
    -0.02299435f, 0.02606289f, -0.01682596f, -0.03385580f, 0.01989376f, -0.03192824f, -0.00177228f, -0.02622695f, 
    -0.02357744f, -0.04114667f, 0.00635960f, 0.00311778f, -0.00549938f, 0.00993116f, -0.02005784f, -0.01512686f, 
    -0.02054209f, 0.00053009f, -0.02498382f, 0.02767183f, -0.02442503f, 0.01860697f, -0.03635788f, -0.01045026f, 
    -0.00485317f, -0.01237384f, -0.01269975f, 0.02522943f, -0.02899720f, -0.00103748f, -0.00047034f, -0.03506277f, 
    0.00910455f, 0.01903301f, 0.01262881f, 0.02918089f, 0.00601825f, 0.00635609f, -0.03250863f, -0.01339004f, 
    -0.01077252f, -0.02022327f, 0.01557454f, -0.03935782f, -0.01096203f, -0.00540867f, -0.02579611f, -0.04150827f, 
    -0.01979842f, 0.02909114f, 0.01233924f, -0.02038077f, -0.01992892f, 0.02172730f, 0.02853668f, -0.00328406f, 
    -0.04187450f, -0.02869350f, 0.00872777f, -0.04184172f, 0.02016928f, 0.00475811f, -0.03550771f, 0.02804556f, 
    0.00070682f, 0.01634775f, -0.01107943f, 0.02157855f, -0.03371071f, -0.03990515f, -0.01990095f, 0.00740901f, 
    -0.02066991f, -0.00074568f, -0.02006103f, 0.00584947f, -0.04106288f, -0.00876104f, -0.03502910f, -0.04028269f, 
    -0.03383063f, -0.04043099f, -0.01200889f, 0.00172337f, 0.02026261f, 0.00813802f, -0.00189216f, -0.00252547f, 
    -0.03390716f, 0.00474537f, 0.02897247f, 0.01914910f, 0.00935286f, -0.00707182f, 0.00372152f, -0.00817454f, 
    0.01332388f, 0.00730917f, 0.02667034f, -0.02987958f, 0.00304912f, 0.01836412f, -0.03887673f, -0.02173815f, 
    -0.03584991f, 0.00676251f, -0.00170877f, -0.03769439f, -0.04045140f, -0.01271013f, -0.01306997f, 0.01370888f, 
    -0.01388539f, 0.02581283f, -0.00060068f, -0.01690043f, -0.00208614f, -0.00506076f, -0.01730311f, -0.02038485f, 
    -0.01727681f, -0.00192019f, -0.02546497f, -0.00210568f, -0.02456797f, 0.00726066f, 0.00996215f, -0.01381117f, 
    -0.03202911f, -0.04165133f, 0.01690130f, -0.00752671f, -0.00224465f, 0.02133869f, -0.03930577f, -0.01369884f, 
    0.02893689f, 0.01294043f, 0.00468974f, -0.03803867f, 0.01329772f, -0.01261763f, 0.02696473f, -0.02186902f, 
    -0.00897297f, 0.01977428f, -0.03582924f, 0.01109561f, -0.00246265f, -0.01456115f, -0.03981202f, -0.00881079f, 
    -0.03087726f, -0.00995185f, -0.02613888f, -0.02539287f, -0.00503626f, 0.01932458f, -0.03009744f, 0.02839763f, 
    -0.03388143f, 0.00119560f, 0.02556483f, -0.03213293f, -0.00720047f, -0.01726709f, -0.01035254f, -0.00142570f, 
    0.02621302f, -0.01991737f, 0.01743054f, 0.00485633f, 0.00553731f, -0.01799992f, -0.01732257f, 0.01793808f, 
    0.01223322f, -0.03171441f, 0.02360832f, -0.04071388f, -0.00040074f, -0.01787528f, 0.00592129f, 0.03420282f, 
    -0.03698692f, 0.01247144f, -0.03012579f, 0.00758920f, 0.02585933f, -0.01233705f, -0.01632934f, 0.02617691f, 
    0.03279183f, 0.01657125f, -0.02887133f, -0.00718634f, -0.02723703f, 0.00731280f, -0.03317404f, -0.01573616f, 
    -0.01718085f, -0.00940616f, -0.03715828f, 0.00068205f, 0.01038282f, -0.01094000f, -0.02754327f, -0.01868615f, 
    -0.02525916f, 0.00638470f, -0.02197837f, -0.01412075f, 0.01898402f, -0.04176120f, 0.02257806f, 0.00722768f, 
    -0.03062888f, -0.01657659f, -0.01205493f, -0.03077361f, 0.00370576f, 0.00614994f, 0.00290430f, 0.00493651f, 
    -0.00577881f, -0.03863934f, 0.02004095f, -0.01434197f, 0.02620102f, -0.01324124f, -0.02668623f, -0.03589762f, 
    -0.03626168f, -0.04099606f, -0.03494410f, 0.00038773f, 0.00900316f, -0.00744153f, 0.00293320f, -0.01306229f, 
    -0.00593413f, -0.04041271f, 0.00030280f, -0.03264323f, 0.02333350f, -0.03617772f, -0.03927516f, 0.00430242f, 
    0.09397469f, 0.05387967f, -0.01212849f, -0.00380227f, -0.00517839f, 0.01474104f, -0.03943089f, 0.02385976f, 
    0.00671471f, -0.03607108f, 0.00508489f, -0.10191751f, 0.35290509f, -0.11214479f, -0.13579278f, 0.12881255f, 
    0.00704302f, -0.02690689f, -0.06483265f, 0.11641748f, 0.02906265f, -0.05164156f, -0.05727853f, -0.05395272f, 
    -0.03771178f, 0.04369294f, -0.01830615f, 0.07805933f, -0.04176484f, -0.06156318f, 0.07357661f, 0.08263598f, 
    -0.08000003f, -0.02785870f, 0.12009087f, 0.00288141f, 0.06246465f, -0.04124216f, 0.01834795f, 0.12501472f, 
    0.00405811f, -0.02344621f, -0.03240994f, 0.00347640f, 0.02197794f, 0.01959862f, -0.10382903f, -0.05420021f, 
    0.22120649f, -0.05139143f, -0.06788210f, -0.06013060f, 0.02074312f, 0.10769553f, 0.08555522f, 0.05562235f, 
    -0.04161639f, 0.01155562f, 0.01054773f, 0.03229542f, -0.10147179f, 0.11003450f, -0.00432643f, 0.11549995f, 
    0.18626943f, -0.02412424f, -0.06702963f, -0.01691750f, -0.02902660f, 0.04221037f, 0.17806964f, 0.08352804f, 
    0.07536932f, -0.06030716f, 0.08477221f, -0.11875453f, 0.00136924f, -0.08138995f, 0.04502078f, 0.03462777f, 
    -0.01841773f, 0.02376948f, -0.03231024f, -0.07850194f, 0.05869735f, 0.08911666f, 0.10438006f, -0.03894133f, 
    0.02305426f, 0.05282720f, -0.06436144f, -0.06607753f, 0.07506590f, -0.10533075f, 0.16597724f, -0.03395538f, 
    -0.07423989f, 0.04887887f, -0.07631951f, 0.06705900f, -0.08358533f, 0.01335201f, -0.11521626f, 0.03849319f, 
    0.01963721f, 0.02179523f, 0.01887250f, 0.14098360f, 0.01216014f, 0.15033220f, 0.00705886f, 0.06465986f, 
    -0.12553835f, 0.11437465f, -0.07587059f, 0.08798310f, -0.06160107f, -0.06846470f, 0.03902024f, 0.12843670f, 
    0.35109195f, -0.00401587f, 0.00912427f, -0.01048070f, 0.02941666f, -0.05872469f, 0.08728636f, 0.07186819f, 
    -0.07771321f, 0.11057948f, -0.00566699f, 0.01468683f, -0.06741434f, 0.17208341f, -0.08774730f, 0.00187258f, 
    -0.06730256f, -0.04658885f, -0.03496806f, 0.10904155f, 0.02055205f, -0.07468379f, -0.05710192f, -0.03010275f, 
    0.09288585f, -0.18505333f, 0.04241870f, -0.11317672f, -0.00588858f, 0.08514950f, -0.00153918f, -0.05795838f, 
    0.03496414f, -0.01060518f, -0.21110700f, -0.01019761f, -0.01019444f, -0.06016661f, 0.07966597f, -0.17260697f, 
    0.13089085f, -0.06855247f, -0.05491224f, -0.06342396f, 0.03933795f, 0.00845564f, -0.02875263f, -0.10616109f, 
    0.08864339f, 0.16598241f, 0.12446459f, 0.04626651f, 0.10962624f, 0.01214755f, 0.10090557f, -0.06975733f, 
    0.04821701f, 0.06114216f, -0.00939929f, 0.00140235f, 0.04368949f, 0.00840010f, 0.09196193f, 0.18058278f, 
    0.00800961f, -0.03775790f, -0.00556460f, 0.03925207f, -0.03451658f, 0.02073745f, 0.09565452f, 0.13925160f, 
    0.01876309f, 0.06503959f, 0.02224243f, 0.05765804f, 0.00475535f, -0.07864338f, 0.01553325f, 0.02196359f, 
    0.00460633f, 0.00406284f, -0.02465152f, 0.05643919f, -0.43687606f, 0.10678276f, -0.08390648f, -0.08395116f, 
    0.02646621f, 0.02980951f, -0.05189747f, -0.09025987f, 0.04424919f, 0.02712272f, 0.05242154f, -0.08140546f, 
    0.20147172f, 0.10335983f, -0.09181348f, -0.09790116f, 0.02920360f, -0.00188262f, 0.05197177f, 0.11408268f, 
    0.17195679f, 0.08546989f, 0.04645881f, 0.06900334f, 0.04213982f, -0.01170534f, -0.09506096f, 0.03201066f, 
    -0.01844867f, -0.02589897f, -0.07563034f, -0.08030611f, 0.14616807f, -0.04150708f, 0.00178683f, 0.07532240f, 
    0.04321884f, -0.20609108f, 0.00717645f, -0.00187119f, -0.01588686f, -0.02701513f, 0.05866603f, 0.05523872f, 
    0.05609857f, 0.04892819f, -0.07592510f, 0.03964802f, -0.09459776f, 0.10052907f, -0.15667015f, -0.09846710f, 
    -0.04195250f, 0.00147909f, -0.00289203f, 0.15478837f, -0.00094999f, -0.04708748f, -0.00835296f, 0.02566589f, 
    0.08322342f, -0.01115143f, 0.06560194f, 0.00637697f, 0.02038774f, -0.01772001f, 0.09886801f, -0.02825910f, 
    0.01226671f, -0.06336322f, 0.07950370f, 0.03454430f, 0.08955648f, -0.07788157f, -0.06345450f, 0.08589657f, 
    -0.00823150f, 0.04370881f, -0.06844111f, 0.02550055f, 0.04405074f, -0.11529573f, 0.05645229f, -0.09352239f, 
    -0.05177790f, 0.01669592f, 0.09395050f, 0.03478516f, 0.00950420f, -0.12798329f, 0.12676607f, 0.02976561f, 
    -0.06762242f, -0.19405527f, 0.06243850f, -0.00181991f, 0.11069445f, -0.14397097f, -0.05993380f, 0.25652346f, 
    0.08356547f, 0.12451287f, -0.04649102f, 0.03118579f, -0.14802764f, 0.03200566f, 0.17439221f, 0.04791057f, 
    -0.01803085f, 0.03956776f, -0.08601336f, 0.06522235f, -0.03596738f, -0.00859265f, -0.00945137f, 0.00686079f, 
    0.04457309f, 0.09281871f, 0.12926807f, 0.10418057f, -0.02338548f, 0.04048491f, 0.08878445f, 0.07277320f, 
    -0.05730734f, 0.06075928f, 0.02034450f, 0.02849143f, 0.00799710f, 0.10069472f, -0.03042129f, 0.16236703f, 
    0.19742645f, -0.18503912f, -0.02851981f, 0.07619257f, -0.00192908f, -0.01550201f, 0.02113098f, 0.07938311f, 
    -0.09184971f, 0.11810663f, -0.09046937f, 0.01848676f, -0.09705011f, 0.12867188f, 0.04363687f, 0.13148102f, 
    0.00174555f, -0.06985990f, 0.16327667f, 0.08618546f, 0.00378224f, 0.16033709f, 0.07215758f, -0.07168952f, 
    0.12199754f, -0.11724462f, 0.02764628f, -0.17894006f, 0.00514855f, -0.05523872f, -0.08349232f, -0.02275296f, 
    -0.02220666f, -0.01020482f, 0.00623740f, 0.03162353f, -0.32644135f, 0.14377640f, -0.00462664f, -0.14325105f, 
    0.00095837f, -0.05444784f, -0.13809711f, 0.03031064f, 0.05285846f, 0.10386955f, 0.01751119f, -0.11198384f, 
    -0.02451103f, 0.08676951f, -0.00434616f, 0.04756710f, -0.03111694f, 0.17074062f, -0.01253388f, -0.02022529f, 
    0.11176559f, 0.09195990f, -0.07097885f, -0.03271935f, 0.16854593f, -0.06342490f, 0.01387165f, 0.02209982f, 
    -0.10155697f, -0.02807782f, 0.02616975f, -0.00606861f, -0.06978261f, -0.00570283f, -0.07922567f, 0.09252487f, 
    -0.10187734f, -0.01105581f, 0.07744735f, -0.15917473f, 0.08208967f, -0.05179548f, 0.01120488f, 0.04437734f, 
    -0.04388246f, -0.00527118f, -0.12016685f, -0.00560611f, 0.04960499f, 0.05367374f, 0.00580222f, 0.19366968f, 
    0.02102672f, 0.09372610f, -0.02191953f, 0.07186652f, 0.06604657f, 0.05056926f, 0.02489131f, -0.18784827f, 
    -0.03744086f, -0.02626977f, -0.03608731f, 0.20638971f, 0.12707259f, -0.10637498f, 0.04183177f, 0.01569455f, 
    -0.02006610f, 0.06618664f, -0.07074090f, 0.03374271f, 0.15973127f, -0.05664222f, -0.18923044f, 0.21448471f, 
    0.04670441f, 0.02372301f, 0.11167181f, -0.06691618f, -0.03637573f, 0.02551986f, 0.00832299f, 0.11076447f, 
    0.06114279f, -0.05177342f, -0.05538984f, 0.10700541f, -0.00645062f, 0.08888111f, -0.00160154f, 0.02631330f, 
    0.03439265f, -0.01972196f, 0.09362261f, 0.12141133f, -0.05661428f, 0.00974375f, -0.13697952f, 0.11733934f, 
    0.01617561f, -0.03236431f, -0.01834778f, -0.01054109f, 0.00614084f, -0.02887901f, 0.00470891f, -0.03668988f, 
    0.11608870f, -0.11821980f, 0.05746582f, 0.12518524f, 0.05591117f, 0.13071612f, -0.01607598f, -0.04336372f, 
    0.04791394f, -0.03302977f, -0.06129585f, -0.06931680f, 0.25027570f, 0.10655929f, -0.05534932f, 0.20055477f, 
    -0.06068527f, 0.02649311f, -0.03243608f, 0.03195748f, 0.04837166f, 0.20082082f, 0.04032120f, 0.08685113f, 
    -0.10434154f, 0.14400727f, -0.01639366f, -0.12587088f, 0.13130695f, 0.05176880f, -0.05364580f, -0.00654442f, 
    -0.06397378f, 0.12136696f, 0.06089191f, 0.00869016f, -0.00130594f, 0.03514103f, -0.13620076f, -0.01774917f, 
    -0.01424376f, 0.01443748f, -0.06251322f, -0.03524533f, 0.02747931f, -0.09741466f, 0.07916531f, 0.03864581f, 
    -0.02255284f, 0.05654816f, -0.06737342f, -0.14036922f, -0.05518488f, 0.02203423f, -0.00339683f, 0.08411724f, 
    0.03972025f, -0.01607945f, 0.00503847f, -0.01011974f, -0.24430373f, 0.04041713f, 0.05768818f, -0.12052973f, 
    0.05273129f, -0.00350409f, -0.04400354f, 0.09384402f, -0.00109886f, 0.04183542f, 0.16312242f, -0.06941655f, 
    0.07389151f, -0.15311240f, 0.04633556f, -0.01511118f, -0.06463116f, -0.05455280f, -0.01268299f, 0.01323685f, 
    -0.00224743f, -0.06832832f, 0.07125820f, 0.03356546f, 0.08718143f, 0.18223087f, 0.02761297f, -0.02540894f, 
    -0.00825596f, -0.07584098f, -0.08037567f, -0.08166635f, -0.05206443f, -0.00468079f, 0.10027234f, 0.11723924f, 
    -0.09432141f, -0.04632503f, -0.00536057f, -0.07123473f, 0.01568556f, 0.03592863f, 0.03825780f, -0.00598404f, 
    -0.02978128f, -0.02427850f, 0.04362493f, 0.05660462f, -0.22106330f, -0.02800553f, -0.01832409f, -0.01204245f, 
    -0.00046080f, -0.02440162f, 0.00601862f, -0.04060424f, 0.05980871f, 0.07864006f, -0.00677409f, -0.07303491f, 
    0.05946459f, -0.20396134f, 0.01548698f, 0.17292938f, 0.11927867f, 0.06243003f, 0.04796742f, 0.03563877f, 
    -0.08538827f, 0.09927278f, -0.04067698f, 0.02975873f, -0.02955782f, -0.12654598f, 0.05604614f, -0.00999417f, 
    0.03471048f, -0.10664340f, -0.04600007f, 0.15544182f, 0.02194838f, -0.13377853f, -0.01878195f, -0.03894893f, 
    0.13321085f, -0.13950695f, 0.01203300f, 0.12265392f, 0.07772900f, 0.02614414f, -0.06171517f, -0.05460594f, 
    0.08407697f, -0.05559138f, -0.01989312f, -0.13948837f, 0.16998340f, 0.06115706f, 0.06887884f, 0.17846523f, 
    -0.10144656f, -0.01662363f, 0.03378627f, 0.03650136f, -0.00638068f, 0.08866861f, -0.03387873f, -0.03143948f, 
    0.09096124f, -0.12935449f, -0.08374488f, 0.04989614f, -0.00696218f, -0.00306940f, -0.04811979f, -0.05638590f, 
    -0.06914388f, -0.00642859f, -0.01691904f, 0.07954173f, 0.07784630f, 0.12065003f, 0.14343290f, -0.09295943f, 
    -0.03180778f, -0.01226563f, 0.12271122f, 0.07624275f, -0.02461606f, -0.01660161f, 0.00591235f, 0.05085088f, 
    0.27385893f, -0.05296544f, -0.07414301f, -0.04236812f, 0.06017275f, 0.13139786f, 0.00035380f, 0.00484479f, 
    -0.00167857f, -0.06337547f, 0.09010682f, 0.03372282f, 0.02979669f, -0.05721724f, -0.04598945f, 0.12056135f, 
    -0.03455256f, -0.08414847f, -0.02271304f, -0.04967172f, 0.14442903f, -0.09803866f, 0.00380086f, -0.08416829f, 
    -0.03322230f, -0.09413846f, 0.09721716f, 0.07491896f, 0.09977495f, 0.03752461f, -0.01208607f, -0.07305598f, 
    0.05407100f, -0.03069778f, -0.08823719f, 0.12240522f, 0.01207146f, 0.09786398f, -0.06157468f, -0.05695541f, 
    0.04357637f, 0.06439695f, 0.00059789f, 0.10991679f, 0.10692520f, 0.08904087f, 0.00539673f, -0.02125562f, 
    0.13604778f, 0.05652411f, -0.09322450f, -0.03758765f, 0.02644873f, -0.03063984f, 0.01509257f, -0.01481547f, 
    0.06623279f, 0.01458476f, -0.04172832f, 0.09069762f, 0.11427307f, -0.12928611f, 0.04889074f, 0.07308287f, 
    0.01082248f, -0.17744529f, -0.09241149f, -0.03566198f, 0.11107644f, 0.11292858f, -0.07702059f, -0.06003379f, 
    0.24601451f, -0.03955047f, -0.00296389f, 0.03291206f, -0.01966310f, 0.00309558f, 0.02898921f, -0.00665920f, 
    -0.04443531f, -0.03084320f, -0.09901873f, -0.06956054f, 0.05454052f, -0.02584647f, -0.02121037f, 0.17248009f, 
    0.00902718f, 0.11058449f, -0.01387281f, 0.06854603f, -0.03175306f, 0.05160438f, 0.04043184f, -0.09884685f, 
    -0.03029378f, 0.01845388f, -0.03023535f, -0.02234543f, 0.02227783f, -0.04102084f, 0.00676230f, -0.02691225f, 
    -0.01120791f, -0.03944125f, -0.03533680f, 0.04072141f, -0.02276725f, -0.00960729f, -0.01862588f, 0.02693845f, 
    0.02084809f, -0.01062615f, 0.00702566f, 0.01766148f, -0.02590603f, -0.00968995f, -0.00624301f, -0.00809200f, 
    0.00849866f, -0.03171267f, -0.02362858f, 0.00160753f, -0.02086656f, 0.02518925f, 0.02435640f, -0.01805103f, 
    -0.00830876f, -0.04237450f, -0.04044133f, 0.02473473f, 0.02177588f, 0.00280759f, -0.02879686f, -0.01644864f, 
    0.00644522f, -0.03353918f, -0.03289682f, -0.03405235f, 0.02059266f, -0.01049558f, 0.02673598f, -0.00066098f, 
    0.01388051f, -0.02177515f, 0.02714614f, -0.03707458f, 0.01788214f, 0.00728632f, -0.01667573f, -0.00149091f, 
    -0.03043431f, 0.02813678f, -0.03502698f, -0.02448469f, 0.01203622f, -0.00676180f, 0.01043448f, 0.01255008f, 
    0.00997196f, 0.00378557f, -0.03997125f, 0.01985618f, 0.02063989f, -0.01433815f, -0.02474311f, -0.00338953f, 
    -0.00216568f, -0.02418198f, -0.00895125f, -0.02245218f, -0.04154133f, 0.01687285f, 0.02640730f, 0.02732790f, 
    -0.02443360f, -0.02935255f, 0.00021945f, 0.00131839f, -0.00536297f, -0.00950666f, -0.00964753f, 0.01666578f, 
    -0.04300834f, 0.00269272f, -0.01673271f, 0.00845705f, 0.01796605f, 0.01292904f, 0.01587897f, -0.00971359f, 
    -0.02593388f, 0.01667641f, -0.03547823f, -0.03642473f, -0.02951588f, -0.03953967f, 0.00638608f, -0.03207617f, 
    -0.01751846f, 0.02308347f, -0.03485114f, 0.02065315f, -0.03043800f, -0.00464630f, 0.00549740f, 0.00765082f, 
    -0.02812298f, -0.03092985f, -0.02961101f, -0.00573426f, -0.02265674f, -0.03651995f, -0.02398585f, 0.00187909f, 
    0.02598477f, -0.04228224f, -0.03874165f, 0.01964207f, -0.02205262f, -0.04165940f, -0.01478242f, -0.02621916f, 
    -0.01854961f, -0.00529558f, 0.03123370f, -0.03835363f, 0.00552504f, -0.00755229f, 0.02659829f, -0.02009079f, 
    0.01053983f, 0.00846000f, 0.00381101f, -0.01121007f, 0.00358799f, -0.00367983f, 0.02715539f, 0.01791048f, 
    0.01254377f, -0.01406340f, -0.01959973f, -0.02566337f, 0.02129997f, 0.00379190f, -0.00171808f, 0.00912574f, 
    -0.04004445f, 0.01644615f, 0.02843180f, -0.00836242f, -0.02256233f, 0.00253317f, -0.00892289f, 0.00123416f, 
    -0.01248509f, 0.02758525f, 0.00819140f, -0.01526673f, 0.01766167f, -0.03335078f, -0.02011726f, -0.01120461f, 
    0.02383002f, -0.01229688f, 0.00466379f, -0.00837260f, 0.01537335f, 0.00909585f, 0.00310771f, 0.02042834f, 
    -0.01360547f, 0.02953416f, 0.02184992f, -0.04288223f, -0.04267337f, 0.01260264f, -0.04008069f, -0.03434698f, 
    0.02725997f, -0.01954165f, -0.00290359f, -0.02900866f, -0.04296019f, 0.00354299f, -0.03682459f, 0.01615847f, 
    -0.00455108f, -0.00241373f, -0.00440535f, 0.02900922f, -0.01827452f, 0.01577380f, 0.02680974f, -0.00318546f, 
    0.00820725f, -0.03691318f, 0.00324390f, -0.02225686f, -0.01206866f, 0.00211322f, -0.00128813f, 0.00311216f, 
    0.02479223f, -0.04235832f, -0.02455979f, 0.00841608f, -0.03219056f, -0.03983974f, -0.01157203f, -0.03521493f, 
    -0.00939377f, -0.00371306f, -0.00860546f, -0.02160485f, 0.00226490f, -0.02594509f, 0.01779302f, -0.02165933f, 
    -0.04008221f, -0.01595921f, 0.00905685f, -0.02217484f, -0.02284267f, -0.02923629f, -0.02562714f, 0.00252001f, 
    0.02098808f, -0.04193977f, 0.00490705f, -0.00987807f, -0.00670289f, -0.02961975f, -0.00753874f, -0.00837408f, 
    -0.01060179f, 0.02014811f, 0.02151805f, 0.01370851f, 0.01904005f, -0.02949631f, -0.02562828f, 0.02674099f, 
    -0.01668707f, -0.03094414f, 0.00313824f, -0.01877640f, -0.02471905f, 0.02379579f, -0.02451209f, 0.00642152f, 
    0.00782686f, -0.03036854f, 0.02686318f, -0.03891940f, -0.04218525f, -0.03224139f, -0.00506258f, -0.03748440f, 
    -0.02976390f, -0.03180483f, 0.02825959f, 0.00182239f, -0.00874018f, -0.01559113f, 0.02799219f, -0.03922288f, 
    0.01364589f, -0.03094967f, -0.01690779f, -0.00833348f, 0.02917167f, 0.02634192f, -0.00453781f, 0.02152615f, 
    -0.04194728f, 0.00214886f, -0.04039104f, 0.00939543f, -0.02256675f, 0.00987531f, 0.01403695f, -0.00068663f, 
    0.00554410f, 0.01329924f, -0.03246201f, -0.00306019f, -0.01041654f, 0.02605080f, -0.00634608f, -0.03685900f, 
    -0.02049878f, 0.00896290f, -0.03092039f, -0.03995432f, 0.00653546f, 0.00332399f, 0.01229900f, -0.02582943f, 
    -0.01986565f, -0.02384860f, -0.00392657f, -0.01018239f, -0.00751174f, -0.00145909f, -0.03173831f, 0.01999171f, 
    0.01596590f, -0.03997220f, 0.02382892f, 0.01273124f, -0.00724808f, -0.01799364f, -0.01405622f, 0.02370800f, 
    -0.02863643f, 0.00845761f, -0.02599829f, -0.01623411f, 0.01714394f, -0.01402828f, 0.00167430f, -0.03311770f, 
    0.01125816f, -0.01924034f, -0.01004960f, -0.01511049f, -0.02513652f, -0.02128024f, -0.04180234f, -0.02043802f, 
    -0.00190210f, -0.01523217f, -0.03488396f, 0.00203992f, -0.02557959f, -0.02361897f, -0.01839348f, -0.01059814f, 
    0.01909303f, -0.03502766f, -0.00305932f, -0.01685836f, 0.01303710f, -0.03548502f, -0.00779447f, 0.02919031f, 
    0.03238684f, -0.03278054f, 0.00524607f, -0.02497727f, -0.03060443f, 0.01848613f, 0.03434229f, -0.00808805f, 
    -0.03319443f, 0.02182198f, -0.00703902f, 0.00341186f, -0.04054103f, 0.00248990f, 0.02969056f, -0.01372717f, 
    0.02802282f, 0.01795931f, 0.01046497f, -0.03403876f, -0.03430321f, 0.00448573f, -0.03306665f, 0.00764987f, 
    -0.00437106f, -0.02934958f, 0.02640877f, -0.01629527f, -0.02924415f, 0.00852098f, -0.04050158f, 0.00179454f, 
    -0.01847205f, 0.00531286f, -0.00787128f, -0.00092289f, -0.01716624f, -0.03163078f, -0.02443371f, 0.02248409f, 
    -0.02208044f, -0.00108125f, 0.00005301f, -0.02025496f, 0.02332961f, -0.02752510f, 0.00561413f, -0.02168337f, 
    0.00688625f, -0.03269463f, -0.04151436f, 0.00819695f, 0.00120402f, -0.03702451f, 0.01643413f, 0.01570028f, 
    -0.03122850f, -0.00913617f, -0.00771625f, 0.00314413f, 0.01614651f, -0.01441052f, -0.01248180f, -0.03698620f, 
    -0.02295810f, 0.03501641f, -0.02451445f, -0.01146233f, -0.03252099f, 0.01556117f, -0.01744733f, -0.02106165f, 
    -0.03756965f, -0.02310753f, 0.02769320f, 0.00274875f, 0.00761922f, 0.02322432f, -0.02028709f, 0.01025671f, 
    0.00549310f, -0.03454921f, 0.02642203f, -0.01378342f, -0.02979046f, -0.00951979f, -0.03076990f, -0.01719027f, 
    -0.02196216f, 0.00025063f, -0.00228187f, -0.02213575f, -0.03655249f, -0.01663959f, -0.00623760f, 0.00403977f, 
    -0.01966506f, 0.01446738f, 0.01732020f, 0.02104003f, 0.02879652f, 0.02808129f, -0.00142161f, -0.03413621f, 
    -0.01598451f, -0.01898241f, -0.03630460f, 0.00638112f, -0.01134283f, -0.03836596f, 0.00157274f, -0.03665492f, 
    -0.02910696f, -0.01845676f, 0.01955764f, -0.01828998f, -0.02009173f, -0.03222761f, 0.01566869f, 0.02610731f, 
    -0.02518710f, 0.02093364f, -0.01266114f, 0.01254613f, -0.00492405f, -0.02482258f, -0.03332549f, 0.02029698f, 
    0.02334417f, -0.02221453f, -0.02996564f, -0.03685696f, 0.01744900f, 0.02397376f, 0.02348705f, -0.03288162f, 
    -0.02570045f, -0.01081194f, -0.02353202f, -0.02017886f, -0.03018605f, -0.03619132f, -0.00383357f, -0.01502859f, 
    -0.03546723f, 0.00634020f, 0.02064529f, 0.03302137f, 0.02791082f, -0.01812846f, 0.02632706f, -0.00129088f, 
    0.01132935f, 0.00679480f, -0.02727372f, -0.02303982f, 0.02370453f, -0.02652671f, -0.03205047f, 0.00600020f, 
    -0.01466927f, -0.01489349f, -0.02381547f, -0.00126855f, 0.00987525f, -0.01199799f, -0.02510458f, 0.00054741f, 
    -0.03223520f, 0.01789244f, 0.00365832f, 0.02532988f, -0.01294958f, 0.02427829f, 0.01175763f, -0.01574538f, 
    -0.02218673f, -0.02141863f, -0.03175325f, -0.00977189f, 0.02078543f, -0.03041576f, -0.01594228f, 0.02090853f, 
    0.02563261f, -0.01811634f, -0.00964470f, 0.01044874f, -0.00105517f, -0.03219293f, 0.02774161f, 0.01793207f, 
    -0.00046599f, -0.00512953f, -0.01183189f, 0.00152604f, 0.00776580f, -0.02168422f, -0.02109288f, -0.02799497f, 
    -0.03954766f, -0.03451271f, 0.02462585f, 0.01124006f, 0.00702762f, 0.01419977f, 0.01923285f, -0.01601005f, 
    0.02595311f, 0.01387664f, -0.01535358f, -0.00125749f, -0.03221731f, -0.03047212f, -0.01256084f, 0.01649251f, 
    0.01987711f, 0.01030308f, 0.00668415f, -0.01761254f, -0.01143449f, 0.01845571f, 0.02665029f, 0.02588684f, 
    0.02608787f, 0.02454022f, -0.00834995f, -0.02117929f, -0.01251774f, -0.00419205f, 0.01662222f, -0.00845313f, 
    -0.00487339f, 0.02504969f, -0.02390921f, -0.02171842f, -0.02923805f, 0.00829038f, -0.03033006f, 0.00256691f, 
    -0.03533961f, 0.01838059f, 0.02173779f, 0.01341303f, 0.02377093f, -0.01871897f, -0.03601328f, 0.00764380f, 
    -0.03728675f, -0.01232708f, 0.02031522f, 0.00332965f, -0.01698592f, -0.02096506f, 0.00742786f, 0.00355768f, 
    0.02626175f, -0.04259042f, 0.02660489f, -0.00273436f, -0.02595646f, 0.02133669f, -0.01481641f, 0.01314500f, 
    -0.03129942f, -0.01480546f, -0.00112962f, -0.01469960f, -0.00968135f, -0.00848685f, 0.00342885f, 0.02694760f, 
    -0.01148273f, -0.02786860f, 0.00881750f, -0.02578688f, -0.02281537f, -0.03157807f, 0.02580489f, -0.00415601f, 
    0.02464465f, 0.01895984f, -0.00618838f, -0.02490737f, -0.03424887f, -0.02089908f, -0.03364068f, 0.02890303f, 
    0.03287945f, 0.01805255f, 0.00040122f, 0.00610132f, -0.00836725f, -0.01999327f, -0.01526047f, -0.03794666f, 
    -0.00118738f, 0.02493162f, -0.03071467f, 0.00857446f, -0.00815534f, -0.00366240f, 0.02979431f, 0.01343464f, 
    -0.03898161f, -0.02192698f, -0.03545856f, -0.03611752f, -0.04289603f, 0.02293946f, -0.01093160f, -0.00654861f, 
    -0.02243448f, -0.03958109f, -0.03795485f, 0.00057818f, -0.01422842f, -0.01054164f, -0.01444937f, -0.01470666f, 
    0.01878886f, -0.00710217f, 0.00219481f, -0.01614801f, -0.02641937f, 0.02577414f, -0.01606659f, -0.01999105f, 
    0.02424517f, 0.02153336f, -0.01327611f, -0.04186116f, -0.02054431f, -0.03243503f, 0.01576569f, 0.00986425f, 
    0.00842832f, 0.00689182f, -0.03908999f, -0.03949912f, -0.03367061f, 0.00818083f, 0.01712395f, -0.01387319f, 
    0.00280990f, -0.02526183f, -0.01845483f, 0.03216756f, -0.02662397f, 0.01472207f, -0.01521730f, 0.01694008f, 
    -0.01835697f, -0.00145661f, 0.02184027f, -0.02028298f, -0.01714361f, -0.04005248f, 0.01293594f, 0.01869029f, 
    -0.03464033f, 0.00004545f, -0.03156133f, -0.03913128f, 0.02526541f, -0.01381448f, -0.01140168f, -0.00008109f, 
    0.02128098f, -0.04143817f, -0.04188533f, -0.00812513f, 0.02630916f, -0.02451828f, -0.03947446f, -0.02532555f, 
    0.00479194f, 0.02201953f, 0.02595627f, 0.01680525f, -0.03430722f, -0.02291132f, -0.00989472f, 0.02309180f, 
    -0.00452377f, 0.01184362f, 0.03496546f, 0.00644059f, 0.02060278f, 0.02381000f, -0.00571406f, 0.01453975f, 
    -0.00526497f, 0.02493113f, -0.00310450f, 0.01933791f, 0.02809289f, -0.03906925f, -0.03627891f, 0.02915692f, 
    -0.04147384f, 0.01698039f, -0.00870542f, -0.01427575f, 0.00841391f, -0.02602442f, 0.00146228f, -0.02484389f, 
    -0.01484141f, -0.01154140f, -0.03001769f, -0.01683502f, -0.00727906f, 0.02041539f, -0.04280000f, 0.02728140f, 
    0.14981432f, 0.13249137f, -0.03711740f, -0.04353359f, -0.01758112f, -0.03500422f, 0.05777194f, 0.00253330f, 
    0.02887948f, 0.02815911f, -0.00375942f, 0.00908258f, 0.02441185f, 0.01387711f, -0.01734485f, 0.08321290f, 
    0.12892359f, -0.04205378f, -0.01168672f, 0.02479817f, 0.03081117f, 0.05367583f, 0.02344092f, 0.04443935f, 
    -0.08357206f, -0.04172916f, -0.07864054f, -0.02860701f, 0.06060537f, 0.09823035f, 0.08569041f, 0.03164518f, 
    0.10317918f, 0.07200886f, 0.04362942f, -0.09089232f, -0.12476055f, 0.11338587f, -0.05205342f, -0.13945818f, 
    -0.10966760f, -0.04567845f, -0.04176484f, 0.01136288f, 0.07448608f, 0.09702489f, -0.04020022f, 0.03857627f, 
    0.25213924f, 0.09857736f, -0.13525535f, -0.09889463f, -0.01200703f, -0.03566625f, -0.04203041f, 0.08667021f, 
    0.06176087f, -0.02711535f, -0.04749659f, 0.00864601f, -0.22471148f, -0.03206008f, 0.09505016f, 0.19544671f, 
    -0.06889509f, 0.06928806f, -0.10688715f, 0.08957168f, -0.03902160f, -0.02498771f, -0.00543626f, 0.02517254f, 
    0.13132253f, -0.09468233f, -0.06344899f, 0.02406739f, 0.15502800f, -0.07096569f, -0.06890348f, 0.14072524f, 
    -0.05030404f, 0.11523981f, -0.02392840f, 0.05085046f, -0.03014895f, 0.05011382f, -0.09577110f, -0.05357744f, 
    -0.00896743f, 0.03590640f, 0.00889821f, -0.07472146f, -0.08526637f, -0.08609223f, 0.04168963f, -0.06071072f, 
    -0.22859116f, 0.04048788f, -0.01520568f, -0.05638596f, 0.01166684f, 0.00768427f, -0.00403281f, 0.02486644f, 
    -0.02108706f, 0.02383121f, -0.03209608f, 0.02429922f, -0.17299707f, -0.02167476f, 0.03147895f, -0.01370319f, 
    -0.01690734f, -0.03525100f, -0.01023288f, -0.01630271f, 0.09090342f, 0.07306246f, 0.02276527f, -0.02127315f, 
    0.03841000f, 0.09229317f, -0.10061190f, -0.16084169f, 0.09078395f, -0.08775773f, -0.06315424f, 0.07031290f, 
    0.05605946f, 0.06771781f, -0.06768698f, 0.04366526f, -0.07250266f, 0.14319463f, -0.04455384f, 0.06112175f, 
    -0.02352902f, 0.04816821f, 0.01008023f, 0.00274245f, 0.00820110f, 0.01275108f, -0.05316749f, -0.00436205f, 
    0.05508149f, 0.05733841f, -0.03210075f, 0.11950464f, 0.03293333f, 0.04914011f, 0.04361080f, 0.03620882f, 
    0.10134374f, 0.10232867f, 0.03291484f, -0.05741106f, 0.11103338f, -0.06864251f, -0.03680952f, 0.16897151f, 
    0.09476466f, -0.09676688f, 0.02714222f, 0.02631682f, 0.07003706f, 0.00912180f, 0.07481588f, 0.13556527f, 
    -0.11839843f, 0.09289391f, -0.05371040f, -0.14206524f, -0.02431435f, 0.01125365f, 0.04548202f, -0.03501922f, 
    0.02166430f, 0.03935700f, -0.10033660f, 0.09554998f, -0.07543156f, 0.03144529f, -0.02355506f, 0.24735083f, 
    -0.03416206f, 0.09545912f, 0.09586892f, -0.04129451f, 0.07360994f, -0.00693136f, 0.06938044f, 0.04318302f, 
    0.21153668f, 0.14984469f, -0.28883377f, 0.19424339f, 0.11797415f, 0.07376651f, 0.00016058f, 0.06283843f, 
    0.01812468f, 0.11959859f, 0.06964336f, -0.02627484f, 0.18324836f, 0.15172997f, 0.05119848f, -0.07321160f, 
    0.00290406f, 0.02458030f, -0.06106858f, 0.05578629f, -0.11234187f, 0.00420306f, -0.04921955f, -0.02225428f, 
    -0.04861390f, -0.13450453f, -0.01688698f, -0.05546942f, 0.01865146f, -0.08404309f, 0.03087693f, 0.10293593f, 
    0.09978922f, 0.01240294f, 0.02766673f, 0.09131774f, -0.06216824f, 0.01884749f, 0.09665907f, -0.02888024f, 
    -0.09612386f, -0.00288407f, -0.08809367f, 0.11397725f, 0.04753986f, 0.00513126f, 0.02028884f, -0.05047645f, 
    0.05928748f, -0.02723605f, -0.07889980f, -0.19859558f, 0.11653635f, -0.12429191f, -0.02977324f, 0.03437003f, 
    0.07548932f, 0.03808586f, -0.06079661f, 0.08836575f, 0.05441884f, 0.14661689f, -0.10913149f, -0.05231970f, 
    -0.06355843f, -0.02840264f, -0.02408008f, -0.05336395f, 0.01388927f, -0.02427815f, 0.00255834f, 0.09919576f, 
    0.25637260f, 0.10653239f, -0.12029755f, -0.05046687f, 0.00559834f, 0.00400131f, 0.00072533f, -0.05910999f, 
    -0.09729110f, 0.07547940f, 0.06863075f, 0.05664378f, 0.07285540f, -0.03994255f, -0.12310056f, 0.13624497f, 
    0.07739551f, -0.04197872f, -0.08706778f, 0.06175157f, 0.17711219f, -0.01146829f, -0.00208345f, 0.06549735f, 
    0.30001304f, -0.16093987f, -0.04654533f, -0.03570409f, -0.19039747f, -0.07604255f, -0.00808717f, -0.03803886f, 
    0.06346130f, -0.12911122f, -0.03985688f, -0.00359885f, 0.33096194f, -0.05067249f, -0.02389604f, 0.20557857f, 
    -0.03425227f, -0.00200412f, 0.03789486f, -0.05904629f, 0.00825730f, -0.00761953f, -0.00162544f, 0.00084530f, 
    0.00243889f, 0.01322521f, -0.02011932f, -0.13972279f, -0.05543070f, -0.08034541f, -0.00145906f, -0.08238164f, 
    0.07649726f, 0.03551157f, 0.11315137f, -0.05633670f, 0.00580082f, -0.16232570f, 0.18265887f, 0.17933157f, 
    -0.10442579f, -0.01614984f, 0.03170425f, -0.05981502f, -0.02902001f, 0.06773435f, -0.02229234f, 0.02098521f, 
    -0.03213291f, 0.21691945f, -0.13811691f, -0.10163212f, -0.02462563f, -0.06854886f, 0.08647790f, -0.02631171f, 
    -0.03719225f, 0.05749018f, 0.00118877f, -0.01660700f, -0.09083058f, 0.18942982f, -0.06241529f, -0.07791431f, 
    0.02733171f, 0.00781799f, -0.00861189f, -0.05991834f, 0.00626566f, 0.04683503f, 0.07430480f, 0.08121645f, 
    0.19209583f, 0.22915848f, -0.08517898f, -0.14083080f, -0.01129268f, 0.04806194f, -0.01430837f, -0.07774300f, 
    -0.10378352f, 0.07541270f, -0.08552657f, 0.02394297f, -0.04360730f, 0.06779505f, -0.00286909f, -0.05048453f, 
    -0.07092222f, 0.04508385f, 0.00326374f, 0.05768104f, 0.00828924f, -0.01723747f, -0.04557141f, -0.09572896f, 
    -0.12489459f, 0.15569364f, -0.09846427f, -0.20252661f, -0.06561737f, 0.02819552f, -0.00776119f, -0.09796648f, 
    0.01354092f, -0.01261503f, -0.01013256f, 0.07311784f, -0.02224784f, 0.09363265f, -0.01941108f, -0.01030028f, 
    -0.02887991f, -0.01239495f, 0.04168584f, 0.01939817f, 0.02364362f, -0.01887794f, -0.07450301f, 0.09739995f, 
    -0.11281230f, 0.16291912f, 0.07806145f, 0.11081544f, 0.00435909f, -0.00570633f, -0.03677473f, -0.06344390f, 
    0.02852028f, 0.10085592f, 0.03466828f, 0.02080686f, -0.21540280f, 0.02086087f, -0.12068613f, -0.00186523f, 
    -0.02861122f, 0.01947025f, -0.01113832f, -0.09533533f, 0.01038134f, 0.00798917f, -0.05561053f, 0.03005343f, 
    0.07648820f, -0.02817464f, 0.07441030f, 0.09740206f, 0.12896089f, -0.03074354f, -0.02769032f, 0.01260490f, 
    0.14249024f, 0.04651122f, 0.01504249f, 0.04274552f, 0.26023045f, 0.08598971f, -0.13719197f, 0.17071815f, 
    0.01727192f, 0.01092096f, 0.08748776f, 0.03634202f, 0.08182324f, 0.01942972f, -0.03805996f, -0.06528409f, 
    0.29978999f, 0.24157640f, -0.19728686f, -0.04481623f, -0.01240598f, -0.05470789f, 0.05408684f, 0.00781653f, 
    0.08476825f, 0.01829099f, -0.02157571f, 0.07951857f, -0.05361526f, -0.10652753f, 0.03435522f, 0.06639160f, 
    -0.03181017f, -0.02059072f, 0.05346559f, 0.06835741f, 0.10404236f, -0.02494465f, -0.06235087f, 0.03925713f, 
    0.29184118f, -0.27107957f, 0.21348064f, 0.15359546f, -0.05918149f, 0.00307161f, -0.06812962f, -0.13474597f, 
    0.06203284f, -0.01267459f, 0.11061490f, -0.02538528f, -0.07473578f, 0.02670148f, 0.08901025f, -0.11719736f, 
    -0.01688237f, -0.07324455f, 0.04107164f, 0.02016392f, -0.04918229f, 0.02133637f, 0.02944216f, -0.01393007f, 
    -0.14662114f, -0.02364789f, 0.06825033f, 0.10588792f, 0.00037207f, -0.00721980f, 0.04974186f, -0.00261006f, 
    -0.05952972f, -0.02093343f, 0.07474163f, 0.01754377f, -0.06881718f, -0.01176648f, 0.05748196f, 0.01940036f, 
    -0.04380241f, -0.05650826f, 0.01390857f, 0.06743713f, -0.11863953f, 0.01809882f, 0.06336888f, 0.06720459f, 
    0.03840185f, -0.00870149f, -0.06998086f, 0.11546362f, 0.10037802f, 0.01802607f, 0.01078096f, -0.00341810f, 
    -0.02259074f, -0.00896269f, -0.09276734f, 0.08862460f, -0.07888201f, -0.07504264f, -0.02397803f, 0.07103162f, 
    -0.00566531f, 0.01503306f, -0.01993968f, 0.06493337f, -0.01539255f, -0.02592870f, 0.02125647f, -0.07779451f, 
    0.29004183f, 0.13141967f, -0.21372418f, 0.01140719f, 0.00946702f, -0.04233515f, 0.01705824f, 0.00470268f, 
    -0.01030617f, -0.00927818f, 0.04131183f, 0.10830535f, -0.35148939f, 0.12914160f, -0.03308240f, -0.08585529f, 
    -0.01738675f, -0.03796738f, 0.04846122f, 0.02825975f, -0.04235761f, -0.03958361f, -0.04258674f, 0.00352209f, 
    0.02438606f, 0.10673871f, -0.02091612f, 0.09879909f, 0.10948129f, 0.00903983f, -0.04290132f, 0.03562305f, 
    0.07125213f, -0.06263319f, 0.04292904f, 0.02032973f, 0.00182956f, -0.11830097f, 0.04884490f, -0.01468142f, 
    -0.05190915f, 0.00613152f, 0.05565178f, 0.05075807f, -0.03976080f, -0.00475850f, 0.00295919f, 0.00715708f, 
    0.40450239f, -0.30919281f, 0.01108949f, 0.38721904f, -0.06336247f, -0.00181102f, -0.03335452f, 0.01908942f, 
    0.10514397f, 0.12964155f, 0.05448107f, 0.04459471f, 0.28364563f, -0.15816879f, 0.00910178f, 0.14227864f, 
    0.09406729f, 0.01750063f, -0.00223694f, -0.01157326f, -0.01777406f, 0.05347642f, 0.04872029f, -0.07658992f, 
    0.21066615f, -0.09122360f, -0.05293631f, -0.08331574f, -0.09642585f, -0.07537445f, 0.09034961f, 0.04492301f, 
    -0.07079432f, -0.01383496f, -0.03606994f, 0.10476416f, 0.20393632f, 0.17758253f, -0.15540002f, 0.03762384f, 
    0.04458126f, -0.02565316f, 0.00678759f, -0.06442703f, 0.04028150f, -0.00550988f, 0.00795046f, -0.02934882f, 
    0.20440784f, -0.00630396f, -0.22079657f, 0.21083747f, 0.07617009f, -0.00659162f, 0.13291505f, 0.00977006f, 
    -0.01878902f, -0.02175698f, 0.00127868f, -0.05087387f, 0.23141941f, 0.17166352f, -0.21027194f, 0.05743033f, 
    0.12382653f, -0.02279988f, 0.04336111f, 0.06116880f, -0.11584208f, 0.04365206f, -0.00495600f, -0.06464824f, 
    0.34724811f, 0.01790334f, -0.17594425f, 0.06957951f, -0.05358800f, -0.08965431f, -0.00189238f, 0.01534648f, 
    0.06501826f, 0.03998506f, 0.13483563f, 0.01998006f, 0.20991714f, -0.04828311f, 0.08578472f, -0.05113548f, 
    -0.01712630f, -0.02149500f, 0.03130449f, -0.16458929f, -0.00683831f, -0.08653019f, -0.02778487f, 0.03265369f, 
    0.31064644f, -0.30700245f, 0.05323566f, 0.25905606f, 0.07854649f, -0.00656293f, -0.02798687f, 0.00636111f, 
    0.10389638f, -0.02558299f, -0.01981129f, 0.00522851f, -0.14128900f, -0.08948367f, -0.04788392f, 0.10064458f, 
    0.03418132f, 0.01659698f, 0.04293875f, -0.01436000f, 0.02193191f, -0.02389665f, 0.01312232f, 0.04340266f, 
    0.06774115f, 0.04706601f, -0.00484038f, -0.01788817f, 0.01087823f, 0.00950810f, 0.05957123f, 0.05651866f, 
    -0.09893852f, 0.04991543f, 0.00716331f, -0.00624263f, -0.01954784f, -0.05739429f, -0.05220504f, -0.23069628f, 
    -0.15720233f, 0.00123512f, 0.08365997f, -0.02747963f, -0.01724942f, 0.02033814f, -0.00393016f, 0.05702532f, 
    0.21378128f, -0.26860976f, 0.05930455f, 0.06078193f, -0.02025279f, -0.01438835f, 0.01337636f, -0.05025769f, 
    -0.12352838f, 0.03327103f, -0.05009234f, 0.05452989f, 0.00054188f, -0.14331177f, 0.07465254f, -0.06681038f, 
    0.01550040f, 0.05199002f, -0.01968284f, 0.00204698f, 0.02429213f, 0.00424269f, 0.03532903f, 0.03572711f, 
    0.04006528f, 0.17398949f, 0.15207762f, -0.10632569f, 0.06426877f, 0.01872640f, 0.06227716f, 0.13220425f, 
    0.13619184f, 0.06372746f, -0.05121758f, -0.03406062f, -0.03667317f, -0.07948107f, 0.03209464f, 0.01234863f, 
    0.12923142f, 0.03681039f, 0.02013209f, -0.02474085f, 0.01631419f, 0.01523040f, 0.02609085f, -0.02495507f, 
    -0.04333015f, 0.11190914f, 0.02437253f, 0.05939477f, 0.04863191f, -0.03479079f, 0.02136326f, 0.02190548f, 
    0.03399294f, -0.10137483f, -0.00534505f, 0.08207127f, -0.10296734f, -0.01836889f, -0.08546364f, 0.09428219f, 
    0.08797333f, -0.00482599f, -0.01375394f, -0.09807955f, 0.10108525f, 0.05568299f, 0.07856177f, 0.07120507f, 
    0.19729449f, 0.14390729f, 0.07187685f, 0.20823199f, -0.01412640f, -0.04660559f, 0.03022509f, 0.04726761f, 
    0.05034888f, 0.05390665f, 0.04341564f, 0.12844731f, 0.10266571f, 0.00891841f, 0.13958086f, 0.38026619f, 
    0.02043062f, 0.06197358f, 0.06103713f, -0.02345316f, 0.04287301f, 0.01331423f, 0.01073894f, -0.05949052f, 
    -0.09678102f, 0.01495092f, -0.02367093f, -0.00625962f, -0.03123807f, 0.06797171f, -0.05203521f, 0.02956937f, 
    0.00086112f, 0.00743204f, -0.01566434f, 0.02783745f, 0.09508468f, -0.07323767f, -0.02633607f, 0.07975406f, 
    0.12176787f, 0.02816317f, 0.06415227f, 0.05034061f, 0.19417170f, 0.05303071f, 0.05857561f, 0.06613443f, 
    0.03255130f, -0.07896274f, 0.18386663f, 0.03774657f, 0.04756103f, 0.10605501f, -0.02466780f, 0.03288655f, 
    0.01259139f, -0.00898928f, 0.05979845f, -0.01532596f, 0.05770308f, 0.03008779f, 0.09144357f, 0.07346330f, 
    0.06095577f, 0.03318401f, -0.02290914f, 0.09038307f, -0.03472665f, -0.05323723f, 0.05700735f, 0.02171365f, 
    0.29797676f, 0.08822141f, -0.13756028f, 0.38107941f, 0.11292554f, 0.04240191f, -0.05466888f, -0.04393478f, 
    0.02229331f, 0.02922989f, 0.08683768f, -0.03849815f, 0.11076580f, -0.04725004f, 0.05866686f, 0.06327898f, 
    0.03419837f, -0.01970345f, 0.02012116f, 0.11302996f, 0.03695291f, -0.11609641f, -0.00761101f, -0.01706492f, 
    -0.05407828f, 0.00784409f, 0.12098754f, -0.19873817f, 0.08185825f, 0.06288555f, -0.02755451f, -0.04137949f, 
    -0.04034938f, 0.01795484f, 0.08682348f, -0.03750506f, -0.26266047f, 0.16635208f, 0.19176215f, -0.29672226f, 
    0.01995458f, 0.00952250f, 0.03557782f, 0.05421500f, 0.02863311f, -0.08131979f, -0.00902854f, 0.05611063f, 
    0.14845411f, 0.17683238f, 0.02110394f, -0.05635351f, 0.11059826f, -0.01967407f, 0.03906811f, 0.04245640f, 
    -0.01555897f, 0.01642597f, -0.07043145f, 0.03953539f, 0.18781459f, -0.13201495f, 0.26968819f, 0.06240402f, 
    -0.04319052f, -0.00336885f, 0.02733762f, -0.06075794f, 0.04955085f, 0.01163298f, 0.07062826f, 0.02298005f, 
    0.25858575f, 0.00472699f, 0.18553616f, -0.11255221f, -0.10128091f, -0.00782851f, 0.04311674f, 0.06722886f, 
    -0.06578215f, -0.00388726f, 0.05722222f, 0.01569591f, -0.39417559f, -0.14102185f, -0.10673150f, 0.03845865f, 
    0.05206927f, 0.16518804f, 0.10330676f, -0.07431524f, -0.07245190f, 0.05775746f, 0.01193713f, 0.06524432f, 
    0.14324987f, 0.10082375f, 0.05252080f, -0.01444389f, 0.09847452f, -0.01566279f, 0.02818725f, 0.07984313f, 
    0.00080960f, 0.01886640f, 0.10296785f, -0.06616326f, -0.24780136f, -0.14302611f, -0.11505834f, -0.06345629f, 
    0.14513081f, 0.09148275f, 0.02345395f, -0.14212652f, 0.02457046f, 0.01007299f, 0.00244302f, -0.05066425f, 
    0.17585252f, -0.01054400f, -0.00013831f, 0.12740558f, 0.06694116f, 0.05942430f, 0.06525140f, -0.04612279f, 
    -0.01989781f, -0.03304243f, -0.02543521f, 0.07832453f, 0.24219623f, 0.04493609f, 0.21531035f, -0.14357221f, 
    0.06758144f, 0.01716000f, 0.06789340f, 0.11903308f, 0.01541633f, -0.04622488f, 0.07661490f, 0.01445894f, 
    0.09448986f, 0.06938795f, 0.04557592f, 0.16622783f, -0.00698121f, 0.04158716f, 0.01240879f, 0.00104327f, 
    0.05538858f, -0.06917960f, -0.08415429f, -0.08628069f, -0.02036123f, -0.00100754f, 0.13747403f, -0.18604374f, 
    -0.00535915f, 0.08429615f, 0.04037584f, -0.05072972f, 0.08245266f, 0.12418929f, 0.09659342f, 0.07306279f, 
    -0.00773260f, 0.04234469f, -0.13996224f, 0.05577930f, -0.06885269f, 0.00981959f, 0.05031822f, -0.03806562f, 
    -0.00721546f, -0.01830111f, -0.07181676f, -0.04709022f, 0.23067859f, 0.10685263f, 0.01514552f, 0.10542110f, 
    0.01436273f, 0.04395131f, 0.01936721f, 0.02672192f, -0.01261920f, -0.00954044f, -0.03150807f, -0.09387304f, 
    0.01498662f, 0.11233072f, 0.07194721f, 0.17730036f, 0.08796722f, 0.05766064f, 0.01684893f, -0.03871039f, 
    0.06099354f, 0.08005203f, 0.08316655f, 0.07645900f, 0.03359875f, -0.06560241f, 0.02436167f, -0.00411913f, 
    0.02348058f, 0.05006322f, 0.02960268f, 0.02369983f, -0.04651553f, 0.05313118f, -0.01099191f, -0.00593557f, 
    0.11188556f, -0.10539452f, -0.05995255f, 0.20960672f, 0.12891591f, 0.09851332f, -0.03965472f, -0.01578148f, 
    0.03447399f, 0.00474344f, 0.09688964f, -0.00096797f, -0.03458493f, -0.15038468f, 0.10225852f, 0.34810722f, 
    -0.02537464f, 0.02104884f, 0.10532530f, 0.13590147f, -0.06084991f, -0.10402680f, 0.15979224f, 0.24475206f, 
    -0.09688737f, -0.02711389f, 0.00861874f, 0.19099648f, 0.11340572f, 0.06811276f, -0.03395944f, 0.00662853f, 
    0.10006414f, 0.03036059f, -0.03726168f, -0.05502703f, -0.35342962f, -0.16828024f, -0.06328727f, -0.03470613f, 
    -0.01519940f, 0.00118021f, 0.04418639f, 0.01002892f, 0.01460661f, 0.13794354f, 0.08827785f, 0.05582945f, 
    0.04074043f, 0.06625469f, -0.02546214f, 0.00698527f, 0.02531553f, 0.07577108f, 0.12192833f, -0.00740504f, 
    -0.06113736f, -0.05953715f, 0.04654137f, -0.09449108f, -0.10051907f, -0.01620346f, -0.06740955f, -0.04399452f, 
    0.07038829f, 0.08193745f, 0.00995342f, -0.02865585f, 0.01581237f, 0.03419156f, 0.01499816f, -0.07573918f, 
    -0.13123183f, -0.00056532f, 0.17064975f, -0.32943848f, 0.10385054f, 0.05279724f, 0.07214531f, 0.08517647f, 
    0.06129988f, 0.00010373f, -0.01868617f, -0.05015750f, 0.14995356f, -0.12371452f, -0.04594741f, 0.30205390f, 
    0.01691866f, 0.07196980f, 0.12749827f, 0.12792186f, -0.00168813f, 0.00721391f, 0.09985912f, 0.10649704f, 
    0.03487359f, -0.13578597f, -0.06057043f, 0.36524025f, 0.09659038f, 0.02340173f, -0.01440813f, 0.05980369f, 
    -0.00803596f, -0.01779095f, 0.04198304f, 0.01684299f, 0.13624521f, 0.24639164f, 0.14333797f, -0.02419513f, 
    -0.07367817f, 0.01335347f, 0.04528088f, 0.04840198f, -0.03209596f, 0.02164925f, 0.03741438f, 0.17196858f, 
    0.25138232f, 0.05620318f, 0.15267964f, 0.02713631f, -0.01069727f, -0.06820183f, 0.03387368f, 0.05635323f, 
    0.11392111f, 0.10622506f, 0.03596738f, 0.07804745f, -0.09526166f, -0.05961480f, -0.03745465f, 0.00317975f, 
    0.13727491f, 0.18856861f, 0.06518620f, -0.04610397f, -0.08046605f, 0.01779546f, 0.07336193f, 0.06703383f, 
    0.06709799f, 0.02789706f, -0.13889992f, 0.13668849f, 0.02524303f, 0.12857248f, -0.00167717f, 0.14816305f, 
    -0.00352624f, 0.00930307f, -0.03359006f, 0.06370229f, 0.15828019f, 0.11356220f, 0.00757038f, 0.10442031f, 
    -0.00796524f, 0.03631306f, -0.10998264f, 0.04349675f, 0.01865496f, 0.07448058f, 0.01962508f, -0.02016886f, 
    0.01316675f, -0.17999768f, 0.01808009f, -0.08114749f, 0.07692555f, 0.09087989f, 0.06680177f, 0.02346604f, 
    0.03448682f, 0.10386141f, -0.00019792f, 0.16294596f, -0.00510885f, 0.06458671f, -0.04242864f, -0.10878361f, 
    0.15178107f, 0.07852973f, 0.04907386f, -0.02528808f, 0.07007021f, 0.00556802f, -0.02739862f, -0.02851349f, 
    0.05426362f, 0.15351704f, 0.09280504f, -0.13921884f, -0.07724278f, 0.05659785f, -0.00198066f, 0.05555665f, 
    0.02018129f, -0.02966362f, 0.07311945f, -0.03597411f, -0.05646749f, -0.04718355f, 0.11913319f, -0.17881373f, 
    0.02378523f, 0.02940365f, 0.08402796f, 0.10337560f, 0.04038204f, 0.02461211f, 0.12928787f, 0.03951684f, 
    0.12628712f, -0.10917784f, -0.05241848f, 0.33785465f, 0.03444853f, -0.03881526f, 0.05101938f, 0.07717815f, 
    0.10810923f, 0.11304362f, -0.05466412f, 0.02761539f, -0.16238303f, 0.06116180f, 0.07135947f, 0.00129828f, 
    0.05199844f, 0.01907782f, 0.05828451f, -0.08372239f, 0.05259333f, 0.02537697f, 0.10481540f, -0.03790276f, 
    0.07453013f, 0.18100384f, 0.21623977f, -0.21464080f, -0.05624987f, -0.00365611f, 0.04648322f, 0.05773686f, 
    0.00569491f, 0.04300979f, -0.04666821f, 0.06169618f, -0.22226192f, -0.13597572f, -0.18648551f, 0.19897425f, 
    0.04589341f, 0.10275321f, 0.01104429f, -0.11353745f, 0.10622422f, 0.03659893f, 0.07182591f, 0.10552637f, 
    0.21315622f, 0.15416101f, 0.10661475f, -0.21795750f, -0.12396578f, -0.05351878f, 0.03909743f, 0.07273063f, 
    0.01127879f, -0.05147528f, 0.08483756f, 0.09127554f, -0.02342905f, 0.06422652f, 0.14209436f, -0.02057064f, 
    0.02180039f, -0.01266132f, -0.05667682f, 0.05821324f, 0.02204315f, -0.01676904f, 0.02632118f, 0.03508940f, 
    0.19155264f, 0.15319270f, -0.11584090f, 0.29342881f, -0.12023469f, 0.03007418f, 0.00284566f, 0.07529458f, 
    0.01967432f, 0.04980975f, 0.07960267f, 0.01427402f, 0.28973055f, -0.18688978f, -0.01452489f, 0.48553360f, 
    -0.10694043f, 0.05991293f, -0.05486219f, 0.06409887f, 0.04019579f, -0.02109354f, 0.11690645f, 0.05224208f, 
    -0.04682568f, 0.22162087f, 0.02162275f, -0.08565090f, 0.04369655f, 0.03961746f, -0.06959682f, 0.02260301f, 
    0.00058744f, -0.00318078f, 0.00489936f, -0.08832554f, -0.09432188f, 0.02475167f, 0.19032152f, 0.23465155f, 
    0.03131724f, -0.00737711f, 0.08735725f, 0.15583391f, -0.09689450f, 0.01926403f, -0.03717472f, 0.01728269f, 
    0.33633924f, 0.23589672f, 0.11969825f, -0.09749521f, 0.06219282f, 0.01458846f, 0.03895472f, 0.11242613f, 
    0.01061923f, 0.09939650f, 0.03284229f, 0.09208360f, -0.08865405f, 0.12075039f, -0.11886161f, 0.03007411f, 
    0.01561263f, 0.10578009f, -0.00032093f, 0.01363720f, -0.03351513f, 0.04343074f, 0.02701697f, 0.08463125f, 
    -0.06041164f, 0.22995773f, 0.15066825f, -0.18883531f, -0.09139308f, 0.00180951f, 0.03284434f, 0.07164181f, 
    0.04676683f, 0.05082800f, 0.00486074f, 0.09553618f, 0.26151371f, -0.05023637f, 0.03504824f, -0.27515173f, 
    0.13771906f, 0.09922139f, 0.05642912f, 0.04803798f, -0.01179708f, -0.00199003f, 0.02725956f, 0.05274617f, 
    -0.12549248f, 0.13725880f, 0.09843929f, -0.04080001f, 0.02974576f, -0.04554341f, -0.02502008f, 0.06237174f, 
    0.00461037f, -0.00788466f, 0.01732634f, -0.07733516f, 0.06553571f, -0.08569679f, -0.04142439f, 0.23687603f, 
    -0.02996146f, 0.01369057f, -0.06781700f, 0.01636508f, -0.00930438f, 0.01954374f, -0.01837921f, -0.18884617f, 
    0.03921502f, -0.03899758f, -0.08011614f, 0.09172183f, 0.04291493f, 0.11682748f, 0.04425868f, -0.06672369f, 
    -0.02090768f, 0.00588697f, -0.07173038f, -0.09642572f, 0.06280696f, 0.08187480f, 0.00246484f, 0.13026291f, 
    0.04600404f, 0.13856634f, 0.03646153f, 0.04995713f, 0.02082842f, 0.00191766f, 0.03778908f, 0.07711598f, 
    -0.04479714f, -0.02071703f, 0.00855546f, 0.02174441f, -0.01096690f, -0.00195803f, -0.02592144f, 0.03124518f, 
    -0.02145394f, 0.01396729f, -0.03787406f, 0.00238154f, -0.00474116f, -0.02764698f, 0.00680031f, -0.00045597f, 
    0.01738604f, -0.00033450f, 0.00193627f, -0.00883401f, -0.00796395f, 0.02561802f, -0.03367503f, -0.03164148f, 
    -0.03390608f, -0.00297166f, -0.02257992f, 0.01951983f, 0.00965147f, -0.04501912f, -0.01645824f, 0.01010397f, 
    0.02864554f, 0.00166230f, -0.01592799f, -0.01921050f, -0.02910514f, -0.02819532f, 0.02333545f, -0.01936200f, 
    0.00609803f, -0.00019663f, 0.00997676f, -0.04326957f, 0.02001520f, 0.00343197f, 0.02100672f, -0.00952460f, 
    -0.02073402f, 0.02407164f, -0.02695813f, 0.02005424f, 0.00555945f, 0.00316239f, -0.03629108f, -0.02035356f, 
    -0.03317975f, -0.00684491f, 0.02826065f, -0.03434753f, -0.04404543f, 0.02450462f, 0.00177156f, 0.01806919f, 
    0.00361586f, 0.00910818f, -0.04215060f, -0.01579091f, -0.02676761f, -0.01879085f, -0.02537637f, -0.01604022f, 
    -0.02449536f, 0.01870856f, -0.02555297f, -0.03703487f, 0.00403341f, 0.02110701f, -0.03760264f, -0.03758155f, 
    0.03328809f, -0.03619928f, 0.02035364f, 0.00635867f, -0.03050600f, -0.01335565f, -0.03068251f, 0.00821188f, 
    -0.01196674f, -0.00390141f, -0.02226096f, 0.01747558f, -0.02215190f, -0.00027253f, -0.02993256f, -0.00515766f, 
    0.01541977f, -0.00466072f, -0.02884908f, 0.01972203f, 0.00436901f, 0.01300154f, -0.02312950f, -0.01244151f, 
    0.01017501f, -0.02920269f, -0.03337337f, 0.02155595f, 0.01205639f, 0.01038342f, 0.00486518f, 0.02261025f, 
    0.01584339f, -0.00092625f, 0.00006940f, -0.03204751f, -0.03511894f, 0.00745467f, -0.03497735f, 0.01442626f, 
    -0.00388785f, 0.02075549f, 0.02008440f, 0.01002111f, -0.02018988f, -0.01619226f, 0.00367805f, -0.01985675f, 
    -0.03079928f, 0.02420196f, -0.03382619f, -0.01076957f, -0.01533824f, 0.02182810f, -0.01604869f, -0.01257850f, 
    0.00169850f, -0.01656704f, 0.02825477f, 0.00450516f, 0.01430455f, 0.01775739f, -0.03339508f, -0.02591862f, 
    -0.04173134f, -0.02367603f, 0.00729625f, 0.00422451f, -0.00005846f, -0.04304554f, -0.02990905f, -0.01327976f, 
    -0.00135857f, 0.01203332f, 0.03125305f, -0.03782825f, 0.01700306f, -0.00287637f, -0.03595716f, -0.01225621f, 
    0.01702604f, -0.00242109f, -0.03797618f, -0.02239939f, -0.00070529f, -0.00830319f, 0.01631490f, -0.04329751f, 
    -0.00930144f, 0.00994779f, 0.01379973f, 0.02692471f, -0.04040402f, -0.02352388f, 0.02202479f, -0.02838171f, 
    -0.02477835f, 0.03075271f, 0.01492973f, 0.00036443f, -0.03191243f, 0.01743521f, 0.02620137f, -0.00823725f, 
    -0.03383325f, -0.02426341f, -0.02681355f, 0.00375765f, 0.00038495f, 0.02055452f, 0.01564123f, 0.00342974f, 
    0.00804534f, -0.02134866f, -0.03527222f, 0.01700414f, 0.02876330f, 0.00313489f, -0.00691800f, -0.02486386f, 
    0.01018111f, 0.01736587f, 0.01941142f, 0.01589053f, 0.01900855f, -0.00093917f, 0.02749971f, -0.02337780f, 
    -0.01821763f, 0.03174579f, -0.01383969f, -0.01714908f, -0.01136221f, 0.01435420f, -0.02438687f, 0.00075033f, 
    -0.00984083f, 0.01703464f, -0.00455994f, 0.02699296f, 0.02671669f, 0.00579293f, -0.03367590f, -0.01914320f, 
    0.00420455f, -0.03065599f, -0.00199411f, 0.00981196f, -0.00563027f, 0.01292202f, -0.00187552f, 0.00187033f, 
    -0.02155451f, -0.02757033f, 0.00955102f, -0.02536351f, -0.03269335f, -0.00559074f, 0.01042439f, -0.00302090f, 
    -0.01107185f, 0.02300747f, -0.00549089f, -0.04314817f, 0.01614410f, -0.00873251f, -0.02905699f, -0.00280936f, 
    0.01834534f, 0.00308152f, 0.02391347f, 0.00776439f, -0.03169435f, -0.01413739f, 0.02189585f, -0.01376608f, 
    -0.00265902f, -0.02995910f, -0.02984848f, 0.00005491f, 0.01406418f, -0.01881964f, 0.02191243f, 0.00139002f, 
    -0.02880027f, -0.00314843f, -0.01002109f, 0.02513384f, -0.02251563f, -0.02626455f, -0.03612569f, 0.01430187f, 
    0.00473230f, 0.02394639f, -0.03419459f, -0.02348147f, -0.02969988f, 0.01694617f, -0.03434305f, 0.01403038f, 
    0.03227727f, -0.03719639f, -0.00415528f, -0.02386116f, 0.01291092f, 0.00263172f, 0.01951421f, -0.01634566f, 
    0.02292959f, -0.01047355f, 0.01326620f, 0.02056230f, -0.03083056f, 0.02366856f, -0.04044607f, -0.00710469f, 
    0.01021196f, -0.02874455f, -0.01041634f, -0.03815255f, 0.02778150f, -0.03897014f, 0.01790721f, 0.00025296f, 
    0.01617713f, 0.00884056f, 0.02178081f, 0.00183180f, 0.01881041f, -0.03849749f, -0.02243445f, -0.01097006f, 
    -0.00221127f, -0.02983542f, 0.01972827f, -0.02365863f, -0.01886127f, -0.03706273f, -0.02703203f, -0.00152609f, 
    0.00579443f, -0.02008527f, 0.02971862f, 0.01601861f, 0.01780387f, -0.02327151f, 0.00761972f, -0.02217435f, 
    0.00284846f, -0.02426174f, -0.02474203f, -0.00167238f, 0.00528558f, 0.00658866f, 0.02648189f, -0.00681405f, 
    0.00066529f, -0.04167512f, 0.01625234f, -0.02010555f, -0.02001289f, 0.02230274f, -0.01391451f, 0.02677710f, 
    0.00717032f, -0.03150462f, 0.02344591f, -0.03653725f, -0.00944947f, -0.03446834f, 0.00513462f, -0.00945145f, 
    -0.01532740f, 0.02985911f, 0.02478680f, -0.00143174f, -0.02445453f, -0.00712796f, -0.00635885f, -0.03147490f, 
    -0.04221947f, 0.01589014f, 0.00000900f, -0.00142812f, -0.04542529f, -0.00559098f, -0.03311652f, 0.00681971f, 
    -0.01183355f, -0.04103436f, 0.01215576f, -0.04013010f, -0.02222035f, 0.01504399f, 0.00710473f, -0.02258506f, 
    -0.00835445f, -0.02534605f, 0.02554917f, 0.01164323f, -0.00093900f, -0.02186895f, -0.00827422f, -0.00613423f, 
    0.00702197f, 0.02182383f, -0.02888291f, 0.02170591f, -0.00834629f, 0.00708108f, -0.04430973f, -0.03257961f, 
    -0.00019706f, -0.02587473f, 0.00251175f, -0.04092211f, 0.01274174f, 0.01170829f, -0.02285839f, 0.00401074f, 
    -0.03319238f, -0.03592963f, -0.01996754f, 0.02057832f, -0.02189144f, 0.01902012f, -0.00208978f, -0.00895830f, 
    -0.00206185f, -0.02219008f, -0.03497602f, 0.02340768f, -0.00326492f, 0.00447045f, 0.02190170f, -0.03617181f, 
    -0.00186683f, -0.02277733f, -0.02728244f, -0.01440603f, 0.02489118f, 0.01288066f, -0.01379463f, 0.01146649f, 
    -0.00414178f, -0.00158327f, -0.02478162f, -0.01856488f, -0.02778845f, -0.03566309f, -0.02830407f, -0.02837209f, 
    -0.00829628f, 0.00420995f, 0.01567063f, 0.00749364f, 0.02044637f, 0.00712828f, 0.01551928f, 0.01417438f, 
    0.00233757f, -0.01665540f, -0.01994472f, -0.03819412f, -0.03106437f, -0.03475799f, -0.00790429f, -0.02665795f, 
    0.01499918f, 0.00542090f, 0.00054285f, -0.01617893f, 0.00514863f, 0.02110551f, 0.01221016f, 0.00072013f, 
    -0.03400935f, -0.03357574f, 0.00608156f, 0.02411568f, -0.02539293f, 0.01365587f, -0.03058938f, -0.00588377f, 
    -0.01736736f, -0.02918386f, -0.03893193f, -0.02113947f, -0.00100266f, -0.02929603f, -0.02515182f, -0.00404597f, 
    -0.02009628f, -0.03459000f, 0.01385961f, -0.03872451f, -0.04296649f, 0.00523845f, -0.03801919f, -0.01922913f, 
    -0.03545073f, 0.02074321f, -0.02463613f, 0.00945084f, 0.00370106f, 0.00271611f, -0.01165961f, 0.02676735f, 
    -0.02753350f, -0.02904345f, 0.00364425f, -0.04342021f, -0.02735627f, 0.01141498f, -0.03295152f, 0.00760777f, 
    0.00631312f, -0.00460542f, -0.00336810f, 0.01152542f, 0.01239170f, -0.02440620f, 0.00632751f, 0.00819861f, 
    0.02437685f, -0.04328922f, 0.01191526f, 0.00354282f, 0.01338870f, -0.01345455f, -0.03475763f, -0.04031802f, 
    -0.02635610f, -0.00353927f, -0.02604262f, 0.00408043f, 0.02694527f, -0.00450642f, -0.00146922f, -0.01750584f, 
    -0.01588031f, 0.02630338f, -0.01446467f, 0.02825216f, 0.00098820f, -0.01108294f, 0.01447166f, 0.00641047f, 
    0.00681822f, 0.00238923f, -0.02406109f, 0.00577598f, 0.02873772f, 0.02310795f, -0.03880390f, -0.03345767f, 
    -0.02702870f, -0.02687220f, -0.00321771f, -0.03834874f, -0.03655586f, -0.00227928f, -0.02334895f, 0.01272571f, 
    0.01302765f, -0.02287563f, -0.02315719f, 0.02848613f, -0.03858836f, 0.01550101f, -0.03317469f, -0.03128544f, 
    -0.04192555f, 0.02597418f, 0.02135880f, -0.02778839f, 0.00183106f, -0.00650913f, 0.00888889f, 0.02723751f, 
    -0.03703872f, -0.01789617f, -0.00998154f, -0.04371313f, 0.00916319f, 0.02832700f, -0.02076298f, -0.03305469f, 
    0.00773404f, -0.01688665f, 0.03033117f, 0.00700156f, 0.01667758f, -0.02891619f, -0.02628217f, 0.01714439f, 
    0.02557810f, 0.02229412f, -0.03754427f, -0.01646944f, -0.02662581f, -0.00270500f, 0.02271822f, -0.01209866f, 
    -0.00052738f, 0.01922628f, 0.01300431f, -0.01331112f, -0.03834080f, -0.01000217f, -0.02511800f, -0.04001970f, 
    -0.01636101f, 0.00584692f, -0.02224013f, -0.01163620f, -0.00397530f, 0.00456306f, 0.00060374f, -0.00230887f, 
    0.02313230f, 0.01623065f, 0.02649874f, 0.04146158f, -0.01583730f, -0.01670844f, 0.02112318f, -0.00103810f, 
    -0.01555948f, 0.00819761f, 0.00094156f, -0.03249544f, -0.02982341f, -0.02290744f, -0.02909979f, -0.02349274f, 
    0.01485711f, -0.01773110f, 0.00087308f, 0.00397083f, -0.01137840f, 0.01241060f, 0.01690323f, -0.03890536f, 
    0.01722203f, 0.01943616f, -0.03263640f, 0.00554247f, -0.03373965f, 0.02414521f, 0.01959462f, -0.02851097f, 
    -0.00144102f, -0.02329399f, -0.02048962f, -0.01734009f, -0.02060038f, -0.03218859f, 0.01410260f, -0.02140641f, 
    -0.00448593f, -0.00579642f, -0.02760180f, -0.01757831f, -0.02717766f, -0.03220550f, -0.00797895f, -0.03133087f, 
    0.00916953f, -0.02421698f, 0.02889867f, -0.00078773f, 0.00688288f, 0.00142296f, 0.01442417f, -0.03253074f, 
    -0.03852443f, -0.00263164f, 0.00716732f, -0.00176704f, -0.02903766f, -0.02831003f, -0.02489597f, -0.02584247f, 
    -0.01032588f, -0.03997095f, -0.04590943f, 0.00621261f, 0.02518061f, 0.00743407f, -0.01833666f, 0.02301088f, 
    -0.02419697f, -0.02040401f, 0.01099807f, -0.04163301f, 0.01602283f, -0.02025267f, -0.02569246f, -0.03902314f, 
    -0.01292375f, -0.01392468f, -0.03471853f, -0.00860789f, -0.01171910f, -0.03416485f, 0.01342670f, -0.01939973f, 
    -0.02917909f, -0.02694203f, 0.02457343f, 0.00370201f, 0.00959390f, -0.00738208f, -0.00357780f, 0.00380560f, 
    0.01551203f, -0.01555035f, -0.00430690f, 0.02392016f, -0.03030959f, 0.03208893f, 0.01377837f, 0.02421543f, 
    0.01081626f, -0.04230425f, -0.04075960f, -0.01651289f, 0.01360937f, -0.03977058f, -0.03040364f, -0.01401688f, 
    0.00096663f, -0.00847816f, -0.01792792f, 0.02410824f, -0.04106233f, 0.02121125f, -0.01004591f, 0.02527430f, 
    -0.01684631f, -0.03223305f, -0.00690068f, -0.01726377f, -0.01905028f, -0.02084073f, 0.01891818f, -0.03125880f, 
    -0.01473169f, -0.01865322f, -0.00822736f, 0.01579351f, -0.01389559f, -0.02216939f, -0.03829921f, 0.01231391f, 
    -0.02477671f, -0.02206663f, 0.02104833f, 0.02640934f, -0.01549973f, 0.01101125f, -0.02057592f, -0.01698576f, 
    0.02425093f, -0.03473623f, 0.01346403f, 0.03762231f, -0.02355701f, -0.01975543f, -0.01008658f, 0.00942935f, 
    0.02371847f, 0.01454734f, -0.01993533f, -0.03470360f, -0.01155619f, 0.01103556f, -0.03545371f, 0.01177012f, 
    -0.02109491f, -0.03630853f, -0.04283627f, -0.01580100f, -0.04222778f, 0.02803293f, 0.01307064f, 0.00255725f, 
    -0.00317227f, -0.00620646f, -0.03166782f, 0.01918397f, -0.03945973f, -0.03875791f, -0.00451631f, 0.00306637f, 
    -0.00793677f, -0.01414702f, 0.02312993f, 0.00312591f, 0.02584632f, -0.01091763f, -0.01375173f, -0.01213445f, 
    -0.02814429f, 0.01637705f, 0.02695440f, 0.00399807f, -0.02559751f, -0.00066893f, 0.00208780f, -0.02984633f, 
    -0.02975340f, -0.00615487f, -0.02364648f, 0.00962434f, -0.00553789f, -0.00201658f, 0.01470768f, -0.02686625f, 
    -0.01220901f, 0.01833048f, -0.01514415f, 0.00567140f, -0.01483947f, -0.02221467f, -0.00622424f, 0.02185859f, 
    -0.02632864f, -0.00013132f, -0.02031905f, -0.01175571f, 0.01068239f, 0.01556052f, -0.03187236f, 0.01949509f, 
    -0.01984462f, -0.01876957f, 0.03285512f, -0.04550777f, -0.00696134f, -0.01052332f, 0.01595522f, -0.01237867f, 
    0.02264837f, 0.00740087f, 0.00223712f, -0.02858004f, -0.01856925f, -0.02021164f, -0.03612825f, 0.01708646f, 
    -0.03547408f, -0.00356705f, -0.04183027f, -0.03576314f, 0.02022120f, -0.01704246f, 0.01604916f, -0.03302319f, 
    -0.03642279f, 0.00359982f, -0.01155944f, 0.00518605f, 0.01418618f, 0.02272514f, 0.00188419f, -0.01262380f, 
    -0.02612589f, 0.01002332f, 0.01568395f, -0.00214912f, 0.01290034f, -0.02063429f, 0.00526120f, -0.03700938f, 
    -0.00786372f, -0.00126061f, -0.03282641f, -0.04166077f, -0.04462909f, -0.02498709f, -0.01100220f, -0.02365280f, 
    -0.02395654f, -0.00790936f, -0.00069713f, 0.01679823f, -0.03407491f, 0.02433573f, -0.03160388f, -0.01986174f, 
    -0.01424498f, -0.03104446f, -0.03336410f, -0.00098133f, 0.03284991f, 0.01498934f, 0.00031995f, 0.02304453f, 
    -0.02022972f, 0.02228605f, -0.02180281f, 0.00097893f, -0.00046945f, -0.04181439f, 0.02008118f, -0.00512095f, 
    0.00431219f, 0.02183864f, -0.02067935f, -0.03132582f, -0.04010176f, -0.01632782f, -0.00140147f, 0.01339548f, 
    -0.01511883f, 0.00228093f, 0.01832726f, 0.02099154f, -0.01308207f, 0.01120163f, 0.00414702f, 0.01367151f, 
    -0.01604198f, 0.00355370f, 0.01758732f, 0.01715333f, -0.03890606f, -0.02999730f, 0.00215082f, -0.03333599f, 
    -0.01389160f, -0.00261850f, -0.03724608f, -0.03541911f, 0.01952605f, 0.00603465f, -0.03883171f, 0.01551085f, 
    0.00316322f, 0.00947725f, -0.00061606f, -0.01281852f, -0.03494829f, 0.02158883f, -0.04276343f, -0.03683880f, 
    -0.00794417f, -0.02516532f, 0.02971749f, 0.03125695f, -0.03608350f, -0.04283549f, 0.01829029f, 0.00496357f, 
    0.01209825f, -0.02187894f, 0.00505078f, -0.02218420f, 0.01266303f, -0.00483027f, -0.02766639f, -0.04586103f, 
    -0.03814403f, 0.02724853f, 0.00188965f, 0.02511629f, 0.00359894f, 0.01281739f, -0.03586291f, -0.03675443f, 
    -0.01988796f, -0.02692914f, -0.02160301f, 0.01583484f, -0.01198356f, -0.03208482f, 0.02563972f, -0.00587785f, 
    -0.02841501f, 0.02069426f, -0.01190151f, -0.03926573f, -0.03578622f, -0.04351339f, -0.01203565f, -0.00657229f, 
    0.01658861f, 0.00525283f, -0.03478822f, 0.00351133f, 0.01741489f, -0.00885731f, -0.00189187f, -0.01011686f, 
    -0.01376526f, -0.03587843f, -0.02584976f, 0.01871543f, -0.00624878f, -0.01993126f, -0.01112117f, -0.03478346f, 
    -0.03788878f, -0.01257357f, 0.01728372f, -0.01096935f, 0.00808802f, 0.01008983f, -0.03736480f, 0.00007716f, 
    -0.01215211f, -0.04185981f, -0.04000084f, 0.01565870f, -0.03358360f, -0.01226601f, -0.01844027f, -0.01436139f, 
    -0.01028589f, 0.01703746f, 0.02830242f, 0.00600695f, -0.03841674f, 0.00200244f, -0.01768821f, 0.01848452f, 
    -0.02044110f, 0.02432367f, 0.01967270f, -0.00235029f, 0.00010589f, 0.02258757f, 0.02544137f, -0.01068899f, 
    0.01085371f, -0.01222291f, -0.03446335f, -0.01053574f, 0.00923506f, 0.01485295f, 0.02077387f, 0.00897184f, 
    -0.01552024f, 0.01435459f, -0.02232532f, -0.03561629f, 0.01364615f, -0.03823583f, -0.03272638f, 0.01532801f, 
    0.01471299f, -0.03772187f, 0.02478344f, 0.02061220f, 0.00630105f, 0.01838172f, -0.02160418f, -0.03041470f, 
    0.02450918f, -0.01207736f, -0.02793726f, -0.02582967f, -0.00918461f, 0.00726821f, 0.02219780f, 0.01935284f, 
    0.02867708f, -0.04111774f, -0.00826447f, -0.03866616f, -0.01783265f, -0.02948406f, -0.01163247f, 0.00246561f, 
    -0.03525355f, -0.02014366f, 0.00315359f, 0.02041710f, 0.02690571f, 0.01929533f, 0.00869283f, 0.00912563f, 
    0.00406594f, -0.00717388f, -0.02808696f, 0.02159840f, -0.02658106f, -0.04047229f, 0.00109319f, 0.01769479f, 
    0.02486176f, -0.00247536f, -0.03294925f, 0.02628315f, -0.03500943f, -0.00705072f, 0.01350993f, -0.00444580f, 
    0.02738345f, -0.01292592f, 0.01273128f, -0.03258526f, -0.03002898f, -0.04245706f, -0.02699276f, 0.00630817f, 
    0.00728923f, 0.01117429f, 0.00145276f, -0.04521262f, 0.02840581f, -0.01311442f, -0.03360144f, 0.01143282f, 
    0.00042737f, -0.03973849f, -0.04218441f, 0.00717393f, -0.03905989f, -0.03593513f, -0.04446759f, 0.02686556f, 
    -0.00187759f, -0.03813188f, -0.02000497f, 0.01515564f, -0.03037952f, 0.00902299f, -0.01759162f, 0.02622149f, 
    -0.00400640f, -0.01418625f, -0.02865237f, 0.00579485f, 0.02475531f, 0.01493315f, -0.00565065f, -0.00553028f, 
    -0.02293527f, 0.01541898f, -0.02295622f, -0.02052980f, -0.02411243f, 0.02154436f, -0.01908790f, -0.03766074f, 
    -0.02103569f, -0.04226443f, -0.03590812f, -0.01198314f, -0.02922490f, -0.03693997f, -0.01953760f, 0.00968316f, 
    -0.00752240f, -0.04027701f, -0.02048588f, -0.04325592f, 0.02530816f, -0.01377375f, -0.01106038f, 0.00520190f, 
    -0.00015084f, 0.03098165f, -0.00592911f, -0.02036832f, -0.02749643f, -0.00080641f, -0.01489188f, -0.03386000f, 
    -0.02836056f, -0.00197068f, -0.00446154f, 0.02666613f, 0.00308897f, -0.00622304f, -0.02435308f, 0.01111538f, 
    0.00157035f, -0.01444660f, -0.01148633f, -0.04536543f, -0.02767803f, -0.00118415f, 0.00312380f, 0.01372462f, 
    -0.00385332f, -0.00870659f, 0.00701355f, -0.00735248f, -0.02500122f, -0.00975618f, -0.02336027f, 0.01434866f, 
    -0.01511652f, -0.00462516f, -0.03053245f, -0.01981240f, 0.01423461f, -0.01837853f, -0.01924986f, -0.02633706f, 
    0.02166809f, 0.01255201f, 0.02300461f, 0.01438880f, 0.00469216f, 0.00500981f, -0.01316523f, -0.02621148f, 
    0.02860872f, 0.01748008f, -0.03040922f, 0.00010067f, 0.00260300f, 0.00272950f, 0.01348758f, 0.01369268f, 
    0.02352798f, -0.02440536f, -0.01905276f, -0.03183408f, -0.02575784f, 0.01066346f, 0.01697602f, -0.01106645f, 
    0.00859234f, 0.01726368f, 0.00319424f, -0.03029427f, 0.01620334f, -0.01328781f, -0.04111662f, -0.03526408f, 
    0.01691558f, -0.01632347f, -0.00915606f, 0.02349040f, 0.03022253f, 0.02360493f, -0.03265537f, -0.03058196f, 
    -0.02040906f, -0.01478625f, 0.02455014f, -0.02506647f, -0.03278618f, 0.00753132f, 0.02743459f, -0.03379345f, 
    0.00014571f, -0.03063194f, -0.03164409f, 0.00235489f, 0.02699805f, -0.01099417f, -0.02310110f, -0.00310753f, 
    0.00419064f, 0.02886658f, -0.03202643f, 0.01272418f, 0.00122010f, -0.01484802f, -0.03512641f, -0.04100032f, 
    0.01349360f, -0.02341088f, -0.03340816f, -0.00432403f, -0.02603268f, 0.02393082f, -0.00682930f, -0.00051724f, 
    -0.03225213f, 0.01139015f, 0.02419239f, -0.04063410f, 0.01519311f, -0.02986826f, 0.01421199f, 0.00047303f, 
    -0.01735873f, -0.03556609f, 0.02580093f, 0.02783350f, 0.01835138f, 0.00138420f, -0.01013237f, 0.01636565f, 
    -0.00029386f, -0.00473418f, -0.03530690f, -0.03235101f, 0.00580963f, 0.02460087f, 0.02438870f, 0.01074779f, 
    -0.04455733f, -0.03636851f, -0.01246579f, 0.02443474f, -0.01290288f, 0.00904744f, 0.01648911f, -0.00282308f, 
    -0.01139780f, 0.01195088f, -0.02821232f, -0.02482050f, 0.00222649f, -0.03555183f, 0.01005087f, -0.04398367f, 
    -0.03745051f, -0.02234637f, -0.01695578f, 0.02190287f, 0.00377261f, -0.00694995f, 0.03074094f, -0.04160061f, 
    0.00480183f, 0.02495501f, -0.02549386f, 0.02448576f, -0.04419748f, -0.02305909f, -0.02666999f, 0.01164851f, 
    -0.02134235f, -0.00923308f, -0.04076467f, -0.01776592f, 0.01914095f, -0.02724924f, 0.01229607f, 0.00817627f, 
    -0.03372341f, -0.00524247f, -0.00727492f, -0.03976548f, -0.01241252f, 0.00979632f, -0.04633721f, -0.03133788f, 
    0.02480664f, 0.02014907f, 0.00623332f, -0.01955990f, -0.03807332f, -0.00378017f, -0.01158349f, -0.02722450f, 
    0.02153298f, -0.01479870f, 0.00742511f, 0.01512877f, -0.04304227f, -0.01083517f, 0.01967171f, 0.00088563f, 
    -0.02182287f, -0.01645060f, 0.02597749f, -0.01791061f, -0.03601953f, 0.00329131f, 0.01858661f, 0.00997101f, 
    0.01852007f, -0.04424321f, 0.02031592f, 0.00842616f, 0.02448087f, -0.01866937f, 0.01292343f, 0.02058255f, 
    -0.01443969f, 0.00601657f, -0.03408850f, -0.03175906f, 0.02352214f, -0.03304297f, 0.01528226f, 0.01190128f, 
    -0.01232758f, 0.03117489f, -0.03256266f, -0.03085057f, -0.04477562f, 0.02159333f, -0.00676948f, 0.01588105f, 
    -0.00539078f, -0.04647030f, -0.02652517f, -0.03224461f, -0.01694534f, -0.00042361f, -0.00050128f, -0.01254976f, 
    -0.02958062f, -0.02437456f, 0.00598983f, -0.02335548f, -0.02907107f, -0.02621821f, -0.02047727f, -0.03180338f, 
    0.01975410f, 0.01498098f, -0.01954524f, -0.00000667f, -0.02761745f, 0.01235434f, 0.00284971f, 0.01505821f, 
    -0.02757562f, -0.04373838f, 0.00192588f, -0.04520398f, 0.00654036f, -0.03477550f, 0.03113193f, -0.00994099f, 
    -0.00338742f, 0.02952920f, -0.04234697f, -0.00562534f, -0.00350387f, 0.01258667f, 0.00459935f, -0.00835490f, 
    0.02548741f, 0.01179263f, 0.01048816f, -0.01046644f, 0.01363384f, 0.01280080f, -0.00401991f, -0.02307425f, 
    -0.03539807f, -0.00686975f, 0.01451616f, -0.02900606f, 0.01959179f, 0.00620192f, -0.01537983f, -0.01474660f, 
    -0.00470108f, -0.02161099f, -0.02901128f, -0.00297590f, -0.04547086f, -0.03609474f, -0.01692231f, 0.01233879f, 
    0.01197051f, -0.01971151f, 0.01272495f, 0.01215901f, -0.01999294f, 0.01211071f, -0.02317843f, -0.02495792f, 
    0.02184710f, -0.00359252f, -0.03483303f, 0.00027445f, 0.01076106f, -0.02635343f, 0.00168498f, 0.00784281f, 
    -0.03610033f, 0.01469688f, 0.01694519f, 0.00315236f, -0.02218543f, -0.02933964f, -0.01388271f, 0.02481841f, 
    -0.02060543f, -0.01664070f, 0.01305816f, -0.01833984f, 0.00826417f, 0.01423818f, -0.03395472f, 0.02281866f, 
    -0.02749835f, -0.03640381f, 0.00107471f, -0.02857992f, -0.03418081f, -0.03777146f, -0.03425649f, 0.00041936f, 
    -0.03491767f, -0.01516477f, -0.03127519f, -0.01208556f, 0.02038901f, 0.01316006f, 0.00963466f, -0.03278018f, 
    -0.03936062f, -0.02670090f, 0.01339437f, -0.01556300f, -0.02372040f, 0.01871315f, 0.00981356f, 0.01813810f, 
    -0.04153380f, -0.03808817f, -0.01595986f, -0.00800608f, 0.02493297f, 0.00361642f, 0.00651862f, 0.00402824f, 
    -0.03900104f, 0.02262109f, -0.00853511f, -0.00814598f, 0.01611724f, 0.02606825f, 0.00745752f, 0.02149966f, 
    -0.02194252f, -0.03218577f, -0.02795932f, -0.02444191f, 0.01369229f, 0.01891558f, -0.04445696f, -0.03679498f, 
    0.00965417f, -0.03318064f, -0.03563047f, 0.00531231f, 0.03020637f, -0.00249755f, -0.04235272f, 0.02158786f, 
    0.00062825f, 0.01394960f, 0.00188559f, -0.01938418f, -0.01216100f, -0.00857563f, 0.02553377f, 0.01543715f, 
    -0.10252105f, 0.11359740f, 0.05405657f, -0.18954784f, 0.02436461f, 0.06907830f, 0.11115125f, 0.03468916f, 
    0.02619705f, 0.10410404f, 0.06835825f, 0.05402822f, -0.04119323f, -0.15885614f, -0.01804385f, 0.00713990f, 
    0.06316856f, -0.01764872f, 0.04364863f, 0.00653631f, 0.04802207f, 0.03866926f, 0.05548505f, 0.02327166f, 
    0.37826881f, 0.26894483f, -0.03622819f, 0.01682149f, 0.06845363f, 0.07051384f, 0.06086064f, -0.01173388f, 
    -0.07474931f, 0.07114302f, -0.07248253f, -0.03688383f, -0.03134190f, -0.07206127f, -0.18817759f, -0.25415608f, 
    -0.09141617f, -0.08616199f, 0.02381151f, 0.01302973f, -0.00528455f, 0.11533869f, 0.01536174f, 0.02507141f, 
    0.04956507f, 0.10599583f, -0.07246818f, -0.01565290f, 0.09787580f, 0.04862313f, -0.11616363f, 0.06315289f, 
    0.08335008f, -0.04048522f, -0.04358464f, 0.04961344f, 0.01814562f, 0.04551855f, 0.08053511f, 0.19380544f, 
    -0.11851083f, 0.01167457f, 0.09616078f, 0.04263327f, 0.05830556f, -0.04476618f, -0.07384721f, 0.02792827f, 
    0.15701284f, 0.06223864f, -0.04845111f, -0.01120496f, -0.07803824f, 0.01782571f, -0.03708806f, 0.10179079f, 
    0.09134150f, 0.00873136f, 0.00362910f, 0.05343261f, -0.04940455f, -0.01975633f, 0.02230781f, -0.02272705f, 
    -0.08123774f, 0.03126756f, 0.05309444f, 0.12918140f, 0.00331436f, 0.07837462f, -0.02752608f, 0.09610536f, 
    -0.02860030f, 0.17919491f, 0.03924567f, -0.00416010f, 0.01856523f, 0.03070340f, 0.03324407f, 0.10440245f, 
    -0.03794856f, 0.08127013f, 0.05060049f, -0.01758933f, 0.28427699f, 0.15295286f, -0.00075138f, -0.02451341f, 
    0.02782266f, -0.08502933f, 0.04555191f, 0.07534530f, 0.07089210f, 0.06131763f, -0.03225504f, -0.09203564f, 
    -0.37562552f, -0.18496715f, 0.05340928f, 0.13920060f, 0.09634553f, -0.02712988f, -0.03992541f, 0.09449325f, 
    0.02538305f, -0.10229839f, 0.02673439f, 0.07779495f, -0.15884015f, 0.32665598f, 0.03132565f, 0.17074418f, 
    0.02650306f, 0.07308967f, 0.06177545f, 0.09980784f, -0.06283525f, 0.04008555f, -0.07096386f, -0.06523159f, 
    -0.11014481f, 0.00912377f, 0.05694785f, 0.01340770f, 0.01629927f, -0.01756412f, 0.10370012f, 0.00660740f, 
    0.07763595f, 0.08699991f, 0.10227408f, -0.01582364f, -0.43239665f, -0.13035581f, -0.05468978f, -0.31077117f, 
    -0.07376267f, -0.00925258f, -0.02316141f, 0.05061623f, 0.03077700f, -0.02300496f, 0.03217452f, 0.14403678f, 
    -0.01849661f, 0.06466725f, -0.01139709f, -0.16592158f, 0.04431074f, 0.12550344f, -0.00961320f, -0.05103636f, 
    0.06887579f, 0.06571966f, -0.12871842f, 0.12051061f, -0.04517684f, -0.17534599f, 0.08663279f, 0.11579908f, 
    0.02456180f, 0.15206929f, 0.07349177f, -0.09924458f, -0.01842275f, -0.05461169f, 0.03876100f, -0.06006379f, 
    0.24908249f, 0.36192906f, -0.01625278f, -0.10210287f, 0.18558091f, 0.17755553f, -0.00462806f, 0.10706253f, 
    -0.09005954f, -0.00019556f, 0.03740343f, 0.03346449f, 0.35102704f, 0.06891404f, -0.10642200f, -0.12893337f, 
    -0.20995845f, 0.04003059f, 0.01578288f, 0.02365868f, -0.16340640f, 0.01819886f, 0.03932713f, -0.03900324f, 
    -0.11303858f, -0.18452294f, 0.01766524f, 0.28178138f, 0.02602518f, 0.09850473f, 0.05681436f, 0.04450458f, 
    -0.04632587f, -0.07297310f, 0.05761597f, -0.00887936f, 0.05189687f, -0.15732051f, -0.05889731f, -0.19783714f, 
    -0.19196072f, -0.04589009f, -0.01983249f, 0.07356482f, -0.05367845f, 0.09885970f, -0.11196728f, -0.01177928f, 
    -0.15900563f, -0.18708804f, 0.10007980f, 0.01005120f, 0.07784338f, -0.01949781f, 0.03621760f, 0.00572917f, 
    -0.01106226f, -0.06100974f, 0.00311088f, 0.11383571f, -0.07279778f, 0.33370310f, 0.08908580f, 0.14126971f, 
    -0.02324485f, 0.01145446f, 0.05660784f, 0.02502703f, -0.07625385f, 0.03331348f, 0.12588456f, 0.00564937f, 
    -0.06955010f, -0.11397357f, -0.06746785f, 0.06096654f, -0.07012757f, 0.05938198f, -0.02107720f, 0.08627272f, 
    -0.04286403f, 0.03657271f, 0.04249230f, 0.01983341f, 0.16817886f, 0.05618612f, 0.01664149f, -0.09380643f, 
    0.02783122f, -0.01233759f, 0.00270182f, 0.09408960f, 0.10316334f, 0.01818158f, -0.05872010f, 0.12065029f, 
    0.17509684f, 0.06462497f, -0.11234605f, 0.00904801f, -0.10459770f, -0.01427604f, -0.11872326f, -0.10235718f, 
    0.07353691f, -0.04638422f, -0.11877358f, 0.04326545f, 0.18065959f, 0.09011146f, -0.01985172f, 0.06455489f, 
    0.05174732f, 0.04351832f, 0.07161897f, 0.06242190f, 0.07027772f, -0.01491005f, 0.00849276f, -0.00932455f, 
    -0.00327784f, -0.02279661f, -0.07806652f, -0.09818887f, -0.10206603f, -0.06201115f, 0.01203295f, -0.07675651f, 
    -0.05376270f, 0.11677044f, 0.08844750f, 0.01350369f, 0.01666992f, -0.22519825f, 0.07726196f, 0.20499440f, 
    0.08840579f, -0.01351529f, 0.01689438f, -0.02908700f, -0.01444362f, -0.04889467f, 0.05318382f, -0.07639989f, 
    0.01007176f, -0.10511059f, -0.16361915f, -0.00043710f, 0.02911659f, -0.09079160f, 0.09020700f, -0.03962240f, 
    0.15041046f, -0.00065466f, 0.01582853f, 0.00102569f, 0.15273096f, 0.07669333f, -0.03340034f, -0.00523067f, 
    -0.01190778f, 0.05417469f, -0.02088123f, -0.03209340f, -0.02012222f, -0.00413073f, 0.03754663f, 0.18771473f, 
    -0.20828721f, -0.00417829f, -0.15672949f, 0.22601345f, 0.00014806f, 0.12071892f, 0.06934342f, 0.01569125f, 
    -0.02474125f, 0.03766803f, -0.03565522f, -0.02566644f, 0.09326653f, 0.02112243f, -0.08050236f, -0.13063402f, 
    -0.10392638f, -0.05392628f, 0.06881268f, -0.01458919f, -0.00840909f, 0.00518337f, -0.02924966f, -0.02559997f, 
    -0.25451270f, 0.08690481f, -0.02568685f, -0.10477340f, -0.04376557f, -0.04663053f, 0.07677364f, -0.03635577f, 
    -0.10600829f, -0.03416759f, -0.01855997f, 0.11177357f, 0.07998075f, -0.03336911f, -0.09360587f, -0.20597453f, 
    -0.08159881f, -0.14043275f, -0.02600608f, -0.10754400f, 0.04989345f, -0.06556289f, -0.02370830f, 0.10314801f, 
    0.14741790f, 0.02369856f, 0.12610607f, 0.15922311f, 0.02870181f, 0.03440445f, 0.04708742f, 0.00166237f, 
    0.00694241f, -0.00523923f, 0.06069088f, -0.07241875f, 0.05318649f, 0.04683685f, -0.07502432f, 0.04612696f, 
    -0.17581078f, 0.07094347f, -0.01314744f, -0.06283551f, 0.12058635f, 0.02511791f, 0.02205129f, 0.04846109f, 
    -0.00053103f, -0.15461047f, 0.19081825f, 0.02532609f, 0.01874374f, 0.04915927f, 0.07588726f, 0.07228804f, 
    0.04853663f, 0.12826359f, -0.02219142f, 0.05806799f, 0.02341304f, 0.22257760f, 0.11856288f, -0.08754279f, 
    0.07991870f, 0.13071260f, 0.07769474f, 0.05812605f, -0.00701523f, 0.02007084f, 0.04841901f, 0.03278972f, 
    -0.12253372f, 0.18479653f, -0.03301422f, -0.07675411f, 0.04982191f, -0.03532363f, 0.05060421f, 0.05887900f, 
    -0.06050280f, 0.08056110f, 0.01233617f, 0.09062949f, 0.40269154f, -0.27359310f, -0.04092846f, -0.10808244f, 
    -0.05608241f, 0.02497114f, 0.04390467f, 0.06986372f, -0.01896167f, -0.01054169f, 0.04922782f, -0.02310765f, 
    0.17688754f, -0.10123330f, 0.23334320f, 0.10045538f, -0.03100083f, 0.07555731f, -0.02689997f, -0.01532307f, 
    0.11835955f, -0.04707460f, 0.11827997f, -0.00919219f, 0.16740368f, -0.02508865f, -0.02216298f, -0.20683330f, 
    0.03741274f, -0.05506680f, 0.05242515f, -0.08657902f, -0.05929654f, 0.01870046f, 0.00192331f, -0.05143909f, 
    0.19615249f, -0.19718415f, 0.18366492f, 0.19274490f, -0.05989781f, -0.05327496f, 0.01393369f, 0.00384640f, 
    0.10518215f, 0.03156736f, 0.01514489f, 0.03647024f, 0.07940041f, 0.12443708f, 0.14702764f, -0.03142555f, 
    -0.04641144f, 0.08783150f, 0.16402033f, 0.12183074f, 0.07244813f, -0.04505530f, 0.07169731f, 0.02602065f, 
    -0.05276057f, 0.07280660f, 0.01344400f, 0.02592999f, 0.10718863f, 0.07562055f, 0.03549841f, -0.02744458f, 
    -0.03944242f, 0.01277641f, 0.04354208f, 0.12214886f, -0.06429115f, -0.19186383f, -0.04889055f, -0.09602792f, 
    -0.04380017f, 0.02700201f, 0.02636426f, 0.01312742f, 0.05057896f, 0.08083800f, 0.00384481f, 0.08327668f, 
    -0.07279721f, 0.05936003f, -0.03187516f, 0.24310580f, 0.06229753f, 0.02761343f, 0.02544271f, 0.04217476f, 
    0.01480720f, 0.05343359f, -0.05657424f, -0.00014142f, -0.02087750f, 0.18319662f, -0.08127045f, -0.04871571f, 
    -0.04227502f, 0.07105190f, 0.04331721f, 0.01617496f, -0.04215689f, -0.07355295f, 0.01946283f, -0.04417646f, 
    -0.34941304f, -0.07669479f, -0.01732523f, -0.21274498f, 0.12349449f, -0.03984408f, -0.01201947f, -0.02084276f, 
    0.02620000f, -0.03975263f, -0.02716198f, 0.06143839f, 0.28319824f, -0.07808141f, -0.15618406f, -0.07705042f, 
    -0.11212270f, 0.04669102f, 0.03144788f, -0.03749631f, -0.00067049f, -0.08909451f, -0.04515075f, 0.03999006f, 
    0.00776264f, -0.09796188f, -0.14829673f, -0.07799307f, -0.08432965f, -0.00723745f, -0.04450797f, 0.05950958f, 
    0.09135430f, 0.03404504f, 0.12746845f, 0.02140052f, 0.44630089f, 0.07231350f, 0.08112238f, 0.21017300f, 
    0.14275029f, -0.01137014f, -0.01610465f, -0.05307256f, 0.02644547f, 0.09781722f, 0.12518710f, -0.03026916f, 
    -0.20366530f, -0.09489962f, 0.03689887f, 0.03047879f, -0.09727309f, 0.05052030f, 0.03881217f, 0.04086683f, 
    -0.00278180f, -0.00969671f, 0.05435215f, -0.03153539f, -0.00394721f, 0.13200133f, -0.09973370f, -0.07639005f, 
    0.11271495f, 0.08575230f, -0.09251613f, 0.06752140f, 0.09000815f, -0.05037471f, -0.06070334f, -0.10463158f, 
    0.20646457f, 0.18964429f, -0.10758827f, 0.08169765f, 0.16661897f, 0.05044106f, 0.15223414f, 0.08120196f, 
    -0.06719282f, -0.02417563f, 0.03173570f, -0.06461614f, -0.09524351f, 0.09288218f, 0.01457102f, 0.10100498f, 
    0.13511167f, 0.06012383f, 0.01836136f, 0.13373087f, -0.04858075f, -0.01688131f, -0.06220694f, -0.00084574f, 
    0.00962501f, 0.17381059f, -0.08264685f, 0.19851008f, 0.06903020f, 0.04101232f, 0.00643819f, 0.07666191f, 
    -0.01662157f, 0.09914221f, 0.01429966f, 0.04605073f, 0.27350739f, -0.08537550f, -0.07721701f, -0.19566076f, 
    -0.18466827f, -0.00270394f, -0.09448677f, -0.08229979f, -0.00233764f, 0.04276188f, -0.00612576f, 0.04534730f, 
    -0.39929736f, -0.23390532f, -0.01976406f, -0.27664572f, -0.02595641f, 0.07686537f, -0.02270131f, -0.02607208f, 
    0.05449656f, 0.06222251f, 0.05105903f, 0.04574124f, -0.07211836f, 0.02156755f, -0.01168956f, -0.02830116f, 
    0.07764839f, -0.02226455f, 0.03473653f, -0.04572679f, -0.01162357f, 0.01878272f, -0.01463941f, 0.09826514f, 
    -0.30642465f, 0.08847403f, 0.10472204f, -0.00444446f, -0.02219660f, 0.05144159f, 0.15170148f, -0.02476956f, 
    -0.06141813f, 0.05426271f, 0.06985720f, 0.06381878f, 0.03270168f, -0.07209317f, -0.09778988f, -0.07825126f, 
    0.00654281f, 0.04440785f, -0.00398967f, -0.00282315f, 0.05461766f, -0.10149809f, 0.05212919f, -0.03445639f, 
    0.17824262f, -0.18087347f, -0.00010780f, 0.02649467f, -0.06866587f, 0.02229710f, 0.02710492f, -0.01348683f, 
    -0.02569812f, 0.03347075f, -0.14234138f, 0.04400105f, -0.06327153f, -0.04212810f, 0.07859508f, 0.03512542f, 
    0.04561321f, 0.08803064f, 0.08468338f, 0.02649963f, 0.03875552f, -0.09870588f, 0.03260183f, 0.06108487f, 
    0.00531498f, -0.11319911f, -0.13397175f, 0.10923363f, -0.08822344f, -0.05223933f, 0.00896328f, -0.04795925f, 
    -0.08717576f, -0.07025678f, 0.03180094f, -0.00702953f, -0.09663848f, 0.29452759f, 0.03516120f, 0.01673855f, 
    -0.09090669f, 0.01082568f, 0.01930328f, 0.01843670f, 0.04640114f, 0.02675929f, -0.07175541f, 0.10925839f, 
    0.00107268f, -0.15494053f, 0.02254681f, 0.07028009f, -0.07316917f, -0.00843485f, -0.04391478f, 0.05383259f, 
    -0.01458771f, 0.09530877f, 0.08906981f, -0.00644785f, 0.21974383f, 0.17721629f, 0.02038251f, 0.13086490f, 
    -0.03480431f, 0.14388917f, -0.03087771f, -0.00915869f, -0.07324532f, -0.10052066f, -0.10861713f, -0.03619920f, 
    0.08232690f, 0.08145449f, 0.09294001f, 0.05596108f, -0.01486721f, -0.02485572f, 0.00308094f, -0.02365392f, 
    0.01346419f, -0.02619225f, -0.03947657f, -0.00964784f, -0.18443505f, 0.00814108f, 0.11385942f, -0.13670856f, 
    0.07207969f, 0.01391703f, -0.07958538f, 0.07991374f, -0.09341859f, 0.04070869f, 0.13962825f, 0.12307606f, 
    0.07546066f, -0.00905754f, -0.11386614f, -0.07131474f, 0.00869308f, -0.01026249f, 0.08554061f, -0.04963819f, 
    -0.06518506f, 0.02879544f, 0.00082918f, -0.06366440f, -0.01165863f, 0.18663923f, 0.03625365f, 0.01997904f, 
    -0.01952170f, 0.05652225f, -0.01345920f, -0.15768631f, -0.00188512f, -0.01230384f, 0.08614308f, -0.06970735f, 
    0.01658250f, -0.05211014f, -0.02987229f, 0.05357365f, 0.06037439f, -0.06408622f, 0.00814509f, -0.02758688f, 
    0.08350235f, 0.05145167f, -0.03800102f, -0.02972664f, -0.16635792f, -0.02758570f, 0.02020482f, 0.14496268f, 
    0.01645684f, 0.06344590f, 0.01728363f, 0.02647884f, -0.03242652f, 0.09386469f, 0.03266336f, 0.04673815f, 
    -0.04484927f, 0.17688113f, 0.02102044f, -0.20226440f, -0.12350498f, -0.00608674f, 0.05748257f, 0.03965424f, 
    0.02300020f, 0.14145370f, 0.01892777f, 0.06157449f, 0.14307834f, 0.04849258f, 0.00454850f, -0.03110057f, 
    0.00311998f, 0.06805948f, 0.02362858f, -0.00055235f, 0.05113129f, 0.04121276f, 0.07931612f, 0.00747078f, 
    0.01331767f, 0.05744495f, -0.14964968f, -0.05268339f, -0.08960199f, 0.06531301f, 0.07211891f, -0.03864566f, 
    0.03311531f, -0.03073228f, -0.07938635f, 0.00231237f, 0.28288856f, -0.07196262f, -0.03391677f, 0.13892338f, 
    0.03566001f, -0.01876089f, 0.02248086f, -0.02340076f, -0.01410500f, 0.07708853f, 0.06079723f, -0.10429856f, 
    0.01267786f, 0.00452601f, 0.04902669f, 0.28522763f, 0.04398689f, 0.04643341f, -0.04387381f, -0.04970342f, 
    -0.03589594f, -0.00299017f, 0.16840777f, -0.09986037f, -0.21788813f, 0.13783242f, -0.02749579f, 0.14392997f, 
    0.00653674f, 0.01440940f, 0.00082354f, 0.09428607f, -0.05972536f, 0.06785077f, 0.10835999f, 0.07572553f, 
    -0.08072082f, -0.14879863f, -0.14396156f, 0.23875546f, -0.01040888f, -0.08555412f, -0.00395444f, 0.02648018f, 
    0.09302603f, 0.04799871f, -0.03833092f, 0.01887823f, 0.08765116f, 0.26609147f, 0.10866626f, -0.00892997f, 
    0.00043071f, -0.03386461f, 0.04259608f, 0.01773349f, 0.05888932f, -0.06560273f, -0.01766859f, -0.05300468f, 
    0.10741189f, -0.14788331f, -0.10250700f, -0.04185466f, 0.03665020f, -0.00871924f, -0.14181238f, -0.03531949f, 
    0.07849704f, 0.11705605f, -0.04970108f, 0.07707591f, 0.08605068f, 0.24347375f, 0.11688020f, 0.10151945f, 
    0.01091689f, 0.02972327f, 0.01156718f, 0.01960604f, 0.03781505f, -0.02255007f, -0.01053060f, 0.14309433f, 
    -0.09170837f, -0.01904680f, 0.00049033f, 0.02237366f, -0.02378704f, -0.06080357f, -0.02531096f, 0.10346021f, 
    0.06627274f, 0.05505949f, 0.00463982f, -0.15834853f, -0.05955930f, 0.04520711f, -0.11988074f, 0.10041719f, 
    -0.01533082f, 0.02694380f, -0.04887155f, 0.06097170f, 0.00244744f, -0.02333784f, -0.10192135f, 0.10239699f, 
    -0.10658035f, -0.09614106f, 0.01663145f, -0.08773577f, 0.07627059f, 0.03836016f, 0.07500601f, 0.01967320f, 
    0.06260815f, 0.06712704f, 0.09692061f, 0.09170589f, 0.11492459f, 0.01198346f, -0.19275111f, 0.19986057f, 
    0.02290186f, 0.05535904f, 0.01296911f, 0.03792518f, 0.07479612f, -0.07473294f, 0.01303775f, -0.00692474f, 
    0.04132735f, 0.05598856f, 0.10046565f, 0.03162489f, 0.07561579f, -0.00467046f, 0.04952347f, 0.06227229f, 
    0.04385057f, 0.00919091f, 0.13062288f, 0.06551185f, -0.09904391f, -0.13660635f, -0.00243006f, 0.12146406f, 
    0.00291669f, 0.04683767f, 0.04073722f, 0.01501713f, -0.05721670f, 0.08687930f, 0.06841531f, 0.18809712f, 
    0.14803131f, -0.04507976f, -0.09689293f, -0.04183493f, 0.06039502f, 0.07599542f, 0.00553903f, 0.05661635f, 
    0.01198976f, -0.05135402f, -0.05967962f, -0.02051853f, -0.29694033f, 0.07553098f, 0.14618322f, 0.01205486f, 
    -0.10672230f, -0.05467302f, 0.08538949f, 0.07762293f, 0.12011163f, -0.01508950f, 0.01952748f, 0.12236870f, 
    -0.17540257f, 0.18338782f, 0.12712729f, -0.15588216f, -0.06028967f, 0.12402317f, 0.14938314f, -0.06407228f, 
    -0.02458511f, 0.05660245f, -0.13427511f, -0.06508266f, -0.04426542f, 0.11865175f, 0.10560557f, 0.01325685f, 
    0.04490798f, 0.05357628f, -0.03813235f, 0.02881664f, 0.04410803f, 0.11587240f, -0.06816056f, -0.15688094f, 
    0.11009425f, -0.00896494f, 0.00260560f, -0.24950436f, -0.01595883f, -0.07818365f, -0.09816123f, -0.12399884f, 
    -0.04641744f, 0.03639188f, 0.03254947f, 0.12645312f, 0.23114930f, 0.30013052f, 0.22507372f, 0.04121127f, 
    0.01067372f, 0.07488365f, -0.06483241f, -0.04312104f, 0.02876301f, -0.04762716f, -0.01646133f, -0.05088102f, 
    0.09046036f, 0.04992888f, 0.06917939f, 0.04983772f, -0.01384323f, 0.05953980f, -0.09080624f, 0.00887522f, 
    0.04469033f, 0.13792063f, 0.00023184f, -0.05483093f, 0.02311014f, 0.24410018f, 0.10673767f, 0.13200733f, 
    0.00362323f, 0.03860644f, 0.14135200f, 0.04631804f, -0.01092721f, 0.12460777f, -0.08203065f, -0.01202460f, 
    -0.18115819f, 0.22798961f, -0.08232411f, 0.03648526f, 0.06424098f, 0.00478547f, 0.00461837f, -0.04272500f, 
    -0.01543434f, -0.03377251f, -0.14487632f, 0.11138725f, -0.20200907f, 0.19357120f, 0.19324078f, -0.04385183f, 
    0.01334324f, 0.05969649f, -0.01698650f, -0.04328652f, 0.00821753f, -0.03020260f, -0.03286001f, -0.11345433f, 
    0.03074173f, 0.08739448f, 0.06209154f, 0.07055328f, 0.06026645f, -0.08787158f, 0.02102895f, -0.03615215f, 
    0.01794186f, 0.05465081f, -0.04193879f, -0.01014790f, -0.00990960f, -0.11712124f, -0.13235825f, 0.14495552f, 
    -0.04401408f, -0.04886040f, -0.02326355f, 0.02965413f, 0.08360550f, 0.04638010f, 0.03469204f, 0.00169231f, 
    0.01034412f, -0.03813575f, -0.06016021f, 0.03043269f, -0.10463551f, 0.08173779f, 0.00090301f, -0.04822843f, 
    -0.01231199f, -0.05939893f, 0.06405520f, -0.06723833f, -0.26296142f, 0.37272689f, 0.15845230f, 0.01726624f, 
    -0.00125608f, -0.01726395f, -0.06369202f, 0.14182569f, 0.04774231f, -0.02780972f, 0.01855719f, -0.03862933f, 
    -0.07050769f, -0.05611070f, 0.05060015f, 0.06800243f, 0.00090665f, -0.02865777f, 0.10344110f, -0.04234653f, 
    0.15840851f, 0.09299334f, 0.04441198f, 0.02641480f, 0.04265747f, 0.01273796f, 0.05824681f, 0.16280146f, 
    0.03598647f, 0.03205910f, 0.03804509f, 0.02255967f, -0.02408352f, -0.01522920f, 0.09775183f, 0.06611690f, 
    -0.37032557f, 0.25346330f, -0.04215239f, -0.10168822f, 0.00837794f, -0.03709007f, -0.00835964f, 0.03021510f, 
    -0.01938669f, -0.00932154f, 0.05723251f, -0.07080430f, 0.09313844f, -0.09657576f, -0.08764689f, 0.02077405f, 
    -0.03621009f, 0.06345159f, -0.06120269f, -0.04464517f, 0.02339707f, 0.01544651f, 0.06390264f, 0.05943832f, 
    -0.10707211f, -0.04738205f, -0.11312741f, -0.01018307f, -0.06972531f, -0.07722508f, -0.04715988f, 0.02325194f, 
    0.05017830f, -0.01359862f, -0.00778402f, -0.09048298f, -0.21434888f, 0.14814003f, 0.02610295f, 0.03807000f, 
    -0.01499740f, -0.11050897f, -0.06379914f, 0.03396586f, 0.02806166f, -0.04801146f, -0.07155056f, -0.11535935f, 
    -0.01620832f, 0.01194822f, -0.07518243f, -0.16119044f, 0.00802594f, -0.01453586f, -0.01790193f, -0.06630706f, 
    -0.02830856f, -0.04491002f, 0.10203058f, 0.01829618f, 0.01757677f, -0.00612460f, -0.04058437f, -0.04285006f, 
    0.08614239f, -0.06376912f, -0.04325274f, 0.00489343f, -0.01106929f, 0.04190514f, 0.04221911f, 0.11705446f, 
    -0.03562955f, -0.03511262f, -0.00333442f, 0.18054989f, 0.01124222f, -0.00409346f, -0.01641330f, 0.01336802f, 
    -0.01166248f, 0.00837157f, 0.15229402f, -0.02304007f, 0.20777366f, 0.20605484f, 0.14144327f, -0.00880371f, 
    0.05929243f, -0.00977324f, 0.03743911f, 0.06610315f, 0.01225175f, -0.01309236f, 0.01442941f, -0.09839275f, 
    -0.03958084f, -0.15358374f, -0.16269311f, 0.27428496f, 0.20446691f, 0.01292633f, 0.01701747f, -0.01358935f, 
    0.03114223f, 0.08734801f, -0.11772348f, 0.05415615f, -0.03240517f, -0.14938413f, -0.10011987f, 0.02981036f, 
    0.00046010f, -0.06174667f, -0.02131059f, 0.15541095f, -0.04166023f, 0.00927113f, -0.03683542f, -0.09446659f, 
    0.14384490f, -0.17811558f, 0.08306795f, -0.04658347f, 0.02375324f, -0.06409734f, 0.02435462f, 0.01079181f, 
    0.01081665f, 0.02179305f, 0.05717745f, -0.03841250f, -0.09057114f, 0.24883302f, 0.17118694f, -0.02326010f, 
    0.01815024f, -0.05026044f, 0.02420521f, -0.08650871f, 0.03692175f, 0.00068990f, -0.01763266f, -0.00024037f, 
    0.07415348f, -0.17741396f, 0.04842067f, 0.16576394f, 0.02463041f, 0.00848074f, 0.01490798f, -0.02199883f, 
    0.08684524f, 0.06219149f, -0.02766943f, 0.10477783f, 0.08582678f, 0.01686585f, 0.07160104f, -0.00178140f, 
    -0.02453740f, -0.00640428f, 0.07053237f, -0.07957381f, -0.03589454f, -0.05031982f, 0.05409961f, 0.04221657f, 
    0.03394813f, -0.18205082f, -0.07516984f, -0.01176066f, -0.02142883f, -0.06550100f, -0.04035014f, 0.00144876f, 
    -0.04953256f, -0.07489406f, 0.06827072f, -0.06494664f, 0.04743545f, 0.02878460f, 0.17324974f, 0.05777957f, 
    0.00101273f, -0.02502680f, 0.21794644f, 0.04772054f, 0.01006511f, -0.06839539f, -0.02192398f, 0.01691892f, 
    0.19682710f, -0.20684671f, -0.07880263f, 0.18658514f, 0.10080653f, 0.02953404f, 0.03160742f, -0.01390224f, 
    0.04359497f, -0.04996174f, 0.06291812f, 0.03535360f, 0.03107224f, -0.09594010f, -0.11081641f, 0.09151132f, 
    -0.02924978f, 0.01385621f, -0.09651132f, 0.01599777f, 0.09938458f, 0.04247924f, 0.09045597f, -0.03477696f, 
    0.25503030f, -0.03756605f, -0.17413959f, -0.03440308f, 0.05579264f, 0.02398993f, 0.03453350f, -0.01354871f, 
    0.11274001f, 0.04984588f, -0.00257061f, 0.08348490f, 0.04945827f, 0.01161364f, 0.09384587f, 0.05260307f, 
    -0.03428222f, -0.09038368f, 0.04543832f, -0.04518827f, 0.13136566f, 0.06529934f, -0.01722747f, 0.13138007f, 
    0.26694590f, 0.12105305f, -0.00526369f, -0.00801495f, 0.02072465f, -0.06810265f, 0.09844252f, 0.03583998f, 
    0.04275487f, -0.04955979f, 0.02680386f, 0.18132380f, 0.06808414f, 0.02385418f, 0.18026537f, 0.14086773f, 
    -0.00669997f, -0.08115920f, 0.01061102f, 0.05981743f, 0.01983742f, -0.02816614f, 0.05994635f, -0.01616672f, 
    0.05028884f, 0.01297332f, 0.15115862f, 0.04708170f, 0.04055141f, 0.06841163f, 0.00762289f, -0.03249671f, 
    0.02131410f, 0.00790711f, 0.01771384f, -0.01441613f, 0.07010040f, -0.10922535f, -0.03911554f, 0.01622328f, 
    0.03336541f, -0.03595211f, 0.03291589f, 0.04198404f, -0.04722117f, 0.05759135f, 0.02374247f, 0.01564947f, 
    -0.16261373f, -0.03327208f, 0.02781991f, -0.15193531f, -0.07053028f, 0.04517833f, 0.03434580f, -0.01213892f, 
    0.01801058f, 0.07397979f, -0.01217929f, 0.00526540f, -0.01191832f, 0.01530758f, -0.01613246f, -0.12521379f, 
    0.12313845f, -0.00717250f, 0.00454320f, 0.05179496f, -0.00230702f, 0.03548902f, 0.06656733f, 0.06919586f, 
    -0.14268489f, -0.01206253f, -0.06019035f, -0.10576607f, 0.05251923f, -0.06781392f, -0.09896870f, 0.03727529f, 
    -0.12644725f, 0.00169517f, 0.02694688f, -0.01209874f, 0.06339580f, -0.31405854f, -0.04184883f, -0.11131392f, 
    -0.03501787f, 0.04324930f, 0.01589752f, 0.00354535f, 0.04687354f, -0.05437922f, -0.02790862f, -0.08335577f, 
    0.17602912f, 0.09579819f, 0.20665100f, 0.03877875f, -0.00534735f, -0.09595000f, 0.05959062f, -0.04378866f, 
    0.05243658f, 0.03548303f, -0.00236296f, 0.01910739f, -0.01948242f, -0.05851123f, 0.15129234f, -0.05043443f, 
    0.11503533f, 0.03892827f, 0.01618761f, 0.14240550f, 0.01094590f, 0.02686260f, -0.04722903f, 0.04751285f, 
    0.01156746f, -0.02021062f, -0.07892382f, 0.07099020f, -0.08024054f, 0.00765457f, 0.01237150f, -0.01464164f, 
    -0.03647378f, -0.00749805f, -0.04198820f, -0.05064674f, 0.06012448f, -0.13106035f, -0.12728184f, -0.00694644f, 
    -0.03608554f, -0.01236440f, -0.00029060f, -0.00742464f, 0.06854802f, 0.02465706f, -0.07959154f, -0.00009898f, 
    0.01740900f, 0.13692099f, 0.04885044f, -0.00999899f, 0.05006093f, -0.00343455f, 0.01112651f, 0.06178451f, 
    -0.04910753f, -0.10911424f, -0.06706959f, 0.02403872f, -0.09592366f, -0.08454878f, -0.11198486f, 0.04641011f, 
    -0.05610457f, -0.03254505f, -0.01065934f, -0.06314113f, 0.03887821f, -0.01802726f, -0.01695139f, 0.05007916f, 
    -0.06568411f, 0.30817699f, 0.13352253f, 0.20204832f, 0.03415463f, -0.02465339f, -0.06856774f, 0.00979867f, 
    0.04037130f, 0.10528632f, 0.14051089f, 0.01527395f, 0.03218130f, 0.22340623f, 0.13867350f, 0.19137147f, 
    0.04332107f, 0.03256430f, 0.00714026f, -0.01325302f, -0.07091592f, 0.06904913f, 0.03667226f, 0.05668440f, 
    -0.15590000f, -0.06215111f, -0.10974125f, -0.07860550f, 0.04521708f, 0.04913487f, 0.02347078f, 0.15924482f, 
    -0.01051172f, 0.06260360f, -0.03492751f, 0.04677657f, 0.24670535f, 0.05721521f, -0.05710723f, -0.15787135f, 
    -0.06717876f, 0.07304540f, 0.03575443f, -0.00457221f, 0.01397658f, 0.05247181f, -0.14069644f, -0.01642735f, 
    0.23374104f, -0.07318244f, 0.03915957f, -0.16532482f, -0.03167497f, 0.01299659f, -0.06396268f, -0.04690999f, 
    0.07157944f, -0.05273599f, 0.11703148f, 0.00119292f, 0.32001153f, -0.11021298f, 0.11689360f, -0.06668986f, 
    0.09644560f, 0.04855392f, -0.03078448f, 0.08230948f, 0.08233291f, 0.07851834f, -0.00043908f, 0.12510607f, 
    0.12036159f, 0.28885183f, -0.04357520f, 0.08038805f, -0.14364830f, 0.01540761f, 0.15879782f, -0.00290050f, 
    0.00428344f, -0.10206261f, 0.10441933f, -0.07496995f, 0.03324376f, -0.03906996f, -0.07829025f, 0.02509348f, 
    0.08972150f, -0.00369325f, 0.04414513f, 0.13995534f, 0.07030674f, -0.06478974f, -0.02308807f, 0.03101050f, 
    0.19763704f, 0.11522934f, -0.07145577f, -0.05568110f, 0.03763794f, -0.03247340f, 0.01655855f, -0.06447555f, 
    -0.13005726f, 0.02597807f, 0.03518213f, 0.10647176f, 0.03420724f, -0.23993392f, -0.01720686f, -0.00018244f, 
    0.00055920f, -0.01279744f, 0.05321868f, -0.09206904f, 0.04716248f, -0.02727205f, 0.06819516f, -0.04648995f, 
    0.20297015f, 0.27962026f, 0.11888581f, -0.03386620f, -0.03872846f, -0.03205524f, 0.09653156f, 0.05266992f, 
    -0.13726413f, 0.01649426f, -0.05472251f, -0.02202094f, -0.03985657f, 0.06995293f, 0.10785668f, -0.02468116f, 
    0.10669535f, -0.00984444f, 0.07964142f, -0.04503638f, -0.10230848f, 0.09943680f, -0.10599664f, 0.04019880f, 
    0.02310245f, -0.12009329f, 0.06435376f, -0.14956017f, 0.13683760f, 0.03720846f, 0.02880713f, 0.08052083f, 
    0.09944923f, 0.12584236f, -0.08829807f, -0.07369970f, 0.02761211f, 0.10064279f, 0.10004383f, -0.16520937f, 
    -0.12059411f, -0.06753999f, 0.03696738f, -0.08887176f, -0.01453890f, 0.02592328f, -0.03372347f, -0.06429160f, 
    -0.27521414f, -0.03747458f, 0.08042094f, 0.12488296f, 0.04990680f, -0.02647936f, 0.08118401f, 0.02851991f, 
    -0.05001896f, 0.04394753f, -0.08454718f, 0.00786130f, 0.27330083f, 0.05418269f, -0.03058237f, 0.02030711f, 
    0.07258795f, 0.12860465f, 0.00592362f, -0.05858880f, -0.08994107f, -0.04007117f, 0.01148561f, -0.03785734f, 
    0.08592667f, 0.01523743f, -0.09049840f, -0.00362602f, -0.04024645f, -0.14551540f, -0.03199589f, 0.14334868f, 
    -0.12604176f, -0.03517418f, 0.13689594f, 0.05781732f, 0.10015991f, -0.13941459f, -0.17310937f, -0.14087367f, 
    0.01358501f, -0.00581877f, 0.02227273f, -0.01846264f, -0.01536182f, -0.05559535f, 0.05290316f, 0.00326000f, 
    0.36817554f, 0.15119520f, 0.10503689f, -0.01314792f, 0.02534101f, 0.00359880f, 0.13216323f, 0.13425191f, 
    0.02747281f, 0.03708551f, -0.02206269f, -0.07694600f, 0.23639080f, -0.13300721f, -0.07304671f, 0.10244785f, 
    0.13885930f, -0.00806330f, 0.09722517f, 0.03060149f, 0.03144539f, 0.00087648f, -0.03451195f, 0.09358676f, 
    0.06545221f, -0.25972393f, -0.06278406f, -0.00212902f, 0.05411914f, 0.00010066f, 0.00050023f, 0.04521573f, 
    0.02949433f, -0.03251756f, 0.02634439f, 0.11860426f, -0.00893000f, -0.20189555f, 0.02621178f, -0.05098434f, 
    -0.01752426f, 0.03350557f, 0.00945652f, 0.05117624f, 0.02295578f, -0.00292252f, -0.01787712f, 0.05999139f, 
    0.31067604f, -0.00882436f, -0.04130191f, -0.03339317f, -0.08916343f, 0.08415551f, -0.03323768f, -0.02592292f, 
    0.02817202f, 0.07048324f, 0.16991402f, -0.00364894f, -0.07954369f, -0.13387302f, -0.20117685f, -0.02741249f, 
    0.12132772f, 0.01962541f, -0.00040003f, 0.00658816f, -0.02695341f, 0.13244070f, 0.10170879f, 0.12095974f, 
    -0.23853441f, -0.09985652f, 0.22447251f, -0.30532792f, -0.15507981f, 0.17917697f, 0.10526430f, 0.02613669f, 
    0.11637055f, -0.00241725f, 0.00932621f, 0.02171312f, 0.03014133f, 0.02892944f, 0.11988223f, -0.16529755f, 
    0.01461406f, 0.01172296f, -0.02156899f, 0.05000016f, -0.08440394f, -0.09055760f, -0.01490364f, 0.03107377f, 
    0.23695651f, 0.03413040f, 0.00981800f, -0.07734226f, 0.01159795f, -0.04136558f, 0.02779987f, 0.03251317f, 
    -0.06275012f, 0.02525172f, -0.02397645f, 0.04007737f, 0.21952485f, -0.00281677f, -0.03553453f, -0.07103048f, 
    0.09057245f, -0.02458877f, -0.03491610f, -0.06274167f, 0.09512171f, 0.03340420f, -0.06360022f, 0.07560818f, 
    -0.01765265f, 0.17980537f, 0.12208612f, -0.15080251f, 0.01890334f, -0.02608811f, 0.03803987f, -0.14032656f, 
    -0.12341251f, 0.10166755f, 0.13311917f, 0.01230926f, -0.29422644f, -0.10848513f, 0.10016981f, -0.17045078f, 
    -0.01710620f, 0.07071144f, 0.11662575f, -0.05727395f, 0.04719537f, -0.03367126f, 0.03424076f, 0.02300285f, 
    0.28167099f, -0.08691263f, -0.04309352f, 0.11303053f, -0.02236163f, 0.09295827f, 0.00297164f, -0.06047113f, 
    -0.04764669f, 0.01010745f, 0.01777985f, 0.03893376f, -0.13780081f, -0.06276638f, 0.05943783f, 0.11258366f, 
    -0.05864284f, -0.09785496f, 0.04029222f, 0.07800347f, -0.07123724f, 0.02684530f, -0.01059652f, -0.03612733f, 
    0.16349401f, 0.07917819f, 0.08542701f, 0.15776433f, 0.07872169f, 0.02566597f, 0.02303506f, -0.04276625f, 
    -0.02008228f, 0.01593243f, 0.02197426f, 0.08824622f, 0.29475608f, -0.02278568f, 0.14729877f, 0.19840461f, 
    0.05783756f, 0.12387378f, 0.03229707f, -0.09673278f, 0.01563437f, 0.06190190f, -0.04350841f, 0.09723325f, 
    0.01766241f, 0.25291631f, 0.24025539f, -0.13047709f, -0.07529539f, 0.05632824f, 0.11112677f, -0.01356146f, 
    -0.00345686f, 0.08553375f, 0.00145803f, -0.00195163f, 0.08190475f, -0.13504232f, -0.09174604f, 0.05384220f, 
    -0.10212292f, 0.01523015f, -0.03592945f, 0.10884084f, 0.00505136f, 0.01652846f, -0.04468284f, -0.05165530f, 
    0.31532562f, 0.00441644f, -0.02581649f, 0.09354666f, 0.00354615f, 0.04517121f, 0.11356292f, 0.00005742f, 
    -0.02490705f, 0.00384431f, 0.00669932f, -0.05611909f, 0.04317298f, -0.01821462f, 0.10562951f, -0.10545895f, 
    0.05587877f, -0.02098270f, -0.03384919f, 0.06641011f, 0.07728406f, -0.02840533f, 0.02414215f, 0.05391722f, 
    0.07293613f, 0.23165210f, 0.16482094f, -0.06403040f, -0.04923370f, 0.05024567f, 0.07308747f, 0.01631046f, 
    -0.03096548f, 0.03605343f, 0.13261071f, -0.02466737f, -0.07607654f, 0.04242646f, 0.04288337f, 0.10319842f, 
    -0.02104612f, 0.14650002f, 0.08714434f, -0.14713475f, 0.13234997f, 0.04935964f, 0.00147981f, 0.10519336f, 
    -0.00211973f, 0.16308720f, 0.00841162f, -0.10454827f, 0.09325035f, 0.05228836f, -0.03685099f, 0.03413985f, 
    -0.01448625f, -0.02291686f, 0.02360653f, -0.03042447f, -0.21619916f, -0.27939767f, -0.13311534f, -0.15360935f, 
    0.06221011f, 0.09754272f, -0.02770174f, 0.03564098f, -0.11915463f, -0.04818204f, 0.10548085f, 0.07230577f, 
    -0.03577124f, 0.06052181f, 0.12863302f, -0.17110698f, -0.06983065f, -0.15340181f, 0.04024572f, 0.00002656f, 
    -0.03710077f, -0.04444886f, 0.01467182f, -0.05043186f, 0.26843938f, 0.03157734f, -0.08637005f, -0.11434785f, 
    0.02742297f, -0.03208459f, -0.09005017f, -0.02715760f, 0.05564496f, -0.00912664f, 0.07300470f, -0.01423714f, 
    0.02745987f, 0.27382013f, 0.10560281f, -0.02944620f, -0.03338575f, -0.00115200f, 0.08498187f, 0.03039736f, 
    0.01665379f, 0.01022127f, -0.00019719f, -0.07955559f, -0.03164466f, -0.11605407f, 0.03635722f, -0.06555975f, 
    0.13038422f, 0.04804074f, -0.16233706f, 0.04360945f, 0.04305006f, 0.11799191f, 0.06822935f, 0.06789491f, 
    0.11280593f, 0.33671814f, 0.10251089f, 0.11274311f, 0.04718387f, -0.05778106f, 0.00084880f, 0.01912521f, 
    -0.04779701f, 0.06296834f, -0.00950886f, -0.01366896f, -0.04493692f, 0.22760603f, 0.07065064f, 0.22066481f, 
    -0.13699330f, -0.04855463f, 0.01474781f, -0.03351783f, 0.00911970f, -0.08794814f, 0.01410431f, 0.12436049f, 
    0.08722334f, 0.06654439f, 0.20460258f, 0.04770914f, -0.01897945f, -0.03496565f, -0.05776728f, 0.03104511f, 
    -0.01487983f, -0.03238055f, 0.05925361f, -0.03315162f, -0.30577093f, 0.06603700f, -0.09369304f, -0.06733683f, 
    0.06371313f, 0.08326210f, 0.01348843f, 0.05181441f, -0.10043846f, -0.09805546f, 0.08430408f, 0.04466782f, 
    -0.32586330f, 0.08647259f, 0.15143745f, -0.02157531f, 0.06238005f, 0.11257061f, -0.00443066f, 0.02649762f, 
    -0.02427118f, 0.03073811f, 0.04830540f, 0.02631563f, -0.25969312f, -0.18786426f, 0.02001468f, -0.11842739f, 
    0.05939860f, 0.06376884f, 0.05355379f, -0.16598354f, -0.04829277f, 0.13005018f, -0.01810557f, -0.00096329f, 
    0.12657429f, 0.03489517f, 0.07746536f, 0.13154653f, 0.12850669f, 0.04920285f, 0.04518106f, 0.13288058f, 
    0.07269956f, -0.07065335f, 0.10295180f, 0.02516882f, 0.54733902f, -0.08646442f, 0.08434428f, -0.02780034f, 
    -0.09468716f, -0.00041322f, 0.03576311f, 0.04950279f, -0.02690025f, -0.04155871f, 0.09112929f, -0.02872469f, 
    -0.03510364f, -0.06973012f, -0.10409514f, -0.06921071f, 0.10186289f, 0.04730888f, -0.03331851f, -0.03976564f, 
    0.10573839f, 0.05032401f, 0.13155091f, -0.01141428f, 0.01346579f, -0.01130400f, 0.14286192f, 0.13269953f, 
    0.02614938f, -0.08096702f, 0.12363750f, 0.08225826f, 0.07455980f, 0.01693398f, -0.08129358f, -0.07830129f, 
    -0.16133638f, -0.19190642f, -0.20159492f, -0.10132501f, -0.01292191f, 0.06893428f, 0.07570081f, 0.02005460f, 
    0.13579391f, 0.16125111f, 0.05865504f, -0.03228844f, 0.19375920f, 0.07500888f, -0.29354456f, 0.00739708f, 
    -0.00994142f, 0.05472466f, -0.05127280f, -0.07102899f, 0.02132387f, 0.03205372f, -0.00478824f, -0.02094326f, 
    0.07730082f, -0.05864848f, 0.04624963f, 0.13447627f, 0.04114226f, -0.04454053f, 0.03215437f, 0.08149955f, 
    -0.04630290f, 0.00617873f, 0.00778047f, 0.03383049f, 0.10201087f, -0.07314613f, -0.03346746f, -0.00974009f, 
    -0.03116640f, -0.03422604f, -0.05255681f, -0.02843956f, -0.11707221f, -0.13226561f, 0.04073245f, 0.00340131f, 
    0.01636877f, 0.00438927f, -0.11989233f, -0.16581351f, -0.01996140f, -0.00182879f, 0.00290421f, 0.00889550f, 
    -0.03235569f, 0.03900691f, -0.00109511f, 0.14072475f, 0.02414595f, 0.05651906f, 0.01845164f, -0.24660964f, 
    -0.01545294f, 0.05247852f, 0.02391452f, -0.12537859f, 0.04654081f, -0.15816461f, -0.05829199f, -0.01379163f, 
    0.26117572f, -0.17611009f, -0.22631648f, -0.17417753f, 0.06331856f, -0.08504307f, 0.06386172f, -0.03577419f, 
    -0.05704644f, 0.06348125f, 0.04227823f, -0.06430873f, -0.01906059f, -0.21393983f, -0.18365921f, -0.17253916f, 
    0.01419136f, 0.02697964f, 0.01255115f, 0.03630588f, -0.06041005f, 0.06611828f, -0.06469931f, 0.06541766f, 
    0.37228614f, -0.26590189f, -0.04866438f, 0.08349367f, 0.11228360f, 0.01323589f, 0.02612760f, 0.07257753f, 
    0.02123103f, -0.07412447f, -0.10411746f, -0.01288331f, 0.29516494f, 0.03714512f, 0.15633649f, 0.14709663f, 
    0.05147706f, -0.03947897f, 0.03724448f, -0.00664493f, 0.02310306f, -0.03178243f, -0.04842067f, 0.02221769f, 
    -0.06954633f, -0.07250666f, -0.00382386f, -0.30705547f, 0.01887191f, 0.01670300f, 0.00508399f, -0.03616341f, 
    0.00997866f, -0.02522768f, -0.05171394f, 0.03024471f, 0.03792626f, 0.00390770f, -0.09507903f, 0.04016858f, 
    0.04032632f, -0.11749721f, 0.06526180f, -0.01833290f, 0.04759355f, 0.00589802f, -0.00828677f, -0.04998865f, 
    -0.07032086f, 0.08253483f, 0.04322612f, 0.16870126f, 0.04181889f, 0.09884555f, 0.09324560f, -0.00774742f, 
    -0.11415122f, 0.08395982f, -0.03133379f, 0.03656305f, -0.20218500f, 0.07318430f, 0.00844395f, 0.08546731f, 
    0.05507844f, -0.11307769f, -0.10031129f, 0.06385595f, -0.04400328f, 0.07228441f, 0.01117554f, 0.00785759f, 
    -0.48509392f, 0.15403904f, 0.07001916f, -0.10019705f, -0.06403580f, -0.02147813f, 0.04819572f, 0.05427948f, 
    0.03468884f, 0.00019689f, -0.00190739f, 0.06411634f, 0.12394293f, 0.11149359f, 0.16040136f, 0.16325213f, 
    -0.13244393f, 0.03029518f, -0.02059136f, 0.03923790f, 0.00407781f, 0.04690818f, 0.05307910f, 0.00131177f, 
    0.18753612f, -0.06065491f, 0.00410355f, -0.21577592f, -0.01421044f, 0.03014484f, -0.01745750f, -0.05358389f, 
    0.18778966f, 0.05868892f, -0.03982456f, 0.05638618f, -0.03081924f, -0.01283070f, -0.22860186f, -0.16286193f, 
    0.11999916f, 0.04195137f, 0.02649798f, -0.00085622f, -0.05432718f, 0.01962818f, 0.04321131f, -0.02768415f, 
    0.04907783f, 0.05025549f, -0.02797274f, 0.02387535f, 0.00432287f, -0.00918064f, 0.02533750f, -0.12764665f, 
    0.05363240f, -0.00164711f, 0.07611988f, 0.01208047f, 0.02740098f, -0.10039515f, 0.14477140f, 0.08215174f, 
    -0.09153711f, -0.02103668f, -0.10234896f, 0.01386796f, 0.01063512f, -0.08609906f, 0.14098313f, -0.12674809f, 
    -0.11199459f, -0.05413903f, 0.09905525f, 0.19467084f, -0.02551304f, 0.00473857f, 0.07248567f, -0.05285792f, 
    -0.10850123f, -0.11203734f, 0.02989257f, 0.05766643f, -0.02733777f, -0.06257803f, 0.06602047f, 0.09494121f, 
    0.00833182f, 0.04277402f, -0.00882992f, -0.05832825f, -0.02817157f, -0.05834419f, 0.05207311f, 0.06439684f, 
    0.11430600f, 0.14621978f, 0.06697607f, -0.09252357f, -0.07264736f, 0.00510386f, -0.02248721f, 0.02471730f, 
    0.06937485f, 0.02738834f, 0.02920473f, -0.06242883f, 0.11167288f, -0.05152701f, 0.03713753f, -0.01230413f, 
    -0.09980924f, 0.01826857f, -0.00524144f, 0.02323494f, 0.04331439f, 0.14765517f, -0.00690304f, -0.08314538f, 
    0.28968158f, -0.00927814f, 0.02786189f, -0.05939934f, -0.00880264f, -0.05637728f, 0.00586162f, 0.13619812f, 
    -0.06365396f, 0.05490564f, 0.01133604f, 0.03682223f, 0.15868033f, 0.21121104f, -0.02866742f, -0.13685285f, 
    0.05788975f, -0.03166863f, -0.10104039f, -0.03785984f, 0.09251549f, 0.00463496f, -0.00522342f, -0.09518395f, 
    0.00682067f, 0.11618943f, 0.01700853f, 0.05195233f, 0.04359598f, -0.10164738f, 0.11868902f, 0.00477263f, 
    0.02471662f, -0.01119488f, 0.00602023f, -0.02239666f, -0.11222729f, 0.03696534f, -0.00187296f, 0.08519133f, 
    -0.04749694f, -0.08794865f, -0.05941480f, 0.14021496f, -0.00033635f, 0.01631353f, 0.03456000f, -0.03213144f, 
    0.14475398f, 0.07022391f, -0.10917859f, -0.03000395f, 0.06748235f, 0.04177199f, -0.03817276f, -0.01950091f, 
    0.04586028f, 0.01979255f, 0.04267170f, 0.00675282f, 0.14221412f, 0.05061396f, 0.18459252f, 0.13406245f, 
    -0.01821990f, 0.03907953f, -0.09423777f, 0.01858258f, 0.04336244f, -0.07756391f, 0.10065444f, 0.09682445f, 
    0.37565747f, -0.27075055f, 0.05061350f, -0.05153379f, -0.13033839f, 0.01583545f, -0.06594642f, 0.09735499f, 
    -0.02782339f, 0.09540779f, 0.03915970f, 0.03370075f, 0.28078702f, -0.10640176f, -0.03516377f, -0.22799948f, 
    0.03701881f, -0.04213471f, -0.11420295f, 0.00383281f, 0.06167099f, -0.05924907f, -0.19694661f, -0.11226216f, 
    0.09023424f, 0.21555895f, -0.17086083f, 0.01945372f, 0.19775988f, -0.05079642f, 0.01209559f, -0.04778275f, 
    -0.06122259f, -0.01074348f, -0.01569735f, -0.04705027f, -0.13765639f, -0.06383258f, -0.00910807f, 0.24800912f, 
    0.12251234f, 0.00257093f, 0.10477062f, -0.06083726f, -0.03388122f, 0.02579450f, 0.02074734f, -0.05277969f, 
    -0.06964187f, 0.09806132f, -0.06271082f, 0.12173761f, 0.13802263f, -0.02465067f, -0.03784072f, -0.03868475f, 
    0.10075773f, 0.04690677f, -0.03305446f, 0.13015309f, 0.22934130f, -0.09111226f, 0.04768582f, 0.18783489f, 
    -0.09919447f, -0.08280416f, 0.05807016f, -0.00339858f, 0.07661608f, 0.09725881f, -0.06458326f, 0.11373354f, 
    0.19795151f, -0.17211905f, -0.07812788f, -0.10757862f, -0.04642072f, -0.04402971f, -0.03495072f, 0.09881051f, 
    -0.08615563f, -0.03751604f, -0.21853526f, -0.08229277f, -0.05391728f, 0.00643526f, 0.01049274f, -0.17837088f, 
    -0.05993202f, -0.02392111f, 0.06374261f, -0.03796829f, 0.06321126f, 0.03863891f, -0.02410951f, 0.00621619f, 
    0.24742717f, -0.00363058f, 0.07882436f, 0.11374307f, -0.11157908f, -0.04829378f, 0.03895687f, 0.05070795f, 
    -0.05984507f, 0.05287253f, 0.05219061f, -0.12549612f, -0.06049170f, 0.07832362f, 0.04983305f, 0.01286195f, 
    0.04935363f, -0.02172873f, 0.01827259f, -0.02192454f, -0.09949803f, -0.00378428f, -0.08668061f, 0.05084413f, 
    0.20706858f, -0.02548051f, 0.08175680f, 0.07320341f, -0.04430345f, 0.00870275f, 0.12365515f, 0.06199582f, 
    -0.03603641f, 0.18240106f, 0.03162348f, 0.09751794f, 0.24426086f, 0.13940176f, -0.00840232f, 0.11120823f, 
    -0.05236696f, 0.05247637f, -0.04348080f, 0.02331293f, -0.06257122f, 0.05942173f, 0.14794479f, -0.05844091f, 
    0.06257607f, -0.04507511f, -0.10540339f, -0.10498415f, 0.03418808f, 0.00712140f, 0.01731956f, -0.00083404f, 
    -0.04000184f, -0.05581846f, 0.05558720f, 0.04660584f, 0.21561584f, -0.15702777f, 0.19266473f, -0.09700928f, 
    -0.01809621f, 0.04421717f, 0.01626363f, -0.07306452f, -0.08000223f, 0.03314694f, -0.01263411f, -0.00123949f, 
    -0.01643115f, 0.21753705f, 0.03789271f, 0.24736527f, -0.02430129f, -0.02064344f, -0.02288883f, -0.04785577f, 
    -0.00063876f, 0.12921524f, -0.05106841f, 0.06040062f, -0.11331765f, 0.16217379f, 0.00208409f, 0.16200744f, 
    -0.03045565f, -0.07382727f, 0.01581967f, -0.01199168f, -0.10007526f, -0.00397762f, 0.07770771f, 0.05595892f, 
    0.01872569f, -0.06139281f, 0.20677193f, 0.21892747f, -0.07904202f, 0.02438864f, -0.04224788f, -0.03165461f, 
    -0.00682984f, 0.02313433f, 0.06035165f, 0.00683275f, 0.11052206f, 0.00337173f, 0.13775425f, -0.01598002f, 
    0.02890240f, -0.07062877f, 0.01251913f, 0.03727061f, -0.08826907f, -0.06367875f, -0.05155940f, 0.06571595f, 
    -0.04090350f, -0.11662395f, -0.03382709f, -0.06458967f, 0.13510630f, 0.00659777f, -0.00978897f, -0.00902464f, 
    0.09433374f, -0.02977804f, -0.14018734f, 0.05082033f, -0.02906045f, -0.01156552f, -0.18717784f, -0.04737944f, 
    0.03919627f, -0.06397379f, 0.11299928f, -0.02617819f, -0.05457517f, 0.10720882f, -0.07641998f, 0.01216335f, 
    0.07672500f, -0.21326847f, -0.17249839f, 0.16093951f, -0.05618877f, 0.03533617f, -0.03498558f, -0.10103185f, 
    0.02301233f, 0.07705558f, -0.01547222f, 0.03847063f, 0.04549905f, 0.09397613f, -0.09764105f, -0.14747107f, 
    -0.03206255f, -0.02648443f, 0.06782368f, -0.04305171f, 0.08261739f, 0.12075970f, -0.00392565f, 0.08504608f, 
    -0.35131189f, -0.07609843f, -0.07813610f, 0.03704241f, -0.07015102f, 0.11043937f, 0.02911418f, -0.02224132f, 
    0.08772700f, -0.05423607f, 0.04003261f, -0.01036691f, 0.14533584f, 0.18278219f, -0.01347011f, 0.09537050f, 
    -0.01869036f, -0.15090984f, 0.01798625f, -0.06206780f, -0.00928075f, -0.06562030f, 0.01243486f, -0.07116155f, 
    0.14264810f, -0.05907291f, 0.18286666f, 0.27431667f, 0.06965087f, -0.07681711f, -0.06560052f, -0.02658856f, 
    0.03345028f, -0.02435296f, -0.02854436f, 0.08154634f, -0.21993674f, 0.06281415f, 0.12490676f, 0.02774828f, 
    0.02989164f, -0.03118790f, 0.07410420f, 0.06813157f, -0.01466503f, 0.04525228f, -0.09971464f, -0.03647936f, 
    -0.05390417f, 0.00740542f, 0.00083863f, 0.16424559f, 0.02626175f, -0.06246270f, 0.08063621f, -0.01613282f, 
    -0.05810697f, -0.03287830f, -0.04041940f, 0.01424361f, 0.04468993f, 0.09772335f, -0.08087207f, -0.24271153f, 
    0.10691788f, -0.05155028f, 0.01486068f, -0.06665610f, 0.02283856f, 0.06418056f, -0.02115888f, -0.04708584f, 
    -0.09873907f, -0.09461924f, -0.06518549f, -0.02126058f, 0.04849137f, 0.03289986f, -0.10392501f, -0.00733091f, 
    -0.04467046f, 0.00493433f, 0.07410878f, -0.11187544f, 0.22785394f, 0.06197448f, -0.30036417f, -0.15513691f, 
    0.02690811f, -0.00340874f, -0.07672653f, 0.05549856f, 0.06337755f, 0.11966044f, -0.01729917f, -0.07512891f, 
    0.02764674f, -0.02941641f, -0.02273286f, -0.04202678f, 0.00098347f, -0.00586654f, -0.04116083f, 0.00026113f, 
    -0.03384653f, 0.02916824f, -0.01066821f, 0.03157188f, 0.00125170f, 0.01627792f, -0.03158192f, -0.02685215f, 
    -0.02096822f, -0.01363329f, -0.03576807f, 0.03208006f, -0.02228427f, 0.00514191f, -0.04007463f, 0.00542419f, 
    -0.02103435f, -0.00927574f, -0.00304715f, -0.01230934f, 0.00248023f, -0.01193903f, 0.02269909f, -0.01038877f, 
    0.01365368f, 0.00778003f, -0.00440699f, -0.00981146f, 0.02337532f, 0.01509477f, 0.01171882f, 0.01972315f, 
    -0.00109549f, 0.01811328f, -0.00431373f, 0.02602944f, 0.01533439f, -0.00638755f, 0.02323916f, -0.00857561f, 
    -0.02453965f, 0.00492881f, -0.02387012f, -0.02532875f, 0.00315586f, -0.00767085f, -0.03448465f, -0.02861311f, 
    -0.00689695f, 0.02724470f, 0.00510210f, -0.01995946f, 0.01631690f, -0.02226291f, 0.02128686f, -0.01739370f, 
    -0.02902041f, 0.02381429f, 0.02603727f, 0.00506232f, 0.00944813f, -0.00595257f, -0.00104333f, 0.01977484f, 
    0.00319762f, 0.01956067f, -0.01974584f, 0.00354091f, 0.02316831f, -0.03794383f, -0.01553892f, -0.02352690f, 
    0.01433698f, -0.01580712f, -0.02326504f, -0.01989832f, 0.00674679f, 0.01831657f, -0.02138280f, -0.00555844f, 
    -0.02044980f, -0.00976453f, 0.03146996f, -0.02893735f, -0.02691950f, 0.00676859f, -0.00508239f, 0.02802834f, 
    -0.03909000f, -0.02718016f, -0.01039590f, -0.02692518f, 0.01571717f, -0.01745592f, 0.02299917f, -0.01466248f, 
    -0.02437352f, -0.00761825f, 0.01579650f, -0.00946847f, -0.01308435f, -0.00573379f, 0.02202553f, -0.03758211f, 
    0.01485518f, 0.01174068f, 0.02185898f, -0.00620108f, -0.01663760f, 0.01097193f, -0.03342853f, 0.02372981f, 
    -0.03997775f, 0.01708362f, 0.03193567f, -0.01221214f, -0.00000622f, 0.01776792f, -0.01548849f, -0.01999523f, 
    0.00985076f, 0.01360243f, -0.03096108f, 0.00356246f, -0.03996353f, 0.00520040f, -0.00972611f, 0.03027951f, 
    0.00903631f, -0.01481634f, 0.01709897f, 0.01252184f, -0.00522719f, 0.02856383f, 0.02683131f, -0.01766313f, 
    0.01727496f, 0.00156516f, 0.03614324f, -0.02326696f, -0.02415942f, 0.00869389f, -0.02431927f, -0.04100139f, 
    0.02848815f, 0.01790574f, 0.03418752f, 0.02994263f, -0.03546511f, -0.03123649f, -0.01699893f, -0.03229072f, 
    -0.02256917f, -0.00996491f, -0.01605499f, 0.02565129f, 0.01626813f, -0.02580994f, 0.03040839f, -0.00396640f, 
    -0.03230307f, 0.02536310f, -0.02582961f, -0.00856103f, 0.00944068f, 0.01094234f, 0.01745239f, -0.00058322f, 
    -0.02904045f, 0.01233257f, -0.02680335f, -0.00681053f, -0.02318778f, -0.02128493f, 0.03275350f, 0.00886980f, 
    0.01631361f, 0.02745705f, -0.01188193f, 0.00779685f, -0.03828374f, -0.03553618f, -0.02315924f, -0.04029777f, 
    -0.01613865f, -0.02536412f, 0.00430133f, 0.03187490f, 0.01255395f, 0.02648596f, 0.02212041f, 0.01415301f, 
    0.00844040f, -0.01981101f, 0.00197043f, 0.01949061f, -0.00995371f, -0.00765969f, 0.01494945f, -0.02334350f, 
    0.02555137f, 0.02038134f, -0.02976681f, 0.02531383f, -0.00190273f, -0.00275763f, -0.00445881f, -0.01367526f, 
    -0.03405558f, 0.03351032f, -0.01292764f, -0.02523880f, 0.00712435f, -0.02395683f, -0.03441882f, 0.00439625f, 
    -0.02538039f, -0.01397512f, 0.00012140f, -0.03303294f, 0.02081544f, -0.03198940f, -0.00400391f, -0.04028166f, 
    -0.02549447f, -0.02004423f, -0.03559503f, -0.01733930f, -0.02520413f, -0.01894178f, -0.02298708f, -0.04057976f, 
    -0.04246785f, -0.01975783f, -0.00921613f, -0.02835508f, 0.02339768f, -0.03154619f, -0.03734153f, 0.02038167f, 
    0.01291935f, -0.00682975f, 0.01515147f, -0.01516765f, -0.01107544f, 0.00555307f, 0.00307763f, 0.02878165f, 
    -0.02001283f, 0.00553072f, -0.04095059f, -0.04038743f, -0.01101649f, -0.03855393f, 0.00679263f, 0.01571708f, 
    0.02449946f, -0.01716276f, -0.02468936f, -0.00488033f, -0.01621570f, 0.01458607f, 0.02985691f, 0.01442751f, 
    0.00403378f, -0.02470325f, 0.00288067f, 0.00252291f, 0.01926361f, 0.01329124f, 0.02878824f, -0.01961124f, 
    -0.02629767f, -0.00283638f, -0.00212526f, -0.02201066f, -0.02416414f, 0.01301333f, -0.01152658f, 0.02221188f, 
    -0.00092359f, 0.00951049f, -0.00630971f, 0.01356403f, 0.00223036f, 0.01276927f, 0.00657949f, 0.00239430f, 
    0.00137099f, 0.02000499f, 0.02647451f, 0.03648655f, -0.03686239f, -0.01047363f, -0.01752080f, -0.00731064f, 
    0.01721942f, -0.00410058f, -0.00646385f, 0.01740716f, 0.00265882f, -0.01864255f, -0.02176247f, -0.00731842f, 
    0.00587039f, -0.02526064f, -0.02379691f, 0.00107943f, 0.00343657f, 0.02024546f, 0.00207791f, 0.01414069f, 
    0.02568081f, 0.00111933f, -0.01877046f, 0.01957121f, 0.01988349f, 0.00552974f, 0.02217744f, -0.00083498f, 
    -0.01591616f, -0.03480499f, -0.00172784f, -0.02811353f, -0.02035742f, 0.00420380f, -0.00959537f, 0.00109600f, 
    -0.03362781f, -0.01575616f, -0.02468125f, 0.03104199f, 0.02815223f, -0.01213162f, 0.00014473f, -0.00138384f, 
    -0.00609258f, 0.02292849f, -0.03042153f, -0.02209000f, -0.02539420f, -0.01108194f, 0.01722863f, 0.01398496f, 
    0.01827030f, -0.01032165f, -0.01324817f, 0.01688579f, 0.02918298f, 0.02541026f, -0.00907820f, -0.03797560f, 
    0.02337939f, -0.00270812f, -0.01836900f, 0.00462111f, 0.00725838f, -0.02432332f, -0.01730925f, 0.03925244f, 
    0.04083940f, -0.03763841f, 0.01808686f, -0.01191228f, 0.01568846f, -0.00690686f, -0.00031780f, -0.02480914f, 
    -0.04312367f, 0.01211702f, 0.01877209f, 0.00263498f, 0.01991545f, 0.02450061f, -0.00101913f, -0.00888708f, 
    0.01632977f, -0.03242972f, -0.00750287f, 0.00770274f, -0.03303112f, -0.02669169f, 0.00189437f, 0.00031648f, 
    -0.00510481f, 0.02026007f, -0.01274607f, 0.00950688f, -0.01798127f, -0.02446540f, -0.02207854f, -0.02522479f, 
    0.00320626f, -0.01465408f, -0.01997527f, -0.01058848f, 0.01768712f, -0.02774523f, 0.01978752f, -0.03092074f, 
    0.01812914f, -0.01452809f, 0.00339244f, -0.01702332f, -0.04145458f, 0.01793797f, 0.01391236f, -0.03353364f, 
    -0.00376581f, 0.01597619f, 0.02790126f, 0.00231912f, 0.02413040f, -0.03000759f, 0.04347853f, 0.01404352f, 
    -0.02083303f, 0.01778216f, -0.02770943f, -0.03975006f, 0.00977137f, 0.01912278f, -0.03240034f, -0.01264169f, 
    -0.01663390f, -0.04158370f, 0.01370313f, -0.00403634f, 0.02692243f, -0.02225918f, -0.00343697f, 0.03207282f, 
    -0.02352231f, 0.02007985f, -0.00521500f, 0.00793533f, 0.00554695f, -0.00480278f, 0.00852527f, 0.01437062f, 
    0.00686519f, 0.00930624f, 0.01092823f, 0.00101609f, -0.03855824f, 0.00480462f, 0.02441256f, -0.02007485f, 
    -0.00823226f, 0.01879088f, 0.03063553f, -0.03253866f, 0.01490354f, -0.03410238f, -0.03017204f, 0.02143084f, 
    0.00524424f, -0.02593060f, -0.03979598f, -0.03707263f, -0.02882794f, 0.00595772f, 0.00290251f, 0.00873818f, 
    0.03264495f, -0.04085800f, 0.02854205f, -0.02865748f, -0.02452107f, 0.02677862f, -0.03941396f, -0.03548149f, 
    0.02749401f, -0.01078122f, -0.03580843f, 0.01582314f, -0.02451273f, -0.04128858f, -0.03327003f, 0.00017796f, 
    -0.04308015f, -0.01505723f, -0.01157677f, 0.01923353f, 0.00606909f, -0.01545134f, -0.01005078f, -0.01681948f, 
    -0.03629224f, -0.02086909f, 0.03734574f, -0.02329297f, -0.01039130f, 0.00704378f, 0.00819821f, -0.03631827f, 
    -0.03586440f, -0.03821443f, 0.00033983f, 0.01360603f, -0.02876633f, -0.02232328f, -0.00045772f, 0.03063132f, 
    0.00412238f, 0.00944087f, -0.02515475f, -0.03017903f, -0.00610730f, 0.01323082f, -0.03803542f, 0.01701837f, 
    -0.03762569f, 0.01024033f, 0.01841677f, -0.00760410f, -0.01217217f, -0.03182796f, 0.02344818f, -0.01752849f, 
    0.00381756f, -0.01712356f, -0.03230575f, 0.00864183f, -0.03208145f, 0.02755910f, 0.02141552f, 0.02878802f, 
    0.02805537f, 0.00065807f, -0.01138949f, 0.01477198f, 0.01763776f, -0.00760458f, 0.02090648f, 0.00551250f, 
    -0.01732939f, -0.02686906f, 0.00654003f, -0.00027504f, -0.00529699f, 0.02751396f, -0.03050692f, -0.00095318f, 
    0.02022885f, -0.01491330f, -0.02458007f, -0.02216815f, -0.00919153f, -0.01096366f, 0.00948788f, 0.03408650f, 
    -0.02581367f, -0.00095356f, -0.02212612f, 0.00657189f, -0.02989675f, -0.00361868f, 0.01435247f, 0.00534421f, 
    0.00877263f, -0.00837450f, -0.01006142f, -0.02009022f, 0.01479701f, 0.00650835f, 0.02462805f, -0.03402720f, 
    0.00632739f, 0.03678432f, -0.02823219f, -0.01607819f, -0.01051449f, 0.01553011f, 0.02363826f, 0.01528046f, 
    -0.02701295f, 0.01834896f, 0.01054280f, -0.02787493f, 0.01686526f, 0.00118075f, 0.01701617f, -0.02765905f, 
    -0.04099600f, -0.01963978f, -0.00778221f, -0.00477298f, -0.01355680f, 0.00776641f, -0.02913796f, 0.00819718f, 
    0.01192829f, 0.02886694f, 0.02521383f, 0.02317324f, -0.02794833f, -0.01900637f, -0.00177415f, 0.00688008f, 
    0.02498291f, -0.02847722f, -0.03628331f, -0.01538500f, 0.01032299f, -0.02768421f, -0.00364570f, -0.03244847f, 
    0.00014487f, -0.02119523f, 0.01156283f, 0.02812845f, -0.00351030f, -0.00002966f, -0.02185557f, -0.03857179f, 
    -0.00123851f, -0.02536217f, -0.00244925f, 0.04286211f, -0.02405947f, -0.03836227f, 0.02215877f, -0.01321480f, 
    -0.01237850f, 0.02327223f, -0.00411693f, 0.02989663f, 0.01826251f, -0.01981683f, -0.01177387f, 0.03324994f, 
    -0.00268298f, -0.03477446f, 0.00941874f, 0.01148191f, 0.00037832f, -0.00692718f, 0.00689252f, 0.00052101f, 
    0.00457491f, -0.00456630f, 0.01825391f, 0.02703597f, 0.00684698f, -0.00968715f, -0.01704784f, -0.03044930f, 
    0.02521355f, 0.00647288f, -0.00878867f, -0.04095181f, -0.01305200f, 0.00336241f, -0.01387445f, -0.00174293f, 
    -0.02519750f, -0.02219670f, 0.03109409f, -0.03584012f, -0.00283482f, 0.01742097f, -0.01477290f, 0.01637885f, 
    0.01542870f, -0.00982174f, 0.02464620f, 0.00415555f, -0.03704627f, -0.03767920f, -0.00168704f, -0.01081566f, 
    -0.04016213f, -0.03323594f, -0.04256563f, 0.02061509f, -0.01589064f, 0.01557544f, -0.01220060f, 0.03033742f, 
    0.01464641f, 0.02183298f, -0.04279655f, 0.01258096f, 0.02323692f, -0.04062222f, 0.01435040f, -0.01851096f, 
    -0.02049464f, 0.02374276f, -0.00682194f, -0.01095735f, -0.03824484f, -0.02342345f, 0.01927522f, -0.00586303f, 
    0.01287415f, -0.02367771f, -0.03774124f, -0.04390629f, -0.01632160f, 0.03721476f, 0.01618787f, 0.00712636f, 
    0.02847391f, -0.03818500f, 0.02482626f, -0.01645504f, -0.03949082f, 0.00030310f, 0.01206305f, 0.02284671f, 
    -0.03500872f, -0.02596964f, -0.01569534f, 0.01081035f, -0.02206215f, -0.01553745f, 0.01689425f, -0.03329246f, 
    -0.00614949f, 0.01134996f, 0.00805388f, -0.01930566f, -0.02736454f, -0.04228137f, 0.00083070f, -0.02952607f, 
    -0.01858844f, -0.00412058f, -0.01529118f, -0.00419146f, 0.01564031f, -0.03984440f, 0.02588106f, 0.02520618f, 
    0.01395414f, -0.02657433f, 0.00378275f, -0.02133357f, 0.00834874f, -0.02072063f, 0.02347499f, 0.01002405f, 
    -0.00373303f, -0.03358818f, -0.00971789f, -0.04258531f, 0.02471406f, 0.04203484f, -0.01586553f, -0.04055947f, 
    0.01629514f, 0.02893301f, -0.02120309f, 0.01896128f, -0.00497152f, 0.02484633f, -0.00494250f, 0.00427263f, 
    -0.03648975f, -0.01946788f, -0.00094424f, -0.00667255f, 0.00306892f, 0.02359365f, 0.00566895f, -0.02967878f, 
    -0.03779126f, 0.02090641f, 0.00222762f, 0.01151321f, 0.01501973f, -0.00865540f, 0.03256541f, -0.02515911f, 
    -0.02407756f, -0.00321216f, -0.03070572f, 0.02324454f, -0.00679504f, 0.00878900f, -0.04336799f, -0.03524012f, 
    -0.03163115f, -0.02872876f, -0.03059643f, -0.00515695f, -0.00929287f, 0.01655804f, 0.01712826f, 0.00904845f, 
    0.00635004f, -0.03022340f, -0.01564115f, -0.00660794f, 0.03248798f, 0.01463405f, -0.04276096f, -0.03191822f, 
    0.01317213f, -0.03209280f, 0.01822212f, -0.02397511f, -0.03549072f, -0.00471973f, -0.03444334f, -0.02866963f, 
    -0.03939065f, 0.00296725f, 0.01496436f, 0.00295626f, -0.01343730f, 0.01721799f, -0.04371951f, -0.00365480f, 
    0.03157747f, -0.04170021f, 0.01710509f, 0.01324498f, -0.00055170f, 0.01992888f, 0.02077946f, 0.00949823f, 
    -0.01145555f, 0.02918969f, 0.02551948f, 0.00452778f, -0.03394004f, 0.02125652f, -0.01555035f, 0.01596072f, 
    -0.03592815f, -0.01924083f, 0.02559376f, -0.02059192f, -0.00941829f, -0.02644910f, 0.02421300f, -0.03556173f, 
    -0.03364609f, 0.02105233f, 0.01664269f, -0.02894948f, 0.01243208f, 0.00166138f, 0.00223642f, 0.00076095f, 
    0.01460913f, -0.03023966f, -0.03578227f, 0.00062793f, -0.03263699f, -0.02454331f, 0.03538135f, 0.02353838f, 
    0.00740939f, -0.00322018f, 0.00394778f, -0.01797681f, 0.01301174f, -0.00273567f, -0.02205731f, 0.02396595f, 
    0.02750349f, 0.01508788f, -0.00901093f, -0.00716666f, -0.04533862f, 0.02051437f, -0.00051714f, 0.00321348f, 
    0.02584873f, 0.01316225f, -0.03550249f, 0.01187699f, 0.00570613f, -0.02649192f, -0.02153413f, 0.02551213f, 
    -0.01283995f, 0.00364942f, 0.03599580f, -0.01311250f, 0.00075279f, 0.01340480f, 0.01040888f, 0.01839405f, 
    -0.03389880f, -0.01168919f, -0.01349291f, -0.03306035f, 0.00749371f, -0.01511044f, -0.02655468f, 0.02624831f, 
    -0.00330302f, 0.01269083f, -0.00399647f, -0.00785099f, -0.00661810f, 0.02099038f, -0.03399504f, -0.02120464f, 
    0.01443627f, 0.01562248f, 0.00815506f, 0.01234551f, 0.00632733f, 0.01406019f, -0.03823448f, -0.00708447f, 
    0.02199840f, -0.00258735f, -0.02786512f, -0.03730869f, -0.02092650f, 0.02546498f, 0.00747355f, -0.02839893f, 
    -0.01564520f, -0.02128088f, -0.00217375f, -0.02163360f, -0.01868109f, 0.01274745f, 0.01765454f, -0.01739665f, 
    -0.00031336f, 0.02919489f, -0.01774536f, 0.00309536f, 0.00504338f, -0.01024535f, -0.04103322f, -0.03070508f, 
    -0.00484736f, 0.00513672f, 0.01529416f, 0.01394625f, 0.00023011f, 0.01997827f, 0.00678932f, -0.01738239f, 
    -0.03303224f, 0.02131068f, -0.02605141f, 0.01467507f, 0.01722977f, -0.03388700f, -0.01959437f, 0.01768347f, 
    -0.03246845f, 0.02420536f, 0.00301231f, -0.00059074f, -0.02019888f, -0.00851494f, -0.02952404f, 0.00783781f, 
    0.02587742f, 0.02704320f, -0.03952092f, 0.01815347f, -0.01158971f, -0.03531134f, 0.03019378f, 0.01302875f, 
    -0.01653616f, -0.01287860f, 0.03447460f, 0.00714578f, -0.01268675f, -0.04104159f, -0.00037201f, 0.01179468f, 
    0.01936357f, 0.01307075f, -0.01823547f, 0.02432980f, -0.00278340f, -0.03274219f, -0.03671644f, -0.00490354f, 
    0.00540728f, -0.02475482f, -0.00899314f, -0.01178492f, -0.02966121f, 0.00268821f, -0.01535797f, -0.03475408f, 
    -0.00279950f, -0.00130057f, 0.00997400f, -0.02391896f, 0.02191932f, 0.02586154f, 0.00482727f, 0.01091457f, 
    -0.02848144f, 0.00301969f, 0.03484681f, -0.00768005f, 0.03070109f, -0.00039271f, 0.00660264f, 0.02144383f, 
    -0.02975846f, -0.02523677f, 0.02042564f, -0.04319395f, -0.03341253f, -0.01557361f, -0.01453257f, -0.03371463f, 
    -0.01209583f, 0.03266794f, -0.03423470f, 0.02802281f, -0.03711979f, -0.00838833f, 0.01196284f, 0.01855230f, 
    0.00899101f, 0.02262880f, -0.00244842f, -0.01244641f, -0.03509011f, 0.02185692f, 0.02960080f, 0.00974624f, 
    -0.03077875f, 0.02038568f, -0.01760823f, -0.01539578f, 0.02196992f, -0.01523122f, -0.01107253f, -0.01333236f, 
    -0.00555695f, -0.00066248f, 0.02584957f, -0.03393644f, -0.02539501f, 0.02520162f, 0.01543144f, -0.03102983f, 
    -0.00159470f, -0.02149643f, 0.02930049f, -0.01032381f, 0.02154058f, 0.02382068f, 0.00589039f, -0.00193538f, 
    0.01012410f, -0.01537069f, 0.03674111f, 0.00479706f, 0.01802128f, 0.02274944f, -0.01332236f, 0.01063592f, 
    0.01772675f, -0.02281307f, -0.04002106f, -0.02142745f, -0.02436092f, 0.03314296f, -0.02609061f, 0.01261470f, 
    -0.04396926f, 0.01771845f, 0.01207383f, -0.00728891f, -0.00563082f, -0.00064998f, -0.02623413f, 0.01793271f, 
    0.00819206f, -0.01163994f, -0.00421879f, -0.00147736f, 0.01684413f, -0.02833715f, 0.02141143f, -0.02105931f, 
    -0.02947167f, -0.03088709f, 0.02167230f, 0.00474694f, 0.02469476f, -0.01018121f, -0.01755252f, 0.00296904f, 
    0.01720142f, -0.03014856f, -0.03144906f, 0.00496314f, 0.00694607f, 0.02305047f, 0.01483808f, -0.01105093f, 
    -0.01793987f, 0.01121558f, -0.02137990f, -0.00372624f, -0.02987257f, 0.00310993f, -0.03040108f, -0.03669817f, 
    0.01099716f, 0.00111699f, -0.01506471f, 0.02128767f, -0.01568083f, 0.01866436f, -0.01829068f, -0.03187815f, 
    -0.01600475f, 0.03350888f, 0.01134328f, -0.02030112f, 0.01959994f, -0.00248580f, 0.00390248f, -0.02703243f, 
    0.02700132f, 0.03082672f, 0.00360714f, 0.01397988f, -0.00310227f, 0.01873053f, -0.01971008f, 0.02589597f, 
    0.01381866f, -0.00671232f, 0.00738310f, 0.00808085f, 0.01316497f, -0.03514884f, -0.00911414f, -0.01628580f, 
    0.03951975f, 0.00403218f, -0.02926138f, -0.03466992f, -0.03041013f, -0.00560266f, -0.01044023f, 0.00640419f, 
    0.00596661f, 0.01492616f, 0.00256124f, -0.03144656f, -0.00276739f, 0.00747063f, -0.02078203f, -0.01800641f, 
    -0.02679628f, 0.01872729f, 0.01614676f, 0.03153824f, -0.02372833f, -0.02442128f, -0.02413182f, -0.02964659f, 
    -0.00602262f, -0.01816897f, 0.00740347f, -0.04771621f, -0.02286952f, -0.01333528f, -0.01930024f, -0.03530932f, 
    -0.00239971f, -0.01232303f, -0.03003719f, -0.01145567f, -0.02543268f, -0.00188025f, 0.03381069f, -0.00997712f, 
    -0.00592598f, 0.02302940f, -0.02162305f, -0.04619522f, 0.03226944f, -0.02383469f, 0.03157553f, -0.00566289f, 
    0.00721075f, -0.04340176f, -0.00230223f, -0.01955534f, 0.00163455f, -0.02401724f, -0.02520685f, 0.01014337f, 
    -0.03734817f, -0.01702528f, 0.03046226f, 0.00477064f, -0.00701842f, 0.01498203f, -0.01625189f, 0.01336677f, 
    -0.00770223f, 0.02617415f, -0.01515016f, -0.00185953f, -0.02216876f, -0.02004156f, 0.02637877f, 0.02553831f, 
    0.01075819f, 0.01454804f, 0.02453057f, -0.02133790f, -0.00867666f, -0.00528225f, 0.00600626f, -0.03678685f, 
    0.03019188f, 0.01388115f, -0.03468441f, 0.02876822f, 0.01799703f, -0.03133284f, 0.01474644f, -0.00501517f, 
    0.01865434f, -0.00695320f, -0.02955934f, -0.03183611f, 0.00389575f, 0.01978803f, -0.04301265f, 0.00348242f, 
    -0.03893342f, -0.01864388f, -0.00103634f, -0.01158816f, -0.02415586f, -0.04001846f, -0.02272595f, -0.03407929f, 
    -0.02453891f, 0.03122728f, 0.02119274f, -0.00578486f, -0.00963667f, -0.03592763f, -0.00505698f, -0.03372868f, 
    0.03228611f, -0.02310072f, -0.02420290f, 0.00319356f, -0.01643979f, -0.03350270f, -0.01624586f, 0.00190050f, 
    -0.01107679f, -0.02993006f, -0.00629914f, -0.01592416f, 0.00235319f, -0.01356139f, 0.02876576f, -0.02630750f, 
    0.01083808f, -0.03889773f, 0.00974077f, -0.01407462f, 0.00349377f, -0.00382129f, -0.03509657f, -0.01020825f, 
    -0.02425583f, -0.01142717f, -0.02507677f, 0.02042065f, 0.03089412f, -0.02291086f, 0.00778067f, -0.00788838f, 
    -0.02950572f, -0.02410104f, 0.01877414f, -0.00011346f, 0.01840413f, -0.03113388f, 0.02313048f, -0.03602440f, 
    0.02442723f, -0.03434018f, 0.01721101f, 0.01365430f, 0.00096846f, 0.01667839f, 0.01005709f, 0.02099075f, 
    0.02494022f, 0.02494428f, -0.02160304f, -0.03239663f, 0.00920134f, 0.02251687f, -0.01262608f, 0.01032887f, 
    -0.00423134f, 0.03026488f, -0.03111683f, -0.00835224f, -0.00321331f, -0.04361275f, 0.02303307f, 0.01178960f, 
    0.01463971f, 0.00233143f, 0.01094806f, -0.03031623f, -0.01172975f, 0.00131916f, 0.02106864f, 0.02119516f, 
    0.00011176f, -0.01033296f, -0.02138255f, -0.02221663f, 0.01408354f, -0.00935846f, -0.04055985f, -0.00941359f, 
    0.01260765f, -0.02857060f, -0.01027920f, 0.01260124f, -0.02188448f, 0.01818495f, -0.02912098f, -0.00500514f, 
    -0.01598943f, -0.02732247f, 0.01263793f, 0.01557057f, 0.02565885f, -0.02140139f, 0.01683077f, -0.01737891f, 
    -0.01812857f, 0.00029288f, 0.02160731f, -0.03978491f, -0.01723615f, -0.03277717f, 0.00007320f, -0.03429381f, 
    -0.00314348f, 0.03109054f, 0.00300866f, -0.02274005f, -0.03556043f, 0.02808694f, -0.04137734f, 0.01045762f, 
    -0.03855037f, -0.02530578f, -0.02472571f, -0.00523270f, 0.01361126f, -0.02881712f, -0.02187951f, 0.01219936f, 
    -0.02761550f, 0.01958884f, -0.01628098f, 0.01294210f, -0.01568832f, -0.01549596f, 0.01844827f, 0.00895397f, 
    -0.01888664f, -0.02320767f, -0.02324804f, -0.01670528f, -0.01995221f, -0.01790629f, 0.00350087f, -0.02384184f, 
    0.02512215f, 0.01465990f, -0.00199771f, 0.02044633f, -0.03586021f, 0.00656873f, -0.01678699f, -0.03195348f, 
    0.02908543f, -0.01342318f, -0.00354975f, 0.00517712f, -0.01776448f, -0.03001954f, 0.02755994f, -0.03331731f, 
    0.03038902f, -0.02274786f, -0.01601658f, -0.01027732f, 0.00590481f, -0.00329569f, -0.03816406f, 0.02406791f, 
    0.01983904f, 0.00569548f, 0.03226682f, 0.04525137f, 0.01637981f, 0.01444748f, 0.00163822f, 0.01607404f, 
    -0.02264511f, -0.02642805f, -0.00347557f, -0.02600895f, -0.02264564f, 0.03409433f, -0.01219569f, -0.02851949f, 
    -0.02248486f, 0.02730307f, 0.02968914f, 0.00725728f, -0.00580366f, 0.02773811f, 0.00935543f, -0.03557431f, 
    0.02016829f, -0.01130862f, -0.02063374f, 0.00139081f, -0.02888737f, 0.00042871f, -0.02243038f, 0.01992872f, 
    0.00424194f, -0.00533282f, 0.00885771f, 0.02076514f, -0.02469235f, 0.02292428f, -0.00119357f, -0.02221022f, 
    0.00495745f, 0.04171580f, 0.01431063f, 0.00107097f, -0.03362869f, 0.02727252f, -0.01638993f, 0.03399947f, 
    0.01725111f, -0.02993232f, 0.02939742f, 0.02221125f, 0.02894474f, -0.01490111f, 0.00281184f, -0.02615087f, 
    -0.00028729f, 0.01519090f, -0.03817799f, -0.00947008f, -0.01152365f, -0.00709890f, -0.04455118f, 0.01771748f, 
    0.01628541f, 0.03186108f, -0.00502906f, -0.02748419f, -0.02389276f, 0.02636475f, 0.02129691f, -0.00069247f, 
    -0.01163078f, 0.01110011f, 0.02892054f, 0.01206370f, -0.03504850f, -0.04234517f, -0.01420477f, -0.00112648f, 
    -0.00092685f, -0.03057112f, -0.03894382f, -0.01963906f, -0.03178284f, -0.03643287f, -0.01515874f, -0.01264559f, 
    0.02795723f, 0.02646729f, -0.00870919f, 0.01474444f, 0.02976293f, -0.01661591f, -0.00203209f, 0.00529434f, 
    0.02769647f, -0.03390595f, -0.00607848f, -0.00939924f, -0.01683251f, 0.01408088f, -0.00227269f, -0.02614559f, 
    -0.00754218f, -0.00501628f, 0.01772917f, 0.01141023f, -0.02864456f, -0.00218254f, -0.02812390f, -0.04129046f, 
    -0.26048332f, -0.09731713f, -0.04128405f, -0.04251087f, -0.06363667f, -0.05737157f, -0.04474904f, -0.08001913f, 
    -0.03644651f, 0.04621571f, 0.10290591f, -0.03848953f, -0.01356713f, 0.06254931f, 0.00682139f, -0.03059703f, 
    -0.06033158f, 0.06339972f, -0.06385412f, -0.01570172f, 0.05232285f, 0.10477971f, -0.07275705f, 0.08834216f, 
    0.34671894f, 0.13913082f, -0.03043062f, 0.02464840f, -0.06896257f, -0.03152912f, 0.02452147f, 0.02694471f, 
    -0.11756925f, 0.02549577f, -0.02649613f, -0.01999581f, 0.10470669f, 0.08308093f, 0.03707178f, -0.10724451f, 
    0.04715982f, 0.04497240f, 0.02219409f, -0.03570571f, -0.05874498f, 0.01648072f, -0.00324382f, 0.01138520f, 
    0.17920864f, 0.03492584f, 0.05869785f, 0.08513772f, 0.01718712f, 0.03177327f, -0.08802443f, 0.08454839f, 
    -0.09800805f, -0.04239984f, -0.01695500f, 0.04759615f, 0.04594639f, -0.00887005f, 0.30607852f, 0.04495132f, 
    0.12450730f, 0.00898110f, 0.11313159f, 0.10600569f, 0.03305894f, -0.03668483f, 0.06959679f, 0.03477713f, 
    -0.05700971f, 0.17615044f, -0.08450522f, -0.11126544f, -0.06155001f, 0.04009702f, -0.00475583f, -0.01563434f, 
    0.07283799f, 0.04538572f, 0.03725667f, -0.03159679f, 0.03024997f, 0.14872049f, 0.13211547f, 0.04160985f, 
    -0.08002613f, 0.02338913f, 0.07070941f, 0.06691402f, 0.00488029f, 0.12361038f, 0.03281037f, 0.03806548f, 
    0.04150360f, 0.05686535f, 0.04713170f, 0.07917818f, 0.05349516f, 0.04205315f, 0.06999625f, 0.07874428f, 
    0.05086593f, 0.02017934f, -0.01645018f, -0.07992512f, 0.20978224f, 0.01197494f, 0.07283577f, 0.09375764f, 
    0.10178701f, -0.04474346f, -0.03647727f, 0.06112523f, 0.00967938f, 0.15518774f, -0.00141257f, 0.00081763f, 
    -0.05027582f, -0.00611230f, 0.00503940f, 0.02374666f, -0.08293676f, 0.04933607f, -0.03531329f, 0.15793556f, 
    0.04300324f, 0.00387776f, 0.06940487f, 0.03149754f, 0.13115487f, 0.31689763f, 0.13774334f, 0.12876523f, 
    0.03797729f, 0.00944531f, 0.03421865f, 0.00059820f, -0.04872152f, -0.05428618f, 0.04621079f, 0.07784633f, 
    -0.03146145f, 0.08584233f, 0.03958169f, -0.04785134f, -0.05881312f, 0.03023909f, 0.00861846f, -0.06849751f, 
    -0.08633948f, 0.04835400f, 0.01187434f, -0.03410107f, -0.29901162f, 0.01197034f, -0.04755651f, -0.08384904f, 
    -0.02295113f, 0.00763990f, -0.14406566f, -0.11545206f, -0.05382455f, 0.03839839f, 0.03233682f, -0.07620270f, 
    0.19624177f, 0.02616424f, 0.13718306f, 0.30296624f, 0.00531964f, 0.01911366f, -0.01443406f, -0.04431231f, 
    0.08715999f, 0.08621835f, 0.08949655f, -0.13832551f, -0.02573096f, -0.19293231f, 0.18448523f, 0.20896558f, 
    0.05722638f, 0.02617877f, 0.06548481f, 0.03707444f, -0.08252920f, 0.05448078f, 0.01206244f, 0.13061421f, 
    -0.20493613f, -0.15448934f, 0.15144140f, 0.11340287f, 0.09961755f, 0.01592258f, -0.06335928f, 0.07867580f, 
    0.03758402f, 0.02567619f, -0.02032764f, 0.00801591f, 0.13412447f, 0.19072117f, 0.08156580f, 0.03704257f, 
    0.01279309f, -0.00307891f, 0.04092987f, -0.02386017f, 0.05727468f, -0.06253435f, 0.03981825f, 0.01799236f, 
    0.37831557f, -0.08028006f, -0.19360101f, 0.13988222f, -0.07128680f, 0.19209456f, 0.00603231f, -0.02515382f, 
    -0.01276003f, 0.06157509f, 0.02377085f, -0.01715927f, 0.15501799f, 0.06859542f, 0.08655297f, -0.05561373f, 
    0.01901730f, -0.02296103f, -0.00485581f, -0.09782317f, 0.01329494f, 0.02737319f, -0.01223829f, 0.07155961f, 
    -0.05431940f, 0.06404841f, 0.05838550f, 0.09019740f, -0.06029603f, 0.09258679f, 0.03399324f, 0.12644386f, 
    -0.05877404f, 0.04625232f, 0.00394334f, -0.07176358f, -0.13399512f, 0.19743483f, 0.09875887f, 0.29916373f, 
    0.16574588f, 0.00733439f, 0.06684484f, 0.02240642f, -0.00776328f, 0.01307527f, -0.02147896f, 0.08302290f, 
    -0.29114318f, -0.18637429f, 0.00549780f, -0.05377437f, -0.03566565f, -0.01898385f, -0.00098391f, 0.09397580f, 
    -0.00468667f, 0.03620287f, 0.02884492f, 0.07261141f, 0.29622740f, 0.13068011f, -0.03881681f, -0.02609731f, 
    -0.02497869f, 0.04501202f, 0.13618483f, 0.06881156f, -0.00709190f, 0.16543883f, -0.10919064f, 0.00996924f, 
    -0.09562432f, 0.31299001f, -0.10801194f, -0.11089846f, 0.04873568f, 0.07390130f, -0.06985253f, 0.12947701f, 
    0.17828548f, 0.02480722f, 0.03606262f, 0.00212301f, -0.19817008f, -0.07322229f, -0.19634379f, 0.05206435f, 
    0.13551541f, -0.05546962f, 0.07407025f, 0.10461305f, -0.03229266f, 0.15749881f, -0.02292806f, -0.01961040f, 
    0.05491040f, 0.03712585f, 0.09112006f, 0.10814139f, 0.04262619f, 0.01471128f, -0.02341488f, 0.00193829f, 
    -0.00560468f, -0.01812261f, -0.02224573f, 0.07527048f, -0.24391578f, -0.03067338f, -0.07245254f, 0.06198737f, 
    0.00329146f, -0.08082351f, 0.03953556f, -0.02762676f, 0.05495348f, -0.12346081f, 0.13950826f, 0.06300290f, 
    0.05638773f, 0.01431005f, 0.06814385f, -0.01247927f, 0.04251990f, 0.12029028f, 0.04979641f, -0.00987192f, 
    0.07357168f, 0.01079883f, -0.05546875f, -0.00881943f, 0.12235227f, 0.02576429f, 0.14280000f, 0.11630556f, 
    -0.05106350f, 0.06269814f, 0.07284470f, 0.04994313f, 0.05188247f, 0.08492302f, -0.13773306f, 0.05204114f, 
    -0.13359056f, -0.09062531f, -0.09955443f, -0.10772301f, -0.07703497f, 0.09038708f, -0.15784685f, 0.11554236f, 
    0.02247606f, 0.03923099f, 0.01427097f, 0.12330207f, 0.13222858f, 0.15187396f, 0.04933879f, -0.03340093f, 
    0.02896875f, -0.02732684f, -0.03726277f, -0.08590488f, 0.00357871f, -0.03260441f, 0.03719495f, 0.00297424f, 
    0.06299252f, 0.00729649f, 0.24538550f, 0.05479708f, 0.04599379f, 0.01023130f, 0.02769848f, 0.03889453f, 
    -0.09313422f, 0.02722447f, -0.01689965f, -0.02645149f, 0.09362218f, 0.12630859f, 0.09313313f, -0.04435948f, 
    -0.00543099f, -0.01765399f, 0.02237017f, -0.09491508f, 0.01017685f, 0.04535145f, 0.02225787f, -0.03002330f, 
    0.00496912f, 0.04741134f, 0.16058339f, 0.03634763f, 0.01330950f, 0.05226180f, 0.14316598f, -0.13456404f, 
    -0.01394729f, -0.00795465f, -0.09765705f, -0.05214098f, 0.09117212f, 0.20784108f, 0.26280743f, 0.14607926f, 
    -0.01601977f, 0.06688638f, 0.12484404f, 0.04502867f, -0.01977897f, 0.07033730f, 0.12440649f, 0.04411523f, 
    0.20722212f, 0.25296372f, 0.07322904f, 0.04582107f, -0.06185069f, -0.01192756f, -0.08714501f, 0.20899339f, 
    0.06059782f, 0.02278984f, -0.01401277f, 0.02206701f, -0.09851817f, -0.25626558f, -0.15854320f, -0.04077599f, 
    0.12381489f, 0.15198734f, -0.03086145f, 0.00673797f, 0.00235367f, 0.00631021f, 0.09578226f, -0.01434042f, 
    -0.19037773f, -0.36445963f, 0.10638669f, -0.06651755f, -0.04706836f, 0.02261900f, 0.03380834f, -0.00439981f, 
    -0.08388361f, -0.03261096f, 0.10859055f, -0.09723295f, 0.23464519f, 0.15206677f, 0.16568121f, -0.08031853f, 
    -0.00715960f, 0.01667814f, 0.07605107f, 0.04811517f, -0.06852713f, 0.04430518f, 0.06557113f, -0.01750596f, 
    0.02070657f, 0.29195741f, 0.04428961f, 0.15020111f, -0.03992538f, 0.10420064f, -0.05141860f, -0.02020267f, 
    0.00372963f, 0.03420857f, 0.15208106f, 0.01321733f, 0.05317461f, 0.17022146f, 0.03794713f, 0.17214975f, 
    0.02789371f, 0.00728147f, -0.08240855f, -0.04857380f, 0.01528270f, 0.02967397f, 0.02112792f, -0.05530201f, 
    -0.08617903f, -0.02617759f, 0.07959621f, -0.00710560f, 0.05049943f, -0.01867380f, -0.03138347f, -0.11433783f, 
    0.10127951f, -0.00651537f, -0.01855281f, -0.04363339f, 0.09469114f, 0.06920509f, 0.04625398f, 0.05143632f, 
    -0.02172946f, 0.11328474f, 0.05638188f, -0.00807809f, 0.07813433f, -0.06938607f, 0.07772660f, -0.00398338f, 
    -0.02264383f, 0.06208190f, -0.10052512f, -0.08685416f, 0.00503281f, 0.01550760f, 0.00845353f, -0.04545736f, 
    -0.03101634f, -0.08396761f, 0.06626067f, -0.06508091f, -0.29346964f, 0.01937867f, -0.02028316f, -0.03875266f, 
    -0.00796820f, -0.10010570f, -0.01222327f, -0.06876423f, 0.07629512f, -0.02981420f, -0.04249582f, 0.00047455f, 
    -0.15976003f, 0.12933472f, 0.10768100f, 0.14203349f, -0.06355778f, -0.01717683f, -0.00908108f, 0.02894323f, 
    -0.08398580f, 0.01025990f, 0.00176225f, 0.04169722f, 0.06906919f, -0.02721973f, 0.08250303f, 0.05295116f, 
    0.08781730f, -0.01017365f, -0.04049833f, -0.00953393f, 0.06802958f, 0.06355679f, -0.04698450f, 0.02169927f, 
    -0.25075838f, -0.49168628f, 0.02944157f, -0.04996983f, -0.06079777f, 0.01850932f, 0.04125438f, -0.06239441f, 
    -0.01759366f, -0.09474020f, 0.09312973f, -0.00877769f, 0.11459625f, 0.18642433f, 0.00078940f, -0.08944369f, 
    0.01874882f, 0.07331126f, 0.01001788f, -0.00345367f, 0.07202043f, -0.10591515f, -0.04776189f, -0.02284684f, 
    -0.31788120f, -0.17434967f, -0.35096338f, 0.06036944f, 0.13626121f, 0.04723175f, -0.02918831f, -0.04283417f, 
    -0.05719339f, 0.06093075f, -0.06821965f, 0.00785559f, 0.06752537f, 0.10325279f, -0.04797355f, -0.05630012f, 
    -0.01162736f, 0.05945439f, 0.01544068f, -0.01464208f, 0.04424881f, 0.10563976f, 0.02380303f, -0.13391645f, 
    -0.07781499f, -0.00477937f, -0.00775035f, 0.04323313f, -0.03762954f, 0.05508525f, -0.07336756f, 0.01351452f, 
    0.00125917f, -0.01113977f, 0.08574375f, -0.00517139f, 0.15393938f, 0.16586523f, 0.19062582f, 0.02172646f, 
    0.06102244f, -0.03386477f, -0.08550382f, 0.03936497f, 0.07360646f, -0.09717710f, 0.02584963f, -0.00469167f, 
    -0.06200876f, -0.03730832f, -0.03534338f, 0.01478017f, 0.08896583f, -0.02357867f, 0.02642991f, 0.00382043f, 
    0.03244152f, 0.00858779f, 0.10432246f, 0.03967523f, -0.07334299f, -0.07428537f, 0.18610020f, -0.01066676f, 
    0.00531748f, -0.05255650f, 0.00370806f, 0.08867747f, 0.04539592f, -0.02418107f, 0.02571128f, 0.04544850f, 
    -0.00028544f, -0.16155505f, -0.29965353f, 0.12075117f, 0.08151555f, -0.01277464f, 0.03445404f, -0.04037927f, 
    -0.11489956f, -0.02139023f, 0.02541374f, 0.01521186f, 0.05635677f, 0.22445343f, 0.06416753f, 0.01555594f, 
    -0.09082858f, 0.04865090f, 0.06143242f, 0.05564266f, 0.00267699f, 0.01407029f, 0.03363351f, 0.11965054f, 
    -0.41193497f, -0.07490429f, -0.18172123f, -0.03244169f, -0.05562534f, 0.06214115f, 0.01594952f, -0.10418265f, 
    -0.07758431f, -0.00863587f, 0.04981270f, 0.01464465f, 0.33955780f, -0.10033268f, -0.13571601f, 0.10587192f, 
    0.01519355f, 0.04529186f, 0.02804805f, -0.13879351f, 0.03880526f, -0.01041755f, 0.09648050f, -0.05619322f, 
    -0.07034027f, -0.01737870f, -0.08563378f, -0.09794922f, -0.04957404f, 0.18538159f, -0.02898561f, -0.13525231f, 
    0.08609543f, 0.08529296f, 0.08158217f, -0.01534720f, 0.20496882f, 0.08981855f, 0.09173465f, 0.08570894f, 
    0.01460775f, -0.05779851f, 0.02136607f, 0.02911082f, 0.03148178f, -0.03232184f, 0.01116896f, 0.03899625f, 
    0.16300702f, 0.32787231f, 0.01223303f, -0.03808983f, -0.01563771f, -0.01693613f, 0.12552896f, -0.05329232f, 
    0.06601476f, -0.10462616f, 0.05406848f, 0.09033619f, -0.12693340f, 0.01802405f, 0.15650015f, 0.23340644f, 
    0.00848444f, -0.07446904f, 0.01508325f, 0.07485785f, 0.02320952f, -0.08802780f, 0.06568059f, -0.01492143f, 
    -0.07401515f, -0.03439526f, -0.11385284f, 0.00174812f, -0.02950068f, -0.03141512f, -0.04541792f, 0.02329922f, 
    -0.03816007f, -0.02086153f, -0.03644720f, 0.01169208f, -0.01131323f, -0.01688525f, 0.05112413f, -0.16004601f, 
    0.00374068f, 0.08458098f, 0.04366010f, 0.00823843f, 0.06151215f, -0.11408044f, -0.00896959f, 0.02490703f, 
    0.08365800f, -0.05212789f, 0.03157964f, 0.09321892f, 0.04994164f, -0.02636673f, -0.07015065f, 0.06071225f, 
    0.03914994f, 0.04527140f, 0.12360279f, 0.12961537f, 0.19755082f, -0.03894654f, 0.05570714f, 0.01368279f, 
    0.08899756f, 0.03847934f, -0.00753559f, -0.02178476f, 0.11161257f, -0.00757691f, -0.10460915f, -0.01837640f, 
    0.04015518f, 0.07401852f, 0.09445871f, 0.19890885f, 0.01163380f, -0.00014385f, -0.00448708f, -0.02073037f, 
    0.05488891f, -0.08013953f, -0.00368610f, -0.01602048f, -0.27203020f, 0.12307714f, 0.08888885f, -0.11610965f, 
    -0.02519710f, 0.11538264f, -0.01500218f, 0.06225991f, 0.14524284f, 0.14273873f, -0.00264393f, 0.10501717f, 
    -0.03586692f, -0.11665846f, -0.17368869f, -0.03431593f, -0.03865442f, 0.07055652f, 0.04099222f, 0.01396629f, 
    0.01423024f, -0.03040828f, -0.03086127f, 0.03519647f, 0.15907945f, -0.02617720f, 0.13388132f, -0.16725290f, 
    0.08350579f, -0.00612170f, -0.00820650f, -0.09215724f, -0.00108590f, 0.01586092f, 0.03939857f, 0.02538222f, 
    0.05124764f, 0.08453117f, 0.00375026f, 0.14558898f, 0.04921254f, -0.03622835f, 0.08694332f, 0.00814153f, 
    0.01562160f, 0.10015899f, 0.06779166f, 0.06976380f, -0.17921107f, 0.12655203f, 0.15820211f, 0.05708271f, 
    0.14135396f, -0.00604699f, 0.09853526f, -0.05192368f, 0.05624060f, -0.07353766f, -0.02032013f, -0.04464008f, 
    0.06278536f, -0.27307048f, 0.24988362f, -0.23196164f, -0.04998625f, 0.00210128f, -0.02654050f, 0.03684971f, 
    -0.10705309f, 0.05140033f, -0.00221063f, 0.07719240f, -0.17300561f, -0.05091135f, -0.08247881f, 0.13896273f, 
    0.11495172f, 0.03176390f, 0.02956059f, 0.00330603f, -0.00376773f, 0.04899246f, 0.08262301f, -0.10860223f, 
    0.10172299f, -0.02053277f, -0.10403188f, 0.18070824f, -0.06561530f, 0.05631378f, 0.05550645f, 0.01317042f, 
    0.07445110f, -0.04905934f, -0.10531939f, 0.01288588f, 0.16780308f, -0.18995926f, -0.03057768f, 0.11556100f, 
    -0.10287585f, 0.03820882f, 0.02466974f, 0.02470865f, -0.00033870f, 0.02759792f, -0.11906856f, 0.00037948f, 
    0.15795761f, -0.06554531f, 0.16173001f, 0.09670334f, 0.06851117f, -0.02240356f, -0.05782414f, 0.06353894f, 
    0.01034158f, -0.09076764f, 0.02144520f, -0.02574178f, -0.22703347f, 0.20954888f, -0.00260308f, 0.00608269f, 
    -0.10958179f, 0.03196392f, -0.05429851f, 0.04088140f, 0.11245687f, 0.00805690f, -0.01426534f, 0.00416865f, 
    -0.13696346f, -0.09690922f, -0.01602858f, -0.03263108f, -0.17958109f, -0.03035347f, 0.06925313f, 0.05620130f, 
    0.07206984f, -0.08331258f, 0.01369008f, 0.06882831f, 0.11202933f, 0.13303930f, 0.04791910f, -0.06897405f, 
    0.03000483f, -0.02880632f, 0.01887360f, -0.03430399f, 0.00876724f, 0.01906889f, 0.06184335f, 0.01813187f, 
    -0.19299957f, -0.05149398f, 0.05404514f, 0.20747942f, 0.05657858f, -0.07246268f, -0.08674063f, -0.14293274f, 
    -0.03415301f, -0.00984033f, 0.02110752f, 0.10518057f, 0.14535548f, 0.16447903f, -0.06231350f, -0.02824415f, 
    0.09509534f, 0.05464777f, 0.06205809f, 0.02538922f, 0.04867290f, 0.10934500f, 0.04420868f, 0.02445083f, 
    0.10149096f, -0.37388071f, 0.18213280f, 0.07195313f, 0.02254595f, -0.00189201f, -0.03458227f, -0.05888491f, 
    -0.00283393f, 0.05989709f, 0.01308463f, -0.06845622f, -0.10090800f, 0.08651835f, -0.13183182f, 0.08822035f, 
    0.02015560f, 0.04608586f, -0.09770448f, -0.08686875f, -0.04897815f, 0.02660759f, -0.04177794f, -0.04776905f, 
    -0.16776608f, -0.02618345f, 0.07041636f, -0.10830873f, -0.05952039f, -0.01807532f, -0.01985199f, 0.01487168f, 
    0.12947777f, 0.02583327f, 0.08932111f, -0.02812380f, 0.02953666f, -0.05079890f, -0.16965674f, 0.00618601f, 
    0.03923665f, -0.03838071f, -0.05710156f, -0.02204590f, 0.01581644f, -0.16391364f, 0.12988351f, -0.08684660f, 
    0.04848915f, 0.08814878f, -0.05750687f, 0.11425520f, 0.02960714f, 0.02781446f, 0.05731738f, -0.11048070f, 
    0.00274853f, 0.13389340f, 0.02616697f, 0.00737736f, -0.12968993f, 0.11972456f, 0.12057901f, -0.00435022f, 
    -0.10337935f, 0.08120994f, 0.02717974f, -0.01578860f, 0.07634797f, 0.07763504f, 0.07742520f, 0.17019646f, 
    0.24092762f, 0.11523323f, -0.05347283f, 0.00731170f, 0.02277597f, 0.08616176f, 0.12354898f, 0.09418629f, 
    0.08039401f, -0.02538106f, -0.03784986f, -0.01091381f, -0.18461435f, 0.04510682f, 0.06804884f, 0.03116837f, 
    -0.02112008f, 0.04338061f, 0.07064801f, 0.05005463f, 0.07382143f, 0.16644956f, -0.04448457f, 0.05238555f, 
    0.11608186f, -0.05499510f, 0.30386108f, -0.26924008f, -0.09653024f, 0.06906569f, 0.07480739f, -0.06235003f, 
    -0.01222661f, -0.00102475f, -0.04264308f, -0.12664686f, -0.20197682f, -0.01895255f, 0.12228822f, 0.01563492f, 
    -0.09291540f, -0.02951648f, -0.01432079f, -0.04755447f, 0.06172394f, -0.13025422f, -0.00658159f, -0.13238597f, 
    -0.11376260f, -0.10929210f, 0.07280289f, -0.24730822f, 0.13990113f, -0.11259317f, -0.09620911f, -0.16738130f, 
    -0.00779447f, 0.00583595f, 0.01545518f, -0.02692509f, 0.08835661f, 0.18574888f, 0.00736915f, -0.01493129f, 
    0.15882619f, -0.01266966f, -0.05647517f, -0.05277674f, 0.04966949f, 0.02378052f, -0.05993008f, -0.00742736f, 
    0.14503612f, 0.22157222f, -0.01263743f, 0.04136325f, 0.08273939f, -0.00923893f, 0.00594245f, 0.12028807f, 
    0.10390152f, 0.05840277f, 0.03984391f, 0.00147851f, 0.14921103f, 0.15301615f, 0.00934711f, -0.05222010f, 
    0.12266614f, 0.05551722f, 0.04600053f, 0.05830895f, 0.09108916f, 0.09319306f, 0.05810946f, -0.00337786f, 
    -0.16127753f, -0.09316380f, -0.08024941f, 0.12879261f, -0.06969180f, 0.03943506f, -0.22164008f, 0.13768201f, 
    -0.06814357f, -0.01889506f, -0.03450722f, 0.01325405f, 0.10937898f, 0.15836881f, 0.18954812f, 0.01008627f, 
    -0.09462965f, -0.06953234f, -0.02928126f, 0.08208320f, 0.02225875f, -0.09326554f, -0.07260581f, -0.10872336f, 
    -0.05027823f, -0.14390321f, 0.15080051f, -0.10820582f, 0.03419697f, -0.02757361f, 0.13650125f, -0.04440195f, 
    -0.08941051f, 0.08016662f, -0.04790522f, 0.08584532f, 0.04282831f, 0.04509047f, 0.02785564f, -0.02230733f, 
    -0.07141336f, -0.14140958f, -0.02865585f, 0.06895644f, 0.05819217f, -0.02425835f, -0.03640845f, 0.14577945f, 
    -0.06624918f, 0.15522948f, -0.01283014f, -0.02759625f, -0.14030403f, 0.04778900f, 0.01061382f, -0.05754540f, 
    0.05651801f, -0.05716169f, 0.03143175f, -0.03102743f, -0.06353195f, 0.28895554f, 0.06073106f, 0.09203841f, 
    0.06811602f, 0.03355630f, -0.11349913f, -0.01798615f, 0.06883168f, 0.02493846f, -0.01340427f, 0.04213390f, 
    -0.05389340f, -0.27320161f, -0.03798992f, -0.09388544f, -0.00905950f, -0.10350369f, 0.11695062f, -0.01632609f, 
    -0.07134939f, 0.05629708f, 0.02261276f, 0.07703205f, 0.29413393f, 0.01604611f, 0.09526862f, -0.00084604f, 
    -0.02571468f, 0.04150824f, 0.14413573f, -0.00389135f, -0.03398148f, 0.01366216f, 0.10889038f, 0.06756981f, 
    -0.29198787f, 0.27684739f, -0.11915307f, 0.00501613f, 0.06323358f, -0.04254530f, -0.01047307f, 0.09848773f, 
    0.04942479f, -0.00237388f, 0.04956135f, -0.01886196f, 0.31913352f, -0.02187103f, -0.11650857f, 0.00902466f, 
    0.10535450f, -0.01205052f, -0.03627245f, 0.00615449f, -0.00822440f, 0.09303089f, -0.00772576f, -0.02388551f, 
    -0.08108294f, -0.01888231f, -0.10796612f, 0.05092247f, -0.05541710f, -0.01028755f, -0.15628920f, -0.10540932f, 
    -0.04723059f, 0.10594690f, 0.05131969f, 0.06421839f, -0.17478552f, 0.26694211f, -0.06132811f, 0.00063003f, 
    -0.08722576f, 0.05464635f, 0.01066028f, -0.00634918f, -0.07959320f, 0.05766222f, 0.03731652f, -0.00898654f, 
    -0.24979354f, -0.08236364f, 0.00609553f, -0.13226865f, -0.00759421f, -0.03531798f, -0.00365014f, 0.01732228f, 
    0.06206262f, -0.00695018f, -0.04135051f, 0.00247225f, -0.00505530f, 0.13242199f, 0.06021018f, 0.01785960f, 
    0.07117842f, -0.02370303f, 0.00082010f, -0.00646728f, -0.00700934f, 0.07178980f, 0.01991408f, 0.07425213f, 
    0.01084859f, 0.17081743f, -0.04582027f, -0.04502423f, -0.18237767f, 0.01925119f, -0.03921187f, 0.06854194f, 
    0.02073396f, 0.10095012f, 0.05604763f, 0.00356200f, 0.05671365f, 0.07177629f, 0.02827314f, -0.01787476f, 
    -0.00497630f, -0.02453648f, 0.07028586f, 0.02727950f, 0.00754482f, 0.06122445f, 0.00014569f, 0.05034951f, 
    0.05193428f, -0.09410572f, 0.04989101f, -0.08180089f, -0.09778641f, -0.03450311f, 0.01006522f, 0.04174319f, 
    0.04636978f, 0.02856582f, -0.03071029f, 0.09102300f, -0.02564401f, 0.06675632f, -0.13510145f, 0.22786306f, 
    0.01652697f, -0.02702556f, 0.03192830f, 0.01342735f, -0.12434975f, -0.06213922f, -0.04891041f, 0.08685362f, 
    0.04711824f, -0.05715822f, 0.11090270f, -0.13405040f, -0.01406526f, -0.06675006f, 0.10970870f, 0.01145309f, 
    -0.01599891f, -0.12460759f, 0.00669567f, -0.01952147f, -0.26885787f, 0.19894901f, 0.18823309f, 0.02760523f, 
    0.02987634f, -0.01278515f, 0.09940846f, 0.00443950f, -0.09734888f, -0.04627244f, -0.03012605f, -0.00857614f, 
    0.08373234f, -0.08026350f, 0.00779378f, 0.13886906f, -0.04681878f, 0.04552605f, 0.00566576f, 0.01804203f, 
    -0.02423140f, 0.13124219f, -0.00052347f, 0.11962399f, -0.27319956f, -0.09303194f, 0.10800196f, 0.05253243f, 
    0.00178515f, 0.03008387f, 0.04956166f, -0.08061697f, 0.17356755f, 0.09557606f, -0.03180965f, 0.04796695f, 
    -0.11623258f, 0.03811167f, 0.00431751f, 0.07701163f, -0.00002659f, -0.16043380f, -0.03531148f, -0.01121065f, 
    -0.05103575f, -0.05343222f, -0.01800028f, 0.00292631f, 0.16241637f, 0.18753192f, -0.01278114f, 0.01743598f, 
    0.09002176f, 0.02599763f, 0.06050301f, 0.00956722f, 0.00337044f, -0.01068197f, -0.04375680f, -0.08456901f, 
    0.13129449f, -0.10143046f, 0.02772884f, 0.02578922f, -0.10268019f, -0.01404241f, -0.08919279f, 0.05821172f, 
    0.01544149f, -0.02833556f, -0.03772995f, 0.04196238f, -0.05273553f, 0.06337608f, -0.06294221f, 0.09631242f, 
    -0.04328281f, 0.00161924f, -0.05320295f, -0.06454343f, 0.01817261f, -0.07366191f, -0.08537229f, -0.04257001f, 
    0.04695439f, -0.07769149f, -0.02055367f, -0.13223067f, 0.11733229f, -0.04315247f, -0.01978535f, 0.06154829f, 
    0.14098814f, 0.05995800f, -0.02184735f, 0.01562238f, -0.08608565f, 0.05338735f, 0.00631661f, 0.24934539f, 
    0.12535325f, 0.05618116f, 0.04249518f, -0.10143702f, 0.06648420f, 0.17078513f, 0.03104850f, 0.07031820f, 
    0.11486626f, -0.11081941f, -0.12980366f, -0.05324093f, 0.03496816f, -0.00183776f, 0.09006418f, 0.14330082f, 
    0.10098075f, 0.09635233f, 0.00130251f, 0.12497851f, 0.08643186f, 0.28357843f, -0.01013253f, -0.15613919f, 
    0.07761436f, -0.07733742f, 0.03350443f, 0.04850246f, -0.01381113f, -0.01394773f, 0.01415477f, 0.02384575f, 
    0.02570830f, -0.01876181f, 0.02904750f, -0.03116077f, 0.02642900f, -0.01371518f, 0.02386311f, -0.01143396f, 
    -0.03228353f, 0.00330821f, 0.01299888f, 0.00571226f, -0.03284120f, 0.00763697f, -0.02442447f, -0.02753714f, 
    -0.00293678f, -0.04032202f, 0.01575926f, 0.01982112f, 0.00489801f, 0.02849376f, -0.01325159f, -0.02092446f, 
    -0.03129570f, 0.00089382f, 0.00773473f, -0.04163228f, 0.01480948f, 0.00141498f, -0.03234963f, 0.02059441f, 
    -0.03014649f, 0.02833076f, -0.01336108f, -0.03043646f, -0.02511664f, -0.04184486f, 0.02234486f, -0.02577601f, 
    0.02824750f, -0.02015541f, 0.02259394f, 0.02970865f, -0.04161490f, -0.02483380f, -0.00889281f, 0.02072164f, 
    0.00103752f, 0.01309381f, -0.01109396f, -0.01212026f, 0.00862542f, 0.01893372f, 0.02020357f, -0.03381199f, 
    -0.02629689f, -0.00513265f, 0.01881950f, -0.02676856f, 0.01370781f, -0.03755900f, -0.00987638f, 0.01105604f, 
    -0.00201936f, 0.02444049f, 0.01576634f, 0.01811910f, -0.00701984f, -0.02689609f, 0.00018208f, -0.03778731f, 
    -0.03929526f, 0.00458632f, -0.00970024f, -0.02884298f, -0.02930545f, -0.00788422f, -0.03740214f, 0.00616422f, 
    0.02313229f, 0.00694126f, -0.03933031f, -0.03904722f, 0.00336387f, 0.00140380f, 0.01029743f, -0.03591717f, 
    0.00967917f, -0.00636065f, 0.00019129f, 0.03007120f, 0.00291519f, -0.01320699f, -0.03184770f, -0.03911357f, 
    0.01025637f, -0.02458383f, 0.01371694f, 0.02501269f, -0.03983789f, 0.01380683f, 0.02761528f, 0.00335737f, 
    -0.00265076f, -0.03100653f, -0.01809779f, -0.02919784f, 0.02131034f, 0.02474898f, -0.01102060f, -0.01159761f, 
    -0.03401310f, -0.01271829f, 0.01995560f, -0.01871784f, 0.00146954f, -0.03499754f, -0.01032645f, -0.02317260f, 
    0.02747629f, -0.01375288f, 0.00024313f, -0.03495899f, -0.01237646f, 0.01121641f, 0.02138978f, 0.02360947f, 
    -0.02803449f, -0.00089445f, 0.00782454f, -0.01128281f, 0.00598291f, 0.02557128f, -0.01518588f, 0.01144516f, 
    -0.03645505f, 0.01079607f, 0.01759162f, 0.02565771f, 0.02131915f, 0.02064221f, 0.01031410f, -0.02762107f, 
    0.00726926f, -0.00707067f, -0.03591875f, 0.02313337f, -0.01778438f, 0.02539025f, -0.02084322f, -0.02074037f, 
    0.00118421f, 0.01460679f, -0.03564038f, -0.01788782f, 0.02322693f, 0.02359577f, -0.03808695f, -0.01543618f, 
    -0.00769606f, -0.03493300f, -0.01209384f, 0.00196476f, -0.02318667f, -0.03791627f, -0.02247246f, -0.01864752f, 
    -0.02254397f, -0.01114174f, 0.02569158f, 0.02852628f, -0.03660136f, -0.02766956f, -0.02948796f, -0.02652761f, 
    -0.04101383f, -0.01652911f, -0.00216374f, 0.00126092f, 0.01218220f, 0.02578568f, -0.00125885f, 0.02797678f, 
    0.02505630f, 0.02247842f, 0.02577328f, 0.00259388f, 0.00842520f, -0.01052998f, 0.02809468f, 0.00865346f, 
    0.02644971f, 0.02620253f, 0.00814968f, 0.00223545f, -0.00050976f, -0.03834085f, 0.03014821f, -0.01661897f, 
    0.02863375f, -0.03309941f, 0.02300891f, -0.04004718f, 0.00328661f, 0.02021354f, -0.03153667f, 0.01819127f, 
    0.00620242f, -0.02911332f, -0.02282387f, -0.03373254f, -0.02408415f, -0.00244308f, 0.00033546f, -0.03909292f, 
    -0.03618224f, 0.00267545f, -0.00762243f, -0.00786624f, -0.01497827f, -0.00958568f, 0.02287027f, -0.03190371f, 
    -0.04040451f, 0.02501900f, -0.02664379f, -0.03313711f, 0.02376213f, 0.02486427f, 0.02131567f, 0.01754107f, 
    0.02898542f, -0.04012706f, -0.04130828f, -0.01737693f, 0.01890265f, -0.00824376f, -0.01890031f, -0.02485851f, 
    -0.00168572f, 0.00737784f, 0.02343682f, 0.01862139f, -0.02994132f, -0.00167687f, 0.00533833f, -0.01106717f, 
    0.03563065f, -0.03190906f, 0.02360822f, -0.03942287f, 0.01164579f, 0.02058523f, -0.03369480f, 0.02026434f, 
    -0.02973974f, -0.03962056f, -0.02463670f, -0.04185901f, -0.02932950f, -0.00912168f, 0.01816609f, -0.02636983f, 
    -0.00311997f, -0.01999130f, -0.02466092f, 0.01827614f, -0.04174330f, -0.02897033f, -0.03519562f, -0.02060492f, 
    -0.03724807f, 0.02077020f, 0.01703100f, -0.03305661f, 0.02802173f, -0.03826622f, 0.00776513f, 0.01495074f, 
    0.00143916f, 0.00419231f, 0.00124013f, -0.01216847f, 0.02115596f, 0.01499911f, -0.03177042f, 0.02013217f, 
    0.00657212f, 0.00504690f, -0.01292551f, -0.00849829f, -0.02437602f, -0.01483887f, 0.01246078f, 0.02609296f, 
    -0.03618090f, -0.01636029f, 0.00144281f, -0.01499906f, -0.03559912f, 0.00188503f, -0.01769855f, 0.00909272f, 
    -0.01479163f, -0.02092830f, -0.01677968f, -0.00872645f, -0.00005451f, -0.01505545f, 0.01602490f, -0.01583808f, 
    -0.01594072f, 0.01190297f, -0.02881833f, 0.02935546f, -0.01801715f, 0.00812399f, -0.03322606f, -0.02869689f, 
    0.01538474f, -0.03649430f, -0.00547514f, -0.03327922f, -0.00606579f, -0.00920371f, 0.00012336f, 0.02754501f, 
    0.01485940f, -0.01221440f, -0.00275013f, -0.02567379f, -0.02250102f, -0.02841286f, 0.01702698f, 0.01543086f, 
    -0.01118374f, -0.02628981f, 0.00845353f, -0.00758567f, 0.01869257f, -0.00475451f, 0.02749793f, -0.04119500f, 
    -0.00189478f, 0.00050118f, -0.02308428f, -0.03852169f, -0.01421568f, 0.00932887f, 0.00477610f, -0.00133011f, 
    0.02668690f, -0.01414271f, -0.03716785f, 0.02461372f, 0.00537662f, 0.01941912f, 0.01875637f, -0.01573525f, 
    -0.02371410f, 0.00640514f, -0.01557179f, 0.02621543f, -0.02803217f, -0.01913429f, -0.01046579f, 0.02948109f, 
    0.01767876f, -0.03599184f, 0.02022290f, -0.01208611f, -0.02779921f, 0.01711783f, 0.00658601f, 0.02075009f, 
    -0.03500510f, -0.00623505f, -0.03780982f, -0.01629584f, 0.00074596f, -0.02572896f, -0.02153395f, -0.00861933f, 
    -0.01195037f, -0.01268944f, 0.00053163f, -0.02394689f, 0.02977352f, -0.02406124f, 0.00413162f, 0.01599481f, 
    -0.00072908f, -0.01562377f, -0.04201037f, -0.00705364f, 0.01470126f, -0.02002363f, 0.01819508f, -0.01254406f, 
    -0.00094643f, -0.04105785f, -0.01529550f, 0.01722292f, 0.01539479f, -0.00999861f, -0.02796779f, -0.02048924f, 
    -0.02524457f, 0.00342558f, 0.01016807f, -0.02985750f, -0.01374003f, 0.02871330f, -0.01813494f, -0.00753114f, 
    -0.02987561f, 0.02498517f, 0.01357039f, -0.02836446f, -0.02439166f, -0.00341166f, -0.00350935f, -0.00904219f, 
    -0.03235005f, -0.04023821f, 0.01807021f, 0.01927274f, -0.03436765f, -0.00752836f, -0.04007874f, -0.02448152f, 
    -0.03276283f, -0.03496651f, 0.02594545f, -0.02694973f, -0.03095587f, 0.00921713f, -0.01270520f, 0.01460353f, 
    0.00589172f, -0.03326026f, 0.00218626f, 0.00805210f, 0.00229678f, 0.01581372f, 0.01564128f, -0.03869209f, 
    0.02015376f, 0.01364142f, 0.00154714f, 0.01257531f, -0.02168167f, 0.01401717f, -0.01896341f, -0.01449057f, 
    0.00782300f, -0.02374981f, -0.00943861f, 0.01852975f, 0.02328648f, -0.00794058f, 0.02353975f, -0.02763735f, 
    -0.00437924f, -0.04174907f, 0.01930808f, -0.03217071f, 0.00321487f, 0.02191843f, 0.01724511f, -0.02685355f, 
    0.01944747f, -0.00583669f, -0.01386003f, 0.02854522f, -0.02058985f, -0.02923933f, 0.01865033f, -0.01246700f, 
    -0.03351248f, 0.00721555f, -0.01361130f, -0.00968628f, -0.02353099f, -0.02311766f, 0.00926851f, -0.03718327f, 
    -0.01042012f, 0.00878819f, -0.00073405f, 0.02882484f, 0.00336937f, 0.00808110f, -0.03190064f, -0.02726283f, 
    -0.02006514f, 0.01273935f, 0.02321833f, -0.02939849f, -0.00933322f, -0.02290725f, 0.00687761f, -0.00436060f, 
    -0.01480912f, 0.02323104f, -0.02264476f, 0.02814976f, -0.03579493f, 0.02240448f, -0.00489372f, 0.00076418f, 
    0.01600653f, -0.02435936f, -0.00677917f, 0.00811246f, -0.00260431f, 0.00983408f, 0.00765455f, -0.00928642f, 
    0.02543004f, -0.00058066f, 0.02786281f, -0.02411257f, 0.00476651f, -0.02706867f, 0.01846466f, -0.03386706f, 
    0.02917848f, 0.00512816f, 0.00236758f, -0.01709926f, -0.03805214f, -0.01876560f, 0.00395652f, -0.03952156f, 
    -0.02041123f, -0.03357983f, -0.01837758f, -0.03119719f, -0.01408520f, 0.01638801f, 0.02976548f, 0.03423868f, 
    -0.01156132f, -0.01242782f, 0.01407234f, -0.01372199f, -0.00702379f, -0.03005224f, -0.03456920f, 0.02656419f, 
    0.01028579f, 0.02349866f, 0.01961373f, -0.02851156f, -0.00755460f, -0.02679854f, 0.00699652f, -0.00304866f, 
    -0.00968785f, -0.01071842f, 0.01931431f, 0.02401165f, -0.00483899f, -0.03631334f, -0.01127834f, 0.00828386f, 
    -0.00808709f, 0.02748989f, 0.00809610f, -0.00272266f, -0.03190221f, -0.00972829f, -0.03559258f, -0.00480230f, 
    0.00067774f, -0.02825355f, 0.01274507f, -0.02710866f, 0.02210183f, 0.00508368f, -0.00127050f, -0.01219073f, 
    0.01906627f, 0.01470786f, -0.01567997f, 0.02672249f, 0.01411141f, 0.01865806f, -0.02874612f, 0.02399474f, 
    0.02697762f, -0.01092814f, -0.01815323f, -0.00015266f, 0.00298698f, -0.03290860f, -0.03768738f, 0.00553383f, 
    0.00317503f, -0.02097271f, -0.03187047f, 0.01979613f, -0.00199825f, -0.02447509f, 0.01194367f, -0.01373656f, 
    0.01145796f, 0.00663102f, -0.00433105f, -0.04186834f, -0.03011215f, -0.00160837f, -0.02634988f, 0.00911213f, 
    -0.03781465f, 0.00753734f, -0.03739644f, -0.03538126f, -0.00045631f, -0.01382429f, 0.02255917f, 0.01369382f, 
    -0.03938537f, 0.01724453f, 0.01578106f, -0.02390521f, 0.01163073f, -0.02550801f, 0.02819132f, -0.03873722f, 
    -0.03705782f, -0.00740888f, -0.01180486f, -0.01807963f, 0.02520878f, 0.01301133f, -0.02670449f, -0.01568552f, 
    0.02078024f, -0.00624000f, -0.02710856f, 0.00438472f, -0.01789494f, -0.02102588f, -0.01523189f, 0.00795983f, 
    -0.03020295f, -0.00781201f, -0.01056874f, 0.02668409f, 0.00613407f, 0.02609113f, -0.04144273f, -0.01239293f, 
    0.01117953f, -0.03089991f, -0.03962495f, -0.01360369f, 0.02759876f, 0.02474832f, -0.02632910f, -0.03042016f, 
    -0.02453483f, -0.02714555f, -0.03848805f, -0.01779325f, -0.02233651f, 0.01470199f, 0.02246210f, -0.02447965f, 
    -0.00156548f, -0.01283519f, 0.02246101f, 0.00045015f, 0.02276914f, 0.02479225f, -0.02166047f, -0.02015925f, 
    -0.01805380f, 0.00760388f, -0.00615762f, -0.03897985f, -0.01483871f, 0.01818552f, 0.01902666f, -0.03391242f, 
    0.00505108f, 0.02053411f, 0.01431488f, 0.02198702f, 0.02332977f, 0.03969811f, -0.00485652f, 0.01988248f, 
    0.00335703f, -0.01439374f, 0.01838201f, 0.00450520f, 0.00901027f, -0.02936159f, 0.02351992f, 0.02531777f, 
    0.01103274f, 0.01148970f, 0.00196494f, -0.00346683f, -0.03825849f, 0.01585963f, -0.02725885f, 0.00817482f, 
    -0.02808899f, -0.03320443f, -0.01994731f, -0.01477127f, 0.00668860f, -0.01886531f, 0.02357899f, -0.01039281f, 
    -0.03153844f, 0.00886166f, 0.02586721f, 0.00768280f, -0.00914530f, -0.00629316f, -0.03705287f, 0.01224659f, 
    -0.00231271f, 0.00713320f, 0.03244888f, -0.03352660f, -0.01431806f, -0.03186592f, -0.00871413f, -0.02906031f, 
    0.00068023f, -0.03991358f, -0.03961179f, -0.00314941f, 0.02760320f, -0.01765875f, -0.00882895f, -0.04128429f, 
    -0.00645659f, -0.03196050f, -0.01688704f, -0.01795723f, 0.02888908f, 0.00587779f, 0.00636990f, -0.01530657f, 
    -0.01732486f, -0.02441661f, -0.03377054f, 0.02790873f, 0.02244412f, -0.01986062f, 0.01650513f, -0.04146728f, 
    -0.01871926f, -0.00074978f, -0.01140924f, -0.03402495f, -0.03764569f, -0.03659752f, 0.02541572f, 0.00930031f, 
    -0.03135170f, -0.07045986f, -0.00305976f, -0.01377207f, 0.06454027f, -0.04929217f, 0.07712156f, -0.01040647f, 
    0.10124040f, 0.08979905f, -0.08085780f, 0.12245367f, -0.14122236f, 0.15746714f, 0.12968706f, 0.11878903f, 
    -0.00056862f, 0.01909626f, 0.11958493f, -0.09733634f, -0.01918877f, -0.00210214f, 0.02617379f, 0.00341525f, 
    0.02888010f, 0.09921447f, 0.04999644f, 0.01778817f, 0.13914354f, 0.03240719f, 0.05221900f, 0.00343851f, 
    0.07060707f, 0.02275903f, -0.11328688f, -0.00852586f, 0.02789568f, 0.10386148f, 0.05670604f, 0.13304375f, 
    -0.14660691f, 0.05915270f, 0.04942349f, 0.05266103f, -0.03693492f, -0.01209473f, 0.16023308f, 0.09982473f, 
    -0.21472919f, 0.09858608f, 0.13515250f, -0.07387474f, 0.08482946f, 0.06619326f, 0.02715868f, -0.10114696f, 
    0.03190663f, 0.06764478f, 0.03485797f, 0.03641161f, 0.18978475f, 0.15558635f, -0.16437757f, 0.03505720f, 
    -0.10040991f, -0.01327546f, 0.09193330f, -0.05450851f, -0.02848276f, -0.01807860f, -0.06366906f, -0.06405478f, 
    -0.09853477f, -0.04010496f, 0.11240636f, 0.07581202f, 0.08168119f, 0.05171064f, 0.01522187f, 0.04264528f, 
    0.09854560f, 0.01418679f, 0.05013315f, 0.00069916f, -0.04433046f, -0.01961874f, 0.05058698f, 0.24694610f, 
    -0.06052939f, -0.07262557f, 0.13528976f, 0.01028232f, -0.03380608f, 0.16454741f, -0.11867913f, 0.09753879f, 
    0.17235030f, 0.12429862f, 0.04038593f, 0.04455213f, -0.02914268f, 0.05065414f, 0.08420131f, 0.03731999f, 
    -0.02426801f, -0.07194596f, -0.06152992f, -0.12385061f, 0.10630524f, 0.13620883f, -0.11701817f, 0.00814603f, 
    0.00263481f, -0.01283083f, 0.06966727f, -0.03580447f, 0.11271264f, -0.04880204f, -0.01302605f, 0.03096990f, 
    -0.38693562f, 0.07964499f, -0.00406529f, 0.04477461f, -0.03565787f, 0.14216137f, 0.01700797f, -0.04171519f, 
    0.01947544f, -0.03529154f, -0.03866350f, 0.02673803f, 0.16801693f, -0.04247871f, 0.18610257f, -0.12242948f, 
    0.10284157f, 0.15175886f, 0.12272590f, -0.01862187f, -0.02008135f, 0.08693480f, 0.01647232f, -0.01094963f, 
    -0.05395017f, -0.01202614f, -0.05654385f, -0.06308633f, 0.05345773f, -0.08831072f, 0.00885378f, 0.07864241f, 
    0.05632513f, 0.15512462f, 0.17529668f, 0.02414230f, -0.13519506f, -0.05919501f, -0.16864537f, -0.05899081f, 
    0.08195378f, 0.14022912f, 0.10976426f, 0.02658518f, 0.06275496f, 0.01871678f, 0.09193477f, 0.13286032f, 
    -0.02754010f, 0.01067957f, -0.14886586f, 0.09888092f, -0.04805548f, -0.11413489f, -0.01166873f, 0.06972751f, 
    -0.06720376f, 0.06683198f, 0.04171326f, 0.04779564f, 0.00106136f, -0.00645867f, -0.01715537f, -0.23634900f, 
    -0.01101571f, -0.05938755f, -0.03254871f, 0.01954078f, -0.02405429f, 0.13608333f, -0.11531615f, -0.04474721f, 
    0.10125608f, 0.08360885f, -0.07482091f, -0.01726480f, 0.04553765f, 0.08677978f, -0.03171438f, 0.02127467f, 
    -0.05366993f, -0.09200092f, -0.00522200f, -0.09323825f, 0.35239431f, -0.03540841f, 0.08038828f, 0.20086141f, 
    -0.02788008f, -0.07607299f, 0.07855594f, 0.17445478f, -0.02611250f, -0.04249054f, 0.02542035f, -0.00150236f, 
    -0.19478376f, -0.03078573f, 0.19043705f, -0.03226144f, 0.04237810f, 0.00234233f, -0.05296884f, -0.07105933f, 
    -0.07279401f, -0.02412915f, -0.02890682f, -0.04518502f, 0.05165691f, 0.11516691f, 0.01508955f, 0.05286638f, 
    -0.09419920f, -0.02856477f, 0.01265714f, 0.04470374f, -0.12013313f, 0.05498969f, 0.03158006f, -0.14954664f, 
    -0.34006640f, 0.25119746f, 0.07815797f, 0.08236960f, -0.04711836f, 0.08920828f, 0.08009744f, 0.00830612f, 
    -0.01002319f, -0.02631692f, 0.03531465f, -0.02628808f, 0.17093816f, -0.05307624f, 0.19059351f, 0.05462824f, 
    -0.16319212f, 0.10220379f, 0.02230564f, 0.00052735f, -0.08800076f, 0.06725738f, 0.05875584f, -0.00228284f, 
    -0.17387788f, -0.11520782f, 0.01459559f, 0.01959148f, 0.03647737f, 0.07916184f, 0.05395341f, 0.00627001f, 
    0.02337935f, -0.00444037f, -0.06679422f, 0.01320335f, -0.26211697f, 0.09239912f, 0.09188613f, 0.00669042f, 
    0.02688370f, -0.05126224f, 0.11826491f, 0.02961850f, 0.05395706f, 0.13439822f, -0.06802374f, 0.18754445f, 
    0.08092155f, -0.14035101f, 0.15686208f, 0.09180741f, -0.10385927f, -0.09959801f, -0.04369017f, 0.03040860f, 
    -0.09190528f, 0.24834470f, -0.06475423f, 0.00854252f, -0.01308876f, 0.01172578f, 0.08759464f, -0.08057998f, 
    -0.01548513f, -0.01951672f, 0.01034782f, 0.02540897f, 0.09514738f, -0.03105631f, -0.05608581f, -0.09772820f, 
    0.29717401f, 0.09137639f, -0.07322246f, 0.01712728f, -0.00715655f, -0.03196837f, -0.04707658f, 0.02173565f, 
    0.00376441f, -0.06086876f, -0.02242649f, -0.00923915f, 0.09887666f, -0.07601065f, 0.01673018f, -0.13759743f, 
    0.11305133f, -0.05380099f, -0.07508010f, 0.06957977f, 0.09147949f, -0.17495488f, 0.09304389f, -0.05133415f, 
    -0.24256216f, 0.08304775f, 0.16645794f, 0.20634355f, -0.02428883f, 0.00396021f, 0.02740842f, -0.08003975f, 
    0.09332390f, -0.02922553f, 0.13216120f, 0.05877186f, 0.13680358f, -0.04082415f, -0.04929144f, -0.08592598f, 
    -0.02653995f, 0.00307859f, -0.06515560f, -0.04519145f, -0.04419626f, 0.01930670f, -0.16418479f, 0.03454426f, 
    -0.29761046f, -0.13274398f, 0.11007296f, 0.11967020f, -0.01766376f, 0.05652988f, 0.14103891f, -0.00122313f, 
    0.03366079f, -0.02140799f, 0.01012530f, -0.08087204f, 0.14025576f, -0.03668427f, 0.02578888f, 0.09136763f, 
    -0.12713215f, 0.07665944f, 0.20163679f, 0.14360029f, -0.11672158f, -0.00189544f, -0.02903092f, 0.03164746f, 
    0.02987978f, 0.02361211f, 0.02857719f, 0.20758896f, -0.00327565f, -0.11855970f, 0.03928402f, -0.08683351f, 
    -0.10020816f, 0.01102981f, 0.00710375f, 0.01271981f, 0.05135505f, 0.08026768f, 0.00639363f, 0.21360666f, 
    0.03560898f, -0.01008406f, -0.02333101f, -0.02247243f, 0.00355747f, 0.01075973f, 0.10875940f, -0.12192694f, 
    0.26759043f, -0.01670619f, -0.14147279f, 0.12654407f, 0.09816201f, 0.00779933f, -0.03128843f, 0.16075185f, 
    0.04806790f, -0.11703653f, 0.10875496f, -0.00529505f, -0.10052364f, -0.00824333f, 0.09709579f, -0.09964740f, 
    0.01193366f, -0.15427771f, -0.09705415f, -0.13080290f, 0.04063858f, 0.05040072f, 0.07495994f, 0.19717096f, 
    0.04990206f, -0.08443478f, -0.14691734f, 0.02545701f, 0.01900629f, 0.18135837f, 0.04507506f, -0.07772323f, 
    -0.13985249f, -0.08771059f, -0.00737357f, -0.02259774f, -0.11119589f, 0.12626752f, 0.00818355f, -0.00714957f, 
    0.00031901f, 0.09541541f, -0.05672788f, -0.04275015f, 0.02594183f, -0.00116777f, 0.01328204f, -0.09495351f, 
    -0.10931068f, 0.08343577f, -0.00696696f, -0.10040285f, 0.13441841f, -0.03458794f, 0.02315526f, -0.03803858f, 
    -0.03122510f, 0.07366193f, -0.09820746f, -0.09139061f, 0.04758991f, -0.08374514f, 0.14478582f, -0.02850780f, 
    -0.05558735f, 0.00534499f, -0.00845545f, 0.00417331f, -0.03679404f, 0.01136325f, 0.07109242f, 0.03201896f, 
    -0.12021291f, -0.03711032f, -0.00335772f, -0.01353991f, 0.18899056f, -0.02852077f, 0.17652553f, 0.01784191f, 
    0.16656700f, 0.00434330f, -0.01856218f, 0.09126932f, 0.10106098f, -0.20021361f, -0.08649219f, 0.10122729f, 
    0.14757378f, 0.04064746f, 0.02393335f, 0.03150380f, 0.00353833f, -0.10573884f, -0.10875083f, -0.05971619f, 
    0.11900835f, 0.04378461f, -0.10366442f, -0.02155837f, -0.08574471f, -0.03587913f, 0.04469405f, 0.05092482f, 
    0.06902202f, -0.01859697f, 0.00980003f, 0.12231484f, 0.08806035f, 0.10071959f, 0.00273044f, 0.04168045f, 
    0.01809476f, 0.02050348f, 0.01667074f, 0.05058867f, 0.04379672f, 0.06339504f, 0.03470554f, -0.04753344f, 
    -0.08924340f, 0.03144679f, 0.05307884f, -0.02483268f, 0.09334551f, 0.07475496f, 0.16164854f, -0.08269890f, 
    -0.01919874f, 0.00587841f, 0.02281179f, -0.01857691f, -0.00190159f, -0.17261668f, -0.07184757f, -0.12367984f, 
    0.06608178f, -0.02648746f, 0.03927778f, 0.03084255f, -0.03202818f, 0.02065691f, -0.15477230f, 0.18059367f, 
    -0.03522486f, -0.17083912f, 0.08846842f, -0.07327768f, 0.08440289f, 0.04418154f, -0.00811699f, -0.08385961f, 
    0.07629313f, 0.09762254f, -0.04910225f, -0.06486648f, 0.15864886f, 0.19114542f, -0.09902553f, 0.07443463f, 
    -0.01221145f, 0.06181646f, 0.08810852f, 0.11521480f, -0.01803977f, -0.05460333f, -0.12155798f, -0.10417440f, 
    -0.14680237f, -0.05020892f, -0.20646828f, -0.14501990f, 0.17918839f, -0.03404409f, -0.00190117f, 0.08471933f, 
    0.01397007f, -0.00326454f, -0.05528207f, 0.09737060f, 0.23716640f, 0.07360836f, 0.10390943f, 0.07506392f, 
    -0.00056316f, 0.01855174f, 0.00506695f, 0.15375249f, -0.00612738f, 0.06259798f, 0.00858014f, -0.03263199f, 
    -0.05493585f, 0.10625708f, -0.17039736f, -0.29286271f, 0.05421127f, 0.00408272f, -0.03818796f, 0.05849228f, 
    0.11691302f, -0.12185410f, 0.06510150f, -0.00265306f, 0.00746424f, 0.00745480f, 0.06675557f, -0.07215319f, 
    -0.00270491f, 0.09498934f, -0.05069321f, -0.13148844f, 0.02943058f, 0.10856658f, 0.04520734f, 0.12482162f, 
    -0.20689027f, -0.03392369f, -0.02126987f, -0.08393988f, 0.06912526f, 0.02055596f, 0.04644602f, -0.01298062f, 
    -0.01531363f, 0.12908046f, 0.15726833f, 0.10945194f, -0.00457774f, 0.00679523f, 0.04317318f, -0.16073070f, 
    0.04124632f, 0.07642522f, -0.04472391f, -0.12406354f, 0.15462992f, 0.07250293f, 0.06889645f, 0.12490698f, 
    -0.00744985f, 0.09056450f, 0.13441153f, -0.00326881f, 0.08147393f, 0.09949713f, 0.03541300f, 0.02391305f, 
    0.05103014f, -0.04197811f, -0.03081990f, -0.10624173f, 0.11411319f, -0.14513095f, -0.00025174f, -0.00720435f, 
    0.01075188f, 0.01743662f, -0.02826512f, -0.04842379f, -0.07121642f, -0.05685608f, 0.00848791f, -0.15347660f, 
    -0.19777589f, -0.00434505f, 0.17677239f, -0.10498124f, -0.01319341f, 0.11376016f, 0.04355731f, -0.00904786f, 
    0.01250108f, 0.12854758f, -0.11003005f, 0.06685174f, 0.03657017f, -0.21396942f, 0.10125722f, 0.05717833f, 
    -0.05589631f, -0.02653021f, 0.04089129f, 0.12679487f, -0.08580194f, 0.08402015f, 0.07719869f, -0.00827739f, 
    -0.20187193f, -0.05250252f, -0.21774329f, -0.28346479f, 0.03628628f, -0.01533036f, 0.04349831f, 0.01441146f, 
    0.00796085f, 0.06621794f, 0.04770894f, -0.09216296f, -0.04342206f, 0.07215501f, 0.06586307f, -0.20489933f, 
    -0.01364043f, 0.10787093f, -0.02907890f, -0.01258602f, 0.00090088f, 0.03077636f, 0.05813457f, 0.01322666f, 
    -0.09189645f, -0.07701346f, -0.03592855f, 0.21220422f, 0.00798488f, -0.05678743f, 0.03503285f, 0.03150770f, 
    -0.00490284f, -0.04904842f, -0.01894712f, 0.01264229f, 0.11237531f, -0.02384401f, 0.01955149f, -0.08933674f, 
    0.02534762f, 0.14111769f, -0.03680507f, 0.05316623f, -0.00707926f, -0.13247466f, 0.05047951f, 0.04782837f, 
    0.06859227f, -0.00458074f, 0.04942476f, 0.14386114f, 0.01819520f, -0.11579826f, 0.02722198f, 0.08366886f, 
    -0.00726740f, -0.08775483f, 0.02676111f, 0.07411016f, 0.04410439f, 0.10259031f, -0.04733239f, -0.08077341f, 
    0.01321654f, -0.05940876f, 0.10099478f, -0.04457499f, 0.10484491f, -0.02084482f, 0.00487578f, 0.23351192f, 
    -0.02433391f, 0.00892194f, 0.00217726f, -0.00969422f, -0.00954644f, 0.02507123f, 0.00478388f, -0.01791832f, 
    0.01300274f, -0.03822163f, -0.02249810f, -0.03711166f, 0.02754998f, -0.01310702f, 0.02197744f, -0.00063207f, 
    0.01828482f, 0.00716665f, -0.03108609f, 0.01235741f, -0.01606568f, 0.02853924f, -0.03554181f, 0.00415112f, 
    -0.00191944f, -0.03900040f, -0.02949847f, -0.02143405f, -0.02646430f, -0.00288515f, 0.01348871f, 0.01138113f, 
    -0.01085322f, -0.03197953f, 0.03101785f, -0.01466160f, -0.03618632f, -0.03270373f, -0.03887428f, 0.03273939f, 
    -0.01707987f, -0.00087195f, -0.01419735f, 0.01507895f, 0.02041969f, 0.01015339f, 0.01537461f, -0.02062124f, 
    -0.02203377f, 0.02331493f, 0.00228715f, -0.03199567f, 0.00602905f, 0.02785127f, 0.00695614f, -0.03356341f, 
    -0.01303935f, -0.00305580f, 0.01588086f, 0.02687929f, -0.00862562f, -0.03771754f, 0.01253709f, 0.01533550f, 
    0.02508938f, -0.03366384f, -0.02705711f, -0.03600201f, -0.04308084f, -0.01389535f, 0.01752961f, 0.03084173f, 
    0.02511663f, -0.03072684f, 0.00507225f, -0.02850562f, -0.01794893f, 0.00332235f, 0.03155519f, 0.02812441f, 
    0.01019134f, 0.01581003f, 0.01849959f, -0.02381962f, -0.02364516f, 0.01123735f, -0.01609509f, 0.01331310f, 
    -0.04078599f, -0.02245572f, -0.02105412f, 0.00024017f, -0.00908054f, -0.00370924f, 0.02003777f, 0.02309685f, 
    -0.02329164f, -0.02156255f, 0.01048562f, -0.00150343f, 0.00152772f, -0.00071098f, 0.01884802f, -0.03810075f, 
    -0.02813812f, -0.03299279f, -0.03431560f, 0.01542096f, 0.02271583f, -0.01601418f, -0.03965754f, 0.01317286f, 
    -0.03262534f, -0.03517538f, 0.00599067f, -0.02466582f, -0.03645488f, 0.01134159f, -0.02761828f, -0.03059393f, 
    0.00220229f, -0.03588785f, 0.01220114f, -0.01519303f, 0.02439144f, 0.00270366f, -0.02305591f, -0.02487838f, 
    -0.00825927f, 0.01100887f, 0.01004835f, 0.02364339f, -0.00633498f, 0.02183228f, -0.00052159f, -0.03863764f, 
    -0.04037683f, -0.04071239f, -0.02562711f, 0.01978641f, -0.01962413f, 0.02029469f, 0.00789185f, 0.02024940f, 
    -0.01741525f, 0.00094836f, 0.02668678f, -0.00950359f, -0.03083011f, 0.02162502f, -0.02843844f, 0.01513877f, 
    -0.00062621f, 0.00884493f, -0.02127894f, 0.02392797f, 0.02997054f, -0.00363091f, 0.00231292f, 0.04119331f, 
    -0.01486904f, 0.03891966f, 0.00358171f, 0.01586963f, 0.02002852f, -0.03281556f, -0.00903128f, -0.03296300f, 
    -0.03773938f, -0.02471117f, -0.03671508f, -0.03791795f, -0.01534903f, -0.03093467f, 0.01186282f, 0.00145712f, 
    -0.00169580f, -0.00855152f, 0.03036966f, 0.02336260f, -0.00009582f, -0.00261999f, -0.02528289f, -0.00806698f, 
    -0.01925622f, 0.02452841f, -0.02942428f, 0.01016645f, -0.01993208f, 0.02279042f, -0.00340044f, -0.03711514f, 
    0.03281470f, 0.01410093f, 0.02552237f, 0.01515678f, -0.03655076f, 0.02903069f, -0.00142707f, 0.00509882f, 
    0.01030412f, -0.03718284f, -0.01160523f, -0.00175225f, -0.00575131f, -0.00477912f, -0.00681289f, 0.02450013f, 
    -0.03809968f, -0.01307746f, -0.04174205f, -0.03651628f, -0.04325040f, -0.01814273f, 0.02656687f, -0.00332153f, 
    0.00076978f, -0.02885509f, -0.03120037f, -0.02569830f, -0.00399140f, -0.03534845f, -0.03807450f, 0.02221098f, 
    0.02417785f, 0.03224357f, 0.01008555f, -0.01338604f, -0.02001235f, -0.00857274f, -0.02960211f, -0.00659618f, 
    -0.03570279f, 0.01866448f, 0.01754790f, 0.01608655f, -0.03096264f, -0.01288370f, -0.03092149f, 0.02082237f, 
    -0.04126260f, 0.00231687f, 0.00495318f, -0.00190567f, 0.01945606f, -0.01489265f, -0.00674320f, -0.03699017f, 
    -0.01145157f, 0.00747979f, 0.00943564f, -0.02220257f, 0.02352422f, -0.03630688f, -0.03520611f, -0.01701414f, 
    0.00186086f, 0.00567145f, 0.01929573f, 0.00697485f, 0.00678757f, -0.00262919f, 0.00699442f, 0.01604351f, 
    0.01359617f, 0.02221122f, 0.00025486f, -0.01973949f, 0.00022627f, -0.01942026f, -0.00210158f, -0.03710139f, 
    -0.03784556f, 0.01945380f, -0.01649865f, 0.01939365f, 0.00839012f, -0.01309453f, -0.01449689f, 0.00736027f, 
    0.02847899f, -0.01322324f, 0.01712640f, 0.00583552f, -0.01001122f, 0.00792308f, -0.03961118f, -0.01466130f, 
    -0.00029735f, 0.00138269f, -0.04201975f, 0.02441640f, -0.00484112f, -0.04535714f, 0.00609310f, -0.02424571f, 
    0.03844549f, 0.01765193f, -0.00435956f, 0.02152243f, 0.01457292f, 0.00432892f, -0.04193420f, 0.02354384f, 
    -0.02854970f, -0.03669245f, -0.02232966f, -0.01663321f, -0.03811478f, -0.03167266f, 0.00416767f, -0.02435092f, 
    0.02664397f, -0.00732666f, 0.01821830f, 0.02420306f, -0.00915514f, -0.00990663f, -0.00422182f, 0.02161324f, 
    -0.02680343f, -0.03795371f, 0.02374992f, -0.03530302f, 0.00556997f, -0.02174418f, -0.01553420f, -0.01498539f, 
    -0.02484076f, 0.01802040f, 0.00504014f, -0.00798988f, -0.00248293f, -0.03074506f, -0.01908456f, 0.00023897f, 
    0.02338702f, -0.02198529f, -0.01919336f, -0.01323393f, -0.01805849f, 0.00447342f, 0.00757740f, 0.00048216f, 
    -0.01311657f, 0.01328965f, -0.03747691f, -0.03422673f, -0.01080195f, 0.00928008f, -0.00402742f, -0.03828601f, 
    0.02697284f, -0.00067994f, 0.01123308f, 0.01990691f, -0.02853474f, 0.02956942f, 0.02381798f, -0.02405477f, 
    -0.02639560f, 0.00205848f, 0.00304425f, -0.01138750f, 0.02272318f, -0.00123919f, -0.01582983f, 0.02506727f, 
    0.02185833f, -0.02022192f, -0.01256387f, -0.04184052f, 0.02379896f, -0.00469239f, -0.02692461f, -0.00161321f, 
    -0.03201219f, -0.00634424f, -0.00918165f, -0.03587764f, 0.00523940f, -0.03544368f, -0.02444745f, -0.00885508f, 
    0.02260869f, -0.02090916f, 0.01135310f, -0.03510922f, -0.03242142f, -0.04287872f, 0.00846035f, -0.01146795f, 
    -0.01225586f, 0.00261848f, -0.03643394f, -0.01862249f, -0.04399058f, 0.02103551f, -0.01318324f, 0.00307228f, 
    -0.01131884f, -0.02115788f, -0.04159612f, 0.01604139f, -0.01689110f, -0.00410056f, 0.02734972f, -0.02698806f, 
    0.00615216f, -0.01340709f, 0.01026734f, -0.00038516f, 0.02555373f, -0.02821518f, 0.03449888f, 0.02506840f, 
    0.01916411f, 0.01136458f, -0.02863871f, 0.01864548f, -0.04331257f, -0.02703197f, 0.00562478f, 0.01141158f, 
    -0.03127616f, 0.03036246f, 0.01700404f, -0.03683337f, 0.02103284f, 0.02319880f, 0.02854683f, -0.01154528f, 
    -0.01212195f, -0.01134683f, -0.00675849f, 0.00932401f, 0.01137525f, 0.02580368f, -0.02588972f, 0.02437200f, 
    -0.03615588f, -0.02759684f, -0.01740459f, 0.00911171f, -0.03854333f, 0.00069899f, -0.02555278f, 0.00120854f, 
    -0.01029473f, 0.00802909f, -0.02350411f, 0.00715008f, -0.02530075f, -0.01149223f, -0.00757669f, -0.03720773f, 
    -0.02101427f, 0.00471893f, -0.02577103f, 0.00690843f, -0.00413367f, -0.02520793f, -0.02023013f, -0.00247833f, 
    -0.01598125f, -0.00052914f, -0.00968615f, -0.03056820f, -0.00359376f, -0.00257290f, 0.00048641f, -0.02243802f, 
    -0.00358964f, 0.02089286f, 0.01720236f, 0.02638814f, -0.02318860f, -0.04403208f, -0.02193937f, -0.00519747f, 
    -0.00377663f, 0.00645452f, 0.02611601f, 0.01031785f, 0.02215371f, 0.00961945f, -0.02974236f, -0.00028515f, 
    -0.04302096f, -0.03246260f, 0.00511549f, 0.01038863f, 0.02506818f, 0.02736431f, 0.01791052f, -0.03272949f, 
    -0.01869996f, -0.00177648f, 0.00692051f, 0.02648753f, 0.02106192f, 0.00557970f, -0.03107374f, 0.00303132f, 
    -0.03498543f, 0.02157234f, 0.02702882f, -0.02031666f, -0.00090980f, 0.01214462f, -0.01213351f, -0.01355930f, 
    0.02603449f, 0.01216308f, -0.03945316f, 0.02262752f, 0.01670941f, -0.02115458f, 0.02103720f, 0.00726018f, 
    0.00122725f, -0.04133459f, -0.01113457f, -0.02243724f, 0.02097096f, 0.01178166f, 0.01099456f, -0.02201175f, 
    0.00331327f, -0.01052727f, 0.02675926f, 0.03872149f, -0.01688087f, -0.00635044f, -0.04020824f, 0.01917665f, 
    -0.01147352f, -0.04167356f, -0.00264279f, -0.02027969f, 0.01009522f, -0.03455880f, -0.02836917f, 0.03901727f, 
    -0.02582039f, -0.00646631f, -0.03649190f, 0.00335998f, -0.02742907f, -0.01139583f, 0.02548901f, 0.01786304f, 
    0.03740117f, 0.01100790f, -0.00897691f, -0.01159116f, -0.00928367f, -0.02475850f, 0.02179332f, -0.00445076f, 
    -0.01654638f, -0.02219916f, -0.01454887f, -0.01510774f, 0.02830976f, -0.02307325f, 0.02056998f, -0.01519575f, 
    -0.02739069f, -0.01610911f, 0.00855956f, -0.02429835f, -0.03365891f, -0.03174038f, -0.03273356f, -0.01380197f, 
    0.00129751f, 0.02449728f, 0.00047664f, -0.00845972f, -0.00843852f, -0.03952606f, -0.02344356f, 0.03503651f, 
    0.00282502f, -0.00996019f, 0.01801806f, 0.00512387f, -0.01392618f, -0.00209867f, 0.00703009f, -0.02684557f, 
    -0.02316951f, 0.00531399f, 0.00471746f, 0.01005852f, -0.03530608f, 0.00353466f, 0.02530561f, -0.02253713f, 
    0.01268498f, -0.03637046f, 0.02178770f, 0.02470019f, -0.03303641f, 0.00448303f, 0.00923294f, 0.00414172f, 
    0.01909194f, -0.01191861f, 0.01798875f, -0.01397889f, 0.01076862f, 0.02352858f, -0.01860405f, 0.01169377f, 
    -0.02431788f, 0.02648492f, 0.00036689f, 0.01981341f, 0.02150963f, -0.03908725f, 0.01803250f, -0.03448154f, 
    0.00330260f, 0.01804218f, -0.01146502f, 0.00621777f, 0.00603845f, -0.01326629f, 0.02873940f, -0.03812249f, 
    0.00054973f, 0.01225805f, 0.00968209f, -0.01804887f, -0.03784526f, -0.03240450f, 0.01879483f, -0.03397708f, 
    0.01936021f, -0.01827565f, -0.02397468f, -0.02487201f, -0.00361885f, 0.00444604f, 0.01186784f, 0.02145124f, 
    0.02625960f, 0.03712019f, -0.00883980f, -0.02030801f, -0.01116741f, -0.04561082f, 0.01378150f, -0.04437776f, 
    -0.00452158f, -0.03579276f, -0.02481708f, -0.03840295f, -0.01761519f, 0.00601262f, -0.04550228f, 0.02582851f, 
    -0.03720881f, 0.01477924f, -0.04046952f, 0.01711143f, -0.03325274f, -0.04085675f, 0.02520718f, -0.02268657f, 
    0.02235095f, 0.00396969f, -0.02904730f, -0.02249179f, 0.00264436f, 0.03028957f, 0.01841131f, 0.02532504f, 
    -0.03839813f, 0.02789593f, -0.02284755f, 0.00142642f, 0.02705882f, -0.04609704f, -0.02198496f, 0.00987742f, 
    0.00774102f, -0.03081647f, -0.03805551f, -0.03153796f, -0.00570601f, 0.00396943f, -0.03145501f, -0.03584692f, 
    0.03484530f, -0.01859889f, -0.02801598f, -0.01943483f, -0.00950444f, -0.02311232f, -0.01553343f, 0.01932518f, 
    -0.00115814f, 0.01760240f, -0.03752800f, 0.02383922f, -0.04268710f, 0.00729867f, -0.01324464f, 0.00954959f, 
    0.01769196f, 0.02243915f, 0.00166611f, 0.01152506f, -0.03291692f, 0.01655555f, -0.00340812f, -0.00024687f, 
    -0.00038402f, 0.01333603f, -0.01781002f, 0.02287537f, 0.02621721f, 0.00240016f, -0.00079110f, 0.02390530f, 
    0.01017978f, -0.02692572f, -0.00110009f, -0.02090077f, -0.02051601f, 0.00972666f, 0.02443341f, 0.00915972f, 
    -0.04078727f, -0.01363456f, -0.01888690f, 0.00776460f, -0.02788908f, 0.01978096f, 0.02224275f, -0.01087177f, 
    -0.04301099f, 0.02361895f, -0.01985347f, 0.02092748f, -0.02791517f, -0.03203467f, 0.01736339f, 0.00341639f, 
    -0.02438094f, 0.01057702f, 0.03058399f, -0.02003410f, 0.00124920f, -0.02812493f, -0.00837630f, -0.03210237f, 
    0.00629034f, -0.00968336f, -0.01602914f, -0.01900065f, 0.01677161f, -0.03053870f, 0.01015981f, -0.01128351f, 
    -0.02144357f, -0.08854995f, -0.01133274f, 0.11618675f, 0.10007224f, -0.04127537f, -0.03403603f, -0.04234144f, 
    0.02632973f, 0.02966412f, -0.02464904f, -0.02217049f, 0.24521625f, 0.17552347f, 0.09853137f, 0.12155356f, 
    -0.03065975f, 0.02596893f, 0.04180561f, 0.02284702f, -0.04553297f, 0.09551074f, -0.01480937f, 0.07037716f, 
    -0.04548827f, 0.13094057f, -0.03974979f, -0.21593744f, 0.10172548f, -0.06251001f, 0.04705702f, 0.08789628f, 
    -0.00544483f, 0.09733531f, 0.06025396f, -0.09118276f, 0.11263277f, 0.16827931f, 0.19372272f, 0.04440768f, 
    0.01336076f, 0.04063379f, 0.00356887f, 0.03462877f, 0.01461834f, 0.08110072f, 0.03708753f, 0.00578809f, 
    -0.17402102f, 0.01816251f, 0.05903086f, -0.15099528f, 0.11621589f, 0.04634513f, 0.01526702f, -0.06556934f, 
    -0.02204499f, 0.06043373f, 0.01211479f, -0.07691856f, 0.13123342f, -0.09755677f, -0.14478830f, 0.00748088f, 
    -0.02345035f, -0.01232858f, -0.05090381f, 0.01603693f, -0.00532798f, 0.04819300f, 0.01363684f, 0.02543126f, 
    -0.09386073f, 0.07155704f, 0.31842214f, 0.07399494f, 0.03455148f, -0.05550672f, 0.06861500f, 0.07104603f, 
    0.17909808f, -0.01193682f, 0.00137375f, -0.01772900f, 0.01687190f, 0.09322896f, 0.15815112f, 0.26990524f, 
    0.00111132f, -0.01936915f, -0.06937392f, 0.05913591f, -0.03787823f, 0.04518134f, -0.01010789f, -0.06476116f, 
    0.11790638f, 0.01585987f, -0.03321347f, 0.01916101f, -0.07047885f, -0.05144719f, 0.10143147f, -0.01325699f, 
    0.08805978f, -0.04869765f, -0.02202582f, -0.01892772f, 0.17628723f, -0.11288959f, -0.24169014f, 0.03069753f, 
    -0.03935435f, 0.00155932f, 0.08828424f, -0.03989612f, 0.07655587f, -0.01730442f, -0.07660796f, 0.05003879f, 
    -0.18053734f, 0.03708357f, 0.05844736f, -0.02465350f, 0.09794336f, 0.09881008f, -0.02920540f, 0.00238533f, 
    0.05711688f, -0.08090488f, -0.01569281f, 0.00001282f, 0.17690916f, -0.05063926f, 0.02672858f, -0.13071603f, 
    0.10083257f, 0.01239917f, 0.00050009f, -0.04347949f, 0.00486077f, 0.06314321f, -0.03006128f, 0.12082981f, 
    -0.16638841f, -0.02498391f, 0.00105372f, 0.20278394f, -0.00332095f, 0.02153121f, -0.06541228f, 0.06244034f, 
    0.07288300f, 0.01827913f, 0.04592836f, 0.14341511f, -0.12132108f, 0.15028101f, -0.19858785f, 0.15916534f, 
    0.13302420f, 0.02363609f, 0.06554559f, -0.08560780f, 0.03279268f, 0.03951559f, -0.03602301f, -0.04262805f, 
    -0.05415928f, 0.10279392f, -0.05818554f, 0.00293390f, 0.03248993f, 0.02008925f, 0.04959537f, 0.07979441f, 
    -0.00130281f, 0.05951020f, 0.06526652f, -0.02293833f, 0.17849486f, -0.12141535f, -0.11624687f, -0.18616106f, 
    -0.06852745f, -0.08681899f, -0.00327530f, 0.00520573f, 0.01209186f, 0.02173427f, -0.06719330f, -0.09306216f, 
    0.16419926f, -0.10305782f, -0.19966793f, -0.16643104f, 0.05119955f, 0.05340356f, -0.07667658f, -0.02926852f, 
    0.03801732f, 0.03821371f, 0.05046342f, 0.02690411f, 0.22282495f, -0.07022372f, 0.14144695f, 0.22215158f, 
    0.07454117f, -0.07258277f, -0.00096508f, 0.04953990f, 0.01735737f, -0.04507725f, 0.07982684f, 0.04803041f, 
    0.03768912f, 0.39328149f, 0.05102845f, -0.13310029f, -0.03384490f, -0.04962900f, 0.10699784f, 0.02163146f, 
    -0.02477061f, 0.01582802f, 0.06331777f, -0.04407458f, 0.24754894f, 0.07410303f, 0.15430132f, 0.11567136f, 
    -0.02186096f, -0.01937277f, 0.06609629f, 0.02515880f, 0.00836085f, 0.01205597f, 0.08689747f, -0.07851381f, 
    -0.11978319f, 0.19586767f, -0.08999869f, -0.00115550f, 0.02248396f, 0.10825192f, 0.03548694f, -0.01904558f, 
    0.02210334f, 0.01613249f, -0.01445481f, 0.03458418f, 0.10338186f, -0.28056014f, 0.04057216f, 0.00434442f, 
    -0.00036940f, -0.11060448f, 0.01190498f, -0.11435292f, 0.06442344f, -0.05488163f, 0.05113599f, -0.03408111f, 
    0.02256994f, 0.12474653f, -0.11163074f, 0.09780087f, 0.06492639f, -0.03432177f, 0.09847435f, -0.05385832f, 
    -0.05547128f, 0.03247907f, 0.00246401f, -0.00249716f, -0.12914714f, 0.07037255f, 0.21031393f, 0.03970279f, 
    0.09356723f, -0.07749396f, 0.03911253f, 0.06288658f, 0.15589505f, 0.06617222f, -0.08594451f, 0.02938189f, 
    -0.03678683f, -0.05506168f, 0.13111100f, -0.05164484f, 0.00328073f, -0.01037759f, 0.04015458f, 0.11495358f, 
    -0.02692011f, 0.05785668f, 0.02801531f, -0.03981997f, -0.05004290f, -0.02732647f, -0.05737604f, -0.15211213f, 
    -0.02036365f, -0.05791053f, -0.03690208f, -0.03666209f, -0.01271766f, 0.04645398f, 0.07956775f, 0.01963226f, 
    0.05149638f, 0.03736244f, 0.22979721f, 0.10228056f, 0.06408257f, -0.01712285f, 0.03617094f, -0.04224411f, 
    -0.00085336f, 0.03218785f, -0.08466507f, -0.01985167f, 0.30757400f, -0.05383264f, -0.10918781f, -0.12346499f, 
    0.08581668f, 0.02109461f, -0.03613772f, -0.05825143f, 0.01441698f, -0.01642143f, 0.02051909f, 0.15717968f, 
    0.13492779f, 0.21789725f, 0.09018365f, 0.12365675f, -0.00335759f, -0.03189820f, -0.11876430f, 0.11304107f, 
    0.03018957f, -0.02689793f, 0.05415570f, 0.12435702f, 0.30713597f, -0.16329283f, -0.24371578f, -0.12809353f, 
    -0.04615467f, 0.02333539f, -0.00289515f, -0.01616192f, 0.05461860f, 0.07223361f, 0.00603438f, -0.09007857f, 
    0.01727455f, 0.08524106f, 0.04875404f, 0.11851718f, 0.00223290f, 0.00130438f, 0.11624947f, 0.12970249f, 
    0.04731509f, -0.04049415f, 0.02646207f, -0.03510104f, 0.11271147f, -0.06142763f, 0.01462393f, 0.10541022f, 
    -0.01676627f, 0.01607403f, 0.04332487f, 0.10147370f, -0.00648434f, -0.08620939f, 0.01518864f, 0.01909060f, 
    0.22710088f, 0.00854918f, 0.12382359f, 0.18162642f, 0.06077150f, 0.01123769f, -0.02471875f, -0.01958195f, 
    0.02309525f, 0.00240354f, 0.00856269f, 0.05186102f, 0.15009710f, -0.07255478f, 0.20732254f, 0.09264506f, 
    0.01392821f, 0.00248007f, -0.03349376f, 0.00015936f, 0.07724278f, 0.02396794f, 0.06304372f, 0.05363846f, 
    0.38206086f, -0.16147412f, -0.09963877f, 0.02789550f, -0.09861653f, -0.04103536f, -0.01461925f, 0.02495353f, 
    -0.02264416f, 0.03875775f, 0.06174299f, -0.00112408f, 0.07904486f, -0.00350139f, -0.07333647f, 0.02443010f, 
    0.02785360f, -0.00324811f, -0.03104614f, -0.08323101f, 0.01312890f, -0.03958128f, 0.01173750f, -0.03528224f, 
    -0.09629961f, 0.03563596f, -0.06960545f, -0.25178903f, 0.06278614f, 0.10422856f, -0.12482998f, 0.14302644f, 
    0.01616646f, 0.01029260f, 0.02711766f, -0.00042705f, -0.15394981f, -0.19452201f, -0.10290276f, -0.19558631f, 
    0.14893627f, 0.04999417f, -0.05860460f, 0.03224747f, 0.03363435f, 0.08093965f, 0.09512075f, -0.07305976f, 
    -0.03545097f, -0.12292472f, -0.17253341f, -0.12996925f, 0.12137815f, -0.02204664f, -0.05632595f, -0.06568468f, 
    -0.01814436f, 0.01736799f, -0.02728702f, 0.06961452f, 0.37629125f, -0.13313836f, 0.03012984f, 0.11971658f, 
    -0.04052103f, 0.01364693f, 0.06174657f, -0.09939276f, 0.05644836f, 0.01426254f, -0.06861928f, 0.07088719f, 
    -0.04971437f, 0.33533961f, -0.03479034f, 0.01670457f, 0.14088131f, 0.00583126f, 0.13119878f, -0.07945180f, 
    0.01856795f, 0.09010885f, -0.01425785f, 0.00370749f, 0.04420956f, 0.15266931f, -0.11709626f, 0.09453656f, 
    0.03614941f, 0.04959318f, 0.01377275f, -0.00704793f, -0.01528076f, -0.01726983f, -0.03620281f, 0.01834871f, 
    0.30102149f, 0.01280407f, -0.09328007f, 0.04874126f, -0.08833902f, -0.01300138f, -0.05612754f, -0.03557299f, 
    -0.04445462f, -0.00032662f, -0.01696200f, 0.04651446f, 0.00452398f, 0.07060333f, 0.13665845f, -0.00498197f, 
    -0.01670066f, -0.02064849f, -0.08876301f, 0.11291039f, -0.03551302f, 0.01027997f, 0.08936507f, -0.03391916f, 
    0.01855191f, 0.11570173f, -0.05754176f, 0.03176864f, 0.23373167f, 0.12681124f, 0.08777502f, 0.02744336f, 
    0.06255274f, -0.01136144f, -0.01908662f, 0.11235330f, 0.27486986f, -0.05012065f, -0.03945038f, -0.05073337f, 
    0.08115780f, 0.00967386f, -0.06664778f, -0.02647543f, 0.03688846f, 0.04431986f, -0.07717356f, 0.05796083f, 
    0.24947469f, 0.07882935f, 0.06925005f, -0.13423273f, 0.08351542f, -0.03298153f, -0.00717273f, -0.06885123f, 
    -0.01151376f, 0.08904155f, 0.08258154f, 0.05332092f, 0.34100208f, 0.02181784f, -0.05393882f, -0.06843253f, 
    -0.03252984f, 0.04941458f, 0.08359557f, 0.08494218f, -0.07276213f, 0.00039005f, 0.02886781f, -0.01073011f, 
    0.00944845f, -0.20511025f, -0.32754353f, -0.00888184f, 0.19106935f, -0.01325674f, -0.02935378f, 0.00124792f, 
    -0.01550698f, 0.01687540f, -0.09563184f, -0.03928873f, 0.01053312f, 0.09722647f, 0.22158220f, 0.00622619f, 
    -0.02725298f, 0.01442996f, -0.02816019f, 0.10752585f, 0.04950747f, 0.00709119f, 0.04634279f, -0.02383119f, 
    -0.14575444f, 0.12326367f, -0.07472880f, -0.28234971f, 0.15442851f, 0.01319128f, 0.00447223f, -0.05392869f, 
    -0.05493955f, -0.05900392f, 0.07301506f, -0.00925561f, -0.04265373f, -0.04584723f, 0.02253407f, 0.16981880f, 
    0.02856854f, 0.05144098f, 0.12163859f, -0.14255308f, 0.15058741f, 0.17631823f, 0.01380549f, 0.17238477f, 
    -0.19170395f, 0.11569166f, -0.14352742f, -0.12118279f, 0.08287328f, 0.03144294f, -0.05149853f, -0.13092616f, 
    0.04749311f, 0.00103716f, -0.07104765f, 0.00564631f, -0.00191542f, -0.15061852f, -0.06824990f, -0.11077470f, 
    0.05151775f, -0.00959188f, 0.03824630f, -0.02192304f, 0.00117215f, -0.00647670f, 0.03740676f, 0.13453232f, 
    -0.20222989f, -0.06827440f, -0.01392187f, -0.22739683f, 0.11784875f, -0.05587731f, 0.04353155f, 0.04002801f, 
    0.03277628f, -0.01382311f, 0.05411417f, 0.06318056f, 0.33707213f, -0.07331041f, -0.23002841f, -0.04476922f, 
    -0.06368377f, 0.03269922f, -0.06278072f, -0.06933734f, 0.08399525f, 0.02230352f, 0.13143939f, 0.08666405f, 
    -0.12238288f, -0.01058608f, 0.10910023f, -0.18134756f, 0.12489928f, 0.03385117f, 0.02664954f, -0.08434186f, 
    0.04091995f, -0.00188375f, -0.00625857f, -0.04863273f, -0.02663982f, -0.06975465f, 0.08772370f, 0.20010237f, 
    0.05983976f, -0.10316855f, -0.03914991f, -0.03578509f, 0.07437947f, 0.08119314f, 0.10962221f, -0.12647034f, 
    -0.22765547f, 0.16145721f, -0.25716293f, -0.00983091f, 0.19931574f, -0.01976580f, -0.04811944f, -0.14564224f, 
    -0.09632907f, 0.02568888f, 0.01450511f, -0.08538197f, -0.00208268f, 0.21312544f, -0.07560305f, -0.13766086f, 
    0.02810961f, -0.06469013f, 0.03332925f, -0.02681308f, 0.00627255f, 0.03540126f, -0.06957188f, 0.02083701f, 
    -0.04737988f, -0.13657324f, -0.01768957f, 0.24456145f, -0.06958871f, 0.03096952f, -0.02507771f, 0.08641703f, 
    -0.02601829f, -0.04118985f, -0.04028832f, 0.06170352f, 0.16063820f, 0.18480293f, -0.07320894f, -0.05584585f, 
    0.10336225f, 0.00622010f, -0.05085921f, -0.00578607f, 0.00258474f, 0.03809594f, 0.09787175f, 0.11640368f, 
    -0.13508832f, 0.20443027f, 0.18409938f, 0.09031863f, 0.02458950f, 0.08069622f, -0.09106865f, 0.19559394f, 
    -0.07825217f, 0.03587919f, 0.05130261f, -0.00487214f, -0.22170457f, 0.02570047f, -0.07137003f, -0.12922715f, 
    0.00601857f, 0.10118969f, -0.09503175f, -0.04895299f, 0.04357594f, 0.04484519f, 0.01173347f, -0.02325289f, 
    -0.02707388f, -0.03782745f, -0.02382359f, -0.01667342f, -0.01476069f, -0.00555972f, -0.02270187f, -0.00111847f, 
    -0.01098254f, -0.02780504f, 0.00071131f, -0.00228735f, -0.03718511f, -0.03467616f, -0.00102185f, 0.01059081f, 
    -0.02870122f, -0.02974261f, 0.00637673f, -0.03971502f, 0.00518017f, -0.00044338f, -0.03627982f, 0.00817599f, 
    -0.03443272f, -0.00861000f, -0.04364223f, -0.04384306f, -0.04062743f, -0.00709808f, -0.02878705f, -0.03592759f, 
    0.02492664f, 0.02697374f, -0.04037069f, -0.01110076f, 0.01862491f, -0.00315536f, -0.02941566f, 0.00877892f, 
    -0.03673033f, -0.00232296f, -0.03613183f, -0.02919899f, 0.00125956f, 0.02371431f, 0.02083841f, 0.00158985f, 
    0.01528835f, -0.01974896f, 0.03686810f, -0.02678165f, 0.01432305f, -0.01271714f, 0.02382867f, -0.03266355f, 
    -0.03214958f, -0.00929342f, 0.01737618f, -0.01971649f, -0.00705210f, 0.01930842f, 0.02592895f, -0.03163170f, 
    -0.04784736f, 0.01134077f, 0.01561638f, -0.02319344f, -0.00915922f, 0.00565494f, -0.02323474f, -0.02765495f, 
    -0.03761059f, -0.03709614f, -0.00694971f, -0.01827152f, 0.00112572f, -0.03413150f, 0.02605215f, -0.03344445f, 
    -0.02016187f, 0.00985548f, -0.00238276f, -0.03525275f, -0.01079944f, -0.03851813f, 0.01200505f, -0.00162366f, 
    -0.00325408f, -0.00525702f, 0.02228002f, 0.00234406f, -0.00550051f, -0.02038445f, -0.03519392f, 0.01598101f, 
    -0.03330598f, -0.03366885f, 0.01250100f, -0.02394243f, 0.02696418f, -0.00476351f, 0.02655867f, 0.00029589f, 
    -0.02025292f, -0.02474503f, 0.03035708f, 0.00077359f, 0.01025679f, -0.03672582f, -0.00880061f, -0.00592558f, 
    0.01527434f, 0.03122808f, -0.02513028f, -0.03057778f, 0.01686554f, -0.00477734f, -0.02006964f, -0.00512780f, 
    -0.01519486f, 0.02326449f, -0.03003546f, -0.00633998f, 0.01557587f, -0.02843863f, -0.02505659f, -0.04082146f, 
    -0.00961307f, 0.01619283f, -0.01964447f, -0.03119088f, -0.02252235f, 0.01193673f, 0.02773730f, -0.03184025f, 
    0.00921874f, 0.02855830f, -0.03281552f, 0.00358335f, 0.02929582f, 0.02476442f, -0.01508268f, -0.00611393f, 
    0.01076482f, 0.03047942f, -0.01053780f, -0.00225624f, 0.00153740f, -0.03943667f, -0.02782958f, 0.00046496f, 
    0.00108186f, -0.03268115f, -0.02852001f, 0.00409053f, -0.02799132f, 0.01265690f, -0.03800239f, 0.01321962f, 
    -0.03409265f, 0.02272971f, 0.01560666f, 0.01674261f, -0.01278679f, -0.02223916f, -0.00686415f, -0.00679582f, 
    0.02263341f, 0.01427972f, -0.00040815f, 0.02303015f, 0.00626136f, -0.03999148f, -0.02534333f, 0.00265880f, 
    0.01554201f, 0.00459441f, 0.00273191f, 0.01512391f, 0.00917958f, -0.01860970f, -0.00026366f, 0.00034271f, 
    0.00348437f, 0.02721880f, -0.01308335f, 0.00834217f, 0.02142760f, -0.03587852f, -0.03858915f, 0.01046512f, 
    -0.03701780f, -0.01178080f, -0.00706104f, -0.04620986f, -0.03514088f, 0.02782180f, -0.01966799f, -0.00747026f, 
    0.02461577f, 0.01618297f, 0.00212248f, 0.02425433f, 0.01691844f, -0.00261976f, -0.02410143f, -0.00887650f, 
    -0.00163255f, -0.00254578f, 0.02234155f, -0.03211256f, 0.00572813f, 0.01860395f, 0.00115420f, -0.02679786f, 
    0.00548088f, 0.01622174f, 0.01512901f, -0.03764743f, 0.01240737f, 0.02463327f, -0.00771794f, 0.01439955f, 
    0.02219454f, -0.00351598f, -0.03864521f, 0.02231273f, 0.02414657f, 0.01536447f, 0.00377772f, -0.01629550f, 
    0.02036682f, -0.00100426f, -0.02530438f, -0.03390110f, -0.00228076f, 0.02159963f, -0.03664441f, 0.02262133f, 
    0.00010295f, -0.00896381f, 0.03231107f, -0.03952502f, -0.04474289f, 0.00853498f, -0.01128804f, -0.03573364f, 
    0.01073325f, -0.04417923f, -0.02084975f, -0.02210301f, 0.00265023f, -0.03010854f, -0.01105222f, 0.00956745f, 
    -0.02607375f, -0.02454418f, -0.02377163f, 0.02031174f, -0.00300246f, 0.01496143f, -0.03977721f, -0.00998160f, 
    0.01306795f, 0.01801375f, -0.01616492f, 0.02498363f, -0.04004894f, -0.03292885f, -0.01773905f, -0.03960247f, 
    0.01733935f, 0.00980390f, -0.01428154f, -0.00834537f, -0.02307150f, 0.01845984f, -0.01402667f, 0.01699618f, 
    -0.02004245f, 0.01052178f, 0.02820610f, -0.03415282f, -0.03306874f, -0.03410364f, -0.04025409f, -0.03850865f, 
    0.01088606f, 0.00391894f, -0.00863649f, 0.01216757f, 0.02866006f, -0.00653728f, -0.02137361f, -0.02059521f, 
    0.01400218f, 0.03152603f, -0.03172038f, 0.01702353f, 0.00762446f, -0.01148231f, 0.01052015f, 0.01396895f, 
    0.01348896f, 0.02024074f, -0.00152212f, 0.02738343f, -0.02966299f, 0.02495519f, 0.00600370f, -0.01693579f, 
    -0.02970588f, 0.03035273f, -0.00020460f, -0.03144589f, 0.01457415f, -0.03227860f, 0.02790799f, -0.01541728f, 
    -0.00746066f, 0.00826783f, -0.02909701f, -0.01557384f, 0.00133015f, 0.01344546f, 0.00626072f, 0.01169874f, 
    -0.00314578f, -0.03286998f, 0.01506691f, -0.00419057f, 0.00466670f, -0.01842779f, 0.01497131f, 0.02626677f, 
    0.00297137f, -0.03706258f, 0.00174881f, -0.03964626f, 0.00962626f, 0.01364107f, -0.01356193f, 0.02221395f, 
    -0.00349321f, -0.02679174f, -0.00522046f, 0.00761692f, -0.02198070f, 0.01945793f, -0.02734205f, -0.02038120f, 
    0.01497405f, -0.03167670f, 0.00175905f, -0.03716696f, -0.00834951f, -0.04291417f, -0.03137952f, 0.01481419f, 
    -0.01325868f, 0.00793242f, -0.01947624f, -0.02663611f, 0.02086341f, -0.03629110f, 0.01365494f, -0.02651836f, 
    -0.02860144f, 0.00669175f, 0.01622811f, -0.00545926f, -0.00273296f, -0.03360221f, 0.00763819f, -0.03230471f, 
    0.02440310f, -0.02561534f, 0.00393386f, 0.02308601f, -0.01091530f, -0.00732132f, 0.00552827f, -0.04558035f, 
    0.02166856f, 0.01673516f, 0.00941145f, -0.03207848f, -0.00222676f, 0.01861727f, 0.01563167f, 0.01261976f, 
    -0.02880104f, -0.01645458f, 0.02041135f, 0.00174663f, -0.02114701f, 0.01869511f, 0.00975329f, -0.00590389f, 
    -0.03048469f, -0.02003404f, 0.01615213f, 0.00393655f, 0.01568993f, -0.03127979f, -0.02455368f, 0.01008009f, 
    0.00711104f, -0.00957554f, 0.01121259f, 0.01716687f, -0.02933283f, -0.00531974f, 0.01435763f, 0.03514307f, 
    0.00556864f, -0.01134096f, -0.00704393f, 0.00101355f, 0.01789604f, -0.00256193f, -0.01706778f, -0.01051577f, 
    0.02378236f, 0.00807844f, 0.02664009f, 0.00733815f, 0.00145841f, -0.00359087f, -0.03006430f, 0.01773460f, 
    -0.00816281f, -0.00166430f, -0.00471499f, -0.00229983f, -0.04115926f, 0.00492809f, -0.00867145f, 0.00651285f, 
    0.03208244f, -0.03256809f, -0.00286494f, 0.00961070f, 0.01997730f, -0.02859424f, -0.03677046f, 0.00301244f, 
    0.00942150f, -0.03170497f, -0.03261114f, -0.03297239f, -0.00650178f, -0.01287607f, -0.00505549f, 0.02784756f, 
    -0.04002959f, 0.02015100f, -0.00258534f, -0.01425742f, -0.02398575f, -0.03519267f, 0.02083866f, -0.02190812f, 
    0.01082906f, -0.00659266f, -0.00072093f, -0.03794283f, -0.02572272f, -0.02050979f, -0.04383720f, -0.01312607f, 
    -0.01849605f, -0.03260183f, -0.00561246f, -0.01691386f, -0.02600296f, 0.02409350f, -0.00114644f, 0.03010040f, 
    -0.01282639f, 0.01650790f, 0.02234672f, -0.00907774f, -0.03835438f, -0.01020395f, -0.02175665f, 0.00404381f, 
    -0.02580049f, 0.01590242f, -0.03928109f, 0.01501583f, 0.00420018f, -0.03348698f, -0.02000081f, 0.03638054f, 
    0.00782702f, -0.01635538f, 0.00832502f, 0.02620232f, 0.00573761f, 0.00808020f, 0.01810689f, 0.01441773f, 
    0.01229893f, -0.00335823f, -0.01143195f, -0.02212978f, 0.00329920f, 0.00941244f, 0.02707148f, -0.00311538f, 
    0.00757061f, -0.01510760f, 0.01666668f, 0.01168330f, -0.03602358f, -0.01006146f, -0.00759058f, 0.01768049f, 
    0.01154200f, 0.00022163f, -0.02363226f, -0.00797056f, 0.01486471f, -0.01197958f, -0.00787278f, -0.04346730f, 
    -0.01015581f, 0.01606840f, 0.02303855f, -0.03752927f, -0.00213956f, -0.00718218f, -0.00670462f, -0.02823054f, 
    -0.01058836f, -0.01268485f, -0.01851640f, 0.02216292f, 0.00937394f, 0.02684197f, -0.01563236f, 0.01487926f, 
    -0.01842616f, 0.01021985f, 0.00095004f, -0.00814517f, 0.01753477f, -0.03638366f, -0.02095990f, -0.02765727f, 
    -0.02463155f, -0.03949453f, 0.00451459f, 0.00061541f, 0.02704374f, -0.02044508f, 0.00865081f, -0.01603846f, 
    0.03301295f, -0.01228097f, 0.00259708f, -0.02683145f, 0.02056290f, 0.00008715f, 0.00520824f, -0.00548074f, 
    0.01522154f, 0.02072076f, 0.00806075f, -0.00815963f, 0.01922082f, -0.04344282f, -0.03904921f, -0.00844279f, 
    0.01827411f, -0.03137761f, 0.01773720f, 0.00723392f, -0.02312266f, -0.02568929f, -0.00087156f, -0.00721444f, 
    -0.00142201f, -0.02088047f, -0.02032937f, 0.01295332f, -0.01745757f, 0.00812296f, -0.00700808f, 0.02428450f, 
    0.02654737f, -0.00279457f, -0.00781613f, 0.02308567f, -0.03608692f, -0.03446416f, 0.00083138f, -0.00668053f, 
    -0.01886967f, 0.02861070f, -0.00308007f, -0.04835496f, -0.03953520f, 0.02407624f, -0.01092081f, 0.03086045f, 
    -0.01629923f, 0.02274933f, -0.04157135f, 0.00379734f, -0.04402066f, -0.03070055f, -0.02687906f, 0.00128867f, 
    0.02337311f, 0.00684687f, -0.02176302f, -0.00581264f, 0.00464695f, -0.00976105f, -0.00644763f, -0.03587962f, 
    0.02118975f, -0.01822935f, -0.02747458f, -0.02446106f, -0.02160259f, 0.03353892f, -0.01823487f, -0.02658861f, 
    0.02308903f, 0.02547125f, 0.02436213f, -0.00818840f, -0.01323664f, 0.02373386f, 0.01699908f, -0.02573824f, 
    -0.02424034f, 0.02456261f, 0.02166774f, 0.02873540f, -0.00013717f, -0.02741456f, 0.02703394f, 0.01922275f, 
    -0.04052622f, -0.00981615f, -0.01254679f, -0.01093959f, 0.01679345f, -0.00887367f, 0.01850830f, 0.00493531f, 
    -0.00416906f, -0.00656578f, 0.01552092f, -0.01651078f, 0.00479473f, -0.01510334f, -0.00557644f, 0.01349889f, 
    0.00384689f, -0.00892501f, -0.04513704f, -0.02902142f, 0.01328679f, 0.02279192f, 0.01772882f, -0.00900459f, 
    0.02454541f, 0.01611427f, 0.02230049f, -0.00621217f, 0.00664476f, 0.01842119f, 0.00329253f, 0.01541691f, 
    -0.00917339f, -0.02440789f, -0.01814268f, 0.00362887f, -0.01410505f, -0.04519920f, -0.03138825f, 0.02461043f, 
    -0.02109687f, 0.04244019f, -0.00212419f, -0.02156993f, -0.00099341f, 0.01395688f, -0.00715421f, -0.03332075f, 
    -0.01303347f, 0.02335609f, -0.04025780f, 0.02251840f, -0.03203256f, -0.00619396f, -0.00878159f, -0.03283166f, 
    -0.02962797f, -0.01044647f, -0.00863462f, 0.01879808f, -0.03777033f, 0.02052544f, 0.00016073f, -0.00162394f, 
    -0.00981893f, 0.00758554f, 0.01982534f, -0.00515591f, -0.02748587f, -0.03385033f, 0.00960575f, -0.00514360f, 
    0.00424337f, -0.00069147f, -0.03369839f, -0.01964520f, 0.00022200f, -0.04382497f, -0.00929596f, 0.01286200f, 
    0.00119749f, 0.00798178f, 0.00121302f, 0.00245514f, -0.01920437f, -0.00993304f, 0.03405556f, 0.02435186f, 
    -0.00118318f, -0.00425677f, 0.00381343f, -0.03914168f, -0.00832556f, 0.00664107f, -0.00361391f, -0.00447397f, 
    -0.01712556f, -0.02305813f, 0.00422556f, 0.00976668f, -0.01696526f, -0.01790550f, 0.00285186f, 0.00274895f, 
    -0.00240646f, 0.00541340f, 0.01571001f, -0.02061900f, -0.01350965f, -0.03671795f, 0.03178031f, -0.00151752f, 
    0.02927176f, 0.00278308f, -0.02670022f, 0.02967093f, 0.00825917f, -0.04091731f, 0.02739246f, -0.04160359f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.01332752f, -0.00651326f, -0.03696407f, -0.01742659f, 0.06179133f, 0.00272713f, 0.05269485f, -0.02254188f, 
    0.02318059f, 0.04747489f, -0.01372133f, -0.00338646f, -0.03402314f, 0.04017490f, -0.01487180f, -0.00939358f, 
    0.03382562f, -0.03945211f, 0.00310354f, 0.00822067f, 0.02700724f, -0.01454189f, -0.01779776f, -0.01635024f, 
    -0.00817524f, -0.00177182f, 0.06686098f, -0.00335450f, 0.03403226f, -0.04453867f, -0.00648504f, 0.00125932f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.08548539f, -0.05027680f, -0.16532975f, 0.22196943f, -0.42424697f, 0.19834739f, 0.03468560f, 0.13535514f, 
    0.01477681f, 0.25994897f, 0.11803434f, -0.12653977f, 0.08983081f, -0.46727464f, 0.03297486f, 0.18291192f, 
    -0.26823768f, 0.14692014f, -0.12764089f, 0.03687682f, 0.31156936f, 0.22682793f, -0.49394375f, 0.17318964f, 
    0.14643417f, -0.03353455f, 0.30750215f, -0.12863158f, -0.18197417f, -0.13918075f, -0.43183380f, -0.06311614f, 
    0.15752648f, -0.10002353f, 0.07790497f, 0.32287779f, -0.29218510f, -0.35690337f, 0.06242662f, -0.37952623f, 
    0.10935137f, 0.23733382f, 0.12767951f, -0.01472559f, 0.10285487f, 0.25658172f, 0.07167796f, 0.07520595f, 
    -0.03828200f, 0.00474541f, 0.09248190f, -0.19894075f, -0.15714417f, 0.21309274f, 0.37537688f, 0.13378647f, 
    0.10693315f, -0.41484019f, 0.14833561f, -0.11522680f, -0.44493014f, -0.10104931f, -0.04680551f, 0.00713436f, 
    0.17055230f, -0.01378697f, -0.00508580f, 0.42973486f, 0.05095000f, 0.17608263f, -0.38205391f, -0.00628981f, 
    0.10056730f, -0.21203852f, -0.17291246f, 0.05807547f, 0.09979414f, -0.11527046f, -0.14585502f, 0.01417482f, 
    -0.33170971f, 0.05434418f, -0.05153772f, 0.06873555f, 0.02663323f, 0.24280639f, 0.30950919f, 0.03123868f, 
    0.00626191f, -0.32102117f, -0.35517088f, 0.05283630f, 0.24704313f, 0.05136910f, 0.28641981f, -0.14449780f, 
    0.02929718f, 0.10187236f, -0.10726634f, -0.31543756f, -0.20968337f, 0.10860930f, 0.13349360f, -0.49058467f, 
    0.30893999f, -0.13537055f, 0.14645280f, -0.12823452f, -0.04562656f, 0.30078512f, 0.06851379f, 0.07595707f, 
    -0.09178195f, -0.14168169f, -0.03221436f, 0.23000365f, 0.12532136f, -0.58105278f, 0.01017772f, 0.14124095f, 
    -0.15439330f, 0.35700753f, -0.14779434f, -0.07343329f, -0.17437121f, -0.16860238f, -0.33065096f, -0.08664796f, 
    -0.11629593f, -0.07255632f, -0.01779621f, -0.42072484f, 0.23533994f, 0.22806464f, -0.14060144f, -0.04708660f, 
    0.35988548f, -0.01275441f, 0.38092643f, 0.06382075f, -0.03634887f, -0.08779819f, -0.08890707f, -0.26223037f, 
    -0.00616913f, 0.03362361f, 0.04894992f, -0.42426285f, 0.17711319f, -0.19752195f, 0.12334060f, -0.01812708f, 
    -0.09560551f, -0.25694990f, 0.07111444f, 0.04656126f, 0.09358648f, 0.13594379f, -0.26449093f, 0.14481173f, 
    -0.15336913f, -0.13367453f, 0.07804567f, 0.12598456f, 0.22451720f, -0.43313763f, -0.25986686f, 0.25289220f, 
    -0.60717195f, 0.05533895f, 0.20913774f, 0.04966279f, 0.06124435f, 0.36914188f, -0.03562114f, -0.11073758f, 
    0.14867924f, -0.08156761f, -0.15526359f, -0.01208590f, 0.17349243f, -0.02739026f, -0.33937997f, 0.13976736f, 
    0.02556532f, -0.05883177f, -0.09256436f, 0.00597587f, -0.37244377f, 0.06135346f, -0.38219085f, 0.12913881f, 
    0.07827972f, -0.10623079f, 0.15846477f, 0.12950335f, 0.04333395f, 0.16007704f, 0.29820842f, -0.13748096f, 
    -0.04552132f, -0.02802826f, -0.00192375f, 0.13092020f, 0.00663418f, -0.40759915f, 0.04346645f, -0.09793805f, 
    0.28359342f, -0.07097211f, 0.14059073f, 0.35445791f, -0.82965881f, 0.16986513f, -0.02393286f, 0.06626794f, 
    -0.04130067f, -0.23368073f, -0.28439277f, 0.14206894f, 0.02238454f, 0.01131829f, -0.12688343f, -0.10892653f, 
    0.09575678f, 0.01165508f, -0.05457282f, -0.17261697f, -0.08860732f, 0.11935502f, -0.20391305f, 0.16622622f, 
    0.01315672f, -0.56564164f, -0.05100423f, -0.00171594f, 0.16987984f, 0.00155263f, -0.13691133f, -0.46154031f, 
    0.12508376f, 0.04321702f, 0.18008280f, -0.48125198f, 0.23240454f, -0.10365927f, 0.12985273f, -0.13367935f, 
    0.02026901f, 0.29850113f, 0.14388207f, -0.14198002f, -0.16560046f, -0.13717537f, 0.27450806f, 0.02813863f, 
    -0.05847349f, 0.09138309f, 0.00553606f, 0.06206149f, 0.24866937f, -0.16131170f, 0.35565647f, 0.21276340f, 
    -0.35355237f, -0.23538254f, 0.19185849f, 0.02010553f, -0.09366859f, -0.27502552f, 0.06762537f, 0.29742986f, 
    -0.31088793f, -0.08687627f, -0.10684095f, -0.20704409f, 0.21082604f, 0.01609585f, 0.31163546f, -0.08128507f, 
    -0.07041492f, -0.18961924f, -0.43588552f, -0.08342535f, -0.33280510f, 0.06811499f, 0.31025350f, -0.14565301f, 
    0.00456628f, -0.06186706f, -0.16748397f, -0.38119033f, 0.16560081f, 0.00434975f, -0.54926121f, 0.14100355f, 
    0.08103132f, 0.04769855f, 0.02181901f, 0.10566468f, -0.08329861f, -0.19841722f, -0.08757475f, -0.35409105f, 
    -0.04700026f, -0.10661089f, -0.11806517f, -0.11210554f, -0.24806483f, 0.41658285f, -0.63376325f, -0.16477656f, 
    -0.04409292f, -0.01352146f, -0.41232577f, 0.14766738f, 0.10100732f, -0.06512531f, 0.54570383f, 0.00749571f, 
    -0.13681515f, -0.02047373f, 0.14786048f, 0.10017075f, 0.29007915f, -0.30592632f, 0.17788127f, -0.53461295f, 
    -0.28842318f, 0.18658312f, -0.21096192f, -0.05219444f, 0.06516217f, -0.06974272f, 0.01796467f, -0.27195349f, 
    -0.23936521f, 0.06562449f, 0.08622681f, 0.27861235f, 0.14771627f, -0.53242189f, 0.04154027f, -0.15573753f, 
    0.01166334f, -0.00706341f, 0.38723671f, 0.10033555f, 0.16502054f, -0.05028533f, 0.29935789f, 0.05892824f, 
    0.15179300f, 0.13916358f, -0.12274315f, -0.45367023f, -0.15461153f, 0.30209377f, 0.14426573f, 0.28422362f, 
    -0.24522738f, -0.01305791f, -0.33704531f, -0.14114639f, 0.10045309f, 0.28615367f, -0.16724946f, 0.47326472f, 
    0.21615370f, 0.05512908f, 0.03606316f, 0.06903415f, 0.11321287f, -0.27220431f, -0.31567922f, 0.01023454f, 
    0.05225834f, -0.29941714f, -0.11639774f, 0.15006055f, 0.05691517f, 0.00413289f, 0.01812885f, 0.08511458f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.19407079f, -0.04875408f, -0.01596995f, -0.01558798f, 0.17337297f, -0.02595033f, 0.02281236f, -0.06046660f, 
    -0.08317426f, 0.22041512f, 0.18295272f, 0.00853003f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
