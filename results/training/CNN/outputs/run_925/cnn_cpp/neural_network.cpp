#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.86298472f, 1.09160805f, -0.02564965f, -0.37982017f, 0.60000163f, -0.92563391f, 0.23579849f, -0.25620562f, 
    -0.90171182f, -0.17532866f, 0.16035485f, 0.14350250f, 0.28074145f, -0.09081733f, 0.20497163f, -0.09299713f, 
    -0.05726229f, -0.22185990f, -0.09380566f, -0.36756608f, 0.21482231f, -0.02134496f, 0.35385385f, 0.09611698f, 
    0.17037006f, -0.74976796f, -0.46982729f, -0.31188905f, -0.44789970f, 0.00695244f, -0.17633203f, -0.47651336f, 
    0.08116824f, 0.22424622f, -0.39035162f, -0.33349383f, 0.13969001f, -0.14237767f, 0.28863105f, -0.48300722f, 
    -0.54079044f, 0.06869524f, 0.17101824f, -0.42069519f, -0.25024638f, 0.21614395f, -0.04445757f, 0.34215635f, 
    -0.06404807f, -0.06293407f, 0.54489475f, -0.43540567f, -0.62038052f, -0.21250850f, -0.55975026f, 0.45448214f, 
    0.86525351f, 0.47800305f, 0.44952855f, 0.63715613f, 0.11264851f, -0.06672333f, -0.64639521f, 0.00618312f, 
    0.28514996f, 0.04076046f, 0.00690045f, -0.28918359f, 0.22715920f, 0.41197535f, -0.16237733f, 0.13244189f, 
    -0.24967988f, 0.07547312f, -0.36442691f, 0.56952614f, -0.46409529f, -0.30753303f, -0.04016047f, -0.32197812f, 
    -0.66434950f, 0.97494698f, -0.37516186f, -0.09093183f, -0.05888825f, 0.17982733f, 0.26361302f, -0.01708165f, 
    0.39952052f, 0.15629935f, -0.24912621f, -0.12410680f, 0.19326985f, -0.22740138f, -0.28532666f, 0.21750882f, 
    -0.04856029f, 0.09931989f, -0.04166472f, -0.03995485f, 0.59585035f, 0.90701729f, 0.36982140f, -0.65762603f, 
    -0.49731642f, -0.59640378f, 0.57167667f, -0.24865441f, -0.39060101f, -0.08564710f, 0.21945937f, 0.09626397f, 
    -0.37640405f, -0.18382776f, 0.41038778f, 0.27566066f, -0.15960912f, -0.17256182f, 0.12247089f, -0.18500693f, 
    0.15813106f, 0.11649556f, -0.12585320f, 0.14993705f, 0.30106500f, -0.69177699f, -0.91882014f, 0.09605672f, 
    0.69159853f, 0.28897986f, 0.07044915f, -0.33647025f, 0.70564497f, 0.07439459f, 0.10088121f, 0.27309123f, 
    -0.42525637f, 0.16334324f, -0.01473287f, 0.22910570f, 0.29943299f, 0.12327537f, -0.10705858f, -0.38089266f, 
    0.40807968f, 0.12854861f, 0.07218680f, 0.22977255f, 0.15082055f, -0.09933406f, 0.68356395f, -0.44743037f, 
    -0.40730166f, -0.60503155f, 0.11312096f, -0.40304139f, 0.22468835f, -0.27359459f, 0.10713286f, -0.31861025f, 
    -0.36146176f, -0.20295709f, -0.45085740f, -0.57620966f, -0.25755465f, -0.21170263f, -0.11134171f, -0.49176818f, 
    -0.39607471f, -0.36947837f, -0.10696919f, -0.16811341f, -0.05384023f, -0.38890556f, -0.38177890f, -0.23125787f, 
    -0.24157128f, 0.03233606f, -0.33384919f, -0.28777614f, -0.38610172f, -0.88252485f, -0.64308685f, -0.57536668f, 
    -0.32087445f, 0.39103949f, -0.01914620f, 0.16189620f, -0.18470652f, -0.10428766f, -0.17084223f, -0.16844216f, 
    -0.33532014f, 0.27831209f, 0.57364416f, 0.26258749f, 0.41412219f, -0.01981864f, 0.34303701f, -0.08656445f, 
    -0.46359384f, -0.25035042f, 0.22873743f, 0.84891427f, 0.16128238f, -0.09606663f, -0.04858671f, -0.57957250f, 
    0.47897393f, 0.38731492f, -0.44144344f, 0.15315692f, -0.24467503f, 0.55726802f, -0.26094797f, -0.57528156f, 
    -0.21916850f, 0.00319695f, -0.07631613f, -0.28192765f, -0.16535151f, 0.28821799f, -0.19480960f, 0.22475220f, 
    0.15846623f, 0.81311506f, 0.07853957f, -0.66959918f, 0.24977103f, 0.58563197f, 0.93633300f, 0.08642443f, 
    -0.52297354f, 0.20533833f, -0.25725624f, -0.54612160f, 0.33101609f, -0.12363859f, 0.22346567f, 0.01121691f, 
    0.16270065f, -0.23341174f, 0.30171505f, 0.39507923f, 0.27670133f, -0.19622453f, -0.02217776f, -0.30361333f, 
    -0.40999195f, 0.11031040f, -0.85086912f, -0.74324876f, -1.03448427f, -0.48138160f, 0.49560001f, -0.77578312f, 
    0.52694017f, 0.75264758f, 0.03191392f, 0.11099020f, 0.14250891f, -0.19938135f, 0.10448001f, -0.20016842f, 
    0.32603812f, 0.15758105f, 0.19640052f, -0.13992675f, 0.09324183f, -0.08354566f, -0.15783645f, -0.13032182f, 
    0.06000160f, 0.02749282f, 0.01809718f, -0.61064976f, -0.84007460f, -0.85645944f, 0.05380707f, -0.37973642f, 
    0.07511084f, -0.23655967f, -0.09017383f, 0.24584755f, 0.00794878f, 0.36884648f, 0.48069802f, 0.28422114f, 
    0.45520929f, -0.05854087f, 0.14840135f, -0.02842602f, -0.04869543f, 0.24953094f, -0.16973470f, -0.22556369f, 
    0.16462126f, 0.41121435f, -0.38121289f, 0.20202981f, 0.72729760f, -0.59436941f, 0.43658194f, 1.14486730f, 
    0.21143799f, -0.71557319f, -0.19013533f, -0.09643218f, -0.06922328f, -0.05690591f, -0.26847249f, -0.11331388f, 
    -0.35804516f, 0.27377179f, 0.11313971f, 0.26187164f, 0.10745216f, -0.22968924f, -0.06929627f, -0.09139789f, 
    0.22862387f, 0.19097711f, -0.33371019f, -0.10772731f, -0.13752273f, -0.40676963f, -0.80311871f, -0.38975906f, 
    -0.14033462f, -0.53065407f, -0.30746406f, 0.22430368f, 0.76371241f, -0.45378664f, 0.21627142f, -0.03534964f, 
    -0.05545834f, -0.27238879f, -0.40255153f, -0.38326702f, -0.00644857f, -0.00682426f, 0.06156792f, 0.09148312f, 
    -0.42442498f, -0.05130317f, -0.27711305f, 0.20458320f, 0.31336632f, 0.38369346f, -0.71229672f, -0.44221514f, 
    0.70237082f, -0.07053023f, 0.36903158f, 0.19435391f, 0.80125713f, -0.51220566f, -0.20638797f, -0.51226240f, 
    0.40360802f, 0.34959382f, 0.13560511f, 0.21467936f, 0.36228144f, 0.04365719f, -0.35238498f, -0.13250141f, 
    -0.28974685f, 0.53707969f, -0.28190047f, 0.05722031f, 0.15190767f, 0.24407919f, 0.28093550f, 0.91914821f, 
    0.63767970f, 0.13333359f, -1.11614788f, -0.20457400f, 0.52940506f, -0.63377309f, -0.06836748f, -0.49108407f, 
    0.37060291f, 0.08095626f, 0.33771160f, 0.13278218f, 0.40572640f, -0.37644261f, -0.05731947f, 0.09032208f, 
    0.22452357f, -0.07340762f, -0.08159730f, 0.04445403f, 0.33626533f, 0.12779565f, -0.27473736f, 0.31640878f, 
    0.46708930f, 0.57352114f, 0.78808892f, 0.54053730f, 0.22025454f, 0.48017964f, 0.34247175f, -0.01668927f, 
    -0.31622910f, 0.16797708f, 0.25819281f, -0.11022592f, -0.54990613f, -0.44523001f, 0.14018956f, -0.19411474f, 
    -0.27068713f, -0.03561039f, -0.19986755f, -0.26039204f, 0.20936821f, 0.47053951f, 0.53000337f, 0.01358467f, 
    0.25510386f, 0.50586665f, 1.01260173f, -0.05448481f, 0.40813944f, -0.28434220f, 0.72722942f, 0.17816825f, 
    -0.80792904f, -0.61869597f, -0.28183529f, -0.12728585f, 0.22698894f, -0.31025597f, 0.47353300f, -0.19619241f, 
    -0.05265106f, -0.37320057f, -0.17684346f, -0.06623781f, -0.15854381f, -0.15575896f, -0.01574021f, -0.14413978f, 
    -0.28686166f, 0.19999924f, 0.86683577f, -0.14130180f, 0.20751725f, 0.43291962f, 0.67283863f, -0.81641430f, 
    0.17381099f, -0.21999682f, -0.19261919f, 0.51767290f, -0.19800892f, 0.54566401f, -0.04438284f, -0.14640403f, 
    -0.28297329f, -0.34878394f, -0.27732512f, -0.39584997f, -0.26408163f, 0.00121949f, 0.10582744f, 0.13971758f, 
    0.01129426f, 0.24646197f, 0.01420632f, 0.57087463f, 0.98406047f, 0.67137569f, 0.97128654f, 0.03269711f, 
    -0.18990675f, 0.15921417f, -0.76239240f, 0.00861118f, -0.03215605f, 0.17595294f, -0.13922785f, 0.14676261f, 
    0.07984476f, -0.13999476f, -0.13173848f, 0.27731833f, 0.32861662f, 0.06575424f, -0.28668001f, 0.13525540f, 
    -0.03985043f, -0.22652133f, 0.02131144f, -0.04611243f, -0.20348957f, -0.18635312f, 0.64291072f, 0.76131779f, 
    0.88621819f, 0.11413544f, 0.11061373f, -0.20592640f, -0.39115191f, -0.01139120f, 0.28341326f, 0.26238894f, 
    0.38522479f, 0.10956352f, -0.05406286f, 0.37525493f, 0.28812671f, 0.59083301f, 0.11273514f, -0.02940097f, 
    -0.11851151f, -0.07017218f, -0.15337805f, -0.30379549f, 0.10252711f, 0.74975950f, -0.59520674f, 0.75018805f, 
    0.35763645f, 0.37409323f, 0.63737923f, 0.47078347f, 0.15813211f, -0.28011432f, -0.25259358f, 0.21317737f, 
    0.17345583f, -0.14569588f, -0.00207486f, -0.51221955f, -0.20741940f, 0.20159294f, 0.30249986f, 0.07843079f, 
    0.22281060f, 0.18601327f, 0.32596919f, -0.10779641f, -0.03543420f, 0.39893532f, 0.99693185f, 0.36255282f, 
    0.05896820f, 0.48818707f, 1.07156587f, 0.31434408f, 0.09335496f, -0.32450655f, 0.44930834f, 0.39139208f, 
    0.12281436f, 0.05825055f, -0.13780567f, -0.01123197f, -0.22264816f, -0.25206494f, 0.04898110f, -0.06302753f, 
    -0.13712215f, -0.15172409f, -0.07443373f, -0.04344814f, 0.16605982f, 0.13130917f, 0.10372619f, 1.09760618f, 
    -0.19629022f, 0.02345634f, -0.59100068f, 0.84914792f, 0.02220151f, 0.15454666f, 0.25709519f, 0.52918321f, 
    -0.14564525f, -0.07663338f, -0.16728179f, 0.30306146f, 0.19929054f, 0.26777610f, 0.47004035f, 0.07484061f, 
    -0.15876295f, -0.42729098f, -0.01906840f, 0.55132490f, 0.20706171f, 0.09373821f, 0.03894937f, 0.03884359f, 
    -0.07995360f, 0.30996156f, 0.67524117f, 0.36697820f, 0.39597392f, -0.66054988f, -0.88857138f, -0.89503521f, 
    -0.20471317f, -0.45870787f, 0.54061824f, 0.34482569f, 0.09690293f, 0.46401396f, -0.33360070f, 0.16600935f, 
    0.17327407f, 0.00852324f, -0.20416629f, 0.26580605f, -0.10130510f, 0.14986536f, 0.15114790f, -0.07891123f, 
    -0.14610690f, 0.62491798f, 0.55097985f, 0.51446998f, 0.47522387f, 0.70080435f, -0.43712407f, 0.58075160f, 
    0.34984639f, -0.08698308f, 0.55293417f, -0.10803147f, -0.47816816f, 0.01585048f, -0.21101601f, 0.00005119f, 
    0.18874659f, 0.18518376f, 0.14682409f, 0.18024415f, -0.04548571f, -0.39187777f, -0.44039831f, -0.27393138f, 
    -0.44406289f, -0.01008102f, -0.41987357f, 0.29869989f, 0.05798297f, -0.40598744f, -0.24349800f, -0.30141291f, 
    -0.46789932f, -0.64917779f, -0.75535810f, -0.61121529f, -0.70309454f, 0.23020047f, 0.22576214f, -0.15836534f, 
    0.05356575f, 0.07822278f, -0.22185291f, 0.15690961f, 0.15694450f, -0.13202952f, 0.35184935f, 0.21044381f, 
    -0.02239562f, -0.11474698f, 0.03121022f, -1.08982420f, -0.35927570f, 0.04554937f, 0.27759665f, -0.24807647f, 
    0.75974369f, 1.14932656f, 0.01579772f, 0.14121389f, 0.61234415f, 0.01649014f, -0.06426813f, -0.01223653f, 
    -0.36748269f, -0.18872327f, -0.02944545f, -0.01542509f, -0.19157933f, -0.01214141f, -0.20472184f, 0.01458303f, 
    -0.04182400f, 0.08834527f, -0.02389219f, 0.16266464f, -1.24158466f, 0.72796851f, 0.57166249f, -1.08464348f, 
    -0.71894687f, 0.59002417f, 0.36056140f, -0.60797107f, 0.19502805f, 0.16338208f, -0.33213881f, 0.17145334f, 
    -0.02162411f, 0.18989484f, 0.16474158f, -0.21205075f, -0.04822908f, -0.20681556f, 0.15061432f, 0.17192544f, 
    0.23717356f, 0.04213815f, 0.13081749f, 0.25432882f, -0.10308143f, 0.67138344f, 0.40484914f, -0.81496066f, 
    -0.78779870f, -0.22247155f, 1.05026245f, 0.01491869f, 0.42073092f, 0.58690786f, 0.38498086f, -0.30045384f, 
    -0.23222868f, -0.31016418f, -0.19747825f, -0.23656631f, -0.13765021f, -0.15982521f, -0.12420017f, 0.17268477f, 
    0.25740445f, -0.18435490f, -0.26272520f, -0.35665143f, 0.00431287f, 0.11167118f, -0.52711725f, 0.99352127f, 
    0.78281587f, 0.32631806f, -0.64881617f, -0.72016674f, 0.65005803f, -0.00489416f, -0.06840505f, -0.47871944f, 
    -0.02452194f, 0.16807249f, -0.06347603f, -0.02854726f, 0.14637671f, -0.23896018f, -0.05848125f, 0.35134891f, 
    -0.08983538f, -0.22663942f, 0.22231281f, 0.17386521f, 0.13113581f, 0.13728146f, 0.09196714f, -0.40258333f, 
    -0.67336804f, -0.80803168f, -0.33187702f, -0.15713936f, 0.39839813f, 0.11108402f, -0.30463687f, 0.67284286f, 
    0.12200959f, -0.27341548f, -0.31537431f, 0.42385167f, -0.44221660f, -0.61482531f, -0.06963936f, 0.09799614f, 
    0.26381692f, -0.06472480f, 0.04382946f, 0.12353136f, -0.20884152f, -0.22429027f, 0.01769480f, -0.02758945f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.14485529f, 0.15739527f, 0.21519662f, 0.12996393f, 0.28594837f, 0.26859778f, 0.04963168f, 0.13227139f, 
    0.09076014f, -0.05492917f, 0.07133950f, 0.37111676f, 0.14578010f, 0.10839546f, 0.08597514f, 0.33017397f, 
    0.15705124f, 0.26937065f, -0.03912302f, 0.05479990f, 0.11783982f, 0.15007097f, 0.30535367f, 0.10155500f, 
    0.35412577f, 0.22656190f, 0.29422209f, -0.08142844f, -0.01101156f, -0.00186654f, 0.33127311f, -0.01500555f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.02816436f, -0.01578440f, 0.04868572f, -0.04115506f, 0.03273955f, -0.04623086f, -0.05035005f, -0.04617937f, 
    0.02234019f, -0.03654416f, -0.04446917f, 0.03768910f, -0.01143450f, -0.02621757f, -0.04063789f, -0.00834079f, 
    0.00432758f, 0.02659496f, 0.01000444f, -0.05602833f, 0.01521003f, 0.01041599f, 0.02434321f, -0.00614248f, 
    -0.00321485f, -0.02379714f, -0.00992837f, 0.03159605f, 0.04147289f, -0.00793391f, -0.03633212f, -0.04210504f, 
    -0.02573726f, -0.00301731f, -0.00327431f, -0.03954185f, 0.00781448f, -0.01371758f, -0.00568661f, 0.01774335f, 
    -0.02831068f, -0.01818785f, 0.00075715f, 0.03056774f, -0.01041232f, -0.04372230f, -0.02036868f, -0.04203633f, 
    -0.05405952f, 0.04084146f, -0.03148799f, 0.00952597f, -0.02593117f, -0.02759975f, -0.05260978f, -0.00191139f, 
    -0.04106929f, 0.00600579f, 0.00340230f, -0.03375211f, -0.01353817f, -0.05664285f, 0.00395469f, -0.03042145f, 
    0.01096115f, 0.03525048f, 0.00638755f, -0.04322459f, -0.00731107f, -0.00693265f, -0.01429461f, 0.03127981f, 
    -0.00072723f, -0.02162930f, -0.01282403f, 0.01901926f, -0.03495894f, -0.03116115f, 0.01364129f, -0.05081379f, 
    -0.00444599f, -0.02451364f, 0.04775238f, -0.04542992f, -0.03583533f, -0.00186166f, 0.02087865f, 0.02037762f, 
    -0.02678879f, -0.05134620f, -0.01449129f, -0.02887963f, -0.06155906f, -0.06145442f, 0.01123553f, 0.02903198f, 
    0.01648765f, -0.04102095f, 0.03636381f, -0.00086235f, 0.00769446f, -0.03488311f, -0.03063391f, 0.02500495f, 
    0.01238429f, -0.01904969f, 0.03586577f, -0.01227429f, -0.01128642f, 0.03109545f, -0.01861540f, -0.03012388f, 
    0.02301198f, -0.01129967f, 0.04621481f, -0.04232705f, 0.02497851f, -0.00146595f, 0.00835614f, -0.01240337f, 
    -0.06165647f, -0.01803583f, -0.03091489f, -0.04305198f, -0.03955190f, -0.01200003f, -0.05424081f, -0.02860085f, 
    -0.01982865f, -0.00213829f, 0.01230274f, -0.02247551f, -0.05324889f, 0.01895607f, 0.03022986f, -0.01763572f, 
    0.04031898f, -0.01395518f, 0.02698560f, -0.00159355f, 0.01856484f, 0.01276904f, -0.03545654f, 0.03179453f, 
    -0.05640457f, 0.03847604f, -0.05484839f, -0.02908382f, -0.02568182f, 0.00782768f, -0.01143784f, -0.03263723f, 
    0.01381183f, -0.01477406f, 0.00514353f, 0.02576570f, 0.01049163f, 0.01907433f, -0.05021167f, 0.01914348f, 
    0.00112792f, 0.00559328f, 0.03824150f, -0.04354040f, 0.01846330f, -0.02387239f, 0.00301347f, 0.00054593f, 
    -0.00452837f, 0.01547752f, -0.02440264f, 0.03122494f, -0.02783415f, 0.02722923f, 0.03426450f, 0.01726147f, 
    0.02377861f, 0.04531409f, -0.02104363f, 0.01203831f, 0.03715653f, -0.03138528f, -0.01680837f, -0.05373197f, 
    0.02236163f, 0.00064456f, -0.04331970f, -0.05912864f, -0.00772505f, 0.02617878f, -0.03851953f, 0.02389903f, 
    -0.00315976f, -0.02324624f, -0.04229567f, -0.02428598f, 0.01357820f, 0.01700496f, -0.04210482f, 0.03551705f, 
    -0.05448899f, 0.00659629f, 0.00357321f, 0.02320351f, 0.02009159f, 0.02717169f, 0.02854910f, -0.03314323f, 
    -0.03534451f, 0.03450557f, 0.01442488f, -0.05651256f, -0.00900869f, 0.03701824f, 0.02868881f, 0.03499041f, 
    0.01160966f, -0.05890422f, -0.01558451f, 0.01487734f, 0.02993482f, 0.01271430f, 0.02839675f, -0.02025616f, 
    -0.00258381f, -0.01585344f, -0.03255962f, -0.00606287f, -0.03438098f, 0.02090128f, -0.02364763f, 0.02106229f, 
    -0.05181749f, 0.02150679f, -0.03248158f, -0.04241730f, 0.01124228f, -0.00279036f, 0.03034378f, 0.02829888f, 
    -0.01396236f, 0.02485546f, -0.02258300f, -0.01801304f, -0.05374307f, 0.00118714f, 0.02007163f, 0.02101829f, 
    -0.01536465f, -0.01003604f, -0.00004112f, -0.01578243f, -0.05346769f, -0.01790475f, 0.02399334f, 0.01187314f, 
    0.00241595f, 0.03118244f, -0.00311542f, 0.01546196f, 0.00782738f, -0.05894797f, -0.00114163f, -0.03393452f, 
    -0.01076117f, 0.03193774f, -0.04468688f, -0.03536188f, 0.03063751f, -0.00380090f, -0.06006894f, 0.02296785f, 
    -0.00543265f, 0.03574929f, 0.02423650f, -0.03541778f, -0.03269305f, -0.01481535f, 0.03431387f, 0.00541751f, 
    0.03415606f, -0.05729132f, -0.04649248f, -0.03149899f, -0.05624406f, -0.02705300f, -0.03269305f, -0.04032388f, 
    0.02499599f, 0.03143467f, -0.02681750f, -0.05281186f, 0.00051902f, 0.01536969f, -0.02834827f, -0.02454340f, 
    0.04960080f, -0.05398498f, -0.02207334f, -0.01483476f, -0.01980251f, -0.00394821f, 0.03273169f, 0.01813075f, 
    0.00671092f, -0.00380725f, -0.05457903f, -0.05205582f, 0.04147002f, 0.02444138f, -0.01961717f, -0.00760271f, 
    -0.04587632f, 0.00185142f, -0.01656833f, 0.03095246f, -0.05125974f, -0.04572308f, 0.01353551f, -0.02335921f, 
    -0.05495278f, -0.00874433f, -0.02558951f, -0.01422223f, -0.05404864f, 0.04326921f, -0.00232977f, 0.00660855f, 
    0.00109985f, 0.03746203f, -0.02662879f, -0.04888006f, -0.02613920f, -0.01059221f, -0.04848560f, -0.03389609f, 
    0.01638149f, -0.02456351f, 0.03695657f, -0.02062181f, -0.01668042f, -0.00612626f, -0.02893439f, -0.02710575f, 
    -0.05863603f, -0.04908183f, -0.01052379f, 0.03557575f, 0.01875646f, 0.02080194f, 0.01885350f, -0.02631387f, 
    -0.01108312f, 0.01116064f, 0.00004407f, 0.02978869f, -0.03395025f, 0.00989763f, 0.00519628f, -0.00808549f, 
    0.02385053f, 0.01107007f, 0.02007065f, -0.05534123f, -0.01573571f, -0.04676845f, -0.05737805f, 0.02047326f, 
    0.03148096f, 0.02870712f, 0.00066777f, -0.03599676f, -0.02713162f, 0.00232634f, 0.02627030f, -0.00065882f, 
    0.00148703f, 0.01999702f, 0.00867611f, -0.02637318f, -0.04502836f, 0.02526389f, -0.05878408f, 0.00779206f, 
    0.03870496f, 0.02053363f, -0.03856228f, -0.00826055f, 0.03210675f, 0.01684777f, -0.02229154f, -0.01935162f, 
    0.02368075f, -0.04324659f, -0.02952836f, -0.01056221f, -0.03478178f, -0.02773522f, -0.03791790f, -0.02401569f, 
    0.00161573f, -0.01268457f, -0.01310560f, -0.02108829f, -0.02313028f, 0.00703997f, -0.03036772f, -0.00810595f, 
    -0.04693095f, -0.01307328f, -0.01009462f, -0.03549989f, 0.03857633f, 0.03036171f, 0.03598090f, -0.02209968f, 
    0.03957221f, -0.00452024f, -0.04486673f, -0.00133809f, -0.02947316f, -0.02221428f, -0.03292849f, 0.04238173f, 
    -0.00533657f, 0.01894369f, 0.02292186f, -0.03561711f, 0.02064519f, -0.03394225f, 0.04485840f, 0.01033288f, 
    0.03168862f, -0.01857275f, -0.03421251f, -0.02260471f, 0.03978268f, 0.01401302f, -0.04224749f, 0.01125252f, 
    -0.04839028f, 0.04135037f, -0.04528351f, -0.00476452f, -0.00809963f, -0.03482403f, -0.00321021f, -0.00548658f, 
    -0.01307299f, 0.04395848f, 0.01847853f, 0.03385925f, -0.02277186f, -0.00520218f, -0.02105759f, 0.01101905f, 
    0.04286719f, -0.00876024f, -0.05309285f, -0.03074931f, 0.00587571f, -0.05600811f, 0.01508730f, 0.02752541f, 
    0.02248421f, 0.03111521f, -0.02271686f, -0.01615796f, -0.02584162f, -0.03671491f, -0.01522944f, -0.01243893f, 
    -0.04411595f, -0.01694347f, -0.03914776f, -0.03642280f, -0.00821113f, 0.00204262f, -0.00828495f, -0.04763136f, 
    -0.00002058f, -0.00535251f, -0.04729114f, -0.02837505f, 0.01011015f, -0.00132700f, 0.02505646f, 0.01838862f, 
    -0.03969484f, -0.04442688f, -0.02794916f, -0.00539824f, 0.01390202f, -0.01033278f, -0.03418886f, -0.02268899f, 
    -0.03594443f, -0.00277925f, -0.01497034f, -0.03924396f, -0.01519554f, -0.05386839f, 0.01231442f, 0.01722004f, 
    -0.05807987f, -0.04235759f, 0.01488038f, -0.02815168f, 0.04576085f, -0.03586496f, 0.04490665f, -0.03740984f, 
    0.00233048f, -0.00915808f, -0.00137485f, -0.01336932f, 0.00642169f, -0.05030392f, -0.02894366f, -0.00592673f, 
    0.02736796f, 0.01186997f, -0.05396516f, 0.04158495f, -0.04002847f, -0.01065113f, -0.00023013f, 0.04483607f, 
    0.00133806f, -0.04007155f, -0.00689277f, 0.03895126f, -0.00379533f, -0.01671772f, -0.03406163f, -0.04897894f, 
    -0.03146414f, -0.04013624f, 0.02722027f, -0.02004693f, 0.03194758f, 0.03320502f, 0.01865811f, -0.05468660f, 
    -0.04114137f, 0.00613810f, -0.05054255f, -0.02244840f, -0.03340792f, 0.03177166f, -0.02714294f, -0.02653382f, 
    -0.02506866f, 0.01473581f, 0.03060804f, -0.05431718f, 0.04668365f, -0.03382702f, -0.03009112f, -0.05047332f, 
    0.04112596f, 0.02685132f, 0.00375493f, 0.04084824f, 0.00776408f, 0.00786117f, -0.03088173f, -0.02618654f, 
    -0.01372110f, -0.04855178f, -0.02076727f, -0.00466192f, -0.00429353f, 0.01049546f, -0.04554167f, -0.04097427f, 
    -0.05029342f, -0.03605946f, -0.05252022f, 0.01304871f, 0.00534466f, -0.02685366f, -0.02605968f, 0.01858632f, 
    0.00007715f, -0.02543857f, 0.03536593f, 0.00940211f, -0.05480890f, -0.04729096f, 0.04105410f, -0.03695576f, 
    -0.04130602f, 0.02409299f, 0.01733005f, 0.04334917f, 0.00099060f, 0.01398702f, -0.00899605f, -0.04904599f, 
    -0.03485387f, -0.02372366f, 0.02497143f, 0.04274935f, 0.04077606f, -0.01923500f, 0.04232050f, 0.02379879f, 
    -0.02171963f, -0.00779555f, 0.03876103f, -0.03886733f, -0.02469289f, 0.03428854f, -0.00704960f, 0.03626563f, 
    0.01939031f, -0.01469830f, -0.04510421f, -0.02007041f, 0.02263973f, -0.03451471f, -0.05139881f, -0.03259528f, 
    0.04491878f, -0.03228996f, -0.01822938f, -0.00992135f, -0.05149360f, 0.01532023f, -0.05098621f, 0.04129260f, 
    0.01081431f, 0.01032352f, -0.02671927f, 0.03838458f, 0.01105341f, -0.01354535f, -0.05343243f, 0.00017728f, 
    0.03477803f, -0.02927804f, -0.00145482f, -0.00493897f, 0.04420622f, 0.00013727f, -0.00241904f, 0.02310540f, 
    -0.04145181f, 0.01651666f, -0.00328914f, 0.01073252f, -0.00777376f, -0.01982994f, -0.01851193f, 0.02911259f, 
    0.03969109f, 0.00993368f, 0.01383246f, -0.00869393f, -0.01336677f, -0.01990380f, -0.03224436f, -0.01895877f, 
    0.01733861f, 0.00697074f, 0.03545832f, -0.01444686f, -0.04827330f, 0.02747419f, 0.00436508f, 0.00732700f, 
    -0.00144356f, -0.05296599f, -0.00494114f, -0.01184097f, -0.04775315f, -0.02722607f, -0.01477330f, -0.00482048f, 
    -0.00259610f, 0.02970870f, 0.00453104f, -0.03245107f, -0.01287565f, -0.04725547f, 0.02280925f, -0.04549916f, 
    0.03819555f, 0.00060040f, 0.01522835f, -0.04311562f, 0.02175392f, -0.02289845f, 0.02588742f, -0.02095089f, 
    0.02427875f, -0.05365226f, -0.04339327f, 0.04375838f, -0.05026301f, 0.00979894f, 0.02319400f, -0.01394980f, 
    0.04436280f, 0.02770730f, 0.03971248f, 0.02024174f, -0.02401065f, -0.04115363f, -0.04025259f, -0.01029049f, 
    -0.01998261f, -0.01901815f, 0.01202874f, 0.00601958f, 0.02927000f, -0.05001672f, 0.01632076f, 0.01847695f, 
    0.02565309f, -0.00356080f, 0.00328171f, -0.04665295f, -0.01100626f, -0.02550823f, 0.00241342f, -0.03495384f, 
    0.03492525f, 0.01661391f, -0.05235909f, -0.04629225f, 0.03562467f, 0.00014079f, 0.03391916f, -0.00806605f, 
    -0.04012194f, -0.03974246f, -0.01098008f, 0.02347980f, -0.03587485f, -0.01374369f, 0.03548256f, -0.05461647f, 
    -0.03732387f, -0.04820202f, 0.03503647f, 0.04361429f, 0.04159143f, 0.04529755f, 0.02752012f, -0.00037681f, 
    0.01370296f, 0.01938724f, 0.03040548f, -0.03105612f, -0.00115259f, -0.02140260f, 0.01478067f, -0.00718096f, 
    -0.01034104f, -0.03299646f, -0.01259950f, 0.03145771f, 0.03950753f, -0.03910141f, 0.00260353f, -0.04140318f, 
    -0.02140149f, -0.03211457f, 0.01699540f, -0.00883966f, -0.04242530f, -0.00213074f, 0.03847795f, 0.03862310f, 
    -0.05263985f, 0.02478399f, -0.00637790f, 0.01844856f, 0.03892162f, 0.01736473f, -0.02071492f, -0.00405994f, 
    0.01153531f, 0.01489798f, -0.06097269f, -0.03497674f, -0.04365706f, 0.00513727f, -0.04746897f, -0.00348778f, 
    -0.01466213f, -0.02967389f, 0.00339340f, -0.00434017f, -0.00259699f, 0.02337942f, -0.04148299f, -0.05126130f, 
    -0.01570993f, -0.04993847f, 0.02841343f, -0.05347385f, -0.03473882f, -0.05769140f, -0.00587146f, 0.02712505f, 
    0.02472789f, -0.04350042f, -0.01025820f, 0.03522036f, -0.00491914f, 0.03306549f, -0.04898232f, 0.03371432f, 
    -0.02814746f, -0.02883422f, 0.02889632f, 0.01724195f, -0.04587538f, -0.03766380f, -0.00092780f, 0.00173624f, 
    -0.00566545f, -0.03994108f, 0.01563982f, -0.03985884f, -0.00460492f, -0.02217134f, -0.00111240f, -0.06019467f, 
    0.00108219f, -0.03800784f, 0.01867854f, -0.00921901f, -0.05730587f, -0.04243117f, -0.05696600f, 0.01829359f, 
    0.01660262f, -0.00965372f, 0.01360801f, -0.02796417f, -0.03762052f, 0.01750459f, 0.04047266f, -0.01476098f, 
    -0.00848831f, -0.01482332f, 0.01410934f, 0.03926125f, -0.00526688f, 0.03140423f, 0.00563939f, 0.03895565f, 
    -0.03971934f, -0.00738619f, 0.00031626f, -0.04922476f, 0.00325878f, 0.03354610f, -0.00156261f, 0.01081979f, 
    0.00103417f, -0.05267584f, -0.00078807f, -0.01623160f, -0.02140551f, -0.02222633f, 0.00324393f, -0.01230517f, 
    -0.03472710f, 0.03482299f, 0.04038109f, 0.00907651f, 0.01463243f, -0.01851630f, -0.04523999f, -0.03253549f, 
    -0.04019618f, -0.04739998f, 0.00870134f, -0.00710503f, -0.03762153f, -0.00581789f, -0.02414353f, -0.01567497f, 
    0.00285552f, -0.04179516f, 0.01485774f, 0.01729121f, 0.03209177f, -0.00645623f, -0.01257028f, 0.00858377f, 
    0.02518279f, 0.00379996f, -0.03954596f, 0.02861609f, 0.03896396f, 0.02962532f, -0.01422143f, -0.03911525f, 
    0.03259585f, 0.01698758f, 0.01049060f, -0.03823700f, 0.01991975f, 0.02254107f, -0.05554834f, 0.02885067f, 
    0.00820637f, -0.05647238f, 0.01606528f, -0.03413027f, -0.00915678f, -0.01567554f, 0.00137042f, 0.00063411f, 
    -0.00432063f, -0.05228212f, -0.05312634f, 0.00408282f, -0.06066001f, 0.01840796f, 0.00078631f, 0.04016489f, 
    0.02106479f, 0.01342245f, 0.00555822f, -0.04290169f, -0.01345445f, 0.02257873f, -0.02370011f, 0.02132782f, 
    0.03889028f, 0.01909925f, -0.00871022f, -0.02985885f, 0.03757198f, 0.00407223f, 0.03126052f, 0.01829086f, 
    0.02702758f, 0.00000161f, -0.05029322f, 0.04196313f, -0.04214008f, 0.00668274f, 0.01810248f, -0.00454628f, 
    -0.00270670f, -0.04929437f, -0.00184326f, 0.03528374f, -0.01724052f, 0.00170989f, 0.00092232f, -0.02844422f, 
    0.01722140f, 0.01332664f, 0.01186179f, 0.04098308f, 0.01421212f, -0.01221425f, -0.00734280f, -0.04295212f, 
    -0.00378326f, 0.01054467f, 0.03665947f, 0.02552512f, -0.04395371f, -0.03903775f, 0.03562935f, 0.03987171f, 
    0.03305108f, -0.04975990f, -0.04345056f, 0.00911115f, -0.02930913f, -0.00718103f, 0.02147022f, -0.01364174f, 
    -0.03779140f, -0.02562004f, 0.02528172f, 0.02767223f, 0.02814717f, -0.04658230f, 0.02257202f, 0.03247989f, 
    -0.05531259f, -0.00433224f, -0.04141861f, 0.03865147f, 0.03885936f, 0.01653453f, -0.04772350f, 0.01055279f, 
    0.02755545f, 0.03598404f, -0.03680500f, 0.03213221f, 0.00823964f, -0.05562801f, -0.03670269f, -0.00217861f, 
    0.03775731f, -0.02721369f, -0.05550349f, -0.02809545f, -0.01395799f, 0.00149006f, 0.04121886f, -0.03640953f, 
    0.02391491f, -0.00208520f, -0.01032215f, 0.02955922f, -0.00901726f, -0.05560792f, -0.05807281f, -0.02609854f, 
    0.03945422f, 0.01005492f, -0.01262686f, 0.03016735f, 0.01735059f, 0.03284852f, -0.01561915f, -0.04639940f, 
    0.03048482f, -0.02182911f, 0.01799856f, -0.00824698f, 0.00079623f, 0.03566807f, -0.05424561f, 0.03610933f, 
    -0.00322157f, -0.01213849f, -0.01078546f, -0.04416205f, -0.01441384f, 0.01858253f, -0.03137380f, 0.02584949f, 
    0.02549816f, -0.03829980f, -0.02513688f, 0.03370915f, -0.02046752f, -0.04029139f, 0.00403379f, -0.04419768f, 
    -0.05271858f, -0.03867199f, 0.01903254f, -0.00924724f, -0.00084204f, 0.01091490f, 0.02153465f, -0.03953609f, 
    -0.04695797f, -0.04699782f, -0.01713652f, 0.03095793f, -0.04041133f, 0.02204270f, -0.02311666f, -0.05589071f, 
    -0.02408672f, 0.00326133f, -0.00598444f, -0.02399243f, -0.04942431f, -0.02301085f, 0.00500693f, 0.04049551f, 
    -0.03645431f, 0.00074492f, -0.04505798f, -0.03298985f, 0.02924602f, -0.03413996f, 0.03563598f, -0.05292555f, 
    -0.05626401f, -0.04686113f, -0.04900525f, 0.02072717f, 0.03530105f, -0.01110330f, -0.02568378f, -0.05234721f, 
    0.02556594f, -0.02822732f, -0.04763677f, 0.02430194f, -0.04458963f, -0.04805455f, -0.01307907f, -0.04816518f, 
    0.00353252f, 0.02852862f, 0.01508652f, -0.04422186f, -0.04792271f, 0.01802709f, -0.03857384f, -0.04124642f, 
    0.03682383f, -0.03812423f, -0.05545631f, 0.00227820f, 0.01715976f, -0.04422864f, -0.04685824f, 0.03835214f, 
    -0.04575991f, -0.02331391f, -0.04212562f, 0.00375137f, -0.04572859f, 0.02769995f, -0.05157056f, -0.02114970f, 
    0.03691957f, -0.04589215f, 0.02407146f, 0.03027572f, -0.05674539f, -0.00691996f, -0.00890129f, -0.02492052f, 
    -0.01419428f, -0.02024854f, -0.01382120f, 0.00320410f, 0.01452692f, -0.00460931f, 0.01519649f, -0.01445634f, 
    -0.03725222f, -0.05885748f, -0.04277128f, -0.02449886f, -0.06083486f, -0.02850382f, -0.03116379f, -0.05954460f, 
    -0.05052501f, 0.01755786f, -0.02239184f, -0.03605686f, 0.02011875f, 0.01040297f, 0.02470758f, -0.01216089f, 
    -0.05594313f, -0.00260971f, -0.00518512f, -0.03774215f, -0.04706485f, 0.01937958f, 0.03503224f, 0.00123833f, 
    0.03480879f, 0.03657860f, -0.02889680f, -0.03962208f, -0.02640619f, -0.04485811f, 0.03571605f, -0.05034344f, 
    0.01641887f, 0.02712671f, -0.01945936f, -0.03009658f, -0.01509547f, -0.04330308f, -0.04452696f, 0.02084447f, 
    -0.05621271f, -0.03461446f, -0.05560684f, 0.02536987f, 0.03854218f, -0.03017529f, 0.02870768f, 0.02332372f, 
    0.02577109f, -0.04222527f, -0.04584720f, -0.03154166f, 0.04041995f, -0.02618405f, -0.05292178f, 0.01816824f, 
    -0.03660056f, -0.05561734f, -0.03377207f, -0.04601377f, 0.00409897f, 0.02872037f, -0.00149915f, 0.01074463f, 
    0.03532512f, -0.05249904f, -0.02334392f, 0.01124632f, 0.01448016f, -0.02419653f, -0.05586139f, -0.00519912f, 
    -0.02057931f, 0.03215744f, 0.02680456f, 0.02917345f, 0.01575560f, 0.02827614f, -0.03535554f, 0.02600425f, 
    0.05365209f, 0.01499150f, -0.00965634f, -0.04892518f, 0.00528586f, -0.01454118f, -0.03989964f, 0.03874904f, 
    -0.04678254f, -0.00694609f, 0.01115701f, 0.00945220f, -0.04327621f, -0.00454029f, -0.00227023f, -0.04713389f, 
    -0.05297995f, -0.00946321f, -0.01021406f, -0.01548254f, -0.02091227f, -0.05663134f, -0.01002203f, -0.03063767f, 
    -0.02344143f, -0.03010011f, 0.03052403f, -0.03091914f, -0.02917701f, -0.04381213f, -0.02876185f, 0.01017965f, 
    -0.04343301f, -0.03552613f, -0.03316320f, -0.00592883f, 0.00091942f, -0.00979235f, 0.01823473f, -0.01907592f, 
    -0.02295065f, -0.02408489f, 0.04265532f, -0.05533492f, -0.00496077f, -0.05312719f, -0.05273982f, -0.04878731f, 
    -0.01049418f, 0.01891985f, -0.05013165f, 0.01869296f, 0.03445646f, -0.05484818f, -0.03933603f, 0.01382790f, 
    0.00905317f, -0.02128158f, 0.02144668f, -0.00703774f, -0.00237793f, 0.02684847f, -0.03659986f, 0.04074676f, 
    0.01101376f, 0.02213804f, -0.05182829f, -0.03370299f, -0.03132031f, -0.01417048f, -0.00965782f, 0.03043556f, 
    0.03832334f, 0.01878304f, 0.04377851f, -0.02257395f, -0.04253793f, -0.02760683f, -0.03484476f, -0.05132686f, 
    -0.03326753f, 0.00536029f, -0.00027770f, -0.03705444f, 0.00716030f, -0.05130316f, -0.00704416f, -0.04156590f, 
    0.00003264f, -0.02471344f, -0.02485109f, -0.05447666f, -0.01636923f, 0.00319886f, 0.03175092f, 0.02357195f, 
    -0.01175073f, -0.04178126f, 0.03106862f, 0.01166455f, 0.01027955f, -0.02132386f, 0.02248085f, -0.00965067f, 
    0.03184274f, -0.02862026f, -0.01284752f, 0.04753104f, 0.02259925f, -0.01350661f, -0.03046706f, -0.02353292f, 
    -0.03729224f, -0.04196790f, 0.01307234f, -0.05107762f, -0.04231298f, -0.01327819f, -0.00140757f, 0.02763319f, 
    -0.02150778f, -0.01753149f, -0.04409960f, 0.03710081f, 0.03030056f, 0.01563512f, -0.05581456f, 0.02152343f, 
    0.01148210f, -0.01600450f, 0.01438988f, -0.00194442f, 0.00719566f, -0.00121215f, -0.01652688f, 0.01184900f, 
    -0.05619454f, 0.01709360f, -0.04994435f, -0.01394522f, -0.02256264f, 0.02367019f, 0.01716634f, -0.05286998f, 
    -0.00586349f, -0.00917701f, 0.00948332f, -0.02001702f, 0.02826822f, -0.02188496f, -0.02227087f, -0.03613785f, 
    0.02596653f, 0.03846359f, 0.03357172f, -0.00181648f, -0.05351056f, -0.04881196f, 0.02358181f, 0.03318378f, 
    0.04051794f, 0.03631485f, 0.03061988f, -0.01780014f, -0.02429095f, -0.01087446f, 0.01073531f, -0.03300503f, 
    0.03086698f, 0.02203212f, 0.02411081f, -0.02752649f, -0.01537794f, -0.02734696f, 0.00808717f, 0.01572588f, 
    -0.05101336f, 0.04227553f, 0.02384430f, 0.00898819f, 0.03863820f, 0.04187502f, 0.04371810f, -0.01954798f, 
    0.00053512f, 0.00123422f, -0.01183523f, -0.04015481f, 0.02122406f, -0.04077466f, -0.02939881f, -0.03449747f, 
    0.02568221f, -0.01773224f, -0.00331512f, 0.01668661f, -0.01115761f, -0.02256117f, 0.04439673f, 0.00270773f, 
    -0.02784615f, -0.04426591f, 0.00121252f, 0.02178753f, -0.02849337f, -0.00575327f, 0.02219665f, -0.02794787f, 
    -0.00203391f, 0.01306670f, 0.02191500f, -0.04512728f, 0.01616491f, 0.03491126f, -0.00595120f, -0.02419346f, 
    -0.01323146f, 0.01137918f, 0.03496099f, -0.03848048f, -0.03733400f, 0.00978255f, 0.00842736f, -0.01622848f, 
    -0.04898385f, -0.01387704f, 0.02792818f, -0.00946517f, -0.05386183f, -0.05294619f, -0.05228079f, -0.00553271f, 
    -0.00743845f, 0.02213397f, -0.04107850f, -0.00317090f, -0.03184808f, -0.00297445f, 0.04128743f, 0.04046632f, 
    -0.03136655f, -0.01744905f, 0.03805807f, 0.02044541f, -0.02387030f, -0.02334862f, -0.00461766f, -0.04256557f, 
    0.04056169f, -0.01855402f, 0.02309395f, 0.03801295f, 0.00630823f, 0.01952205f, -0.00707655f, 0.02312658f, 
    -0.03258340f, -0.00322921f, -0.02432669f, -0.03641577f, -0.04042277f, 0.04393900f, -0.04585145f, 0.03040922f, 
    0.00860809f, 0.00779815f, 0.02627346f, -0.04792373f, -0.00685635f, 0.00288511f, 0.01921263f, -0.02449148f, 
    0.04101321f, -0.00257544f, 0.02986078f, 0.02975768f, -0.04982942f, -0.03625583f, -0.04005615f, 0.04456893f, 
    0.02008514f, 0.01318830f, 0.03405081f, 0.02529270f, -0.02950737f, -0.02800560f, -0.00420991f, -0.01525293f, 
    0.02405046f, -0.04728256f, 0.01230542f, 0.01572016f, -0.03059441f, 0.02003436f, -0.01743212f, -0.04956658f, 
    0.03098881f, -0.03352323f, -0.01310503f, -0.01712304f, -0.04163798f, 0.01233648f, 0.03490009f, -0.01530972f, 
    0.02645292f, 0.05026234f, 0.01866106f, 0.03381989f, -0.01762850f, 0.03009086f, 0.04049443f, -0.03117517f, 
    0.01788820f, 0.00517618f, 0.03623110f, 0.03377719f, 0.02580409f, 0.01087927f, -0.01608689f, 0.03491066f, 
    -0.03498977f, -0.02058240f, 0.01953232f, -0.03434116f, 0.03400349f, 0.00635271f, -0.00297211f, 0.00219738f, 
    -0.03962921f, 0.02128787f, -0.04836589f, 0.03101491f, 0.02897822f, -0.02949844f, -0.03688149f, 0.04775145f, 
    -0.00280845f, 0.03582809f, 0.01063181f, -0.01108235f, 0.02006853f, -0.00313249f, 0.01015758f, 0.04454685f, 
    0.00209603f, -0.03804716f, -0.03093876f, -0.00468117f, 0.02554066f, 0.03751299f, 0.00460387f, 0.00831079f, 
    0.01089107f, -0.01968879f, 0.03849608f, -0.01537316f, -0.03614875f, 0.04024716f, 0.02252830f, -0.00787013f, 
    0.01721369f, 0.02691312f, -0.03479699f, 0.02156954f, -0.03617530f, 0.00169378f, 0.02726052f, -0.02714248f, 
    -0.02179940f, 0.02138530f, 0.02738051f, 0.00477671f, 0.00817618f, 0.03546512f, -0.03689570f, -0.02807012f, 
    -0.02957471f, 0.04243778f, 0.00025810f, -0.00844567f, -0.05541527f, -0.03793091f, -0.03866540f, 0.02837575f, 
    0.04427061f, 0.04261494f, 0.00899848f, -0.03887698f, -0.01523009f, 0.02822335f, 0.00648617f, -0.03381545f, 
    0.00179062f, 0.02077288f, 0.03723648f, -0.02548700f, -0.01061400f, -0.01300217f, -0.05362800f, -0.02140798f, 
    0.02407127f, 0.01957182f, 0.02308398f, -0.02331937f, -0.01809928f, 0.02576292f, -0.01045066f, 0.00541240f, 
    -0.02218150f, -0.01356044f, -0.00895246f, 0.02264672f, -0.02779822f, -0.04323662f, -0.02082683f, 0.01039893f, 
    0.01842973f, -0.01688319f, 0.02697376f, 0.01306055f, -0.04125875f, 0.04242851f, 0.00227799f, -0.04760736f, 
    -0.03156088f, 0.00586470f, 0.01238943f, 0.03459315f, -0.02395911f, -0.04715620f, 0.00884227f, 0.02653489f, 
    -0.02211492f, 0.01250241f, -0.04955289f, -0.03528580f, 0.00305592f, -0.01500102f, 0.04062222f, -0.01083373f, 
    0.00631316f, -0.03206963f, -0.02072294f, -0.03497193f, 0.01220983f, -0.01025335f, -0.00363837f, -0.01614176f, 
    -0.02707419f, -0.00106227f, 0.00506535f, -0.05366360f, 0.00581673f, -0.03101822f, -0.04773677f, -0.05161275f, 
    -0.01464657f, 0.00251616f, -0.04064784f, 0.03326511f, 0.01496632f, -0.05170664f, -0.01473715f, 0.03336286f, 
    -0.01506383f, -0.00137095f, -0.01931131f, 0.02559011f, 0.01578026f, -0.00616001f, -0.02790512f, 0.03771774f, 
    0.02950074f, -0.04876081f, -0.04807949f, -0.02244822f, 0.04466664f, 0.01616094f, -0.04589951f, -0.04033097f, 
    0.00184769f, -0.02465571f, 0.00365158f, -0.02995539f, -0.03672408f, 0.00367675f, -0.01631782f, -0.02109169f, 
    0.03593402f, -0.02558673f, -0.05680110f, 0.02826258f, -0.01633893f, 0.00280108f, -0.00155676f, -0.01551474f, 
    -0.03119051f, 0.04783588f, -0.05599646f, -0.04703071f, -0.04189222f, -0.04571791f, -0.00018700f, -0.03255196f, 
    -0.05069824f, -0.02118974f, 0.00110224f, -0.04793975f, 0.02491154f, -0.02041067f, 0.03990515f, -0.02456377f, 
    -0.03783920f, 0.01124591f, 0.03344748f, -0.00650171f, -0.02687326f, -0.02953599f, 0.03611571f, -0.00809473f, 
    -0.01734933f, -0.04918434f, -0.04836579f, 0.00492917f, 0.04111621f, -0.03949454f, -0.00863669f, -0.01254567f, 
    -0.00137006f, 0.02936250f, -0.02078335f, 0.02501269f, 0.03748858f, 0.00417673f, 0.04600626f, -0.02180130f, 
    0.02269359f, 0.03352617f, 0.01273697f, 0.02123753f, -0.00715964f, -0.04564660f, -0.02054327f, -0.04228695f, 
    0.00323793f, -0.04374177f, -0.02266675f, -0.04073124f, -0.04480068f, -0.03347574f, -0.01695073f, -0.02760954f, 
    0.03020167f, -0.02449313f, 0.04591480f, 0.02027670f, -0.03207700f, -0.00793702f, -0.03447798f, 0.04134576f, 
    0.01557054f, 0.03657137f, -0.01746163f, -0.02045007f, -0.02018715f, -0.03332252f, -0.00631625f, 0.01150538f, 
    -0.03909945f, 0.00571747f, -0.00963522f, 0.02316364f, 0.03196400f, -0.02241330f, -0.01091633f, 0.03323141f, 
    -0.01721198f, -0.01155324f, 0.03132408f, -0.03145163f, -0.03184312f, -0.01717246f, -0.04153589f, -0.03789381f, 
    -0.01948356f, 0.01211295f, 0.01805175f, 0.00575320f, 0.01284207f, -0.04363852f, 0.02938776f, -0.03651234f, 
    0.04741540f, -0.01111425f, 0.01349513f, 0.03140667f, -0.05447073f, -0.02369482f, 0.03205230f, -0.02066820f, 
    0.01321489f, 0.04539252f, 0.01507623f, 0.03765085f, 0.04322660f, -0.04621366f, 0.04198151f, 0.02822891f, 
    0.05345906f, 0.00908150f, -0.03801765f, 0.01562574f, 0.01069243f, -0.01738021f, 0.04015703f, 0.01227641f, 
    -0.02339463f, -0.00348893f, -0.02902591f, -0.05084682f, 0.00076276f, 0.00010785f, 0.00949323f, 0.03517759f, 
    -0.03284582f, -0.00322823f, 0.01069851f, -0.02654362f, -0.03854864f, 0.02767546f, 0.02424307f, -0.01207327f, 
    0.03060532f, 0.01717838f, -0.00614895f, -0.01117422f, -0.03777402f, 0.04172140f, -0.03020091f, 0.03195104f, 
    -0.01291994f, -0.03075654f, 0.05088835f, -0.01927583f, 0.00281628f, 0.03696884f, -0.04126459f, 0.00477543f, 
    -0.00798720f, -0.00169089f, -0.02975066f, 0.02475155f, 0.03520200f, 0.02882910f, 0.01386965f, -0.02652771f, 
    -0.04560265f, -0.04572241f, -0.03391193f, 0.03695625f, -0.03591776f, 0.02779684f, -0.03826959f, -0.03948239f, 
    0.02438485f, -0.03051491f, 0.00761080f, -0.01236753f, 0.04249521f, -0.01647191f, -0.02266856f, 0.03465346f, 
    -0.02193335f, 0.02098548f, 0.00924114f, -0.04350821f, 0.01890817f, -0.02583302f, -0.04773114f, -0.02249905f, 
    -0.00056805f, -0.04584094f, -0.02038238f, -0.03949235f, -0.02343782f, -0.01755806f, -0.03634387f, -0.00859623f, 
    -0.01625369f, 0.02025194f, 0.00793012f, 0.04515122f, 0.00221833f, -0.03939393f, 0.03367539f, 0.02502414f, 
    0.00613238f, -0.02029066f, 0.01401623f, -0.02701282f, 0.01580677f, -0.04391965f, -0.00159371f, 0.02740235f, 
    -0.02801394f, -0.04699905f, -0.03869062f, 0.03445145f, 0.00251770f, -0.05004939f, 0.01094217f, 0.00186441f, 
    -0.05297685f, -0.01072677f, -0.01127762f, -0.02707657f, 0.03315890f, -0.02716359f, -0.04658466f, -0.01714206f, 
    -0.00207091f, -0.04744968f, 0.03016021f, -0.05229770f, 0.03898040f, -0.04990966f, -0.02662610f, -0.04081190f, 
    -0.02959481f, 0.01825475f, -0.05203161f, 0.00380857f, 0.04120928f, 0.01689366f, -0.02383704f, 0.01949814f, 
    0.00382269f, -0.00384099f, 0.02882470f, -0.04998134f, -0.00063711f, -0.02882706f, 0.03584286f, -0.03123637f, 
    -0.05332910f, -0.02826641f, -0.01783800f, -0.00985071f, -0.04352481f, -0.03723744f, -0.03622599f, 0.04880280f, 
    0.04622148f, 0.00162001f, 0.04491332f, 0.02069481f, 0.02188245f, -0.00984243f, -0.02680718f, -0.00731717f, 
    -0.00981019f, -0.02374588f, 0.00476828f, -0.04345992f, 0.02501093f, -0.01287575f, -0.02071339f, -0.03630645f, 
    -0.05272530f, -0.04134537f, 0.03489234f, -0.05064115f, 0.03722548f, 0.04479117f, 0.01794620f, 0.01153668f, 
    -0.04176969f, -0.01816403f, 0.03218223f, -0.01416168f, -0.02277381f, 0.02835657f, 0.04020607f, 0.03160318f, 
    -0.05212197f, -0.04777171f, -0.01812600f, 0.01796718f, -0.01863619f, 0.01242473f, 0.03339090f, 0.04523150f, 
    -0.04986315f, -0.02946457f, -0.04048208f, 0.03720858f, 0.04242634f, -0.04018158f, 0.00916831f, -0.01664080f, 
    -0.02912203f, 0.02014120f, -0.04442733f, 0.03701992f, -0.00651911f, 0.01999364f, 0.03819786f, -0.03927718f, 
    -0.05057039f, -0.03249333f, 0.00567524f, -0.03053299f, -0.03191526f, 0.00462277f, 0.02860444f, 0.03145672f, 
    0.01555137f, 0.02074648f, -0.03187430f, -0.02935247f, 0.01978409f, -0.00224592f, -0.04129926f, -0.02598726f, 
    -0.04241861f, -0.05545281f, -0.03093103f, -0.02170775f, -0.02958520f, 0.02147428f, -0.02460221f, -0.00923464f, 
    -0.05189013f, 0.04288464f, -0.04906054f, 0.01403196f, 0.01165057f, -0.01578398f, -0.04362664f, -0.05353915f, 
    0.01313821f, -0.02359413f, -0.02628172f, 0.01010668f, 0.02380790f, -0.00116065f, 0.01228518f, -0.05325608f, 
    -0.03539683f, -0.01646924f, 0.02097460f, -0.04070799f, 0.03264271f, 0.04558608f, -0.03802692f, -0.04271685f, 
    -0.01414888f, -0.00068256f, -0.00031473f, -0.00089413f, 0.00110662f, -0.01876520f, 0.03668283f, -0.00864662f, 
    0.02105387f, 0.01456611f, 0.00734494f, 0.00695967f, -0.01752401f, -0.03312674f, -0.01829454f, -0.03720506f, 
    -0.03656151f, -0.00565664f, -0.01175964f, 0.02872108f, -0.04152402f, 0.02163632f, 0.01477171f, -0.02072134f, 
    -0.02739825f, 0.01727684f, 0.02339572f, 0.03969584f, -0.01510715f, 0.03604225f, 0.04062949f, 0.01819057f, 
    0.00077373f, -0.04347134f, 0.00345661f, -0.02486475f, -0.03473315f, -0.00736724f, 0.04815240f, -0.01283173f, 
    -0.04632322f, 0.01062887f, -0.04387444f, 0.03830433f, 0.04696637f, 0.00481805f, 0.00633401f, 0.04618561f, 
    -0.00528337f, 0.04140053f, -0.01302786f, 0.04348424f, -0.02387506f, -0.01380530f, -0.03928125f, 0.02052772f, 
    0.04646658f, 0.02432480f, 0.00476739f, -0.04628741f, -0.02288584f, -0.04634828f, 0.03016836f, -0.03995954f, 
    0.02363482f, -0.02638432f, 0.01572203f, 0.01951287f, 0.01575733f, -0.02881975f, -0.03794749f, 0.00634850f, 
    0.00566628f, 0.01962814f, -0.01258225f, -0.01279802f, -0.04527576f, 0.03299440f, -0.04915345f, -0.05299701f, 
    0.01251086f, 0.02485665f, 0.03066481f, 0.04246261f, 0.03826431f, 0.02530318f, -0.00524460f, -0.01483445f, 
    -0.01863999f, -0.04933068f, -0.03317286f, 0.01579638f, -0.02899701f, -0.03232079f, 0.04827938f, 0.00241622f, 
    -0.01343459f, 0.04190336f, -0.02256007f, -0.03063412f, -0.05227993f, 0.00647104f, 0.04551706f, -0.05170476f, 
    -0.02953607f, -0.01875246f, 0.04386488f, 0.03480237f, 0.02891871f, 0.03670226f, 0.03355448f, -0.02853967f, 
    -0.03070872f, -0.01246118f, -0.01760152f, 0.04284936f, 0.03052910f, -0.03615503f, 0.00002857f, -0.04986262f, 
    -0.00294884f, -0.04255471f, -0.00529147f, 0.00903652f, 0.00449736f, -0.00452350f, 0.03205146f, 0.04349896f, 
    -0.01948326f, -0.02438035f, -0.04449847f, -0.04816015f, 0.02707001f, -0.00542654f, 0.01768239f, -0.04366466f, 
    0.00386782f, -0.03771513f, 0.04112722f, 0.02955325f, -0.02255760f, -0.00561767f, -0.04189089f, 0.04489610f, 
    0.01151398f, -0.01620679f, -0.00521833f, 0.01889090f, 0.00952652f, 0.00896463f, -0.00391352f, -0.01662392f, 
    0.03010829f, 0.03757439f, -0.03572382f, -0.03905701f, -0.02140272f, -0.04149206f, -0.04820411f, -0.01592262f, 
    -0.01456845f, -0.05265212f, -0.03221506f, -0.03403753f, -0.01401607f, -0.02948498f, -0.02563709f, -0.02139602f, 
    -0.01440423f, 0.01120997f, 0.01659740f, 0.01620615f, -0.00595776f, 0.03761197f, 0.04931008f, -0.02897647f, 
    0.00161506f, 0.02589772f, -0.00144355f, -0.03425075f, -0.02418462f, -0.05039351f, 0.02995807f, -0.00068735f, 
    -0.02565203f, 0.00415090f, -0.01117934f, 0.02324051f, 0.04396993f, 0.01317008f, 0.04636854f, -0.02021338f, 
    -0.03572280f, -0.01686525f, 0.01002581f, 0.01787454f, 0.01250162f, 0.01724782f, 0.02887172f, -0.04995501f, 
    -0.02231004f, -0.04821675f, 0.01563137f, 0.01288376f, -0.01988053f, -0.00917620f, -0.01374876f, -0.04810360f, 
    -0.01415139f, -0.00548093f, 0.03117810f, 0.00025229f, 0.01762879f, -0.04802478f, -0.04376315f, 0.00021769f, 
    0.03876498f, 0.03800396f, -0.04073467f, -0.01362150f, 0.01649635f, 0.03953214f, -0.00891279f, 0.05462174f, 
    0.06146549f, 0.04313971f, 0.25089172f, 0.01050117f, 0.11435562f, -0.11454899f, 0.00720671f, -0.13824272f, 
    -0.11541792f, -0.01321896f, -0.07166369f, -0.06808017f, -0.17242754f, -0.02638647f, 0.06183594f, -0.03703472f, 
    0.08895653f, 0.01668128f, 0.05596216f, -0.13163388f, -0.08160249f, 0.21678416f, -0.08318288f, 0.01178364f, 
    -0.07196076f, -0.06231795f, -0.09939427f, -0.10305360f, -0.14358631f, 0.00885894f, -0.07888590f, 0.00727703f, 
    -0.03155771f, -0.13425069f, 0.21051739f, -0.01712589f, 0.00756740f, 0.01540277f, 0.05126422f, 0.04603907f, 
    -0.09165765f, -0.14703637f, 0.00339821f, -0.09671397f, -0.11236259f, 0.12507538f, 0.15241414f, -0.02585996f, 
    -0.53039795f, 0.09667808f, -0.13582510f, -0.02305614f, 0.19293100f, -0.00694036f, 0.12565175f, 0.08411457f, 
    -0.13010843f, -0.04308009f, 0.00328102f, -0.11242827f, 0.08437335f, -0.25863326f, 0.02927223f, 0.06266235f, 
    -0.07888697f, 0.10425594f, -0.04568455f, -0.07646333f, -0.07105333f, 0.05537929f, 0.10707043f, -0.04892635f, 
    0.08132714f, 0.02325694f, 0.12208420f, 0.00249254f, -0.01566976f, 0.05977025f, 0.07383011f, 0.01334330f, 
    0.01707344f, 0.00448264f, -0.08990538f, -0.03729526f, -0.20989799f, -0.19139352f, 0.03271187f, -0.04127819f, 
    0.11564928f, 0.14883500f, -0.11314054f, 0.05161805f, 0.01283499f, -0.12566532f, -0.05388954f, 0.02165239f, 
    0.22537938f, -0.18009633f, -0.06432585f, 0.21464868f, 0.05865418f, 0.01201989f, 0.02225848f, -0.13628104f, 
    -0.11662957f, 0.09508791f, 0.15478595f, -0.06776673f, 0.01392656f, -0.28677073f, 0.12107140f, -0.27316564f, 
    -0.04668041f, -0.00782918f, 0.04216991f, 0.01767520f, 0.21822715f, -0.03684836f, 0.00806252f, 0.06313524f, 
    -0.19988413f, -0.00289435f, -0.12445048f, -0.05052711f, 0.05116744f, 0.00565949f, 0.07475583f, -0.04206312f, 
    0.10578196f, 0.05249906f, -0.09011303f, 0.22284406f, -0.16834784f, -0.18856971f, 0.00138600f, -0.14110190f, 
    -0.18538678f, -0.03654665f, -0.01325923f, 0.03060183f, -0.06552196f, 0.04978469f, 0.04305755f, -0.01629146f, 
    0.34863272f, 0.14903298f, -0.10743739f, 0.15602925f, 0.09266505f, 0.17409301f, 0.10969480f, -0.02887651f, 
    -0.01992222f, 0.03557761f, 0.04061518f, -0.14796478f, 0.22293819f, -0.14421204f, 0.01431898f, -0.22865357f, 
    0.14364015f, 0.05840595f, 0.08280915f, 0.02422716f, 0.14806692f, 0.06917085f, -0.03218019f, 0.03824197f, 
    0.36290663f, -0.08056061f, 0.09183714f, 0.11374503f, -0.04872960f, 0.08264345f, 0.03986757f, 0.14542650f, 
    0.09955589f, 0.00223102f, 0.01172809f, -0.05822859f, -0.36769047f, 0.15786082f, 0.09199100f, 0.02810506f, 
    -0.09144097f, 0.02073414f, 0.05085719f, -0.05561507f, -0.07764868f, -0.02052494f, -0.15723035f, 0.00462678f, 
    -0.33690807f, 0.03315404f, 0.17785780f, 0.05822637f, 0.00675312f, -0.07287481f, -0.03722536f, 0.17067017f, 
    0.06433775f, 0.07146552f, 0.01069388f, 0.09292792f, -0.00036928f, 0.11287494f, 0.11765811f, 0.15530387f, 
    -0.06593148f, 0.07438146f, 0.02477639f, 0.25492236f, -0.16706860f, 0.06569777f, -0.13024037f, -0.06392165f, 
    0.23375596f, 0.09269435f, 0.08741046f, 0.02097545f, -0.14790353f, 0.02678993f, -0.20469630f, 0.09430188f, 
    0.04580726f, -0.07679845f, 0.14429450f, 0.14482182f, -0.15504840f, 0.21732081f, -0.07065230f, 0.15975639f, 
    0.08599298f, 0.02101744f, 0.17996843f, 0.04882358f, -0.02647923f, 0.06800804f, -0.13281789f, 0.08807121f, 
    0.07627577f, -0.23970988f, 0.15869872f, 0.09557375f, -0.11270810f, 0.13401836f, 0.22874622f, -0.07561750f, 
    0.05367427f, 0.00584242f, -0.21831284f, 0.00274930f, -0.02313641f, -0.13390964f, 0.26753077f, 0.08121572f, 
    0.07528496f, -0.05727404f, 0.07684746f, 0.06454109f, 0.06670649f, -0.03665096f, 0.15011972f, 0.02178886f, 
    -0.12297112f, 0.03881259f, 0.32483742f, -0.08820837f, 0.00062926f, 0.05447187f, -0.01502353f, 0.06092371f, 
    0.10674498f, 0.01503605f, 0.06894914f, 0.05023796f, -0.17114377f, 0.15872893f, 0.09127508f, -0.24966614f, 
    0.14956543f, 0.03076159f, 0.11727927f, -0.07824288f, 0.09407099f, -0.03971691f, 0.09069005f, -0.14171971f, 
    0.08874842f, 0.30949676f, 0.05034888f, 0.04717048f, 0.09258412f, 0.15985636f, -0.03543537f, -0.10743040f, 
    -0.03121398f, 0.01903972f, -0.05180747f, 0.06232571f, -0.08312801f, 0.11866484f, 0.36750391f, 0.05744132f, 
    -0.07590932f, 0.09557325f, 0.12403244f, -0.01803650f, 0.03668826f, -0.09064363f, 0.01891624f, 0.07645628f, 
    -0.04690570f, 0.09166810f, 0.00455535f, -0.05004823f, 0.08655624f, 0.00802965f, -0.09869494f, 0.02607795f, 
    -0.13589165f, 0.07597264f, -0.04722025f, 0.11473627f, 0.49017686f, -0.06669119f, 0.25182828f, -0.02327596f, 
    -0.06508044f, 0.00050638f, 0.03591929f, -0.01395237f, 0.11432001f, -0.09728806f, 0.11857774f, 0.04588950f, 
    0.78275752f, 0.10284699f, 0.08544350f, -0.12197462f, 0.05504299f, 0.08856799f, 0.21320921f, 0.11382905f, 
    -0.08500085f, 0.01606255f, 0.06733306f, 0.05452316f, 0.23293318f, 0.24770685f, -0.15768509f, 0.01266362f, 
    -0.05812804f, 0.06898276f, 0.07331049f, 0.08574034f, -0.09657624f, -0.00143884f, 0.02610501f, 0.08535415f, 
    -0.09823190f, 0.16774830f, 0.01120899f, -0.00305918f, 0.23907726f, -0.14060675f, 0.06855752f, 0.07129786f, 
    0.02665276f, 0.04210234f, -0.02301471f, -0.11139866f, -0.02130606f, 0.09876822f, -0.08186550f, -0.36949104f, 
    -0.11584168f, 0.11062559f, 0.09683137f, -0.07571317f, -0.14628315f, 0.22201861f, -0.10210767f, 0.10762279f, 
    -0.42383122f, -0.24936570f, 0.30896169f, 0.43949124f, -0.28887537f, -0.16996577f, -0.03146015f, 0.03242689f, 
    -0.05073121f, -0.09867405f, -0.02879283f, 0.06838140f, -0.09478644f, -0.04865037f, -0.09394320f, 0.07131828f, 
    0.13261934f, -0.07432377f, -0.06690606f, -0.03553254f, -0.01954487f, 0.14697675f, 0.00639642f, 0.03241974f, 
    -0.42279202f, 0.08134001f, -0.07858036f, -0.02184376f, 0.21341555f, 0.20508395f, -0.06846263f, 0.01062616f, 
    -0.07295091f, -0.01140413f, 0.12444756f, -0.15363826f, -0.32314301f, 0.19157280f, 0.20898229f, 0.03958885f, 
    0.11349812f, -0.06216396f, -0.07014353f, -0.12352051f, -0.03167313f, 0.15025753f, -0.08485968f, 0.16004866f, 
    -0.00405026f, 0.02266276f, 0.09239994f, -0.06298290f, -0.18463588f, 0.00634289f, 0.16796897f, -0.08548751f, 
    0.03980317f, 0.03494518f, 0.07448053f, -0.20564027f, -0.20290534f, -0.05309214f, 0.00295885f, -0.10806511f, 
    0.08859272f, 0.32721651f, -0.04974950f, 0.10859369f, 0.11639302f, -0.16075554f, 0.02288040f, -0.23946097f, 
    0.01977358f, 0.08104191f, 0.07076216f, -0.11975428f, 0.08728984f, -0.10553769f, 0.04610619f, -0.04899211f, 
    0.02910040f, 0.20040660f, 0.34697005f, 0.22168058f, -0.16048901f, -0.36026949f, -0.02388625f, 0.25489905f, 
    -0.04799461f, 0.05701253f, 0.08317072f, 0.11073828f, -0.01924807f, -0.26529437f, -0.10214258f, 0.01793173f, 
    -0.11285018f, 0.17014037f, -0.01347759f, 0.06907705f, 0.04890488f, 0.05923882f, 0.02422406f, -0.05568462f, 
    -0.05320974f, 0.01204907f, 0.03187180f, 0.17657264f, 0.23235671f, 0.12096165f, -0.11453743f, -0.07670635f, 
    0.03697177f, -0.05110062f, 0.25391135f, 0.09029650f, 0.07330489f, -0.11973963f, -0.00962032f, 0.08198243f, 
    -0.65397000f, 0.16540149f, -0.31493598f, 0.00837864f, 0.20538954f, -0.07997658f, 0.16719051f, -0.02712482f, 
    0.10488509f, -0.05019270f, 0.18130881f, -0.00934526f, -0.27577659f, -0.09738997f, -0.23476881f, 0.05539980f, 
    0.16724199f, 0.14013174f, 0.02124554f, -0.03483818f, 0.08830920f, 0.04761262f, -0.03072167f, 0.05152524f, 
    0.45691073f, 0.21743786f, 0.12226745f, 0.05770464f, 0.12347347f, 0.10259092f, 0.05871468f, -0.06603659f, 
    -0.00166680f, 0.09555880f, 0.05184305f, -0.08124250f, -0.50284129f, -0.02243047f, -0.08150138f, -0.08632880f, 
    0.22093561f, -0.05117400f, 0.11883877f, 0.15246579f, -0.08838871f, 0.18300994f, 0.14279988f, 0.02645783f, 
    -0.41263357f, -0.02438046f, 0.04185599f, 0.03361443f, 0.09345000f, -0.13508475f, -0.04425490f, 0.04236354f, 
    -0.10247631f, -0.03504334f, 0.15273735f, -0.00005458f, 0.23293126f, -0.11541048f, 0.04919626f, -0.08659554f, 
    -0.24189721f, -0.06785139f, 0.00804048f, 0.00110516f, 0.06290355f, 0.04430659f, -0.12191651f, -0.12949644f, 
    0.22160508f, 0.07251407f, 0.15676461f, 0.09978639f, -0.07278680f, -0.00394842f, -0.01810235f, 0.15391824f, 
    0.04333095f, 0.02572917f, 0.11551169f, 0.09197278f, 0.30449483f, 0.46947104f, 0.10722097f, 0.17123517f, 
    -0.06187245f, 0.15405321f, 0.07827175f, 0.09293517f, -0.03698914f, 0.10296126f, -0.00231454f, 0.12766449f, 
    0.22149272f, 0.19067663f, 0.12619622f, 0.12010141f, -0.05804217f, -0.18206726f, -0.07589012f, 0.03343437f, 
    -0.13809451f, 0.06496593f, 0.16429706f, -0.00720431f, 0.35348293f, 0.34593636f, 0.08513574f, 0.10272105f, 
    -0.08258531f, 0.06079715f, 0.14696227f, -0.01295166f, 0.10206413f, 0.09900677f, -0.11999662f, 0.04388730f, 
    -0.08528686f, 0.05199804f, 0.12526859f, -0.00178973f, 0.06559375f, 0.17032024f, 0.22000916f, 0.05179720f, 
    0.11612101f, 0.12856323f, -0.17581522f, -0.02180394f, 0.12048222f, 0.20010814f, 0.08258447f, 0.03762784f, 
    0.08466002f, -0.00228469f, 0.10259028f, -0.00309923f, 0.02166772f, -0.03381171f, -0.17064206f, 0.05314871f, 
    0.30453491f, 0.04633285f, 0.17441720f, 0.05148004f, -0.01858266f, 0.03693199f, 0.04758801f, 0.21298075f, 
    0.05164972f, -0.01133445f, 0.03900023f, -0.06163112f, 0.48713508f, 0.23100932f, -0.12392340f, -0.18889783f, 
    -0.01206218f, 0.12960771f, 0.06785798f, -0.05958690f, 0.15617689f, 0.01244673f, 0.10620042f, -0.05491220f, 
    -0.01691316f, 0.01056507f, 0.25990298f, 0.18999526f, -0.14960712f, 0.05031993f, -0.18723987f, -0.23821490f, 
    0.12043575f, -0.03602725f, -0.06716597f, 0.06613690f, 0.19143301f, 0.28063020f, 0.15010487f, -0.05757992f, 
    -0.14727002f, -0.08425671f, 0.07533745f, 0.12238216f, 0.15954897f, 0.08608560f, 0.08668117f, -0.07201892f, 
    -0.16589583f, 0.02405071f, 0.28719321f, 0.29197910f, -0.09898782f, -0.01043088f, 0.03278051f, 0.10254762f, 
    0.02358142f, -0.13216326f, -0.01242522f, 0.14778739f, -0.44177818f, -0.01267014f, 0.01742754f, -0.10613202f, 
    0.22388849f, 0.23128134f, 0.06717490f, 0.07567023f, -0.08464199f, -0.04725655f, 0.02511754f, 0.02698184f, 
    0.27747557f, -0.17307226f, 0.23693666f, -0.00491292f, -0.07819431f, 0.10724236f, 0.02065085f, 0.03453504f, 
    0.09596065f, -0.07119934f, -0.09146735f, 0.09660964f, 0.09359738f, -0.06895547f, -0.13868943f, 0.08373966f, 
    0.12312949f, -0.10043067f, 0.09502350f, -0.00488574f, -0.01996683f, 0.17644207f, 0.14886390f, 0.00310163f, 
    0.30262578f, -0.06393866f, 0.32729015f, 0.19058974f, 0.01200498f, -0.05848105f, 0.01520393f, -0.04853207f, 
    0.04713761f, -0.02934247f, -0.06527220f, -0.13478336f, -0.12307379f, -0.11069763f, -0.18111596f, 0.13632829f, 
    0.06279377f, 0.12038089f, -0.00384740f, -0.04486452f, -0.08062140f, 0.03334928f, -0.01886570f, 0.02533421f, 
    0.24835071f, 0.11221100f, 0.00479141f, 0.48248243f, -0.11897106f, 0.02529829f, 0.04558304f, 0.02985505f, 
    0.08645838f, 0.01843328f, 0.09469438f, 0.10799550f, 0.14168388f, 0.25917822f, 0.09393346f, 0.08963463f, 
    -0.05366307f, 0.00597687f, -0.02247452f, -0.01839874f, -0.07610152f, 0.08838955f, 0.10478163f, -0.02915547f, 
    -0.13233432f, 0.37077472f, 0.07195929f, 0.20272501f, -0.10273968f, 0.01714560f, 0.08274487f, 0.04291407f, 
    0.02998398f, 0.13806821f, -0.13196538f, -0.03076763f, -0.04329512f, 0.18114434f, 0.05551940f, -0.15517598f, 
    0.06010497f, 0.04776733f, 0.08106949f, 0.09662547f, 0.00696204f, -0.02141310f, -0.05076547f, -0.04990332f, 
    0.25625819f, -0.11155415f, 0.10553339f, 0.07281331f, -0.03017971f, -0.06559515f, 0.04550878f, -0.12343684f, 
    -0.01693972f, -0.08356448f, -0.03992924f, 0.15544383f, -0.00659954f, -0.06237349f, 0.01963422f, -0.20472275f, 
    -0.00678618f, -0.16812357f, 0.06830125f, 0.08174124f, 0.08015843f, 0.11423001f, 0.16262583f, -0.03099129f, 
    0.02198603f, -0.05182282f, 0.06088974f, 0.20638815f, 0.08345314f, 0.10394110f, -0.03146210f, -0.02970256f, 
    0.00641794f, 0.05970439f, -0.01710954f, -0.03811760f, 0.32523909f, 0.21432087f, 0.12502429f, 0.33403051f, 
    0.05554489f, -0.18182126f, 0.00836856f, -0.03468957f, -0.00644214f, 0.04432083f, -0.08368100f, 0.03312686f, 
    -0.15135896f, -0.02020372f, 0.16195805f, -0.29463050f, 0.12593928f, 0.08208513f, -0.15022384f, 0.09201698f, 
    0.09260517f, -0.05447452f, -0.09092364f, 0.00049276f, 0.01073266f, 0.38647854f, 0.07320089f, 0.06935543f, 
    -0.06547033f, -0.01783456f, 0.09273289f, -0.14636342f, -0.13351984f, -0.02202005f, 0.17877030f, 0.05552160f, 
    0.02891460f, -0.03317956f, 0.19757478f, 0.13340439f, -0.09675338f, -0.07007536f, -0.03698802f, -0.04817056f, 
    -0.01179435f, 0.18115635f, -0.05299722f, -0.08011795f, 0.25330737f, 0.21470506f, 0.20406640f, 0.00289780f, 
    -0.00759244f, 0.02502462f, -0.04226035f, -0.13088274f, 0.07009815f, -0.00783471f, 0.06775584f, 0.08019137f, 
    -0.32220995f, -0.12360902f, 0.11511156f, 0.00437821f, 0.16289413f, -0.12274981f, -0.13304403f, 0.11997160f, 
    0.04399488f, 0.10692589f, -0.00209669f, 0.03559541f, 0.04217173f, 0.16960509f, 0.32951126f, 0.18752949f, 
    0.05672472f, 0.04519834f, 0.11049854f, -0.03831794f, -0.05061680f, -0.04564431f, 0.09489235f, -0.16097881f, 
    0.04411143f, 0.25294748f, 0.09096154f, -0.11432305f, 0.05756266f, 0.07642592f, -0.04651167f, -0.06565082f, 
    -0.16687001f, 0.08047426f, -0.02925656f, 0.24184959f, -0.18535352f, -0.25126013f, -0.14022170f, 0.10898230f, 
    0.15574864f, -0.02573252f, -0.06161821f, 0.08321955f, 0.16498229f, 0.03993791f, 0.08474830f, 0.10030265f, 
    0.11086322f, -0.16419746f, -0.24828075f, -0.03271117f, 0.03278513f, 0.09757490f, -0.16680655f, -0.03193985f, 
    0.16531013f, 0.06612047f, -0.08459212f, -0.08256778f, -0.22483838f, -0.14031616f, 0.01912386f, 0.05853863f, 
    0.14137819f, -0.00649912f, 0.03024938f, -0.19680247f, 0.05647500f, -0.11779575f, 0.09359349f, 0.05685860f, 
    -0.19650112f, -0.37901288f, -0.21954587f, -0.14184101f, 0.14929436f, -0.09874389f, 0.13747205f, -0.06927867f, 
    0.02598721f, 0.11828188f, -0.06666453f, -0.17873597f, -0.25512585f, -0.30199283f, 0.05458555f, 0.01428060f, 
    0.16233657f, 0.02856754f, 0.05613792f, -0.04089773f, 0.08977009f, 0.08073915f, 0.13119465f, 0.06270511f, 
    -0.19467179f, -0.12318987f, 0.00600492f, 0.10595697f, 0.21391459f, -0.09734687f, -0.08063341f, 0.11696342f, 
    -0.11168541f, 0.03323375f, 0.16380151f, 0.00650791f, -0.31612271f, 0.10396192f, -0.06292475f, -0.02076178f, 
    0.09584709f, 0.08598202f, -0.05759881f, -0.07017215f, 0.12594175f, -0.04908246f, -0.02921288f, 0.16851366f, 
    0.03159964f, -0.13319431f, -0.26594689f, -0.00371301f, 0.22815734f, -0.01526091f, -0.05031101f, -0.10742099f, 
    0.02171678f, 0.00207802f, -0.13906901f, 0.05443355f, -0.02807799f, -0.11827681f, -0.06524457f, 0.12469216f, 
    0.05739056f, -0.09090070f, 0.09150679f, 0.14289245f, 0.06245195f, 0.05658748f, -0.04005536f, 0.14178590f, 
    -0.01337875f, -0.37477145f, -0.06551225f, 0.21586429f, -0.09334154f, -0.11257927f, 0.01278783f, -0.00681059f, 
    -0.10987405f, 0.06068068f, 0.11164436f, 0.19217256f, -0.05756898f, -0.04831171f, -0.24570093f, -0.12447824f, 
    0.14620408f, -0.04185855f, -0.13246182f, -0.10489164f, -0.13018221f, -0.00551862f, 0.11167973f, -0.01480830f, 
    0.21836254f, 0.06259473f, 0.13097033f, 0.23214085f, -0.00121871f, -0.07234506f, -0.07028627f, -0.02164406f, 
    0.12468737f, -0.07891185f, 0.09487499f, -0.10635331f, -0.23453707f, 0.32649490f, 0.06473897f, 0.08918706f, 
    -0.03912357f, 0.01197297f, 0.00766819f, 0.13172245f, -0.06747762f, -0.01439275f, -0.00186958f, -0.05684605f, 
    0.32979673f, 0.19559935f, -0.20746619f, 0.14992672f, 0.13522442f, -0.19551358f, 0.00144294f, -0.06309910f, 
    0.06797082f, -0.07505964f, -0.06273599f, -0.05973946f, 0.09730078f, 0.17183372f, -0.15020877f, 0.11284529f, 
    -0.02554620f, 0.04856546f, -0.02941541f, -0.08321293f, 0.00023311f, 0.04847683f, -0.04630928f, -0.05178551f, 
    0.06211502f, -0.15083824f, 0.00593161f, 0.04347421f, -0.05204454f, 0.10030810f, -0.07152355f, 0.03474368f, 
    0.11529704f, 0.09690240f, 0.01160974f, -0.04975511f, 0.10947521f, 0.31117079f, 0.10515430f, 0.50729728f, 
    0.02457515f, 0.07382987f, -0.04847518f, -0.12175772f, -0.06680759f, -0.12840573f, 0.09384926f, -0.24922577f, 
    0.18550284f, -0.39176020f, -0.07495085f, 0.16155894f, 0.02097381f, -0.05245084f, 0.05216203f, 0.02793404f, 
    -0.06879888f, -0.16190597f, 0.03399593f, -0.08610592f, -0.26538816f, -0.09754415f, -0.11193080f, 0.28756136f, 
    0.00162024f, 0.17258625f, 0.02179073f, -0.09410166f, -0.01834415f, 0.12466463f, 0.03722423f, 0.00616656f, 
    -0.14780939f, 0.22670929f, -0.00432599f, -0.08303743f, 0.14800224f, -0.02061347f, 0.08075631f, 0.00046921f, 
    -0.10751877f, 0.00176697f, -0.00667575f, -0.10517988f, -0.19004883f, 0.07533176f, -0.10869579f, 0.02842886f, 
    -0.05708162f, -0.12873495f, 0.06253649f, -0.11391393f, -0.02575846f, 0.07147665f, -0.05024075f, -0.15056650f, 
    0.52451909f, 0.07238069f, 0.16987324f, 0.01131964f, -0.10172310f, 0.07296581f, 0.01791085f, 0.01515109f, 
    -0.10759553f, 0.08976826f, 0.14167270f, 0.12231547f, -0.07905417f, 0.01964213f, -0.07579497f, 0.09000004f, 
    -0.00021428f, 0.07828470f, -0.05119686f, -0.00344038f, 0.02925482f, -0.00340698f, 0.03718369f, -0.00054039f, 
    -0.12714419f, 0.09892177f, -0.24080481f, -0.02802796f, -0.03089809f, 0.10266741f, 0.05475171f, 0.02082708f, 
    0.06438106f, 0.22526819f, 0.12637590f, 0.10699484f, 0.03567713f, -0.16114624f, -0.12843511f, 0.20415686f, 
    -0.10454877f, -0.11514379f, 0.06123634f, -0.02949068f, 0.04176166f, -0.03840600f, -0.14845397f, 0.04872023f, 
    -0.22703500f, -0.10676917f, -0.18143357f, -0.01161579f, -0.04401448f, -0.16796562f, 0.04747100f, -0.04437127f, 
    -0.06332750f, 0.17946616f, -0.10052251f, -0.04746704f, -0.10060096f, 0.20384727f, 0.10931610f, 0.14987276f, 
    0.15879385f, -0.05922149f, -0.00762834f, -0.14273673f, 0.08224806f, 0.14139779f, 0.14160094f, 0.07491083f, 
    -0.08322070f, 0.21589911f, -0.06723304f, -0.03525165f, 0.11391531f, -0.01266793f, -0.06434723f, -0.07588112f, 
    0.04874757f, 0.05465355f, -0.11525526f, -0.01576789f, -0.16088748f, -0.26269090f, -0.07107171f, 0.05136534f, 
    0.00484619f, -0.09945084f, 0.01838182f, -0.02055055f, -0.03996615f, 0.00167553f, -0.01070266f, -0.02161853f, 
    0.21884739f, -0.01339935f, -0.31874609f, -0.02784315f, 0.11554844f, -0.09491817f, -0.00792315f, -0.00884355f, 
    0.00502354f, -0.11406052f, -0.08217651f, 0.03627326f, -0.10837655f, 0.27232474f, -0.10768279f, 0.08046529f, 
    0.00457516f, 0.05875352f, 0.14679572f, 0.03526178f, 0.12874191f, 0.28795198f, -0.03187617f, -0.18316180f, 
    0.20370576f, -0.20765936f, 0.00129989f, 0.21046303f, 0.02036254f, 0.03781242f, -0.02609654f, 0.05850188f, 
    0.05400470f, 0.22022028f, -0.02582427f, 0.18156610f, 0.07347887f, 0.08779681f, 0.26571363f, -0.35812804f, 
    -0.02576354f, -0.01929911f, 0.17254084f, -0.02288402f, 0.08221306f, 0.00059430f, -0.03063601f, 0.09795262f, 
    0.25108400f, 0.02369243f, -0.00371911f, -0.10832259f, -0.00563857f, 0.05762516f, -0.08890139f, -0.03460619f, 
    0.01942149f, 0.03886891f, -0.08835068f, -0.04635339f, 0.06539306f, 0.01553110f, 0.05243621f, -0.00668534f, 
    -0.12646785f, 0.12285608f, 0.01103517f, -0.10649403f, -0.00924227f, 0.10093553f, 0.00486996f, -0.01164605f, 
    0.02911554f, -0.09268733f, -0.35170960f, -0.06055445f, -0.02113505f, -0.21233979f, 0.04409721f, 0.03445096f, 
    -0.12370274f, 0.00256789f, 0.10756686f, -0.04086728f, 0.04745132f, 0.19164008f, -0.17452849f, -0.14081538f, 
    -0.04126317f, -0.01695017f, -0.04211667f, -0.00248289f, -0.08507156f, 0.05308583f, 0.02133093f, 0.04806525f, 
    0.09724700f, 0.01334264f, -0.16126806f, 0.03447149f, 0.13062271f, 0.00710911f, 0.04446520f, -0.18775754f, 
    0.04717835f, -0.03077363f, -0.04905621f, 0.07728520f, -0.10230824f, 0.04554518f, 0.05049118f, -0.00459737f, 
    0.06761008f, -0.12154869f, 0.15186840f, -0.06871253f, -0.15867609f, 0.10807584f, -0.15309636f, 0.06767418f, 
    -0.03311988f, 0.12860104f, -0.01197824f, 0.08663186f, 0.10606812f, 0.02333526f, 0.06779227f, -0.02756041f, 
    0.05789948f, -0.03105011f, 0.08257467f, -0.16081166f, -0.05764743f, 0.47741717f, -0.25347748f, -0.16565609f, 
    0.28320301f, 0.07971201f, 0.07814756f, 0.04205374f, 0.13299784f, -0.03949622f, -0.05973566f, -0.00937032f, 
    0.25992256f, 0.05915127f, -0.27757788f, 0.05450983f, -0.16142948f, -0.00789808f, -0.01889415f, 0.04147870f, 
    0.10877369f, -0.05216857f, 0.02795521f, 0.12809061f, 0.09871905f, -0.08826145f, -0.00991717f, -0.09730068f, 
    -0.07512727f, -0.08243103f, -0.06927169f, -0.05442788f, 0.17192370f, 0.01747412f, -0.06054415f, 0.07194419f, 
    -0.32570347f, 0.10203794f, -0.03120346f, 0.18167928f, -0.05360261f, -0.05243499f, 0.10152390f, 0.03836669f, 
    -0.01730785f, -0.02981107f, -0.15402856f, -0.14154443f, 0.16751201f, 0.16227001f, 0.25661656f, -0.04891010f, 
    0.15107943f, 0.18755122f, -0.01066697f, -0.08696242f, 0.06899040f, 0.02930861f, -0.05147440f, -0.03903130f, 
    -0.04062708f, -0.16924916f, 0.11941630f, -0.04745859f, 0.01435852f, 0.14980192f, -0.03084235f, 0.00856536f, 
    0.05365422f, -0.14268164f, 0.09294827f, 0.12205659f, 0.57587349f, 0.42901051f, 0.20678601f, -0.14691828f, 
    0.14746077f, -0.03080207f, 0.03029037f, 0.21511291f, 0.02582792f, 0.10709859f, 0.04295982f, 0.06153766f, 
    0.52168530f, -0.10551164f, 0.00505426f, 0.24231730f, -0.11994755f, 0.01392144f, -0.13221301f, -0.13325144f, 
    -0.04687190f, 0.02196529f, 0.10518638f, -0.06572045f, 0.22971679f, 0.02510742f, -0.06369944f, 0.03987925f, 
    0.27201051f, 0.17829770f, 0.06514757f, -0.00740309f, 0.03569484f, -0.05104016f, -0.10309393f, -0.06153353f, 
    0.47136125f, -0.32824811f, -0.23154658f, -0.34588373f, 0.15491202f, 0.08882291f, 0.04818942f, -0.06859665f, 
    0.07713025f, 0.05043470f, 0.05259655f, -0.05495397f, -0.07681900f, -0.17116877f, -0.00378910f, 0.29712418f, 
    -0.00017070f, 0.08916986f, 0.03948564f, 0.00023856f, 0.09073731f, -0.14064458f, 0.06996889f, 0.22388402f, 
    0.35530502f, 0.23494413f, 0.13780104f, 0.03710861f, 0.05169082f, 0.04086369f, -0.07184020f, 0.14189899f, 
    0.15787296f, -0.02210374f, -0.07557687f, 0.05290140f, 0.42085248f, -0.17533807f, -0.14065231f, -0.02992421f, 
    -0.10061170f, -0.02617474f, 0.22012876f, 0.20132662f, 0.07457004f, -0.02235535f, 0.05590758f, -0.07567156f, 
    0.21428052f, -0.16007574f, 0.03150268f, -0.00754820f, 0.04242641f, 0.09894855f, -0.10687587f, 0.00384007f, 
    -0.00839326f, -0.06370470f, 0.04601344f, 0.05123849f, 0.24343002f, 0.13576326f, -0.07405751f, 0.03514748f, 
    0.01532141f, -0.01393991f, -0.11310184f, 0.08409589f, 0.02740810f, 0.23482808f, 0.03010803f, 0.06109303f, 
    0.17815623f, 0.01468650f, -0.19501282f, 0.05062334f, -0.02120821f, 0.15211712f, 0.03173958f, 0.07648107f, 
    0.08971071f, 0.05867332f, -0.05890635f, -0.01888208f, -0.21483140f, 0.02620129f, -0.02778934f, -0.03259027f, 
    -0.06935737f, -0.11462847f, -0.03078536f, -0.09908199f, 0.09400191f, 0.30280757f, 0.15378751f, 0.05012203f, 
    -0.16877110f, -0.18772514f, -0.04624252f, -0.15319601f, -0.01151556f, 0.10229912f, -0.04972531f, -0.01972772f, 
    -0.01339259f, -0.02307420f, 0.01742657f, -0.04276658f, -0.06056663f, 0.49074015f, 0.07890444f, -0.07590083f, 
    0.12780245f, 0.04300017f, -0.05081083f, -0.02282710f, -0.18058093f, 0.26563972f, 0.07753335f, 0.01250746f, 
    0.74672580f, -0.39675015f, 0.00724239f, 0.26225185f, 0.04440986f, 0.17721847f, -0.17584626f, 0.05503822f, 
    -0.02449517f, 0.01013386f, 0.02440890f, 0.02078903f, -0.23070069f, -0.01840478f, 0.13836545f, 0.21377546f, 
    0.00467190f, 0.03972144f, -0.00724447f, 0.00075550f, -0.05773545f, 0.01201008f, -0.13102593f, -0.10523272f, 
    0.03066929f, -0.00546702f, -0.13025013f, -0.16708818f, -0.03298955f, -0.02630489f, -0.02923883f, -0.05024494f, 
    0.14572483f, -0.04690168f, 0.05347257f, 0.07534864f, 0.48643500f, -0.07365999f, -0.08055638f, 0.29994607f, 
    0.06622417f, 0.04140888f, -0.01640759f, 0.02765984f, -0.06914679f, 0.00304360f, 0.09320280f, 0.04883931f, 
    0.30314729f, -0.21100655f, -0.18932559f, -0.08133819f, -0.03807313f, 0.01657972f, 0.04156924f, -0.12671582f, 
    -0.11497305f, 0.02659953f, -0.11073542f, 0.03292309f, -0.05567320f, 0.37788042f, 0.14891559f, -0.23516479f, 
    -0.04103139f, 0.03144052f, 0.19231895f, 0.04051262f, -0.13042279f, -0.07305807f, 0.18368989f, 0.11276606f, 
    0.02481593f, 0.21481681f, 0.06650197f, -0.02688611f, 0.15890136f, 0.16805635f, 0.05857096f, -0.08526475f, 
    -0.06102844f, 0.00165171f, -0.09273354f, 0.03655276f, -0.37883171f, 0.09430179f, 0.21370295f, -0.17057893f, 
    -0.06316334f, 0.00323864f, 0.10456999f, 0.02922891f, 0.03688531f, 0.01236882f, 0.10908817f, 0.00336940f, 
    -0.25428510f, 0.07205766f, 0.10596824f, -0.18508925f, 0.08104917f, 0.20593296f, 0.17346780f, -0.14901611f, 
    -0.10244161f, -0.01171050f, -0.00922148f, -0.02720726f, -0.26214772f, -0.00176270f, 0.14011990f, 0.02394024f, 
    0.00650349f, 0.08892825f, -0.08059311f, -0.00048690f, -0.06886508f, -0.09153864f, -0.01660454f, -0.10527161f, 
    0.30735224f, 0.25086340f, 0.00114028f, -0.17564367f, 0.15043639f, 0.02923012f, -0.06285075f, -0.07366845f, 
    0.01805878f, 0.07971999f, 0.03649279f, 0.00008728f, 0.07069512f, 0.30203199f, 0.00022690f, 0.08274362f, 
    0.12360705f, -0.03950457f, 0.04631117f, 0.01502702f, -0.04191346f, 0.10030960f, 0.13878524f, 0.05115611f, 
    -0.19731914f, 0.38974553f, 0.00667282f, -0.19388270f, 0.05219178f, 0.04564955f, -0.11388605f, -0.08281616f, 
    -0.10263407f, -0.04663043f, 0.07295546f, 0.03137621f, 0.10504404f, 0.11476985f, -0.32009050f, 0.17145678f, 
    0.13397281f, 0.05945656f, -0.20991348f, -0.02361906f, -0.06507920f, -0.11311129f, -0.05061556f, 0.14211750f, 
    -0.17144863f, -0.01251879f, -0.12446925f, -0.24261786f, -0.02909880f, 0.13175583f, 0.02652331f, -0.03363688f, 
    -0.07171001f, 0.05090745f, -0.06314769f, 0.03019000f, 0.40982422f, -0.16584353f, -0.00480695f, 0.04448161f, 
    0.08122333f, 0.10426160f, 0.03519488f, 0.00859257f, 0.02503955f, -0.00504399f, 0.03151086f, -0.00912949f, 
    0.02319275f, -0.25364652f, -0.28769624f, -0.12669452f, 0.01793853f, 0.02444917f, 0.12218677f, -0.00203489f, 
    0.00931129f, 0.05189091f, -0.07460321f, 0.03446433f, 0.18302098f, 0.03945798f, 0.08492105f, 0.14486112f, 
    0.11534280f, -0.06357412f, -0.03657417f, -0.09143775f, 0.07522254f, 0.19378200f, 0.17932177f, 0.04754845f, 
    -0.32667431f, -0.04304648f, 0.10463846f, -0.17599401f, 0.15366425f, -0.04030129f, 0.00375911f, 0.02585413f, 
    -0.07962706f, -0.04443160f, 0.07276887f, 0.02255760f, 0.16264649f, 0.36291444f, 0.48880035f, -0.05434994f, 
    -0.02001684f, -0.03561583f, -0.08244038f, 0.31985110f, 0.04153381f, 0.07605374f, 0.04538535f, 0.06123004f, 
    0.24485114f, -0.16384849f, -0.17467381f, 0.04187362f, -0.01017921f, 0.14941320f, -0.01374056f, -0.01535127f, 
    -0.01820009f, -0.06193947f, -0.00459774f, 0.25619745f, -0.35457316f, 0.03702091f, 0.33703080f, 0.15581812f, 
    0.28856578f, 0.09452667f, -0.08954709f, 0.16135773f, 0.07471608f, 0.04132777f, 0.07407208f, -0.06757063f, 
    0.03949829f, 0.00784499f, -0.01641418f, 0.01855023f, -0.00105398f, -0.01901602f, -0.04742873f, 0.01351584f, 
    -0.04410093f, -0.01441782f, -0.00517338f, -0.04371207f, -0.04921607f, 0.00386013f, 0.01536810f, 0.01068949f, 
    -0.01087609f, -0.00150875f, -0.04367892f, 0.00941577f, -0.05230778f, 0.02344097f, 0.03628009f, -0.05314317f, 
    0.02289148f, 0.00057591f, 0.03451250f, 0.03007611f, -0.05223692f, 0.03904793f, 0.00688025f, -0.01288514f, 
    -0.01208790f, 0.03856518f, 0.01207869f, 0.01973612f, -0.01770780f, 0.01305723f, 0.00264749f, 0.04209281f, 
    0.03502506f, -0.03437960f, 0.04205785f, -0.00335377f, 0.01562713f, 0.03793838f, 0.02876855f, -0.00639149f, 
    -0.03814961f, 0.01674644f, 0.04999656f, 0.02858020f, -0.04278480f, 0.03196451f, -0.02750359f, 0.02062018f, 
    -0.04958603f, -0.00191706f, 0.00661966f, 0.04608517f, 0.02591379f, 0.00581830f, -0.04783083f, 0.00012679f, 
    -0.04034295f, -0.01708516f, -0.04844760f, 0.04512481f, 0.02364594f, -0.03549682f, -0.01453728f, -0.05195929f, 
    0.00731430f, 0.03761587f, -0.03654697f, -0.00841627f, -0.05767229f, 0.01335770f, -0.04139888f, -0.01249743f, 
    0.03888992f, 0.00730545f, -0.02223604f, -0.03833076f, 0.01444658f, -0.03713412f, -0.02198556f, -0.03870446f, 
    -0.04804334f, 0.01777303f, -0.04429241f, 0.03755714f, -0.00347122f, -0.04846749f, 0.02405781f, -0.05001624f, 
    -0.01620431f, -0.04619683f, -0.03356495f, -0.01331648f, 0.03017151f, -0.03132391f, 0.00915849f, -0.04596368f, 
    0.01639008f, 0.04156980f, 0.00648526f, 0.02620667f, 0.03935111f, -0.02992876f, 0.03039063f, -0.04415596f, 
    -0.03194081f, 0.04331752f, -0.02018070f, -0.04327178f, 0.00128868f, -0.03107264f, 0.03296112f, 0.01588418f, 
    0.02814130f, -0.00703296f, -0.02453681f, -0.01802866f, -0.02012697f, 0.03021006f, 0.04240490f, 0.03131170f, 
    0.01070450f, 0.02605799f, 0.02593349f, -0.02342263f, -0.03064500f, 0.01619718f, -0.02856654f, -0.04608956f, 
    -0.04884150f, 0.00451899f, -0.00796940f, 0.00664155f, 0.02776325f, -0.01067536f, -0.02260309f, -0.05019735f, 
    -0.05006250f, -0.04594900f, -0.02315661f, -0.00572802f, -0.01438490f, -0.02797279f, -0.02629403f, -0.04772554f, 
    0.00779847f, 0.00431663f, 0.00521189f, 0.02390986f, 0.03631749f, -0.03881266f, -0.04134239f, -0.01925310f, 
    0.04234066f, 0.02756757f, 0.01207033f, -0.00578884f, -0.03853029f, -0.04045648f, 0.00748635f, 0.02063476f, 
    -0.00998734f, -0.01458497f, 0.02384550f, -0.02901644f, -0.02874888f, 0.02534255f, 0.02527463f, 0.02851793f, 
    0.01405999f, 0.01745585f, 0.03259508f, -0.00434212f, -0.01578020f, 0.02973302f, 0.04518070f, -0.01928928f, 
    0.00715595f, -0.04763440f, 0.01336536f, -0.01404623f, 0.02258448f, -0.03353504f, -0.04299888f, 0.02600772f, 
    -0.04998528f, 0.01569551f, 0.01062909f, -0.05349910f, -0.04407284f, 0.04024392f, -0.02333050f, -0.02535286f, 
    0.02803001f, 0.02570633f, 0.05201191f, 0.03155394f, -0.00530155f, -0.01672430f, -0.00848457f, -0.02908055f, 
    -0.06050183f, 0.04417478f, -0.05049550f, 0.02388648f, -0.01634494f, -0.04655473f, -0.02250650f, 0.04730887f, 
    0.04248177f, -0.04015647f, 0.02293620f, -0.01798277f, -0.00645952f, -0.03808804f, -0.04596755f, -0.00132924f, 
    0.01935208f, 0.04172992f, -0.01445562f, -0.03239678f, 0.03929140f, -0.00837732f, -0.01965747f, 0.03357541f, 
    -0.02074981f, -0.00056129f, -0.01597954f, -0.05454110f, -0.02019487f, 0.05598941f, -0.04036964f, 0.01130102f, 
    -0.03308327f, -0.03086174f, 0.03882542f, 0.00167619f, 0.04845564f, -0.01591903f, 0.04210584f, 0.04387718f, 
    0.04536838f, -0.04472070f, 0.00889181f, 0.02869628f, -0.05061338f, -0.01449267f, 0.00023352f, -0.01126968f, 
    -0.05426500f, -0.03454385f, 0.01258204f, 0.02107230f, -0.03217108f, -0.02198328f, 0.00791863f, 0.01024999f, 
    0.04269911f, 0.02782427f, 0.00079589f, -0.01729107f, -0.02691858f, -0.01474697f, -0.04499600f, -0.01986463f, 
    -0.00617621f, 0.00964325f, -0.03307561f, -0.03738266f, -0.03100693f, 0.04990285f, -0.00201785f, 0.00658684f, 
    0.03815251f, -0.02195806f, -0.02165536f, -0.05480172f, 0.00872869f, -0.01000802f, 0.04830249f, 0.03881321f, 
    -0.04061736f, 0.02426310f, -0.00518312f, 0.00393538f, 0.00881565f, -0.05124236f, -0.01341311f, -0.02579172f, 
    0.01263637f, -0.01401912f, 0.01579524f, 0.02988793f, -0.02380967f, -0.05031127f, 0.03704200f, -0.03984625f, 
    -0.02341717f, 0.03642287f, 0.00024571f, 0.01564857f, -0.02848704f, -0.03594221f, -0.02414718f, -0.05068675f, 
    0.01304778f, 0.03981561f, -0.02146642f, 0.00035733f, 0.00976766f, -0.05191481f, 0.02399485f, -0.02090034f, 
    -0.01876995f, 0.02961687f, -0.03244643f, -0.02168918f, -0.00007291f, 0.02521213f, 0.04023827f, 0.01975256f, 
    0.03667011f, -0.02502332f, 0.01896313f, -0.04992776f, 0.00291122f, 0.00293802f, 0.01407666f, -0.00975048f, 
    -0.04733733f, 0.03051788f, -0.00121960f, -0.03833203f, 0.00276536f, -0.01993646f, -0.04425756f, 0.00165355f, 
    -0.03648025f, -0.00882331f, -0.04819294f, -0.02540562f, -0.02841119f, 0.01941998f, 0.04131174f, 0.01370393f, 
    0.03874755f, 0.04090108f, 0.01836993f, 0.00657110f, -0.02279487f, 0.04101130f, -0.04337451f, -0.01538722f, 
    0.03386949f, 0.00764279f, -0.04897419f, -0.00199458f, 0.03943418f, -0.03871226f, -0.02940213f, 0.00230740f, 
    -0.03257925f, -0.00283601f, -0.04249546f, 0.01816085f, -0.02058915f, 0.01810559f, -0.04413712f, -0.02528546f, 
    -0.05138749f, 0.01534529f, 0.01905779f, 0.02744906f, 0.03005336f, 0.01223678f, 0.03669060f, 0.03529767f, 
    -0.46949553f, 0.14959064f, 0.06261438f, -0.01214221f, -0.05216364f, 0.01772158f, -0.01259367f, -0.04556645f, 
    -0.03192169f, 0.05923399f, -0.01362855f, -0.01538902f, -0.21113917f, -0.05118148f, 0.07427979f, -0.10998144f, 
    0.08774402f, -0.03640442f, 0.05396187f, 0.00674068f, -0.03479596f, -0.24410908f, -0.01271742f, -0.07095376f, 
    0.23588935f, -0.21203507f, -0.08386702f, -0.02886919f, -0.00752002f, -0.08976284f, -0.09381870f, -0.18868780f, 
    -0.11301216f, 0.19069144f, -0.10935542f, -0.02197448f, 0.33606640f, -0.13370471f, -0.22879878f, 0.05812666f, 
    0.05043303f, 0.00281937f, -0.11330743f, 0.08251557f, -0.01987031f, -0.07084436f, 0.08229566f, 0.01593764f, 
    0.11782816f, 0.27381977f, -0.31346789f, -0.12673967f, -0.05309524f, 0.07556356f, 0.04258531f, 0.11507725f, 
    0.06068800f, 0.07606097f, -0.05160135f, 0.10396945f, -0.39109480f, -0.04027522f, 0.07123853f, 0.16605575f, 
    0.05430459f, 0.11385715f, 0.02820698f, -0.01205748f, 0.01941783f, 0.05700011f, -0.04652822f, 0.09680399f, 
    0.10531159f, -0.20732513f, 0.10120074f, -0.19821273f, 0.01124213f, -0.14043005f, 0.00058543f, -0.10501524f, 
    -0.12421960f, -0.00705369f, -0.18692353f, -0.15001564f, -0.36256716f, -0.33403274f, -0.07878396f, -0.07250901f, 
    -0.07137807f, 0.01447416f, 0.08921798f, 0.08170619f, 0.01605043f, 0.12591743f, 0.05001825f, -0.02666229f, 
    0.12468315f, 0.04646977f, -0.16587611f, 0.11132734f, 0.03416212f, 0.09090557f, 0.00266659f, 0.07107659f, 
    -0.09693878f, -0.08664368f, 0.04412762f, -0.22670926f, 0.37131348f, -0.41079584f, -0.09971132f, -0.01806189f, 
    -0.01292764f, 0.06790484f, -0.14538373f, 0.00127754f, -0.00373588f, -0.04596283f, -0.01511930f, -0.02610874f, 
    -0.33405751f, 0.26983884f, 0.25306123f, -0.37628612f, 0.09562045f, 0.09104334f, 0.07648532f, -0.04717750f, 
    0.04350046f, -0.01173191f, 0.03189055f, 0.04473996f, -0.14092624f, 0.11645652f, 0.03721663f, -0.08849602f, 
    0.05163015f, -0.09749620f, -0.10605018f, 0.18008986f, -0.12174739f, 0.02653023f, 0.12531498f, 0.14109029f, 
    0.23749577f, 0.01945078f, 0.07279470f, 0.33195239f, -0.12846237f, 0.06172175f, -0.01089433f, 0.03990159f, 
    0.06588361f, 0.15879934f, 0.05353589f, 0.03451597f, -0.13993603f, -0.00680639f, -0.07171617f, -0.11953956f, 
    -0.10343328f, -0.03783960f, -0.05307046f, 0.07426063f, 0.09503009f, -0.14211491f, -0.11600552f, 0.06463329f, 
    -0.25845155f, -0.22515088f, 0.09301207f, -0.06216943f, -0.04997516f, 0.03804520f, -0.04233706f, -0.06983198f, 
    -0.06906824f, 0.03509858f, 0.03068117f, -0.04121367f, 0.29277220f, 0.13726871f, -0.11742946f, -0.01058637f, 
    -0.06212905f, 0.00214741f, -0.03215629f, -0.00327763f, 0.07987898f, -0.03594011f, 0.14950268f, -0.05836910f, 
    0.28379759f, 0.14036319f, 0.20105875f, 0.27464119f, -0.13658895f, 0.03767546f, 0.21314085f, 0.14801970f, 
    0.05066924f, 0.04723025f, 0.07504073f, -0.00810494f, 0.36029571f, 0.00115710f, -0.04533432f, 0.20167743f, 
    -0.14351059f, -0.01944819f, -0.04954764f, 0.04128482f, -0.02741679f, 0.02879657f, -0.07017883f, 0.06969650f, 
    0.38907740f, 0.04383802f, 0.11593427f, 0.25425202f, -0.00364350f, 0.04514567f, -0.01298888f, 0.12147447f, 
    0.02425056f, 0.02209087f, -0.01477753f, -0.07578965f, 0.57174772f, 0.08531582f, 0.05553350f, 0.31214246f, 
    -0.03062417f, -0.01052268f, 0.03501173f, 0.02790600f, 0.05254854f, -0.14786305f, 0.11020898f, -0.00438324f, 
    0.09144869f, -0.04513091f, 0.18511285f, -0.05426156f, -0.12956707f, 0.02411861f, 0.06756949f, 0.00702539f, 
    0.10487739f, 0.02320303f, 0.08673984f, 0.10564897f, 0.26648086f, -0.01167016f, 0.22168717f, 0.20874794f, 
    -0.05980493f, 0.03308087f, -0.08253238f, -0.02684073f, 0.24476235f, 0.00826660f, 0.12713386f, -0.00918111f, 
    0.19600582f, -0.06711306f, 0.25844049f, 0.26887658f, -0.06392455f, 0.02456953f, 0.06019769f, 0.16567110f, 
    0.00299176f, 0.02066923f, -0.00739442f, 0.02302797f, 0.23161218f, -0.04305888f, 0.25174004f, -0.13580367f, 
    -0.14926785f, 0.01760057f, -0.04802257f, -0.08292751f, 0.14053540f, 0.11136105f, -0.12106229f, 0.00480275f, 
    -0.04809505f, -0.15382643f, 0.06996871f, -0.01469460f, 0.05783449f, -0.08148305f, -0.02103457f, -0.06855898f, 
    0.05835026f, -0.02268065f, 0.06390940f, 0.15771669f, 0.47097293f, 0.23842366f, 0.17310973f, 0.19414589f, 
    -0.07702606f, 0.10299350f, -0.02828865f, 0.07834544f, 0.05885909f, -0.00122236f, -0.08655937f, 0.02381612f, 
    -0.17617956f, -0.12434870f, -0.08005729f, -0.02809217f, -0.03141535f, 0.01029874f, -0.08722407f, 0.01518811f, 
    0.02472810f, -0.04145691f, 0.13182290f, -0.01968992f, -0.21923722f, -0.07478596f, 0.09205254f, 0.03895906f, 
    0.05178352f, 0.03753992f, 0.09397956f, -0.01063401f, -0.06740928f, -0.07509051f, -0.01138039f, 0.03455148f, 
    -0.22295150f, -0.14689274f, -0.03343890f, 0.23538390f, 0.04913196f, -0.02983196f, 0.13894914f, -0.01490386f, 
    -0.03975086f, 0.20472643f, 0.02380822f, -0.03093903f, 0.21967535f, -0.13405839f, 0.02144007f, -0.05731077f, 
    0.08221279f, -0.01085053f, -0.04374487f, -0.15062672f, -0.04193073f, -0.06010643f, 0.05715382f, 0.03851429f, 
    0.05230056f, -0.08028997f, -0.02069836f, -0.01995002f, -0.00903598f, -0.02950997f, 0.02737200f, 0.14073408f, 
    0.06980840f, 0.01878855f, -0.04835419f, 0.04171348f, -0.03855215f, -0.06059903f, 0.04321775f, -0.18522933f, 
    -0.01948623f, 0.06583952f, 0.12291560f, -0.02682493f, 0.09779243f, 0.00534855f, 0.08716766f, 0.01579035f, 
    0.01423536f, -0.17358688f, 0.07144014f, 0.12534279f, -0.13158679f, -0.08275423f, 0.05053926f, 0.20655395f, 
    0.01470716f, 0.06268602f, 0.04613732f, 0.14508730f, 0.31860223f, -0.11697636f, -0.08803289f, 0.20691696f, 
    0.19071424f, -0.12677909f, 0.12685668f, 0.11098894f, 0.11070452f, -0.14298896f, 0.04954174f, 0.02756466f, 
    0.10743234f, -0.28594899f, -0.26015437f, -0.19932730f, 0.25808892f, 0.15526602f, -0.08545616f, -0.15393198f, 
    0.04679893f, 0.07838831f, -0.12249546f, 0.17962052f, -0.31777352f, -0.27720559f, 0.15453248f, 0.20340824f, 
    0.04362982f, 0.00922232f, -0.01542729f, 0.06679168f, 0.07213821f, -0.08381245f, 0.01478201f, -0.05760316f, 
    -0.23910753f, -0.33544806f, 0.28173551f, 0.22099507f, 0.12799643f, 0.16917831f, -0.07843292f, 0.15865371f, 
    0.08436833f, 0.07505572f, -0.03620161f, 0.01337154f, -0.07894205f, 0.09810991f, -0.22365664f, 0.04026916f, 
    0.21321139f, 0.01375794f, 0.11653157f, 0.12729684f, -0.02504192f, 0.11236260f, -0.09056433f, 0.21541019f, 
    0.40815479f, 0.04220951f, 0.23721881f, 0.28030196f, 0.06850638f, 0.00229525f, 0.01958794f, 0.01107477f, 
    -0.05756573f, -0.34662476f, -0.09647775f, -0.12381102f, 0.21719979f, 0.11615730f, 0.04947094f, 0.32987031f, 
    0.03702332f, 0.00786309f, 0.02115287f, -0.04376936f, -0.01076265f, 0.12829454f, -0.03308188f, 0.08055741f, 
    -0.16052184f, 0.28858355f, -0.15544568f, 0.17557329f, 0.08864703f, -0.00299422f, 0.10658611f, 0.09435837f, 
    -0.19064841f, 0.01285510f, -0.02648361f, -0.11488919f, -0.06764290f, 0.22244990f, -0.17122386f, -0.10593769f, 
    0.11209898f, 0.11316663f, 0.06060072f, 0.09893804f, 0.02678438f, 0.13438171f, 0.02100275f, 0.13007532f, 
    0.00436155f, -0.15444785f, -0.11780943f, -0.34501091f, 0.22931121f, 0.14691636f, -0.07349444f, 0.17112765f, 
    0.00365026f, 0.05622885f, -0.03489949f, 0.00932250f, -0.23364502f, -0.09564542f, -0.21996501f, 0.13648663f, 
    0.01068088f, 0.11085507f, 0.13790882f, 0.03619488f, 0.04618396f, 0.12860487f, -0.04209436f, 0.12446643f, 
    0.08067182f, 0.16881186f, 0.06331149f, -0.06598433f, -0.03313766f, -0.03032175f, -0.01224277f, -0.00186262f, 
    -0.04945167f, -0.01591286f, 0.02829870f, 0.17869009f, 0.04180737f, 0.08985534f, -0.16582789f, -0.23571059f, 
    0.10275167f, 0.09364995f, 0.01850902f, 0.09336859f, 0.14589158f, -0.11072136f, 0.00874365f, 0.03723768f, 
    -0.38549387f, 0.10962988f, 0.12886803f, 0.07493844f, -0.12933892f, 0.02413591f, 0.15126930f, 0.11400571f, 
    0.12876853f, 0.07803681f, 0.05052716f, 0.02588850f, -0.05157289f, 0.08957529f, 0.19885705f, 0.03921041f, 
    -0.01867658f, 0.02089044f, 0.03055789f, 0.08558187f, -0.04059241f, -0.07499150f, 0.03174515f, -0.02845819f, 
    -0.21719867f, 0.09695665f, 0.02148909f, 0.05775593f, -0.13558576f, 0.04267537f, 0.02203292f, 0.10662372f, 
    -0.05766528f, 0.07112135f, -0.01006403f, 0.06123611f, -0.42401749f, 0.17470130f, 0.13215235f, 0.04062468f, 
    -0.10772329f, 0.08458257f, 0.01059527f, 0.06813806f, -0.05503134f, -0.17418242f, -0.03955398f, 0.08183478f, 
    0.00174065f, -0.29793957f, 0.32647455f, -0.00057890f, -0.03418702f, 0.02262018f, -0.03060357f, 0.03291509f, 
    0.06510895f, -0.16091311f, -0.00835358f, -0.12027967f, -0.31763446f, 0.05908514f, 0.36557603f, -0.16650531f, 
    -0.09368881f, -0.07610678f, -0.00056308f, 0.07672386f, 0.07375656f, -0.15031885f, 0.00218378f, 0.02069906f, 
    -0.11655924f, 0.39670336f, 0.00695226f, -0.31406623f, 0.01510465f, 0.08204249f, -0.02523234f, 0.11629902f, 
    0.15399732f, 0.18814340f, 0.15521322f, 0.08397631f, 0.14761800f, 0.10251060f, -0.00777307f, -0.02330747f, 
    -0.10316625f, 0.10172435f, 0.04391817f, 0.02908358f, 0.06158392f, 0.14132136f, 0.14584571f, -0.02920180f, 
    -0.20457244f, 0.18323772f, -0.14000916f, -0.16851319f, -0.14893310f, 0.00420727f, 0.05436928f, 0.03150739f, 
    0.01773227f, -0.09642360f, 0.05386755f, -0.02603317f, 0.46978217f, 0.01943709f, -0.00496792f, 0.03377718f, 
    -0.14005648f, 0.17207976f, -0.09415023f, -0.01748767f, 0.08623619f, 0.02071427f, 0.08451498f, 0.04693284f, 
    0.13480453f, 0.15334895f, 0.28062972f, -0.27152330f, 0.02283062f, -0.08569346f, 0.08248408f, 0.04599987f, 
    0.03780242f, -0.04103769f, 0.10583211f, 0.24674033f, 0.05491778f, -0.08925605f, 0.21026392f, -0.20947336f, 
    -0.13357750f, 0.05226493f, -0.09890623f, -0.00381730f, 0.17727405f, 0.02107161f, 0.02524019f, 0.04092029f, 
    0.33028534f, 0.04271152f, 0.08760790f, 0.34871525f, 0.21803048f, 0.11667033f, 0.03399451f, 0.03832553f, 
    -0.11672828f, 0.08400444f, 0.22592226f, -0.00341548f, -0.34301981f, 0.19214691f, -0.27878302f, -0.14076087f, 
    0.13305265f, 0.04865975f, 0.11699011f, -0.13061260f, 0.02019281f, 0.05352260f, 0.04807708f, 0.10170335f, 
    -0.73712927f, -0.13043875f, 0.12147014f, 0.29565874f, -0.07895450f, -0.10394067f, 0.00482480f, -0.03720554f, 
    -0.03477711f, 0.18053770f, 0.00654942f, 0.02526200f, 0.15840621f, -0.22766265f, 0.09387815f, -0.28207505f, 
    0.11416475f, 0.09485777f, -0.12673523f, 0.04967143f, 0.19359751f, -0.06606814f, -0.07541109f, 0.03327465f, 
    -0.27068800f, -0.03633959f, 0.22986504f, 0.24770443f, 0.06172240f, 0.04453000f, 0.06655445f, 0.04869855f, 
    0.11757725f, 0.03586833f, 0.01552318f, 0.06099767f, 0.18953814f, 0.10773191f, -0.12547211f, -0.13667387f, 
    0.23046230f, 0.14891216f, 0.08321780f, 0.00742887f, 0.06517652f, 0.00183929f, 0.13595645f, 0.03600207f, 
    0.05505507f, 0.12621062f, 0.09407060f, 0.24723776f, 0.08161641f, 0.16726777f, 0.02245296f, 0.12838465f, 
    -0.04096319f, 0.06622997f, 0.07763772f, -0.09647582f, 0.09341422f, -0.00933129f, -0.07104994f, 0.08031885f, 
    -0.05257814f, -0.10653444f, 0.00069785f, -0.05667936f, 0.00300154f, 0.17242970f, 0.02495709f, 0.14059450f, 
    -0.00386040f, -0.10368410f, -0.15457459f, 0.04241901f, 0.01038695f, -0.17242476f, -0.07422913f, -0.05013224f, 
    -0.00336824f, 0.13466235f, -0.10702455f, -0.04563542f, -0.04406794f, 0.20896517f, 0.05580031f, 0.02565989f, 
    0.25052276f, 0.01455565f, 0.08890147f, 0.20117211f, -0.02796272f, 0.01432648f, 0.13521942f, 0.03423212f, 
    0.15303938f, -0.00174855f, -0.07504597f, 0.21735990f, 0.10957555f, 0.01467445f, 0.07565112f, 0.09676534f, 
    -0.10973130f, 0.05711219f, -0.03239017f, 0.15881841f, -0.05599033f, -0.04691302f, -0.05472987f, -0.22619069f, 
    0.03147015f, -0.10799257f, 0.19325018f, -0.05117030f, -0.04878705f, 0.08564899f, 0.06337471f, 0.04445959f, 
    0.09220997f, 0.08212104f, 0.01739900f, 0.16891932f, 0.09554830f, 0.07410306f, 0.05749565f, -0.04763808f, 
    0.20385036f, 0.04064666f, -0.14021134f, 0.02568060f, 0.18420169f, 0.19756521f, -0.08954615f, 0.07570287f, 
    0.15900566f, -0.01239458f, -0.06105443f, -0.12701456f, -0.06449070f, 0.06458768f, -0.05485839f, -0.03847208f, 
    0.10385314f, -0.01307274f, 0.03545291f, -0.18073675f, 0.11540037f, -0.03390968f, 0.15722813f, 0.05485475f, 
    0.10330244f, 0.06645431f, 0.21005395f, -0.00225995f, -0.05439137f, -0.07784823f, 0.07770330f, -0.11654273f, 
    0.08458212f, 0.01830164f, -0.07627501f, -0.03600267f, -0.00441008f, -0.01223778f, 0.07708354f, 0.11491197f, 
    -0.32293794f, -0.13246794f, -0.08874222f, -0.19891234f, -0.08368261f, -0.09758048f, 0.10712050f, -0.19074973f, 
    0.07819507f, 0.16315942f, -0.10444941f, -0.00925332f, 0.05839192f, -0.03849343f, -0.00260419f, -0.18284410f, 
    0.01282758f, 0.03229453f, -0.03751686f, 0.00008999f, 0.10950973f, -0.03924646f, 0.22832675f, 0.06651021f, 
    -0.19032691f, 0.03049062f, 0.22912963f, -0.28110051f, 0.16866501f, 0.01024979f, -0.05673255f, 0.21718928f, 
    0.05421826f, 0.11377037f, 0.03070252f, 0.05449039f, 0.05862714f, -0.01482182f, -0.05282230f, -0.23753259f, 
    -0.16583158f, -0.00969322f, 0.11412068f, -0.06901861f, 0.10275219f, -0.06248384f, 0.07621156f, -0.06419902f, 
    0.18504424f, 0.19624725f, 0.14122668f, 0.24678954f, -0.08196698f, -0.02408769f, 0.01274650f, -0.05131017f, 
    -0.05969932f, 0.01873811f, -0.07025267f, 0.06920300f, 0.06254163f, 0.08626345f, -0.02421959f, 0.54095733f, 
    0.00211714f, -0.06850913f, -0.05554290f, 0.04108223f, 0.17042544f, 0.00041982f, -0.01674351f, 0.06541800f, 
    -0.05728777f, -0.28822336f, -0.12790275f, 0.03660019f, -0.03570873f, 0.00771882f, -0.07596447f, 0.14955463f, 
    0.18290956f, 0.10032618f, -0.01392597f, -0.24644572f, 0.31397530f, -0.34742117f, -0.04393457f, 0.27493456f, 
    0.23732559f, 0.18586722f, 0.03372134f, -0.10825548f, -0.06661031f, -0.21226190f, 0.03993149f, -0.03274994f, 
    -0.24481755f, -0.13562416f, -0.22009575f, -0.19275233f, 0.21012338f, -0.05414822f, 0.04893291f, -0.08116699f, 
    0.16735578f, -0.06357057f, -0.15747252f, -0.15406771f, 0.23111644f, -0.06720734f, 0.11739926f, 0.00892918f, 
    0.17442892f, 0.01072673f, 0.08231921f, -0.07305072f, -0.01525777f, -0.03234099f, 0.04641255f, 0.12279029f, 
    0.10303891f, -0.06372569f, 0.40669402f, 0.07885628f, 0.14018214f, 0.05169220f, -0.13260785f, -0.06707896f, 
    -0.07415978f, -0.07205433f, 0.12116032f, 0.09388272f, -0.30082887f, -0.30974323f, 0.18919961f, 0.15288565f, 
    -0.02189438f, 0.08680791f, -0.08126199f, -0.06220820f, 0.06524330f, -0.01878876f, 0.04236890f, 0.02765181f, 
    0.02958523f, -0.05870605f, -0.09729099f, -0.17545249f, 0.13086161f, 0.01016567f, 0.13449360f, -0.02103991f, 
    0.14979967f, -0.03807258f, -0.02425884f, 0.15335520f, -0.19682249f, 0.07801252f, 0.23217350f, 0.19933675f, 
    -0.06119823f, 0.00469895f, 0.10516368f, -0.00631893f, 0.05936301f, 0.05540538f, 0.00360108f, 0.01124200f, 
    0.38483596f, 0.03198231f, -0.09383065f, 0.23161460f, 0.06569153f, 0.20164151f, 0.17341854f, 0.16417576f, 
    -0.05649796f, -0.05390668f, 0.09765270f, 0.25512964f, -0.24128814f, 0.08427784f, 0.14374465f, -0.08856986f, 
    0.12427780f, 0.08928707f, 0.01655045f, -0.21534136f, -0.12377527f, -0.01561739f, 0.01099304f, 0.19139111f, 
    0.21488845f, 0.09767566f, -0.05823967f, 0.10762066f, -0.01029105f, -0.00604000f, -0.06504256f, 0.02684006f, 
    -0.01154049f, 0.04643856f, 0.22428812f, -0.12602258f, -0.33274344f, -0.24721232f, -0.13862534f, -0.05764681f, 
    -0.19066092f, -0.10615127f, 0.12724608f, 0.00045779f, -0.05684014f, -0.17799701f, -0.00226273f, -0.11266774f, 
    0.01108256f, -0.03660855f, -0.01463937f, 0.11041774f, -0.04597430f, 0.03980032f, 0.02406423f, 0.11525598f, 
    -0.06355796f, -0.10089788f, 0.01009052f, 0.03199227f, -0.02675548f, 0.13393906f, -0.01386018f, 0.01003130f, 
    -0.02825146f, 0.03501871f, -0.11942969f, -0.23536681f, 0.02589685f, -0.06126999f, -0.01264336f, -0.11126774f, 
    -0.08621676f, 0.27880046f, 0.04038724f, -0.06237214f, -0.04739046f, -0.00276860f, -0.04722810f, 0.19268999f, 
    0.07729527f, 0.08098704f, 0.08765060f, -0.04649416f, 0.18275355f, -0.18237688f, -0.15544480f, -0.19388452f, 
    -0.22944279f, 0.05052479f, -0.05242879f, -0.21388520f, -0.01714269f, -0.05631200f, -0.01815426f, -0.03372159f, 
    0.02819195f, 0.05409104f, -0.06585049f, -0.32412845f, 0.24049750f, 0.18031801f, 0.03451796f, 0.15063612f, 
    0.04278573f, 0.09349231f, -0.06001186f, -0.18015128f, -0.01838294f, 0.13285176f, -0.03165288f, 0.06855957f, 
    -0.26449817f, -0.08598257f, -0.04899439f, -0.01588261f, 0.07280245f, 0.03422073f, 0.09328604f, -0.03778004f, 
    0.19819656f, -0.32465526f, -0.03683568f, -0.20856006f, 0.02216631f, -0.00859031f, 0.23746939f, 0.02533914f, 
    0.04490353f, -0.00789955f, 0.05762723f, 0.11155662f, 0.20310484f, 0.08611827f, -0.14075933f, 0.05428741f, 
    0.02714882f, -0.09499107f, 0.04875142f, 0.05908680f, 0.04495368f, 0.11458968f, 0.07718463f, 0.15493529f, 
    0.42076710f, 0.23545638f, -0.03926392f, 0.12240811f, 0.01429168f, 0.05705091f, 0.02591133f, 0.05021873f, 
    0.03305256f, 0.05365521f, 0.16039869f, 0.13570645f, 0.21550889f, 0.32558000f, 0.17695627f, 0.13147525f, 
    -0.21277985f, -0.04041240f, -0.08805657f, -0.08316976f, 0.00107085f, -0.02870662f, 0.02427545f, 0.08330005f, 
    -0.23017216f, 0.13748941f, -0.06636187f, 0.03322940f, -0.04220483f, -0.07324513f, -0.11265888f, 0.04169017f, 
    0.02989754f, 0.09048582f, 0.05754946f, 0.09090952f, 0.03975527f, 0.21369290f, -0.02756551f, -0.13033655f, 
    -0.04294320f, 0.10705330f, -0.09828483f, 0.02704954f, 0.09068315f, -0.03905535f, 0.07178677f, -0.07481074f, 
    0.11374002f, -0.02205348f, -0.07414492f, 0.06653357f, 0.00486433f, -0.15561110f, 0.24448746f, 0.07009392f, 
    0.18275186f, 0.14347203f, -0.01993296f, 0.08338901f, -0.00340471f, -0.27792135f, 0.22545387f, 0.20074047f, 
    0.06535266f, 0.07711747f, -0.11205748f, -0.04345043f, 0.09477410f, -0.04260236f, -0.05691822f, -0.08249119f, 
    0.42053843f, 0.20038711f, -0.00218558f, 0.01568054f, -0.11930773f, -0.07993782f, -0.08413022f, 0.07144959f, 
    -0.02696948f, -0.07195045f, 0.10174903f, -0.15211350f, 0.38872713f, -0.04817991f, -0.13263264f, -0.08154685f, 
    0.03357505f, -0.10915789f, -0.06110109f, 0.06329910f, 0.01826903f, 0.03578455f, -0.01486637f, -0.09289769f, 
    -0.02726931f, -0.23365350f, -0.14332139f, -0.17758206f, -0.11302638f, 0.02043417f, -0.01422504f, -0.01072760f, 
    -0.03187110f, -0.15490229f, 0.07938313f, -0.04629297f, 0.17469026f, 0.09938385f, -0.09050955f, -0.05766527f, 
    -0.25389433f, -0.12558836f, -0.08970685f, -0.06027768f, 0.02510750f, 0.03357616f, -0.05130231f, -0.01901091f, 
    0.25231317f, -0.00747776f, -0.01910131f, 0.34513199f, 0.06162549f, -0.05895447f, -0.09185869f, 0.08121271f, 
    0.20541015f, 0.10500064f, 0.06626268f, -0.10107875f, 0.43867522f, 0.08943718f, 0.08157753f, 0.09718792f, 
    0.24030949f, -0.02990490f, 0.15047354f, 0.11432827f, -0.02959859f, 0.16056691f, -0.10435158f, 0.02471116f, 
    0.01924211f, -0.23164585f, -0.06484316f, -0.15484110f, 0.06613812f, 0.03411949f, 0.04390333f, -0.18433216f, 
    -0.09558767f, -0.06483038f, 0.12278568f, -0.01473873f, 0.51779288f, -0.19533256f, -0.12237059f, -0.12156283f, 
    0.06259970f, -0.05282895f, -0.06623634f, 0.01154797f, 0.10572267f, 0.16244979f, 0.02385181f, -0.00757718f, 
    -0.00651508f, 0.24948090f, -0.26212391f, 0.13502164f, 0.15065055f, 0.08201656f, -0.15890867f, 0.04819309f, 
    -0.04857056f, 0.04145512f, -0.02194277f, 0.03559037f, 0.32946125f, 0.02895084f, -0.41752124f, -0.26727864f, 
    0.11434685f, 0.03630706f, -0.08572122f, -0.03424142f, -0.07784441f, 0.05612272f, 0.01849670f, -0.03250870f, 
    0.06992617f, 0.05054732f, 0.00746619f, 0.06696358f, -0.08189073f, 0.00266874f, -0.05045828f, -0.09972162f, 
    -0.04122995f, -0.03406050f, 0.01153877f, 0.06545702f, 0.02577373f, -0.41711313f, -0.12986685f, -0.04014403f, 
    -0.08972861f, 0.04073882f, 0.04002197f, 0.03522556f, -0.10548023f, 0.09204839f, 0.00757666f, 0.03648499f, 
    -0.04232202f, 0.05093556f, -0.13151918f, 0.05207955f, -0.05604283f, 0.01624031f, -0.00703547f, 0.02268217f, 
    0.02102497f, 0.14626172f, 0.12750810f, 0.04407244f, -0.30102473f, -0.04395462f, 0.11152110f, 0.18911499f, 
    0.04103833f, -0.04709733f, -0.03366999f, 0.09118858f, -0.20751053f, 0.03611345f, 0.11456811f, -0.07419425f, 
    0.22793965f, 0.11557886f, -0.14781445f, -0.01508162f, 0.30235800f, 0.03003403f, 0.11460968f, 0.24373865f, 
    0.06813649f, 0.04255047f, 0.04001731f, -0.24136661f, -0.37394524f, -0.05239150f, -0.16268103f, -0.01953083f, 
    0.05031467f, -0.00211667f, 0.11758900f, 0.06982034f, 0.10503612f, 0.04571897f, -0.04864403f, 0.01554334f, 
    0.07200205f, 0.17393900f, -0.13342011f, -0.04997173f, -0.07021596f, 0.05408818f, 0.03771462f, -0.01613444f, 
    0.09186971f, -0.00787137f, -0.15211408f, -0.03186465f, 0.33933592f, -0.20847948f, -0.09957007f, -0.08794644f, 
    -0.00597659f, 0.00550331f, 0.04407694f, 0.05197343f, 0.03198099f, 0.16191417f, -0.03369486f, 0.04815222f, 
    -0.26118436f, 0.10085164f, 0.10754053f, 0.06044908f, -0.10806946f, 0.18108132f, -0.05092658f, 0.15424447f, 
    0.10005441f, -0.04343906f, 0.05729603f, 0.05128059f, -0.26876402f, -0.08900891f, 0.25589195f, 0.00935727f, 
    0.05818118f, -0.03038818f, 0.08297250f, 0.15942541f, 0.11639929f, 0.04941593f, -0.00288436f, 0.11489665f, 
    0.06430499f, 0.25072414f, -0.17737870f, -0.05471031f, -0.07406726f, 0.05628143f, 0.01914758f, -0.05992591f, 
    -0.13815443f, -0.12401249f, 0.16511071f, 0.11515499f, 0.33908686f, -0.24243212f, 0.04491255f, -0.39597914f, 
    -0.19401477f, -0.20027962f, 0.08066718f, 0.13777936f, 0.15240270f, 0.06100219f, -0.14331786f, 0.15150106f, 
    -0.07732303f, 0.29973769f, -0.11395990f, 0.09575996f, 0.05135144f, 0.08748472f, 0.13090448f, 0.05145125f, 
    0.06148770f, 0.05158243f, 0.03253043f, 0.02219022f, 0.01374673f, -0.11668784f, -0.09910865f, -0.09422455f, 
    0.05897152f, 0.00158023f, 0.12189157f, 0.07766983f, 0.02926388f, -0.18922602f, 0.08479030f, -0.14607506f, 
    0.43808639f, -0.18488170f, -0.07542301f, -0.07561935f, 0.00571999f, -0.10761940f, -0.01564923f, -0.17425570f, 
    -0.05256000f, 0.18032461f, -0.18405204f, 0.08119946f, -0.04906643f, -0.10225321f, -0.08191764f, 0.08748519f, 
    0.06475451f, 0.05184484f, -0.01512015f, 0.09918537f, 0.16153121f, -0.18698914f, -0.10479565f, -0.23713046f, 
    -0.09079430f, 0.14254744f, 0.03439875f, -0.10420801f, -0.07959640f, 0.08009158f, -0.00186247f, 0.03432731f, 
    0.04190321f, 0.10797891f, -0.01780009f, 0.12887822f, -0.35162008f, 0.02530969f, -0.34724945f, 0.15194100f, 
    0.02686703f, 0.03557850f, 0.06117564f, 0.06386557f, 0.00280837f, 0.08166908f, -0.00039165f, 0.20070507f, 
    0.08186955f, -0.08264339f, 0.26680380f, 0.00611930f, 0.12372754f, 0.12780833f, 0.06429553f, 0.01276458f, 
    0.01720921f, -0.15829767f, -0.32356584f, -0.30945507f, 0.14097139f, 0.07739398f, 0.16742852f, 0.27603069f, 
    0.08703679f, -0.11156119f, 0.04304533f, -0.10345839f, 0.00970103f, 0.27091661f, -0.01313070f, 0.11645037f, 
    0.01986940f, -0.00881011f, -0.29453120f, 0.24181357f, -0.07811341f, 0.04570421f, -0.12610215f, 0.21354353f, 
    -0.11477757f, -0.01643440f, -0.01836540f, -0.28010625f, 0.10140508f, -0.28591746f, 0.09437182f, 0.02269772f, 
    0.15383503f, 0.03047248f, -0.18462493f, -0.13001810f, -0.13140804f, 0.06727422f, 0.25923935f, 0.21002911f, 
    -0.02688406f, 0.16815956f, -0.22663100f, -0.45069793f, 0.05770275f, 0.08284908f, -0.05522293f, -0.01236214f, 
    -0.01317163f, 0.17115165f, -0.20160711f, 0.15029922f, -0.02325338f, -0.07800138f, -0.20691371f, -0.14178941f, 
    0.01599775f, -0.07795771f, 0.01360178f, 0.16889286f, -0.01887533f, 0.08338661f, 0.23301087f, 0.24671018f, 
    -0.24272777f, -0.08242555f, -0.03005164f, 0.38688579f, -0.06018940f, -0.07481026f, -0.09889065f, 0.10300315f, 
    0.11928459f, 0.15021582f, -0.06320010f, 0.13012260f, -0.16360037f, 0.14887802f, -0.16606514f, -0.06710296f, 
    -0.05047578f, 0.19665381f, 0.00027744f, 0.04601396f, 0.22489358f, -0.14991245f, -0.03942175f, -0.03249009f, 
    -0.44582403f, 0.12564473f, 0.11963110f, -0.13818358f, -0.01293961f, 0.14199527f, 0.06756730f, 0.02767473f, 
    0.02479389f, 0.10556093f, -0.06740002f, 0.15279697f, -0.21098076f, -0.01386495f, 0.19055235f, -0.17600930f, 
    0.02215744f, -0.11770938f, 0.14171179f, 0.04632450f, 0.18007247f, -0.09946966f, 0.12132123f, 0.02673121f, 
    0.05279002f, -0.03458868f, 0.15278448f, 0.18753818f, -0.21987306f, 0.12380780f, 0.01583543f, 0.02898689f, 
    0.16570741f, 0.03122721f, -0.03594153f, -0.11503151f, -0.11584772f, -0.13819632f, -0.04825079f, -0.01665170f, 
    -0.08030041f, 0.14479871f, -0.00080031f, -0.10534953f, -0.05223105f, -0.13982382f, 0.03959705f, -0.04688723f, 
    0.04390622f, -0.23741543f, 0.08172762f, 0.07102294f, 0.03710385f, -0.01533156f, 0.25403503f, 0.06395152f, 
    0.22054735f, 0.02014493f, -0.15429990f, -0.21406525f, 0.09286153f, -0.29757559f, 0.06031205f, 0.28727710f, 
    -0.10157333f, 0.00552700f, 0.02095542f, -0.03615247f, 0.07275153f, -0.07723966f, 0.20324695f, 0.20066050f, 
    -0.06165319f, 0.00176952f, 0.11336402f, 0.05934570f, 0.08113357f, -0.01948094f, -0.15080684f, 0.04169885f, 
    0.03577108f, 0.00339497f, 0.20539320f, 0.18730359f, -0.24061443f, 0.03641273f, 0.40042171f, 0.04879929f, 
    -0.18480580f, 0.06365260f, -0.05659003f, -0.12630916f, 0.11614950f, 0.10680422f, 0.04161332f, 0.10964260f, 
    0.28198287f, -0.32690904f, -0.08044264f, 0.23967934f, 0.05891491f, -0.03656969f, 0.05422571f, 0.02301029f, 
    0.06759598f, -0.07995632f, -0.15396319f, 0.04309278f, 0.23165344f, 0.02525699f, 0.10699759f, -0.30904487f, 
    0.01411651f, 0.06090632f, 0.11274976f, 0.01749064f, 0.16631559f, 0.19104621f, -0.17529310f, 0.11302970f, 
    0.14304475f, 0.03709148f, 0.00099416f, 0.23410380f, 0.00267848f, -0.06405093f, 0.06894573f, 0.10400341f, 
    -0.00815767f, -0.07702461f, 0.12725343f, 0.32855359f, 0.16108739f, 0.00301175f, 0.00086616f, 0.02941203f, 
    0.02184657f, 0.09088155f, -0.16705272f, -0.09460313f, -0.02416758f, 0.00000648f, -0.02363701f, 0.04620312f, 
    0.00370311f, 0.21458077f, 0.06100895f, -0.02292947f, 0.13927208f, 0.06349716f, -0.01140347f, 0.00377720f, 
    -0.03800207f, 0.11916829f, 0.28682441f, -0.11843280f, -0.05536038f, 0.30152145f, 0.04454723f, -0.11799110f, 
    -0.03654616f, -0.05018638f, 0.06217350f, 0.08068532f, 0.08255730f, -0.12119956f, -0.04030764f, -0.06503629f, 
    -0.54590976f, -0.13776122f, -0.03076339f, 0.08495177f, -0.02787570f, -0.17226237f, 0.02319815f, -0.05232529f, 
    -0.10102044f, 0.18885483f, 0.04224256f, -0.14258906f, 0.52375579f, -0.18009207f, 0.00654099f, -0.29440337f, 
    0.07166754f, 0.01894655f, -0.13107552f, -0.11906654f, -0.04257936f, -0.10878831f, -0.11262801f, 0.00481762f, 
    -0.41239306f, 0.25417873f, -0.16634977f, 0.09530227f, -0.14804390f, 0.11399530f, -0.11044262f, 0.15606999f, 
    0.13248800f, 0.10859122f, 0.08495923f, 0.09621504f, 0.15987934f, -0.02897069f, -0.20205607f, -0.02486738f, 
    0.11788740f, 0.05971718f, 0.00561080f, 0.07981174f, 0.03931117f, -0.11523078f, 0.09949831f, -0.17226568f, 
    -0.00868998f, -0.01810651f, 0.02974443f, 0.00739212f, 0.02710854f, -0.00616448f, -0.02755421f, -0.04223238f, 
    -0.05061734f, -0.04359096f, -0.02263686f, -0.02193782f, -0.02019829f, 0.02655429f, 0.00024849f, 0.03166341f, 
    -0.01802289f, -0.03530520f, -0.02217432f, -0.00409569f, 0.01926027f, 0.01772094f, 0.00225824f, 0.04297482f, 
    0.03924580f, 0.03407141f, -0.04880942f, -0.01958065f, -0.01629411f, -0.01352413f, -0.04741015f, -0.04484290f, 
    -0.00352425f, 0.01865605f, 0.04074066f, -0.00771494f, -0.01467753f, -0.00486352f, -0.04733457f, 0.00490205f, 
    -0.00293395f, 0.00570899f, 0.01484783f, 0.01785769f, -0.04645395f, 0.01908392f, -0.02578601f, -0.04144827f, 
    0.01397947f, -0.01585193f, -0.00370260f, -0.03105298f, -0.02806527f, 0.04271949f, 0.02857481f, -0.00099601f, 
    0.00104732f, 0.02685433f, -0.00071068f, -0.01386778f, 0.02593935f, -0.01976670f, -0.01357920f, -0.01244379f, 
    -0.01827121f, -0.04461555f, -0.01065931f, -0.00927837f, 0.01210365f, -0.02756478f, 0.01833167f, 0.01640367f, 
    0.03655215f, 0.03077934f, -0.04791401f, -0.04758877f, 0.03185257f, -0.02272560f, 0.02185931f, -0.02741989f, 
    -0.04484075f, 0.03325085f, -0.03505016f, 0.03831560f, -0.01302052f, 0.00551390f, -0.05735467f, -0.01316895f, 
    0.02827567f, 0.03256081f, -0.03205409f, -0.03720481f, -0.01657419f, -0.01264299f, 0.01349209f, -0.02581996f, 
    0.02955958f, -0.01177316f, -0.01404194f, -0.00906708f, -0.05483891f, 0.01737056f, 0.00284266f, 0.02756732f, 
    0.01176524f, -0.00940880f, -0.02294002f, 0.01269508f, -0.03839425f, 0.03977472f, -0.03664272f, -0.02664765f, 
    0.01273830f, 0.03867025f, 0.00248169f, -0.02120564f, 0.03265068f, -0.04204671f, -0.00604053f, 0.01150081f, 
    0.01898358f, -0.00714166f, 0.02275668f, 0.02787437f, -0.02558173f, -0.01143864f, 0.02332670f, -0.04632499f, 
    0.02566808f, -0.03704367f, -0.03270860f, -0.03201515f, 0.03378117f, -0.02696072f, 0.00528310f, 0.01345672f, 
    -0.00769689f, 0.00098073f, 0.03852502f, 0.01231398f, 0.01092883f, 0.00647997f, -0.00669197f, -0.01637430f, 
    0.04543680f, 0.02730058f, -0.05760937f, -0.03390402f, 0.02845459f, 0.01290467f, 0.01316542f, -0.04453022f, 
    0.00062172f, 0.01797310f, -0.02890368f, -0.03967328f, -0.05144133f, -0.02584148f, -0.05797474f, -0.04978715f, 
    -0.00228526f, 0.01529216f, 0.04402334f, -0.00613589f, 0.02144515f, 0.02916193f, 0.00009909f, 0.02524438f, 
    -0.01981056f, 0.01824230f, 0.01984984f, -0.02080884f, 0.02196869f, -0.00285938f, -0.05984021f, -0.05809542f, 
    0.01623188f, 0.03943319f, 0.02456016f, 0.03347488f, -0.00051043f, 0.01448787f, -0.01762003f, 0.03827104f, 
    -0.01674674f, -0.05164687f, -0.00848157f, -0.05583608f, -0.04049175f, 0.01595367f, -0.02830137f, 0.00607574f, 
    -0.01353169f, 0.00888831f, -0.01439303f, -0.00958978f, 0.01854361f, -0.02949223f, 0.00611344f, 0.03192878f, 
    0.01020682f, -0.04023925f, -0.03870733f, 0.02433867f, -0.02379570f, 0.03846619f, 0.01448772f, -0.04917530f, 
    0.01496783f, -0.00202999f, -0.04632226f, -0.01434101f, -0.03959669f, -0.05426742f, 0.02386328f, -0.05607876f, 
    -0.04551930f, -0.02747552f, 0.03164532f, 0.04380091f, 0.01136847f, 0.05754281f, -0.00752728f, -0.00996683f, 
    -0.00347859f, 0.02132427f, -0.00099249f, -0.03433253f, -0.05829212f, 0.03301444f, 0.00943830f, 0.03516390f, 
    -0.01420421f, -0.01833301f, -0.03488961f, -0.04425671f, 0.03113651f, 0.00696264f, 0.03503721f, 0.00815673f, 
    0.00873410f, 0.00645445f, 0.02827434f, 0.01836153f, -0.04819543f, -0.05142846f, 0.03295644f, -0.02289678f, 
    -0.00631432f, 0.03752373f, -0.01668778f, -0.03777979f, 0.02024008f, 0.01879372f, -0.00722018f, -0.04707752f, 
    -0.02364286f, 0.00678408f, -0.02737777f, 0.00933667f, -0.00997543f, 0.02167325f, 0.02257129f, -0.03002658f, 
    -0.00760784f, -0.02601955f, -0.00706812f, 0.00375669f, -0.04697140f, -0.02477746f, -0.04578770f, -0.01978996f, 
    -0.03023293f, -0.00131631f, -0.05692845f, -0.05861821f, 0.01912711f, -0.03944388f, -0.05447206f, -0.01748114f, 
    -0.03316854f, -0.04860362f, -0.03635193f, -0.01394280f, -0.00460522f, 0.02029066f, 0.02009125f, -0.01742719f, 
    0.00991360f, 0.02936731f, -0.02514692f, -0.02721236f, -0.01227896f, 0.02886614f, 0.02767531f, -0.02490961f, 
    -0.01563855f, -0.04163586f, -0.00057477f, -0.01392325f, 0.02337115f, 0.01799893f, -0.03225207f, -0.04062469f, 
    0.03287397f, 0.00149852f, 0.00992064f, -0.02555474f, -0.04105745f, -0.05109606f, 0.02471784f, -0.04100879f, 
    -0.02118641f, -0.01030267f, -0.04811430f, 0.03956112f, 0.00237021f, -0.00935112f, -0.05635611f, -0.02566815f, 
    -0.02036707f, 0.02405851f, -0.05025863f, 0.00546699f, -0.04230701f, 0.00273389f, -0.04153375f, 0.01097796f, 
    -0.02802216f, 0.00454757f, 0.02716735f, -0.03541045f, 0.04137189f, -0.02148106f, -0.04755101f, 0.00676416f, 
    0.00619856f, 0.03607502f, -0.00800174f, -0.04730363f, 0.03886665f, 0.01063696f, 0.03121065f, -0.04864409f, 
    -0.00754483f, -0.04043753f, -0.03545195f, 0.03175794f, 0.02104304f, 0.01874123f, 0.00289762f, -0.03641374f, 
    -0.00130023f, 0.02747498f, -0.00936305f, 0.03604920f, -0.01537013f, 0.00923960f, -0.00298111f, -0.04168722f, 
    0.02579315f, -0.04024433f, -0.04472106f, -0.00876845f, -0.05246981f, -0.03632157f, -0.01415668f, 0.01983069f, 
    -0.03274875f, 0.02703420f, -0.00890653f, 0.03097768f, 0.03237530f, 0.00153737f, -0.04076495f, -0.04750575f, 
    -0.02508030f, 0.01866327f, 0.00115745f, 0.01485781f, -0.01612734f, -0.00450949f, -0.01047247f, 0.00597439f, 
    -0.04255770f, 0.14472534f, 0.01801565f, -0.28211230f, -0.00018502f, 0.15290937f, 0.05818059f, -0.01943451f, 
    0.14417091f, 0.19769399f, -0.00214662f, 0.05454355f, 0.24527593f, -0.02399898f, 0.02152188f, 0.03916251f, 
    -0.18589289f, -0.18379174f, -0.14987059f, 0.13346615f, 0.12731661f, -0.20240803f, 0.05933993f, 0.11772500f, 
    0.19641708f, -0.18620649f, 0.01581705f, 0.11760715f, 0.01235600f, 0.03718579f, -0.08062807f, 0.04768763f, 
    0.05263862f, -0.04724457f, 0.08424772f, 0.07930238f, 0.25869751f, 0.13496897f, 0.00777946f, 0.05560049f, 
    0.02382688f, 0.03981866f, -0.09129963f, 0.18351659f, 0.13599318f, -0.03592408f, -0.04626926f, 0.26753813f, 
    -0.00884320f, 0.03112740f, -0.11554638f, -0.19748439f, -0.12068148f, 0.01787811f, -0.04756721f, -0.00533261f, 
    0.12273800f, 0.06967827f, 0.06811296f, -0.04073331f, 0.13376686f, 0.28184325f, 0.07327966f, 0.14904138f, 
    0.11743473f, -0.03537824f, -0.08341982f, -0.06010872f, -0.08123985f, 0.08436730f, -0.00347285f, -0.01181019f, 
    0.09448789f, 0.15175819f, 0.17547983f, -0.00207168f, -0.00834538f, -0.07138702f, -0.04908884f, 0.12133606f, 
    -0.01220070f, 0.12695195f, -0.01770776f, 0.02636495f, -0.11057395f, 0.24352916f, 0.04524463f, -0.10139279f, 
    0.08200675f, 0.12093277f, -0.08279628f, 0.00914689f, 0.02163792f, 0.15680894f, 0.23684038f, -0.07357752f, 
    -0.11402312f, 0.09001078f, 0.10291752f, 0.06707893f, -0.00550453f, 0.12905262f, -0.07201979f, 0.00470271f, 
    0.18773475f, -0.20666358f, 0.04867240f, 0.16290694f, 0.35706219f, 0.15006366f, -0.04905885f, 0.12254858f, 
    0.09225002f, 0.01551138f, 0.02727948f, 0.14417346f, -0.23282228f, 0.12234677f, -0.04257848f, 0.06493451f, 
    0.45140028f, -0.16821611f, -0.13775727f, 0.24801245f, -0.03872460f, -0.03394827f, 0.06246578f, 0.09061049f, 
    -0.04879865f, -0.09266049f, 0.09402130f, -0.03912954f, 0.20160349f, 0.15281196f, -0.14525788f, 0.11683151f, 
    0.11427314f, 0.09715677f, -0.05100244f, 0.07810507f, 0.06194449f, -0.07276989f, 0.06362585f, 0.02891717f, 
    -0.35420573f, -0.04740322f, 0.39120641f, 0.11065206f, -0.09639151f, 0.16561846f, 0.03000227f, -0.13202420f, 
    0.13541526f, 0.06331924f, 0.08320556f, -0.01866199f, 0.12072153f, -0.26983970f, 0.01466622f, 0.14499418f, 
    0.00491915f, -0.01609357f, -0.07685539f, 0.02662089f, -0.14071050f, -0.17879370f, 0.07643876f, 0.14965416f, 
    -0.50131714f, 0.16565269f, -0.00468620f, -0.26019800f, 0.10469234f, -0.07303737f, -0.10409878f, 0.00336167f, 
    -0.14738546f, -0.18130639f, -0.06226439f, -0.07563054f, 0.42301553f, -0.03800055f, -0.06623439f, -0.07288877f, 
    -0.09884632f, 0.02852362f, -0.00336410f, 0.13420728f, -0.07828211f, -0.01277008f, 0.02674851f, -0.01648528f, 
    -0.08832886f, 0.06847274f, 0.12327600f, 0.15307383f, 0.02891710f, 0.09335952f, 0.02906659f, -0.14397229f, 
    -0.04168576f, -0.16671588f, 0.04476951f, 0.00863993f, 0.31642231f, -0.00432399f, -0.02090158f, 0.00941166f, 
    0.02638657f, -0.06910606f, 0.02221736f, 0.03149007f, 0.03627732f, -0.05477531f, 0.14389032f, 0.13388178f, 
    -0.33086240f, 0.24904087f, 0.31410357f, 0.28372887f, 0.16218135f, 0.16716775f, 0.19161765f, -0.09957141f, 
    0.06394137f, 0.21128373f, -0.06156043f, -0.00505340f, 0.14253874f, -0.30687881f, -0.12256267f, 0.27894679f, 
    -0.16607292f, 0.08921745f, 0.05123780f, 0.06442361f, 0.04752618f, -0.09843533f, 0.00375400f, -0.09244961f, 
    -0.21243449f, 0.10042527f, 0.25513536f, 0.16261820f, 0.06518358f, -0.03050465f, 0.01832770f, 0.04506040f, 
    -0.03948945f, 0.06287859f, -0.02561440f, 0.02608453f, 0.12292376f, 0.16057406f, -0.12902480f, 0.08999345f, 
    -0.07046859f, 0.11147921f, -0.09572200f, -0.02334769f, 0.03579867f, -0.05522110f, 0.02803184f, -0.05145885f, 
    0.20818456f, 0.03201815f, -0.10274182f, 0.04445691f, -0.05529616f, 0.01492137f, -0.03618274f, 0.00079194f, 
    -0.13672547f, -0.00324721f, -0.08307425f, 0.06169917f, 0.32757583f, -0.29829255f, -0.07945618f, 0.15049416f, 
    -0.22320245f, 0.00461292f, -0.17484675f, -0.03869375f, -0.14695102f, 0.05611857f, -0.01347669f, 0.06436750f, 
    -0.34240100f, -0.15166155f, 0.07642382f, 0.14627621f, 0.08396517f, 0.13268217f, -0.00428296f, -0.05833494f, 
    -0.05325599f, 0.03958928f, -0.02044255f, -0.21905516f, 0.14864436f, -0.13627318f, -0.13099913f, 0.20918335f, 
    0.12473991f, 0.04878867f, 0.09864950f, 0.12839754f, -0.02371186f, 0.02280387f, 0.06276161f, -0.06056286f, 
    0.13381059f, -0.10478762f, -0.03131703f, -0.09336068f, -0.05621130f, 0.14485802f, -0.02622372f, 0.05500076f, 
    0.18054229f, 0.11444879f, -0.11658306f, 0.16145442f, -0.52585441f, -0.05765525f, -0.26208997f, -0.00378257f, 
    0.13202003f, -0.16544525f, -0.01725708f, 0.01014469f, 0.00565306f, 0.09688183f, 0.02913881f, -0.06312400f, 
    -0.24467875f, 0.05964804f, 0.16127004f, -0.25670019f, -0.03536111f, -0.13212036f, 0.00364780f, 0.13827126f, 
    -0.03735275f, 0.02023723f, -0.08957309f, 0.01920966f, -0.42469847f, -0.16525549f, 0.24619234f, 0.06058989f, 
    -0.08672631f, -0.02319642f, -0.04962116f, 0.07153581f, -0.05648600f, 0.02508503f, 0.10540844f, 0.04274355f, 
    -0.34209159f, 0.06823222f, -0.09068930f, -0.12382745f, -0.07355308f, 0.16281722f, 0.09035145f, 0.00490023f, 
    -0.03324056f, -0.08491407f, -0.07506371f, 0.21915920f, -0.31881946f, -0.19844989f, 0.17452824f, 0.14648791f, 
    0.00083425f, -0.17602573f, -0.10512059f, 0.20081389f, 0.10239092f, 0.02091246f, 0.19235013f, -0.01675300f, 
    -0.03398982f, 0.01380963f, -0.01700254f, -0.03872547f, -0.05082954f, 0.01879198f, -0.05097201f, -0.03153820f, 
    -0.01825631f, 0.00470970f, -0.03404879f, 0.01181346f, -0.05026975f, -0.00841913f, -0.00724168f, 0.01592432f, 
    0.03865358f, 0.00684285f, -0.04916892f, 0.00305682f, 0.01917539f, -0.01937871f, -0.00107424f, -0.01528167f, 
    0.03554754f, 0.00430824f, -0.05369759f, 0.02714175f, 0.04808742f, -0.02743723f, -0.01418318f, -0.03267696f, 
    -0.02227648f, 0.01601181f, -0.02599193f, -0.02299617f, -0.04040709f, -0.05117267f, -0.01824379f, -0.00244265f, 
    -0.02154000f, 0.03546770f, 0.02121710f, 0.01789084f, 0.02614713f, 0.03181186f, 0.01552407f, -0.01160373f, 
    -0.02003837f, 0.03348873f, -0.03321188f, 0.02401508f, 0.01392219f, 0.01594680f, -0.03543487f, -0.02283544f, 
    0.03907702f, -0.04787203f, -0.00505398f, -0.03244559f, 0.02357727f, 0.02938868f, -0.04262637f, -0.00899527f, 
    0.03718632f, 0.01722353f, -0.04082283f, 0.01187507f, -0.04402512f, 0.00196959f, -0.03500961f, -0.05229226f, 
    0.00192784f, -0.03886629f, -0.02164917f, -0.04796260f, -0.03419548f, 0.03543897f, 0.04650658f, -0.00848754f, 
    -0.04155731f, -0.02316267f, -0.00067752f, -0.00964997f, -0.03515720f, -0.01259573f, -0.00460972f, -0.00966551f, 
    -0.01580322f, -0.05551303f, -0.05842613f, 0.00072967f, -0.02390546f, -0.03397604f, -0.04169790f, -0.00995864f, 
    0.00541443f, 0.01661059f, -0.02525236f, 0.03323193f, 0.03608306f, -0.02213055f, 0.00859376f, 0.00624831f, 
    -0.03167181f, 0.00081708f, -0.06163657f, 0.03705450f, 0.02480954f, -0.05074564f, 0.03827287f, -0.03891179f, 
    0.01479563f, 0.04409187f, -0.00441384f, -0.01847736f, -0.01970099f, 0.00099588f, -0.04859589f, 0.01043538f, 
    -0.04702925f, 0.02647516f, 0.01718172f, -0.03717056f, 0.03745368f, -0.00963023f, 0.03666725f, -0.04128867f, 
    0.00414968f, 0.03705724f, 0.01801292f, 0.04778551f, 0.01816083f, -0.02877903f, 0.03900804f, 0.01925966f, 
    0.02479218f, -0.01489560f, 0.01672144f, 0.00466209f, 0.02880145f, -0.04860686f, -0.02375223f, -0.05752926f, 
    -0.01261898f, 0.03496313f, -0.00957327f, -0.05053297f, 0.03003751f, -0.01575233f, -0.00484255f, 0.00053148f, 
    0.03440796f, -0.04247640f, -0.00617715f, 0.00315764f, 0.01436184f, -0.01818599f, 0.02413008f, 0.04067244f, 
    -0.01229477f, 0.04009181f, -0.02724111f, -0.00150434f, -0.04843637f, -0.04095448f, 0.00335122f, 0.00354576f, 
    0.02200744f, 0.02099247f, -0.01086535f, 0.02942516f, -0.00223348f, -0.04467849f, -0.00895210f, 0.01784114f, 
    0.03631506f, -0.00385211f, -0.05434568f, -0.04355602f, 0.02956683f, -0.00598551f, -0.01796948f, 0.03225257f, 
    0.00845374f, 0.00029077f, 0.02926501f, -0.05887984f, 0.03848859f, 0.00732345f, -0.02884913f, -0.03438133f, 
    -0.01205672f, -0.01519517f, -0.01138075f, 0.03445342f, 0.01023825f, -0.01077853f, 0.03382052f, 0.02017361f, 
    -0.02420277f, -0.05322770f, 0.03247800f, -0.00081745f, 0.02793814f, 0.03313588f, -0.05470531f, -0.02051990f, 
    0.00696504f, 0.00293960f, 0.03017826f, -0.03815185f, -0.02895789f, -0.01232282f, 0.03955904f, -0.04850835f, 
    -0.04665948f, -0.03723603f, -0.02235715f, -0.03112207f, -0.04490747f, -0.03077466f, -0.04167248f, -0.01889896f, 
    0.00417082f, 0.02166556f, 0.00895027f, -0.05276860f, 0.03610324f, -0.00434048f, 0.00303180f, -0.01727903f, 
    0.03196518f, -0.02361898f, -0.00373099f, 0.02635282f, 0.00510373f, -0.02413940f, -0.01115398f, -0.00298045f, 
    -0.06238963f, 0.00704031f, -0.03326987f, -0.01112469f, 0.03860844f, -0.06008000f, -0.03095403f, -0.02433604f, 
    -0.00145388f, 0.03159545f, -0.02695225f, 0.03962569f, 0.02843065f, -0.05098997f, -0.04948405f, 0.00155867f, 
    -0.00622044f, 0.01297844f, -0.00473117f, -0.03583385f, -0.03027834f, -0.04088414f, -0.02604580f, -0.02142596f, 
    0.01144112f, -0.03024348f, 0.04120132f, -0.05788729f, 0.00674053f, 0.03325360f, 0.02913455f, 0.01347885f, 
    0.02560297f, -0.05490235f, -0.00875365f, -0.04294174f, -0.05889702f, -0.01512345f, -0.05044872f, -0.00562914f, 
    -0.00549075f, -0.03702006f, -0.01402510f, -0.02363529f, 0.00811166f, -0.01877587f, -0.02157966f, -0.03789041f, 
    -0.01666541f, 0.00597980f, -0.03289618f, -0.05743375f, 0.02275069f, -0.01548143f, 0.00123967f, 0.00722189f, 
    0.02814334f, -0.03210992f, -0.03524762f, -0.01464561f, 0.04346714f, 0.03946130f, -0.04527093f, 0.00474915f, 
    -0.03359875f, 0.03657016f, 0.04582444f, 0.00952245f, -0.01736758f, -0.00763351f, 0.01481549f, 0.03931554f, 
    -0.01308647f, -0.05179537f, 0.02258651f, -0.01541873f, -0.02238292f, -0.00692412f, 0.00477504f, -0.02209367f, 
    -0.01615543f, 0.04198041f, 0.02014170f, 0.03964689f, -0.03501421f, -0.00829074f, -0.04599370f, -0.00281533f, 
    0.03050040f, -0.01051911f, -0.01336951f, -0.02058167f, -0.05867074f, 0.04021613f, -0.03227432f, -0.00154079f, 
    0.00184991f, -0.01102124f, 0.04301591f, -0.04463308f, -0.03835822f, -0.02466973f, -0.03264257f, -0.02542166f, 
    0.04332899f, 0.00992091f, -0.00824499f, 0.01493634f, -0.02791055f, -0.02688321f, -0.03738248f, 0.00067827f, 
    0.02767497f, 0.04170735f, 0.01936775f, -0.05000981f, 0.01876104f, -0.04780934f, 0.03579212f, 0.00895538f, 
    -0.04647783f, 0.02908110f, 0.02306848f, 0.02515426f, -0.04461570f, -0.01899317f, -0.00706550f, -0.02326996f, 
    -0.05627912f, -0.01537785f, 0.01613600f, 0.00395787f, 0.02867482f, 0.04086538f, 0.01965504f, -0.00736024f, 
    -0.02272046f, -0.05107542f, 0.05312373f, -0.00191458f, 0.00051188f, -0.01702505f, -0.00039876f, -0.03554654f, 
    -0.13136169f, 0.21117745f, -0.33460131f, -0.40176687f, 0.12181533f, 0.14377506f, 0.00589756f, -0.09781408f, 
    -0.01847931f, -0.01484271f, -0.04910433f, -0.11611046f, -0.14439690f, -0.04503489f, 0.02609557f, -0.29712775f, 
    0.04516439f, 0.10130208f, 0.10982990f, 0.07858405f, 0.06155607f, -0.14231229f, -0.00936779f, -0.03722467f, 
    0.37537879f, 0.03967164f, 0.33942237f, 0.08134978f, -0.03002468f, -0.08201005f, 0.14852548f, 0.18213835f, 
    0.03057823f, 0.12691441f, -0.07075019f, 0.09736140f, 0.40828875f, 0.00672388f, -0.24219812f, -0.11817592f, 
    0.02119885f, 0.10941765f, 0.03990522f, 0.01662189f, 0.03642137f, -0.14281920f, 0.12690008f, -0.03689159f, 
    0.21738942f, 0.18199667f, -0.12225436f, -0.03364747f, 0.03173976f, 0.04487726f, -0.05088088f, 0.06036217f, 
    0.15312639f, -0.06919804f, 0.02588074f, 0.16162018f, -0.03628041f, 0.00397687f, 0.11819680f, 0.19260702f, 
    -0.07098159f, -0.01239283f, -0.05225885f, 0.10321625f, 0.02540879f, -0.09556626f, -0.07888566f, 0.12471628f, 
    -0.11720263f, -0.14682193f, -0.19827405f, -0.32797819f, -0.02622010f, -0.12496908f, 0.00316761f, -0.01082136f, 
    0.00799600f, -0.05062379f, -0.13921165f, -0.04820900f, -0.21153736f, -0.01709858f, -0.05374821f, -0.47813985f, 
    -0.01513946f, 0.00164499f, 0.10749426f, 0.00511140f, 0.10120802f, 0.12819129f, 0.11038095f, 0.00583378f, 
    0.25768784f, -0.13196909f, -0.05779747f, -0.00829784f, -0.08496051f, 0.09682681f, -0.09249245f, 0.14816411f, 
    0.08929095f, 0.09961001f, -0.03581023f, -0.13463755f, -0.02283694f, -0.56876457f, 0.06443608f, 0.06081036f, 
    0.05214703f, -0.00838586f, -0.23718533f, 0.05982773f, 0.09418820f, 0.00944330f, -0.05131922f, -0.17190187f, 
    0.30191472f, 0.09495706f, 0.10671177f, -0.05002228f, -0.13590726f, 0.15749444f, -0.08437376f, 0.14033026f, 
    0.00596330f, -0.01381585f, 0.09575112f, 0.01889649f, 0.13686644f, 0.11708187f, 0.29206935f, 0.00717411f, 
    0.16345474f, -0.10972177f, 0.02164061f, 0.18723226f, -0.11370384f, 0.09747345f, 0.02323977f, 0.00371730f, 
    0.01807704f, -0.07322671f, -0.09667655f, 0.16266894f, -0.13520591f, -0.04523574f, -0.08649129f, 0.05609508f, 
    0.07561935f, -0.00322227f, 0.02238237f, 0.03027689f, -0.08281300f, 0.07793318f, -0.05578506f, 0.15250756f, 
    -0.18864875f, -0.03822310f, -0.17986782f, -0.06360936f, 0.01600083f, -0.12504840f, -0.07412840f, 0.11637508f, 
    0.24826437f, -0.21358261f, -0.24317780f, -0.03426528f, 0.08543188f, 0.04969439f, -0.09755863f, -0.00734664f, 
    0.03712851f, 0.10467064f, 0.02794321f, -0.04603770f, 0.20949273f, 0.06206528f, -0.06565934f, -0.07670163f, 
    0.18260945f, 0.16697389f, 0.01639498f, 0.03067989f, 0.02599448f, -0.02053304f, 0.17538150f, 0.13867188f, 
    0.35697830f, 0.21245842f, 0.10804866f, 0.04618091f, 0.06765192f, 0.08096901f, 0.16176611f, -0.08225890f, 
    -0.05372949f, 0.05879113f, 0.13215487f, 0.10245775f, 0.11762474f, -0.18173431f, -0.04782677f, -0.18700369f, 
    0.11809400f, -0.08772929f, 0.00569777f, -0.10911991f, 0.21552232f, 0.05576449f, 0.03098713f, -0.00331474f, 
    0.36607909f, 0.22405003f, 0.04264790f, 0.12920938f, 0.12747201f, 0.11954468f, 0.00079304f, 0.09356103f, 
    0.11650267f, -0.00507679f, 0.01549151f, 0.19350779f, 0.38219696f, 0.09113393f, 0.02757916f, 0.05302615f, 
    0.12518571f, 0.00320650f, -0.06862497f, -0.03111396f, 0.00091974f, 0.02588698f, 0.10585314f, -0.06228420f, 
    0.29834658f, 0.05185821f, -0.16808912f, -0.01924172f, -0.09326641f, -0.06592374f, -0.01764844f, 0.03479770f, 
    -0.07585888f, -0.05585210f, 0.13243103f, 0.04953947f, 0.25032714f, 0.02901395f, 0.09085891f, -0.00589613f, 
    -0.02860365f, 0.09188952f, -0.03018954f, -0.02676728f, 0.06813993f, -0.06302386f, 0.15245128f, 0.00554455f, 
    0.15600322f, -0.09733839f, 0.21182193f, 0.29773495f, -0.00364687f, 0.03208635f, 0.08828258f, 0.09588071f, 
    -0.03617777f, 0.06996237f, 0.04532016f, 0.12246959f, -0.17963256f, -0.08311322f, 0.18111427f, 0.06108648f, 
    0.07077061f, -0.05905242f, -0.00398844f, 0.02035630f, 0.01418753f, 0.07269771f, -0.10821202f, 0.04556619f, 
    0.06332966f, 0.03355280f, -0.00904389f, -0.11947212f, 0.09110993f, -0.00821654f, 0.04547181f, 0.13603802f, 
    0.06066484f, 0.11319190f, -0.01303240f, -0.07848317f, 0.25665098f, 0.18413894f, -0.12876140f, 0.16657376f, 
    0.20832115f, -0.00003008f, -0.00671389f, 0.16130662f, -0.03611640f, 0.05559252f, -0.08757006f, 0.08104880f, 
    -0.25573584f, -0.03216350f, -0.22606267f, -0.41817480f, -0.00488168f, 0.03153669f, 0.16386506f, -0.04469279f, 
    0.00772733f, 0.01598830f, 0.07399584f, -0.06512321f, 0.55689454f, -0.27732787f, 0.06398271f, 0.11083933f, 
    -0.21333414f, -0.02648077f, -0.03306840f, 0.05464135f, 0.02564546f, 0.11314788f, -0.06904928f, 0.07843244f, 
    -0.23393187f, -0.09361996f, -0.26385400f, 0.05622746f, -0.01587085f, 0.09514464f, 0.05086510f, 0.04226528f, 
    0.06755803f, 0.19569299f, 0.07556899f, -0.09416224f, -0.08294197f, -0.13779040f, 0.10515399f, 0.19370273f, 
    0.03820624f, -0.06814601f, 0.12950493f, -0.06994178f, 0.01181811f, -0.09702038f, -0.00132481f, 0.10459721f, 
    0.22926500f, 0.02147115f, -0.22686163f, -0.14714126f, -0.03162712f, 0.05289554f, 0.11615094f, 0.04836113f, 
    0.01447584f, -0.06800021f, 0.08652969f, 0.21236420f, -0.11581836f, -0.19638544f, 0.16665061f, -0.00221848f, 
    0.00270301f, -0.20471296f, 0.07170708f, 0.08813807f, 0.12143014f, -0.04229862f, 0.02471225f, 0.07037109f, 
    0.26445690f, 0.10138080f, -0.32076985f, -0.12276370f, -0.09874951f, 0.13331343f, 0.08325198f, 0.05393618f, 
    0.11897494f, 0.01712442f, 0.11021354f, 0.11253667f, 0.01828085f, -0.12864996f, -0.03474454f, -0.05903163f, 
    0.07352468f, 0.03610939f, 0.01889840f, 0.15069434f, 0.12259551f, -0.07435504f, 0.04149082f, 0.11442868f, 
    0.20119603f, 0.21739522f, -0.02621509f, 0.25515944f, 0.05155301f, -0.02224341f, 0.02456425f, 0.10972137f, 
    0.13126814f, 0.00851637f, -0.04524256f, 0.07009728f, -0.24749604f, 0.06612512f, 0.03817219f, 0.01731894f, 
    -0.00520363f, 0.10353374f, 0.08709116f, 0.13246584f, 0.16163036f, 0.02814138f, 0.08973026f, -0.16009238f, 
    -0.13069008f, -0.10921876f, 0.26110277f, 0.02085583f, 0.08562977f, 0.06142883f, -0.07689651f, -0.02594258f, 
    -0.03627805f, -0.00351843f, -0.00556658f, 0.14704216f, 0.16324741f, -0.13421465f, -0.01667858f, -0.03286884f, 
    0.13032153f, -0.19648133f, 0.14523831f, 0.14533316f, -0.00641645f, 0.12402268f, 0.03207620f, 0.12912606f, 
    -0.07451537f, 0.00148031f, -0.02623851f, 0.00796258f, 0.07529271f, 0.09326849f, -0.04423937f, 0.14874718f, 
    0.09015892f, -0.17369959f, -0.06817710f, -0.08498325f, 0.05017234f, 0.20590204f, 0.15061574f, -0.12294124f, 
    0.17871448f, -0.00657287f, 0.15113655f, 0.01768230f, -0.02576049f, 0.12146281f, 0.00299347f, 0.12069602f, 
    -0.05714963f, -0.09421916f, 0.14467695f, 0.14023335f, -0.00026466f, 0.00931086f, -0.13854982f, -0.00093383f, 
    0.04103072f, 0.06195892f, 0.06643394f, -0.07950131f, -0.35378546f, 0.30987769f, -0.17307667f, 0.02329198f, 
    0.10599273f, -0.07886522f, 0.05273852f, 0.03477560f, 0.01324231f, 0.06446283f, 0.16078158f, 0.10296985f, 
    -0.09948318f, -0.22682613f, -0.17987324f, 0.05627887f, -0.11124275f, 0.08712976f, -0.07215709f, 0.02831796f, 
    0.06336433f, 0.07681435f, -0.11823391f, 0.07923150f, -0.10256854f, -0.05942992f, 0.19430485f, 0.00242124f, 
    0.00813685f, 0.06613366f, 0.20083433f, -0.01599782f, 0.08581387f, 0.09254407f, 0.04959735f, 0.07725427f, 
    -0.42679134f, 0.05924468f, 0.11247245f, 0.11026954f, 0.14233296f, -0.19971995f, -0.11260733f, 0.18500574f, 
    0.09904451f, 0.11753677f, 0.02458439f, 0.12207212f, -0.26259455f, -0.09208472f, -0.14049539f, -0.06960943f, 
    0.09062555f, 0.09927145f, -0.00819900f, -0.03375925f, 0.07608592f, -0.17719595f, 0.01415575f, 0.06873478f, 
    -0.01656990f, 0.16270199f, -0.17538990f, -0.26560780f, 0.00604993f, 0.07217600f, 0.10509439f, -0.02414044f, 
    0.03303082f, 0.05074919f, -0.02511041f, 0.10323002f, -0.32239306f, 0.13557376f, 0.07009617f, 0.07211780f, 
    -0.00898435f, 0.10717057f, -0.05710860f, 0.04802501f, 0.04858154f, -0.09774844f, 0.08508573f, 0.18129243f, 
    -0.05256162f, 0.25140223f, -0.17824544f, 0.05484258f, 0.11112619f, 0.14207451f, -0.07217456f, 0.03261081f, 
    0.08810232f, 0.06232267f, -0.12003268f, 0.08898304f, -0.50972116f, 0.17078093f, 0.07076060f, -0.19779339f, 
    0.23445490f, 0.08244937f, -0.08355417f, -0.03114760f, 0.09494925f, -0.21954738f, 0.12672873f, -0.09259258f, 
    -0.38934857f, -0.23362520f, 0.17518191f, -0.13099329f, 0.00772333f, -0.01146114f, 0.18164504f, -0.11059698f, 
    0.14352660f, -0.00682086f, 0.01224689f, 0.10664710f, -0.38169461f, -0.25113219f, 0.45876220f, 0.03043072f, 
    0.13314912f, -0.01200974f, -0.01330091f, 0.00335728f, 0.01757127f, -0.04540202f, 0.11743130f, 0.06473286f, 
    0.09032239f, 0.33522242f, -0.18156566f, 0.03442976f, 0.17613883f, -0.13750273f, -0.12146604f, 0.17230500f, 
    -0.05238329f, -0.00741484f, 0.19212924f, 0.09159370f, 0.07893548f, 0.46418983f, -0.10950323f, -0.03828501f, 
    0.13780977f, 0.04235572f, -0.02198701f, -0.00613476f, 0.05684341f, -0.04738542f, 0.14584352f, 0.10291148f, 
    -0.07460491f, 0.00771142f, -0.12134312f, -0.06749915f, 0.14735095f, -0.05165056f, 0.10016309f, -0.04092782f, 
    0.08990587f, -0.07410322f, 0.03101747f, 0.09293053f, -0.10286430f, 0.13916381f, 0.09777394f, 0.01055438f, 
    -0.03940745f, 0.00047657f, 0.05025137f, 0.11209731f, 0.12389151f, -0.05579459f, 0.02098381f, 0.12639375f, 
    0.05357506f, 0.13058023f, 0.11267756f, -0.29808220f, -0.01734326f, 0.07123878f, 0.06048032f, 0.14471756f, 
    0.08229312f, 0.07131743f, -0.02258067f, 0.19840303f, -0.02735443f, -0.06961158f, -0.12626326f, 0.07175101f, 
    0.18010296f, -0.02670550f, -0.15521088f, -0.10595821f, -0.10375933f, 0.03886203f, 0.15876272f, 0.16459306f, 
    0.03408148f, 0.06537110f, -0.00114622f, -0.24117659f, 0.08652498f, 0.08990171f, 0.16390318f, -0.01716318f, 
    0.05448909f, 0.04985633f, 0.11754292f, 0.01324590f, 0.16939464f, -0.09173404f, -0.15559906f, 0.13574234f, 
    -0.16070536f, -0.09454179f, -0.00277148f, -0.06334057f, 0.09076598f, -0.03805041f, 0.02326634f, -0.01323038f, 
    -0.07674579f, -0.16311036f, -0.14092678f, -0.26344010f, 0.00312448f, -0.12278913f, -0.01179548f, -0.06254313f, 
    -0.02534630f, 0.05773104f, 0.06233402f, -0.04289402f, -0.13217010f, 0.04288669f, 0.02377604f, 0.12583648f, 
    -0.06861347f, 0.06258953f, -0.07957782f, -0.03846307f, 0.14562090f, -0.12195615f, -0.06797046f, 0.03156372f, 
    -0.13125622f, 0.00188659f, 0.03467343f, -0.01568367f, -0.02610647f, 0.17085262f, 0.00702219f, 0.05015191f, 
    0.10337723f, 0.19082397f, -0.03333242f, 0.05690978f, -0.30880913f, -0.15209365f, 0.01064761f, 0.11061427f, 
    -0.01609655f, 0.04724067f, -0.15391822f, -0.00813259f, -0.04450072f, -0.01751631f, 0.02984990f, -0.07987803f, 
    -0.08929612f, -0.23963875f, -0.09518404f, 0.29244375f, -0.22740163f, 0.03727223f, -0.01635320f, 0.12137274f, 
    -0.06369659f, -0.06912909f, -0.01774607f, 0.13233380f, 0.25889063f, 0.12740944f, -0.12452718f, -0.10166526f, 
    -0.04544919f, 0.01947214f, -0.10751851f, 0.05760898f, 0.01922921f, 0.13505255f, 0.00435802f, 0.14942038f, 
    -0.29984227f, 0.17004812f, 0.06624626f, 0.23258165f, 0.11647239f, 0.15544243f, 0.07483053f, 0.14277954f, 
    0.02109733f, -0.01717279f, -0.00455143f, -0.08065933f, -0.24966848f, 0.13940009f, 0.31056958f, -0.07628832f, 
    0.25111336f, 0.12848346f, 0.02046420f, -0.00418931f, -0.04609596f, -0.01188035f, 0.02868844f, 0.13253815f, 
    0.09681264f, -0.32651904f, 0.17624959f, 0.26109660f, 0.01385320f, -0.11361726f, 0.08649734f, -0.03376094f, 
    0.12944093f, 0.01709487f, 0.03483088f, -0.07195766f, 0.15826000f, 0.02088702f, 0.08504508f, -0.22373281f, 
    0.00936009f, -0.03160530f, 0.12874141f, 0.17269000f, 0.07879087f, -0.08974583f, 0.00480350f, -0.05505166f, 
    -0.06527504f, 0.03522566f, -0.11682905f, 0.01777510f, 0.06655183f, -0.07765988f, -0.00086957f, 0.00379042f, 
    0.09875273f, -0.02570203f, 0.40078655f, 0.30132198f, 0.13124932f, 0.01433968f, -0.04368793f, 0.06036498f, 
    -0.01362090f, -0.01982670f, 0.01253366f, -0.02919128f, -0.05325979f, -0.18344088f, 0.02748192f, 0.00369339f, 
    0.05565053f, 0.20323277f, 0.29117972f, -0.19350952f, 0.10081402f, 0.04245343f, 0.09379670f, -0.03402463f, 
    0.11924738f, 0.09285535f, -0.04084410f, 0.33341786f, -0.26519808f, 0.25159624f, -0.16605754f, -0.06208742f, 
    -0.10070099f, -0.04868351f, 0.16516462f, 0.11535963f, 0.04342825f, -0.17758848f, -0.14406002f, -0.06430739f, 
    -0.21994483f, -0.05711032f, -0.10866368f, 0.13933919f, 0.00041010f, -0.13133903f, 0.12139981f, 0.10294496f, 
    -0.03955922f, -0.06559107f, 0.22313319f, -0.16151360f, 0.09416457f, 0.17555943f, 0.15632497f, 0.11376493f, 
    0.18851107f, 0.17165382f, 0.03396097f, -0.08344384f, 0.20495167f, 0.05316561f, -0.10804267f, -0.09373947f, 
    -0.03176402f, 0.19626935f, 0.13449039f, -0.33555472f, 0.15446305f, 0.05390744f, 0.00599615f, 0.01336367f, 
    -0.09077939f, -0.06854185f, 0.00508094f, 0.05520406f, -0.27350622f, 0.01670283f, -0.07165766f, 0.05001569f, 
    0.03166941f, -0.09854389f, 0.09420516f, 0.01230793f, -0.10961770f, 0.04687407f, 0.14711149f, 0.03104681f, 
    0.02217422f, 0.17268620f, -0.18901506f, 0.10318938f, 0.11808394f, -0.06289246f, -0.00167583f, 0.06239513f, 
    -0.03150404f, -0.06797333f, 0.06539968f, -0.09675497f, 0.21344279f, -0.28156662f, -0.07895720f, 0.26829717f, 
    -0.00182009f, 0.04634171f, -0.03206368f, 0.07833503f, -0.07607519f, 0.08904054f, -0.00153354f, 0.05700927f, 
    0.20572725f, -0.00825384f, -0.21032557f, -0.15870753f, 0.11615932f, -0.01002447f, -0.01773000f, 0.06457535f, 
    -0.01863239f, 0.04650012f, 0.10657068f, -0.00302183f, 0.00092297f, 0.12233733f, 0.10313458f, -0.16960451f, 
    0.27140743f, 0.00104227f, 0.00309433f, -0.08013138f, 0.14906248f, 0.04608864f, 0.03199147f, 0.00629531f, 
    -0.09412614f, 0.05695048f, 0.05701201f, -0.12992544f, 0.15308543f, 0.01428479f, -0.07724281f, 0.00613410f, 
    -0.11322913f, 0.01830792f, 0.11464965f, 0.10658870f, 0.00074507f, 0.18864042f, 0.25205937f, -0.35472074f, 
    0.07942401f, 0.06585822f, 0.03434971f, -0.01325241f, 0.09610147f, 0.09652141f, -0.05294771f, -0.02952233f, 
    0.08136158f, 0.22803475f, -0.11496912f, -0.11662091f, 0.04578897f, 0.05277547f, -0.07400084f, 0.09873067f, 
    -0.07648554f, 0.03217086f, 0.02750093f, -0.17442934f, 0.13678488f, 0.02724316f, -0.31686851f, -0.32020772f, 
    0.19322796f, 0.11342759f, 0.05991336f, 0.02198849f, -0.09195954f, -0.04411368f, -0.10389876f, -0.04570741f, 
    0.01365801f, 0.14725228f, -0.08094475f, -0.23689306f, -0.03854600f, -0.09496697f, 0.05421887f, 0.09762317f, 
    -0.09355508f, 0.07600146f, 0.06950127f, -0.01663206f, 0.05845676f, -0.11135704f, -0.08755074f, 0.24543487f, 
    -0.06203213f, -0.02574499f, 0.03908454f, 0.08905892f, -0.14698993f, -0.08120622f, 0.13766494f, 0.10733925f, 
    -0.00458279f, 0.12929834f, 0.15503766f, -0.11352760f, -0.00387176f, 0.08824763f, 0.00283800f, -0.04700425f, 
    0.09021579f, 0.05974316f, -0.00423090f, -0.00666633f, -0.19410406f, 0.15840712f, -0.11853179f, -0.15324610f, 
    0.05597932f, -0.07677781f, 0.02427857f, 0.00772806f, -0.07136817f, 0.13158166f, -0.00908929f, 0.07269254f, 
    0.15781501f, -0.09432038f, 0.18512440f, 0.13124146f, 0.02677491f, -0.00005902f, 0.12043233f, -0.00700683f, 
    0.02671319f, -0.17377856f, 0.07688785f, 0.10879010f, -0.26218545f, -0.23898591f, -0.27258906f, -0.03087310f, 
    -0.04065195f, 0.03415660f, 0.01864437f, 0.09840836f, -0.12676968f, 0.04509547f, -0.01011589f, 0.06364156f, 
    -0.05679176f, -0.03338386f, -0.12316135f, 0.13968261f, -0.05535710f, 0.12974113f, -0.10980137f, -0.14138997f, 
    0.11910032f, -0.07314260f, -0.14464380f, 0.06558904f, -0.48581636f, -0.21785507f, -0.09098305f, 0.27813810f, 
    0.04223817f, -0.03150769f, 0.18322347f, -0.10582868f, 0.17289682f, -0.03768733f, 0.04816641f, -0.01845884f, 
    0.25709355f, -0.08961493f, 0.20573269f, -0.02525191f, 0.00775051f, -0.01163746f, 0.08711702f, -0.02457902f, 
    0.03497223f, 0.03076459f, 0.02805007f, -0.10799291f, -0.06396753f, -0.05280020f, -0.02469650f, 0.16189055f, 
    -0.11548756f, -0.06274455f, -0.05673648f, -0.05867380f, 0.07985365f, 0.04838533f, 0.02667431f, 0.08284180f, 
    -0.08720386f, 0.31082529f, 0.29588500f, 0.38307595f, 0.13941161f, -0.17292318f, -0.04742096f, -0.01200824f, 
    0.06737506f, 0.07385899f, 0.04380476f, 0.02988654f, 0.17580324f, 0.35835171f, 0.24781775f, 0.02126534f, 
    -0.01198084f, 0.10478211f, 0.16588549f, 0.05186780f, -0.17261222f, 0.09764590f, 0.02748602f, -0.17317159f, 
    -0.10461898f, 0.11900933f, -0.01655705f, -0.15171672f, -0.18615174f, 0.00018072f, 0.08352495f, -0.13270992f, 
    0.01532088f, 0.02378600f, 0.09374227f, -0.00706485f, -0.00753910f, 0.11489737f, 0.04108659f, 0.02673367f, 
    -0.03900634f, 0.10920919f, -0.08708598f, -0.11817902f, 0.01814064f, 0.05879426f, 0.01914327f, 0.02385718f, 
    -0.20709193f, 0.13960087f, -0.02262298f, -0.12228244f, -0.07176357f, -0.00447222f, 0.04220292f, -0.05691699f, 
    0.08000063f, -0.02841616f, 0.01426634f, -0.05753368f, -0.07885364f, 0.02412795f, 0.05898545f, 0.15980469f, 
    -0.01283119f, -0.03191124f, 0.01187090f, -0.09502757f, 0.02031791f, 0.01755156f, 0.03563517f, 0.00855470f, 
    -0.03322691f, 0.06126539f, 0.33251151f, 0.12133114f, 0.04456227f, 0.02051006f, 0.02506085f, 0.03401084f, 
    -0.17575508f, 0.09823842f, 0.05815521f, -0.07543927f, 0.31575841f, 0.12601255f, 0.14487894f, 0.29058918f, 
    0.08582403f, -0.01234579f, 0.02319589f, 0.03406795f, 0.04007258f, -0.00342810f, -0.01223275f, -0.01908430f, 
    -0.08464375f, 0.09842287f, 0.04550576f, 0.01197409f, 0.09357480f, -0.02098616f, -0.05401628f, 0.10807211f, 
    0.03174439f, -0.05723709f, -0.03625593f, 0.03722249f, 0.33217311f, -0.09058066f, 0.09214403f, 0.23893316f, 
    -0.20687696f, 0.05240308f, 0.00947126f, -0.08421875f, 0.04050155f, -0.07707649f, 0.13928257f, 0.05098748f, 
    -0.00025934f, 0.35831660f, 0.28798977f, 0.06382652f, 0.05397069f, -0.04646607f, 0.07419428f, -0.09388117f, 
    -0.02905040f, 0.14133365f, -0.11287422f, 0.02701842f, 0.40010101f, 0.25473240f, -0.01233403f, -0.03258190f, 
    -0.11316727f, -0.10093392f, -0.01531929f, 0.01472830f, 0.01014181f, -0.05947959f, 0.14878762f, 0.13488542f, 
    -0.01051594f, -0.14278226f, 0.05755769f, 0.31735831f, -0.00004969f, -0.05229704f, 0.11343440f, -0.00002265f, 
    0.00458206f, 0.02518114f, -0.00064350f, -0.04028741f, 0.08750600f, 0.11692857f, 0.48992464f, 0.04230702f, 
    0.02869130f, 0.08722480f, 0.06844467f, 0.09071504f, 0.12031292f, 0.06001464f, -0.00161589f, -0.08242024f, 
    -0.20694223f, 0.25672463f, 0.33110276f, -0.09121097f, 0.05565398f, -0.00008741f, 0.04489952f, 0.04375506f, 
    0.04066582f, 0.11179708f, 0.02655265f, 0.10455688f, -0.08309702f, -0.24731050f, -0.11415008f, -0.20432088f, 
    0.15230043f, -0.11549554f, -0.11244561f, 0.06440031f, 0.11836191f, 0.01207253f, 0.07756373f, -0.04313811f, 
    -0.14752698f, -0.21755308f, -0.06522184f, 0.04605472f, -0.06217138f, -0.03225715f, -0.04084190f, -0.08286884f, 
    0.11122036f, -0.12508593f, 0.07993454f, 0.07275418f, 0.18575718f, -0.07073840f, -0.16908771f, 0.22790858f, 
    -0.03139418f, -0.04899975f, 0.02883703f, -0.03407659f, 0.01514977f, 0.15638183f, 0.09679608f, 0.08596780f, 
    0.21289743f, -0.19942029f, -0.18534604f, 0.33655661f, -0.08816466f, -0.06947639f, -0.03660174f, 0.08723552f, 
    0.05338423f, 0.11187585f, -0.06374311f, -0.08269991f, -0.10738856f, -0.23058157f, -0.33919969f, 0.19315276f, 
    -0.03360982f, -0.02008915f, 0.02309627f, 0.00904171f, -0.00169099f, 0.08424626f, 0.09808093f, 0.03998270f, 
    -0.52060956f, -0.51572073f, 0.01855828f, 0.34347776f, -0.05858289f, -0.02919316f, 0.13427801f, 0.05144593f, 
    0.00521102f, 0.04219138f, -0.04870452f, 0.08283081f, -0.16492572f, -0.20376478f, 0.09715940f, 0.03392268f, 
    -0.08992179f, -0.04465650f, -0.01308096f, -0.03468365f, 0.06468222f, 0.01906174f, -0.07350193f, 0.10491446f, 
    0.15974662f, -0.33745056f, -0.16272268f, 0.28834152f, 0.03386497f, 0.05686098f, -0.07633392f, 0.00924720f, 
    -0.05651816f, 0.08893431f, -0.07857167f, -0.11328413f, 0.06114265f, -0.23813935f, 0.00229872f, -0.13222809f, 
    -0.04441329f, 0.04759846f, 0.11914001f, 0.06693194f, 0.00811475f, 0.09842168f, -0.00162816f, 0.09445259f, 
    -0.07127213f, -0.29049128f, -0.01583432f, 0.44376713f, -0.01392184f, -0.21694542f, 0.05812357f, 0.00268269f, 
    -0.00635573f, 0.08793892f, 0.06558891f, -0.06705046f, -0.21264753f, -0.10281816f, -0.10641282f, 0.05358117f, 
    -0.02919720f, -0.02919127f, -0.03647706f, 0.02564558f, 0.00868478f, -0.04656754f, -0.00410806f, -0.13503172f, 
    0.15374309f, 0.13700154f, 0.28725699f, 0.16844036f, -0.04404527f, -0.00132982f, -0.09122277f, 0.01696314f, 
    0.18705958f, 0.03216409f, -0.02615105f, -0.02109922f, -0.04714732f, 0.64849323f, 0.28949383f, -0.07352529f, 
    0.04170553f, 0.05649868f, -0.06432374f, 0.15248308f, -0.04438934f, -0.06259201f, 0.00750367f, -0.07264741f, 
    0.65520412f, 0.38449040f, -0.00714013f, 0.23289852f, 0.16245371f, -0.03784577f, 0.07347659f, 0.02221357f, 
    0.14692180f, 0.06749386f, -0.10521894f, -0.00638593f, 0.24289906f, -0.03344075f, -0.30512276f, -0.10856123f, 
    -0.04743397f, 0.14356510f, 0.14117615f, -0.04769378f, -0.06291861f, 0.07035401f, 0.04940682f, -0.09704227f, 
    -0.23920839f, 0.05089003f, 0.00477204f, 0.01135059f, 0.08116784f, -0.05542055f, -0.05613330f, -0.06805041f, 
    0.01681970f, 0.05308227f, 0.03787936f, -0.05476592f, 0.38857260f, 0.30073205f, 0.01150536f, 0.19717455f, 
    0.01731734f, 0.12637101f, 0.18342178f, 0.06832749f, 0.00461912f, -0.10163376f, 0.03150825f, -0.03617247f, 
    -0.06159774f, -0.09857699f, 0.05666475f, 0.13228007f, -0.04061727f, 0.12083101f, -0.07436814f, 0.09411326f, 
    -0.09793481f, 0.00347252f, 0.03446077f, -0.07422945f, -0.13610050f, -0.01084313f, 0.13187249f, 0.04178061f, 
    0.09884269f, -0.08393683f, 0.01525234f, -0.13577428f, -0.00400098f, 0.11460955f, 0.02850440f, 0.10729443f, 
    -0.08065356f, -0.09666137f, -0.18078834f, 0.00802787f, -0.03402879f, -0.02198788f, -0.11771306f, 0.03679171f, 
    -0.00161923f, 0.10576413f, -0.01371817f, 0.00181372f, 0.17451662f, 0.01886613f, -0.06029274f, -0.01274222f, 
    0.15395105f, 0.01622487f, 0.08311162f, 0.08243077f, -0.08661216f, 0.04589717f, 0.19704098f, 0.07876582f, 
    0.16359371f, -0.02244486f, -0.16432913f, 0.34978580f, 0.19790587f, 0.05272058f, 0.01962393f, 0.04993521f, 
    -0.07706823f, 0.02766727f, -0.04207822f, 0.09267525f, 0.11162082f, -0.20516828f, 0.17343374f, -0.21692671f, 
    -0.04935747f, -0.07468098f, 0.24785340f, -0.00469682f, -0.01641203f, 0.00515492f, -0.05747538f, 0.02276817f, 
    0.16049919f, -0.08470903f, -0.17064855f, 0.10712864f, 0.01501438f, -0.06000303f, 0.04363937f, -0.11599599f, 
    0.13148890f, 0.04599847f, 0.02637317f, 0.13550083f, -0.15481432f, -0.02202206f, -0.21602285f, -0.26676491f, 
    0.04532363f, 0.05436522f, 0.02170414f, 0.01161225f, -0.09992364f, -0.10370779f, -0.06066325f, 0.02705915f, 
    0.18050246f, -0.10999200f, 0.15693210f, -0.15914796f, 0.13435021f, -0.00952755f, 0.16438532f, 0.01651427f, 
    -0.00118095f, 0.10359390f, 0.20867248f, -0.06913381f, -0.22142345f, -0.00663771f, -0.10103124f, -0.12461689f, 
    -0.00828627f, 0.01365081f, 0.00448384f, 0.11725107f, 0.06742907f, -0.00334992f, -0.11245339f, -0.04051914f, 
    -0.47045752f, -0.21848305f, 0.19660001f, -0.24400416f, -0.02808271f, 0.01596056f, 0.10221423f, 0.03579091f, 
    0.05905224f, 0.02837978f, 0.04056068f, 0.02802715f, -0.13002189f, -0.00300297f, 0.22638403f, -0.08683070f, 
    -0.02304859f, 0.11761230f, -0.04375137f, -0.01909507f, -0.01918733f, -0.03090015f, 0.06889387f, 0.02385710f, 
    0.11475599f, 0.08646049f, 0.14338683f, -0.27431452f, 0.03035913f, -0.01108536f, -0.03661343f, 0.13528226f, 
    -0.05908487f, 0.05096919f, 0.16021150f, -0.03024605f, 0.06528775f, 0.03979616f, -0.06630763f, -0.26595023f, 
    0.00564503f, -0.04857475f, 0.02696425f, -0.09617651f, 0.10983905f, 0.00266217f, 0.04580089f, 0.03803500f, 
    0.44806051f, -0.18387742f, -0.05090314f, 0.18542954f, -0.05828758f, 0.00006680f, -0.05778356f, -0.06099449f, 
    -0.02786924f, -0.02673919f, -0.03510329f, -0.05130975f, 0.10807725f, 0.21393569f, -0.21264507f, 0.41716599f, 
    -0.01422342f, 0.15839477f, -0.06173666f, 0.00286375f, -0.02648570f, 0.12959507f, 0.02473315f, -0.02065010f, 
    0.05465883f, 0.06394434f, -0.09853485f, -0.03552924f, 0.06624796f, -0.08749065f, -0.06302463f, 0.09640317f, 
    0.00056789f, 0.09565833f, 0.03222237f, -0.09926753f, 0.06567543f, -0.02851708f, 0.08935687f, 0.27619880f, 
    0.15930699f, 0.04478221f, -0.06198990f, -0.00500561f, -0.02156100f, -0.04055641f, -0.07030899f, -0.05738474f, 
    0.00976986f, 0.03108829f, -0.15277730f, -0.17649980f, 0.02101143f, 0.08873361f, -0.14789124f, -0.02618267f, 
    -0.10674339f, -0.11240692f, 0.02595088f, 0.16623561f, 0.21456318f, 0.30409515f, 0.26668251f, -0.14907014f, 
    0.29008493f, -0.10114542f, -0.05899213f, -0.06935430f, -0.00142283f, -0.05761001f, -0.06970393f, -0.01081097f, 
    0.31591997f, 0.13499057f, 0.14985423f, -0.16036044f, -0.02132004f, 0.03772841f, -0.11834269f, -0.01940655f, 
    0.09421100f, -0.01552571f, 0.08850398f, -0.12320722f, 0.22864628f, -0.07372008f, -0.05971011f, 0.11151369f, 
    0.09980862f, -0.03353236f, -0.08332250f, -0.03790293f, 0.09238573f, -0.02555161f, 0.19204177f, 0.01041778f, 
    -0.30332890f, 0.23191585f, 0.17190732f, -0.17827937f, -0.01621988f, 0.00388868f, 0.07331348f, -0.01297267f, 
    0.15118761f, 0.10257110f, 0.08146450f, 0.12245645f, -0.34027424f, 0.15309826f, 0.22596265f, 0.23252535f, 
    -0.13565281f, -0.01005711f, -0.12091894f, -0.04050018f, -0.08072677f, -0.00990041f, 0.14200881f, -0.10318575f, 
    0.23805270f, 0.04409465f, 0.00439193f, -0.29052714f, 0.06481349f, 0.12056845f, 0.01139741f, 0.10805298f, 
    -0.00406490f, -0.02829763f, 0.03453482f, 0.06563110f, -0.02603821f, 0.18158141f, 0.15470874f, 0.08471042f, 
    0.09202215f, 0.02994550f, 0.05037983f, -0.07573580f, -0.07118849f, 0.06905064f, -0.01194729f, 0.12734151f, 
    0.23152880f, -0.08218173f, -0.12703417f, 0.03432836f, 0.01646027f, -0.07308175f, 0.11965448f, -0.04184506f, 
    -0.09394640f, -0.03814771f, 0.12562165f, -0.02821518f, 0.02111776f, -0.50278741f, -0.20155525f, 0.01404997f, 
    -0.10403349f, 0.01645501f, 0.12445261f, -0.08040336f, -0.00997004f, -0.12878284f, 0.14044130f, 0.08349367f, 
    0.14611740f, -0.23526472f, -0.11516241f, 0.27085057f, -0.04675188f, 0.14632171f, 0.13907655f, -0.02129507f, 
    -0.03510264f, -0.02197463f, 0.08684570f, 0.00288751f, -0.16029090f, 0.13407470f, -0.10294501f, 0.05589767f, 
    -0.03121691f, 0.01620027f, 0.01335105f, -0.08462572f, 0.11057671f, -0.05308150f, -0.00050603f, 0.09443399f, 
    0.21974909f, -0.18850914f, 0.18276465f, -0.06015359f, 0.17584397f, -0.11574508f, 0.07888263f, 0.02841265f, 
    0.10239013f, 0.05506253f, -0.01508308f, -0.05893071f, -0.00228569f, -0.04501444f, 0.09982897f, -0.30384043f, 
    -0.22125627f, 0.02756269f, 0.12910862f, -0.19810438f, -0.01074355f, 0.09433457f, -0.03319033f, 0.12776783f, 
    -0.02574953f, 0.02567055f, -0.01348044f, -0.01778880f, 0.00642153f, -0.05857928f, 0.01098849f, -0.04536064f, 
    0.00376783f, -0.04169838f, 0.03071180f, -0.05129402f, 0.02638716f, 0.00627418f, -0.03474703f, 0.03884404f, 
    -0.03849510f, -0.03762205f, 0.02910126f, -0.05555863f, -0.03983314f, -0.03469704f, 0.03722640f, -0.04570893f, 
    0.01160400f, 0.02539864f, 0.03644420f, 0.04412748f, -0.00821931f, -0.01993256f, 0.02554892f, -0.00831446f, 
    -0.00046671f, -0.04213067f, -0.00268718f, -0.01609626f, 0.03685357f, -0.02871538f, -0.05041491f, -0.01786250f, 
    0.03885249f, -0.01040096f, 0.01640481f, 0.01433476f, -0.03350760f, -0.01828860f, 0.03770741f, 0.02388483f, 
    -0.04256196f, 0.00923583f, 0.03419274f, -0.02703694f, -0.00864354f, -0.05781599f, -0.03927682f, -0.02794185f, 
    0.00550846f, 0.03877730f, -0.00301064f, -0.05342607f, -0.01074542f, 0.03337213f, -0.03450827f, -0.03962714f, 
    -0.02534582f, 0.03506683f, 0.00970483f, 0.04154485f, -0.01604171f, -0.05420949f, -0.02379646f, -0.02928065f, 
    0.00741611f, -0.03265976f, -0.04927593f, -0.03023863f, 0.03374971f, -0.03372364f, 0.01181138f, -0.02681943f, 
    -0.05496521f, -0.03513066f, 0.03226587f, -0.01638930f, 0.00225997f, -0.03999297f, 0.04092084f, -0.03335625f, 
    -0.02728819f, -0.01378288f, -0.03158495f, -0.05304998f, -0.04537437f, 0.04784879f, 0.03305892f, 0.03002102f, 
    -0.02742446f, -0.01566590f, -0.02997845f, 0.02493264f, -0.02069274f, 0.03268645f, 0.00029002f, 0.02072827f, 
    0.00601790f, -0.02787056f, -0.03438399f, -0.02956343f, 0.00930681f, -0.00329243f, -0.04244427f, -0.01640743f, 
    -0.02530447f, -0.02959145f, 0.00057242f, -0.01612351f, 0.00639767f, -0.00401509f, -0.03723702f, 0.04174401f, 
    -0.06120132f, -0.03044155f, -0.04853129f, -0.03559546f, -0.03111698f, -0.02002693f, -0.00954367f, 0.00791348f, 
    -0.00187559f, -0.05286774f, -0.02706066f, 0.04226141f, 0.02874518f, -0.02354490f, -0.01145138f, -0.03360046f, 
    0.01606143f, -0.00817681f, -0.03663439f, 0.00138390f, -0.05146611f, -0.03133516f, -0.00108569f, -0.04457268f, 
    -0.02153403f, 0.01257671f, 0.01616592f, -0.02745175f, 0.00223572f, 0.02916468f, -0.03727482f, 0.00407074f, 
    -0.00688994f, -0.02209650f, 0.01808845f, -0.01308179f, 0.03148188f, 0.00526592f, 0.00130655f, 0.01155009f, 
    -0.05285880f, 0.01744132f, -0.01806615f, -0.03353475f, -0.05582076f, -0.05780924f, 0.03905362f, 0.03015924f, 
    -0.04871585f, 0.03142276f, -0.04855420f, 0.04216274f, 0.04780877f, -0.00282177f, -0.02231572f, -0.03517165f, 
    -0.05172684f, -0.01219402f, 0.00322534f, 0.02968632f, -0.03458627f, -0.01890819f, -0.01061023f, -0.01449076f, 
    0.00447716f, 0.00920043f, -0.04572420f, 0.01570872f, -0.00575697f, -0.00549032f, -0.01205119f, -0.01522017f, 
    0.01935532f, -0.00110833f, -0.02099102f, -0.02149263f, -0.03289700f, 0.00081477f, 0.04042706f, 0.02004540f, 
    0.01744146f, -0.00310058f, 0.02696601f, -0.03361778f, -0.04186600f, 0.00419574f, 0.01364383f, 0.01084954f, 
    0.00419963f, -0.03681282f, -0.04429059f, -0.03358108f, 0.04558641f, -0.04651884f, 0.04389900f, -0.05492869f, 
    0.01669883f, 0.01267626f, -0.05565038f, 0.04054725f, 0.04464702f, 0.04120491f, 0.02515842f, 0.00002360f, 
    0.01474940f, 0.03996536f, -0.02786291f, 0.03384805f, 0.01542859f, 0.01336594f, 0.02063010f, 0.03718174f, 
    -0.02795315f, -0.01548251f, -0.01950248f, -0.03825834f, 0.04244008f, 0.00301279f, 0.04022908f, 0.02321660f, 
    0.04086950f, -0.01874572f, 0.04724796f, -0.04585004f, -0.04654313f, -0.00350521f, 0.05378157f, 0.00425082f, 
    0.00317027f, 0.02125377f, 0.03868138f, -0.01303611f, 0.02213720f, -0.00186694f, -0.02728434f, 0.03877564f, 
    0.04172704f, 0.01785586f, -0.03635991f, 0.03300810f, -0.03993044f, -0.02197373f, -0.02127210f, -0.00522290f, 
    -0.02744977f, -0.01711257f, 0.01643141f, -0.01670410f, -0.00738690f, -0.00700068f, -0.02861301f, -0.02048898f, 
    0.01419166f, 0.03681936f, 0.00216375f, -0.02122751f, -0.02547532f, 0.03804106f, -0.04261980f, -0.05873420f, 
    0.01258406f, -0.05041821f, 0.02320280f, -0.02071299f, 0.03461483f, 0.02625447f, 0.01990280f, 0.01175818f, 
    -0.01428780f, 0.00905800f, 0.01994750f, -0.04690995f, 0.00124324f, 0.01542850f, -0.01832320f, 0.04929138f, 
    0.04497949f, -0.02987867f, 0.02776615f, 0.01818526f, 0.03500331f, 0.02029380f, 0.01420476f, 0.03743084f, 
    0.03401148f, 0.00873595f, 0.00122440f, 0.01053527f, 0.03752320f, 0.01353976f, 0.03842301f, -0.02852567f, 
    0.03753992f, 0.01810023f, -0.05557730f, -0.03837653f, -0.03297913f, 0.01583945f, -0.01028164f, -0.04774450f, 
    0.03199086f, 0.02474475f, 0.02210643f, 0.03752045f, -0.03958631f, 0.02021375f, -0.00047974f, -0.03316412f, 
    0.00182464f, 0.01891102f, -0.03382516f, 0.03020537f, -0.03974643f, -0.04022520f, -0.02152181f, -0.02464787f, 
    -0.02814166f, -0.02323464f, -0.01459316f, 0.03172357f, -0.03347857f, 0.02442972f, 0.00668357f, -0.05246104f, 
    -0.00467433f, -0.00093137f, -0.04838886f, 0.02480696f, -0.03074178f, -0.03537904f, -0.00776546f, 0.00468914f, 
    0.02315259f, -0.00740191f, -0.00877823f, -0.01832810f, -0.02802707f, 0.01228433f, -0.05011594f, 0.03438013f, 
    -0.02406638f, -0.03475879f, 0.03993627f, 0.03995156f, 0.00279728f, -0.01286072f, -0.00690218f, -0.03369511f, 
    0.02697410f, -0.01645713f, -0.00272473f, 0.00900675f, -0.04474491f, 0.00116499f, 0.02235928f, 0.00927529f, 
    -0.00413279f, -0.00633211f, 0.00344930f, 0.04052410f, -0.01324074f, 0.00756990f, -0.01365547f, -0.02455647f, 
    0.01768788f, -0.04094470f, -0.01040572f, -0.03125679f, 0.03486524f, -0.00563765f, 0.01855635f, -0.03048709f, 
    -0.05696217f, -0.03101815f, -0.04796457f, 0.04193092f, -0.01608423f, -0.02858368f, 0.03091680f, -0.01678659f, 
    -0.02844523f, 0.03344994f, 0.02447567f, -0.05003531f, 0.00507740f, -0.03307751f, -0.02519675f, -0.02818591f, 
    0.01120182f, 0.01330809f, 0.00366197f, -0.04274026f, 0.00274729f, 0.00741815f, -0.02120634f, -0.01880991f, 
    -0.03856194f, 0.00495348f, 0.02434468f, 0.00094996f, -0.02071667f, -0.05469546f, 0.01994192f, -0.00131692f, 
    -0.05643469f, 0.02535554f, 0.03774569f, 0.01050130f, -0.02310682f, -0.03036600f, -0.00626425f, 0.00092103f, 
    -0.02051489f, 0.01568916f, 0.03836668f, -0.04421414f, -0.02479953f, -0.05321925f, -0.03941029f, 0.03238171f, 
    -0.04681960f, -0.02267760f, -0.04559314f, -0.04977893f, 0.02233052f, -0.05122950f, 0.00814108f, 0.00513056f, 
    -0.02047782f, 0.03228289f, -0.05374108f, -0.00687714f, -0.00416290f, -0.02087186f, 0.01701465f, -0.02306520f, 
    0.00002410f, -0.01564741f, -0.03129172f, 0.03401831f, -0.01966502f, 0.03445283f, -0.04269144f, 0.04349694f, 
    0.00297005f, -0.05735891f, 0.03634122f, -0.00519372f, 0.00361590f, 0.00943194f, 0.01120127f, -0.00849532f, 
    0.02467592f, 0.00422705f, -0.05300452f, 0.01114640f, -0.03024661f, 0.03651660f, 0.00544190f, 0.03243050f, 
    -0.02823158f, 0.01552473f, -0.01317623f, 0.02915961f, -0.00817585f, 0.01013805f, -0.00902351f, 0.01401874f, 
    0.00913462f, 0.02728093f, -0.02512704f, -0.04377320f, -0.04332516f, 0.01732389f, -0.02039398f, -0.01899001f, 
    0.03256120f, -0.04153515f, 0.01653881f, 0.03808086f, 0.00933042f, -0.03549178f, -0.00990382f, -0.03213999f, 
    -0.04733195f, 0.04013408f, -0.05332039f, 0.01628619f, 0.02079622f, 0.00862020f, -0.00381851f, -0.01468467f, 
    -0.01808631f, 0.03179528f, 0.02925528f, -0.02769120f, -0.05456745f, 0.01281707f, 0.04160538f, 0.03835286f, 
    -0.00669844f, 0.04014955f, -0.03803368f, -0.01787807f, -0.00611151f, -0.00005534f, -0.05534329f, -0.03816799f, 
    0.04240495f, 0.00044201f, 0.03232504f, -0.02404003f, 0.03600304f, 0.00560039f, 0.02665644f, 0.00289304f, 
    -0.04960351f, -0.00047034f, 0.02663614f, 0.03416563f, -0.00635145f, 0.01897398f, -0.00347131f, 0.00886068f, 
    -0.05729252f, -0.05013404f, 0.00844151f, -0.03885077f, -0.04007491f, 0.04148693f, 0.02531935f, -0.04294007f, 
    -0.04041547f, -0.00845565f, -0.04375472f, -0.01019326f, -0.01120106f, 0.03946495f, 0.03155477f, -0.01878409f, 
    0.00706609f, 0.02361827f, 0.02284363f, -0.02467149f, 0.01356199f, 0.01772195f, 0.02419639f, -0.04702667f, 
    0.01941687f, -0.00386948f, 0.03917366f, 0.00324225f, 0.00110653f, -0.05102044f, 0.00605753f, -0.02460536f, 
    0.04070194f, -0.00105961f, 0.03480135f, -0.02387102f, -0.00890408f, -0.04580796f, 0.01998109f, -0.02238073f, 
    -0.02603439f, 0.00028443f, -0.04457081f, 0.01758147f, -0.05520710f, -0.04239384f, -0.00870209f, -0.03028218f, 
    0.03017161f, -0.02750822f, -0.01833733f, 0.03506599f, 0.01157401f, 0.02885010f, 0.00265877f, -0.04980244f, 
    -0.02017236f, -0.05656881f, 0.01901430f, -0.01806277f, 0.02280726f, -0.03734908f, 0.03534266f, -0.02938321f, 
    0.02755777f, -0.00547943f, 0.02040299f, -0.05032193f, 0.01115473f, 0.02601008f, -0.04818243f, -0.03228419f, 
    -0.04406656f, 0.04263162f, 0.02002500f, -0.02779497f, 0.01694255f, 0.02435807f, -0.00285095f, 0.02543514f, 
    0.01933838f, 0.02961232f, 0.00426841f, 0.03257268f, 0.00141745f, -0.04684736f, 0.02037579f, 0.01559142f, 
    -0.03822896f, -0.03589085f, -0.01200865f, -0.00656623f, 0.01877692f, -0.05540829f, -0.04072523f, 0.02387793f, 
    -0.04390332f, -0.03443381f, -0.02309425f, -0.03072361f, -0.05321625f, 0.03590255f, 0.01895475f, 0.03223379f, 
    0.03242529f, -0.03082373f, -0.02155169f, 0.03852782f, -0.01541670f, -0.00342374f, 0.02834091f, 0.01962507f, 
    -0.04362316f, 0.02628141f, -0.04995317f, -0.03279832f, 0.00891399f, 0.04028500f, -0.03131540f, -0.00259286f, 
    -0.02048103f, 0.01637962f, -0.03639502f, 0.00769140f, 0.02438257f, -0.05559549f, -0.00608267f, -0.02154249f, 
    -0.05232965f, 0.00878908f, 0.00403560f, -0.03171443f, -0.02800835f, 0.02141336f, 0.00410814f, 0.02106532f, 
    -0.03483289f, 0.00177877f, 0.02580157f, -0.02842577f, 0.01100126f, -0.00047632f, 0.02568219f, 0.01026789f, 
    -0.00419026f, -0.03909614f, -0.04254835f, -0.03256390f, -0.01269565f, -0.04981162f, -0.03070091f, 0.02844767f, 
    -0.01920527f, -0.00121438f, -0.03121057f, -0.05510330f, -0.00471292f, -0.01077179f, 0.01251849f, -0.00537762f, 
    -0.02189057f, -0.04951800f, 0.03649418f, 0.01246121f, 0.01798259f, 0.03338667f, -0.03123240f, -0.04372869f, 
    -0.03931046f, 0.04107636f, 0.02457211f, -0.00062008f, 0.01311112f, -0.04072738f, -0.01291154f, 0.00841186f, 
    0.02719891f, 0.02619345f, -0.04166256f, 0.02951748f, 0.04318680f, -0.03375050f, -0.02057021f, -0.03966332f, 
    0.04024038f, 0.03294471f, -0.05102695f, 0.01356814f, -0.02230736f, -0.05017792f, -0.05474039f, 0.02483549f, 
    0.02782974f, -0.02670157f, -0.02417157f, -0.02320561f, -0.04907055f, -0.04920339f, -0.01519143f, 0.01623715f, 
    -0.02241594f, 0.02797820f, 0.02738705f, -0.04380020f, -0.03713974f, -0.05787580f, 0.00464658f, -0.01832172f, 
    -0.02507697f, 0.02405418f, 0.00995061f, -0.02652461f, 0.00744425f, -0.01352544f, -0.00819183f, -0.03600541f, 
    0.00712652f, -0.04386467f, -0.03684852f, -0.00706023f, -0.04921541f, -0.00430995f, -0.03382371f, 0.02828109f, 
    0.10260621f, 0.04404168f, 0.17374575f, 0.01049999f, 0.00091224f, -0.02876993f, -0.00370900f, 0.02424912f, 
    0.11505698f, 0.02388680f, -0.03609221f, 0.11604413f, 0.09289689f, 0.14811991f, 0.03383903f, 0.04047308f, 
    -0.05520236f, 0.06948017f, -0.11525436f, 0.07740048f, -0.01405615f, 0.24148622f, -0.04770763f, 0.01728201f, 
    -0.35643694f, 0.10779526f, -0.03131254f, 0.02953910f, 0.03572294f, 0.15697388f, 0.06453759f, 0.14480332f, 
    0.14313129f, -0.27709007f, 0.32883337f, 0.03296591f, -0.36094359f, 0.21497539f, 0.28746828f, 0.00730600f, 
    -0.07645063f, -0.03814584f, -0.03315920f, -0.17937578f, -0.02499991f, 0.22664176f, 0.02965474f, 0.18045942f, 
    -0.36749259f, -0.05059542f, 0.22629198f, -0.13038576f, -0.03883091f, -0.06347375f, 0.11975975f, -0.09372116f, 
    -0.01313703f, 0.02814644f, 0.06383445f, -0.22056390f, 0.34600735f, 0.06753267f, 0.09790069f, 0.14461614f, 
    0.07289137f, -0.02016278f, -0.05126068f, -0.06830159f, 0.01475247f, -0.08710546f, 0.06934102f, -0.13096848f, 
    -0.13263589f, 0.18317646f, 0.08886672f, -0.00218299f, -0.02846593f, 0.03324403f, -0.04311759f, 0.12839556f, 
    -0.03724019f, 0.13109201f, 0.38426447f, 0.15380935f, 0.06978580f, 0.03319234f, 0.11227505f, 0.03187300f, 
    -0.01064935f, 0.14319715f, 0.00549312f, 0.18222094f, 0.05704289f, -0.24868399f, 0.01799615f, -0.02460525f, 
    -0.09209877f, 0.07367134f, 0.25632635f, 0.28042245f, -0.01631224f, 0.01247630f, -0.00483574f, -0.07969121f, 
    0.10690024f, -0.01652675f, 0.02571994f, 0.39776918f, -0.13019720f, 0.25011817f, -0.06192718f, 0.09444603f, 
    0.01299456f, -0.09026922f, 0.33917952f, 0.13931245f, 0.13434108f, -0.07556448f, -0.05267382f, -0.02837928f, 
    -0.10373904f, 0.09658814f, -0.22251680f, 0.36640003f, -0.11511640f, -0.16493981f, 0.08414970f, 0.09005839f, 
    0.04484671f, -0.10369458f, 0.09001525f, -0.03716333f, 0.10908185f, 0.01317325f, -0.07665469f, 0.16082002f, 
    0.00627382f, 0.12629102f, 0.05581151f, -0.01738407f, 0.06180433f, -0.03464656f, -0.08715676f, -0.10832697f, 
    0.02581600f, 0.06474498f, 0.01230945f, 0.08007662f, 0.21341349f, 0.04241575f, 0.10328035f, -0.12483622f, 
    0.01808473f, -0.06991878f, 0.07194284f, -0.05653496f, -0.14871113f, -0.06440008f, 0.10257664f, -0.03142279f, 
    0.19384943f, 0.01788328f, 0.01176886f, 0.08116937f, -0.13894817f, 0.25652662f, 0.03785507f, 0.06570778f, 
    -0.05892545f, 0.21341909f, -0.01951081f, -0.07880608f, 0.08057617f, -0.08394225f, -0.02804673f, 0.11202492f, 
    0.17131492f, -0.06737082f, 0.07921574f, -0.10370444f, -0.04886835f, -0.21472155f, 0.05249525f, -0.18299118f, 
    -0.02189441f, 0.07504796f, -0.01226110f, 0.03030528f, -0.10486470f, 0.09809607f, -0.12315914f, 0.02524327f, 
    -0.25018117f, -0.01181335f, -0.01043880f, -0.00411522f, 0.12953526f, -0.15179169f, -0.18375485f, -0.03367443f, 
    0.00730758f, 0.00977693f, 0.05503928f, 0.17669620f, 0.07969777f, 0.34445021f, -0.01344358f, -0.11295996f, 
    0.11145736f, -0.00678896f, 0.02386942f, 0.14088298f, 0.04054674f, 0.13391617f, 0.09448414f, 0.03596647f, 
    -0.10429335f, 0.14980224f, 0.07482889f, 0.10010336f, -0.07034736f, -0.07029735f, -0.09865473f, -0.04552158f, 
    -0.06126884f, 0.11162916f, 0.19018000f, 0.19507447f, -0.27187127f, -0.01512915f, -0.23575322f, 0.00822515f, 
    -0.01931035f, 0.08091717f, 0.03413584f, 0.03875378f, 0.07558408f, 0.22732478f, -0.10071895f, -0.03518227f, 
    -0.27779609f, -0.04973717f, -0.17689689f, 0.19975433f, 0.00413291f, 0.02360034f, 0.15525208f, 0.06288584f, 
    0.05966593f, 0.03765317f, -0.24342164f, -0.06534613f, -0.03713863f, 0.14096655f, -0.19080997f, -0.15366261f, 
    0.15951741f, -0.04214299f, 0.05229650f, 0.04751255f, -0.10655920f, -0.05236597f, -0.12036127f, 0.03059593f, 
    -0.05211572f, 0.10407419f, -0.06430898f, 0.03687378f, 0.04051273f, -0.09049235f, -0.04356855f, 0.03388447f, 
    -0.05475557f, 0.08511523f, 0.08438215f, -0.00798718f, -0.02119710f, -0.01406098f, -0.15900819f, 0.01705101f, 
    0.06996363f, 0.03915421f, 0.11597691f, 0.01099943f, -0.06250334f, -0.08095245f, 0.20881990f, -0.09660660f, 
    -0.15531252f, 0.21042052f, 0.15186910f, 0.01380887f, 0.06810670f, 0.12286987f, -0.08301570f, 0.01959833f, 
    0.08570300f, 0.03445920f, -0.09007223f, -0.26481959f, -0.34699741f, -0.06444672f, -0.02735967f, 0.05265522f, 
    0.01772550f, -0.11752789f, 0.09305341f, 0.08956221f, 0.09137516f, 0.09575963f, 0.19771650f, -0.01859080f, 
    -0.05248583f, 0.14541674f, 0.20391715f, 0.01357071f, -0.01274982f, 0.09399751f, 0.10731129f, 0.01858097f, 
    0.01939821f, -0.01305728f, -0.23785172f, 0.22752433f, 0.22415964f, 0.10789377f, 0.01828813f, 0.02661660f, 
    0.03722842f, 0.05651219f, -0.08698853f, 0.04980456f, 0.07826469f, 0.07207809f, -0.01610789f, 0.05324900f, 
    0.75350046f, 0.21570796f, 0.10107721f, -0.34008995f, 0.03864473f, 0.06333242f, 0.02990546f, 0.01036661f, 
    0.15958342f, -0.13467853f, -0.06322991f, 0.19006912f, -0.34366745f, 0.05051064f, -0.07615674f, 0.18391874f, 
    -0.06130454f, 0.01176152f, 0.24145074f, 0.10800274f, -0.01759090f, 0.14328048f, 0.12702104f, 0.03691564f, 
    -0.15180926f, 0.09352711f, 0.19208767f, -0.06777489f, 0.22098830f, -0.04832635f, 0.09975234f, -0.10951983f, 
    -0.12802710f, 0.03069422f, -0.04494732f, -0.13478544f, -0.08256513f, 0.05156185f, -0.10909048f, 0.11374432f, 
    -0.07208475f, -0.01852968f, 0.03198421f, 0.07714520f, -0.05948899f, 0.11749712f, -0.08722719f, 0.07680190f, 
    0.02412259f, 0.01552370f, 0.00841169f, 0.02859853f, -0.01862043f, 0.03340580f, 0.02799551f, -0.04061946f, 
    -0.04546100f, -0.00797809f, 0.02716851f, 0.02248389f, 0.00217197f, 0.03810332f, 0.01561120f, -0.01977807f, 
    0.00136378f, -0.00537378f, 0.02029198f, -0.00679178f, 0.01408242f, -0.02837530f, 0.01090551f, 0.04090057f, 
    -0.02036729f, -0.01454091f, -0.04317301f, -0.00972779f, 0.03304642f, -0.03471410f, -0.05214780f, -0.03178501f, 
    -0.02049834f, 0.01920275f, -0.00316203f, -0.04422494f, 0.02581548f, -0.04849653f, -0.05112867f, -0.04493093f, 
    0.02225107f, -0.04441036f, -0.00609730f, -0.01368952f, -0.03674315f, -0.01112583f, -0.04898177f, -0.00896163f, 
    -0.00161585f, -0.01634770f, -0.01894252f, 0.04164967f, 0.03607025f, -0.05372861f, 0.02816603f, 0.03607219f, 
    0.01087227f, 0.00902071f, -0.00859250f, 0.00312181f, 0.00610300f, -0.02685048f, -0.02309997f, 0.01204324f, 
    -0.00370063f, -0.00948316f, -0.02640153f, -0.00019093f, -0.05720910f, -0.04168876f, 0.02991261f, 0.03568730f, 
    0.01793732f, 0.03793475f, 0.01964663f, 0.03709608f, -0.05585128f, -0.01948139f, -0.05765842f, -0.01544422f, 
    0.03078877f, -0.01398928f, -0.02507616f, -0.00208126f, -0.04447258f, 0.01521522f, -0.00103007f, -0.05103466f, 
    -0.05812495f, 0.02150435f, -0.03797158f, -0.02586810f, -0.05751298f, 0.01615612f, -0.04555312f, -0.05439010f, 
    -0.03999207f, 0.02376352f, -0.01403945f, -0.00687655f, -0.04983971f, -0.00216431f, -0.04328762f, 0.00412366f, 
    -0.05193371f, 0.03901262f, 0.00242466f, 0.00578457f, -0.04685558f, -0.04087957f, -0.00653616f, 0.03162303f, 
    0.03941689f, -0.03131528f, -0.04038977f, 0.00826079f, 0.02641892f, 0.01088520f, -0.04954687f, 0.00108267f, 
    0.01905204f, 0.00711546f, -0.00669537f, 0.01076271f, -0.01067495f, -0.02765861f, -0.02354592f, -0.03124677f, 
    0.00797196f, -0.05393247f, -0.00759235f, -0.05220366f, -0.00727893f, 0.03682008f, 0.04179960f, -0.01065468f, 
    -0.04702445f, 0.00159165f, 0.04123899f, 0.04073719f, -0.02730622f, -0.00218349f, -0.02035609f, 0.02271963f, 
    -0.03117754f, -0.00592841f, -0.04777246f, 0.00040022f, -0.05554634f, -0.03843037f, -0.01587297f, -0.02177335f, 
    0.03269831f, 0.04216170f, -0.03318185f, -0.03153115f, -0.00122674f, 0.03531212f, -0.01094856f, 0.01180043f, 
    0.03807282f, -0.00743054f, -0.05505964f, -0.05128872f, -0.02889804f, 0.02490403f, 0.02347815f, -0.00159828f, 
    0.02185656f, -0.03198445f, -0.00568340f, -0.00039698f, -0.01142972f, -0.01707892f, 0.02140788f, 0.00809584f, 
    0.02823623f, -0.01206335f, 0.02136937f, 0.01261865f, -0.05616918f, 0.03883399f, 0.00207841f, 0.03984052f, 
    0.02779109f, -0.05519356f, -0.02400798f, -0.01336369f, 0.00450327f, -0.04571059f, -0.04378583f, -0.01445513f, 
    -0.04572328f, 0.03803663f, 0.02619169f, 0.03632780f, -0.02634297f, -0.01090806f, 0.01770182f, -0.03736997f, 
    -0.00214600f, -0.04800990f, -0.02986588f, -0.02874959f, -0.01783310f, 0.01002100f, -0.01225964f, 0.00291328f, 
    0.00348801f, -0.01407890f, -0.05910040f, 0.02655377f, -0.01834340f, -0.02188434f, -0.05011122f, 0.00591870f, 
    -0.02723384f, 0.01899886f, 0.03717322f, 0.00351849f, -0.03440703f, 0.03484770f, 0.01275676f, 0.00177493f, 
    0.00469592f, 0.01552289f, -0.00934843f, -0.03825086f, -0.04895001f, -0.04635270f, -0.05338454f, 0.01789501f, 
    -0.04975161f, 0.01395754f, -0.01890057f, 0.04064280f, 0.01246685f, -0.00667320f, -0.05780064f, -0.05789534f, 
    -0.02191938f, -0.02359280f, 0.00149450f, -0.05295090f, -0.04560081f, -0.04105131f, 0.03136444f, -0.04430817f, 
    0.04278765f, 0.00104451f, 0.02458057f, -0.00252723f, -0.03453794f, 0.01848613f, 0.02534444f, -0.00034681f, 
    -0.05569844f, 0.02742074f, -0.01962640f, -0.00563233f, -0.01744351f, 0.03455146f, 0.00092945f, 0.00043800f, 
    0.01823323f, 0.02299482f, 0.03705251f, -0.05499247f, -0.05111983f, -0.00339239f, -0.03617423f, -0.02685638f, 
    -0.05221224f, 0.03959655f, 0.03962588f, -0.00957772f, -0.00425143f, -0.02422721f, 0.01851620f, 0.00331324f, 
    -0.03851514f, -0.02898296f, 0.01964680f, -0.05864156f, 0.00529693f, 0.02696047f, -0.01071634f, -0.01305790f, 
    0.01550679f, -0.00347405f, 0.01213193f, 0.00730099f, 0.03119415f, 0.04006079f, -0.04278009f, 0.00411079f, 
    0.00263325f, -0.04660473f, 0.02601379f, -0.03936395f, -0.01865723f, -0.04781258f, 0.04061374f, 0.01788420f, 
    -0.00263768f, 0.01668130f, -0.03276526f, 0.04147635f, 0.02400982f, -0.05750829f, -0.05734143f, 0.01859003f, 
    0.03864910f, -0.00113169f, -0.00569963f, -0.02092410f, 0.01614623f, -0.00310518f, -0.03924041f, 0.03666606f, 
    -0.01411848f, -0.04043994f, -0.04004742f, -0.00617270f, -0.03070170f, -0.03521386f, -0.01495290f, -0.00726302f, 
    -0.05720295f, -0.02157121f, -0.01819393f, 0.02862163f, -0.00842791f, 0.00325515f, -0.00892964f, -0.02766731f, 
    -0.03582275f, -0.05065391f, -0.00802908f, -0.05398607f, 0.03210092f, -0.05423626f, -0.01208243f, -0.00867045f, 
    -0.00925147f, -0.03792231f, -0.05653308f, -0.02535903f, -0.01963982f, -0.03516886f, -0.00440285f, 0.00657228f, 
    -0.05391246f, -0.00661458f, -0.02287596f, 0.03395289f, -0.04508410f, -0.01844022f, -0.03966175f, -0.04866375f, 
    0.00592442f, 0.03087235f, -0.04306398f, -0.05486597f, 0.01596852f, 0.00620182f, -0.03620880f, -0.03508723f, 
    0.01280943f, 0.01499502f, 0.01006756f, -0.00892781f, -0.04509545f, 0.00554993f, 0.02100122f, -0.01695044f, 
    -0.02792645f, -0.05586179f, -0.01397874f, -0.00304114f, -0.04759151f, -0.00565322f, 0.03964503f, -0.02480624f, 
    -0.00755490f, 0.00312995f, -0.02784246f, 0.02007159f, -0.05518452f, 0.00921023f, -0.04256870f, -0.03073239f, 
    0.04115962f, -0.03813571f, 0.04255740f, 0.00599895f, -0.01631898f, -0.01654439f, -0.01290910f, -0.03842028f, 
    0.01758158f, 0.00541830f, -0.01211063f, 0.04052522f, -0.02961031f, 0.03042486f, -0.01176023f, -0.05557702f, 
    0.02272172f, 0.00532558f, -0.05285006f, -0.05161016f, -0.05349725f, -0.01206046f, 0.00765131f, 0.03525836f, 
    -0.04995969f, 0.00727707f, -0.00226472f, 0.02133171f, -0.01148489f, 0.00790774f, -0.04827503f, -0.01817253f, 
    -0.04362334f, 0.00738275f, 0.00320501f, 0.02106670f, 0.01667372f, 0.04453348f, 0.00711756f, 0.02549871f, 
    -0.03884219f, -0.00560856f, 0.00128567f, 0.00095694f, 0.04748387f, 0.02462291f, -0.04381797f, -0.02736233f, 
    -0.02338836f, -0.02397487f, -0.02823791f, -0.05031265f, 0.01973435f, 0.01112238f, -0.05355665f, -0.01820573f, 
    -0.04611437f, -0.02024971f, -0.00812915f, -0.01479287f, 0.01664982f, -0.00350240f, -0.01841265f, -0.02927590f, 
    0.02185021f, -0.02540331f, -0.00689166f, 0.03364792f, 0.04326714f, 0.01910414f, -0.03234216f, -0.03912000f, 
    0.01900814f, -0.04901530f, 0.01624011f, -0.03092560f, -0.05315389f, -0.01190337f, 0.02526497f, -0.01789500f, 
    0.02855308f, -0.01728707f, -0.03321537f, -0.01297691f, -0.00051993f, -0.00246933f, 0.03638226f, 0.00233850f, 
    0.01712586f, -0.02089183f, 0.01536975f, -0.05486979f, -0.04796126f, -0.04889785f, 0.04014374f, 0.03300469f, 
    -0.01326862f, 0.03021193f, -0.01982757f, -0.03818029f, -0.03564261f, -0.04958048f, 0.00262902f, -0.04886318f, 
    -0.04750581f, -0.03691763f, -0.02139969f, 0.01279644f, -0.00805174f, -0.05070528f, -0.05246478f, -0.04359517f, 
    -0.03937770f, -0.03738729f, 0.01371533f, -0.02108534f, 0.04548836f, 0.00742869f, -0.03836545f, 0.02650324f, 
    -0.00598888f, -0.03835500f, -0.04226208f, -0.01867590f, -0.01517213f, 0.00057226f, -0.01233443f, 0.02147704f, 
    -0.00465439f, -0.03253222f, 0.02728827f, -0.04098722f, 0.01460741f, 0.03908844f, -0.00636772f, 0.00791617f, 
    -0.04877381f, -0.00004058f, 0.01116967f, -0.05688326f, 0.03681818f, -0.01922283f, -0.05708061f, 0.00792324f, 
    0.03538325f, 0.00583345f, -0.03014541f, 0.01785621f, 0.04254602f, -0.02964361f, 0.02394117f, -0.01142314f, 
    -0.03660115f, 0.00028376f, 0.04181230f, 0.02481253f, -0.00811949f, -0.02606405f, -0.05390902f, -0.01545295f, 
    -0.01329654f, 0.03167254f, 0.02488754f, 0.04514099f, -0.03103762f, -0.00387627f, 0.04750187f, -0.04250533f, 
    0.01979981f, -0.03746501f, -0.01038873f, -0.02123605f, -0.01946063f, 0.02847991f, -0.01850699f, -0.02735398f, 
    0.01028397f, 0.02174362f, 0.03683269f, -0.02454511f, -0.00490718f, 0.03187539f, 0.04339533f, 0.00291716f, 
    -0.03179846f, -0.01089513f, 0.00550861f, -0.03862486f, -0.03488002f, 0.04304689f, 0.00117155f, -0.00476531f, 
    0.02150490f, -0.01112158f, 0.03630815f, -0.01703614f, -0.02510405f, -0.00271265f, 0.03262554f, 0.01630113f, 
    -0.02271150f, -0.01931355f, -0.00441918f, 0.00215814f, 0.01788772f, 0.02989286f, -0.02068827f, -0.00178718f, 
    -0.02737026f, 0.02022665f, 0.01723115f, 0.01452858f, 0.03235485f, -0.00440413f, -0.03364547f, 0.00608095f, 
    0.01535145f, 0.01466123f, 0.00514378f, -0.04612296f, -0.03675450f, -0.02158623f, 0.01918132f, -0.04282430f, 
    0.01880681f, -0.01733657f, -0.03678620f, 0.02111330f, 0.04988130f, 0.03195154f, -0.05203110f, 0.04585031f, 
    -0.02638931f, 0.04166180f, -0.00528450f, 0.02720253f, -0.01132345f, -0.01354835f, -0.00800678f, 0.02256650f, 
    0.00362191f, 0.05062780f, 0.04822057f, -0.00714269f, -0.03035711f, 0.02762424f, -0.00382548f, -0.01122440f, 
    -0.04569471f, 0.02592049f, 0.00227114f, -0.03770402f, 0.00280592f, -0.00263740f, 0.01076783f, 0.02669089f, 
    -0.03972823f, -0.02220175f, -0.02893189f, -0.04639550f, 0.01003660f, -0.04058447f, 0.00555267f, -0.02710602f, 
    0.00639977f, -0.00423051f, -0.01944154f, 0.00656499f, 0.02468939f, 0.03412997f, -0.00375287f, -0.03936730f, 
    0.04215626f, -0.02773273f, -0.03070276f, -0.00821943f, 0.01231963f, 0.04225316f, -0.05388032f, 0.00832141f, 
    -0.00393094f, -0.01591308f, -0.02517942f, 0.01863471f, 0.03452792f, 0.01616212f, -0.02484449f, 0.02468280f, 
    -0.02716814f, 0.01561641f, -0.01539027f, 0.01356058f, 0.03143936f, -0.00414196f, -0.00909032f, 0.00269483f, 
    -0.03010108f, -0.02031839f, 0.00401771f, 0.00994103f, 0.02847974f, -0.02239164f, 0.03288119f, 0.00595317f, 
    0.03770233f, -0.01186381f, 0.01862151f, -0.00853724f, 0.04231699f, -0.00012839f, 0.00805901f, -0.03136296f, 
    0.00759954f, -0.02604547f, 0.01916300f, 0.03752403f, -0.03070980f, 0.02318797f, -0.01811712f, -0.03868541f, 
    0.01620350f, -0.03753660f, 0.02687106f, -0.05306635f, -0.02121307f, -0.02450001f, 0.01334150f, -0.01689877f, 
    0.02058779f, 0.00753722f, 0.04654305f, 0.00464573f, -0.01874417f, -0.03613628f, -0.00447511f, -0.01718280f, 
    0.02538317f, 0.00362696f, 0.04433069f, -0.03951726f, -0.04880618f, 0.00846233f, 0.01381282f, 0.00781981f, 
    -0.03180575f, -0.05008046f, -0.02509058f, 0.00945761f, 0.03420065f, -0.02327023f, -0.02333802f, -0.01424011f, 
    0.02483094f, 0.03548143f, -0.01395781f, 0.04040982f, 0.03878607f, -0.04005524f, 0.01641295f, 0.02844023f, 
    -0.02444392f, 0.01017679f, -0.02341955f, -0.00807791f, 0.03148129f, -0.05081725f, -0.00712454f, 0.02801917f, 
    0.03134004f, 0.00871401f, -0.03779195f, -0.00604191f, -0.01046884f, 0.03270904f, -0.01035544f, -0.01968126f, 
    0.04049225f, -0.05367830f, 0.01049283f, -0.00783450f, 0.04017904f, 0.00479852f, -0.06235540f, -0.05990856f, 
    0.01366650f, -0.01622477f, -0.00274800f, -0.05212616f, -0.04178628f, 0.03018493f, 0.02735462f, -0.03141849f, 
    0.02988390f, 0.00557222f, 0.02071643f, -0.02203610f, -0.04747013f, 0.00173601f, -0.04163675f, -0.03832414f, 
    -0.05397999f, -0.04770089f, -0.05004495f, -0.00731320f, -0.04533739f, -0.03792476f, 0.03693553f, 0.03215425f, 
    0.02225992f, 0.02802787f, -0.01709451f, 0.01751915f, 0.03578838f, -0.01725862f, 0.00160424f, 0.00510068f, 
    -0.00544573f, 0.01400795f, -0.01431374f, 0.00420918f, 0.02332274f, -0.00732543f, -0.05067433f, -0.01470585f, 
    0.00960216f, 0.00905562f, 0.02127206f, 0.03794397f, -0.02953812f, 0.03090107f, -0.00996679f, -0.01632619f, 
    0.03303981f, 0.03500247f, 0.02125827f, -0.01667931f, 0.01976777f, -0.04887358f, 0.03320401f, 0.04276353f, 
    0.01557674f, -0.02761028f, -0.04508674f, -0.02937689f, -0.04846953f, -0.00784954f, -0.02260271f, -0.00961403f, 
    -0.03924784f, -0.01505159f, -0.06227022f, -0.05538857f, -0.03824976f, 0.03214302f, 0.02171381f, -0.04162820f, 
    -0.00987554f, 0.03246184f, 0.03049659f, -0.03292895f, -0.03723212f, 0.00270716f, -0.01827611f, -0.02624023f, 
    -0.05873789f, -0.04534952f, 0.02075660f, -0.01515815f, -0.03206413f, -0.02263269f, -0.06295191f, 0.03267924f, 
    0.02470203f, 0.00212986f, 0.02424222f, -0.01024834f, -0.00727813f, -0.02797988f, 0.02234396f, -0.03036839f, 
    -0.03214680f, -0.04029146f, -0.04552539f, -0.01941970f, -0.02344800f, -0.05355553f, 0.01705111f, 0.02526143f, 
    -0.04075715f, -0.02062641f, -0.01854180f, -0.01347255f, -0.00631361f, -0.01630010f, 0.02755363f, 0.02412045f, 
    -0.00942076f, -0.00656814f, -0.02556278f, -0.02323173f, -0.04864866f, -0.03288369f, -0.02943398f, 0.02830839f, 
    -0.01262428f, -0.05285917f, 0.03183154f, -0.00164502f, 0.00641681f, -0.00840113f, 0.03231288f, 0.01054054f, 
    -0.00712177f, 0.02477917f, 0.00909483f, 0.00705343f, 0.02044185f, -0.03076116f, 0.03119607f, -0.02339017f, 
    -0.03436399f, -0.01337103f, 0.00733270f, 0.03086108f, -0.03335777f, -0.00914123f, 0.00172986f, -0.06350737f, 
    0.03038792f, 0.03701578f, -0.04671248f, 0.03233242f, -0.01062658f, -0.02372260f, -0.00189969f, -0.05827764f, 
    0.01738502f, -0.00691260f, 0.03167351f, 0.01913824f, -0.05384520f, 0.00214310f, 0.00584937f, 0.00227816f, 
    -0.02745438f, -0.00679019f, -0.03203788f, -0.00027005f, -0.00947441f, -0.04403110f, 0.01463081f, -0.05161459f, 
    0.03572324f, -0.00171009f, -0.01780379f, -0.03215148f, -0.01063812f, -0.05796328f, -0.03830864f, -0.06346362f, 
    0.02237526f, -0.02151181f, -0.05373450f, -0.02983300f, -0.03980962f, -0.03715406f, 0.01067842f, 0.00849454f, 
    -0.05039775f, -0.03062172f, -0.05825829f, -0.03170884f, 0.01237852f, -0.06265023f, -0.04561612f, -0.02383734f, 
    -0.00911363f, -0.05310676f, 0.00650225f, -0.05932497f, 0.00764281f, -0.03672695f, 0.01535610f, -0.01266706f, 
    0.02428137f, -0.00854775f, 0.03341075f, 0.01353870f, -0.00033730f, -0.02945334f, -0.06056633f, 0.02360490f, 
    -0.06046447f, 0.03201076f, -0.00082649f, -0.00960082f, 0.02862863f, -0.01996578f, 0.01227847f, -0.03889957f, 
    0.02917673f, 0.01509869f, 0.02189539f, -0.00321250f, -0.00037048f, 0.00514459f, 0.01381436f, -0.01517356f, 
    0.01127992f, 0.02265915f, -0.01666493f, -0.02675523f, 0.01159833f, -0.05927222f, 0.02918304f, -0.03934786f, 
    -0.01666602f, -0.00654264f, -0.04418350f, 0.02184108f, -0.03414611f, 0.00792810f, 0.01983498f, -0.01272697f, 
    -0.04756980f, 0.02972244f, -0.00423154f, 0.01560298f, 0.02325581f, -0.06014320f, -0.04918161f, -0.03925985f, 
    -0.03876511f, -0.01995504f, -0.03120024f, 0.02295956f, -0.01088133f, -0.00622526f, -0.06419613f, 0.02752445f, 
    -0.05655079f, 0.02558561f, -0.03626676f, -0.03523843f, -0.01667544f, 0.02759488f, -0.02420005f, 0.03718283f, 
    -0.04615184f, 0.01961437f, 0.00548445f, 0.03419011f, -0.02966368f, -0.01343573f, -0.02201536f, -0.03572221f, 
    -0.06167920f, -0.00929671f, -0.03057571f, 0.02917323f, -0.01286795f, -0.06397201f, 0.03363955f, -0.06400427f, 
    -0.06177821f, -0.01627553f, -0.04241575f, -0.01554623f, -0.05756398f, 0.02138609f, -0.00162514f, 0.02637016f, 
    0.01456544f, -0.06042000f, -0.06124029f, 0.01907319f, -0.00620537f, -0.04771890f, -0.02463600f, 0.03437122f, 
    -0.03671958f, 0.02195692f, 0.00183187f, 0.03239839f, -0.04290542f, -0.00687857f, 0.01528353f, -0.04043924f, 
    0.00691139f, -0.01903836f, 0.02302865f, 0.00108763f, -0.01596573f, -0.01132033f, -0.01981233f, 0.03114071f, 
    -0.03505620f, 0.03223411f, -0.04776824f, 0.01421959f, 0.04086374f, -0.01967978f, 0.00769849f, -0.02202455f, 
    0.02766163f, 0.03429514f, 0.00450010f, -0.02820151f, 0.01578061f, -0.02324895f, -0.00628908f, 0.01570487f, 
    -0.05387348f, -0.01998028f, -0.01598528f, -0.05762193f, 0.01614395f, -0.05091488f, 0.01569882f, 0.03419468f, 
    -0.01127647f, 0.01292361f, 0.03332965f, 0.02627332f, -0.04544319f, -0.04779142f, -0.04507259f, 0.00637468f, 
    0.02427466f, -0.03571136f, 0.00461647f, -0.04313574f, -0.01419269f, 0.03407304f, 0.03851971f, 0.02965069f, 
    0.02993306f, 0.00155261f, -0.04615000f, 0.02760659f, 0.01261420f, 0.01330572f, 0.03017450f, -0.02645178f, 
    -0.02238290f, -0.05346973f, -0.05844706f, -0.04265425f, 0.01415586f, 0.03158323f, 0.00707337f, 0.01517577f, 
    -0.03501096f, 0.00359217f, 0.00871601f, -0.05962156f, -0.00092857f, 0.03685592f, -0.00241402f, -0.06072404f, 
    -0.17987846f, 0.26173925f, -0.16092539f, -0.05818198f, 0.07260591f, -0.01030902f, 0.02439464f, -0.06915879f, 
    -0.05264741f, 0.07935414f, -0.10088177f, -0.04958602f, 0.13685894f, 0.12011915f, -0.18813139f, -0.27890009f, 
    0.01816199f, 0.02344798f, -0.04390241f, 0.05160162f, 0.00693745f, -0.05328893f, 0.02633305f, -0.14415012f, 
    0.07527802f, -0.13087460f, 0.29187122f, 0.03805690f, 0.00238989f, 0.02587013f, 0.21684127f, 0.10202979f, 
    -0.10274805f, 0.08597945f, 0.04849743f, 0.11440255f, 0.20284423f, -0.01022454f, 0.18022883f, -0.07946333f, 
    0.08618606f, 0.10963131f, -0.03184805f, -0.01192813f, 0.07110023f, -0.12614295f, -0.14946167f, -0.02713126f, 
    -0.14972010f, -0.04470893f, 0.14479187f, -0.11034546f, -0.16093940f, 0.00705319f, 0.06958627f, -0.03379382f, 
    0.21320269f, -0.00677562f, 0.00138053f, -0.08390372f, -0.01804341f, 0.05547012f, -0.14364624f, 0.03099938f, 
    -0.10415594f, 0.17648669f, -0.15502225f, 0.07074864f, 0.14382495f, -0.14251108f, 0.07904810f, 0.04097027f, 
    -0.09818050f, -0.12089848f, 0.05293038f, -0.29412475f, 0.02948083f, -0.11288261f, 0.06676742f, -0.05064141f, 
    0.01518950f, -0.10362495f, 0.05309119f, 0.00575467f, 0.01153050f, -0.03210759f, 0.14009580f, 0.08990362f, 
    -0.01583352f, 0.11305502f, -0.05001013f, -0.07579327f, 0.04221973f, -0.03736838f, 0.09401441f, -0.08436099f, 
    0.36466417f, 0.25882083f, -0.09923019f, -0.07485158f, -0.11514182f, 0.10077062f, -0.07973657f, 0.10868306f, 
    -0.03558913f, 0.06942031f, -0.02573619f, 0.06552653f, 0.07316776f, -0.54091525f, 0.07711457f, -0.06249380f, 
    0.02333449f, -0.00134110f, -0.04072269f, -0.00091750f, -0.04377683f, -0.09784663f, -0.10459854f, -0.06525228f, 
    0.37880942f, 0.16231878f, -0.11813404f, 0.04130320f, -0.05346888f, 0.03084801f, 0.07079124f, 0.11902442f, 
    -0.06984151f, -0.09069742f, 0.13704389f, 0.00386375f, 0.26710564f, 0.18792993f, -0.10430339f, -0.07705090f, 
    0.20431651f, -0.00964950f, 0.00437706f, 0.14985959f, 0.03088312f, 0.09227217f, -0.10552841f, 0.01887035f, 
    -0.04877865f, 0.27736062f, -0.05959566f, 0.04967126f, -0.00679218f, 0.18272382f, -0.02022743f, 0.00615544f, 
    -0.11015341f, 0.11457649f, -0.11600915f, -0.10549179f, -0.24592115f, 0.00149850f, -0.02139644f, 0.26452777f, 
    -0.06264205f, -0.10679922f, -0.06044666f, 0.06382982f, -0.01689936f, -0.07248503f, 0.07023125f, 0.04722568f, 
    0.02025479f, 0.19004105f, -0.08084289f, -0.10960029f, 0.07351048f, -0.03597774f, -0.08917770f, 0.18507741f, 
    -0.01405733f, -0.04320933f, 0.05272020f, -0.20497793f, -0.13036713f, -0.39119390f, 0.02290070f, 0.03979326f, 
    0.13826731f, -0.05787357f, 0.10639496f, 0.01674308f, 0.01957398f, 0.00627836f, 0.06621549f, -0.05185807f, 
    0.20246999f, -0.00765648f, 0.05992847f, -0.10357711f, -0.08866421f, 0.03476970f, 0.10764793f, -0.05450033f, 
    -0.03709005f, -0.02559891f, 0.16328865f, 0.16744751f, 0.09029460f, -0.06854595f, 0.08478239f, -0.31955588f, 
    0.13606355f, -0.07016703f, 0.13991058f, 0.05452997f, 0.11759722f, 0.06469074f, -0.09623662f, 0.04769979f, 
    0.41105229f, 0.32807946f, 0.28065488f, 0.03265504f, 0.09637455f, 0.04903829f, 0.00389704f, 0.10845486f, 
    0.05498358f, 0.02004551f, 0.00092893f, 0.06693511f, 0.20680064f, 0.10021441f, 0.08452594f, -0.05120428f, 
    -0.13199089f, 0.05629312f, -0.06474146f, -0.03176808f, 0.15137193f, 0.07211928f, -0.03499482f, 0.03869415f, 
    0.10907237f, -0.04366808f, 0.02470108f, 0.00951365f, -0.05883805f, 0.08549356f, 0.05011456f, 0.08276292f, 
    -0.08558147f, -0.05437039f, 0.04772151f, -0.00024181f, -0.15232055f, -0.13782674f, 0.19144879f, -0.18127559f, 
    -0.10816553f, 0.13371424f, -0.05214354f, 0.02571547f, -0.01301568f, -0.05867979f, -0.03128523f, -0.10958569f, 
    0.47929928f, -0.31144455f, 0.00837185f, 0.12041500f, -0.00898680f, 0.00373567f, 0.10008793f, 0.21478571f, 
    -0.05491405f, 0.06236544f, -0.07615270f, 0.05979799f, 0.03166853f, -0.20327327f, 0.07984888f, -0.08470137f, 
    0.14042547f, -0.05487019f, 0.17820790f, 0.03051290f, 0.01667606f, 0.01540562f, 0.00386283f, 0.08107724f, 
    0.07534168f, 0.33771706f, 0.21194023f, 0.25928351f, 0.05225572f, -0.11635005f, 0.06080631f, -0.11402188f, 
    -0.01949812f, -0.03234996f, 0.04787772f, -0.05235388f, -0.00200978f, 0.15076998f, -0.11713413f, -0.16334558f, 
    -0.00156688f, 0.00266272f, 0.06140527f, 0.13961162f, -0.05831946f, -0.02150715f, -0.10046177f, 0.02142220f, 
    -0.09829709f, 0.10498495f, 0.02667777f, -0.15494761f, 0.06532650f, 0.07998841f, -0.05963375f, -0.01746751f, 
    -0.04060643f, 0.06259362f, 0.05365428f, 0.04403744f, 0.26434064f, 0.04029307f, -0.01787762f, -0.02410871f, 
    -0.09516577f, -0.04751893f, 0.11883564f, 0.25055838f, 0.02581350f, 0.13886163f, -0.14071381f, 0.06884322f, 
    -0.15832540f, 0.09206603f, -0.16088909f, 0.07183284f, 0.00434329f, 0.06804547f, -0.07433616f, 0.05915944f, 
    -0.01297799f, 0.20039780f, -0.12320889f, -0.07609386f, -0.19244102f, -0.42383969f, -0.08564836f, 0.19771498f, 
    0.17839646f, -0.08726673f, 0.28633070f, -0.07328047f, -0.06557019f, -0.01203934f, -0.04183736f, 0.04973856f, 
    -0.09419913f, 0.21738532f, -0.06988315f, -0.02104180f, -0.10661142f, 0.04234876f, 0.11214221f, -0.00338339f, 
    -0.02175998f, -0.06335188f, 0.02935783f, 0.01853853f, -0.02001513f, -0.12923594f, -0.16816856f, 0.13203669f, 
    -0.06737754f, -0.13132200f, -0.02909469f, 0.12923796f, 0.10907781f, 0.04923136f, 0.02480428f, 0.02238473f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.01951594f, -0.01930598f, -0.00732238f, 0.00133337f, -0.03221468f, -0.02337288f, -0.12548776f, -0.06557975f, 
    0.10025386f, -0.12956068f, 0.02795116f, -0.04878794f, -0.02958354f, 0.06812958f, 0.04550849f, 0.06858576f, 
    0.04513192f, -0.01553365f, 0.08410359f, -0.00341011f, 0.08401821f, 0.11720250f, 0.12454514f, -0.04722700f, 
    0.03088068f, 0.03512386f, -0.05310915f, 0.01544630f, -0.01118551f, -0.01260991f, -0.01871116f, 0.01216687f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.17768349f, 0.10335957f, -0.11749852f, 0.07879908f, -0.01169783f, 0.11244830f, 0.32048154f, 0.16495863f, 
    -0.47196415f, 0.42063847f, -0.25686461f, 0.09724288f, 0.26104537f, 0.06638700f, -0.59814972f, -0.10681062f, 
    0.29429871f, -0.13837615f, -0.33932772f, -0.01620832f, 0.04310641f, -0.30256218f, -0.66092318f, 0.18376385f, 
    -0.50167292f, -0.12733257f, 0.04742609f, 0.17068884f, -0.12995967f, 0.06695678f, -0.03609506f, 0.07744667f, 
    -0.17336695f, -0.14101289f, -0.07936423f, -0.12301534f, -0.04087538f, 0.00902658f, -0.21154451f, -0.14927994f, 
    -0.33761990f, -0.33617663f, 0.18607530f, -0.16330956f, 0.44260371f, 0.21818286f, -0.21860939f, 0.04366534f, 
    0.35667196f, 0.05911058f, 0.49298427f, -0.11790767f, 0.28214741f, -0.20287296f, -0.42267162f, -0.19039156f, 
    -0.24420443f, 0.13049364f, -0.07876383f, -0.46557844f, 0.03004850f, 0.13376659f, -0.13784979f, 0.25500110f, 
    -0.09456995f, -0.11268348f, 0.06464301f, -0.00854176f, -0.11617672f, 0.11741912f, 0.41171932f, -0.24682504f, 
    -0.09495016f, 0.25398815f, 0.27359381f, 0.18013470f, -0.38323638f, -0.70392364f, -0.02508597f, 0.06268720f, 
    -0.07975424f, 0.02936648f, -0.15693428f, -0.11748149f, 0.32747874f, -0.03870568f, -0.31255648f, -0.27532601f, 
    -0.21265821f, -0.02035084f, -0.10099018f, 0.08230978f, 0.09657487f, 0.13759822f, 0.12260181f, 0.52217573f, 
    -0.14230269f, -0.01552238f, 0.15238957f, 0.14525354f, -0.12441635f, 0.15754618f, 0.19976068f, -0.15460402f, 
    0.03401170f, -0.49930063f, -0.31694534f, -0.02522853f, -0.42742446f, -0.07273275f, 0.42160201f, 0.27011687f, 
    -0.01941565f, -0.02716932f, 0.49401593f, -0.02386092f, -0.52093709f, -0.29747298f, -0.29615036f, 0.27619329f, 
    -0.24947064f, 0.01622421f, 0.07194381f, 0.38442093f, -0.09788160f, 0.05230501f, -0.15652756f, -0.14204963f, 
    0.05586701f, -0.14093666f, 0.08933815f, 0.07787463f, 0.10023709f, -0.02386137f, -0.11680906f, 0.28933465f, 
    0.12045446f, -0.30374485f, -0.17300627f, 0.09366082f, -0.14941446f, 0.05003662f, -0.24681792f, -0.70928997f, 
    -0.10520254f, 0.14802429f, 0.24194789f, -0.06345509f, -0.16307594f, 0.13303980f, 0.31120956f, -0.05452848f, 
    -0.31475830f, 0.06308649f, -0.05953046f, 0.32820192f, -0.10933111f, -0.11347131f, -0.10003547f, 0.25175351f, 
    0.01995155f, 0.09594969f, 0.01276356f, 0.06192821f, -0.11244906f, 0.10055019f, 0.14662392f, 0.10468253f, 
    0.07010041f, 0.27818081f, -0.06193130f, 0.06802624f, 0.11271955f, 0.37821233f, 0.46572584f, -0.58778298f, 
    0.55450433f, 0.12093281f, -0.30848145f, 0.07822128f, -0.32299924f, 0.11013766f, -0.25323799f, -0.23591463f, 
    0.09603632f, 0.06966642f, 0.16831993f, -0.39329034f, 0.14470971f, 0.14384919f, -0.15254056f, -0.27289015f, 
    -0.14027981f, -0.01110503f, -0.12317614f, -0.16826101f, 0.04841115f, 0.08245922f, 0.40727484f, 0.09104229f, 
    -0.49576637f, -0.35492700f, -0.22057478f, 0.07991054f, 0.10465223f, 0.11285117f, 0.15072030f, 0.02627274f, 
    -0.63090116f, 0.17871390f, -0.26186419f, 0.02405456f, 0.05265507f, -0.14170557f, 0.20857874f, -0.42769077f, 
    0.58688408f, -0.06249154f, 0.14775860f, 0.08183113f, -0.15486717f, -0.00511232f, -0.04033609f, 0.00959539f, 
    0.12684314f, 0.06930663f, -0.05887029f, 0.13301142f, -0.14517160f, 0.10447787f, 0.05646722f, -0.14445108f, 
    0.48575664f, 0.22483729f, 0.24087811f, -0.06512881f, -0.15043867f, 0.13054100f, -0.26902437f, -0.41143572f, 
    -0.47828710f, -0.08565739f, -0.23940121f, 0.12019785f, -0.36559030f, -0.65667599f, -0.12707737f, 0.44227710f, 
    -0.02714151f, 0.00463089f, 0.11742950f, -0.02539567f, -0.06611411f, 0.00802665f, 0.09924784f, -0.37032759f, 
    -0.16696441f, 0.09946974f, 0.06214233f, 0.17237934f, -0.12940809f, -0.12980725f, -0.03299155f, -0.31968170f, 
    0.22319449f, -0.06361648f, 0.04844632f, -0.14603011f, 0.39128894f, -0.60829526f, 0.20358476f, -0.23495823f, 
    0.03505932f, -0.08176850f, 0.06720891f, -0.10287142f, 0.40755001f, 0.35772792f, -0.51587772f, -0.04190773f, 
    0.34792337f, 0.12373392f, -0.07724039f, -0.26747546f, -0.02332605f, 0.02837420f, 0.06919590f, -0.61558968f, 
    0.05379707f, 0.12355404f, -0.00608983f, 0.11349529f, 0.05310968f, -0.07281223f, -0.18077478f, -0.05328854f, 
    -0.17945440f, 0.37921008f, 0.44549450f, -0.11653023f, -0.64845371f, 0.24071865f, -0.28996477f, 0.12915292f, 
    -0.51852560f, 0.10626052f, 0.16410841f, 0.14830828f, -0.10968249f, 0.28678915f, 0.15047134f, -0.57556874f, 
    -0.01625814f, -0.10144203f, -0.12175033f, 0.25467885f, 0.06471347f, 0.15624340f, -0.07070539f, -0.40256476f, 
    -0.06051123f, 0.11249205f, 0.05947647f, 0.16672762f, 0.07551153f, 0.15485048f, -0.22813606f, -0.87243253f, 
    0.25861773f, -0.62307775f, -0.18337786f, -0.11148354f, -0.63436943f, 0.31535566f, 0.16201264f, 0.02400864f, 
    0.45992756f, 0.03388292f, -0.13672651f, 0.07474933f, 0.14957111f, 0.55503780f, 0.01561807f, 0.06863507f, 
    -0.17957684f, 0.02728894f, -0.12465911f, -0.04977565f, 0.05782264f, -0.14888224f, -0.08430813f, 0.33702296f, 
    -0.01256690f, 0.05178720f, 0.07273088f, -0.05874101f, -0.17100956f, -0.12762649f, -0.56538761f, 0.08291372f, 
    0.12627767f, 0.45523405f, -0.45258662f, 0.09227471f, -0.01456964f, -0.23029779f, 0.32536981f, 0.48948079f, 
    -0.05879518f, 0.02416538f, -0.17364092f, 0.06865491f, 0.14644830f, -0.47455141f, 0.35105845f, -0.01569792f, 
    0.03693352f, 0.15161939f, 0.05876723f, -0.16283016f, -0.04698484f, 0.08128409f, 0.00845377f, 0.27756429f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.00065881f, 0.09386691f, -0.01249878f, -0.10018668f, 0.02686518f, 0.03465762f, 0.04880275f, 0.13417785f, 
    -0.15469217f, 0.01323359f, -0.12035050f, -0.06282572f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
