#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.66117591f, 1.81062078f, 0.08463232f, 1.50493062f, 0.44134185f, -0.02096071f, 0.12547323f, -0.56048691f, 
    -0.39627606f, 0.74955487f, 1.90887797f, 1.12022924f, -0.85569406f, -0.26570514f, -0.47695875f, -0.30163836f, 
    -0.35801548f, -0.51714200f, -0.75322521f, -0.98140723f, -0.99049139f, 0.83254522f, 1.41089821f, 0.80375892f, 
    0.51209491f, 0.83272201f, -0.21426405f, -0.10946704f, -0.30726936f, -1.48459256f, 0.92154860f, -0.93980604f, 
    -0.84292752f, -0.91489124f, -0.41275102f, 0.90388232f, 1.75870645f, 0.37139922f, 0.93518811f, 1.04689527f, 
    1.03106034f, -0.06030686f, -0.59035504f, 0.45217872f, -0.20996103f, 1.34678853f, 0.83730435f, 1.29869795f, 
    -1.09806490f, -0.86111575f, -0.29059651f, 1.14523685f, 0.77933729f, -0.41309547f, 0.53862983f, 1.31455326f, 
    -1.35055542f, 0.85262066f, -0.27532437f, -1.55831385f, 0.54782706f, 0.14100364f, 0.11811855f, 0.45255059f, 
    1.25652766f, 1.03923512f, 0.93696624f, -0.96743476f, -0.02295209f, 0.15841921f, 0.39582479f, 0.52610070f, 
    -1.53600514f, -0.62666267f, 0.26839095f, 0.07979145f, 1.45127809f, 0.34235355f, -0.35946310f, -0.72563487f, 
    0.02146569f, -0.87731040f, -1.54951739f, -1.30669808f, 0.58010179f, -0.13445835f, 0.20843156f, -0.83723944f, 
    -0.14092748f, -0.74979037f, 1.31045115f, 0.16533731f, -1.42662024f, -0.67895705f, -0.75225049f, 0.78683996f, 
    -0.68425363f, -0.68362153f, 0.38736534f, -1.15907991f, -0.14234252f, -0.78976637f, -1.20018494f, 0.77513760f, 
    1.17674375f, -0.12188268f, 0.18445569f, 0.67340511f, 1.46754694f, -0.89875990f, -1.13431311f, 1.52333736f, 
    0.87108690f, 0.21066365f, -0.21493906f, -0.02440571f, -0.48757678f, 1.20430946f, -1.35122740f, -1.15492415f, 
    -1.28805399f, 0.49884278f, 0.69493800f, 0.16286136f, -0.08859578f, 0.46941602f, 0.77193028f, -1.31221867f, 
    -0.66008437f, -0.45001164f, -1.55060923f, -1.32141268f, -0.37090936f, 0.72734708f, -0.77763790f, -2.03305125f, 
    0.69555378f, -0.60525531f, 0.27750468f, 1.23477566f, -1.10127854f, -0.12194689f, 0.26375657f, 0.94847101f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.02510577f, 0.18112388f, 0.33830160f, 0.02682821f, 0.56146467f, 0.38566631f, 0.45696515f, 0.16685413f, 
    -0.23765069f, -0.13826717f, -0.09496821f, 0.14970265f, 0.09041563f, 0.06424366f, 0.36227661f, 0.24783933f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.26283017f, -0.18799400f, 0.10805989f, -0.17968903f, 0.42808619f, -0.36098510f, -0.10261626f, 0.24656495f, 
    0.11550260f, -0.12303299f, 0.07364017f, 0.11566573f, -0.28090736f, 0.04268982f, 0.01887397f, -0.11883622f, 
    0.05888217f, 0.00958233f, -0.16896893f, -0.03574501f, 0.08455062f, 0.18466434f, -0.05989587f, -0.24312739f, 
    0.41746002f, -0.36334178f, -0.34952560f, -0.03638679f, 0.08041336f, 0.09366935f, 0.03330017f, 0.02600155f, 
    -0.15044588f, -0.03637141f, 0.02754000f, 0.10238148f, 0.06383796f, 0.01021285f, -0.01790828f, 0.05627169f, 
    -0.17544468f, 0.25188959f, 0.03067775f, -0.41657797f, -0.41024432f, 0.23670830f, -0.01701763f, -0.00239330f, 
    0.11169046f, -0.08408035f, 0.06831870f, 0.06777377f, 0.03947126f, 0.10812370f, 0.10953979f, 0.13724500f, 
    0.14703700f, -0.01341378f, 0.01326585f, -0.03255122f, 0.20703600f, -0.60160345f, 0.19121303f, 0.10536643f, 
    0.04753694f, -0.08521263f, -0.00328415f, -0.15924741f, 0.01677625f, -0.16189826f, -0.08542633f, -0.09738693f, 
    -0.07875980f, 0.15614997f, -0.08627108f, 0.25846907f, -0.06447161f, -0.06116643f, -0.29199836f, -0.12797622f, 
    0.34798801f, -0.01654850f, 0.07220682f, -0.08586870f, 0.18145613f, -0.14942850f, -0.44123566f, -0.01371418f, 
    0.07114872f, -0.04595092f, -0.10867047f, 0.11952799f, 0.04073884f, 0.17426878f, -0.11464158f, -0.13029079f, 
    -0.13714671f, -0.02165448f, -0.08481555f, -0.03287764f, 0.11157335f, 0.24790905f, -0.28298339f, 0.10266682f, 
    0.15636007f, -0.14346495f, -0.16803807f, -0.12764697f, 0.03269180f, -0.04911871f, 0.03340525f, -0.02682971f, 
    0.03032358f, 0.02202684f, 0.01864280f, -0.02984277f, -0.12598929f, -0.02653960f, 0.07429984f, 0.04981860f, 
    0.03054732f, -0.09481537f, -0.04243041f, -0.14112116f, 0.43353540f, -0.29331824f, -0.02099862f, 0.08816425f, 
    0.10132898f, -0.05192504f, 0.02847384f, -0.07088219f, -0.08238819f, 0.10303617f, -0.03630216f, 0.13415703f, 
    -0.02508490f, 0.10926249f, -0.10520064f, -0.21238013f, -0.09617595f, -0.07618678f, 0.13333490f, -0.14128837f, 
    -0.10508575f, -0.31758460f, -0.19346949f, 0.09623182f, -0.09519181f, -0.01245726f, -0.15407716f, -0.04462698f, 
    -0.04093361f, 0.03398118f, -0.10268696f, 0.00555363f, -0.05542728f, 0.00895518f, -0.22912675f, -0.06301009f, 
    0.52511227f, 0.30487826f, 0.61257374f, -0.04056540f, -0.50726384f, 0.05910088f, 0.37702665f, 0.01942711f, 
    0.06074233f, 0.05436543f, -0.14057684f, 0.03851849f, 0.08091399f, -0.06872375f, -0.04020772f, 0.18605876f, 
    -0.07794597f, -0.01352705f, 0.10466355f, 0.20332657f, 0.07006045f, -0.28198579f, -0.34641531f, -0.02309639f, 
    -0.89485788f, 0.26725051f, 0.05703942f, 0.05758059f, 0.12029773f, -0.01769110f, 0.14717534f, -0.13041656f, 
    -0.08698605f, 0.00716838f, -0.03004341f, -0.03326936f, -0.02880345f, 0.12894268f, -0.24584712f, 0.10640022f, 
    -0.16715908f, -0.35789403f, 0.08960570f, 0.14127506f, 0.30123392f, -0.06154409f, 0.07693917f, -0.18334188f, 
    0.12188804f, -0.16306786f, -0.02140504f, 0.04515263f, 0.20955107f, 0.00171565f, 0.05177467f, 0.04666389f, 
    -0.02661627f, -0.01367861f, -0.00026464f, -0.05461871f, -0.66247082f, 0.42505199f, -0.19320647f, -0.19886437f, 
    -0.16869260f, 0.03110607f, -0.05151139f, -0.14145678f, 0.02983705f, -0.06639433f, 0.15289709f, -0.06223121f, 
    0.19291589f, 0.17895430f, -0.15694666f, -0.14250587f, -0.11695518f, -0.01386110f, -0.03263571f, -0.14109237f, 
    0.31952703f, 0.20882411f, 0.09124377f, 0.06373076f, 0.20972450f, 0.01815318f, 0.00486167f, 0.00101549f, 
    0.03145960f, -0.20322926f, -0.03294024f, 0.01943828f, 0.04728789f, -0.04648006f, -0.05586225f, 0.14972651f, 
    0.16175106f, 0.08695027f, -0.02080459f, 0.08222622f, -0.33185303f, -0.29149750f, 0.02289549f, 0.20824008f, 
    -0.34611925f, -0.02756495f, -0.03230326f, -0.01646823f, 0.09384368f, 0.05773587f, -0.04784362f, 0.00712356f, 
    0.06615357f, 0.06150319f, 0.07830235f, -0.10070633f, -0.18913256f, -0.01773637f, -0.12079298f, 0.15811877f, 
    -0.11225715f, -1.28947115f, 0.45401502f, 0.18725824f, -0.41493386f, -0.02957593f, -0.16910733f, 0.10252165f, 
    -0.02006302f, 0.01897127f, -0.11388517f, -0.01550707f, -0.02947548f, 0.01203325f, -0.08978026f, -0.00767790f, 
    -0.04706443f, 0.11566510f, 0.18632752f, -0.06449623f, 0.72785264f, 0.02894870f, 0.20653045f, -0.42715821f, 
    -0.08854321f, 0.03448673f, -0.08898417f, 0.04330404f, -0.06815190f, -0.04324814f, 0.11216879f, 0.07553295f, 
    -0.10974284f, -0.09938011f, 0.17921717f, -0.18382137f, -0.12094170f, -0.01568757f, -0.13389076f, -0.01038217f, 
    -0.13873117f, -0.01746328f, 0.42537448f, 0.04585410f, 0.41264591f, -0.27548611f, 0.04908010f, -0.11753380f, 
    -0.01517480f, -0.10360309f, -0.19636515f, 0.04379753f, -0.04314282f, -0.01248546f, -0.03965705f, 0.01255416f, 
    -0.08175332f, -0.07924322f, 0.12329707f, -0.07271814f, 0.31529415f, 0.22943108f, -0.32287091f, 0.03704651f, 
    0.25914928f, 0.11365090f, 0.22847711f, 0.18711050f, 0.07679431f, 0.05039741f, -0.14322805f, -0.20657407f, 
    0.00776812f, 0.12153792f, 0.09002430f, 0.12702899f, 0.05576955f, -0.13909097f, -0.19677112f, -0.00478718f, 
    0.42360881f, -0.07225478f, -0.12275407f, 0.08554036f, -0.17909691f, -0.04031905f, 0.09722124f, -0.05787855f, 
    -0.04745993f, 0.06097256f, -0.02868133f, 0.01617363f, -0.09791059f, 0.00209944f, -0.07863031f, 0.13880564f, 
    0.26087037f, 0.12083551f, -0.23558357f, 0.09923730f, -0.75060779f, 0.01583423f, 0.03587018f, -0.14065360f, 
    0.22799207f, -0.09017782f, -0.25437063f, 0.23595540f, -0.04719596f, -0.07254557f, -0.04456588f, -0.09989352f, 
    0.10898204f, -0.33143482f, 0.16950409f, -0.02476846f, 0.07275514f, -0.14893107f, 0.12968846f, -0.21209286f, 
    0.65486240f, 0.47719601f, 0.20039962f, 0.06473998f, 0.30534446f, -0.12645108f, -0.00604693f, -0.07745759f, 
    -0.10299876f, 0.08100618f, 0.06423716f, -0.03590813f, -0.02046664f, -0.09098003f, -0.08751611f, -0.03076392f, 
    0.22868030f, 0.12281086f, 0.11561728f, 0.27334043f, -0.14417493f, -0.04345758f, 0.13505960f, 0.05670293f, 
    -0.14850919f, 0.00925550f, -0.03166906f, 0.05726827f, 0.03134819f, -0.07395218f, -0.04186175f, 0.06233370f, 
    0.10622877f, 0.10770425f, -0.07909272f, 0.03434015f, -0.02139957f, -0.03226694f, -0.12828575f, 0.03525490f, 
    0.07339062f, -0.89074993f, -0.14946876f, -0.34037840f, 0.00830261f, 0.16760182f, -0.18737431f, 0.02176570f, 
    -0.10864955f, 0.02064574f, 0.01192403f, 0.07195966f, 0.09450527f, -0.13987094f, 0.07918303f, 0.03876266f, 
    -0.14439085f, -0.32521966f, -0.06377220f, -0.00435600f, 0.22829686f, 0.13527043f, 0.11409654f, 0.13741818f, 
    0.41452619f, -0.20344310f, 0.01234386f, 0.06183647f, -0.07918775f, 0.11426568f, 0.13082589f, 0.12021202f, 
    0.23764388f, 0.05512420f, 0.02351950f, -0.01618429f, 0.05903166f, -0.05252858f, -0.02933750f, 0.11635479f, 
    -0.36092788f, 0.07877336f, -0.35696489f, -0.12042875f, -0.15681133f, -0.08275689f, 0.08096052f, -0.13818650f, 
    0.09317043f, 0.01011700f, 0.13208334f, 0.23183046f, -0.33408803f, -0.00487577f, 0.15579303f, 0.13393249f, 
    -0.08054162f, 0.01012295f, -0.04699247f, -0.13006701f, 0.25608930f, -0.05598934f, -0.17815870f, -0.02136168f, 
    -0.40384659f, 0.09161024f, 0.08626777f, -0.16447811f, 0.01924133f, 0.07405221f, 0.04360212f, 0.16870134f, 
    0.04545292f, -0.06365594f, 0.01990103f, 0.02889407f, 0.14976342f, -0.20548294f, 0.01229080f, -0.03192184f, 
    0.13354684f, -0.73629594f, 0.00683832f, -0.53063673f, -0.17030290f, -0.15278940f, -0.12446614f, 0.00210174f, 
    0.18148789f, -0.08019274f, -0.07079249f, -0.04581184f, -0.19028006f, 0.12399577f, -0.17566840f, -0.19222346f, 
    -0.26372674f, -0.05043291f, 0.09197540f, -0.30326891f, 0.27730352f, 0.34314221f, -0.08072014f, -0.22576568f, 
    -0.13128664f, 0.03652586f, 0.10237479f, -0.16445282f, -0.05633313f, -0.06320628f, -0.09588981f, -0.22671172f, 
    0.07749576f, -0.05963664f, 0.18525626f, 0.03063133f, -0.11520642f, 0.06009065f, -0.06262299f, 0.06166729f, 
    0.48549023f, -1.02114415f, -0.00835416f, -0.11331926f, -0.14842474f, 0.05347503f, 0.10321612f, -0.36845696f, 
    0.02172745f, -0.11342855f, 0.12239522f, 0.01859961f, -0.11262440f, 0.16028227f, -0.20081221f, 0.04048900f, 
    -0.02908965f, -0.19400020f, 0.15308528f, 0.09233043f, 0.41916296f, -0.87068021f, -0.02260528f, 0.00045390f, 
    -0.11002222f, -0.11378339f, 0.06345826f, 0.00298785f, 0.10503361f, 0.07169311f, 0.02648915f, 0.03312118f, 
    -0.09076637f, 0.01465222f, 0.01983875f, 0.08827661f, -0.18735692f, 0.11318009f, -0.07508563f, -0.03954216f, 
    0.10158220f, -0.22202918f, 0.04049311f, -0.22894976f, -0.16170883f, 0.15257078f, 0.03196338f, 0.03923703f, 
    0.19135417f, 0.05050238f, -0.09348992f, -0.10730785f, 0.09451380f, 0.04896361f, 0.10705430f, 0.03210144f, 
    0.01300529f, -0.31997156f, -0.21765952f, 0.06128143f, -0.81010377f, -0.06776354f, -0.07590467f, -0.08069710f, 
    0.29850563f, 0.00158609f, 0.06677894f, -0.02489911f, 0.07943814f, 0.17884706f, 0.00943256f, -0.10993598f, 
    0.11557009f, -0.02977746f, -0.05596099f, 0.10341803f, -0.00115017f, 0.04006934f, 0.04569423f, -0.36381680f, 
    0.34930232f, -0.43968290f, 0.07599604f, -0.24006967f, -0.11175844f, 0.09714830f, -0.01337277f, 0.16581161f, 
    -0.10620928f, 0.07387628f, -0.06098584f, -0.08102486f, 0.01710716f, 0.11106550f, -0.05104768f, -0.08780991f, 
    -0.00360128f, 0.04913029f, -0.32160041f, -0.03466037f, -0.06229535f, 0.21011662f, -0.54881591f, 0.04596476f, 
    0.00610108f, 0.11296530f, 0.23981979f, 0.00536177f, -0.07420990f, -0.11435966f, -0.05080690f, 0.11482147f, 
    -0.02940412f, -0.11780217f, -0.18047698f, -0.12031280f, 0.09021017f, 0.13187803f, -0.15943943f, 0.04768018f, 
    0.47417712f, 0.06361784f, 0.37222457f, 0.14033690f, 0.26788980f, -0.18389525f, -0.05093909f, -0.13484442f, 
    0.05403043f, 0.04931579f, 0.10540713f, -0.13769862f, -0.00479046f, -0.02754911f, -0.07074944f, 0.11761447f, 
    -0.14979890f, 0.04601889f, 0.08479463f, -0.03490895f, -0.74714869f, -0.35217896f, 0.26825160f, -0.42497319f, 
    -0.02056520f, 0.11249225f, -0.21111782f, -0.17260367f, 0.00086411f, 0.00942458f, -0.05976041f, 0.03438288f, 
    -0.05230772f, -0.02446370f, 0.06906586f, -0.11623672f, -0.05362773f, -0.05284080f, -0.03213364f, -0.02126905f, 
    -0.32875311f, -0.22593914f, 0.18825184f, -0.21258289f, 0.07561456f, 0.14839613f, -0.04729378f, 0.12642677f, 
    -0.02789615f, -0.07352452f, -0.11355852f, 0.05543971f, -0.04967941f, 0.09980500f, 0.00812261f, -0.13186619f, 
    -0.17784517f, -0.01217351f, -0.14936212f, 0.05157015f, -0.08815201f, 0.45096946f, -0.00519507f, -0.06864263f, 
    0.17245813f, 0.00092045f, 0.19403745f, 0.06979399f, -0.01014276f, -0.19225661f, -0.00035190f, 0.01155489f, 
    0.05356977f, 0.00942823f, -0.08424111f, 0.07433848f, 0.06188155f, -0.11568639f, 0.06076704f, -0.05370061f, 
    0.28323013f, -0.45216626f, -0.07934498f, -0.56078744f, -0.24784689f, 0.13718413f, -0.14117955f, 0.10470969f, 
    -0.07024597f, -0.12203345f, 0.00487307f, 0.01230367f, 0.03834780f, -0.25057858f, -0.08770548f, 0.10349917f, 
    -0.18655457f, 0.06948636f, 0.12119556f, -0.00451412f, -0.00262178f, 0.17386192f, 0.11634760f, 0.04201463f, 
    -0.04606263f, 0.03754156f, 0.24209942f, 0.05153320f, -0.08757658f, -0.10647270f, -0.16772375f, -0.00127470f, 
    -0.07264342f, -0.04406444f, -0.11598616f, 0.01362547f, -0.09489274f, -0.06168669f, -0.20814142f, 0.16418396f, 
    0.84819818f, -0.08199394f, 0.09616429f, -0.06952498f, 0.36492494f, -0.23428003f, -0.15658921f, 0.06193968f, 
    0.04020745f, 0.26822922f, 0.14234787f, -0.00072296f, -0.17427519f, -0.03159561f, 0.05388452f, 0.06052013f, 
    -0.17609818f, -0.01996217f, -0.02387584f, -0.08344166f, -0.11201418f, -0.32808131f, 0.05261035f, 0.11370539f, 
    0.22171506f, -0.28659743f, 0.03221884f, -0.23083276f, 0.03565298f, -0.02133603f, 0.00664454f, 0.07085739f, 
    -0.18293662f, 0.03792650f, 0.15889455f, -0.15758912f, -0.10635925f, -0.00873652f, -0.11941192f, -0.04712483f, 
    -0.05083838f, -0.23080522f, -0.39854440f, 0.19276355f, -0.40396142f, -0.00769582f, -0.13994756f, 0.15914014f, 
    0.24803102f, 0.04773446f, -0.06897348f, -0.13566805f, 0.00033093f, -0.02859469f, -0.16302912f, -0.01797597f, 
    -0.04253046f, 0.20919248f, 0.07046458f, -0.07138071f, 0.60398978f, 0.24487805f, -0.21279100f, 0.39520168f, 
    -0.20494261f, -0.08602754f, 0.07575715f, -0.14163738f, -0.01168112f, 0.00992528f, 0.00239538f, -0.11280265f, 
    -0.05093975f, 0.05458310f, -0.12304053f, 0.06933017f, -0.03227166f, -0.08127522f, 0.16501079f, -0.04911935f, 
    -0.19902861f, -0.02186689f, 0.22151208f, 0.07291579f, 0.10779869f, -0.03051277f, -0.18180908f, -0.03861764f, 
    0.15377724f, 0.20489132f, -0.08309483f, -0.16145694f, -0.09251647f, -0.03800848f, -0.02215656f, 0.05775128f, 
    -0.05704825f, -0.11328004f, -0.06548244f, 0.00256551f, 0.84181935f, -0.11187837f, -0.21398003f, -0.01186387f, 
    -0.62576365f, -0.16172720f, -0.05360716f, 0.08926792f, 0.15158105f, 0.15363574f, -0.04558325f, -0.01563467f, 
    -0.11488455f, 0.01638429f, -0.05042059f, 0.02492131f, 0.05388188f, -0.01385579f, 0.23169805f, 0.16443296f, 
    -1.02699387f, -0.39326918f, 0.09783686f, -0.66628516f, -0.60667616f, 0.01395063f, 0.24044995f, -0.17410758f, 
    0.02409706f, -0.17802288f, 0.18034598f, 0.21374354f, 0.15824908f, -0.17437457f, -0.09293029f, -0.02211086f, 
    -0.03455072f, 0.13070908f, -0.07504157f, -0.16385527f, 0.47578028f, -0.10099576f, 0.07942230f, -0.40120721f, 
    -0.14242344f, 0.20047493f, 0.05827186f, -0.26223266f, 0.02045969f, 0.11035220f, 0.04363201f, 0.04829474f, 
    0.04710594f, 0.03742824f, 0.01566485f, -0.16216588f, -0.02445418f, 0.01613776f, 0.01735547f, 0.02603204f, 
    0.03723957f, -0.02051523f, -0.41132635f, -0.11493880f, -0.17763747f, -0.25076377f, -0.06403828f, -0.17797874f, 
    0.09808316f, 0.04843961f, -0.15567611f, -0.23136345f, 0.01045919f, 0.09014897f, -0.19267347f, -0.07651815f, 
    -0.00425630f, -0.15068550f, 0.11193931f, 0.03100360f, -0.16508895f, -0.48158887f, -0.49244726f, 0.02669535f, 
    0.40472984f, 0.02482510f, 0.01376301f, 0.10605211f, -0.03107310f, 0.08177844f, 0.02862888f, 0.05140239f, 
    0.08701170f, 0.04174124f, -0.05217980f, 0.19408384f, 0.01875007f, 0.00813897f, 0.05886669f, 0.18490772f, 
    -0.18523301f, -0.08680899f, 0.07304807f, -0.37102953f, -0.22812338f, -0.02207368f, -0.19259267f, -0.00729721f, 
    -0.07475139f, 0.00373668f, -0.04485602f, 0.10104056f, -0.09883165f, -0.08899914f, 0.02406358f, -0.10929690f, 
    -0.02441703f, -0.15121427f, 0.06518918f, -0.00069764f, 0.30028600f, 0.18234003f, -0.22598134f, 0.25063962f, 
    -0.00627277f, -0.00423050f, 0.14426856f, -0.07552191f, 0.18424563f, -0.14149289f, -0.12485721f, -0.03379744f, 
    -0.02812308f, -0.09173069f, 0.08459572f, -0.00271220f, -0.08908509f, -0.00884261f, -0.09780328f, -0.09723138f, 
    -1.03703737f, -0.66511565f, -0.67774343f, -0.12319899f, -0.46107364f, -0.06876694f, -0.13155915f, -0.07986160f, 
    0.04174507f, -0.06669547f, -0.06872497f, -0.06975668f, -0.00018290f, 0.06386067f, 0.02633274f, 0.08157246f, 
    -0.16947243f, 0.04307695f, -0.13294369f, -0.00707135f, -0.51131290f, -0.35344037f, -0.35345197f, 0.25446299f, 
    0.32680732f, 0.02085024f, 0.20100272f, 0.18205591f, 0.07698524f, -0.11859307f, -0.10302875f, 0.03407901f, 
    0.06934608f, -0.32327503f, 0.03847826f, 0.01575992f, -0.08931742f, 0.05543215f, 0.12360794f, -0.20195329f, 
    0.71224248f, 0.34863329f, -0.10692609f, 0.20863615f, 0.10321204f, 0.05603025f, 0.10475329f, 0.07701215f, 
    0.07170455f, 0.04228430f, -0.05121406f, -0.14520057f, -0.09466872f, 0.06633154f, 0.00924508f, -0.14215727f, 
    0.01244556f, 0.21806644f, 0.01467585f, -0.00957729f, 0.21289997f, -0.71806461f, -0.21325549f, 0.18846926f, 
    0.04144121f, 0.25300571f, -0.11233690f, 0.12039989f, 0.09008969f, -0.11626232f, -0.03187054f, 0.05977293f, 
    -0.26288444f, -0.08165272f, -0.04367844f, 0.08919001f, 0.00243747f, 0.10526004f, -0.03886577f, -0.04511689f, 
    -0.55127239f, 0.11719102f, 0.18147062f, 0.06879362f, -0.15979220f, -0.15191723f, -0.34056452f, -0.08580802f, 
    0.18965325f, -0.13973251f, 0.03132228f, -0.23703830f, -0.02199976f, -0.00047170f, -0.05487311f, -0.06757792f, 
    -0.11181054f, 0.03652187f, 0.28790087f, 0.14970160f, 0.23013814f, -0.08940560f, -0.27997071f, -0.01900719f, 
    -0.05697838f, -0.30189773f, -0.21019715f, 0.07313473f, 0.01157442f, 0.02354658f, -0.08697996f, -0.02739437f, 
    0.26372933f, -0.20006783f, 0.02504002f, -0.06847903f, -0.05997663f, 0.20733280f, 0.00774289f, 0.02547623f, 
    0.41552630f, -0.22951894f, 0.28340203f, 0.18707082f, 0.15194975f, -0.09899738f, 0.04074315f, 0.04393942f, 
    -0.10787716f, 0.00672086f, -0.03721476f, 0.10129143f, -0.08122404f, 0.04246566f, 0.10028183f, -0.10222757f, 
    -0.08277082f, -0.01647555f, 0.14403704f, 0.10150717f, -0.23972915f, 0.03802036f, 0.05037279f, 0.00953751f, 
    -0.26686564f, -0.14775826f, -0.13622123f, 0.00985432f, -0.11742760f, -0.02001496f, -0.10658810f, 0.07575168f, 
    -0.14928612f, 0.02223380f, 0.13443726f, 0.10531889f, 0.08143131f, -0.04693462f, 0.16754344f, -0.15998363f, 
    -0.20947878f, 0.15345694f, -0.34107676f, -0.20222893f, -0.24515209f, 0.08149990f, 0.04158228f, 0.10810450f, 
    -0.05785978f, 0.06547881f, -0.07867980f, -0.04553795f, 0.09447850f, 0.10319479f, -0.11140240f, 0.05883040f, 
    -0.04973682f, 0.01101038f, -0.03559361f, 0.01310390f, 0.04784732f, -0.03889686f, 0.29451239f, 0.08633316f, 
    -0.06584641f, 0.06092383f, -0.07644489f, 0.02422181f, 0.09614795f, -0.03610594f, -0.00873659f, 0.13958725f, 
    0.01054536f, -0.02918957f, 0.11611709f, 0.01781949f, 0.03229199f, -0.04120678f, -0.01677755f, 0.02586765f, 
    0.30683455f, 0.34232014f, 0.32573524f, 0.44536605f, 0.00559984f, 0.04075471f, 0.13590878f, -0.14036666f, 
    -0.11829572f, 0.05079203f, 0.14941341f, 0.05581142f, -0.14821295f, -0.08606713f, -0.20866680f, -0.02182309f, 
    -0.02870764f, 0.17348135f, 0.06779262f, 0.08248060f, 0.39163879f, 0.52319688f, -0.01414867f, 0.01498451f, 
    0.02585580f, 0.00898232f, -0.02494521f, -0.05335660f, 0.12046579f, -0.06665538f, -0.15899800f, -0.01592393f, 
    -0.20626666f, 0.04187546f, -0.14049898f, 0.01259552f, -0.03467523f, -0.10854851f, 0.06044255f, 0.07422733f, 
    0.14030114f, 0.17586216f, -0.21017739f, 0.14869781f, 0.13289109f, 0.26371297f, -0.17541735f, 0.12988031f, 
    0.11264711f, 0.31881747f, -0.06090578f, -0.10181913f, 0.13339382f, -0.07938807f, -0.10872623f, 0.02269239f, 
    0.11203506f, 0.00154008f, -0.03990375f, 0.03586136f, -0.25803864f, 0.05164082f, 0.40280184f, 0.25109190f, 
    -0.21577744f, -0.09299876f, -0.06180404f, 0.14561194f, -0.00463047f, 0.02462254f, 0.05884242f, -0.07123638f, 
    0.14113982f, -0.12778343f, 0.00640116f, 0.11962226f, 0.02951843f, 0.13138820f, 0.16506797f, 0.21382187f, 
    -0.72769809f, -0.03505778f, -0.03403497f, 0.07031234f, 0.26998493f, 0.07062312f, 0.02535887f, 0.07858936f, 
    -0.05571003f, 0.15491454f, -0.01549625f, 0.18105270f, 0.07024992f, -0.02562742f, 0.05354752f, 0.01752422f, 
    -0.01714953f, 0.03832369f, 0.10618506f, -0.16875765f, 0.06474999f, -0.19014259f, 0.08644941f, 0.09132729f, 
    -0.03795679f, -0.09421907f, 0.03907827f, -0.01411192f, -0.09582103f, 0.04828677f, 0.16320448f, -0.02333578f, 
    -0.17455593f, 0.06976426f, 0.11645330f, 0.11651619f, -0.02994461f, 0.00288687f, 0.18221836f, 0.23661228f, 
    -0.01916375f, 0.24134950f, 0.07468688f, -0.33688354f, -0.21497343f, 0.15047239f, -0.02105994f, -0.20750719f, 
    0.21190764f, 0.05821189f, 0.18294311f, 0.01151965f, -0.04748845f, -0.03679954f, -0.00959452f, 0.13542150f, 
    -0.06647687f, -0.13643552f, -0.17866877f, 0.01923346f, -0.48199487f, -0.71030128f, 0.31429324f, 0.19110593f, 
    0.13651285f, -0.20158526f, 0.07973465f, -0.00662744f, -0.24640134f, 0.12421582f, 0.03465711f, 0.12055714f, 
    -0.13753001f, -0.12135827f, 0.03883996f, -0.08582317f, -0.25334734f, 0.04192872f, -0.00323463f, 0.02432289f, 
    -0.37966061f, -0.05345428f, 0.10596158f, -0.11905753f, -0.53280532f, -0.14260562f, 0.12094973f, -0.01920191f, 
    -0.13056985f, -0.18835166f, -0.20363334f, -0.13152413f, 0.05448683f, 0.05939513f, 0.06194729f, -0.12174966f, 
    0.14501844f, 0.06609148f, -0.19873190f, 0.01886307f, -0.38193825f, -0.09859925f, 0.18260820f, -0.12327812f, 
    0.09898015f, -0.09115057f, -0.07302906f, -0.23189037f, 0.18490633f, 0.07046372f, -0.17462207f, -0.13987392f, 
    0.06921141f, 0.06238106f, 0.00513500f, -0.00202273f, 0.02064586f, -0.06111090f, -0.00319485f, -0.00466043f, 
    -0.90790713f, -0.02412868f, -0.47038713f, -0.22573763f, 0.26499134f, 0.05473338f, -0.09690468f, 0.15079243f, 
    0.01095741f, 0.01296738f, -0.13869268f, -0.20319121f, 0.02245142f, 0.10283978f, -0.22950280f, -0.08490853f, 
    0.35499680f, 0.11322587f, -0.07984413f, -0.13512239f, -0.78481895f, -0.17218436f, -0.21759038f, 0.11968691f, 
    0.20989731f, 0.13514464f, 0.08165447f, 0.09438584f, 0.27047670f, 0.25643554f, 0.12057585f, 0.03261250f, 
    0.00598046f, 0.05713410f, 0.05153307f, -0.05572608f, 0.08052690f, -0.06729577f, 0.20532244f, 0.27693415f, 
    0.58167952f, -0.04264452f, -0.12443312f, 0.08319811f, -0.41263312f, -0.07318666f, -0.04246769f, -0.03906727f, 
    -0.24991402f, 0.00308960f, -0.02719871f, 0.26067489f, 0.06660531f, 0.00158770f, 0.10593606f, -0.05244639f, 
    0.16827248f, 0.08345070f, -0.02858122f, 0.04855675f, -0.13469157f, -0.13126722f, 0.26673520f, 0.30119589f, 
    0.18899198f, -0.02277304f, 0.02038222f, 0.05351863f, -0.02407021f, 0.09818955f, -0.01158055f, -0.05750572f, 
    -0.15250449f, -0.08397434f, -0.12385870f, -0.04943290f, -0.00449205f, -0.02224057f, 0.04500793f, -0.28007105f, 
    -0.32009318f, 0.24000275f, -0.08796177f, 0.21099216f, -0.28445363f, 0.03917282f, -0.13230915f, 0.23238055f, 
    -0.26930293f, -0.19889800f, -0.07524432f, -0.02611027f, 0.00009935f, 0.07054241f, 0.04885918f, -0.03616347f, 
    -0.08690558f, -0.04960215f, -0.12178938f, -0.08794048f, 0.00853026f, 0.49726564f, -0.29653215f, -0.37785450f, 
    -0.20154782f, -0.04196105f, -0.07600201f, -0.17699455f, -0.14429764f, -0.04003460f, 0.00626992f, -0.09355956f, 
    0.07646143f, 0.03701875f, -0.06973463f, 0.05292187f, -0.08883939f, 0.07539373f, 0.06863453f, -0.20029587f, 
    -0.07585902f, 0.12777174f, -0.05041626f, 0.40220788f, -0.10222951f, 0.05014598f, 0.16047038f, 0.05667007f, 
    0.17293133f, -0.06925297f, 0.13616683f, 0.05641427f, -0.00852975f, -0.00098028f, 0.00952528f, -0.07422163f, 
    -0.05342656f, 0.05109204f, -0.04484366f, 0.13844152f, -0.42174482f, 0.30687726f, 0.04578683f, -0.36596581f, 
    -0.23991592f, 0.30612430f, 0.18307965f, 0.06137259f, -0.22145256f, -0.04106996f, 0.09809198f, 0.07319415f, 
    -0.09790922f, -0.03343789f, 0.09487745f, 0.03892057f, 0.04331192f, 0.02124579f, -0.00107176f, 0.13732947f, 
    0.34254101f, 0.21143267f, 0.11250138f, 0.04031278f, -0.44565308f, 0.12053366f, -0.03802677f, -0.02079690f, 
    -0.07559913f, 0.09392182f, 0.10843793f, -0.01561121f, 0.09803072f, 0.03967195f, 0.00579698f, 0.15794449f, 
    -0.19576119f, 0.02422382f, 0.19580472f, 0.00706291f, 0.04192759f, -0.08475331f, 0.00721615f, 0.25623298f, 
    -0.16868453f, -0.29195911f, -0.07465214f, -0.12275720f, -0.06630637f, 0.01970504f, -0.15174438f, 0.03469352f, 
    0.11641010f, 0.04696342f, 0.21924555f, -0.23129556f, -0.07112919f, 0.04839497f, 0.08150110f, -0.20768620f, 
    -0.77404112f, 0.14668247f, -0.11739621f, -0.18871647f, -0.05977708f, 0.11264482f, -0.05714261f, 0.05076988f, 
    -0.12680475f, -0.33562443f, 0.00909653f, -0.06641022f, 0.04529281f, -0.02811555f, 0.06113312f, 0.28674528f, 
    0.08791602f, -0.11572411f, 0.00572653f, 0.12800819f, -0.26405430f, 0.10391816f, -0.20879664f, -0.13150440f, 
    -0.14435731f, -0.01706905f, 0.12128149f, 0.08570467f, 0.14872327f, 0.18566731f, 0.05065178f, 0.17726903f, 
    0.39165667f, -0.02938441f, -0.33953440f, -0.04686240f, 0.05604533f, -0.12086742f, 0.00529157f, 0.12259597f, 
    0.07491311f, -0.20177224f, 0.33925295f, 0.32604754f, 0.22165467f, 0.02131296f, 0.18564887f, 0.23307683f, 
    0.00063445f, -0.01782014f, 0.08050395f, -0.00858008f, 0.05412229f, 0.02982167f, 0.02326334f, 0.05316062f, 
    0.04565191f, 0.03678957f, 0.06893469f, 0.00997480f, 0.24996158f, 0.16843058f, 0.11949230f, 0.07018276f, 
    0.10332561f, -0.30989814f, -0.01449484f, 0.04984705f, 0.20130971f, 0.13636135f, -0.14707941f, -0.28884622f, 
    -0.00940707f, 0.10655969f, 0.17468068f, 0.08370541f, 0.26229259f, 0.06586605f, -0.15388621f, 0.01737036f, 
    -0.15456237f, 0.09760316f, 0.16725247f, 0.10165985f, -0.02926312f, -0.22854723f, -0.06213856f, 0.13126172f, 
    -0.05316792f, 0.10929993f, 0.00732181f, -0.12205273f, -0.13512032f, 0.08103977f, -0.17640123f, -0.05514836f, 
    0.05195989f, -0.46991190f, 0.11544742f, 0.01645759f, -0.08973947f, -0.00655630f, 0.10147577f, 0.32866800f, 
    -0.17953700f, -0.00570273f, 0.08819965f, 0.08718602f, -0.04421557f, -0.12152028f, -0.07491296f, 0.04100947f, 
    -0.23842302f, 0.00040378f, 0.05837908f, -0.00262319f, -0.03172701f, 0.18573651f, 0.19177902f, 0.02796049f, 
    -0.60956430f, 0.05956627f, -0.25552490f, -0.11707889f, -0.40671802f, 0.20018664f, 0.16265725f, 0.10018378f, 
    -0.06039646f, -0.13193259f, 0.28609788f, -0.23948249f, -0.20706844f, -0.29875377f, -0.10633869f, 0.04923612f, 
    -0.11484837f, -0.06302478f, 0.06792439f, 0.08085261f, -0.12843160f, 0.41915402f, -0.35906523f, -0.30371165f, 
    0.09882678f, 0.25055090f, 0.19053490f, 0.28337753f, -0.15616882f, 0.03312063f, -0.07212695f, 0.14375779f, 
    0.05375193f, -0.22167020f, 0.05718458f, 0.03229567f, 0.06861071f, 0.02627271f, 0.02411288f, -0.21023674f, 
    0.22739153f, 0.22514737f, 0.23323388f, -0.29052770f, 0.15409561f, 0.06544628f, -0.17165394f, -0.03247949f, 
    -0.07154521f, 0.28388956f, -0.14331225f, -0.15788104f, 0.03491779f, -0.11242189f, -0.06093832f, 0.01095666f, 
    -0.07633657f, 0.00995922f, -0.04999945f, 0.06517498f, -0.47833222f, -0.51973146f, -0.49485388f, -0.09674250f, 
    0.14332493f, 0.06450788f, 0.07167767f, -0.00802306f, 0.13027136f, 0.04310419f, 0.10331819f, 0.13458164f, 
    -0.07831406f, 0.07147364f, -0.07702586f, 0.11495037f, 0.09287084f, -0.01180477f, -0.03967531f, 0.11152167f, 
    -0.11258347f, 0.29581311f, 0.00587036f, -0.21528637f, 0.09118380f, -0.04113920f, -0.00224377f, -0.25881371f, 
    -0.03091111f, -0.05362308f, 0.27315536f, 0.06611972f, -0.03830454f, 0.05422497f, 0.13589299f, -0.05870014f, 
    0.02168003f, 0.00753671f, 0.18584405f, -0.17544410f, -0.54269028f, -0.43869409f, 0.03325434f, 0.10717988f, 
    0.20192339f, 0.03804485f, 0.03974542f, -0.05442169f, -0.12972821f, -0.12599285f, 0.05366637f, -0.13455866f, 
    -0.12123900f, -0.01532734f, -0.01294671f, -0.08449924f, 0.05307321f, -0.10242340f, -0.05477298f, -0.03229987f, 
    -0.32086340f, -0.07233270f, -0.38000447f, 0.18607827f, 0.44209424f, 0.02356225f, -0.23938479f, -0.06121588f, 
    0.05388783f, 0.15385847f, 0.04709103f, 0.06533873f, 0.18797219f, 0.13917710f, 0.23010430f, -0.14054681f, 
    0.05575480f, -0.18385766f, -0.25460735f, -0.33734769f, -0.78811753f, -0.21060717f, -0.00890917f, 0.06271005f, 
    -0.22144935f, -0.15845393f, 0.01046958f, 0.04880304f, -0.06805950f, -0.15396549f, -0.06630225f, 0.12280297f, 
    0.13007140f, -0.01283821f, 0.01306844f, -0.06961734f, 0.03413001f, -0.18916312f, -0.01164059f, -0.00126272f, 
    -0.27349856f, 0.29656747f, -0.36447152f, 0.42246366f, -0.28146484f, -0.17127168f, 0.03000200f, -0.04678398f, 
    0.15048572f, -0.01341901f, 0.04609828f, -0.02599213f, 0.17027482f, 0.04495094f, 0.12518424f, -0.20061333f, 
    0.01500488f, 0.02451733f, -0.29460788f, -0.12865138f, -0.14632393f, 0.60956317f, 0.17746888f, -0.18490532f, 
    -0.34206539f, 0.22899775f, -0.12851536f, 0.15354499f, 0.09815827f, 0.01225845f, 0.16257504f, 0.07825051f, 
    -0.08952473f, -0.02188679f, -0.18807659f, 0.11576991f, -0.14093375f, -0.10949131f, 0.14368632f, -0.03513561f, 
    0.06575033f, -0.49787137f, -0.08666281f, 0.04919274f, 0.00650683f, -0.10979277f, 0.06339737f, -0.03035556f, 
    0.02178725f, 0.01072760f, 0.05205313f, 0.08749459f, 0.08919555f, -0.00402984f, 0.07411942f, -0.21719585f, 
    -0.10627051f, -0.01770963f, 0.02892482f, -0.12101664f, 0.19382514f, -0.04793653f, -0.10834323f, -0.18449621f, 
    0.15281974f, -0.16625659f, 0.16800705f, -0.06440810f, -0.06187590f, -0.14771324f, -0.01983350f, 0.01782368f, 
    0.01902179f, 0.03407826f, 0.02536878f, -0.03736751f, 0.29865950f, 0.14805192f, 0.02796949f, -0.15026487f, 
    -0.44478557f, 0.00711841f, -0.10541819f, 0.24854267f, 0.11329921f, -0.05090712f, -0.16117634f, -0.07419707f, 
    0.01059026f, 0.10595171f, -0.23339909f, -0.17724183f, -0.02794191f, -0.04492621f, 0.05568533f, 0.11291081f, 
    0.11618710f, -0.15388910f, -0.20132485f, -0.16867885f, -0.19781755f, 0.48799810f, 0.04842754f, 0.04701846f, 
    -0.28760159f, 0.13898194f, 0.00040344f, -0.03794530f, -0.00126697f, 0.04756610f, -0.04608532f, 0.00477050f, 
    -0.05878090f, 0.00804867f, -0.15560482f, 0.12994280f, 0.02141649f, -0.01218360f, 0.06982748f, -0.12031207f, 
    0.13700610f, -0.13782841f, -0.20306687f, 0.45848912f, -0.09014162f, 0.17358571f, 0.19881608f, -0.17089175f, 
    0.06704734f, 0.04259674f, 0.00720681f, 0.16050960f, -0.15644564f, -0.02483180f, 0.02602207f, -0.04194341f, 
    0.03363699f, 0.25745618f, -0.10586722f, 0.11204245f, 0.01265510f, 0.43618551f, -0.09784620f, 0.26107493f, 
    -0.27909434f, -0.12264297f, 0.02318680f, -0.03060134f, 0.01018710f, -0.04229135f, -0.06398472f, 0.08441625f, 
    0.08213547f, -0.00120232f, -0.06320276f, 0.02013102f, -0.08089848f, -0.08197628f, -0.15841092f, -0.21135864f, 
    0.50162810f, -1.29810345f, -0.33491653f, -0.13523781f, -0.23116201f, -0.04585991f, 0.14066976f, -0.01830520f, 
    -0.13014741f, 0.02213427f, -0.10902124f, 0.00678557f, 0.21517961f, 0.25146434f, 0.23400852f, -0.08136246f, 
    0.02755689f, -0.11999340f, -0.20378554f, 0.05966294f, -0.50823092f, -0.16037121f, 0.13263574f, -0.95193416f, 
    0.28104874f, -0.24768001f, -0.17779103f, -0.05912315f, -0.05022394f, -0.21315409f, -0.09060019f, -0.06667130f, 
    -0.07875362f, 0.23317312f, 0.10697500f, -0.04037600f, 0.04843428f, 0.01657610f, -0.01226970f, 0.06736144f, 
    -0.29290447f, -0.13422623f, -0.06326965f, -0.04723997f, 0.03812686f, 0.11531390f, 0.17611675f, 0.14252481f, 
    -0.06715539f, 0.08715752f, 0.09486692f, -0.09759582f, -0.00010270f, -0.08602524f, -0.38493419f, 0.10018955f, 
    0.10855092f, -0.12092704f, 0.08177170f, 0.10771694f, -0.73771101f, -0.37141517f, -0.00188669f, -0.34361580f, 
    0.05449795f, -0.00609870f, -0.04096154f, 0.12887204f, -0.21366359f, -0.01118997f, 0.06121160f, -0.12076099f, 
    -0.00632959f, 0.13201568f, 0.00178322f, -0.02865103f, -0.05383991f, -0.10894237f, 0.02077561f, 0.06327380f, 
    -0.04367425f, -0.45047519f, -0.15728498f, -0.14318858f, 0.52933002f, 0.00191189f, -0.03480373f, 0.13104042f, 
    0.06951889f, 0.19894518f, -0.08171167f, -0.05483283f, -0.00117340f, 0.02580773f, -0.05227343f, 0.00736499f, 
    -0.14662001f, 0.09712320f, -0.17383151f, 0.11685262f, 0.25957069f, -0.24905242f, 0.17914754f, -0.16600339f, 
    0.40852493f, 0.02689061f, -0.10332114f, 0.09918191f, -0.05749794f, 0.06403955f, 0.01397715f, -0.06108752f, 
    0.17840497f, -0.11227237f, -0.15380506f, 0.12705860f, 0.16132362f, -0.19374539f, 0.19034192f, 0.00979407f, 
    0.23924436f, 0.22304916f, -0.39961377f, -0.60994470f, -0.09667172f, 0.07750470f, -0.04522571f, 0.11268955f, 
    -0.10526989f, 0.10106699f, -0.00971646f, -0.30488941f, -0.11191554f, -0.05453254f, -0.06286929f, -0.00555197f, 
    -0.12655088f, 0.37238431f, 0.01711193f, 0.33854344f, 0.20130989f, -0.27660888f, 0.10955667f, 0.32740757f, 
    0.33602208f, -0.01110060f, 0.00047567f, 0.10177358f, 0.04962569f, -0.11309458f, 0.02559787f, 0.00144519f, 
    -0.28753859f, -0.00426070f, -0.06280191f, 0.10688670f, 0.12580523f, 0.23009863f, 0.00439056f, 0.09403065f, 
    -0.28499267f, 0.09790510f, 0.14787014f, -0.14181912f, -0.44753915f, -0.05054434f, 0.00563532f, 0.00872661f, 
    -0.07061204f, -0.18471618f, 0.01782148f, 0.06695082f, -0.04186777f, 0.12616284f, -0.09645140f, 0.11863212f, 
    -0.04889433f, 0.01145184f, -0.07727014f, 0.03450930f, -0.34155619f, -0.64566988f, -0.05691781f, -0.09420969f, 
    -0.07782496f, 0.05227270f, -0.18467163f, -0.11062016f, -0.09489291f, -0.23054224f, -0.16374475f, 0.02965056f, 
    -0.00348264f, -0.00818072f, -0.13030292f, -0.10727572f, 0.10934026f, -0.14311016f, -0.01200772f, -0.01137532f, 
    0.06604012f, -0.03781245f, 0.28297469f, 0.02494659f, 0.14794263f, -0.04042089f, 0.09858357f, -0.06760316f, 
    -0.01984798f, -0.13861130f, 0.08588084f, 0.05064601f, 0.23565698f, 0.02107039f, -0.18191488f, -0.11850175f, 
    -0.06598276f, 0.06913871f, 0.01888113f, -0.09436121f, 0.49366617f, 0.32399756f, 0.00858876f, 0.39612678f, 
    0.29615521f, 0.04780216f, -0.08177782f, -0.09924020f, -0.02936911f, 0.10340516f, -0.36078224f, 0.09099651f, 
    0.01097905f, 0.04424680f, -0.12957253f, 0.07448895f, -0.11801832f, 0.19692434f, 0.13807736f, -0.15094849f, 
    -0.11362050f, -0.07119678f, -0.23813352f, -0.13544108f, -0.20180492f, -0.17953941f, -0.03588015f, 0.01676080f, 
    -0.09283476f, -0.12406354f, 0.11116340f, -0.01597606f, -0.07041219f, -0.08772212f, -0.06768022f, 0.00217409f, 
    -0.07331208f, -0.15827949f, -0.09220909f, -0.07526914f, -0.22202413f, -0.33789971f, -0.48369944f, -0.08631402f, 
    0.02596327f, 0.00204392f, -0.18297084f, -0.06490085f, -0.05942321f, -0.04861283f, -0.08302828f, 0.03357049f, 
    -0.00932050f, -0.13728911f, -0.04301331f, -0.25385809f, 0.06020226f, -0.07643009f, -0.03248684f, 0.21939291f, 
    -0.64698613f, 0.24459597f, -0.10023785f, 0.07769515f, 0.15223266f, -0.13773860f, -0.28878164f, -0.22462058f, 
    0.08828161f, -0.06985701f, -0.10649928f, 0.04713190f, 0.03328530f, -0.13190447f, -0.11279615f, -0.03538169f, 
    -0.07915098f, 0.03792396f, 0.02434809f, -0.15402426f, -0.15926021f, -0.00115425f, -0.37501684f, -0.31500128f, 
    -0.00672077f, 0.12450638f, -0.14992000f, -0.11369996f, 0.07530094f, -0.05571476f, -0.21138944f, -0.01933088f, 
    0.00315829f, -0.07938276f, -0.03152294f, 0.04753448f, -0.13354747f, 0.03552825f, -0.06828845f, 0.04356338f, 
    0.05407206f, 0.31891376f, 0.44766581f, 0.11969895f, 0.28209272f, 0.34262908f, 0.34605062f, -0.01257147f, 
    0.12033848f, -0.10549702f, -0.17302114f, 0.02092654f, 0.28182614f, 0.08423541f, -0.16954105f, -0.15799025f, 
    0.03279243f, 0.05382388f, 0.07804256f, -0.16006090f, 0.10978282f, 0.29075605f, 0.40418643f, 0.31456485f, 
    0.49334234f, 0.12955248f, 0.24652076f, 0.02782234f, -0.03413537f, -0.05150684f, -0.17557314f, -0.06279515f, 
    -0.07937319f, 0.01825901f, -0.22674049f, -0.07255135f, -0.02616067f, 0.01467618f, 0.01781939f, -0.06530762f, 
    0.00024412f, 0.43082461f, 0.15735523f, 0.10146974f, 0.27996039f, 0.06548458f, 0.37594411f, -0.08946293f, 
    -0.06632056f, 0.04781240f, -0.15321775f, -0.15459554f, -0.09634596f, -0.20504969f, 0.09765070f, 0.01154437f, 
    -0.00130791f, 0.07553839f, -0.12338493f, -0.00541619f, 0.51653385f, -0.47459748f, 0.35527751f, 0.02535765f, 
    0.03322802f, 0.03166037f, 0.10710457f, -0.06469975f, -0.08217869f, -0.03819907f, -0.09184117f, 0.16281779f, 
    -0.15124598f, 0.17759547f, -0.10277396f, -0.17759159f, 0.09061284f, -0.01830106f, 0.10680887f, -0.04556113f, 
    -0.32308608f, -0.08264399f, 0.18235831f, -0.13548598f, -0.02358318f, -0.25693697f, 0.12962541f, 0.04126059f, 
    -0.07786914f, 0.04251302f, -0.08758536f, 0.11678942f, 0.05688466f, -0.27730942f, -0.05634753f, 0.05650535f, 
    0.04758339f, 0.04292369f, 0.01610501f, 0.08818687f, 0.26833230f, 0.53588355f, 0.25265861f, -0.38833237f, 
    0.18469846f, -0.24324590f, 0.07180787f, -0.15949719f, -0.16175023f, 0.04128651f, -0.07804395f, -0.10342118f, 
    -0.24051325f, -0.11567372f, 0.05440313f, 0.05713351f, 0.05604226f, 0.14035378f, 0.12340251f, 0.00059162f, 
    0.09147500f, 0.30731341f, -0.13361362f, 0.21818893f, 0.49163353f, -0.29694656f, -0.03367064f, -0.20676011f, 
    -0.24117084f, -0.11018309f, -0.21025968f, 0.02542006f, -0.18334225f, -0.08295019f, -0.07002994f, -0.10430016f, 
    -0.12242015f, 0.09608505f, -0.17411542f, -0.19086950f, -0.11318996f, 0.00610983f, 0.08136133f, 0.06499156f, 
    -0.10896847f, 0.20006762f, -0.10961533f, -0.01436275f, 0.05564682f, -0.11763085f, -0.04484532f, 0.21738526f, 
    -0.06670729f, -0.09240966f, -0.12251348f, 0.07158495f, 0.05998285f, -0.01767729f, -0.14267935f, 0.06881908f, 
    0.25422093f, 0.40451804f, -0.14141417f, 0.20043543f, 0.15631601f, 0.07997384f, 0.04774480f, -0.35241941f, 
    -0.16849542f, -0.20961162f, 0.07470891f, -0.05190475f, 0.01728311f, -0.16055043f, 0.05216165f, -0.09541892f, 
    0.10533795f, -0.13381210f, 0.16844508f, -0.07237270f, -0.21156110f, -0.41316891f, -0.02869078f, 0.21686929f, 
    0.49698272f, 0.22830538f, 0.05780469f, -0.14370440f, -0.11946198f, -0.09468120f, 0.05481206f, 0.11595279f, 
    0.17118084f, 0.03659383f, 0.23629102f, -0.12089036f, 0.11278827f, 0.10849889f, 0.06825785f, -0.12198009f, 
    0.09558259f, 0.06965255f, 0.00697940f, 0.17416075f, 0.26586777f, -0.30402285f, -0.04223691f, -0.06791467f, 
    0.01027814f, 0.03774884f, -0.00576685f, -0.08464540f, -0.13461839f, 0.03360227f, -0.00340273f, 0.23084192f, 
    0.09565808f, -0.04285344f, 0.05776224f, 0.17527014f, -0.46420193f, -0.10007021f, -0.16565931f, -0.43488050f, 
    -0.76731199f, -0.05079851f, -0.11592681f, -0.05055719f, 0.09063355f, 0.09647047f, 0.20294914f, 0.09546763f, 
    0.14490806f, -0.10408434f, 0.14921600f, -0.13900009f, -0.11575897f, -0.35310829f, 0.22426271f, -0.19700715f, 
    0.29269302f, 0.25162548f, -0.05964940f, 0.15103559f, 0.14029779f, 0.06587291f, 0.05632577f, -0.10880132f, 
    -0.14071828f, -0.06865470f, -0.14539267f, 0.07740729f, -0.02564966f, -0.20726524f, -0.11247282f, -0.20365071f, 
    -0.05043258f, -0.02390000f, 0.21960706f, 0.03424212f, 0.24625887f, -0.05337160f, -0.52458411f, -0.07784664f, 
    0.03673080f, 0.21011513f, 0.13030005f, -0.06547218f, 0.00056451f, -0.12631339f, -0.14558205f, -0.04895768f, 
    -0.02987104f, 0.10533468f, -0.16456056f, 0.01869933f, 0.01863801f, 0.12335245f, 0.04178788f, -0.10841130f, 
    -0.08161595f, 0.14500870f, -0.26366934f, 0.01471791f, -0.15895051f, -0.02801137f, 0.05884808f, -0.29286340f, 
    -0.07019803f, -0.07429902f, 0.23000674f, 0.04826804f, 0.09986356f, 0.02183219f, 0.13672024f, -0.02173210f, 
    -0.02519538f, -0.03699835f, 0.29760635f, -0.01487690f, 0.24678938f, 0.02821057f, -0.24547164f, -0.00462000f, 
    0.14894743f, 0.17191778f, -0.01246556f, -0.15909883f, -0.01334021f, -0.07156570f, 0.15724964f, 0.09108761f, 
    0.02682888f, 0.00380441f, 0.00446540f, -0.15115708f, 0.08486154f, 0.08051355f, 0.09072624f, -0.03205545f, 
    -0.14221109f, -0.36551341f, 0.27916703f, 0.02019516f, 0.09765503f, -0.15640992f, -0.12163609f, -0.01051929f, 
    -0.28011873f, 0.30972797f, 0.03204336f, -0.03788942f, 0.02102949f, -0.16176523f, 0.01232273f, 0.02688188f, 
    -0.09922507f, -0.10959523f, 0.15190838f, -0.09008619f, -0.20717414f, -0.08624898f, 0.51448548f, -0.34599829f, 
    -0.10724112f, 0.01102069f, 0.00997614f, -0.21687637f, -0.00602052f, -0.19138782f, 0.02375437f, 0.02767072f, 
    -0.18900517f, 0.02005151f, -0.06338102f, -0.15635720f, 0.10563325f, -0.06910069f, -0.09686565f, -0.13506588f, 
    -0.46653673f, 0.09895342f, -0.25122413f, -0.42082348f, -0.52658916f, -0.03129227f, 0.06040773f, -0.06734170f, 
    0.07585077f, -0.18473461f, 0.15990846f, 0.00548071f, 0.02211562f, -0.07356545f, 0.13220105f, -0.18759792f, 
    -0.02075752f, -0.08137821f, 0.05782105f, -0.00782249f, -0.04593221f, -0.05785438f, 0.30714834f, 0.16925120f, 
    0.12672292f, -0.11505643f, -0.00085389f, 0.12454417f, -0.07184262f, 0.07260071f, 0.00723212f, -0.08585077f, 
    0.04622542f, 0.04867825f, 0.07125244f, 0.12197087f, -0.12811598f, 0.00391442f, 0.02054193f, 0.01501322f, 
    0.25871000f, 0.32335380f, 0.09604870f, -0.03468867f, 0.07103870f, -0.32347864f, -0.08392704f, -0.06353454f, 
    -0.17366919f, -0.06421905f, 0.10932545f, -0.03492802f, -0.00986816f, -0.10076439f, -0.01249253f, -0.15168527f, 
    -0.05883141f, 0.08611379f, 0.15051483f, -0.02443273f, -0.29599196f, 0.36600381f, -0.03688094f, -0.35963452f, 
    -0.12202127f, 0.04366439f, -0.03677673f, 0.06846224f, 0.08418009f, -0.17410600f, 0.07737933f, -0.02226435f, 
    -0.05817003f, -0.02646902f, 0.11678270f, -0.10685018f, 0.11247176f, -0.04751531f, 0.07240294f, 0.15767325f, 
    -0.22853136f, 0.01759064f, 0.00172035f, -0.73611027f, -0.40621489f, -0.30103865f, 0.07141738f, -0.21228409f, 
    0.09388384f, -0.30384126f, 0.13438624f, 0.07378292f, 0.06950954f, -0.03530881f, 0.07086761f, -0.03706371f, 
    0.04565795f, -0.39288625f, -0.29243401f, 0.07591035f, -0.11637865f, -0.00769259f, -0.21680115f, 0.03276421f, 
    -0.24436080f, -0.09140100f, 0.06677038f, -0.13652876f, -0.10522377f, 0.12212659f, 0.07442318f, -0.13539705f, 
    0.00242134f, 0.05450125f, -0.07627332f, 0.08757990f, -0.00321343f, -0.19114827f, 0.08675065f, 0.13050693f, 
    -0.65479320f, 0.01278292f, 0.37999871f, -0.21726254f, 0.06957788f, 0.07237592f, 0.15804192f, -0.00859426f, 
    -0.14040801f, -0.07893536f, 0.01130201f, -0.13637903f, -0.13319589f, 0.00131320f, 0.15223074f, 0.16729656f, 
    0.01304109f, 0.14358220f, -0.20244297f, 0.20893958f, 0.13016936f, -0.65704775f, 0.40804794f, -0.26916698f, 
    -0.24473491f, -0.08757453f, 0.08356690f, -0.29517266f, -0.05317226f, 0.02027323f, -0.01260809f, -0.04435765f, 
    -0.09329295f, -0.25305432f, -0.29098383f, -0.11026944f, 0.06598723f, -0.04075546f, -0.07449532f, -0.01887375f, 
    -0.09924718f, -0.23053151f, -0.09821571f, 0.31843653f, 0.06526370f, 0.09185596f, 0.12595992f, -0.20704664f, 
    0.09587689f, 0.12291568f, 0.08930096f, 0.11706288f, -0.02756346f, -0.12182967f, -0.01755598f, -0.23104374f, 
    -0.33979696f, -0.10085934f, -0.16000204f, 0.07051131f, -0.81787425f, -0.08946573f, 0.34244457f, -0.11527640f, 
    -0.02708380f, 0.20316967f, 0.00964834f, -0.05152780f, -0.05353457f, 0.12411696f, -0.00635957f, -0.04952760f, 
    -0.24787982f, 0.05647760f, 0.06699420f, -0.00530690f, -0.05421083f, 0.13290042f, -0.09657609f, 0.24042298f, 
    -0.23887885f, 0.24603069f, -0.28193164f, 0.22527391f, -0.36200848f, 0.05995284f, 0.18978754f, 0.20778014f, 
    0.20286375f, -0.21326099f, -0.09677027f, 0.08835655f, 0.08314255f, 0.04638647f, 0.08069572f, -0.01338135f, 
    -0.08404741f, 0.15860987f, 0.27494198f, -0.06819510f, 0.25671753f, -0.05049123f, 0.30708170f, -0.58624083f, 
    -0.68104970f, 0.03902618f, -0.10756465f, 0.10567087f, -0.25431451f, 0.06166847f, -0.03294725f, -0.02833648f, 
    -0.04650669f, -0.17222315f, -0.21023020f, -0.09525616f, -0.04318396f, -0.13826528f, 0.17923018f, 0.10655973f, 
    -0.77749962f, 0.36745784f, 0.40887147f, -0.28237247f, 0.16425905f, 0.13540691f, -0.00089332f, -0.01986326f, 
    0.04192206f, 0.09455375f, -0.23075196f, 0.05879019f, 0.02379370f, -0.10005117f, -0.01696555f, 0.04876875f, 
    0.11136407f, 0.22391894f, -0.07519943f, 0.04268174f, 0.11558551f, 0.03850910f, -0.12103012f, -0.69608867f, 
    -0.57208723f, -0.09814737f, -0.03365659f, 0.06113743f, 0.05564753f, 0.03141947f, 0.19044481f, -0.28045189f, 
    0.08254053f, -0.12809721f, 0.03966600f, -0.00818697f, 0.19677037f, -0.20910847f, -0.16923638f, -0.16686511f, 
    0.39954501f, -0.25494775f, -0.07463704f, 0.18062387f, 0.24289627f, 0.00540055f, -0.15275368f, 0.06910963f, 
    -0.08294873f, 0.11642110f, -0.13321495f, 0.04750017f, 0.15210287f, 0.22625129f, 0.14068909f, -0.19083427f, 
    0.10674746f, 0.06146766f, 0.03206749f, -0.00184727f, -0.15410966f, -0.34657091f, -0.10706834f, 0.34490070f, 
    0.15185614f, -0.08040033f, 0.00674462f, -0.03319360f, -0.18015181f, 0.02510944f, -0.17953432f, -0.16392291f, 
    0.00849148f, 0.22281840f, 0.09357861f, 0.19598868f, -0.19846947f, 0.04774883f, 0.06994200f, 0.04159635f, 
    -0.52086782f, 0.10481078f, -0.14496516f, 0.02060557f, 0.01274253f, -0.07795396f, -0.06413842f, -0.11774902f, 
    0.01435226f, -0.11115553f, 0.08507726f, -0.00325439f, -0.00655740f, 0.12114486f, 0.27371994f, 0.02010014f, 
    0.08668920f, 0.13441768f, -0.06107105f, 0.13444915f, 0.44183907f, -0.40085495f, -0.15836383f, -0.00297324f, 
    -0.21123761f, 0.04778581f, 0.04084540f, 0.11938544f, 0.14368686f, -0.03687169f, 0.02628294f, 0.14436056f, 
    0.02884532f, -0.12968744f, 0.05292230f, 0.02719276f, -0.02407072f, -0.03083089f, -0.01822785f, 0.04428688f, 
    -0.15225331f, 0.49200174f, -0.04095441f, 0.37340337f, -0.13922299f, 0.21148379f, 0.01955342f, 0.05065593f, 
    0.25382555f, 0.02161666f, -0.15865076f, -0.01081201f, 0.14647390f, 0.02242042f, 0.07245123f, 0.16291000f, 
    0.03486064f, 0.04712224f, -0.41817412f, -0.05856108f, -0.45005569f, 0.11158095f, -0.42285353f, 0.37993124f, 
    -0.27379966f, 0.21331859f, 0.11663499f, -0.18130299f, 0.02761198f, 0.04090390f, -0.25148630f, 0.04541245f, 
    -0.13482879f, 0.17506604f, 0.13989657f, 0.13446267f, -0.01322919f, -0.00497754f, -0.09317975f, -0.13485765f, 
    0.05841026f, 0.00196697f, -0.06550961f, -0.11602764f, -0.29243198f, -0.06435024f, 0.21571213f, 0.04809712f, 
    -0.14925556f, -0.18020666f, -0.07637666f, 0.13745041f, -0.17831099f, -0.08991031f, 0.07709803f, 0.07503545f, 
    0.18823937f, -0.05522692f, 0.34656996f, -0.00809755f, 0.47355399f, -0.56683654f, 0.06585212f, 0.20017703f, 
    0.32496437f, -0.15796024f, -0.18908335f, 0.03811849f, 0.09550577f, 0.10800333f, 0.00335283f, -0.02692259f, 
    -0.01961173f, 0.03517344f, -0.05451737f, -0.02056270f, -0.15687039f, 0.20825009f, -0.14533500f, 0.15442356f, 
    -1.01319516f, -0.59796625f, -0.41673967f, -0.37278426f, -0.41876858f, 0.05926631f, 0.01612482f, -0.18007527f, 
    -0.07594239f, -0.11126217f, 0.13951570f, -0.09153245f, -0.10701340f, -0.18960342f, 0.10756894f, -0.08450601f, 
    -0.08606534f, 0.16332358f, 0.02170374f, -0.05556803f, -0.96000046f, -0.03580816f, 0.18639049f, -0.15777902f, 
    -0.37782788f, 0.24458703f, -0.14508978f, -0.06653669f, -0.10653604f, 0.10042764f, 0.05414249f, 0.00288859f, 
    -0.09152739f, 0.12128413f, 0.01231794f, 0.07018810f, -0.14943115f, -0.17705132f, -0.19807486f, -0.09602322f, 
    0.43361890f, 0.17429066f, -0.05281493f, 0.02960579f, -0.02932499f, -0.23457398f, -0.09179761f, -0.11321592f, 
    0.19627225f, 0.07094362f, -0.11802320f, -0.09838989f, -0.14914888f, -0.03678712f, -0.03468185f, -0.07209738f, 
    0.08090308f, 0.17573972f, 0.14608602f, 0.04180265f, 0.31668776f, 0.02770240f, -0.09608538f, 0.07334456f, 
    0.03064655f, 0.14384291f, 0.07228594f, 0.21712160f, -0.23439209f, 0.13454853f, -0.04573587f, -0.08958890f, 
    -0.01533587f, -0.12054170f, 0.08326001f, -0.01184333f, -0.04535614f, -0.00545392f, -0.02122190f, 0.16767357f, 
    -0.85602683f, -0.69906449f, -0.30893558f, -0.13256760f, -0.28817099f, 0.09675992f, 0.24250783f, 0.01409953f, 
    -0.17694972f, -0.05772343f, 0.21495655f, -0.04981505f, 0.12711164f, -0.05411944f, -0.03604233f, -0.01044338f, 
    -0.03037383f, 0.13360538f, 0.13890022f, 0.15846710f, -0.38787654f, 0.01742394f, 0.11899903f, -0.13873191f, 
    -0.20823236f, 0.21352936f, -0.03209406f, -0.04691696f, 0.01519736f, 0.01527194f, -0.05186681f, 0.22174899f, 
    0.13917203f, 0.26418430f, 0.06171609f, 0.22696716f, 0.10816480f, 0.15586437f, -0.11840377f, 0.12691008f, 
    -0.08583077f, -0.16928196f, -0.19834666f, 0.17337839f, -0.03904993f, 0.15139781f, 0.16758937f, 0.15598130f, 
    0.13413627f, -0.08457165f, 0.27700400f, 0.09325888f, 0.21395300f, -0.02546758f, 0.01302805f, 0.09573516f, 
    0.02695627f, -0.26942465f, 0.20694762f, 0.08208952f, -0.75029016f, -0.64157414f, -0.02030645f, -0.26569599f, 
    0.02099587f, 0.13186622f, -0.05472017f, -0.11099393f, -0.11840174f, 0.17367737f, 0.09391537f, 0.07321035f, 
    0.05898468f, 0.03565798f, 0.07154955f, 0.01931330f, 0.09215841f, 0.04233241f, 0.05145967f, 0.05018685f, 
    0.45076913f, 0.16549322f, -0.50331414f, 0.11068677f, -0.06060444f, -0.23895752f, -0.26146016f, -0.20782316f, 
    -0.08542427f, -0.21345754f, 0.11057375f, 0.13251324f, -0.02902415f, -0.14963971f, -0.10991325f, -0.11945591f, 
    -0.09918366f, 0.07871358f, -0.20967323f, 0.11827960f, 0.39804915f, 0.06493940f, 0.09718778f, 0.02525602f, 
    -0.37217173f, -0.07037473f, -0.22572945f, 0.03273998f, -0.03171921f, 0.07556033f, -0.04239736f, 0.04304547f, 
    -0.12647280f, -0.10289193f, -0.23170918f, -0.08846933f, -0.26224875f, -0.17542736f, -0.21063526f, -0.16728416f, 
    -0.73538440f, -0.40594804f, 0.07408269f, 0.01466469f, 0.52424031f, 0.12155494f, 0.04810642f, 0.03327496f, 
    -0.02430309f, -0.18910316f, 0.15719549f, -0.00275374f, 0.02949275f, -0.04334765f, 0.04744557f, -0.06372485f, 
    -0.03380859f, -0.10440391f, -0.14357622f, 0.05295108f, 0.22395976f, 0.11580104f, 0.07359823f, -0.01715169f, 
    0.12637235f, -0.07141771f, 0.10448430f, -0.00390050f, 0.12948900f, 0.02385489f, -0.08876026f, 0.06524874f, 
    0.01599958f, -0.02465279f, 0.13159570f, 0.01094598f, 0.09348849f, 0.01422869f, -0.22047916f, 0.19929078f, 
    0.03047480f, 0.02707126f, -0.10158260f, 0.09275410f, -0.02913899f, -0.15563324f, 0.08163749f, 0.01898378f, 
    0.15916258f, -0.14728002f, -0.01427833f, -0.00875099f, 0.04340544f, -0.23656957f, 0.03789844f, -0.25341040f, 
    0.02082867f, 0.05461840f, 0.18514825f, -0.01761312f, -0.29875797f, -0.23575082f, 0.04742679f, -0.05121798f, 
    0.29991439f, 0.04512876f, 0.13417959f, 0.09884318f, -0.04784213f, -0.04235353f, 0.06670024f, 0.02260606f, 
    0.17996563f, -0.05574492f, 0.00414946f, -0.07619216f, 0.00417573f, -0.05226308f, -0.06521101f, 0.23569620f, 
    0.29800031f, -0.07193043f, 0.21994857f, -0.06511991f, -0.16384667f, 0.18134849f, 0.01459568f, 0.09230970f, 
    0.16943029f, 0.22536077f, 0.08157104f, -0.03892796f, -0.02800930f, -0.05276551f, -0.13376023f, 0.02835892f, 
    0.10185280f, -0.45800492f, -0.09501133f, 0.01044209f, -0.00410248f, 0.17062797f, -0.49421492f, 0.19718477f, 
    0.04852166f, 0.07539964f, -0.06896486f, -0.00379161f, 0.05613389f, 0.16769624f, -0.06063846f, -0.01729273f, 
    0.15333386f, -0.04530125f, 0.13411485f, 0.01934293f, 0.13180470f, 0.17432663f, -0.00521409f, -0.14459327f, 
    0.11012210f, -0.56629163f, -0.27724275f, -0.07563043f, -0.50247097f, 0.02292544f, 0.05491118f, 0.07230204f, 
    0.04869894f, -0.03701213f, -0.04649698f, 0.09526790f, -0.00446547f, 0.08130004f, -0.09221914f, 0.03413477f, 
    0.02367144f, -0.04490497f, -0.08126794f, -0.05876749f, 0.71352148f, 0.28510335f, -0.41608244f, -0.33251405f, 
    -0.25706375f, -0.19678739f, 0.00736834f, -0.04323849f, 0.10992664f, -0.09166562f, 0.23764183f, -0.00364964f, 
    -0.08702783f, 0.13884918f, -0.00506970f, 0.02472034f, 0.05451571f, 0.00641791f, 0.04571729f, 0.17523134f, 
    -0.03557300f, 0.04764124f, -0.05540451f, -0.02834585f, -0.07232030f, -0.00392378f, -0.12701960f, 0.15293138f, 
    -0.09818263f, -0.04001053f, -0.27695468f, -0.21085665f, 0.10335808f, -0.13740906f, -0.13338885f, 0.00924432f, 
    -0.14838453f, 0.00742094f, -0.11120076f, -0.08110830f, 0.47079918f, -0.18335921f, -0.03148637f, 0.10441356f, 
    0.02731825f, 0.03597139f, 0.16052058f, -0.07753221f, 0.28128219f, -0.05227136f, 0.00524184f, -0.02695039f, 
    -0.03742573f, 0.24742006f, 0.03963339f, -0.20507650f, -0.20740470f, -0.00633952f, -0.19583060f, -0.11636553f, 
    0.13794895f, -0.44274819f, -0.45648760f, -0.13083474f, -0.30312857f, 0.01181510f, 0.08362309f, 0.09187010f, 
    -0.05520061f, 0.27867350f, -0.07254258f, 0.10364256f, -0.09921848f, -0.08944825f, -0.04867128f, -0.03999415f, 
    0.04243050f, 0.04361998f, -0.07909213f, -0.07527895f, 0.73007762f, -0.01290148f, -0.21968299f, -0.11394685f, 
    0.23073746f, 0.13616173f, 0.04415369f, 0.01656621f, 0.11994167f, 0.09626862f, 0.28179139f, 0.02405736f, 
    0.09427460f, 0.02119390f, 0.10331238f, 0.04190433f, -0.12793536f, -0.16086677f, -0.04180067f, 0.08329082f, 
    0.39914671f, -0.31233397f, -0.27157459f, 0.25524667f, 0.07367194f, -0.03525653f, 0.01700981f, -0.08890178f, 
    -0.03946204f, -0.01443438f, -0.00251055f, -0.09572721f, 0.09059529f, 0.18043499f, -0.06849720f, 0.15538059f, 
    0.01673691f, 0.12778607f, -0.14345272f, -0.03116012f, 0.45225587f, -0.29012400f, -0.34133905f, 0.00778903f, 
    -0.02232473f, 0.15976954f, -0.02952038f, -0.04811472f, -0.01685317f, -0.14814687f, 0.20060383f, -0.08733547f, 
    -0.15055814f, 0.15789601f, 0.14558776f, 0.14340489f, -0.04710106f, -0.01773369f, 0.10607890f, 0.00383539f, 
    -0.86693776f, 0.13407400f, 0.10976020f, -0.11733621f, -0.13265726f, -0.06979299f, 0.02236933f, 0.00673487f, 
    -0.11312146f, -0.06994562f, -0.31297836f, 0.24906413f, 0.20403697f, 0.02020922f, 0.04337318f, -0.00347166f, 
    -0.11635087f, -0.01395165f, -0.26443505f, 0.05934082f, 0.37469086f, 0.06692261f, 0.12243487f, -0.15570076f, 
    -0.12547360f, -0.26502797f, -0.20920934f, -0.12646301f, -0.11300942f, -0.42833984f, -0.00978972f, -0.06702892f, 
    0.15912700f, 0.08853845f, -0.13073015f, -0.10454479f, -0.24022861f, 0.02545418f, 0.00564492f, 0.11025692f, 
    -0.40602872f, 0.60170907f, -0.29597399f, 0.34440303f, 0.22669473f, 0.23171802f, 0.02278928f, 0.14067832f, 
    -0.03576952f, 0.06256628f, 0.09870474f, 0.08192152f, 0.09258585f, -0.07689097f, 0.12260298f, -0.06598631f, 
    0.12829660f, -0.10561169f, -0.09788620f, 0.01944310f, -0.55757076f, 0.42144182f, -0.01196134f, -0.03996591f, 
    0.01969674f, -0.15751381f, -0.09655123f, 0.08903453f, -0.11873854f, -0.00993849f, -0.02429225f, -0.04678352f, 
    -0.00610020f, -0.14713788f, -0.01854217f, 0.09778827f, 0.12219651f, 0.04053356f, -0.08049218f, -0.03362880f, 
    -0.42508414f, -0.49803835f, 0.13991806f, 0.05683562f, -0.18502742f, 0.07058328f, 0.08194073f, 0.17835212f, 
    0.01568962f, 0.30386207f, -0.17853089f, -0.04639374f, 0.02598089f, -0.17795873f, -0.08079059f, -0.22398831f, 
    0.09908474f, -0.05513203f, -0.05421726f, 0.00507486f, -0.60604668f, 0.37341720f, 0.04795602f, 0.04951780f, 
    0.07892463f, 0.14939442f, -0.02278541f, 0.21157198f, 0.00545484f, -0.04552711f, 0.14726499f, 0.20485963f, 
    0.00206142f, -0.02981699f, -0.02384113f, -0.13160785f, 0.16969362f, -0.12164492f, -0.07377922f, -0.13169096f, 
    -0.22113845f, -0.07482656f, -0.33348584f, -0.32997486f, 0.34780064f, 0.11547896f, -0.29272157f, 0.03867983f, 
    -0.13253939f, -0.07616133f, -0.09679954f, 0.04371554f, -0.11154941f, -0.05502509f, -0.11472026f, 0.19212973f, 
    0.06109750f, 0.20353673f, 0.25610995f, 0.00759943f, 0.16322149f, 0.02645882f, 0.01635935f, 0.10091885f, 
    -0.25626290f, -0.19133799f, 0.23769510f, -0.01967191f, -0.08951030f, -0.01756676f, -0.15532520f, -0.15043694f, 
    -0.07334352f, 0.20415123f, -0.12920284f, 0.09983097f, -0.04366808f, 0.03605647f, -0.01571440f, -0.10938064f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.13056843f, 0.01681764f, -0.09752107f, -0.02029344f, 0.06079530f, 0.08995401f, -0.03541225f, -0.15504409f, 
    -0.06235960f, 0.02254604f, 0.11314713f, -0.00119539f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
