#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.72798973f, 0.42284238f, 0.22989899f, -0.33739075f, 0.63988996f, -0.49922788f, -0.05413780f, -0.57964969f, 
    -0.43383893f, -0.29369739f, 0.26280889f, 0.30288455f, 0.07334896f, -0.13695806f, 0.06121211f, -0.24014108f, 
    -0.11001668f, -0.08287515f, -0.45480552f, -0.16362135f, 0.31821704f, 0.23052637f, 0.38474235f, 0.31090140f, 
    -0.17382362f, -0.53226548f, -0.80666870f, -0.21334645f, 0.30555451f, 0.53593040f, -0.63763487f, 0.26828846f, 
    0.49807939f, -0.38365841f, 0.11675332f, 0.41489571f, 0.09688541f, -0.07504099f, -0.25224224f, -0.04278938f, 
    -0.10205667f, 0.01458266f, -0.15045735f, 0.05368107f, -0.10381373f, -0.12683652f, -0.17000417f, -0.00972902f, 
    0.03380154f, -0.06873941f, -0.79291630f, -0.52116817f, -0.15896587f, -0.46772119f, -0.19439279f, 0.46043351f, 
    -0.13146175f, -0.06182850f, 0.46978548f, -0.08865401f, 0.12336206f, 0.09774952f, 0.31508103f, 0.07775381f, 
    -0.21080631f, 0.08441263f, 0.00362983f, -0.12463489f, -0.52583075f, 0.32510632f, -0.18923615f, -0.07848264f, 
    0.04778038f, 0.00814959f, -0.04519599f, 0.33654210f, 0.61689115f, 0.56274551f, -0.49576908f, 0.54551345f, 
    0.27077094f, -0.44694912f, -0.78826600f, -0.18275577f, -0.40143129f, 0.36575431f, -0.07249776f, -0.25714293f, 
    0.13531494f, -0.21882126f, 0.38475397f, 0.15224819f, -0.40140721f, 0.16845179f, -0.24541794f, -0.02089642f, 
    -0.22347638f, 0.23053181f, -0.12610064f, 0.38757119f, -0.46166161f, -1.07754350f, -0.61272603f, 0.35527912f, 
    0.25836259f, -0.42840290f, 0.78007579f, 0.38396135f, -0.42801592f, -0.03133129f, 0.29371148f, -0.15581746f, 
    -0.24976419f, 0.21310627f, 0.30491176f, -0.30961466f, 0.09039671f, -0.18845321f, -0.02555081f, -0.05554612f, 
    0.26068884f, -0.20398603f, 0.31448817f, -0.40378109f, 0.11207722f, 0.03691171f, 0.68427974f, 0.74143350f, 
    -0.92110175f, -0.33383390f, 0.20048365f, -0.08533239f, 0.49083087f, -0.22510001f, 0.08626948f, 0.52673894f, 
    0.37957948f, 0.05681794f, 0.02767958f, -0.01257509f, 0.33025083f, 0.15288688f, 0.04548132f, 0.13607101f, 
    -0.06956190f, 0.04796891f, 0.39990261f, 0.00915784f, -0.14137273f, 0.15679152f, 0.19002630f, -0.50136840f, 
    0.21930476f, 0.47863945f, 0.70017606f, 0.22238265f, 0.02464199f, 0.38065559f, 0.12078275f, -0.34689552f, 
    0.40981868f, 0.22158246f, -0.36767316f, -0.07085865f, 0.05109968f, -0.21304111f, -0.20230252f, -0.16853532f, 
    0.01128692f, 0.14612140f, 0.10053897f, -0.15385813f, -0.11540972f, -0.09189367f, -0.05517817f, 0.89253199f, 
    0.38029277f, 0.72607696f, -0.52253604f, -0.67184019f, 0.12615772f, -0.19737065f, 0.30682936f, 0.60479093f, 
    0.30604216f, 0.19307128f, 0.24491240f, -0.22475614f, -0.31669989f, 0.00209155f, -0.08060779f, 0.03208140f, 
    -0.05303783f, -0.12918390f, -0.05811777f, 0.04591858f, -0.01480858f, 0.22559118f, -0.02071566f, -0.12165230f, 
    -0.83724236f, 0.31505027f, -0.37603298f, -0.38236383f, 0.27244374f, 0.04529126f, -0.21687037f, -0.16215934f, 
    -0.00542944f, 0.57458186f, 0.28576955f, -0.42996603f, 0.37162367f, -0.29919881f, 0.01981394f, 0.01623041f, 
    -0.23320304f, 0.40819684f, 0.02452417f, -0.04276363f, 0.22158922f, -0.24498299f, 0.03870195f, -0.03443618f, 
    0.02927068f, -0.66846806f, -0.64563471f, -0.56860358f, -0.49777091f, -0.18034859f, -0.35536617f, -0.39746323f, 
    0.18890558f, -0.05233672f, 0.42745307f, -0.15826294f, 0.29249093f, -0.01872138f, 0.22180440f, -0.02511993f, 
    0.33900633f, 0.15472195f, 0.08596886f, 0.20946521f, 0.15392767f, -0.13792281f, 0.00780030f, 0.11836401f, 
    0.08579993f, 0.28430760f, -0.37442833f, -0.45077381f, 0.37527746f, -0.38525707f, -0.76282465f, -0.10427391f, 
    -0.49596432f, -0.24285164f, -0.14757073f, 0.07413569f, 0.00403965f, 0.40045810f, -0.12947768f, -0.08229059f, 
    0.10787591f, -0.45797133f, -0.24569701f, 0.01361004f, -0.34077966f, 0.02230584f, 0.21539152f, 0.40435162f, 
    0.09440588f, 0.05179771f, 0.10369676f, 0.67946863f, 0.55969763f, 0.19295977f, -0.65333205f, -0.44439241f, 
    -0.18289831f, 0.27303410f, -0.13323766f, -0.36211750f, -0.21645483f, 0.14251764f, 0.28841987f, 0.39232084f, 
    0.29773512f, 0.19688562f, 0.17467810f, 0.39149231f, 0.28987542f, -0.12406163f, -0.17970149f, -0.01837627f, 
    -0.09876025f, -0.04258240f, 0.12502700f, 0.28092539f, 0.07665647f, -0.39333013f, -0.84815508f, -0.48657072f, 
    -0.14029551f, -0.47893909f, 0.37148076f, 0.23252738f, -0.08670139f, 0.32292995f, 0.30459943f, -0.24143298f, 
    0.04822361f, 0.14151514f, 0.01379419f, 0.13484722f, -0.06857383f, -0.46574521f, 0.23362619f, 0.16048464f, 
    0.03428284f, 0.36833280f, 0.18744922f, -0.16072625f, 0.39736736f, 0.80892748f, -0.83010727f, 0.18450129f, 
    0.92443138f, 0.46759009f, -0.76161569f, -0.03521187f, 0.10471264f, 0.23644756f, 0.41149166f, 0.16107483f, 
    0.01242461f, -0.36522454f, 0.12120728f, -0.08739174f, -0.33084226f, -0.07082656f, -0.18581815f, 0.05681150f, 
    0.05966881f, -0.01851589f, 0.07234942f, 0.10684937f, -0.11469982f, 0.23944919f, 0.27092931f, 0.02038993f, 
    0.31711304f, 0.65054768f, 0.44852895f, 0.39698482f, 0.37109494f, 0.35606197f, 0.13021436f, -0.14284837f, 
    -0.55596471f, -0.18264674f, -0.03629491f, 0.12611917f, 0.14901970f, -0.22670063f, 0.01662763f, 0.32620758f, 
    0.33881295f, -0.22090924f, -0.30282339f, -0.23921174f, -0.37189904f, 0.33045447f, 0.07540153f, 0.89985728f, 
    0.17895460f, -0.69395542f, -0.03980275f, -0.65908289f, -0.15074734f, 0.60652626f, -0.35124865f, 0.18215604f, 
    0.31258240f, 0.38986534f, 0.39664000f, -0.13616699f, -0.05862843f, 0.12655242f, 0.06014217f, 0.19308592f, 
    -0.24334672f, 0.24008271f, 0.45416519f, -0.25431311f, 0.15516324f, 0.27786925f, 0.29331973f, 0.14819689f, 
    -0.14344372f, -0.52527595f, -0.38106328f, -0.63194501f, -0.49588686f, -0.24646913f, 0.66021276f, 0.42818356f, 
    -0.10713744f, 0.25394908f, 0.04501431f, -0.05305267f, -0.16018181f, -0.29066959f, -0.32889819f, 0.20613669f, 
    -0.01422185f, -0.09666505f, -0.06044995f, 0.02501415f, -0.18516949f, 0.16985187f, -0.02194529f, -0.03110761f, 
    0.12511516f, -0.30428585f, -0.65971327f, -0.47338867f, -0.42109364f, 0.15476224f, -0.38644952f, 0.56090486f, 
    0.49328178f, -0.05561333f, 0.27744043f, 0.27620444f, 0.04150466f, -0.10208733f, -0.35782358f, -0.06999383f, 
    -0.28758758f, -0.14140092f, 0.20617414f, -0.25662479f, -0.04514088f, -0.08817089f, -0.00142725f, -0.42693430f, 
    0.06870487f, -0.29261243f, -0.44018498f, -0.38414350f, -0.06229645f, 0.24843191f, -0.17912287f, -0.30319393f, 
    0.58321214f, -0.19985627f, 0.09477696f, -0.21704073f, 0.08017731f, -0.27686471f, -0.25132078f, -0.31291690f, 
    -0.23846407f, 0.19547385f, -0.01171291f, 0.13250096f, -0.38383001f, -0.22575839f, -0.18542591f, -0.19480662f, 
    0.40470290f, 0.38510534f, 0.36846471f, 0.30704513f, -0.50840139f, -0.76208359f, -0.71545231f, 0.08703196f, 
    0.76726764f, 0.18031868f, 0.19009373f, -0.26005861f, 0.04751370f, 0.18500932f, -0.01768695f, 0.20424365f, 
    -0.19724755f, -0.23787452f, -0.31358281f, 0.03758987f, 0.14454146f, 0.34643909f, 0.02374950f, 0.07107721f, 
    -0.07930211f, -0.00776300f, 0.09428138f, -0.00081390f, 0.35450166f, 0.07578152f, 0.27666980f, -0.61075824f, 
    -0.74246413f, -0.52381158f, -0.23235726f, -0.55145007f, -0.65143782f, 0.16508397f, 0.25091335f, 0.49043721f, 
    0.08927391f, -0.18211994f, -0.04636362f, -0.01506884f, -0.05935787f, -0.15668544f, 0.24770048f, 0.28411299f, 
    0.14238930f, 0.03690987f, -0.17910571f, 0.00144049f, 0.12701549f, 0.71402901f, 0.72038645f, 0.31067824f, 
    0.31356367f, -0.65123767f, -0.60964179f, -0.48929241f, 0.35247955f, -0.37761021f, 0.36776137f, 0.21615130f, 
    0.27779761f, 0.25257060f, 0.07944684f, -0.08011773f, -0.19855703f, -0.29527873f, 0.12442530f, -0.07894277f, 
    -0.03655403f, 0.08182338f, 0.20717372f, 0.19376607f, -0.02429453f, 0.21322012f, 0.45082396f, -0.12202828f, 
    0.18372165f, 0.79064959f, 0.68174642f, -0.52700996f, 0.05925483f, -0.53217244f, -0.31476560f, 0.28457475f, 
    0.12256470f, -0.01914437f, 0.09783488f, -0.04353497f, -0.25884014f, -0.21499963f, -0.04760947f, 0.29030526f, 
    0.16373342f, 0.32437453f, -0.17553480f, 0.31984109f, -0.12504703f, 0.34539360f, -0.26254112f, 0.86493593f, 
    -0.25175059f, 0.16456057f, -0.26067543f, -0.02834246f, 0.60797417f, 0.45790663f, -0.20865338f, 0.09083743f, 
    0.07621686f, -0.07852945f, 0.61790651f, -0.26272929f, 0.11913941f, 0.01556502f, -0.01154794f, -0.03203212f, 
    0.05322984f, -0.06412949f, -0.04772063f, 0.10955832f, 0.12640139f, 0.06512767f, -0.02626588f, 0.09477212f, 
    -0.36121002f, -0.78494090f, 0.15185580f, 0.37049696f, -0.62670416f, 0.05931732f, -0.54898608f, 0.30217198f, 
    -0.27668953f, 0.13512750f, 0.38465524f, 0.17864612f, 0.16230115f, 0.26675266f, 0.41522899f, 0.09494392f, 
    0.28619897f, 0.19152130f, -0.39035973f, 0.30131537f, 0.21782635f, -0.08897301f, 0.27032530f, -0.31099713f, 
    -0.13946702f, 0.94925207f, 0.75234300f, -0.58442420f, -0.31303138f, -0.29114059f, -0.16781418f, 0.36063954f, 
    -0.52122712f, 0.18240501f, 0.32554170f, 0.29753417f, -0.02108502f, -0.09825786f, -0.23353218f, 0.07869295f, 
    0.19832975f, -0.22882795f, -0.03541359f, 0.00930062f, -0.10861368f, -0.03507830f, -0.00666190f, 0.03717105f, 
    0.02626258f, -0.13759017f, -0.12140726f, -0.44727546f, -0.11832479f, -0.28410360f, -0.13173345f, 0.27282238f, 
    -0.65937942f, -0.20284647f, -0.09273887f, -0.34476075f, -0.22880451f, 0.03238389f, 0.28357914f, -0.05313728f, 
    0.40884256f, 0.22632305f, 0.12656628f, 0.39091519f, 0.32303828f, 0.18878783f, 0.32287565f, 0.26276672f, 
    -0.19570200f, 0.19725423f, 0.19743161f, -0.12295950f, 0.66841793f, 0.05608617f, 0.77318734f, 0.27665389f, 
    -0.19853543f, 0.00976676f, -0.10651171f, -0.21836232f, -0.14717299f, -0.57622087f, -0.57376933f, 0.01783270f, 
    -0.21094994f, 0.07899815f, 0.19930664f, 0.32040861f, -0.02162265f, 0.02050544f, -0.12648931f, 0.02749588f, 
    -0.20704854f, -0.42359257f, 0.25829247f, -0.28234240f, -0.27207795f, -0.78913558f, 0.26781949f, 0.68878728f, 
    -0.30682257f, -0.65498859f, 0.49247780f, 0.84284765f, -0.55519956f, 0.19990128f, -0.10570849f, 0.17272305f, 
    -0.02792002f, -0.02071979f, -0.33466035f, 0.11424372f, -0.02464789f, -0.20064765f, -0.08889262f, -0.10663309f, 
    -0.28315881f, 0.19572458f, 0.05715772f, 0.21173316f, -0.06090742f, -0.63393706f, -0.28699380f, -0.52161020f, 
    -0.26199344f, -0.58503342f, 0.53147858f, 0.82378066f, -0.03092659f, 0.53289723f, 0.58568281f, -0.08534981f, 
    -0.36924720f, -0.13479957f, -0.41328189f, 0.10465430f, -0.15435691f, 0.18346648f, -0.10345846f, -0.20220165f, 
    -0.16957824f, -0.18404409f, -0.17008066f, -0.19853258f, -0.08391227f, 0.00819437f, -0.10865051f, 0.82330346f, 
    0.20919786f, 0.70509017f, 0.62364656f, -0.06544839f, -0.00627224f, -0.11981227f, 0.56635505f, 0.12465835f, 
    -0.26526129f, -0.08352399f, 0.03102905f, -0.32593411f, -0.29856592f, -0.10612909f, 0.27018416f, -0.16792434f, 
    -0.37113482f, -0.23988761f, 0.21958189f, -0.08290887f, -0.33717975f, 0.20590845f, 0.12848626f, 0.66287214f, 
    0.55216432f, 0.43444756f, 0.31168965f, 0.78101403f, 0.35279548f, -0.46909076f, 0.34206480f, 0.30388275f, 
    0.01508187f, -0.17393936f, 0.03437773f, -0.10692749f, -0.00715588f, 0.26541728f, -0.04948125f, 0.21197200f, 
    -0.05887263f, -0.23901503f, 0.12613076f, -0.13813795f, 0.14485443f, 0.26432618f, 0.12815556f, 0.08092436f, 
    0.02479533f, -0.52650946f, 0.04198617f, 0.25713122f, -0.19137935f, -0.02185127f, -0.63419157f, -0.02365271f, 
    -0.34464315f, -0.60482305f, -0.43719161f, -0.11191984f, 0.42987239f, 0.24246579f, 0.14531179f, -0.40588421f, 
    -0.37408504f, -0.54258800f, 0.26622570f, 0.33497676f, -0.23322244f, 0.03580200f, -0.26602763f, -0.19346648f, 
    -0.22531009f, 0.11034077f, -0.90382797f, -0.43600878f, 0.07542247f, -0.22255164f, 0.10303906f, 0.90426612f, 
    0.48460695f, 0.43965477f, 0.19991198f, -0.06482483f, 0.33417317f, -0.39281508f, 0.21115126f, -0.19094488f, 
    0.06423236f, 0.08976007f, 0.15419361f, 0.04408848f, 0.01317203f, 0.11212873f, 0.15160389f, 0.31043181f, 
    0.17797694f, -0.03482455f, 0.42050937f, 0.52687550f, -0.96827406f, -0.00700601f, -0.80713308f, 0.20111917f, 
    -0.46316445f, 0.14712562f, 0.12981929f, -0.50301313f, -0.02619397f, 0.28294066f, -0.04700876f, 0.16088423f, 
    -0.02409221f, 0.21797761f, 0.21935555f, -0.25249565f, -0.18901300f, -0.08771186f, 0.01804789f, -0.09371891f, 
    0.06161153f, -0.06571471f, 0.20111552f, -0.09392840f, 0.56479764f, -0.39804468f, -0.06989856f, 0.15756612f, 
    0.77884084f, -0.29336828f, -0.67216951f, 0.13571784f, -0.42808893f, -0.36543944f, 0.24233073f, 0.23561209f, 
    0.33177742f, -0.37583998f, 0.07419445f, -0.41870734f, 0.11689033f, 0.21739830f, 0.18508576f, -0.00906232f, 
    0.30392361f, -0.34109402f, -0.26723722f, 0.04668205f, 0.91823971f, 0.53403741f, 0.05648978f, 0.96856582f, 
    0.80390233f, 0.41989034f, -0.11359163f, -0.22404209f, 0.05098204f, 0.05329661f, -0.13159391f, 0.30388853f, 
    -0.00950895f, 0.01535786f, -0.02175702f, 0.11739685f, -0.15022559f, 0.15215878f, -0.00146300f, -0.01306989f, 
    0.20677933f, 0.11415376f, 0.05304683f, -0.16391863f, 0.16373597f, -0.47675791f, -0.41714129f, -0.12364145f, 
    -0.33878788f, -0.37521541f, -0.04251337f, -0.38934293f, 0.30039412f, 0.04668648f, -0.40762559f, -0.30668652f, 
    -0.17335597f, -0.14331068f, -0.20712404f, -0.43466565f, -0.26103422f, 0.51063854f, 0.22455186f, 0.16540101f, 
    -0.03676770f, 0.37721854f, 0.18157649f, 0.10996670f, 0.02931922f, -0.02558086f, -0.60034913f, 0.35313135f, 
    -0.16726440f, 0.15255453f, 0.08073911f, -0.02964630f, -0.02751589f, -0.49240988f, -0.56431252f, -0.24350002f, 
    0.32444894f, 0.34926164f, 0.50088847f, 0.18831491f, 0.36308989f, 0.11130631f, 0.17721169f, 0.27718225f, 
    0.10569189f, 0.41677019f, -0.17023225f, -0.20277137f, -0.09812349f, 0.08879044f, 0.50150204f, 0.92595047f, 
    0.71335661f, -0.03997840f, 0.27362603f, -0.04971702f, -0.47231805f, -0.65946627f, 0.55429322f, -0.20149234f, 
    0.19055754f, -0.24126884f, 0.12305078f, -0.03692391f, -0.15244316f, -0.13161401f, 0.22378486f, -0.16449057f, 
    -0.10567767f, -0.02386135f, 0.40537018f, 0.26434115f, 0.42486745f, 0.03820730f, -0.34590691f, -0.19062293f, 
    -0.17081124f, 0.42873743f, -0.48678663f, -0.62804872f, -0.52867728f, 0.64324462f, -0.60822463f, -0.46917471f, 
    0.03237275f, -0.26866350f, -0.00959308f, -0.36765486f, 0.37163082f, 0.18826684f, 0.11253339f, 0.06574824f, 
    -0.28880715f, -0.21262476f, -0.12951834f, 0.33974358f, 0.04159042f, -0.02948091f, 0.11604118f, -0.01600256f, 
    -0.29573563f, 0.41634685f, 0.72564834f, 0.21621248f, 0.78388470f, 0.75674677f, 0.57103139f, -0.01837656f, 
    -0.74141777f, 0.05711012f, -0.29418078f, 0.02661214f, 0.11622352f, -0.34543678f, 0.39524770f, -0.09172070f, 
    0.25964868f, 0.01069932f, 0.17330232f, 0.06706724f, -0.01464795f, 0.12212774f, 0.04717402f, 0.18956634f, 
    0.07606000f, 0.31061515f, 0.31082329f, 0.35024881f, 0.63664430f, -0.01328979f, -0.21984531f, -0.67018360f, 
    -0.26102695f, -0.53265297f, 0.03809796f, 0.79317951f, 0.30040473f, 0.24777138f, -0.23203216f, 0.08279144f, 
    -0.47530526f, -0.05267542f, -0.21835297f, 0.28197488f, -0.19150282f, -0.23252808f, 0.10289046f, -0.21239892f, 
    -0.16949238f, 0.05925859f, -0.11344026f, -0.24001080f, -0.71996617f, -0.74620789f, 0.78345418f, 0.30808076f, 
    0.27241683f, 0.35821345f, -0.09898157f, 0.22647189f, -0.67085439f, -0.36640409f, 0.30596003f, -0.16499929f, 
    0.22795475f, 0.19712675f, 0.25720111f, -0.17199276f, -0.19298330f, -0.32438040f, 0.14070491f, 0.13126586f, 
    0.41548958f, 0.27156749f, 0.16039717f, -0.24752747f, -0.73170316f, -0.66429359f, 0.40243885f, 0.50139713f, 
    -0.05815531f, -0.07763074f, 0.82379997f, -0.00873274f, -0.18819447f, 0.41626707f, 0.03263696f, -0.16568007f, 
    0.10406786f, 0.11026533f, -0.15702294f, 0.11807044f, 0.26004738f, 0.05464892f, 0.21079600f, -0.34233484f, 
    -0.00599990f, -0.08426119f, 0.07169966f, 0.49261957f, -0.29816639f, 0.41186649f, 0.74704921f, -0.49910596f, 
    -0.62968594f, -0.67874855f, 0.67813259f, 0.13811085f, -0.33638337f, -0.59424084f, -0.07207448f, 0.03197799f, 
    0.22222947f, -0.02689075f, 0.30403492f, 0.20059051f, 0.01115269f, -0.02309474f, 0.17368758f, -0.07969601f, 
    -0.24192716f, 0.01773425f, 0.30114707f, 0.24802780f, -0.32013875f, 0.45510447f, 0.01583034f, -0.19512874f, 
    -0.25441933f, 0.00119060f, 0.32189748f, 0.70117885f, 0.51593393f, -0.46714729f, 0.43674952f, 0.34510699f, 
    0.10604940f, 0.30541894f, 0.36523974f, 0.30327702f, -0.18011710f, -0.41497317f, -0.12378792f, 0.05681509f, 
    -0.21925882f, 0.43811995f, 0.01765694f, -0.25942191f, 0.37393966f, -0.19324653f, 0.00779512f, 0.22143802f, 
    -0.07620487f, -0.64828175f, 0.11696731f, -0.03950223f, -0.10250409f, 0.13885894f, 0.58739758f, 0.62215972f, 
    0.29009128f, -0.24687079f, -0.33337101f, 0.03067448f, 0.02644236f, -0.62588757f, -0.64888895f, -0.03348589f, 
    0.28063831f, -0.10678647f, -0.11931018f, -0.19490345f, -0.43924230f, -0.43504030f, -0.44801396f, 0.32438591f, 
    0.74950522f, 0.62186348f, 0.59924090f, -0.00104964f, 0.21198015f, -0.60464078f, -0.60756582f, -0.25910634f, 
    -0.14195637f, -0.03681646f, 0.19129528f, -0.40278351f, -0.08548019f, 0.37931517f, -0.00034831f, -0.23749942f, 
    -0.26006255f, 0.01415580f, 0.25151944f, -0.41369364f, 0.15003091f, 0.05747829f, 0.14839885f, -0.16797386f, 
    0.37266532f, -0.00411896f, 0.16580017f, 0.00166324f, 0.70766568f, 0.52338403f, 0.45335057f, 0.52872443f, 
    0.45318681f, -0.15012300f, 0.09476506f, -0.30888805f, -0.34741530f, -0.06493291f, -0.16802858f, 0.05217114f, 
    -0.20639512f, 0.13102661f, -0.25673020f, -0.11229625f, 0.15448450f, -0.31452501f, 0.20788756f, 0.20100592f, 
    0.08489417f, -0.34684595f, 0.04841336f, 0.09789047f, -0.15934533f, 0.59142309f, 0.12927788f, -0.64662826f, 
    -0.60668606f, -0.44449574f, -0.56676131f, -0.15478040f, 0.24012201f, 0.19191252f, -0.02700800f, 0.12410822f, 
    0.13004197f, 0.05923439f, 0.12054624f, -0.05695456f, -0.05628835f, -0.43032077f, -0.03019462f, 0.17981549f, 
    0.24739687f, -0.11845229f, -0.20124145f, 0.13876812f, 0.47976762f, 0.16381057f, 0.39198428f, 0.52671349f, 
    0.06130822f, -0.64145350f, -0.21971779f, -0.41358054f, 0.20808139f, 0.59080291f, 0.07686091f, 0.22240061f, 
    0.45340258f, -0.59037519f, 0.20438857f, -0.13188349f, -0.26292279f, 0.15834664f, 0.04491526f, -0.20090853f, 
    0.11578131f, 0.35833010f, -0.20343857f, -0.15993737f, 0.56587261f, 0.80793780f, 0.55649292f, 0.88844246f, 
    0.18080138f, 0.51451266f, 0.12585077f, 0.00355619f, -0.15820663f, -0.36488625f, 0.23950918f, 0.20055924f, 
    -0.01179038f, 0.21551935f, -0.37259322f, -0.07066879f, -0.18737257f, 0.21388787f, -0.14035930f, -0.20077011f, 
    -0.07258846f, 0.08172878f, -0.14850090f, -0.06189736f, -0.26157510f, 0.55373293f, -0.00567941f, -0.46084929f, 
    -0.71770597f, 0.17986360f, -0.36417800f, -0.16065966f, -0.17324768f, -0.10594705f, -0.40405810f, -0.09260976f, 
    -0.15256038f, 0.53572869f, 0.00503197f, -0.43156961f, -0.37515149f, 0.11828555f, -0.10308230f, 0.08626691f, 
    0.16861984f, 0.03385217f, -0.15210788f, -0.01776480f, 0.10657380f, -0.23903720f, 0.43200734f, -0.02610674f, 
    0.20034392f, 0.58660388f, -0.09959948f, 0.66143769f, 0.50020736f, -0.04862145f, -0.02831060f, 0.36043385f, 
    -0.52367359f, -0.27302706f, -0.39674789f, -0.00855794f, 0.34602988f, -0.40914568f, -0.36720791f, -0.20632151f, 
    -0.06919365f, -0.03548619f, -0.04638524f, 0.07455499f, 0.35937288f, -0.08483449f, 0.22824627f, 0.73704433f, 
    0.16333738f, -0.06774871f, -0.14863807f, 0.18054922f, -0.73661208f, -0.06834117f, -0.27538761f, -0.00111788f, 
    -0.41539532f, -0.60186154f, 0.20771545f, 0.06328932f, -0.09316847f, -0.46767026f, 0.00941801f, 0.14100985f, 
    0.22945075f, 0.31697592f, 0.15728903f, -0.10417462f, -0.30793032f, -0.09073339f, -0.06442992f, -0.13539140f, 
    -0.21247429f, -0.75470579f, -0.32886353f, 0.18658410f, -0.44475400f, 0.52346277f, 0.87683564f, 0.45244712f, 
    -0.00590827f, -0.00749383f, -0.47626325f, 0.07902450f, 0.21183877f, 0.02508222f, -0.21284886f, -0.35795972f, 
    0.16930850f, 0.08651531f, -0.17983942f, -0.17447256f, 0.08399726f, 0.25042295f, -0.13132311f, 0.16611402f, 
    0.16009808f, 0.05561294f, -0.41571426f, 0.61210996f, 0.54003567f, 0.50339884f, 0.28807694f, 0.04309342f, 
    0.33694988f, 0.55460209f, 0.46814257f, -0.32490504f, -0.23685837f, -0.03219759f, -0.14706521f, -0.44645208f, 
    -0.06191510f, -0.08812698f, -0.12234521f, -0.10083383f, 0.20286882f, -0.08058894f, -0.14932221f, -0.01625538f, 
    0.12200902f, -0.03392989f, 0.56899983f, -0.72454613f, 0.74992973f, 0.38190070f, -0.28958640f, 0.59626973f, 
    0.14379928f, 0.21966843f, -0.68211234f, -0.25459024f, 0.11219814f, 0.03480816f, -0.31099185f, 0.32619157f, 
    0.23538572f, 0.08097212f, 0.23348235f, 0.12587762f, 0.00278806f, -0.03588662f, 0.02082972f, 0.44681075f, 
    0.28240514f, -0.00937516f, 0.26754096f, -0.01241887f, 0.74754989f, 0.15200727f, -0.12452534f, 0.09170506f, 
    -0.43836048f, -0.41009456f, -0.35703272f, -0.21579725f, -0.33035746f, -0.08635183f, -0.17542216f, -0.17545418f, 
    0.34205404f, 0.16461563f, -0.38071078f, -0.22635517f, -0.31605676f, -0.01082016f, 0.21079242f, -0.27206522f, 
    0.16395718f, 0.09889236f, 0.38947466f, -0.17135926f, -0.60303307f, -0.45959863f, -0.23758288f, -0.45786333f, 
    0.34350228f, -0.47454968f, 0.00241891f, -0.32188833f, -0.89244497f, 0.16082959f, -0.44712615f, 0.26538059f, 
    0.35081327f, 0.14310288f, 0.12819970f, 0.04052830f, -0.11686648f, 0.25271472f, -0.02727011f, -0.02403728f, 
    0.00900871f, -0.21024409f, 0.01454021f, -0.09931986f, -0.13527533f, -1.35810006f, 0.50587779f, 0.51026267f, 
    -0.54899567f, -0.39886039f, 0.57030040f, 0.25041810f, -0.27191401f, 0.39037633f, 0.40080893f, -0.16298178f, 
    -0.06603642f, 0.02841565f, 0.23267275f, 0.09684465f, -0.19047013f, 0.08270092f, -0.22570190f, -0.06364463f, 
    -0.27945632f, 0.19961496f, 0.06906825f, 0.02823423f, 0.19000332f, -0.11362062f, -0.12872918f, -0.40752581f, 
    0.88039434f, -0.00772990f, -0.57148194f, 0.05035193f, 0.04305485f, 0.68321741f, 0.17215331f, -0.02599736f, 
    0.04451677f, 0.04034163f, 0.00498064f, -0.06173562f, -0.11712543f, 0.22448134f, 0.06900087f, 0.15410900f, 
    -0.00161782f, -0.32592326f, 0.06897005f, 0.04550526f, -0.23943596f, -0.24076557f, -0.29065448f, 0.79724532f, 
    0.46075901f, -0.47072831f, 0.55724233f, -0.10049191f, -0.07819203f, 0.25643411f, -0.64010078f, 0.62721819f, 
    -0.29355499f, 0.05860322f, -0.38023862f, -0.34204403f, 0.01528160f, -0.25870261f, -0.01143239f, -0.19532490f, 
    0.19005036f, 0.06426138f, 0.06713206f, 0.06093828f, 0.01867733f, -0.15519792f, -0.00996325f, -0.05197788f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.01175286f, 0.00406147f, 0.06708915f, 0.24279664f, 0.18726867f, 0.09533735f, -0.03730324f, 0.12629952f, 
    0.18450621f, 0.05914794f, 0.24230097f, -0.00678645f, 0.33051056f, 0.15534247f, 0.06473081f, 0.10794332f, 
    0.18859512f, 0.10824469f, 0.06748886f, 0.13003655f, 0.17696591f, -0.01703754f, -0.00811454f, 0.18322659f, 
    0.26159865f, 0.14487348f, 0.07398676f, -0.01721655f, 0.01745187f, -0.05161336f, -0.05265138f, 0.23551373f, 
    -0.06306349f, 0.17089111f, 0.03173365f, 0.04425131f, 0.15318115f, 0.01444102f, 0.30968773f, 0.11859455f, 
    0.29676914f, 0.24970166f, 0.00998593f, 0.13686611f, 0.23869655f, 0.04055806f, 0.24724181f, 0.10053230f, 
    0.07321715f, -0.04104680f, 0.05958741f, 0.17377929f, 0.27187392f, 0.34861112f, 0.13181400f, 0.18869135f, 
    0.08106932f, 0.13255890f, 0.00369805f, 0.36406100f, 0.15438953f, -0.13777836f, 0.14144211f, 0.27830827f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.13964328f, 0.04340993f, 0.17872797f, 0.17117028f, -0.00949674f, -0.04402287f, -0.17351629f, -0.11962034f, 
    -0.00026603f, 0.00684229f, -0.00552445f, 0.07712097f, -0.01713750f, -0.01833610f, -0.01542376f, 0.09350803f, 
    -0.01316565f, -0.02460731f, 0.06105030f, 0.07738036f, 0.14484803f, 0.18666147f, 0.06937441f, -0.02955402f, 
    0.10146249f, 0.13971178f, -0.02959939f, -0.07561307f, 0.08540898f, -0.01049341f, -0.12381399f, 0.06988319f, 
    0.09325457f, 0.12853441f, 0.02306115f, -0.01644529f, 0.15298897f, -0.00449794f, -0.09136287f, 0.06809051f, 
    -0.14927238f, 0.02305762f, -0.02202717f, 0.03325886f, 0.07699402f, -0.01858502f, 0.19006287f, -0.04692427f, 
    -0.05727480f, 0.08208567f, 0.26176620f, -0.05241968f, 0.00852371f, 0.02005631f, 0.16951521f, 0.03176927f, 
    0.03409258f, -0.09268570f, 0.05912570f, 0.17804922f, 0.24707745f, -0.04417484f, -0.09040942f, 0.22961587f, 
    -0.01155080f, -0.00350442f, 0.04174345f, 0.02787933f, -0.06207605f, -0.09004406f, -0.06272973f, -0.17593278f, 
    0.16078763f, -0.21310973f, 0.04579781f, 0.08167604f, 0.05600757f, 0.10463230f, 0.08530529f, -0.00509488f, 
    0.12960964f, -0.01742381f, 0.11698858f, 0.09846701f, -0.34711918f, 0.11676656f, 0.02234587f, -0.05917178f, 
    0.01393534f, 0.05352668f, -0.10601069f, 0.07872132f, 0.03772413f, 0.05665269f, 0.16034096f, -0.02450824f, 
    0.07239145f, 0.09316485f, 0.08533150f, 0.13387206f, -0.16256079f, -0.07406468f, 0.07569308f, -0.00572651f, 
    -0.00254236f, 0.07497352f, -0.07394271f, 0.09705927f, 0.02309080f, 0.10728838f, -0.09243331f, 0.13332304f, 
    -0.09470926f, -0.17903867f, -0.10200758f, -0.00121758f, -0.00569033f, -0.03678093f, -0.05837993f, -0.07465995f, 
    0.14705780f, -0.12296698f, 0.12989254f, -0.30827290f, -0.08300813f, 0.00943969f, -0.13894396f, -0.04552292f, 
    0.03013070f, -0.05733322f, 0.05813373f, 0.08306444f, -0.01176248f, -0.14902407f, -0.11007841f, 0.05104809f, 
    0.04302346f, 0.06610155f, -0.01615495f, -0.02057236f, 0.16470504f, 0.05442200f, -0.11652530f, -0.13312699f, 
    -0.20875026f, 0.21868119f, -0.02138928f, 0.10809752f, 0.00555798f, -0.09029546f, 0.11114045f, 0.01298709f, 
    0.05007666f, -0.12332837f, 0.09254191f, -0.11380641f, 0.14299193f, 0.28680119f, 0.03644610f, -0.01996426f, 
    0.09853140f, 0.02410647f, 0.04417496f, -0.00729682f, -0.04281037f, 0.06881312f, 0.00420083f, 0.02235557f, 
    0.01145727f, -0.21456389f, -0.03635707f, -0.12294833f, 0.01933262f, -0.10020501f, 0.11519700f, 0.04909362f, 
    -0.04167583f, 0.04702126f, -0.08090737f, 0.07885168f, -0.10919952f, 0.17849310f, 0.12040147f, 0.17409885f, 
    -0.05703726f, 0.20258442f, -0.01764745f, 0.02852502f, 0.01010368f, 0.07617664f, 0.06068769f, -0.21491566f, 
    -0.24543341f, 0.12744063f, 0.25658739f, 0.16848755f, -0.00469851f, 0.03154964f, 0.05492328f, -0.00744804f, 
    0.03465149f, -0.01826508f, 0.18482682f, 0.01190051f, -0.25327694f, 0.09601378f, 0.10264996f, 0.08463889f, 
    -0.03925078f, 0.07335891f, 0.06264195f, -0.02288472f, 0.05358501f, 0.12908527f, 0.14399306f, 0.14747919f, 
    0.10342348f, -0.11579542f, 0.05799980f, -0.16902365f, 0.00739704f, -0.08841796f, -0.05807732f, 0.14024688f, 
    -0.12912226f, 0.19708520f, 0.15429519f, -0.06709960f, -0.23572329f, -0.02170279f, -0.20049991f, 0.12513766f, 
    -0.09466610f, -0.06037010f, 0.15987286f, -0.20015274f, -0.15379849f, 0.05891207f, -0.03310718f, 0.12402641f, 
    -0.07820977f, -0.04148879f, 0.08347497f, -0.00092820f, 0.03684366f, 0.08845993f, -0.01895894f, -0.14022562f, 
    0.10050825f, -0.11043041f, -0.01479361f, -0.07210274f, 0.00814456f, -0.27021879f, 0.04342079f, -0.02940824f, 
    0.09129056f, 0.00873585f, -0.08047936f, -0.07523292f, 0.07755125f, 0.14858094f, -0.05323328f, -0.00190633f, 
    0.00452873f, 0.13095777f, 0.02021324f, 0.29033551f, 0.06436796f, 0.07919072f, 0.02351418f, 0.06166933f, 
    -0.07273950f, -0.12569845f, -0.14670619f, -0.04825959f, -0.10621820f, -0.14547423f, -0.03481752f, -0.10050740f, 
    0.09983592f, 0.01379991f, -0.12114531f, 0.07676952f, -0.03918816f, 0.05111409f, 0.08606318f, 0.02207839f, 
    0.17992871f, -0.07050073f, 0.03617590f, -0.14502925f, -0.07053063f, 0.10423921f, 0.00510910f, 0.14522888f, 
    -0.05364989f, -0.07936326f, -0.12757967f, -0.10247935f, -0.06998962f, 0.12339687f, -0.00259873f, 0.07856409f, 
    0.04507324f, 0.06363662f, -0.05898750f, 0.13377139f, 0.05809567f, 0.07762909f, 0.04410621f, 0.04262689f, 
    -0.00176746f, 0.06781086f, 0.10553133f, 0.02394824f, -0.00688924f, 0.07717010f, 0.07301312f, 0.05854676f, 
    -0.07449991f, -0.28795773f, -0.14134930f, -0.14097042f, -0.00947244f, 0.15153001f, -0.06533140f, 0.01419804f, 
    0.04944103f, 0.02521159f, 0.08406925f, -0.02074614f, -0.00013284f, 0.21137589f, -0.02400215f, -0.01069350f, 
    0.12802948f, 0.05154087f, 0.16773018f, 0.05037414f, 0.15683421f, 0.15431516f, -0.05349381f, -0.03555193f, 
    -0.04964618f, 0.08226124f, 0.10279863f, 0.03479423f, -0.08197380f, -0.12795050f, 0.17125817f, 0.22366592f, 
    -0.05637677f, 0.04256363f, 0.01988454f, 0.28653821f, -0.03208479f, -0.00377268f, 0.11927492f, 0.18004051f, 
    0.14689787f, 0.20249726f, 0.01152589f, -0.00669880f, 0.01975589f, 0.00546918f, 0.13107558f, 0.05035055f, 
    -0.01514732f, 0.27876082f, -0.06186383f, 0.12405941f, 0.08976801f, -0.02078586f, -0.02238557f, 0.04093014f, 
    -0.03535466f, 0.06429255f, -0.05244047f, 0.09284744f, 0.12769130f, 0.12804981f, -0.03349813f, -0.03938853f, 
    -0.13250080f, 0.05101660f, 0.14968047f, -0.09910334f, 0.08810993f, 0.02260833f, 0.14315796f, 0.12963466f, 
    0.22484483f, -0.29759318f, 0.08724485f, 0.06314837f, -0.27887198f, 0.02390070f, 0.09255758f, 0.03816278f, 
    -0.02539954f, -0.01960895f, -0.04552113f, 0.04102485f, -0.10986947f, 0.11128148f, 0.04041502f, -0.10043493f, 
    0.10302769f, 0.14348863f, -0.25609314f, 0.18224211f, -0.06351890f, -0.05281896f, -0.01715802f, 0.03792806f, 
    0.02608839f, -0.05083248f, 0.24708883f, -0.08447357f, 0.17371121f, 0.14941730f, -0.09699412f, 0.17109025f, 
    0.01048447f, -0.02287066f, 0.11975610f, -0.01817400f, 0.13314918f, 0.01196462f, -0.12515308f, 0.05877686f, 
    0.20501204f, 0.06266523f, 0.04230694f, 0.19821164f, 0.02098026f, 0.03469739f, 0.01349929f, 0.03349145f, 
    0.08870971f, -0.00913171f, -0.09448827f, -0.02781642f, -0.07413463f, 0.11549482f, -0.04825624f, -0.16755360f, 
    -0.18206684f, -0.04686037f, -0.05293835f, -0.06224039f, -0.15006183f, -0.00426767f, 0.03183138f, 0.05708308f, 
    -0.03800326f, 0.05286128f, 0.10145348f, 0.05703999f, 0.09246803f, 0.05194984f, -0.00617786f, 0.05835647f, 
    -0.03089071f, -0.15870680f, -0.24710964f, -0.19361638f, 0.13597167f, 0.03629538f, -0.00484435f, 0.10133842f, 
    -0.03982038f, 0.11434387f, 0.01595881f, -0.03043175f, 0.11291444f, 0.04891755f, 0.06536392f, -0.15746561f, 
    0.28790107f, 0.15768409f, -0.16668794f, 0.07792641f, 0.03305758f, 0.09013562f, -0.07884151f, -0.00295527f, 
    -0.11956017f, -0.12925796f, 0.02082592f, 0.24222457f, 0.23088580f, 0.13598928f, 0.09522539f, 0.15506768f, 
    -0.01196834f, 0.01709582f, 0.00846350f, 0.05241857f, 0.03907386f, -0.01139524f, -0.08076221f, -0.13317482f, 
    -0.08095764f, -0.06557386f, -0.00201122f, 0.08490597f, -0.13897225f, -0.05658771f, -0.00157812f, 0.04914059f, 
    0.12642860f, 0.31760380f, 0.13405281f, 0.25064602f, 0.06801217f, -0.09492552f, 0.20325834f, -0.14351694f, 
    0.12798874f, -0.06762052f, -0.08521599f, 0.00833886f, -0.04596508f, -0.23872936f, 0.06286002f, -0.08563004f, 
    -0.02420415f, -0.11466247f, 0.16405766f, -0.12433236f, -0.04412453f, 0.00093852f, 0.00009850f, 0.10541996f, 
    0.03536603f, 0.03332801f, -0.04277025f, -0.00049037f, 0.20661204f, -0.18705992f, -0.14948112f, 0.18838437f, 
    0.08206256f, 0.05302614f, -0.05180406f, -0.04665432f, -0.03349691f, -0.02574953f, -0.09854950f, -0.07011209f, 
    -0.03307218f, 0.01310798f, -0.04369151f, 0.04406554f, 0.07938102f, 0.14508125f, 0.05384118f, -0.05285646f, 
    -0.07167280f, 0.00950727f, -0.02881094f, 0.16751732f, -0.23030727f, -0.03081983f, 0.10175846f, 0.14950505f, 
    0.03577948f, -0.03814880f, 0.22437981f, 0.15816805f, 0.04924872f, 0.16555397f, 0.11479098f, 0.12793711f, 
    0.02979785f, 0.05073207f, -0.06660422f, -0.01715481f, 0.04058450f, -0.02550150f, -0.00098198f, -0.07501759f, 
    0.13956413f, 0.17306650f, 0.00688285f, -0.04229181f, -0.03197800f, -0.19280927f, -0.11909528f, -0.05610294f, 
    0.08506929f, 0.03249853f, 0.04781884f, 0.08773642f, 0.02036261f, -0.05832198f, -0.00045505f, 0.05329980f, 
    -0.05865349f, -0.15612903f, -0.08188479f, 0.02944574f, 0.01699594f, 0.00936433f, 0.03161555f, -0.16246082f, 
    -0.00710102f, 0.00351808f, -0.08094630f, -0.07309549f, -0.04273215f, 0.00873204f, -0.08739918f, 0.13719781f, 
    0.04743618f, 0.07918063f, -0.08075657f, 0.07410447f, -0.00078620f, 0.05145374f, -0.00852017f, -0.12080107f, 
    0.32022861f, 0.07350600f, -0.06912419f, -0.00901170f, -0.05735365f, 0.07033712f, 0.10014661f, 0.06934955f, 
    0.10322131f, 0.12259471f, 0.05019503f, 0.03125677f, -0.03695411f, 0.09755621f, 0.00893114f, -0.01333327f, 
    0.03509030f, 0.00837864f, -0.05852309f, -0.01851378f, -0.00575611f, 0.04470185f, -0.00484807f, 0.03027427f, 
    -0.13658404f, -0.00600910f, 0.03463897f, 0.00022029f, 0.18940668f, -0.02005474f, -0.15131795f, 0.05559409f, 
    -0.11490677f, -0.09899022f, 0.02985027f, 0.23604660f, -0.00876961f, 0.26515767f, 0.07482921f, -0.04758668f, 
    -0.00581522f, 0.01953937f, -0.06119394f, 0.01396808f, 0.05959375f, 0.05287363f, -0.04516521f, -0.13213037f, 
    -0.22667307f, -0.19613579f, 0.23892850f, 0.01532534f, 0.00659968f, -0.02116395f, 0.07363936f, -0.05639509f, 
    0.00443637f, 0.14791198f, -0.01386114f, 0.18192689f, -0.05688952f, -0.06236466f, -0.03659277f, -0.09215400f, 
    0.01244373f, 0.01831785f, 0.09290555f, 0.17796253f, -0.03965827f, 0.02366683f, 0.00351790f, 0.04683007f, 
    -0.00268511f, -0.21494509f, 0.12292387f, -0.28273317f, 0.11095895f, -0.01259570f, 0.00553194f, 0.03551940f, 
    -0.01749314f, -0.12112503f, -0.02043040f, -0.07977511f, -0.03109407f, 0.10872943f, 0.04517927f, 0.03427817f, 
    -0.07936343f, 0.05692941f, -0.06564670f, -0.10311463f, 0.10915711f, -0.07553222f, 0.06418420f, 0.01168934f, 
    -0.36413974f, 0.07863545f, 0.19102401f, 0.03765072f, 0.07462485f, -0.05859150f, -0.06741168f, 0.03528739f, 
    0.11489039f, -0.06744725f, -0.14578207f, 0.10116933f, 0.78832287f, 0.10433587f, -0.05159971f, -0.04646003f, 
    -0.03118285f, 0.17106581f, -0.01178013f, 0.20894395f, 0.04716806f, 0.10110420f, -0.03750710f, 0.15066698f, 
    -0.05255490f, -0.14999954f, 0.16940737f, -0.10710343f, 0.02182969f, 0.14230210f, 0.23428136f, 0.18667802f, 
    -0.01271005f, 0.01905475f, -0.07433353f, -0.02515356f, 0.19296268f, 0.22999123f, 0.02823101f, -0.08566917f, 
    0.12816885f, 0.13921277f, 0.09363843f, -0.02407634f, -0.00208889f, 0.00808811f, 0.14371309f, 0.04489329f, 
    0.02889765f, -0.02164029f, -0.02951267f, -0.00321597f, -0.02091310f, 0.02048528f, 0.01613505f, -0.00871212f, 
    -0.03473937f, 0.04115700f, 0.00103493f, -0.03903631f, -0.03052436f, -0.03851842f, -0.04202067f, 0.01812573f, 
    -0.01011526f, 0.00196082f, -0.03125832f, 0.02816030f, 0.02297369f, -0.03334298f, 0.01186823f, 0.02471007f, 
    -0.02863012f, 0.02479856f, 0.00141115f, 0.01023632f, -0.02144389f, 0.02354505f, -0.00315252f, -0.01863045f, 
    -0.01236254f, -0.01726018f, 0.00151375f, 0.01735576f, -0.01278238f, -0.00110214f, 0.00499074f, -0.03968588f, 
    -0.04052181f, 0.02851993f, 0.02033666f, -0.02921703f, -0.03464271f, -0.02557364f, -0.00080772f, 0.00804933f, 
    0.02245716f, -0.02607031f, 0.01210277f, -0.00449475f, 0.01040237f, 0.01327160f, -0.01671194f, -0.02934914f, 
    -0.03168945f, -0.04120729f, 0.02464260f, -0.00819138f, -0.03985341f, 0.02431533f, 0.02381047f, -0.03065258f, 
    -0.00040420f, -0.01329427f, 0.03596682f, -0.02989656f, 0.02789075f, 0.01827715f, -0.01872913f, -0.01310276f, 
    -0.02407516f, -0.01364803f, 0.02927739f, 0.00949494f, 0.02116642f, 0.01945082f, -0.03182735f, 0.01985715f, 
    -0.02819511f, 0.01982250f, -0.01428404f, -0.01416637f, 0.02358222f, -0.01950926f, -0.03190029f, 0.01795015f, 
    0.02910694f, 0.02547282f, -0.03896851f, -0.02852983f, 0.01543539f, 0.00808896f, 0.00212531f, -0.00915986f, 
    0.00388502f, -0.00965075f, 0.01638038f, -0.00978630f, -0.03038395f, 0.01166577f, 0.02183207f, 0.01877075f, 
    -0.00553333f, 0.01525720f, 0.02092305f, 0.00072448f, -0.02061002f, 0.02736741f, 0.02909773f, -0.01471969f, 
    0.04039024f, 0.02197343f, 0.00368820f, -0.00804160f, -0.03601799f, 0.01106119f, -0.02942133f, 0.01195672f, 
    0.02254433f, -0.01609191f, 0.00946285f, 0.01254199f, -0.01820158f, -0.02719226f, -0.00366721f, -0.01432698f, 
    0.02253493f, -0.03255685f, -0.01675744f, -0.01324222f, -0.00786531f, -0.00538991f, 0.02104517f, -0.00306950f, 
    -0.02641026f, 0.00032541f, -0.01979802f, -0.00254319f, 0.00697319f, 0.02626682f, 0.02849458f, -0.03026588f, 
    -0.03539770f, -0.04027945f, -0.03804970f, 0.01837092f, 0.02179083f, 0.01902930f, -0.02852122f, -0.02528192f, 
    0.01204586f, -0.03408504f, -0.01528903f, 0.02943286f, 0.02090369f, 0.02156729f, 0.00571582f, -0.01199629f, 
    0.00401290f, 0.00918799f, -0.01164301f, -0.02562764f, 0.01535720f, 0.02670142f, -0.03081001f, 0.00937319f, 
    -0.02044474f, -0.00705147f, -0.03873855f, -0.00520330f, -0.00182177f, 0.02296587f, -0.01480655f, -0.03028533f, 
    -0.03761466f, -0.02512199f, -0.00405732f, -0.01042354f, -0.04098884f, -0.01420057f, -0.01472602f, -0.01208197f, 
    0.00557201f, 0.01452535f, -0.03476413f, 0.00574868f, 0.01258221f, 0.02563616f, -0.00236152f, -0.02227870f, 
    0.01383551f, -0.02506861f, -0.03348301f, 0.01114487f, -0.00006909f, -0.02162859f, -0.03272161f, -0.01210437f, 
    0.00231482f, -0.02549186f, 0.02316117f, -0.01654531f, 0.00709763f, 0.00346208f, -0.02227053f, -0.03703841f, 
    -0.01989110f, 0.00624372f, -0.00893922f, 0.02529271f, -0.01582498f, 0.02105497f, 0.01835529f, -0.03098154f, 
    -0.00857962f, 0.00778437f, -0.00397622f, -0.03237756f, -0.01740004f, 0.02978259f, -0.00078438f, -0.01482932f, 
    0.02750707f, 0.01124561f, 0.02980201f, -0.03604586f, -0.01484030f, -0.02950005f, -0.00134831f, 0.00423497f, 
    -0.00010692f, 0.02937149f, -0.03911880f, -0.01487167f, -0.00079751f, -0.01310674f, 0.02952719f, -0.01822661f, 
    -0.03083923f, 0.00415275f, -0.01272869f, -0.00969626f, -0.02366275f, -0.00173654f, 0.01124708f, -0.00598380f, 
    0.00874440f, 0.00877451f, -0.02118081f, -0.03213178f, 0.00447085f, 0.00096633f, -0.04013523f, -0.01239394f, 
    0.02222427f, -0.01968766f, -0.03391173f, -0.01134084f, -0.03829900f, -0.00875177f, 0.02972988f, 0.00040413f, 
    0.00484436f, 0.02808484f, -0.00876282f, 0.01917039f, 0.00842730f, -0.02758333f, 0.01606887f, -0.02767415f, 
    -0.00027894f, -0.01190435f, -0.03572754f, 0.01921047f, -0.02952737f, 0.01809444f, -0.00158139f, -0.01028362f, 
    0.02490838f, -0.01925139f, 0.01100510f, 0.00385890f, -0.03797588f, 0.00530491f, -0.03973879f, 0.00189367f, 
    -0.02320258f, -0.00945669f, -0.01120473f, -0.03318697f, -0.02186056f, -0.01759939f, -0.03429009f, 0.00954865f, 
    0.02300107f, 0.01938623f, 0.02416935f, 0.00394997f, 0.01362775f, 0.02516552f, 0.01607804f, -0.00873725f, 
    -0.03038864f, -0.00989637f, -0.01201981f, -0.01268701f, 0.01096129f, 0.01074958f, 0.01400307f, -0.01370703f, 
    0.02109509f, -0.02028725f, 0.02029925f, 0.01821103f, -0.04043191f, -0.01041603f, 0.00626139f, 0.02017906f, 
    0.01431977f, 0.02532195f, 0.01538283f, 0.01506417f, 0.00481477f, -0.00338768f, -0.03744339f, -0.02889854f, 
    -0.02887901f, -0.01922844f, -0.00631802f, -0.01747179f, 0.00793434f, 0.02346809f, 0.00029885f, 0.01171624f, 
    0.00151840f, -0.00244728f, -0.01433177f, -0.00127002f, -0.00908025f, 0.02903744f, -0.03345625f, -0.03281901f, 
    0.00420660f, 0.02857563f, 0.01639817f, -0.03281082f, -0.01617500f, -0.03986747f, 0.02322562f, -0.03831428f, 
    -0.01405017f, -0.04125090f, -0.03148641f, 0.00384103f, -0.00781248f, -0.00644411f, 0.02571581f, 0.03396372f, 
    0.01965875f, 0.01351780f, -0.00039567f, -0.03856919f, -0.01402091f, -0.00547212f, -0.03236446f, -0.02773151f, 
    -0.00092284f, 0.00136509f, 0.02543561f, -0.03564961f, 0.03487261f, 0.01559125f, 0.00042162f, 0.01530199f, 
    0.01338816f, 0.00524960f, 0.01191149f, -0.02232293f, -0.00127579f, 0.01227560f, -0.00440993f, 0.02599935f, 
    -0.01484808f, 0.02476948f, -0.01348285f, -0.00624720f, -0.03665437f, -0.02762815f, -0.02412981f, -0.02025547f, 
    0.00229112f, -0.00103151f, -0.03083994f, -0.00177648f, -0.02569291f, -0.00375517f, 0.00578279f, 0.02507366f, 
    0.02886052f, -0.03390077f, 0.02518458f, -0.03459196f, -0.00491532f, -0.02437123f, -0.03253331f, -0.00906243f, 
    0.00186128f, -0.02848188f, -0.01431631f, -0.02859894f, 0.02490092f, -0.03297677f, -0.01238961f, 0.00201310f, 
    -0.00504296f, -0.02247509f, -0.03322032f, 0.00376496f, -0.03395965f, -0.03558857f, -0.00882390f, 0.02489391f, 
    -0.01522079f, 0.03538834f, -0.00106496f, 0.02771826f, 0.01038453f, -0.04163718f, -0.00266359f, -0.01805685f, 
    0.00007943f, -0.00943924f, 0.02341629f, -0.02163051f, 0.02602422f, 0.00004614f, -0.01001752f, 0.00617661f, 
    -0.03719035f, -0.01599634f, 0.02467515f, 0.01563374f, 0.00041935f, -0.01484299f, 0.01594256f, -0.01254392f, 
    -0.01565544f, -0.01937941f, 0.00949313f, -0.02748898f, -0.00130996f, -0.01259369f, -0.01535174f, 0.00474237f, 
    -0.00558904f, -0.01172808f, -0.02152761f, 0.01347817f, 0.01213664f, -0.03536772f, 0.00956269f, -0.03960801f, 
    -0.03435418f, -0.02579072f, -0.01929571f, 0.01391144f, -0.00676666f, -0.03111369f, 0.02404343f, -0.03175458f, 
    -0.00057306f, -0.03501699f, 0.00034921f, -0.00656515f, -0.00348807f, -0.01890816f, -0.00619399f, -0.03456868f, 
    -0.04020151f, 0.02916326f, -0.04005899f, -0.04185939f, -0.03051713f, 0.02128004f, 0.01162024f, -0.00946094f, 
    -0.01966160f, 0.00104996f, -0.03468657f, -0.00453307f, -0.02173715f, -0.00383821f, 0.00973623f, -0.02863655f, 
    0.00938908f, -0.00489713f, -0.02630002f, -0.01661447f, -0.03608687f, 0.01432746f, -0.00918266f, -0.02459577f, 
    -0.00387582f, -0.01100639f, -0.01977353f, -0.02981379f, -0.02240975f, 0.00741347f, -0.02224458f, -0.03301854f, 
    -0.00508455f, 0.02995599f, -0.01436681f, -0.02434748f, 0.01819260f, -0.03162605f, -0.03240772f, 0.00811599f, 
    0.02851511f, -0.01748534f, 0.00570476f, -0.00159712f, 0.02220096f, -0.01170884f, 0.02804178f, -0.00287969f, 
    0.00743433f, -0.02473363f, -0.00939771f, -0.01552724f, -0.02691808f, -0.01583262f, -0.03203227f, 0.01669034f, 
    0.01733565f, -0.03302361f, -0.03144952f, -0.01308491f, 0.00760900f, 0.00335323f, 0.00980556f, -0.02747525f, 
    -0.03866607f, -0.03588779f, -0.01017231f, -0.00645891f, -0.00168406f, -0.03780270f, -0.01135409f, -0.02452506f, 
    -0.00755460f, -0.03048366f, 0.02154730f, -0.00192904f, 0.02357705f, 0.01684679f, -0.02681947f, 0.00609444f, 
    -0.01864533f, -0.03547204f, 0.01072044f, 0.02251023f, 0.00713836f, -0.03025184f, 0.01317958f, 0.02202271f, 
    0.01257536f, -0.00762776f, -0.03508264f, 0.02429332f, -0.01481885f, -0.03813296f, -0.03432777f, 0.02965921f, 
    -0.02513373f, -0.03570484f, -0.03187998f, -0.00670852f, -0.01447117f, -0.04011425f, 0.02999695f, 0.00175637f, 
    0.01431991f, 0.03896945f, -0.00245367f, 0.02907689f, -0.03545937f, 0.00778933f, 0.00332785f, 0.02530089f, 
    -0.00508547f, -0.00786821f, -0.01028896f, -0.04172041f, -0.00499862f, 0.00958898f, 0.01923436f, 0.02664785f, 
    -0.01028998f, 0.01639017f, 0.02551227f, 0.01415096f, -0.01296535f, -0.00311299f, -0.02624878f, -0.00749591f, 
    -0.03256050f, 0.01706910f, -0.02194096f, 0.00064607f, -0.00127269f, 0.03001384f, 0.02952397f, -0.03473297f, 
    0.01556313f, -0.00370619f, -0.03582025f, -0.01511565f, -0.03324092f, 0.00542277f, 0.02892320f, 0.00406609f, 
    0.00149322f, 0.02679984f, 0.01273007f, -0.02596914f, 0.01683478f, -0.00523087f, 0.02708678f, -0.02447951f, 
    0.02369317f, -0.01798720f, -0.01553203f, -0.00608572f, 0.02736128f, 0.03719342f, 0.02499641f, 0.02821580f, 
    -0.03954667f, -0.04117652f, -0.00739447f, 0.02966732f, -0.00470570f, -0.01424409f, -0.00485767f, 0.00430365f, 
    -0.03427148f, -0.00946793f, -0.02984910f, -0.02678278f, -0.03603935f, -0.00260885f, 0.00790069f, 0.00779226f, 
    -0.01305532f, -0.02100381f, 0.00288363f, 0.00516624f, -0.01137098f, -0.04157906f, 0.02681596f, 0.03348054f, 
    -0.03511934f, 0.00453423f, -0.04082471f, -0.02613789f, -0.00199272f, 0.00274058f, -0.04099768f, -0.03339181f, 
    -0.03677768f, 0.02519059f, -0.00665906f, 0.02835905f, -0.02890160f, -0.03869004f, 0.00095022f, -0.01022944f, 
    0.02611354f, 0.00235497f, 0.02943301f, -0.02351972f, -0.02350278f, -0.00413116f, 0.02351998f, 0.00747114f, 
    -0.02165939f, -0.03997953f, -0.01424335f, 0.00711132f, 0.02111032f, -0.01930052f, -0.01168131f, -0.03735384f, 
    -0.03203633f, 0.02077513f, -0.01150743f, -0.02446452f, 0.01633435f, 0.02318334f, 0.01037534f, 0.02555232f, 
    -0.03202670f, 0.02556497f, -0.02462376f, 0.01598040f, 0.00968986f, -0.00422513f, 0.00059885f, -0.00280717f, 
    0.02859194f, -0.02145902f, 0.01571020f, 0.02336694f, -0.03907571f, 0.02197442f, -0.00043154f, -0.01084322f, 
    -0.03055017f, -0.00904157f, -0.03090494f, 0.00920605f, -0.02853648f, 0.03873752f, 0.00442582f, -0.00799357f, 
    -0.00286913f, -0.02307555f, -0.03131392f, -0.01133545f, 0.02561330f, -0.03119905f, -0.03938089f, -0.00203579f, 
    -0.03136395f, -0.02482639f, 0.02656272f, -0.00028862f, -0.03645816f, 0.00454656f, 0.01894506f, 0.01167942f, 
    -0.00526254f, 0.00654386f, -0.02643684f, 0.01277080f, 0.01803591f, 0.00103380f, -0.02239963f, -0.02372592f, 
    -0.01370893f, 0.00694054f, -0.00968626f, 0.02913782f, 0.00961598f, -0.02124486f, -0.03421716f, -0.01070699f, 
    -0.02546441f, -0.00858314f, 0.00207512f, -0.03614163f, 0.00353376f, -0.03121183f, -0.01015879f, -0.00540415f, 
    -0.02669198f, -0.14796221f, -0.27534977f, -0.34413046f, 0.09693631f, 0.07607349f, 0.15158278f, 0.04382818f, 
    0.07329866f, -0.15906769f, 0.13214676f, 0.06338289f, 0.05283257f, 0.05204821f, -0.05659975f, 0.19812270f, 
    -0.06638020f, -0.01689879f, -0.01824454f, 0.11287483f, 0.05216583f, -0.02730032f, 0.03696069f, 0.01430037f, 
    -0.02234303f, -0.05881339f, 0.06441431f, -0.15428689f, -0.06259239f, 0.04724477f, 0.02597089f, 0.09159809f, 
    -0.00292114f, 0.03079393f, 0.09794010f, 0.10957205f, -0.15574443f, 0.12921858f, 0.04615441f, -0.41378462f, 
    0.07576607f, 0.00049409f, -0.03194250f, 0.02276523f, 0.09398276f, -0.00467767f, 0.07556651f, 0.03511302f, 
    0.13705224f, -0.05055171f, -0.13255103f, 0.16736069f, -0.02719977f, -0.07955990f, -0.06493556f, 0.02351824f, 
    0.05488062f, 0.13621469f, 0.01483302f, 0.02149168f, -0.02088269f, 0.19097416f, -0.01510921f, -0.02067732f, 
    0.01277644f, 0.11705732f, 0.03360114f, -0.00698087f, -0.05882466f, -0.02072799f, 0.19550870f, 0.10243621f, 
    0.24042289f, 0.17731515f, -0.06891487f, 0.04407944f, 0.01577688f, -0.11199995f, -0.01407918f, 0.15590392f, 
    0.00842702f, 0.04031593f, -0.03279924f, 0.01927364f, 0.24511559f, 0.05513438f, 0.07414295f, 0.24456395f, 
    0.03008516f, 0.11315019f, 0.02771919f, -0.07726430f, 0.04349453f, 0.04958187f, -0.00120919f, 0.08010501f, 
    0.07899185f, -0.13542931f, 0.04733925f, -0.10739142f, -0.04739642f, -0.01455857f, -0.07770398f, 0.09794409f, 
    0.00828994f, 0.00441354f, 0.02119686f, 0.00553431f, -0.29191956f, -0.14422278f, -0.07403869f, -0.24814515f, 
    0.08278093f, 0.03938301f, 0.04753036f, -0.01213953f, -0.00301374f, -0.00125155f, 0.03796381f, -0.00365993f, 
    -0.11907764f, -0.01195592f, 0.01839202f, -0.11508455f, 0.02166921f, 0.00704962f, 0.07744690f, -0.05636477f, 
    -0.02299597f, 0.07905690f, 0.04577515f, -0.07880785f, 0.14579730f, 0.10222407f, 0.00337012f, 0.02951429f, 
    0.02937376f, 0.00553503f, -0.14549305f, -0.01698823f, -0.02175180f, -0.16885540f, 0.01191028f, 0.05947190f, 
    -0.07250091f, 0.09992713f, 0.13421078f, -0.07496978f, -0.01968981f, 0.11029859f, 0.08645783f, 0.00501570f, 
    0.03820622f, 0.01642264f, 0.00336957f, 0.09576043f, 0.20403722f, -0.16853458f, 0.05237968f, 0.17083870f, 
    -0.06515261f, -0.07452641f, 0.01987373f, 0.05440823f, 0.01706694f, 0.03730530f, 0.01625312f, 0.09553198f, 
    0.13010015f, -0.06775291f, -0.19436575f, 0.11429652f, 0.08202214f, 0.09392302f, -0.06077353f, 0.08938933f, 
    0.07836667f, 0.09521444f, -0.00515126f, 0.00521014f, -0.16332050f, 0.12545122f, 0.10442831f, 0.09811012f, 
    0.11935873f, 0.02299742f, 0.00281482f, -0.06592666f, 0.11896973f, 0.05951755f, 0.08203697f, 0.17785291f, 
    0.03621140f, -0.03620842f, -0.06167695f, -0.17358162f, -0.04263666f, -0.01219135f, 0.04332242f, 0.01110265f, 
    0.01173492f, -0.01812579f, 0.04992741f, 0.00282924f, -0.11821463f, -0.12608235f, -0.13129085f, -0.06430710f, 
    -0.01333092f, -0.01487009f, -0.03776726f, 0.02930065f, 0.01765798f, -0.11783556f, -0.05514195f, 0.02475369f, 
    0.12342836f, -0.24063773f, -0.08053270f, -0.01591374f, -0.00393170f, 0.00775662f, 0.01522993f, -0.18112354f, 
    0.11981021f, 0.08667358f, 0.01784076f, 0.01577439f, 0.02133631f, 0.15019436f, -0.05070162f, 0.01481238f, 
    0.02990943f, -0.02628252f, 0.00499788f, 0.04880721f, 0.04813505f, 0.04649837f, -0.01979614f, -0.00225715f, 
    0.00372176f, 0.02337979f, 0.05180898f, -0.12838109f, 0.08277284f, 0.10834706f, -0.07772275f, -0.00500661f, 
    -0.02963464f, 0.04980595f, 0.02734904f, 0.01589892f, -0.15533711f, 0.14125344f, 0.05443641f, 0.08967319f, 
    0.05838686f, 0.02331369f, 0.02217563f, -0.02797693f, -0.05389825f, 0.04035231f, -0.03680761f, 0.09032544f, 
    0.21683922f, 0.16124792f, -0.01572866f, -0.10301588f, -0.08936122f, -0.08025494f, -0.02176091f, 0.11978721f, 
    0.08394638f, 0.09950645f, 0.04312611f, 0.04779414f, 0.16736415f, 0.26828641f, -0.08707233f, 0.01629378f, 
    0.04034999f, 0.05250036f, 0.06387439f, -0.03737991f, -0.00424383f, 0.10140819f, 0.11733995f, 0.02996442f, 
    -0.09794464f, 0.03788063f, 0.10859258f, 0.10260584f, 0.04220917f, -0.01868004f, 0.10394040f, 0.04865653f, 
    -0.07110377f, 0.01390376f, 0.02875182f, -0.00060842f, -0.09228198f, 0.17699535f, 0.09866750f, 0.17109567f, 
    0.04441059f, 0.04732341f, 0.11968541f, 0.08904535f, 0.10333896f, 0.03728628f, 0.03858448f, 0.02623393f, 
    -0.03278731f, 0.06462222f, -0.00466151f, -0.09666771f, 0.02203945f, 0.02124185f, 0.04039901f, -0.03920408f, 
    0.03173036f, 0.11476265f, 0.04631532f, -0.04272241f, 0.11492650f, 0.01642774f, -0.03593532f, -0.07029231f, 
    0.07936226f, -0.07188591f, -0.03446583f, 0.02490670f, -0.00144595f, 0.01442710f, 0.04578671f, -0.05827245f, 
    0.02687089f, -0.17168126f, -0.13532117f, 0.09534985f, -0.04201131f, -0.03349699f, 0.07081646f, -0.06482225f, 
    0.11055174f, -0.04210279f, 0.18318520f, 0.04587764f, 0.32623580f, -0.13209699f, 0.00652536f, -0.04177910f, 
    0.02285418f, -0.00525631f, 0.03464752f, -0.07185107f, 0.04019300f, 0.11400591f, -0.07770339f, 0.12265985f, 
    -0.08716895f, -0.00087193f, -0.02105163f, 0.02673183f, 0.05377898f, -0.04823030f, -0.02572115f, 0.04836714f, 
    0.03991972f, -0.13696128f, 0.08605035f, 0.09482609f, -0.05020797f, 0.06845354f, 0.09904808f, -0.10837091f, 
    0.01405812f, 0.03023677f, 0.01176007f, 0.10988783f, 0.02271998f, 0.05302465f, -0.07429915f, -0.03283523f, 
    -0.08231632f, 0.10143232f, -0.10939045f, -0.14588022f, 0.03766870f, -0.08009332f, 0.01709819f, 0.00262512f, 
    0.06931099f, 0.13862403f, -0.07068290f, -0.02618486f, 0.21134008f, -0.03784621f, 0.02805354f, -0.01566705f, 
    0.01103371f, 0.08624653f, 0.09639425f, 0.12734759f, 0.06956223f, 0.00666375f, 0.04859955f, 0.00295098f, 
    -0.17295961f, -0.09470088f, 0.34707481f, -0.06023197f, 0.00774498f, -0.02280344f, -0.14006855f, 0.01578717f, 
    0.11790694f, -0.11210613f, -0.04165764f, -0.01668626f, -0.39338493f, -0.11346378f, 0.14826879f, -0.11525016f, 
    -0.00937973f, 0.02321361f, 0.02206102f, -0.06028904f, 0.04454157f, 0.02390495f, -0.01672504f, -0.04416052f, 
    -0.19408379f, 0.13290192f, -0.07598972f, -0.14002898f, -0.03253312f, -0.06920486f, -0.00274691f, 0.02441565f, 
    0.02326672f, 0.12906687f, 0.02953867f, -0.07922208f, -0.05358835f, -0.01342313f, 0.02352900f, -0.10868114f, 
    0.02612141f, -0.05283152f, 0.05198495f, -0.00073166f, 0.10609791f, 0.05899817f, -0.03960270f, -0.05122739f, 
    0.24983433f, 0.08946864f, -0.22437438f, -0.01527930f, -0.07928246f, 0.10648207f, -0.02883545f, -0.06853610f, 
    0.11585141f, 0.11177237f, 0.04649322f, 0.00468323f, -0.29004273f, -0.06741758f, 0.10172071f, -0.04987275f, 
    0.12513435f, 0.00477583f, -0.03954442f, 0.03728028f, -0.02160212f, -0.02217560f, -0.00020884f, 0.14467785f, 
    -0.15464194f, -0.15578330f, 0.10690283f, -0.16618004f, -0.11788998f, 0.01543761f, -0.01028251f, -0.07902991f, 
    0.04223048f, -0.00365252f, 0.01431344f, -0.00353498f, -0.45487571f, 0.18267755f, -0.11434733f, -0.19593854f, 
    0.03243013f, -0.07047537f, -0.01500537f, 0.08662988f, 0.05891052f, 0.02114206f, -0.01174041f, -0.06738001f, 
    0.05470422f, -0.05101078f, 0.22166304f, -0.19077696f, 0.03934848f, -0.17394663f, -0.03311275f, -0.10456967f, 
    0.02229878f, 0.02462425f, -0.02634566f, -0.01665388f, -0.11800417f, -0.03762523f, -0.20692742f, 0.33108377f, 
    0.00550791f, -0.05247127f, 0.13334560f, -0.00628084f, 0.03346029f, 0.02606304f, 0.02352079f, 0.05949117f, 
    0.26085159f, -0.22106984f, -0.06698146f, 0.08402502f, 0.03185407f, 0.10103116f, 0.05246767f, -0.03277082f, 
    0.06313542f, 0.04574933f, 0.05082620f, 0.09293527f, 0.01619119f, 0.21104784f, 0.09353314f, -0.05050027f, 
    0.08933082f, 0.09036828f, 0.08134634f, -0.02200091f, 0.04432153f, -0.03491951f, 0.01057503f, 0.06893478f, 
    -0.08999409f, 0.05756534f, -0.12188436f, 0.14526528f, -0.00367066f, 0.06239279f, -0.00011933f, 0.05310923f, 
    0.11425653f, 0.06894562f, 0.05723630f, 0.02462178f, -0.15661518f, 0.09949232f, -0.06736641f, 0.00126987f, 
    0.13967451f, -0.02462268f, 0.04217304f, 0.12373909f, 0.03668341f, 0.01822721f, -0.00087667f, 0.02472218f, 
    -0.01609181f, 0.07131230f, 0.21725705f, -0.15900743f, -0.00597409f, 0.06654792f, -0.05976342f, 0.08112602f, 
    -0.02504301f, 0.07885530f, -0.07008965f, 0.08430115f, 0.13947740f, 0.05254116f, -0.21075691f, 0.01739892f, 
    0.00758052f, -0.02948279f, -0.05959328f, -0.01169324f, -0.10379634f, 0.02633531f, 0.03623430f, -0.01528892f, 
    -0.00933979f, 0.11737385f, 0.01064331f, -0.10030880f, -0.10205223f, 0.01083088f, 0.12205041f, 0.06660567f, 
    -0.05223726f, 0.08031647f, -0.00713920f, 0.11309925f, 0.14392111f, 0.10624279f, -0.00631591f, -0.32139403f, 
    0.04882206f, -0.01684719f, 0.01598954f, 0.05070399f, 0.11723232f, 0.08866169f, -0.03218016f, -0.07456516f, 
    -0.17749000f, 0.03283384f, -0.10674545f, -0.20071642f, 0.10235652f, -0.09054863f, -0.08167626f, 0.01432137f, 
    0.00365311f, -0.01189494f, -0.02596914f, -0.08473970f, -0.16315326f, -0.06225292f, -0.03229432f, -0.09815078f, 
    0.00608057f, 0.07145005f, -0.01704310f, -0.05032718f, 0.06076087f, 0.03470926f, 0.09200376f, -0.08215770f, 
    0.04202072f, 0.10200672f, -0.02040186f, 0.09334567f, 0.00695696f, 0.01093436f, 0.06850043f, -0.06348000f, 
    -0.00196069f, 0.09867694f, 0.06926914f, 0.03677623f, -0.10494844f, -0.09793045f, 0.07375149f, -0.05287427f, 
    -0.10204920f, -0.06946290f, 0.00045510f, 0.02992458f, 0.01843366f, -0.00051296f, -0.02724747f, -0.01662657f, 
    0.27582309f, 0.08797143f, -0.00861656f, 0.00794730f, 0.09737466f, -0.01761130f, -0.03483726f, -0.06347721f, 
    0.04166655f, -0.10427112f, 0.00148332f, 0.06013082f, 0.26858032f, -0.08777950f, 0.08178506f, 0.17760465f, 
    0.06491216f, -0.00635836f, -0.03642312f, -0.02623549f, 0.00966463f, -0.07239057f, 0.02668509f, 0.13508880f, 
    0.27794448f, 0.03252634f, -0.17261884f, 0.09966222f, 0.14698592f, -0.03978022f, 0.02394071f, -0.02867665f, 
    -0.06119522f, 0.12525496f, 0.14689068f, 0.14787248f, -0.16668752f, -0.09815662f, 0.04371470f, -0.12821768f, 
    0.10486693f, 0.05147666f, 0.00789651f, 0.07005195f, 0.10716658f, 0.11332215f, -0.06328367f, 0.08945771f, 
    0.09520254f, -0.05830453f, -0.22437781f, -0.19868129f, -0.05023313f, -0.02611022f, 0.14333765f, -0.06688444f, 
    0.04909921f, 0.06103190f, -0.03934986f, 0.03557345f, -0.08382850f, -0.28320786f, -0.00555329f, 0.04773968f, 
    -0.00324900f, -0.07153495f, -0.01452903f, -0.06352893f, -0.01553072f, 0.05980612f, 0.16829924f, 0.03605613f, 
    0.16252811f, -0.06870402f, 0.01075247f, 0.18225725f, 0.10322422f, 0.01461696f, 0.01707656f, -0.12323976f, 
    -0.00984685f, 0.05025543f, 0.07170901f, 0.07783445f, -0.40317035f, -0.03719473f, 0.20976454f, 0.22505650f, 
    0.01500540f, 0.02839966f, 0.05921050f, 0.08821283f, 0.09278201f, 0.03744203f, -0.07140924f, 0.02454494f, 
    -0.20776230f, 0.21435653f, 0.04472124f, -0.07288960f, 0.04423569f, 0.03863010f, 0.02536999f, -0.01473111f, 
    -0.06441146f, -0.00017608f, 0.08209666f, 0.01173559f, -0.18963830f, -0.03686526f, -0.10790567f, 0.15505876f, 
    0.08807454f, -0.04433069f, -0.03843996f, 0.13033859f, -0.02181356f, 0.03705976f, -0.01667717f, -0.02295242f, 
    -0.06181582f, -0.03003220f, -0.17550285f, 0.09644574f, 0.10251061f, -0.07176380f, 0.03053343f, 0.10797417f, 
    0.09654091f, -0.04687949f, 0.03278512f, -0.03476630f, 0.10005926f, 0.14407036f, 0.24463412f, -0.09274006f, 
    -0.03978977f, 0.02725055f, -0.04759816f, 0.08120538f, -0.05266238f, 0.01947215f, 0.02401337f, 0.01276713f, 
    -0.30872488f, 0.02059800f, -0.25657868f, 0.07486693f, 0.06837602f, 0.00227823f, 0.06309836f, 0.10515096f, 
    -0.01891112f, -0.08310242f, -0.05040096f, -0.04364347f, -0.04997467f, -0.01099911f, 0.04703742f, -0.34920594f, 
    -0.05962496f, -0.01189110f, 0.01338668f, 0.01263287f, -0.07620822f, 0.14313312f, 0.05439653f, -0.04643854f, 
    -0.08427244f, 0.08890118f, -0.03690025f, 0.04667430f, 0.07890149f, -0.02988383f, 0.07459855f, -0.02047935f, 
    -0.00024026f, -0.00294853f, 0.12944776f, -0.10887226f, 0.13007356f, -0.07128493f, 0.18733236f, -0.19200559f, 
    -0.05632237f, 0.03714133f, 0.10207409f, -0.00817516f, -0.00673239f, 0.00743025f, -0.00950850f, 0.05202358f, 
    0.04073097f, 0.07619154f, -0.08119968f, -0.11283591f, -0.00289897f, 0.02127613f, 0.09405140f, 0.08946792f, 
    0.02812649f, -0.03092842f, -0.02516711f, 0.06624224f, 0.05710852f, -0.13696074f, -0.13478403f, 0.07943040f, 
    0.07906374f, -0.00211858f, -0.01096640f, 0.24565552f, -0.07041965f, 0.01567400f, 0.01719433f, 0.05800664f, 
    -0.03745921f, -0.06575255f, -0.11698843f, -0.04559351f, -0.00834131f, 0.12091666f, 0.05956172f, 0.14208800f, 
    -0.03084203f, -0.01284527f, -0.00268624f, 0.10650016f, 0.03786597f, -0.09186440f, 0.19842471f, -0.02399543f, 
    -0.02644851f, 0.05054472f, 0.03461035f, 0.05566137f, 0.02198979f, 0.03321517f, 0.07080190f, -0.02321568f, 
    0.10665788f, -0.26250017f, -0.11591380f, 0.05858689f, -0.05891306f, 0.00069834f, -0.03326847f, 0.12759095f, 
    -0.09563400f, 0.07024460f, -0.02063313f, -0.01960759f, -0.23276505f, -0.02492647f, 0.14864250f, 0.10749713f, 
    0.02328648f, 0.03571059f, 0.05224555f, -0.05241695f, 0.04600089f, 0.01970036f, -0.00735273f, 0.05705676f, 
    0.10369908f, 0.27598271f, -0.14779110f, 0.05042874f, 0.10542230f, -0.03086847f, 0.04486091f, 0.02441101f, 
    -0.01303643f, 0.02500735f, -0.00784623f, 0.09462909f, -0.00976764f, -0.13537553f, -0.07735243f, -0.13437988f, 
    0.05108977f, 0.01112020f, 0.03191140f, 0.10141135f, -0.08528893f, 0.06762716f, -0.05256227f, 0.02765007f, 
    -0.13309728f, -0.25149384f, -0.09713282f, 0.03962483f, 0.00406530f, 0.01519103f, 0.00383406f, 0.21943486f, 
    -0.01527461f, 0.06856234f, 0.04959934f, 0.01622928f, -0.02893991f, -0.16955838f, -0.08400374f, 0.12361064f, 
    0.00291305f, 0.02709804f, 0.03961511f, 0.12376838f, 0.04897146f, -0.03859522f, 0.07265031f, -0.04847024f, 
    -0.21919201f, 0.00744250f, -0.06162593f, 0.14901295f, 0.01223989f, 0.04939938f, -0.03628250f, 0.10157137f, 
    0.04501796f, -0.07881097f, -0.06182063f, 0.07676588f, 0.10664359f, -0.04062265f, 0.09806369f, 0.07964814f, 
    0.12087896f, -0.02326277f, -0.03178210f, 0.12261985f, 0.04650754f, 0.01895639f, 0.02162838f, -0.05929658f, 
    -0.11981531f, -0.06610429f, 0.11578389f, 0.01887271f, 0.02837262f, 0.05824222f, 0.13210969f, -0.00138789f, 
    -0.04424099f, 0.04817763f, 0.00750866f, 0.02126473f, -0.14859946f, -0.26730865f, 0.12099799f, 0.08598241f, 
    -0.15502192f, 0.06987286f, 0.05784667f, -0.11695883f, 0.01963494f, 0.03104121f, -0.04882349f, -0.05671781f, 
    -0.16416843f, 0.07122950f, 0.16802943f, -0.08701287f, -0.10165696f, 0.01088078f, 0.00110402f, 0.06717950f, 
    0.10064122f, 0.12375578f, 0.02022883f, 0.05314146f, -0.00912247f, 0.11248244f, 0.19710386f, -0.05568169f, 
    0.15047719f, 0.02400116f, 0.00258327f, 0.01643191f, 0.01771651f, 0.03490311f, -0.03590249f, -0.00691894f, 
    -0.09766896f, 0.03812126f, -0.21715502f, -0.01342552f, 0.03447874f, 0.01667767f, -0.10217759f, 0.01278741f, 
    0.00274517f, -0.02424916f, -0.01097088f, 0.04446124f, 0.12497621f, -0.23834802f, 0.16706483f, -0.20466445f, 
    -0.11324156f, -0.03898246f, 0.03059381f, -0.04835394f, -0.01808914f, -0.02222804f, -0.08835994f, -0.03631669f, 
    0.06734241f, -0.12129319f, 0.07736642f, 0.02589570f, -0.02167457f, 0.04674715f, -0.00494473f, -0.09115437f, 
    0.01248522f, 0.07761387f, 0.01320411f, 0.03797569f, 0.21948084f, -0.02650708f, 0.02351679f, 0.05532064f, 
    -0.07561208f, 0.12896745f, -0.02736845f, 0.05922011f, -0.03761925f, 0.07046214f, -0.06754197f, 0.07194305f, 
    -0.41679385f, 0.13768815f, -0.07505391f, 0.01859733f, -0.02209967f, -0.01246926f, -0.06929561f, 0.17358284f, 
    -0.15792485f, 0.01805699f, -0.13745925f, 0.05526949f, -0.39842021f, -0.07962022f, -0.12153807f, -0.02151678f, 
    0.09242180f, -0.01569428f, 0.04699219f, 0.06221889f, 0.08291857f, 0.04432577f, 0.05186131f, 0.05681363f, 
    0.27358237f, 0.01539526f, 0.05974179f, 0.18035443f, -0.10147029f, 0.11886704f, 0.00782530f, 0.05105141f, 
    -0.00049610f, 0.02492798f, 0.07280351f, -0.09394126f, 0.09152249f, -0.02668079f, 0.02944453f, 0.11453460f, 
    -0.01929495f, -0.05152495f, 0.00730594f, -0.06385010f, -0.02894215f, -0.03892646f, 0.06955537f, 0.11623137f, 
    0.07558227f, 0.10314141f, -0.02988195f, 0.05178249f, 0.03203631f, 0.09630394f, -0.06402648f, -0.09793247f, 
    -0.15920912f, 0.04719070f, -0.03500105f, 0.09525675f, -0.13658313f, 0.06487238f, -0.06909865f, 0.05859870f, 
    0.13829216f, 0.09640714f, -0.05284307f, -0.10779798f, 0.05350747f, 0.10411875f, -0.00638255f, 0.05089258f, 
    -0.01822993f, -0.23633774f, 0.04795257f, -0.10645395f, -0.01568135f, 0.10986313f, 0.14525975f, 0.06450122f, 
    -0.06952529f, 0.07729406f, -0.01457580f, 0.03278636f, 0.00328587f, 0.09246022f, 0.00100746f, -0.04060613f, 
    -0.01791127f, -0.04272235f, 0.03165610f, 0.11935468f, -0.09570334f, 0.00649939f, -0.03136051f, 0.02248061f, 
    0.12494551f, 0.09593775f, -0.01001342f, 0.07851541f, -0.03859875f, -0.00750197f, 0.02442031f, 0.04139923f, 
    -0.01268140f, -0.00044719f, -0.00402530f, 0.10217255f, 0.21929662f, -0.16822527f, -0.08184724f, -0.02796757f, 
    0.08958282f, 0.05302586f, -0.03400942f, 0.04798831f, -0.00044458f, -0.04363303f, 0.04378984f, 0.16206491f, 
    -0.23930016f, 0.11731021f, 0.09142438f, -0.09987794f, 0.10662773f, 0.08261759f, 0.08162594f, 0.12687208f, 
    0.03781595f, 0.06549992f, 0.00810133f, -0.06080583f, 0.23097575f, -0.32366574f, 0.22924525f, 0.22708471f, 
    -0.14581050f, -0.06058498f, 0.15025197f, -0.16556600f, 0.05948825f, 0.01712047f, -0.00620807f, 0.03862887f, 
    -0.21404468f, -0.17772621f, 0.18112831f, 0.00560877f, 0.00062171f, 0.04041694f, 0.15814233f, 0.04826295f, 
    -0.04874750f, 0.00679599f, -0.00426124f, -0.03453923f, 0.20951925f, 0.23008195f, 0.11968050f, -0.06133507f, 
    -0.05592520f, 0.10864057f, -0.01133247f, 0.02956187f, -0.06250343f, -0.03666295f, -0.04405252f, 0.04578336f, 
    -0.18170097f, 0.01002839f, 0.13271450f, 0.15995406f, -0.19609603f, 0.09080933f, 0.07303794f, 0.03686165f, 
    0.01274764f, -0.02045872f, -0.07016464f, -0.06690093f, 0.02720776f, 0.14457703f, -0.33277971f, 0.01216360f, 
    0.03192211f, 0.05432816f, 0.00694376f, 0.07236714f, 0.03821761f, 0.13325290f, 0.02795933f, 0.10665172f, 
    -0.19000711f, 0.19432679f, -0.25381735f, -0.02592244f, 0.02097022f, 0.00748627f, -0.08354690f, 0.08323479f, 
    0.03988760f, 0.02623960f, -0.03050352f, 0.01056386f, -0.22174591f, -0.11236125f, 0.28582707f, -0.06274095f, 
    0.10522013f, -0.05882358f, 0.01612345f, 0.01220369f, -0.03178949f, -0.00664445f, -0.02673354f, 0.01574408f, 
    -0.15967949f, 0.11996102f, 0.04144236f, -0.12701847f, 0.08655483f, -0.04347790f, 0.00658958f, 0.07651106f, 
    -0.04408677f, -0.02770394f, -0.04994078f, -0.03950528f, 0.08096543f, -0.04848285f, -0.03659123f, 0.20345542f, 
    0.05282610f, 0.02022389f, -0.03629280f, -0.04647936f, -0.05981960f, -0.09672096f, 0.02664299f, 0.07839162f, 
    -0.08968006f, -0.20881802f, 0.27764860f, 0.22222964f, -0.09382301f, -0.01213561f, -0.00253644f, 0.01536848f, 
    0.08467920f, -0.06104793f, -0.04427202f, -0.06188717f, 0.16235189f, 0.16837408f, -0.10562873f, 0.09280629f, 
    0.03644309f, 0.08359907f, 0.05831546f, -0.00334755f, -0.02125998f, 0.07911162f, 0.07249510f, 0.12737691f, 
    -0.22464578f, -0.15259910f, 0.30395523f, 0.20207807f, 0.05075561f, 0.07673759f, -0.11891840f, 0.02488784f, 
    0.07208733f, 0.02231986f, 0.11049836f, 0.00907554f, -0.16907462f, -0.00705268f, 0.20596060f, 0.02933562f, 
    -0.04338587f, -0.00283288f, -0.07046992f, 0.01411780f, 0.06063393f, -0.05904337f, -0.06645774f, 0.07115799f, 
    -0.02728741f, 0.16206461f, 0.17210464f, 0.10826647f, -0.02247972f, 0.02491868f, 0.03459452f, 0.05126967f, 
    -0.04121511f, 0.01009279f, 0.06924564f, 0.05494302f, 0.15148132f, -0.12032686f, 0.15275981f, 0.06182855f, 
    -0.00298639f, 0.00860925f, 0.14058289f, 0.15278618f, -0.02067441f, 0.03144435f, -0.06020892f, 0.08857197f, 
    -0.13516621f, 0.20917788f, 0.11293228f, 0.04398229f, 0.08360922f, 0.06656776f, 0.02273123f, -0.00230981f, 
    0.05868929f, 0.03058594f, 0.02241063f, 0.10376941f, 0.13220561f, -0.05616989f, 0.18430290f, 0.14803421f, 
    0.03852894f, 0.01232936f, 0.08426771f, 0.02001078f, 0.06661057f, 0.00506744f, 0.03802691f, 0.03306655f, 
    -0.36480111f, 0.07218988f, -0.15543492f, 0.03463139f, 0.24148984f, -0.02198067f, -0.07413738f, 0.08618437f, 
    0.01140703f, 0.04966572f, 0.03821880f, 0.02338769f, 0.06203838f, 0.20595443f, 0.00817998f, 0.03575597f, 
    0.09651402f, 0.01780045f, -0.02894183f, -0.01247779f, 0.06988695f, 0.09752516f, 0.07382561f, 0.02326331f, 
    -0.13265456f, 0.27928117f, 0.06525651f, -0.14247058f, 0.03783158f, 0.03505285f, -0.03451636f, -0.01876263f, 
    -0.06011793f, -0.02870711f, 0.03418398f, -0.02447517f, 0.06957731f, -0.04214319f, 0.12807453f, 0.01136255f, 
    -0.00131876f, 0.04010643f, 0.08489186f, -0.09032921f, -0.02157045f, -0.02068768f, 0.08090423f, 0.00320261f, 
    0.01174844f, 0.00904230f, 0.04593196f, 0.09218176f, 0.14151235f, 0.00332901f, 0.08325054f, 0.10073103f, 
    0.09917165f, 0.04938113f, 0.01490481f, 0.05389017f, -0.22552355f, 0.12096137f, -0.11699235f, -0.24997862f, 
    0.03482627f, -0.18019512f, 0.03649466f, -0.07027711f, 0.07356540f, -0.02299995f, -0.14883009f, 0.03673284f, 
    0.23090427f, 0.02874444f, -0.04872281f, -0.16257663f, -0.01980696f, 0.06504384f, 0.09724388f, 0.04427627f, 
    0.02232741f, 0.08648239f, 0.02246602f, 0.08742066f, 0.11965168f, 0.04985562f, 0.11694501f, -0.05046540f, 
    0.00112689f, -0.03735801f, 0.01103113f, 0.00592153f, 0.03493556f, 0.01468461f, 0.02273471f, 0.06079937f, 
    0.32350942f, 0.20499356f, 0.02103428f, -0.23300795f, 0.12955469f, 0.03426063f, -0.08488081f, -0.04716595f, 
    0.09122759f, 0.02651583f, 0.07549329f, 0.02011845f, 0.33784446f, 0.01644103f, 0.19518824f, 0.22861636f, 
    -0.08027577f, 0.03245327f, 0.01322413f, -0.07047214f, 0.08582157f, -0.06477921f, -0.01338091f, -0.01718109f, 
    0.07560352f, -0.08942814f, -0.00253013f, -0.15387022f, -0.04382002f, -0.03721108f, -0.04999833f, 0.01107365f, 
    -0.05707097f, 0.09287795f, 0.09114590f, -0.04920243f, 0.17075442f, -0.07214477f, 0.02868942f, -0.14514336f, 
    0.03741769f, -0.03441395f, 0.00115397f, -0.03475107f, 0.06558490f, 0.03778021f, 0.01183681f, -0.09336454f, 
    0.36930376f, -0.00300001f, -0.00985535f, 0.10340998f, -0.14472719f, 0.04698231f, 0.08871028f, 0.02626605f, 
    0.08323925f, -0.01679125f, 0.03373535f, -0.00142413f, -0.15748014f, 0.07849726f, 0.05642675f, 0.07188457f, 
    0.05426813f, -0.06153478f, 0.01189083f, 0.08494885f, -0.00143119f, -0.00306069f, 0.05429052f, 0.12730163f, 
    0.04218492f, 0.13420019f, 0.11368889f, 0.06908186f, 0.03721577f, 0.05919923f, -0.04376048f, -0.02825259f, 
    0.06157991f, 0.08091328f, 0.02773073f, -0.06323847f, -0.09743653f, 0.16770190f, -0.03356881f, 0.11978100f, 
    -0.01910912f, 0.01890857f, 0.10053045f, 0.13074194f, 0.01166417f, 0.03850475f, 0.03610451f, -0.07489604f, 
    0.15614477f, 0.21525991f, 0.05666153f, -0.16315952f, -0.06060731f, -0.15851836f, 0.06555251f, -0.07057079f, 
    0.04991991f, 0.03270821f, 0.00016051f, 0.05346907f, -0.05721601f, -0.11301578f, -0.14945933f, -0.18813121f, 
    -0.11224794f, -0.14744860f, -0.13801497f, -0.06398622f, -0.06015413f, -0.16150139f, 0.05951670f, 0.07490852f, 
    -0.02649777f, 0.05930062f, 0.10972947f, -0.16996084f, 0.00005526f, -0.07887279f, -0.03194689f, 0.03204847f, 
    0.12029586f, 0.10042667f, 0.04660274f, 0.12006820f, -0.22703463f, 0.17173226f, -0.13033397f, -0.04726016f, 
    -0.02648250f, 0.00264588f, 0.01407611f, -0.00563902f, -0.08084106f, -0.08181265f, -0.04485189f, -0.03894783f, 
    -0.00312891f, 0.02012226f, 0.04146118f, -0.00897841f, -0.02321976f, -0.02752139f, 0.13871168f, -0.05132383f, 
    -0.02463549f, 0.00482259f, 0.05808989f, 0.16626923f, 0.11894783f, -0.08549232f, -0.00177923f, 0.14062282f, 
    -0.06533553f, 0.01669748f, -0.01937510f, 0.05963280f, -0.01791391f, 0.02828402f, 0.05081621f, -0.01177833f, 
    -0.17323288f, -0.11550798f, -0.02368071f, 0.05538127f, -0.00755507f, 0.01114840f, 0.01479087f, 0.10112183f, 
    0.03424045f, -0.11958288f, 0.03977828f, 0.09096575f, -0.04422966f, -0.17401849f, 0.07850771f, -0.00546201f, 
    -0.10425629f, 0.00240926f, 0.05142362f, 0.10078721f, 0.07403706f, -0.06217181f, 0.18453114f, 0.09640616f, 
    0.06967019f, -0.11789566f, -0.04936990f, -0.13796236f, -0.09536541f, -0.13264617f, 0.03849559f, 0.03494445f, 
    0.01254794f, -0.03562840f, 0.04334010f, 0.05101782f, 0.06031015f, -0.11198930f, -0.00686394f, 0.02914057f, 
    -0.06998776f, 0.03598379f, -0.07893660f, 0.09597660f, 0.05686127f, -0.06524970f, -0.11378974f, 0.12557833f, 
    0.04597748f, -0.04518208f, -0.06410033f, 0.00789539f, -0.00653335f, -0.04773911f, -0.09371036f, 0.02866622f, 
    0.08681918f, 0.08042093f, -0.00674213f, 0.00356311f, -0.14020780f, 0.06120163f, 0.09036636f, -0.04189791f, 
    -0.08608498f, 0.04972284f, 0.05071648f, -0.06672314f, -0.10198487f, -0.09130391f, -0.00003114f, 0.11212367f, 
    -0.26353121f, 0.30035681f, 0.11744995f, -0.07714021f, 0.09430584f, 0.11140770f, -0.00527583f, 0.01621334f, 
    -0.03083665f, -0.12509020f, 0.02322282f, -0.02661972f, 0.02068716f, -0.11731224f, -0.03052204f, 0.12408498f, 
    0.02912896f, 0.12921754f, 0.06105101f, 0.06938485f, -0.04727079f, 0.01784183f, -0.10126677f, 0.08356532f, 
    0.12858447f, 0.11952110f, 0.20386305f, 0.30162644f, -0.01920200f, 0.02370126f, 0.04893575f, 0.03274743f, 
    -0.05800297f, 0.05713824f, 0.07784510f, -0.00294928f, -0.03231315f, 0.03719893f, -0.01636196f, -0.01450999f, 
    -0.06469740f, 0.02808260f, 0.12734239f, 0.06992447f, -0.03022235f, 0.00993153f, 0.07930622f, -0.00577128f, 
    0.10639955f, 0.01103628f, -0.02102297f, -0.13953701f, -0.09711234f, 0.09304743f, 0.09013422f, 0.07188404f, 
    -0.04749581f, 0.05686811f, 0.10737894f, -0.04384808f, 0.17697901f, -0.01961436f, 0.16579528f, -0.09533402f, 
    -0.01558384f, 0.03839355f, 0.08577110f, 0.05863042f, -0.00233282f, -0.04504094f, 0.07695701f, 0.00554505f, 
    -0.17021187f, 0.00070974f, -0.09623949f, -0.14789119f, 0.06088752f, -0.03857750f, -0.00297109f, 0.02768490f, 
    -0.02770984f, 0.04784729f, -0.07122525f, 0.10950237f, -0.01210534f, -0.06773384f, -0.12165966f, 0.18901564f, 
    0.09922463f, -0.05447645f, 0.02602064f, -0.06348186f, -0.03519683f, -0.12974189f, 0.05673881f, -0.01726756f, 
    0.31642318f, -0.00219068f, 0.15311658f, 0.22078715f, -0.01295988f, 0.09846921f, -0.07836083f, -0.00359910f, 
    0.05046109f, -0.01749917f, 0.03506210f, -0.03428743f, 0.40080759f, 0.02268288f, -0.03902360f, -0.12783946f, 
    -0.11804699f, 0.00665780f, 0.04605455f, 0.05366118f, -0.00285901f, -0.01026987f, -0.04741241f, -0.02119701f, 
    0.16452873f, -0.15057150f, -0.20066348f, 0.02053177f, 0.00031865f, -0.08174215f, 0.07512754f, -0.11683464f, 
    -0.03031659f, 0.02206149f, -0.01145764f, 0.09405458f, -0.29223132f, 0.04074153f, 0.01884153f, 0.04300229f, 
    0.02659614f, 0.09832613f, 0.01228537f, -0.04793629f, 0.07485890f, -0.02236649f, -0.01570110f, -0.04713161f, 
    0.17011516f, -0.06596282f, 0.05074922f, -0.04069052f, -0.04973101f, 0.03449285f, -0.02561003f, 0.06230554f, 
    0.07264705f, -0.04239021f, -0.02632578f, -0.09901260f, 0.27420899f, -0.06458104f, 0.01138588f, 0.03873429f, 
    -0.11692262f, -0.06234512f, 0.09331153f, 0.02727830f, -0.01107887f, -0.10198388f, 0.02602929f, 0.07347576f, 
    -0.03305602f, -0.30785698f, 0.05040784f, 0.03736399f, 0.00080139f, -0.10248651f, -0.07690591f, -0.01094253f, 
    0.10276163f, -0.07066329f, -0.04792350f, -0.01810531f, 0.15310362f, -0.22513898f, 0.16953719f, 0.01240534f, 
    0.04712300f, 0.03037449f, 0.09746877f, -0.09720506f, -0.03928940f, 0.06329727f, -0.13123339f, 0.01156427f, 
    0.00726049f, -0.22097361f, 0.00439443f, 0.15746105f, 0.06791171f, 0.03520603f, -0.01428443f, -0.05724583f, 
    0.01829334f, 0.01475017f, 0.00576224f, -0.02685499f, -0.10924188f, -0.15085326f, -0.10241710f, -0.08167243f, 
    -0.07784618f, -0.09262791f, -0.08186474f, 0.02415235f, 0.10172576f, 0.03806398f, -0.11124413f, 0.13651659f, 
    0.19019580f, 0.16881441f, -0.00362992f, -0.00667681f, 0.04156867f, 0.02894952f, -0.00619077f, 0.06365077f, 
    -0.05448396f, 0.01085436f, -0.06668552f, -0.06573002f, -0.10266262f, -0.14327869f, -0.02880503f, 0.10226874f, 
    0.08165850f, 0.10411952f, 0.01083937f, 0.15381189f, -0.02785784f, -0.01835041f, -0.01376160f, 0.12685727f, 
    -0.03885994f, 0.06870114f, 0.03626309f, -0.22978067f, 0.02297907f, 0.00149947f, 0.04442481f, -0.01605400f, 
    -0.00690061f, -0.00420757f, 0.00846787f, -0.00040335f, 0.27267510f, -0.25993934f, -0.00087252f, 0.11389878f, 
    0.13972121f, -0.02865220f, -0.02292348f, 0.00036547f, 0.00510701f, 0.02135358f, -0.00866815f, -0.06308337f, 
    -0.24612603f, 0.23232433f, 0.10280728f, 0.30298918f, 0.01324929f, 0.02665307f, 0.10334607f, -0.08392827f, 
    -0.04581834f, -0.00534553f, -0.06133308f, 0.00940419f, 0.05797986f, 0.00349978f, -0.07880925f, 0.19102393f, 
    0.03058273f, 0.08408659f, -0.02127727f, -0.08746378f, 0.08162800f, -0.03552223f, 0.03524037f, -0.14230883f, 
    0.25125355f, -0.24522236f, 0.09848573f, 0.03987534f, -0.07386589f, -0.05963777f, 0.08039819f, 0.02799898f, 
    0.08811105f, 0.04810551f, -0.05682042f, 0.00490232f, 0.02176960f, 0.12393077f, 0.10895866f, -0.21837357f, 
    -0.08376103f, -0.02962985f, 0.06890541f, 0.06786964f, -0.00608429f, -0.05384289f, -0.08954391f, -0.00073597f, 
    0.27001172f, -0.00484872f, 0.02470563f, -0.04087368f, -0.09109308f, -0.00806241f, -0.06569397f, 0.03637809f, 
    0.13500389f, 0.09310112f, 0.07551724f, 0.05502475f, 0.01173082f, -0.05222468f, -0.10169335f, 0.01365335f, 
    -0.03930461f, -0.02712099f, 0.10089359f, 0.09388931f, 0.05059791f, 0.01349868f, -0.13684875f, 0.02741426f, 
    -0.15806119f, 0.02520500f, 0.05701733f, 0.00184732f, 0.03630541f, 0.17936245f, 0.03033218f, -0.07960561f, 
    -0.06230886f, 0.03233921f, -0.00133298f, 0.00281072f, -0.08075678f, -0.16731983f, 0.00682054f, 0.00740334f, 
    -0.12551068f, -0.01227366f, -0.08107865f, 0.08502842f, 0.04193512f, -0.05216324f, 0.08852685f, -0.04919052f, 
    0.24901433f, 0.13604936f, 0.01803151f, -0.07716338f, 0.09511054f, 0.11974870f, 0.08552414f, 0.01661923f, 
    0.01049393f, 0.00687113f, -0.00921967f, -0.14901556f, 0.22898433f, 0.21043335f, 0.09937427f, 0.06885433f, 
    0.09651094f, 0.10818363f, 0.06215611f, -0.00499909f, 0.01966019f, 0.08054741f, 0.03351641f, -0.10191176f, 
    -0.02288316f, -0.13171194f, -0.04565256f, 0.22593431f, -0.01275291f, -0.00007663f, -0.01420008f, 0.03133525f, 
    0.07800335f, 0.06401136f, -0.04767004f, 0.00873174f, -0.22695044f, -0.01403949f, 0.06663240f, -0.16582716f, 
    0.05763047f, -0.00431516f, 0.04381622f, 0.07455171f, 0.11845898f, 0.03858115f, 0.04058918f, 0.03889614f, 
    -0.03455897f, -0.09114568f, 0.01075503f, -0.05915300f, -0.01779453f, 0.07645434f, -0.02518967f, 0.02813668f, 
    0.03327844f, 0.00196015f, 0.14446305f, -0.04532037f, -0.22796673f, 0.14461116f, 0.15182213f, -0.14092360f, 
    -0.01272805f, -0.01591975f, 0.00427615f, 0.07742029f, -0.00755688f, -0.02063884f, 0.05209833f, 0.07203672f, 
    0.39411801f, 0.03863489f, 0.08554297f, -0.01446379f, -0.06592288f, 0.03039313f, 0.09097888f, 0.06653993f, 
    -0.03708857f, -0.05395053f, -0.02592034f, 0.10750481f, 0.02311756f, -0.06684431f, 0.04395263f, 0.14154482f, 
    -0.10838915f, -0.01116654f, 0.03772071f, -0.05505475f, 0.00359801f, 0.09234487f, 0.00785367f, -0.01911740f, 
    -0.08220627f, -0.03895754f, -0.05264328f, 0.03009732f, -0.00670066f, 0.09005154f, 0.09382474f, 0.07222533f, 
    0.01565582f, -0.02827697f, 0.04480176f, 0.02259767f, -0.04338411f, 0.10051209f, -0.04578494f, -0.10259233f, 
    0.05021198f, 0.06602298f, 0.09767508f, -0.01969018f, 0.03125614f, -0.00489083f, 0.04893787f, -0.04112964f, 
    0.16633475f, 0.03983654f, -0.06813212f, -0.13800223f, 0.04191437f, 0.04652802f, -0.03298575f, -0.05397317f, 
    0.06080215f, 0.06772678f, -0.16066094f, -0.00375984f, 0.34435678f, 0.04471304f, 0.05644769f, -0.12019018f, 
    -0.15165533f, 0.04150950f, -0.03859699f, 0.12293798f, -0.03008782f, 0.02016171f, 0.08585696f, -0.00500550f, 
    -0.12400509f, 0.06958411f, -0.00075753f, 0.08372100f, 0.01269797f, 0.06354579f, 0.06759306f, 0.09449780f, 
    -0.01143072f, 0.09911125f, -0.01139288f, -0.04031794f, 0.09785361f, -0.16384922f, 0.04889011f, 0.07162143f, 
    0.08803240f, 0.05541967f, 0.01670825f, 0.10628355f, -0.05854624f, -0.03254931f, 0.04181984f, -0.00957264f, 
    0.30648124f, 0.04355904f, -0.11402719f, 0.03022224f, -0.07351404f, 0.06664515f, 0.09436434f, 0.05943148f, 
    -0.00448459f, 0.13677786f, 0.06697618f, -0.03930474f, 0.28831705f, -0.06547128f, 0.05961688f, -0.19399567f, 
    0.04940116f, 0.06945545f, -0.03039321f, -0.01014006f, -0.11509535f, -0.03568288f, 0.06962087f, 0.01840430f, 
    0.08403061f, 0.13428178f, 0.20140921f, 0.19488810f, 0.03299211f, -0.01135487f, 0.10597061f, 0.02629341f, 
    -0.04005960f, -0.04241950f, -0.05189310f, -0.02858779f, 0.00590592f, -0.02504387f, -0.04509903f, 0.29169136f, 
    0.13017929f, 0.01471833f, 0.06804153f, -0.08867606f, -0.00751325f, 0.03530181f, -0.08674992f, 0.12791757f, 
    0.46152970f, -0.11412495f, 0.07345677f, -0.08408707f, 0.05321492f, 0.04189462f, -0.02983848f, 0.01355772f, 
    0.04710317f, 0.06121502f, 0.02412196f, -0.01796643f, 0.17795596f, -0.05636571f, 0.06959418f, 0.00113055f, 
    0.06956477f, 0.05984624f, -0.08091351f, 0.05085607f, 0.08174638f, 0.05790770f, 0.01643467f, 0.15097404f, 
    -0.14348677f, 0.06583603f, -0.03120236f, -0.14383779f, 0.11962316f, -0.00609775f, -0.11530518f, 0.04149729f, 
    -0.00186645f, 0.04343266f, -0.08027464f, -0.00543115f, 0.06054153f, -0.06130205f, -0.02511763f, -0.07339711f, 
    0.10253531f, 0.07470249f, 0.07454958f, -0.00720094f, -0.00729278f, -0.00023036f, -0.03332635f, 0.14137532f, 
    -0.15180002f, -0.04247990f, -0.05259772f, 0.19709271f, 0.14250782f, 0.12324654f, -0.00600210f, 0.09635104f, 
    0.05588388f, 0.11693062f, 0.04770454f, -0.04816057f, 0.23301767f, 0.12782195f, 0.19046095f, 0.15505363f, 
    0.04529646f, 0.11462963f, 0.09016913f, -0.11483900f, 0.02082057f, 0.06328581f, -0.00940756f, 0.03117095f, 
    0.12140464f, 0.14806975f, -0.06034717f, 0.15072556f, 0.06260113f, 0.03664075f, 0.11327570f, -0.00612811f, 
    0.05463556f, 0.13955940f, -0.05965983f, -0.04780161f, -0.01074297f, 0.02646158f, -0.11855544f, -0.03344668f, 
    0.11885136f, 0.03627812f, 0.03495412f, 0.02070496f, 0.00910250f, 0.06417111f, 0.11239868f, 0.15641998f, 
    0.34576499f, 0.09412166f, 0.21623163f, 0.09797954f, 0.08665159f, 0.10979146f, -0.14604922f, 0.03239460f, 
    0.04365574f, 0.08073805f, 0.00214222f, 0.07419845f, -0.15422826f, 0.00717119f, -0.13710290f, -0.22682932f, 
    0.18550082f, 0.03001934f, -0.07991201f, 0.10322808f, 0.05557710f, 0.04349411f, 0.09534688f, 0.04635362f, 
    -0.06347299f, 0.08421732f, 0.21417159f, -0.00507547f, 0.01812491f, 0.04838629f, -0.12906373f, -0.01315275f, 
    0.01992683f, -0.02888934f, 0.08355295f, -0.14110433f, 0.07824650f, 0.10804096f, -0.00098291f, -0.05163598f, 
    0.04797301f, -0.14117871f, 0.05167023f, -0.08836073f, 0.07526584f, -0.05634321f, -0.02852222f, 0.12771793f, 
    0.22328368f, 0.14281955f, 0.02237658f, 0.24242733f, -0.01783241f, 0.00739778f, 0.04312139f, -0.01240433f, 
    0.01206437f, 0.08243494f, -0.07736894f, -0.07362643f, 0.38512489f, 0.07793438f, 0.07409058f, 0.05013714f, 
    0.03104408f, -0.01313486f, 0.06357739f, -0.02921531f, -0.07292249f, 0.06228717f, 0.01736288f, -0.17405847f, 
    0.02823932f, 0.09746871f, 0.06127640f, 0.06028895f, 0.08137103f, 0.03598789f, 0.01732399f, -0.13360725f, 
    0.02548062f, -0.03176653f, -0.01698258f, 0.10167225f, 0.03945374f, 0.10599663f, 0.20651548f, 0.15613905f, 
    -0.02805728f, -0.01793226f, -0.04612971f, 0.11455806f, 0.08860840f, -0.00722416f, -0.01494105f, -0.05588592f, 
    0.17296900f, -0.01191017f, -0.07121049f, -0.07574504f, -0.02902405f, -0.11272333f, 0.00864507f, 0.10060087f, 
    0.03988624f, 0.15547179f, 0.04136264f, 0.09331829f, 0.06577966f, 0.26397544f, 0.03053504f, -0.07571171f, 
    0.08614141f, 0.08855797f, 0.09409530f, 0.03744527f, 0.09139790f, -0.04347559f, 0.15169013f, -0.01949764f, 
    -0.10787937f, -0.12627204f, -0.04392444f, -0.10146799f, 0.23023599f, -0.09847084f, -0.00826745f, -0.02634224f, 
    0.06291186f, 0.11010889f, 0.11713004f, 0.06714962f, -0.02147659f, -0.00580608f, 0.01505129f, 0.02696472f, 
    0.03489785f, 0.07700989f, 0.07584708f, -0.07653026f, 0.13495819f, -0.04576128f, -0.03747025f, 0.04432846f, 
    0.14873165f, 0.01500796f, 0.14085124f, 0.04585383f, 0.00173018f, 0.00004220f, 0.02877258f, -0.07075597f, 
    0.12137274f, -0.01515788f, 0.05024715f, 0.11591721f, 0.04813232f, -0.03092799f, -0.00954835f, 0.12781359f, 
    0.10055062f, -0.09533240f, 0.02767770f, -0.15874091f, 0.02722250f, -0.02566262f, 0.10116583f, 0.07703020f, 
    0.05096648f, 0.08535548f, -0.07379798f, 0.10965218f, -0.06189979f, -0.10236148f, -0.10070755f, -0.01970586f, 
    0.00993998f, 0.13793278f, 0.09295426f, 0.01790900f, -0.16082461f, -0.07417084f, 0.07676507f, -0.08084455f, 
    0.03140630f, -0.03796240f, -0.14459576f, -0.03531737f, 0.07793832f, -0.08930773f, 0.04015104f, 0.06553986f, 
    0.31754318f, 0.01414156f, -0.11020166f, -0.24022776f, -0.02556852f, -0.04461898f, 0.03473047f, 0.03588186f, 
    0.05513341f, 0.05717662f, 0.02131004f, 0.02586618f, -0.02461872f, 0.10372577f, 0.02392547f, 0.13677965f, 
    -0.03044333f, -0.10336420f, 0.04335504f, -0.03099966f, -0.01139520f, -0.00658361f, -0.03890523f, -0.18619871f, 
    -0.19480155f, -0.24181142f, -0.08659063f, -0.09576783f, 0.21926786f, 0.02106567f, -0.20218331f, 0.04829353f, 
    0.08929642f, -0.11029473f, 0.10632182f, 0.05598534f, -0.11295181f, 0.06435423f, -0.08429956f, -0.01977704f, 
    0.27917013f, 0.04965297f, 0.00861217f, -0.05466864f, -0.04271338f, 0.01996718f, 0.16568738f, 0.13291888f, 
    0.04300181f, -0.06808054f, -0.07767107f, 0.05086118f, -0.04730194f, -0.01662296f, -0.00173950f, -0.06224171f, 
    -0.04089074f, 0.23784655f, -0.11410247f, -0.04928206f, 0.24431133f, 0.06395166f, 0.06768468f, 0.08655318f, 
    -0.05182399f, -0.04928243f, 0.11556896f, 0.03024043f, 0.11186285f, -0.00745297f, 0.01905495f, 0.10817343f, 
    -0.16629601f, 0.15693368f, -0.01143174f, -0.13051227f, 0.14812617f, 0.01315682f, 0.11629353f, -0.06729057f, 
    0.09911659f, 0.14198716f, -0.06749619f, 0.03530645f, -0.05106222f, 0.12216589f, -0.02436380f, 0.02218531f, 
    0.07606300f, 0.02660579f, -0.05922368f, 0.01502482f, 0.02618397f, -0.02466846f, 0.21965556f, -0.04628319f, 
    -0.26283589f, -0.00503381f, 0.00552169f, -0.15267539f, 0.30477116f, -0.02819618f, -0.00084326f, -0.12472431f, 
    -0.02395163f, 0.11939389f, 0.11631013f, 0.04008603f, -0.00264007f, 0.09968242f, 0.17430064f, 0.16526778f, 
    0.01108653f, 0.03827025f, 0.00101146f, -0.03507958f, 0.06229984f, 0.03300349f, -0.01781505f, -0.11660761f, 
    0.18153228f, -0.07164517f, -0.08577164f, 0.04247679f, -0.02105530f, -0.07127127f, -0.03747182f, 0.02529957f, 
    -0.12431460f, 0.10690383f, 0.22601372f, 0.08866145f, -0.26087150f, 0.21558559f, -0.09502549f, -0.02159594f, 
    0.15952633f, -0.03115464f, 0.08519023f, -0.07914535f, 0.01825791f, -0.00963738f, 0.03215431f, 0.04500661f, 
    -0.07444376f, 0.20123529f, -0.03402027f, 0.07529575f, 0.15792136f, -0.04419400f, 0.05928672f, 0.04788361f, 
    0.14857243f, 0.13667549f, -0.04552065f, -0.10121810f, -0.11448146f, -0.11225522f, -0.03436475f, 0.05217605f, 
    0.11409000f, -0.03551235f, 0.01298331f, -0.10039330f, 0.04175329f, 0.09337605f, 0.15558147f, 0.18672732f, 
    0.33509943f, -0.09938241f, 0.04733864f, -0.15328814f, 0.19008315f, 0.11325404f, 0.01045711f, 0.03740889f, 
    -0.00666731f, -0.19311559f, 0.02910911f, -0.13610238f, 0.14368384f, -0.20539115f, 0.17072402f, 0.05423230f, 
    -0.22878364f, -0.10455654f, 0.06030452f, 0.04581975f, 0.06940591f, 0.18510650f, -0.10015905f, 0.19613816f, 
    0.24602115f, 0.08961079f, 0.07525298f, 0.08678333f, -0.04565242f, 0.02750676f, 0.02743598f, -0.09043506f, 
    -0.06524923f, 0.06998949f, 0.15604846f, 0.07965514f, -0.15916306f, 0.08313883f, -0.10961890f, -0.01793718f, 
    0.03731716f, -0.08488188f, 0.02994241f, 0.05804107f, 0.15095147f, 0.06614175f, 0.19771318f, 0.06327134f, 
    0.16482732f, 0.05434920f, 0.10455056f, 0.09369535f, 0.10007608f, 0.01843106f, 0.05805959f, 0.10504930f, 
    0.05319133f, -0.00329517f, 0.02712141f, -0.03798937f, 0.15085582f, -0.00822045f, -0.01646709f, -0.03315279f, 
    -0.13230112f, 0.10417061f, -0.02128039f, 0.03913214f, 0.06374878f, -0.08237796f, -0.00028899f, -0.10924810f, 
    0.00128854f, 0.04250907f, -0.09548561f, 0.11364156f, 0.13462383f, 0.03213260f, 0.03657969f, -0.05966648f, 
    -0.01785848f, -0.02311250f, 0.12325066f, 0.12560764f, -0.01195908f, -0.01177524f, 0.01085841f, -0.14461493f, 
    0.16093759f, -0.12208062f, -0.05513907f, -0.08815458f, 0.07463945f, 0.02431994f, 0.01469950f, -0.03168112f, 
    0.15437301f, 0.10764354f, -0.00464265f, -0.17751607f, 0.00372796f, -0.03113358f, 0.00519008f, 0.06918294f, 
    0.05047099f, -0.01931281f, 0.11669366f, 0.04304577f, -0.00074367f, -0.05209891f, -0.02247941f, 0.04057858f, 
    0.09567588f, -0.04649259f, 0.03373592f, -0.05329536f, -0.02043583f, 0.03397562f, 0.11321635f, 0.05345524f, 
    -0.17768447f, -0.08166471f, 0.13208044f, -0.08561406f, 0.20574197f, 0.01698097f, -0.11196883f, -0.19842239f, 
    0.02509777f, -0.04389026f, 0.03002634f, 0.03437888f, 0.02755800f, 0.11429961f, -0.10344144f, 0.12507614f, 
    -0.02027690f, 0.01607275f, 0.02442287f, -0.01914611f, 0.06603635f, 0.08793009f, -0.02285963f, -0.00618708f, 
    0.15240268f, -0.07732610f, -0.03892964f, -0.15176117f, 0.09532921f, 0.08566175f, 0.12611711f, -0.05497806f, 
    0.18381150f, 0.06520275f, -0.06259464f, -0.03906083f, -0.13518688f, -0.05031760f, -0.09052003f, 0.11910478f, 
    -0.01597576f, 0.06601759f, 0.03987238f, -0.07610616f, -0.03020899f, 0.04467520f, -0.03908568f, -0.03839975f, 
    0.26637599f, 0.11993559f, -0.02068320f, 0.02268904f, -0.11476019f, -0.02763924f, 0.01437442f, 0.15845442f, 
    0.11798353f, -0.06178319f, 0.04804036f, -0.17236514f, -0.03390658f, -0.09657472f, -0.09454498f, -0.20439793f, 
    0.00983604f, -0.08364644f, -0.09573343f, 0.02803572f, 0.04525591f, 0.02461298f, 0.03100576f, -0.00308142f, 
    -0.03096779f, -0.04529028f, 0.00747122f, 0.12211563f, -0.00673973f, 0.03731825f, 0.04395442f, -0.05686655f, 
    0.16192381f, 0.12783638f, -0.00152526f, 0.08973708f, 0.08137181f, 0.01328319f, -0.07171577f, 0.16583322f, 
    0.10251510f, -0.02241354f, -0.09029403f, 0.06557605f, -0.01215162f, 0.17150718f, -0.05082798f, 0.02897074f, 
    0.42955598f, -0.00872941f, -0.08655132f, -0.01379350f, -0.04514575f, 0.06695814f, 0.06242988f, 0.00954237f, 
    -0.05570170f, 0.09510791f, 0.12846558f, -0.10945855f, -0.38945109f, 0.04062745f, -0.09084766f, 0.09321052f, 
    0.09558786f, 0.05331746f, 0.01654010f, -0.05910600f, -0.04938078f, -0.03222802f, 0.06152448f, -0.06078750f, 
    -0.09258385f, 0.14028110f, -0.07358027f, -0.12547591f, -0.04746107f, 0.01811671f, -0.24168320f, -0.08491633f, 
    -0.00079395f, -0.05606178f, 0.05906044f, 0.01813669f, -0.03456980f, -0.15003838f, 0.04867886f, 0.02387100f, 
    -0.03486870f, -0.04292601f, -0.02841774f, -0.01348193f, 0.04005259f, 0.00841056f, -0.02549722f, 0.06575192f, 
    -0.01199914f, 0.02038584f, -0.01517516f, -0.01207218f, -0.00432516f, -0.02876613f, -0.01213683f, 0.01071121f, 
    0.02322127f, -0.01408277f, 0.01839125f, 0.01049530f, 0.02617100f, -0.02230615f, 0.00090249f, 0.01897220f, 
    0.01194052f, -0.03734364f, 0.02931791f, -0.01976481f, 0.03571654f, -0.01563318f, -0.00362924f, -0.01098046f, 
    -0.02421151f, 0.00820517f, -0.02282771f, 0.00244742f, -0.03912317f, -0.00691276f, -0.02488769f, 0.01142242f, 
    -0.01580599f, 0.01945730f, -0.03701052f, -0.00793159f, -0.01580447f, 0.02828810f, -0.02339909f, 0.02513106f, 
    0.01092177f, 0.00409561f, -0.02263892f, 0.01666434f, -0.01360140f, 0.02513234f, -0.02733782f, -0.01462985f, 
    -0.03683375f, -0.00148321f, -0.00354841f, 0.00388338f, -0.03992245f, -0.00484286f, 0.01748829f, 0.00605791f, 
    -0.03642254f, 0.02653247f, -0.01569116f, -0.03502878f, 0.01207331f, -0.02061000f, -0.03535286f, -0.03579181f, 
    -0.02830692f, 0.00414673f, -0.01374169f, 0.01059778f, 0.00061465f, -0.03430092f, -0.03430907f, -0.02049268f, 
    -0.02134329f, -0.01797270f, -0.04116458f, -0.01600369f, -0.01940491f, 0.03071495f, -0.01336470f, 0.01974887f, 
    0.01762443f, -0.02925375f, -0.01226305f, -0.02276365f, -0.02514395f, -0.01441591f, -0.00128161f, -0.04001541f, 
    -0.00318310f, 0.02216811f, -0.00428877f, 0.02196149f, 0.02645821f, -0.03728627f, 0.00938282f, 0.01905908f, 
    -0.03278224f, -0.00087126f, 0.01670363f, 0.00064771f, -0.00935466f, 0.00710719f, -0.03573077f, -0.03065482f, 
    0.02819946f, 0.00362324f, 0.02211215f, -0.02135845f, 0.02588252f, 0.01967709f, 0.02938779f, 0.00556498f, 
    -0.00861456f, 0.00941560f, -0.01221918f, 0.00811829f, -0.02614246f, -0.02173865f, -0.02049500f, 0.00199368f, 
    -0.00614546f, 0.01417248f, 0.02736170f, 0.01291969f, -0.03779054f, -0.00339458f, -0.02174961f, -0.02051533f, 
    -0.03396561f, -0.01347919f, -0.01702738f, 0.01899270f, -0.01908350f, -0.00438994f, -0.00144242f, -0.01950559f, 
    0.02413112f, -0.00344172f, -0.02106692f, -0.01255050f, -0.03508002f, 0.00085492f, -0.00734237f, -0.00723339f, 
    0.01361763f, -0.00576867f, -0.00307663f, -0.02359155f, -0.03894044f, -0.00841976f, 0.02168541f, -0.02505087f, 
    0.01282075f, 0.02245625f, -0.02006417f, 0.01320849f, -0.01083124f, -0.00788012f, 0.02895296f, -0.02742366f, 
    0.01355755f, -0.00480262f, 0.00769696f, -0.01617889f, -0.01237218f, 0.00533721f, -0.02995742f, -0.02043072f, 
    -0.03041355f, -0.01363373f, -0.00819655f, -0.00266568f, -0.01940389f, -0.03500329f, 0.00650217f, 0.02563321f, 
    0.01319412f, 0.02025940f, -0.03554567f, -0.01917446f, -0.03588269f, -0.01151404f, -0.00025478f, -0.03133598f, 
    0.00840323f, -0.01117087f, -0.00191491f, 0.02542298f, 0.01729052f, 0.00135903f, -0.04153090f, 0.00426101f, 
    0.02367895f, -0.04105639f, 0.00593465f, -0.02090959f, -0.01423148f, -0.02393452f, -0.01094905f, 0.00183960f, 
    -0.01956805f, 0.02206770f, -0.00853057f, 0.01272051f, -0.01653590f, -0.02034992f, -0.00699207f, -0.00434005f, 
    -0.00664230f, 0.02009808f, -0.02412346f, -0.01711174f, 0.00762761f, 0.02203642f, 0.02947150f, 0.02792861f, 
    -0.02585759f, -0.02085924f, 0.00455679f, 0.00872555f, 0.02875375f, -0.03843206f, -0.01105604f, -0.03927367f, 
    -0.03229127f, 0.00782487f, -0.03906679f, -0.03827045f, -0.02096146f, -0.01010427f, 0.02887285f, -0.01338683f, 
    -0.03661662f, -0.02395489f, -0.00966904f, -0.03183075f, 0.02227510f, 0.02017427f, 0.01501026f, 0.02875529f, 
    -0.02883875f, 0.01833881f, 0.01800553f, 0.00658734f, -0.03609128f, 0.01468440f, 0.00251946f, -0.02576617f, 
    0.01002968f, -0.03947053f, 0.01997072f, 0.00871100f, 0.00193676f, -0.01496748f, 0.00362859f, 0.01314593f, 
    -0.02550562f, 0.00244539f, -0.02456542f, -0.02248400f, 0.00781884f, 0.01668575f, -0.02287846f, -0.01670983f, 
    0.01146273f, 0.00719500f, -0.02653384f, 0.02286976f, 0.02987945f, 0.00191717f, -0.03224472f, -0.03572343f, 
    0.00288625f, -0.04048279f, 0.00330575f, -0.03620109f, 0.00343003f, 0.02652197f, -0.00738933f, 0.03339420f, 
    0.02319099f, -0.00670478f, -0.00606474f, 0.00759020f, -0.03735163f, -0.03725110f, -0.00358009f, -0.01405074f, 
    0.02077974f, -0.02576555f, 0.01212877f, -0.04001711f, -0.03883212f, 0.00997077f, 0.02550646f, 0.02934981f, 
    0.01017815f, -0.03739572f, -0.03086466f, 0.01280741f, 0.01982705f, 0.00074593f, 0.00650553f, -0.02240049f, 
    -0.00131652f, -0.01147876f, -0.03089790f, 0.00256766f, -0.00196627f, 0.01471626f, -0.03468943f, 0.03059976f, 
    0.02420951f, -0.01065381f, 0.02795412f, -0.01767462f, -0.01829857f, -0.01292639f, 0.02396760f, -0.01081216f, 
    -0.00394512f, -0.03525432f, 0.00032710f, -0.03115263f, -0.00186369f, 0.01154409f, -0.00953543f, -0.04125122f, 
    -0.02905053f, 0.00179001f, 0.00820053f, -0.01339158f, 0.01536287f, -0.00360767f, -0.02661764f, 0.00764765f, 
    -0.01559734f, -0.01912894f, 0.02690713f, -0.01058113f, -0.02813252f, 0.00496779f, -0.03961980f, -0.02787456f, 
    -0.01462116f, 0.02040736f, 0.02227470f, -0.02806714f, -0.00900360f, 0.00042621f, -0.01097938f, -0.00363367f, 
    -0.03907515f, -0.00995978f, 0.00350297f, 0.01154191f, -0.03584834f, 0.01901837f, 0.02421022f, -0.04001454f, 
    -0.01048205f, -0.01388949f, -0.03171098f, -0.00159901f, -0.02930288f, 0.02644765f, -0.00420175f, 0.02854821f, 
    0.00980201f, 0.02885236f, 0.02789027f, 0.00971713f, -0.00098627f, 0.02320695f, 0.00519212f, 0.00530093f, 
    0.00487069f, 0.00532956f, -0.02226820f, -0.01001411f, 0.01305256f, -0.01776850f, -0.02042156f, -0.03873260f, 
    -0.00727164f, -0.04082422f, 0.02585258f, -0.04092962f, 0.01111433f, -0.02080549f, -0.01355177f, -0.00920323f, 
    0.02676315f, 0.00049239f, 0.01127158f, 0.01720026f, 0.00857999f, 0.01923782f, 0.01739866f, -0.02839009f, 
    -0.00546992f, 0.02177187f, 0.00025687f, -0.00854998f, -0.02813847f, -0.01386779f, -0.01366488f, 0.00201384f, 
    -0.01626491f, -0.02772878f, 0.00371319f, -0.01274788f, -0.00606903f, -0.00114917f, -0.00304137f, -0.01858606f, 
    0.01982652f, 0.01182637f, 0.01199708f, 0.02679389f, -0.00790436f, -0.00985033f, -0.02855575f, -0.03296492f, 
    -0.00680680f, -0.02925954f, -0.00520596f, 0.00990726f, -0.00094153f, -0.02676826f, -0.00807915f, 0.02471521f, 
    -0.03220075f, 0.01136947f, -0.02749994f, 0.01109775f, 0.03505370f, -0.01761056f, -0.02177839f, -0.00009814f, 
    -0.02953055f, -0.03302094f, -0.02586686f, 0.00564203f, 0.00117840f, 0.00974004f, 0.01398866f, 0.00495371f, 
    0.02034804f, -0.00018287f, -0.03177975f, -0.02284313f, -0.00243519f, -0.02071167f, -0.00667903f, 0.01599077f, 
    -0.02259684f, -0.02501865f, -0.02237820f, 0.02900646f, -0.01031713f, 0.02873883f, -0.00198866f, 0.00196904f, 
    -0.00687975f, 0.01026568f, -0.00336468f, -0.00635691f, 0.02791376f, -0.03302524f, -0.04051202f, 0.01931818f, 
    0.01777527f, 0.02826602f, -0.03003422f, -0.00199790f, 0.01114215f, -0.01447721f, -0.01248589f, -0.04030151f, 
    -0.02404459f, -0.02366623f, 0.01737394f, -0.03275194f, -0.03356980f, -0.03494520f, 0.02011118f, 0.01760891f, 
    0.00779400f, -0.01492539f, -0.02161540f, -0.03721839f, -0.02776484f, -0.03872322f, -0.00689136f, -0.00064605f, 
    -0.03012002f, 0.02407358f, -0.02767374f, 0.01937821f, -0.02874764f, -0.01184182f, -0.00865124f, 0.02723535f, 
    0.00575326f, -0.02091063f, 0.01740322f, -0.01426511f, -0.01961415f, 0.01146288f, 0.00725336f, -0.01822336f, 
    -0.03458101f, 0.01417820f, 0.00248093f, 0.01330729f, 0.02322479f, -0.00870287f, -0.00638428f, 0.00405727f, 
    -0.03980374f, 0.00894949f, -0.01249245f, -0.01180807f, -0.00732450f, -0.02008510f, -0.02181658f, 0.00624208f, 
    -0.02375724f, 0.02290529f, 0.02280905f, -0.01792577f, 0.00273671f, 0.00489111f, -0.03943926f, -0.02089004f, 
    -0.02519249f, 0.01672049f, -0.03250955f, 0.00856770f, 0.02209320f, 0.00392300f, -0.00669957f, -0.02751916f, 
    -0.00418515f, -0.02850545f, -0.01700920f, 0.02636096f, -0.02243440f, -0.01383422f, -0.01203360f, 0.02784708f, 
    -0.00154824f, -0.02616984f, -0.04098651f, 0.02454915f, 0.01072620f, -0.00318186f, -0.03024543f, -0.01189977f, 
    0.02171977f, 0.00806871f, -0.01094355f, 0.02614220f, -0.03572687f, 0.03145427f, 0.01634421f, 0.01141702f, 
    -0.02271559f, -0.01688825f, 0.02788310f, -0.01367753f, -0.02098704f, -0.01617248f, 0.01101237f, 0.01594987f, 
    -0.01867514f, 0.01111835f, 0.02608887f, -0.02608574f, -0.00515638f, 0.01007954f, -0.01822630f, 0.00748886f, 
    0.00725882f, -0.00779297f, -0.01546528f, -0.01723009f, -0.00455049f, -0.03290024f, 0.02654996f, -0.02332461f, 
    -0.01040362f, 0.01744257f, -0.03438265f, -0.02032135f, 0.01679721f, -0.02663502f, -0.02764453f, -0.03516560f, 
    -0.01847938f, -0.03104858f, -0.02588557f, -0.01163095f, -0.00525032f, -0.00740684f, -0.01994012f, 0.00075545f, 
    -0.03901532f, 0.03582940f, -0.00499477f, -0.00933689f, -0.01847975f, -0.01879761f, 0.01537802f, 0.01392651f, 
    -0.02891592f, 0.02510196f, -0.01887115f, 0.02628495f, -0.03750604f, 0.00772908f, -0.04055028f, -0.01413582f, 
    0.02983018f, 0.00781125f, -0.00054215f, 0.00495552f, -0.01261568f, -0.01983753f, -0.02078105f, 0.01059708f, 
    0.02136327f, -0.02923797f, -0.03523278f, -0.02597313f, -0.03740656f, 0.01937195f, 0.00494163f, -0.02562553f, 
    -0.03916865f, 0.02061141f, -0.00752303f, 0.01849647f, 0.02581633f, -0.01862435f, -0.01039622f, -0.02196732f, 
    0.01556617f, 0.02333980f, 0.01921762f, -0.01779630f, -0.03675951f, -0.00221789f, -0.03483958f, 0.00021246f, 
    0.00479795f, -0.00093627f, -0.00932062f, -0.01455902f, -0.03389382f, 0.01059418f, -0.01125500f, 0.02044372f, 
    -0.00526901f, 0.00455247f, -0.02214962f, -0.02995478f, -0.03521356f, -0.01730254f, 0.02490109f, -0.02846168f, 
    0.02657845f, -0.00775414f, 0.01101964f, -0.01667503f, -0.03401072f, 0.01776890f, 0.00053540f, -0.01998102f, 
    0.02504355f, 0.00314250f, -0.02043119f, -0.00408420f, -0.01332994f, 0.00543034f, -0.00793531f, -0.03063230f, 
    0.00042769f, -0.01534359f, -0.03414328f, -0.03804745f, 0.02237124f, -0.02953261f, -0.02769257f, -0.01949769f, 
    -0.01350539f, -0.02217089f, 0.00292785f, -0.01374599f, 0.01243830f, -0.00574002f, -0.01660157f, 0.02723520f, 
    0.00130674f, -0.02902194f, -0.02107013f, 0.02117861f, 0.01306970f, 0.00374190f, 0.02841675f, -0.03244107f, 
    -0.02489505f, -0.00434731f, -0.03236614f, -0.03180283f, -0.00954736f, -0.01010856f, -0.03360225f, -0.03444140f, 
    0.00241309f, -0.01560572f, -0.02822393f, 0.00504892f, -0.02901896f, -0.00340060f, -0.02824487f, -0.01138064f, 
    -0.01339330f, -0.00785491f, -0.03328704f, -0.02025797f, 0.02173289f, 0.01097768f, 0.01196534f, -0.00657382f, 
    0.00610432f, -0.02684681f, 0.00200117f, 0.01427960f, -0.01593710f, -0.00950640f, 0.00797538f, -0.02015398f, 
    -0.00204996f, -0.02986130f, -0.02908675f, -0.02011788f, 0.02728550f, -0.00680808f, 0.02990230f, -0.03198057f, 
    -0.03050738f, -0.03499314f, -0.01119188f, 0.02369508f, -0.03506422f, -0.00942057f, 0.02024505f, -0.00147795f, 
    0.01351408f, -0.04085026f, 0.02338419f, -0.02773258f, -0.01904252f, 0.02322611f, 0.01198227f, 0.02934615f, 
    -0.00135249f, -0.03303564f, -0.01828213f, 0.02990839f, -0.02458843f, -0.03315209f, 0.02888257f, -0.02042161f, 
    0.01556844f, -0.03037237f, -0.03124772f, 0.02812939f, -0.01320629f, 0.01251703f, -0.01013489f, -0.01724088f, 
    -0.03519270f, -0.01634967f, 0.02097918f, -0.02185165f, -0.02935949f, -0.00745122f, 0.02274976f, -0.03358620f, 
    -0.00615834f, 0.01625455f, 0.00817762f, 0.01513121f, -0.01793355f, -0.01587939f, -0.01916673f, 0.00219225f, 
    -0.01509018f, -0.01192023f, -0.03950914f, -0.02693858f, -0.02899229f, -0.01864271f, -0.00679390f, -0.01017517f, 
    0.01344242f, -0.02039772f, -0.00245928f, -0.01028814f, 0.01799539f, -0.00031597f, -0.03831098f, -0.04468122f, 
    0.02152345f, -0.00361391f, -0.02467197f, 0.01385433f, 0.02513597f, -0.00437313f, -0.00856877f, -0.02449074f, 
    -0.00475937f, -0.00423478f, 0.02324884f, -0.02416286f, -0.02136196f, 0.02486244f, 0.01609229f, -0.01019307f, 
    0.00827629f, 0.00271976f, -0.01685586f, 0.01384427f, 0.02660659f, 0.01309919f, 0.01741237f, 0.00045925f, 
    0.00623676f, 0.03083436f, -0.01227174f, 0.02201483f, 0.00528214f, 0.02001768f, -0.01581620f, -0.04306653f, 
    -0.02237683f, 0.00611034f, -0.00571167f, 0.00365515f, 0.02974964f, 0.01627032f, -0.03363087f, -0.01569158f, 
    0.01868885f, 0.00148632f, -0.00837185f, 0.02291873f, -0.00793381f, 0.01145427f, -0.00053867f, -0.03144871f, 
    -0.02420075f, 0.01505343f, -0.01496005f, -0.04306224f, -0.01288268f, -0.02360789f, 0.01722916f, 0.01409910f, 
    0.01628173f, 0.01093553f, 0.02666294f, 0.00625903f, -0.00639542f, -0.03038308f, -0.00147152f, 0.00095709f, 
    -0.01861080f, 0.00271149f, -0.00246804f, -0.03240811f, -0.00492129f, -0.00506104f, 0.00370752f, 0.00485664f, 
    0.02933651f, 0.03454129f, -0.02678825f, 0.03220594f, -0.02131339f, -0.01583111f, 0.01263389f, -0.01053154f, 
    0.02974859f, -0.00362096f, -0.01417796f, -0.00130968f, -0.02266929f, -0.03083439f, -0.00421310f, 0.02740424f, 
    -0.00274705f, -0.00440681f, -0.00722360f, -0.03485876f, -0.02619042f, -0.01395389f, -0.03446544f, -0.03354360f, 
    0.03030783f, 0.02183938f, 0.00086402f, -0.01049143f, -0.01532454f, 0.03330285f, -0.03440429f, -0.03858819f, 
    0.00230635f, -0.00715452f, -0.03375068f, -0.02904370f, 0.02199704f, -0.01689075f, -0.02705949f, -0.02871046f, 
    -0.02919545f, -0.03644707f, -0.01420686f, -0.01386642f, 0.02555307f, 0.00951777f, -0.03995385f, 0.01086485f, 
    0.00311389f, 0.01787681f, -0.00131438f, -0.02002553f, 0.02361985f, 0.02121079f, -0.00356363f, -0.03030965f, 
    -0.00932262f, 0.02665963f, 0.00045209f, -0.03206480f, 0.02053280f, -0.01123854f, 0.01945107f, -0.01582143f, 
    -0.00568910f, 0.00825080f, 0.02365536f, -0.02310473f, 0.02272994f, -0.00822306f, -0.02386280f, 0.01201114f, 
    -0.00492397f, 0.00437324f, -0.00862321f, -0.00771090f, 0.00157639f, -0.03776712f, -0.01037457f, -0.01997137f, 
    -0.01414874f, -0.03521296f, 0.00781412f, 0.00973292f, 0.01411926f, -0.02652104f, -0.02422538f, 0.00443484f, 
    -0.02723355f, -0.03961490f, -0.01117862f, 0.00443573f, 0.02915129f, -0.03510027f, 0.02459353f, -0.01089823f, 
    -0.02368986f, 0.03421192f, -0.03732964f, -0.01304508f, -0.03954949f, 0.00459507f, -0.02120581f, -0.01779904f, 
    -0.04154164f, 0.00452989f, 0.01896611f, -0.01859045f, 0.03012754f, -0.02113243f, -0.01820980f, -0.00566563f, 
    0.02639509f, -0.02086507f, -0.00610579f, 0.00389361f, 0.01274695f, -0.00876545f, 0.00951954f, -0.00678083f, 
    -0.00936224f, 0.03294886f, 0.01096712f, -0.03798326f, 0.01613422f, 0.00706987f, 0.01165440f, -0.02000837f, 
    -0.00815783f, -0.03706060f, -0.00990927f, -0.03683585f, 0.01314064f, -0.00519154f, 0.02365204f, -0.00391564f, 
    0.01622127f, -0.00749442f, -0.01255766f, -0.03718139f, -0.01450103f, 0.01705567f, 0.00412196f, 0.00112282f, 
    -0.02222302f, 0.00808481f, -0.00503197f, -0.02081421f, -0.03126738f, -0.01465047f, 0.02264073f, 0.00455342f, 
    -0.00994106f, 0.02066551f, 0.00340303f, -0.00883826f, 0.01572406f, 0.02851881f, -0.03618962f, -0.03579948f, 
    -0.01498776f, 0.00118751f, -0.00110236f, -0.00145275f, 0.02670452f, 0.00496203f, -0.03480565f, -0.01817753f, 
    0.00917148f, 0.00358359f, -0.03097531f, 0.01973843f, -0.01317075f, -0.00977680f, -0.02147262f, -0.01910402f, 
    -0.01244250f, 0.00013081f, -0.02127245f, 0.00241550f, -0.00366135f, -0.04206429f, -0.04453422f, -0.02665109f, 
    0.00518640f, 0.01135910f, 0.00989329f, -0.03524933f, 0.01951345f, -0.00440367f, -0.00224921f, 0.02553929f, 
    -0.01943346f, 0.01044761f, -0.02823842f, -0.03896213f, -0.01453424f, -0.03430078f, -0.01563573f, -0.02302062f, 
    -0.01945373f, -0.01395171f, -0.02242289f, -0.03453401f, -0.02963861f, -0.03910872f, 0.00435684f, 0.01549950f, 
    -0.00471656f, -0.03776214f, 0.01942634f, 0.02373040f, 0.01503362f, -0.03481958f, -0.04139167f, -0.00195818f, 
    -0.00323182f, 0.00712201f, -0.03147211f, 0.02103186f, 0.00572938f, -0.03845004f, 0.02812774f, -0.00746278f, 
    -0.01576120f, 0.02296357f, -0.03817857f, 0.00401069f, -0.01848773f, -0.00052929f, -0.02347080f, 0.01482831f, 
    -0.04220130f, -0.03433530f, -0.02732872f, 0.02774644f, -0.01151704f, -0.03319336f, -0.00905461f, -0.03193217f, 
    -0.00521538f, -0.00476776f, 0.00913679f, -0.00665050f, 0.02382285f, -0.04179894f, 0.01688095f, -0.02094144f, 
    0.02500370f, -0.03360235f, 0.02579191f, 0.00542477f, -0.01669824f, -0.03670705f, 0.00586302f, 0.01998953f, 
    -0.01357533f, -0.00604081f, 0.01263696f, 0.01320244f, -0.03557582f, -0.01403658f, -0.03535407f, -0.03405919f, 
    -0.00868524f, 0.00177919f, -0.00160918f, -0.02840064f, 0.00989347f, -0.01140435f, 0.00746122f, 0.00144645f, 
    -0.02953019f, 0.02143080f, -0.02545610f, -0.01919686f, -0.01122051f, -0.04140199f, -0.04094951f, -0.04022075f, 
    -0.03665047f, 0.00350912f, -0.01498012f, -0.03515504f, 0.02002410f, -0.00476996f, 0.00237381f, -0.01002641f, 
    0.02516501f, -0.02166492f, -0.01462487f, -0.00688249f, -0.04298642f, 0.00774807f, 0.01699917f, 0.01651288f, 
    -0.02112124f, -0.03677118f, -0.03797725f, 0.00396357f, -0.00896228f, -0.00247739f, -0.01180514f, -0.02339109f, 
    0.02697808f, -0.00058715f, 0.01117306f, -0.01721442f, 0.01480149f, -0.02093885f, -0.03284061f, -0.01542472f, 
    0.00031287f, -0.02522513f, 0.02362710f, -0.03984597f, -0.02945416f, -0.01490541f, -0.00493597f, 0.01629060f, 
    -0.03720628f, 0.02635094f, -0.00074988f, 0.00423317f, -0.02979589f, -0.01619292f, 0.02534485f, 0.04020173f, 
    0.02964873f, -0.01726331f, -0.04081987f, 0.01347182f, -0.00965399f, -0.01923629f, -0.03526427f, -0.03072339f, 
    0.02756601f, -0.00124249f, -0.01715898f, 0.00678967f, -0.00089509f, -0.00735025f, 0.02030266f, 0.01268521f, 
    0.02497617f, 0.00969099f, -0.00428618f, 0.02691064f, -0.01734969f, -0.00338618f, -0.03868952f, -0.02414002f, 
    0.01788010f, -0.00380861f, 0.02012602f, 0.02595094f, -0.00997267f, -0.00953930f, 0.02015326f, 0.00279736f, 
    -0.00762200f, -0.02071225f, 0.00057960f, -0.01184461f, -0.04364738f, 0.01315838f, -0.02942814f, 0.02334363f, 
    0.02034785f, 0.01471108f, -0.03652440f, 0.01951331f, -0.00980787f, -0.00604982f, 0.00622861f, -0.02468103f, 
    0.00624932f, -0.01044551f, 0.02300287f, 0.01046546f, -0.02699355f, 0.02266089f, -0.00516360f, -0.04101539f, 
    -0.01258161f, 0.00982280f, -0.03868502f, -0.00154184f, 0.00814762f, -0.02546704f, 0.00006002f, -0.00267348f, 
    0.01510111f, -0.02650934f, -0.02924350f, -0.02579985f, 0.01704948f, 0.02285687f, 0.03031654f, 0.02172184f, 
    -0.00636892f, -0.01376235f, 0.02471759f, 0.00245392f, -0.03072805f, -0.03862006f, 0.01751743f, 0.00597132f, 
    0.02853145f, -0.00312816f, -0.02072086f, 0.01713530f, -0.01685547f, 0.02249317f, -0.03764439f, -0.02100794f, 
    0.01355465f, -0.04297209f, 0.00110842f, 0.02372667f, -0.00659390f, 0.02623860f, 0.01923284f, -0.01465123f, 
    0.00580700f, 0.02474749f, -0.00501639f, -0.01349294f, -0.01883058f, 0.01579814f, -0.00353830f, -0.02598467f, 
    -0.01206212f, 0.02286037f, 0.01631786f, -0.03101008f, -0.03557424f, 0.00256201f, -0.03525854f, -0.01427163f, 
    -0.02474909f, -0.01659748f, -0.02572229f, 0.02135695f, 0.02193355f, 0.01202109f, -0.00412627f, 0.00061426f, 
    -0.01639663f, -0.01338153f, 0.01720247f, -0.01178089f, -0.03665620f, -0.01222899f, -0.03523131f, -0.04224726f, 
    -0.03172800f, -0.02637241f, 0.02345696f, 0.00964783f, -0.02543403f, -0.00660384f, -0.03064744f, -0.03614293f, 
    -0.01887876f, 0.00134701f, -0.03755407f, 0.02747923f, -0.01569652f, 0.02078318f, -0.02850439f, -0.04165420f, 
    -0.03772322f, 0.02494588f, 0.01510940f, -0.03595688f, -0.00288465f, -0.03890086f, -0.01098433f, -0.01550884f, 
    -0.01084480f, 0.01457626f, -0.01980192f, -0.00771155f, -0.03648795f, -0.00485078f, -0.03385364f, 0.02183213f, 
    -0.00318765f, 0.01229997f, -0.01243726f, 0.00003912f, 0.03005737f, -0.04087825f, -0.02178013f, 0.03079153f, 
    -0.00852338f, -0.02195035f, -0.00791571f, -0.03618509f, 0.00771893f, -0.03893691f, -0.04076331f, 0.00037149f, 
    -0.02035676f, 0.00641753f, -0.00434918f, -0.03825795f, 0.02853060f, 0.01232524f, 0.00162561f, -0.01176044f, 
    0.02219425f, -0.03009046f, 0.02193291f, 0.01399732f, -0.00239429f, 0.02866937f, -0.00476673f, -0.02536272f, 
    0.01293255f, 0.00586881f, -0.03651727f, 0.00612432f, 0.00944344f, -0.02886307f, 0.00727945f, 0.01416805f, 
    0.00368203f, -0.03786591f, -0.01178085f, -0.00437135f, 0.02025959f, 0.01669529f, 0.00789890f, -0.03648024f, 
    -0.00738101f, 0.02834145f, 0.01854032f, -0.00516177f, 0.02049400f, -0.01874885f, -0.02675632f, -0.01254674f, 
    0.01601290f, 0.02560047f, 0.01770940f, -0.02550436f, 0.02621771f, -0.02326778f, 0.00929064f, -0.02745553f, 
    -0.00585042f, 0.01103508f, 0.02444018f, -0.03764827f, -0.01899848f, -0.00174043f, -0.02350732f, -0.03764990f, 
    0.02172025f, -0.03311991f, -0.00322948f, -0.02733014f, -0.02202612f, -0.01458718f, -0.03658194f, -0.02497120f, 
    0.00852423f, 0.01789391f, -0.03175658f, -0.02210589f, 0.02170193f, -0.02476795f, 0.00629699f, 0.01850483f, 
    0.00982564f, -0.00251522f, -0.04190279f, -0.00659721f, 0.00237969f, 0.00494167f, 0.01069825f, -0.00236672f, 
    -0.00827717f, 0.02751697f, -0.01777085f, -0.00014830f, -0.03862230f, 0.01303883f, -0.00290853f, -0.02495347f, 
    -0.02557788f, -0.01700074f, 0.00968118f, 0.00545982f, -0.01574212f, -0.02485287f, 0.03172057f, 0.02109429f, 
    0.00901740f, -0.03028651f, -0.03596051f, -0.00195761f, -0.00663993f, -0.04492348f, 0.00534215f, 0.00921513f, 
    0.00820999f, -0.04213656f, -0.04343458f, -0.02720295f, 0.01943005f, -0.01825879f, 0.00009329f, -0.00301140f, 
    0.01103506f, 0.01869169f, -0.02870219f, -0.02014477f, -0.02119611f, 0.00734847f, 0.00381832f, -0.04180092f, 
    -0.02081467f, -0.01476809f, -0.04032876f, -0.00556563f, -0.01082987f, -0.00045869f, -0.03685393f, 0.00813028f, 
    -0.03013786f, -0.00971535f, 0.00434754f, 0.01594352f, -0.00156266f, 0.00739677f, 0.02117110f, -0.00115436f, 
    -0.03694792f, 0.02148129f, -0.04042053f, 0.02677460f, 0.01890617f, -0.01966974f, -0.00603173f, -0.02865484f, 
    0.00843438f, 0.00534350f, -0.01610277f, -0.01473624f, -0.02675789f, 0.00761575f, 0.00434804f, 0.01213474f, 
    -0.03372950f, 0.00376819f, -0.03345247f, 0.01968263f, 0.02688762f, -0.02564265f, -0.01797903f, -0.00860209f, 
    -0.03639268f, 0.00310382f, 0.02005751f, -0.00965232f, -0.01401541f, 0.01353587f, 0.01218198f, -0.01373158f, 
    0.01448390f, -0.01248778f, -0.01329736f, -0.03500243f, -0.01707177f, -0.02745967f, -0.04433863f, 0.01120323f, 
    0.01072350f, -0.02536538f, 0.01635383f, 0.01322255f, -0.02752518f, -0.02971116f, 0.01103164f, -0.03451716f, 
    -0.02820193f, -0.03218851f, 0.01748897f, 0.02043662f, 0.00571113f, -0.00662221f, 0.01826065f, 0.00173354f, 
    -0.01718789f, 0.01867951f, -0.00328387f, -0.01494030f, 0.01324879f, -0.02385075f, -0.03715591f, -0.03500888f, 
    -0.00045385f, 0.01906384f, -0.00460452f, 0.01077116f, 0.01767169f, -0.03961817f, -0.03388793f, -0.02589368f, 
    -0.02995250f, -0.00664574f, 0.00053252f, -0.00655111f, -0.01503722f, 0.02439507f, -0.03329607f, 0.02517367f, 
    0.02877657f, -0.01154780f, -0.03360812f, -0.04422787f, -0.03508985f, 0.00885077f, 0.00466935f, -0.01012332f, 
    0.02223915f, 0.01121340f, 0.00294010f, -0.02612352f, -0.03814710f, -0.01682418f, -0.03017567f, -0.03298355f, 
    0.01827508f, -0.03441511f, -0.00839386f, -0.01569676f, 0.02552056f, -0.01305248f, -0.02021201f, 0.02397969f, 
    -0.02999750f, -0.02197118f, 0.00302671f, -0.01084490f, -0.01401860f, -0.00298009f, -0.00568821f, 0.00915136f, 
    -0.03768884f, 0.00719927f, -0.03772972f, -0.01912010f, 0.01353677f, 0.01679838f, 0.02594377f, -0.02052440f, 
    -0.00113396f, -0.03457379f, 0.02108490f, -0.00278518f, 0.03126386f, 0.01997034f, -0.02680468f, 0.01075922f, 
    0.02671858f, -0.02890771f, 0.01225005f, 0.00334252f, 0.02213487f, -0.03063979f, -0.03850864f, -0.00909935f, 
    0.02255383f, 0.02930548f, 0.02576728f, -0.00505529f, -0.00446106f, 0.01986855f, 0.01929615f, 0.00960561f, 
    0.03439824f, 0.01272705f, -0.00012048f, 0.03150846f, -0.00922402f, -0.02539993f, 0.01726397f, 0.00755671f, 
    -0.01510216f, -0.00952879f, -0.01608188f, -0.00177319f, -0.01453741f, -0.03524084f, 0.01911487f, 0.01900679f, 
    -0.00129940f, 0.00073798f, -0.04443728f, 0.01874338f, -0.00599198f, -0.02868934f, 0.00521608f, -0.00107268f, 
    -0.00568209f, -0.01864775f, -0.01484587f, 0.01406625f, -0.02451829f, 0.01099370f, 0.01973704f, -0.02286426f, 
    0.00206634f, 0.01727730f, -0.04440992f, 0.02625069f, -0.02250082f, 0.00540257f, -0.00562578f, -0.03207351f, 
    0.00064462f, -0.03027790f, -0.01665947f, -0.02875852f, 0.03092816f, -0.01993317f, 0.00191627f, -0.00324910f, 
    0.02692562f, 0.01677683f, -0.03601275f, 0.02224220f, -0.01439431f, 0.00501068f, -0.01256956f, -0.01655591f, 
    -0.02055803f, -0.00125645f, -0.03027356f, 0.02524931f, -0.03640248f, -0.03569863f, -0.00960098f, -0.03160651f, 
    -0.03317841f, -0.01529555f, 0.00149706f, -0.02244472f, -0.04006029f, 0.01283041f, -0.02593996f, -0.03584081f, 
    0.01273151f, 0.00288271f, -0.00138920f, 0.00437575f, -0.01126709f, 0.00097689f, -0.01726866f, -0.01912396f, 
    -0.02924908f, -0.02320828f, 0.02264963f, 0.02963330f, -0.02208066f, -0.00928864f, -0.01061829f, -0.00752784f, 
    0.00195122f, -0.01458511f, -0.04110251f, -0.02053661f, -0.01964634f, -0.00491173f, 0.02645816f, -0.01646377f, 
    -0.02583821f, 0.02164144f, 0.02226162f, -0.01311366f, 0.01514038f, 0.01004951f, 0.00164143f, -0.03221633f, 
    -0.02844956f, -0.04564763f, -0.02717571f, 0.03273037f, -0.04109231f, -0.01034523f, -0.04010241f, -0.03510483f, 
    0.00817351f, -0.00918704f, -0.04031943f, -0.01406575f, -0.00020048f, 0.02583354f, 0.00366601f, 0.01923236f, 
    -0.02768220f, -0.00231682f, 0.01921515f, -0.01819457f, -0.01953458f, -0.03090195f, -0.04329783f, 0.02507027f, 
    -0.02668997f, -0.04502228f, -0.04053009f, -0.02834510f, 0.00934373f, -0.02972448f, 0.02596681f, 0.02306256f, 
    -0.02187798f, 0.00158870f, -0.02390203f, -0.03818600f, -0.03971461f, 0.00045373f, -0.01805040f, 0.00651153f, 
    -0.01469902f, -0.03795530f, -0.01797926f, -0.01529055f, 0.01918558f, -0.00610717f, -0.00518497f, -0.03108589f, 
    -0.02734928f, -0.02980743f, -0.02462712f, -0.00077039f, -0.01171801f, -0.02211331f, 0.01109959f, -0.01553079f, 
    0.03444419f, 0.02150460f, 0.01043361f, -0.02445803f, 0.01943531f, -0.00217619f, -0.02103502f, -0.01967595f, 
    -0.00917432f, -0.00419738f, 0.01692156f, -0.00706116f, -0.00789732f, 0.01849650f, 0.00924813f, 0.01828157f, 
    -0.03725886f, -0.00816843f, 0.01846276f, -0.03064361f, -0.00512404f, -0.02438618f, -0.01219393f, -0.03278475f, 
    -0.00408833f, 0.01252947f, -0.00449464f, -0.01298276f, 0.01609737f, 0.00820684f, 0.02050967f, 0.02531885f, 
    -0.02475116f, -0.01566164f, -0.02341671f, -0.00553457f, -0.01963866f, 0.00297075f, -0.04293399f, -0.00668925f, 
    -0.04144808f, -0.00442969f, -0.02337728f, 0.01380136f, -0.00010775f, 0.00455660f, -0.01750155f, 0.02679445f, 
    -0.02349768f, -0.02221208f, -0.03974539f, 0.02715575f, 0.00158786f, -0.02258860f, 0.02661978f, 0.02267024f, 
    0.01718430f, -0.00996247f, 0.01529349f, -0.02467201f, 0.01851354f, -0.00070338f, -0.01564653f, -0.04276181f, 
    -0.00347703f, -0.02241091f, 0.00519024f, -0.03570220f, -0.00684435f, 0.01566980f, 0.01670030f, -0.03041120f, 
    -0.03427845f, -0.02257147f, -0.01686698f, -0.02659734f, -0.03989559f, 0.02761963f, -0.00736300f, -0.00729553f, 
    -0.00248602f, 0.00277282f, -0.02474537f, -0.01792677f, -0.00775791f, -0.00400262f, 0.01280899f, -0.01553741f, 
    -0.00141166f, -0.02958565f, -0.01616520f, -0.01561558f, 0.02479059f, -0.00230561f, -0.02864178f, -0.02479149f, 
    -0.03795004f, 0.01491352f, -0.02141336f, -0.02070695f, -0.02443373f, -0.03165634f, -0.01491657f, -0.03518284f, 
    0.00405799f, -0.01414559f, -0.01674574f, 0.00684643f, -0.02471330f, 0.00105562f, -0.01694055f, 0.02983334f, 
    -0.03375958f, 0.02260701f, -0.01574838f, -0.01333032f, -0.03415400f, -0.00765634f, 0.01247139f, 0.00349047f, 
    0.00050261f, -0.01401954f, 0.00512046f, -0.00007345f, 0.01295944f, -0.02148952f, -0.01166956f, 0.02472934f, 
    0.01543904f, 0.01757224f, -0.00673159f, 0.02847710f, -0.03953230f, -0.03645046f, -0.00849316f, -0.02440837f, 
    -0.02336798f, 0.00091872f, 0.00252681f, -0.00106090f, -0.01929930f, 0.00261285f, 0.01377348f, -0.03063234f, 
    -0.02150503f, -0.01699553f, -0.00106717f, -0.01778469f, -0.03126245f, 0.03495614f, -0.02243276f, 0.02268400f, 
    -0.02232893f, -0.03347352f, -0.00398675f, -0.03338574f, -0.00507050f, -0.02112167f, -0.03979677f, 0.00264427f, 
    -0.00124129f, -0.00017792f, -0.02368919f, 0.01923646f, -0.01486694f, -0.01119689f, 0.01290540f, 0.00926223f, 
    0.02243756f, -0.03263592f, -0.01824733f, -0.00976746f, -0.02296360f, -0.01184480f, 0.01442486f, 0.02473873f, 
    0.00226914f, 0.00035038f, -0.01285962f, 0.03125625f, 0.02422099f, 0.03838023f, -0.02964098f, 0.01591669f, 
    0.00420269f, 0.03538397f, -0.00026811f, -0.04228094f, -0.00487392f, 0.00810282f, 0.01382367f, -0.02232867f, 
    0.00179679f, -0.02297096f, -0.01704869f, -0.02240323f, -0.03458593f, -0.03671905f, -0.02833069f, 0.00260709f, 
    -0.03929411f, -0.02012932f, -0.01532805f, 0.01854638f, 0.01977930f, -0.00618647f, -0.04323664f, -0.01214301f, 
    -0.02268947f, 0.01054183f, -0.04316832f, 0.00530218f, -0.02095698f, 0.01503172f, 0.02285043f, -0.02372633f, 
    0.00398224f, 0.02734923f, 0.00565967f, -0.00237233f, -0.01970687f, -0.00030206f, -0.00739701f, 0.02744287f, 
    -0.02528348f, -0.03206123f, 0.00951143f, -0.00471416f, 0.00862758f, 0.02413007f, -0.03309116f, -0.00617312f, 
    -0.01271454f, 0.01011670f, -0.02396021f, 0.03469748f, -0.00616839f, 0.03157942f, 0.01630799f, -0.03670412f, 
    0.01170392f, 0.02391032f, 0.02571479f, -0.02138511f, -0.04450484f, -0.00250333f, 0.01007888f, -0.02186154f, 
    0.02262309f, 0.03048949f, -0.02628515f, -0.03697559f, -0.01861727f, -0.00616224f, 0.01547916f, 0.00157112f, 
    -0.02594783f, 0.02628680f, -0.01207783f, -0.00316808f, -0.03395380f, 0.01289283f, -0.00552806f, -0.00115674f, 
    -0.01032523f, -0.00046055f, 0.00101553f, -0.01922769f, 0.01611134f, -0.03114646f, 0.01669421f, -0.02442471f, 
    -0.01310883f, -0.04249012f, 0.00993673f, 0.02269770f, -0.02201162f, 0.01807137f, -0.04079633f, 0.01070656f, 
    -0.02587918f, 0.00100451f, -0.03216669f, -0.01616012f, 0.01146360f, 0.02653739f, -0.03281713f, 0.02608084f, 
    -0.03089099f, -0.03667070f, 0.00024534f, 0.01672178f, -0.02440231f, 0.02682347f, 0.00999166f, -0.00489602f, 
    -0.01380841f, 0.02711431f, 0.03531934f, -0.00339264f, -0.00249825f, -0.01435178f, -0.03238829f, -0.01575206f, 
    -0.00499333f, 0.04124955f, 0.02690756f, -0.02494615f, 0.02492500f, -0.03778750f, 0.01945318f, 0.03519863f, 
    0.00890340f, 0.02128985f, -0.03621747f, -0.01829222f, -0.00502345f, -0.03532623f, -0.03361890f, -0.02977387f, 
    0.01785324f, 0.00174626f, -0.04102538f, 0.00265002f, 0.00289812f, 0.00498894f, 0.01817727f, -0.01794420f, 
    -0.04127811f, 0.02439615f, -0.00751194f, 0.00480265f, 0.00511934f, 0.01564333f, 0.01462043f, -0.00964291f, 
    0.01231349f, -0.03159162f, -0.00260863f, -0.01864098f, -0.00473256f, 0.00048393f, -0.02154318f, -0.03876410f, 
    -0.02333392f, 0.01746673f, -0.04042693f, 0.01652039f, -0.01102156f, 0.01766504f, -0.03467410f, -0.02304748f, 
    0.00461277f, 0.00739190f, -0.04116184f, -0.00200286f, 0.01303758f, -0.04015245f, -0.02561937f, 0.01829499f, 
    0.00954360f, 0.02574636f, -0.01177901f, -0.04396081f, 0.01214536f, 0.00297478f, 0.00134439f, 0.00419665f, 
    0.02987584f, -0.00428010f, -0.03561351f, -0.03270636f, -0.01011601f, -0.01471840f, -0.00044061f, -0.01408306f, 
    -0.01869635f, -0.03832023f, 0.02398223f, -0.00098541f, 0.02550429f, -0.00958914f, -0.04292856f, -0.04336582f, 
    -0.02456002f, -0.01987599f, 0.02478044f, 0.01319443f, 0.00566351f, 0.01299291f, -0.02075501f, 0.00953539f, 
    -0.00891372f, 0.00352245f, 0.00072875f, -0.01905449f, -0.00989467f, 0.02481136f, 0.00879922f, -0.01374899f, 
    0.02645564f, 0.00398550f, 0.01254353f, 0.00900437f, -0.04127556f, -0.04396300f, 0.02545021f, 0.02397443f, 
    0.02906638f, 0.01945617f, -0.02462245f, -0.00881424f, 0.02357116f, -0.01971712f, -0.03677764f, 0.00805590f, 
    -0.02734893f, -0.00193718f, -0.02943282f, -0.01279179f, -0.00429648f, -0.01386229f, -0.02177160f, -0.03768165f, 
    0.02476756f, 0.02257450f, 0.00560209f, -0.00471847f, -0.00107723f, -0.01942086f, -0.01765426f, 0.01763131f, 
    -0.02636338f, -0.00277305f, 0.01881306f, -0.01713110f, 0.01248091f, 0.03194680f, 0.03807748f, 0.00644508f, 
    0.02260508f, -0.03247287f, 0.02083002f, -0.04177800f, -0.00286746f, -0.00668495f, -0.00104312f, -0.01028782f, 
    -0.00667561f, 0.01745365f, 0.01592803f, -0.01343290f, -0.01652806f, 0.00293466f, 0.01081132f, 0.01182182f, 
    -0.02222111f, -0.02000316f, -0.00850462f, 0.01384798f, 0.02612308f, 0.02457004f, 0.01656801f, 0.02524530f, 
    -0.00688455f, -0.01478750f, -0.03148136f, -0.00575087f, 0.01594086f, -0.04507736f, -0.01092031f, -0.01189007f, 
    0.01494879f, -0.02661941f, -0.00776004f, -0.02565156f, 0.01602129f, -0.02510021f, -0.01743590f, 0.00393804f, 
    -0.01388930f, -0.01338262f, -0.01050218f, 0.02360813f, -0.03673929f, -0.01083434f, -0.02883126f, -0.01826665f, 
    -0.01089823f, 0.01697198f, 0.01846649f, 0.01403092f, 0.00351072f, -0.01083003f, 0.00806691f, -0.00789193f, 
    0.01052048f, -0.01417821f, 0.00868444f, -0.02832094f, -0.04481077f, -0.01488764f, -0.02012469f, -0.01558905f, 
    0.01918477f, 0.02105648f, -0.00691699f, -0.03647809f, -0.00640239f, 0.00897238f, 0.00903616f, 0.01292515f, 
    0.00278329f, -0.02749925f, 0.01008848f, -0.00888647f, -0.02921461f, -0.00886576f, -0.01339461f, -0.00557959f, 
    0.01820293f, 0.02684256f, -0.03652943f, 0.00495403f, -0.00319063f, 0.00996920f, -0.02782797f, -0.01434934f, 
    -0.01971859f, -0.03140316f, -0.03996111f, -0.03808522f, -0.03699617f, -0.03373317f, -0.00240017f, 0.01039078f, 
    0.01148392f, -0.02927944f, -0.02762083f, 0.01934200f, 0.00904705f, -0.02331007f, 0.02787220f, -0.01476982f, 
    0.01203722f, 0.02075528f, 0.03988248f, -0.00104706f, -0.00238378f, -0.01624242f, 0.01343986f, 0.00425253f, 
    0.01147387f, -0.01929488f, -0.01248194f, 0.00036790f, 0.00608967f, 0.02108773f, -0.00523409f, -0.00787651f, 
    -0.00149264f, 0.02296480f, -0.04391647f, 0.01245533f, 0.00254800f, 0.01846951f, 0.00859368f, 0.00037950f, 
    0.02679203f, 0.00692977f, -0.01044380f, -0.03516758f, -0.03161035f, 0.01154740f, -0.01902511f, 0.00600295f, 
    0.02284328f, 0.01519052f, 0.00334437f, -0.00275624f, -0.01721865f, 0.01013877f, 0.01442927f, -0.02599988f, 
    -0.04281629f, -0.03144604f, 0.01932958f, 0.02054884f, -0.00002012f, 0.03721422f, -0.00142447f, 0.01341497f, 
    -0.01517626f, 0.01937023f, -0.04485523f, -0.00460443f, -0.01019397f, -0.01264034f, 0.00639013f, -0.00473308f, 
    -0.01386214f, 0.00726318f, -0.01028298f, -0.03842777f, 0.01167229f, 0.00874592f, 0.01419024f, 0.00124050f, 
    -0.01934031f, -0.02815671f, -0.03030699f, -0.00978335f, -0.04182419f, -0.01298178f, -0.02697605f, 0.02181477f, 
    -0.00775612f, 0.02489298f, -0.03343592f, -0.03786751f, 0.00356252f, -0.04076957f, 0.02507334f, -0.02513003f, 
    -0.02695674f, 0.02074344f, -0.01319293f, -0.04168246f, 0.01123318f, 0.00456575f, -0.00019549f, -0.01511442f, 
    -0.03259545f, 0.00279026f, 0.01771835f, 0.02244697f, 0.01130679f, 0.02122966f, 0.01730543f, 0.00324979f, 
    -0.00121250f, -0.03369476f, 0.01871660f, 0.02159763f, -0.04287436f, -0.00325813f, -0.02700034f, -0.04162137f, 
    0.01146740f, -0.00575415f, -0.03543862f, 0.02317294f, -0.01660409f, 0.01365402f, -0.01576015f, -0.02816479f, 
    0.02817776f, -0.02781199f, 0.01748967f, 0.02080877f, 0.00099198f, -0.03784848f, -0.02714666f, -0.02395407f, 
    -0.03863357f, -0.01432730f, -0.02054027f, -0.03985925f, -0.00859691f, -0.01614696f, -0.03139395f, -0.02315030f, 
    -0.01725745f, -0.00700935f, 0.02052998f, -0.01224176f, 0.03556928f, -0.03728492f, 0.01796821f, -0.01136343f, 
    -0.01022281f, 0.01912582f, -0.01958333f, -0.02537753f, -0.02871225f, -0.04031394f, 0.00201228f, -0.03231016f, 
    0.00800208f, -0.01375478f, 0.01311852f, -0.02830525f, -0.01970044f, 0.01841903f, 0.02843315f, 0.00353454f, 
    -0.02344132f, -0.00227070f, -0.03231865f, -0.02544755f, 0.02778528f, -0.02358107f, 0.03035234f, -0.02637570f, 
    -0.00830203f, 0.01766314f, 0.00767571f, 0.02330666f, 0.02277707f, -0.01939423f, -0.03428096f, 0.01556452f, 
    0.02041894f, -0.03623973f, -0.00132859f, -0.01878328f, 0.01001091f, 0.00643523f, 0.01462239f, -0.03374909f, 
    0.00317867f, -0.03231413f, -0.00771335f, -0.03626547f, -0.02150284f, -0.01255980f, -0.02876564f, 0.01651858f, 
    0.00060106f, 0.02375880f, -0.03800177f, -0.02880127f, -0.03217577f, 0.01505580f, -0.01555412f, -0.00806393f, 
    -0.04271178f, 0.01866741f, -0.00188018f, 0.02767964f, -0.02042548f, -0.02620662f, -0.00940645f, 0.00255905f, 
    -0.04327036f, -0.01235639f, -0.00885822f, 0.02295162f, -0.03402203f, -0.01562623f, -0.02404312f, -0.02841874f, 
    -0.01683292f, -0.01299642f, -0.00357451f, 0.01552524f, 0.00737529f, -0.00908431f, -0.00872977f, 0.02081368f, 
    -0.00235691f, -0.02291924f, -0.03460872f, -0.03452237f, -0.03747282f, -0.01259952f, -0.02480208f, 0.01739585f, 
    -0.01401171f, 0.01453573f, 0.00091804f, -0.01064030f, 0.02301582f, 0.00310548f, -0.02134123f, 0.02092887f, 
    -0.00382422f, -0.01068706f, -0.00646283f, -0.02999720f, -0.01659627f, 0.02426298f, -0.01057118f, -0.00068161f, 
    -0.04094354f, 0.00565530f, 0.02167012f, -0.01999114f, -0.01508075f, -0.02542850f, 0.00927640f, 0.02131654f, 
    0.01319231f, 0.02439759f, 0.03089446f, -0.01161221f, -0.00709528f, -0.01676679f, 0.03205037f, -0.03508972f, 
    -0.02424514f, 0.03243294f, -0.03758881f, 0.01000404f, -0.03023883f, 0.00458026f, 0.00033655f, -0.01325144f, 
    -0.00439441f, -0.00867347f, 0.01526697f, -0.01451616f, 0.00442561f, -0.00512735f, -0.00950539f, -0.02895805f, 
    0.00378513f, -0.00822599f, -0.03314902f, 0.02480839f, 0.01377543f, -0.02892293f, 0.01041107f, -0.00785022f, 
    -0.03725342f, 0.00160835f, -0.03854496f, -0.00228815f, 0.01104463f, 0.01541578f, 0.00366926f, -0.00399616f, 
    -0.01357301f, -0.03809019f, -0.00704011f, 0.02125573f, 0.02166366f, -0.02120710f, 0.00468105f, 0.00426937f, 
    -0.03204611f, 0.00913760f, 0.03004649f, -0.02844649f, -0.01866752f, -0.02526757f, 0.01142322f, 0.02817237f, 
    0.00555150f, -0.03669592f, 0.00618966f, -0.02560143f, -0.00582358f, -0.03095398f, -0.03144007f, 0.01530262f, 
    0.04174187f, -0.00771238f, 0.02152210f, -0.03056208f, -0.01204811f, -0.03803755f, -0.02273924f, -0.00714536f, 
    -0.04219678f, 0.01817087f, -0.02346948f, 0.02000938f, -0.03649524f, -0.02623473f, -0.03446992f, 0.02849372f, 
    0.02099886f, -0.03767424f, -0.03899768f, -0.01268688f, -0.01244348f, -0.02304159f, 0.02140988f, 0.01602924f, 
    -0.01663275f, -0.02155682f, -0.00844805f, -0.00157835f, -0.02811572f, 0.01424268f, 0.01094932f, -0.02697078f, 
    0.00042037f, -0.00066338f, -0.02305602f, 0.00893023f, 0.01333039f, -0.01382483f, -0.01620459f, -0.01051731f, 
    -0.03425746f, -0.01523567f, 0.02908086f, -0.01019030f, -0.00734050f, -0.01372962f, -0.01179773f, 0.01664295f, 
    0.01170249f, 0.02512230f, -0.00235827f, -0.00239755f, 0.00558011f, -0.03636416f, 0.00864246f, -0.01624188f, 
    -0.02543323f, -0.04238289f, -0.01687102f, 0.01588945f, -0.04337323f, 0.02108275f, -0.02285606f, 0.02656366f, 
    0.01987684f, 0.01375572f, -0.03447468f, -0.01003535f, 0.00317886f, 0.00084196f, 0.00114048f, 0.01273939f, 
    -0.01319954f, 0.01995617f, 0.00197283f, 0.01993531f, -0.02231637f, 0.02324226f, 0.02386603f, -0.01885942f, 
    -0.01291544f, 0.01283770f, -0.02712394f, -0.01189175f, -0.01926043f, 0.00235632f, 0.01688995f, -0.03875057f, 
    0.01205798f, 0.01568486f, -0.00616601f, 0.01831167f, -0.02376723f, 0.01442047f, 0.00822326f, -0.00290603f, 
    0.00682729f, -0.00325648f, -0.04154665f, 0.00469015f, -0.02954115f, -0.01415976f, -0.02816137f, 0.02212317f, 
    0.03087470f, 0.00421655f, 0.01144939f, -0.00215715f, -0.04652681f, 0.00961604f, -0.01516368f, 0.02857835f, 
    0.01168204f, 0.00726745f, 0.02038386f, 0.02105716f, -0.00766627f, -0.03317560f, -0.00053973f, 0.00100046f, 
    -0.02864745f, -0.00434517f, -0.00245084f, -0.03173922f, -0.04197128f, 0.02686901f, -0.02216868f, -0.02916448f, 
    -0.02141900f, -0.01237711f, 0.01870239f, 0.01928117f, -0.01265640f, -0.01807058f, -0.03852822f, -0.02818987f, 
    0.00881835f, -0.03459042f, -0.01977544f, -0.02147141f, -0.00499686f, -0.01093850f, -0.01904179f, 0.00534550f, 
    0.01492694f, -0.02595183f, -0.03609925f, -0.01819180f, -0.00551439f, -0.02828965f, 0.02769649f, -0.00483299f, 
    -0.00326734f, 0.01090829f, -0.02053327f, 0.01203943f, 0.02879202f, 0.01959572f, 0.02529583f, 0.01386346f, 
    0.00443086f, -0.03568060f, 0.01622437f, -0.02363199f, -0.01229999f, 0.00358696f, -0.01655479f, 0.03521271f, 
    0.03122720f, 0.02013632f, 0.00800568f, -0.00903249f, -0.03897202f, 0.01200400f, 0.01486328f, -0.02688119f, 
    -0.02353952f, -0.03154293f, 0.01802651f, -0.02114666f, -0.00741430f, -0.02730647f, -0.02591561f, 0.01484466f, 
    -0.02424414f, -0.01255650f, -0.00320191f, 0.01883217f, -0.00392382f, -0.01821202f, -0.03240072f, -0.00306230f, 
    -0.00561993f, 0.00086724f, 0.01862982f, 0.00633537f, 0.00249834f, -0.04622085f, -0.00643944f, 0.02076692f, 
    -0.01334416f, -0.00260478f, -0.01754680f, 0.03481854f, -0.02923179f, 0.00980977f, -0.00978005f, 0.02825526f, 
    -0.04298694f, -0.01078083f, 0.02088169f, 0.02904470f, 0.00502813f, 0.00248778f, -0.00201069f, 0.02329047f, 
    -0.02898388f, -0.00020898f, -0.03575664f, -0.00546641f, 0.02602722f, -0.01943670f, 0.01039292f, -0.01760226f, 
    0.00639705f, -0.04214258f, 0.02104572f, 0.02068527f, -0.01661625f, 0.02624147f, 0.01652352f, -0.03447939f, 
    -0.02448211f, -0.03777683f, -0.03642766f, -0.02248783f, 0.00103720f, -0.02258687f, -0.03805679f, -0.03317894f, 
    -0.02050067f, 0.00242531f, 0.02051831f, -0.03752295f, 0.01180843f, 0.02142644f, -0.01826279f, 0.02457447f, 
    -0.04316123f, -0.02960338f, 0.01736951f, 0.02246409f, -0.01387157f, -0.02771023f, 0.01971360f, -0.03532784f, 
    0.02491628f, 0.00710608f, 0.00537894f, 0.01304576f, -0.04553584f, 0.02616059f, -0.02030097f, 0.01348496f, 
    -0.00755372f, 0.02182816f, -0.01127591f, 0.01974974f, -0.03019737f, -0.02090369f, 0.01786296f, 0.00907979f, 
    -0.03045420f, 0.00685168f, 0.00925586f, 0.00097561f, -0.03641659f, -0.01973042f, -0.02017174f, 0.01634351f, 
    -0.03056431f, -0.00093406f, 0.02796728f, 0.00846697f, -0.02989517f, 0.00989522f, 0.02443240f, 0.01114094f, 
    -0.03318262f, 0.00976712f, 0.00426820f, 0.01695341f, -0.03802495f, 0.01259709f, -0.02828970f, -0.00433699f, 
    0.00672322f, 0.02412174f, 0.02884387f, 0.00379389f, 0.00462287f, -0.01965499f, 0.02618628f, 0.00880662f, 
    -0.02434415f, -0.04065425f, -0.01407692f, -0.01378174f, -0.01860946f, -0.03304704f, -0.00862604f, -0.01224419f, 
    0.01541420f, -0.03387012f, -0.01629816f, -0.03948152f, -0.01925779f, 0.01573114f, -0.03768846f, -0.03981452f, 
    0.03141655f, -0.03425450f, 0.01319326f, -0.03997321f, 0.02272963f, -0.00466560f, 0.02660180f, 0.02695973f, 
    0.00174070f, 0.01230618f, 0.00466234f, -0.03274505f, 0.00259623f, -0.03509594f, -0.00434541f, -0.00622571f, 
    0.01321742f, -0.02099629f, -0.03658466f, 0.02345842f, 0.01815386f, -0.00206204f, -0.03132576f, 0.00801241f, 
    0.01208710f, 0.01901480f, 0.02130946f, 0.02841120f, -0.00618010f, 0.00116668f, 0.00706475f, 0.00813502f, 
    0.03044661f, 0.02563425f, 0.00717502f, -0.03330794f, -0.02235377f, -0.02372234f, -0.01311820f, -0.03146407f, 
    -0.00435359f, -0.00516475f, -0.01121954f, -0.04260236f, -0.01619369f, 0.02269087f, 0.00682467f, 0.00836801f, 
    -0.03249069f, 0.00417881f, -0.01352009f, 0.02461734f, -0.00657244f, -0.04600270f, -0.00175629f, -0.02413988f, 
    -0.04012761f, -0.01852617f, 0.01754533f, -0.03451548f, 0.00589253f, 0.01815253f, -0.04648165f, -0.03559473f, 
    0.18619266f, -0.26375064f, -0.10745490f, -0.05296477f, -0.01030886f, 0.07325069f, 0.03704068f, 0.10923703f, 
    -0.06103816f, -0.03054465f, 0.04808721f, -0.02471857f, 0.55357075f, -0.25775456f, 0.05610029f, -0.17236952f, 
    -0.00571858f, 0.10208924f, 0.01676404f, 0.10179329f, 0.02585761f, -0.06870325f, 0.03266593f, 0.00526711f, 
    -0.21767639f, -0.27591112f, -0.19886033f, 0.00229421f, -0.09096769f, 0.12135803f, -0.02905967f, -0.03581976f, 
    0.05950397f, 0.06808740f, 0.00009377f, 0.08572561f, 0.00564637f, 0.10959538f, 0.01529527f, 0.24117349f, 
    0.00681658f, 0.02461332f, 0.04926241f, -0.08685510f, 0.02216579f, 0.07018819f, -0.08106039f, 0.04721233f, 
    0.32258630f, -0.23954663f, -0.07514206f, -0.03909875f, 0.06774544f, 0.03041670f, -0.01928036f, 0.00042692f, 
    0.10097338f, 0.16170658f, 0.10130011f, -0.02190623f, -0.06873965f, -0.13242932f, -0.12640184f, 0.37420839f, 
    -0.01617623f, 0.08050214f, 0.07342397f, 0.00926381f, 0.01952602f, 0.05150696f, 0.00289938f, -0.11230507f, 
    0.24632761f, 0.14616005f, 0.08046244f, -0.07903633f, 0.00666497f, -0.05434751f, 0.00889074f, 0.00977278f, 
    0.00777496f, 0.06933660f, -0.10737532f, 0.05194785f, -0.10556009f, 0.20890304f, -0.00079692f, 0.46223971f, 
    0.00653087f, -0.09887637f, 0.10211434f, 0.02854893f, 0.00847402f, -0.04948049f, -0.01049194f, -0.14279239f, 
    -0.16330114f, -0.26267081f, -0.00675786f, -0.07631855f, 0.03599839f, 0.01429950f, -0.00367514f, -0.06595095f, 
    -0.11647248f, -0.00146879f, 0.02010387f, 0.12172496f, -0.40463212f, -0.21297909f, -0.12381710f, -0.23475426f, 
    -0.00114691f, 0.01964726f, -0.04811116f, -0.14021704f, -0.02369088f, -0.12847611f, -0.00292315f, -0.01802778f, 
    -0.17086355f, 0.04641422f, -0.18084499f, 0.06105196f, 0.03447455f, -0.09160078f, 0.01825537f, -0.10176758f, 
    -0.06091569f, 0.05974282f, -0.06419154f, 0.01704109f, 0.13349545f, -0.05560888f, -0.10879483f, 0.31502959f, 
    0.12005421f, -0.06272710f, -0.07171740f, 0.04781351f, -0.09617762f, -0.02691346f, -0.02186416f, -0.12749021f, 
    -0.19157197f, -0.17826085f, 0.03540485f, -0.03506061f, 0.07167524f, -0.03142653f, 0.02353967f, -0.05152250f, 
    0.06440739f, 0.00726127f, 0.15227601f, 0.01083811f, 0.19437507f, 0.10665698f, 0.11098983f, -0.26607516f, 
    0.00381966f, 0.01220379f, 0.02198944f, 0.04234542f, 0.05147926f, -0.01284269f, 0.06007775f, 0.05353954f, 
    0.14808084f, 0.01343826f, 0.09044617f, -0.08240481f, 0.07352589f, 0.18084699f, -0.11549223f, -0.02857696f, 
    0.17210978f, 0.03525440f, -0.18164879f, -0.02925581f, -0.00544407f, 0.04086747f, 0.07248134f, 0.05525467f, 
    0.03578291f, -0.02808944f, 0.05500618f, -0.05290820f, 0.11645726f, -0.04244477f, -0.05337303f, -0.01159234f, 
    0.01594321f, -0.20193085f, -0.34830016f, -0.03906662f, 0.06310853f, -0.04232467f, 0.01017143f, -0.02611072f, 
    -0.03827893f, -0.02408388f, 0.07682300f, 0.06361707f, 0.01915326f, -0.36586434f, -0.07525031f, -0.05474240f, 
    0.08142213f, 0.00114009f, -0.05706050f, 0.05171389f, -0.07501806f, 0.02679544f, -0.00706784f, 0.07953201f, 
    0.12437150f, -0.06391884f, -0.06208150f, -0.01203065f, 0.01818444f, -0.11744519f, 0.05516786f, -0.01819483f, 
    0.03952033f, 0.00046324f, 0.01157613f, 0.08466037f, -0.01990762f, -0.14197630f, -0.06203108f, -0.03922838f, 
    0.00283632f, 0.00832372f, -0.09402352f, 0.01413845f, 0.09893899f, 0.01322376f, -0.00745219f, -0.03084869f, 
    -0.07646421f, -0.14863162f, -0.31971157f, 0.16218084f, -0.03274726f, 0.03220446f, -0.03790559f, -0.03308365f, 
    -0.12530109f, -0.06140262f, -0.09029678f, -0.05080155f, -0.09634259f, 0.24808669f, 0.10534278f, 0.07723783f, 
    -0.02828442f, 0.05771336f, 0.01120594f, 0.03635180f, -0.02095317f, 0.04909030f, -0.03506823f, 0.00579083f, 
    0.11585109f, 0.17972668f, 0.22137721f, -0.31859139f, 0.01569592f, 0.02491532f, -0.02048754f, -0.05245143f, 
    -0.05536982f, 0.01516966f, -0.04862830f, 0.02559456f, 0.06102008f, 0.12756480f, 0.04602830f, 0.21516974f, 
    0.00509442f, 0.04172302f, 0.17932598f, -0.03159334f, 0.02022294f, -0.02235670f, -0.02585571f, 0.01316898f, 
    -0.20002076f, 0.03957237f, -0.03641145f, -0.12673107f, 0.08637531f, 0.05656373f, 0.16014327f, 0.03471416f, 
    0.06985426f, 0.05242484f, 0.00867641f, -0.09696437f, -0.05300959f, 0.07439436f, 0.01857845f, 0.19825979f, 
    0.16303737f, 0.06650504f, 0.02563772f, 0.15516964f, 0.04299992f, -0.00729581f, 0.05329928f, 0.02734962f, 
    -0.16265094f, -0.03727556f, -0.24794513f, 0.01042253f, -0.00430371f, -0.03141373f, -0.00337533f, -0.17274730f, 
    0.00188768f, -0.02908040f, -0.09346709f, -0.08452671f, 0.22365211f, 0.03119096f, 0.04042369f, -0.03282028f, 
    0.00110070f, 0.02543154f, 0.00683261f, -0.04121066f, 0.02504193f, 0.01455678f, -0.07050400f, -0.10945421f, 
    0.41789290f, -0.31500566f, 0.07480789f, -0.12097450f, -0.01154528f, -0.02776725f, 0.04004800f, 0.01282960f, 
    0.03925635f, 0.01865064f, 0.06058205f, 0.03717785f, -0.21833245f, -0.23034887f, -0.20732415f, -0.19246553f, 
    -0.05144068f, -0.03631673f, 0.01473662f, -0.07414080f, 0.06166026f, 0.06934433f, 0.05597173f, -0.04881453f, 
    -0.02331935f, 0.17240991f, 0.03077816f, -0.07610253f, 0.04305986f, -0.01160225f, -0.01686007f, -0.15358651f, 
    -0.04007302f, 0.07030846f, 0.14939897f, 0.03514303f, -0.19788587f, 0.35481638f, 0.16145490f, -0.06895078f, 
    0.01778322f, 0.02679750f, 0.08496211f, -0.04048912f, -0.01270213f, 0.04462137f, -0.01684593f, -0.02008944f, 
    0.01237727f, 0.00071130f, -0.05508296f, -0.12256604f, -0.10384136f, -0.09792723f, 0.01633297f, -0.02752195f, 
    -0.03494921f, -0.00941007f, 0.09534332f, 0.08172843f, 0.07218652f, -0.30841655f, 0.01505865f, -0.12585206f, 
    0.09303350f, -0.03358697f, -0.02307828f, 0.01388738f, 0.02131450f, -0.06176885f, -0.07429902f, 0.07813796f, 
    -0.05154901f, -0.05247584f, 0.24323612f, 0.31378856f, 0.07096080f, 0.01792315f, -0.07549371f, -0.02335809f, 
    0.09026859f, -0.01252608f, 0.01164298f, 0.00626750f, 0.00997007f, -0.00551222f, 0.10951781f, 0.16199653f, 
    0.04396207f, 0.08833997f, 0.03291798f, -0.01719699f, -0.00605592f, 0.08682495f, -0.02915344f, 0.03711262f, 
    -0.18266630f, 0.38293865f, 0.09233804f, -0.36060137f, -0.01107782f, 0.05902585f, -0.02708072f, -0.06973587f, 
    0.06544744f, 0.00123504f, 0.00211069f, -0.02083134f, -0.04719939f, -0.21322571f, -0.19866182f, 0.01785485f, 
    0.02699278f, -0.11640467f, -0.06029525f, -0.12207238f, -0.01463281f, 0.08902831f, -0.16307196f, 0.03422626f, 
    0.23638104f, -0.10576437f, -0.06641616f, 0.09359813f, 0.00656087f, 0.00388612f, 0.02885166f, 0.00132131f, 
    0.09324767f, -0.11483265f, -0.01333446f, -0.10144696f, -0.24594685f, 0.17507762f, 0.09417061f, -0.04463552f, 
    0.03248372f, 0.02941097f, 0.03301372f, 0.10633945f, -0.09244947f, -0.05329210f, 0.04938431f, 0.03937659f, 
    -0.20248462f, -0.07229815f, 0.01374965f, 0.13664220f, 0.10097630f, 0.05601318f, -0.01216087f, -0.00750029f, 
    -0.00439409f, -0.04755883f, 0.03967467f, -0.01379414f, -0.12921523f, 0.12600605f, 0.00066405f, -0.21325281f, 
    0.12414026f, 0.05436972f, 0.03106920f, 0.00882998f, 0.01552090f, -0.01238244f, -0.12848008f, -0.04317790f, 
    0.10847860f, 0.17162733f, 0.12478868f, 0.03963558f, 0.10894762f, -0.05367469f, -0.03408569f, -0.09297117f, 
    -0.10998105f, -0.03624806f, 0.02606415f, 0.12722826f, -0.05961616f, -0.02560659f, -0.00738045f, 0.05056463f, 
    -0.01514101f, 0.07889658f, 0.02429722f, -0.02985735f, 0.06797126f, 0.04851512f, -0.15057218f, 0.04098704f, 
    0.42417648f, -0.23296735f, -0.02235886f, -0.04406083f, 0.10279351f, 0.07507952f, 0.10462935f, 0.05490901f, 
    0.03934555f, 0.10098686f, 0.04991646f, 0.03002961f, 0.01349988f, -0.06503826f, 0.01357236f, 0.23747168f, 
    0.01501247f, 0.09975773f, 0.06997779f, 0.10081133f, -0.01885278f, 0.05168822f, -0.02242886f, -0.06494951f, 
    -0.03991652f, -0.10575081f, 0.12712052f, -0.00469572f, -0.08092128f, -0.01091950f, -0.07019083f, -0.00382586f, 
    0.05722362f, -0.05772818f, -0.03358684f, -0.02299996f, -0.19027317f, -0.04071354f, 0.03196463f, -0.18082400f, 
    -0.04122348f, -0.00673897f, -0.02007142f, 0.00176322f, 0.06133561f, 0.13274260f, 0.06053045f, 0.00638294f, 
    -0.01742466f, 0.10009862f, 0.07300676f, -0.01034347f, -0.05922175f, 0.01724341f, -0.04152760f, 0.04902520f, 
    -0.02413066f, -0.02401968f, -0.04694020f, 0.09805865f, 0.12488926f, -0.11664415f, 0.11261166f, -0.23708685f, 
    0.08564240f, -0.04007049f, -0.02904442f, -0.02552429f, 0.05529378f, 0.04123553f, 0.04192920f, 0.01953187f, 
    0.05594317f, 0.14014207f, -0.14589715f, -0.21559806f, -0.10317340f, 0.00117482f, 0.06284340f, 0.11851565f, 
    0.07317030f, 0.09114201f, -0.04221915f, 0.00944704f, 0.10139413f, 0.18722375f, 0.10362446f, -0.15496591f, 
    0.02351031f, 0.06667473f, 0.04313559f, -0.07506134f, 0.07760826f, -0.02926648f, -0.04382809f, 0.01932416f, 
    0.03412340f, 0.13253397f, 0.17929822f, -0.02822348f, -0.03660704f, 0.03308111f, 0.02670770f, -0.08042759f, 
    0.00309723f, 0.05379663f, -0.00922748f, 0.06635954f, -0.05030182f, -0.02821889f, -0.18587153f, 0.14840813f, 
    0.03781481f, -0.04098274f, -0.04546623f, 0.02092022f, 0.02824957f, -0.00269810f, 0.02290465f, 0.04806577f, 
    0.10175502f, -0.01046385f, 0.07412308f, -0.13521923f, -0.08433326f, 0.05962171f, -0.05585124f, -0.00970546f, 
    -0.01592498f, 0.05290952f, -0.05226345f, 0.01425593f, -0.03896575f, 0.07541294f, -0.03116796f, 0.04977510f, 
    -0.01486943f, 0.08532254f, 0.09780671f, -0.02072807f, -0.02585225f, -0.08991862f, -0.03950621f, 0.12667623f, 
    0.11073318f, -0.24401079f, 0.08922559f, -0.07036778f, 0.03477996f, 0.08621789f, -0.07725993f, -0.10400357f, 
    -0.00165040f, 0.03485222f, 0.04808072f, 0.12647419f, 0.17188971f, -0.06348460f, 0.19617893f, -0.09212523f, 
    -0.00933707f, 0.03698063f, 0.07398359f, -0.05248874f, -0.00543819f, 0.04034758f, 0.04066200f, 0.09104412f, 
    0.29866737f, -0.02935998f, 0.01253230f, 0.06749684f, 0.18814421f, -0.05313021f, 0.07239951f, 0.00409207f, 
    -0.01183666f, -0.07193147f, -0.04375761f, -0.01534229f, -0.02562503f, -0.03893659f, -0.07604231f, 0.00143239f, 
    -0.05680163f, 0.05226656f, 0.00751075f, 0.03717086f, -0.01612930f, 0.13905795f, 0.06294893f, 0.07769408f, 
    0.14493564f, -0.10177060f, -0.24756031f, -0.28566119f, -0.05141493f, 0.16149555f, -0.00331590f, 0.01902104f, 
    -0.03221089f, -0.05835708f, -0.00445935f, 0.06753971f, -0.19665290f, -0.25527698f, -0.14476344f, 0.02887214f, 
    0.01416990f, 0.03932587f, -0.05800766f, -0.02627235f, -0.12685767f, 0.05776963f, 0.21550220f, -0.00140787f, 
    0.02040970f, -0.04381640f, -0.06253424f, 0.12733702f, 0.16293672f, -0.01925056f, -0.07859827f, 0.03770186f, 
    -0.08843920f, -0.06610796f, 0.04098455f, 0.01233144f, -0.23097394f, 0.13580406f, 0.08017263f, 0.05743683f, 
    0.14474125f, 0.11176940f, 0.07746610f, 0.08027481f, -0.04418323f, -0.00089898f, -0.11696253f, 0.03800708f, 
    0.02338229f, -0.02547274f, 0.01340227f, 0.00391833f, -0.00070339f, -0.02041054f, -0.01696323f, 0.02112245f, 
    0.03165129f, -0.01934204f, 0.00432098f, -0.01918005f, -0.03145793f, 0.02386981f, 0.00154684f, -0.03421459f, 
    -0.02143189f, 0.03697452f, 0.00102580f, 0.02109184f, 0.01589507f, -0.01495818f, -0.03698295f, -0.02923814f, 
    0.02333559f, -0.02841114f, 0.01281477f, -0.03113755f, -0.01948746f, -0.00890535f, 0.00774482f, 0.01104353f, 
    0.01754406f, -0.01210765f, -0.01266530f, -0.02974973f, -0.03184652f, 0.01607963f, 0.02941700f, -0.02015500f, 
    -0.02546191f, 0.02238467f, 0.02831616f, -0.00942705f, -0.02898088f, -0.00561643f, -0.03154279f, -0.01582372f, 
    -0.00166742f, -0.02231814f, -0.02120676f, 0.04180593f, -0.01288910f, -0.01986375f, -0.01662724f, -0.01042014f, 
    0.03036052f, -0.00445066f, -0.03850883f, 0.01540471f, -0.00037446f, 0.03179419f, -0.01979759f, 0.01961548f, 
    -0.01428664f, 0.01110636f, 0.03249193f, -0.02065524f, 0.01480135f, -0.03284011f, 0.00358906f, 0.01145536f, 
    -0.02879837f, 0.00606683f, 0.02987358f, -0.02769090f, -0.02753660f, -0.01548316f, 0.03149321f, -0.00723628f, 
    -0.00934356f, 0.00006284f, -0.03654512f, 0.02184687f, -0.01600474f, 0.00054992f, 0.00995102f, 0.02727637f, 
    -0.01572143f, 0.00126798f, 0.01254789f, -0.01491297f, 0.01023254f, -0.00878003f, -0.02488310f, -0.03318037f, 
    -0.02192022f, -0.03319812f, 0.03845712f, -0.02565933f, 0.00423103f, 0.02668576f, 0.02992366f, -0.02612446f, 
    0.02735649f, 0.01183870f, 0.00838295f, -0.02260162f, 0.00596904f, -0.00633832f, -0.01166236f, -0.02828382f, 
    0.01587614f, -0.01917856f, 0.01825314f, -0.03335402f, 0.02230014f, -0.02369958f, -0.01193864f, -0.02578592f, 
    0.03101185f, 0.03625587f, -0.00039726f, 0.00147262f, 0.01093526f, 0.02227864f, -0.01861835f, -0.01461950f, 
    -0.03569233f, -0.02059299f, -0.01368293f, 0.00062146f, 0.03492418f, -0.03456762f, -0.01045733f, -0.02563183f, 
    0.00494359f, -0.00950261f, -0.03549262f, -0.00222011f, 0.01169969f, -0.00154849f, -0.01515998f, -0.00028470f, 
    0.03447549f, -0.01686913f, 0.00157700f, 0.02535129f, -0.03127456f, -0.00089186f, -0.01865240f, 0.02489690f, 
    0.02461656f, -0.02639730f, 0.00658805f, 0.03363555f, -0.00608392f, -0.01792794f, -0.00891784f, -0.01699761f, 
    -0.03039060f, 0.02853173f, 0.02278445f, -0.01154177f, -0.01580183f, 0.03384754f, 0.02360157f, 0.00891496f, 
    -0.01213342f, 0.00809802f, -0.03860120f, -0.03122745f, 0.03282164f, 0.01410876f, -0.00651056f, 0.01713211f, 
    0.03311734f, -0.02310011f, 0.02550635f, 0.02821805f, 0.01779632f, -0.00011342f, 0.01242208f, -0.00035578f, 
    0.02871843f, -0.02169969f, 0.01328957f, 0.00092451f, -0.01991808f, -0.02146567f, -0.01542138f, 0.02778925f, 
    -0.02694847f, 0.02352995f, -0.01069030f, -0.02804872f, -0.01327163f, -0.01569830f, -0.03522909f, -0.02457171f, 
    -0.00571439f, 0.00351024f, 0.02738620f, -0.02541568f, -0.03283155f, 0.02129339f, 0.00698049f, -0.01517577f, 
    0.00967446f, -0.01787544f, -0.02108802f, 0.01204906f, -0.02246340f, -0.01697049f, -0.00628316f, -0.03331618f, 
    -0.01358836f, 0.01891777f, 0.00825993f, 0.03575224f, -0.00066371f, -0.00247000f, -0.00224123f, 0.02833437f, 
    -0.02997572f, 0.02142806f, 0.00210022f, -0.02822934f, 0.02410275f, -0.02141186f, -0.00602562f, 0.00774871f, 
    -0.01841171f, 0.03034538f, -0.01787318f, -0.00639595f, -0.02973823f, -0.03669653f, 0.02773044f, -0.01489353f, 
    -0.02879732f, -0.02138259f, -0.00953486f, -0.00471814f, -0.04058164f, -0.02641835f, -0.02049675f, 0.00900982f, 
    0.00723003f, 0.02657536f, -0.00754032f, -0.03347079f, 0.03061316f, -0.00646132f, -0.03449220f, -0.01499315f, 
    -0.03349004f, -0.03184230f, 0.00742338f, -0.03953069f, 0.02437494f, 0.01059194f, 0.00091470f, -0.03046987f, 
    0.00526281f, -0.02243292f, -0.01754944f, -0.01536653f, -0.00901200f, -0.02722277f, 0.02175600f, 0.00646806f, 
    0.03196798f, 0.01309676f, 0.02308581f, 0.00668283f, 0.01477068f, 0.01035117f, -0.03119486f, -0.02374181f, 
    0.02619951f, 0.01566295f, -0.00310630f, 0.02035948f, -0.01296120f, -0.02911543f, 0.03490176f, -0.00954152f, 
    -0.01827744f, 0.00222664f, 0.00540175f, -0.03253793f, 0.00383158f, -0.00442972f, -0.00612432f, 0.01140030f, 
    0.02260783f, -0.02383836f, -0.01074430f, -0.00488936f, -0.01233405f, -0.01268064f, 0.00681564f, 0.00329492f, 
    0.02377704f, -0.03704509f, -0.00552635f, -0.00922844f, 0.01473622f, -0.00172721f, -0.02950365f, -0.03758234f, 
    -0.02867827f, -0.03655477f, -0.03486586f, -0.02598607f, 0.02808736f, -0.02086163f, -0.03015188f, 0.02295325f, 
    -0.00238519f, 0.02582651f, 0.02955096f, 0.00537695f, -0.02524843f, -0.03508437f, -0.00979610f, 0.02348104f, 
    -0.00893591f, 0.01121531f, 0.02591329f, -0.01911847f, 0.00098456f, -0.02289598f, 0.02406325f, -0.02219416f, 
    0.00598903f, 0.03662657f, 0.03031582f, -0.00759849f, -0.01035412f, -0.00165367f, 0.01338346f, 0.01757413f, 
    0.00038195f, -0.02156215f, -0.01635205f, -0.01756275f, 0.01204871f, 0.00089400f, -0.01561566f, -0.01992200f, 
    -0.02543924f, -0.01454547f, -0.03203100f, -0.03052192f, -0.01432436f, -0.03605144f, 0.02291423f, -0.01012422f, 
    -0.03536354f, -0.03382961f, -0.02080277f, -0.03605078f, 0.00930289f, -0.02100928f, -0.03915272f, -0.01737504f, 
    0.00886414f, 0.03098037f, -0.00324702f, 0.00814354f, -0.01932090f, 0.03046853f, 0.01497199f, -0.01050869f, 
    0.02322695f, 0.00000929f, -0.02247082f, -0.00584266f, 0.02157406f, -0.01781974f, 0.02655615f, 0.01635169f, 
    0.00925815f, 0.04289670f, -0.01487443f, -0.03311590f, -0.01893760f, 0.03116490f, -0.02739339f, -0.00801763f, 
    -0.03250840f, 0.00229842f, -0.01802119f, 0.01278073f, -0.03747143f, 0.00330090f, -0.02547043f, -0.03816956f, 
    0.00104643f, 0.00389720f, -0.02010707f, -0.02710470f, -0.01846964f, 0.00005290f, 0.00668064f, -0.02798134f, 
    0.00597208f, 0.02005927f, 0.02580294f, -0.00643715f, 0.01551338f, 0.00454942f, -0.02009091f, -0.00376089f, 
    0.01055524f, 0.03684812f, -0.02973034f, 0.00407464f, -0.01162346f, 0.03453628f, -0.02455968f, -0.03336758f, 
    -0.01920201f, 0.00221209f, -0.03334089f, 0.01009971f, -0.00770229f, -0.02985859f, -0.00302653f, -0.02860641f, 
    0.00848570f, -0.00576802f, 0.00614185f, -0.00145237f, -0.03722137f, 0.02459904f, 0.02057185f, -0.03634696f, 
    -0.03652895f, -0.01474526f, -0.01428898f, -0.02483338f, -0.02529385f, -0.01865369f, -0.01472162f, 0.00377067f, 
    0.03358150f, 0.01908686f, -0.02252733f, -0.02240364f, -0.03748271f, 0.02736866f, 0.00255930f, -0.02307682f, 
    0.00829388f, -0.01026687f, -0.01295208f, -0.00094752f, -0.04012870f, -0.01382723f, 0.02677752f, 0.00481528f, 
    -0.00057304f, -0.03349291f, -0.03570979f, -0.02700279f, 0.01644920f, 0.01365016f, 0.00762507f, -0.01306764f, 
    0.00270985f, -0.00307688f, 0.01466206f, -0.03128327f, -0.03550122f, 0.01985637f, 0.01235347f, -0.01968644f, 
    -0.02706550f, 0.00060190f, -0.02491567f, 0.02524832f, 0.01328124f, 0.02370851f, 0.00628769f, 0.00024679f, 
    0.02055674f, 0.03342691f, 0.00165411f, -0.02276330f, -0.02608079f, -0.02321240f, -0.01939276f, 0.00845771f, 
    -0.03022523f, -0.02429233f, 0.01713214f, -0.03504121f, 0.00836986f, -0.00632646f, 0.02228597f, -0.02571900f, 
    0.01343557f, -0.00383620f, -0.03085858f, -0.02661121f, -0.01018032f, 0.02607380f, 0.03006614f, -0.03387454f, 
    0.02320074f, 0.02088095f, -0.02606715f, 0.00980779f, -0.02131930f, -0.00835211f, -0.01366706f, 0.03251296f, 
    -0.01479758f, 0.01340777f, -0.03261628f, 0.01879893f, -0.00495333f, 0.01349781f, 0.02637114f, -0.00747073f, 
    0.00393756f, -0.00855120f, 0.02067542f, 0.01036585f, 0.02199048f, -0.01353821f, -0.03214950f, 0.01176758f, 
    0.00231822f, -0.00332527f, 0.01321891f, 0.00140410f, 0.02626875f, -0.02338064f, 0.01748104f, -0.01419881f, 
    0.00365314f, 0.02225795f, 0.00231633f, 0.03500098f, 0.00472014f, -0.01160950f, 0.00655969f, -0.01134276f, 
    -0.01661422f, 0.01836367f, 0.01935143f, -0.03049847f, 0.02591285f, -0.00937876f, 0.01828407f, 0.01197219f, 
    -0.02420318f, -0.01375034f, 0.01741495f, -0.01541902f, -0.00648230f, -0.02725250f, 0.02323814f, 0.02259462f, 
    -0.02503866f, -0.00082966f, 0.02287624f, -0.02482453f, -0.01769713f, 0.01846559f, 0.02430237f, -0.01868078f, 
    -0.03598427f, -0.01169660f, -0.00731282f, -0.01027291f, -0.00905615f, 0.01184790f, -0.01155169f, -0.00420017f, 
    0.02857347f, 0.01201040f, -0.03808773f, 0.01993295f, -0.00952158f, -0.01611285f, 0.03318747f, -0.01363839f, 
    0.01167573f, 0.02673071f, -0.03565961f, 0.01622829f, -0.01760460f, -0.00127635f, 0.01591508f, -0.01750043f, 
    -0.03710084f, 0.00365306f, -0.03057965f, 0.00771405f, -0.00427884f, -0.00873877f, -0.00835263f, -0.01759361f, 
    0.03096675f, 0.00894661f, -0.00186316f, -0.00284199f, 0.00084166f, 0.03181184f, 0.00612190f, 0.03278246f, 
    -0.03792843f, 0.02735365f, -0.00195567f, 0.02306906f, -0.01693505f, -0.02526578f, -0.03732251f, -0.00825077f, 
    0.01934524f, 0.01285953f, 0.00477802f, -0.01099407f, 0.00068877f, -0.03637995f, -0.01843368f, -0.01519241f, 
    0.02101155f, -0.02528045f, 0.02847216f, 0.01719564f, -0.00201520f, 0.02153160f, 0.02912535f, -0.02170367f, 
    0.01310554f, -0.01079502f, -0.03849688f, 0.01097229f, 0.01048703f, 0.02448436f, -0.01382622f, 0.02379065f, 
    -0.00538321f, 0.01463460f, -0.00043531f, 0.02003017f, -0.03563977f, 0.02109837f, -0.02552474f, 0.00698781f, 
    -0.02405095f, 0.02226829f, -0.01715368f, -0.02542816f, 0.02677994f, -0.03049006f, 0.00674311f, -0.02619210f, 
    -0.00267302f, 0.01325864f, -0.03728985f, 0.00253584f, 0.02825975f, -0.01455886f, -0.02003171f, 0.02210276f, 
    0.00600126f, -0.01907980f, 0.01077225f, -0.01001183f, -0.00847364f, -0.01881528f, -0.03084799f, 0.01644988f, 
    0.02842544f, -0.01316399f, -0.01118498f, -0.03510548f, -0.02033914f, -0.02780911f, -0.03883291f, 0.02154576f, 
    -0.00487944f, -0.01436235f, -0.03309858f, -0.03045862f, 0.02408578f, -0.02939773f, -0.01015234f, 0.01029765f, 
    -0.00261617f, 0.01591689f, 0.00583107f, 0.00379157f, -0.01053466f, -0.00896604f, -0.00005675f, -0.01774733f, 
    0.01234076f, -0.03151425f, 0.00076138f, 0.01620161f, -0.03715901f, 0.01614685f, -0.02397297f, 0.00172283f, 
    0.01742996f, 0.02755005f, -0.02375372f, -0.02707755f, 0.02158917f, -0.02203038f, -0.01307933f, 0.02996966f, 
    -0.01794737f, 0.01576130f, 0.00453073f, 0.01981538f, -0.03455960f, -0.03250530f, -0.00146653f, 0.02287341f, 
    0.02693537f, -0.00821271f, -0.00775111f, -0.00073725f, -0.02095725f, -0.00832476f, -0.00619499f, -0.01352924f, 
    0.03028594f, -0.02482497f, 0.02656460f, -0.01962218f, 0.03033835f, -0.03004473f, 0.00317237f, -0.02401385f, 
    0.00938616f, 0.03325499f, -0.03366020f, -0.02899895f, 0.02272316f, 0.01178796f, 0.01389019f, 0.02486332f, 
    0.00986937f, -0.00782075f, 0.02632620f, -0.03329081f, 0.01743989f, 0.00832959f, 0.00538138f, 0.00979644f, 
    -0.02301426f, -0.01105142f, 0.00508914f, -0.01940490f, -0.01291634f, 0.02389596f, -0.01398796f, -0.01330163f, 
    0.02316010f, -0.02346775f, 0.00670758f, -0.00513128f, -0.03481742f, -0.04835138f, -0.03411184f, 0.00057849f, 
    -0.04298441f, -0.01986136f, 0.01412003f, -0.00202915f, 0.00267384f, 0.00700189f, -0.05026215f, -0.05899798f, 
    -0.01903329f, -0.04387992f, -0.01887712f, -0.04587420f, 0.03510956f, -0.03409208f, -0.00814763f, -0.03505981f, 
    0.03148702f, -0.02625701f, -0.02058150f, -0.00598944f, -0.06056223f, -0.03788127f, -0.00982708f, -0.03352008f, 
    0.01368798f, -0.02161027f, 0.01524467f, -0.01850454f, -0.00063547f, 0.00734203f, -0.00904300f, -0.02112440f, 
    -0.03099392f, 0.01720404f, -0.01707696f, -0.03112860f, 0.00452742f, 0.01572857f, -0.03733740f, -0.00200174f, 
    -0.02646844f, -0.02400489f, -0.01714855f, -0.00662677f, 0.00900688f, 0.01154228f, -0.02042302f, 0.01520217f, 
    0.01484779f, -0.00906507f, -0.02443167f, -0.02620943f, 0.01923381f, -0.01682236f, 0.03256489f, -0.01959777f, 
    0.02056483f, -0.02436085f, -0.02565768f, 0.02209135f, -0.01023330f, 0.04107090f, 0.00129019f, -0.03919777f, 
    0.00562312f, 0.00685625f, 0.00821267f, -0.00840093f, -0.02738648f, -0.01294347f, -0.01128736f, -0.04250534f, 
    -0.01889673f, -0.00405439f, 0.01399315f, -0.00603884f, -0.01970215f, -0.03814929f, -0.00847575f, 0.01799853f, 
    0.04417429f, 0.01510005f, 0.01063108f, -0.02739411f, 0.02964933f, 0.02835288f, 0.01856325f, 0.02281272f, 
    0.01999324f, -0.03029168f, -0.02231786f, 0.00654821f, -0.02582435f, -0.02832606f, -0.04429644f, 0.00961654f, 
    0.01194319f, 0.00253173f, -0.03692690f, -0.04068843f, 0.01045045f, -0.02487605f, -0.02278779f, -0.03976693f, 
    0.01265621f, 0.00616276f, -0.04189752f, -0.03825888f, 0.03400106f, -0.02159834f, -0.01727492f, -0.05150081f, 
    -0.02740546f, -0.02501030f, -0.00830187f, -0.00440829f, 0.01716421f, -0.04463822f, -0.05088845f, 0.00522905f, 
    0.02443090f, -0.01774129f, -0.01128137f, -0.04861064f, 0.02640547f, -0.03557513f, 0.02148613f, -0.00068561f, 
    -0.01837644f, -0.02169333f, 0.01086145f, 0.00714081f, 0.01663190f, -0.02126672f, 0.02890322f, 0.04045419f, 
    0.03383484f, -0.04249178f, -0.03445824f, 0.00658956f, -0.02277396f, -0.03027623f, -0.03780879f, 0.01074765f, 
    -0.01755695f, 0.03880091f, -0.03315692f, -0.02477485f, 0.00098933f, -0.01523601f, 0.03473903f, -0.03528294f, 
    -0.00888643f, -0.00828276f, 0.01638822f, -0.00310142f, -0.00141674f, 0.02026495f, -0.01959779f, -0.01656662f, 
    -0.02578250f, 0.02665555f, -0.01356434f, -0.01821331f, -0.00482013f, -0.01680092f, -0.01794018f, -0.03645206f, 
    -0.02482623f, -0.02968605f, -0.02327128f, -0.00271138f, 0.02547921f, -0.02261926f, -0.01323413f, -0.03856013f, 
    -0.00271276f, -0.01672078f, -0.00779449f, 0.00349268f, 0.02818665f, -0.01449859f, -0.02321893f, 0.02551946f, 
    -0.03642954f, -0.01370818f, -0.04989512f, -0.01594052f, -0.01493386f, -0.04662782f, -0.00599313f, -0.03390685f, 
    -0.03575392f, 0.00637128f, -0.01620874f, 0.02033529f, -0.02273630f, 0.00826533f, -0.05677397f, -0.05640149f, 
    -0.03095386f, -0.03830167f, -0.04576471f, 0.00290477f, 0.01330324f, -0.01755993f, -0.05490796f, 0.00841317f, 
    -0.01792877f, -0.03910910f, -0.01571707f, 0.01066929f, -0.00581583f, -0.01594144f, 0.01159095f, -0.03770330f, 
    0.00341143f, -0.05120372f, 0.00225374f, 0.00969814f, 0.04003008f, -0.01983436f, 0.01577183f, 0.01302718f, 
    0.00950239f, -0.01258742f, 0.00405000f, -0.04943091f, -0.01336627f, 0.02316720f, -0.04091453f, -0.02612901f, 
    -0.00435462f, -0.02978023f, 0.00351642f, -0.01341170f, -0.01754683f, -0.01177768f, 0.00410004f, -0.01186860f, 
    -0.01349103f, -0.01665214f, -0.02009591f, 0.00402236f, -0.03968842f, -0.01088560f, 0.01433896f, -0.01543620f, 
    -0.03125062f, -0.00125890f, 0.00262092f, -0.00486247f, 0.00796031f, 0.01062851f, -0.02675381f, -0.01423681f, 
    0.02070534f, -0.03820405f, -0.02518704f, -0.02636532f, 0.00578555f, -0.03094332f, -0.03191296f, -0.01937064f, 
    0.01657392f, -0.01183031f, 0.01928724f, -0.02654459f, -0.03372414f, -0.01031731f, -0.03680117f, -0.00995942f, 
    0.00123521f, -0.01095339f, -0.01389012f, -0.02534856f, -0.00066768f, -0.02490152f, -0.00309359f, -0.03677971f, 
    0.00350655f, 0.03090651f, -0.01315536f, -0.02140740f, 0.01816338f, -0.00622672f, -0.02892900f, -0.00534743f, 
    0.03481501f, 0.01452030f, 0.00930537f, 0.01060290f, -0.01019598f, -0.05072381f, -0.02472980f, -0.00287047f, 
    -0.00176949f, 0.02787524f, -0.00658761f, -0.03086802f, 0.03007673f, 0.02111393f, -0.05122431f, -0.02067406f, 
    0.02405760f, -0.03395117f, -0.00042653f, -0.02685343f, 0.01712284f, -0.00467052f, -0.04036639f, -0.00127773f, 
    -0.01674288f, 0.01630899f, 0.00502611f, 0.03826168f, 0.01492400f, -0.01536592f, 0.00964101f, -0.00580204f, 
    -0.02111668f, -0.01155081f, -0.00754928f, -0.03968118f, -0.03291437f, -0.02298012f, -0.00545607f, -0.01821230f, 
    0.01999518f, -0.05118005f, -0.02333473f, 0.00037407f, 0.03208402f, -0.01494040f, 0.02220031f, 0.00155952f, 
    -0.01345226f, -0.03868058f, 0.03384392f, -0.00386248f, -0.03659899f, -0.05143048f, -0.06249279f, -0.06329923f, 
    -0.02810891f, -0.03198169f, -0.01825857f, -0.03783400f, 0.00450612f, 0.02583739f, -0.02287754f, -0.05225721f, 
    -0.01900424f, -0.02954446f, -0.04511094f, -0.02014694f, 0.01059305f, 0.00431349f, -0.03375705f, -0.04753898f, 
    -0.02753064f, -0.04241000f, 0.00982447f, -0.04397243f, -0.03071251f, -0.01783533f, -0.00045573f, 0.00609112f, 
    0.04041336f, -0.02890961f, -0.03269737f, -0.02883297f, -0.03776013f, 0.01535120f, 0.00118014f, -0.02240040f, 
    -0.02757880f, 0.00505659f, -0.03611793f, -0.00682173f, -0.00137788f, -0.04250894f, -0.03487054f, -0.00818074f, 
    -0.03188020f, -0.05838917f, 0.01818601f, 0.00532042f, -0.03315524f, 0.03207749f, 0.02009298f, -0.00473586f, 
    0.03953651f, 0.02786473f, 0.03361601f, 0.00453233f, 0.04057362f, 0.01446314f, 0.00992060f, -0.03760185f, 
    0.03362200f, -0.03422666f, 0.00599442f, 0.01907675f, 0.00779027f, -0.01496348f, -0.02840110f, -0.04192308f, 
    -0.02410011f, -0.00824244f, -0.06048102f, -0.02018485f, -0.02641645f, -0.04090980f, -0.04606466f, -0.01066852f, 
    -0.01472489f, -0.02904916f, -0.00829719f, 0.01318384f, -0.01571900f, 0.00414531f, -0.03304213f, 0.01599902f, 
    -0.01546246f, 0.00871561f, -0.01545728f, -0.01873821f, 0.01063172f, -0.01081646f, 0.00032655f, 0.01497467f, 
    0.02804906f, -0.02117043f, -0.00641633f, 0.04012628f, -0.04032548f, 0.00505536f, -0.01460954f, -0.02409214f, 
    -0.00462701f, -0.00909376f, -0.01705646f, -0.04590351f, 0.01532893f, 0.00563651f, -0.03776915f, -0.04002247f, 
    0.02389561f, 0.03961814f, 0.00082617f, -0.00016781f, -0.02425420f, -0.00975549f, 0.00037050f, -0.00329963f, 
    0.03449589f, -0.00996217f, -0.01589287f, -0.01095403f, 0.00349056f, -0.01290943f, -0.01964300f, -0.02067135f, 
    -0.00495633f, -0.00672390f, 0.01673489f, 0.00400828f, 0.03805081f, 0.00421482f, 0.02329403f, -0.03610653f, 
    -0.00244712f, -0.04450871f, -0.01985249f, -0.00457517f, -0.00904378f, -0.01913141f, -0.01019108f, 0.01209187f, 
    0.00414812f, -0.03027581f, 0.02610618f, -0.00873146f, -0.00030078f, -0.00650112f, -0.03336230f, 0.00583618f, 
    0.00822468f, -0.03134040f, -0.02354739f, -0.02088875f, -0.02600469f, -0.02639506f, 0.01047201f, -0.00798979f, 
    -0.03646874f, -0.02117441f, -0.04888162f, 0.01036377f, -0.03719850f, -0.01096042f, 0.00192412f, -0.02124986f, 
    0.00655829f, -0.00497681f, -0.00335705f, -0.04037067f, -0.03927718f, 0.01316275f, 0.00186381f, -0.00549868f, 
    0.01376285f, -0.02840093f, -0.01715763f, -0.04875808f, 0.02698372f, 0.02003409f, -0.03347358f, -0.02357020f, 
    -0.02028567f, 0.02680281f, -0.00962065f, 0.01929278f, 0.01114466f, -0.02605097f, 0.03635955f, -0.00640914f, 
    0.00827343f, 0.01649472f, -0.02726787f, -0.01993231f, 0.00171097f, 0.03317120f, -0.04450674f, 0.01162989f, 
    0.00787779f, -0.00540814f, -0.03059878f, -0.01013187f, 0.03193303f, -0.00873414f, -0.03537906f, -0.00566991f, 
    -0.03162518f, -0.01131704f, -0.00063639f, 0.00056314f, -0.02891657f, -0.03300679f, -0.03374684f, 0.00897439f, 
    0.01228217f, -0.01896872f, 0.01568065f, 0.03272089f, -0.00120217f, -0.03431787f, 0.00390201f, -0.00670487f, 
    0.02415322f, -0.02335736f, 0.00176682f, 0.00593995f, -0.02744557f, -0.01973939f, -0.00189918f, 0.00087304f, 
    -0.03927703f, -0.01055309f, 0.00797624f, -0.01705991f, 0.02812620f, -0.02589532f, 0.00737044f, -0.02252967f, 
    -0.00175867f, -0.03775579f, 0.00487310f, 0.00082560f, -0.04356034f, -0.02644320f, -0.00118132f, -0.03676191f, 
    0.01168451f, -0.00508057f, 0.02509103f, 0.01551420f, -0.02872261f, 0.03989091f, -0.00062090f, -0.01850619f, 
    -0.02016863f, -0.02578387f, 0.02055651f, -0.00281999f, 0.00309872f, -0.04374982f, 0.00026336f, -0.03086844f, 
    0.00584836f, -0.01909574f, 0.02007589f, -0.02004327f, 0.02700424f, -0.02903166f, -0.01018799f, 0.02278900f, 
    -0.00772796f, -0.01090775f, 0.00541443f, -0.02698429f, -0.02372709f, -0.01847930f, 0.00744999f, -0.01751109f, 
    -0.03690815f, -0.02710950f, 0.00988654f, -0.02337079f, -0.01182096f, 0.00269174f, -0.00686543f, -0.01249853f, 
    -0.02778599f, 0.00036594f, -0.03149616f, -0.04417722f, -0.03221683f, -0.03074306f, -0.01893845f, -0.00448825f, 
    -0.01638771f, 0.02475206f, 0.00990844f, -0.01581123f, 0.02773202f, -0.00954974f, -0.01072446f, -0.01731620f, 
    -0.05517628f, -0.01729238f, -0.00147672f, -0.01343250f, 0.02305439f, -0.00451004f, -0.02018700f, -0.01178990f, 
    -0.00455298f, 0.01313837f, 0.01877374f, 0.00668278f, -0.03962083f, -0.01763658f, -0.00328083f, 0.02402620f, 
    0.00816269f, -0.00632109f, 0.02390141f, -0.01141112f, -0.01255655f, -0.05248057f, 0.03199615f, -0.02179316f, 
    -0.03200493f, 0.02770929f, -0.04631815f, 0.01008052f, -0.01591631f, -0.02331744f, -0.00432221f, -0.02101216f, 
    0.03904266f, -0.01405285f, 0.02029914f, -0.02274201f, -0.00556241f, 0.01000737f, -0.00556893f, -0.03629719f, 
    -0.00026557f, -0.01293327f, -0.02648946f, -0.02219942f, -0.00436759f, -0.03503415f, -0.02187196f, 0.02135855f, 
    0.00218969f, -0.02354236f, -0.02371196f, 0.04358468f, 0.03502303f, -0.03970230f, -0.03072976f, -0.01752485f, 
    -0.03544655f, 0.01240196f, 0.00591349f, 0.01051622f, -0.02013821f, -0.00487485f, 0.02365603f, -0.01859753f, 
    -0.01156945f, -0.04393085f, -0.03867911f, -0.01300985f, -0.03935115f, 0.01095483f, 0.00653365f, -0.00311553f, 
    -0.03052421f, -0.00072035f, -0.00936267f, -0.01839453f, -0.05427069f, -0.02689130f, 0.00901365f, -0.04541399f, 
    0.03837084f, 0.01188897f, -0.02604026f, 0.00940439f, 0.00393615f, -0.02327130f, -0.01974519f, -0.01518166f, 
    0.01511244f, -0.00265165f, 0.02083304f, -0.00630460f, -0.03110546f, -0.02370960f, 0.01984503f, -0.00393755f, 
    -0.01081341f, 0.02107246f, 0.02805657f, 0.00828627f, 0.00992401f, -0.00893924f, 0.01293926f, -0.01375350f, 
    0.00182670f, -0.00087879f, -0.02371483f, -0.00768837f, 0.01052943f, 0.00662325f, 0.00185369f, 0.00233320f, 
    -0.03241397f, -0.01693155f, -0.02885154f, -0.03704416f, -0.01282517f, 0.01180428f, 0.01287595f, 0.01525113f, 
    -0.02413833f, -0.02505991f, -0.02118591f, 0.00372347f, -0.03841829f, 0.01336125f, 0.02515683f, 0.00213109f, 
    -0.00073680f, 0.00178682f, 0.00563159f, -0.00273021f, -0.00924009f, -0.03871910f, -0.00423980f, -0.02267034f, 
    0.02173567f, -0.02752852f, 0.01214751f, -0.01062153f, 0.01616730f, -0.03092148f, 0.01714594f, -0.03885786f, 
    0.00673937f, -0.03754466f, -0.01074118f, -0.01981046f, 0.01560500f, -0.03195057f, 0.02828582f, -0.03172339f, 
    0.02112039f, -0.02829571f, -0.03545614f, -0.03497887f, -0.03745005f, -0.01832562f, -0.02315289f, -0.02334507f, 
    0.02397648f, -0.01743992f, -0.00973378f, -0.03605994f, -0.04244607f, -0.01457484f, 0.02460688f, -0.01781110f, 
    -0.00362774f, -0.00351558f, -0.02870445f, -0.03313857f, -0.03813905f, -0.02058169f, 0.00018498f, -0.03858995f, 
    -0.02020234f, -0.00383132f, 0.02697927f, -0.02316123f, -0.00188181f, -0.02040964f, 0.01051588f, -0.03181510f, 
    0.02327666f, -0.00489199f, -0.00840318f, -0.02864399f, 0.00145532f, 0.02468026f, 0.00162956f, 0.02138667f, 
    -0.00009857f, -0.00901783f, 0.00719830f, -0.04368689f, 0.01820543f, 0.00855354f, -0.02815273f, 0.00765523f, 
    -0.01343977f, -0.01727805f, 0.00256858f, 0.02979083f, 0.02510184f, -0.01985310f, -0.01556529f, 0.02031557f, 
    0.00342447f, -0.00798770f, 0.04047384f, -0.01899419f, 0.02525846f, -0.02997219f, -0.01279577f, 0.00099626f, 
    -0.04179548f, -0.00344019f, 0.01161486f, -0.01599994f, 0.01482589f, -0.00659926f, 0.01494270f, -0.02863052f, 
    -0.00880553f, 0.00765625f, 0.00714364f, -0.01521956f, -0.00691859f, -0.00196380f, -0.02650934f, -0.03347257f, 
    -0.02278844f, -0.03059110f, 0.02906912f, 0.01523389f, 0.00274920f, -0.02534551f, -0.01402999f, -0.03048167f, 
    0.00201577f, 0.02692320f, -0.00440403f, -0.03890167f, 0.01439904f, -0.02986082f, -0.02386794f, 0.01415107f, 
    0.01981896f, -0.01058034f, 0.01323063f, -0.02308984f, -0.01300531f, 0.01792260f, 0.02826025f, -0.00342790f, 
    0.02754632f, -0.00362887f, 0.00314059f, 0.01414373f, 0.02848283f, -0.02642268f, -0.00429706f, -0.01464401f, 
    0.02004068f, -0.03673007f, -0.03458809f, -0.01494339f, 0.03138421f, -0.01304343f, 0.02533043f, 0.02518586f, 
    0.02887105f, 0.00164083f, 0.00655858f, 0.00440086f, 0.00285057f, -0.03048499f, 0.00559393f, -0.00641903f, 
    -0.03559684f, 0.00683627f, 0.01308391f, 0.03628019f, 0.02167738f, -0.03653656f, -0.03567939f, 0.01562706f, 
    0.00440662f, 0.01073522f, -0.02787693f, -0.01783775f, -0.01950502f, -0.00229916f, 0.00167447f, -0.02200597f, 
    0.01109767f, 0.00531001f, -0.02257189f, 0.00012521f, -0.00969960f, 0.00567615f, -0.00935804f, -0.01991598f, 
    -0.02114257f, -0.03979013f, -0.02017804f, -0.00414846f, -0.01307267f, -0.01632792f, 0.02011308f, 0.04186982f, 
    -0.00476347f, 0.01413747f, -0.01305649f, -0.03603077f, -0.01033184f, -0.03528050f, -0.01141713f, -0.00155346f, 
    -0.02775304f, 0.00862168f, -0.01515513f, 0.02439426f, 0.00366520f, -0.03554018f, -0.01184069f, 0.01061053f, 
    -0.04025374f, 0.00675871f, -0.01296955f, 0.01039898f, -0.00679562f, -0.01385957f, 0.01501937f, 0.02412802f, 
    0.01028387f, -0.00470789f, 0.01431647f, -0.01395669f, -0.02904580f, 0.01247425f, 0.01772068f, -0.00662779f, 
    0.02255661f, -0.03854064f, -0.01232559f, -0.01158955f, 0.02230204f, 0.01600983f, -0.04187929f, 0.01324446f, 
    0.00138226f, -0.02543666f, 0.01258906f, 0.00247015f, 0.00999702f, 0.00192211f, -0.01459489f, 0.02024737f, 
    -0.03378658f, -0.02245027f, -0.03405199f, 0.00904135f, 0.00886299f, -0.00795073f, 0.00718191f, -0.00352822f, 
    0.00258634f, -0.01455400f, 0.01638545f, 0.00914780f, -0.00234211f, 0.01591488f, -0.00914522f, -0.02050110f, 
    0.01030695f, 0.00836109f, 0.02790179f, -0.01989402f, -0.00527120f, 0.02016186f, 0.02208663f, -0.02633951f, 
    0.01177718f, 0.01957031f, -0.01453888f, -0.01288415f, 0.02415278f, -0.01421176f, -0.02220967f, -0.02686862f, 
    0.02623029f, -0.01141980f, 0.01152107f, -0.00962955f, 0.01904109f, 0.00072743f, -0.02362012f, -0.00047985f, 
    0.00301435f, -0.02643282f, -0.02710251f, -0.02350405f, 0.00243874f, 0.00590049f, -0.00032644f, -0.02937594f, 
    -0.02622347f, 0.02059170f, 0.02861083f, -0.00967531f, 0.00374743f, 0.01117314f, -0.00551866f, -0.00420569f, 
    0.01460978f, -0.03012352f, -0.03778867f, -0.01598475f, -0.02666792f, 0.02015255f, 0.01419163f, -0.01689551f, 
    -0.01152848f, -0.01164755f, 0.00538377f, 0.02003003f, -0.03454119f, -0.01851182f, 0.00802980f, -0.02162623f, 
    0.01362553f, 0.02564161f, -0.01639454f, 0.02806977f, 0.01366242f, -0.03465983f, 0.01508987f, 0.01956182f, 
    0.01732825f, 0.00111767f, 0.02979387f, -0.02316672f, 0.01932068f, -0.02660683f, -0.02385724f, 0.02399852f, 
    -0.00913451f, -0.03041881f, -0.03594325f, -0.02900265f, 0.00860946f, -0.01045613f, -0.02305580f, -0.03524897f, 
    -0.00264316f, -0.01958565f, -0.01447197f, 0.02638370f, -0.02896096f, -0.01932004f, -0.01903453f, 0.00179719f, 
    -0.02244158f, -0.03007323f, -0.00360948f, -0.00373037f, 0.00255721f, 0.01250816f, -0.03704698f, -0.03734094f, 
    -0.00206683f, -0.02436410f, 0.00842568f, 0.01537760f, 0.01675681f, 0.00143239f, -0.02448321f, -0.00481818f, 
    0.02857202f, 0.00302306f, -0.03888383f, 0.02548300f, -0.02277000f, 0.02989028f, 0.02608970f, 0.02252621f, 
    0.00301433f, -0.01533724f, -0.02841470f, -0.03767531f, -0.02313684f, -0.02929655f, -0.02608513f, 0.02708648f, 
    0.02772940f, 0.02881929f, -0.02506244f, 0.00304995f, -0.03932271f, 0.02852413f, -0.00616204f, -0.00296743f, 
    0.00654181f, -0.00578653f, 0.02017285f, -0.04223257f, -0.01630978f, -0.00883060f, 0.01922625f, -0.00858898f, 
    0.02099145f, -0.01962919f, 0.00743424f, -0.02712944f, 0.00555447f, 0.02448904f, -0.02361788f, 0.00496217f, 
    0.01746920f, 0.03076938f, -0.03615626f, 0.02550524f, -0.00517015f, 0.02860723f, -0.00624062f, 0.04285485f, 
    0.02622647f, 0.01890113f, 0.00877032f, 0.01253732f, -0.03146814f, 0.00397552f, 0.02238054f, -0.01753725f, 
    0.01139262f, -0.00804296f, 0.02808545f, -0.03139949f, -0.02201113f, 0.02952567f, -0.00644559f, -0.00604718f, 
    -0.02836349f, 0.00549398f, 0.02218170f, -0.01445442f, 0.01366216f, -0.01300276f, 0.01877572f, 0.02503623f, 
    -0.00336176f, 0.02816453f, 0.02405583f, 0.01605654f, 0.01994208f, 0.01157317f, -0.02556928f, 0.01028388f, 
    0.00251794f, -0.02230172f, -0.02149663f, 0.01579579f, 0.02654000f, -0.03072824f, 0.01475505f, 0.00156309f, 
    0.02296314f, 0.00834622f, -0.01363494f, 0.02772425f, -0.03942715f, -0.01563236f, -0.02314494f, 0.02462851f, 
    0.02750348f, -0.02557838f, -0.01493482f, -0.02944217f, -0.02454361f, 0.01268886f, 0.00799866f, -0.01045096f, 
    0.01912928f, 0.01401922f, -0.02300137f, 0.02779872f, 0.01423125f, -0.03067809f, -0.03438942f, 0.01814221f, 
    0.01751276f, 0.02202332f, -0.00042025f, -0.00243330f, -0.01500940f, -0.01254698f, 0.00807001f, -0.00060601f, 
    -0.03709027f, -0.01397957f, -0.03199878f, 0.02231792f, -0.03054660f, 0.02599245f, 0.02301148f, -0.03038981f, 
    0.01011445f, -0.00659749f, 0.00108337f, 0.02289725f, -0.03363437f, -0.02609402f, 0.01061994f, 0.02606692f, 
    0.00825141f, -0.04016897f, -0.01820537f, 0.02811434f, 0.00132286f, 0.02877666f, -0.02789784f, -0.02129296f, 
    0.00840767f, 0.01265685f, -0.01389482f, 0.02370216f, -0.03586341f, -0.02296425f, 0.01065153f, 0.01324284f, 
    -0.00232343f, -0.01079283f, -0.02696690f, 0.02898159f, 0.02782540f, -0.01459445f, -0.01079253f, -0.02858650f, 
    0.01897708f, 0.01924152f, -0.03273845f, 0.01416708f, 0.03168749f, -0.03068665f, -0.02756764f, -0.02549695f, 
    -0.00070149f, 0.02106913f, -0.01443049f, -0.03698797f, -0.00063266f, -0.01581682f, -0.01114106f, 0.02131909f, 
    -0.03914107f, 0.00547010f, 0.01673487f, 0.01949149f, 0.00770509f, -0.03689058f, -0.04120507f, -0.04070447f, 
    0.02968845f, 0.00843324f, 0.02290920f, 0.02669180f, -0.03276482f, -0.00600859f, 0.01634700f, -0.03437290f, 
    0.02038213f, -0.00862970f, -0.00713802f, 0.02970554f, -0.01009536f, -0.01354081f, -0.04083384f, -0.03542441f, 
    -0.03501920f, 0.02514960f, 0.03184994f, -0.02390621f, 0.00700673f, -0.01237337f, 0.01294998f, -0.02578149f, 
    0.02874247f, 0.01344875f, -0.04017876f, -0.02774103f, -0.03167931f, -0.02036561f, -0.03441120f, 0.01553442f, 
    -0.03620858f, -0.03278122f, -0.01700315f, -0.01117848f, -0.01813817f, -0.00961216f, -0.02867969f, 0.03338961f, 
    0.00832710f, 0.01230076f, -0.03911320f, -0.02765457f, 0.01351946f, 0.01281204f, 0.00820602f, 0.00994569f, 
    0.01913593f, -0.00132669f, -0.03833454f, 0.02649847f, 0.00168840f, 0.01544746f, -0.03236282f, -0.02826886f, 
    0.01436241f, -0.03401294f, 0.01246247f, 0.01678980f, -0.02622267f, -0.01592762f, 0.02275833f, 0.01907743f, 
    -0.00375579f, -0.02692565f, 0.01195925f, -0.00020750f, -0.02842040f, -0.01389233f, -0.00302646f, -0.01554138f, 
    -0.00463389f, 0.01244094f, -0.04136649f, -0.03869221f, 0.00371137f, 0.02588559f, -0.02350961f, -0.01735179f, 
    -0.03968005f, 0.00599369f, 0.02628712f, -0.01386690f, -0.01794631f, -0.02541190f, 0.00413363f, -0.01051963f, 
    -0.01529749f, 0.00028794f, -0.01387284f, 0.02937940f, 0.01843782f, -0.02652524f, -0.02756716f, -0.00492099f, 
    -0.01680413f, -0.00542818f, -0.00459963f, -0.03171188f, 0.02277700f, -0.03810339f, 0.02297601f, 0.01542340f, 
    0.00838996f, 0.00677216f, -0.02529150f, 0.01584384f, -0.00461469f, -0.00449498f, -0.02099218f, -0.04132888f, 
    -0.00072884f, -0.01611159f, -0.00359463f, 0.01216699f, -0.01460137f, -0.00365772f, 0.01639293f, -0.01850946f, 
    -0.02959584f, -0.00834834f, 0.00169586f, 0.01070461f, -0.00892317f, 0.00551314f, -0.01816804f, 0.00379322f, 
    -0.01509556f, -0.01023336f, -0.01757201f, 0.00000624f, -0.00905671f, 0.01219855f, -0.00663279f, 0.01639615f, 
    -0.00751431f, 0.01661898f, -0.02034664f, -0.02350342f, -0.00398294f, -0.03632022f, -0.01381594f, 0.02366171f, 
    0.02563475f, -0.03174388f, -0.03466892f, 0.01772484f, 0.00608071f, -0.03158357f, -0.01457211f, -0.00554853f, 
    0.02043381f, 0.01422813f, 0.02655084f, -0.00767596f, 0.00147944f, -0.02978562f, -0.03193774f, 0.01359321f, 
    0.00063634f, -0.00305422f, -0.02151744f, -0.02345470f, 0.00988107f, -0.02502939f, 0.01202857f, -0.03375642f, 
    0.03467225f, 0.01324382f, 0.01923643f, -0.03170163f, -0.01768461f, -0.00899098f, -0.01010558f, -0.03366403f, 
    -0.01715920f, -0.03196872f, -0.01415249f, 0.02496846f, -0.04292014f, -0.02978184f, -0.00617825f, -0.02935132f, 
    0.01356504f, 0.02265166f, 0.02466196f, 0.01624361f, -0.01756219f, -0.00244417f, 0.00083697f, 0.00474820f, 
    0.01518540f, -0.01237739f, 0.01322245f, 0.00353266f, -0.02264646f, -0.01935525f, 0.01358641f, -0.02688816f, 
    0.01380366f, 0.03254629f, -0.03407436f, 0.00201417f, -0.01776473f, -0.01513738f, -0.03787314f, -0.04184610f, 
    0.00549573f, -0.02684022f, -0.02358383f, -0.01459336f, -0.01998963f, 0.02710468f, 0.02649647f, 0.00199595f, 
    -0.03905746f, 0.02878759f, -0.00205215f, -0.00146937f, -0.01136433f, -0.02935734f, -0.01655105f, -0.01164212f, 
    -0.28632015f, 0.06678179f, 0.08479602f, -0.01632403f, -0.00998853f, -0.08045609f, -0.05473030f, -0.02083698f, 
    0.03246357f, 0.08292674f, -0.13718379f, 0.05730243f, -0.15552114f, -0.08410913f, -0.00341204f, -0.18542926f, 
    0.10976819f, -0.02663596f, 0.02349335f, -0.08802707f, 0.01687623f, -0.03047042f, -0.05807768f, 0.09412809f, 
    -0.11852399f, -0.10612018f, 0.02481965f, 0.05486492f, 0.07324707f, 0.02425950f, -0.03348165f, -0.15171500f, 
    -0.01155125f, 0.00910977f, 0.03891622f, 0.07447408f, -0.20444936f, 0.17966203f, 0.04038678f, 0.10938442f, 
    0.08401279f, 0.06235826f, -0.01895968f, 0.04201698f, -0.01467280f, -0.00929433f, -0.02688838f, 0.14867702f, 
    -0.42006448f, 0.08353230f, -0.12214694f, -0.14803173f, 0.17169097f, -0.03225174f, -0.01627232f, 0.00207526f, 
    -0.01607522f, 0.01193098f, -0.05927074f, 0.02772119f, 0.25239763f, 0.22153001f, -0.07775629f, -0.10773924f, 
    -0.02889782f, -0.05510047f, 0.00371842f, 0.00152161f, 0.03145369f, 0.01906327f, 0.03821824f, 0.07372612f, 
    -0.19107117f, 0.04499961f, 0.12417571f, 0.10057864f, 0.04062841f, -0.03397061f, -0.03368771f, 0.04817748f, 
    -0.01195808f, -0.06049412f, -0.01435622f, -0.02274965f, 0.24584982f, 0.17462358f, -0.02267077f, 0.03486494f, 
    -0.01628170f, -0.02410419f, 0.14155202f, -0.06219498f, 0.05401711f, -0.02323645f, 0.04755422f, 0.07011117f, 
    -0.01769621f, -0.14238261f, -0.01682632f, 0.06094815f, 0.15006080f, 0.11003897f, 0.00147800f, -0.03669112f, 
    0.01800147f, 0.02827048f, 0.08702377f, -0.14702311f, -0.15863943f, -0.02956878f, 0.14520474f, 0.29065439f, 
    0.11248191f, 0.11690533f, 0.10274351f, 0.10769655f, 0.08285053f, 0.06551944f, 0.06303768f, 0.16052277f, 
    -0.15652776f, -0.24493343f, -0.07865135f, -0.08265831f, 0.04318976f, 0.00327210f, 0.01114611f, 0.12551546f, 
    -0.02978782f, -0.04364430f, 0.01173696f, 0.02509269f, 0.31438771f, 0.21913205f, -0.10437535f, -0.04424256f, 
    0.01779092f, 0.04386996f, 0.17784962f, -0.06126659f, 0.14758272f, 0.00631156f, 0.08662637f, 0.09324959f, 
    -0.17931643f, -0.03177311f, -0.07783821f, 0.01413100f, 0.07517758f, 0.06791266f, -0.04296700f, 0.06399998f, 
    0.02111199f, -0.01426132f, 0.00125849f, 0.06157751f, -0.19875224f, 0.00753630f, 0.12777175f, 0.15081258f, 
    -0.02222516f, -0.01669833f, 0.02473227f, 0.00130228f, 0.08512355f, -0.01153447f, 0.07374956f, -0.01940459f, 
    0.16738148f, 0.25363326f, 0.21483472f, 0.05720244f, 0.01796804f, 0.06511814f, -0.00899546f, -0.02972327f, 
    -0.07208414f, 0.03915234f, 0.06685079f, -0.01940002f, 0.23552349f, 0.10015340f, -0.13123702f, -0.03471110f, 
    -0.06131938f, -0.04199923f, -0.00206717f, -0.06714749f, -0.08698216f, -0.06631666f, 0.01175320f, 0.05948521f, 
    -0.20980917f, -0.14331755f, -0.03883449f, 0.05841052f, 0.06441009f, 0.02185757f, 0.02763075f, 0.04348499f, 
    0.07697999f, 0.03912824f, -0.04486259f, 0.10797369f, -0.21952790f, 0.10118607f, -0.04010510f, -0.03742623f, 
    0.08050115f, 0.00211426f, -0.00215144f, 0.00706339f, 0.06114627f, 0.04194732f, -0.00625786f, -0.00966522f, 
    -0.16495733f, -0.07519089f, -0.10628301f, -0.08798420f, 0.08157759f, 0.07256885f, 0.10818204f, -0.03730394f, 
    0.02291921f, -0.15121199f, -0.10100675f, 0.11684936f, -0.10090618f, 0.09433983f, -0.00916281f, -0.00432736f, 
    0.02998702f, 0.00795156f, -0.08248603f, 0.07752103f, 0.15188785f, -0.07676455f, 0.04687772f, 0.01003076f, 
    0.01566347f, -0.09288710f, -0.07756953f, -0.22909899f, -0.12638338f, -0.05661863f, 0.10752932f, -0.03641914f, 
    0.06406316f, 0.00412593f, 0.04476111f, 0.07750604f, -0.00877388f, 0.00192050f, 0.04683122f, -0.03998065f, 
    -0.14409927f, 0.00350727f, 0.04139414f, -0.03453446f, 0.02602059f, -0.11022886f, -0.00871565f, -0.07995749f, 
    0.00634290f, 0.03592403f, 0.08755087f, 0.09890368f, 0.01266861f, -0.11227904f, 0.05260308f, 0.03451496f, 
    0.11446092f, 0.04906480f, 0.06797895f, 0.01817442f, 0.28073755f, 0.12454629f, 0.24423571f, -0.04356712f, 
    0.02214381f, -0.01153575f, -0.00700218f, -0.06423698f, 0.11905172f, -0.14172183f, -0.03760922f, 0.02328514f, 
    -0.09023938f, -0.25634933f, 0.00081317f, -0.03076060f, 0.03812125f, -0.11269147f, -0.07231023f, 0.00687119f, 
    0.09409389f, 0.09026375f, -0.06302703f, 0.10612535f, 0.08321891f, 0.02747991f, -0.14735040f, -0.09940289f, 
    0.09943104f, -0.13173592f, 0.01457459f, -0.14214619f, -0.02491415f, -0.08457440f, -0.07219542f, -0.05873976f, 
    -0.25340348f, -0.12691285f, 0.02489028f, 0.00019316f, -0.05771276f, -0.04474928f, -0.05469865f, 0.08392131f, 
    0.16642247f, 0.11358897f, 0.17266785f, 0.05944140f, 0.04837002f, 0.09024467f, 0.20740762f, 0.03727934f, 
    0.04936394f, 0.00203367f, -0.02637028f, -0.00453581f, 0.04667152f, 0.14685687f, -0.02136352f, 0.08524182f, 
    -0.05525661f, -0.13853192f, -0.02330915f, -0.18955597f, 0.05166388f, -0.11300544f, 0.02062820f, 0.06015474f, 
    -0.04485214f, -0.06251170f, 0.00839287f, -0.02109660f, -0.06769357f, 0.01445250f, -0.07511465f, 0.14207199f, 
    0.07115502f, 0.03627153f, -0.07438321f, -0.02052419f, 0.06071711f, -0.03880433f, 0.00340991f, 0.01780250f, 
    0.17357090f, -0.07048962f, 0.27773139f, 0.28690097f, 0.12952170f, 0.04768008f, -0.05983169f, 0.00552106f, 
    0.09056535f, -0.03551463f, 0.03892009f, -0.09492602f, 0.24313025f, 0.08498198f, 0.18849961f, 0.27783996f, 
    0.08406334f, -0.03382070f, -0.05502558f, -0.07289658f, 0.07935663f, 0.05370507f, 0.06759316f, 0.14557466f, 
    -0.17661935f, -0.05625669f, -0.11066324f, -0.04139020f, 0.03540733f, 0.11120947f, -0.03247467f, 0.06038679f, 
    -0.15738459f, 0.12969792f, 0.16760711f, -0.15551418f, -0.23155130f, 0.14187045f, 0.06440069f, 0.09936491f, 
    0.02939048f, 0.00459186f, 0.02069980f, -0.08715205f, 0.11029411f, -0.07971663f, -0.05030636f, 0.10795245f, 
    -0.04736272f, 0.23088023f, -0.26051947f, -0.18510041f, 0.05852454f, 0.03425757f, 0.07479481f, -0.05935819f, 
    -0.01012071f, 0.10070295f, -0.09658629f, 0.10280803f, -0.16781476f, -0.12286558f, -0.14873254f, -0.13196687f, 
    0.01534679f, -0.11041091f, -0.12865664f, 0.06232536f, 0.06545253f, -0.06495914f, 0.19845466f, -0.00831986f, 
    0.35566774f, -0.02975802f, 0.26847500f, 0.24278040f, 0.05395208f, 0.04969680f, 0.00728265f, 0.02259918f, 
    0.00637754f, 0.02032217f, 0.07382363f, 0.06174654f, -0.13127215f, -0.02187009f, -0.00497827f, -0.02417058f, 
    0.15705961f, 0.08343761f, 0.08523442f, 0.11164574f, 0.10646816f, -0.00001073f, 0.07929748f, 0.07988150f, 
    -0.05696569f, -0.08911739f, 0.00094387f, -0.05897806f, -0.03943294f, -0.02052311f, -0.03826940f, -0.01787826f, 
    0.01029067f, 0.02428432f, 0.09712709f, 0.22184008f, 0.12576963f, -0.01713178f, 0.08480496f, 0.09513346f, 
    -0.08942887f, -0.08005545f, 0.09593618f, -0.03651131f, 0.13461339f, 0.14684238f, 0.00059019f, -0.08771195f, 
    -0.24105237f, 0.02090908f, -0.00279158f, -0.04662262f, 0.10705695f, -0.06199836f, 0.05041280f, 0.02582869f, 
    -0.01364508f, 0.05607934f, 0.00434508f, -0.13372932f, 0.18978570f, 0.02425115f, 0.25863087f, 0.24664247f, 
    0.01895813f, 0.05885940f, -0.02242587f, -0.06296159f, 0.12901156f, 0.02297948f, 0.12128633f, 0.16506334f, 
    -0.22960013f, -0.06251821f, -0.02378004f, -0.09242865f, -0.01904037f, 0.04232429f, -0.06165191f, 0.11798529f, 
    0.08222838f, -0.09271546f, 0.10031701f, -0.03707063f, -0.23657699f, 0.12220765f, -0.03989019f, -0.39789075f, 
    -0.03860492f, 0.02070016f, -0.02844367f, 0.09435409f, 0.05979403f, 0.12984349f, -0.04473866f, 0.03547136f, 
    -0.30074981f, -0.01717450f, -0.06643983f, -0.16961001f, 0.01879555f, -0.02031169f, 0.01213700f, -0.04363977f, 
    0.02802910f, -0.04433113f, 0.04886996f, -0.03187209f, -0.02631528f, 0.10197447f, -0.16369423f, -0.10199419f, 
    0.10086629f, -0.00596849f, 0.04106917f, -0.02906456f, 0.00879719f, 0.03758809f, 0.03419502f, -0.00636315f, 
    0.01179284f, -0.08255368f, 0.09969001f, -0.04036016f, 0.06475397f, 0.00587772f, 0.00171141f, 0.06990846f, 
    -0.10255615f, -0.04421472f, 0.07671884f, -0.04438787f, 0.11349741f, -0.02885697f, 0.03400598f, 0.16606188f, 
    -0.03930763f, 0.17303111f, -0.08895966f, -0.08066911f, -0.11928385f, -0.19451359f, 0.03007988f, -0.00531824f, 
    -0.21913986f, -0.06765387f, 0.08981067f, 0.23729487f, 0.01984627f, -0.02103233f, -0.02142349f, 0.01761203f, 
    0.06089417f, -0.09190561f, 0.14434768f, -0.00283039f, 0.23838982f, 0.29700607f, 0.22573011f, 0.16434203f, 
    0.10328140f, -0.03842741f, 0.10709122f, 0.03002805f, 0.09474275f, 0.08467656f, -0.02401035f, 0.11149316f, 
    -0.19221465f, -0.12132317f, 0.09179449f, 0.06793514f, -0.08696773f, -0.09891541f, -0.16518034f, -0.03329441f, 
    0.10554247f, -0.06481741f, 0.02819465f, 0.09900133f, -0.16741444f, 0.04047034f, 0.16647449f, 0.12645672f, 
    -0.07203225f, -0.03865963f, 0.05071842f, -0.02541960f, -0.00907549f, -0.07844344f, 0.11347052f, 0.10627772f, 
    0.14985244f, 0.18942015f, 0.25773436f, 0.28922355f, 0.13348025f, 0.03698772f, 0.01600437f, 0.08928188f, 
    -0.04956223f, -0.01533793f, 0.05184534f, 0.04460352f, -0.03236800f, -0.14757834f, -0.05876891f, -0.09283923f, 
    -0.00888484f, -0.05206869f, 0.09811164f, -0.02071718f, -0.03600628f, -0.05688943f, 0.02254750f, -0.04628367f, 
    0.14943199f, 0.24636595f, 0.05775034f, 0.03221639f, 0.02604941f, -0.05845672f, -0.02268013f, 0.11944216f, 
    -0.01592888f, 0.11122832f, -0.14041771f, -0.10919977f, 0.12227826f, -0.19633779f, -0.12316940f, -0.08023209f, 
    0.01178714f, -0.03109011f, 0.06856815f, -0.03563897f, 0.01982690f, 0.04767339f, 0.17522870f, 0.06090556f, 
    -0.30701223f, 0.15177052f, 0.00776187f, -0.03639081f, 0.00445066f, -0.05021797f, 0.00241920f, 0.12842461f, 
    -0.01241385f, -0.01883925f, 0.06068346f, -0.03797018f, 0.07858144f, 0.14135799f, 0.08751147f, 0.19755489f, 
    -0.01753212f, -0.00149308f, -0.02137101f, 0.03444371f, 0.03367569f, 0.03632914f, -0.04323277f, -0.06544361f, 
    -0.24220498f, 0.29625291f, 0.12675272f, -0.16210777f, -0.05678663f, 0.05446794f, -0.10727119f, -0.03052660f, 
    0.16010100f, 0.01583153f, -0.06732364f, 0.01474596f, -0.11131421f, -0.03817450f, -0.03768284f, 0.13239403f, 
    -0.02973068f, -0.05600241f, 0.05393155f, -0.12087465f, -0.06186903f, 0.01333719f, -0.04857946f, -0.04768131f, 
    -0.09331018f, -0.07243890f, 0.01071085f, 0.06797887f, -0.00738427f, -0.01412258f, -0.04602397f, -0.03541299f, 
    -0.02127176f, 0.04548103f, 0.17501849f, -0.08608693f, 0.27006364f, -0.12137374f, 0.05905030f, -0.01491174f, 
    0.05060908f, -0.12603377f, 0.14281923f, -0.06325392f, 0.06949963f, 0.08656912f, -0.08310108f, -0.08016743f, 
    0.03360801f, 0.05292673f, -0.07187914f, -0.11210158f, -0.00409458f, -0.06969358f, -0.13992199f, 0.06455176f, 
    0.11584877f, -0.06152450f, 0.04642969f, -0.03589237f, 0.34102333f, -0.07375024f, -0.09336511f, 0.02539827f, 
    -0.00475148f, -0.11246309f, -0.07422185f, -0.03244976f, 0.05890942f, -0.03189057f, 0.03353333f, 0.03035284f, 
    0.04917141f, -0.10995882f, 0.08901063f, 0.12059360f, 0.04568741f, -0.07698262f, -0.11078464f, -0.10847706f, 
    -0.00980644f, -0.05651024f, 0.08083549f, 0.02239706f, -0.11876760f, 0.06839339f, -0.04415126f, 0.08968931f, 
    0.05766260f, -0.03482087f, -0.02749305f, -0.01662304f, 0.05175820f, 0.10302803f, 0.08665767f, -0.02829931f, 
    0.22363544f, 0.02190427f, -0.19934908f, -0.00863791f, 0.12933539f, -0.05108396f, -0.04616754f, 0.14997494f, 
    0.05273692f, 0.07664742f, 0.10807031f, -0.02043417f, -0.07582369f, 0.11133296f, 0.07054604f, -0.27699867f, 
    -0.10178819f, -0.08950253f, -0.09796537f, 0.06567568f, 0.04528908f, -0.06880487f, 0.21950188f, -0.06945717f, 
    -0.18306069f, -0.00798423f, 0.08873666f, -0.01987031f, -0.02576191f, 0.00890785f, 0.05415739f, 0.02766689f, 
    -0.03847622f, -0.02004465f, 0.03465080f, 0.10062244f, 0.02338109f, -0.06992539f, 0.13527805f, 0.04491643f, 
    0.05826820f, 0.03555547f, 0.09153884f, -0.01414061f, -0.10213501f, 0.03650789f, -0.13866363f, -0.02934522f, 
    0.13018498f, 0.05601157f, -0.10816770f, -0.12391143f, -0.01455321f, -0.04222063f, 0.05111542f, -0.14073618f, 
    0.18528280f, 0.02183466f, 0.13864316f, 0.04006957f, -0.06013042f, -0.06371932f, 0.08404814f, 0.09013134f, 
    0.02400416f, 0.10178557f, -0.04089335f, -0.07291394f, -0.06527107f, 0.07950775f, -0.03902851f, 0.12288432f, 
    0.19004872f, -0.01283279f, 0.12279828f, 0.06156869f, -0.00341508f, -0.06068918f, -0.03534348f, 0.00835039f, 
    -0.06531765f, -0.04057783f, -0.08893479f, 0.04144237f, 0.08304991f, -0.09266177f, -0.03779805f, 0.12602790f, 
    0.12546776f, 0.04645183f, -0.07737640f, 0.01124880f, 0.00943928f, -0.09259360f, -0.09776071f, -0.18168440f, 
    0.28874749f, 0.00568722f, 0.01692734f, 0.02362364f, -0.02142217f, -0.04603104f, 0.00373736f, -0.07594105f, 
    -0.01898375f, 0.10217464f, 0.12107798f, 0.15429483f, -0.29640961f, -0.24083629f, 0.17118284f, -0.00865340f, 
    -0.10546362f, -0.05951402f, -0.07249916f, -0.00444455f, 0.04892764f, -0.07252136f, -0.09183922f, -0.15263838f, 
    -0.22349170f, 0.10887086f, 0.17009600f, 0.05940887f, 0.00914742f, -0.00837340f, -0.00215928f, 0.03690942f, 
    -0.04889007f, -0.04025661f, 0.06466193f, -0.03730011f, 0.22865453f, 0.08623884f, -0.03103775f, 0.06194897f, 
    -0.00116000f, -0.09708434f, 0.07681651f, -0.15564229f, -0.08438101f, -0.02022070f, -0.05265551f, 0.09810053f, 
    -0.10595030f, -0.08441925f, -0.07430824f, -0.03422880f, 0.06760456f, -0.18742836f, 0.08985222f, -0.02320164f, 
    0.05059883f, 0.00738050f, -0.01871144f, 0.06589821f, -0.44423717f, 0.23048742f, 0.22340535f, 0.02715206f, 
    0.07079742f, 0.06390595f, 0.04619370f, 0.15416348f, 0.15501934f, -0.04318472f, -0.02454786f, -0.18717356f, 
    0.10056370f, 0.09011755f, 0.16836616f, 0.03363196f, 0.09271056f, 0.17408392f, 0.04138407f, 0.09644195f, 
    -0.09674093f, 0.05301432f, 0.15494098f, 0.06665411f, -0.20048302f, 0.05399387f, 0.10533286f, 0.10807325f, 
    -0.08235116f, 0.15629473f, 0.07791749f, 0.06373136f, -0.02154545f, 0.05213799f, 0.10348324f, 0.14790432f, 
    0.14379118f, -0.01106420f, 0.20758949f, 0.22179365f, 0.00316512f, 0.04638075f, -0.06956128f, 0.16057023f, 
    0.05635306f, 0.19102190f, 0.07057126f, -0.01303957f, -0.15908730f, 0.23771633f, -0.04543440f, 0.10380320f, 
    -0.04722536f, 0.07100572f, 0.04223157f, 0.00518865f, -0.05578860f, 0.10117125f, 0.01254071f, 0.02554963f, 
    0.06475353f, -0.00230525f, 0.20189621f, 0.09345653f, -0.02223721f, 0.04774525f, -0.00414403f, -0.14239453f, 
    -0.03194372f, -0.08527248f, -0.08726168f, -0.01791800f, -0.01788437f, -0.09278385f, 0.02193098f, -0.09050243f, 
    -0.00095307f, -0.10026768f, -0.07155409f, -0.20344165f, -0.11206736f, -0.01601055f, -0.04847801f, -0.00121516f, 
    -0.03020870f, 0.12820551f, 0.03629171f, -0.03029968f, -0.01226300f, 0.02308514f, 0.00083517f, -0.05458738f, 
    -0.06149073f, -0.03939852f, -0.04484196f, 0.02149336f, -0.27530444f, 0.09431608f, -0.13900641f, 0.02302895f, 
    0.09650749f, -0.02645960f, 0.00834920f, 0.10352273f, 0.06689444f, 0.21493647f, -0.00490843f, 0.02774173f, 
    0.34648803f, -0.06993376f, -0.14186306f, -0.05047148f, 0.06979279f, 0.05831348f, 0.01065663f, -0.00912146f, 
    -0.06077230f, 0.06757284f, -0.15639412f, -0.14577009f, -0.46701187f, 0.08543102f, 0.12369493f, 0.06181737f, 
    0.11202718f, 0.10013130f, 0.04697333f, 0.03552466f, 0.12939326f, 0.07375681f, 0.08779455f, -0.13746183f, 
    0.19964518f, -0.04294540f, 0.04935978f, -0.04600280f, 0.20573907f, -0.06307001f, -0.03544131f, -0.06768930f, 
    0.02353786f, -0.17367941f, -0.14169563f, -0.14912756f, 0.05972859f, 0.02883049f, 0.19384895f, 0.09403427f, 
    0.06204153f, -0.20241030f, 0.07359384f, 0.07887863f, -0.03497835f, 0.08280746f, -0.01485774f, 0.06162751f, 
    0.30460787f, 0.07423841f, 0.04165749f, 0.01958687f, 0.10169607f, 0.09706905f, -0.08739960f, -0.00454076f, 
    -0.05045063f, 0.14883582f, 0.07320494f, 0.02826361f, 0.16567549f, 0.09743208f, 0.06270630f, -0.03158204f, 
    0.08278100f, 0.15510951f, 0.16436745f, 0.16583160f, -0.00318686f, 0.00543944f, 0.13958484f, 0.18704127f, 
    -0.13185844f, 0.07281729f, 0.10328033f, -0.09896848f, 0.01802834f, -0.13192913f, 0.03432206f, -0.05474679f, 
    -0.04831291f, 0.05457485f, -0.01568027f, 0.18036132f, -0.00998888f, 0.03094581f, -0.13513069f, -0.23177810f, 
    0.01395216f, 0.01435661f, -0.19041888f, -0.05447554f, -0.00097694f, -0.01227504f, -0.07382425f, -0.10259648f, 
    0.30097151f, 0.12534210f, -0.12308320f, 0.09126156f, 0.10288575f, 0.07434363f, 0.04889684f, 0.22599480f, 
    0.04560544f, -0.20914638f, -0.13479985f, 0.14831363f, -0.18503815f, 0.17162329f, 0.01580590f, -0.08023185f, 
    0.09703115f, 0.15479355f, -0.02272686f, 0.10852861f, -0.10978253f, 0.08576640f, 0.09166820f, -0.13940986f, 
    -0.14023915f, 0.18710603f, 0.25897077f, 0.18716726f, -0.13900332f, 0.02887629f, 0.02363401f, 0.10704483f, 
    0.04068840f, 0.01105504f, 0.09946997f, 0.04761825f, -0.11114094f, 0.47652128f, 0.11640798f, 0.04984491f, 
    0.02067869f, -0.13710895f, 0.20291679f, 0.01178327f, 0.10062075f, -0.03384696f, -0.20765446f, 0.09251275f, 
    -0.10897931f, 0.24158114f, -0.15212905f, -0.20504954f, -0.03719611f, -0.04586375f, -0.03785706f, -0.02192098f, 
    -0.09460399f, -0.00790818f, -0.04372074f, -0.00670131f, 0.25488499f, 0.16744857f, -0.11596899f, 0.01070112f, 
    0.04699406f, 0.07254574f, -0.02762439f, -0.00005325f, -0.17410511f, 0.00467626f, 0.00241824f, 0.04056231f, 
    0.14018312f, 0.03004357f, 0.01015527f, -0.09256531f, -0.02445765f, -0.13291441f, 0.04952549f, 0.03825105f, 
    0.04516029f, -0.04771832f, -0.24967454f, -0.09012740f, 0.04174681f, -0.08329020f, -0.03973051f, -0.03041019f, 
    0.02727422f, 0.06341224f, -0.07497534f, -0.09252722f, -0.14744528f, 0.01349768f, -0.02030651f, -0.08561388f, 
    0.20703161f, 0.16230969f, 0.00435181f, 0.11935066f, -0.02422162f, 0.03525994f, -0.06977395f, 0.04781378f, 
    0.01850840f, -0.04927292f, 0.11413927f, 0.16753404f, -0.19323093f, 0.30915022f, -0.07693563f, -0.12364913f, 
    0.04939061f, -0.07066388f, -0.02936519f, 0.00342664f, -0.11313333f, -0.12705608f, -0.05417667f, -0.11593916f, 
    -0.00998636f, -0.14715335f, -0.01922879f, 0.10286804f, -0.01547415f, -0.00455169f, -0.00765266f, -0.09479380f, 
    -0.04710601f, 0.28534082f, 0.03556453f, 0.17488153f, -0.20935483f, 0.21678489f, 0.09396628f, 0.20550051f, 
    0.21847948f, -0.04484520f, -0.00374280f, -0.07199244f, 0.01111463f, -0.17669573f, 0.06161039f, -0.06995530f, 
    0.17876618f, -0.03329330f, 0.15062113f, -0.11184157f, 0.17294988f, 0.04023937f, -0.01591837f, 0.05012513f, 
    0.02421190f, 0.02721387f, -0.06214308f, -0.05267556f, -0.19035982f, -0.03639846f, 0.26846766f, 0.20477417f, 
    0.03290013f, -0.00595910f, -0.07268727f, 0.04207503f, 0.04624362f, 0.05281172f, -0.07298481f, 0.04908907f, 
    -0.20632784f, 0.24638346f, -0.10398734f, -0.17762549f, 0.01189339f, -0.02223877f, -0.00177668f, 0.03105862f, 
    0.21694005f, 0.07968903f, -0.06673396f, -0.08701166f, 0.06766113f, 0.16340037f, -0.01923046f, 0.01826769f, 
    -0.02294514f, 0.00865539f, 0.27809653f, 0.03197302f, -0.05160534f, 0.20174982f, -0.02221097f, 0.17399620f, 
    0.08442782f, -0.06149080f, 0.10915826f, -0.07222454f, -0.02123137f, -0.05440618f, -0.19929248f, -0.16686282f, 
    -0.04942179f, 0.03230917f, -0.03730152f, 0.00659458f, -0.03022441f, -0.02484928f, -0.16485104f, -0.19344242f, 
    -0.11779947f, -0.00358559f, -0.04476349f, -0.04194326f, -0.01948244f, -0.00507617f, -0.05627281f, 0.00867892f, 
    0.11700501f, 0.06137354f, 0.11058219f, 0.12182177f, 0.02120768f, 0.02258479f, -0.01431826f, -0.10828760f, 
    -0.10107312f, 0.03260830f, -0.00208942f, -0.03652084f, -0.09214607f, -0.02439192f, -0.06158531f, -0.17462221f, 
    -0.05400270f, 0.04779036f, -0.15547428f, 0.02289376f, 0.09637233f, -0.02003879f, -0.01572387f, -0.19457422f, 
    -0.08175108f, 0.14300923f, -0.20561534f, -0.19781303f, -0.07433551f, 0.00680861f, -0.00405381f, 0.00679001f, 
    -0.08984527f, 0.02352108f, -0.02461354f, -0.06308495f, -0.01043688f, 0.08310068f, 0.16295408f, 0.17854412f, 
    -0.03537361f, 0.15339220f, -0.05663414f, 0.07939853f, 0.03465756f, -0.02166279f, -0.06615431f, 0.03720772f, 
    -0.21763375f, 0.10720138f, -0.08328868f, -0.12627350f, 0.08369943f, -0.00883315f, -0.03424610f, -0.10877699f, 
    0.01749360f, -0.03645179f, 0.09414069f, 0.08210862f, 0.02500067f, 0.09297369f, 0.23199506f, 0.00217933f, 
    -0.06313396f, -0.05034234f, -0.02646300f, 0.01809167f, 0.08871967f, 0.04919873f, 0.01522778f, -0.02708552f, 
    -0.02293661f, 0.14951752f, 0.03869718f, -0.13595687f, 0.05439235f, 0.06917447f, 0.04354937f, 0.02880773f, 
    -0.03013831f, 0.08359031f, -0.00995569f, 0.17960191f, 0.04265989f, -0.04020765f, -0.08527412f, -0.06915639f, 
    0.07757212f, -0.04399368f, -0.06301710f, -0.08371866f, -0.02782158f, 0.00166242f, 0.03298369f, 0.12348995f, 
    0.26212609f, 0.06103396f, -0.16814405f, -0.07431158f, 0.13649473f, -0.01120106f, -0.08959830f, 0.03262353f, 
    -0.10705942f, 0.04369562f, -0.01226436f, 0.10556444f, 0.00923920f, -0.04168811f, 0.14792201f, 0.08069770f, 
    0.00646047f, 0.05853237f, -0.06356545f, 0.00753053f, 0.10269366f, -0.20530099f, 0.04083852f, 0.01752478f, 
    -0.08063287f, -0.15258874f, -0.00915929f, 0.21479319f, 0.18486299f, 0.05760207f, -0.00387194f, -0.05636530f, 
    0.09980015f, 0.01257266f, -0.15723915f, 0.04632882f, 0.80497772f, -0.08999013f, 0.04962464f, -0.02943222f, 
    0.17219101f, 0.03516890f, -0.02334376f, 0.08276108f, -0.02484882f, 0.01145649f, 0.18118450f, 0.12052044f, 
    0.52035540f, 0.00765665f, -0.00782412f, 0.21321994f, -0.00167134f, 0.12650794f, 0.16535155f, 0.12231471f, 
    0.04003893f, 0.10373248f, -0.08097506f, 0.03118249f, -0.32996461f, 0.24132723f, 0.18616673f, 0.05155437f, 
    0.03624097f, 0.02852437f, -0.00172122f, -0.06982857f, 0.07203666f, 0.05183436f, 0.17294079f, 0.05192354f, 
    -0.02142836f, 0.02652651f, -0.01371133f, 0.01477710f, -0.00420194f, -0.00771400f, -0.04056166f, -0.03197798f, 
    -0.00963840f, -0.00033424f, -0.02758213f, -0.04024317f, 0.03973695f, -0.01956032f, 0.01645445f, -0.01565977f, 
    -0.01891580f, -0.00535004f, -0.01722600f, 0.00244592f, -0.01311843f, -0.01757601f, -0.00577168f, -0.00874525f, 
    0.00069152f, -0.01650079f, -0.03914961f, -0.00674851f, -0.03132942f, 0.00951224f, -0.04032749f, 0.00451999f, 
    -0.01888078f, 0.00412115f, 0.01625294f, -0.02167972f, -0.01178358f, 0.00029451f, -0.03600860f, -0.01896180f, 
    0.01916910f, 0.01692331f, 0.02108770f, 0.02110743f, 0.02601767f, -0.03849258f, -0.01554712f, -0.02769833f, 
    0.01313790f, 0.02552393f, 0.02988483f, -0.02937520f, -0.02653706f, -0.00263503f, -0.02228655f, -0.02068371f, 
    0.01084622f, 0.02092255f, 0.02866241f, -0.01550379f, 0.01007964f, -0.02101951f, 0.00950125f, -0.03624951f, 
    -0.02231859f, 0.00820702f, -0.00991609f, 0.01279981f, -0.03584170f, -0.00427773f, 0.02889973f, -0.00558535f, 
    0.00160070f, 0.00264281f, 0.00605108f, -0.03763746f, -0.01837729f, 0.02877858f, -0.00524468f, -0.01768963f, 
    0.00709624f, -0.00499658f, -0.02678438f, -0.02801901f, -0.02399752f, 0.02935326f, -0.03572708f, 0.02683300f, 
    -0.01697544f, 0.01950024f, -0.04069442f, 0.00647143f, -0.02405255f, 0.01468353f, -0.03795686f, 0.01929415f, 
    -0.03768516f, 0.02182609f, 0.01454357f, -0.01157645f, 0.01815758f, -0.03542881f, -0.01335888f, 0.00253615f, 
    0.00918650f, 0.03000264f, 0.02574988f, -0.01823048f, 0.02599944f, -0.01273158f, -0.03303819f, -0.02019366f, 
    -0.00216886f, -0.01059494f, 0.02618410f, -0.03039283f, -0.04080284f, -0.00324574f, -0.00321504f, 0.00944741f, 
    -0.02494370f, -0.00029683f, -0.01527994f, -0.00647174f, -0.00042206f, -0.03460156f, -0.01960840f, 0.02561626f, 
    -0.00382898f, 0.00921322f, 0.02364707f, -0.03022211f, -0.02493135f, 0.01223392f, -0.01879773f, -0.01418637f, 
    -0.01761714f, -0.03883694f, -0.03690290f, 0.00273139f, 0.02333850f, -0.02543537f, -0.03083983f, -0.00093854f, 
    -0.02063624f, -0.01586858f, 0.00534581f, 0.00406548f, 0.00237680f, 0.02804201f, 0.00639202f, 0.02652870f, 
    -0.04138323f, -0.03010686f, 0.01743325f, 0.01589613f, 0.01466508f, -0.01882319f, 0.02628918f, -0.04169872f, 
    0.01780046f, -0.00561741f, -0.04095362f, 0.01015613f, 0.00242527f, 0.01640645f, 0.00239816f, 0.02601793f, 
    0.02995154f, -0.00612923f, 0.02471947f, 0.00355033f, 0.01477556f, 0.00478229f, -0.01887841f, 0.01723530f, 
    0.00854370f, -0.00101131f, -0.02786910f, -0.04058677f, -0.00211880f, -0.01371038f, 0.02383894f, 0.02154750f, 
    -0.02714071f, -0.01895039f, 0.02580413f, -0.03516683f, -0.01938109f, -0.03084285f, 0.01431413f, -0.03491309f, 
    -0.00695194f, 0.00852909f, -0.00824485f, 0.01364431f, 0.00180586f, -0.01789971f, 0.01063677f, -0.02125153f, 
    0.02951680f, -0.03758112f, -0.03023953f, -0.02195981f, -0.02470856f, -0.03847057f, -0.03452758f, -0.01756329f, 
    -0.02712300f, -0.03019468f, 0.01329150f, -0.02147632f, 0.01836690f, -0.01546245f, -0.02616463f, -0.02544017f, 
    -0.04011557f, 0.01227284f, 0.01495299f, -0.03752885f, -0.01499842f, -0.02137605f, -0.01094020f, -0.03143618f, 
    0.00149968f, 0.02661894f, -0.02686412f, 0.00382530f, 0.00839373f, -0.00505460f, 0.01300027f, -0.02406255f, 
    -0.01719656f, -0.03399369f, -0.00107021f, -0.03879332f, -0.01808091f, -0.02314790f, 0.03174581f, -0.02966987f, 
    -0.02637722f, 0.01158078f, 0.00200138f, -0.03054562f, 0.01827800f, 0.01878652f, -0.00547113f, 0.01330986f, 
    -0.03442628f, -0.03036935f, 0.00587719f, -0.00945819f, 0.01665600f, -0.02890624f, 0.01532874f, 0.02976558f, 
    -0.02083654f, -0.01596896f, -0.03272637f, -0.01395209f, -0.02805649f, 0.02013926f, -0.03000690f, -0.03271953f, 
    -0.01052391f, 0.00936461f, -0.03545283f, -0.01105373f, 0.00275885f, 0.01904535f, 0.02144518f, 0.01370662f, 
    0.01396207f, 0.01177417f, 0.00154961f, 0.01374740f, -0.01029869f, -0.01574508f, -0.00595834f, 0.00869470f, 
    -0.02072937f, -0.01134771f, -0.03003283f, 0.00315023f, -0.02210963f, -0.00924046f, 0.00690859f, -0.00030061f, 
    0.01661972f, -0.03206875f, -0.02042770f, 0.01824240f, -0.01611210f, -0.01543241f, 0.02762013f, 0.01919642f, 
    -0.02962974f, -0.01282318f, 0.00445942f, -0.02981417f, 0.02479933f, -0.02865436f, 0.00507496f, 0.01523065f, 
    -0.03116393f, 0.02792787f, 0.00178260f, 0.02809548f, 0.02654322f, -0.01586096f, 0.02698343f, -0.01763718f, 
    -0.01787683f, -0.03007083f, 0.01485832f, 0.01765764f, 0.02204365f, -0.03515258f, -0.01000694f, -0.01746596f, 
    -0.01289004f, -0.01488833f, 0.00534283f, -0.00976186f, 0.01651009f, -0.01632193f, 0.02128766f, -0.03039264f, 
    -0.02461749f, -0.00335701f, -0.02360787f, -0.00546777f, 0.00272586f, -0.00281385f, 0.02055384f, -0.02965629f, 
    0.01917632f, -0.00939249f, 0.00817364f, -0.03277482f, 0.00926719f, 0.01749140f, 0.01867201f, 0.00487157f, 
    -0.02341545f, -0.00079287f, -0.02562691f, -0.03731425f, -0.02854697f, -0.01143165f, -0.02337824f, -0.03870682f, 
    0.00538759f, -0.02627158f, 0.00184235f, 0.01771645f, -0.03428115f, 0.02063940f, -0.01569493f, -0.02589559f, 
    0.02890794f, -0.01179658f, -0.01438267f, 0.01548234f, 0.01312767f, -0.01830754f, 0.02946418f, 0.02322234f, 
    0.01915375f, -0.01937955f, -0.03906164f, -0.00781649f, 0.02545529f, 0.01228914f, -0.02776520f, 0.01405467f, 
    0.01811215f, -0.04163054f, -0.04203249f, -0.02351301f, -0.02778802f, -0.00159131f, 0.00532030f, -0.02171243f, 
    -0.01961972f, -0.00937549f, -0.02301829f, 0.01288750f, 0.00752746f, 0.01049245f, -0.02851817f, -0.03127169f, 
    0.01107340f, -0.03681787f, -0.02744670f, 0.01250643f, 0.00687386f, 0.02693520f, -0.00903377f, 0.00942527f, 
    -0.00087809f, -0.00424961f, -0.04142675f, -0.00890329f, 0.00056559f, 0.00562709f, -0.02728137f, 0.00151353f, 
    0.00471620f, -0.03628417f, -0.03532906f, -0.02651270f, 0.00455665f, 0.02810563f, 0.00578045f, 0.02169228f, 
    -0.00206029f, 0.00161728f, 0.00539394f, 0.01529985f, 0.01727199f, -0.01662793f, 0.02037691f, -0.02582063f, 
    -0.03642843f, -0.02097827f, -0.02776550f, -0.02511461f, 0.00790896f, 0.00733060f, 0.01053699f, -0.00724316f, 
    -0.01567653f, -0.01703227f, -0.03215560f, -0.00772095f, 0.02580580f, -0.00356389f, -0.03105712f, 0.02479000f, 
    -0.02846966f, -0.02029225f, 0.00050454f, -0.01223063f, -0.01690728f, -0.00715478f, -0.01546762f, 0.03891260f, 
    -0.02176016f, -0.01957099f, -0.01533117f, -0.04055966f, 0.01720747f, -0.04128004f, -0.03691750f, -0.03815577f, 
    -0.01634633f, -0.00627299f, -0.00071377f, -0.00231049f, 0.01651435f, -0.01024149f, 0.02552697f, 0.01230292f, 
    -0.00515919f, -0.03056049f, -0.03181757f, -0.02698193f, -0.00465526f, -0.02960413f, -0.02580202f, 0.00164124f, 
    -0.01008314f, 0.00885460f, 0.01622446f, -0.01583605f, -0.01816234f, 0.00785824f, -0.02281952f, -0.01286872f, 
    0.01793674f, 0.01089582f, 0.00373206f, 0.00470533f, -0.03618101f, 0.02969892f, 0.00028789f, 0.00394660f, 
    -0.03590197f, -0.02430559f, 0.02986829f, -0.04164838f, 0.00731008f, -0.00921390f, 0.02136241f, 0.01737529f, 
    0.00950051f, -0.03339106f, -0.00026249f, 0.01837960f, -0.03777028f, -0.03534539f, 0.02967911f, 0.01462464f, 
    -0.02624161f, 0.00356956f, 0.00048925f, 0.00862308f, -0.01084923f, -0.02458910f, 0.02192470f, -0.02715335f, 
    -0.01392321f, -0.01402975f, 0.01211813f, -0.04010115f, -0.00889233f, 0.00166823f, 0.02597221f, 0.00796688f, 
    0.00899668f, -0.01893637f, -0.01594056f, -0.02480268f, 0.01857126f, 0.01371685f, 0.01333316f, -0.02567725f, 
    -0.03027926f, -0.01071654f, 0.02910364f, -0.00119721f, 0.02128261f, -0.02508304f, 0.01425281f, 0.01280454f, 
    0.01553393f, 0.01253253f, -0.03459008f, -0.01099873f, -0.03555105f, 0.01087244f, -0.03757618f, 0.01664359f, 
    -0.02513498f, -0.03592305f, 0.01345256f, 0.01782071f, -0.01194993f, 0.01093215f, -0.02782362f, -0.02510524f, 
    -0.02659969f, -0.00172159f, 0.01024575f, 0.03003322f, 0.01387073f, 0.00785602f, 0.02883317f, -0.03128304f, 
    0.01599005f, 0.00034084f, 0.00244762f, 0.00433446f, -0.02979347f, -0.02919132f, -0.03209646f, 0.02787503f, 
    0.02238949f, 0.01365840f, 0.00270457f, -0.03855639f, 0.01206180f, -0.01985326f, 0.01003925f, -0.01849480f, 
    -0.00492469f, -0.03656719f, -0.00031830f, 0.02499348f, 0.00445465f, -0.03701893f, -0.02202239f, 0.00009998f, 
    -0.01058381f, -0.03328922f, -0.01350575f, 0.00117344f, 0.02941458f, -0.01142546f, -0.02099296f, -0.03552444f, 
    -0.02286005f, 0.01997366f, 0.01152512f, -0.00520799f, -0.00564080f, -0.01400422f, 0.00989700f, 0.02235872f, 
    0.00059636f, 0.02703848f, -0.03166869f, 0.00071816f, -0.00267195f, -0.04090340f, -0.03027013f, 0.01815658f, 
    -0.00293563f, -0.02117849f, 0.02420327f, -0.00098481f, -0.01072327f, -0.00777250f, -0.02395464f, -0.00777643f, 
    -0.02223704f, -0.00874865f, 0.01116571f, 0.02415613f, -0.02160613f, -0.01143078f, -0.03345199f, 0.02988641f, 
    -0.03184854f, 0.00918083f, -0.02817097f, -0.04020721f, -0.03340171f, 0.02549312f, -0.00831940f, -0.02023147f, 
    0.01054261f, -0.02238775f, -0.03584344f, 0.00067387f, -0.03864463f, 0.02204493f, -0.03909131f, -0.00108323f, 
    0.02004897f, -0.00338792f, 0.02322293f, 0.02152105f, -0.03545312f, -0.01240128f, -0.03111948f, -0.02537274f, 
    0.01465772f, 0.02417404f, 0.00079184f, 0.02197804f, -0.02229122f, -0.02153877f, -0.02781019f, 0.02980467f, 
    0.02689332f, -0.02418947f, -0.03545545f, 0.00784585f, -0.03464093f, -0.01137081f, 0.02259552f, -0.04181578f, 
    -0.02168963f, -0.00285573f, -0.03365596f, -0.03622781f, 0.01146206f, 0.01310406f, 0.01762021f, 0.00795095f, 
    0.02919059f, -0.03493404f, 0.00480808f, 0.00861456f, 0.02365416f, 0.00852692f, 0.01888128f, -0.02622034f, 
    0.01887259f, -0.00510426f, -0.02399178f, -0.00698974f, 0.00080663f, 0.01790325f, -0.00635311f, 0.02220673f, 
    -0.03153313f, 0.01213864f, -0.03883073f, -0.04177676f, 0.02256399f, -0.03590172f, -0.00304503f, 0.01718476f, 
    0.00586300f, -0.01130846f, 0.01804979f, -0.02075862f, 0.00349038f, 0.01417639f, -0.03019293f, 0.01065465f, 
    -0.01079823f, 0.01121696f, 0.01807803f, 0.00518440f, 0.00242952f, -0.01190438f, -0.03136527f, -0.01283938f, 
    0.01285553f, -0.03266299f, 0.01744665f, 0.01854992f, -0.02600402f, 0.00788253f, 0.00358275f, -0.00177082f, 
    0.00926381f, -0.00850878f, -0.01380945f, -0.03026562f, -0.03529707f, 0.01020746f, 0.02223616f, 0.02166959f, 
    -0.00538286f, 0.01363112f, 0.02802078f, -0.00267073f, -0.02637752f, -0.00007830f, 0.01821393f, -0.02427744f, 
    -0.03596982f, 0.00870700f, 0.01447171f, -0.00785460f, -0.03436725f, 0.00749680f, -0.01429102f, -0.01476079f, 
    0.02616798f, 0.01550031f, -0.02798238f, 0.01569914f, -0.02863963f, -0.02199563f, 0.00483787f, 0.01283171f, 
    0.01257607f, 0.00238629f, 0.02884402f, 0.02521922f, -0.00156871f, -0.02224045f, -0.02802955f, -0.01060821f, 
    0.00138937f, 0.01633499f, 0.01730841f, -0.02561550f, -0.00219141f, -0.02136770f, -0.00148430f, 0.00025091f, 
    0.03513502f, -0.02135996f, 0.00907209f, 0.00037088f, 0.02720047f, -0.02071126f, -0.01088519f, -0.02549081f, 
    0.00259517f, -0.01565514f, -0.00702029f, 0.02490421f, -0.02045623f, -0.00622821f, -0.02787091f, -0.00916879f, 
    -0.02333028f, -0.00701852f, -0.01129909f, 0.01781961f, -0.00862678f, 0.00950851f, -0.01709389f, -0.01960594f, 
    0.02591752f, -0.03324008f, 0.01409662f, 0.02989964f, 0.02983652f, -0.00245782f, 0.03190923f, -0.00752862f, 
    -0.00664726f, 0.02887738f, -0.03793660f, -0.03455057f, 0.02168292f, -0.01720732f, 0.02137537f, -0.00428120f, 
    -0.02426061f, 0.00588236f, 0.02619500f, 0.02135360f, -0.02658601f, 0.01463270f, -0.03094196f, 0.01960431f, 
    -0.00250198f, 0.02199674f, -0.02877272f, -0.00441138f, -0.02234094f, 0.02294230f, 0.01290319f, -0.00580311f, 
    0.01369207f, 0.01240796f, -0.01023462f, -0.01747564f, -0.00807036f, -0.00677913f, -0.00604423f, -0.02345542f, 
    -0.00673924f, -0.01472191f, 0.01318414f, 0.01975514f, -0.00135101f, -0.03592606f, -0.01454002f, -0.03612842f, 
    0.00754702f, -0.03135883f, -0.01627382f, 0.00738893f, -0.03077032f, -0.01716762f, 0.02375137f, -0.02960263f, 
    -0.03187537f, 0.00204541f, -0.03309539f, -0.02826368f, -0.02290486f, 0.02773314f, 0.01188915f, 0.01519426f, 
    -0.02152700f, -0.00048559f, 0.01088644f, 0.01241618f, -0.01742306f, -0.01799837f, -0.01930435f, 0.03071501f, 
    -0.03596736f, 0.02844098f, -0.00992530f, 0.01536925f, -0.03055861f, 0.00204842f, 0.00430810f, -0.01560052f, 
    0.02804881f, -0.03106631f, -0.02322482f, -0.02781585f, 0.02326754f, 0.02365266f, 0.01087905f, 0.00376539f, 
    -0.01725625f, -0.02218323f, -0.01866739f, -0.00034296f, -0.03402092f, -0.02382035f, 0.00555460f, 0.00657901f, 
    0.01059520f, 0.01787731f, 0.02559867f, -0.01385313f, 0.02375269f, -0.00713317f, -0.03326472f, 0.03155065f, 
    -0.03653529f, 0.02153560f, -0.01302957f, -0.02947824f, -0.02496721f, 0.00805856f, 0.01006939f, -0.03811507f, 
    -0.03885853f, -0.00283729f, -0.02651247f, -0.03301705f, -0.03110744f, -0.02144045f, -0.01860496f, -0.00438140f, 
    0.03367444f, -0.02928977f, -0.00906617f, -0.00229377f, -0.02629870f, -0.02669622f, 0.02818474f, -0.00138112f, 
    -0.03264959f, 0.01484724f, -0.01590002f, -0.02427384f, 0.02576239f, 0.01639589f, 0.01113118f, 0.03420597f, 
    -0.02555047f, 0.03039037f, -0.02479372f, -0.00560388f, 0.01799647f, -0.01591211f, 0.02989842f, -0.02607897f, 
    0.03345958f, -0.00448638f, 0.00275059f, -0.00618495f, -0.02735860f, -0.03223734f, -0.01885757f, 0.02347231f, 
    0.02377168f, -0.01821592f, 0.02265725f, 0.01423722f, 0.00393411f, 0.02645386f, 0.03075455f, -0.01954279f, 
    -0.03603659f, 0.01892218f, -0.03239180f, -0.01597787f, 0.01151618f, 0.01827086f, -0.02971708f, 0.02729850f, 
    -0.02859373f, -0.02634355f, 0.03749218f, -0.00373995f, -0.01405590f, -0.02220570f, 0.02692376f, -0.00752126f, 
    0.03100764f, 0.01666309f, 0.00703098f, -0.00702433f, -0.02786855f, -0.02015500f, 0.00230601f, 0.02373949f, 
    -0.00225072f, -0.02729690f, -0.01774677f, -0.01748481f, -0.03212799f, 0.01486831f, 0.00913307f, 0.00855294f, 
    -0.01938555f, -0.02464538f, -0.01752050f, 0.01420473f, 0.01648212f, 0.02169832f, -0.02486949f, -0.01828195f, 
    -0.00929380f, -0.03879261f, 0.02372604f, -0.03666080f, -0.00990690f, 0.01882243f, -0.00191755f, -0.00466123f, 
    0.02797095f, -0.03131830f, 0.02275067f, -0.00126261f, -0.01186757f, 0.00560763f, -0.00986601f, -0.01861372f, 
    0.02592319f, 0.01594990f, -0.00481509f, 0.01927099f, -0.01530047f, -0.03339839f, 0.02294989f, -0.01352232f, 
    0.00242119f, -0.01512892f, 0.00404849f, -0.00541486f, 0.02437635f, 0.03266776f, -0.02912782f, -0.02115049f, 
    0.01699308f, -0.00080480f, -0.00973184f, 0.01704881f, 0.00531423f, -0.01500627f, -0.01212670f, 0.00272223f, 
    -0.00656527f, 0.00652107f, 0.03143241f, -0.01519596f, 0.00667830f, -0.01772793f, 0.02850091f, 0.03338960f, 
    -0.03203286f, -0.02504174f, -0.01713580f, 0.02143373f, -0.00064470f, -0.01783704f, -0.01750546f, -0.00289439f, 
    -0.03700146f, -0.02434392f, -0.03811948f, -0.03406677f, 0.01056527f, 0.03151406f, 0.02790903f, 0.03059576f, 
    -0.00065566f, 0.00449883f, -0.02721967f, 0.00618640f, -0.00387725f, -0.02040813f, 0.01513860f, -0.01310255f, 
    -0.00462570f, -0.02046753f, -0.03463370f, -0.01287935f, 0.01025959f, 0.03137490f, -0.00934563f, -0.00765580f, 
    0.02156410f, -0.01017732f, -0.02587445f, -0.01372762f, 0.02441693f, -0.01976409f, 0.03241103f, -0.00540761f, 
    0.01444362f, -0.01011192f, 0.03239757f, 0.03273055f, -0.02039651f, -0.02206625f, 0.02540893f, -0.00450692f, 
    0.00174484f, 0.02188496f, 0.01274041f, -0.02209463f, 0.02612343f, 0.02600763f, 0.02112968f, 0.00378240f, 
    -0.00518016f, 0.00024178f, -0.02165468f, 0.00122990f, -0.03522106f, -0.00897861f, -0.00712706f, -0.02597861f, 
    -0.00316747f, -0.02887797f, -0.03265987f, -0.01733034f, 0.03182691f, 0.01361133f, 0.02980724f, -0.03810657f, 
    -0.00100247f, -0.01662818f, -0.03496016f, -0.03444766f, 0.01553863f, -0.02390162f, -0.00265477f, -0.00424767f, 
    0.02190453f, -0.00176296f, 0.00531989f, -0.03803831f, -0.02998075f, -0.03507777f, 0.00974864f, -0.02323769f, 
    0.01896578f, -0.01008659f, -0.00655297f, -0.00783143f, 0.00237227f, 0.00866239f, 0.02125392f, 0.02637021f, 
    -0.02362671f, 0.01733536f, 0.01757981f, -0.02179926f, 0.03097454f, -0.03085912f, -0.03924936f, -0.01298594f, 
    0.01152658f, 0.02018999f, 0.01028753f, -0.00108561f, -0.02780022f, -0.01613284f, 0.01538294f, 0.02425193f, 
    -0.01332512f, 0.01968437f, -0.01872251f, 0.03058435f, -0.03242894f, -0.02007158f, 0.03445594f, 0.00529656f, 
    -0.01471537f, -0.01554897f, 0.03082119f, -0.00562399f, -0.03604486f, -0.01839494f, -0.03598379f, -0.00671667f, 
    0.01720022f, 0.01206614f, 0.01608441f, 0.01684639f, -0.03018426f, 0.02736518f, -0.01398538f, -0.00505613f, 
    -0.01804067f, 0.02666593f, 0.02557369f, 0.01828239f, 0.00092811f, -0.03548019f, -0.03219800f, -0.02780476f, 
    0.02666665f, -0.01809392f, 0.01581858f, 0.02971859f, -0.03451670f, 0.00564505f, -0.02563922f, 0.01263715f, 
    -0.02786785f, -0.01131301f, -0.01073860f, 0.02519875f, -0.02333048f, -0.02852333f, 0.02962190f, -0.00183212f, 
    0.00981245f, 0.00584171f, -0.03526441f, 0.00458609f, 0.02853085f, 0.02709808f, -0.03499594f, -0.00473428f, 
    0.00672501f, 0.02801923f, -0.01288510f, 0.00826556f, 0.02212943f, 0.03111915f, 0.00453281f, 0.00863610f, 
    0.01916646f, -0.03314453f, -0.01773563f, 0.03441288f, -0.03143752f, -0.01896595f, -0.03086071f, -0.02663239f, 
    -0.01881732f, -0.02831944f, -0.02151004f, 0.01552709f, 0.03397297f, -0.03172376f, 0.02261081f, -0.03659680f, 
    -0.02975460f, -0.02455843f, 0.01728626f, 0.01624171f, 0.00371220f, 0.01827364f, -0.02977306f, 0.00606942f, 
    0.00205217f, -0.01917697f, -0.00287128f, 0.00078853f, 0.02970910f, -0.00489273f, -0.01157005f, -0.03047375f, 
    -0.03445159f, 0.00339017f, 0.00679555f, -0.00733168f, -0.00839818f, 0.02101420f, 0.02729606f, -0.03807180f, 
    0.01843398f, 0.02747641f, 0.02646110f, -0.03265603f, -0.00155113f, -0.00224266f, 0.02568728f, 0.00257757f, 
    -0.02649500f, -0.03434489f, -0.03673037f, -0.01346143f, -0.01059189f, -0.02400892f, 0.02219709f, -0.02281689f, 
    -0.02407906f, -0.01253606f, 0.01549159f, 0.01271293f, 0.02955004f, -0.01267502f, 0.02494104f, -0.02819448f, 
    -0.03679122f, 0.01616425f, -0.00445368f, 0.02533828f, -0.02987646f, -0.02585400f, 0.00049944f, 0.01180216f, 
    -0.02238936f, -0.01572742f, -0.02012849f, -0.02353994f, -0.03424319f, -0.00722300f, 0.01201832f, 0.00829345f, 
    -0.00131904f, -0.02124301f, -0.01650790f, 0.00358354f, 0.00878289f, -0.02817347f, -0.00895335f, 0.00805364f, 
    -0.00584392f, -0.02137279f, -0.01856113f, 0.00580906f, -0.01847138f, -0.03059563f, 0.01141898f, -0.00816745f, 
    -0.00108527f, -0.00521374f, -0.01898711f, 0.00263790f, 0.03333699f, 0.01323056f, -0.00184141f, -0.01291392f, 
    -0.03536984f, -0.03262338f, 0.00307347f, 0.00153304f, -0.01971775f, -0.00140631f, 0.00941771f, 0.00129729f, 
    -0.02137978f, -0.01914124f, -0.01133838f, 0.00725894f, -0.03724278f, -0.02560878f, -0.03173639f, 0.00763453f, 
    0.02978889f, 0.02940372f, 0.01096149f, -0.00933564f, 0.04320163f, -0.03041975f, -0.03562245f, 0.02818874f, 
    0.00047029f, -0.01645199f, 0.00200385f, -0.03378411f, 0.03267652f, -0.02976466f, 0.01664431f, -0.03887435f, 
    0.00694504f, -0.01761124f, 0.00944095f, 0.01687248f, 0.00827184f, 0.02070780f, 0.02333205f, -0.03531639f, 
    0.00162634f, -0.00070951f, 0.02930953f, -0.02796944f, 0.00851107f, 0.01044909f, -0.03621087f, -0.01858347f, 
    0.00395367f, 0.01465841f, -0.01830639f, -0.01131669f, -0.00895074f, 0.01359030f, 0.00025477f, 0.02717629f, 
    0.02411071f, -0.02269645f, 0.02187363f, -0.00123333f, 0.02856022f, 0.00751890f, 0.02763187f, -0.03834239f, 
    0.00680785f, 0.02868505f, -0.02331977f, 0.01624930f, -0.02043823f, -0.02408888f, 0.03030861f, -0.01566860f, 
    -0.01416349f, -0.00698158f, -0.03429096f, 0.00787328f, -0.02268801f, 0.03302803f, -0.02905358f, 0.00978731f, 
    -0.01526709f, 0.01081916f, 0.01498166f, 0.03236139f, -0.01754163f, -0.03227172f, 0.01794728f, -0.01660817f, 
    0.02861248f, -0.01008758f, -0.01173390f, 0.03011043f, -0.02819251f, 0.01609547f, -0.00908595f, 0.00702214f, 
    0.02292223f, 0.01377154f, -0.03003636f, 0.02067162f, 0.00045326f, 0.00402669f, -0.01433162f, 0.01795395f, 
    -0.02076361f, 0.01956497f, -0.00031183f, -0.01500325f, 0.00278559f, -0.02027739f, -0.03585947f, 0.03162796f, 
    0.02206025f, -0.00585426f, 0.03058331f, -0.00139077f, -0.01402622f, 0.00655584f, -0.02073682f, 0.00872175f, 
    -0.03467980f, -0.03056473f, 0.01067110f, -0.02347561f, 0.02252927f, 0.01902957f, 0.00028949f, 0.00085580f, 
    0.00802676f, -0.02654283f, 0.01497468f, 0.03241368f, -0.03334502f, -0.03129335f, -0.01050626f, 0.00524614f, 
    0.00499096f, 0.00289745f, -0.00813385f, -0.00881290f, 0.03206244f, 0.01445729f, -0.02855056f, 0.02443754f, 
    0.01172932f, 0.00277736f, 0.03314822f, 0.02489683f, 0.00000566f, 0.00288260f, 0.00320091f, -0.01643924f, 
    0.03075889f, 0.01093660f, 0.03354481f, 0.02285467f, 0.01604261f, -0.03116709f, 0.00825466f, -0.03449833f, 
    -0.01764101f, -0.02702387f, 0.02664560f, 0.03383166f, 0.01276695f, -0.03658693f, -0.01632994f, 0.03107799f, 
    0.01495244f, -0.02243508f, 0.03288183f, 0.00947436f, 0.02297597f, 0.02501998f, 0.02742843f, 0.00688219f, 
    -0.00063370f, -0.00644526f, -0.01499225f, 0.00927859f, -0.00518076f, 0.01649847f, -0.03178217f, -0.02269531f, 
    0.03135410f, -0.02580240f, -0.01161284f, 0.02238857f, -0.02419881f, -0.01646462f, 0.00990382f, -0.01278366f, 
    -0.01218495f, -0.03693832f, -0.01073768f, -0.00088259f, -0.01606239f, 0.01223627f, 0.00170788f, 0.03018555f, 
    -0.01673835f, 0.01609010f, 0.00024886f, -0.03179957f, -0.03010380f, -0.02239261f, -0.02403264f, -0.01284357f, 
    -0.02601811f, -0.00549365f, -0.02165903f, -0.03411693f, -0.02680421f, 0.00672445f, 0.00521481f, 0.03124833f, 
    0.02513693f, 0.01148517f, -0.01023677f, 0.01100204f, 0.01614046f, -0.03416188f, -0.03778046f, -0.00989519f, 
    -0.04027989f, 0.02451494f, 0.02463981f, 0.02018836f, 0.02809995f, 0.00619667f, 0.01949449f, 0.01417095f, 
    -0.01864421f, 0.00520215f, -0.00507054f, 0.01834656f, 0.02452745f, 0.03808486f, 0.02688160f, -0.01654473f, 
    0.00008674f, -0.00929128f, -0.03019868f, 0.02528492f, 0.00241193f, -0.00560471f, 0.02285025f, 0.00915287f, 
    0.02844137f, -0.03998685f, -0.03144559f, -0.02711871f, 0.01775983f, 0.00782380f, -0.02098742f, -0.02284357f, 
    0.02209391f, -0.03464353f, 0.01826350f, 0.02678112f, 0.01622480f, 0.02456735f, -0.01556562f, -0.01541691f, 
    0.02922035f, 0.02381616f, -0.03869589f, -0.02560330f, -0.00466308f, 0.02247071f, -0.03555315f, -0.01518399f, 
    -0.00808791f, -0.04006473f, -0.01138575f, -0.00003807f, -0.00962348f, 0.02987825f, 0.02902702f, -0.00294386f, 
    -0.02277592f, -0.00267991f, -0.01938093f, -0.01034280f, 0.00532943f, 0.01762751f, 0.00499554f, 0.02104744f, 
    -0.03703437f, -0.03146747f, 0.02653022f, -0.02774101f, -0.03690230f, 0.02731443f, -0.01580646f, -0.03923020f, 
    -0.02424888f, 0.00065975f, -0.03010564f, 0.02638039f, 0.02405295f, -0.01339273f, -0.01858282f, -0.02884150f, 
    0.02071027f, -0.01831714f, 0.02769963f, -0.03528365f, 0.00081326f, -0.01602484f, -0.01125315f, 0.02666610f, 
    -0.03031413f, 0.01967107f, 0.02371425f, 0.01065781f, -0.00736854f, -0.00870273f, -0.00017568f, -0.01384504f, 
    -0.01685162f, 0.01544740f, 0.02118486f, 0.01586681f, -0.01718106f, -0.00299099f, -0.00362396f, 0.02455094f, 
    -0.00279276f, -0.03942735f, 0.00424402f, 0.02129504f, 0.00267806f, -0.02113390f, -0.04157915f, -0.00051437f, 
    -0.03174156f, -0.01459196f, 0.02522017f, -0.02712361f, -0.00883535f, -0.03805435f, -0.00489943f, 0.00409508f, 
    0.00936640f, 0.02314865f, -0.03118010f, 0.00569716f, 0.00350508f, 0.02144549f, 0.01357225f, -0.02931314f, 
    -0.02681950f, 0.02713453f, 0.00113789f, -0.02176422f, 0.01314037f, -0.03461864f, -0.01700344f, -0.01312630f, 
    0.02173253f, -0.01802854f, -0.02591422f, 0.00041179f, -0.03722657f, -0.01423618f, 0.00037623f, 0.01696297f, 
    -0.01576398f, 0.02841931f, 0.02119679f, 0.00299640f, -0.03050045f, -0.03412814f, -0.01010549f, -0.01886685f, 
    0.02340803f, 0.02262896f, -0.02005055f, 0.01499871f, -0.00363812f, 0.00043159f, -0.02574109f, -0.04081818f, 
    0.01877455f, 0.03273061f, 0.02181031f, 0.01402979f, -0.02505145f, 0.01152123f, 0.01810316f, -0.03539811f, 
    -0.03960301f, -0.02083991f, 0.00648838f, -0.01497617f, 0.01708198f, 0.00877138f, -0.02997544f, 0.00906975f, 
    0.00373285f, 0.01004864f, -0.01398992f, 0.02759404f, 0.00872521f, -0.02676364f, 0.01329945f, 0.01626482f, 
    -0.03973702f, -0.01234595f, -0.02910591f, 0.02567825f, 0.01964775f, -0.02086657f, 0.00558318f, 0.02441821f, 
    0.02919363f, -0.00692647f, 0.01771718f, -0.00117732f, -0.02506852f, -0.01348882f, -0.00394924f, -0.00628321f, 
    -0.03717950f, -0.02223204f, -0.02046905f, -0.01219349f, -0.02835191f, -0.03061720f, -0.01039157f, -0.00101525f, 
    -0.00472050f, -0.03867909f, -0.00867739f, 0.00303304f, 0.00908340f, 0.01832968f, -0.01099157f, 0.01434634f, 
    -0.00242083f, 0.00388558f, -0.00425393f, 0.00748671f, -0.02597516f, 0.01762813f, 0.02653142f, 0.03155446f, 
    -0.00923990f, 0.02218259f, -0.00724497f, -0.02530321f, -0.03469114f, 0.02419302f, 0.00628035f, -0.03947914f, 
    0.02806045f, 0.02744853f, -0.01608080f, -0.01769636f, 0.02665878f, -0.01708434f, -0.01069109f, -0.03940508f, 
    -0.03548777f, -0.00199279f, -0.03050279f, 0.00149050f, 0.03661595f, 0.01574037f, 0.00108665f, -0.00813341f, 
    -0.03219596f, -0.01106100f, 0.00616698f, 0.00269379f, 0.00896060f, -0.02082381f, 0.00131874f, 0.00350923f, 
    -0.02102944f, 0.02204800f, -0.03485973f, -0.00398725f, -0.02559118f, -0.00741875f, -0.02443672f, -0.01975081f, 
    -0.03028827f, 0.01109699f, -0.00399523f, -0.01050450f, -0.04109791f, -0.00697763f, 0.00325805f, -0.02027094f, 
    0.00587816f, -0.00613501f, -0.00970285f, -0.00302400f, -0.01494573f, -0.00274358f, 0.00472834f, 0.02694187f, 
    -0.03897142f, 0.03177645f, -0.02524241f, 0.01166694f, -0.03955656f, -0.01828422f, -0.00822439f, -0.00458717f, 
    -0.00920905f, 0.00327799f, -0.00612684f, 0.01481526f, -0.01853645f, -0.03240285f, -0.02774556f, -0.04023262f, 
    -0.00430607f, -0.01414253f, -0.03218997f, -0.03160369f, 0.01508596f, -0.03576683f, 0.02950066f, -0.02925862f, 
    0.02558251f, -0.02677235f, -0.00025374f, -0.00235799f, 0.00883645f, 0.02310586f, 0.01002825f, -0.02591027f, 
    0.00555650f, -0.00984470f, -0.02081040f, 0.00703630f, 0.01607183f, 0.01351865f, -0.03440514f, -0.03481383f, 
    0.01722872f, -0.00277224f, 0.02118549f, -0.02225234f, -0.02829454f, 0.01463273f, -0.03952539f, -0.02803337f, 
    -0.02205861f, 0.01449627f, -0.01785370f, -0.01247759f, -0.00261054f, -0.02754526f, -0.02556969f, -0.02161532f, 
    0.04031277f, -0.00682447f, -0.03744897f, 0.01022084f, 0.00656327f, 0.01611449f, -0.00472815f, -0.00652816f, 
    0.00071689f, -0.02236685f, -0.01791164f, -0.00504664f, -0.01775458f, -0.02859579f, -0.02530637f, -0.03943129f, 
    -0.01116855f, 0.01728320f, -0.01266004f, 0.00528675f, -0.00876352f, 0.00985132f, -0.01361716f, -0.01571189f, 
    -0.00907019f, -0.02837733f, 0.02933805f, -0.03974375f, -0.01398451f, -0.02135630f, 0.00241007f, 0.01334272f, 
    0.02828738f, -0.02325999f, -0.01141097f, 0.00823081f, 0.00582309f, 0.02652432f, -0.00980194f, -0.03402983f, 
    -0.00060261f, -0.01629277f, 0.02250257f, 0.00868377f, 0.00822061f, -0.00742657f, 0.02050813f, 0.02847826f, 
    0.00846676f, -0.02351243f, 0.01793430f, -0.02572526f, -0.01391659f, -0.02845508f, 0.01143170f, -0.02194923f, 
    -0.00599390f, -0.00084364f, 0.03927142f, 0.00491460f, -0.00319857f, -0.00478957f, -0.01368917f, -0.00805307f, 
    -0.03385792f, -0.03393897f, 0.01466666f, 0.01526840f, -0.01176046f, -0.00957980f, -0.01854082f, -0.01760199f, 
    -0.03873056f, 0.01000904f, 0.03010316f, 0.02981606f, -0.02525693f, 0.01285331f, 0.01549502f, -0.02982203f, 
    -0.02730771f, 0.00197609f, -0.00515008f, 0.01952787f, -0.02704215f, -0.01188666f, -0.01436047f, -0.00072151f, 
    0.00285113f, 0.03998782f, -0.02613625f, -0.02320141f, 0.01623395f, -0.01668428f, -0.03835317f, -0.03895265f, 
    -0.00627757f, 0.01986017f, -0.02302070f, -0.00356283f, 0.01128204f, 0.00680748f, -0.01668014f, 0.00932328f, 
    -0.03471277f, -0.00428550f, -0.01883188f, -0.00361816f, -0.01447460f, -0.00403498f, -0.00882755f, 0.02638927f, 
    -0.02221197f, 0.00580176f, 0.00527866f, 0.02196011f, -0.01543079f, 0.02072444f, 0.02602112f, -0.03324169f, 
    0.02536277f, -0.00639828f, 0.01003855f, 0.01358084f, 0.00326721f, -0.01308198f, 0.01993471f, 0.01385446f, 
    -0.03855176f, -0.02647648f, 0.00790097f, 0.01636048f, 0.02168663f, 0.00657154f, 0.00802445f, -0.02240619f, 
    0.00752384f, -0.00103299f, -0.00777322f, 0.02577279f, -0.03394878f, 0.02373469f, -0.00477557f, -0.03056884f, 
    0.00194811f, -0.02797124f, -0.02682904f, -0.01091560f, 0.00301414f, 0.02728973f, -0.01457924f, 0.02111672f, 
    0.00719754f, -0.02212133f, -0.02143173f, 0.01106961f, 0.02749371f, -0.03288229f, -0.00790298f, 0.02722009f, 
    -0.02315087f, 0.01466029f, 0.01551454f, -0.00647088f, -0.01396434f, 0.02776842f, -0.00568968f, 0.01818166f, 
    -0.01118420f, 0.03023558f, 0.00310574f, 0.02100575f, -0.00134450f, 0.02542341f, -0.02765952f, -0.02603281f, 
    0.02452456f, 0.02231107f, -0.00958205f, -0.00086481f, 0.02136868f, 0.00804671f, -0.01797017f, 0.02117145f, 
    0.02528931f, 0.01502570f, -0.01676339f, 0.00725419f, 0.00123957f, 0.00993058f, 0.01041904f, 0.01553577f, 
    -0.02096264f, -0.03381512f, 0.00224089f, -0.00898427f, 0.02857580f, -0.00230899f, -0.03892786f, -0.02783877f, 
    -0.03904422f, -0.01776280f, -0.00220749f, -0.04080041f, -0.00408067f, -0.03055709f, -0.01957000f, -0.00882926f, 
    -0.01429423f, -0.02418480f, 0.03016637f, -0.01497361f, 0.02804934f, 0.02279336f, -0.01976403f, -0.01262033f, 
    0.01529960f, 0.02974515f, -0.01747374f, 0.00392541f, 0.02329407f, 0.03018619f, 0.01441765f, 0.02936074f, 
    -0.04109005f, -0.01417418f, -0.02157746f, -0.01130328f, -0.03980020f, 0.02926159f, 0.03966820f, -0.02407812f, 
    0.00601885f, -0.00125988f, 0.00052255f, -0.01630813f, -0.01707552f, 0.02836770f, -0.01297718f, 0.00241314f, 
    0.02265896f, -0.02994754f, -0.03516278f, -0.00854343f, -0.01164701f, 0.01457566f, -0.02111766f, -0.00132338f, 
    0.01860360f, 0.01040436f, -0.01972431f, 0.01584607f, -0.02837521f, 0.00120549f, -0.00736166f, -0.03344706f, 
    -0.00056021f, -0.02862441f, 0.01253129f, 0.01622868f, -0.02844847f, -0.02435642f, 0.03564427f, -0.00810493f, 
    0.02504689f, 0.02197021f, -0.02725861f, 0.00275950f, -0.01721733f, 0.03967787f, -0.00799619f, -0.01213783f, 
    -0.01413298f, 0.00382295f, 0.04068098f, 0.00211290f, -0.03999631f, -0.02195963f, -0.02533639f, 0.01641648f, 
    0.02764630f, -0.02486222f, 0.02848079f, -0.01067278f, 0.01974028f, 0.00242682f, 0.01941856f, -0.01891539f, 
    -0.02419145f, -0.02633728f, 0.00903988f, -0.01418283f, -0.01814478f, 0.01427014f, -0.03596682f, -0.01741398f, 
    -0.00619615f, -0.01076733f, -0.00465992f, 0.02261885f, -0.03422325f, -0.03072263f, -0.02398461f, -0.01277719f, 
    -0.00647345f, -0.00166700f, -0.01382350f, -0.03457669f, -0.00785243f, -0.00315724f, 0.00170121f, -0.01360823f, 
    -0.01938585f, -0.03371542f, -0.00193458f, -0.00357131f, -0.03537687f, -0.00704963f, -0.02578655f, -0.02976888f, 
    -0.02034167f, -0.00013579f, 0.02250335f, -0.02221014f, -0.01169420f, 0.01610300f, 0.02151889f, -0.04072772f, 
    -0.00301080f, 0.00293314f, -0.01129150f, 0.01467255f, -0.01218042f, 0.02276727f, -0.02491306f, 0.03989575f, 
    0.02960235f, 0.00597626f, 0.02014014f, 0.01877226f, -0.01530151f, -0.00971109f, -0.03206334f, 0.02457660f, 
    0.00213308f, -0.02565133f, -0.03318582f, -0.00155268f, -0.01125644f, -0.02537088f, 0.01236318f, -0.01184703f, 
    -0.03546971f, -0.02024958f, -0.01677741f, 0.01535819f, -0.03053799f, 0.01788995f, 0.00356064f, -0.01584528f, 
    -0.03542080f, -0.03007172f, -0.00724072f, 0.00439383f, -0.03314941f, 0.01238665f, -0.01796362f, -0.01693298f, 
    -0.00346142f, 0.00290090f, -0.03464298f, -0.03162820f, -0.02509771f, 0.02489304f, -0.03611565f, -0.01965135f, 
    -0.03808767f, -0.03735398f, -0.00304302f, -0.03923279f, -0.00516636f, 0.01953485f, 0.01459156f, -0.01024368f, 
    -0.02122556f, -0.03836867f, -0.00184405f, -0.03007346f, -0.00459500f, 0.02062776f, -0.03550076f, -0.03542388f, 
    -0.03414717f, 0.00000930f, -0.00032194f, -0.01746367f, -0.03717478f, -0.00417539f, 0.01362940f, -0.00875742f, 
    0.02440190f, -0.01746490f, 0.02801739f, 0.01200054f, -0.03058589f, 0.02642211f, 0.00474052f, 0.01050768f, 
    0.01349538f, -0.03120655f, 0.01445815f, 0.00799952f, -0.01668705f, -0.00469741f, 0.00925208f, -0.00494964f, 
    -0.03451152f, 0.01829136f, -0.02414298f, 0.00298804f, 0.01583692f, -0.02264327f, -0.02220193f, -0.02802920f, 
    -0.10278174f, 0.07002557f, 0.25769424f, 0.14616229f, -0.07669742f, -0.06484944f, -0.06064340f, 0.06500990f, 
    0.06135655f, -0.00481924f, -0.06714878f, 0.03118486f, -0.31516147f, -0.11164831f, 0.11415897f, -0.04627558f, 
    0.09214295f, 0.00670677f, 0.09660952f, -0.10057925f, 0.05234950f, 0.03444033f, -0.02605565f, 0.05204383f, 
    -0.12846960f, -0.16230312f, -0.04010911f, 0.18514147f, 0.10457306f, -0.08971830f, -0.03524102f, -0.06057344f, 
    0.12652722f, -0.03952084f, 0.10339238f, 0.01243620f, -0.04140425f, 0.10141935f, -0.04520838f, 0.02513950f, 
    -0.00483869f, 0.00984505f, -0.01239456f, 0.00792154f, -0.11774676f, 0.03035526f, 0.01811033f, 0.02320524f, 
    -0.30958891f, -0.06899866f, -0.01194187f, -0.17114440f, 0.09122710f, -0.02047880f, -0.01803037f, -0.03938084f, 
    -0.04012549f, 0.01104030f, -0.08569650f, -0.08800723f, 0.23146920f, -0.02393476f, 0.19195497f, -0.05243519f, 
    0.03109323f, -0.07759304f, -0.05377135f, 0.05394290f, 0.04220734f, 0.05457051f, -0.08417749f, 0.05567368f, 
    -0.20940073f, 0.13368750f, -0.00026448f, -0.03848403f, 0.00146423f, -0.11753289f, 0.01849467f, -0.15063781f, 
    0.08077863f, 0.04013088f, 0.00474994f, 0.00702341f, 0.43553326f, -0.09036472f, -0.07826389f, 0.00489743f, 
    0.00216243f, 0.01068116f, -0.00463146f, 0.04695325f, -0.00993337f, -0.00054128f, -0.12497503f, 0.03721290f, 
    -0.15533780f, 0.03541353f, 0.15151455f, 0.01476852f, 0.03996311f, 0.06984369f, 0.08810815f, -0.04932555f, 
    -0.02617299f, -0.10075909f, 0.07305696f, -0.01764388f, -0.08483773f, -0.06412899f, 0.18487436f, 0.19526824f, 
    0.09937054f, 0.18414089f, 0.00030900f, -0.07782871f, -0.00867222f, -0.06597112f, -0.03185754f, 0.07226872f, 
    0.28515452f, 0.04717622f, -0.06572912f, 0.15171099f, 0.01802737f, -0.11762998f, 0.08588267f, 0.08130457f, 
    -0.04689230f, -0.00558584f, -0.04605028f, 0.10623447f, 0.12860666f, -0.06423191f, -0.01959330f, 0.10434353f, 
    -0.03332281f, 0.03309852f, -0.01059476f, -0.00407086f, -0.02516242f, -0.06942672f, 0.10004768f, 0.07893462f, 
    -0.12252307f, -0.08337326f, 0.05395069f, -0.04316506f, -0.02221332f, 0.06462938f, -0.11152542f, 0.09134542f, 
    -0.10820131f, 0.00621754f, -0.00110009f, -0.01861817f, -0.30373940f, 0.01210030f, 0.12063058f, -0.08356734f, 
    0.02002647f, 0.00937940f, 0.04054800f, -0.08744494f, 0.06104566f, -0.09051283f, 0.01565666f, -0.01336286f, 
    0.00535527f, 0.07797679f, 0.17518182f, 0.03121171f, 0.08625650f, -0.04392241f, 0.07051453f, -0.14502336f, 
    -0.05500250f, -0.04669159f, 0.11142426f, -0.03565899f, -0.07154627f, 0.20333914f, -0.18391962f, 0.08532421f, 
    -0.05141336f, -0.01705182f, -0.02335015f, 0.05104495f, -0.00419955f, -0.04538859f, -0.09703866f, 0.04792286f, 
    0.07092687f, -0.05773448f, 0.02372093f, 0.06062103f, 0.12664822f, 0.05059894f, -0.06797548f, 0.11622675f, 
    0.01783374f, 0.05425751f, -0.06274980f, 0.11905222f, -0.12815575f, -0.05926429f, 0.11777729f, 0.12568547f, 
    0.10286827f, 0.04320882f, 0.05983044f, 0.00114905f, 0.02515954f, 0.16103323f, -0.09439359f, -0.04894169f, 
    -0.07807219f, 0.16831224f, 0.10610438f, 0.20124754f, 0.08088429f, 0.07673253f, 0.05715467f, -0.03442290f, 
    0.08186743f, -0.00504095f, -0.14619942f, 0.06970262f, -0.09250811f, 0.20548183f, 0.01869292f, 0.16663596f, 
    0.02047894f, 0.10628750f, -0.07396873f, 0.14019318f, 0.06681379f, 0.02715751f, 0.07018614f, -0.04091113f, 
    0.20756407f, 0.14915740f, -0.11946429f, 0.08432506f, -0.09195786f, -0.08480672f, 0.04211515f, -0.13433617f, 
    -0.08505291f, 0.00019796f, -0.00217095f, 0.09849905f, 0.27677807f, -0.11729121f, -0.12991904f, -0.04169007f, 
    -0.06792523f, 0.01181040f, -0.00930754f, -0.07340440f, -0.04172215f, -0.11404610f, 0.01640982f, -0.04785619f, 
    -0.40407732f, 0.01475268f, 0.11397190f, -0.16130480f, -0.02698066f, -0.09393118f, 0.09017012f, -0.04471687f, 
    -0.02473969f, 0.10778474f, 0.04173706f, 0.00148483f, 0.12930740f, 0.20183985f, -0.14065936f, 0.20111336f, 
    0.02642000f, -0.00839581f, 0.05196721f, -0.01620742f, 0.10086603f, 0.03787066f, -0.03621413f, 0.02872376f, 
    0.13057762f, -0.12538809f, -0.04575662f, -0.11525041f, 0.08019941f, -0.11963168f, 0.01097728f, -0.05498904f, 
    -0.01686301f, 0.19780888f, 0.03405094f, 0.03647589f, -0.23064621f, 0.16560636f, -0.04130730f, 0.02051057f, 
    -0.00016611f, -0.02071856f, -0.16053240f, -0.06936406f, -0.01843583f, -0.03797397f, 0.00658257f, -0.03962540f, 
    0.00581782f, -0.04800596f, -0.01196639f, -0.06800323f, 0.05800884f, -0.05486439f, 0.00605374f, -0.06576005f, 
    0.12173497f, 0.04721333f, 0.00209005f, -0.01898544f, 0.01272117f, -0.12255318f, 0.18868756f, 0.09281974f, 
    -0.04383763f, -0.12609170f, 0.11525993f, 0.05566994f, 0.00443499f, 0.10422412f, -0.04269506f, 0.02050148f, 
    0.21503909f, 0.03593403f, 0.23032452f, -0.17054233f, 0.06697697f, -0.06587791f, 0.08029427f, 0.11001199f, 
    0.01966703f, -0.00129421f, 0.00323312f, 0.00971056f, -0.40713266f, -0.00912660f, -0.02401839f, -0.00049164f, 
    0.08310527f, 0.07774295f, 0.01276412f, -0.03165161f, 0.05298188f, 0.03729625f, -0.01989851f, -0.04496793f, 
    -0.12498967f, -0.06151740f, 0.15105960f, -0.01081276f, 0.07659604f, -0.01946663f, -0.06367040f, 0.05543061f, 
    0.04992376f, -0.01460648f, 0.00309633f, 0.01654494f, -0.02596664f, 0.01760667f, -0.07490276f, 0.07831042f, 
    0.05446331f, 0.05508184f, -0.08785612f, -0.08389078f, -0.09080753f, -0.02882507f, 0.03225574f, 0.01039368f, 
    0.30614689f, 0.05569020f, -0.08340621f, 0.05392909f, 0.10362193f, 0.08347161f, -0.03290662f, 0.12113451f, 
    -0.16557844f, 0.02764860f, 0.11551018f, 0.02036828f, -0.10662404f, 0.10946447f, 0.02341202f, 0.10894085f, 
    0.04644248f, 0.07445727f, 0.02610925f, -0.01342959f, -0.04354768f, 0.04038367f, 0.01014538f, 0.03582400f, 
    0.04185527f, 0.26905444f, 0.12761211f, 0.04586839f, 0.04071405f, 0.05364157f, 0.06198769f, 0.03352738f, 
    0.10014527f, 0.04414999f, -0.04525863f, 0.08581586f, 0.13136965f, 0.44682038f, -0.07280547f, 0.12656449f, 
    0.00456782f, -0.05977932f, -0.04167576f, 0.09343146f, 0.03075914f, 0.00047651f, 0.05020784f, 0.05409747f, 
    -0.25356904f, 0.19614083f, -0.10651264f, 0.03265913f, 0.03731376f, -0.00418901f, 0.04354079f, -0.02827865f, 
    -0.04473597f, 0.01243581f, 0.03537518f, 0.01348229f, 0.21028797f, 0.06474333f, -0.00924935f, 0.11217201f, 
    0.21318798f, 0.05359619f, 0.03246304f, 0.04516747f, -0.10304163f, 0.00811328f, 0.07087080f, 0.05370287f, 
    0.03921631f, -0.04777223f, 0.05571891f, -0.13106294f, -0.04791473f, 0.00891873f, -0.02546874f, 0.06194533f, 
    -0.04091481f, -0.00120456f, -0.01054151f, 0.14144969f, 0.17465751f, -0.24251235f, -0.09458256f, 0.09418510f, 
    -0.06187705f, 0.04373078f, -0.03710497f, -0.02965372f, -0.08021282f, 0.09208256f, -0.02116123f, -0.06682617f, 
    -0.00754557f, 0.31865728f, 0.07568865f, 0.09562417f, 0.04127029f, -0.02620142f, -0.03692654f, 0.09473523f, 
    0.08708227f, 0.00324047f, 0.02408777f, -0.05732603f, -0.13740237f, 0.21435924f, -0.08532989f, -0.01268174f, 
    0.03337499f, 0.03324767f, 0.01915983f, -0.01562632f, -0.05093141f, -0.05650783f, -0.00716450f, 0.03045940f, 
    -0.04698571f, -0.05323800f, -0.06498272f, -0.02961691f, 0.11269487f, 0.09531633f, 0.03325997f, 0.00447599f, 
    -0.08214975f, 0.01697516f, 0.05871735f, -0.01975626f, -0.22029714f, 0.30679324f, 0.02979762f, 0.02442235f, 
    -0.01862318f, 0.01036783f, 0.02363330f, 0.08769523f, 0.00406183f, 0.05400700f, -0.02730090f, -0.00024900f, 
    -0.05459323f, 0.13928191f, 0.13425110f, -0.19396633f, 0.10719518f, -0.02042037f, 0.03165720f, 0.04028057f, 
    0.07869822f, -0.03047152f, 0.01763438f, 0.01371077f, -0.07115440f, 0.16839421f, 0.15528223f, 0.13589911f, 
    0.05710043f, 0.02628649f, -0.11154903f, -0.01438219f, -0.00038360f, 0.02899677f, 0.02420865f, 0.07365680f, 
    -0.19325928f, 0.16552593f, 0.02822822f, -0.08189806f, -0.06470109f, -0.09038042f, 0.04386083f, 0.02871531f, 
    0.07214531f, 0.03013101f, 0.06032848f, -0.12109786f, 0.24520922f, -0.03691355f, 0.18307230f, 0.03149245f, 
    -0.05142437f, 0.06702325f, 0.04345680f, -0.24905178f, -0.05894198f, 0.12699834f, 0.08438317f, 0.05294760f, 
    -0.18522581f, -0.32969895f, -0.04961708f, 0.03854741f, 0.00639121f, 0.03177392f, -0.03567294f, -0.01055219f, 
    -0.05732979f, 0.00004856f, 0.10650612f, 0.00184375f, 0.09686970f, 0.15243013f, 0.09200599f, -0.03192721f, 
    -0.08469986f, -0.07903755f, 0.06666595f, -0.07781597f, 0.09559021f, 0.00346001f, -0.08691735f, -0.04246976f, 
    -0.03839501f, 0.03659911f, 0.12210397f, -0.00813156f, -0.06415354f, 0.05412645f, -0.09066235f, 0.02003647f, 
    0.13746090f, -0.00435852f, 0.01659294f, 0.00838319f, -0.23972957f, -0.01740242f, 0.02994462f, 0.02002810f, 
    -0.14454021f, 0.00051811f, 0.01022382f, -0.05424908f, 0.05475826f, -0.04873601f, 0.01935040f, 0.06322194f, 
    -0.08063551f, -0.01375249f, 0.01259445f, 0.26638106f, 0.06768334f, 0.01226825f, 0.00156346f, 0.03531097f, 
    -0.02024548f, -0.01696314f, -0.01204685f, -0.02824256f, 0.05569191f, -0.04989543f, 0.01048907f, 0.23180410f, 
    -0.00883899f, 0.02384712f, -0.06745405f, 0.03554438f, 0.03566700f, 0.02514741f, -0.10732405f, 0.02211582f, 
    -0.10974023f, 0.10767351f, -0.06827548f, -0.14771216f, 0.03154389f, -0.08756587f, -0.05111516f, -0.07256761f, 
    -0.02066256f, 0.00665406f, 0.00174305f, -0.14197682f, 0.05762597f, -0.16050792f, -0.11150045f, -0.00571493f, 
    -0.00388933f, -0.00568378f, -0.04150762f, 0.00917373f, 0.06379359f, 0.14237261f, 0.07468368f, 0.10617856f, 
    -0.02398310f, 0.01529288f, -0.00913956f, 0.06663399f, 0.00350272f, 0.07870774f, 0.06986977f, 0.10457823f, 
    -0.13134329f, 0.09020884f, -0.03565749f, 0.04993903f, 0.04978038f, 0.03957197f, 0.10545144f, -0.05275475f, 
    0.02579444f, -0.07028866f, 0.01375022f, -0.19261651f, 0.02707963f, 0.09950121f, 0.01164478f, -0.04590433f, 
    0.27234197f, 0.20902529f, -0.18892060f, -0.03919349f, 0.03564709f, -0.05846367f, 0.01765758f, 0.04608701f, 
    -0.03244197f, -0.07162581f, -0.00371736f, 0.12348160f, 0.04567648f, -0.22201933f, 0.06878722f, 0.06037875f, 
    -0.01373660f, -0.02888602f, 0.00973711f, 0.04227099f, -0.00651454f, -0.02136502f, 0.09448867f, -0.06514215f, 
    -0.17237294f, -0.03363318f, 0.09323713f, 0.17013606f, 0.07935359f, 0.12819424f, -0.00480799f, -0.13155824f, 
    -0.00588146f, 0.06171719f, 0.11337841f, -0.07400149f, -0.20352459f, -0.14891769f, 0.30495200f, -0.07946832f, 
    0.13523203f, -0.13447131f, 0.05409091f, -0.11035937f, 0.14631239f, -0.13795100f, 0.11417069f, 0.02197925f, 
    0.59037608f, 0.08895907f, 0.04944858f, 0.06056760f, 0.03637471f, 0.03041822f, -0.09193826f, 0.03881478f, 
    0.12849088f, -0.03958215f, 0.04686217f, 0.01414891f, -0.10063867f, 0.05704248f, 0.00169673f, -0.05509757f, 
    -0.04673018f, -0.06988841f, -0.06668464f, -0.12177287f, -0.01420319f, 0.02103346f, 0.13205434f, 0.01655207f, 
    0.00845554f, -0.01719787f, -0.01278910f, 0.01326379f, 0.03059492f, 0.01209057f, 0.01831701f, -0.02928450f, 
    -0.02604010f, -0.00118207f, -0.03026771f, 0.02370369f, -0.03084748f, -0.00610396f, 0.01537534f, 0.01964099f, 
    -0.00958839f, -0.00713317f, -0.00388342f, -0.04266062f, 0.00193190f, -0.02880145f, -0.00976449f, 0.01152404f, 
    -0.01227877f, 0.02909509f, -0.01392739f, -0.03361787f, 0.00723322f, 0.02041046f, 0.01624300f, 0.01392499f, 
    0.01761973f, 0.02138305f, -0.02958629f, -0.03753711f, 0.00091926f, 0.00575258f, 0.02274564f, -0.01811425f, 
    -0.01278260f, -0.00339865f, -0.01022359f, 0.01902743f, -0.02539362f, 0.00895223f, -0.03347744f, -0.03939227f, 
    -0.00065035f, 0.02353030f, -0.02528934f, 0.02462273f, -0.03684938f, 0.01289099f, -0.00734682f, 0.02345565f, 
    -0.03997140f, 0.02620236f, -0.00302878f, -0.01104938f, 0.00195280f, -0.00787129f, -0.03240130f, 0.02679344f, 
    -0.00235743f, 0.01693966f, -0.01546393f, 0.02111963f, -0.01994947f, 0.02544578f, -0.00249026f, -0.02044079f, 
    0.00117303f, -0.02798568f, -0.02018583f, -0.03450237f, -0.02473291f, -0.04048183f, 0.01469835f, 0.02300863f, 
    -0.01591940f, 0.01202869f, -0.03585962f, -0.03211488f, -0.02722469f, 0.01718036f, -0.02410163f, -0.02604879f, 
    -0.03797735f, -0.01980063f, -0.00728274f, -0.01672717f, -0.03972470f, -0.02328822f, -0.02982794f, 0.02629855f, 
    -0.01671851f, 0.00336140f, -0.01482654f, -0.00348845f, -0.02611203f, -0.04156977f, -0.01330404f, -0.03926647f, 
    -0.01798958f, -0.02791607f, -0.00865777f, -0.01513166f, 0.02691634f, 0.02354049f, 0.00388477f, 0.02020388f, 
    -0.01960281f, -0.00582622f, 0.01948451f, -0.02282623f, 0.00963148f, -0.00585580f, -0.03133346f, 0.02570907f, 
    -0.01280198f, 0.01697440f, -0.03538432f, -0.03225081f, -0.01368497f, 0.01420830f, 0.00438264f, -0.01311227f, 
    -0.03581748f, 0.02477006f, -0.00365789f, -0.02499312f, -0.03518075f, -0.03818695f, 0.00023494f, 0.02451024f, 
    0.03159055f, -0.03202930f, -0.02734294f, 0.00027650f, -0.00039622f, 0.02490164f, 0.01582184f, -0.00310369f, 
    -0.03390779f, 0.02620524f, -0.01002692f, -0.00672710f, 0.02470564f, -0.00867458f, 0.01229016f, -0.00022004f, 
    -0.00248980f, -0.03548957f, -0.00839778f, -0.04412217f, 0.00908970f, -0.00322346f, -0.02449880f, -0.03124740f, 
    -0.00948623f, -0.04009648f, 0.01687631f, -0.00479785f, -0.03515020f, 0.01891908f, -0.01853543f, -0.01302570f, 
    -0.01622477f, 0.01862681f, -0.03896994f, 0.01240364f, 0.02389569f, -0.00627369f, 0.01316141f, -0.03819009f, 
    0.02735669f, -0.03673306f, -0.01822563f, -0.02038172f, -0.00655271f, 0.00284225f, 0.00096253f, -0.01966740f, 
    -0.00303624f, 0.01710995f, -0.02431405f, 0.01834905f, -0.02282698f, -0.00211030f, -0.02180403f, 0.02568488f, 
    -0.00991239f, 0.01819384f, 0.01273722f, -0.01485888f, -0.02551026f, 0.00342370f, 0.00850700f, -0.01727911f, 
    -0.00941388f, 0.00135976f, 0.00734125f, 0.02479433f, 0.00618985f, -0.01691851f, -0.01166680f, -0.02739876f, 
    0.01600670f, -0.01938438f, 0.00316178f, 0.01712399f, 0.01368391f, -0.02650329f, -0.03977377f, -0.02877134f, 
    0.02842477f, 0.00574013f, 0.01331031f, 0.02753436f, -0.02865537f, -0.00541683f, 0.02921356f, -0.01392353f, 
    -0.03435470f, -0.03581781f, 0.01440654f, -0.00765168f, 0.02224528f, -0.03769962f, 0.00839700f, -0.03164190f, 
    -0.01696292f, -0.00082711f, -0.02381194f, 0.00686427f, -0.01369419f, -0.03545948f, 0.03323690f, -0.04039530f, 
    -0.03059390f, 0.00891496f, 0.02724012f, -0.01049706f, -0.03709449f, -0.02398892f, -0.00212331f, -0.01278740f, 
    0.02170534f, 0.00560179f, 0.00884033f, -0.00343077f, -0.00518169f, 0.02164163f, 0.01802318f, -0.02855485f, 
    -0.00178222f, -0.04036533f, 0.02621556f, 0.01432011f, -0.03839344f, 0.01329414f, -0.04470005f, -0.01054023f, 
    -0.02260697f, 0.00271875f, -0.01567112f, 0.01674475f, 0.01607651f, 0.02171054f, -0.02136575f, -0.01301604f, 
    0.00300333f, -0.00053068f, -0.00453008f, -0.02121703f, 0.00842987f, -0.03189839f, -0.01267589f, -0.02616528f, 
    0.01276413f, -0.00547505f, -0.03009368f, -0.01076355f, -0.03183899f, -0.02187113f, -0.00647185f, -0.03605138f, 
    -0.03084054f, -0.00071939f, -0.03983920f, -0.02934008f, -0.01219569f, 0.02021968f, -0.01760993f, -0.01391593f, 
    0.00596897f, 0.02631545f, -0.03997479f, 0.01486565f, -0.03349444f, -0.00466503f, 0.00046466f, -0.03265827f, 
    0.01665556f, 0.01757065f, -0.01694785f, -0.00816217f, 0.01657668f, 0.03190939f, 0.01850550f, -0.01447550f, 
    -0.03609809f, 0.00680808f, -0.02207094f, -0.03804601f, 0.01423626f, 0.00035727f, -0.01136229f, 0.01170772f, 
    -0.01878713f, -0.02917498f, -0.02758175f, 0.00665258f, 0.01839648f, 0.02539021f, -0.02222250f, -0.00180538f, 
    0.00149842f, 0.02839622f, -0.00721724f, -0.02428741f, -0.00422145f, -0.03410097f, 0.01160031f, 0.02282339f, 
    -0.03811136f, -0.02856739f, -0.03270469f, -0.01508185f, -0.03030407f, -0.03067262f, -0.03879816f, -0.00612146f, 
    -0.01325439f, 0.02518348f, -0.01027364f, -0.04400970f, 0.02455180f, 0.01972898f, -0.02881543f, -0.03975533f, 
    -0.03684355f, 0.02369657f, -0.03314144f, -0.01543968f, 0.00391848f, -0.02126811f, -0.02608056f, -0.03306395f, 
    -0.03747615f, -0.00239864f, 0.02366798f, -0.01619182f, 0.00665431f, 0.00910913f, -0.02048006f, 0.00951014f, 
    -0.03485114f, -0.01223296f, -0.02803557f, 0.01353907f, 0.02196730f, 0.01887980f, 0.01648925f, 0.01477531f, 
    -0.00309638f, 0.00694920f, 0.02547236f, 0.01710105f, 0.01577669f, -0.03578671f, 0.00661327f, 0.01589166f, 
    0.00471479f, 0.02640564f, -0.03479989f, 0.02117301f, 0.01506813f, 0.00153709f, -0.03623939f, 0.02383457f, 
    -0.00487468f, 0.01363184f, -0.01738665f, -0.01088336f, 0.00895081f, 0.00306173f, -0.00494759f, -0.00505393f, 
    -0.02854445f, -0.03083759f, -0.02501047f, -0.03428499f, 0.01744589f, 0.00752483f, -0.00396191f, -0.02833764f, 
    -0.00700385f, -0.00711069f, 0.02039373f, 0.01372914f, -0.01733169f, -0.01519073f, -0.03863458f, 0.00605936f, 
    -0.00926417f, 0.02426040f, -0.00982289f, 0.01709684f, -0.01904489f, -0.02234593f, -0.01010202f, 0.02393827f, 
    0.02457121f, 0.01826924f, -0.03929026f, 0.01561660f, 0.00333646f, 0.00552167f, -0.03678218f, 0.01792346f, 
    0.01337082f, -0.03366299f, 0.01346271f, -0.02128562f, -0.01681390f, 0.00698329f, -0.03129321f, -0.03574349f, 
    -0.03138732f, 0.01789840f, 0.01270388f, -0.00288934f, 0.03169047f, -0.01475302f, 0.00170014f, 0.01317111f, 
    0.01694342f, -0.01179080f, -0.02743858f, 0.01229714f, 0.00747954f, 0.02081980f, -0.02984353f, 0.00296706f, 
    -0.03296435f, 0.00448831f, -0.00451646f, 0.01022002f, 0.00541119f, -0.01069035f, 0.02613459f, 0.01192654f, 
    -0.00929443f, 0.01305718f, 0.01204642f, 0.00930931f, -0.01572980f, -0.03315959f, -0.03371203f, -0.02850885f, 
    -0.01550401f, 0.02375053f, -0.01189267f, -0.01033237f, -0.03388587f, 0.01219774f, -0.02603538f, -0.00417923f, 
    -0.01231819f, 0.01896993f, -0.01420866f, -0.01629793f, -0.01982400f, -0.03137134f, 0.02093799f, -0.01659237f, 
    -0.03913193f, 0.02354797f, 0.00617572f, -0.03811887f, -0.00948099f, -0.00272982f, -0.00524171f, -0.02649478f, 
    -0.00220045f, 0.02708320f, -0.04005518f, -0.02354928f, -0.03017656f, 0.01164150f, -0.02046616f, -0.03167515f, 
    -0.02547787f, 0.03148932f, 0.01588860f, -0.01698572f, 0.00126994f, 0.00434750f, 0.01065352f, -0.02913863f, 
    0.01035286f, 0.02752513f, -0.00235228f, 0.02548058f, 0.00708343f, 0.02654571f, -0.00292697f, 0.02111838f, 
    0.00103935f, 0.01200225f, -0.02395153f, -0.01234641f, -0.00271943f, 0.00296354f, 0.02773757f, -0.00186184f, 
    0.02660461f, -0.01840812f, -0.01757310f, -0.01110171f, 0.02427981f, -0.03647400f, 0.01741104f, 0.02827232f, 
    0.01043540f, -0.00380852f, -0.00067280f, 0.01100796f, -0.03087177f, -0.03135616f, -0.01811058f, 0.02723278f, 
    0.01479714f, 0.01225057f, 0.00643633f, -0.02221770f, -0.04010153f, -0.03057555f, -0.01164185f, -0.01623027f, 
    -0.03528452f, -0.03567016f, -0.00620107f, -0.01767529f, 0.00184943f, -0.03178596f, 0.00379762f, -0.02716247f, 
    -0.01390832f, 0.01363076f, -0.03009727f, -0.02701821f, -0.00308508f, -0.04324888f, 0.03425510f, -0.01850836f, 
    0.01827485f, 0.00694037f, -0.02827882f, -0.02460228f, -0.03122160f, -0.00310205f, -0.03099922f, -0.02053068f, 
    0.00686694f, 0.03017835f, -0.01339262f, -0.02208443f, -0.00259791f, -0.03079106f, -0.04214974f, -0.02052659f, 
    0.01051997f, 0.02675300f, 0.02288513f, -0.00363297f, 0.00789903f, 0.01991835f, -0.03654968f, -0.02020734f, 
    -0.03539412f, 0.00549926f, -0.02876693f, -0.02294531f, 0.01493592f, 0.00053195f, -0.01572750f, 0.01605032f, 
    -0.01552173f, -0.02419786f, -0.01144992f, -0.01185177f, 0.00682519f, 0.01551362f, 0.03178323f, -0.00331952f, 
    -0.01659515f, 0.00851916f, -0.03370995f, 0.01727888f, -0.03006073f, -0.03053873f, -0.00020666f, -0.02157959f, 
    -0.01694824f, -0.01624081f, 0.00115410f, 0.00592720f, -0.00571165f, -0.02940517f, 0.01873005f, 0.01753820f, 
    -0.02041009f, -0.03952077f, -0.00418358f, -0.01978006f, 0.02616969f, -0.03696903f, -0.00519231f, -0.02793690f, 
    0.03032275f, 0.00931496f, 0.00449516f, 0.01216754f, 0.02240945f, 0.01356680f, 0.01911560f, -0.02997382f, 
    0.01099219f, 0.01378774f, 0.01440169f, -0.03356245f, -0.01135142f, -0.00954448f, 0.01032026f, -0.03228956f, 
    0.00909225f, -0.02444725f, 0.02696378f, -0.00284519f, 0.00412838f, -0.02783638f, -0.01237079f, -0.01000837f, 
    -0.01966782f, -0.01805059f, -0.01367519f, -0.00929062f, 0.00999194f, -0.03131378f, -0.03252849f, 0.02116864f, 
    -0.03534506f, -0.00496607f, -0.03753369f, 0.00357437f, -0.03404500f, -0.00360246f, 0.02998343f, 0.01328938f, 
    0.00088628f, 0.00511657f, 0.02304446f, 0.02502172f, -0.00532938f, -0.03561684f, -0.04095435f, -0.03276461f, 
    -0.03840322f, 0.02380788f, -0.02334571f, 0.01086231f, -0.01613801f, -0.03211865f, -0.00197708f, 0.01135646f, 
    -0.01924305f, -0.00081576f, -0.02524139f, 0.01566302f, 0.02672070f, -0.01637637f, 0.02956733f, -0.03759299f, 
    0.00571042f, 0.02542724f, -0.00857654f, -0.00501919f, 0.00312760f, 0.02100721f, 0.00493443f, -0.00956594f, 
    0.00146361f, 0.02099957f, -0.04312861f, -0.00858065f, -0.01939871f, -0.02262796f, 0.00840663f, -0.02851727f, 
    0.00171405f, -0.01940937f, 0.00361081f, -0.00422135f, 0.02684593f, 0.02699038f, -0.01774881f, 0.00448260f, 
    -0.02947971f, -0.00271804f, 0.00930569f, -0.02814077f, 0.00587085f, 0.02416616f, 0.01933106f, -0.03543473f, 
    -0.01806399f, -0.03922437f, -0.00465813f, 0.00088758f, 0.01004749f, 0.01640164f, -0.00699490f, -0.01971938f, 
    -0.03576893f, 0.00469270f, -0.02864091f, 0.02449556f, -0.00152251f, -0.01756432f, -0.03601499f, 0.00239575f, 
    0.01053461f, -0.03414664f, 0.01843879f, 0.00781909f, -0.01702736f, -0.01583618f, -0.00937654f, 0.00732779f, 
    -0.02216438f, -0.02648773f, -0.02711596f, 0.01395109f, -0.03671020f, 0.01025304f, -0.01995273f, 0.02951873f, 
    -0.01635483f, -0.00972125f, -0.01713330f, 0.02150114f, -0.01996972f, -0.01253647f, -0.02489933f, 0.02662842f, 
    -0.10745166f, 0.03399352f, 0.00164164f, -0.29874721f, 0.14021257f, 0.04619650f, -0.05687612f, -0.06690431f, 
    0.03507155f, 0.08004670f, 0.08498530f, -0.10893896f, 0.22585928f, 0.00383030f, 0.10107294f, 0.20089547f, 
    -0.02771518f, 0.02530217f, -0.03418084f, 0.08561144f, -0.07481002f, 0.02807222f, 0.00379246f, -0.00386324f, 
    -0.04096247f, 0.08227594f, 0.21465994f, -0.04487595f, 0.03378794f, 0.06118379f, 0.11142126f, 0.10999013f, 
    -0.03109954f, -0.05056482f, 0.05369924f, 0.04819288f, 0.11722928f, -0.07613824f, 0.02358286f, -0.11669255f, 
    0.03924931f, 0.00814300f, -0.03652209f, 0.00098799f, -0.00483552f, 0.01096435f, 0.03557450f, -0.01837720f, 
    0.35291088f, 0.06699418f, -0.04505556f, 0.11655074f, -0.12865548f, 0.01972071f, 0.00897812f, -0.03665511f, 
    -0.02036350f, 0.02578809f, 0.06154259f, -0.00351123f, -0.02253548f, 0.21431385f, -0.10995517f, -0.17128696f, 
    0.00972725f, 0.12031090f, -0.09167035f, -0.06444939f, -0.02683403f, 0.02421184f, 0.07417750f, -0.07771461f, 
    0.09146731f, -0.03645218f, 0.07005876f, 0.27363741f, -0.01346508f, 0.01420477f, 0.02527362f, 0.05541313f, 
    -0.17242046f, 0.03981890f, -0.00294328f, -0.12062164f, 0.09438732f, 0.11809710f, -0.12696780f, -0.11316869f, 
    0.00719131f, -0.00290667f, 0.00573335f, -0.00658208f, 0.04200144f, 0.01989636f, -0.02061294f, -0.04071223f, 
    0.14608662f, 0.12368407f, 0.03680891f, -0.28935444f, -0.06314210f, -0.13058640f, -0.00045266f, 0.00941802f, 
    0.00712855f, -0.00232209f, -0.00404507f, 0.05800937f, 0.07684773f, -0.10382057f, 0.11233228f, -0.02765422f, 
    0.00458295f, -0.08415156f, -0.00477972f, 0.07961733f, 0.01120671f, -0.03496992f, 0.08335998f, -0.02613262f, 
    -0.05000480f, 0.06669913f, 0.17299286f, -0.03943051f, 0.01578131f, 0.10912684f, -0.00283527f, 0.06809761f, 
    0.05304594f, -0.03062068f, -0.02456972f, 0.03274174f, 0.22424482f, 0.17333356f, -0.05714098f, -0.20051233f, 
    0.04199869f, 0.03281599f, -0.03532349f, -0.00495926f, 0.06753615f, -0.06507502f, -0.07187840f, -0.02455138f, 
    0.25487977f, 0.02410387f, -0.07444207f, -0.13262869f, -0.05491628f, -0.09540728f, 0.08174376f, -0.00949776f, 
    -0.00878606f, 0.01574173f, -0.03844805f, -0.01742415f, 0.29581341f, -0.07670665f, 0.04519166f, 0.26448441f, 
    -0.11407160f, 0.00009772f, 0.00083541f, -0.02388968f, -0.13621321f, 0.08673063f, 0.04548182f, -0.05546432f, 
    0.06951673f, 0.06586505f, -0.14086536f, 0.08165208f, -0.03242967f, -0.01659988f, -0.02463765f, 0.07127371f, 
    0.08100122f, -0.02168324f, 0.03039437f, 0.05974978f, 0.43132105f, -0.17237724f, -0.22282232f, -0.00241095f, 
    0.00967258f, -0.02908358f, -0.11932292f, -0.02329825f, -0.01924392f, 0.04758954f, 0.01523334f, 0.13419762f, 
    0.06767267f, -0.01824860f, 0.04536926f, -0.12342796f, -0.01418739f, -0.09011262f, 0.02705838f, 0.01224780f, 
    0.02785480f, -0.04884210f, -0.05148942f, -0.00124659f, 0.25473574f, 0.08515134f, 0.02321596f, 0.01060847f, 
    0.00875720f, 0.02557250f, -0.11291126f, 0.09020481f, 0.11161844f, -0.09733721f, -0.01775151f, 0.17179695f, 
    0.03637207f, -0.04795700f, -0.20368274f, -0.17790066f, -0.00842437f, 0.01725164f, -0.10336742f, -0.01092446f, 
    -0.13389894f, 0.06116313f, 0.10024353f, 0.08452093f, 0.14346302f, 0.01399507f, 0.10440505f, -0.20743918f, 
    -0.07045137f, 0.01688700f, 0.08135900f, 0.00216395f, 0.01125093f, -0.13179839f, 0.05503415f, 0.11494841f, 
    -0.05777655f, 0.19373970f, -0.09115874f, -0.08734009f, 0.06561359f, 0.13926254f, 0.02726561f, 0.07607187f, 
    0.09278333f, 0.06849877f, 0.06102130f, -0.01260935f, 0.10769282f, -0.17011411f, -0.08037078f, 0.06689125f, 
    0.04290147f, 0.02087026f, 0.00552849f, 0.07940726f, -0.01264701f, 0.09188471f, -0.04382524f, 0.11476917f, 
    0.17261668f, -0.03883920f, -0.00972957f, 0.40911657f, -0.01038951f, -0.05115472f, -0.01412655f, 0.00951145f, 
    0.08051567f, -0.08153237f, 0.05319881f, -0.11738104f, 0.47718403f, 0.08485606f, 0.01697717f, -0.08338790f, 
    -0.06257638f, -0.04060125f, -0.10061430f, -0.12622619f, -0.19055708f, -0.03429494f, -0.04377080f, 0.07056475f, 
    -0.02103981f, 0.12912953f, -0.00057801f, 0.10178468f, -0.14750135f, 0.05867109f, 0.09430423f, -0.03315402f, 
    -0.01969061f, 0.01904608f, 0.06130705f, 0.00705524f, 0.34277466f, 0.02424270f, -0.07410699f, -0.12749232f, 
    -0.11929524f, 0.00916704f, 0.04003394f, 0.01081026f, -0.05399191f, 0.03300985f, -0.02471433f, 0.11279206f, 
    -0.09367083f, 0.14480714f, 0.05180263f, 0.00967702f, -0.08609997f, 0.02663472f, -0.04424229f, -0.04023617f, 
    0.09479216f, 0.05650783f, -0.06978175f, 0.03516375f, 0.11417763f, 0.00785848f, -0.26506868f, 0.22845063f, 
    -0.00078100f, 0.04267743f, 0.04862655f, -0.10383757f, -0.07215942f, -0.08091444f, 0.09287335f, 0.07231367f, 
    -0.14661053f, -0.15013310f, 0.13762905f, 0.23950428f, -0.08434208f, 0.02909220f, -0.08261409f, -0.11491624f, 
    -0.10280280f, 0.04238100f, -0.04722847f, 0.08178104f, 0.22808529f, -0.00306495f, 0.02758355f, -0.07042067f, 
    0.05475566f, -0.01837034f, -0.01284357f, -0.00309865f, 0.05550690f, 0.05100827f, 0.01486008f, 0.04883268f, 
    0.29140401f, 0.10105016f, -0.15967357f, 0.12334471f, -0.01273410f, 0.01582314f, 0.02863394f, -0.04959485f, 
    -0.06694275f, -0.01858407f, 0.00103969f, 0.04824361f, 0.13520922f, -0.00207395f, 0.06403014f, 0.18014443f, 
    -0.15556009f, 0.00262491f, -0.02993413f, -0.00152828f, -0.01392259f, -0.05118836f, 0.01232875f, -0.00700995f, 
    -0.10898346f, 0.05815080f, 0.05999110f, 0.03319445f, -0.10811947f, 0.00224027f, -0.00808938f, -0.01635721f, 
    0.10619179f, 0.04285780f, -0.02918164f, -0.08957852f, 0.38063318f, -0.26183447f, -0.03541237f, 0.05772135f, 
    -0.10173310f, 0.01548083f, -0.07037971f, -0.03030892f, 0.07665750f, -0.02237336f, 0.04797352f, 0.05082753f, 
    0.12301237f, -0.34269163f, -0.12483490f, 0.01297328f, -0.10143796f, -0.08094915f, -0.12326249f, 0.20747207f, 
    0.03902168f, 0.05360766f, -0.00485510f, -0.08894663f, 0.18431140f, -0.38112345f, 0.08179686f, -0.13757811f, 
    -0.08021732f, 0.02043411f, -0.13214989f, 0.06040578f, 0.08590229f, 0.14433248f, 0.01370269f, -0.09249176f, 
    0.25001994f, -0.11171938f, 0.09364995f, 0.39560246f, -0.10443057f, -0.03621510f, -0.05461650f, -0.03489958f, 
    0.04197169f, 0.00602658f, -0.05967588f, -0.10753021f, -0.11673559f, 0.04978942f, 0.11909540f, 0.00216337f, 
    -0.04922101f, -0.07563286f, 0.02182876f, 0.03554999f, 0.11850397f, -0.02277197f, -0.07048653f, 0.07995651f, 
    -0.08258963f, 0.01240007f, -0.02785575f, -0.06039622f, 0.09578017f, 0.02362875f, -0.04438071f, 0.00036704f, 
    0.08293524f, 0.07372572f, -0.02202293f, -0.14762390f, 0.15185660f, -0.13512814f, -0.08253565f, 0.04008795f, 
    0.01599334f, 0.04749541f, -0.05983821f, 0.05825912f, 0.07786419f, 0.02260930f, -0.04441387f, 0.16988239f, 
    0.00210539f, 0.00178731f, 0.06268662f, -0.21564643f, -0.09889851f, 0.00164571f, 0.14315204f, -0.04241683f, 
    0.02302031f, 0.00477759f, -0.04484523f, 0.03801796f, 0.19048601f, -0.17838821f, 0.09637885f, 0.20105146f, 
    -0.01465134f, -0.00887935f, -0.08589829f, -0.01634218f, -0.02220874f, 0.03918738f, -0.04162223f, -0.04369651f, 
    -0.26203969f, 0.09064958f, 0.01033145f, 0.17994097f, -0.01894636f, -0.06956308f, 0.06390809f, -0.07285947f, 
    0.10594577f, 0.00457046f, 0.08915359f, -0.03245223f, 0.29361412f, -0.12365460f, -0.29472184f, 0.10152885f, 
    -0.04772091f, 0.00619280f, -0.06484254f, -0.07603016f, -0.05993913f, 0.07406375f, -0.05845375f, -0.05379264f, 
    -0.02725219f, -0.13409452f, -0.08516569f, 0.15881157f, -0.05270282f, 0.01133109f, -0.10709231f, -0.03587796f, 
    0.04855494f, -0.03320524f, -0.00475985f, 0.02908335f, 0.31174362f, 0.13647701f, -0.05878548f, -0.31889305f, 
    -0.00977622f, -0.08567761f, 0.03376260f, -0.00777292f, -0.07847381f, -0.04076309f, -0.10882682f, -0.06912725f, 
    0.23181175f, -0.11801637f, -0.04118095f, 0.12136198f, -0.04222004f, 0.04862964f, -0.11448378f, -0.07022702f, 
    -0.05895572f, -0.01492381f, 0.00656217f, 0.02110295f, -0.00471803f, -0.08549333f, -0.02543668f, 0.00484105f, 
    -0.03122553f, -0.07792202f, -0.06353381f, 0.20673904f, 0.04996486f, -0.01439928f, 0.05263394f, -0.02767764f, 
    -0.01716660f, -0.07162776f, -0.03416307f, 0.05013845f, 0.06662057f, 0.08676094f, 0.09798243f, 0.03666069f, 
    0.01500441f, -0.00202854f, 0.01056406f, -0.05689149f, 0.14015304f, 0.05641905f, -0.02342513f, 0.26827067f, 
    -0.11020428f, 0.09723125f, -0.07017782f, 0.04494491f, -0.02341877f, 0.02273617f, 0.11064953f, 0.10708857f, 
    -0.07635982f, -0.11530850f, -0.16634549f, -0.01633351f, 0.07142182f, -0.01569420f, 0.05984848f, 0.05688751f, 
    0.03183208f, 0.02364565f, 0.00030288f, -0.11769761f, 0.08956765f, -0.01585399f, 0.03657448f, -0.03934896f, 
    0.18346955f, 0.06321450f, -0.05042882f, 0.03031468f, -0.02705164f, 0.13714319f, -0.05996495f, -0.15035987f, 
    0.23550566f, -0.04046274f, 0.06511229f, 0.25324029f, -0.06402789f, -0.08599307f, -0.00649925f, 0.01954359f, 
    0.07819554f, 0.01079807f, -0.02357061f, -0.02460944f, 0.01522677f, -0.02919593f, -0.03029523f, -0.35097384f, 
    0.05740492f, -0.07981943f, 0.05574105f, 0.08388109f, 0.10987434f, 0.00903663f, 0.07669584f, 0.04704187f, 
    0.18402196f, -0.06131206f, 0.00347818f, 0.12129680f, -0.12579609f, -0.07007001f, -0.04513644f, -0.03937327f, 
    -0.04879545f, 0.03776884f, 0.06627659f, 0.15456726f, 0.09391549f, 0.06182543f, 0.01121379f, -0.08896598f, 
    0.03662008f, 0.04876883f, -0.02497529f, 0.03003359f, 0.00462763f, -0.07470092f, -0.05379642f, 0.15567410f, 
    0.29619443f, -0.15761733f, 0.03503285f, 0.08984485f, 0.00351236f, 0.01322853f, -0.01391079f, -0.03519199f, 
    0.06354336f, -0.08577510f, -0.09537463f, 0.06114522f, 0.17482033f, -0.02000314f, 0.07425302f, 0.18007238f, 
    -0.02871104f, 0.04640128f, 0.01530281f, -0.00259971f, 0.03072285f, 0.05924974f, 0.09661232f, -0.00389079f, 
    0.03859304f, 0.03499217f, -0.02162221f, 0.04696514f, -0.02257948f, 0.01618966f, -0.04418509f, 0.00393034f, 
    0.06338084f, -0.03317305f, -0.02779751f, 0.01264536f, -0.04920956f, -0.04313498f, -0.11043556f, -0.16791949f, 
    0.08443842f, -0.09427127f, 0.04254168f, -0.00224774f, 0.03473987f, -0.02731932f, 0.03934284f, 0.01593620f, 
    0.00817077f, 0.04191509f, 0.14763281f, -0.01081852f, -0.11298330f, 0.00888849f, 0.07700063f, 0.02547868f, 
    0.10449889f, 0.04640267f, -0.14632916f, -0.01409206f, 0.00683070f, 0.19058947f, 0.08744863f, -0.04085563f, 
    0.01746503f, 0.00731673f, 0.05795882f, 0.10397419f, 0.04856551f, 0.04892721f, 0.02541767f, 0.00717511f, 
    -0.33434612f, 0.09079614f, -0.01623408f, -0.10314002f, 0.08042273f, 0.04824634f, 0.06750656f, -0.10171310f, 
    -0.01274643f, 0.05458555f, 0.03170923f, -0.01684915f, 0.28579551f, -0.10606822f, -0.10577203f, 0.13477425f, 
    0.04081132f, 0.01587056f, 0.01021210f, -0.00994718f, -0.01877730f, -0.02371847f, 0.01984691f, -0.00186622f, 
    0.05780256f, 0.34459797f, 0.15405175f, 0.36509284f, -0.01489029f, 0.05978239f, 0.03044334f, 0.05478263f, 
    0.00854454f, 0.14716536f, -0.08711656f, 0.10143575f, -0.42642951f, 0.36744440f, 0.02383000f, -0.20391472f, 
    0.04950863f, -0.05141099f, 0.11779188f, 0.15713739f, 0.00513274f, 0.04153711f, -0.11708821f, 0.01659261f, 
    0.03507600f, -0.02522291f, -0.12744577f, -0.12726350f, -0.18245037f, 0.09165460f, 0.06245228f, -0.07190858f, 
    0.00909240f, -0.14154160f, -0.05314544f, 0.02070083f, 0.20517801f, -0.06754739f, 0.00189158f, 0.33045092f, 
    -0.06050854f, 0.03753298f, 0.04115320f, 0.05380566f, 0.09297754f, 0.02717380f, -0.06559967f, 0.10878852f, 
    -0.35660553f, 0.14875796f, 0.09197390f, -0.01246008f, 0.08462044f, -0.02533369f, 0.16504788f, 0.03833588f, 
    0.08589935f, -0.03462294f, 0.02993831f, -0.01771260f, -0.26259458f, -0.14181593f, -0.07444028f, 0.26224652f, 
    0.06950741f, 0.00254540f, 0.00935906f, 0.03962826f, 0.13797385f, 0.08218893f, 0.01527198f, 0.03783264f, 
    -0.01178744f, -0.08868711f, 0.13027418f, -0.11579803f, -0.04233076f, 0.12970030f, -0.02614127f, -0.00349435f, 
    0.08478029f, 0.05932175f, -0.07022934f, 0.05530121f, -0.46741104f, -0.27083427f, -0.12838823f, 0.06454530f, 
    0.13347690f, -0.01333599f, -0.10232189f, -0.00689580f, 0.07321472f, 0.04079960f, 0.00476956f, 0.07500963f, 
    -0.04079640f, 0.26127067f, -0.05256003f, 0.07841094f, -0.04555507f, 0.06304391f, -0.05302658f, -0.04469527f, 
    0.04934480f, 0.08906604f, -0.04238931f, 0.00654691f, 0.09797569f, 0.29313505f, -0.11767767f, -0.28247771f, 
    -0.14300542f, 0.01489942f, 0.08370268f, -0.04749737f, 0.02075080f, 0.13058013f, 0.06413991f, -0.06859117f, 
    0.05564677f, 0.24106161f, -0.00104674f, 0.33844209f, -0.03000645f, -0.03204986f, -0.03908716f, -0.02491129f, 
    0.05240051f, -0.03425501f, 0.11076372f, -0.06256275f, -0.12161207f, -0.11447650f, 0.03384602f, 0.16889662f, 
    -0.01198296f, -0.08541276f, 0.03568909f, 0.08992697f, 0.00632787f, 0.10864041f, 0.03762634f, 0.03700659f, 
    0.06448315f, -0.06682410f, -0.10299419f, -0.06872191f, 0.18155527f, 0.07086041f, 0.05003050f, 0.04611430f, 
    0.15381588f, 0.05715994f, 0.01970073f, 0.02235116f, 0.02009846f, -0.06846811f, -0.00224551f, 0.04738130f, 
    -0.00337989f, -0.02217580f, -0.01898058f, -0.00512318f, 0.11809164f, 0.03790605f, -0.00753366f, -0.02339267f, 
    -0.08947605f, -0.13051198f, 0.12961538f, -0.11876310f, -0.06242609f, 0.04082663f, 0.05051255f, -0.06588579f, 
    0.04382334f, 0.03136759f, 0.07023238f, -0.03281446f, -0.08330550f, -0.24012722f, -0.02461311f, 0.05958846f, 
    0.14723006f, 0.07937838f, 0.00999567f, 0.04360225f, 0.04838851f, 0.03404576f, -0.05102453f, -0.01153441f, 
    0.01245716f, 0.04642448f, -0.17912497f, -0.24770303f, -0.06641951f, 0.05742769f, 0.00165954f, -0.08169576f, 
    0.04396772f, -0.03382951f, 0.07980330f, 0.06163313f, -0.12440143f, 0.16749889f, -0.06453429f, -0.15003207f, 
    0.01242005f, -0.06491717f, 0.03294799f, -0.01136547f, -0.05555395f, 0.00103209f, 0.00221187f, 0.11686749f, 
    0.01120491f, 0.30293593f, 0.08803045f, 0.08597008f, 0.04197282f, 0.04986748f, 0.12035446f, 0.12792656f, 
    0.06625806f, -0.03968826f, -0.03514812f, -0.02884675f, 0.32403827f, -0.22106127f, -0.24430247f, -0.13538380f, 
    0.01969769f, -0.03871324f, 0.13346484f, 0.10124228f, 0.06371960f, 0.00697626f, 0.03242627f, 0.01872692f, 
    0.02636769f, -0.04496444f, -0.13277268f, 0.30484703f, 0.06073361f, -0.01149961f, -0.02512624f, 0.13392514f, 
    0.02493206f, 0.05239139f, 0.02440687f, 0.05493870f, -0.00419371f, -0.03982096f, -0.14347610f, 0.13129482f, 
    0.08007971f, -0.08985060f, -0.10671977f, 0.14840552f, 0.15527320f, 0.00403051f, 0.03506884f, 0.04016230f, 
    0.13445978f, -0.13135462f, 0.14960887f, -0.08385561f, 0.01503544f, 0.05103897f, 0.02982252f, -0.05186036f, 
    0.04980099f, 0.06122723f, 0.10376228f, 0.13104768f, -0.27557483f, -0.38710994f, -0.07633552f, 0.15832388f, 
    0.02303690f, -0.08791742f, -0.02079806f, 0.08022713f, 0.07499377f, -0.02283988f, -0.04170612f, -0.00582133f, 
    -0.12525451f, 0.08206522f, -0.02381312f, 0.05227590f, 0.21470295f, 0.03464537f, 0.09951568f, 0.02307921f, 
    0.07616141f, 0.02134758f, 0.16526680f, 0.15917355f, -0.16241363f, -0.21097226f, -0.14410949f, 0.22180946f, 
    0.09777682f, 0.18816061f, 0.00416995f, 0.02018585f, -0.02903475f, 0.00173467f, 0.00794070f, 0.04910031f, 
    0.41127422f, -0.05655473f, 0.02524621f, 0.06265099f, -0.02763390f, 0.13634412f, -0.07929883f, 0.07553621f, 
    -0.01282012f, 0.05980561f, 0.08968484f, -0.02051774f, -0.05191094f, 0.05903700f, 0.14553867f, 0.02180962f, 
    -0.03272385f, -0.02163693f, -0.03274857f, 0.06460670f, -0.01593605f, -0.01940429f, 0.13181536f, 0.00485496f, 
    -0.43376774f, 0.19868751f, 0.05632669f, -0.02379857f, 0.16896707f, -0.04975018f, 0.05840608f, -0.03161926f, 
    0.14899300f, -0.06233086f, -0.00206962f, -0.08595761f, -0.06574974f, 0.06245974f, -0.26945937f, -0.27734530f, 
    -0.10346497f, 0.06716877f, -0.05973339f, -0.13594396f, -0.09133752f, -0.08784357f, 0.02492511f, -0.05893027f, 
    -0.18213347f, 0.05197921f, 0.00388519f, -0.15398659f, -0.08713554f, 0.01757277f, -0.01946196f, 0.14941724f, 
    -0.02509048f, 0.08542549f, -0.06351777f, -0.01254460f, -0.17086074f, -0.21047118f, 0.01176102f, -0.03182403f, 
    -0.08795895f, -0.06461149f, 0.06795439f, 0.03369783f, 0.04851297f, 0.03692657f, -0.00966460f, 0.14079681f, 
    0.23897919f, -0.08633370f, 0.16101068f, 0.14753288f, 0.01075934f, 0.03164750f, 0.01238957f, -0.14674468f, 
    0.16739516f, -0.05133688f, 0.00092915f, 0.08497117f, -0.05872785f, 0.03251740f, -0.13734721f, -0.19236565f, 
    0.06623913f, -0.05598186f, 0.06371479f, 0.00588686f, -0.04124683f, 0.06337705f, 0.06166675f, 0.01072142f, 
    0.35516715f, 0.08489366f, -0.03317296f, 0.23292071f, 0.06254008f, 0.15072367f, -0.00318009f, -0.06646504f, 
    -0.10318421f, -0.00546437f, -0.02064709f, 0.19256571f, 0.36055624f, -0.08719438f, -0.02630522f, 0.18482256f, 
    0.07597271f, 0.11859296f, -0.04600828f, 0.06521615f, 0.03418668f, -0.05069574f, 0.02967897f, 0.14843808f, 
    0.05491369f, -0.31269670f, -0.03770833f, -0.07807788f, -0.09199710f, 0.01411532f, -0.03435428f, 0.02311013f, 
    0.06679964f, -0.06440193f, -0.00757692f, 0.17169906f, 0.09119895f, -0.07105801f, 0.02128724f, -0.12726818f, 
    -0.10311896f, 0.07033537f, 0.06339129f, 0.02772793f, 0.04284765f, 0.07771737f, 0.00494433f, -0.11864986f, 
    -0.06572361f, 0.05803959f, 0.10786463f, 0.08384980f, -0.02078553f, -0.00142858f, 0.11203735f, 0.01987208f, 
    0.08001105f, 0.02348450f, 0.16564491f, 0.06588183f, 0.11342338f, 0.13526526f, -0.05909379f, -0.02045134f, 
    0.03987580f, 0.00481473f, -0.10778037f, 0.10821579f, 0.11699327f, -0.02087875f, -0.00439448f, 0.01800622f, 
    0.48889229f, -0.25190309f, -0.21281815f, 0.25445464f, 0.05158716f, 0.09078228f, 0.04907769f, 0.04656516f, 
    -0.02429028f, 0.08252263f, 0.02039330f, 0.09648043f, 0.13424253f, -0.20862636f, -0.02094570f, 0.08742607f, 
    -0.05785627f, -0.02578269f, 0.04001746f, 0.09139287f, 0.07978351f, 0.01434886f, 0.05124164f, 0.15113430f, 
    0.26224953f, 0.12017397f, -0.23222274f, 0.35226279f, 0.18545887f, 0.00152049f, -0.07437339f, 0.05324953f, 
    -0.03237601f, 0.00953368f, -0.03813391f, 0.12848510f, 0.16386886f, 0.04687668f, 0.20005351f, -0.04265908f, 
    0.21582292f, -0.06054064f, 0.03771413f, 0.02075699f, 0.05100593f, 0.00292878f, 0.12755722f, 0.02790263f, 
    -0.33647516f, 0.16176212f, 0.03188055f, 0.16403493f, 0.11811648f, 0.01136146f, 0.00727530f, 0.08453071f, 
    -0.08097307f, -0.04365592f, 0.04763084f, 0.03851144f, 0.13683945f, -0.24510136f, -0.27290076f, 0.27630419f, 
    -0.02492503f, 0.09915340f, -0.01128234f, 0.07754021f, 0.07592153f, 0.09700876f, 0.06012570f, -0.02116790f, 
    -0.03521786f, -0.06349845f, -0.16563833f, -0.06155441f, -0.00007237f, 0.05916690f, 0.12034124f, 0.01329960f, 
    0.06564305f, -0.09568398f, 0.02500089f, 0.03919929f, -0.05323850f, 0.00005910f, -0.04904015f, -0.27700800f, 
    0.11195881f, 0.00950361f, -0.09618958f, -0.09761544f, 0.12671362f, -0.08295577f, -0.00321491f, 0.05240259f, 
    0.32339823f, 0.24409369f, 0.00868270f, 0.11340414f, -0.01637188f, -0.04911445f, 0.02185612f, 0.06469426f, 
    0.08497456f, -0.05333728f, 0.00164488f, 0.06688885f, -0.28006425f, -0.01514678f, 0.11881067f, -0.10352363f, 
    -0.00513530f, -0.05035413f, 0.09696759f, 0.00395038f, 0.06084365f, -0.04736566f, -0.01359081f, -0.09392408f, 
    0.24800888f, 0.15123264f, 0.08305170f, 0.29976189f, 0.12576284f, 0.01003051f, 0.02630676f, 0.08198275f, 
    -0.07773425f, -0.01040162f, -0.02049118f, 0.16205697f, 0.17082526f, -0.14797065f, 0.04379009f, 0.11685090f, 
    0.04789212f, 0.04842702f, 0.03886785f, 0.11843065f, 0.04611317f, -0.03975227f, 0.09184942f, 0.09348352f, 
    -0.01552264f, -0.19330375f, 0.02521842f, -0.05082146f, -0.06476457f, 0.01321198f, -0.02880205f, -0.04357167f, 
    0.06050675f, -0.03655292f, 0.09873114f, 0.09428991f, 0.26242498f, 0.12223147f, 0.18794233f, 0.21709457f, 
    -0.05424587f, 0.00753894f, 0.00091737f, -0.03121552f, 0.07980151f, -0.00685717f, 0.09955968f, 0.13740048f, 
    -0.05237222f, -0.21419176f, 0.00427626f, 0.12092253f, -0.03919837f, 0.07223298f, 0.10708510f, 0.01096540f, 
    0.11870742f, -0.09620570f, 0.00992859f, -0.09745395f, 0.09082842f, 0.02560669f, 0.12339794f, 0.16086662f, 
    0.06253920f, 0.06702407f, 0.05750194f, 0.02495985f, 0.06384060f, -0.05991410f, 0.14933632f, 0.04474583f, 
    -0.06359817f, -0.05230492f, -0.22527865f, -0.16674644f, -0.07401634f, 0.11431880f, 0.13317651f, 0.00411115f, 
    0.00750097f, -0.05103140f, 0.19296820f, -0.05031504f, -0.29748538f, -0.05021484f, -0.01097173f, -0.17698312f, 
    0.04658459f, -0.04907622f, -0.00059468f, 0.09664743f, -0.02485210f, -0.03310773f, -0.03702131f, 0.00510633f, 
    -0.25496146f, -0.22307722f, 0.17743106f, 0.36174718f, -0.00586168f, -0.08233280f, -0.00224022f, -0.01100072f, 
    0.06474848f, 0.07663222f, 0.10441261f, -0.04200744f, 0.25439194f, 0.29356015f, 0.24161573f, 0.22753990f, 
    0.02517154f, -0.07099771f, 0.00739270f, 0.13762483f, 0.13082337f, 0.11440007f, 0.00780599f, 0.10100193f, 
    -0.08283176f, 0.34504965f, 0.02111343f, 0.02354569f, -0.03975615f, 0.07694650f, -0.02216780f, 0.13217610f, 
    -0.07489832f, 0.02822714f, 0.14032108f, 0.09116587f, -0.39571431f, 0.02368483f, -0.02710004f, -0.00130013f, 
    -0.17361479f, 0.09808543f, -0.02423809f, 0.11160188f, -0.12338489f, 0.05004195f, -0.02368046f, -0.03889441f, 
    -0.26760295f, -0.10735743f, 0.09544393f, 0.11334302f, -0.00190349f, 0.04156979f, -0.07911033f, 0.02880141f, 
    0.00955728f, -0.01632928f, 0.05663989f, 0.01467164f, -0.04281158f, -0.02952640f, 0.02185587f, -0.01142784f, 
    0.06403378f, 0.15233225f, 0.07557234f, -0.00587866f, 0.09283286f, 0.01588894f, 0.03873492f, 0.00571371f, 
    0.05516154f, -0.14043993f, -0.20220344f, 0.14792062f, -0.07366180f, 0.10247748f, 0.08944469f, 0.08328367f, 
    -0.08242897f, -0.02370321f, 0.02824218f, -0.06247069f, 0.00417055f, -0.04348724f, -0.10377282f, -0.02915508f, 
    0.01344574f, 0.00095235f, 0.03296193f, 0.04306629f, 0.00042775f, 0.06733295f, 0.15865409f, -0.08372206f, 
    0.04977361f, -0.12803854f, -0.11073975f, 0.13598740f, 0.03401153f, -0.02903885f, 0.02708874f, 0.08648393f, 
    0.07622471f, 0.07462414f, -0.04085070f, -0.02166008f, 0.19420379f, 0.02528568f, 0.05192811f, 0.12021605f, 
    0.00226437f, 0.02201088f, -0.03183396f, 0.01853668f, -0.06470759f, 0.06641496f, -0.03222155f, -0.05342708f, 
    -0.04027542f, -0.00704245f, -0.08511773f, 0.05638738f, 0.11513467f, 0.00186080f, 0.07605600f, -0.05289901f, 
    0.01410878f, -0.08693748f, 0.12160926f, -0.04938071f, 0.14724645f, -0.20679700f, 0.09222234f, -0.09288002f, 
    -0.08881304f, 0.06190148f, 0.04793194f, 0.05525747f, 0.03535114f, 0.00370340f, -0.03969255f, -0.06055101f, 
    -0.05818897f, -0.00065625f, -0.11346783f, -0.10041233f, 0.06183053f, -0.00025425f, 0.06122574f, 0.05212036f, 
    -0.00189021f, 0.05863924f, -0.00256402f, 0.05147780f, 0.36702165f, 0.09099383f, 0.24688594f, -0.16726649f, 
    0.00142567f, -0.04779570f, 0.04929512f, 0.09858177f, -0.01930990f, -0.03628571f, 0.14553148f, 0.04202978f, 
    0.04920067f, -0.19476344f, 0.01266209f, 0.06671408f, -0.07554586f, 0.13226615f, 0.05841326f, 0.09138348f, 
    0.02212840f, 0.01586009f, -0.04727894f, 0.08214916f, 0.10595539f, -0.00804660f, -0.19777970f, 0.01952286f, 
    -0.02998910f, -0.11905205f, -0.03855976f, 0.02624494f, -0.08402015f, 0.00172659f, -0.06609580f, -0.02036558f, 
    -0.05352604f, -0.04036738f, -0.09688801f, -0.12037291f, -0.01700789f, 0.01239765f, -0.01301852f, 0.01674193f, 
    0.01790206f, 0.04575850f, -0.00727419f, 0.09830012f, 0.14658724f, 0.05282453f, 0.06143654f, 0.11132256f, 
    0.04354632f, 0.02580304f, 0.05943042f, -0.01944675f, -0.10329493f, 0.08454000f, -0.02445580f, -0.00117107f, 
    0.00119889f, -0.04735579f, 0.00232442f, 0.16381864f, 0.02298368f, -0.08020940f, -0.10767486f, 0.00107613f, 
    -0.05910742f, 0.03641937f, 0.05342231f, -0.02289343f, -0.37469500f, 0.05765133f, -0.02650219f, -0.28331926f, 
    0.15869716f, 0.01150002f, 0.06821614f, 0.07542141f, 0.08236051f, 0.04328723f, 0.05689847f, 0.12917174f, 
    -0.05881232f, 0.00655429f, 0.04834716f, -0.02807256f, 0.10651112f, -0.06852163f, -0.00501777f, 0.09206542f, 
    -0.00562269f, -0.03576871f, -0.10870624f, -0.00037714f, 0.08186237f, 0.02107767f, 0.15262517f, -0.06535862f, 
    0.07019208f, -0.07334869f, -0.06402358f, 0.05871860f, -0.07354259f, -0.06100818f, -0.04492185f, -0.03817065f, 
    -0.09467307f, -0.08370555f, -0.16606037f, 0.21575066f, 0.05226894f, -0.01787134f, -0.07510950f, 0.10381850f, 
    -0.01315438f, 0.10051057f, 0.04705169f, -0.01797929f, -0.07851529f, -0.16456862f, -0.10812950f, 0.12073035f, 
    0.02973604f, 0.07695886f, 0.12793404f, 0.11116374f, 0.01501792f, 0.05867021f, 0.21100858f, -0.09114566f, 
    -0.07155386f, -0.01851351f, -0.00201740f, 0.09968708f, 0.00111622f, -0.06130206f, -0.05072814f, 0.06550909f, 
    0.02198939f, 0.05372805f, 0.10423508f, -0.05074348f, 0.01642734f, -0.11430251f, 0.17914560f, 0.17030893f, 
    0.13489446f, -0.00780923f, -0.04548945f, 0.01529660f, 0.02231893f, 0.04855821f, -0.04664982f, -0.00798344f, 
    0.16163285f, -0.06937537f, 0.09409165f, -0.04138710f, 0.01686776f, -0.02132818f, 0.00329635f, 0.12185712f, 
    -0.03802833f, 0.07575889f, 0.04848803f, -0.00851849f, 0.21206525f, 0.16088234f, 0.20317082f, -0.00980536f, 
    0.00324100f, 0.04103213f, 0.09779718f, -0.02249747f, 0.03258156f, 0.02683615f, 0.02232558f, -0.07648314f, 
    -0.19075020f, 0.05700333f, 0.01367592f, -0.20249377f, 0.14067212f, 0.04402043f, 0.06838765f, -0.01024652f, 
    -0.03357981f, -0.02586540f, -0.03738216f, -0.02031050f, 0.08042765f, 0.07956201f, 0.02378447f, -0.04551183f, 
    0.12874195f, 0.01407756f, 0.08147059f, 0.04255343f, 0.01510534f, 0.03853476f, -0.04664686f, -0.01690285f, 
    -0.09571949f, 0.07950767f, 0.03454794f, -0.08420343f, 0.02532958f, 0.08900762f, -0.09596017f, 0.04309636f, 
    0.07188802f, -0.08212680f, -0.00056896f, -0.08942281f, 0.35767609f, -0.01307765f, 0.13801131f, 0.00399663f, 
    -0.04665010f, 0.00853391f, -0.04194951f, -0.02189600f, 0.05450438f, 0.09958749f, 0.09707862f, 0.01424325f, 
    -0.00143544f, -0.03778076f, 0.00130740f, 0.12439117f, -0.03774452f, -0.05331186f, -0.01971003f, -0.05305423f, 
    -0.08760226f, -0.06261119f, -0.05941309f, -0.10526709f, 0.10194102f, -0.06486637f, -0.10592706f, -0.16237511f, 
    -0.03262371f, 0.07517684f, -0.04569424f, 0.09704361f, 0.05578713f, -0.02479920f, -0.09485272f, -0.04364788f, 
    -0.10259771f, 0.25153574f, -0.12725398f, 0.05137509f, -0.01945953f, -0.06391070f, -0.02819368f, 0.11989775f, 
    -0.06289906f, 0.06493699f, -0.00056009f, 0.03426527f, -0.22447230f, -0.20823802f, -0.01503033f, 0.05855732f, 
    0.00778116f, -0.02842027f, 0.03744313f, 0.08500297f, 0.04122441f, 0.07048880f, 0.07699704f, -0.00526452f, 
    0.05758265f, -0.13260224f, -0.05351987f, -0.04253955f, -0.01113934f, 0.05942229f, 0.00551668f, 0.09912984f, 
    0.01707417f, 0.07799103f, 0.05295896f, -0.01918495f, 0.13524979f, 0.16646868f, -0.12763649f, -0.03332672f, 
    0.11362942f, 0.01086893f, 0.01508968f, 0.03717102f, 0.05360742f, -0.02029247f, 0.06456989f, 0.02538358f, 
    -0.14095923f, 0.03279006f, -0.01150927f, -0.08548216f, -0.09251124f, -0.00465958f, 0.07338532f, 0.03836080f, 
    -0.02025575f, 0.04963654f, -0.04555720f, 0.19003701f, -0.11488501f, 0.02030152f, 0.02587716f, 0.02924068f, 
    0.10489829f, 0.02180103f, -0.02009854f, -0.04293457f, 0.02855428f, -0.01547664f, -0.08514349f, -0.03338786f, 
    -0.07901127f, 0.03374343f, 0.12158836f, -0.16064848f, 0.20990665f, -0.01978294f, 0.11067534f, 0.01086450f, 
    0.02393048f, 0.12905994f, 0.09133781f, -0.01149069f, -0.17978190f, 0.06844056f, 0.07146350f, 0.05648332f, 
    0.04349979f, 0.05342743f, 0.07436836f, -0.05735038f, -0.05092744f, 0.00073777f, -0.06547947f, 0.00067324f, 
    0.04409248f, 0.17024215f, -0.08934176f, -0.11246736f, 0.15502793f, 0.03088976f, 0.08753488f, -0.00946907f, 
    -0.03579820f, 0.03655871f, -0.03389723f, 0.01930524f, 0.04533650f, -0.12139420f, -0.10643254f, -0.01723547f, 
    -0.01756034f, 0.04004587f, -0.13131236f, -0.18702897f, -0.09281430f, -0.02184185f, 0.03890790f, 0.08985845f, 
    0.01258999f, 0.02547269f, -0.00585466f, 0.07883933f, 0.10346796f, 0.01729430f, -0.00544671f, 0.10665379f, 
    -0.11105451f, -0.15571982f, -0.07433906f, -0.06234482f, 0.12919557f, 0.23824216f, 0.07968412f, 0.07515816f, 
    0.05362434f, -0.03327456f, 0.20645320f, -0.08415497f, 0.04099351f, -0.08560520f, 0.01786317f, -0.00264269f, 
    -0.16191255f, -0.12834454f, 0.17698060f, 0.06256776f, 0.05034857f, 0.02281174f, -0.03601893f, 0.06532581f, 
    0.09233645f, -0.05507893f, 0.02576674f, 0.02758239f, 0.22714162f, 0.17638561f, 0.00114772f, -0.13086471f, 
    0.04130628f, 0.04389338f, 0.04965395f, -0.05441662f, -0.06613075f, -0.03944952f, -0.05309283f, -0.02268831f, 
    0.34595889f, 0.00183889f, 0.21873447f, -0.29264724f, -0.05199142f, 0.07785132f, 0.08360049f, 0.15935050f, 
    0.00128228f, 0.03843862f, 0.01068611f, -0.05806588f, -0.00991860f, -0.03262873f, -0.00257564f, 0.01460981f, 
    -0.10503493f, 0.03214849f, -0.06007653f, -0.02746201f, 0.03731128f, 0.00985805f, 0.02679952f, 0.14318186f, 
    0.12240728f, 0.07992671f, -0.04137450f, 0.00479491f, -0.00860961f, 0.00446182f, 0.03725000f, 0.03342803f, 
    -0.06444730f, 0.02989112f, -0.04431816f, -0.03050263f, -0.02255769f, -0.15694059f, 0.21636865f, 0.02777324f, 
    0.07446895f, 0.00347025f, 0.03676661f, -0.01682207f, 0.00940763f, -0.01817120f, 0.00359475f, 0.06237986f, 
    0.05287229f, 0.05802002f, 0.16638629f, -0.00134110f, 0.13784882f, 0.00744767f, 0.02451423f, 0.06800612f, 
    -0.04273953f, -0.07019559f, -0.10684466f, -0.02666915f, -0.04471833f, 0.10174822f, 0.05135119f, 0.19776255f, 
    0.04418826f, -0.04724451f, 0.06681088f, 0.08211816f, 0.05975562f, 0.08368259f, 0.04852672f, 0.08611793f, 
    0.25296998f, 0.08759442f, -0.03051037f, -0.08814447f, -0.01379339f, 0.03825399f, 0.04694985f, 0.00650050f, 
    0.06564473f, -0.06894474f, -0.05401426f, -0.00710840f, -0.00093260f, -0.05504835f, -0.03687168f, -0.15692116f, 
    0.17103058f, 0.00987021f, 0.05357043f, -0.00978277f, -0.02521504f, 0.02668182f, 0.01979689f, 0.08178511f, 
    -0.08938476f, -0.04113200f, 0.02226071f, -0.15028834f, -0.00276620f, 0.03463680f, -0.02753840f, 0.06229727f, 
    0.00166300f, 0.02865746f, 0.05342166f, -0.00199154f, -0.00328805f, 0.00724210f, 0.00068990f, 0.02542469f, 
    -0.02101633f, 0.01004615f, 0.04454069f, 0.06287257f, 0.07466377f, -0.03246912f, -0.07380004f, 0.01637682f, 
    0.25505105f, 0.12586133f, 0.03328086f, -0.15765631f, 0.11227693f, -0.00715565f, 0.01734963f, 0.00062913f, 
    0.05349730f, 0.06164110f, -0.05714386f, 0.02930713f, 0.06307476f, 0.06817046f, -0.06403597f, 0.17181563f, 
    -0.00248455f, 0.02846699f, 0.04241354f, -0.01990626f, -0.02218260f, 0.10008492f, -0.02491102f, 0.04144160f, 
    -0.08870929f, -0.03291683f, -0.00243417f, -0.06873865f, 0.07353614f, 0.07714488f, 0.09054078f, 0.02917595f, 
    0.01287647f, 0.00553677f, 0.07134862f, 0.04125762f, -0.09929143f, 0.23388678f, -0.00000031f, 0.15357403f, 
    -0.04556656f, 0.09295924f, 0.02923999f, 0.00475752f, 0.00680541f, 0.05250527f, -0.12086079f, -0.05803100f, 
    -0.27567744f, -0.10301258f, -0.00341932f, 0.12073588f, 0.20305108f, 0.00308504f, -0.02475925f, -0.04456610f, 
    0.08164950f, 0.01545421f, -0.04860292f, -0.02398768f, -0.04649938f, -0.01581788f, -0.05211876f, -0.15481952f, 
    0.07114229f, 0.04885628f, 0.07050326f, 0.12790610f, 0.01575216f, 0.06381498f, -0.01257283f, 0.00737319f, 
    0.15828951f, -0.00757278f, 0.00509865f, -0.13196424f, 0.03990662f, 0.06492639f, -0.00644255f, -0.02909084f, 
    -0.09130182f, -0.01399033f, -0.07312375f, -0.03636038f, 0.14768773f, 0.02866359f, 0.00116008f, 0.06089922f, 
    -0.04320302f, 0.16437149f, -0.00636124f, 0.03285742f, 0.04457775f, -0.07676776f, 0.08431280f, 0.06637186f, 
    0.05100848f, -0.01022165f, -0.21619032f, -0.05100989f, 0.08573025f, 0.02456707f, 0.02235998f, 0.11257762f, 
    0.04933089f, -0.03345028f, 0.01909025f, 0.06880859f, -0.31749049f, -0.08634257f, -0.05597679f, -0.20409489f, 
    0.03727297f, 0.07213202f, -0.08920877f, -0.04380331f, 0.01659796f, -0.08900468f, -0.04187249f, 0.12953334f, 
    0.16015983f, 0.08586352f, -0.04758087f, -0.07883442f, -0.04944922f, -0.00956512f, -0.01980086f, 0.00467773f, 
    0.03763878f, 0.00743459f, 0.00417826f, 0.01980842f, 0.19828641f, 0.14612362f, 0.07242913f, -0.19322293f, 
    0.03105170f, -0.00968030f, 0.00647342f, -0.00083637f, -0.08599444f, 0.06516113f, -0.01349217f, 0.06974156f, 
    -0.04513813f, -0.00190558f, -0.02344558f, -0.04470502f, -0.01572499f, 0.01586799f, -0.02422646f, 0.01025463f, 
    -0.00131759f, -0.00187010f, -0.04157084f, -0.01402094f, 0.01936594f, 0.01768362f, -0.00554078f, 0.00093341f, 
    0.00480493f, -0.03286936f, -0.03771873f, 0.01705240f, 0.00863677f, 0.00709067f, -0.00269461f, -0.02626181f, 
    -0.00164009f, 0.00333039f, 0.02347873f, 0.00965431f, 0.02771237f, -0.00938679f, -0.03701598f, -0.04302851f, 
    0.01575759f, 0.02327240f, 0.00257691f, 0.00579303f, 0.02580672f, 0.00498514f, 0.01034094f, 0.00913144f, 
    -0.01232094f, 0.02098446f, -0.04063499f, -0.04179425f, 0.01788332f, 0.00064406f, -0.04057826f, -0.00027514f, 
    -0.04092908f, -0.02219396f, -0.01656822f, 0.01167910f, 0.01779410f, -0.00134373f, 0.01495447f, -0.01538294f, 
    -0.03530780f, 0.01952680f, 0.01838911f, 0.02151877f, 0.02139825f, 0.01974621f, 0.02875473f, -0.01551759f, 
    0.02153423f, -0.01778012f, -0.01171187f, -0.01903810f, 0.00764471f, 0.02259053f, 0.01288675f, 0.00535979f, 
    -0.02167755f, -0.01139477f, -0.04219665f, -0.03437968f, 0.01360202f, -0.04139065f, -0.00160978f, 0.00397213f, 
    -0.01075822f, 0.02217172f, 0.02451489f, -0.00667081f, -0.04166377f, -0.01871094f, -0.02305472f, -0.04058204f, 
    -0.01359714f, -0.00718673f, -0.03111359f, -0.00553630f, 0.01636244f, -0.03888127f, -0.01142722f, -0.03571719f, 
    -0.02816896f, -0.04199417f, -0.00952136f, -0.03451743f, 0.01207296f, 0.00635656f, -0.01963550f, 0.00742189f, 
    0.00859587f, -0.03435950f, -0.03532668f, -0.02467323f, 0.02081784f, -0.02749048f, -0.03172482f, -0.01368083f, 
    -0.02834496f, -0.03112125f, 0.02035914f, -0.00309573f, -0.00668187f, -0.03643350f, 0.01947225f, -0.02364185f, 
    0.00608027f, 0.00168843f, -0.00365055f, 0.02212098f, -0.01059741f, 0.01826501f, 0.02473769f, -0.01686782f, 
    0.01155528f, -0.02181018f, -0.03988013f, -0.00371665f, -0.02990349f, 0.01316144f, -0.02342883f, 0.01852307f, 
    0.00759695f, -0.03418188f, -0.03673350f, 0.01872467f, -0.03290905f, 0.02232497f, -0.02853933f, -0.04316071f, 
    -0.03754936f, 0.00845221f, -0.02200313f, -0.04137706f, 0.01512122f, 0.02591401f, 0.01515541f, 0.00198553f, 
    -0.03180869f, -0.04097369f, -0.03265486f, 0.02244305f, -0.00312873f, -0.04212891f, 0.00006247f, -0.03591794f, 
    -0.00772897f, -0.02730986f, -0.01125919f, 0.01245687f, 0.02377564f, -0.03882653f, 0.02063680f, 0.00742621f, 
    0.02524340f, -0.01296276f, -0.02978661f, -0.02806388f, -0.01422059f, -0.02446387f, -0.03727528f, -0.03618955f, 
    -0.00175855f, 0.02066801f, -0.01891781f, -0.00429001f, 0.01369543f, -0.03811394f, 0.00087033f, -0.03414073f, 
    0.01432444f, -0.04604028f, -0.00112666f, -0.03429308f, -0.02309250f, -0.00306948f, -0.03699106f, 0.02789082f, 
    -0.02631692f, 0.02114982f, 0.01183754f, -0.03178236f, 0.01164926f, -0.00394856f, -0.00547315f, 0.01272491f, 
    -0.01344552f, -0.03998290f, -0.04435074f, -0.01712302f, -0.03679478f, -0.00899779f, -0.02185172f, -0.04048856f, 
    0.00134222f, -0.00182610f, 0.01280759f, 0.02254625f, -0.00303465f, -0.03346023f, -0.02882783f, -0.02603107f, 
    0.01401648f, 0.02008139f, 0.00056145f, -0.00300773f, -0.03867156f, 0.00247285f, -0.01299157f, 0.02456300f, 
    0.01460712f, -0.00210903f, -0.03602897f, -0.03638743f, -0.01999411f, 0.01829394f, 0.00422905f, -0.02257414f, 
    0.01711107f, -0.02137647f, 0.00140601f, -0.02781864f, -0.02262471f, 0.01833303f, 0.02140521f, -0.02625957f, 
    -0.03890314f, -0.00665159f, -0.02582194f, -0.00033493f, -0.02658005f, 0.00697682f, 0.00479514f, 0.02421292f, 
    -0.04305816f, 0.02515362f, -0.00464228f, -0.04387593f, -0.02917743f, -0.00142103f, 0.00440566f, 0.00582709f, 
    -0.01753578f, -0.02549545f, 0.00601059f, 0.01571213f, 0.02188015f, 0.02618145f, -0.03554145f, -0.02349164f, 
    -0.01349443f, 0.01033912f, -0.02700383f, -0.00237771f, 0.02836507f, -0.03066513f, -0.01551599f, -0.01464531f, 
    -0.02208820f, -0.04359324f, 0.01002750f, -0.04365495f, 0.02444235f, -0.04340069f, 0.00855095f, -0.03873434f, 
    -0.03452818f, -0.00189904f, 0.00633046f, 0.01337014f, 0.00657108f, -0.02530316f, -0.00211714f, -0.00001452f, 
    -0.00193999f, 0.01291001f, 0.01298604f, -0.02022965f, -0.04467187f, 0.01770836f, -0.02009572f, -0.03944933f, 
    0.01031094f, -0.04016460f, 0.01927170f, -0.03158192f, -0.03878433f, 0.01506962f, -0.02720519f, 0.00292181f, 
    -0.00226780f, -0.01767808f, -0.02826118f, 0.02284901f, 0.00130264f, -0.01051223f, -0.00607249f, 0.02517116f, 
    -0.00856751f, -0.02823270f, -0.03713230f, -0.03853016f, -0.00502747f, 0.02310855f, -0.01090891f, -0.02656115f, 
    0.02213749f, -0.00494701f, 0.00878161f, -0.00677184f, 0.00475802f, 0.02543269f, -0.03315610f, 0.01963337f, 
    -0.03872421f, -0.04440203f, 0.01733118f, -0.02988132f, -0.01475902f, 0.00494418f, 0.01701002f, 0.01502778f, 
    -0.04358462f, 0.01488141f, 0.01076496f, 0.01635799f, -0.02932563f, -0.00162992f, -0.00943717f, -0.02332480f, 
    -0.00536919f, -0.00082101f, -0.04196016f, -0.00858518f, 0.01623124f, 0.01961892f, 0.00521107f, -0.00710092f, 
    0.00512018f, -0.01703600f, 0.00988951f, 0.00943144f, -0.02640506f, -0.02686224f, 0.02690365f, -0.01232289f, 
    -0.00437587f, -0.02676047f, -0.01631824f, -0.04260738f, 0.01346514f, 0.00193098f, -0.03506387f, 0.00083381f, 
    -0.04282678f, 0.00960209f, -0.01692796f, 0.01641107f, 0.01265724f, -0.03558722f, 0.02203563f, -0.02977065f, 
    -0.01038000f, 0.00203112f, 0.01145722f, -0.01735202f, 0.02539840f, 0.00014863f, -0.01675376f, 0.00780482f, 
    0.02155889f, 0.00584342f, -0.00360107f, -0.02882662f, -0.02081155f, -0.02511648f, 0.01324676f, -0.01359939f, 
    -0.02543882f, -0.02033683f, 0.01383797f, 0.01785513f, -0.01699002f, 0.01568525f, 0.01555074f, -0.04503819f, 
    0.01087364f, -0.01799435f, 0.00186767f, -0.01335724f, 0.01197851f, -0.01602936f, 0.00116679f, 0.00536476f, 
    -0.00038334f, 0.00812927f, 0.02078610f, 0.01361923f, 0.00290585f, 0.02167587f, -0.00168802f, -0.03336301f, 
    -0.01744632f, 0.01100818f, 0.01369355f, -0.02107341f, -0.03841031f, -0.01200964f, 0.01265768f, -0.01690241f, 
    0.02163268f, -0.03341093f, 0.02133706f, 0.00252809f, -0.02135784f, 0.01126373f, -0.02979194f, 0.02299322f, 
    0.00754787f, 0.01766170f, 0.00380576f, -0.03147881f, -0.04011753f, -0.02459402f, -0.02785315f, -0.04515421f, 
    -0.03076907f, -0.02300237f, -0.02574266f, 0.01419941f, -0.03349769f, -0.02033507f, -0.03673786f, 0.01734994f, 
    -0.04253734f, 0.01719834f, 0.01759895f, -0.02026399f, 0.02301538f, 0.00588802f, 0.01720996f, 0.02320984f, 
    -0.00707458f, 0.00987510f, 0.00147622f, -0.02324989f, -0.00975334f, 0.02436273f, -0.03744376f, 0.02562055f, 
    0.01541683f, -0.02523544f, 0.01994894f, 0.00037396f, 0.01164599f, -0.01944131f, -0.02776519f, 0.00446781f, 
    0.00931574f, -0.01106305f, -0.01872951f, -0.01406625f, 0.01291198f, 0.02383485f, 0.00549896f, 0.01863203f, 
    0.02537657f, -0.03185253f, -0.03889901f, -0.00467562f, 0.02623152f, 0.01493002f, -0.00313735f, -0.02744639f, 
    -0.00380545f, -0.00228912f, -0.00124390f, 0.00803703f, -0.01565132f, -0.02484815f, 0.02316833f, -0.00636264f, 
    -0.04164203f, 0.02401789f, 0.02483907f, 0.00573840f, 0.00409732f, 0.00778286f, 0.01703806f, 0.00135225f, 
    0.02218667f, 0.01554261f, 0.02671877f, -0.02188038f, -0.00403037f, 0.01254168f, 0.00859893f, 0.01836028f, 
    0.01530947f, 0.00060197f, -0.03763165f, 0.02697307f, 0.00823677f, -0.02861263f, -0.01941141f, -0.00536689f, 
    0.02558238f, -0.00644396f, -0.00632925f, -0.00520198f, -0.03438540f, -0.02586720f, -0.03605855f, 0.00806795f, 
    0.00254233f, -0.02222603f, 0.01572549f, -0.03996139f, 0.02050341f, -0.04641283f, 0.01313908f, 0.00204113f, 
    0.00241456f, -0.00487066f, 0.01340546f, -0.03783518f, 0.02176657f, -0.04423485f, -0.02610121f, -0.02510768f, 
    -0.01839452f, -0.00980974f, -0.04162078f, -0.03035596f, 0.00249393f, -0.03501614f, -0.00751834f, -0.00065957f, 
    0.00674656f, -0.02091415f, 0.01106128f, -0.03086608f, 0.00913679f, -0.00092204f, -0.00567693f, 0.00292285f, 
    -0.00077245f, 0.02145968f, -0.01199047f, -0.02572841f, -0.02493693f, 0.00261747f, -0.00334241f, -0.02079017f, 
    0.01085632f, 0.01698519f, 0.02268353f, -0.01550596f, 0.00125623f, -0.03581212f, 0.01439939f, -0.01871303f, 
    -0.03000889f, -0.00844587f, -0.00202435f, 0.02256187f, -0.03325447f, -0.02326850f, -0.04152717f, -0.01556872f, 
    -0.02287740f, -0.02668065f, -0.04037255f, 0.02311796f, 0.02015731f, 0.01157379f, -0.03293246f, -0.01839218f, 
    -0.03958676f, 0.01044221f, -0.02440727f, 0.00219636f, -0.03613613f, -0.01391243f, -0.03499318f, -0.03088700f, 
    0.01239341f, -0.02730148f, -0.01452778f, -0.00886366f, 0.01082211f, 0.02244663f, -0.04127032f, 0.00077573f, 
    0.01534226f, -0.00473619f, -0.00837525f, -0.03687304f, -0.03794277f, -0.01992622f, -0.03665459f, -0.00886609f, 
    0.01413727f, 0.01871362f, -0.02202902f, 0.02124677f, -0.03980738f, 0.00931283f, 0.00067093f, -0.03877090f, 
    0.02557806f, 0.01751934f, -0.01457805f, -0.03900553f, -0.03928932f, 0.00732299f, 0.02503256f, -0.02516331f, 
    0.00817793f, -0.01003428f, 0.00898843f, -0.00381861f, -0.04452821f, -0.00551367f, 0.00878365f, -0.02780335f, 
    -0.03500141f, -0.00291909f, -0.03246589f, 0.02172428f, 0.02418442f, -0.02328020f, -0.03159975f, -0.01229821f, 
    0.01120218f, -0.03394103f, 0.01157237f, -0.00352402f, 0.00584283f, -0.03518015f, -0.01834645f, -0.01841415f, 
    -0.02715840f, -0.00497677f, 0.01684912f, -0.01467122f, -0.01824700f, 0.00247361f, 0.01619003f, -0.02255414f, 
    0.01558862f, -0.01025100f, 0.02147583f, -0.01611074f, 0.01078180f, -0.03566267f, -0.02259302f, -0.04409397f, 
    -0.00565591f, -0.02186348f, 0.01045651f, 0.02082176f, -0.01215239f, 0.02490271f, -0.00093110f, -0.00636024f, 
    -0.03319480f, 0.00547862f, 0.01351350f, 0.00167684f, 0.01164441f, 0.00367411f, -0.01765255f, -0.02405819f, 
    0.01005099f, -0.01746166f, 0.01540296f, 0.01293591f, -0.04240029f, -0.03293362f, -0.00637729f, 0.02529657f, 
    -0.00898288f, -0.01439512f, -0.03561424f, -0.03726917f, -0.00509251f, 0.00136617f, 0.02130991f, -0.02540188f, 
    0.00828975f, -0.03092717f, -0.01615732f, -0.02144453f, -0.03464919f, 0.00438990f, -0.01471069f, -0.02053042f, 
    -0.00964256f, 0.00260052f, 0.00447516f, -0.00930195f, 0.02823028f, -0.02528330f, -0.03002890f, 0.01011198f, 
    -0.03132882f, -0.03275043f, 0.00024214f, -0.02613102f, 0.00667188f, -0.03772575f, 0.02247884f, -0.03991706f, 
    0.02626801f, -0.00629620f, -0.01313940f, 0.02575570f, -0.04278593f, -0.03270767f, 0.00387641f, -0.00036048f, 
    -0.00628410f, 0.00956604f, 0.02077606f, -0.00011949f, -0.01450427f, -0.00562149f, -0.00181932f, -0.00958897f, 
    0.01519640f, -0.04335544f, 0.02358636f, -0.01278355f, -0.00919876f, -0.00245152f, -0.03796003f, 0.01167836f, 
    0.02343607f, -0.02050979f, -0.04445629f, 0.00163822f, -0.03383021f, 0.00129215f, 0.01636844f, -0.00920640f, 
    -0.00302600f, -0.02325657f, -0.02043772f, -0.00718463f, -0.03982178f, -0.03665543f, -0.04423223f, 0.00096600f, 
    -0.06525093f, 0.01347531f, 0.07500356f, -0.12021165f, 0.13414937f, -0.11824197f, -0.01178483f, -0.10319389f, 
    -0.09027246f, 0.02546167f, -0.08324774f, 0.09826678f, 0.36376429f, -0.09227823f, -0.09293928f, 0.03638705f, 
    -0.01296308f, 0.05207615f, -0.04471900f, 0.07374153f, -0.02971080f, -0.05319779f, -0.03023051f, 0.00432786f, 
    0.05067265f, 0.20285602f, -0.00549464f, 0.02263240f, -0.00823541f, 0.11370602f, 0.04383002f, -0.01559428f, 
    -0.05118229f, 0.05386645f, -0.03786216f, -0.00119650f, -0.24797891f, 0.04479914f, 0.11214328f, -0.01945896f, 
    0.01426332f, 0.00617498f, -0.00144304f, 0.07841560f, 0.05804894f, 0.02503464f, 0.05644261f, 0.05342187f, 
    0.12610784f, 0.01703610f, -0.06439449f, -0.02129140f, -0.06956645f, 0.03058138f, -0.04271314f, 0.09154999f, 
    0.00373999f, 0.00732482f, 0.02478995f, 0.04891337f, -0.22021078f, 0.04052774f, -0.17467646f, 0.09313226f, 
    0.02412329f, -0.01259247f, 0.03739107f, -0.07008206f, -0.02281841f, -0.04228998f, 0.02643271f, -0.09600568f, 
    0.12342471f, -0.07464414f, 0.05136167f, 0.05286442f, -0.03298240f, 0.07335005f, 0.06430180f, 0.06178133f, 
    -0.00648864f, -0.09535722f, -0.01157621f, -0.04646116f, -0.46881330f, -0.03213013f, -0.01833852f, 0.13305308f, 
    0.00986213f, -0.01071155f, 0.00055163f, -0.14711271f, 0.00252720f, 0.02732841f, 0.05043352f, -0.04504271f, 
    -0.04268161f, 0.04974138f, -0.05774503f, -0.00214607f, 0.13810809f, -0.09085260f, -0.02516758f, -0.04822623f, 
    -0.03950325f, -0.02423898f, 0.10547932f, 0.02115840f, 0.12680402f, 0.06643547f, 0.24967925f, 0.12504658f, 
    0.10342301f, 0.11838625f, 0.11246558f, 0.11866435f, 0.03212867f, 0.09678078f, 0.06151377f, 0.02614537f, 
    -0.13629979f, 0.02596322f, 0.05960927f, 0.18262975f, 0.07910651f, 0.01080558f, -0.04624411f, 0.05280859f, 
    -0.04704294f, -0.06285127f, 0.01574855f, -0.03934223f, -0.06719240f, -0.11078248f, 0.14764990f, -0.01877889f, 
    -0.00196228f, -0.00159948f, -0.03517104f, 0.07637423f, 0.12785104f, 0.00646286f, -0.03623625f, -0.07994789f, 
    0.05160151f, -0.07819733f, 0.02756836f, -0.01450865f, -0.02566401f, 0.06729772f, 0.14810617f, -0.04473350f, 
    0.08380900f, -0.06051324f, -0.05516047f, 0.03030713f, 0.50597531f, 0.08626253f, 0.05525651f, 0.24697602f, 
    -0.17537588f, 0.00364795f, 0.00260211f, -0.01875230f, -0.03248171f, -0.00083040f, -0.00018235f, -0.06394409f, 
    0.20717426f, 0.19660480f, -0.12211637f, -0.04130903f, -0.09862210f, 0.15332602f, -0.05617641f, 0.00431633f, 
    0.05284723f, 0.10461821f, -0.05617172f, 0.02193858f, 0.11287448f, -0.07200006f, -0.00026059f, 0.02104015f, 
    0.08041517f, 0.00253817f, 0.06188894f, -0.01827898f, -0.12141135f, 0.06170245f, -0.03719043f, -0.10417522f, 
    0.14316812f, 0.01954564f, 0.11690642f, 0.04800480f, 0.00237613f, 0.10316714f, 0.03900617f, 0.00417824f, 
    0.01479514f, -0.05121288f, -0.02299666f, 0.01018000f, 0.27516377f, 0.19101202f, 0.04372445f, -0.01070357f, 
    0.05029500f, -0.01618252f, -0.00619627f, -0.07047497f, -0.01393437f, -0.10310338f, 0.02152618f, 0.09253747f, 
    0.13032721f, 0.01358160f, 0.01205317f, -0.14109471f, 0.04747005f, 0.06874026f, 0.00785935f, 0.05185086f, 
    -0.01187704f, -0.06500826f, 0.04153200f, 0.06481527f, 0.17261365f, -0.04135780f, -0.12247176f, -0.17561682f, 
    0.01540485f, 0.02158554f, 0.03774311f, 0.00815198f, 0.05838819f, -0.01452962f, -0.00449332f, -0.05123693f, 
    -0.18351583f, -0.21217133f, -0.02166881f, 0.01273429f, 0.02514713f, 0.04409508f, 0.03104850f, 0.02850464f, 
    0.06106006f, -0.01260464f, -0.06448137f, -0.07357837f, -0.37147549f, -0.01510281f, 0.07732588f, 0.03192240f, 
    -0.12988332f, -0.02610894f, -0.00803692f, 0.05815538f, -0.06909946f, -0.02970475f, -0.02851327f, -0.03743366f, 
    0.36892086f, -0.04125177f, 0.01214579f, -0.09967718f, -0.18461215f, 0.06636392f, -0.11247413f, 0.00716126f, 
    0.03642457f, -0.04886348f, -0.02656687f, 0.01608936f, -0.13371821f, -0.11974983f, 0.17776746f, -0.03876540f, 
    -0.05840751f, -0.00294777f, -0.12994564f, -0.01347372f, 0.00321510f, -0.04329196f, -0.05390914f, -0.05657415f, 
    -0.06529307f, 0.04241586f, -0.08734712f, 0.25051615f, 0.02909462f, -0.02016385f, -0.03525947f, 0.00120133f, 
    0.08597550f, -0.07816889f, -0.09347142f, 0.13083474f, -0.19883457f, -0.16414467f, -0.12663449f, -0.06583590f, 
    0.05531668f, -0.00370533f, 0.15029328f, 0.08127449f, 0.01879456f, -0.04955472f, -0.06340814f, -0.06499073f, 
    0.05467009f, 0.02501991f, 0.08862387f, 0.11979630f, -0.00321858f, 0.08652569f, 0.02703126f, 0.05682185f, 
    -0.02019306f, 0.05332870f, 0.12645137f, 0.13383719f, 0.09612551f, 0.17522681f, 0.11775903f, 0.04506046f, 
    0.04429992f, 0.14339748f, 0.00217359f, -0.04883835f, -0.03805809f, 0.03099103f, -0.01364816f, 0.04246826f, 
    0.01484611f, -0.30868021f, -0.05190700f, -0.01715069f, -0.06862011f, 0.01160447f, 0.05239890f, -0.04895855f, 
    -0.05989879f, -0.04043987f, -0.03039151f, -0.00943760f, 0.10643892f, 0.18972492f, 0.04530278f, 0.11305663f, 
    0.15486677f, -0.00836176f, -0.00974022f, 0.00397387f, 0.06244082f, -0.00379235f, 0.03179784f, 0.04616859f, 
    0.10650336f, 0.26636896f, 0.07756487f, 0.04019741f, -0.04061418f, 0.16492625f, 0.11007024f, -0.10320377f, 
    -0.08198255f, -0.01196809f, -0.01262703f, -0.00757288f, 0.05620898f, 0.01987463f, 0.21268559f, 0.01673672f, 
    -0.17383042f, 0.00542886f, 0.08634275f, 0.07250720f, -0.03745604f, 0.07673338f, 0.03924691f, 0.02971076f, 
    -0.04325831f, 0.10100234f, 0.07001260f, 0.07275539f, -0.02700242f, -0.02132534f, -0.01641488f, -0.14572480f, 
    -0.02978096f, -0.01156420f, -0.01757500f, -0.05258434f, 0.12862635f, -0.06373120f, -0.01767102f, -0.01907169f, 
    0.07140198f, 0.02945461f, -0.00254007f, 0.00230919f, 0.08361299f, 0.04361898f, 0.06939460f, 0.04110542f, 
    0.15185940f, -0.02722038f, -0.24774088f, 0.30471268f, -0.15170255f, 0.09975545f, 0.00129317f, 0.02322624f, 
    -0.06613922f, 0.01727496f, -0.03204471f, 0.00845489f, -0.03973754f, -0.08282985f, -0.08510304f, -0.12220532f, 
    -0.04315272f, -0.07517041f, -0.04447067f, 0.06337354f, -0.07384432f, 0.08828217f, 0.08389526f, 0.06240180f, 
    0.17816570f, 0.01422749f, 0.21731439f, -0.07341962f, -0.19557220f, 0.10199451f, -0.03242795f, 0.06888982f, 
    0.00832428f, 0.01572015f, -0.03355818f, -0.00100255f, 0.08520664f, 0.13039386f, 0.09915215f, 0.12932098f, 
    0.13967900f, -0.02979817f, 0.11434653f, 0.16053416f, 0.14534782f, 0.01067264f, -0.01152803f, -0.03149729f, 
    -0.11245989f, -0.05277843f, 0.11763829f, 0.08005310f, -0.00885258f, -0.02906018f, 0.05339958f, -0.10133196f, 
    0.15826884f, 0.08385696f, 0.04943219f, 0.03132329f, -0.07814275f, -0.01202539f, 0.15563369f, -0.03206738f, 
    -0.11161294f, -0.00203452f, -0.00481041f, 0.00338795f, -0.03011652f, 0.00482290f, 0.04091237f, 0.00093862f, 
    0.04695734f, -0.04072459f, -0.02996339f, 0.15940845f, 0.05175864f, -0.00195096f, 0.14936076f, -0.01908271f, 
    -0.11786286f, 0.01468261f, -0.02382709f, -0.02043713f, -0.17191142f, 0.04066183f, 0.12016349f, -0.04074466f, 
    -0.09350596f, 0.02487071f, -0.00541238f, 0.07550564f, 0.06936266f, 0.11154509f, 0.03160699f, 0.04033765f, 
    -0.31600657f, -0.01365191f, -0.04442924f, 0.19546278f, -0.04624839f, -0.00701220f, -0.05652774f, -0.05454413f, 
    0.03562970f, -0.08715927f, -0.05282111f, -0.06003831f, 0.08455200f, -0.04580661f, -0.10740781f, -0.20257029f, 
    0.10394259f, 0.09034434f, -0.01041803f, -0.02519715f, 0.01645530f, 0.06582753f, 0.00853227f, -0.01036473f, 
    -0.11116831f, 0.00553023f, -0.07270545f, 0.02722840f, 0.00851249f, 0.05337754f, -0.00096485f, 0.04293370f, 
    0.04993923f, 0.03637074f, 0.08766130f, -0.01966431f, -0.08623791f, -0.03240158f, -0.16953431f, 0.02158067f, 
    -0.03951764f, -0.10555003f, 0.08658461f, 0.11001439f, -0.00884195f, 0.05160473f, -0.04814770f, -0.08825243f, 
    -0.07574403f, -0.05914057f, -0.03338533f, -0.03104466f, -0.10439070f, -0.00540027f, 0.03355746f, -0.03419849f, 
    -0.07756746f, -0.04215799f, -0.03165096f, 0.02908538f, 0.08289588f, -0.07538670f, -0.06080227f, -0.09764739f, 
    -0.02416543f, 0.12354290f, -0.07881983f, -0.00930209f, -0.09354662f, -0.13753417f, 0.02235382f, -0.02372941f, 
    -0.20972343f, 0.08004341f, 0.17477645f, 0.11450870f, -0.04545085f, -0.10197244f, 0.02728952f, 0.09507224f, 
    -0.03130504f, -0.05602233f, 0.00455977f, 0.03878384f, 0.13592017f, 0.13207634f, 0.06340791f, 0.11799780f, 
    -0.02344542f, 0.09512057f, 0.04072409f, 0.08868007f, 0.03920411f, 0.07856183f, 0.08091000f, 0.01764009f, 
    -0.03938426f, -0.08691503f, 0.09632582f, 0.30928808f, 0.00528123f, -0.01684609f, -0.04133978f, -0.05562898f, 
    -0.01267001f, 0.02848990f, 0.01736003f, 0.13401820f, -0.06071075f, 0.00062531f, 0.05116395f, -0.01355007f, 
    -0.01230789f, 0.02090529f, 0.02086205f, -0.07504037f, -0.10661610f, -0.06671767f, 0.02417793f, -0.03773891f, 
    -0.07530850f, 0.13221432f, 0.16362305f, -0.01983045f, -0.06028119f, 0.05870168f, 0.02114973f, 0.05425299f, 
    -0.09490501f, -0.04390396f, 0.06579047f, 0.07475813f, 0.20069800f, -0.08426115f, 0.08103117f, -0.08732751f, 
    -0.01602188f, -0.05009067f, 0.02140828f, 0.06747349f, -0.00944673f, -0.05080321f, 0.03479200f, 0.02101407f, 
    0.20198336f, 0.17679946f, 0.10502572f, 0.10682277f, -0.09804870f, 0.04682352f, 0.00771993f, 0.14790151f, 
    -0.07836106f, 0.07529131f, -0.02932846f, 0.09400522f, 0.35091037f, -0.15388800f, 0.06709583f, 0.06239838f, 
    0.04542495f, -0.01860566f, 0.11874960f, 0.03756881f, -0.04283967f, -0.09683577f, 0.08431564f, 0.06507700f, 
    -0.00083954f, 0.07867584f, -0.02434394f, -0.06932715f, -0.04700858f, -0.04603834f, -0.08750197f, -0.01772637f, 
    0.07087818f, -0.03150960f, 0.02872783f, 0.01311993f, 0.12954707f, 0.09868992f, -0.00983459f, 0.13494159f, 
    -0.01285793f, 0.10812403f, 0.03097465f, 0.09735665f, -0.00893480f, 0.02082976f, -0.00481311f, -0.00069519f, 
    -0.26708257f, 0.11054396f, 0.14030813f, 0.06866118f, -0.01997441f, 0.04131228f, -0.09590917f, -0.02449377f, 
    0.09100990f, 0.09532635f, -0.00272566f, -0.13204950f, -0.16428575f, 0.13199998f, 0.04898272f, 0.00364491f, 
    0.01615526f, -0.10926440f, 0.08512665f, -0.04047248f, -0.12057809f, 0.07738544f, -0.12215139f, -0.00682486f, 
    0.15848400f, -0.01777854f, 0.30340326f, 0.07556364f, -0.06139311f, -0.06201584f, -0.02138540f, 0.04539531f, 
    -0.04226631f, 0.02346393f, -0.03114212f, 0.08772416f, 0.26400977f, 0.26717204f, -0.10757038f, 0.26617086f, 
    0.06912724f, -0.04325424f, 0.09155373f, 0.05709250f, -0.08510997f, 0.13980186f, -0.07657959f, -0.09752271f, 
    -0.24744444f, -0.13447723f, -0.04395280f, 0.02978274f, 0.08191647f, -0.07133013f, 0.04085784f, 0.04462313f, 
    -0.09081544f, -0.01457775f, 0.00407080f, 0.03667128f, -0.05548825f, 0.02874886f, -0.10706318f, 0.10858047f, 
    -0.00266302f, 0.05020373f, 0.10395277f, 0.01626416f, 0.12369417f, -0.02886239f, -0.03967727f, -0.02400872f, 
    -0.02500553f, -0.03399118f, -0.02414898f, -0.03257487f, -0.03076524f, -0.02006639f, -0.01855291f, 0.00098454f, 
    -0.01826271f, 0.02822019f, 0.00790160f, 0.00582248f, -0.00131245f, -0.00719483f, -0.00716083f, -0.01795633f, 
    -0.00822977f, 0.01933794f, 0.01300399f, 0.01784885f, 0.01068875f, 0.01157295f, 0.01447861f, -0.04060239f, 
    0.02461821f, -0.03269348f, 0.00721947f, 0.01003351f, -0.01917847f, 0.00741981f, -0.01167440f, -0.01586247f, 
    0.01957393f, -0.02592482f, -0.03159614f, -0.04072211f, -0.04075477f, -0.00351193f, -0.03590215f, -0.01075892f, 
    -0.00797964f, 0.02158276f, 0.01076906f, 0.02748572f, 0.00411352f, -0.03671343f, -0.02819611f, -0.00642441f, 
    0.01569536f, -0.01726622f, 0.02207024f, -0.02247321f, 0.00000535f, -0.03926704f, -0.03604530f, -0.03483723f, 
    -0.01822214f, -0.01968116f, 0.02034369f, 0.02557634f, 0.00723543f, -0.03210726f, 0.01376482f, 0.02764684f, 
    -0.01333494f, 0.00957481f, -0.00862570f, -0.02716182f, 0.01153025f, -0.01869653f, 0.02108746f, 0.01633749f, 
    -0.00054971f, -0.03254954f, -0.02803317f, -0.02136401f, 0.02424756f, 0.01651293f, -0.02395588f, 0.02245401f, 
    -0.01776309f, -0.02545295f, -0.03757073f, 0.00178800f, 0.02646243f, 0.02578387f, 0.02132464f, -0.04150032f, 
    -0.03372892f, 0.00714897f, -0.03714032f, 0.00922509f, -0.01629291f, 0.02489387f, -0.00209629f, -0.01862521f, 
    -0.03122249f, -0.02073755f, 0.01263502f, -0.01494923f, -0.02052183f, -0.01841205f, 0.01799207f, -0.00156468f, 
    0.01943723f, -0.00413691f, -0.00681424f, -0.00327172f, -0.00499536f, -0.03352059f, 0.01889057f, 0.02026005f, 
    -0.00562029f, -0.00708623f, -0.03932780f, 0.01472172f, 0.00756819f, 0.02500192f, -0.01360665f, 0.01464730f, 
    -0.01468460f, -0.04079284f, 0.02688850f, -0.00470382f, -0.00139226f, -0.00020623f, 0.00847639f, 0.02916202f, 
    -0.01858634f, 0.00864699f, -0.02468739f, 0.00645063f, -0.01609765f, 0.02167992f, -0.00957002f, 0.01090533f, 
    -0.00628737f, -0.00513735f, -0.00240834f, -0.01057673f, 0.01700827f, -0.04078388f, -0.03637071f, -0.00675023f, 
    -0.00242500f, -0.02404828f, -0.02586991f, -0.00402322f, -0.03252364f, 0.02096790f, 0.01900701f, 0.02618004f, 
    -0.01612839f, -0.00935909f, -0.03693721f, 0.01352850f, 0.00001089f, -0.02082658f, -0.00178137f, -0.02711543f, 
    -0.00391662f, -0.02136721f, -0.01763916f, 0.02013862f, -0.03465008f, -0.03997112f, -0.00746192f, -0.01439450f, 
    0.00458017f, -0.00382020f, -0.00875480f, 0.01565119f, 0.02451051f, -0.03797560f, -0.01896190f, 0.01830881f, 
    -0.03773618f, 0.00187778f, -0.02636595f, -0.01044495f, 0.01111265f, 0.00730814f, -0.03792332f, 0.00147813f, 
    -0.00924173f, -0.03148052f, 0.00261535f, 0.01467140f, 0.00257146f, -0.03134109f, 0.02548991f, -0.01425424f, 
    0.02306936f, -0.04199962f, -0.01372736f, -0.00874615f, -0.00022968f, -0.00848213f, -0.01078585f, -0.01168758f, 
    -0.01105406f, 0.02717957f, 0.00966511f, 0.00463395f, -0.00709469f, -0.01777440f, -0.01797647f, -0.04189853f, 
    0.01103707f, 0.00646476f, 0.00214063f, -0.03078613f, -0.04145199f, 0.01748672f, -0.01615775f, -0.03302934f, 
    -0.00522192f, 0.02745065f, 0.00547228f, -0.03159324f, -0.03561781f, 0.00670900f, -0.02534514f, -0.03625733f, 
    0.01240196f, 0.02576808f, 0.00630688f, -0.04150828f, -0.03325029f, -0.01773837f, -0.04054916f, -0.00937373f, 
    0.00188319f, -0.02817944f, 0.02483857f, -0.02490198f, -0.00597672f, 0.02705263f, -0.00611333f, 0.01220620f, 
    0.00805947f, -0.02391723f, 0.00026986f, 0.00527184f, -0.01075570f, -0.03558191f, 0.01743557f, -0.00152432f, 
    -0.02441559f, -0.03932241f, -0.01220274f, -0.01424234f, -0.01931947f, -0.04026766f, 0.00909967f, 0.02245221f, 
    -0.03150518f, -0.01914645f, -0.00950134f, 0.02191220f, 0.00063647f, -0.02550291f, 0.01775778f, -0.02530193f, 
    -0.03868048f, -0.02732662f, 0.02094447f, 0.01373106f, 0.00639234f, -0.03846543f, 0.01709471f, 0.02706093f, 
    0.01540385f, -0.02802705f, -0.00070601f, -0.00765927f, 0.01459855f, 0.02167623f, -0.01575725f, -0.01954346f, 
    0.00939579f, 0.01445298f, -0.00383708f, -0.04106598f, 0.02735936f, 0.02571158f, 0.02235099f, 0.01409942f, 
    0.01691512f, -0.00278572f, 0.01271682f, 0.01864913f, -0.01099302f, -0.02922607f, 0.00266365f, 0.00874477f, 
    0.00843665f, -0.00390230f, -0.03741805f, -0.03799999f, -0.01953462f, 0.02780632f, -0.03325155f, 0.02441133f, 
    0.01333578f, -0.01689829f, -0.00820463f, -0.03997735f, -0.02580434f, 0.02848959f, -0.00908930f, -0.03354609f, 
    0.02308142f, 0.01140007f, 0.00721602f, 0.01316595f, 0.00932419f, -0.00100171f, -0.02596084f, -0.01152094f, 
    -0.00525205f, 0.01248170f, -0.02155927f, 0.01074967f, -0.00831934f, 0.01878244f, -0.04030951f, 0.02347982f, 
    0.00342701f, -0.04197856f, 0.02832018f, -0.00028934f, -0.03101019f, -0.02088678f, -0.01122420f, -0.02142232f, 
    -0.03774678f, -0.04080250f, -0.03191433f, -0.02551505f, 0.01870524f, -0.02808612f, -0.00345495f, -0.03484804f, 
    0.02280515f, -0.03933018f, 0.01836854f, -0.03737880f, 0.00405030f, -0.03926299f, -0.02181165f, 0.02392532f, 
    -0.00321415f, 0.02137464f, -0.02854953f, -0.02333906f, 0.00558305f, 0.00524229f, -0.01525060f, 0.00526677f, 
    0.00692303f, -0.04081312f, -0.00399255f, -0.03471658f, -0.02647040f, -0.03592947f, 0.00028544f, -0.02586463f, 
    -0.01715997f, -0.01430332f, -0.02990146f, 0.02484991f, 0.02702114f, -0.01712050f, 0.01556462f, -0.03962184f, 
    0.01517567f, 0.01545571f, 0.02406024f, 0.01452731f, -0.03708124f, 0.02319602f, -0.02511449f, 0.00836000f, 
    0.02895980f, -0.01966168f, -0.01552961f, -0.01121494f, 0.02273647f, -0.00535803f, -0.02586544f, -0.00143270f, 
    0.00191488f, -0.01004817f, -0.02247522f, 0.02673073f, -0.03289917f, -0.02821457f, -0.00294257f, -0.03362963f, 
    -0.01003564f, -0.03768462f, 0.02395062f, 0.02741589f, -0.02318855f, -0.03115323f, -0.03467642f, -0.01038094f, 
    0.02155212f, -0.01538671f, 0.01452898f, -0.00534242f, -0.03961322f, 0.00848940f, -0.03455535f, -0.02500680f, 
    -0.03840206f, -0.04174918f, 0.00467197f, -0.00186770f, 0.00545040f, 0.00101735f, 0.02375998f, -0.01956246f, 
    0.01979753f, 0.00421959f, -0.03473558f, -0.04129404f, -0.04052066f, 0.01094058f, 0.00954129f, -0.02735838f, 
    -0.02237199f, 0.02635952f, -0.03768841f, 0.00822950f, 0.00756354f, 0.02542658f, 0.01267758f, -0.03549112f, 
    0.00511659f, -0.04091348f, 0.01846693f, -0.00282783f, -0.00200242f, 0.02256621f, -0.02022425f, -0.02978582f, 
    -0.01613811f, -0.02955922f, -0.01603288f, 0.01713493f, 0.02899760f, -0.01455106f, 0.02391797f, -0.01143127f, 
    -0.04208345f, -0.03602652f, 0.00101970f, -0.01377527f, -0.03274925f, -0.00158713f, 0.00622315f, 0.01364882f, 
    -0.03619438f, 0.01152357f, -0.00281831f, -0.02995782f, -0.00463955f, -0.04073124f, 0.00252911f, -0.00243512f, 
    -0.00395216f, 0.01072555f, -0.02379109f, -0.02834097f, -0.02744267f, -0.03384205f, 0.01718812f, 0.01921024f, 
    0.02219436f, 0.01756216f, -0.03043795f, 0.01780360f, -0.01551032f, -0.02941740f, -0.02444725f, -0.02126112f, 
    -0.00422235f, 0.02610626f, -0.02949732f, 0.01914258f, 0.00528461f, 0.01766649f, 0.01342004f, -0.04165177f, 
    -0.02369565f, -0.01499755f, 0.01465886f, -0.01509140f, -0.00268298f, -0.03056928f, -0.00800639f, 0.00504918f, 
    -0.00281604f, 0.02478419f, -0.00463317f, 0.00374595f, -0.03352740f, 0.02872680f, 0.00727687f, -0.03495641f, 
    0.02631569f, -0.01113960f, 0.01508723f, -0.00938493f, 0.00153556f, -0.02355300f, 0.00766965f, 0.00382747f, 
    0.01808831f, -0.03999576f, -0.04037106f, -0.00480249f, 0.01124050f, 0.01526801f, -0.01240614f, 0.01604532f, 
    0.02549356f, -0.01300197f, -0.01848522f, -0.01017845f, 0.01754437f, -0.02672505f, -0.02584698f, -0.04089522f, 
    -0.03261334f, 0.02048491f, 0.01248724f, 0.01453135f, -0.04154011f, -0.03246949f, -0.00657849f, -0.01972822f, 
    0.01251167f, -0.02537808f, 0.02319285f, -0.02135323f, -0.02262950f, -0.00129136f, -0.01779735f, -0.02085924f, 
    0.02661903f, -0.03968329f, 0.02471056f, 0.00364211f, -0.02868821f, 0.00413730f, -0.02064047f, -0.01551066f, 
    -0.01897202f, -0.01261741f, -0.01176233f, 0.00728156f, -0.01478254f, -0.00026605f, -0.02804811f, -0.03128801f, 
    -0.02545424f, 0.02455151f, 0.00266972f, -0.01741409f, 0.02569403f, 0.01362380f, -0.00756021f, -0.01058039f, 
    -0.01450661f, 0.02325287f, -0.02341729f, -0.01563237f, 0.02387589f, -0.01947431f, -0.03331973f, -0.01490777f, 
    0.00400993f, 0.02288971f, 0.00468071f, -0.02553064f, -0.00466174f, -0.04103979f, 0.00080718f, -0.02153663f, 
    0.00836955f, -0.01643501f, 0.01462174f, 0.00732951f, 0.02435358f, -0.01443729f, -0.01655539f, -0.01627083f, 
    -0.02605432f, 0.01615163f, 0.01611696f, -0.03932093f, 0.02489516f, -0.02999132f, 0.01676921f, -0.00039438f, 
    0.01829242f, -0.00046092f, 0.02014654f, -0.01164546f, 0.02148465f, 0.00188299f, -0.01749644f, -0.03876501f, 
    0.01052557f, -0.03552549f, 0.02966367f, -0.01951050f, -0.01346551f, -0.01243105f, -0.03407672f, 0.00854613f, 
    -0.03327166f, -0.00862989f, -0.00764412f, 0.01893120f, -0.03628974f, 0.00843323f, 0.00049536f, -0.02916826f, 
    -0.03947702f, -0.03844348f, 0.01042536f, -0.02991224f, -0.00609485f, 0.01126353f, -0.00782061f, 0.02265527f, 
    0.00852710f, -0.00920579f, -0.03869506f, 0.00748738f, -0.01923499f, -0.03574846f, 0.01006546f, -0.02026999f, 
    0.02557734f, -0.02295467f, -0.00519443f, -0.02058749f, -0.00048003f, 0.01426240f, -0.00441695f, -0.00881778f, 
    -0.00186060f, 0.02351529f, -0.01297545f, 0.00384660f, -0.00924620f, -0.02230722f, 0.01827236f, -0.00562222f, 
    -0.00111709f, -0.03774730f, -0.02578100f, 0.02523465f, -0.03572243f, 0.02947874f, -0.02934228f, -0.04084686f, 
    -0.00534964f, -0.00799623f, 0.02587974f, 0.00885556f, -0.00953436f, 0.01743794f, -0.01925060f, 0.00184996f, 
    0.01776741f, -0.02276398f, -0.04117728f, -0.01259453f, -0.01186899f, 0.01000986f, 0.02908992f, -0.03725651f, 
    -0.04092407f, -0.03668558f, -0.03874159f, 0.01528032f, -0.00889858f, -0.03595316f, -0.01115434f, -0.03518416f, 
    0.01942412f, -0.01329728f, -0.03720229f, -0.00839114f, -0.01172311f, -0.03064358f, 0.00129999f, 0.01320258f, 
    -0.03885848f, -0.01058490f, -0.00488573f, 0.02750239f, -0.04101273f, 0.02864461f, -0.01853330f, -0.03396859f, 
    0.00289422f, -0.00915842f, -0.01073913f, -0.03519135f, -0.01378018f, -0.01493156f, 0.02702640f, -0.00103215f, 
    -0.03650953f, -0.03831768f, -0.03506427f, -0.00338141f, -0.01452826f, -0.00196845f, 0.02852270f, -0.01468131f, 
    -0.03470673f, -0.01594487f, 0.01217134f, -0.00095239f, 0.00679217f, 0.00941858f, -0.03897647f, 0.02691014f, 
    0.02073567f, -0.02021481f, 0.00395471f, -0.02250370f, -0.03404375f, -0.00369900f, -0.00887434f, 0.02472887f, 
    -0.00225124f, -0.03502027f, -0.01486662f, -0.01794136f, -0.00685932f, 0.02692297f, -0.03250154f, -0.01173628f, 
    0.02571383f, -0.01303005f, -0.02092383f, 0.00601881f, 0.02246256f, 0.02969918f, 0.01389634f, -0.00461502f, 
    0.01209057f, -0.02325615f, 0.00896215f, -0.00512684f, 0.02345777f, -0.02445743f, 0.00050656f, 0.00310672f, 
    0.00252531f, 0.02656910f, 0.02956120f, -0.00953100f, 0.03347600f, -0.03843196f, -0.03805443f, -0.00680618f, 
    0.02905212f, -0.01916660f, -0.00238306f, -0.02720532f, -0.01630541f, 0.02837303f, 0.00137334f, -0.00822026f, 
    -0.02297244f, 0.02872848f, -0.00846175f, -0.01327967f, 0.00664469f, -0.03496220f, -0.01208651f, 0.02986078f, 
    0.02833763f, -0.03418000f, -0.00292836f, 0.02307390f, -0.01255974f, 0.00027167f, -0.01101405f, 0.01145218f, 
    -0.01208733f, -0.01755241f, 0.01053842f, -0.01830235f, 0.00966614f, -0.01043147f, 0.00639505f, 0.01714684f, 
    0.00803979f, -0.01051449f, -0.01366689f, -0.00132131f, -0.03518546f, -0.01372894f, -0.00971460f, -0.01292911f, 
    -0.00210998f, -0.01025075f, -0.04159742f, 0.02968512f, -0.01023645f, -0.00333147f, -0.02554231f, 0.00479405f, 
    0.00468764f, -0.02281408f, -0.03864125f, -0.01647889f, -0.03926280f, -0.03731617f, 0.00043415f, 0.02697787f, 
    -0.01703724f, -0.02495864f, 0.02947591f, -0.01115371f, -0.00729082f, -0.00903577f, 0.02072989f, -0.01029254f, 
    -0.01269079f, -0.01276820f, 0.01871952f, 0.02658407f, 0.02674130f, 0.00610580f, 0.01204161f, 0.00532244f, 
    -0.02175955f, -0.03720827f, 0.00366060f, 0.01960135f, -0.03736947f, -0.02312045f, 0.00923069f, -0.02884463f, 
    -0.00530684f, -0.00194562f, -0.01785446f, -0.01703757f, -0.02254865f, -0.00603845f, 0.00802449f, 0.02604396f, 
    -0.02196614f, 0.00814892f, -0.02833693f, 0.00978399f, -0.01388172f, 0.01401830f, -0.00235589f, 0.03310840f, 
    -0.00413414f, -0.02404993f, 0.02773606f, -0.00977919f, -0.02894861f, -0.01758537f, 0.02789275f, 0.02849173f, 
    -0.02919892f, -0.02115838f, 0.02864745f, 0.00190184f, 0.00702842f, -0.02605190f, 0.02013612f, 0.01385364f, 
    -0.01788884f, -0.01128357f, -0.00450732f, -0.00375617f, 0.02908744f, -0.01503969f, -0.01993817f, -0.01907618f, 
    -0.01130507f, 0.02929918f, -0.01896241f, 0.00987465f, 0.02606511f, -0.03844449f, 0.01510345f, -0.01488536f, 
    0.00356871f, -0.02445902f, -0.03996551f, -0.03238627f, 0.02004184f, 0.01024217f, 0.02561468f, -0.02538941f, 
    0.02010613f, 0.00002145f, -0.02667788f, 0.02712508f, -0.02015702f, -0.03992037f, -0.03177675f, -0.03714055f, 
    -0.03496620f, 0.02491208f, 0.01236027f, -0.03682037f, -0.02035323f, -0.04099687f, 0.02678915f, 0.01820076f, 
    0.00140347f, 0.01742936f, -0.02309478f, -0.02679650f, -0.01808494f, -0.00364751f, 0.02934439f, -0.01667701f, 
    -0.02498339f, 0.01828437f, -0.02583037f, -0.01092098f, 0.00002551f, 0.02310878f, 0.01991481f, -0.03070997f, 
    -0.00742275f, -0.00120241f, 0.02748916f, -0.03200626f, -0.00737821f, 0.00094503f, -0.01562971f, -0.02467791f, 
    -0.01472140f, 0.00369161f, -0.02569937f, -0.01631701f, -0.00293846f, -0.02529542f, 0.01191409f, -0.03032451f, 
    -0.03659602f, -0.03719563f, 0.00716853f, -0.03547634f, -0.02044796f, 0.00374507f, -0.03851981f, 0.00706348f, 
    0.02525092f, -0.04052811f, -0.02490277f, -0.02107219f, -0.03286722f, -0.00071980f, 0.02078940f, -0.00182979f, 
    0.01377811f, -0.03398629f, -0.00329709f, 0.01182875f, -0.02629497f, -0.00517417f, -0.00656459f, 0.01848563f, 
    -0.02886669f, -0.02810171f, -0.02477782f, 0.02580068f, -0.02963316f, -0.03031670f, 0.01559472f, 0.01228537f, 
    -0.01245112f, 0.02135351f, -0.03967658f, 0.02532872f, -0.00511190f, 0.00480250f, 0.02311610f, -0.00838683f, 
    -0.00726574f, -0.03366657f, -0.02722850f, -0.01077557f, 0.02785729f, -0.00828333f, -0.01025695f, 0.00040808f, 
    0.00676279f, 0.01397510f, -0.03420219f, 0.00298971f, 0.00682647f, 0.00008637f, 0.02120566f, -0.03333674f, 
    -0.00874728f, -0.03326137f, -0.03826954f, 0.02740636f, 0.00698425f, 0.00366001f, -0.03394882f, -0.01595633f, 
    -0.03465480f, -0.00998572f, -0.01509696f, -0.03178281f, -0.03495114f, -0.01886471f, -0.00158722f, -0.00126276f, 
    0.02091175f, -0.01492113f, 0.02308613f, -0.00418410f, -0.02291500f, -0.02847187f, 0.00920300f, 0.00511862f, 
    0.02134665f, -0.02905947f, 0.00780467f, -0.03486601f, -0.02756187f, 0.02011258f, 0.02489731f, -0.03790281f, 
    0.00735248f, 0.00576124f, -0.00022029f, -0.02510979f, -0.03271454f, -0.03675448f, -0.01528233f, 0.00623047f, 
    -0.02356187f, -0.01939693f, 0.01790563f, -0.01603156f, -0.04147084f, 0.01234094f, 0.02206850f, -0.03068880f, 
    -0.01424627f, -0.00761277f, 0.02112309f, -0.02945559f, -0.00256841f, -0.00258285f, -0.03536984f, 0.01202585f, 
    -0.00313517f, 0.00988374f, -0.00944884f, 0.01848239f, -0.01269150f, -0.02017954f, 0.01886292f, 0.01901148f, 
    0.01331695f, -0.00860494f, 0.00485477f, 0.00355934f, -0.00718538f, -0.03959397f, -0.01781728f, 0.02109897f, 
    -0.00268098f, -0.03105560f, -0.00476610f, 0.00081390f, -0.02025372f, -0.03993841f, 0.01865203f, -0.01880751f, 
    -0.02903229f, -0.00309919f, 0.02813872f, -0.02268272f, 0.02809588f, 0.02780350f, 0.01347119f, -0.01530945f, 
    -0.00397958f, -0.00070967f, -0.01021275f, -0.01160623f, 0.02935847f, 0.01088540f, -0.02774115f, 0.00587255f, 
    -0.03395607f, -0.03463018f, -0.00418387f, 0.02979498f, -0.00622388f, -0.00234814f, -0.00195145f, 0.00001676f, 
    -0.02081232f, -0.01133196f, -0.00190988f, -0.03420521f, 0.01295440f, -0.01340163f, 0.02432423f, 0.00277897f, 
    -0.03340701f, 0.01995471f, 0.02172049f, -0.03007345f, 0.00438526f, -0.01485193f, 0.02374334f, -0.03543961f, 
    0.02504639f, 0.00348000f, 0.01090105f, 0.02685145f, 0.00498009f, 0.01240894f, -0.00268439f, 0.01009390f, 
    -0.00040131f, 0.02107052f, -0.02961022f, 0.00235857f, 0.00608145f, -0.03988893f, -0.02711433f, 0.02584959f, 
    0.03403682f, 0.00471045f, 0.02673282f, -0.01669939f, 0.01136946f, -0.03346136f, -0.01149665f, -0.00642477f, 
    0.02047461f, 0.00664503f, -0.02575014f, -0.02192778f, 0.01598652f, 0.01269382f, 0.00640041f, -0.02750339f, 
    -0.02727361f, -0.03615130f, -0.03587101f, 0.01310543f, 0.01169983f, 0.01363105f, -0.02058560f, -0.03034314f, 
    0.00052672f, 0.00260783f, -0.03854470f, 0.01955129f, -0.03419341f, 0.00214290f, -0.03850221f, -0.02827438f, 
    -0.01516062f, -0.03276391f, -0.01472821f, 0.01521878f, -0.03571421f, -0.02383499f, 0.00613570f, -0.02040141f, 
    -0.02891706f, 0.02493688f, 0.01671400f, 0.01174731f, -0.01744216f, 0.00136420f, 0.01360897f, 0.02052897f, 
    -0.03353764f, 0.02267303f, 0.00007640f, -0.02235726f, -0.02873969f, 0.01166267f, -0.00943785f, -0.02481977f, 
    -0.03468395f, -0.02465136f, 0.00884200f, 0.02633855f, -0.00212456f, 0.01591686f, -0.00080430f, -0.01249312f, 
    -0.02148373f, -0.01851764f, 0.02492925f, -0.01025389f, 0.02543532f, 0.01284673f, -0.02703132f, -0.00543607f, 
    -0.01183269f, 0.01943020f, -0.01100819f, -0.00304721f, -0.02654658f, 0.01545825f, -0.02779808f, -0.00600685f, 
    0.00238506f, -0.03519361f, -0.01126873f, 0.00085939f, -0.03196847f, -0.00361957f, -0.01017193f, -0.00062266f, 
    -0.01612346f, 0.00677661f, 0.02771086f, -0.02791043f, -0.00969673f, -0.00065202f, 0.01288894f, 0.00140149f, 
    -0.00844441f, -0.02728462f, -0.00178394f, -0.03337492f, 0.00601603f, 0.01361625f, 0.00359543f, -0.00115551f, 
    0.00882637f, 0.02936869f, 0.00222552f, -0.02644055f, -0.02614545f, 0.02580963f, -0.00177359f, 0.02714846f, 
    -0.00921934f, 0.01981967f, 0.01060412f, -0.03324270f, 0.01175186f, -0.03734095f, -0.01031541f, -0.01039125f, 
    -0.02949416f, 0.02687142f, 0.02683207f, -0.00526260f, 0.01756088f, -0.01395553f, 0.02808991f, -0.00931334f, 
    -0.01339840f, -0.02433137f, 0.00543316f, 0.02210063f, 0.01875360f, 0.03585434f, -0.03495483f, 0.01300139f, 
    -0.01977591f, 0.02818302f, 0.02088727f, 0.00002493f, -0.00236040f, 0.02640492f, -0.03384521f, -0.00074739f, 
    -0.03843801f, -0.02448945f, -0.03237823f, -0.02439542f, -0.04051947f, -0.00970827f, -0.01804101f, 0.01891197f, 
    -0.00929695f, -0.02253951f, -0.03023276f, 0.00928815f, 0.02330071f, 0.02768110f, 0.01712147f, 0.01422396f, 
    -0.01672498f, -0.04159008f, -0.03795369f, -0.01550651f, 0.00315229f, 0.00678671f, 0.01319442f, 0.02072096f, 
    -0.02821900f, -0.03584535f, -0.02824955f, 0.00713162f, -0.01753999f, -0.01217808f, 0.00786296f, -0.00341130f, 
    0.01113741f, -0.00162637f, 0.01780467f, -0.02479990f, -0.02974229f, -0.02318965f, 0.00421546f, 0.01993360f, 
    -0.03427216f, -0.03998396f, 0.02923721f, -0.00414189f, -0.01578706f, -0.01039866f, -0.03090414f, -0.00182580f, 
    0.00627470f, 0.02582930f, 0.01799516f, -0.00749635f, -0.02579797f, -0.02624165f, -0.00406633f, 0.01667735f, 
    -0.04147869f, 0.00419408f, -0.03904134f, -0.00671661f, -0.02036486f, -0.00998424f, 0.01992363f, -0.04032360f, 
    0.02082397f, -0.04061804f, -0.03253307f, 0.00608177f, -0.01617598f, -0.02138192f, -0.02812395f, -0.02634505f, 
    -0.00846319f, 0.00279106f, 0.02086050f, -0.03887539f, -0.04171557f, -0.01191252f, 0.01093657f, -0.01385016f, 
    -0.02430519f, 0.00907467f, -0.03851349f, -0.03948005f, 0.01305683f, -0.03175076f, -0.00089187f, -0.02234702f, 
    0.00464084f, -0.03052092f, -0.02571851f, -0.01558864f, -0.00701352f, -0.00014871f, -0.00627743f, 0.02204743f, 
    -0.03937409f, -0.02943405f, 0.02355156f, -0.03240187f, 0.02354066f, -0.00847679f, -0.03747481f, 0.02660460f, 
    0.02090918f, 0.00397707f, -0.00248884f, -0.04047620f, -0.02324543f, 0.01333448f, -0.01117525f, -0.03862826f, 
    -0.01855025f, -0.00230706f, 0.01579122f, -0.02068749f, 0.00557532f, -0.00390549f, -0.03844299f, 0.00364206f, 
    0.01742476f, -0.00304182f, -0.01998269f, -0.02203437f, -0.03637472f, 0.01726023f, -0.02347177f, -0.02315896f, 
    -0.02219859f, 0.02943038f, 0.01022573f, -0.01714708f, -0.03587580f, -0.00350171f, -0.01671050f, 0.00720169f, 
    -0.03919599f, 0.01701265f, 0.00076371f, -0.03921741f, 0.02674597f, -0.04154212f, -0.04198300f, 0.01901131f, 
    -0.03116906f, 0.01684529f, -0.00129394f, 0.00165511f, 0.02401191f, 0.00821549f, -0.02920573f, 0.02230383f, 
    -0.02228411f, -0.00484311f, 0.02285446f, -0.01436399f, -0.02476169f, -0.02233158f, -0.02706878f, 0.00976602f, 
    0.02667215f, 0.02319258f, -0.00702447f, 0.01612961f, 0.00404216f, -0.00361636f, -0.01702428f, -0.01540429f, 
    0.00176382f, -0.03393529f, -0.04161244f, -0.00798441f, 0.02302029f, 0.02725211f, 0.02304031f, -0.02283828f, 
    0.02265158f, -0.03417781f, -0.01755549f, -0.00279962f, -0.03346840f, -0.00624351f, 0.00301808f, 0.02666606f, 
    -0.00793709f, -0.03747293f, 0.01055238f, -0.00449322f, 0.00918944f, -0.02105570f, 0.02556735f, 0.00723969f, 
    -0.01642005f, 0.00565930f, 0.03189599f, 0.01334950f, -0.01406653f, -0.00324895f, -0.00339572f, 0.02057546f, 
    0.01923119f, -0.01597196f, -0.03252684f, -0.00938889f, -0.01851219f, -0.03322839f, 0.02004383f, 0.01108512f, 
    0.01356190f, -0.01122468f, 0.00029373f, -0.03141379f, -0.00463040f, -0.03320195f, -0.00748598f, 0.02657442f, 
    0.00208712f, 0.01073482f, -0.00655644f, -0.01009841f, -0.00146834f, -0.03062394f, -0.00463866f, -0.01249546f, 
    0.02820970f, -0.00778550f, -0.02124731f, -0.01110924f, -0.03712852f, 0.00264606f, -0.03394797f, 0.01047185f, 
    -0.01720026f, -0.03259531f, 0.01884131f, 0.02720640f, 0.01643420f, -0.02798828f, -0.03882873f, -0.01574741f, 
    -0.03160105f, -0.02881046f, 0.01893657f, -0.03108646f, -0.03440895f, 0.01721641f, -0.00381293f, 0.02754380f, 
    0.02679630f, 0.01551020f, 0.02221646f, -0.00949803f, 0.01239596f, 0.00081803f, -0.01806918f, -0.02015751f, 
    -0.04226466f, 0.01768947f, -0.01743993f, 0.02465069f, 0.00278750f, -0.00391133f, -0.01941880f, -0.03781122f, 
    0.02090022f, -0.02918602f, -0.00241411f, 0.00429826f, -0.02955880f, -0.01139625f, 0.01745882f, -0.01040762f, 
    0.01788394f, -0.00333367f, -0.00873727f, -0.03927216f, -0.02868850f, -0.03207110f, -0.03952507f, -0.02362681f, 
    -0.03568637f, 0.02431000f, -0.04055945f, -0.03319604f, -0.00903045f, 0.02833531f, 0.00840766f, -0.03762381f, 
    -0.01844050f, -0.01751130f, 0.00262133f, -0.01716079f, -0.00160367f, -0.01261981f, 0.00766075f, -0.03988784f, 
    0.02485942f, 0.00216274f, -0.01367020f, -0.00792371f, 0.00159648f, 0.01708116f, 0.00863563f, -0.02284538f, 
    0.02497611f, 0.00694113f, 0.01153156f, 0.02919032f, -0.00980426f, 0.02278473f, -0.04157083f, -0.03639819f, 
    -0.01666527f, 0.01835653f, -0.01306314f, -0.01906001f, -0.02761208f, 0.00553660f, -0.00832084f, 0.00063214f, 
    -0.03604997f, -0.03322166f, -0.02669893f, -0.00385265f, -0.01013185f, 0.01705735f, 0.00217788f, 0.01673839f, 
    0.00895803f, -0.02984019f, -0.02317951f, -0.02181297f, -0.02706241f, 0.02152220f, -0.00883586f, -0.03000053f, 
    0.00788238f, -0.03135182f, -0.01859154f, 0.00748315f, -0.01223746f, -0.03804346f, -0.00212094f, 0.01009285f, 
    -0.00263091f, -0.01351351f, 0.01542467f, 0.02700976f, -0.02780115f, 0.02034737f, -0.01013280f, -0.02326268f, 
    -0.04236414f, -0.02986131f, -0.04300452f, -0.02265431f, 0.00711215f, -0.02353556f, 0.00775479f, 0.02992297f, 
    0.03154160f, 0.03557990f, -0.03289510f, -0.02630878f, 0.01447867f, 0.02992369f, -0.00547231f, -0.03702608f, 
    -0.02793724f, -0.01462982f, -0.03954605f, 0.01339915f, -0.00259193f, -0.02785906f, -0.04167746f, 0.02601635f, 
    -0.03987672f, -0.01404937f, -0.01975174f, 0.00458718f, -0.02480864f, 0.00567014f, 0.00116174f, -0.00707641f, 
    -0.01173702f, 0.02242912f, 0.02361399f, -0.03173760f, -0.03197530f, -0.04378194f, -0.01752115f, -0.04003914f, 
    -0.03943372f, -0.02885512f, 0.02228805f, 0.01964273f, -0.03262669f, -0.00989359f, -0.01285501f, 0.01406061f, 
    -0.01636251f, 0.00867357f, -0.00871881f, -0.04278458f, 0.01644395f, 0.02193508f, 0.00644188f, -0.00427484f, 
    -0.02843653f, 0.02665427f, 0.01717169f, 0.01904802f, 0.02394952f, -0.01160332f, -0.03166932f, -0.03107876f, 
    0.02544055f, -0.03311616f, -0.03841369f, 0.02664613f, -0.04018815f, -0.03266303f, 0.01076089f, -0.03329228f, 
    0.03052834f, -0.00034702f, -0.02304036f, -0.01481807f, -0.02781493f, -0.01009159f, 0.01038814f, -0.02345717f, 
    0.01112435f, 0.01227928f, 0.00213408f, -0.02734228f, -0.02313586f, 0.01982909f, -0.00368443f, 0.01695701f, 
    0.00658002f, -0.03926884f, 0.02105861f, 0.00927575f, -0.03171720f, 0.00582459f, 0.02313402f, -0.02776937f, 
    -0.03432480f, -0.03739633f, 0.01704850f, -0.01476932f, -0.04077309f, 0.00333422f, 0.02330171f, -0.01632736f, 
    0.00585620f, -0.02453339f, -0.03103487f, -0.00894534f, -0.03297230f, 0.01641542f, -0.01538850f, -0.00125085f, 
    -0.03109750f, -0.03537149f, -0.02889791f, -0.02971395f, 0.00750831f, 0.01945673f, 0.00957056f, 0.01671110f, 
    -0.02355032f, 0.01407696f, -0.02716917f, -0.02007177f, -0.03894698f, -0.02616427f, 0.02515232f, -0.03499626f, 
    -0.03810954f, -0.03185425f, -0.03381508f, -0.02091129f, 0.01610418f, 0.01619536f, -0.01164886f, 0.02516679f, 
    -0.02975918f, -0.04016687f, -0.02420120f, -0.00087661f, 0.01023366f, 0.02503564f, 0.01649087f, -0.02092245f, 
    -0.00523583f, -0.01642855f, 0.00156353f, -0.02107196f, -0.03481254f, -0.00817426f, 0.01942296f, 0.01675447f, 
    0.00283637f, -0.00740509f, 0.02211983f, -0.00096859f, 0.00969864f, -0.02920628f, 0.00512380f, -0.00441051f, 
    -0.03004915f, -0.00304563f, -0.02771358f, -0.01157086f, -0.00591434f, -0.02790387f, -0.01659450f, 0.02522503f, 
    -0.01344208f, -0.01378161f, 0.02773671f, 0.01779481f, -0.02237475f, -0.03126020f, -0.01958674f, -0.01122727f, 
    0.02475297f, -0.03386791f, -0.03796924f, -0.01931622f, 0.01352882f, -0.00845693f, 0.02846563f, -0.02564806f, 
    0.01895482f, 0.01089322f, -0.00671931f, -0.00358102f, 0.00864423f, -0.02698560f, 0.02450153f, -0.00519580f, 
    -0.00672765f, 0.00048675f, -0.03917294f, -0.04112338f, 0.02362629f, -0.00660124f, 0.02049948f, 0.02763157f, 
    0.02351305f, 0.01678331f, -0.01249693f, 0.02424235f, -0.04171165f, 0.01727251f, 0.01997528f, 0.01666831f, 
    0.01461167f, -0.02674900f, -0.03852817f, -0.01074219f, -0.00233122f, -0.02738540f, -0.02005668f, 0.02671195f, 
    0.00941628f, -0.02140983f, 0.02574143f, 0.02641160f, -0.03079704f, -0.03952220f, -0.01844478f, 0.02732616f, 
    -0.01530221f, -0.00481586f, -0.01374098f, 0.02512923f, -0.03566820f, -0.00137676f, 0.01357410f, 0.02441087f, 
    0.01994194f, 0.02762183f, -0.02052077f, -0.03437818f, 0.00693716f, 0.00838464f, 0.02539748f, 0.03021192f, 
    -0.02649377f, 0.00385618f, -0.00766604f, -0.01265595f, -0.04178517f, -0.00944829f, -0.02737452f, 0.00053162f, 
    -0.03447751f, -0.00479494f, 0.02062653f, -0.03915025f, -0.00975064f, -0.03913587f, -0.02189590f, 0.01928284f, 
    -0.00772724f, -0.04015447f, -0.01746265f, -0.01865348f, -0.00892508f, 0.00835113f, 0.00079979f, -0.04152465f, 
    0.01487606f, -0.04193572f, -0.04328596f, 0.01370137f, -0.02457140f, 0.00090745f, -0.02981282f, -0.03560600f, 
    0.01812016f, -0.03399921f, -0.01154618f, -0.03732587f, -0.02309364f, -0.02568665f, -0.00260770f, 0.00247695f, 
    -0.00346755f, 0.01163784f, -0.02002423f, -0.03476038f, -0.03740712f, 0.01033954f, 0.00897999f, -0.00942671f, 
    -0.01689660f, 0.00517092f, 0.01080049f, 0.00529499f, 0.02735287f, 0.00207268f, 0.02667877f, -0.03934497f, 
    0.01659599f, -0.01570636f, -0.01731618f, -0.01523641f, -0.03820824f, -0.04240558f, 0.01353040f, -0.00341370f, 
    -0.01236463f, 0.01103668f, -0.02405824f, 0.01653686f, -0.01560604f, 0.02736630f, 0.02675503f, 0.00075450f, 
    -0.03000157f, 0.00738622f, -0.02834433f, 0.01049762f, 0.01768471f, -0.03106288f, -0.01483606f, -0.02928243f, 
    -0.00293705f, 0.02274514f, -0.01430929f, 0.00372413f, -0.01507828f, -0.03989722f, -0.00641621f, 0.02475644f, 
    -0.01378745f, 0.02477351f, 0.01884742f, 0.00648031f, 0.00109720f, -0.02172881f, -0.00962212f, -0.01585153f, 
    0.01122777f, -0.02101546f, 0.00486130f, 0.02435555f, 0.01891642f, -0.03063112f, -0.02097083f, -0.01620817f, 
    0.01033617f, -0.02509258f, -0.03771352f, 0.02600745f, 0.01185269f, 0.02068317f, 0.01449850f, -0.03417060f, 
    -0.04354002f, 0.01634876f, -0.02284890f, 0.01745701f, 0.02164046f, -0.04066877f, -0.01386326f, -0.00511198f, 
    -0.00290264f, 0.00872040f, 0.01243429f, 0.02798660f, -0.03086101f, -0.00858158f, 0.02310285f, 0.00577229f, 
    -0.02737741f, 0.01149950f, -0.03415867f, -0.03146908f, -0.02398285f, 0.01695600f, -0.00559218f, 0.00384292f, 
    0.01149883f, -0.02115313f, -0.00130652f, -0.02848512f, 0.00807737f, 0.01908512f, -0.02753817f, -0.02397290f, 
    0.02831551f, -0.04372967f, 0.01892065f, 0.01398564f, -0.02773405f, 0.01275241f, 0.00588263f, 0.00890122f, 
    -0.02889418f, 0.02432715f, 0.01300287f, -0.01404959f, -0.01284308f, -0.02243295f, -0.03828945f, 0.02015044f, 
    0.00356143f, -0.00993348f, -0.03243561f, -0.04042208f, 0.02453431f, -0.03841553f, -0.01874811f, 0.00086840f, 
    -0.03370908f, -0.02091126f, 0.01976943f, -0.03909751f, -0.01983091f, -0.03998898f, 0.00087252f, -0.02132710f, 
    -0.02434962f, 0.02679359f, -0.01987522f, -0.01183237f, -0.00337851f, 0.00703938f, 0.02122253f, -0.03269699f, 
    -0.00445827f, 0.01772542f, 0.02589778f, 0.01434086f, 0.01019221f, 0.01427667f, -0.01935038f, -0.03222825f, 
    -0.02315339f, -0.00130803f, -0.00945273f, 0.01931499f, -0.01458455f, 0.00032339f, 0.01686967f, -0.01154649f, 
    0.00873980f, -0.00444809f, 0.00759918f, -0.02336837f, 0.00323870f, 0.00372137f, 0.01527052f, -0.00334201f, 
    -0.03396432f, -0.03976678f, 0.02738478f, -0.02007146f, -0.01359984f, -0.03044411f, -0.00248812f, 0.02553174f, 
    0.00964540f, -0.01349073f, 0.02024104f, 0.02172278f, 0.00170660f, 0.02674907f, -0.04035789f, -0.03829809f, 
    -0.00645305f, -0.01740258f, 0.00446672f, -0.02630364f, 0.02156196f, -0.03970671f, -0.03220745f, -0.02052021f, 
    -0.02069120f, 0.01933325f, -0.00911323f, 0.01209507f, 0.00927049f, 0.02840216f, -0.03921384f, -0.02688819f, 
    0.01985894f, 0.01050111f, -0.02932996f, 0.02077052f, 0.00124236f, 0.00102426f, -0.03859172f, 0.03441902f, 
    0.01732400f, 0.00448017f, -0.01720982f, -0.01307807f, -0.01708470f, -0.02298974f, 0.02559829f, -0.01303755f, 
    -0.00723396f, -0.01723995f, -0.03481703f, 0.02441126f, -0.00527076f, 0.01571579f, -0.03300874f, -0.00731596f, 
    -0.03343860f, 0.02357306f, 0.00204529f, -0.04081383f, -0.04023310f, 0.01328498f, 0.02104659f, -0.03253166f, 
    -0.00272807f, -0.00584298f, 0.01587554f, -0.00099402f, -0.04286116f, -0.03255164f, -0.00456791f, -0.01872084f, 
    -0.03672144f, -0.03663911f, -0.01302081f, 0.00451079f, -0.01716260f, -0.00056761f, -0.03841564f, -0.00778809f, 
    -0.03618721f, 0.00102733f, 0.00499215f, -0.03836790f, 0.02280413f, 0.00514451f, 0.00380089f, 0.01175495f, 
    0.00364195f, 0.02325959f, -0.02072800f, 0.00539601f, -0.00143188f, 0.01822343f, -0.00734740f, -0.02555151f, 
    -0.00636434f, -0.02490281f, -0.02443895f, -0.01870873f, 0.02636507f, 0.03003325f, -0.01583708f, 0.02074919f, 
    -0.02802607f, -0.02811023f, 0.00057383f, -0.02349614f, -0.03123579f, -0.00640437f, -0.00118735f, -0.03719210f, 
    0.02009274f, -0.01715779f, -0.00144138f, -0.03345101f, 0.01247400f, -0.00987055f, -0.02249854f, -0.00452588f, 
    -0.02866343f, 0.00133142f, -0.03454001f, 0.02110966f, 0.00611280f, 0.01215627f, -0.02015215f, 0.02293448f, 
    -0.02297292f, -0.02170742f, -0.01114198f, 0.00050020f, -0.01769547f, 0.01725775f, -0.00238484f, -0.03773726f, 
    -0.01824759f, -0.03094525f, -0.00772447f, 0.00340741f, -0.01285618f, 0.02464366f, 0.01482791f, 0.02384211f, 
    0.01540106f, -0.03927036f, -0.01857048f, 0.00124157f, -0.01309862f, 0.00329286f, 0.02865436f, 0.01558316f, 
    0.01652220f, 0.00696426f, -0.01512962f, 0.01117335f, -0.02641887f, -0.04115880f, -0.01725144f, 0.02217573f, 
    -0.01843286f, -0.02311317f, 0.03681534f, 0.01696652f, -0.00096096f, 0.01249699f, 0.00215895f, -0.01669805f, 
    0.00055923f, 0.02530823f, 0.00113628f, 0.01494842f, -0.02029868f, -0.02298967f, 0.00274071f, 0.00517931f, 
    -0.02166830f, 0.00946666f, -0.01315981f, -0.01184887f, -0.02767786f, 0.00654172f, -0.02767226f, 0.02659562f, 
    0.03254042f, 0.01025257f, -0.00962540f, -0.02193074f, -0.00852486f, -0.02929178f, -0.04255924f, -0.01424946f, 
    -0.00929924f, -0.03466742f, -0.01504738f, 0.02861824f, -0.01370605f, 0.00139855f, 0.00839989f, -0.03537188f, 
    0.02350254f, -0.00541911f, 0.02332420f, -0.00231628f, -0.04305756f, 0.02862477f, -0.02651918f, -0.00648417f, 
    -0.24110050f, -0.27939650f, -0.04648075f, 0.18526793f, 0.02038717f, -0.02833417f, 0.08934491f, 0.03836783f, 
    0.05096151f, -0.04507267f, -0.03505599f, -0.05322817f, -0.33635136f, 0.10778591f, -0.12934101f, -0.14844230f, 
    0.02100096f, -0.00545699f, -0.03682698f, -0.05589877f, 0.00421471f, 0.01737537f, -0.01032763f, 0.11243305f, 
    -0.25148535f, -0.29386911f, 0.07324420f, -0.10620251f, -0.03531408f, 0.12028907f, 0.07170621f, -0.14132750f, 
    -0.13921641f, 0.02076761f, -0.11254896f, -0.00799892f, -0.00355419f, 0.06677844f, 0.15465157f, 0.05219695f, 
    0.00564322f, -0.03462477f, 0.04811468f, 0.02850747f, -0.00207957f, -0.03836143f, -0.03609118f, 0.11905901f, 
    -0.40142968f, 0.16308989f, -0.05489176f, -0.07172226f, 0.18095469f, 0.05325206f, -0.14597505f, -0.07825839f, 
    -0.00061132f, 0.03132626f, -0.05896774f, -0.08134390f, -0.15078974f, 0.17862117f, 0.00958078f, 0.02105883f, 
    0.01820954f, 0.08250318f, -0.00500631f, -0.06529536f, 0.17738596f, -0.01596386f, 0.10340317f, 0.02440327f, 
    0.00023661f, -0.01964559f, 0.09196246f, 0.07847029f, -0.05370842f, 0.15127611f, -0.06044934f, -0.00017294f, 
    0.00440287f, -0.05007112f, -0.02716445f, 0.04479404f, 0.43039662f, 0.16962346f, -0.11587227f, 0.09787980f, 
    -0.13330890f, -0.11821534f, -0.05154270f, -0.02221818f, 0.01940276f, -0.09433258f, 0.06148078f, -0.06729932f, 
    0.00939204f, -0.33982038f, -0.02392915f, -0.11108785f, 0.12926647f, 0.03163321f, -0.05912710f, -0.03576074f, 
    0.13583380f, -0.05639945f, 0.01289022f, -0.16311921f, -0.33508530f, -0.02978092f, -0.02483200f, -0.15929176f, 
    0.06702641f, 0.02173228f, 0.09574347f, -0.02992864f, 0.01778581f, 0.06235029f, -0.02221228f, -0.03785997f, 
    -0.44560176f, -0.12654890f, 0.01700282f, 0.31572694f, 0.03519844f, -0.00786965f, 0.01247332f, -0.02078290f, 
    -0.00480558f, -0.08064412f, -0.09729117f, -0.07936810f, 0.23124768f, 0.51679981f, 0.09786330f, -0.00577928f, 
    -0.04591136f, -0.02779047f, 0.04456234f, 0.00225812f, -0.03602795f, -0.03913511f, -0.01847429f, 0.10613092f, 
    -0.25850961f, 0.02137073f, -0.08149887f, -0.11820441f, 0.07277989f, 0.03292709f, 0.07908781f, -0.05608029f, 
    0.02549993f, 0.06149378f, -0.04855666f, 0.03451011f, 0.12203759f, -0.17123888f, -0.08355173f, 0.31019229f, 
    -0.09743683f, 0.04737181f, -0.10517845f, 0.02701819f, 0.01772007f, -0.01113848f, 0.08666524f, -0.00405119f, 
    0.19506294f, 0.13414261f, 0.15062766f, 0.17657304f, 0.04243409f, 0.15615760f, 0.01415982f, -0.08041396f, 
    0.08021304f, 0.01862844f, 0.01151348f, -0.02388884f, 0.17641522f, 0.02414937f, 0.02231229f, -0.04029603f, 
    0.03980047f, -0.14324875f, -0.01559045f, -0.01274484f, -0.16100356f, 0.01289192f, 0.00134027f, 0.07293677f, 
    -0.15278760f, 0.07840066f, -0.16127177f, -0.24537678f, 0.06684880f, -0.01908457f, -0.00589685f, 0.00698635f, 
    0.06176819f, 0.04632129f, -0.09893035f, 0.02712989f, -0.37343067f, 0.08964010f, -0.14115888f, -0.19139302f, 
    0.18632051f, 0.02326348f, -0.03900559f, 0.04407753f, -0.03572716f, -0.01746815f, -0.02795349f, 0.01316717f, 
    -0.14008598f, 0.15453282f, -0.00813589f, 0.00383493f, 0.10841379f, 0.06324603f, 0.08437424f, -0.10467202f, 
    0.03218038f, -0.01352397f, 0.03305257f, -0.03069234f, 0.08623955f, -0.17376329f, 0.04783508f, -0.28351939f, 
    0.22445491f, 0.03583286f, -0.03285910f, 0.03950676f, 0.10655464f, 0.03770022f, 0.00342627f, -0.02636325f, 
    0.02051777f, 0.10326820f, 0.05249202f, 0.04607249f, -0.04499291f, -0.13009587f, -0.01459556f, 0.05892802f, 
    0.00955158f, 0.02336158f, 0.05333067f, -0.00792751f, 0.25971630f, 0.52809793f, 0.00444123f, -0.01242479f, 
    -0.06977901f, -0.12236693f, -0.04572469f, 0.19206029f, -0.04057552f, -0.07036187f, 0.14147431f, -0.04248824f, 
    0.41039640f, -0.00098795f, -0.02835576f, 0.16382103f, 0.03562887f, -0.08320828f, 0.03393613f, -0.06157916f, 
    -0.02700463f, 0.02771197f, 0.06538253f, 0.05882007f, 0.39480135f, -0.05630086f, 0.15391326f, 0.06109386f, 
    -0.06922133f, -0.08642402f, 0.07796385f, 0.02699554f, -0.05039759f, 0.01738155f, -0.03827351f, -0.00381540f, 
    -0.25204000f, 0.00118538f, -0.07925241f, 0.08018840f, 0.08818889f, 0.01667998f, 0.01278638f, 0.07388609f, 
    0.03374786f, 0.04873779f, 0.04486960f, -0.03350258f, 0.18058276f, 0.22186844f, -0.01227898f, -0.02696380f, 
    0.07641508f, -0.07689837f, 0.01878965f, -0.00268762f, -0.07861169f, -0.00907606f, -0.00738376f, -0.01321981f, 
    -0.16627190f, -0.07494432f, -0.00948973f, 0.06035825f, 0.05039184f, 0.02168604f, 0.00095749f, 0.07105047f, 
    0.11220958f, 0.04677712f, 0.01164214f, 0.02414952f, 0.22688009f, 0.18329489f, 0.13117698f, 0.04418154f, 
    -0.17014253f, 0.03153735f, 0.04951292f, -0.05248468f, 0.03779175f, -0.03522009f, 0.03223646f, 0.05044200f, 
    -0.30505219f, 0.19395004f, -0.22169544f, 0.14802784f, -0.08614695f, -0.02419991f, 0.06510071f, -0.01231330f, 
    0.15567781f, -0.02222055f, 0.02895162f, -0.12681204f, 0.49515560f, 0.16565472f, -0.09742311f, -0.31495458f, 
    0.10706783f, 0.08466896f, -0.08936945f, -0.11079841f, 0.06367224f, 0.04734685f, -0.02993098f, -0.05651634f, 
    -0.05560775f, 0.03881247f, 0.20460279f, 0.07252914f, -0.03335994f, 0.00303962f, 0.06268232f, -0.14367256f, 
    0.05611072f, -0.05869400f, -0.03879011f, 0.00256199f, 0.42773780f, 0.14310887f, 0.23673636f, 0.14294225f, 
    -0.03463725f, -0.06785603f, 0.07359941f, 0.01935939f, -0.03855685f, -0.05956205f, 0.01354694f, -0.01673822f, 
    -0.25484157f, -0.00649328f, -0.02062641f, 0.09058721f, -0.06249876f, -0.00408145f, -0.03225892f, 0.06487239f, 
    -0.04588172f, 0.04908448f, 0.01913570f, 0.01287088f, -0.01895918f, 0.11105077f, -0.08377580f, -0.12760386f, 
    0.11489598f, -0.00288278f, 0.06141627f, -0.01455828f, 0.06757506f, -0.03148659f, -0.02518263f, 0.00496711f, 
    -0.05630961f, 0.09831420f, 0.05503517f, -0.11313653f, 0.05728705f, -0.03573055f, -0.12238887f, -0.03082327f, 
    -0.11369277f, -0.01160515f, -0.06022784f, 0.05074637f, -0.18922700f, -0.29466763f, 0.14951591f, -0.11003338f, 
    -0.02168744f, 0.08154967f, 0.08561628f, -0.11795620f, 0.02668325f, 0.00379061f, 0.06491626f, 0.06791839f, 
    0.34371242f, 0.05428827f, 0.17645220f, 0.15972374f, -0.02893951f, 0.06059832f, 0.02288336f, 0.03739894f, 
    -0.03017058f, 0.08550218f, 0.01444214f, -0.01639401f, -0.31735444f, -0.14792861f, -0.00925315f, 0.10688320f, 
    0.15703861f, 0.11118751f, 0.05085409f, 0.01898172f, 0.08634150f, 0.05318103f, -0.10750788f, -0.11037333f, 
    -0.14276874f, -0.10761718f, -0.00273080f, 0.04612838f, -0.01854875f, -0.04556400f, -0.00204012f, -0.10982858f, 
    0.06199932f, -0.00336450f, 0.15243219f, 0.12277851f, 0.23847945f, 0.49171659f, 0.13953725f, -0.12245133f, 
    0.02169583f, -0.04777395f, 0.00062122f, 0.15794182f, 0.02065327f, -0.07687221f, 0.01751809f, 0.05910637f, 
    -0.01994983f, -0.26286295f, -0.01301107f, -0.11068410f, -0.08356971f, -0.01226903f, 0.00562925f, -0.06249294f, 
    0.03094362f, -0.06594355f, 0.01401294f, -0.02505472f, 0.20503935f, -0.05005630f, 0.18155643f, 0.16385095f, 
    0.01208479f, -0.06254320f, -0.00731393f, -0.04911480f, 0.00338774f, 0.06249710f, -0.00094768f, 0.07119021f, 
    0.25144973f, 0.08259550f, -0.15995142f, -0.09439354f, -0.01198563f, -0.04244247f, -0.04046116f, 0.12851176f, 
    0.02849814f, -0.02182354f, -0.00919575f, -0.03741248f, -0.24732208f, 0.10760473f, 0.12817146f, -0.13904707f, 
    0.09192383f, 0.15573974f, -0.03401466f, -0.02882843f, 0.06825261f, 0.06125527f, 0.05736199f, -0.04851421f, 
    -0.16645038f, 0.08577774f, -0.06417149f, 0.11051873f, 0.07837150f, 0.12873057f, 0.00096580f, -0.07468945f, 
    -0.09051032f, -0.04771265f, 0.05856175f, -0.11440840f, 0.11592598f, 0.07895590f, -0.03151285f, -0.20168671f, 
    -0.13407786f, 0.12363382f, 0.08400986f, 0.00357286f, -0.00948613f, 0.06860898f, 0.10929532f, 0.02243528f, 
    0.06663195f, -0.12388147f, 0.05799535f, -0.08335388f, -0.03001132f, 0.04054686f, 0.10161621f, -0.01269755f, 
    -0.01128296f, 0.01136912f, 0.04027113f, -0.00637926f, -0.02518546f, 0.29417336f, -0.16269577f, -0.05066448f, 
    0.07996415f, 0.10077540f, -0.17399883f, -0.02698567f, -0.00251655f, 0.00462771f, -0.01664598f, -0.04394076f, 
    0.53326833f, 0.31753087f, 0.03091142f, -0.08689576f, -0.06343423f, -0.03596625f, 0.01108039f, 0.05519951f, 
    -0.08703912f, -0.16157699f, 0.05572752f, -0.00519271f, 0.01949726f, 0.33919013f, 0.30999523f, 0.09522699f, 
    -0.06332440f, 0.06262853f, -0.03530511f, -0.09107435f, 0.00164657f, 0.07810325f, 0.02334631f, 0.06803560f, 
    -0.01981508f, 0.07815168f, 0.02824771f, 0.02050170f, -0.02450082f, -0.11772975f, -0.05306771f, 0.10054374f, 
    -0.06955313f, 0.08478174f, -0.05332782f, 0.11451966f, 0.14003724f, 0.08017035f, 0.18258648f, -0.00121669f, 
    -0.00860938f, -0.03439764f, 0.16596277f, -0.01456084f, -0.00225153f, -0.00416736f, 0.03336667f, 0.10875015f, 
    0.40653878f, 0.12834181f, 0.07285142f, 0.14692007f, -0.04877861f, 0.05345297f, -0.00286256f, -0.04039504f, 
    -0.00363302f, 0.00239977f, -0.04741733f, 0.01716012f, -0.05394848f, 0.08050214f, 0.08858189f, 0.01525775f, 
    -0.01058215f, -0.06629440f, 0.01708249f, -0.00949584f, -0.09181776f, -0.06950209f, 0.06987473f, 0.00064656f, 
    0.33717090f, -0.05888274f, 0.07432816f, 0.12691858f, -0.16821101f, 0.02191348f, 0.08370811f, 0.07750782f, 
    -0.04866495f, 0.07317854f, 0.00287246f, -0.04542437f, 0.09890097f, 0.09634774f, -0.13723283f, 0.16070636f, 
    0.03101425f, -0.00851770f, -0.05471579f, -0.01500777f, -0.05004644f, -0.01249285f, 0.01434559f, 0.06099083f, 
    -0.05566477f, 0.22152279f, -0.10211317f, -0.06855699f, 0.12323844f, 0.17380537f, 0.00937033f, 0.02052760f, 
    0.06765849f, -0.06988938f, -0.05562181f, -0.05634813f, 0.06291559f, 0.11054420f, 0.09032532f, 0.15942946f, 
    -0.02711442f, 0.05166576f, 0.05490271f, -0.02862319f, -0.01684762f, -0.01445662f, -0.06400707f, -0.02156514f, 
    0.19696845f, 0.17970116f, 0.08268879f, 0.35493428f, -0.20075308f, 0.01748949f, 0.03993448f, -0.00946309f, 
    -0.02195793f, 0.03122104f, -0.03872092f, 0.03925452f, 0.16300771f, 0.13168189f, 0.03097021f, 0.07473157f, 
    -0.04800262f, -0.07232686f, 0.07815588f, 0.04683645f, -0.03794871f, -0.00399305f, -0.09656701f, 0.01635917f, 
    -0.35741103f, -0.23148239f, -0.14195684f, -0.12643620f, 0.03750899f, 0.05456306f, 0.01564215f, 0.10947576f, 
    -0.06091229f, -0.03922760f, 0.20854975f, -0.06371813f, -0.35579777f, -0.41109875f, 0.16478756f, 0.15934454f, 
    -0.00077248f, 0.13029492f, 0.12286343f, -0.10019277f, -0.00744739f, 0.01339668f, -0.04022272f, -0.02121033f, 
    -0.24409904f, 0.18718830f, -0.08015781f, 0.23884216f, -0.02893555f, -0.10730779f, 0.00102496f, 0.02170348f, 
    0.16093805f, -0.09382086f, -0.01454278f, -0.15057209f, 0.07344201f, 0.14093803f, -0.21221535f, 0.10181265f, 
    -0.05458524f, -0.09605408f, -0.12330934f, 0.00569167f, 0.05330400f, 0.02659062f, -0.04409359f, -0.02433868f, 
    0.03131237f, 0.02550112f, -0.03216277f, -0.02827910f, 0.00514865f, -0.01633345f, -0.00001977f, -0.01502416f, 
    0.00638647f, 0.01953592f, -0.01805538f, -0.00553163f, -0.02309116f, -0.03103337f, -0.02804329f, -0.03904036f, 
    -0.01488039f, 0.01504098f, 0.02587043f, 0.02490686f, 0.00483519f, 0.00686890f, 0.00176220f, 0.01873017f, 
    -0.03458729f, -0.01653025f, 0.01186597f, -0.00039442f, 0.00308226f, -0.02446873f, 0.01406475f, -0.02757264f, 
    -0.03349949f, -0.01785689f, -0.01869175f, -0.02505452f, 0.01810139f, 0.02499308f, -0.00626204f, 0.00065578f, 
    -0.00062930f, -0.04080021f, 0.02652124f, -0.01674900f, 0.02148613f, 0.01561714f, -0.00371993f, -0.00891032f, 
    0.00802807f, -0.01870115f, 0.01573240f, -0.01945717f, 0.00025478f, -0.02607463f, -0.00782948f, 0.01470322f, 
    0.01567301f, -0.01703358f, -0.00493513f, -0.00178120f, -0.00656590f, -0.00650325f, -0.01303006f, -0.03255653f, 
    0.01187554f, -0.02714262f, -0.02033549f, -0.04167584f, -0.02224440f, 0.01214100f, 0.01706280f, 0.01610956f, 
    -0.02625180f, -0.02718448f, 0.02316536f, 0.00556324f, -0.03621337f, -0.03922262f, -0.02035771f, -0.03324112f, 
    0.02554758f, 0.00017290f, 0.00186679f, 0.00592488f, 0.03143055f, -0.00787835f, 0.02451367f, 0.00097530f, 
    0.02921617f, 0.00943538f, 0.02853904f, 0.00311281f, 0.02352856f, -0.00574946f, 0.01538664f, -0.02212623f, 
    0.03447371f, -0.00901603f, -0.01095124f, -0.02695637f, -0.03990025f, -0.00463200f, 0.01487151f, -0.00530480f, 
    -0.00421781f, -0.03094709f, -0.01706554f, -0.02542136f, 0.03020423f, -0.01834277f, -0.04219949f, -0.00978508f, 
    0.02208309f, 0.00572756f, 0.02695706f, 0.01509671f, 0.00017850f, 0.00951716f, 0.03252794f, -0.03172025f, 
    -0.01740894f, -0.01865734f, -0.00905907f, 0.00850839f, 0.02163566f, 0.00543602f, -0.03951095f, 0.00977853f, 
    -0.02640746f, 0.01219047f, 0.02205149f, 0.02710661f, -0.03917200f, 0.00464484f, -0.02912243f, 0.02820199f, 
    0.00045806f, -0.01414541f, 0.01951016f, 0.00640127f, -0.01979203f, -0.01042250f, -0.03735136f, -0.00446968f, 
    -0.01026594f, 0.01706987f, 0.00516291f, -0.03279989f, -0.02644840f, -0.01076710f, -0.03489344f, 0.00726321f, 
    -0.00664943f, -0.02133440f, 0.01080603f, -0.01681400f, -0.02220949f, -0.00712326f, 0.02326381f, 0.00160117f, 
    -0.02924642f, -0.01048011f, -0.03938173f, -0.02704397f, -0.01195342f, 0.02087166f, -0.02867220f, -0.02673006f, 
    -0.00946174f, -0.02869603f, -0.00082353f, -0.03460712f, 0.02941669f, 0.01542801f, 0.01220019f, 0.02226580f, 
    -0.01598979f, -0.03422536f, -0.01072849f, 0.00611462f, 0.00835252f, 0.01343365f, 0.00137552f, -0.00249069f, 
    -0.03100652f, -0.03258675f, -0.00523688f, -0.01074028f, -0.01169682f, 0.03060753f, -0.03759359f, 0.02107060f, 
    0.02322620f, 0.01671106f, -0.02785928f, 0.01501284f, 0.00039644f, -0.02831758f, -0.04075318f, -0.01554887f, 
    -0.00127709f, 0.00046124f, -0.02912354f, -0.03598503f, -0.03632804f, -0.02680463f, -0.00930241f, -0.03117746f, 
    0.02612967f, 0.00973289f, 0.01407882f, -0.03945418f, 0.01187146f, 0.01700950f, 0.02783579f, 0.00480488f, 
    0.00877214f, -0.03621537f, 0.01325244f, -0.00121297f, -0.02929641f, -0.00352045f, -0.01109885f, -0.00108498f, 
    -0.01695919f, 0.00545346f, 0.02402470f, -0.01708673f, 0.00173959f, -0.01552678f, -0.03673772f, 0.00549966f, 
    -0.01199487f, -0.00528929f, 0.01659173f, 0.02931141f, 0.00641654f, -0.02429387f, 0.02384875f, -0.02375139f, 
    0.00137922f, -0.00317460f, -0.03076028f, -0.03634037f, -0.02213771f, -0.01267204f, 0.02930557f, -0.03220528f, 
    -0.00894304f, -0.01470573f, 0.02086443f, 0.00230325f, 0.01451720f, 0.00812466f, -0.00038781f, -0.03476129f, 
    0.01797772f, -0.02983185f, 0.01579810f, 0.00791785f, -0.03746557f, 0.01740631f, 0.01512758f, -0.03261236f, 
    0.00552458f, -0.00878315f, 0.02207812f, -0.00650920f, 0.00630508f, -0.02077288f, 0.00427538f, -0.01529866f, 
    0.00715310f, -0.00936838f, 0.00957178f, -0.00028843f, 0.01766166f, 0.00316285f, -0.02101988f, -0.00936650f, 
    -0.03496357f, -0.03777198f, 0.02524352f, 0.02759681f, -0.02185883f, -0.00304343f, 0.01891275f, 0.01012170f, 
    0.00638992f, -0.03258419f, -0.00576315f, 0.02566977f, -0.01233408f, 0.03373025f, -0.00840556f, 0.01060345f, 
    -0.00754046f, -0.03582450f, -0.04105491f, -0.01986011f, 0.01064959f, -0.00419101f, -0.01720454f, -0.02430134f, 
    0.01152278f, 0.01237578f, 0.02063594f, -0.02738655f, -0.03234425f, -0.02395351f, 0.02648463f, -0.03570960f, 
    0.00851431f, -0.00062942f, -0.02764166f, -0.00642797f, -0.00199269f, 0.01748985f, 0.02168971f, -0.03781697f, 
    0.00736699f, -0.00824323f, -0.03626984f, -0.01425460f, -0.01539830f, -0.01601562f, 0.02964889f, 0.00900805f, 
    0.01166792f, 0.01714000f, 0.01152656f, -0.03239975f, -0.00720814f, -0.00472323f, 0.00108806f, 0.02717038f, 
    -0.01942883f, -0.01901729f, 0.00209192f, 0.00278692f, 0.02398201f, -0.03837146f, -0.00045499f, -0.01482595f, 
    0.02648959f, 0.01320438f, 0.02646315f, -0.02145535f, -0.03213251f, -0.00952452f, 0.01365670f, 0.01030198f, 
    -0.02649795f, 0.02014951f, 0.01619600f, 0.00545438f, 0.02097318f, 0.00989009f, 0.02658393f, -0.02927675f, 
    0.01199326f, -0.01653175f, 0.01672466f, -0.02054119f, -0.03318579f, -0.03618504f, -0.03646063f, 0.02542559f, 
    -0.02496446f, -0.04168425f, -0.03396585f, 0.00782460f, -0.03539471f, 0.01968964f, -0.03803691f, 0.02682770f, 
    0.01317826f, -0.03647941f, -0.01616914f, -0.02639962f, 0.01510749f, 0.01881987f, -0.00788966f, 0.02394329f, 
    0.03627709f, 0.02477319f, -0.01610670f, -0.02581368f, -0.03992494f, -0.02099218f, -0.00481449f, 0.03090359f, 
    -0.03554934f, -0.01057338f, 0.01396175f, -0.00295387f, 0.00483610f, -0.02246597f, -0.03929555f, 0.01947873f, 
    -0.01402406f, 0.02649184f, -0.01642824f, -0.00410551f, -0.01238344f, -0.00204551f, -0.03897979f, 0.01364880f, 
    -0.01709205f, 0.00418238f, -0.02978196f, -0.01173773f, -0.00576772f, 0.01500770f, 0.02805278f, 0.00746794f, 
    0.00337194f, 0.00944298f, -0.01714752f, 0.00741187f, -0.02611397f, -0.03956283f, -0.01066340f, -0.02810534f, 
    0.00941107f, -0.01021602f, -0.03937412f, 0.01238540f, -0.03379676f, -0.02961038f, 0.01728537f, -0.03908763f, 
    0.02136480f, -0.01439390f, 0.00839617f, -0.00021876f, -0.00138354f, -0.03972764f, 0.01702092f, 0.02840180f, 
    -0.00680154f, -0.02685549f, -0.00542246f, -0.00057316f, 0.04235599f, 0.02178243f, -0.01191699f, -0.03466855f, 
    -0.02801781f, -0.02028824f, -0.01842736f, -0.03554414f, 0.02730886f, -0.04101440f, -0.00162482f, -0.03874008f, 
    -0.02685005f, -0.03937870f, 0.01530244f, 0.00560827f, -0.00377190f, -0.00949817f, -0.04147315f, 0.00121979f, 
    -0.03360216f, 0.01059160f, -0.03400151f, 0.01631412f, -0.01219214f, 0.00162874f, -0.02958893f, 0.02379981f, 
    0.01201257f, -0.01976721f, 0.00039371f, 0.02243292f, 0.01893039f, 0.01430312f, -0.00375059f, 0.02977844f, 
    0.02118639f, -0.02697103f, 0.00644805f, -0.03341879f, 0.02046180f, -0.02188758f, -0.00647123f, -0.01856669f, 
    0.00973343f, -0.00721256f, -0.01423626f, -0.01466040f, 0.00759223f, -0.01145689f, 0.03248673f, 0.01447389f, 
    -0.03522819f, -0.02575229f, -0.02681712f, -0.03661256f, -0.03261361f, 0.00787819f, -0.00477212f, -0.00188866f, 
    0.01719561f, -0.01813849f, 0.01769357f, -0.00074148f, 0.03220579f, 0.00299528f, 0.03282462f, -0.01593455f, 
    -0.02338976f, 0.01313996f, 0.01691322f, 0.02271328f, -0.00397747f, -0.02073215f, 0.00988683f, -0.02567126f, 
    0.00955354f, 0.02861043f, 0.00953647f, 0.00740249f, -0.01373569f, -0.02259962f, -0.00199196f, 0.00979808f, 
    0.02240782f, -0.02317099f, 0.00295310f, 0.02160182f, -0.02381267f, 0.01684034f, -0.00714860f, -0.02333963f, 
    0.02309990f, -0.03161860f, -0.02929398f, -0.01392920f, -0.01781533f, -0.00429540f, 0.02355619f, -0.02297240f, 
    -0.00902279f, -0.00132309f, -0.03346816f, -0.02413571f, -0.01513115f, -0.02980020f, -0.03368519f, -0.02145844f, 
    -0.00317976f, 0.00731626f, 0.01785720f, -0.00783293f, -0.03212760f, 0.02747747f, 0.00010473f, 0.02041453f, 
    -0.01912273f, 0.02588266f, -0.01325937f, -0.03470862f, -0.02806791f, 0.02382956f, 0.02757850f, -0.03568203f, 
    -0.03441039f, 0.03446538f, -0.01365949f, -0.02720335f, 0.00777265f, -0.02074472f, -0.03972855f, -0.03814450f, 
    -0.01267917f, 0.00833443f, -0.01711828f, 0.02518232f, -0.00151662f, 0.00716505f, 0.00921344f, 0.03006149f, 
    0.02829704f, -0.02575194f, 0.02373306f, -0.01596404f, -0.02771527f, 0.02511422f, -0.02539816f, 0.00003849f, 
    -0.01208536f, -0.02568812f, -0.03556707f, -0.04012365f, -0.02244491f, -0.00414797f, -0.00081997f, -0.00444615f, 
    -0.03346121f, 0.03066651f, -0.03273979f, -0.02086934f, 0.00464400f, -0.03450775f, -0.00463331f, -0.03953364f, 
    -0.02312019f, -0.01301938f, 0.00338041f, -0.03775775f, -0.00173654f, -0.00939065f, -0.00251921f, -0.03627927f, 
    -0.02111640f, -0.03746929f, 0.02349057f, 0.00914240f, -0.03292882f, 0.00383762f, 0.01461606f, -0.02363712f, 
    0.02240132f, -0.02491445f, -0.02328873f, 0.00761510f, -0.00626106f, 0.03151428f, 0.02618884f, -0.02320201f, 
    -0.03556581f, -0.03502895f, -0.03086078f, -0.01087470f, 0.02712903f, 0.01402460f, 0.02843030f, 0.00589403f, 
    0.00848608f, 0.02043561f, -0.04034891f, -0.02003729f, -0.03223006f, 0.01623886f, 0.01414617f, -0.02213137f, 
    0.02164968f, -0.03511733f, -0.00350070f, -0.02717617f, 0.02660187f, -0.00661729f, 0.01833482f, -0.00875811f, 
    0.02730091f, -0.03468876f, 0.01403282f, -0.00645037f, -0.01285991f, -0.00005891f, -0.00678424f, -0.01915866f, 
    0.02790365f, 0.01052634f, -0.02572687f, -0.02913506f, -0.04022029f, -0.01551125f, 0.00092598f, -0.02612446f, 
    0.01562767f, 0.01878393f, 0.01222267f, -0.00231236f, 0.02513490f, 0.02604832f, 0.02704871f, -0.02945326f, 
    -0.03678377f, -0.00068495f, 0.01272936f, -0.03185344f, -0.01587738f, 0.01221054f, -0.03688887f, 0.01070858f, 
    -0.00164105f, 0.01139236f, -0.01789987f, 0.01270138f, -0.02489393f, -0.01653483f, 0.00572992f, 0.03094487f, 
    -0.03088348f, 0.01007888f, 0.01698751f, 0.02651565f, -0.03118181f, -0.02801972f, -0.00147360f, 0.02503037f, 
    0.01356224f, 0.02294896f, -0.02385196f, 0.00345177f, 0.00559160f, 0.01886081f, -0.01885266f, 0.02425089f, 
    -0.00924509f, -0.01225676f, -0.00234489f, -0.02257602f, 0.00499392f, 0.01118145f, -0.00356104f, 0.02174662f, 
    0.00596467f, 0.03445570f, -0.00702913f, 0.01359430f, -0.00943967f, -0.02686164f, -0.00574472f, -0.02004635f, 
    0.02690575f, -0.00598933f, -0.03485523f, 0.00406452f, -0.00819079f, -0.00880607f, 0.01934192f, -0.03070263f, 
    -0.04258697f, 0.01529201f, -0.02688540f, -0.00008661f, 0.02122267f, 0.00592251f, 0.02346659f, 0.02946859f, 
    -0.00994744f, 0.01051895f, -0.03302731f, 0.01324290f, -0.02435298f, -0.01921421f, -0.01604860f, -0.01348565f, 
    0.00979153f, 0.00972835f, -0.04172684f, 0.02756920f, -0.03621385f, -0.02010861f, 0.00655912f, 0.02373214f, 
    -0.04214370f, -0.03736541f, 0.01179637f, -0.03627376f, -0.00585362f, -0.02944643f, 0.00984697f, 0.02592845f, 
    0.03528881f, -0.02270472f, -0.02244494f, -0.00092710f, 0.02973240f, -0.01642571f, -0.01701364f, -0.01785447f, 
    -0.02686401f, 0.03482030f, -0.02255118f, -0.02781547f, 0.02151717f, 0.03402703f, 0.03162662f, -0.00192960f, 
    -0.01593206f, -0.00552463f, -0.01804760f, 0.00402112f, -0.01207249f, 0.02608062f, 0.01070990f, -0.01438603f, 
    0.00088963f, 0.01342587f, -0.02493236f, 0.01214676f, -0.01979171f, 0.00383796f, -0.01963329f, -0.00867860f, 
    -0.01857447f, -0.00957104f, 0.00810204f, 0.01571509f, 0.01137422f, -0.03450749f, 0.01118252f, -0.01786116f, 
    0.00722675f, -0.02267176f, 0.00963916f, -0.03607398f, -0.00873600f, 0.00365355f, -0.01622592f, 0.02123563f, 
    0.01638625f, 0.01998505f, 0.01073222f, -0.01270545f, 0.03162529f, 0.02583650f, 0.02037423f, 0.02042505f, 
    -0.01687972f, 0.03031422f, 0.02506961f, 0.03170773f, 0.02454362f, -0.01642979f, -0.02641480f, 0.03162587f, 
    -0.01811009f, -0.00700275f, -0.02345996f, -0.00483957f, -0.01294922f, -0.02492798f, -0.01192917f, 0.02371696f, 
    0.00045020f, -0.02791039f, -0.02168785f, -0.01822681f, -0.02239469f, 0.01155152f, -0.03152393f, -0.03122462f, 
    -0.03279414f, 0.01923792f, 0.00926077f, -0.01533071f, 0.01114639f, -0.01308213f, 0.00978820f, -0.03273348f, 
    0.00512969f, -0.01439421f, 0.03537841f, 0.01573356f, 0.01659663f, 0.02219979f, 0.02289298f, 0.03131528f, 
    0.02998430f, -0.00177178f, -0.03304696f, -0.03576136f, -0.00489002f, 0.01525475f, 0.00584907f, -0.02367754f, 
    -0.01650325f, -0.02571668f, 0.02151168f, 0.02707030f, -0.01447942f, 0.03198240f, -0.03109063f, 0.02979325f, 
    -0.02174881f, -0.01022634f, -0.01901226f, -0.01531741f, 0.01525364f, -0.01653728f, 0.02213673f, 0.03563527f, 
    -0.03443986f, -0.01494756f, 0.02051916f, -0.03445683f, 0.03497886f, -0.01635087f, 0.01701424f, 0.01659560f, 
    0.01074612f, -0.00125872f, 0.01766956f, -0.00582081f, -0.02873846f, 0.03580550f, 0.02768092f, -0.02343482f, 
    0.01260510f, 0.02308616f, -0.01522981f, 0.03579548f, 0.01162704f, 0.03486167f, 0.02118080f, -0.03389715f, 
    0.01894445f, -0.02585909f, -0.03224951f, 0.00997473f, -0.00845300f, 0.01895266f, 0.01119258f, 0.01234825f, 
    -0.01733666f, -0.01216465f, 0.01514455f, -0.03360389f, -0.01104400f, -0.01758260f, 0.01684141f, -0.01729648f, 
    0.00921094f, -0.02428466f, 0.03494279f, -0.00104257f, -0.02385797f, 0.00904850f, -0.02479286f, -0.00673539f, 
    -0.02145589f, 0.01300032f, -0.01926283f, -0.00433386f, -0.02780423f, -0.01160487f, 0.03008795f, -0.02908822f, 
    -0.02185126f, -0.03530852f, 0.02091701f, -0.01128498f, 0.03421313f, 0.02450631f, 0.02122483f, 0.02973211f, 
    -0.01286966f, -0.00795877f, -0.02614357f, -0.00192493f, -0.00518315f, -0.02850986f, -0.01566481f, 0.01954900f, 
    -0.00205186f, -0.02057989f, -0.01553212f, 0.00434450f, -0.00310447f, 0.02758870f, -0.01078399f, 0.02259913f, 
    0.00982275f, -0.00341235f, 0.03027333f, 0.01587941f, -0.01123250f, 0.03504504f, 0.03178725f, -0.02074765f, 
    -0.01644218f, -0.00750695f, -0.02285588f, -0.01530268f, 0.01502023f, -0.03398108f, -0.02956809f, -0.01767880f, 
    0.03268923f, 0.03419615f, -0.00370471f, 0.01091760f, -0.01342912f, -0.02002138f, -0.01028324f, -0.00696308f, 
    -0.00647193f, -0.01808380f, -0.00755887f, -0.01338499f, -0.02494784f, -0.00355443f, -0.00582684f, 0.00493306f, 
    -0.02424911f, -0.01511010f, -0.01724337f, 0.02652059f, -0.00366562f, 0.03261939f, -0.00637502f, 0.03378958f, 
    -0.01495793f, -0.02496289f, -0.00029854f, 0.02565762f, 0.00311007f, -0.01044806f, -0.02305692f, -0.03255876f, 
    -0.02912406f, -0.01993182f, 0.00280430f, -0.01560484f, 0.01320107f, -0.01913304f, -0.02926010f, 0.00720952f, 
    0.01356880f, 0.03494530f, 0.01513827f, -0.03032088f, -0.00378746f, 0.03560774f, -0.00610883f, -0.00630852f, 
    0.02892221f, -0.01826975f, 0.03095656f, 0.02605961f, 0.01732066f, 0.01805504f, -0.00762181f, 0.03413864f, 
    0.01014559f, -0.01414885f, 0.00783717f, -0.02375735f, 0.02960478f, 0.02200652f, 0.02160294f, -0.03529929f, 
    0.03174558f, -0.01066847f, -0.00485024f, -0.01980825f, 0.00869637f, -0.00139302f, 0.02676436f, -0.01470425f, 
    0.00549556f, -0.02617034f, 0.01096083f, 0.00327308f, -0.03078235f, -0.00485520f, -0.00111727f, -0.02070745f, 
    0.03376383f, 0.02929248f, -0.03013664f, -0.02432015f, -0.03267511f, -0.01126680f, -0.02159478f, 0.03449214f, 
    -0.02280144f, -0.03523790f, 0.02177533f, 0.00352662f, -0.00421727f, -0.02862588f, -0.01773905f, -0.03541462f, 
    0.01848653f, -0.02978595f, 0.02069100f, -0.03496746f, -0.01599903f, 0.01887597f, -0.03445930f, 0.02041761f, 
    0.01031266f, -0.01665131f, 0.01281318f, -0.00276910f, 0.01212106f, 0.02033695f, -0.03133764f, -0.03028914f, 
    0.01340856f, 0.01673478f, 0.01265029f, 0.03370876f, -0.03503869f, 0.01765172f, -0.02199096f, -0.03000428f, 
    -0.01208756f, -0.03393390f, -0.03288512f, 0.03152748f, -0.01811615f, 0.03112368f, -0.02766673f, 0.01694818f, 
    -0.02636360f, 0.03057551f, -0.02101783f, 0.00856721f, -0.01005480f, -0.00090123f, 0.00479404f, -0.00149934f, 
    0.00402557f, -0.02699975f, 0.00358661f, -0.02499924f, -0.01917764f, -0.01520944f, 0.03379976f, -0.00795995f, 
    0.02142794f, 0.01535861f, -0.00727598f, -0.00901003f, 0.01835651f, 0.01827786f, -0.00003023f, -0.01256839f, 
    0.00394511f, -0.02123939f, 0.03489074f, -0.02233266f, -0.02803220f, 0.00168743f, -0.03322189f, 0.02798728f, 
    0.03437974f, -0.02217617f, -0.03377586f, -0.03037904f, 0.00388768f, -0.02143121f, -0.02851684f, 0.00839485f, 
    -0.01150745f, -0.02057097f, -0.00684613f, 0.00862297f, -0.02759151f, -0.03516038f, 0.02889091f, -0.02084154f, 
    -0.02735033f, -0.00157538f, -0.00486297f, 0.01804007f, -0.01445739f, -0.01818072f, 0.03373891f, 0.01467689f, 
    0.00832461f, 0.02217177f, 0.00696629f, -0.01361086f, -0.02707077f, -0.02239876f, -0.00728169f, 0.01156581f, 
    0.01953737f, -0.02263606f, -0.02128533f, -0.01627180f, -0.03102180f, -0.00394714f, -0.02470834f, 0.01872946f, 
    -0.01355344f, 0.02603276f, 0.01566127f, -0.00756338f, -0.03291112f, 0.01210645f, -0.01980604f, 0.03328817f, 
    0.02269480f, -0.02708131f, 0.02799566f, 0.00169219f, -0.01342103f, 0.00228179f, 0.01475199f, 0.00893754f, 
    0.00831495f, 0.00943264f, 0.03405527f, 0.03151106f, -0.02375836f, 0.03043054f, -0.02257690f, -0.00346226f, 
    0.02714848f, -0.00283479f, 0.02072216f, -0.03546938f, 0.02835731f, 0.01728388f, -0.00918871f, 0.01061051f, 
    -0.00987210f, 0.00551710f, -0.00293706f, -0.01123800f, 0.01996008f, 0.03517554f, -0.01549669f, 0.01151669f, 
    -0.03386576f, 0.01590448f, 0.00141248f, -0.02032078f, 0.01987619f, -0.02197782f, 0.02414386f, -0.01058428f, 
    -0.01080967f, 0.01045967f, -0.03112333f, -0.00016392f, 0.01181971f, -0.02029299f, 0.01784467f, 0.00472088f, 
    0.01488790f, 0.00986931f, -0.03353131f, 0.00758797f, 0.01384278f, 0.03083160f, -0.02428997f, -0.01540668f, 
    0.00457664f, -0.00915192f, 0.03271586f, 0.02735412f, 0.01548744f, 0.02500849f, 0.01155533f, -0.02347231f, 
    0.02226527f, 0.00173470f, 0.00134851f, -0.01723968f, -0.01570067f, -0.02580891f, -0.02179307f, -0.02149685f, 
    -0.01928363f, -0.03218875f, 0.02865314f, -0.02104501f, -0.02754711f, 0.01072595f, -0.03315911f, -0.01037062f, 
    0.01916763f, -0.02866443f, -0.01851599f, 0.02160235f, -0.03362530f, -0.01797003f, -0.03566222f, 0.01297016f, 
    0.01634210f, 0.02071356f, -0.02520212f, 0.00112254f, -0.01702434f, 0.01376578f, 0.03400315f, -0.02764133f, 
    -0.02072601f, -0.03291785f, 0.00577503f, -0.00846966f, -0.03083416f, 0.02890427f, -0.02941488f, -0.01051440f, 
    -0.01785380f, 0.00323486f, 0.03489024f, -0.00570440f, -0.02171944f, -0.00051320f, -0.02252790f, -0.01832090f, 
    -0.01459591f, 0.00312329f, 0.01466294f, -0.00920337f, 0.03347999f, -0.01228217f, -0.03119224f, -0.02113141f, 
    -0.00689748f, 0.02714434f, -0.00194114f, -0.02427003f, 0.03456527f, 0.00506471f, 0.01254117f, -0.00506343f, 
    0.02436174f, -0.01296365f, -0.00954145f, -0.00257788f, 0.03571293f, -0.01012939f, -0.01186343f, 0.02508770f, 
    -0.01695665f, -0.00394634f, -0.01909046f, 0.03004317f, -0.02842068f, 0.02514615f, -0.02241988f, 0.02191789f, 
    -0.00114904f, -0.01973249f, -0.00195190f, 0.00586636f, 0.02452603f, -0.01842760f, 0.01037684f, -0.01666944f, 
    -0.01125040f, -0.00846662f, 0.01337733f, -0.03381419f, -0.02125887f, 0.03220390f, -0.01404251f, 0.01124563f, 
    0.00846251f, -0.00226990f, -0.00521446f, -0.03005357f, 0.03019679f, 0.00619366f, -0.00081811f, 0.01225489f, 
    0.00548041f, -0.01157224f, -0.02052358f, -0.00730015f, -0.03524269f, 0.03097098f, 0.03065899f, 0.02818935f, 
    0.02155315f, 0.00545881f, 0.01133048f, -0.03387559f, -0.01965565f, -0.02400933f, -0.01346927f, 0.01194247f, 
    -0.00485463f, -0.03002499f, -0.02706111f, -0.01608798f, -0.00275205f, 0.02045803f, -0.03571196f, 0.02307420f, 
    -0.03285183f, -0.01672254f, -0.02100275f, -0.03460974f, -0.02122862f, 0.00689640f, -0.00862242f, 0.01108596f, 
    -0.02271664f, 0.02480792f, -0.01194641f, 0.01753311f, 0.02794039f, -0.00802278f, -0.00915035f, 0.02463452f, 
    -0.00303058f, -0.00801451f, 0.01984830f, -0.02387551f, 0.01886871f, -0.02313786f, -0.00207777f, -0.03353319f, 
    -0.00094773f, -0.01652763f, -0.01239806f, -0.01993253f, 0.02880558f, 0.01794234f, -0.03056424f, 0.00237816f, 
    -0.02386563f, 0.02907325f, 0.02684347f, 0.03498711f, 0.01494740f, -0.01375677f, -0.00554779f, -0.02173349f, 
    -0.03258866f, 0.00035296f, -0.03111946f, 0.01075545f, -0.00384463f, -0.00442324f, -0.00377384f, 0.01585815f, 
    0.02601644f, 0.03195649f, -0.00809730f, -0.00839473f, -0.02359951f, -0.02401080f, -0.01110910f, 0.00614902f, 
    -0.00998157f, -0.03194834f, -0.02498342f, -0.03377098f, 0.00176805f, 0.01885028f, 0.00181091f, -0.02733670f, 
    -0.02805399f, 0.02893390f, 0.02690291f, 0.01364946f, 0.03204103f, -0.03535144f, -0.02921923f, -0.03258706f, 
    -0.00274181f, 0.01455925f, -0.03300270f, 0.01548387f, -0.02282297f, 0.01971845f, 0.00113589f, 0.00985026f, 
    -0.02503270f, -0.00873447f, 0.01133802f, 0.02670267f, 0.00464237f, -0.00401371f, -0.03020099f, 0.01379513f, 
    -0.01660676f, 0.01432528f, -0.02750778f, -0.03199555f, -0.00696056f, -0.00353244f, -0.03525315f, -0.00732155f, 
    -0.00234934f, -0.00162575f, -0.01908117f, 0.00303569f, 0.02444323f, -0.00142248f, -0.00170466f, -0.02577062f, 
    -0.01234134f, -0.00482488f, 0.03051767f, 0.03083388f, -0.00146305f, 0.01091680f, 0.02083604f, 0.02106747f, 
    -0.00958745f, 0.02849915f, -0.00283471f, 0.01483438f, -0.01577547f, -0.01844894f, 0.01048675f, 0.01831407f, 
    0.01906040f, -0.02846339f, -0.00627010f, -0.03383815f, 0.01237183f, 0.01758390f, 0.00339130f, 0.00316093f, 
    0.03444917f, -0.01537383f, -0.00266895f, 0.01790553f, 0.03598543f, -0.02470905f, 0.00558013f, 0.00459736f, 
    -0.02942409f, 0.00092266f, 0.00483469f, 0.02447941f, 0.00990791f, -0.02820296f, 0.03306548f, -0.00148940f, 
    0.00209329f, -0.01662271f, -0.01424072f, -0.01039177f, 0.00503920f, -0.00938986f, -0.01789515f, 0.00047524f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.01246112f, -0.00116857f, 0.01069036f, 0.03821941f, -0.00504493f, 0.06750832f, 0.01506086f, -0.04093836f, 
    -0.00348755f, -0.03626820f, 0.06003513f, -0.00129468f, -0.00570691f, -0.00840323f, -0.04502955f, 0.06317018f, 
    -0.02320228f, 0.01247643f, -0.03443274f, -0.03380568f, -0.01860396f, -0.00130586f, 0.09588772f, 0.04811078f, 
    -0.01855755f, 0.02607829f, -0.04075921f, 0.01161285f, -0.03635940f, -0.03417782f, -0.03798208f, -0.03478263f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.01652421f, 0.11304100f, 0.18899682f, -0.05636712f, 0.10350511f, -0.50904393f, -0.11499491f, -0.06786141f, 
    0.09834009f, -0.06027729f, -0.65908951f, 0.13374464f, -0.00186985f, 0.16943882f, -0.01440430f, 0.28558362f, 
    -0.09442475f, -0.07459667f, 0.10765489f, -0.37560034f, -0.09857094f, 0.16470082f, 0.02595826f, -0.23936264f, 
    -0.05784996f, 0.18538184f, -0.13532129f, 0.11615681f, -0.16303779f, 0.43540230f, -0.15713076f, -0.06130918f, 
    -0.34292462f, 0.04589137f, 0.00152857f, 0.24099168f, -0.05467217f, -0.03778330f, 0.05950353f, -0.14020811f, 
    -0.09128084f, 0.11657131f, 0.10489733f, -0.05900299f, 0.06028259f, 0.01237949f, 0.10576136f, -0.79212385f, 
    -0.02119533f, 0.09348883f, 0.16653404f, -0.30879566f, -0.13088961f, 0.47075531f, -0.05983137f, 0.01480729f, 
    0.09076093f, 0.25258741f, -0.01932717f, -0.14663748f, -0.13085897f, 0.20686157f, -0.05103368f, -0.07002492f, 
    0.15228015f, 0.04386986f, -0.08912825f, -0.20611042f, 0.49673811f, 0.14710796f, 0.02329807f, -0.08172977f, 
    -0.11685214f, 0.11037609f, 0.00617236f, 0.10436804f, -0.09658456f, 0.10782552f, 0.07285949f, -0.06637649f, 
    0.00094128f, -0.06534518f, -0.08217628f, -0.61012596f, 0.04900752f, 0.05578981f, -0.52598923f, 0.18208557f, 
    -0.10604476f, -0.03567341f, -0.00193017f, -0.15860765f, -0.01461529f, -0.21746443f, -0.09263143f, -0.05682862f, 
    0.10489056f, -0.05904007f, -0.73258322f, 0.11556370f, 0.42022610f, -0.19864613f, -0.03746980f, 0.00538920f, 
    -0.11812924f, 0.15031765f, -0.30471307f, 0.11624912f, 0.11231406f, -0.13688269f, -0.37514868f, 0.10407992f, 
    0.16426438f, 0.14342283f, -0.08008276f, 0.28865552f, -0.12359217f, 0.21020365f, 0.30769855f, -0.16133085f, 
    -0.05491558f, -0.31197008f, 0.04216433f, 0.16108906f, 0.06841451f, -0.74327546f, -0.14371520f, 0.06943988f, 
    0.29659829f, -0.00363919f, -0.27275109f, 0.41401774f, -0.32454374f, -0.29142326f, 0.15650426f, -0.02332071f, 
    -0.13256696f, 0.02070592f, -0.52598590f, -0.18495153f, -0.12998126f, 0.00943200f, 0.30769551f, 0.18442076f, 
    0.01581007f, 0.13024400f, 0.03028228f, 0.06291046f, 0.04619695f, -0.25593585f, -0.03735282f, 0.08532419f, 
    0.13546461f, 0.12121463f, -0.18085560f, -0.07523565f, 0.16299045f, -0.32726762f, -0.09133165f, 0.16185005f, 
    -0.47356024f, -0.02714967f, -0.23463841f, 0.11592152f, -0.26847607f, 0.05461079f, -0.16746379f, 0.09328918f, 
    0.16139016f, 0.07764468f, 0.17487498f, -0.08589347f, 0.03438913f, 0.09756377f, 0.29706213f, -0.20413491f, 
    0.11030155f, -0.01370139f, 0.08576269f, 0.31395841f, 0.17106779f, -0.52748621f, 0.18786125f, 0.09917299f, 
    0.05278528f, -0.01462645f, 0.01330094f, 0.05016269f, 0.02104865f, 0.32207343f, 0.05879661f, 0.00995340f, 
    0.20607370f, 0.01062848f, 0.21622941f, -0.33088103f, 0.06266791f, -0.33783251f, -0.02911220f, 0.12835108f, 
    0.01680931f, -0.16763447f, 0.64434850f, -0.13810962f, 0.08365729f, -0.17014334f, -0.19743466f, 0.05817520f, 
    -0.16070515f, -0.00477475f, -0.14754426f, -0.25680670f, -0.07117763f, -0.02459628f, 0.15673429f, -0.13631521f, 
    -0.08133750f, 0.17203128f, -0.12127759f, 0.13083065f, 0.02250172f, -0.12146259f, -0.07910878f, 0.14992262f, 
    0.03709988f, -0.09520923f, -0.35466507f, -0.53468490f, -0.45702296f, 0.23221833f, -0.07321606f, 0.08122747f, 
    0.06287950f, -0.05679091f, -0.08085031f, -0.10205893f, -0.07877307f, -0.14307441f, -0.19553511f, 0.35695654f, 
    -0.08556224f, 0.05842905f, 0.07348356f, 0.32173339f, 0.01399909f, -0.17668633f, -0.06364036f, -0.31602958f, 
    -0.10721461f, 0.33996829f, -0.11078213f, -0.12336884f, 0.14889872f, -0.17366415f, -0.11297397f, -0.12601614f, 
    -0.14153667f, -0.08278026f, 0.21677010f, -0.40152222f, 0.03502145f, 0.06884279f, -0.00078763f, 0.05799920f, 
    -0.07093521f, 0.07157096f, -0.21033300f, -0.01158161f, 0.03034506f, 0.13853031f, 0.46930578f, -0.29810479f, 
    -0.13653256f, 0.11059681f, 0.16644575f, 0.34781599f, -0.03486966f, 0.28365466f, -0.32461751f, -0.29974431f, 
    -0.02714692f, -0.35846961f, 0.13764729f, 0.03386336f, 0.04442932f, 0.14229503f, -0.14581363f, -0.15545346f, 
    -0.18560719f, -0.05389667f, 0.34957391f, 0.24093035f, -0.02784276f, -0.12068309f, 0.13522825f, -0.01926683f, 
    0.00576538f, -0.00717873f, 0.18759525f, 0.09581174f, -0.00688518f, 0.06464013f, -0.21362312f, 0.30158284f, 
    -0.10948493f, 0.08877846f, 0.06954548f, 0.39087722f, 0.13014761f, -0.22395736f, -0.35808504f, 0.31744331f, 
    0.04665430f, -0.50238246f, -0.01097762f, 0.09183302f, 0.02796783f, -0.17073302f, -0.00322000f, 0.06039917f, 
    -0.36896610f, -0.12062443f, 0.38209185f, -0.14472923f, 0.09483048f, 0.30439621f, 0.08921201f, -0.00910338f, 
    0.10892605f, 0.03925066f, -0.17169012f, -0.05761131f, 0.13483652f, 0.13216752f, -0.42289877f, 0.06693516f, 
    -0.07693501f, -0.04491594f, 0.11352330f, -0.36534235f, -0.02902305f, -0.28962007f, 0.32593098f, -0.21819714f, 
    0.14598000f, 0.07560679f, 0.03530648f, 0.12385199f, 0.12639879f, -0.66309619f, -0.03718869f, 0.06746138f, 
    0.23250471f, 0.08146638f, -0.31611696f, -0.24491735f, -0.29251969f, 0.10771880f, -0.09250630f, -0.09186921f, 
    -0.10639350f, 0.04236221f, -0.23249954f, -0.11159956f, -0.00154621f, 0.02716750f, -0.21586043f, -0.10631863f, 
    0.03285153f, 0.04836013f, -0.06289805f, -0.28922796f, -0.13645472f, -0.16008466f, 0.30714309f, 0.41831422f, 
    0.06003869f, -0.52708572f, -0.11438207f, -0.12246997f, -0.07750721f, 0.17436416f, -0.02771531f, 0.03379901f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.10761405f, 0.15917195f, 0.10503399f, -0.09834997f, 0.19589846f, -0.11133166f, -0.01452973f, -0.15737621f, 
    -0.03644153f, -0.14262317f, 0.18682107f, -0.11044577f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
