#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    1.90996766f, 0.89509445f, -0.85167742f, 0.27170804f, 0.59898001f, 0.98067766f, 0.42504856f, -0.17328188f, 
    1.01238704f, 0.35991001f, -0.27425838f, 0.63046736f, -0.31333628f, 0.03205980f, 0.23280880f, 0.14115284f, 
    -0.72113907f, -0.21667066f, 0.10776041f, 0.25414595f, 0.18110633f, 0.32991716f, 0.13064206f, -0.18538830f, 
    0.36033833f, -0.55055481f, 1.90501225f, 0.87059295f, -0.80786449f, 0.56442660f, -0.49251100f, 0.47495171f, 
    -0.32864416f, -0.27076876f, -0.27473828f, 0.18035915f, 0.06383993f, 0.05956817f, 0.24232684f, 0.24956775f, 
    0.34053743f, 0.45609820f, 0.02836926f, 0.26359475f, 0.35337886f, 0.06479846f, 0.12512131f, -0.02419167f, 
    0.04424205f, 0.40736386f, 0.19032016f, 0.60673892f, -0.51276839f, -0.42080328f, 0.28289890f, -0.98190767f, 
    -1.76164865f, -0.97537965f, 0.03330103f, 0.30336374f, -0.44191206f, -0.10644153f, 0.03154366f, -0.47031009f, 
    -0.37993827f, -0.64390248f, 0.19123770f, -0.43981117f, -0.08258967f, 0.29681510f, 0.04897502f, 0.40184230f, 
    0.20615092f, 0.06757779f, -0.53936213f, 0.78139240f, -2.00330186f, 0.20670304f, 1.31501579f, 0.83092207f, 
    -1.32304263f, 0.62417042f, 0.44854826f, -0.17435540f, 0.27951929f, 0.31541026f, 0.17607072f, -0.10378792f, 
    -0.29425412f, 0.12848246f, -0.33001369f, -0.18075193f, -0.17552760f, -0.04156574f, -0.20109846f, -0.07070191f, 
    0.03466165f, -0.00835688f, -0.02622167f, -0.11862541f, 0.47612029f, -0.35621980f, 0.70747572f, 1.06741512f, 
    0.92741692f, 0.39749992f, 0.75911039f, 0.47345823f, -0.00704842f, -0.06470116f, 0.10192440f, -0.38567165f, 
    -0.38020802f, 0.30872986f, 0.21759433f, 0.31030321f, 0.35009122f, 0.03047463f, 0.36729193f, 0.36017630f, 
    0.54854625f, 0.28795806f, -0.00740190f, 0.09691243f, 0.53658056f, 0.02990638f, 0.85862702f, 0.83043885f, 
    0.74215949f, 1.07893062f, 0.84936190f, -0.24237667f, 0.96210450f, -0.39506754f, -0.38107014f, -0.85699737f, 
    -0.68175417f, -0.69252026f, 0.24510087f, -0.14273322f, -0.32637450f, -0.40923923f, -0.29838425f, -0.27283955f, 
    -0.39340624f, -0.03787602f, -0.08439153f, -0.31607601f, -0.30569878f, 0.09963022f, -1.23425412f, -1.38788736f, 
    -1.61147380f, -0.45691469f, 0.02818329f, -0.83518445f, 1.13722515f, 1.06075943f, -0.47319490f, 0.28589666f, 
    0.21452098f, -0.12167620f, 0.37772754f, -0.46269420f, 0.30515015f, -0.12516156f, 0.12295922f, 0.29954931f, 
    -0.12994882f, -0.24185142f, -0.05877465f, 0.13080993f, -0.05588868f, 0.17098871f, 0.09113152f, -0.27222338f, 
    -0.87706959f, -1.10242367f, -1.09790766f, 0.25634676f, 0.05125030f, -0.66670030f, -0.81655574f, -0.52376980f, 
    0.37418807f, -0.28152049f, 0.08430871f, 0.47716585f, 0.44710362f, 0.38478699f, -0.04668607f, -0.27462104f, 
    -0.20595725f, 0.27601230f, 0.48253918f, 0.55649960f, 0.16280937f, -0.03182659f, -0.33879486f, -0.16844781f, 
    -1.69302154f, -0.25767392f, -0.32849994f, -0.61503971f, -0.69292361f, 0.96428490f, 0.92821521f, -0.57723749f, 
    0.43559036f, 0.40080643f, -0.06698892f, -0.31544229f, 0.36415964f, -0.01124979f, -0.00743000f, -0.13385992f, 
    0.35191852f, 0.24042848f, -0.14659128f, -0.63073373f, 0.20367497f, -0.16937663f, 0.36030084f, -0.06172628f, 
    0.18899229f, 1.79647720f, 0.85132045f, 0.47986346f, 0.40055478f, 0.05680524f, -0.65486747f, -0.65516239f, 
    0.63125271f, -0.73209959f, -0.15996981f, 0.02720154f, -0.33907089f, 0.38149571f, 0.08937978f, 0.13311806f, 
    -0.18654983f, -0.02353553f, -0.05547414f, 0.11406752f, 0.48059255f, 0.22400020f, 0.22824934f, 0.28096193f, 
    0.24313703f, -0.01450995f, 1.29893923f, 0.80997556f, 1.59547734f, 0.66300339f, 0.75255001f, 0.65873778f, 
    0.10935546f, 0.02633953f, -0.28467557f, 0.08827467f, 0.63918811f, 0.79560584f, -0.32466376f, 0.00987125f, 
    -0.03588348f, -0.15127359f, -0.05539291f, 0.16573480f, 0.15440193f, -0.19543642f, 0.00087335f, -0.29088223f, 
    0.23466954f, 0.12940279f, -0.09589144f, 0.03510950f, 0.06488165f, -0.88672918f, 1.09099936f, -0.56334573f, 
    -0.39874366f, -0.38560969f, -0.26612908f, 0.81057215f, -0.76123655f, -0.22431885f, -0.54055715f, -0.59801829f, 
    0.45949331f, -0.42845815f, 0.40657327f, 0.76780844f, -0.29023346f, -0.52323294f, -0.31233999f, -0.50349653f, 
    0.02308513f, 0.15157761f, 0.27075225f, 0.47543278f, -0.16394727f, -0.02225664f, -1.18169200f, -1.47475588f, 
    -0.73791045f, 0.19289370f, 0.34020635f, 0.45403779f, 0.57196492f, 0.81449258f, -0.34835264f, -0.38674092f, 
    -0.39174455f, -0.55016363f, -0.79008693f, -0.03790866f, 0.09732646f, 0.08022969f, 0.40180790f, -0.03306835f, 
    0.01283014f, -0.44343588f, -0.42740831f, -0.57508081f, 0.22217953f, 0.33601046f, -0.14750180f, 0.99574631f, 
    0.93137550f, 1.26753283f, -0.02473076f, -0.96112186f, -1.25192964f, -0.35114151f, -0.55738622f, 0.10346364f, 
    -0.05596065f, 0.24606572f, 0.78046346f, -0.19879185f, 0.24396791f, -0.05006061f, 0.49452779f, -0.08558071f, 
    -0.01449926f, -0.31675920f, 0.12783530f, -0.05698066f, 0.33033156f, -0.31365156f, 1.02199280f, -0.85903460f, 
    -1.02357936f, -1.15971255f, 0.51503587f, 0.74088681f, 0.96066159f, -0.54739565f, 0.09415779f, 0.26500908f, 
    -0.05617664f, 0.11701732f, 0.12801975f, 0.03028036f, -0.32753289f, -0.15574585f, -0.04236105f, 0.00869531f, 
    0.02831020f, -0.40134320f, -0.05875751f, 0.21856928f, 0.11990394f, -0.05575474f, 0.01630733f, -1.18345010f, 
    0.66120732f, 0.36767364f, -0.79346144f, -1.29350388f, 0.44101158f, -0.82181382f, 0.31724671f, 0.24291039f, 
    -0.93807375f, -0.54795539f, 0.12190707f, -0.15067518f, 0.53337431f, -0.12416589f, -0.51802981f, -0.11714687f, 
    -0.27604553f, -0.01137538f, -0.54990262f, 0.28453475f, 0.25978664f, 0.02045730f, 0.02088579f, -0.08619349f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.46492258f, 0.32330024f, 0.73536545f, -0.00345679f, 0.46352184f, -0.02240245f, 0.31262186f, 0.58063632f, 
    0.02711624f, 0.18914597f, 0.29104403f, 0.48247653f, -0.34247518f, 0.33008727f, 0.23837109f, 0.42864129f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.36939830f, -0.18817239f, 0.01758788f, 0.00422097f, -0.21877486f, -0.16290191f, -0.13881508f, 0.24068791f, 
    0.00934934f, 0.04745492f, 0.19259875f, -0.06909145f, -0.46123570f, 0.13128133f, 0.06796488f, -0.76520723f, 
    -0.09791264f, 0.06206061f, 0.16405731f, -0.12269362f, 0.07848690f, 0.09560749f, -0.10126588f, -0.02695166f, 
    -0.09847963f, -0.31327736f, 0.33789998f, 0.01451366f, -0.01129226f, -0.20785040f, 0.03640247f, -0.15821734f, 
    -0.03020301f, -0.16208802f, 0.13840522f, -0.07929809f, 0.18508843f, -0.13856049f, -0.23837996f, 0.68209428f, 
    -0.22382218f, 0.09061522f, 0.06811313f, -0.13281444f, 0.08615939f, 0.05045049f, -0.03804814f, -0.03845533f, 
    0.12061994f, 0.06734969f, 0.03480763f, 0.14321885f, -0.13053332f, 0.09888152f, 0.07885517f, 0.01133856f, 
    0.05073773f, -0.09590618f, 0.06825953f, 0.07478381f, -0.00888663f, 0.03273996f, 0.45630765f, 0.04119559f, 
    -0.12406217f, 0.05215286f, 0.06253032f, -0.00980389f, 0.03940437f, -0.13120899f, 0.05297719f, -0.08547006f, 
    -0.79382151f, 0.50177729f, -0.08891883f, -0.34935120f, 0.15628286f, -0.14576475f, -0.05191111f, 0.01702308f, 
    0.03897864f, 0.03505040f, 0.06155438f, 0.08049729f, -0.37825546f, -0.79862356f, 0.04535611f, -0.40714753f, 
    0.16383399f, -0.14714263f, 0.11347337f, 0.04176231f, -0.01185000f, -0.21187244f, -0.10069405f, 0.07913157f, 
    0.95750016f, 0.13545999f, 0.10171676f, -0.32516634f, 0.14832792f, 0.01612178f, -0.06778404f, 0.12173549f, 
    0.02747596f, -0.08201685f, -0.15917464f, 0.11553569f, 0.45914969f, -0.10708070f, 0.02776552f, -0.02727603f, 
    -0.31124634f, -0.00536535f, -0.17192870f, 0.20224282f, -0.18957554f, -0.22787276f, 0.00053383f, 0.09216232f, 
    0.16800235f, -0.15991198f, -0.18477143f, 0.05584566f, -0.23463286f, -0.04504045f, 0.13165422f, 0.03762521f, 
    0.21666011f, -0.02246222f, 0.09114423f, -0.06845164f, -0.19931647f, -0.24014232f, -0.35296157f, 0.43781748f, 
    0.13026366f, 0.04484316f, -0.15437971f, -0.07194757f, 0.05874252f, -0.04690110f, -0.03662904f, -0.25906292f, 
    0.22071816f, 0.12557971f, -0.18128935f, -0.66037619f, 0.33076891f, -0.02696300f, 0.08435807f, 0.16263697f, 
    -0.06325492f, -0.01470021f, -0.14445233f, 0.02137024f, 0.45058301f, -0.03225334f, -0.06662042f, 0.25445303f, 
    -0.07339651f, -0.12759379f, 0.12847480f, 0.03422568f, -0.04133946f, -0.04062534f, -0.16547400f, -0.17574920f, 
    -0.11334708f, -0.09830628f, 0.50070500f, -0.31117973f, -0.14577849f, -0.10686915f, 0.22232583f, -0.27132031f, 
    -0.16652398f, 0.12468088f, -0.01113504f, -0.02790850f, -0.35694692f, 0.16082430f, -0.32809815f, 0.15171729f, 
    0.05774409f, 0.08882993f, 0.04685152f, -0.23945582f, 0.05015553f, -0.07208110f, 0.13532837f, -0.10360076f, 
    0.48336104f, -0.40667129f, 0.25572407f, 0.14350227f, -0.14783914f, -0.18880247f, -0.33038816f, -0.12052009f, 
    -0.24223833f, 0.01446145f, -0.29833490f, 0.19342685f, -0.11733939f, 0.28416649f, -0.18473111f, -0.48578161f, 
    -0.11566274f, 0.15821677f, 0.06075080f, -0.16977777f, 0.19999087f, 0.08835632f, -0.02214391f, 0.22409916f, 
    -0.16991948f, -0.24377403f, -0.08248426f, -0.41096520f, 0.04135113f, -0.11160927f, 0.27351645f, 0.17778102f, 
    0.01252880f, -0.23417790f, 0.14154196f, -0.17963262f, -0.34676155f, -0.47617385f, 0.14677233f, 0.17009312f, 
    -0.23798628f, 0.00979962f, -0.09634668f, 0.03462816f, 0.02323222f, 0.06622259f, -0.02297967f, -0.07071687f, 
    0.36471805f, 0.17821786f, 0.21117660f, 0.24795349f, -0.21493071f, 0.16543783f, -0.06271475f, 0.02037506f, 
    0.15785880f, 0.32331723f, 0.04208544f, -0.12890050f, 0.50130880f, -0.01054165f, -0.10380732f, 0.24606448f, 
    -0.11907035f, 0.19889246f, 0.07784552f, 0.02765742f, -0.05678172f, 0.09795126f, -0.17458928f, -0.11230401f, 
    0.75614709f, -0.19211257f, -0.21415444f, 0.03037139f, 0.08301339f, 0.14201154f, 0.16962083f, -0.02329956f, 
    0.05628339f, -0.13518265f, 0.06502894f, -0.06000280f, 0.28467384f, -0.02141990f, 0.30465344f, -0.28188363f, 
    -0.07820775f, -0.13796005f, 0.15038273f, 0.07203999f, -0.20248215f, 0.19698776f, -0.01931624f, -0.01907966f, 
    -0.63461614f, -0.05545874f, -0.19861346f, -0.01026154f, 0.16910848f, -0.08314641f, -0.08032338f, 0.04252790f, 
    0.15326278f, 0.07930917f, 0.12694243f, -0.01264651f, 0.25363553f, 0.00887268f, 0.06623095f, 0.30621579f, 
    -0.00380287f, -0.12427585f, 0.18241008f, -0.02488129f, 0.00664170f, 0.22393863f, 0.04192665f, 0.23379551f, 
    0.15759933f, 0.27406666f, 0.35357216f, 0.29459149f, -0.30230826f, -0.05639081f, -0.01424592f, 0.03132196f, 
    -0.25189799f, -0.08961947f, -0.06256449f, -0.04848258f, -0.23168473f, -0.00292754f, -0.54955113f, -0.07338675f, 
    0.08868673f, -0.06451060f, -0.03194424f, 0.24319178f, 0.06220084f, 0.10777958f, 0.04377735f, -0.11441634f, 
    -0.08897763f, -0.09768283f, 0.21372096f, -0.44495633f, 0.16207747f, -0.18061954f, -0.10145447f, 0.24073802f, 
    0.11841302f, -0.22440256f, 0.07604692f, -0.21114454f, -0.09228096f, -0.14883126f, -0.05263993f, -0.10081103f, 
    -0.04725768f, 0.01903220f, -0.03416036f, -0.01915533f, 0.10624101f, -0.19590366f, -0.03036221f, 0.08558142f, 
    0.55495137f, -0.81929159f, -0.09234412f, -0.45665109f, 0.15533447f, -0.04534810f, -0.44039291f, 0.10470229f, 
    0.08594566f, -0.22873527f, 0.08401993f, -0.09925906f, -0.72485292f, -0.21659924f, 0.11115535f, -0.11844119f, 
    -0.09935714f, 0.10684533f, -0.11076114f, -0.07000349f, -0.04091579f, -0.08716375f, -0.24080648f, -0.07865194f, 
    0.42631248f, -0.32897907f, -0.10291991f, -0.10023452f, 0.04648526f, -0.26594239f, 0.21744996f, 0.08106641f, 
    0.06922089f, 0.08013153f, 0.27547842f, -0.06936199f, 0.11688367f, -0.05284336f, -0.50900149f, 0.09368280f, 
    0.06143511f, 0.10711243f, 0.05549882f, -0.16256207f, -0.12910366f, -0.17084755f, -0.00668629f, -0.07651671f, 
    -0.94910145f, -0.07341340f, 0.09324968f, -0.49548522f, 0.28529269f, 0.16911432f, 0.03965122f, -0.03410715f, 
    -0.11584302f, 0.17467859f, 0.01000172f, -0.05838820f, 1.14230585f, -0.08626705f, -0.17617001f, -0.30481917f, 
    -0.09600564f, 0.23574089f, -0.19636938f, 0.15378806f, 0.05953871f, 0.14023955f, 0.06768653f, -0.18256474f, 
    -0.08744263f, -0.03287102f, 0.04535635f, -0.00832786f, 0.01179821f, 0.01357403f, 0.01368553f, -0.05375063f, 
    0.04466124f, -0.24274451f, 0.06004533f, -0.04158310f, -0.34750500f, -0.02294177f, 0.12687401f, -0.04080763f, 
    0.14336151f, -0.05739613f, 0.00735203f, -0.10291646f, 0.15331222f, 0.10814815f, 0.06658988f, 0.17819758f, 
    0.78140479f, -0.08122903f, 0.04938101f, 0.50729293f, -0.24858910f, -0.05058334f, 0.07511593f, 0.02757551f, 
    -0.06787422f, -0.05230746f, 0.05826660f, 0.09225149f, -0.45798215f, -0.31806555f, -0.00701774f, -0.31206429f, 
    -0.04727704f, 0.04546460f, -0.21906953f, -0.06047848f, -0.02716009f, 0.03028405f, -0.13633263f, 0.05220805f, 
    0.72998106f, -0.13219638f, 0.28311133f, 0.24248488f, 0.10742482f, -0.14285702f, -0.16678256f, -0.01071250f, 
    -0.15803707f, 0.07068963f, 0.00243529f, -0.17854489f, -0.65115565f, 0.34955668f, -0.27271298f, -0.15398288f, 
    -0.01833714f, 0.00004660f, 0.05740789f, 0.07953178f, -0.14119194f, -0.01164922f, 0.04462079f, -0.07320122f, 
    0.19174746f, 0.16071151f, 0.04442313f, 0.13532008f, 0.01233758f, 0.08513913f, -0.05368635f, -0.05127451f, 
    -0.06682504f, 0.12525755f, 0.10872918f, 0.03215686f, -0.27929851f, -0.47671112f, -0.76168340f, -0.00928420f, 
    -0.06260169f, -0.03298854f, -0.22810383f, 0.11944675f, -0.10843741f, 0.09888548f, 0.27275696f, -0.07261117f, 
    -0.05958510f, -0.10691636f, -0.04574120f, 0.35570651f, 0.16460931f, -0.04111894f, 0.36555353f, -0.01309183f, 
    -0.17443153f, 0.12946728f, -0.07076672f, -0.11661326f, 0.29134259f, 0.06254962f, -0.33845583f, 0.00313402f, 
    0.22157516f, 0.13460024f, -0.06376941f, -0.17294846f, -0.17886034f, 0.05425994f, -0.27143914f, -0.15242477f, 
    -0.55600923f, -0.17038353f, 0.35629511f, -0.04584329f, -0.06806421f, 0.08383314f, 0.05090529f, -0.05470151f, 
    -0.24078616f, -0.06739720f, -0.12065729f, 0.14735678f, -0.41916737f, 0.15577839f, -0.71231163f, -0.50674289f, 
    -0.02884463f, -0.08168060f, -0.07730389f, -0.25307080f, -0.11954530f, -0.01871215f, -0.07584579f, 0.05161212f, 
    0.25953847f, -0.27930984f, -0.46445841f, -0.29389280f, -0.15286355f, 0.03322984f, -0.14114816f, -0.01478083f, 
    0.03462109f, -0.16140887f, 0.08162773f, -0.15285869f, 0.20041743f, 0.21015678f, 0.17559621f, -0.14784116f, 
    -0.02566702f, 0.00450487f, 0.14907162f, 0.33086661f, -0.08925751f, -0.07341648f, -0.00086585f, -0.05119535f, 
    0.35764658f, 0.43045098f, 0.05208397f, 0.34943742f, 0.24393404f, 0.23081191f, -0.14943445f, -0.12913823f, 
    0.16821276f, -0.00348097f, -0.05546937f, 0.12957761f, -0.13554665f, 0.16830756f, 0.09451069f, 0.09090346f, 
    -0.06645539f, 0.17807703f, 0.13085327f, 0.12566495f, -0.00214177f, 0.18330707f, -0.04552775f, -0.02625301f, 
    -1.27322280f, -0.28956580f, -0.12483467f, -0.02786319f, -0.19022590f, -0.15042952f, 0.00106514f, -0.03492473f, 
    -0.25043872f, -0.15260589f, 0.10275633f, -0.16376196f, -0.55149508f, -0.77446330f, -0.35088551f, -0.01781199f, 
    -0.37366092f, -0.04918311f, 0.10863689f, -0.18648611f, 0.12369075f, -0.14722274f, 0.15142158f, 0.05348767f, 
    0.14762357f, -0.14370938f, -0.06994251f, -0.07188241f, -0.29579836f, -0.23394218f, 0.21579114f, -0.09444542f, 
    -0.17722076f, 0.15196717f, -0.29995817f, 0.03159351f, 0.31672546f, 0.16867150f, -0.20153120f, 0.07217182f, 
    -0.34598503f, 0.04581530f, -0.23648787f, -0.25600803f, 0.05111691f, -0.13316652f, 0.12935497f, -0.08671531f, 
    -0.25406316f, 0.30562890f, -0.08772891f, -0.37192830f, -0.18310794f, -0.24875970f, -0.09671532f, 0.13947861f, 
    -0.05458307f, -0.12931168f, -0.15960555f, -0.10704450f, 0.40961817f, -1.09339142f, 0.14322099f, -0.02697901f, 
    -0.02937195f, 0.19600481f, -0.04177859f, 0.00708735f, -0.01678885f, -0.18165693f, 0.00655978f, -0.06838384f, 
    -1.00550079f, -0.96588326f, 0.13043547f, 0.07649084f, -0.02557856f, -0.09018151f, -0.07676936f, -0.13286646f, 
    0.04565901f, -0.12420772f, 0.06815898f, -0.05433151f, 0.43539882f, 0.17790946f, 0.35735720f, 0.20345297f, 
    -0.15865722f, 0.07437095f, 0.15278268f, 0.05863643f, -0.01684659f, 0.01914375f, 0.12954183f, -0.22071868f, 
    -0.38888380f, 0.15079147f, 0.06649888f, -0.23485893f, -0.00202554f, 0.00841928f, -0.02732190f, -0.11343819f, 
    -0.11720710f, 0.18915993f, -0.07719191f, 0.23864457f, 0.16591014f, -0.35640860f, 0.40433726f, 0.60838991f, 
    0.12406642f, 0.16086200f, 0.01063119f, -0.17862014f, 0.17134617f, 0.10356338f, -0.04897556f, -0.09864365f, 
    -0.09829158f, 0.12854259f, 0.12240130f, 0.19956915f, 0.02798880f, 0.06123217f, 0.04435601f, -0.03440448f, 
    -0.16657040f, 0.01604931f, 0.04930637f, 0.22077531f, 0.19728772f, 0.01126172f, 0.10428945f, 0.02803694f, 
    -0.01111856f, 0.02993506f, 0.01912675f, -0.03883177f, -0.06599609f, 0.15980700f, 0.07002514f, 0.16387424f, 
    -0.00204287f, 0.01357864f, -0.15449855f, 0.04806817f, -0.23206680f, -0.02757846f, 0.15104768f, 0.04494398f, 
    -0.11020665f, -0.05259674f, 0.01023719f, 0.01637431f, -0.10280450f, 0.38797265f, -0.18511933f, 0.12595679f, 
    -0.15724871f, -0.27524424f, 0.07492135f, 0.00852055f, -0.18719365f, -0.03976033f, -0.01694607f, -0.15830162f, 
    -0.05190468f, -0.55266047f, -0.06188176f, 0.22957313f, -0.31791857f, 0.13187830f, 0.07429145f, -0.05328106f, 
    -0.14804897f, 0.16939178f, -0.14010766f, 0.04161981f, -0.96938217f, 0.34578732f, -0.12226491f, -0.04692851f, 
    -0.05437895f, 0.01922171f, 0.08234490f, -0.11205599f, -0.08753288f, -0.11969015f, -0.12696712f, -0.03544458f, 
    -0.17191494f, 0.29235736f, -0.21169575f, -0.17450427f, -0.03838980f, -0.12774082f, 0.20910554f, 0.06424764f, 
    -0.02947060f, -0.09672797f, 0.21101004f, -0.21090259f, 0.52316517f, 0.22786978f, -0.23293751f, 0.10716352f, 
    0.20580128f, -0.03577554f, 0.17105481f, 0.17822552f, -0.05506912f, 0.16485065f, 0.27838337f, 0.19555187f, 
    -0.38824329f, 0.17693615f, -0.05197704f, 0.10177786f, -0.03119232f, 0.02196614f, 0.02509472f, 0.04098473f, 
    0.01257641f, -0.04862447f, -0.01544235f, 0.06192475f, 0.10612840f, -0.08887029f, -0.18867077f, 0.46898741f, 
    0.02967274f, -0.01771166f, 0.14734340f, 0.27726158f, 0.12910879f, -0.16698579f, 0.12506136f, -0.08143129f, 
    -0.15775800f, 0.05288161f, 0.03355066f, 0.06680630f, 0.00819024f, 0.10612436f, 0.22711262f, 0.08905518f, 
    0.04559467f, 0.10638702f, -0.01533046f, 0.13983899f, 0.03040805f, -0.13757691f, 0.28775850f, 0.21068023f, 
    -0.12526943f, -0.08329228f, -0.14084093f, -0.24908547f, 0.16230507f, 0.15743506f, 0.05067414f, -0.24079403f, 
    -0.51165086f, -0.02134476f, -0.04189669f, -0.34039643f, 0.09739500f, 0.01224727f, -0.23990951f, 0.18183979f, 
    0.11534387f, -0.11441258f, 0.00312313f, -0.02516925f, 0.29691499f, 0.23041593f, -0.19664571f, 0.03090465f, 
    -0.15823123f, 0.21542674f, -0.03408672f, -0.00709017f, -0.02486135f, -0.05673590f, -0.02949939f, 0.14598410f, 
    -0.28894061f, -0.51351255f, 0.15754563f, 0.38707829f, -0.08861726f, -0.15232819f, 0.10626838f, 0.03311943f, 
    -0.20571102f, 0.25202546f, 0.18742530f, 0.19735427f, -0.50014317f, 0.26928103f, 0.36483586f, 0.06296220f, 
    -0.10402020f, 0.17662930f, -0.21151339f, 0.15852666f, 0.21689793f, -0.08017182f, -0.22724926f, -0.03956460f, 
    -0.51437718f, -0.21027096f, 0.09168687f, -0.04186387f, 0.06711904f, -0.08547933f, 0.06152752f, -0.01596502f, 
    -0.02327486f, -0.01514668f, -0.07212082f, -0.08504104f, 0.85756588f, -0.21052755f, -0.25318754f, -0.69352591f, 
    0.13795589f, 0.10047711f, -0.04073921f, 0.18344602f, 0.01830491f, -0.27964076f, -0.15844059f, 0.03285358f, 
    0.10169291f, 0.09443869f, -0.05913808f, -0.45733467f, 0.06118270f, -0.05047034f, -0.24342294f, -0.07180114f, 
    0.00854956f, -0.06606475f, -0.05034169f, 0.09117854f, 0.09445827f, -0.14590903f, 0.35660428f, 0.39459589f, 
    0.06428158f, 0.01391995f, -0.03460946f, 0.02306099f, 0.04491182f, 0.35615289f, 0.21765904f, 0.23969114f, 
    0.08712234f, -0.06499701f, 0.17970602f, 0.11034857f, -0.09351243f, -0.19261107f, -0.15028434f, -0.03109068f, 
    -0.02373268f, -0.06542939f, -0.10852643f, -0.03811837f, -0.54371017f, 0.12342986f, 0.16345671f, -0.40187457f, 
    -0.00177007f, -0.09082037f, -0.00343291f, 0.01323633f, 0.08317798f, -0.17022146f, -0.04954216f, -0.29822350f, 
    -0.21896033f, 0.15452799f, 0.20623535f, -0.17010807f, -0.00946204f, 0.08006384f, -0.13799845f, -0.04613963f, 
    0.24418455f, 0.03421987f, -0.14478511f, 0.31009921f, -0.09886225f, 0.10218174f, 0.24211518f, 0.12841535f, 
    -0.08482306f, 0.00968711f, 0.09954929f, -0.03183381f, -0.13522905f, -0.12243291f, -0.22523770f, -0.02409965f, 
    -1.04404914f, -0.10100678f, -0.41203287f, -0.38553724f, 0.31594431f, 0.00982451f, -0.14935754f, -0.00292757f, 
    -0.00763454f, 0.09513041f, -0.08656700f, 0.09776328f, -0.52468181f, -0.20033614f, -0.22068974f, 0.06923392f, 
    0.08416054f, -0.04214608f, -0.06822821f, 0.09991366f, 0.00112490f, 0.44128308f, 0.45056054f, 0.01214180f, 
    -0.77569336f, -0.34886909f, -0.03965943f, 0.00581472f, -0.00117476f, 0.07857110f, 0.09496029f, -0.14332262f, 
    0.09372570f, -0.47274029f, 0.08091344f, -0.01107519f, 0.00084503f, 0.24720931f, 0.05888758f, 0.00224563f, 
    -0.19716932f, -0.22098041f, -0.08930305f, 0.09409271f, 0.07838777f, -0.10202412f, 0.07315306f, 0.01864078f, 
    0.00018306f, -0.06141633f, 0.33648446f, 0.17299885f, 0.07904323f, 0.26900750f, 0.16853954f, -0.00499535f, 
    -0.16693364f, -0.01428783f, -0.15374190f, 0.13573205f, -0.08634322f, 0.02224200f, 0.00354673f, 0.00415777f, 
    0.06633593f, 0.25317696f, 0.03079249f, -0.24951495f, -0.00372310f, -0.13181214f, -0.35626584f, 0.15445785f, 
    0.60739923f, -0.13135111f, -0.33361185f, -0.03876387f, -0.01032907f, 0.30551296f, -0.50763571f, -0.21174619f, 
    0.04535967f, -0.05832705f, -0.09443378f, 0.00803043f, 0.25732109f, -0.06453953f, -0.22684892f, 0.09453460f, 
    -0.21559443f, 0.16347265f, 0.11267722f, -0.00867938f, -0.16555716f, 0.06968743f, 0.29754955f, 0.22396509f, 
    0.17468596f, -0.06511204f, -0.10616875f, -0.19693883f, -0.06684704f, 0.06323784f, 0.08097877f, 0.13028249f, 
    0.43431923f, -0.21956638f, -0.09926479f, -0.00049652f, -0.21155372f, -0.04474535f, 0.22136228f, 0.50612402f, 
    -0.00345521f, -0.04375401f, -0.02024582f, 0.36318940f, -0.05860583f, 0.01069885f, 0.15131897f, -0.11925045f, 
    -0.81453699f, -0.04618743f, -0.15375173f, 0.26865634f, -0.08187424f, 0.20688930f, 0.07566876f, 0.24985141f, 
    0.03465267f, -0.18919115f, -0.08458472f, -0.03688713f, -0.03528080f, -0.08364799f, 0.21586256f, 0.11910642f, 
    0.02707691f, -0.15460819f, -0.10451800f, -0.03494691f, 0.04657752f, -0.24520734f, -0.31400922f, -0.37424323f, 
    -0.23030375f, 0.24586296f, -0.51260728f, -0.24703848f, -0.05797740f, 0.08759096f, -0.15430684f, -0.01519211f, 
    -0.11301906f, 0.03847190f, -0.04296625f, 0.02460404f, 1.17465258f, -0.05831646f, 0.55306083f, -0.22289678f, 
    -0.11703046f, 0.04626145f, -0.00953047f, -0.01373400f, 0.16048537f, -0.03735244f, 0.17835419f, 0.08320885f, 
    0.40171042f, -0.10571687f, 0.22677335f, -0.19424775f, 0.14573711f, 0.03442946f, -0.06787064f, 0.08758359f, 
    -0.09436223f, 0.00895524f, -0.11435004f, -0.25898021f, -0.17690942f, -0.05031325f, 0.22034682f, -0.22221354f, 
    -0.31657803f, 0.05035861f, -0.01760557f, 0.22389375f, 0.05284288f, -0.15708701f, 0.02789079f, 0.17861909f, 
    -0.60725117f, -0.42794475f, -0.18145649f, -0.35750401f, 0.02506951f, 0.07913171f, 0.13128389f, -0.06795677f, 
    0.02208415f, -0.24656028f, 0.16897419f, 0.10670698f, -0.15705466f, 0.18346569f, -0.09233589f, -0.47444925f, 
    -0.13078734f, -0.02738738f, 0.01179693f, 0.02118828f, 0.09623374f, -0.17962183f, -0.09899171f, -0.07993062f, 
    0.37569728f, -0.13949117f, -0.15237163f, -0.12385868f, -0.23810942f, 0.18244272f, -0.25868440f, 0.06877668f, 
    -0.34189656f, 0.34527650f, -0.10367618f, 0.10589731f, -0.19546311f, 0.15172805f, 0.23260230f, -0.35213551f, 
    0.23756039f, 0.07994824f, 0.03193682f, -0.06439744f, -0.14441296f, -0.05291182f, 0.22625697f, 0.00581474f, 
    0.21378256f, 0.10185347f, 0.06992374f, -0.07454170f, -0.30188194f, -0.21062303f, 0.00924962f, 0.15851444f, 
    0.19384435f, 0.20035507f, 0.06238535f, 0.20942593f, 0.02432860f, 0.29865876f, 0.29498187f, 0.04538950f, 
    -0.09963813f, -0.09675584f, 0.06830256f, -0.09947567f, 0.14688841f, 0.09584343f, 0.12087210f, -0.02628296f, 
    -0.68121636f, -0.12994368f, -0.54790407f, 0.28313115f, 0.18628252f, -0.19217521f, 0.02442009f, -0.14324996f, 
    0.17666633f, -0.06848326f, 0.06407395f, 0.11715742f, 0.17654842f, 0.33200362f, 0.31522146f, -0.71577692f, 
    0.13645883f, -0.12403787f, 0.14750992f, 0.02099231f, -0.07956741f, 0.05033167f, -0.00904053f, -0.19267593f, 
    0.12156441f, -0.10930409f, -0.20956777f, -0.16787505f, -0.00790091f, -0.02242089f, -0.02473510f, -0.04183831f, 
    0.02118460f, 0.12540720f, 0.08493074f, 0.19738363f, 0.09338183f, 0.14356948f, 0.26648808f, 0.36783296f, 
    -0.07519869f, -0.18223229f, -0.09716159f, -0.24392165f, -0.06052026f, 0.03043010f, 0.06384119f, 0.04618538f, 
    -0.41441184f, 0.30145770f, -0.16750820f, -0.09330051f, -0.27979353f, 0.26993331f, -0.00162123f, 0.09062303f, 
    0.05381109f, 0.06290201f, 0.08058398f, -0.08561400f, 0.33543795f, -0.37559533f, 0.45675808f, 0.36269766f, 
    0.14379145f, -0.02799833f, -0.06162154f, 0.00356770f, -0.18434362f, -0.03372102f, -0.23214588f, -0.05589475f, 
    0.14509048f, 0.06310631f, -0.19924940f, 0.07982282f, -0.11483826f, -0.25489405f, -0.53576362f, -0.03394160f, 
    -0.14334209f, 0.06983350f, -0.07557807f, -0.24700916f, 0.87510586f, 0.28280544f, -0.21092451f, -0.44847533f, 
    -0.25578469f, 0.06562655f, -0.21978684f, -0.10591155f, -0.22128317f, 0.05591701f, -0.14220910f, 0.10432118f, 
    -0.11904794f, -0.53523660f, -0.07070659f, -0.05000285f, -0.00173846f, 0.05601028f, -0.11584784f, -0.33406192f, 
    0.04245649f, -0.04086603f, 0.01423897f, -0.03680350f, 0.16994967f, 0.40071300f, -0.18520406f, 0.02456503f, 
    -0.05073922f, 0.03679991f, -0.04334716f, -0.32821831f, -0.01461044f, -0.10028520f, -0.20430048f, 0.04767231f, 
    0.41057903f, 0.00149437f, 0.52541333f, -0.01432686f, 0.16585591f, 0.04490115f, 0.02138133f, -0.15110868f, 
    -0.13701168f, 0.19648261f, 0.01514013f, 0.01945107f, -0.27535513f, 0.25335017f, 0.09765641f, 0.25541517f, 
    0.00321724f, -0.19000234f, -0.25866944f, -0.18904734f, 0.02147981f, -0.34056321f, -0.12808566f, -0.09930608f, 
    -0.04883156f, 0.43502808f, 0.25131270f, 0.43114090f, 0.38560620f, 0.02211383f, 0.07550322f, 0.19228509f, 
    -0.10416032f, 0.16978194f, 0.22017671f, 0.00787259f, -0.33409461f, -0.10013203f, -0.33981135f, -0.27943167f, 
    -0.19756897f, -0.05235535f, -0.01171785f, -0.01090436f, -0.31911185f, -0.15626656f, 0.04470469f, -0.09775800f, 
    -0.30312744f, -0.22635643f, -0.35684747f, -0.31661859f, 0.05478059f, 0.08600987f, -0.01721118f, -0.25247985f, 
    -0.23536685f, -0.15166499f, 0.08209129f, -0.09877037f, 0.29817396f, 0.15577805f, -0.11512737f, 0.17925306f, 
    -0.13181013f, 0.02784789f, -0.05757085f, -0.16067958f, -0.03024927f, -0.03241049f, 0.11738110f, -0.18775919f, 
    0.14164263f, 0.35384095f, 0.00957588f, 0.22372875f, 0.23810954f, 0.07998914f, 0.14566253f, 0.02883459f, 
    0.17516680f, 0.18213877f, 0.01168561f, -0.16269507f, -0.55530888f, -0.13138932f, -0.22798683f, 0.14620581f, 
    -0.31143099f, -0.12076008f, -0.07443764f, -0.16969986f, -0.09423978f, -0.02699379f, -0.04138598f, -0.23642524f, 
    -0.22687379f, 0.11157946f, -0.25540259f, 0.21938692f, -0.38237378f, 0.01553226f, -0.07164806f, -0.20881079f, 
    -0.14678816f, 0.17884040f, -0.24222656f, -0.10825408f, 0.31510618f, 0.23841977f, -0.13881133f, 0.56355196f, 
    0.18419233f, -0.18927838f, 0.13989992f, -0.15093109f, -0.00306930f, -0.13984418f, -0.04000507f, 0.04629686f, 
    0.21048731f, 0.19686343f, 0.17690966f, 0.09190986f, 0.07877686f, 0.03545276f, -0.06789734f, -0.08251382f, 
    0.00622406f, -0.09381534f, -0.03301329f, -0.15241602f, 0.01183860f, 0.17066176f, -0.26180688f, 0.07063536f, 
    0.27969325f, -0.12220101f, -0.22111599f, 0.00810662f, -0.01128363f, 0.03069078f, 0.16395907f, 0.24046199f, 
    -0.37458992f, 0.07755645f, -0.27249163f, -0.74990386f, 0.17454760f, -0.20274997f, -0.08496545f, 0.24660456f, 
    0.22289369f, 0.02807682f, -0.17221983f, -0.25118691f, -0.36150670f, -0.09777491f, 0.11800655f, -0.12888367f, 
    0.26185215f, -0.21918996f, -0.18075229f, 0.02053208f, -0.09307309f, 0.05331779f, -0.03293940f, -0.01856089f, 
    0.08909715f, 0.01024899f, -0.06620755f, 0.44923273f, 0.07410955f, -0.03146876f, -0.02644998f, 0.00635747f, 
    -0.07139466f, 0.02056711f, -0.02309761f, 0.36373210f, 0.03313280f, 0.07450476f, 0.02059562f, 0.29015025f, 
    0.09789308f, -0.13874246f, -0.36153066f, -0.08684537f, 0.09152130f, -0.09722177f, 0.11070435f, -0.52145922f, 
    -0.37964761f, -0.00836547f, 0.40934291f, -0.13118824f, -0.13273947f, 0.03206654f, -0.00406692f, -0.20022783f, 
    0.05581941f, 0.01147672f, 0.00546089f, 0.02487109f, -0.46514305f, 0.42914638f, 0.11084351f, -0.20016678f, 
    0.18138896f, 0.16881624f, -0.25302961f, -0.13064358f, 0.02445545f, 0.15211828f, 0.19798619f, -0.16652051f, 
    -0.14223112f, -0.32444775f, 0.29214460f, -0.05808629f, -0.19737810f, -0.04344562f, 0.27509338f, -0.17626238f, 
    0.06096532f, -0.06518106f, 0.23532376f, -0.20833680f, 0.02727982f, 0.05611190f, -0.20213673f, -0.14367393f, 
    0.11407492f, 0.18583758f, 0.02155393f, -0.11760476f, 0.21753161f, 0.20543353f, -0.09506480f, -0.06477481f, 
    0.25646541f, 0.10322650f, -0.05022158f, 0.40877894f, 0.16690448f, -0.11252978f, -0.17700344f, -0.26886648f, 
    0.05129090f, 0.01619475f, -0.06112082f, -0.00858624f, -0.37711471f, -0.62018263f, 0.15769447f, -0.34145954f, 
    0.11552245f, -0.19750451f, -0.11741637f, -0.09240464f, -0.16716509f, -0.05842460f, -0.03133782f, 0.26756772f, 
    -0.24253964f, 0.53750259f, -0.01844612f, 0.34354982f, -0.29881462f, 0.42906111f, -0.37709439f, -0.06258915f, 
    -0.04348798f, -0.18580440f, -0.08839690f, 0.06115703f, -0.48952055f, -0.50719124f, -0.02055058f, 0.16451970f, 
    -0.05123968f, -0.13886800f, -0.05403864f, 0.03743865f, 0.03194296f, 0.23806298f, 0.17806384f, 0.11279302f, 
    -0.21286273f, 0.48768982f, -0.17582859f, 0.02592548f, -0.31815577f, 0.08796570f, -0.29594186f, -0.20167284f, 
    0.07067966f, -0.06677738f, 0.13984491f, 0.02312434f, 0.02650508f, -0.09164872f, -0.05952025f, -0.77565277f, 
    0.07857528f, -0.09349057f, 0.01357233f, 0.07850321f, 0.17317647f, 0.05286194f, 0.01544683f, -0.01477954f, 
    -0.69679278f, 1.00150836f, 0.26361319f, 0.08034161f, 0.02753119f, 0.23429295f, 0.21713182f, -0.16932188f, 
    -0.00140190f, 0.18611953f, 0.11269354f, -0.05850464f, 0.40572348f, -0.76196831f, 0.11866822f, -0.57321078f, 
    -0.18861219f, 0.10287943f, -0.19320470f, 0.05854039f, -0.30641714f, -0.27198705f, 0.01059907f, -0.37120450f, 
    -0.12830299f, -0.16009243f, 0.43207222f, -0.00333280f, -0.01705293f, 0.07074508f, 0.01807126f, -0.21314029f, 
    -0.02233897f, 0.04822710f, 0.16089562f, 0.01901847f, -0.25202933f, 0.02327774f, 0.12060951f, -0.01275878f, 
    0.13229036f, -0.02021568f, -0.00138295f, 0.02841122f, 0.00464543f, 0.12495545f, 0.23044614f, 0.36119878f, 
    0.19406098f, 0.18908779f, -0.32861453f, -0.02493845f, 0.31201851f, -0.05316124f, 0.07316369f, -0.23834199f, 
    -0.08757919f, -0.22213456f, -0.08217384f, -0.14941606f, -0.17370598f, 0.29271841f, -0.63011938f, -0.28763992f, 
    0.08470005f, -0.13453093f, -0.11557090f, 0.01201172f, -0.11273011f, 0.22205403f, -0.06713331f, 0.08331635f, 
    0.21780734f, -0.60475183f, -0.20748833f, 0.33591810f, -0.09120246f, 0.16725385f, -0.17720596f, 0.15761811f, 
    -0.10286877f, 0.22514381f, -0.12091224f, -0.16877636f, -0.16498572f, -0.20423704f, -0.09434970f, -0.13347431f, 
    0.15925525f, 0.13397524f, 0.05764963f, -0.31415939f, -0.16998562f, -0.16687183f, -0.28342184f, 0.02074218f, 
    -0.21596542f, -0.60389268f, -0.04102235f, 0.04916854f, 0.27714866f, -0.13068792f, -0.16354913f, -0.07110199f, 
    0.08684433f, 0.12420721f, -0.02738475f, 0.15615712f, -0.05026076f, -0.12394381f, -0.18289633f, 0.06888911f, 
    -0.10404035f, 0.16066742f, 0.36863261f, 0.16886272f, -0.08811394f, -0.19950424f, -0.17116390f, -0.03107956f, 
    -0.22565052f, 0.25655755f, -0.13956876f, -0.53125924f, 0.34775814f, 0.08446758f, 0.00449254f, 0.00539747f, 
    -0.26296586f, 0.09196866f, 0.14544232f, -0.16823573f, -0.46198747f, 0.12448557f, 0.27152932f, 0.17222343f, 
    -0.14693794f, -0.15189019f, 0.09692710f, -0.04873645f, -0.17604588f, -0.12776379f, 0.14584580f, -0.02415911f, 
    0.02488140f, -0.30639139f, 0.18578765f, -0.25948220f, -0.03647486f, 0.02794746f, 0.10272866f, 0.37267837f, 
    -0.00977155f, 0.01788921f, -0.03870726f, 0.08980785f, -0.14379045f, 0.39132357f, -0.35796401f, -0.79747128f, 
    0.00008899f, 0.00578962f, -0.10631355f, 0.05899670f, -0.06769805f, 0.23913488f, -0.18718843f, -0.05571903f, 
    -0.58012092f, 0.79848045f, 0.01701873f, 0.43629649f, 0.24152941f, 0.02140351f, -0.14895207f, 0.13739267f, 
    -0.04665114f, 0.21730879f, 0.06764903f, -0.05059064f, -0.20947538f, -0.19185817f, 0.36499983f, 0.22771858f, 
    0.11741892f, -0.02722544f, 0.06255879f, -0.14041455f, 0.14140128f, 0.13535753f, 0.05029612f, 0.24043994f, 
    -0.73794889f, -0.93967837f, -0.00231689f, 0.04084627f, 0.28590792f, 0.07900136f, 0.21867037f, 0.02336364f, 
    0.39737657f, -0.08076821f, 0.07267000f, 0.16632093f, -0.68803215f, 0.17753233f, -0.37328076f, -0.25349376f, 
    0.20407167f, -0.00346184f, -0.16242646f, 0.06750680f, 0.04442233f, 0.21828434f, 0.01405882f, 0.14631516f, 
    0.35575300f, 0.09346980f, 0.30406079f, 0.10628857f, 0.25362498f, 0.27355447f, 0.05459848f, 0.15526982f, 
    -0.01359507f, 0.12810849f, 0.03651946f, -0.03976033f, -0.15038945f, -0.29980117f, -0.27609393f, 0.12098085f, 
    0.10776584f, -0.17550547f, -0.05276348f, -0.04522413f, -0.13176869f, -0.19892621f, -0.09040828f, -0.07947709f, 
    -0.27297816f, -0.38173684f, -0.26185656f, -0.11595851f, -0.09987477f, 0.01481852f, -0.01462582f, 0.21029486f, 
    0.02150589f, 0.22022161f, 0.11347862f, 0.17640570f, -0.55021322f, 0.10139681f, -0.14489685f, -0.69131899f, 
    0.14529656f, -0.00185127f, -0.34987339f, 0.10034794f, -0.10501637f, -0.19353049f, -0.38530374f, -0.60991341f, 
    0.30865353f, -0.08706159f, -0.12562706f, 0.04481899f, -0.15073200f, 0.10207258f, 0.01205464f, 0.11642085f, 
    0.00543684f, 0.08143438f, -0.02208661f, 0.03718744f, 0.54748923f, -0.01827788f, -0.08213802f, -0.13464202f, 
    0.11924491f, 0.17559829f, 0.06319394f, 0.12086683f, -0.21582282f, 0.22324835f, -0.04256973f, 0.14255318f, 
    0.24652216f, 0.36276454f, -0.36779237f, 0.11477971f, -0.39622971f, -0.31786844f, 0.06662673f, -0.25971866f, 
    -0.02662009f, -0.03727194f, 0.18503848f, -0.25772578f, -1.46589994f, -0.09000523f, 0.16794243f, -0.14515245f, 
    0.17732377f, 0.15443322f, 0.03118038f, -0.18808547f, 0.20983557f, 0.22560579f, 0.14571248f, 0.42944303f, 
    -1.08455729f, -0.29751748f, -0.11615248f, -0.50110650f, 0.11672521f, 0.11661144f, -0.06885308f, -0.09325905f, 
    -0.14363234f, 0.13675933f, -0.04158204f, 0.22337106f, -0.02127176f, -0.25210053f, 0.14809571f, 0.12180837f, 
    0.11953472f, -0.01537807f, 0.03736434f, 0.04579165f, 0.15813829f, -0.07326775f, -0.08760094f, 0.34288424f, 
    0.16177575f, -0.08119614f, -0.02447360f, -0.11047660f, -0.27319247f, 0.08236193f, -0.04666799f, -0.26579571f, 
    0.02328611f, -0.31674474f, -0.34231803f, -0.10749008f, 0.09805682f, 0.09257769f, 0.00798508f, -0.23814009f, 
    0.26073906f, -0.22803386f, 0.01706749f, 0.26637912f, 0.00909239f, 0.08263899f, 0.40932274f, 0.04321470f, 
    0.07830708f, 0.12707278f, -0.18730482f, 0.18050493f, -0.04277128f, -0.09714436f, 0.29521134f, 0.01987450f, 
    0.15649696f, -0.23232061f, 0.16503763f, -0.07362452f, 0.00131518f, -0.16759661f, -0.13114631f, -0.20954315f, 
    -0.07437764f, 0.29852507f, 0.27848613f, -0.01391450f, 0.01083884f, 0.18498300f, -0.04281502f, -0.31637385f, 
    -0.25256670f, -0.13541827f, 0.09464446f, 0.08254502f, 0.12315921f, 0.04424782f, 0.12623410f, -0.03094805f, 
    0.09179944f, -0.04717883f, -0.08955138f, -0.03986013f, 0.04443516f, -0.17153607f, -0.24331734f, 0.58583057f, 
    -0.08035541f, 0.05859393f, -0.00490231f, 0.17437170f, 0.10063284f, -0.19230029f, 0.04760335f, 0.01484846f, 
    0.45427537f, 0.47894415f, -0.47276136f, 0.19985591f, 0.02327794f, 0.01053351f, -0.18744738f, 0.02864837f, 
    0.27659917f, 0.06681439f, 0.15857625f, 0.22597246f, -0.49858460f, 0.09502226f, -0.32818890f, -0.20048594f, 
    0.38284507f, -0.15296915f, 0.04030554f, -0.07260709f, -0.01130198f, -0.03316114f, 0.25385770f, 0.03170181f, 
    0.06429538f, -0.46946087f, 0.17004962f, -0.23691785f, 0.07414057f, -0.16721623f, -0.04478948f, -0.06025821f, 
    -0.10167108f, -0.08572815f, -0.14507297f, 0.06602705f, -0.18735251f, -0.55764693f, 0.29012558f, -0.55947900f, 
    0.13703297f, -0.13842234f, -0.03520620f, -0.06983319f, 0.07067051f, 0.08604179f, 0.17531042f, 0.15206249f, 
    -0.50905442f, 0.38994601f, 0.19106977f, 0.14433350f, -0.12176144f, -0.01288225f, 0.15052211f, -0.18016240f, 
    -0.03512867f, -0.08792239f, 0.27136540f, -0.33950490f, 0.45550951f, 0.15499347f, -0.23505382f, 0.15204006f, 
    -0.09970566f, 0.04382236f, -0.24319796f, 0.11245520f, -0.00240992f, -0.03759092f, -0.17038123f, 0.19123010f, 
    0.18246002f, -0.53452629f, 0.01395326f, 0.00386863f, -0.18714127f, 0.23249193f, -0.06843089f, -0.00907397f, 
    -0.12320039f, -0.00585247f, -0.16107972f, 0.01884801f, 0.22264291f, 0.35176221f, -0.28412130f, -0.04153587f, 
    0.13909221f, -0.08546779f, 0.08968159f, 0.04173006f, -0.01293190f, -0.00280430f, -0.08541660f, -0.12368464f, 
    0.73907202f, -0.43936658f, -0.48720056f, -0.20271371f, 0.06171413f, -0.05728665f, -0.00237127f, -0.02730932f, 
    0.24864015f, 0.06242291f, 0.13325493f, 0.05534424f, 0.19426373f, 0.11363934f, 0.16147475f, -0.72807604f, 
    0.06534810f, -0.11591765f, 0.06350339f, 0.27373818f, -0.25997612f, 0.16795737f, 0.10203244f, -0.08600307f, 
    0.04133205f, 0.18094365f, -0.20284744f, 0.08602668f, -0.27629015f, -0.19098467f, 0.06646418f, -0.21089506f, 
    0.01143049f, 0.13080536f, 0.03293121f, -0.25327483f, 0.04283844f, -0.26332539f, -0.20505252f, 0.22688577f, 
    -0.11605656f, -0.08694106f, -0.01642651f, -0.03053528f, 0.13227548f, -0.10464247f, -0.05962649f, 0.09188741f, 
    0.03691291f, -0.37155318f, -0.38535944f, 0.04538111f, 0.15856597f, -0.05881752f, 0.06753722f, 0.00371879f, 
    -0.16889554f, 0.13388760f, 0.07729374f, 0.07479375f, -0.36027265f, 0.13782965f, -0.06198329f, 0.04720890f, 
    -0.19868168f, 0.07818550f, -0.11250191f, -0.25333771f, 0.01872754f, -0.01734070f, 0.08196811f, -0.10289481f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.21837851f, 0.02815920f, -0.15131120f, 0.05792532f, -0.01422247f, -0.01458098f, 0.00708823f, -0.12538300f, 
    -0.07469147f, -0.01557511f, 0.21450509f, 0.03822612f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
