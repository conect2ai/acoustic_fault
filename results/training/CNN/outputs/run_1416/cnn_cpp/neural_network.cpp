#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    1.03553522f, 0.01579777f, -0.10875605f, 0.01858651f, 0.37438935f, 0.09199654f, 0.32316533f, 0.51979297f, 
    0.45800468f, -0.37625584f, -0.27971017f, -0.46505657f, -0.50391942f, -0.34710851f, -0.76057124f, 0.17537661f, 
    0.78031886f, -0.08765721f, -0.48180029f, 0.75039983f, 0.29653564f, 0.21971346f, -0.09512046f, 0.14958999f, 
    -0.13388614f, -0.56489205f, -0.13775331f, -0.00070912f, -0.29316628f, -0.08603874f, -0.63637829f, 0.62837267f, 
    -0.85805070f, -0.06140883f, -0.41866583f, -0.09223960f, -0.32385415f, 0.43669033f, -0.17355971f, 0.01400991f, 
    -0.66123420f, -0.57285714f, 0.47544432f, 0.31409365f, 0.59076375f, -0.08203354f, 0.79758853f, -0.75932497f, 
    -0.79356956f, -0.72704387f, 0.06652125f, -0.36007553f, 0.09224556f, -0.26693204f, -0.28809026f, -0.70924264f, 
    -0.24534059f, -0.06837558f, 1.07755315f, -0.65293837f, -0.31738460f, -0.14634477f, -0.22032063f, 0.36395216f, 
    0.31255734f, 0.71917105f, 0.62766254f, -0.97210902f, 0.01151084f, -0.25478375f, 0.10388344f, -0.03606353f, 
    -0.86957514f, 0.12833840f, -1.14080453f, -0.39324579f, 0.54739249f, 0.25974363f, 0.07974469f, 0.56287348f, 
    0.18109554f, 1.03409839f, -0.76489598f, 0.59917659f, -0.35749587f, -0.11039753f, 0.17479593f, 0.48673049f, 
    -0.14706267f, -0.14465789f, -0.12898785f, 0.45937106f, 0.50909311f, -0.35211813f, 0.14673907f, 0.80283624f, 
    -0.02619691f, -0.43616989f, -0.44823334f, -0.91978604f, -0.35835660f, 0.43108445f, 0.16082399f, 0.31684732f, 
    -0.91946185f, 0.24303113f, -0.11678562f, -0.28127071f, 0.18621728f, -0.09711673f, -0.46665353f, 0.31335330f, 
    0.64630109f, 0.62184185f, -0.33142662f, 0.90835834f, -0.50246876f, 0.36423114f, 0.38877138f, 0.68540907f, 
    -0.83549088f, -0.40071306f, 0.44681612f, 0.09327544f, 0.33343670f, 0.33059305f, -0.46742749f, -0.33922485f, 
    0.01738361f, 0.76402771f, 0.30652300f, 0.31159070f, -0.45923099f, -0.50580263f, -0.26779267f, -0.52633446f, 
    -0.18351375f, -0.37271935f, -0.21213047f, -0.66731292f, -0.49254951f, -0.43064347f, -0.58782881f, -0.41702193f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.36052153f, -0.20204209f, 0.19716579f, 0.47984529f, 0.08136156f, 0.00662947f, -0.40271831f, 0.06682174f, 
    0.68237895f, 0.06833715f, 0.08037662f, 0.57637596f, 0.26060179f, 0.48562041f, -0.03655173f, -0.11765555f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.08608233f, 0.05530177f, -0.22180969f, 0.11243284f, 0.08254584f, 0.03292745f, 0.01233517f, 0.27391598f, 
    -0.08186816f, -0.10401058f, -0.08889919f, 0.32350007f, -0.14932704f, 0.08491565f, -0.08021874f, 0.09232095f, 
    -0.14873044f, -0.00821962f, -0.39250806f, 0.12582880f, 0.04868438f, 0.22099902f, -0.09175559f, -0.26264155f, 
    0.01046295f, -0.00010786f, -0.24846727f, 0.13478011f, 0.10132822f, -0.06171065f, 0.05879216f, -0.05165930f, 
    0.10625183f, 0.24820100f, 0.20559561f, 0.15483873f, 0.08342240f, 0.22342212f, -0.01238385f, -0.19168635f, 
    0.02715194f, 0.05638335f, -0.00674826f, -0.19169977f, -0.01141168f, -0.22664484f, -0.02439467f, -0.02961621f, 
    -0.11608616f, 0.14886364f, -0.18325776f, 0.20916599f, 0.02124306f, -0.14042291f, 0.46179458f, -0.23485734f, 
    -0.18634216f, 0.04343884f, -0.22368833f, 0.17899325f, 0.14244242f, 0.06435499f, 0.19436416f, -0.30371526f, 
    -0.43594807f, 0.20008770f, -0.01301560f, 0.08248394f, -0.05549125f, -0.00716398f, 0.05471171f, 0.12240744f, 
    -0.02332980f, -0.13118652f, -0.02363331f, -0.09550829f, 0.16880275f, 0.33784640f, 0.09510190f, 0.00405677f, 
    0.01629654f, -0.25838488f, 0.08531839f, -0.24268274f, 0.15152659f, 0.15526493f, -0.27006251f, -0.27042419f, 
    0.13610207f, 0.15961826f, -0.22860979f, -0.10944783f, 0.07868296f, 0.05774053f, 0.06920624f, -0.26681679f, 
    -0.14046785f, 0.05354650f, 0.01783790f, 0.41936162f, 0.47087374f, 0.24875446f, 0.18743786f, -0.17869321f, 
    0.08617326f, 0.00928667f, 0.11872224f, 0.15184747f, 0.11691350f, 0.02472008f, -0.22609271f, 0.00547726f, 
    -0.17838690f, -0.25774020f, 0.06136459f, 0.12490160f, 0.15413453f, 0.20282975f, -0.02010641f, -0.02089777f, 
    0.16070880f, 0.07068643f, -0.04643797f, 0.03511782f, 0.12319735f, 0.17463754f, 0.13051678f, 0.09381630f, 
    0.22176497f, 0.11487185f, 0.02074880f, -0.15221429f, 0.01912180f, -0.25623038f, 0.02035899f, 0.28508213f, 
    -0.02373214f, 0.06012390f, 0.06917282f, 0.12180854f, 0.08183184f, 0.12040602f, -0.09961392f, -0.01018787f, 
    -0.06787760f, -0.01963516f, 0.00020688f, 0.02035345f, -0.00247644f, -0.08212578f, 0.02998951f, -0.03583789f, 
    -0.07177929f, 0.01743163f, 0.04639591f, 0.02099415f, -0.07362691f, -0.07522136f, -0.04665544f, -0.04396010f, 
    0.04963434f, -0.07828229f, -0.06641543f, -0.02876327f, 0.01022454f, 0.02624720f, -0.06003368f, -0.05682243f, 
    -0.07355276f, -0.07657200f, -0.03026006f, 0.01118677f, 0.03913142f, -0.07389031f, 0.01543721f, 0.03657211f, 
    -0.01717783f, -0.07906888f, 0.02292127f, -0.01219926f, 0.06228635f, 0.02080202f, 0.01371677f, -0.05138762f, 
    0.00041619f, -0.03381222f, -0.03448298f, -0.07381478f, 0.03569423f, -0.06408431f, -0.00651390f, 0.01286541f, 
    0.04440264f, -0.09101968f, 0.04489132f, 0.06637888f, -0.06238161f, -0.00406574f, -0.02047118f, -0.08835891f, 
    0.01842828f, 0.05855840f, 0.06347330f, -0.04195436f, 0.01549415f, 0.01883081f, 0.05314773f, 0.00393819f, 
    0.05313226f, -0.04316354f, 0.04412769f, -0.00561013f, 0.00384239f, 0.01477498f, 0.03795613f, 0.05559377f, 
    -0.01080612f, 0.03241728f, 0.00033099f, -0.05685696f, 0.01980906f, 0.03201953f, -0.02264087f, -0.00425853f, 
    0.01461043f, 0.03240179f, 0.06888174f, -0.06542283f, -0.08819810f, -0.07099000f, 0.03436515f, -0.04347492f, 
    -0.00950622f, 0.06603120f, -0.06534357f, 0.02872356f, 0.00144386f, -0.07372481f, 0.02158272f, -0.07202849f, 
    -0.08342701f, -0.08952109f, 0.02300568f, -0.05325729f, 0.02305135f, -0.06191370f, 0.04497720f, -0.03076084f, 
    0.01959117f, 0.04861106f, -0.06830728f, -0.02971110f, -0.01456679f, -0.00544622f, -0.08002669f, -0.06809347f, 
    0.00978865f, -0.01690389f, -0.06237592f, -0.04554499f, -0.01018845f, -0.08468141f, 0.03874383f, -0.01405739f, 
    -0.05053703f, 0.06399314f, -0.03784085f, -0.05909188f, 0.07293059f, 0.03366453f, -0.00653055f, 0.02224796f, 
    -0.06665982f, -0.01421430f, -0.07186130f, 0.06450258f, -0.00754150f, 0.04685345f, 0.03606011f, 0.04918604f, 
    -0.05591813f, 0.04027639f, 0.04475000f, -0.01306648f, 0.03279217f, -0.08077582f, -0.06172819f, 0.01518723f, 
    0.01248152f, -0.10380264f, -0.25718224f, 0.12070456f, 0.00123865f, 0.20781714f, 0.10584834f, 0.25500593f, 
    0.03106805f, 0.32793036f, 0.24545804f, 0.13505395f, -0.11907973f, 0.11875538f, -0.09907505f, 0.12750964f, 
    0.07738122f, -0.12683818f, -0.75125241f, -0.83833241f, -0.48450109f, -0.11723287f, -0.10056807f, -0.14325811f, 
    -0.10262923f, 0.10624599f, -0.21004070f, 0.18400219f, -0.19698398f, 0.04274762f, -0.09873219f, -0.07104273f, 
    0.11199174f, 0.09185266f, 0.15039484f, -0.09493470f, 0.11189067f, -0.03545990f, -0.08774545f, -0.04691575f, 
    -0.11828939f, -0.16367410f, -0.03055956f, 0.07709815f, 0.03664942f, -0.34855902f, -0.01819928f, -0.15563874f, 
    -0.15786432f, 0.02849416f, -0.14845182f, -0.22731030f, -0.06242958f, -0.00065819f, 0.37304053f, -0.45407614f, 
    0.17456722f, 0.16241854f, -0.15293741f, 0.29224768f, 0.18917154f, 0.08750010f, 0.12723133f, -0.07064755f, 
    -0.81517524f, -0.12811555f, -0.12291513f, -0.11257342f, -0.07219964f, -0.05095429f, -0.05989052f, -0.08441200f, 
    -0.14001504f, -0.02063192f, -0.18833183f, -0.10372801f, 0.18842115f, 0.16480787f, 0.06970198f, 0.17266820f, 
    -0.02566829f, -0.21540600f, -0.27222121f, -0.22282653f, -0.29351300f, 0.12359168f, 0.08096997f, 0.02204135f, 
    -0.01166551f, 0.03214033f, -0.42383102f, -0.14236283f, 0.08153652f, -0.30597013f, -0.12580660f, -0.25470823f, 
    0.17053080f, -0.10951892f, 0.09744046f, 0.27723244f, -0.20299068f, 0.15270238f, -0.10071168f, 0.05542282f, 
    -0.12642094f, 0.18093187f, -0.10019497f, 0.01435073f, 0.37985715f, -0.31366232f, -0.03177692f, 0.02653260f, 
    -0.02474961f, 0.07787549f, -0.10903677f, 0.04648193f, -0.15166259f, -0.06505627f, 0.02623923f, 0.30590937f, 
    -0.37049285f, 0.14385211f, -0.11773803f, -0.01586130f, 0.03345353f, 0.17644690f, -0.14757732f, -0.00846131f, 
    0.44245237f, -0.12719621f, -0.03415451f, 0.20264125f, 0.21807255f, 0.12372261f, -0.04923483f, 0.25835469f, 
    0.40911064f, 0.23215729f, 0.11694884f, 0.17416252f, -0.12991579f, 0.08682397f, 0.06018489f, -0.00174055f, 
    0.09827122f, -0.20312639f, -0.00920060f, 0.08623069f, 0.08283661f, 0.08792244f, -0.06150195f, 0.00009728f, 
    0.16272965f, -0.54798293f, -0.03553259f, -0.06806595f, -0.02986044f, 0.10888796f, -0.46384996f, 0.00926645f, 
    0.04147517f, 0.11755424f, 0.10904172f, 0.08946741f, -0.20736203f, -0.02573335f, -0.33745500f, 0.03858936f, 
    0.03396547f, 0.07764442f, 0.03724765f, -0.17444021f, -0.02735439f, 0.56297934f, 0.15307704f, 0.08196189f, 
    -0.05755951f, -0.12748344f, 0.01176263f, 0.02281325f, -0.22232072f, -0.10241924f, -0.18752518f, -0.03168595f, 
    0.06061335f, -0.06939325f, 0.31680518f, 0.05378320f, 0.09667540f, -0.14606293f, -0.31394321f, -0.38770190f, 
    -0.30808383f, -0.21012159f, 0.01938469f, 0.06286623f, 0.07386424f, 0.08938678f, -0.53127927f, -0.24188581f, 
    0.52698493f, 0.12378959f, 0.13069458f, -0.12752344f, -0.04513437f, -0.23591733f, -0.16442905f, -0.17825115f, 
    0.06976879f, 0.30657899f, -0.01174949f, 0.09630147f, -0.43426687f, 0.13655436f, 0.05838230f, 0.22335985f, 
    -0.09342701f, 0.08312565f, 0.17502600f, 0.13138798f, 0.15685014f, 0.02084768f, 0.17085345f, 0.23354989f, 
    0.06390547f, 0.26145428f, 0.55173111f, 0.35788250f, -0.06450811f, -0.09209836f, 0.05243223f, -0.18106550f, 
    -0.09316336f, 0.07685291f, -0.07946777f, 0.12638083f, 0.13509098f, -0.02120732f, -0.35936537f, -0.26986173f, 
    0.07030370f, -0.04391259f, -0.04941114f, -0.16505069f, 0.16894075f, 0.35221687f, 0.01970477f, 0.00447576f, 
    0.02934140f, 0.05957323f, 0.14439473f, 0.16681199f, -0.17597169f, -0.26707119f, 0.37035388f, -0.11339317f, 
    0.09076197f, 0.02578666f, 0.15511313f, -0.13898923f, 0.02651630f, 0.32041162f, 0.03048376f, -0.01808731f, 
    0.19953303f, -0.04869318f, 0.02513072f, 0.03979639f, 0.17149688f, 0.16676040f, -0.17682479f, -0.18281899f, 
    0.00514875f, -0.01686910f, 0.00078455f, -0.02605767f, -0.13196404f, 0.09459171f, -0.12183239f, -0.39724120f, 
    -0.00816369f, 0.01957279f, 0.06324468f, 0.05763716f, -0.02208036f, 0.04798522f, 0.09650664f, -0.27043861f, 
    -0.14071648f, 0.03363576f, 0.15836039f, 0.12733154f, 0.02948823f, 0.02097035f, 0.01021437f, 0.15898529f, 
    0.23907208f, 0.05676201f, -0.08212433f, -0.22049548f, -0.10239320f, 0.19993636f, -0.03878257f, 0.19582814f, 
    0.11145605f, 0.25895181f, 0.16538389f, -0.12573443f, 0.02160588f, 0.10826273f, -0.00570295f, 0.07317202f, 
    -0.25666288f, -0.14216708f, -0.10264702f, 0.12667607f, -0.05340452f, -0.02752410f, 0.07040300f, -0.15493627f, 
    -0.05474591f, -0.17396452f, -0.07800870f, 0.04894429f, 0.02537165f, 0.09067763f, 0.02793570f, -0.12787443f, 
    -0.11865439f, 0.04608649f, 0.33677030f, 0.50535738f, 0.15535682f, 0.18020260f, 0.00580045f, -0.22388852f, 
    0.16719756f, 0.06993623f, 0.25827059f, -0.03884224f, 0.03235684f, 0.01331796f, 0.25674284f, -0.11171366f, 
    -0.05532290f, 0.11580195f, -0.00416144f, 0.00993213f, -0.19511881f, -0.07998127f, -0.10030580f, -0.16452698f, 
    -0.02046572f, 0.04765766f, 0.10488773f, -0.00750395f, 0.20479311f, 0.10045844f, -0.01593987f, -0.03037168f, 
    0.35045952f, 0.02795099f, 0.17055644f, -0.08638875f, -0.02691909f, -0.13182554f, -0.04253366f, 0.12296844f, 
    0.19502899f, 0.06562710f, 0.26267532f, -0.02200777f, 0.04021995f, 0.15794393f, -0.18027538f, -0.16228110f, 
    0.19690809f, -0.08884866f, 0.16555846f, -0.31505978f, -0.03049839f, 0.04138104f, 0.01873937f, 0.19256070f, 
    0.01506236f, 0.06255285f, -0.10312939f, -0.02180861f, 0.32584774f, 0.16770922f, 0.12681174f, -0.02683316f, 
    0.09064776f, -0.26354340f, 0.06954546f, -0.08518299f, 0.18019316f, 0.04095031f, -0.08157450f, 0.19607399f, 
    0.25244060f, 0.02765227f, 0.06572462f, -0.31819081f, -0.20956570f, 0.04324351f, 0.11230857f, 0.23654860f, 
    -0.03435557f, 0.00856648f, 0.02889432f, -0.01238497f, 0.04467228f, 0.14584208f, 0.03209686f, -0.04678312f, 
    -0.04065062f, 0.07755945f, -0.01840078f, 0.02796230f, -0.34398353f, -0.31515753f, -0.31101033f, -0.10287616f, 
    0.03643218f, -0.07796828f, 0.08831896f, -0.11080860f, 0.07836574f, -0.00261262f, -0.11772829f, -0.24639735f, 
    -0.25644273f, 0.09340347f, -0.17133617f, 0.05783071f, 0.00319482f, -0.12687913f, -0.16284065f, -0.15037996f, 
    0.15523355f, 0.23697194f, 0.37011519f, 0.55810404f, -0.13729671f, -0.07925343f, -0.12040025f, -0.04534948f, 
    0.09443470f, -0.02115885f, -0.07083968f, -0.16217437f, -0.12803109f, -0.14867403f, -0.18286963f, 0.12703893f, 
    0.10131984f, -0.04773961f, 0.14087421f, 0.07343343f, 0.37318268f, 0.02986144f, -0.01280604f, -0.02147298f, 
    -0.04598302f, -0.02083754f, 0.01427491f, -0.08452860f, 0.37385708f, -0.11323483f, -0.14217064f, -0.00599794f, 
    0.08191429f, 0.10056949f, 0.15424198f, 0.05967590f, 0.10425843f, -0.13566490f, 0.39080039f, -0.19678961f, 
    0.25356123f, 0.13579327f, -0.15472549f, -0.12644379f, 0.10307031f, -0.00374826f, -0.13262862f, 0.19410865f, 
    0.47667065f, 0.25743613f, 0.02786729f, -0.36167163f, 0.11501741f, 0.06399201f, 0.25897646f, -0.15855893f, 
    -0.48071611f, 0.02109350f, -0.17697109f, 0.20154050f, 0.00406263f, -0.09547464f, -0.19909091f, -0.10840408f, 
    -0.11811683f, 0.04283272f, 0.18961422f, -0.00189806f, 0.11056339f, 0.10930600f, 0.04393122f, 0.13954431f, 
    -0.00978440f, -0.08147238f, 0.46483767f, -0.45440933f, -0.01784563f, 0.30100954f, 0.11887405f, 0.17812149f, 
    -0.14623523f, -0.15431064f, 0.02583809f, -0.05081467f, -0.21862671f, -0.12346488f, -0.24984720f, 0.03303535f, 
    0.08509801f, 0.04493626f, 0.24703388f, 0.04391184f, -0.09114217f, 0.25223762f, -0.03413869f, -0.02451242f, 
    -0.08706822f, 0.10845897f, 0.16617149f, -0.03519639f, -0.19099833f, 0.45620590f, -0.26264742f, 0.11290687f, 
    0.03825220f, 0.09770045f, 0.06976718f, 0.19253117f, 0.00042530f, -0.24292430f, -0.17121543f, -0.15235357f, 
    0.07484292f, 0.08518714f, -0.01748450f, 0.10836124f, -0.09921873f, -0.26961511f, -0.20709595f, -0.31948039f, 
    0.09858090f, -0.01769012f, 0.13810354f, -0.03217152f, 0.14818327f, -0.15890369f, 0.03012697f, 0.18512170f, 
    0.26507735f, 0.30286893f, -0.01614204f, -0.13649957f, 0.07021978f, 0.11651392f, -0.04963736f, -0.01086926f, 
    0.05800456f, -0.07942336f, -0.06970560f, 0.01728511f, 0.03479837f, 0.00157305f, -0.05359707f, 0.01600798f, 
    0.04819863f, 0.01701700f, -0.09363113f, 0.07109152f, 0.01678820f, 0.01697729f, -0.03336048f, -0.09223410f, 
    0.03175202f, -0.03885212f, 0.05024287f, -0.01971651f, -0.07001133f, -0.02517881f, -0.07665885f, -0.03110222f, 
    0.04756061f, -0.04654358f, 0.00874431f, 0.05791053f, 0.02470585f, -0.04347599f, -0.03436559f, 0.05423072f, 
    -0.08807518f, -0.04351235f, 0.06015500f, 0.02504105f, 0.01625812f, 0.05019216f, 0.04098625f, -0.03798037f, 
    -0.00869777f, -0.01526087f, -0.03700540f, -0.02592838f, 0.05208293f, 0.04410921f, -0.01070378f, 0.06807230f, 
    0.00720884f, -0.02256024f, -0.05891018f, 0.01554356f, 0.02078569f, 0.02251272f, 0.03726970f, -0.02377464f, 
    -0.00557806f, 0.04755544f, 0.02427926f, -0.07696452f, -0.06488254f, -0.02399862f, -0.06347811f, -0.02068080f, 
    -0.03496855f, 0.00177520f, -0.02841404f, 0.03418013f, 0.07105909f, -0.00485636f, -0.02680666f, -0.04950226f, 
    -0.04263559f, 0.04302117f, -0.05083097f, -0.08591574f, -0.05626190f, 0.04454243f, -0.06261109f, 0.02966589f, 
    0.04273940f, -0.05567314f, -0.05872646f, -0.07929054f, 0.03227912f, -0.07592145f, -0.06030823f, -0.04456637f, 
    0.00334598f, -0.09533193f, -0.04818135f, 0.05862134f, -0.04728272f, 0.01090435f, 0.06300528f, -0.08728356f, 
    0.00690957f, 0.05381899f, -0.07935034f, 0.02147587f, 0.00612567f, 0.06304514f, -0.05962534f, 0.00649772f, 
    -0.00392765f, 0.00527729f, -0.02897450f, -0.03467690f, -0.01815050f, 0.05182847f, -0.04059335f, 0.07151116f, 
    0.02446950f, -0.05225557f, -0.07511501f, -0.07701211f, 0.05395156f, 0.01352416f, -0.05271800f, 0.01712332f, 
    -0.00017459f, -0.06435429f, -0.05821623f, -0.00800037f, -0.06922089f, -0.06003867f, -0.03509607f, -0.08156896f, 
    0.06278394f, -0.03264404f, -0.06214788f, -0.02369580f, -0.09019349f, -0.08641409f, -0.05400180f, 0.02861048f, 
    -0.09743845f, 0.03641842f, 0.01753840f, -0.00997977f, -0.08492371f, 0.05002464f, 0.06698792f, -0.07506335f, 
    -0.14183274f, 0.19325638f, -0.25207680f, 0.09134338f, 0.07883120f, -0.05175745f, 0.22051920f, -0.14894539f, 
    0.02788550f, -0.18645884f, -0.11950493f, 0.14977755f, -0.18667263f, -0.20790066f, -0.16957965f, -0.07479717f, 
    -0.05173224f, 0.02952184f, 0.00659972f, 0.17690460f, -0.07757267f, 0.02525091f, -0.03017395f, -0.13836737f, 
    0.02365568f, 0.06875198f, 0.16899538f, -0.62129581f, -0.30814815f, -0.30746627f, 0.07901603f, -0.08146647f, 
    0.16466649f, -0.15944722f, -0.10362814f, 0.01044678f, 0.38322574f, -0.29416597f, -0.13394226f, -0.25488731f, 
    -0.32883862f, -0.14754730f, 0.18286438f, 0.03380092f, 0.19729246f, -0.27920270f, -0.03855951f, 0.01580163f, 
    -0.16150559f, -0.06759237f, -0.05678933f, 0.19300218f, -0.11508417f, 0.08537659f, -0.06761003f, -0.37721065f, 
    0.01271411f, 0.02440090f, 0.06622189f, 0.26043063f, 0.05250045f, 0.10081924f, -0.26645628f, 0.14488073f, 
    0.07074836f, 0.21743137f, 0.01251862f, -0.05074822f, -0.16251151f, -0.02173426f, -0.18056285f, 0.00497299f, 
    0.37866274f, 0.42617834f, 0.11987101f, 0.10780736f, -0.01765727f, 0.17969704f, 0.02707975f, 0.08754329f, 
    0.14690466f, -0.30946749f, -0.24957094f, -0.38575372f, 0.26798061f, -0.01635291f, -0.28704685f, 0.11166576f, 
    -0.02389675f, 0.00250292f, 0.19896406f, 0.05587532f, 0.08599378f, 0.05752684f, -0.19376607f, -0.04683799f, 
    0.17612025f, -0.00462036f, 0.17522484f, 0.07141517f, -0.61037070f, 0.21558522f, -0.01511789f, -0.09519575f, 
    0.05490021f, 0.17469330f, 0.04657480f, -0.02179008f, 0.21831444f, 0.27864432f, 0.33708289f, -0.33046472f, 
    -0.14826967f, -0.13465041f, 0.02200831f, 0.23841521f, 0.16571464f, -0.20448644f, -0.19390124f, 0.10079058f, 
    0.10437033f, 0.12179440f, 0.16134045f, -0.10915168f, -0.06008230f, 0.04129785f, 0.05476834f, 0.19597135f, 
    0.36224154f, -0.29080555f, 0.09189683f, -0.04574967f, 0.04373305f, 0.14017475f, -0.04964942f, -0.58863384f, 
    -0.23215766f, 0.24056993f, 0.04031483f, -0.09416333f, -0.27587414f, 0.07681786f, 0.18916976f, -0.21248962f, 
    -0.17988601f, -0.32700741f, -0.09332951f, 0.01130347f, -0.16656739f, 0.12510535f, -0.00138444f, 0.18144035f, 
    0.06051120f, 0.00913175f, 0.13996400f, 0.05779270f, -0.11493311f, 0.09483802f, 0.25171071f, 0.02759450f, 
    0.06699607f, -0.00646616f, -0.10354945f, -0.07050139f, 0.16059956f, 0.27098161f, -0.11936370f, -0.24501441f, 
    -0.05513479f, -0.05378632f, -0.19637883f, 0.01803802f, 0.40659192f, 0.00219029f, 0.06537405f, 0.04791682f, 
    0.00585433f, 0.10118760f, 0.04758134f, -0.07164684f, -0.01779492f, -0.01567562f, 0.18234178f, -0.06438604f, 
    0.09569036f, -0.02626850f, -0.11164100f, 0.17824431f, 0.16557276f, 0.05662056f, -0.07473762f, -0.18949080f, 
    0.29200298f, 0.22980669f, -0.01719691f, 0.03754712f, 0.04661258f, -0.12668024f, -0.06377449f, 0.35840949f, 
    -0.10849181f, -0.02530306f, 0.06967402f, -0.07179168f, -0.00944785f, 0.02448292f, 0.02579753f, -0.41109359f, 
    0.03119133f, 0.10284481f, -0.02026721f, 0.01171190f, -0.08293241f, -0.00211642f, 0.02777340f, -0.15496489f, 
    -0.02338583f, 0.12116700f, -0.10339869f, 0.03760270f, 0.04209704f, 0.08845475f, 0.16524470f, 0.03049772f, 
    0.11462465f, 0.58845633f, -0.07418174f, 0.17139418f, 0.20980369f, 0.07170331f, 0.05817206f, -0.09494627f, 
    -0.03359443f, 0.16317506f, -0.16565089f, 0.04618267f, 0.02667951f, 0.04531202f, -0.07644270f, -0.19482861f, 
    0.12919714f, -0.37100884f, -0.11532027f, -0.08206724f, -0.07854173f, 0.05801272f, 0.07163598f, -0.00522456f, 
    0.17975584f, -0.06034830f, -0.10543667f, -0.01210227f, -0.20095310f, 0.12053698f, -0.25559217f, -0.11317519f, 
    0.05870651f, 0.13820562f, -0.00311715f, -0.07910960f, 0.03164203f, -0.64818877f, 0.01222587f, -0.30350715f, 
    0.28143772f, 0.19591242f, -0.17984754f, 0.08363417f, 0.04963773f, 0.05284810f, -0.37568569f, 0.00148627f, 
    -0.13767511f, 0.04869063f, -0.23506571f, -0.05632308f, 0.05976078f, -0.11948673f, -0.15440902f, -0.14485726f, 
    0.01843144f, 0.04136643f, -0.03292431f, 0.03855754f, -0.02755575f, 0.30742201f, 0.27570081f, -0.15405801f, 
    0.10309358f, 0.05947333f, -0.71149606f, -0.11340705f, -0.12299000f, -0.02672793f, -0.02886446f, 0.13024341f, 
    0.00631797f, 0.34916067f, 0.26076028f, 0.04860578f, 0.13197459f, -0.10161621f, 0.00419802f, 0.22430070f, 
    -0.12181564f, 0.03329760f, -0.04962396f, 0.23321997f, -0.01241366f, -0.15494277f, 0.05623093f, 0.08203723f, 
    -0.05607267f, -0.02068874f, -0.11231199f, 0.13348538f, -0.20896897f, 0.00253115f, -0.11633781f, 0.08613254f, 
    0.12438095f, 0.07265320f, 0.06728010f, -0.21831943f, 0.27683136f, 0.35011342f, -0.23175251f, -0.10235044f, 
    -0.27620748f, -0.27117038f, 0.06193068f, 0.08377123f, 0.18547148f, -0.09691667f, 0.24939613f, 0.05380457f, 
    -0.14827470f, -0.09545885f, -0.10066134f, -0.03675231f, 0.02780933f, -0.16182195f, 0.20655364f, -0.21442544f, 
    -0.29671291f, 0.10995831f, -0.09391353f, 0.24607891f, 0.01095796f, 0.04076035f, 0.00700762f, -0.65653360f, 
    0.24016975f, -0.22647825f, -0.15253599f, 0.15303054f, -0.03142663f, 0.23127186f, -0.14289875f, 0.00531490f, 
    -0.14500038f, -0.04740194f, -0.29866129f, 0.12500393f, -0.06043491f, 0.28539360f, -0.00734242f, 0.02879519f, 
    -0.04938429f, -0.50537449f, -0.53830731f, -0.40955916f, 0.10198779f, 0.00386023f, 0.27503029f, -0.09912249f, 
    0.14212584f, -0.09533146f, 0.08111865f, -0.66246510f, -0.10902581f, -0.10652821f, -0.10921711f, 0.19927400f, 
    0.02787150f, 0.11687323f, 0.01585810f, 0.26825210f, 0.24875836f, 0.09840050f, 0.01847222f, 0.03198694f, 
    -0.00993061f, -0.06451108f, -0.06084270f, -0.08324286f, 0.20007405f, -0.61501950f, -0.14712270f, -0.03603489f, 
    0.07716736f, 0.13491698f, 0.14328191f, 0.07142617f, 0.03767648f, 0.22098611f, -0.24778220f, 0.04012645f, 
    -0.07110388f, -0.13411109f, -0.15570080f, 0.11225028f, -0.11996767f, 0.14113551f, 0.34854957f, 0.20324326f, 
    -0.04525402f, 0.01169742f, -0.13247687f, 0.28086615f, 0.00426369f, 0.27347898f, -0.08778045f, 0.30825615f, 
    0.13519533f, 0.16283636f, -0.02975602f, -0.03686862f, 0.11392847f, 0.18965293f, -0.03519273f, -0.02435228f, 
    0.08647045f, -0.09856579f, -0.00875988f, 0.08298136f, 0.12647215f, 0.14261305f, -0.05845579f, -0.31989372f, 
    -0.32614484f, 0.02680484f, -0.46773705f, -0.17240942f, 0.31647718f, -0.03903667f, 0.07141652f, 0.05756420f, 
    -0.03970926f, -0.02397143f, 0.10082753f, 0.43949169f, 0.04734858f, 0.21365701f, 0.13447796f, 0.05922934f, 
    0.18648875f, 0.03330659f, 0.09483846f, 0.19779098f, 0.19042870f, 0.28369018f, 0.13768703f, -0.02944954f, 
    0.01839576f, 0.15052852f, 0.08025488f, -0.05319010f, 0.03648730f, -0.02709864f, 0.00958705f, 0.10122355f, 
    -0.07320987f, 0.09793495f, -0.43846190f, -0.24368767f, -0.27002570f, 0.05394900f, 0.24037129f, 0.19029251f, 
    0.08530087f, 0.09974237f, -0.12787688f, 0.14417361f, -0.01567827f, -0.07520843f, 0.04637847f, -0.34044409f, 
    0.09419387f, 0.19797267f, 0.04509169f, 0.13151281f, 0.07466347f, 0.15453246f, 0.14377455f, 0.46641612f, 
    0.43810317f, 0.15457141f, 0.03150107f, -0.15036288f, 0.12916365f, 0.06848366f, 0.09800548f, -0.07910322f, 
    0.10949320f, -0.11842260f, -0.20741375f, 0.05144890f, 0.14988358f, -0.08708026f, -0.00702946f, -0.05401856f, 
    -0.11648630f, -0.03039004f, 0.20754872f, 0.32567981f, 0.16888323f, 0.00311937f, 0.14249568f, 0.11127231f, 
    0.15507039f, 0.18538965f, 0.15734553f, 0.07473610f, 0.04373454f, 0.33094931f, 0.26321360f, 0.17978619f, 
    0.12550002f, 0.00298542f, 0.04798235f, 0.15974897f, -0.03094216f, -0.05365501f, -0.08948407f, 0.02126522f, 
    0.18023831f, 0.07168017f, 0.01609956f, 0.01762949f, 0.11347074f, -0.23124993f, -0.22416291f, 0.06945840f, 
    0.03901356f, 0.06324035f, 0.03250381f, -0.15905894f, 0.06449100f, 0.15395707f, 0.21557541f, -0.11360968f, 
    -0.06647169f, 0.05339434f, -0.01508213f, 0.14281617f, -0.08666625f, -0.10899089f, -0.05040003f, 0.07168643f, 
    -0.08895809f, 0.09908802f, -0.02608542f, 0.10096075f, 0.02360611f, 0.18098909f, 0.19408455f, 0.12027302f, 
    -0.05144621f, 0.10046424f, 0.05638683f, 0.10151885f, 0.08623926f, -0.10914219f, -0.19400416f, 0.20486312f, 
    -0.24146567f, -0.02074517f, 0.30518159f, -0.05182089f, -0.13643417f, 0.02776689f, 0.05172618f, -0.16940269f, 
    0.18027678f, 0.10224193f, 0.10004613f, -0.23828289f, 0.06888125f, -0.01552329f, 0.24882989f, -0.03873928f, 
    -0.05243520f, -0.07021827f, 0.03586668f, 0.24478658f, 0.16453502f, 0.07037494f, -0.05445389f, -0.15184414f, 
    0.12629382f, -0.02742572f, -0.08457751f, -0.09531099f, 0.09263797f, 0.16235127f, 0.07802661f, -0.11278283f, 
    -0.09212398f, -0.19075109f, -0.00917119f, -0.16506289f, 0.02163817f, -0.03961651f, 0.51220077f, -0.16827059f, 
    0.19402187f, 0.05662221f, 0.01143947f, 0.09465843f, 0.09641634f, 0.01205036f, 0.01448050f, -0.37900516f, 
    0.05881678f, 0.06912615f, 0.20667392f, 0.00995704f, 0.08998913f, 0.06364545f, -0.03986501f, 0.03681412f, 
    -0.15955484f, -0.04072241f, -0.16147868f, -0.16773623f, 0.03251456f, 0.13242467f, 0.02396429f, -0.15566447f, 
    -0.11523367f, 0.34564891f, -0.00693593f, 0.21235695f, 0.05487200f, 0.00986675f, -0.04824137f, 0.05953269f, 
    0.45480862f, -0.14421669f, -0.51794744f, -0.05035444f, -0.13971640f, -0.06584351f, 0.18580116f, 0.01380786f, 
    -0.13099243f, 0.41256201f, -0.03720454f, 0.20645541f, -0.19939980f, 0.25184652f, 0.32913259f, -0.10979264f, 
    -0.00626227f, 0.00743935f, 0.02861071f, 0.39824954f, 0.08539616f, 0.10464427f, -0.17717424f, -0.16445497f, 
    -0.02907645f, -0.24004409f, -0.08300164f, 0.20705831f, -0.09112470f, -0.10511565f, 0.12928779f, -0.03867638f, 
    -0.00383961f, -0.03637577f, -0.07720039f, -0.09727519f, -0.09714881f, 0.18936244f, 0.21071008f, -0.11327533f, 
    -0.16954342f, -0.18797863f, 0.03996906f, -0.08217983f, -0.19878057f, -0.17583093f, 0.04398549f, -0.11128189f, 
    0.07509231f, 0.04787359f, 0.10009135f, 0.08449560f, 0.05007645f, 0.13638613f, 0.23076098f, -0.10176022f, 
    -0.24171430f, -0.03388245f, 0.09835298f, -0.27977237f, 0.14473540f, -0.21362376f, 0.18328008f, 0.11447416f, 
    -0.30481982f, -0.13304976f, -0.06387298f, 0.00689749f, -0.02518604f, 0.01610156f, -0.11161331f, 0.10712501f, 
    0.00134251f, 0.11351240f, -0.06159811f, -0.29717317f, -0.05298671f, -0.12863094f, 0.13602068f, 0.12968329f, 
    -0.24347630f, 0.08321047f, -0.04380951f, 0.09859315f, 0.09903841f, -0.22409797f, 0.10656492f, 0.00412557f, 
    -0.06560729f, -0.04301080f, 0.48516789f, -0.16353102f, -0.05401271f, -0.11874367f, -0.07666478f, 0.19561143f, 
    0.00388537f, 0.02962631f, 0.21504855f, 0.22834198f, 0.32878962f, 0.39424092f, 0.06238786f, 0.00503528f, 
    -0.09115265f, 0.15837187f, 0.04793689f, 0.09609524f, -0.22708049f, -0.18393217f, -0.02477526f, -0.18487889f, 
    -0.04989517f, 0.07817320f, 0.14376567f, 0.03376353f, -0.24770260f, 0.64815909f, -0.13480222f, 0.38320673f, 
    0.09646127f, -0.05716816f, -0.18118219f, 0.03726123f, 0.02146378f, 0.23028021f, -0.51320738f, 0.05938915f, 
    0.14548737f, -0.00695261f, 0.04246652f, 0.19562426f, -0.03681980f, -0.20128785f, -0.01975508f, 0.34279034f, 
    0.23759152f, -0.03873786f, -0.13406312f, 0.04482512f, -0.19296020f, 0.07833575f, 0.15907592f, 0.00575611f, 
    0.27250600f, -0.05774835f, 0.42378917f, 0.09355341f, 0.17438208f, -0.05160085f, 0.05912478f, -0.01684542f, 
    0.14459297f, 0.04584676f, 0.05768270f, -0.12474664f, 0.44501746f, -0.20980610f, 0.33071309f, 0.18026981f, 
    -0.06201874f, -0.03356249f, 0.26346025f, -0.16413844f, -0.33223283f, -0.04095576f, -0.18724325f, -0.04095293f, 
    0.08564865f, 0.13660164f, 0.02840605f, -0.09944956f, 0.33997443f, 0.13360913f, 0.22351871f, 0.03651465f, 
    0.03146336f, 0.21833819f, 0.02983785f, 0.15596686f, -0.21874300f, -0.32121444f, 0.04093088f, 0.06439141f, 
    0.11601058f, 0.24500684f, 0.24553032f, 0.22684094f, 0.43548933f, 0.17827648f, -0.08711626f, -0.27858984f, 
    0.19525902f, 0.02741097f, 0.08009219f, -0.04411836f, 0.05997483f, -0.05727129f, -0.17047480f, -0.00978815f, 
    -0.22472942f, 0.15700759f, -0.10055926f, 0.12748103f, 0.02000133f, -0.05009833f, 0.19040070f, -0.02206655f, 
    0.02690987f, 0.36386657f, 0.07065642f, -0.18403295f, 0.00736926f, 0.05310422f, 0.01351089f, 0.15286411f, 
    0.20421825f, 0.10850946f, -0.09115478f, -0.03160382f, -0.08517772f, -0.02451917f, 0.27577081f, 0.11589657f, 
    0.06955340f, 0.26896140f, 0.58525926f, 0.15316406f, -0.16827068f, -0.21737866f, 0.07106027f, -0.08836321f, 
    -0.14744069f, 0.07148533f, 0.20283930f, 0.51889223f, 0.12656100f, 0.01484464f, 0.01477332f, 0.00134806f, 
    0.05459490f, 0.25321674f, 0.06281123f, -0.14868155f, -0.00452553f, 0.04836911f, -0.01125014f, 0.11741877f, 
    0.02715815f, -0.01168390f, -0.06371826f, 0.01225172f, -0.05451299f, 0.10814512f, 0.11268841f, 0.05819714f, 
    -0.12417451f, 0.04740323f, 0.05169185f, 0.11714523f, 0.13840999f, -0.10909202f, -0.63733935f, 0.35307494f, 
    0.09754892f, 0.21489690f, -0.08860461f, 0.20165695f, -0.11041290f, 0.13085760f, -0.09832782f, -0.41604480f, 
    -0.33029369f, -0.14238188f, 0.07802445f, -0.08076356f, -0.10546590f, -0.09162661f, 0.01930954f, 0.29203713f, 
    0.15817487f, 0.10973816f, -0.08706679f, -0.19285575f, -0.21229956f, 0.14814378f, 0.15119241f, -0.08749880f, 
    0.00029520f, -0.58309704f, -0.77707118f, -0.10416187f, -0.04325308f, 0.10749932f, 0.11031052f, -0.10061085f, 
    0.03884018f, 0.14040501f, 0.01206680f, 0.13107392f, 0.05421284f, -0.11896212f, -0.07649391f, 0.03593929f, 
    0.15008032f, -0.16768670f, 0.04691161f, 0.12710524f, 0.32879013f, -0.18551813f, 0.17379610f, 0.06820899f, 
    -0.01383671f, -0.07496651f, 0.06616173f, -0.28589034f, -0.33969870f, -0.27452737f, 0.27315292f, 0.03134619f, 
    -0.05201472f, 0.14352481f, 0.03768311f, 0.07300249f, 0.30113178f, 0.15932541f, 0.04509258f, -0.20006318f, 
    -0.02654584f, -0.08018903f, -0.03967399f, -0.16407965f, 0.08474119f, 0.35744300f, 0.15269350f, 0.05959719f, 
    0.12325646f, -0.05946841f, -0.21620989f, 0.23989370f, -0.03049811f, 0.04373495f, -0.37624469f, -0.49215618f, 
    -0.61819547f, -0.08535990f, -0.28014618f, -0.04270464f, -0.08287585f, -0.18943423f, 0.03750173f, -0.00928407f, 
    0.22555251f, 0.27284488f, 0.02378776f, -0.24036697f, 0.07067706f, 0.14783612f, 0.07531216f, 0.06908771f, 
    0.14620538f, -0.05079187f, -0.04715449f, 0.17611000f, 0.14029194f, 0.16707487f, 0.11854831f, -0.12011316f, 
    -0.24227524f, 0.14764260f, -0.05792042f, 0.13972065f, -0.03980574f, 0.11192296f, 0.03180670f, -0.01067908f, 
    0.21834251f, -0.02469515f, -0.03796441f, 0.24802604f, 0.05115972f, 0.07289226f, 0.03123352f, 0.12824522f, 
    -0.15072669f, 0.09347513f, 0.01961370f, 0.00481198f, -0.27919000f, -0.16357704f, 0.04886304f, 0.00521285f, 
    -0.04494135f, 0.23348661f, -0.15242752f, 0.11302409f, 0.21554276f, 0.12646671f, -0.16993339f, 0.20196618f, 
    -0.13507541f, -0.09397346f, -0.20959620f, -0.03887283f, -0.51666403f, -0.09187268f, 0.28279358f, -0.09533656f, 
    0.09739695f, -0.31150219f, -0.03793056f, 0.08597749f, 0.18153599f, 0.00448518f, 0.02014840f, -0.32980773f, 
    0.19451377f, -0.27951604f, 0.05745128f, -0.24011593f, -0.00527662f, 0.03017178f, 0.19109964f, -0.02278640f, 
    0.01882346f, -0.14190073f, 0.06216494f, 0.02387677f, 0.15330775f, 0.10983019f, 0.03484415f, -0.09843801f, 
    -0.23317714f, 0.12481315f, 0.32582891f, -0.00423916f, 0.12711088f, -0.15988275f, -0.20339862f, -0.00402944f, 
    0.01855084f, 0.10015535f, -0.00803658f, -0.26406121f, 0.10089354f, 0.09059224f, -0.08701967f, 0.16995496f, 
    0.07615000f, -0.02729952f, 0.13118212f, 0.13546400f, -0.05446538f, 0.05787798f, 0.20069799f, 0.01024410f, 
    0.17111152f, -0.16487604f, 0.12716292f, -0.45131132f, -0.34189376f, -0.34900054f, -0.26775482f, 0.07583403f, 
    -0.05319879f, -0.09317570f, 0.11379424f, 0.04398945f, 0.10039118f, 0.18498857f, 0.10755891f, 0.04179444f, 
    0.11410008f, -0.05913996f, 0.14773104f, -0.02037463f, -0.07705378f, 0.10489119f, -0.16194500f, -0.36639556f, 
    0.02904704f, 0.07353254f, 0.05075633f, 0.05556357f, 0.06023373f, -0.11892058f, 0.06294392f, 0.25809661f, 
    0.17902654f, -0.27898803f, -0.02777776f, -0.29917860f, -0.10522289f, 0.15944856f, 0.31347921f, 0.15138447f, 
    -0.02310596f, -0.11345258f, -0.02961616f, -0.17543092f, -0.00465812f, 0.12734081f, 0.06246191f, 0.19702663f, 
    0.43995503f, 0.17592990f, -0.25468457f, -0.09035864f, -0.05563761f, 0.20089994f, -0.12171575f, -0.02942039f, 
    -0.21619071f, -0.33470836f, 0.07183039f, -0.00448925f, 0.01780373f, 0.20998488f, -0.08751003f, -0.12796451f, 
    -0.11827517f, -0.04378992f, -0.16592723f, 0.22442013f, -0.01631016f, -0.15435080f, 0.14608403f, 0.16201757f, 
    0.04689258f, -0.05224320f, 0.20610657f, -0.08929337f, -0.16027950f, 0.17505921f, 0.26268330f, 0.13017777f, 
    -0.03000306f, 0.16691473f, -0.02562874f, 0.00279993f, -0.73333651f, -0.20353884f, -0.21523881f, -0.21797906f, 
    0.01943115f, -0.17668222f, 0.13501023f, -0.24587139f, -0.04795265f, -0.23311733f, -0.37614393f, -0.55470294f, 
    -0.25893432f, -0.12759413f, -0.16599643f, 0.19020978f, 0.05517124f, -0.05445493f, 0.11812237f, -0.38315502f, 
    -0.02771228f, -0.20660038f, 0.15238357f, 0.03411773f, 0.01132827f, -0.20908621f, 0.30362946f, 0.15983397f, 
    0.06597129f, 0.10556881f, -0.08440396f, 0.01435860f, -0.16742659f, 0.15273900f, -0.04468575f, -0.05124724f, 
    -0.55665052f, 0.08428973f, 0.18022028f, 0.14112055f, 0.07392228f, 0.17148936f, 0.02611872f, 0.05897855f, 
    -0.03617344f, 0.63819957f, -0.08291575f, -0.03113029f, -0.23012158f, -0.04251886f, 0.07634541f, -0.05445580f, 
    0.07470879f, -0.14835002f, -0.08265048f, 0.52600986f, 0.04391115f, 0.00348854f, -0.01244492f, 0.18767367f, 
    0.05161171f, -0.20882531f, 0.12787485f, -0.11369983f, -0.33912185f, -0.07080595f, 0.03384992f, 0.11789186f, 
    -0.00109224f, 0.31809229f, 0.04814948f, 0.09028514f, -0.20294692f, 0.06768251f, 0.24162766f, -0.04001911f, 
    -0.00006709f, 0.01944295f, -0.00401931f, 0.13689737f, 0.16167669f, 0.66491801f, 0.11433630f, -0.37491167f, 
    -0.03619166f, 0.12075188f, -0.15258576f, -0.06212902f, 0.09375066f, -0.09847541f, -0.25819027f, 0.00390968f, 
    -0.06451719f, -0.01578030f, 0.19065215f, 0.17919075f, 0.01584466f, -0.04452878f, 0.19693777f, 0.25154063f, 
    0.13413985f, -0.06920104f, -0.20582382f, -0.11078869f, -0.03939600f, 0.04985066f, 0.02100251f, 0.04536676f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.25677329f, -0.06056448f, 0.02606093f, 0.25289607f, -0.06650520f, 0.12270914f, 0.04860887f, 0.00756698f, 
    0.10535854f, -0.10431278f, -0.05602432f, -0.09950006f, 0.14964388f, 0.24251755f, -0.01823469f, 0.04591087f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.40546677f, -0.10720599f, 0.32271677f, -0.05756626f, 0.21050982f, -0.15322912f, -0.04495103f, 0.21795774f, 
    0.01063654f, 0.71697366f, -0.05634578f, -0.03954669f, -0.07946304f, -0.20997861f, -0.34484571f, -1.00560749f, 
    -0.03613187f, -0.08678808f, -0.24445465f, -0.23098812f, -0.30998653f, 0.13016634f, 0.09521201f, 0.05213445f, 
    -0.08579241f, -0.11225586f, 0.49524766f, -0.63463700f, 0.19849007f, -0.59152365f, 0.15876609f, 0.11714306f, 
    -0.01613477f, -0.16421518f, -0.08460411f, 0.44019109f, 0.21536241f, 0.02459817f, 0.16483827f, -0.55943418f, 
    0.45892978f, -0.33731246f, -0.23371719f, 0.10915358f, 0.17698629f, 0.21951947f, -0.51905012f, 0.10319701f, 
    -0.10149696f, -0.15138051f, -0.02504346f, -0.16444224f, -0.07115477f, -0.04456913f, -0.21551186f, -0.21334115f, 
    -0.19422862f, -0.15353829f, -0.09979376f, 0.15161997f, -0.08237600f, -0.08656642f, -0.24274001f, -0.24300286f, 
    0.18373582f, 0.20796119f, 0.78668308f, 0.26001874f, -0.06903614f, 0.64333010f, 0.04988422f, -0.30555451f, 
    0.07768610f, -0.14680277f, -0.02295648f, 0.21582763f, -0.24918167f, 0.59065098f, -0.24736647f, 0.32585958f, 
    -0.24351688f, 0.05056204f, 0.12490804f, 0.04642411f, -0.23818620f, -0.03461297f, -0.17682764f, -0.18806043f, 
    -0.00137636f, -0.10080148f, 0.05994151f, -0.12574524f, -0.02012196f, -0.20559007f, 0.08063886f, -0.03179371f, 
    0.18451592f, 0.00591231f, -0.35471722f, 0.09421293f, -0.48445931f, -0.07851860f, 0.17904362f, 0.12621509f, 
    0.01584368f, 0.15074794f, 0.40231100f, -1.03345287f, 0.19001555f, -0.21183620f, 0.12140816f, 0.08966184f, 
    -0.31922081f, -0.25366005f, -0.20175260f, 0.15070334f, -0.48391184f, 0.14577690f, 0.04037905f, -0.03390622f, 
    -0.20312184f, -0.11656204f, 0.39917058f, 0.09242044f, 0.03063006f, 0.03361449f, 0.12018725f, 0.57569724f, 
    0.34827450f, -0.15988730f, -0.30169883f, -0.07336459f, 0.53419280f, 0.39280096f, -0.11620176f, 0.00444872f, 
    0.66351658f, -0.04045185f, -0.21005762f, -0.05706638f, 0.22138773f, -0.49376982f, -0.58848274f, -0.54536921f, 
    0.04740217f, 0.00587770f, 0.11916962f, -0.35190037f, -0.28888324f, 0.44372174f, 0.04201902f, 0.36223620f, 
    -0.13139066f, 0.16887540f, 0.23731475f, 0.13025889f, 0.30927345f, 0.20782517f, 0.15848954f, -0.50835103f, 
    0.19304194f, -0.15992577f, 0.04171087f, -0.06676504f, -0.07009915f, -0.09913014f, 0.21220936f, -0.23620552f, 
    0.05600793f, -0.03395112f, -0.21836993f, 0.09171484f, -0.25212297f, 0.04890450f, -0.07071588f, 0.16459283f, 
    -0.01693523f, -0.22955447f, -0.19750857f, 0.12997690f, -0.09641650f, -0.07779226f, -0.08294454f, 0.22199300f, 
    0.10429683f, 0.14309493f, -0.12710562f, -0.17593998f, -0.04254016f, 0.01960438f, -0.02284613f, -0.24982682f, 
    0.14859307f, 0.03848491f, -0.19493373f, 0.17353952f, -0.28248841f, 0.11257175f, 0.24659871f, 0.13808812f, 
    0.09408136f, 0.16910468f, -0.23486982f, 0.01514085f, -0.16694909f, -0.11317080f, -0.19748665f, -0.18513985f, 
    0.35289073f, -0.02273762f, 0.44020087f, -0.10771365f, -0.28553653f, -0.06855068f, 0.23544735f, 0.02954289f, 
    -0.42674857f, 0.72561884f, -0.00522705f, -0.26621515f, 0.21085899f, 0.52353412f, 0.25384334f, -0.16960400f, 
    0.44525996f, 0.00747964f, -0.24678600f, 0.71823341f, -0.01231406f, -0.23212552f, 0.09306796f, -0.47233236f, 
    0.30604601f, -0.02613872f, -0.24592376f, -0.38494122f, 0.47139785f, -0.40743524f, -0.34146160f, -0.10568070f, 
    0.46091050f, 0.22128756f, 0.56199574f, 0.07041654f, 0.24851918f, -0.18286054f, 0.14823684f, -0.25993109f, 
    -0.26192734f, -0.07915387f, 0.19328718f, 0.37759319f, -0.21237630f, -0.00408050f, 0.00848081f, -0.29023045f, 
    -0.25528458f, -0.09871514f, -0.22053757f, -0.05814556f, 0.39776590f, -0.14848053f, -0.07907727f, -0.17291833f, 
    0.19573416f, 0.52303445f, 0.03732547f, -0.14387995f, 0.02434733f, 0.23341514f, 0.23541667f, 0.52315903f, 
    -0.11087864f, -0.05342641f, 0.71268117f, -0.19966158f, 0.05663167f, 0.68584907f, -0.24221849f, -0.08118685f, 
    -0.22726277f, -0.03970188f, 0.20541775f, 0.04533164f, 0.10175262f, -0.04147333f, 0.30302432f, -0.08613697f, 
    -0.32477853f, 0.09156450f, -0.04071579f, 0.21396287f, -0.01181210f, -1.04258311f, -0.15041880f, -0.07340454f, 
    -0.11606821f, -0.04671670f, -0.14080393f, -0.07601094f, -0.20067349f, 0.40570438f, 0.03643198f, 0.07079975f, 
    0.11422887f, 0.21758020f, -0.21810347f, 0.04346287f, -0.22834170f, -0.12018445f, -0.14658251f, -0.17003259f, 
    0.06860703f, 0.24314964f, -0.03046370f, 0.01992390f, -0.12064078f, 0.06040567f, -0.02668756f, -0.07363281f, 
    -0.28329378f, -0.04596071f, 0.17930293f, -0.38456714f, 0.21638179f, 0.19944058f, -0.06031493f, -0.04721247f, 
    0.34746525f, -0.55197829f, 0.01792688f, 0.17412853f, -0.25255206f, 0.17479382f, 0.32803789f, 0.16373681f, 
    -0.30203757f, -0.01016337f, -0.18382737f, 0.11833990f, 0.17145695f, -1.02391112f, 0.17917886f, 0.23394971f, 
    -0.26453751f, -0.35172954f, 0.20024708f, 0.13176438f, -0.14024045f, 0.25662515f, 0.02575188f, -0.14207292f, 
    -0.39516485f, -0.03021511f, 0.34573659f, -0.31519610f, 0.14337115f, 0.08040956f, -0.16533095f, -0.00690639f, 
    -0.21809067f, -0.06875959f, 0.13074525f, 0.14779894f, -0.05947555f, 0.15612899f, 0.27579618f, 0.07898472f, 
    -0.23343633f, -0.22682281f, -0.88704151f, 0.41753063f, 0.00145511f, -0.34696633f, -0.18361600f, -0.33103111f, 
    0.03180475f, 0.25360376f, -0.09560718f, -0.20762032f, 0.22225615f, -0.09743703f, 0.20776093f, 0.41858485f, 
    -0.15754646f, -0.01697570f, -0.02618786f, 0.49945885f, 0.01031542f, 0.22437255f, -0.00949479f, 0.06973584f, 
    0.53885591f, -0.62849754f, -0.04881060f, -0.62717587f, 0.20417249f, -0.15360698f, 0.12176962f, 0.08797982f, 
    0.20868613f, -0.19689585f, -0.14577653f, -0.09809532f, -0.10168981f, -0.34597793f, 0.19726084f, -0.58802348f, 
    -0.48928899f, -0.21283868f, 0.29945409f, -0.39831981f, 0.28639963f, -0.11688962f, 0.29409176f, 0.35102344f, 
    0.04550231f, -0.03134497f, -0.10072012f, -0.22802906f, -0.16457151f, -0.15534580f, -0.05238566f, 0.02463146f, 
    -0.02974775f, 0.18213703f, 0.03646513f, 0.09816909f, -0.19242470f, -0.03881395f, 0.11277836f, -0.08472573f, 
    0.25179484f, -0.12404258f, 0.59403396f, -0.36395347f, -0.08736956f, 0.24294010f, 0.00130812f, 0.16136128f, 
    0.08858912f, 0.52872038f, 0.29231837f, -0.16350105f, -0.03309137f, 0.18379490f, 0.06886398f, -0.61654395f, 
    0.47587302f, -0.15413700f, 0.25546354f, 0.23575811f, 0.28327143f, 0.03751937f, 0.14246000f, -0.63264197f, 
    0.10773554f, 0.13790894f, -0.01158122f, 0.06906854f, -0.10344831f, 0.41227701f, -0.54419321f, 0.16487011f, 
    -0.24589910f, -0.16687387f, -0.15706146f, 0.21435492f, -0.15556869f, 0.23656739f, 0.03835925f, 0.31838879f, 
    -0.10541393f, -0.33777717f, 0.35061687f, 0.05356189f, 0.18979172f, -0.32723564f, 0.18159026f, -0.35313654f, 
    -0.07752428f, -0.15053254f, -0.09749094f, -0.44496873f, 0.05488790f, -0.04404986f, -0.21000366f, 0.13959515f, 
    -0.07626957f, 0.66748518f, 0.10722278f, -0.52660632f, 0.28884047f, 0.34135479f, 0.50989670f, 0.48426419f, 
    0.12742126f, -0.24144976f, -0.61239243f, 0.25218973f, 0.20438896f, -0.04143360f, -0.10613553f, -0.14441000f, 
    -0.05746818f, -0.25289261f, -0.14396228f, -0.37324956f, 0.37315825f, 0.15914941f, -0.05155794f, 0.54858565f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.01308594f, 0.49959561f, 0.34806082f, 0.08045945f, 0.01075811f, 0.01338165f, 0.37725568f, -0.05511536f, 
    0.03715564f, 0.18830599f, 0.05601926f, -0.20730746f, 0.05515466f, 0.07609621f, 0.45724413f, 0.03986714f, 
    -0.17072178f, -0.09701974f, 0.68175769f, -0.19620809f, 0.07963537f, -0.19896428f, -0.18894929f, 0.18527447f, 
    0.37965396f, 0.10798480f, -0.15599459f, -0.03962772f, 0.33356172f, -0.19681470f, -0.08807436f, 0.21868591f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.39192864f, 0.74875003f, 0.02116978f, 0.02868213f, 0.05823052f, 0.03116246f, 0.40315646f, 0.33505672f, 
    -0.41077504f, -0.15968314f, -0.08286646f, 0.08359353f, -0.04247285f, 0.36337423f, 0.04290477f, -0.06909838f, 
    0.10789693f, 0.22977507f, -0.49760151f, -0.06647043f, -0.36715162f, 0.06865929f, -0.49106431f, 0.34588373f, 
    0.05620031f, 0.83998090f, -0.08046693f, -0.11223794f, 0.14669789f, 0.18685615f, 0.37024188f, 0.24637713f, 
    -0.39936748f, 0.68374985f, -0.29874188f, -0.02351166f, -0.41250539f, 0.01271673f, 0.42437980f, 0.04697181f, 
    0.11322269f, 0.21778315f, 0.09769748f, 0.11243390f, 0.04974103f, -0.21207926f, 0.06760447f, -0.29679838f, 
    -0.23986381f, 0.15525852f, -0.34566984f, 0.03941638f, -0.06043123f, -0.54261124f, -0.11152850f, 0.38376805f, 
    0.46236768f, 0.57295454f, 0.08377630f, 0.06064615f, -0.31740704f, 0.63532007f, 0.19649273f, -0.06669039f, 
    -0.13916461f, -0.00707570f, -0.10013741f, 0.16453308f, -0.10251784f, -0.04949996f, 0.14577954f, 0.01274651f, 
    -0.16906789f, -0.12654482f, 0.11695866f, 0.15018426f, -0.01098062f, -0.00028078f, -0.00186940f, -0.04682818f, 
    0.05992021f, -0.11019243f, -0.08203374f, 0.00842924f, -0.13536109f, -0.01996505f, -0.01081448f, 0.08985358f, 
    -0.16398336f, -0.00098348f, 0.00968216f, 0.07985974f, -0.00565998f, 0.02666753f, -0.17330970f, -0.10691325f, 
    0.47487885f, 0.25851583f, -0.24091850f, -0.01897512f, -0.24414083f, -0.09483889f, 0.58320683f, -0.37789550f, 
    0.09728336f, 0.31821293f, 0.13023297f, -0.13845728f, -0.04355578f, 0.44388393f, 0.35620466f, 0.13434595f, 
    -0.43997312f, -0.06474915f, 0.23849295f, 0.09353758f, 0.01964228f, 0.29548046f, 0.21627840f, -0.23674864f, 
    0.17879753f, -0.05952243f, -0.04121383f, 0.32470208f, -0.00802594f, -0.04447662f, 0.02750533f, -0.32397318f, 
    -0.03816028f, -0.00072337f, -0.16587530f, -0.08671393f, 0.10141550f, -0.06283964f, -0.02993401f, -0.13174459f, 
    0.02543349f, 0.03177425f, 0.14542389f, 0.02389785f, 0.10736899f, -0.13875359f, -0.04657379f, -0.13744673f, 
    0.03485252f, -0.14450432f, 0.09580594f, 0.09299904f, -0.14213704f, -0.12440553f, -0.14296293f, 0.11302956f, 
    -0.18620342f, -0.06699446f, -0.03598468f, 0.14316627f, -0.17252128f, 0.08129514f, -0.13344347f, -0.05675838f, 
    0.06373702f, -0.05695877f, -0.10121934f, -0.16442797f, -0.09164172f, -0.15861256f, -0.01858937f, 0.16720745f, 
    0.12908553f, -0.12067274f, 0.09939447f, 0.04772699f, -0.11483558f, -0.16559973f, -0.04697764f, -0.09050801f, 
    0.04928512f, 0.03151848f, -0.17060634f, -0.02419925f, 0.15979530f, -0.09173080f, -0.10223950f, -0.12973370f, 
    0.07959130f, 0.04078133f, 0.07988665f, -0.00356992f, -0.19831716f, -0.16562736f, -0.09187226f, -0.12010983f, 
    -0.47073838f, -0.17460173f, 0.14022358f, -0.01756019f, 0.23720971f, 0.04805809f, 0.07694861f, -0.07992728f, 
    -0.32976636f, -0.48217317f, -0.12113302f, -0.00608710f, -0.04198327f, 0.22188930f, 0.49152148f, 0.19666331f, 
    -0.06397328f, -0.24096778f, 0.53556764f, 0.00658888f, -0.03325506f, 0.02518844f, -0.32872537f, 0.46597001f, 
    -0.08376712f, 0.50163817f, 0.13249063f, -0.20824808f, 0.25321123f, -0.44025952f, -0.26112324f, 0.15989770f, 
    -0.13148326f, -0.09441010f, 0.33122042f, 0.03723088f, -0.06565763f, 0.12161518f, 0.30955601f, 0.08296726f, 
    -0.01835853f, -0.08680500f, 0.07701052f, 0.05834776f, -0.15129715f, 0.07354287f, 0.26993707f, -0.29777297f, 
    -0.14251974f, -0.13728134f, -0.35609391f, 0.15951715f, 0.11754205f, -0.06012794f, -0.03349508f, -0.02090320f, 
    0.41960239f, -0.07418820f, 0.02589500f, -0.31712398f, 0.07286789f, 0.08595643f, 0.11035179f, 0.37466758f, 
    -0.40818739f, 0.03229767f, 0.31985575f, -0.17559078f, 0.72595835f, 0.02437362f, -0.25243098f, -0.01336720f, 
    0.24657300f, 0.07612305f, 0.07984073f, 0.15818979f, 0.07654862f, -0.31310555f, -0.00344032f, -0.10625708f, 
    -0.00113346f, 0.28882697f, -0.52443796f, -0.00307449f, 0.02678956f, 0.06384141f, -0.04300061f, -0.72707283f, 
    0.58144546f, -0.80229163f, -0.12288319f, -0.06168836f, 0.12609552f, -0.00774451f, -0.19492385f, 0.14864480f, 
    0.23814440f, 0.34465107f, -0.21684587f, 0.12342934f, 0.41701698f, -0.10184719f, -0.02803471f, 0.09357366f, 
    -0.39915219f, 0.53901923f, 0.00889594f, -0.16424316f, -0.02860452f, 0.55607140f, -0.23065050f, 0.32451844f, 
    -0.26198539f, 0.22536032f, 0.23293166f, 0.12817676f, -0.50369483f, -0.29203236f, -0.26007664f, -0.54110968f, 
    -0.40399852f, 0.41572341f, -0.12542501f, 0.43260315f, 0.18128660f, -0.08494741f, 0.11052292f, -0.12047291f, 
    0.07049181f, 0.09008607f, -0.11029094f, 0.11013452f, -0.08712927f, -0.05327935f, 0.06666822f, -0.06211788f, 
    -0.13912676f, -0.00406190f, 0.01750247f, -0.17583418f, 0.01717684f, -0.15528576f, -0.12342829f, -0.15983258f, 
    -0.03035915f, -0.01443079f, -0.16354682f, -0.11900921f, -0.12461086f, 0.01837944f, 0.08354561f, 0.04551093f, 
    0.02717814f, -0.14537907f, 0.00942572f, 0.01581179f, -0.15039243f, -0.05553079f, -0.08084617f, -0.13664606f, 
    -0.00295886f, -0.41736233f, 0.24358626f, 0.07688957f, 0.31406474f, 0.17638585f, -0.51335871f, -0.14067125f, 
    0.53428072f, 0.32207036f, 0.01763963f, -0.05131541f, -0.04226989f, 0.24480085f, -0.08313784f, 0.35278976f, 
    0.01328873f, 0.17284533f, -0.18344337f, 0.13615522f, -0.31864986f, -0.09678524f, -0.21369605f, -0.37086374f, 
    0.01947852f, -0.01179601f, 0.06336045f, 0.43137085f, 0.44859698f, -0.09729531f, 0.13345908f, 0.04488031f, 
    -0.12438241f, 0.40494952f, 0.14691639f, -0.07090232f, -0.10678004f, 0.08251981f, 0.06586496f, 0.05596780f, 
    -0.14850886f, 0.20390807f, -0.14391690f, 0.04072233f, -0.05175661f, -0.15647513f, 0.19213280f, -0.27072290f, 
    -0.02922593f, -0.04244024f, -0.82789111f, -0.16611511f, -0.19061255f, -0.27832612f, -0.29159120f, -0.42645827f, 
    0.31403694f, -0.08285490f, 0.04598603f, -0.21584451f, 0.17275114f, 0.05579896f, 0.28269288f, 0.32524866f, 
    0.14487103f, -0.10204127f, -0.06779235f, -0.00320664f, -0.02550035f, -0.16934943f, -0.01389405f, -0.21080531f, 
    -0.04799793f, 0.07586517f, 0.15190363f, -0.03869308f, 0.15165652f, 0.10682295f, -0.01784267f, 0.05996995f, 
    -0.13138367f, -0.18850653f, 0.05448312f, -0.16695184f, 0.05299349f, 0.12190621f, 0.14015631f, 0.03582788f, 
    -0.06543136f, 0.00345621f, -0.12175685f, 0.03162112f, -0.20040740f, -0.18585749f, -0.10892588f, 0.00391741f, 
    -0.50692087f, 0.98108929f, -0.15123917f, 0.09118856f, -0.53584188f, -0.00963311f, 0.74013287f, 0.20646009f, 
    -0.16374095f, 0.07838065f, 0.11757366f, -0.05570686f, -0.02451618f, 0.00280109f, 0.33550411f, 0.11602776f, 
    0.06742470f, -0.21997735f, 0.66908836f, 0.04201898f, 0.03342203f, 0.20323411f, 0.02976903f, 0.30381536f, 
    0.23507138f, 0.80642796f, 0.16694854f, -0.32362515f, -0.06070000f, 0.08063779f, 0.04843932f, 0.18453409f, 
    0.07328740f, 0.25522220f, 0.31159750f, 0.04570214f, -0.10718326f, 0.11562939f, 0.15838827f, 0.22562297f, 
    0.39471778f, -0.21090336f, 0.14995441f, -0.15439567f, 0.04890931f, -0.11705392f, 0.45550752f, -0.20515947f, 
    -0.28824711f, -0.01238809f, 0.22620597f, 0.05684938f, 0.73352921f, -0.28399700f, 0.06366765f, 0.41024500f, 
    0.24816234f, -0.07243240f, 0.08091788f, -0.13343640f, -0.06544275f, 0.22759561f, -0.11482038f, 0.06674279f, 
    -0.11623312f, 0.22461039f, 0.00253171f, -0.15373619f, -0.34702075f, 0.15067600f, 0.31331378f, 0.10672780f, 
    0.18641543f, -0.15398265f, -0.04144886f, -0.00689080f, -0.06250693f, -0.07505966f, 0.30242664f, -0.35433480f, 
    0.29988810f, 0.16893984f, -0.19038822f, 0.03931603f, 0.02000821f, 0.11286618f, 0.14381042f, 0.64225233f, 
    0.37461087f, -0.00063540f, -0.18590143f, -0.03651524f, -0.22815445f, -0.11938822f, 0.32325372f, 0.28678784f, 
    -0.07958705f, 0.11635584f, -0.09662496f, 0.07930184f, -0.19758219f, -0.13077132f, -0.03278622f, -0.18559569f, 
    -0.06071789f, -0.22073777f, -0.00227787f, -0.07230176f, -0.09135171f, -0.17424352f, -0.13947093f, -0.08423907f, 
    -0.04602662f, -0.08904335f, -0.04865978f, 0.08812415f, 0.07603240f, 0.09361977f, 0.06168282f, 0.02325551f, 
    0.01532638f, 0.01507919f, -0.05552268f, -0.07919714f, -0.17675216f, -0.03132646f, -0.01635432f, -0.17604814f, 
    0.27046105f, -0.15465967f, -0.09535721f, 0.13312267f, 0.58599490f, 0.01895042f, 0.05673477f, 0.26602992f, 
    -0.36444011f, -0.03169995f, 0.13034748f, -0.11173517f, 0.11088509f, 0.25611892f, -0.13255036f, 0.45262191f, 
    -0.08977798f, 0.19982241f, 0.26038653f, -0.03450792f, 0.15917888f, 0.05936336f, -0.17450105f, -0.00826898f, 
    -0.12257317f, -0.00134230f, -0.12606087f, 0.19860406f, 0.16933414f, -0.04615096f, -0.16714594f, -0.26121235f, 
    0.45339951f, 0.19673266f, -0.04512911f, -0.02345110f, -0.94628221f, -0.15888195f, 0.28165966f, -0.34255981f, 
    0.48456523f, 0.26358828f, -0.11927405f, 0.05058321f, -0.06665401f, 0.26003113f, 0.33417642f, -0.04193034f, 
    -0.32093066f, -0.15797313f, 0.08287936f, 0.09436926f, -0.48595306f, 0.24574657f, 0.29570660f, -0.26345134f, 
    -0.16567786f, -0.09606985f, 0.03065571f, 0.19162731f, -0.03627452f, 0.24559651f, -0.27529252f, 0.05469485f, 
    0.56494355f, -0.31465486f, 0.08754393f, 0.01746112f, -0.11342166f, 0.13552912f, -0.23481479f, -0.41693085f, 
    0.46735623f, -0.18978976f, -0.12739803f, -0.13146672f, -0.08124135f, -0.26152110f, 0.19289196f, 0.52667135f, 
    -0.35436860f, 0.02833515f, 0.03987212f, 0.03739563f, 0.37473837f, -0.20946151f, -0.17004201f, 0.01661994f, 
    -0.04776628f, -0.01413688f, -0.05316500f, 0.22217771f, 0.30918100f, -0.09468910f, -0.39687043f, -0.26192954f, 
    -0.01269246f, 0.00953089f, -0.00709906f, -0.09105584f, -0.41472435f, -0.02348761f, -0.04111981f, -0.48864788f, 
    0.47434041f, 0.16124359f, -0.09315108f, 0.04909033f, 0.13110979f, 0.32762364f, 0.18398698f, -0.05306552f, 
    0.24963216f, 0.05678285f, 0.18940866f, 0.02697156f, -0.38568604f, 0.01958433f, 0.05747743f, 0.13568549f, 
    0.01420260f, 0.06895465f, -0.02497889f, 0.31082687f, 0.05327698f, -0.20270652f, 0.43790567f, 0.08221297f, 
    -0.20557140f, 0.37536752f, 0.22635116f, 0.09916005f, 0.25511768f, 0.11175475f, 0.24322905f, -0.43041730f, 
    0.29533756f, 0.17879052f, 0.09732786f, -0.10691458f, -0.00473502f, -0.30348933f, 0.18732829f, 0.01762062f, 
    -0.55819952f, -0.12308735f, 0.14647728f, 0.03452474f, 0.37722349f, 0.06601884f, -0.22834556f, 0.17594846f, 
    0.41605201f, -0.44884330f, 0.12854937f, 0.04230175f, -0.14716317f, 0.53190702f, -0.68002725f, -0.16863003f, 
    0.32185891f, -0.61334300f, 0.33156618f, 0.08544631f, 0.08541125f, -0.17130220f, -0.32806116f, 0.39145520f, 
    0.16210623f, -0.27894387f, 0.03663545f, 0.08867267f, -0.08038052f, -0.04315490f, 0.30306503f, -0.07357583f, 
    -0.03069414f, -0.03909731f, 0.85276771f, -0.07239842f, 0.15238544f, -0.12370043f, 0.00808699f, 0.81129026f, 
    0.26466441f, 0.29246518f, 0.11670965f, -0.17712542f, 0.34727010f, -0.57819676f, 0.21159327f, 0.31194797f, 
    -0.04207916f, -0.18177770f, 0.43960720f, 0.02189259f, -0.33588865f, 0.04073665f, -0.04408035f, -0.11524171f, 
    0.26799324f, -0.07230870f, -0.11383115f, 0.01767110f, 0.07228650f, -0.38960448f, 0.53108180f, 0.12421025f, 
    0.00291382f, -0.16544183f, 0.03637556f, -0.11235245f, -0.29923031f, -0.29896429f, -0.02450717f, 0.81495029f, 
    0.02772653f, 0.08905295f, -0.15768373f, -0.11252272f, 0.31548303f, 0.10078530f, -0.35858238f, 0.27987480f, 
    0.00677001f, 0.10169518f, -0.16673180f, 0.00448040f, -0.18155730f, 0.03828929f, -0.21133715f, 0.00231531f, 
    0.04367879f, -0.11910754f, 0.10859758f, 0.01526184f, 0.09238135f, -0.01274546f, -0.07712073f, 0.03380826f, 
    0.09319945f, -0.19866171f, 0.08500171f, 0.14726734f, -0.00565828f, -0.17886584f, 0.03153090f, 0.12983850f, 
    -0.06574996f, -0.02868563f, -0.15233293f, 0.00148160f, 0.08617464f, 0.09747438f, -0.00445400f, -0.17351344f, 
    0.35313457f, -0.04694911f, -0.44978014f, -0.00165496f, -0.15710461f, 0.07706665f, 0.04045746f, 0.01687699f, 
    0.16172515f, 0.12486164f, 0.08253692f, -0.10183178f, 0.05617757f, 0.38633284f, -0.14933510f, -0.14924239f, 
    0.14437748f, 0.05077469f, -0.19172513f, 0.16903664f, -0.08526977f, 0.05563184f, 0.19697289f, 0.01523582f, 
    -0.82517207f, 0.11086114f, 0.16790842f, 0.33046958f, -0.15042844f, -0.55425715f, 0.30985603f, -0.28837791f, 
    0.04868673f, -0.60166538f, 0.09211331f, -0.17506324f, 0.29056790f, 0.14971152f, -0.25374284f, -0.15537013f, 
    0.11007131f, -0.25294468f, -0.13913617f, -0.06199978f, -0.16318823f, 0.03566847f, 0.22367091f, -0.01989433f, 
    0.27757245f, -0.09597147f, 0.26967049f, -0.15192617f, 0.10643782f, 0.20099384f, 0.06724605f, 0.44884840f, 
    0.33804062f, -0.35787249f, 0.06941359f, 0.23965308f, 0.05532209f, -0.49411303f, 0.29053828f, 0.13746420f, 
    0.01036925f, -0.94147927f, 0.52499914f, -0.08405183f, 0.33916539f, -0.02542409f, -0.40324444f, 0.25433648f, 
    0.09985960f, -0.18675607f, 0.02832520f, -0.12210544f, -0.04266608f, 0.03211815f, 0.40393469f, 0.17064853f, 
    -0.20937216f, 0.02268210f, 0.76978397f, 0.06442972f, 0.06808375f, -0.68322164f, -0.17209028f, 0.16176106f, 
    0.20853466f, -0.02517393f, 0.14189798f, 0.05566783f, 0.44618231f, -0.74269128f, -0.26462591f, 0.11344467f, 
    0.05952231f, -0.09214106f, -0.00136503f, -0.15900911f, -0.10733592f, -0.04868045f, 0.08827286f, -0.07004245f, 
    -0.05321663f, -0.18355536f, -0.07625393f, 0.15887165f, -0.01856246f, -0.16331361f, -0.09404313f, -0.03344493f, 
    -0.04388873f, 0.09913318f, 0.15720183f, 0.12355684f, 0.11065327f, -0.18663564f, 0.04898980f, -0.01304257f, 
    0.13075042f, 0.10852440f, 0.03730550f, -0.12046703f, -0.14733657f, -0.09602919f, -0.01753726f, -0.17583551f, 
    0.73383778f, -0.19027413f, -0.06708229f, -0.10535711f, 0.21226116f, -0.16677897f, -0.06697563f, 0.25158471f, 
    -0.03401853f, 0.35476774f, -0.01063370f, -0.10953368f, 0.11269333f, 0.44323006f, -0.23856632f, -0.35229653f, 
    -0.07200801f, 0.12986946f, 0.13781731f, -0.02563184f, -0.02186709f, 0.03021544f, 0.04767104f, -0.18892030f, 
    -0.01482073f, -0.66165954f, 0.03773313f, 0.49931383f, -0.00821349f, 0.14295635f, 0.34739771f, 0.05576530f, 
    0.08370923f, -0.12969287f, 0.17428333f, 0.00907394f, 0.03803223f, -0.07410503f, 0.33979130f, -0.67017031f, 
    0.52282035f, 0.22203676f, 0.01458069f, 0.05259655f, -0.07664306f, 0.05610384f, 0.41183278f, -0.07733659f, 
    -0.15023270f, 0.15912780f, -0.25602582f, -0.02029067f, -0.00811368f, -0.48722205f, 0.24003664f, -0.19397148f, 
    0.03116043f, -0.09069384f, 0.02343499f, 0.48371708f, 0.26096290f, 0.06070763f, -0.12119202f, -0.13108954f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.05681911f, 0.33070159f, -0.10783684f, 0.18415292f, -0.15363500f, -0.01573367f, -0.01420515f, 0.01818601f, 
    0.04668734f, 0.30624089f, -0.16280992f, 0.31011826f, -0.02613043f, -0.19375050f, 0.39082456f, 0.10157704f, 
    -0.08019020f, -0.17333262f, -0.06724408f, 0.34098774f, 0.04541152f, 0.33566937f, -0.13078724f, 0.50958073f, 
    0.39506593f, -0.14296053f, -0.24255702f, 0.12008962f, 0.25548342f, -0.11416946f, -0.11126475f, 0.16310553f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.25424790f, -0.77132529f, -0.08881091f, 0.31211993f, -0.01947049f, -0.07901220f, -0.28637770f, -0.27520633f, 
    -0.49740845f, 0.24805579f, 0.16578342f, 0.01583578f, -0.57473767f, 0.13518596f, 0.01163279f, -0.78280210f, 
    -0.38753220f, 0.09913170f, 0.41015789f, 0.04504097f, 0.08262558f, -0.04187791f, -0.36814597f, -0.45395193f, 
    0.30422348f, -0.15896238f, 0.48414922f, -0.23968594f, -0.31324047f, 0.04533025f, 0.12514968f, 0.19387068f, 
    -0.23998916f, -0.82688761f, -0.11187704f, 0.09569941f, 0.04486897f, -0.04454741f, 0.40686744f, -0.09392513f, 
    -0.26205364f, 0.09154014f, 0.08268014f, 0.07289077f, -0.17788213f, 0.05423241f, -0.06892180f, -0.19187294f, 
    -0.16471981f, -0.00412078f, 0.26845530f, 0.16802540f, 0.45405680f, -0.07329430f, -0.27358645f, 0.41232011f, 
    0.11303158f, -0.16391592f, -0.69086277f, 0.26920098f, 0.48078626f, 0.13144639f, 0.08703000f, -0.04848086f, 
    -0.24458006f, 0.36585030f, 0.14061023f, 0.22339916f, -0.12482879f, 0.05863231f, -0.74685508f, 0.26730883f, 
    0.01013957f, -0.49443829f, 0.09271266f, -0.55399013f, -0.07692447f, 0.00129061f, 0.30751759f, 0.21401004f, 
    0.14615884f, 0.06359907f, -0.07055348f, 0.44992694f, -1.08693814f, -0.13110107f, 0.36366358f, -0.41672468f, 
    0.25138018f, -0.06620556f, -0.28856885f, 0.10279599f, -0.69062412f, -0.08828284f, -0.16667068f, 0.06197539f, 
    -0.22639245f, 0.12073498f, -0.00432056f, 0.06784070f, 0.01164404f, 0.15551378f, 0.43482223f, -0.34652889f, 
    -0.44478106f, 0.16931731f, 0.09521808f, 0.11598924f, -0.00274162f, 0.07987858f, 0.03765466f, -0.14044720f, 
    -0.02516381f, -0.12111714f, -0.32496986f, 0.39737558f, -0.07804928f, 0.25577256f, -0.33750072f, -0.21796516f, 
    0.23887338f, -0.07262256f, 0.30072013f, -0.45101592f, -0.35182622f, 0.04558945f, 0.13829672f, 0.15623343f, 
    0.02223600f, 0.39217782f, -0.02569236f, 0.10769084f, -0.05649828f, 0.02842825f, -0.14615966f, -0.65875733f, 
    0.32709220f, 0.19320168f, 0.07140205f, 0.07567626f, -0.14195968f, -0.00170309f, -0.62017584f, -0.34646177f, 
    0.07467685f, -0.09289972f, 0.25778738f, -0.05194086f, -0.33123836f, 0.15602389f, 0.43509784f, -0.70890480f, 
    -1.07064378f, -0.05279451f, -0.39538807f, -0.00547705f, -0.40126714f, 0.08566657f, 0.21284875f, 0.13958414f, 
    -0.17587943f, -0.64718378f, -0.02665735f, 0.09278987f, 0.06407925f, -0.08554028f, -0.55995351f, 0.28244957f, 
    -0.00680458f, -0.26852620f, 0.14107616f, 0.04109172f, 0.18703772f, -0.02033107f, -0.41717967f, -0.07040077f, 
    0.37717366f, -0.20343897f, -0.31010222f, 0.20101249f, -0.04524886f, 0.07980904f, -0.40774897f, 0.14612201f, 
    0.02192284f, 0.04061811f, 0.16601308f, 0.26479343f, 0.03291725f, 0.05732750f, 0.25709152f, 0.26056099f, 
    0.33999142f, 0.48390174f, 0.15232122f, -0.67472285f, -0.04616228f, 0.07218350f, -0.27632484f, 0.20481679f, 
    -0.39657018f, -0.39976379f, 0.06979813f, -1.03421652f, 0.26512504f, -0.07686240f, 0.40021089f, 0.26314232f, 
    0.41481382f, -0.16313756f, -0.31849214f, -0.56645101f, -0.18639252f, -0.59102964f, -0.88081968f, 0.09063578f, 
    -0.17694606f, -0.13109340f, -0.36556369f, -0.22089289f, -0.65418690f, 0.02482997f, -0.33530596f, -1.65646708f, 
    0.09035199f, -0.32167935f, -0.03796038f, -0.59301496f, -0.16215894f, 0.04283010f, -0.31523997f, 0.09401272f, 
    0.50230801f, 0.43012974f, -0.05287263f, 0.41233030f, 0.28138641f, 0.04027129f, -0.34067416f, -0.34921724f, 
    -0.64127386f, 0.13426983f, 0.30594587f, -0.71198416f, -0.35801348f, -1.06278479f, -0.24528773f, -0.05653717f, 
    -0.53748095f, -0.07646859f, -0.56334084f, -0.17075251f, 0.32125682f, 0.16241333f, 0.25773999f, -0.43428817f, 
    -0.17872347f, -1.09488785f, -0.12163437f, -0.97095764f, -0.08799109f, -0.08836006f, -0.16990301f, 0.07383876f, 
    0.19165426f, -0.96425378f, -0.04380608f, 0.26468185f, -0.06634462f, -0.03446060f, -0.31242353f, -0.11860821f, 
    0.17825101f, -0.10922774f, -0.44497806f, -0.78251427f, -0.31282628f, 0.29104331f, -1.40380323f, 0.30324683f, 
    0.37892291f, -0.08168253f, -0.53718662f, 0.40768486f, 0.41371000f, -0.00580197f, -0.36349320f, 0.03019125f, 
    0.32102683f, 0.34560704f, 0.09070391f, 0.03754127f, -0.16183627f, 0.16233668f, -0.73939967f, -0.03080881f, 
    -0.18217106f, 0.38542667f, 0.16565962f, 0.05918096f, 0.23232307f, -0.03223942f, 0.26040912f, -0.33705595f, 
    0.09010096f, -0.18867697f, -0.40799466f, -0.07142894f, -0.34166017f, 0.12612844f, -0.93853849f, -0.16796540f, 
    -0.57379889f, -0.15674965f, -0.87278527f, -0.45075095f, -0.91166717f, -0.08034375f, -0.20158660f, -0.28367430f, 
    -0.53872532f, -0.26980901f, -0.15200508f, -0.46084648f, 0.08103039f, 0.01262107f, -0.96276629f, -0.07734874f, 
    0.51083219f, -0.46947408f, -0.13001186f, 0.16912758f, 0.04120257f, -0.03414084f, -0.48423964f, 0.26122695f, 
    -0.08054054f, -0.05158101f, 0.22105663f, -0.20234333f, 0.39045578f, -0.27006477f, 0.67942733f, 0.00334020f, 
    0.26103011f, -0.15569556f, -0.34049794f, -0.13746811f, 0.14762476f, 0.03206889f, -0.41435993f, 0.18166170f, 
    0.32991999f, -0.29600492f, -0.03316725f, -0.22331080f, 0.16506954f, -0.06781632f, 0.76349324f, 0.18762985f, 
    -0.52673078f, -0.31545398f, 0.07032695f, -0.32944760f, -0.11436690f, -0.08842070f, 0.21640675f, 0.29247516f, 
    0.13670549f, 0.04243296f, 0.14123334f, -0.02156453f, -0.35665891f, -0.27984458f, -0.63023448f, 0.10273904f, 
    0.31523296f, -0.03218953f, 0.29033166f, 0.02646523f, -0.07569976f, 0.12843053f, -0.71587139f, -0.12851295f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.00701636f, 0.32681063f, 0.10486054f, 0.01612214f, -0.20165838f, -0.43833405f, -0.09579128f, 0.10562792f, 
    0.38704675f, 0.29191190f, 0.06054282f, -0.15346643f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
