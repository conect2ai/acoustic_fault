#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.22544782f, -0.50667351f, -0.10580453f, -0.07176103f, 0.60871744f, -0.20946743f, -0.24916516f, -0.23495938f, 
    -0.56480438f, -0.08124013f, -0.29580221f, 0.89520174f, -0.09417365f, -0.26152831f, 0.05936497f, -0.28634039f, 
    -0.31747681f, -0.33644098f, 0.48280573f, 0.28759477f, 0.10887776f, -0.36989981f, 0.00417601f, 0.57331669f, 
    -0.00903899f, -0.42571458f, -0.13999180f, 0.20807612f, 0.17519702f, 0.23333518f, 0.72855842f, 0.76879275f, 
    0.23979317f, -0.27361649f, 0.04550621f, -0.24236639f, 0.77903950f, 0.59685630f, 0.74106836f, 0.25351161f, 
    0.10593026f, 0.10938919f, 0.31600910f, 0.36196956f, -0.14156619f, 0.50066632f, 0.61311567f, 0.35766530f, 
    -0.73722738f, 0.49444613f, -0.32178873f, 0.09628925f, -0.06140174f, -0.05726837f, -0.69647515f, -0.32318938f, 
    -0.26199904f, 0.28470111f, 0.67012638f, 0.40190038f, 0.14902236f, 0.06868435f, 0.21769199f, -0.44603187f, 
    -0.43314964f, -0.67315346f, -0.53351921f, 0.12047449f, 0.58511090f, -0.05111375f, -0.20097511f, -0.14220779f, 
    0.65617448f, 0.02372908f, 0.51118910f, 0.42217174f, -0.38529408f, -0.08494154f, 0.22482039f, 0.52999490f, 
    0.17221327f, 0.01588057f, 0.97599274f, -0.66984022f, 0.36977112f, 0.19818720f, -0.26474097f, 0.22185454f, 
    -0.05599850f, 0.00596987f, 0.60273737f, 0.30835643f, 0.21500793f, 0.25528061f, 0.06202190f, -0.59967256f, 
    -0.33614779f, -0.28068376f, 0.29695311f, 0.50921482f, -0.71795088f, -0.09076792f, -0.27661711f, -0.77473706f, 
    -0.18024974f, -0.19081129f, -0.02992122f, 0.18383089f, -0.57585168f, -0.56483424f, -0.38213894f, 0.23310843f, 
    0.52387500f, -0.30625781f, 0.47562429f, -0.27962384f, 0.02689093f, -0.24958819f, -0.31158337f, -0.53132737f, 
    -0.15834165f, 0.19232436f, -0.62045294f, -0.43826327f, -0.03546646f, 0.06551637f, 0.26817200f, -0.60408211f, 
    -0.49766168f, -0.53651685f, -0.13045754f, -0.25004491f, 0.00704597f, 0.10924062f, -0.06751619f, 0.35393673f, 
    0.49970871f, 0.33437583f, -0.60510862f, -0.71273220f, -0.44880641f, -0.18272774f, 0.13189819f, -0.00637502f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.02412810f, -0.32772517f, -0.10222926f, 0.10842995f, 0.06096933f, -0.29774067f, -0.00443156f, 0.15142436f, 
    -0.29137835f, -0.23199064f, -0.00152165f, -0.01931133f, -0.11922447f, -0.33842063f, 0.38880536f, 0.35676920f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.01230639f, -0.11882491f, -0.14816357f, 0.20186570f, -0.01136081f, -0.13772233f, 0.11409938f, -0.18135294f, 
    -0.07738543f, -0.20144306f, 0.01804882f, -0.13210987f, 0.08326719f, 0.07878625f, -0.04109849f, -0.19513747f, 
    0.03724091f, -0.03926882f, -0.28339818f, -0.00410009f, 0.00022857f, 0.00828601f, -0.20713393f, -0.10424677f, 
    0.05528911f, 0.03153050f, 0.03279239f, 0.26168975f, 0.08233839f, 0.13896796f, 0.05119463f, 0.06236201f, 
    -0.11914613f, 0.00548465f, 0.03556254f, -0.05425312f, -0.08216755f, 0.05754853f, 0.16332692f, -0.04203834f, 
    -0.03046560f, -0.00139753f, 0.01791094f, -0.02575787f, 0.08578914f, 0.11475286f, 0.20228989f, -0.19740285f, 
    0.06412115f, 0.08178301f, 0.16070138f, -0.02119515f, 0.09385954f, -0.07480296f, 0.17922133f, 0.23186895f, 
    0.05686339f, -0.09760880f, -0.02670480f, -0.02323526f, 0.02536996f, 0.03538061f, -0.07285231f, 0.48240778f, 
    0.06178365f, 0.14028981f, 0.07060570f, -0.30104196f, -0.05917876f, -0.00228065f, 0.04418027f, 0.11275539f, 
    -0.44247556f, 0.04635576f, 0.05519567f, -0.11550820f, 0.12762506f, -0.13675040f, 0.13360670f, 0.00104290f, 
    0.20104545f, 0.04588494f, -0.43012968f, -0.24752595f, -0.08419099f, -0.14960040f, -0.00758439f, -0.06615131f, 
    0.06566910f, 0.08733623f, -0.07778864f, -0.22149809f, 0.02560124f, 0.05762615f, 0.22830868f, -0.01499272f, 
    -0.08075572f, -0.24652827f, 0.08412300f, -0.53153551f, 0.14519814f, -0.07218391f, 0.09544858f, 0.16441366f, 
    0.05333635f, -0.15402356f, 0.03414535f, -0.11160558f, 0.09907709f, -0.02119999f, 0.12057197f, -0.00905011f, 
    0.01071225f, -0.05915219f, 0.07258870f, 0.00785118f, 0.00829539f, -0.10790697f, -0.21671084f, 0.00299437f, 
    0.01887146f, 0.17695534f, 0.21189153f, -0.11284619f, 0.02866733f, 0.13387381f, 0.20375048f, -0.28808218f, 
    -0.04709902f, 0.20003736f, 0.08109792f, 0.13633989f, -0.05359662f, -0.01736901f, 0.00521977f, -0.25614569f, 
    0.02965065f, -0.28441530f, -0.05324739f, -0.02753502f, 0.04736700f, -0.03522515f, -0.07533018f, 0.04803108f, 
    0.10871600f, 0.33101571f, 0.21233474f, -0.01604096f, -0.10998727f, -0.06035917f, 0.07333866f, -0.00114866f, 
    0.05421759f, -0.00007448f, -0.15229359f, 0.20620401f, 0.00176385f, -0.00471702f, 0.09505770f, 0.13315779f, 
    -0.11674278f, -0.02786140f, 0.00092058f, -0.25015414f, -0.06697942f, -0.05009466f, -0.23565322f, 0.12426842f, 
    0.17531095f, 0.03494553f, -0.20399593f, 0.08435071f, 0.04201593f, -0.14465982f, 0.04545210f, 0.18744051f, 
    0.12805919f, 0.03331057f, -0.14295503f, -0.01232396f, -0.19114688f, -0.12498408f, 0.11959690f, -0.01236164f, 
    -0.09948817f, 0.03242089f, 0.07930612f, 0.03903722f, -0.01737427f, 0.21522598f, -0.16355595f, -0.01027291f, 
    0.04072541f, -0.06753426f, 0.08373907f, -0.02860304f, -0.05212165f, 0.06559450f, 0.09769604f, 0.02087478f, 
    0.10574063f, 0.20910081f, -0.03919103f, 0.08349531f, 0.10464055f, 0.17862411f, 0.10733232f, 0.19599719f, 
    -0.30107540f, 0.04227969f, 0.07689196f, 0.06285962f, 0.06475360f, -0.07747835f, 0.15648046f, 0.08822536f, 
    -0.11132015f, -0.08141088f, -0.07757073f, -0.11389690f, 0.10896272f, -0.04712243f, -0.19020814f, 0.04916252f, 
    -0.15510575f, -0.21329774f, 0.27095431f, 0.02331272f, -0.10189177f, -0.11985147f, 0.00432084f, -0.13595052f, 
    -0.14529276f, -0.04702771f, -0.29176334f, 0.09940317f, -0.11613357f, -0.10578158f, 0.06137058f, -0.01542808f, 
    -0.12918909f, -0.08061508f, -0.14593747f, 0.42024305f, 0.21760544f, 0.01137481f, -0.15228932f, -0.03717965f, 
    -0.11394206f, -0.02899826f, 0.01783532f, 0.06620455f, -0.11455595f, 0.17626213f, 0.14467619f, 0.07826628f, 
    -0.02313364f, 0.00891043f, 0.00680657f, 0.11752193f, -0.13568442f, -0.13440616f, 0.05193811f, 0.11948387f, 
    -0.02826824f, 0.09693540f, 0.01906327f, -0.01549882f, -0.26948720f, -0.04546346f, 0.28353861f, 0.13203329f, 
    0.07023296f, -0.28566390f, 0.06617429f, -0.04959484f, -0.02342060f, -0.09481950f, 0.06079505f, -0.01749161f, 
    -0.29345334f, -0.00193020f, -0.06081694f, -0.09680710f, -0.27796558f, 0.00679072f, -0.09723658f, -0.01853154f, 
    -0.04528795f, -0.05737842f, -0.06329795f, -0.03849355f, 0.12218983f, -0.01482924f, 0.06790806f, -0.08848806f, 
    -0.11881790f, -0.42606735f, 0.15919897f, 0.25594264f, -0.23620135f, 0.13438755f, -0.10636310f, 0.09354521f, 
    -0.08128118f, -0.01363718f, -0.10339660f, -0.20514831f, 0.09547564f, 0.07297600f, 0.03245467f, 0.11998218f, 
    0.03521010f, 0.09114861f, 0.12174231f, -0.08764264f, 0.12343858f, -0.10930594f, -0.17336780f, -0.14928111f, 
    -0.27027360f, -0.01895064f, 0.08518936f, 0.22532201f, 0.08849702f, 0.26232013f, -0.03548664f, 0.11884481f, 
    -0.04611096f, -0.00761796f, -0.13837567f, 0.03075635f, -0.01765770f, 0.22819906f, -0.16775994f, -0.24660367f, 
    -0.04367245f, -0.04586469f, -0.20334998f, 0.00515390f, 0.11239871f, 0.04410039f, 0.05375407f, -0.12617771f, 
    0.11100351f, -0.13942227f, -0.11577818f, 0.00400145f, -0.05598585f, 0.01533956f, -0.11155926f, -0.07369500f, 
    0.25083125f, 0.16643481f, 0.03670539f, -0.00896332f, 0.05635311f, 0.01441987f, 0.06180312f, 0.02617229f, 
    0.02287640f, 0.28493133f, 0.09621532f, 0.09485769f, 0.12235685f, -0.01405035f, 0.06635843f, 0.14490806f, 
    0.18726844f, -0.07714032f, 0.01204646f, -0.33638445f, -0.12124608f, 0.30788344f, 0.10948786f, 0.05582403f, 
    0.11515967f, -0.03796407f, -0.18903574f, -0.01425771f, -0.01368958f, -0.06202675f, -0.01107126f, -0.13239324f, 
    0.07421614f, -0.10386749f, 0.07515395f, 0.01920235f, -0.08331913f, 0.00675290f, 0.10862818f, 0.02673842f, 
    0.10032336f, 0.08622865f, 0.08859918f, -0.02741733f, -0.11849988f, -0.07276711f, -0.06705963f, -0.19585018f, 
    -0.07412922f, 0.07915374f, -0.02050040f, -0.00972214f, -0.14936975f, -0.16852471f, -0.07144509f, -0.27097982f, 
    0.09385980f, 0.12711874f, 0.10588235f, -0.07130310f, 0.07557043f, -0.12734316f, -0.33848932f, 0.03026216f, 
    0.14396954f, 0.27320659f, 0.03657071f, 0.01422427f, -0.13798495f, 0.03077021f, -0.01115022f, 0.32790029f, 
    -0.06971047f, -0.18611681f, 0.19060521f, 0.12710692f, 0.05428674f, -0.02442926f, 0.08249640f, -0.11670865f, 
    -0.04810675f, 0.00915283f, 0.03093423f, 0.06456243f, -0.01250730f, 0.01583773f, -0.01558057f, -0.08973853f, 
    0.01804656f, -0.06456330f, 0.00193218f, 0.01835217f, 0.06602252f, 0.01049923f, -0.08089654f, 0.04717566f, 
    0.02550184f, -0.05506184f, -0.02562308f, -0.07306743f, 0.00822239f, -0.00499572f, 0.06352684f, 0.06120670f, 
    0.03534345f, 0.00052011f, -0.04813997f, 0.00387411f, -0.06653175f, -0.05426664f, 0.00432127f, -0.03241090f, 
    0.05739430f, 0.04979340f, -0.06277148f, 0.02226661f, -0.07551096f, -0.06726984f, -0.01029535f, 0.05037967f, 
    -0.02285454f, 0.03394207f, 0.03766534f, -0.02650085f, 0.02426308f, 0.06678384f, -0.05457323f, -0.02839806f, 
    -0.07122204f, -0.06303626f, -0.06455065f, -0.02504296f, -0.03994815f, -0.02150821f, -0.05649140f, -0.07940318f, 
    -0.08414435f, -0.05757416f, -0.08313245f, 0.02604598f, 0.00130965f, 0.06003411f, -0.05677494f, -0.07335194f, 
    -0.06410707f, -0.00168247f, -0.09431660f, 0.03651404f, -0.02036954f, -0.01702975f, -0.09301165f, 0.00237410f, 
    -0.05558733f, 0.00255039f, -0.05649643f, 0.02401361f, 0.07267831f, -0.06436186f, 0.04400989f, -0.04445830f, 
    0.02545171f, -0.02706108f, -0.08731814f, -0.09208567f, -0.04962521f, -0.00789473f, 0.00825828f, -0.02387998f, 
    -0.02746325f, -0.02290180f, 0.02704565f, -0.07787668f, -0.04383621f, -0.03608064f, -0.00659225f, 0.02639098f, 
    -0.04947666f, -0.04993646f, -0.06681848f, 0.03038128f, 0.04720614f, -0.06121147f, -0.00388132f, -0.02291195f, 
    0.02985515f, 0.00973781f, -0.04324193f, 0.05491531f, -0.02277311f, -0.03749790f, 0.03662581f, -0.01967132f, 
    -0.01480709f, 0.01913570f, 0.05530745f, 0.05378280f, -0.00416701f, -0.07589175f, 0.06604335f, -0.05014221f, 
    0.03316062f, 0.00162944f, 0.01064609f, -0.00520534f, -0.00270245f, -0.05828638f, 0.00127125f, 0.03009310f, 
    -0.04438490f, -0.09635789f, -0.02943577f, -0.00497744f, 0.06413814f, -0.04354582f, 0.01387011f, 0.01098756f, 
    -0.01815900f, -0.01846837f, -0.05367405f, 0.00117498f, 0.03315192f, -0.00442318f, -0.01611888f, 0.05468903f, 
    0.23446724f, 0.08437274f, -0.26150361f, -0.06119858f, 0.07880149f, 0.07853451f, 0.03666263f, -0.13298437f, 
    -0.29264405f, -0.34155348f, -0.41948688f, -0.11819320f, -0.16744553f, -0.12456630f, -0.04529328f, -0.06106117f, 
    0.06664973f, -0.03817265f, -0.06102473f, -0.03688842f, -0.12405135f, 0.08771276f, -0.12371276f, 0.11038691f, 
    0.07186461f, 0.07603309f, 0.03776357f, 0.10684260f, 0.20654367f, 0.23379910f, -0.04306751f, 0.01714807f, 
    -0.06272256f, 0.01989752f, -0.02616468f, -0.00635680f, 0.06580641f, -0.02431512f, 0.28911346f, 0.10188622f, 
    0.12747990f, -0.05539131f, -0.04600122f, -0.06573717f, -0.00018588f, -0.21993507f, 0.09219873f, 0.02717206f, 
    0.04868196f, 0.13207155f, 0.11876290f, 0.07585376f, -0.14818887f, 0.03100807f, -0.39963442f, 0.08891957f, 
    -0.39115632f, 0.06227974f, 0.01876870f, 0.08963081f, 0.10448988f, -0.03599557f, -0.07582668f, -0.11923141f, 
    0.05672855f, -0.43839732f, 0.22702852f, -0.05026669f, 0.09259640f, 0.14624071f, 0.03095556f, 0.01965155f, 
    -0.16928343f, -0.22427051f, 0.17045917f, 0.12471869f, 0.01162316f, -0.04608119f, 0.06658791f, -0.08997993f, 
    0.08944052f, -0.16471916f, -0.13894708f, -0.16208372f, 0.09167604f, -0.01591324f, 0.03961235f, -0.10043804f, 
    -0.12727948f, 0.01325815f, 0.11434039f, 0.04154865f, 0.07252259f, -0.07850131f, -0.04357643f, 0.07711406f, 
    0.12437129f, -0.04370441f, 0.16201605f, -0.13142863f, -0.22262029f, 0.06726373f, -0.07336416f, -0.05191280f, 
    0.05841731f, 0.11308423f, 0.03130890f, 0.09792126f, -0.34558091f, 0.07897686f, -0.35291344f, -0.06258228f, 
    -0.08632165f, -0.07593931f, -0.08328069f, -0.00181371f, -0.03294111f, -0.36053774f, -0.26175237f, -0.67293549f, 
    -0.04930691f, -0.00807277f, -0.12621249f, -0.04159638f, 0.13038252f, -0.02107731f, -0.32317132f, -0.12789990f, 
    -0.00586214f, 0.14957580f, 0.02233807f, 0.12517390f, 0.17344731f, -0.00923550f, 0.06534531f, 0.26673475f, 
    -0.08597137f, 0.11266559f, -0.07930557f, -0.07347662f, 0.25830033f, 0.03208398f, -0.03005011f, 0.32883188f, 
    0.03519806f, -0.08994076f, 0.14896365f, -0.26266533f, -0.06824064f, -0.14680332f, 0.09322810f, 0.13762067f, 
    -0.02340210f, -0.26283205f, 0.03364945f, -0.26539215f, 0.02627151f, 0.04891520f, 0.00162918f, -0.22857453f, 
    -0.08284885f, -0.00132965f, 0.01801647f, -0.06521580f, -0.12692818f, 0.07665126f, 0.06115113f, 0.05506861f, 
    0.00622844f, 0.03143592f, -0.06216017f, -0.07350399f, 0.19848770f, 0.07236807f, 0.08129153f, 0.00162793f, 
    0.02495147f, 0.09709035f, 0.08131036f, -0.10164169f, -0.11320111f, -0.28349212f, -0.07613633f, 0.11467212f, 
    0.10721111f, 0.16954342f, -0.14018802f, -0.25277296f, -0.02780940f, -0.09958219f, -0.06819884f, 0.08285414f, 
    -0.01700545f, -0.06420980f, 0.03735836f, -0.09918325f, -0.01406316f, -0.06700006f, 0.27395886f, 0.10978640f, 
    0.09658582f, -0.37701046f, -0.14587785f, -0.06748749f, 0.01492626f, 0.01101377f, 0.00107758f, 0.20394221f, 
    -0.13800332f, -0.07694228f, -0.04960889f, 0.08380971f, -0.06091595f, -0.04139857f, 0.06593637f, 0.07575265f, 
    -0.05748708f, -0.22053576f, 0.14017783f, 0.11973634f, 0.06337474f, 0.10456757f, -0.10884104f, 0.12774886f, 
    0.09771083f, 0.29219145f, -0.12107030f, 0.12053562f, 0.04016061f, -0.14692026f, 0.16557707f, 0.01455002f, 
    0.08457092f, -0.03612049f, -0.21638665f, -0.30263209f, 0.09497983f, 0.07371180f, 0.13243379f, 0.12657970f, 
    -0.02384350f, -0.02855225f, -0.11550388f, 0.18506961f, 0.23527116f, -0.01798024f, -0.12016296f, 0.00065807f, 
    0.09731371f, 0.05988226f, -0.10832649f, 0.11910434f, -0.16833661f, 0.00326692f, 0.04610023f, -0.01498489f, 
    -0.03657717f, -0.08832972f, 0.06169116f, -0.12100078f, 0.12326497f, -0.40821958f, -0.24729468f, 0.08452005f, 
    0.00791739f, 0.05794442f, -0.13500062f, 0.00133793f, 0.08755583f, -0.11932271f, 0.35414356f, -0.07292774f, 
    -0.18904954f, -0.07509980f, -0.13574161f, -0.18953125f, -0.00837876f, -0.06113464f, -0.08170386f, 0.34391302f, 
    0.15610842f, 0.41812268f, 0.13112780f, 0.01489922f, 0.04433821f, -0.01393511f, -0.08000079f, -0.02078478f, 
    -0.10945194f, -0.14541781f, -0.30631557f, 0.01962893f, 0.14229956f, 0.00201848f, 0.15282336f, -0.06507947f, 
    0.07638972f, 0.14254287f, -0.02412559f, -0.17991920f, 0.01103604f, -0.11690664f, 0.14119084f, -0.13373198f, 
    0.15252249f, 0.03467965f, 0.17702132f, 0.13991050f, 0.24685560f, -0.10491346f, -0.04667575f, -0.09519890f, 
    0.10869152f, 0.07690029f, -0.00578298f, -0.11971800f, -0.25828719f, -0.13254656f, 0.02897599f, -0.03644548f, 
    -0.04731499f, 0.03082795f, -0.01939327f, 0.00291328f, 0.40575948f, 0.21913080f, 0.28178316f, -0.13893786f, 
    0.01732111f, 0.04619828f, 0.09100687f, 0.00226656f, -0.11266154f, 0.21422027f, 0.08270863f, 0.09322334f, 
    -0.02864379f, -0.01452626f, -0.11218885f, -0.13390373f, 0.03080665f, 0.08825956f, -0.63300508f, -0.50704288f, 
    -0.08857536f, -0.03395025f, -0.03182511f, -0.12990862f, -0.01630041f, -0.04296472f, -0.18831661f, -0.12989831f, 
    -0.10151123f, -0.03084068f, -0.11503004f, 0.00100405f, -0.01552217f, -0.06046361f, 0.04226662f, -0.04073428f, 
    0.50386286f, 0.16909458f, -0.08806384f, 0.03784100f, -0.13346705f, -0.01917637f, 0.10532226f, 0.04004936f, 
    0.04433041f, -0.14627059f, -0.09209497f, 0.51116031f, -0.02775153f, -0.00505044f, 0.01926588f, -0.02781659f, 
    -0.00650027f, 0.08527042f, -0.03269958f, -0.00214418f, 0.00577829f, -0.00798017f, -0.00522781f, 0.05767182f, 
    0.05428906f, 0.11012489f, 0.15355451f, 0.02084388f, -0.11615568f, -0.00237725f, -0.02528604f, 0.14569539f, 
    -0.00199128f, 0.07401785f, -0.10172506f, -0.01408794f, -0.22036760f, -0.29764894f, -0.19964892f, -0.10552967f, 
    0.16144921f, 0.01137367f, 0.05338950f, 0.01251390f, -0.07993516f, -0.29175699f, -0.02494395f, -0.25877774f, 
    -0.02087249f, -0.09431149f, 0.12422406f, 0.08006399f, -0.00102754f, 0.06977654f, 0.00262444f, 0.06440945f, 
    -0.27062142f, 0.03644070f, 0.08320919f, 0.03568526f, 0.04701634f, -0.00512653f, -0.09811717f, 0.11364602f, 
    -0.02321432f, -0.04800330f, 0.05113296f, -0.06536426f, 0.19454862f, 0.04360409f, 0.05431890f, 0.08122532f, 
    -0.27976039f, -0.24693891f, 0.05339310f, 0.03181956f, -0.02248755f, -0.02177734f, -0.08485478f, -0.02440254f, 
    0.19808829f, -0.18312977f, -0.21257639f, 0.03442190f, 0.01996377f, 0.16302919f, -0.11085822f, 0.31448811f, 
    -0.19705322f, -0.00606948f, 0.02589850f, -0.09588095f, 0.02144950f, -0.56644458f, 0.04141194f, -0.17734529f, 
    0.10218828f, -0.01097079f, 0.07316884f, 0.45454407f, 0.01520743f, 0.19102488f, -0.14971916f, -0.01882184f, 
    0.04771943f, -0.05925982f, -0.04218428f, 0.00499341f, 0.33197799f, 0.32201588f, -0.07200269f, -0.27067065f, 
    -0.06549206f, -0.06680498f, 0.16577195f, -0.01140242f, -0.01138347f, -0.04783555f, 0.09445184f, -0.20359844f, 
    -0.02295968f, -0.21800156f, 0.01707967f, 0.22563308f, -0.11674414f, 0.14299752f, 0.39762968f, -0.01300337f, 
    0.27914357f, 0.25356928f, 0.03179862f, 0.10903734f, -0.11966652f, -0.17819354f, -0.02378079f, 0.01310584f, 
    -0.08845777f, -0.24991331f, 0.19332218f, -0.10410518f, 0.10789671f, 0.06335384f, -0.02660384f, 0.13211028f, 
    -0.10128803f, 0.02029252f, -0.55285716f, -0.29690522f, -0.07585674f, -0.19220401f, 0.02066578f, -0.16555752f, 
    -0.07304291f, -0.15699990f, 0.15085785f, -0.47396123f, -0.00914286f, -0.25739193f, 0.05697899f, -0.19312187f, 
    -0.15075736f, 0.02892284f, 0.42545128f, 0.00668808f, -0.04116209f, -0.43945545f, -0.05871662f, 0.04559180f, 
    0.19844519f, 0.12490486f, 0.17231163f, -0.01760561f, -0.18856138f, 0.09783131f, 0.09584069f, 0.05045313f, 
    -0.01279123f, 0.37476107f, -0.07494406f, 0.10194828f, 0.09647476f, -0.04249045f, 0.05745722f, 0.25432548f, 
    -0.01648633f, 0.10081724f, -0.08749451f, -0.10728719f, -0.15917557f, -0.03654522f, -0.19552565f, 0.15840024f, 
    -0.02310149f, -0.01294569f, -0.15480658f, 0.01387829f, -0.32367811f, 0.00346433f, -0.06541821f, -0.19468457f, 
    0.15079138f, 0.06992082f, 0.12912355f, 0.13112211f, 0.02166164f, -0.05402952f, 0.17673919f, -0.18994293f, 
    0.12836911f, -0.08113872f, -0.02090448f, 0.11546975f, 0.01625345f, 0.12393720f, 0.15094300f, 0.15595390f, 
    0.16596757f, 0.12540337f, 0.02052002f, -0.04036569f, -0.08499160f, 0.00958346f, 0.11240654f, 0.01789673f, 
    0.01733198f, -0.07401302f, -0.06179221f, 0.03944066f, 0.02890446f, 0.06789619f, -0.03656805f, -0.08775122f, 
    0.15767676f, -0.06487124f, 0.07524931f, 0.12196767f, -0.18005058f, 0.00372756f, -0.08309672f, -0.08976910f, 
    -0.00801182f, 0.08601099f, 0.04464422f, -0.02408239f, 0.03157339f, -0.05470814f, 0.13897344f, 0.03449502f, 
    -0.23834197f, 0.01274235f, 0.11900297f, 0.02781781f, 0.05108460f, 0.07235929f, -0.08047936f, -0.06782886f, 
    -0.01132042f, -0.13995160f, -0.05929188f, -0.00207116f, 0.13295925f, -0.33987573f, -0.18386339f, 0.01420948f, 
    0.02002261f, 0.04318104f, 0.17555754f, -0.10962942f, -0.06013443f, 0.00832999f, 0.14772077f, 0.43595585f, 
    0.07715800f, 0.09091176f, 0.03906536f, 0.00559022f, -0.03809213f, 0.02356159f, 0.06371636f, -0.05582280f, 
    0.08258032f, 0.03280756f, 0.21662433f, -0.06170006f, -0.16133749f, 0.07917482f, 0.02906490f, 0.08291595f, 
    0.00372946f, -0.33897355f, 0.19473411f, -0.09389906f, -0.18775031f, -0.01101022f, 0.14468649f, -0.01051672f, 
    0.14058797f, -0.17775190f, 0.04711525f, -0.06772967f, -0.14230947f, -0.24001406f, -0.05324365f, 0.12956741f, 
    0.03175297f, -0.01132966f, -0.00465337f, 0.07244949f, 0.12874641f, -0.08972748f, 0.03568425f, 0.03596633f, 
    -0.01783615f, 0.12474223f, -0.13045670f, 0.07232180f, -0.01901924f, 0.03824872f, 0.07220820f, 0.15616065f, 
    0.03078705f, 0.02349927f, -0.08503290f, -0.11161971f, 0.27988902f, 0.35464072f, -0.00072317f, -0.02103462f, 
    -0.05310937f, -0.06647719f, 0.19817334f, 0.27220517f, -0.09620146f, 0.20528319f, 0.20103161f, 0.05189186f, 
    -0.04703686f, -0.19384752f, 0.22360212f, -0.06469300f, -0.03766719f, -0.26609680f, -0.06881854f, 0.14522856f, 
    0.04880080f, -0.03093566f, -0.11440624f, -0.10487084f, 0.01383055f, 0.15276061f, -0.14341825f, -0.02662205f, 
    -0.30559185f, -0.08769832f, -0.20590706f, -0.03214808f, 0.13434775f, -0.08541372f, -0.01337547f, -0.06346215f, 
    0.10043985f, -0.00392558f, 0.08790714f, -0.02343838f, -0.06737858f, 0.07280832f, -0.12626012f, -0.05642346f, 
    -0.07757680f, -0.19923194f, 0.13670802f, 0.05957250f, -0.02596756f, 0.06968272f, -0.03877745f, -0.10596976f, 
    0.06890742f, 0.14070491f, 0.04461491f, -0.22704422f, -0.23477623f, 0.07631864f, 0.02389318f, -0.19105607f, 
    0.02152649f, 0.10339925f, 0.05402144f, 0.31031889f, -0.03116815f, -0.18201768f, 0.04188638f, -0.15724634f, 
    -0.11046069f, 0.12317998f, 0.20560473f, 0.05781246f, 0.03540438f, 0.29624724f, 0.29917809f, 0.14015976f, 
    -0.03041296f, -0.11827561f, -0.04268500f, 0.02825994f, 0.06570725f, -0.28639293f, -0.12343694f, -0.46872658f, 
    0.19681309f, 0.14189309f, 0.13553475f, 0.10264220f, -0.14185484f, 0.00594522f, -0.26301950f, -0.12611946f, 
    0.40156826f, -0.16654427f, -0.02546186f, 0.12282307f, -0.11548597f, 0.01298731f, 0.15009981f, -0.27530533f, 
    0.08907831f, 0.26181602f, -0.10755802f, -0.09984320f, 0.01460073f, 0.09802825f, 0.15198457f, 0.05774194f, 
    0.30454826f, -0.05317388f, 0.09857672f, -0.06061873f, -0.00295614f, -0.00481713f, -0.04310668f, 0.27017000f, 
    -0.14403184f, -0.24129832f, 0.31638119f, -0.53497130f, -0.00223503f, -0.08388057f, -0.23310860f, 0.03927892f, 
    0.09813930f, 0.12107185f, -0.04416547f, -0.13186634f, -0.09786754f, 0.01154992f, 0.07300568f, 0.04680569f, 
    -0.07437257f, -0.05037769f, 0.05364577f, -0.25156951f, -0.13971740f, -0.36008221f, -0.05503498f, -0.07894233f, 
    -0.05406319f, 0.05545339f, 0.09919903f, 0.05901076f, -0.18729603f, -0.10102624f, 0.31614140f, 0.04961798f, 
    -0.04143052f, -0.07076337f, 0.06027050f, -0.04112795f, 0.01110719f, 0.15375225f, 0.17742574f, 0.17464837f, 
    0.05131518f, -0.14777806f, -0.05510808f, -0.10625337f, 0.18523477f, -0.11712767f, -0.01942434f, 0.33323559f, 
    0.00377811f, 0.03368620f, -0.00992770f, -0.12141523f, 0.08241136f, -0.00006889f, -0.10140345f, -0.15529124f, 
    -0.28155124f, -0.46747404f, 0.25322157f, 0.00856242f, -0.13990112f, 0.11172742f, -0.06999513f, -0.04751452f, 
    0.16734028f, -0.03814148f, -0.24287005f, -0.06728536f, -0.08040214f, 0.00251065f, -0.01729815f, -0.08154410f, 
    -0.14819458f, -0.16318345f, 0.07481555f, 0.05022424f, 0.10146471f, 0.08279762f, -0.03223364f, -0.15890846f, 
    -0.05832362f, -0.01688896f, -0.19352894f, -0.45625183f, -0.09704372f, 0.04981106f, 0.08363838f, -0.03383112f, 
    -0.04543062f, -0.07156481f, 0.02858846f, -0.10349670f, -0.04569946f, -0.28242224f, -0.04983292f, 0.10079539f, 
    0.00495900f, -0.05494329f, 0.02540490f, 0.13169919f, -0.54620373f, -0.31906784f, -0.01866127f, 0.11215720f, 
    -0.03843033f, 0.08539106f, -0.00066557f, 0.12990998f, -0.04112025f, -0.13735522f, -0.10892711f, 0.18117242f, 
    0.19291334f, 0.11475694f, -0.03884523f, 0.00129764f, -0.03976520f, -0.07474110f, 0.25936690f, 0.18453711f, 
    -0.02324945f, 0.02529233f, 0.09387964f, -0.08075236f, 0.18936330f, 0.05762141f, 0.01667797f, 0.02925966f, 
    -0.00502185f, -0.07077534f, 0.13073637f, -0.13523997f, -0.06125516f, 0.06687417f, 0.16771293f, -0.03299004f, 
    -0.39051485f, -0.61288154f, -0.11783662f, 0.08699547f, -0.05376980f, -0.06840649f, -0.10677546f, 0.12874025f, 
    0.08614226f, -0.06416874f, -0.09539904f, -0.29566899f, 0.02814314f, -0.00766347f, -0.16543637f, -0.03054153f, 
    -0.16909137f, -0.00046224f, -0.35754550f, -0.07645915f, 0.05046492f, -0.02183881f, 0.17494321f, 0.14466354f, 
    0.01401366f, 0.17348595f, 0.01430980f, 0.14974490f, 0.20978658f, 0.11357241f, 0.05913326f, 0.03199143f, 
    0.06697258f, 0.02935977f, 0.03828430f, 0.00670908f, 0.07755693f, 0.09030898f, -0.18502341f, -0.10589638f, 
    -0.02584876f, 0.13247687f, -0.01801162f, 0.08260973f, 0.08393929f, -0.09280811f, 0.24568290f, 0.41168427f, 
    -0.17493211f, -0.08996787f, 0.27068707f, -0.04352808f, 0.03316168f, -0.06879659f, -0.04301277f, 0.01236373f, 
    -0.01390281f, 0.13022693f, -0.08275120f, 0.10226631f, 0.04343535f, -0.01468552f, 0.06585357f, 0.17004344f, 
    -0.01195880f, 0.08952476f, 0.20057370f, 0.06349605f, 0.13581865f, 0.00507415f, 0.01489003f, 0.06970137f, 
    0.10952085f, 0.07311736f, -0.11248747f, 0.02229564f, -0.05992547f, -0.02184653f, 0.00673585f, -0.04052230f, 
    -0.30447397f, -0.06839046f, 0.04429078f, 0.23717918f, -0.02994600f, 0.09984302f, -0.33377439f, 0.06425926f, 
    0.15452482f, 0.01503803f, -0.12597214f, 0.17123182f, -0.17631729f, -0.02658233f, -0.05051564f, -0.17329639f, 
    0.09345775f, 0.08036960f, -0.08058089f, 0.28804284f, -0.10095117f, -0.15935263f, -0.06365804f, 0.00238545f, 
    -0.33369014f, 0.25888467f, 0.04967067f, 0.07590150f, 0.03153358f, 0.11986269f, 0.29661408f, -0.05248700f, 
    -0.23508240f, -0.28676128f, -0.06934224f, 0.21891391f, 0.31555694f, -0.06168788f, 0.14485444f, 0.26605305f, 
    -0.05213188f, -0.05885801f, -0.14504544f, -0.08663051f, 0.00759483f, 0.21985844f, -0.06665742f, 0.18811798f, 
    -0.33316836f, 0.13374496f, 0.06723836f, 0.03702155f, 0.00375633f, -0.08354061f, 0.06034019f, -0.26756889f, 
    -0.03666870f, 0.03011834f, 0.15694232f, 0.03344027f, -0.04838025f, -0.15286335f, 0.07472910f, -0.21022488f, 
    -0.04091075f, 0.06580822f, 0.11567206f, -0.04125175f, -0.04692148f, -0.00789301f, 0.17039622f, 0.09397282f, 
    0.00012033f, -0.26718915f, -0.41130960f, -0.13747233f, -0.02985502f, 0.10387979f, 0.05488905f, -0.05141173f, 
    -0.00284369f, 0.05430110f, -0.04391029f, 0.23075041f, 0.23078662f, -0.05721815f, -0.08390137f, -0.08803029f, 
    -0.19083080f, 0.12371738f, 0.07710913f, -0.13689689f, -0.18734902f, -0.11534020f, 0.01879389f, 0.13728590f, 
    0.01152229f, -0.09975904f, -0.00594025f, -0.01109547f, -0.07911723f, 0.38297236f, 0.03384531f, 0.06160718f, 
    -0.06912322f, -0.13924722f, 0.04949230f, 0.10968325f, 0.08183143f, -0.27138939f, -0.07628919f, 0.22001201f, 
    0.21381311f, -0.21134724f, 0.01167032f, -0.15472466f, -0.06925546f, 0.09579705f, -0.09175954f, 0.01643260f, 
    -0.02252492f, 0.06260466f, 0.11019035f, 0.06460153f, 0.01128738f, -0.03327996f, -0.04662342f, -0.19369324f, 
    0.02870118f, 0.25832567f, -0.06837163f, 0.06552862f, 0.17634813f, -0.07913218f, 0.13939132f, 0.09708765f, 
    -0.18273282f, -0.12719114f, -0.08322974f, -0.15622891f, -0.14264303f, 0.23347434f, -0.14633672f, -0.08526182f, 
    0.08850858f, -0.25405410f, 0.01211930f, -0.07246429f, 0.06619400f, 0.00927936f, -0.14055741f, -0.22647713f, 
    0.06222219f, -0.04448347f, -0.01233258f, 0.15916550f, 0.00753072f, 0.13785101f, 0.08926210f, -0.12372502f, 
    0.08959117f, -0.15420510f, -0.15985171f, -0.31116685f, -0.25571227f, -0.16056742f, -0.03425265f, 0.14925338f, 
    -0.00513955f, -0.14878942f, 0.00403674f, 0.07203237f, 0.58429307f, 0.05205075f, 0.20454699f, 0.06715375f, 
    -0.01004446f, -0.12294701f, -0.00293604f, 0.11514523f, 0.10582985f, 0.54264671f, 0.16793275f, 0.02319501f, 
    0.03412536f, -0.06010639f, 0.03451513f, -0.02501989f, -0.18001364f, 0.03915506f, -0.38402334f, -0.18243684f, 
    0.12574796f, 0.20496581f, 0.00933945f, 0.29936072f, -0.10701179f, 0.04739954f, -0.12287364f, -0.24275164f, 
    0.01776060f, 0.04765319f, 0.02604663f, 0.01266351f, -0.06023759f, 0.02512713f, 0.00472745f, -0.03934607f, 
    -0.08552032f, -0.18730396f, -0.19800313f, 0.06445401f, -0.06505085f, 0.06998839f, 0.06377912f, -0.08545859f, 
    -0.25726119f, 0.01252203f, -0.40677434f, 0.05912971f, 0.00940029f, 0.13840550f, -0.23931874f, -0.03478042f, 
    0.06837958f, -0.06223259f, 0.28911170f, 0.13873895f, -0.39765757f, 0.00511593f, 0.00060545f, 0.15878266f, 
    0.06430733f, 0.17787883f, 0.04195194f, -0.08191241f, 0.02495619f, -0.32696214f, 0.10239776f, -0.05486978f, 
    0.04930346f, -0.02548925f, 0.11811131f, 0.00767115f, 0.17355593f, -0.08418477f, 0.14183377f, -0.03209347f, 
    -0.02241371f, -0.01334245f, -0.00662444f, -0.03009196f, 0.02828865f, -0.04931276f, 0.12904829f, -0.13678397f, 
    -0.03283824f, 0.03916046f, 0.01164249f, -0.03330150f, -0.20850472f, 0.04781134f, 0.08141898f, 0.05442414f, 
    -0.27523971f, 0.07396153f, -0.05346173f, -0.06519967f, 0.03348217f, 0.07882416f, -0.00370679f, 0.39626944f, 
    0.19886462f, -0.05146462f, 0.07633531f, 0.01035278f, -0.03886993f, 0.11147324f, 0.06206259f, 0.04920198f, 
    0.27040574f, -0.24152425f, -0.27852887f, 0.02194668f, 0.11571689f, 0.09499595f, 0.18708225f, 0.12744384f, 
    0.00739645f, -0.34786013f, -0.13752317f, 0.17259659f, -0.01006727f, -0.16506509f, 0.19822982f, 0.18344416f, 
    0.15078717f, -0.06739721f, -0.16145773f, 0.03218536f, -0.01359956f, -0.09407914f, 0.10467795f, 0.19515225f, 
    0.16217361f, 0.01908623f, -0.06965981f, 0.12525345f, 0.17604704f, 0.11637946f, 0.00209882f, 0.17988512f, 
    -0.04577595f, 0.07096270f, -0.12428830f, 0.08124618f, 0.02854785f, 0.03307031f, 0.27688581f, -0.03738138f, 
    -0.07012777f, 0.07101753f, -0.06794348f, 0.08561847f, -0.14713629f, 0.21179019f, 0.04857238f, -0.28180742f, 
    -0.21914096f, 0.02433474f, 0.18952368f, -0.02455724f, -0.10971428f, -0.07243273f, 0.19892217f, 0.05047935f, 
    -0.25055525f, 0.15408273f, 0.12630291f, 0.05132546f, 0.05698675f, -0.05128328f, -0.19529530f, 0.28980488f, 
    -0.01702986f, -0.27744544f, 0.00094672f, -0.03743385f, 0.05573566f, -0.08787367f, -0.01342985f, -0.00957719f, 
    -0.18020254f, 0.13614148f, 0.12434220f, -0.32919174f, 0.04485301f, 0.03791142f, 0.12051167f, 0.06489082f, 
    -0.02374509f, 0.19547433f, -0.23063022f, -0.06298261f, -0.02608042f, -0.08873631f, -0.01080631f, -0.21541046f, 
    -0.11063060f, -0.02613007f, -0.05431045f, -0.20552002f, 0.12316856f, -0.15603796f, -0.07743827f, 0.02300826f, 
    0.11021042f, 0.04543269f, 0.03154651f, -0.22867857f, 0.05209904f, 0.18031593f, -0.09768648f, 0.01501438f, 
    0.07916153f, -0.09888002f, 0.26008245f, 0.00399145f, -0.04259956f, -0.12340019f, -0.23623638f, 0.16912144f, 
    0.07770982f, -0.12602404f, -0.04177080f, -0.04325892f, -0.07049913f, -0.13863100f, -0.17152712f, -0.35666209f, 
    0.19186212f, 0.16581824f, 0.04203195f, -0.28436404f, 0.00296355f, -0.13356085f, -0.17161930f, -0.12389787f, 
    0.17186479f, -0.08798509f, -0.00093648f, -0.03479519f, 0.18164007f, -0.03524860f, -0.01171951f, 0.22303343f, 
    0.19658978f, 0.00900964f, 0.07828826f, -0.17553206f, 0.04027414f, -0.12311431f, -0.01238829f, 0.13164526f, 
    -0.18414852f, 0.15056579f, 0.13513672f, -0.14121255f, -0.01332601f, 0.06035733f, 0.06495051f, -0.12580121f, 
    0.10585243f, 0.34028783f, -0.29652435f, -0.27464756f, 0.21577993f, 0.16701537f, 0.17015234f, 0.14095728f, 
    0.17413107f, 0.15999158f, -0.22578931f, 0.03860121f, -0.34875467f, -0.07483620f, 0.17630702f, 0.08325747f, 
    0.23390464f, 0.01689960f, -0.12814207f, -0.26767930f, 0.13027740f, -0.09091898f, 0.00390027f, 0.08517156f, 
    0.32899854f, 0.21587981f, 0.08563977f, -0.38629600f, -0.11477503f, 0.05352085f, -0.06473939f, 0.06358393f, 
    0.17239922f, 0.09174638f, 0.14057398f, 0.01733921f, 0.08048535f, -0.20686282f, 0.20696963f, 0.04763678f, 
    -0.02295981f, -0.07313018f, -0.00416493f, -0.06580991f, 0.18771575f, 0.00236939f, -0.19231157f, -0.02437074f, 
    0.17187212f, 0.17523544f, -0.03322765f, 0.10292660f, -0.03871489f, 0.06099295f, -0.12528238f, -0.23031676f, 
    0.10339733f, 0.08767700f, -0.10381009f, -0.00411877f, -0.04971147f, 0.04991035f, 0.07065204f, 0.06495828f, 
    0.05179751f, -0.01292158f, -0.21622011f, -0.12319891f, 0.10012926f, -0.00459829f, -0.08820452f, 0.02362120f, 
    -0.35226119f, 0.21848083f, 0.24063329f, 0.01351600f, -0.15265101f, 0.15110083f, -0.22080311f, -0.04245377f, 
    0.15802927f, 0.02017195f, 0.06704882f, -0.01764851f, -0.16381893f, -0.02218426f, -0.04898660f, 0.04988662f, 
    0.08836877f, 0.08123589f, -0.14277174f, 0.23431617f, 0.14492252f, -0.01593463f, -0.16711824f, -0.13128707f, 
    0.08898445f, 0.16740027f, 0.16402505f, -0.08385325f, -0.17472810f, -0.00137490f, 0.06261264f, 0.11688176f, 
    0.04387816f, 0.00645246f, -0.13500492f, 0.10505232f, 0.10203522f, -0.05690245f, -0.03765428f, 0.31370088f, 
    -0.14870274f, -0.04929821f, -0.00974984f, 0.11107390f, -0.01305856f, 0.34350842f, 0.23701194f, 0.02883866f, 
    -0.06906030f, -0.05240975f, 0.20221512f, -0.07991689f, 0.06583032f, 0.02534863f, 0.11563872f, -0.00381656f, 
    -0.08082508f, -0.06413984f, 0.02133045f, 0.01902559f, -0.08249826f, 0.11656554f, 0.09797549f, 0.03445031f, 
    -0.05928862f, 0.28779241f, -0.08259307f, 0.02494301f, -0.03537380f, 0.11643244f, -0.04897451f, 0.11603379f, 
    -0.02487734f, 0.21091729f, 0.10422295f, -0.16809118f, -0.04672585f, -0.12973103f, -0.16021341f, 0.14628191f, 
    0.06201686f, -0.05190520f, 0.07741948f, -0.07038791f, 0.09068809f, -0.16335687f, -0.03690450f, 0.12099178f, 
    0.08709582f, -0.02632851f, -0.19351910f, 0.14846282f, 0.11413673f, -0.27846301f, 0.08852469f, 0.05736673f, 
    0.07705312f, -0.04543532f, -0.08201628f, -0.05951042f, -0.10659651f, 0.08358242f, 0.23559205f, 0.11200226f, 
    0.14880183f, 0.10141883f, 0.07983246f, -0.05114721f, 0.04612790f, -0.16907106f, 0.29942715f, 0.35497391f, 
    -0.06900956f, -0.07257026f, 0.04601336f, -0.14452961f, -0.04356913f, -0.24177934f, -0.23352787f, -0.12570047f, 
    -0.37601134f, 0.16087694f, 0.08192755f, 0.06452182f, -0.15631919f, -0.09188731f, -0.09633315f, -0.18616430f, 
    -0.25752759f, -0.06144980f, 0.07477556f, 0.10959902f, 0.07893551f, 0.03064199f, -0.08947904f, 0.10664961f, 
    -0.12066097f, -0.26176018f, -0.12540732f, -0.28931350f, 0.05807923f, 0.20832705f, -0.18047695f, 0.01305854f, 
    -0.07862137f, -0.09760584f, -0.05797715f, 0.29080865f, -0.12810732f, 0.00066133f, -0.09460939f, 0.12695375f, 
    -0.08781575f, 0.09019897f, -0.02801668f, 0.22251175f, 0.02612138f, -0.04963017f, 0.08270671f, -0.10993659f, 
    -0.05865479f, 0.02426458f, 0.08650252f, 0.01231472f, -0.18850926f, -0.08350173f, -0.07981308f, -0.12792866f, 
    -0.03494742f, 0.16952136f, 0.05733291f, -0.00429675f, -0.48892322f, -0.20679508f, -0.13078478f, 0.08742673f, 
    0.14923562f, -0.11729894f, 0.00462938f, 0.02483086f, 0.05024948f, -0.10065652f, 0.08428368f, -0.06410845f, 
    0.18121786f, -0.18425012f, 0.00404992f, 0.05402485f, 0.17095320f, 0.04868570f, 0.08497221f, -0.01467451f, 
    -0.08168326f, 0.11091977f, 0.03446322f, 0.04813756f, 0.11771250f, -0.01116059f, 0.22709060f, 0.17293063f, 
    0.22422105f, 0.32356432f, -0.24058448f, 0.09658607f, -0.16783299f, 0.08655871f, 0.07884909f, 0.01495607f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    -0.03778152f, -0.19431947f, 0.15166646f, -0.04262722f, 0.34985372f, -0.03779232f, -0.01939810f, 0.22536609f, 
    0.00308018f, 0.21740015f, 0.10355259f, 0.10347987f, -0.12948354f, 0.04695181f, 0.09770060f, 0.06602591f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.39258176f, -0.04808089f, 0.22788724f, 0.03273296f, -0.30958042f, -0.08527066f, 0.17135672f, 0.14180891f, 
    -0.29575995f, -0.37771782f, -0.41536844f, 0.13229479f, 0.25923929f, 0.47209397f, 0.21195860f, 0.44490615f, 
    0.12023909f, 0.07652082f, -0.41026714f, 0.20207357f, 0.13149308f, 0.26525122f, -0.52197963f, 0.05222002f, 
    -0.09210254f, -0.36124557f, -0.03161427f, -0.08618572f, 0.29775745f, -0.23644042f, 0.26073262f, 0.26699430f, 
    -0.19879286f, 0.34387928f, -0.01826019f, 0.22784720f, 0.23022337f, 0.25847641f, 0.35914421f, -0.20620589f, 
    -0.29612806f, 0.20931381f, -0.01828392f, 0.35564807f, -0.31462881f, 0.37276876f, -0.17376937f, -0.38443649f, 
    -0.46255207f, 0.02284342f, -0.18235651f, 0.12221029f, 0.07784530f, -0.18297540f, -0.00794432f, 0.28080633f, 
    0.46360007f, 0.64154464f, 0.18270512f, 0.39259505f, -0.32299277f, -0.22960517f, 0.05251865f, 0.28830108f, 
    -0.22891414f, -0.02860427f, -0.09795851f, 0.19995493f, -0.18443936f, -0.15383980f, -0.12418908f, -0.23361623f, 
    -0.18857291f, 0.19474369f, -0.21168566f, 0.01376936f, -0.12643826f, 0.05140337f, -0.15476695f, -0.00929597f, 
    0.10204663f, -0.79194087f, 0.33178589f, 0.17454456f, 0.64712226f, -0.07827720f, 0.42866164f, 0.09832741f, 
    0.03742503f, 0.49254328f, -0.69189173f, 0.18100148f, -0.13331905f, -0.17912297f, -0.16324127f, -0.28645164f, 
    -0.19603036f, 0.25071448f, -0.24064510f, 0.05619455f, 0.21857458f, -0.23166429f, 0.56323856f, 0.00301515f, 
    0.07209260f, -0.19270669f, -0.24661256f, 0.36534536f, 0.04969047f, 0.41495547f, -0.13956156f, 0.47896832f, 
    -0.20999946f, 0.50995970f, -0.21038389f, -0.05654558f, -0.17870678f, -0.06383711f, -0.44698846f, 0.29650077f, 
    0.47423956f, -0.16696405f, -0.09478595f, -0.43982020f, -0.15867494f, -0.00445316f, 0.34570768f, 0.06924340f, 
    -0.16815931f, -0.17252739f, 0.40803275f, 0.09762102f, 0.24370308f, -0.37868777f, -0.48957595f, 0.60075504f, 
    -0.16119075f, 0.27749267f, -0.32868186f, 0.08223023f, -0.41764775f, 0.37779713f, 0.13173041f, -0.23062153f, 
    0.03673414f, -0.34961289f, -0.10967095f, -0.16342714f, -0.46164370f, 0.05263129f, 0.28060371f, 0.36345920f, 
    -0.37503976f, -0.05480979f, -0.16780834f, 0.03014741f, 0.04275749f, 0.03634429f, 0.32066065f, 0.15873608f, 
    -0.11794938f, -0.00030879f, 0.01170690f, -0.23178360f, -0.19496009f, 0.00352594f, -0.25336164f, 0.10578056f, 
    -0.22711080f, -0.09952798f, 0.08032010f, -0.23460093f, -0.08443463f, 0.18864334f, -0.16674902f, -0.21990891f, 
    0.23622160f, -0.45029724f, 0.32001716f, 0.01739447f, 0.09764631f, -0.18801031f, 0.36318597f, -0.07597330f, 
    -0.20015767f, -0.56098711f, 0.42888412f, -0.08890633f, 0.47486106f, 0.05021109f, 0.12259296f, -0.06891697f, 
    0.05978053f, -0.08346879f, 0.11221310f, -0.08364134f, -0.23504290f, -0.11151987f, -0.14856921f, 0.03027863f, 
    -0.00117087f, -0.02564770f, -0.11293140f, -0.10100398f, -0.10363099f, 0.18626614f, -0.23742834f, -0.03271046f, 
    -0.28864360f, 0.06930045f, -0.18784684f, -0.07490711f, 0.41200459f, -0.12667044f, -0.01470746f, 0.06240909f, 
    0.22484541f, -0.29246697f, 0.34609762f, -0.10601114f, 0.12887903f, 0.03907152f, 0.25370911f, -0.02077474f, 
    0.07822330f, -0.00670572f, 0.60708731f, 0.08272912f, -0.03361468f, -0.20908450f, 0.49669409f, 0.14393631f, 
    -0.37793437f, -0.07006632f, -0.23836304f, -0.43419188f, 0.15246457f, 0.30119619f, -0.16363993f, 0.34915245f, 
    0.13691767f, -0.09806749f, 0.20142710f, 0.19802824f, 0.69106734f, -0.13127863f, -0.63212377f, 0.00813250f, 
    0.15917388f, 0.20709126f, -0.20153961f, 0.27889007f, -0.05660521f, -0.49217275f, 0.09597980f, 0.30133989f, 
    0.09379847f, 0.03628645f, 0.46111223f, 0.23820220f, -0.08209639f, -0.15373620f, -0.27012247f, -0.58777320f, 
    -0.17513531f, -0.48074988f, -0.18284729f, 0.48853874f, 0.29599252f, -0.59968817f, 0.18555118f, 0.12031578f, 
    0.24638525f, 0.09287059f, -0.34341592f, -0.20965745f, 0.10797544f, 0.08264193f, -0.83687478f, 0.31536493f, 
    -0.18338780f, -0.12562780f, 0.14773265f, -0.41626948f, 0.35888842f, -0.15952438f, 0.30177855f, 0.25096238f, 
    -0.40239778f, 0.27392125f, -0.15534778f, -0.15057746f, -0.30603951f, 0.29469320f, -0.27010855f, 0.19744903f, 
    -0.30176178f, -0.03313082f, -0.14206600f, -0.38165891f, 0.34245449f, 0.29070833f, 0.24915649f, 0.08626874f, 
    0.25960097f, -0.25356644f, -0.43439543f, 0.13424404f, 0.21750112f, -0.11472552f, 0.15159871f, 0.18355305f, 
    -0.16910347f, 0.52898538f, 0.13927266f, -0.05608313f, 0.44165653f, -0.30301338f, -0.10006267f, 0.36988351f, 
    0.49602327f, -0.23045997f, 0.34003222f, -0.03102727f, 0.28059849f, -0.18102357f, -0.21624325f, 0.11860494f, 
    0.28614768f, -0.00439998f, 0.08189200f, 0.22580074f, 0.29717299f, 0.35026717f, -0.19216006f, -0.23392664f, 
    0.48455560f, 0.32004714f, 0.40372723f, 0.09516048f, -0.11161361f, 0.51383853f, -0.09044012f, -0.11428653f, 
    0.22662161f, 0.71980357f, -0.28923091f, -0.00543561f, 0.22889942f, -0.18591848f, -0.07378499f, -0.38165063f, 
    -0.51176625f, 0.22041561f, -0.39582416f, -0.01429036f, 0.10050727f, -0.02619065f, -0.10799971f, 0.03454401f, 
    -0.27355203f, -0.15442084f, -0.00562259f, 0.10740956f, 0.03378588f, -0.04522026f, 0.33576986f, 0.28776297f, 
    0.49010086f, 0.08991905f, 0.35606852f, -0.15337154f, -0.62026036f, -0.00368180f, -0.20059067f, 0.53633291f, 
    -0.13767748f, 0.20134531f, -0.12194906f, 0.25498036f, -0.08119339f, -0.08758519f, -0.23510228f, 0.12241030f, 
    0.03980958f, 0.11874256f, 0.47179118f, -0.07575095f, -0.07260550f, 0.40173733f, -0.26727468f, -0.00453112f, 
    0.14563066f, -0.43678942f, 0.31131116f, -0.55657500f, 0.21379364f, 0.32432833f, 0.10324661f, -0.44861177f, 
    0.11264485f, 0.38404354f, 0.21996546f, -0.02696202f, 0.30809343f, -0.13688777f, -0.36392248f, 0.00823263f, 
    -0.00568569f, -0.25481275f, -0.12479912f, -0.28022650f, 0.24957533f, 0.33204603f, 0.16538155f, 0.22764789f, 
    -0.01769813f, 0.46903712f, -0.28845373f, -0.14910176f, -0.70040846f, 0.00135815f, 0.12929143f, -0.31268901f, 
    0.23617822f, 0.31872627f, 0.11898099f, -0.72869110f, -0.06168902f, -0.12678114f, 0.31169108f, 0.14688054f, 
    -0.11108620f, -0.06022574f, 0.17586797f, -0.09516537f, 0.34023103f, 0.47783011f, 0.48537564f, -0.60097116f, 
    0.12200502f, 0.02375923f, -0.16593800f, 0.35275695f, -0.27312633f, -0.45241421f, -0.07936449f, 0.28573677f, 
    0.38173690f, 0.43175349f, -0.17739587f, -0.10504233f, -0.09353048f, 0.18197578f, -0.36639977f, 0.40393516f, 
    0.10483730f, -0.10475785f, -0.37040007f, 0.16009615f, -0.20471838f, 0.43157440f, -0.05749652f, -0.17354310f, 
    -0.24320918f, 0.01351294f, -0.09154450f, 0.12888531f, 0.53010577f, 0.20431526f, -0.29409885f, -0.32289472f, 
    -0.12575221f, -0.11381711f, 0.45835981f, 0.26131350f, 0.32406235f, 0.25436306f, -0.00322811f, -0.05636460f, 
    -0.65596652f, 0.24588390f, -0.26270679f, 0.04893715f, 0.34073204f, 0.07093935f, -0.41173640f, 0.20734276f, 
    0.19049835f, 0.00868524f, -0.24423200f, -0.08797386f, 0.02731577f, 0.18324885f, 0.19329993f, 0.35802916f, 
    -0.04721963f, 0.52523464f, 0.00709514f, 0.08547588f, 0.45560896f, -0.61052346f, 0.24548683f, -0.01240801f, 
    0.33264968f, -0.54009593f, -0.11938629f, 0.12217957f, -0.03151682f, 0.39129418f, -0.27845016f, 0.33343577f, 
    0.14011286f, 0.18332888f, 0.10841588f, 0.00444102f, -0.04566357f, 0.43246606f, -0.00375045f, -0.09298351f, 
    0.30514410f, 0.37371966f, 0.45135236f, 0.00034693f, 0.21860711f, -0.47823665f, -0.07621761f, -0.31104597f, 
    0.58382618f, -0.02960403f, 0.29750982f, -0.19454727f, 0.34654382f, 0.09712044f, 0.24495412f, -0.38827392f, 
    0.09524742f, -0.22923946f, 0.52601796f, 0.15911871f, -0.00384067f, 0.03449162f, -0.18295157f, 0.04056187f, 
    0.47274297f, -0.52735323f, -0.00811199f, -0.01273254f, 0.21446367f, -0.22294126f, -0.11341921f, 0.19706750f, 
    -0.00643332f, -0.12692080f, 0.07433119f, -0.24541563f, 0.51254970f, -0.03738961f, 0.23640150f, 0.35849768f, 
    0.68462944f, -0.15076742f, 0.12242690f, -0.02342305f, 0.05352449f, 0.13379638f, -0.39541698f, 0.38987812f, 
    -0.29278535f, 0.37839958f, 0.12270910f, -0.04450768f, -0.12737337f, -0.25780523f, 0.16495359f, -0.09533756f, 
    -0.18055825f, 0.22259448f, -0.08247494f, 0.07846783f, 0.41112888f, -0.40043333f, -0.01192488f, -0.24403796f, 
    -0.18798600f, -0.10081029f, 0.04873624f, 0.19110402f, -0.03326733f, 0.01549187f, 0.22862601f, 0.26597136f, 
    0.30574876f, -0.52756613f, 0.13294287f, -0.15978956f, -0.06253886f, 0.12801406f, 0.03712610f, 0.30964810f, 
    -0.23470743f, 0.53058565f, -0.40458700f, -0.29560512f, 0.16578990f, 0.35563201f, 0.03211909f, 0.10013022f, 
    0.18374395f, 0.31068853f, -0.19605516f, 0.01222101f, 0.22614034f, -0.42630249f, 0.07640061f, 0.24425253f, 
    0.70293760f, 0.65407956f, -0.11032274f, 0.09244394f, -0.14896385f, 0.18454848f, -0.03531210f, -0.20409067f, 
    0.03359919f, -0.09782366f, -0.09309521f, 0.19976580f, -0.35800108f, 0.40574825f, 0.38797227f, 0.18284094f, 
    0.01044955f, 0.05675707f, 0.56228620f, -0.26338917f, -0.25978845f, -0.34148312f, -0.01140757f, 0.12311607f, 
    0.00782733f, -0.11553704f, 0.18162818f, 0.17640531f, 0.12146644f, 0.15868914f, -0.14645438f, -0.17976157f, 
    0.01927272f, 0.09755025f, -0.13765535f, -0.02356108f, 0.02526717f, -0.06008421f, -0.25805783f, -0.10516882f, 
    -0.44550070f, 0.38258538f, 0.00608127f, 0.19686651f, -0.14199688f, -0.02675368f, -0.55113643f, 0.17147090f, 
    0.27643672f, 0.02736439f, 0.07076541f, -0.45776647f, 0.42723614f, 0.06758478f, 0.19768597f, -0.38654381f, 
    0.13472261f, -0.27261290f, 0.52952772f, 0.20294513f, -0.41447341f, 0.06493229f, 0.36948726f, 0.10122894f, 
    0.04166551f, 0.05389650f, 0.13049439f, -0.10286582f, -0.00958936f, 0.29897454f, 0.09627378f, -0.26688385f, 
    -0.41559029f, 0.28530687f, -0.13166547f, -0.16741799f, 0.07052264f, -0.08276479f, 0.24964947f, 0.04996803f, 
    -0.09101578f, 0.27173999f, -0.34629658f, 0.03205161f, 0.31704929f, 0.26680198f, 0.14105994f, 0.16514736f, 
    -0.42237866f, -0.13770230f, 0.28705257f, 0.11894387f, -0.24370906f, 0.51364547f, 0.34997267f, 0.29789293f, 
    -0.06870409f, 0.49723190f, 0.35712883f, -0.19231217f, 0.02817913f, -0.04013107f, -0.09381595f, 0.03341036f, 
    0.55476952f, 0.12972224f, -0.10718056f, 0.13897982f, 0.14179173f, -0.31945500f, 0.08872607f, 0.35715145f, 
    0.13379489f, -0.57488507f, 0.02958638f, 0.24710073f, -0.31546250f, 0.43636876f, -0.20074691f, -0.13567890f, 
    -0.03055599f, -0.13419890f, 0.21979600f, 0.14109668f, 0.16772114f, 0.33832112f, -0.27745327f, -0.04796031f, 
    -0.41794217f, -0.54011559f, 0.34502152f, -0.09901269f, 0.57362306f, 0.31512752f, -0.03637527f, 0.09695048f, 
    -0.27242672f, 0.51271445f, -0.10460276f, 0.01980508f, 0.31244057f, -0.06887094f, 0.22559854f, -0.09437953f, 
    0.49822065f, -0.22070858f, 0.07409259f, 0.02207804f, 0.58493495f, 0.30124357f, -0.12838194f, -0.23825254f, 
    -0.51759863f, 0.33035320f, -0.15977785f, -0.22776139f, -0.29356498f, -0.15802190f, 0.01405798f, 0.31950954f, 
    -0.24452050f, 0.22238998f, -0.24889109f, -0.15114513f, 0.24057436f, -0.18791215f, 0.38392389f, 0.35039017f, 
    -0.16402742f, 0.21120587f, -0.26046681f, -0.13910043f, 0.34636518f, -0.10390799f, -0.50442433f, 0.19678743f, 
    -0.05433718f, 0.24711560f, -0.12386469f, -0.05281870f, -0.07131927f, -0.28681633f, 0.20697238f, 0.36703503f, 
    -0.56529617f, 0.37034762f, 0.17956281f, 0.17382802f, -0.01957569f, 0.01144685f, -0.04490515f, -0.00425444f, 
    0.08940826f, -0.25800186f, -0.22202362f, -0.09025910f, 0.31558585f, -0.28960064f, 0.21660751f, 0.29048467f, 
    -0.10672647f, 0.12948720f, -0.21824247f, -0.23992851f, -0.24627168f, 0.06129084f, -0.01747659f, -0.09574737f, 
    -0.26465884f, 0.14111617f, 0.11800304f, -0.06164936f, 0.03446482f, -0.09596446f, -0.23866984f, 0.15072201f, 
    0.51056367f, 0.26857138f, 0.34163544f, 0.20902538f, 0.01060975f, 0.16848439f, -0.34959823f, 0.04724633f, 
    0.19351624f, -0.42629683f, -0.01545864f, -0.46404460f, -0.12261584f, 0.26688752f, 0.15948077f, 0.23285414f, 
    -0.11114964f, 0.20603986f, -0.32561350f, -0.24372213f, 0.47750345f, -0.11429676f, -0.47371644f, 0.14787219f, 
    0.18479849f, -0.01052177f, 0.21300057f, 0.07794617f, -0.17824186f, 0.13178134f, 0.32942235f, -0.15564068f, 
    0.04837542f, -0.04251810f, -0.01251066f, -0.13021842f, 0.15700102f, 0.13923980f, 0.17514367f, -0.42628917f, 
    0.17759179f, -0.14364268f, -0.30807415f, 0.01987018f, -0.53203791f, 0.07997968f, -0.17171872f, -0.31517833f, 
    -0.05931970f, -0.19095048f, -0.07621503f, -0.15779272f, -0.16024774f, 0.13788921f, -0.11280969f, -0.06218880f, 
    0.19837037f, -0.23246655f, -0.20045322f, -0.09098753f, -0.13356453f, -0.11392477f, -0.22461474f, -0.08582792f, 
    0.33319503f, -0.27793232f, 0.26571044f, 0.21436244f, 0.06159175f, -0.22722259f, -0.32359865f, 0.14721340f, 
    -0.03412578f, 0.13775596f, -0.15646510f, 0.16947560f, 0.17596711f, 0.07750775f, 0.24582939f, -0.19198455f, 
    -0.05846841f, 0.49463761f, 0.18917303f, 0.05645091f, 0.17164651f, -0.42447105f, 0.28790969f, 0.36738518f, 
    0.09989168f, -0.60737848f, -0.23999268f, 0.42328924f, -0.13723801f, 0.26192075f, -0.09699336f, -0.06252140f, 
    0.32194844f, -0.26935005f, -0.36180872f, -0.15066311f, -0.60980725f, 0.21704374f, 0.34468555f, 0.23383622f, 
    -0.19576573f, 0.35478047f, -0.37026021f, -0.14117000f, 0.42518756f, -0.10861947f, 0.27519295f, 0.12037302f, 
    -0.13068120f, 0.04149444f, 0.04334931f, -0.14193049f, 0.18185382f, -0.17342231f, -0.66515958f, 0.27927896f, 
    -0.07107051f, 0.20004939f, 0.27070013f, -0.28093442f, 0.43670970f, -0.09516655f, 0.10472578f, -0.27161905f, 
    -0.01723892f, 0.20377724f, -0.14865758f, 0.01785387f, 0.62467456f, 0.25727198f, -0.49287492f, -0.26254138f, 
    0.24451490f, -0.20570214f, 0.07861319f, 0.02428093f, -0.12818050f, 0.08684260f, 0.17266043f, 0.11027312f, 
    -0.18559751f, -0.24787734f, 0.48160720f, 0.09467192f, -0.04707560f, 0.01594896f, 0.20413840f, 0.19691348f, 
    0.01537153f, 0.34313923f, -0.04802525f, 0.05330238f, 0.13954046f, 0.40385947f, 0.08881799f, -0.12202877f, 
    -0.05550205f, -0.26417089f, 0.12814076f, -0.10464674f, 0.18486638f, -0.12366390f, 0.16375250f, -0.20807248f, 
    0.05833998f, -0.12773672f, -0.16092688f, -0.06034725f, -0.24962986f, -0.15410706f, -0.10659107f, -0.22719353f, 
    0.09319793f, 0.05469766f, -0.14664631f, 0.20965534f, -0.08965629f, -0.24065262f, 0.15803126f, 0.09019327f, 
    -0.16471212f, -0.24056056f, -0.05723296f, 0.15411825f, -0.11052623f, -0.02774259f, -0.28847569f, -0.12326103f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.04680132f, -0.05246590f, 0.09054874f, 0.26503983f, 0.16489395f, 0.38972631f, 0.15230250f, 0.11071511f, 
    0.36591554f, 0.01846121f, -0.03434189f, 0.33046231f, -0.12990552f, -0.23100474f, 0.26924142f, 0.23124471f, 
    -0.05169789f, -0.04378439f, 0.25340992f, 0.21395513f, -0.05228243f, -0.20127296f, 0.38614675f, 0.02068408f, 
    0.31004354f, -0.15906028f, -0.02306686f, -0.16370206f, -0.09467493f, -0.31296015f, 0.00996582f, 0.21912004f, 
    0.00268095f, 0.34523329f, 0.34266135f, 0.36634088f, 0.37847903f, 0.14315584f, -0.27280217f, 0.52495438f, 
    -0.02103539f, 0.05133412f, 0.12928718f, 0.29446709f, 0.32200241f, 0.02578379f, 0.33924347f, 0.00129325f, 
    0.20612024f, 0.02254933f, 0.24818097f, -0.20667468f, 0.42195866f, -0.12178396f, -0.16818316f, 0.01790288f, 
    0.14852300f, -0.04878210f, -0.11014356f, 0.05762295f, -0.06558581f, -0.00076404f, -0.04439647f, -0.12929597f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.24129321f, 0.23876871f, 0.45446146f, 0.19929245f, -0.09651271f, 0.45123389f, -0.16830914f, 0.16356802f, 
    0.19041984f, -0.21705769f, 0.09185841f, -0.02202755f, -0.08128144f, 0.22872283f, -0.33131921f, 0.18660606f, 
    -0.41436785f, 0.15866628f, 0.06655794f, 0.07018457f, 0.14367792f, 0.12383045f, 0.23263299f, -0.09622281f, 
    -0.17519373f, 0.24024056f, 0.38452914f, 0.03480409f, 0.20228739f, 0.26862159f, 0.06803456f, 0.10207547f, 
    0.29485980f, 0.16646443f, -0.04192511f, 0.23775110f, 0.09792341f, -0.32630134f, 0.00604395f, 0.20256355f, 
    -0.06286732f, 0.37179402f, -0.19365574f, -0.14464228f, -0.01158344f, 0.00496130f, 0.06226683f, 0.20855434f, 
    0.01131508f, 0.67968136f, -0.03911212f, -0.07895590f, 0.10357431f, 0.25890931f, -0.26302618f, 0.05087312f, 
    0.02578904f, -0.16268590f, -0.23330913f, 0.20091568f, 0.16569433f, -0.24801774f, 0.02549203f, 0.02977207f, 
    0.05248808f, 0.04545611f, 0.07060616f, 0.19567318f, 0.06760670f, -0.57715672f, -0.07184690f, -0.11242213f, 
    -0.71709061f, 0.28013992f, 0.01895274f, 0.08219466f, -0.07539444f, 0.04904950f, -0.03777171f, -0.27028239f, 
    0.25794622f, 0.19096223f, 0.39393851f, 0.39523205f, -0.13418972f, 0.01318557f, 0.11480912f, -0.00987046f, 
    0.07782202f, -0.00080936f, -0.34852406f, 0.06233915f, -0.21545710f, 0.09631940f, 0.01862061f, -0.29598850f, 
    0.17637974f, -0.10987373f, -0.02544917f, -0.13974096f, -0.06595759f, 0.25001520f, 0.02471087f, 0.35031241f, 
    0.02701379f, 0.06335596f, 0.01992628f, 0.19934678f, 0.45810992f, -0.28603864f, 0.10730786f, -0.03040271f, 
    0.37998343f, 0.09150603f, 0.14466885f, 0.12337935f, -0.10538950f, -0.08304469f, 0.22687048f, 0.00881830f, 
    -0.14604552f, -0.31388327f, 0.50194329f, 0.49713936f, -0.27817032f, 0.13523658f, 0.03858368f, -0.11417330f, 
    -0.07821912f, -0.31152067f, -0.02881856f, -0.07463112f, -0.02595781f, 0.53512990f, 0.10194407f, -0.10740406f, 
    -0.01613563f, -0.27377039f, -0.08957758f, 0.05440974f, 0.14020132f, 0.09188205f, 0.23424706f, 0.14226897f, 
    -0.40680930f, -0.15765613f, -0.49225140f, -0.13658141f, 0.31664202f, -0.07490765f, -0.18502779f, -0.15865640f, 
    0.23866682f, 0.33457980f, -0.14624083f, -0.12116697f, -0.01140696f, 0.22718041f, 0.04258183f, 0.49880302f, 
    0.10066975f, 0.30009913f, 0.08785766f, -0.05519460f, -0.00786849f, -0.09520505f, 0.14280266f, -0.26289970f, 
    -0.07970963f, 0.26316428f, -0.00041424f, -0.20356224f, -0.20035888f, 0.21484315f, 0.22364758f, 0.20594126f, 
    -0.19661954f, -0.25629631f, -0.00361395f, 0.07700907f, 0.21916686f, 0.16012315f, -0.03620569f, 0.10402450f, 
    0.00805980f, 0.16573986f, -0.52058643f, -0.21132043f, 0.20462546f, 0.08076472f, 0.00174619f, 0.00236118f, 
    0.38450432f, -0.07476546f, 0.05513706f, -0.16825162f, 0.08749649f, -0.84025115f, 0.31385446f, 0.23856649f, 
    0.24670228f, 0.07205169f, 0.05795949f, -0.04646478f, 0.05182695f, 0.17357887f, -0.02322716f, -0.61602181f, 
    -0.00292065f, -0.11538360f, 0.46496138f, -0.39200073f, -0.03164420f, -0.20926435f, 0.16747892f, -0.24459493f, 
    0.32442784f, 0.37958562f, -0.01709379f, -0.13585769f, 0.41411754f, -0.07201133f, 0.30153906f, 0.64313978f, 
    -0.19321853f, -0.14571664f, -0.13344100f, -0.27745116f, -0.15467346f, 0.22682433f, 0.08113592f, -0.23624684f, 
    -0.13032587f, 0.35930654f, 0.14575610f, 0.49159878f, -0.06217000f, 0.19893652f, -0.05769173f, 0.54169357f, 
    0.34709942f, -0.08561097f, 0.16844468f, -0.03101886f, 0.19993989f, 0.16922843f, 0.32367560f, 0.08462077f, 
    -0.00617134f, 0.60905182f, -0.04104722f, -0.00467006f, 0.08570991f, 0.12147331f, 0.01135654f, -0.10755769f, 
    0.20918237f, 0.09283554f, -0.15684831f, -0.59746277f, -0.09707622f, -0.60229594f, 0.09115015f, -0.55385280f, 
    -0.63614839f, 0.17073654f, 0.01062380f, 0.33561665f, 0.02168488f, 0.07919238f, 0.31769952f, -0.09453874f, 
    0.30458680f, -0.00773839f, 0.36309609f, 0.26588541f, 0.25154328f, -0.07838523f, -0.14445114f, -0.09990334f, 
    0.28377476f, 0.29661456f, -0.31161150f, -0.07870929f, 0.04426692f, 0.08427838f, -0.11714157f, 0.28758249f, 
    -0.21225981f, 0.02044554f, 0.27120242f, -0.09096086f, 0.03431202f, 0.44574544f, -0.06761952f, -0.55470502f, 
    -0.07854848f, 0.08079544f, 0.25280339f, 0.16008377f, -0.06885465f, 0.10472870f, 0.17653023f, 0.23927341f, 
    0.07982873f, -0.51947874f, 0.05549965f, 0.02673411f, -0.10559272f, -0.11681549f, 0.09040954f, 0.01080680f, 
    0.25550842f, -0.00232162f, 0.42039075f, 0.21663591f, -0.14538738f, 0.25666037f, 0.04907792f, 0.10483962f, 
    -0.16744281f, -0.00650562f, 0.25625205f, -0.27988297f, 0.07726486f, 0.55532598f, -0.54974437f, 0.17198418f, 
    -0.52161294f, -0.14576244f, -0.04236047f, 0.29510611f, -0.07368238f, -0.03762098f, 0.32639745f, 0.08584337f, 
    -0.10818241f, 0.17897712f, 0.11189085f, 0.16602443f, 0.13656601f, 0.50100046f, -0.34425557f, -0.32353982f, 
    0.71173614f, 0.17891634f, 0.49674249f, 0.19998054f, -0.27743378f, 0.16914982f, -0.27211055f, -0.66182899f, 
    0.47558028f, 0.14014336f, 0.16550365f, 0.19815363f, -0.19520406f, 0.20203011f, -0.09400830f, 0.33951756f, 
    0.11722569f, 0.36378247f, 0.14359774f, 0.03802782f, 0.42992198f, -0.74796718f, 0.22843458f, 0.21243024f, 
    -0.11600175f, -0.08040293f, 0.06763742f, -0.05732638f, 0.23482883f, -0.33577147f, 0.07975642f, -0.09999582f, 
    0.03352891f, -0.68696684f, 0.04772336f, 0.47990534f, -0.02643396f, 0.23181587f, -0.02732303f, -0.05926996f, 
    -0.26054886f, 0.09798294f, -0.11577430f, -0.06314894f, -0.03731331f, -0.40339071f, -0.70438898f, 0.43697849f, 
    -0.08278371f, -0.09577192f, -0.09981631f, -0.09859394f, 0.11966952f, 0.14433108f, -0.19708027f, -0.01550743f, 
    0.27852535f, 0.02749242f, 0.14448926f, -0.53619611f, -0.05477082f, 0.32726866f, 0.00350233f, -0.35152879f, 
    0.60013729f, -0.10780226f, 0.73690170f, -0.24881695f, -0.02202537f, 0.03254510f, -0.18440664f, -0.57499593f, 
    0.42082524f, 0.06413202f, -0.16608365f, 0.14510493f, -0.15194781f, -0.09963248f, -0.08587692f, 0.34991762f, 
    0.00726732f, 0.47794408f, 0.29073748f, -0.38199472f, 0.23288131f, 0.01064633f, -0.08932262f, -0.11141472f, 
    0.03909624f, 0.09038898f, 0.12603027f, 0.06268322f, 0.23610035f, 0.22120106f, -0.07276250f, -0.02649008f, 
    0.02481627f, -0.78820115f, 0.09513973f, 0.29664573f, 0.28805915f, -0.03996598f, 0.01383279f, 0.07393751f, 
    0.06626516f, -0.18454546f, -0.00737382f, 0.63606524f, 0.11627360f, 0.36752090f, 0.17352229f, 0.39505097f, 
    0.19767466f, -0.05673473f, -0.09990521f, 0.03264420f, 0.02399931f, 0.29604375f, -0.01234217f, 0.10092200f, 
    0.27062583f, -0.24607228f, -0.00050592f, -0.23396336f, -0.09432709f, -0.21672627f, 0.39766219f, -0.21070676f, 
    -0.14344984f, -0.07487091f, 0.30255952f, 0.00075781f, -0.05123461f, 0.15284035f, 0.41535851f, 0.60264021f, 
    0.10625166f, 0.17061853f, -0.00585503f, -0.16466722f, 0.24709117f, -0.27558041f, 0.17736895f, 0.20823623f, 
    0.06595077f, 0.18377471f, 0.16468826f, 0.01930217f, 0.32307392f, 0.09435418f, -0.16163836f, 0.17881320f, 
    0.14327128f, 0.08113815f, 0.21429186f, -0.06687891f, -0.05992195f, 0.24216151f, -0.25577673f, -0.04920074f, 
    -0.09889571f, 0.18310088f, -0.45166332f, -0.15603602f, 0.11137947f, 0.20522869f, 0.06452145f, 0.04855420f, 
    0.09690267f, 0.14900252f, 0.11833696f, 0.34032014f, -0.08382297f, 0.80476832f, 0.27738178f, -0.02053044f, 
    0.71719867f, 0.03252871f, 0.03006427f, -0.08880024f, -0.11237457f, 0.04248039f, 0.01982797f, 0.22605291f, 
    -0.36251879f, -0.08932392f, -0.22899410f, 0.12861967f, -0.14755531f, 0.01255079f, 0.19376157f, 0.09356064f, 
    -0.43987447f, 0.18984219f, 0.48471430f, -0.39847854f, 0.15026414f, -0.35922846f, 0.26584083f, 0.28627285f, 
    -0.11339691f, -0.14730911f, 0.05337779f, 0.01721013f, 0.26840380f, 0.04997726f, 0.23816361f, 0.06009544f, 
    0.01512121f, -0.32061929f, -0.22732560f, 0.13418853f, -0.05000726f, 0.01143078f, -0.23032562f, -0.12511031f, 
    0.29934675f, 0.47218969f, 0.18869574f, 0.01797911f, 0.15533091f, 0.03136307f, -0.29655391f, 0.06906331f, 
    -0.03657664f, 0.09326877f, -0.16621807f, -0.40654162f, 0.01533918f, -0.17444581f, 0.04623347f, -0.03358028f, 
    -0.16501790f, -0.00282702f, -0.07281665f, 0.08108606f, 0.08647494f, -0.05571255f, 0.02497357f, -0.12359278f, 
    -0.04168652f, -0.15587546f, -0.09081846f, -0.11669095f, 0.06173468f, 0.02143885f, -0.12720038f, -0.05795088f, 
    -0.11832736f, -0.06929462f, -0.10804784f, -0.02509418f, -0.12478732f, 0.03778626f, 0.00828584f, -0.02823908f, 
    -0.01844587f, -0.08297803f, 0.07508307f, -0.03642663f, -0.10555265f, 0.02853858f, -0.05844485f, 0.08080601f, 
    -0.04998194f, -0.04755590f, -0.04890301f, -0.11495010f, -0.12775634f, 0.04708887f, -0.11077870f, -0.04506673f, 
    0.00359026f, 0.06833877f, 0.06182693f, 0.04572264f, 0.03658576f, 0.07801593f, -0.08074863f, 0.03158758f, 
    -0.12299930f, -0.00437574f, -0.09964471f, -0.08568758f, -0.12565824f, -0.01417891f, -0.02280043f, 0.11583911f, 
    0.06403289f, 0.01417097f, 0.02934542f, -0.12392108f, 0.06102585f, 0.06210082f, -0.09233014f, -0.02264184f, 
    0.22150359f, 0.34617528f, 0.40761191f, -0.01368537f, -0.02386767f, -0.23145345f, 0.09946211f, 0.22588469f, 
    0.01194851f, 0.16509166f, 0.02189593f, 0.03939591f, 0.10810842f, 0.24895701f, 0.04448074f, -0.74937826f, 
    -0.36574861f, 0.34911141f, 0.64702117f, 0.03333467f, -0.09913509f, -0.50465780f, 0.30391589f, -0.08845229f, 
    0.20126949f, -0.02669711f, -0.36681014f, -0.38277829f, 0.15527913f, 0.15086003f, 0.29506361f, -0.25848722f, 
    -0.13866732f, -0.23705062f, 0.05656888f, -0.06862123f, -0.08062675f, 0.07201900f, -0.37734246f, -0.06393001f, 
    -0.02726010f, 0.14324917f, -0.00747584f, 0.33982128f, 0.23962969f, 0.02882310f, 0.36556724f, 0.32454020f, 
    0.37940681f, 0.00098497f, 0.31325394f, 0.04570796f, -0.07578467f, -0.00061694f, 0.01879499f, 0.12074751f, 
    -0.16118172f, -0.02206195f, -0.08932190f, 0.10234380f, 0.01041282f, 0.08444241f, 0.05438159f, 0.09765203f, 
    0.11336156f, 0.25511587f, 0.42155316f, 0.23654416f, -0.04744725f, 0.39118892f, 0.07827149f, 0.19980416f, 
    -0.27179885f, -0.02281914f, 0.11255518f, 0.05035312f, 0.03625538f, 0.14382133f, 0.03320896f, 0.30460736f, 
    -0.51631856f, 0.29902035f, 0.17172165f, 0.15370834f, -0.31206101f, -0.33609420f, 0.56911129f, -0.21470359f, 
    -0.32044160f, 0.15509339f, 0.17716359f, -0.17815353f, -0.09948235f, 0.11542825f, 0.54334128f, -0.04337820f, 
    -0.11684494f, -0.08139539f, 0.06873772f, -0.17690004f, 0.27505469f, -0.31676731f, -0.21481934f, -0.04674729f, 
    0.02027484f, 0.06344253f, -0.33492240f, 0.32434809f, -0.00470053f, -0.48418379f, 0.16112612f, 0.26194280f, 
    0.34222004f, 0.87146622f, 0.47778025f, 0.12688315f, -0.03912872f, 0.14806393f, 0.03184016f, 0.10588570f, 
    0.00673293f, -0.12476247f, -0.17253931f, -0.04167714f, 0.24937768f, -0.08365058f, 0.05684141f, 0.07609062f, 
    -0.06138358f, 0.04980478f, -0.08227386f, 0.05066939f, 0.05602343f, -0.06525139f, -0.01010260f, -0.12434042f, 
    -0.04035123f, 0.02631399f, -0.00733595f, 0.07831064f, 0.07981624f, -0.11919269f, -0.01719257f, -0.06311706f, 
    -0.06464393f, 0.08106317f, -0.12883547f, -0.12422306f, 0.01611828f, 0.09195380f, -0.04407495f, -0.04759622f, 
    -0.04354955f, -0.04703477f, 0.00371501f, -0.04623584f, -0.08430617f, 0.08043084f, -0.01042946f, -0.05508278f, 
    0.01052170f, -0.05130792f, -0.03357432f, 0.04318794f, 0.06984154f, 0.09331940f, -0.07330722f, -0.00014902f, 
    -0.05147924f, -0.08443312f, -0.06592924f, -0.04156428f, -0.03786269f, -0.00414926f, -0.02542134f, 0.10471559f, 
    -0.07655369f, -0.01399854f, 0.02462757f, 0.06678362f, 0.02219344f, -0.02642899f, 0.00856808f, 0.12488601f, 
    -0.08511449f, -0.00990901f, -0.05681724f, -0.10938708f, -0.08762272f, 0.04395748f, -0.01367113f, 0.09223235f, 
    0.16739595f, 0.06455503f, -0.08521700f, 0.16420093f, 0.03593613f, 0.25472131f, -0.04103665f, 0.03509489f, 
    0.84372336f, 0.30760333f, -0.06421950f, -0.05754056f, -0.09565178f, -0.13076444f, 0.17973372f, -0.10407505f, 
    -0.29402405f, 0.05262887f, 0.07782923f, 0.03865206f, 0.08798905f, -0.02552115f, -0.13695590f, 0.25020909f, 
    -0.12434153f, 0.04385367f, -0.40363646f, -0.39929038f, 0.32708412f, -0.48883915f, -0.01620139f, 0.07843687f, 
    -0.19688086f, -0.03685669f, 0.00924321f, 0.27841094f, -0.11021793f, 0.34191713f, 0.25530595f, -0.18402576f, 
    0.09208667f, -0.12781534f, 0.18709199f, 0.03218168f, 0.03840663f, 0.40588516f, -0.17050239f, -0.31680983f, 
    0.07507246f, -0.17659853f, -0.31524318f, -0.09015967f, 0.10917747f, 0.11017182f, 0.29760459f, 0.09111467f, 
    0.32480195f, 0.23012689f, 0.36003906f, -0.21762598f, -0.14811759f, 0.19323705f, -0.05497391f, -0.03316709f, 
    0.01574424f, -0.07576879f, -0.11530334f, 0.08649522f, -0.05201901f, -0.04723110f, -0.08862846f, 0.01250285f, 
    -0.04720838f, 0.03298068f, -0.04338633f, 0.07356316f, 0.09742299f, -0.11426152f, 0.04117996f, 0.06599233f, 
    -0.00299991f, -0.09358960f, -0.04651511f, 0.03455092f, -0.08077333f, -0.12445384f, -0.01097241f, 0.05551599f, 
    -0.07513231f, 0.00293924f, 0.04254627f, -0.00247418f, -0.13783276f, -0.03473186f, -0.01247580f, -0.10954295f, 
    -0.12611508f, 0.00262849f, -0.04287543f, -0.03007906f, -0.00053301f, 0.10436076f, 0.00788810f, 0.06353442f, 
    0.08002712f, -0.07390632f, 0.00255784f, -0.07488648f, 0.05976205f, 0.04682918f, 0.08241148f, -0.11450353f, 
    -0.12252733f, -0.10323901f, -0.07489830f, 0.03849013f, -0.05758904f, 0.03990458f, -0.01310013f, 0.06794876f, 
    0.01408277f, -0.02911839f, -0.14067312f, -0.06183175f, -0.16602084f, -0.11829073f, 0.02951032f, -0.13710321f, 
    -0.12807575f, -0.18570465f, -0.36769161f, 0.55642337f, 0.02125935f, 0.58163089f, 0.17721991f, 0.11390848f, 
    0.53363240f, 0.11965039f, 0.11220849f, 0.27155349f, 0.09504708f, -0.06734438f, -0.00002079f, 0.01652804f, 
    0.03486729f, -0.01894533f, -0.37675369f, 0.20501290f, 0.13992780f, -0.20988533f, 0.12091653f, 0.41607705f, 
    -0.04088793f, -0.32234725f, -0.30991197f, -0.18962243f, -0.17755198f, -0.15332936f, -0.17140049f, 0.25089619f, 
    0.06254416f, 0.17831109f, 0.17698875f, 0.22112641f, -0.03732414f, -0.07469397f, 0.15665706f, 0.32782638f, 
    0.24815147f, -0.26340881f, 0.15299755f, -0.20867147f, 0.29327202f, 0.06690124f, -0.02307722f, -0.10679493f, 
    0.10022301f, -0.28204316f, -0.06903100f, -0.07570534f, -0.04968580f, 0.07444876f, 0.29698825f, -0.01523542f, 
    0.15627748f, -0.06517803f, -0.15161282f, -0.12899223f, -0.11742561f, 0.20825633f, -0.07160273f, 0.05118569f, 
    0.17837946f, 0.13696161f, 0.05431808f, 0.24634509f, 0.07390881f, 0.29602203f, -0.09682723f, 0.10407741f, 
    0.60407448f, 0.41975960f, -0.00080890f, 0.00148942f, 0.04413997f, -0.05920682f, -0.02711909f, 0.01899016f, 
    0.22244819f, 0.30264270f, 0.19257876f, 0.15398116f, -0.15566809f, 0.00300098f, 0.26396966f, 0.47809142f, 
    -0.23398751f, -0.03296281f, -0.20999244f, 0.12205455f, 0.03321708f, -0.35840002f, 0.05608423f, -0.40915310f, 
    -0.12581868f, -0.15322563f, 0.21949385f, 0.34906748f, -0.05406487f, 0.23016079f, -0.03132902f, 0.37938124f, 
    0.22523089f, -0.36609164f, -0.01446366f, 0.05582288f, 0.24070689f, 0.05816149f, -0.25421637f, -0.52477151f, 
    0.30839086f, 0.23578283f, -0.06762066f, -0.07258157f, 0.11470144f, -0.12205707f, 0.19027622f, -0.06097464f, 
    0.02914606f, -0.12725091f, 0.21637952f, -0.24278353f, -0.14402653f, 0.06164770f, 0.04375518f, -0.04378614f, 
    -0.11868975f, -0.02561203f, -0.09755969f, -0.06739293f, -0.02957703f, -0.11093891f, 0.03375302f, -0.05222724f, 
    -0.07139839f, -0.07349603f, -0.05205907f, 0.11832361f, 0.02770634f, -0.05375335f, 0.11070190f, -0.08811578f, 
    -0.01709896f, -0.02775925f, 0.06262927f, -0.03403638f, -0.09736013f, -0.03024748f, 0.01494026f, -0.10002618f, 
    0.08205345f, -0.11012094f, -0.07477415f, 0.10551417f, -0.11695717f, -0.10211384f, -0.02572486f, -0.05427377f, 
    -0.06720138f, -0.05618066f, 0.00131291f, -0.05712725f, 0.08499204f, 0.07360515f, -0.03467280f, -0.06817998f, 
    -0.07958844f, 0.09361863f, -0.08252566f, 0.11454512f, -0.03319532f, -0.08544002f, -0.11419904f, 0.02896708f, 
    -0.08582252f, 0.00196372f, -0.07233442f, -0.04272260f, -0.10333201f, -0.00397447f, 0.03226763f, 0.10824405f, 
    0.02368598f, -0.07136367f, 0.01640578f, -0.03063381f, -0.07810767f, -0.02553152f, 0.03550060f, -0.01052669f, 
    -0.14111125f, -0.10740617f, -0.17884395f, 0.35198870f, -0.11033401f, -0.46272168f, -0.12798871f, -0.13339303f, 
    -0.21065748f, -0.32209846f, -0.09855065f, -0.12858914f, 0.08297232f, -0.04865580f, 0.02314284f, 0.44867599f, 
    0.19088730f, -0.32217491f, -0.43742368f, 0.19120190f, 0.00671209f, 0.09623133f, 0.00240397f, 0.41862252f, 
    0.00605992f, -0.11798345f, -0.23223133f, -0.06446133f, 0.08476438f, 0.05779487f, 0.11135259f, 0.03471706f, 
    0.22909299f, 0.03545831f, -0.07520404f, 0.15275252f, 0.03869727f, -0.02334195f, 0.04648359f, 0.11486251f, 
    0.00558471f, -0.22362882f, 0.14796169f, -0.32008174f, 0.31039959f, -0.22041999f, -0.00347849f, 0.01616385f, 
    -0.17164992f, 0.20140445f, 0.26622149f, -0.08716781f, 0.13104255f, -0.01110927f, -0.18930961f, -0.02389085f, 
    0.20212528f, -0.05964223f, -0.68999726f, -0.21259576f, -0.05786558f, -0.04699885f, -0.06101592f, -0.04010415f, 
    -0.26805997f, -0.08911020f, 0.28025860f, 0.05774383f, -0.11187796f, -0.11040939f, -0.17218460f, 0.07043570f, 
    -0.13434947f, -0.15291180f, -0.11019218f, 0.05012691f, -0.02193862f, 0.12565117f, -0.19252397f, 0.04476081f, 
    -0.41367862f, 0.01262172f, -0.08495630f, 0.39350602f, 0.20375571f, 0.43503872f, -0.10506139f, 0.12935984f, 
    -0.05762870f, -0.15718254f, 0.00405881f, 0.39080575f, 0.14405340f, 0.12624493f, -0.18149784f, 0.00748120f, 
    0.47800049f, 0.26867497f, 0.17536013f, 0.14378741f, -0.12877604f, 0.06850997f, 0.41473648f, -0.13525482f, 
    0.05501714f, 0.43659884f, -0.01280238f, -0.19244497f, -0.05655177f, 0.12839344f, 0.11034367f, 0.34994897f, 
    -0.05747126f, 0.23862857f, -0.11588822f, -0.03550219f, -0.25788409f, 0.10214758f, 0.20591518f, 0.04253088f, 
    0.09195888f, 0.04755219f, 0.23088659f, 0.68438709f, 0.09835412f, 0.02194570f, 0.03464289f, 0.11667792f, 
    0.02649662f, -0.18155243f, -0.01251427f, -0.31447017f, -0.12321621f, 0.35864815f, 0.04606694f, 0.34726566f, 
    0.51374203f, -0.16021065f, -0.09965978f, -0.03441999f, -0.10682553f, 0.08088510f, -0.07728864f, -0.05861213f, 
    -0.15724112f, -0.03600546f, 0.10648493f, -0.19548640f, 0.06621052f, 0.10998157f, -0.06236493f, -0.22942562f, 
    0.43423614f, 0.21782950f, 0.67227656f, 0.37773865f, 0.24157149f, -0.02325979f, -0.08926829f, 0.35568884f, 
    0.00825931f, 0.16979906f, -0.04941464f, 0.04879803f, -0.06108785f, 0.11790576f, 0.06544923f, -0.18591316f, 
    -0.05969608f, 0.53087473f, 0.15354680f, -0.18601575f, -0.01064588f, 0.27509105f, -0.03206014f, 0.15940312f, 
    -0.04200172f, 0.08863943f, -0.03947323f, -0.05512335f, 0.29145855f, -0.01738423f, 0.12750442f, 0.09744799f, 
    -0.12274132f, 0.20087263f, -0.27382678f, 0.16491038f, 0.06155714f, 0.08298613f, -0.01800185f, 0.07758359f, 
    0.08244579f, 0.38106304f, 0.24409786f, -0.20068093f, -0.04634976f, -0.72544289f, 0.14882982f, 0.06776462f, 
    -0.58256984f, -0.16237608f, 0.05768111f, 0.16074921f, -0.09113845f, 0.34502313f, -0.20231175f, -0.16627254f, 
    -0.22213075f, 0.37155831f, 0.34099233f, -0.11438015f, 0.00412137f, -0.09316862f, 0.29130909f, -0.34994200f, 
    -0.02979331f, 0.27378386f, 0.12348267f, -0.00587689f, 0.09000836f, 0.49273729f, 0.34601617f, 0.01138538f, 
    -0.06527030f, -0.15542124f, -0.01473303f, -0.14799683f, 0.18413034f, -0.15677808f, -0.06766809f, -0.14668503f, 
    -0.07156031f, 0.38688076f, -0.14798102f, 0.28449833f, -0.20073521f, -0.01406338f, 0.30996075f, 0.53363317f, 
    0.21512459f, 0.28079712f, 0.19597583f, 0.04909175f, -0.12631094f, 0.12720004f, 0.15162036f, 0.06822124f, 
    -0.09875558f, 0.09818092f, 0.08487540f, 0.26090243f, 0.32691747f, -0.11197856f, 0.02795279f, -0.06903909f, 
    -0.05784732f, 0.05238693f, 0.29490855f, 0.32984295f, 0.06596684f, 0.25161132f, -0.13623586f, 0.16452628f, 
    0.81452745f, -0.02276065f, 0.09678839f, 0.03105881f, 0.12111478f, 0.00003613f, -0.49090102f, 0.17338800f, 
    -0.50467181f, 0.16795109f, -0.15779731f, -0.20872818f, 0.04714015f, -0.31921327f, 0.24678528f, 0.21523042f, 
    0.02316600f, 0.09572134f, -0.31396511f, -0.44785577f, 0.13422002f, -0.26501790f, 0.26489574f, 0.10644004f, 
    -0.15339634f, -0.07751841f, 0.05470440f, 0.22187839f, -0.04282411f, -0.18336208f, 0.12286137f, 0.32511106f, 
    -0.00780201f, -0.28647310f, -0.04955097f, -0.33327755f, 0.05347070f, 0.44125515f, -0.02386208f, -0.28557855f, 
    -0.02452724f, 0.54832858f, -0.10035415f, -0.03845754f, 0.13232160f, 0.32815981f, 0.05806280f, -0.08510657f, 
    0.18543425f, 0.02529050f, -0.38597947f, -0.03459951f, 0.04012473f, -0.07015412f, 0.03952472f, -0.00366350f, 
    -0.02188770f, -0.11239395f, 0.10375185f, 0.00067295f, 0.10289322f, -0.00069307f, 0.09689365f, -0.12128711f, 
    -0.10054526f, -0.12019694f, 0.08746120f, -0.05116379f, 0.06254606f, -0.01842830f, 0.07548468f, 0.06987430f, 
    -0.05282032f, -0.05178556f, 0.10840890f, -0.06261647f, 0.00989424f, -0.07499740f, 0.07190265f, -0.03321066f, 
    -0.11833660f, -0.09948541f, -0.03066616f, -0.08604439f, -0.05333625f, 0.06643431f, -0.02653606f, -0.06438805f, 
    -0.08624697f, -0.11741449f, -0.00964013f, 0.00216788f, -0.07998508f, 0.04856899f, -0.10949720f, 0.02234912f, 
    0.01316550f, 0.01862174f, 0.04217711f, -0.05434431f, -0.08901444f, -0.07447666f, -0.03664954f, -0.05764572f, 
    0.12060288f, 0.11262049f, -0.06349367f, 0.08752061f, -0.11283302f, -0.02345024f, -0.05306527f, -0.10794324f, 
    -0.12333161f, 0.09068422f, -0.01231799f, 0.09010282f, 0.07365669f, -0.11316228f, -0.09308992f, -0.00273208f, 
    -0.01523419f, 0.40228131f, 0.52389640f, 0.26340204f, -0.04701498f, 0.09080234f, 0.10259551f, 0.36613828f, 
    0.35787880f, -0.02338837f, -0.09820384f, -0.19815992f, 0.01795302f, 0.11507969f, -0.11379027f, 0.16714489f, 
    -0.17289215f, 0.26665026f, 0.14816566f, 0.24388254f, -0.34291923f, -0.29560852f, 0.30789253f, -0.06679819f, 
    -0.29385611f, 0.17110997f, 0.07059910f, 0.03764165f, -0.00867452f, -0.18017212f, 0.31525007f, -0.18116198f, 
    -0.04680281f, -0.17700118f, 0.09237512f, 0.08157448f, 0.13263842f, -0.04424203f, 0.02539325f, 0.16103712f, 
    -0.04191644f, -0.18655968f, -0.39532441f, 0.00910776f, -0.10438231f, -0.27901539f, 0.01909081f, -0.16765074f, 
    0.37819505f, 0.78138804f, 0.14167038f, 0.12289715f, 0.15706061f, 0.09001582f, 0.14502186f, 0.09348440f, 
    -0.19960731f, -0.11512407f, 0.06420478f, -0.05041177f, 0.07424346f, -0.12468448f, -0.03145681f, 0.04079571f, 
    -0.06247404f, 0.05068466f, -0.00984961f, -0.12891714f, -0.02903588f, 0.05499433f, -0.01563444f, -0.02544610f, 
    -0.09384677f, -0.07377555f, -0.04974309f, -0.04266995f, -0.07663904f, 0.09276582f, -0.06969693f, -0.05813824f, 
    -0.06070751f, -0.13468744f, 0.04075210f, 0.06183387f, -0.04358561f, 0.04786533f, -0.01938591f, -0.05713658f, 
    -0.06335005f, 0.01965141f, 0.01378061f, 0.00625674f, -0.11528229f, -0.10134773f, -0.07563103f, -0.00797861f, 
    -0.08761630f, -0.14643113f, -0.00300705f, -0.03438924f, 0.02586113f, 0.02382296f, -0.06145885f, 0.05475232f, 
    0.09227847f, -0.02109277f, -0.00228864f, -0.02755465f, 0.00561566f, 0.01581993f, 0.00973693f, 0.01031430f, 
    -0.00423748f, 0.06407491f, -0.01599592f, -0.06030416f, 0.09972621f, -0.07231503f, -0.01747659f, 0.11469981f, 
    -0.08959914f, -0.03512605f, 0.09149079f, -0.14116852f, -0.02900355f, -0.03765414f, -0.03857650f, -0.02724746f, 
    -0.02991422f, -0.07202690f, -0.10060617f, 0.01875698f, 0.04307561f, -0.05277250f, -0.00159749f, 0.12140284f, 
    -0.06348564f, 0.04282757f, -0.02362645f, 0.02259291f, 0.08400346f, -0.11207276f, -0.10261467f, -0.03754153f, 
    0.06493983f, -0.03011254f, -0.08487642f, 0.01533236f, 0.06817552f, -0.13327377f, -0.11361703f, 0.09986075f, 
    -0.06166835f, -0.08381740f, 0.08438382f, -0.00422006f, 0.08626838f, 0.08606282f, -0.09292041f, -0.07251936f, 
    -0.07958222f, -0.07378417f, 0.03386353f, -0.11212695f, -0.10488548f, -0.10567211f, -0.12722361f, -0.09844263f, 
    0.02374154f, -0.05506185f, 0.04833287f, -0.01607689f, -0.05889004f, 0.08236424f, -0.06578319f, 0.00705036f, 
    -0.10649559f, -0.06643957f, -0.08584559f, -0.07206279f, 0.00326473f, -0.09800446f, -0.05717614f, 0.08540697f, 
    -0.12294684f, 0.09371847f, 0.03434122f, -0.14511739f, -0.15218571f, 0.06822754f, 0.11394976f, -0.11434412f, 
    0.22714174f, -0.12781776f, 0.51527458f, -0.09177618f, 0.07252322f, 0.28636533f, 0.21406573f, -0.28530005f, 
    -0.21466622f, 0.07980517f, 0.02413026f, -0.20533438f, -0.00166780f, -0.34663460f, 0.06270714f, -0.13359070f, 
    -0.11792602f, -0.16181931f, -0.25920913f, 0.08331346f, -0.04248158f, 0.08189634f, 0.15572789f, -0.07698991f, 
    -0.55002457f, -0.41185966f, -0.30922174f, 0.27679592f, 0.08156302f, 0.10738572f, 0.03094113f, -0.08406053f, 
    -0.33612767f, 0.01418921f, -0.22104868f, -0.20048590f, 0.06014384f, -0.00127548f, -0.12454139f, -0.19679427f, 
    0.02428748f, -0.03604652f, 0.09129509f, 0.17570989f, 0.04839710f, -0.05217765f, 0.11044516f, -0.11113542f, 
    -0.17850772f, -0.31076786f, -0.09174170f, -0.04825173f, -0.23749311f, -0.24001476f, 0.24575843f, -0.05677706f, 
    -0.12315115f, -0.06833451f, 0.06418733f, -0.30963224f, -0.05744950f, 0.07168964f, 0.00691210f, 0.10872505f, 
    -0.08315726f, -0.11088321f, -0.08697293f, -0.04407548f, 0.02276568f, 0.00642513f, -0.05797679f, 0.03711531f, 
    -0.06351244f, 0.03723091f, -0.04369158f, -0.07027607f, -0.09686518f, -0.04454929f, -0.01473849f, 0.10472719f, 
    -0.05286177f, -0.06258705f, -0.04329669f, -0.01846077f, 0.02603439f, -0.09052072f, -0.07191575f, 0.02569213f, 
    -0.07961480f, -0.08075554f, -0.03864215f, 0.04050967f, -0.04134982f, -0.04712836f, -0.04903680f, 0.01840471f, 
    -0.10041752f, -0.09384999f, -0.04117868f, -0.02653829f, -0.09222193f, 0.04616488f, 0.03488114f, 0.04816334f, 
    -0.02167330f, 0.01737326f, -0.03161174f, 0.10672741f, 0.02576441f, 0.09217929f, -0.07390039f, 0.01588142f, 
    -0.01638857f, 0.00318682f, 0.07876489f, -0.10943340f, -0.03045934f, -0.09494061f, 0.11521187f, 0.01888733f, 
    -0.07466850f, 0.09482525f, -0.11243618f, 0.03264674f, 0.02058711f, 0.08001085f, 0.02281546f, -0.09541889f, 
    -0.03461929f, -0.10930710f, -0.00183432f, 0.04473114f, 0.08657610f, -0.00954165f, -0.01943132f, -0.06354525f, 
    -0.04366679f, -0.14845981f, -0.01754595f, -0.06019315f, -0.05261762f, -0.00018496f, 0.05979830f, -0.02931495f, 
    -0.00778413f, -0.13716565f, -0.07042021f, 0.08756744f, -0.13509721f, -0.12226522f, 0.07782861f, -0.04981609f, 
    -0.08970274f, -0.08333677f, -0.05256927f, 0.01032442f, -0.09997904f, -0.11023995f, 0.00275256f, 0.05554903f, 
    -0.03574292f, -0.02115306f, 0.04353843f, 0.00569894f, -0.02397216f, -0.13141550f, 0.00766261f, -0.08399411f, 
    -0.02459352f, -0.07479827f, -0.08478111f, 0.01548237f, -0.01946436f, -0.10423737f, 0.00301556f, -0.03175643f, 
    0.07425918f, 0.09277762f, -0.07716591f, -0.04642360f, -0.03117479f, -0.04563175f, -0.02175781f, -0.06311604f, 
    0.05976862f, -0.07995269f, -0.05993856f, 0.01671743f, -0.08119783f, -0.09750250f, -0.12123902f, -0.05768691f, 
    0.12858579f, -0.06287596f, 0.53988445f, -0.02866234f, 0.05323189f, -0.19704299f, 0.13675198f, -0.20145035f, 
    0.11217370f, 0.07962537f, 0.01699813f, 0.14133079f, -0.01662235f, -0.04147688f, 0.41418105f, -0.67429984f, 
    -0.32740092f, -0.00695612f, 0.08259417f, 0.15189458f, -0.15433878f, -0.04808677f, -0.11068617f, -0.09596656f, 
    0.27741441f, 0.06476851f, 0.52811706f, 0.14507942f, -0.03366853f, 0.26841569f, -0.35537490f, -0.09892641f, 
    0.05577336f, 0.35416117f, 0.03039197f, -0.10307465f, 0.13940118f, -0.08990663f, -0.19717935f, 0.46111137f, 
    -0.02921558f, -0.22173947f, 0.16655719f, 0.01442059f, 0.17980899f, 0.28003252f, 0.06326987f, 0.01708268f, 
    -0.13562366f, -0.65745217f, -0.28336766f, 0.05985136f, 0.05271749f, -0.15457654f, 0.10321900f, 0.02840436f, 
    -0.31671110f, -0.19373167f, 0.02345132f, -0.12460391f, -0.00649832f, 0.11731554f, -0.00588611f, 0.02118545f, 
    -0.16229966f, 0.06890641f, 0.68282932f, 0.20441951f, -0.08638142f, -0.19076118f, -0.09193455f, -0.00183613f, 
    0.43638718f, 0.04399278f, -0.04430052f, -0.40426219f, -0.01757446f, -0.10791308f, -0.62023979f, 0.57383120f, 
    -0.24691786f, 0.25971496f, -0.01321020f, 0.13090415f, 0.23198421f, 0.30227026f, -0.14838436f, 0.37335926f, 
    -0.16442995f, -0.14891310f, -0.70916021f, 0.40212965f, 0.35342500f, 0.28934425f, 0.17252497f, -0.12435291f, 
    0.06620099f, -0.03445805f, -0.12865958f, 0.36191592f, -0.14960329f, 0.00201557f, 0.23688319f, -0.41970822f, 
    -0.00249658f, 0.06231787f, -0.22141191f, 0.04876791f, 0.02160659f, 0.24005948f, -0.10487676f, -0.33299336f, 
    -0.09185114f, 0.46224734f, -0.37076131f, -0.00204429f, -0.22754854f, 0.26137155f, 0.20058174f, -0.02727690f, 
    0.19665082f, 0.17715916f, -0.00971244f, 0.35985142f, 0.17287615f, 0.07660593f, 0.02844293f, -0.07731903f, 
    0.06666671f, 0.18056044f, 0.20587145f, -0.12396777f, -0.05388585f, 0.38627365f, 0.26847845f, -0.37046924f, 
    -0.96616924f, -0.09682557f, -0.08557968f, 0.40009800f, -0.07366836f, -0.06903886f, 0.16675361f, -0.03494795f, 
    0.22408643f, -0.22524959f, 0.04970269f, 0.01503898f, -0.04561884f, 0.15062803f, -0.02169128f, -0.37468851f, 
    0.46194109f, 0.04241294f, -0.04448748f, 0.34908631f, -0.36283594f, 0.27562615f, -0.17044589f, -0.06728489f, 
    0.16607608f, 0.29793218f, -0.02617520f, -0.34693119f, 0.09210002f, -0.18335700f, -0.35822377f, 0.20759462f, 
    -0.01268789f, -0.38891309f, -0.02312897f, -0.04049773f, 0.21194123f, -0.25799170f, 0.41551903f, 0.34678099f, 
    -0.40325835f, -1.05441689f, 0.18651034f, 0.09688020f, 0.03464775f, -0.32967153f, -0.12041102f, 0.04320030f, 
    -0.25868231f, -0.03468977f, -0.07983715f, -0.31616879f, 0.30440864f, -0.03552394f, 0.13237205f, 0.12112417f, 
    -0.04530435f, 0.15090793f, 0.18294220f, -0.12160148f, 0.11351450f, 0.13710913f, 0.07145479f, -0.23659393f, 
    -0.03394019f, -0.11259598f, -0.02493698f, 0.34627953f, -0.11493898f, 0.16182281f, 0.30328861f, -0.17333901f, 
    -0.29851234f, 0.03055257f, -0.30350837f, 0.13619095f, 0.19958149f, -0.29528618f, -0.11616526f, -0.03363820f, 
    0.05879406f, -0.06417911f, 0.05131270f, -0.27378121f, 0.08547629f, 0.02883198f, -0.18710610f, 0.39151067f, 
    -0.04960020f, 0.25139326f, 0.07191908f, 0.00236495f, 0.17286135f, -0.04618713f, -0.14160585f, 0.25422314f, 
    0.09438963f, -0.24917068f, 0.09797495f, -0.15637335f, -0.01475768f, 0.44905585f, 0.09337596f, 0.21378933f, 
    -0.34214181f, -0.22099760f, -0.16412282f, 0.01770419f, 0.22329389f, -0.04478474f, 0.16777162f, -0.07480113f, 
    -0.07080270f, 0.17700721f, -0.18968242f, -0.23733316f, 0.15392728f, -0.06162459f, -0.11187670f, 0.03658339f, 
    -0.05604447f, 0.05092632f, 0.37765643f, -0.01395973f, 0.00664000f, -0.18474093f, 0.27018833f, 0.05342836f, 
    -0.56423992f, 0.04893919f, 0.00306837f, -0.20905025f, 0.06358679f, 0.06123920f, 0.05108524f, -0.44607249f, 
    -0.14269416f, 0.10974389f, 0.17755345f, 0.06039267f, -0.10915262f, 0.20457651f, -0.06400135f, 0.06370530f, 
    -0.03919917f, -0.26753247f, 0.58782470f, 0.13672039f, 0.13419726f, 0.16573510f, -0.33148926f, 0.03359937f, 
    0.12754495f, 0.22705100f, -0.23132354f, -0.01699863f, -0.20707954f, -0.18548924f, 0.16392078f, 0.02159459f, 
    0.04061140f, 0.07586668f, -0.08293211f, 0.04676379f, -0.02711392f, 0.37944806f, -0.20165661f, 0.24500073f, 
    -0.06360016f, -0.20692970f, -0.32041249f, 0.01474787f, -0.07005796f, 0.14551015f, 0.12777679f, 0.11472422f, 
    -0.37349495f, 0.17877071f, 0.63280952f, -0.13602912f, 0.06808785f, -0.16964936f, 0.09610249f, 0.01663016f, 
    -0.21153736f, -0.08102063f, -0.37459093f, 0.53295553f, 0.06401509f, 0.66597611f, 0.09315707f, 0.10002480f, 
    0.06057996f, -0.26659602f, -0.04993859f, -0.17545971f, 0.05259935f, 0.19389609f, 0.06634216f, -0.08136538f, 
    -0.34326732f, -0.09981894f, -0.19886103f, 0.18741627f, 0.15265509f, 0.28455651f, -0.19813085f, -0.16432561f, 
    -0.34059018f, -0.00453082f, 0.26975453f, -0.39216623f, -0.05763182f, -0.13148399f, 0.21449487f, 0.53270811f, 
    0.29067123f, -0.01182941f, 0.00917045f, -0.07624946f, 0.04630437f, -0.04752333f, 0.59293211f, 0.04412552f, 
    0.23204827f, 0.29923639f, 0.06056314f, 0.15269943f, 0.16576090f, -0.02071862f, -0.38986999f, 0.53804427f, 
    -0.03427387f, 0.03270589f, 0.12459476f, -0.13062721f, -0.08374902f, 0.15351173f, -0.18515490f, 0.09044947f, 
    -0.05268614f, 0.20780809f, -0.19264641f, -0.04007626f, -0.01058498f, 0.14727838f, 0.05418217f, 0.01927607f, 
    -0.00531538f, -0.08909419f, -0.08436725f, -0.10749682f, -0.08272065f, 0.06739594f, 0.01555023f, 0.08523468f, 
    0.10277395f, -0.06276939f, -0.12205543f, 0.02311300f, -0.03042945f, -0.11937362f, -0.05869893f, 0.11769336f, 
    -0.00787293f, -0.07332743f, -0.08111956f, 0.07577258f, -0.17130712f, -0.04971727f, -0.10711231f, -0.05411758f, 
    0.07822472f, 0.08494098f, -0.10547084f, 0.06964217f, -0.06495749f, 0.08823861f, -0.14435147f, -0.09334252f, 
    0.02412653f, 0.01409711f, 0.02856367f, -0.07701817f, -0.12012392f, -0.02009780f, -0.04958422f, -0.01374823f, 
    -0.07997021f, -0.02820871f, -0.12464479f, -0.11434694f, -0.06316427f, -0.08049651f, -0.01929661f, -0.09444119f, 
    0.04422215f, -0.02622820f, -0.08769222f, -0.12216634f, 0.06726409f, 0.07261828f, 0.03372145f, 0.06610930f, 
    -0.04540316f, 0.10986470f, -0.09687837f, 0.01819940f, -0.08859953f, 0.01263559f, -0.06686883f, 0.05116157f, 
    0.15668619f, 0.20361166f, 0.03688476f, -0.04001410f, -0.02463643f, 0.17148551f, 0.00891646f, 0.42213970f, 
    0.60403377f, -0.05357303f, 0.09602454f, -0.17928118f, 0.08015317f, 0.19170307f, -0.22866727f, 0.08060288f, 
    0.08174638f, 0.07655151f, 0.19997044f, -0.21104756f, -0.01434240f, 0.03747227f, 0.19537915f, 0.07135618f, 
    0.03741600f, 0.21935068f, 0.28313187f, 0.14553753f, 0.14071400f, -0.13575467f, 0.30423412f, 0.39985731f, 
    -0.09547520f, -0.16071074f, 0.02808090f, -0.08437987f, 0.15938847f, -0.10854436f, 0.11443190f, -0.12220046f, 
    -0.05928138f, 0.27659154f, -0.08430131f, 0.12919125f, -0.20182304f, 0.23347057f, -0.01134331f, 0.23833582f, 
    0.11755100f, 0.40037370f, 0.33797395f, 0.19138221f, 0.19805944f, 0.07805514f, -0.13875014f, -0.07048470f, 
    -0.13309677f, 0.25134978f, -0.27503979f, 0.00008353f, 0.21263038f, -0.04166114f, 0.10558143f, -0.11087114f, 
    -0.33957356f, 0.32436934f, -0.75522482f, 0.03982297f, -0.12494673f, 0.08970863f, -0.46669599f, 0.37429938f, 
    0.58949345f, 0.10191756f, 0.02747579f, 0.13051549f, -0.09545548f, 0.34329629f, -0.31523719f, 0.05340301f, 
    -0.02708571f, 0.09920954f, 0.02237651f, -0.10728259f, -0.20941244f, 0.01580741f, 0.10579912f, -0.16393073f, 
    0.27176306f, 0.04676503f, 0.72591645f, 0.14570256f, -0.01959612f, -0.10299145f, -0.03726364f, -0.03742430f, 
    0.44765028f, 0.06803675f, 0.00096508f, 0.17616183f, 0.14687601f, -0.06222654f, 0.26749632f, 0.16315487f, 
    -0.13906650f, 0.36616138f, -0.10283671f, -0.00686141f, -0.07888842f, 0.01422301f, -0.14430766f, 0.09397907f, 
    0.20685996f, 0.37026590f, 0.19170244f, 0.06336176f, -0.01492027f, 0.15032680f, 0.10489044f, 0.06709588f, 
    0.11749573f, -0.16431364f, 0.21917848f, 0.65015715f, 0.13233744f, -0.14172424f, -0.11971627f, 0.06449101f, 
    0.06913674f, 0.28063604f, 0.02403974f, -0.26408038f, 0.12217362f, -0.00445347f, -0.30891356f, -0.16048647f, 
    0.30922812f, -0.05566148f, -0.03264750f, 0.20786510f, 0.01655852f, -0.03079175f, 0.16398479f, 0.32168028f, 
    -0.35904428f, 0.24899502f, 0.14387092f, -0.14953582f, 0.32883984f, 0.07948760f, -0.14317630f, 0.20083734f, 
    0.26943412f, 0.28510320f, -0.28044704f, -0.19306140f, 0.16118601f, -0.00257802f, -0.09139045f, -0.00614077f, 
    -0.07760733f, 0.19304712f, 0.25068259f, 0.35206434f, 0.07953125f, 0.01658743f, -0.18455912f, -0.26653641f, 
    -0.02412930f, 0.12798660f, -0.04238910f, -0.33609012f, -0.39983544f, 0.21670456f, 0.48415050f, -0.18483220f, 
    -0.25961915f, 0.06613307f, -0.16529456f, 0.00100861f, 0.37658072f, 0.17269592f, 0.30254158f, 0.09144585f, 
    0.32060331f, -0.01116970f, 0.01716039f, 0.30243629f, 0.21900877f, -0.03703836f, -0.05093509f, 0.01047074f, 
    0.08944373f, 0.03822729f, -0.50055385f, -0.13722834f, -0.07289332f, 0.88306063f, 0.14130180f, -0.09222621f, 
    0.44631454f, 0.14969142f, -0.00643980f, 0.05886948f, 0.08833132f, -0.03578104f, 0.37886000f, 0.26045015f, 
    -0.29451898f, 0.06706690f, 0.02754674f, 0.11896958f, 0.19429632f, 0.10068721f, -0.30013263f, 0.32844606f, 
    -0.04702187f, 0.28729758f, -0.13500710f, -0.36828795f, 0.08731728f, -0.17678937f, 0.20078030f, 0.22496739f, 
    -0.05649660f, 0.10776908f, 0.20601514f, 0.25249982f, -0.12751235f, 0.26850760f, 0.13491139f, -0.25452861f, 
    0.00681309f, -0.05711078f, 0.19775289f, 0.16783752f, -0.11397208f, 0.07628330f, 0.03117568f, -0.09151936f, 
    -0.03611090f, -0.09019133f, 0.16102901f, -0.13958251f, 0.30156717f, -0.18428926f, 0.20362580f, 0.08279769f, 
    0.39681786f, 0.22893253f, 0.13579352f, -0.22199598f, 0.00798745f, 0.24577452f, -0.01589913f, -0.09166675f, 
    0.05661450f, 0.33889011f, 0.44827402f, 0.09865870f, -0.07917297f, -0.02931548f, -0.15106639f, 0.02408786f, 
    0.08578309f, 0.16259070f, 0.00092194f, 0.01325901f, -0.02194063f, -0.03564443f, -0.00041143f, 0.14496045f, 
    0.38200051f, 0.28450301f, 0.25253406f, 0.36000916f, -0.47126323f, -0.03905012f, 0.49365771f, -0.17236783f, 
    -0.40533552f, -0.04002833f, 0.10767137f, 0.02505459f, -0.15194431f, 0.07249682f, 0.18249743f, -0.36580688f, 
    -0.12182692f, -0.22744201f, 0.00901433f, 0.16441937f, 0.32265148f, -0.03868717f, -0.27244559f, 0.19567515f, 
    0.01703194f, -0.49922413f, -0.14728372f, 0.16794102f, 0.09518608f, -0.46078306f, -0.09207044f, -0.34089804f, 
    0.42130369f, 0.58095300f, 0.30159840f, 0.11695033f, -0.09408618f, 0.17943448f, -0.17770015f, -0.12022115f, 
    0.05886890f, -0.15137345f, 0.21897523f, 0.03137923f, 0.07536807f, -0.15647107f, 0.06120406f, 0.12185556f, 
    0.00844476f, 0.32432470f, -0.13711469f, -0.19391842f, 0.00610067f, -0.41629684f, -0.33928242f, -0.03555271f, 
    -0.31026530f, 0.15563832f, 0.05144648f, 0.43889773f, -0.04984114f, 0.04133185f, 0.24453342f, 0.29228875f, 
    -0.08631010f, 0.27215147f, 0.00702146f, 0.07778787f, 0.19286299f, 0.06316330f, 0.00737134f, 0.09797630f, 
    0.42901197f, 0.23130663f, -0.07295903f, -0.18851995f, -0.04028221f, 0.09838731f, -0.16667640f, -0.13249309f, 
    0.10202256f, 0.37205529f, 0.25026205f, 0.24076803f, 0.00734135f, -0.01367345f, -0.19911103f, 0.17915724f, 
    -0.18719687f, -0.11373467f, 0.12266408f, -0.37808153f, 0.17258415f, 0.00324183f, 0.45470828f, 0.12810823f, 
    -0.24271116f, -0.15044965f, 0.08726831f, 0.02273111f, 0.20943817f, -0.01770686f, -0.19733451f, 0.04408830f, 
    0.02782381f, -0.42647213f, 0.08813377f, 0.06707484f, 0.06016284f, -0.02927314f, -0.00175422f, 0.08380254f, 
    -0.23221108f, 0.21635145f, 0.42112866f, 0.04931259f, 0.05902934f, -0.03954783f, -0.02571092f, 0.19856705f, 
    -0.31245035f, -0.11270418f, -0.10171539f, -0.01663650f, 0.06997088f, 0.28218713f, -0.15507367f, -0.27982444f, 
    -0.30955556f, 0.00554137f, -0.18778947f, -0.03975153f, -0.09662154f, 0.21711329f, 0.06919203f, -0.03850397f, 
    0.15382946f, 0.12466212f, 0.84133589f, -0.02553437f, 0.08039811f, 0.07264803f, -0.15534854f, -0.15959947f, 
    0.37504312f, 0.27745485f, -0.00438654f, 0.21739683f, 0.11676303f, -0.28572333f, 0.11422886f, 0.46127474f, 
    0.02554176f, 0.28148016f, 0.07521810f, -0.37938145f, 0.03503121f, 0.16569445f, 0.07264869f, -0.00974614f, 
    0.04052198f, 0.10793877f, 0.10109863f, -0.10077594f, 0.33514535f, 0.23973759f, -0.05340704f, 0.02826251f, 
    -0.10920717f, -0.33338085f, 0.12200428f, 0.00600307f, 0.29384053f, -0.06254864f, 0.00454507f, 0.01405726f, 
    0.14434803f, -0.06170483f, -0.07880615f, -0.12626813f, 0.06066743f, 0.06002165f, -0.41931438f, 0.25605544f, 
    0.60773551f, 0.11054576f, 0.02454272f, -0.03208634f, -0.00832611f, 0.03930657f, 0.24405645f, -0.32123923f, 
    -0.91732091f, -0.01459963f, 0.34092560f, -0.35569191f, -0.02779151f, 0.20708369f, -0.02126464f, 0.05167966f, 
    0.65544945f, 0.11908005f, -0.34783047f, -0.23549721f, 0.16186908f, -0.36536899f, 0.11857785f, -0.39499187f, 
    0.09522419f, -0.25312698f, -0.11004595f, 0.03309783f, -0.36200517f, 0.17790943f, -0.10699650f, 0.14720528f, 
    -0.14067110f, 0.39616007f, 0.33753422f, -0.16789009f, 0.14894840f, 0.02611024f, 0.08676584f, -0.15132256f, 
    -0.01613348f, -0.25995466f, 0.17517172f, -0.14281578f, 0.24238282f, -0.00046052f, -0.14596972f, 0.07626319f, 
    0.02539036f, -0.08244038f, 0.17355220f, 0.31862926f, -0.25809973f, 0.22404455f, -0.03122704f, -0.07760739f, 
    0.07552779f, 0.06796749f, 0.09715906f, -0.14007686f, -0.05034037f, 0.06352390f, 0.01097334f, -0.01197457f, 
    -0.09175650f, -0.09860718f, -0.10106523f, -0.02992041f, 0.00989576f, 0.05654535f, -0.05668646f, 0.04556588f, 
    -0.04212710f, -0.09615887f, 0.04574749f, 0.03936802f, 0.01695306f, 0.05359434f, -0.08213257f, -0.12966886f, 
    -0.07789195f, 0.00374959f, 0.10653961f, -0.16589294f, 0.03403272f, -0.08078334f, -0.11140678f, -0.12230179f, 
    0.01132906f, -0.13346647f, -0.12083622f, -0.05203447f, 0.02284011f, -0.09349766f, 0.11137890f, 0.00326902f, 
    -0.02911204f, 0.08641581f, 0.02214141f, -0.03756626f, 0.02570187f, -0.12880954f, 0.01130366f, 0.02754653f, 
    0.01605940f, 0.09332805f, -0.06653829f, 0.04940902f, -0.01388199f, -0.10081110f, 0.11742759f, 0.04335080f, 
    0.05223949f, 0.00441532f, 0.08262289f, -0.07405674f, -0.00348348f, -0.13115464f, 0.06302685f, 0.04313228f, 
    -0.01004703f, 0.06093773f, -0.08986060f, 0.02623963f, 0.01418208f, -0.03553931f, -0.08301128f, 0.11607417f, 
    -0.03646666f, 0.05745411f, 0.12128338f, -0.00539117f, 0.09052321f, -0.04473627f, 0.00307938f, -0.06170401f, 
    -0.05938953f, 0.08136822f, -0.00937848f, 0.03156331f, 0.06672293f, 0.08650832f, -0.08908215f, -0.02507320f, 
    -0.05279891f, 0.02785270f, 0.00794883f, 0.01252094f, 0.03251021f, 0.09255597f, 0.02503490f, -0.02404493f, 
    -0.07906498f, -0.10305527f, -0.01595792f, 0.04457280f, -0.05260672f, -0.11019534f, -0.07984857f, -0.02200930f, 
    -0.08856356f, -0.04064178f, -0.04965653f, -0.05452049f, 0.07004526f, -0.04847652f, -0.04545815f, -0.09752877f, 
    -0.04057118f, -0.03238264f, -0.04001476f, 0.04749037f, -0.10392642f, -0.05314957f, 0.00750315f, -0.05422510f, 
    -0.01744440f, 0.00585504f, 0.09599705f, -0.09270424f, 0.08353959f, -0.05898803f, 0.00870393f, 0.05283588f, 
    0.22149800f, -0.00547201f, 0.04763272f, -0.35525164f, -0.07022513f, -0.55327016f, 0.12163252f, -0.30296940f, 
    -0.09907174f, 0.40235913f, -0.02557528f, 0.33314753f, 0.07158431f, 0.08108046f, 0.36232507f, -0.25834954f, 
    0.21594582f, 0.15946838f, 0.21709885f, 0.11206274f, 0.04517919f, -0.30784646f, 0.07006504f, 0.19201694f, 
    0.22362283f, 0.19659097f, -0.29826885f, -0.31920770f, 0.24563730f, -0.25586417f, -0.21918218f, 0.13357425f, 
    -0.28431627f, 0.15780860f, 0.30081767f, 0.13212955f, 0.12573470f, 0.29139873f, -0.13561970f, -0.03309152f, 
    0.05479464f, -0.14847638f, 0.18870088f, 0.05357959f, -0.07869504f, 0.16717094f, 0.21460980f, -0.14047754f, 
    0.01472839f, -0.47483459f, -0.22053030f, 0.00300793f, 0.14798334f, -0.09478826f, 0.01979473f, 0.06618363f, 
    0.20876200f, 0.14073423f, 0.51749575f, 0.02586039f, -0.16285644f, 0.02570493f, 0.07970654f, -0.07661639f, 
    0.29008767f, 0.11402120f, 0.03265090f, -0.01319870f, -0.11629307f, 0.07178523f, 0.19134404f, -0.47157785f, 
    -0.46701658f, 0.00335074f, 0.02011697f, 0.16683044f, 0.03508918f, -0.00245784f, 0.12495134f, 0.22774222f, 
    -0.03098558f, 0.03867175f, 0.05310494f, 0.09847712f, 0.16562679f, 0.23347129f, 0.14950778f, -0.15671508f, 
    -0.30220118f, 0.19098566f, -0.33038551f, -0.41477835f, 0.03853225f, 0.32771879f, 0.03323336f, 0.14688236f, 
    -0.12669249f, -0.02958319f, 0.28309000f, -0.04441226f, 0.37150103f, 0.05009984f, 0.00752777f, -0.62097353f, 
    -0.07058361f, -0.01587264f, -0.24677573f, 0.41336057f, -0.30628115f, 0.02394895f, 0.21920064f, 0.21185812f, 
    -0.04275786f, -0.03396729f, 0.14043044f, -0.07741108f, 0.07440758f, 0.08363363f, 0.25491491f, 0.08769600f, 
    0.10053632f, -0.03320466f, 0.34071711f, -0.06724744f, -0.01679857f, 0.15353255f, 0.05664200f, 0.09871446f, 
    0.12835155f, 0.31580353f, 0.16152883f, -0.24536252f, -0.04916386f, -0.19236147f, -0.08693668f, 0.04796334f, 
    -0.14815128f, 0.08641888f, -0.08427711f, 0.19106714f, 0.09484673f, 0.19523463f, 0.06180134f, 0.15058315f, 
    0.02376176f, 0.28505665f, 0.42531767f, 0.09154134f, -0.12270358f, -0.27633315f, 0.34241050f, 0.06261178f, 
    0.44917905f, 0.08113188f, -0.33675364f, 0.36122227f, -0.03628239f, 0.15645827f, 0.09715965f, -0.35863963f, 
    0.06590837f, 0.18773678f, 0.11625116f, 0.08386201f, 0.12612554f, -0.08709174f, -0.34923434f, 0.31719878f, 
    0.05090470f, -0.12622996f, -0.03148319f, -0.04879953f, 0.12628490f, -0.03506315f, 0.45251954f, -0.24977875f, 
    -0.03197084f, 0.22774944f, 0.20884098f, -0.04656152f, 0.23241748f, 0.05598089f, -0.19992971f, 0.12019569f, 
    -0.05202946f, -0.17792261f, 0.16028020f, 0.09287373f, 0.07002060f, -0.05527739f, 0.07909700f, 0.01388432f, 
    0.09164124f, 0.08212548f, -0.12583630f, -0.07568279f, 0.12388365f, -0.08971585f, 0.10190913f, 0.10087072f, 
    0.03898873f, -0.08288898f, -0.09657696f, 0.09290226f, -0.03665579f, -0.05508811f, 0.00551450f, -0.05365364f, 
    0.02222853f, 0.06937967f, -0.07604747f, -0.11682883f, -0.12386355f, -0.06220856f, 0.01119899f, 0.01085569f, 
    0.05555537f, -0.14507525f, -0.07567042f, -0.04879840f, -0.02250536f, -0.03982984f, 0.01426604f, -0.10960146f, 
    -0.05649071f, 0.01352993f, -0.05982208f, 0.11222572f, 0.10376120f, -0.00456965f, -0.11428589f, 0.02697018f, 
    -0.10838754f, 0.02879701f, -0.00104371f, 0.00289026f, -0.10619821f, 0.00798906f, -0.00040127f, 0.02304914f, 
    -0.12142349f, -0.06954994f, -0.09669683f, -0.06956606f, -0.10244481f, -0.06119478f, -0.04512966f, -0.10448977f, 
    0.05417531f, -0.04930243f, -0.11613135f, 0.09379417f, 0.01024417f, -0.07194018f, 0.06799722f, 0.00882724f, 
    0.31927368f, 0.24115197f, -0.02001476f, 0.24206814f, -0.11957434f, -0.50017732f, -0.07890184f, -0.15975828f, 
    -0.54144531f, 0.43458748f, 0.00962245f, 0.05311410f, 0.02147976f, -0.01911695f, 0.09825445f, 0.13921465f, 
    0.33312443f, 0.11560088f, 0.40290397f, 0.32898220f, 0.09355307f, 0.07666449f, 0.27373287f, 0.19715346f, 
    0.12970208f, -0.10395277f, -0.45496234f, -0.07665972f, 0.02262564f, -0.01256914f, -0.00063776f, -0.46964788f, 
    -0.09782948f, 0.09487912f, 0.28387219f, 0.14085226f, -0.08643103f, 0.11278787f, -0.15162608f, 0.22877397f, 
    0.17237455f, -0.16802788f, 0.12894699f, 0.16061044f, 0.17575097f, -0.24406227f, 0.01842933f, 0.03982143f, 
    0.28781629f, -0.04490584f, 0.22527401f, -0.14616048f, -0.02921614f, -0.10015361f, -0.01440045f, -0.05414546f, 
    0.20548710f, -0.32063770f, 0.31550494f, 0.06788515f, 0.05473752f, 0.24200679f, -0.10359309f, 0.08815945f, 
    -0.21788500f, 0.05483508f, 0.41820756f, 0.07367441f, 0.04914521f, -0.36243898f, 0.20235555f, 0.31511068f, 
    -0.73088413f, -0.28268978f, -0.11443119f, -0.30672309f, -0.01196464f, -0.00732586f, 0.17463447f, -0.02633669f, 
    -0.18500921f, 0.02668691f, -0.16610166f, 0.01714526f, -0.07158661f, 0.40365621f, -0.25164500f, -0.13913994f, 
    0.01122950f, 0.15725964f, 0.52062553f, 0.12074462f, 0.30753273f, -0.00732146f, -0.02639997f, 0.37380254f, 
    0.05644103f, -0.01306313f, -0.16598217f, -0.25384924f, 0.07752613f, -0.14006212f, 0.34906253f, -0.28869066f, 
    -0.12404688f, 0.16816472f, -0.29230803f, 0.04376429f, -0.35953206f, 0.08797718f, -0.46233043f, 0.34592077f, 
    0.01701513f, 0.21786982f, 0.05021822f, -0.09253333f, 0.18243179f, 0.01765450f, 0.15275070f, -0.08062290f, 
    -0.20797130f, 0.18501003f, 0.36189198f, -0.03968879f, 0.15299565f, -0.30389640f, -0.00805638f, -0.10441765f, 
    -0.11603962f, -0.12783931f, 0.10292669f, -0.03130151f, 0.06678845f, -0.08131646f, -0.12153851f, -0.12480430f, 
    0.05394430f, 0.03669756f, 0.08459204f, 0.09900262f, 0.07768535f, -0.00131457f, 0.00635312f, -0.10681508f, 
    -0.05148072f, 0.01910232f, -0.12995736f, -0.03833686f, 0.04722358f, -0.11550532f, -0.00958792f, -0.12862012f, 
    0.05595708f, 0.04153275f, 0.10016211f, -0.08181415f, 0.00458132f, -0.09072103f, -0.03784365f, -0.07883734f, 
    -0.05489882f, -0.04878081f, -0.01147660f, 0.08335856f, 0.02778902f, -0.03106621f, -0.06503815f, -0.04680699f, 
    0.09551284f, -0.06184142f, -0.01191244f, -0.13497242f, -0.03241684f, -0.10044292f, -0.05226475f, 0.04932136f, 
    0.06052026f, -0.12235272f, 0.08803487f, 0.10982153f, -0.11624819f, -0.09419452f, 0.10719131f, 0.02996540f, 
    0.05119768f, 0.03754588f, 0.10569096f, -0.03979883f, 0.03417811f, 0.01384135f, 0.04159476f, -0.07184075f, 
    0.20677693f, -0.02053513f, -0.16458844f, 0.05603365f, 0.04909609f, 0.25330219f, 0.23532532f, -0.50037622f, 
    -0.11028915f, 0.01555896f, 0.03334504f, 0.10382096f, 0.10584123f, 0.15574469f, 0.37571749f, -0.00919919f, 
    -0.19174992f, -0.09914384f, 0.03259562f, 0.22798447f, 0.00152669f, 0.02037420f, 0.12402302f, -0.12122644f, 
    -0.47618413f, 0.14283338f, 0.23953937f, -0.57516515f, -0.04988822f, -0.01346522f, 0.30494612f, 0.46471235f, 
    -0.22947033f, 0.09533934f, 0.18747114f, 0.05864664f, 0.25518095f, 0.15189640f, 0.07474903f, -0.12032589f, 
    0.16266085f, -0.53018034f, -0.03178344f, 0.39874431f, -0.03285880f, 0.16999507f, 0.07471758f, -0.01444103f, 
    0.15018809f, -0.02810705f, 0.11938440f, 0.03332636f, 0.13786148f, 0.03419443f, -0.05935908f, 0.10895039f, 
    0.06993202f, 0.06766216f, 0.13674626f, -0.59689558f, -0.06757433f, 0.02617013f, -0.07345975f, 0.05844625f, 
    -0.07547304f, 0.04017816f, 0.08531518f, -0.06618609f, 0.08722411f, -0.10251660f, -0.00150820f, 0.03343587f, 
    -0.12185764f, -0.00618416f, -0.06290665f, 0.00063068f, 0.09808724f, -0.10005825f, 0.07549890f, -0.00136002f, 
    0.04911497f, -0.15883283f, 0.05800665f, 0.00935363f, -0.06693307f, 0.00038931f, 0.07949208f, -0.06289143f, 
    0.05307936f, 0.03577855f, -0.12114096f, 0.01838589f, 0.00563928f, -0.07790030f, -0.00545634f, -0.10877052f, 
    -0.00379596f, -0.13630727f, 0.07296138f, 0.03361024f, -0.13755591f, -0.01126721f, -0.00771188f, 0.02411144f, 
    -0.10374552f, -0.02092363f, 0.00359524f, 0.01029638f, -0.06033025f, 0.07102499f, -0.04292579f, -0.12864453f, 
    -0.06663989f, -0.00617602f, -0.08119241f, 0.03139554f, -0.04119995f, -0.08181089f, -0.01057485f, 0.00716291f, 
    -0.06497314f, 0.08395898f, -0.13803482f, -0.12026329f, 0.03979787f, -0.12807906f, 0.11824010f, -0.03526868f, 
    -0.19970152f, 0.22019584f, 0.19561261f, -0.38791773f, 0.04056405f, -0.22753070f, -0.35372561f, 0.19365217f, 
    0.05372379f, -0.16397645f, -0.02573954f, 0.19206588f, -0.07719818f, 0.18047489f, -0.09916091f, 0.25681251f, 
    -0.24945422f, 0.36432764f, 0.20347925f, 0.01163748f, 0.07041671f, 0.16690043f, 0.06395249f, -0.20273638f, 
    0.22978726f, 0.22651842f, 0.49492520f, 0.28479677f, -0.08347753f, 0.38392836f, 0.07960594f, -0.22083141f, 
    0.19008245f, 0.14006095f, 0.14202955f, 0.08950626f, 0.09985438f, -0.23574322f, -0.06393136f, 0.02288197f, 
    0.01133931f, 0.53168863f, -0.02901491f, -0.20287691f, -0.08340476f, -0.26335868f, 0.28289032f, 0.11443961f, 
    -0.04956513f, 0.30164015f, 0.18149334f, 0.01089511f, 0.17460220f, 0.10048485f, -0.25305423f, 0.11179201f, 
    -0.11904119f, -0.20075390f, -0.05560537f, 0.53329182f, 0.11789293f, -0.04810660f, 0.05501021f, -0.04309152f, 
    0.08589483f, -0.20203507f, -0.24285363f, 0.11948360f, 0.04520541f, 0.28275356f, -0.29030183f, 0.19091477f, 
    0.41908780f, 0.08109431f, -0.00888090f, -0.18602531f, -0.03863790f, -0.22094961f, 0.13506542f, -0.22400936f, 
    -0.31770423f, 0.03048379f, 0.31724358f, -0.05807966f, 0.04888836f, 0.43345323f, -0.16253349f, 0.45357472f, 
    0.39818785f, 0.05183646f, -0.93666285f, -0.14823382f, 0.28616151f, -0.13892964f, 0.06898075f, -0.36542836f, 
    0.26869717f, -0.31666818f, 0.00088405f, 0.18210173f, -0.24804297f, 0.47253701f, 0.32564333f, -0.14946143f, 
    0.29524788f, 0.40753213f, 0.17681709f, 0.07263108f, 0.36701337f, -0.29254317f, -0.10904305f, -0.01747248f, 
    0.27892724f, -0.11460037f, 0.06432605f, -0.06657203f, -0.07234782f, -0.06318373f, 0.19855422f, 0.00867970f, 
    0.18557622f, -0.01929265f, 0.23117255f, 0.28345323f, -0.24532716f, 0.18330944f, -0.15473285f, 0.06787884f, 
    0.18746299f, -0.03420705f, -0.04624534f, 0.02027823f, 0.03629166f, -0.36300731f, -0.10757397f, 0.03300410f, 
    0.14230517f, 0.33606350f, 0.01980638f, 0.11716263f, -0.04475952f, -0.08796027f, 0.14327623f, -0.22647478f, 
    0.11323498f, -0.04437240f, -0.03413925f, 0.14665844f, -0.09469479f, -0.16696866f, 0.07057247f, 0.32409358f, 
    0.21905895f, -0.08592740f, -0.08910945f, 0.23368382f, 0.02677936f, 0.02021882f, -0.21378434f, -0.30059868f, 
    0.02114521f, 0.14021660f, 0.14524777f, 0.22367647f, 0.04826608f, 0.16104297f, -0.16095042f, 0.49191147f, 
    0.16239916f, -0.01192511f, 0.20190553f, -0.00015569f, 0.37661496f, 0.10101409f, 0.15541817f, -0.39581594f, 
    0.06074571f, -0.12213466f, -0.21479209f, -0.06901571f, 0.06255656f, -0.10273729f, 0.20173357f, 0.04153131f, 
    0.05475769f, -0.12638706f, 0.45968434f, 0.28644285f, -0.22929186f, 0.21417688f, -0.11759708f, 0.05965647f, 
    -0.06566330f, -0.02008503f, 0.09353595f, -0.09162737f, -0.01852746f, -0.06316178f, 0.00012298f, -0.12590557f, 
    -0.06504585f, 0.04967085f, -0.06697992f, 0.06472345f, 0.02557700f, 0.03195762f, 0.09376356f, 0.07208895f, 
    -0.06516718f, -0.07065791f, -0.00367606f, -0.14034039f, -0.09836422f, 0.10289844f, -0.00183342f, 0.03221784f, 
    0.02476414f, -0.00259798f, -0.05109787f, -0.14148431f, -0.01492106f, -0.07017780f, 0.09203470f, -0.07014994f, 
    -0.09482618f, -0.01337803f, -0.02718489f, -0.07189524f, 0.05164609f, -0.13378544f, -0.01096572f, -0.08259675f, 
    0.12853107f, 0.01215074f, -0.02076942f, -0.09936400f, -0.00585745f, -0.09212233f, 0.09001059f, -0.11851637f, 
    -0.07450999f, -0.04515274f, 0.04648972f, -0.00250363f, -0.02352506f, -0.04801838f, 0.06740634f, -0.09626697f, 
    0.01289950f, 0.06389420f, 0.08275750f, -0.11025272f, -0.11230542f, -0.10178109f, 0.03751503f, -0.03274206f, 
    0.08583543f, -0.13734980f, 0.01783315f, 0.26902303f, -0.04781768f, -0.05871778f, 0.29212904f, -0.43652624f, 
    -0.37317950f, 0.04880125f, -0.01265631f, 0.34045404f, 0.11142874f, 0.32068160f, 0.25215283f, -0.21338837f, 
    -0.26371536f, -0.36215550f, -0.46880105f, -0.01958877f, 0.14887562f, -0.28592837f, 0.08658505f, -0.35116518f, 
    -0.24632967f, -0.13993706f, -0.43102226f, -0.56341165f, -0.23875724f, 0.36645901f, -0.13722219f, 0.42710665f, 
    0.01961646f, 0.23169939f, 0.08458507f, -0.13570002f, 0.24417676f, -0.27517223f, 0.19616944f, 0.01736406f, 
    -0.00739327f, -0.29455268f, 0.18558662f, 0.05009209f, 0.17405324f, 0.14487280f, -0.06028084f, 0.29201573f, 
    -0.24390069f, -0.52585280f, -0.21324338f, 0.03082567f, -0.08760156f, 0.03820137f, 0.21862103f, 0.10167913f, 
    -0.06685547f, 0.23708442f, -0.10174961f, -0.14410901f, 0.09584206f, 0.21425419f, 0.08907867f, -0.10229323f, 
    -0.06431940f, 0.07844761f, 0.19115894f, -0.05752864f, 0.04704872f, 0.27872217f, -0.01038059f, -0.06833121f, 
    0.25984696f, -0.17729171f, -0.09781721f, -0.19702522f, 0.01594271f, 0.07549237f, -0.18349265f, 0.27603841f, 
    0.09862372f, -0.25793478f, -0.04103458f, -0.10521306f, -0.08111523f, 0.16702881f, 0.13527717f, -0.28024539f, 
    -0.29885134f, 0.00685232f, -0.17022365f, -0.00118679f, 0.04290781f, 0.13941409f, 0.16597126f, -0.15182319f, 
    -0.21359029f, -0.00179853f, -0.06769323f, 0.08965151f, 0.11937881f, -0.02140730f, 0.11036179f, -0.22445607f, 
    -0.06443162f, -0.20732808f, -0.07457145f, 0.04916711f, -0.12058824f, -0.12216017f, -0.25054717f, -0.03067609f, 
    -0.12018986f, 0.05133645f, -0.06436412f, -0.10087492f, -0.08556063f, 0.20957634f, -0.08359868f, 0.03654861f, 
    0.20601888f, -0.06541397f, -0.32575572f, -0.32153660f, -0.01391490f, 0.14935197f, 0.02264005f, -0.07326731f, 
    0.48319358f, 0.26090133f, -0.43009278f, -0.08813492f, -0.02256228f, -0.03325817f, 0.21733119f, 0.09038080f, 
    0.35572323f, 0.33791360f, 0.01122000f, -0.26679656f, 0.07638979f, 0.01046705f, 0.21220584f, 0.05101814f, 
    0.45122409f, -0.00757301f, 0.58814871f, -0.18999550f, -0.05026972f, 0.18838090f, 0.27389905f, 0.33629665f, 
    -0.08078269f, 0.24014640f, -0.41398576f, -0.08870815f, 0.57791913f, -0.28635797f, 0.48722404f, 0.37667647f, 
    -0.26235515f, -0.03029286f, 0.08049528f, 0.11109732f, -0.05590959f, 0.38986254f, 0.05704538f, -0.19889949f, 
    -0.01738434f, -0.18715158f, 0.05310614f, 0.44982597f, 0.13924725f, 0.04965223f, -0.09076563f, -0.13418114f, 
    0.45847741f, 0.18472692f, 0.18497679f, 0.05896183f, 0.28971735f, 0.04545933f, 0.29756662f, 0.03379162f, 
    0.08733952f, 0.50029480f, 0.37948459f, -0.24831547f, 0.01652556f, 0.08531371f, -0.01638822f, 0.09599897f, 
    -0.07804300f, -0.10087369f, -0.07002977f, 0.07105954f, -0.03597246f, -0.06875792f, 0.10312703f, 0.03966848f, 
    -0.01861621f, 0.05654047f, -0.04438194f, 0.07652248f, -0.05570171f, 0.02696741f, -0.16840191f, -0.08853004f, 
    0.03683613f, -0.07758974f, 0.02582406f, 0.01005008f, 0.03128064f, 0.08751979f, 0.07239269f, -0.00908948f, 
    -0.04926615f, -0.11137087f, -0.00793021f, -0.17901884f, 0.00417858f, -0.01900626f, -0.11251858f, 0.08491933f, 
    -0.15358119f, -0.14201342f, 0.04843067f, -0.10006334f, 0.06702556f, -0.07866654f, -0.01425498f, 0.05080537f, 
    -0.04728317f, -0.03212465f, -0.01600956f, -0.12891155f, -0.01408778f, -0.04289983f, 0.06590267f, 0.02726000f, 
    -0.12202617f, 0.02335938f, -0.03741881f, 0.10786489f, -0.14603721f, 0.09349639f, 0.07915799f, 0.12142344f, 
    -0.05262794f, -0.12182244f, -0.13213827f, -0.11071419f, -0.13874102f, -0.02451555f, -0.09933877f, 0.05377882f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.21639825f, 0.15130951f, 0.04587624f, -0.16274576f, 0.05534001f, 0.14812909f, -0.01332553f, 0.20805812f, 
    0.21082354f, -0.05788642f, -0.04560094f, 0.09464833f, 0.03370652f, 0.22598857f, -0.09670416f, 0.40959871f, 
    0.18649706f, -0.06319815f, 0.18583038f, 0.11072705f, -0.17088753f, -0.03501026f, 0.34306228f, 0.08235233f, 
    0.02098618f, -0.13617477f, -0.13666505f, 0.09459524f, 0.08095521f, -0.06217352f, -0.14740479f, -0.27796528f, 
    -0.09227780f, 0.19454417f, -0.42351368f, 0.12125035f, -0.11719684f, -0.10393600f, -0.04086348f, 0.34044352f, 
    0.24234045f, 0.15216607f, 0.32094678f, 0.25903720f, 0.00899578f, -0.07878394f, -0.10253057f, 0.18770954f, 
    0.08509029f, 0.28584802f, 0.02608036f, 0.21450497f, -0.36411503f, -0.11794445f, 0.07355352f, -0.03650078f, 
    -0.00285140f, 0.03524106f, 0.08291040f, 0.06875657f, 0.18259817f, -0.04642283f, 0.14751042f, 0.08414947f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    0.05693654f, -0.35670310f, 0.06728689f, 0.34918490f, -0.17097004f, -1.06495380f, -0.50793070f, 0.16176231f, 
    -0.04505089f, 0.07913934f, 0.23139220f, -0.19433123f, -0.03045623f, 0.07925231f, -0.09002364f, 0.09501313f, 
    0.03567733f, 0.08225249f, 0.25024590f, -0.04995762f, 0.28622860f, 0.09430040f, 0.29156524f, 0.08140723f, 
    0.09528387f, -0.07945972f, 0.08654376f, -0.15157343f, 0.03813796f, 0.08385188f, -0.52944362f, -0.03224428f, 
    0.52513921f, -0.02598600f, -0.75940698f, -0.02945728f, -0.01926446f, 0.31029460f, 0.15013403f, 0.10062108f, 
    -0.00373269f, -0.39640129f, -0.11126903f, -0.35795560f, 0.24645182f, -0.07538766f, -0.02473524f, -0.15280604f, 
    -0.20236595f, 0.08309221f, 0.05655047f, -0.18457918f, -0.88027000f, -0.02681095f, -0.22351752f, 0.08173169f, 
    -0.03707355f, 0.16651593f, -0.06321314f, -0.06110341f, -0.65398169f, 0.06277532f, 0.07616112f, -0.07586887f, 
    -0.11422285f, -0.19361885f, 0.22746150f, 0.14055857f, 0.17984992f, -0.14833196f, 0.31697831f, -0.09814111f, 
    0.01954840f, 0.05395839f, -0.47748509f, -0.83887577f, -0.04523319f, 0.24045272f, -0.07650882f, 0.07552175f, 
    -0.06546500f, -0.02929150f, -0.29535940f, -0.06241059f, 0.08882068f, -0.18843733f, 0.13726670f, -0.03271520f, 
    -0.97576588f, 0.03964406f, 0.00286522f, 0.32374409f, -0.02178815f, 0.03485744f, 0.08453650f, -0.14949200f, 
    -0.72964495f, 0.23102483f, 0.38627538f, 0.10382242f, -0.02894650f, 0.02162131f, 0.37332371f, 0.27390575f, 
    0.14651497f, -0.29880911f, 0.02982995f, 0.07470414f, -0.11885909f, 0.05117870f, -0.11254622f, 0.27324137f, 
    0.16425161f, -0.22253035f, 0.03954647f, -0.17814682f, 0.07950881f, 0.08784631f, 0.17673357f, -0.11775565f, 
    -0.12537885f, -0.15407045f, -0.00225602f, 0.06181613f, 0.22788976f, -0.14725511f, 0.03111822f, 0.05541400f, 
    -0.94121027f, -0.01751357f, -0.22382782f, -0.13820316f, 0.31116423f, 0.24809182f, -0.79825604f, -1.16822338f, 
    -0.32385790f, -0.09642126f, -0.05843480f, -0.71651989f, -0.09012580f, 0.11708068f, -0.07382336f, -0.10100392f, 
    0.17773493f, 0.04049468f, -0.40282366f, -0.19662805f, -0.05987212f, -0.41068229f, -0.21999183f, 0.04549709f, 
    -0.09360802f, -0.10074197f, 0.05695261f, -0.09895860f, 0.07505704f, -0.08745401f, 0.12943424f, 0.24069889f, 
    0.64360082f, -0.21289605f, -0.80906379f, -0.90191579f, 0.05703154f, -0.32394013f, -0.44130349f, 0.26919818f, 
    0.24323277f, -0.24788639f, 0.27759352f, -0.68272966f, 0.41730362f, -0.02164488f, 0.06001411f, 0.23580238f, 
    0.00900152f, 0.03336433f, -0.02437282f, 0.18695343f, -0.06837487f, 0.11830610f, 0.08874125f, -0.09429315f, 
    -0.16887097f, 0.17493498f, 0.24236257f, -0.02450011f, -0.49345550f, 0.20899884f, 0.21536054f, 0.05713990f, 
    0.17564842f, 0.09358279f, 0.03337420f, -0.07465112f, -0.63505483f, 0.18925577f, 0.25811866f, 0.13981535f, 
    -0.35798815f, -0.12557611f, 0.27589771f, 0.17213383f, -0.01739386f, -0.30765310f, 0.08632249f, -0.33963907f, 
    -0.04590330f, 0.08908120f, -0.58148801f, -0.12337829f, 0.17926916f, 0.17220391f, -0.12601104f, 0.00352749f, 
    0.05938750f, -0.06704214f, -0.01864452f, 0.08345484f, -0.02523890f, 0.03055687f, 0.34283090f, 0.27521351f, 
    0.37083870f, 0.14261955f, 0.13008711f, -0.34431559f, -0.07434843f, -0.05743300f, 0.11983293f, 0.05870793f, 
    -0.54717189f, 0.16521375f, 0.00728848f, 0.12765759f, 0.14047100f, 0.07643785f, 0.02447419f, -0.69765866f, 
    -0.62860686f, 0.13096604f, 0.08931478f, -0.16587611f, -0.52700573f, 0.09678913f, -0.69859755f, 0.07188432f, 
    0.19275157f, -0.12465925f, 0.01170546f, -0.04463441f, 0.07617303f, -0.41285723f, -0.29938957f, -0.07102335f, 
    0.24318896f, 0.08101666f, -0.45348462f, -0.35218453f, -0.38769412f, -0.17008729f, -0.63671058f, -0.18901812f, 
    0.14954790f, -0.09294085f, 0.08011793f, 0.34504735f, 0.02035600f, -0.08913352f, -0.11338381f, 0.00368058f, 
    0.20097679f, -0.11303437f, 0.05908809f, -0.05516050f, -0.34876138f, 0.15306133f, 0.34658605f, -0.03132899f, 
    0.37041906f, -0.00521223f, 0.04803404f, 0.25472292f, -0.00553341f, 0.06150744f, 0.04350448f, 0.51414907f, 
    0.09792687f, -0.00320191f, -0.09204920f, -0.26701218f, -0.02700288f, 0.00400341f, 0.00491250f, 0.14438003f, 
    -0.16243322f, 0.46325809f, 0.03062626f, -0.06516409f, -0.78804618f, -0.01296241f, 0.00753254f, -0.12087724f, 
    0.00865104f, 0.20508629f, -0.09420060f, 0.09573856f, -0.37223852f, 0.02931231f, 0.04795300f, 0.02630888f, 
    0.00694029f, -0.38283864f, -0.02790542f, -0.12620425f, -0.29457906f, 0.33693904f, -0.04459855f, 0.02276931f, 
    0.13103181f, -0.86749458f, 0.27705789f, -0.04764353f, -0.15756540f, 0.48777869f, 0.26630738f, 0.23710772f, 
    0.26544741f, -0.12177216f, -0.21425532f, 0.32703331f, -0.06204056f, -0.07686982f, -0.15833527f, 0.08896226f, 
    -0.08863417f, -0.06790346f, 0.10564809f, -0.29599363f, 0.01299220f, -0.00775110f, 0.03058459f, 0.08513625f, 
    -0.15066063f, 0.08172308f, -0.06394373f, -0.66881323f, 0.00239218f, -0.01831212f, -0.26892191f, -0.50200427f, 
    -0.39765838f, 0.07689294f, -0.26631528f, 0.36609384f, 0.03855851f, 0.06506570f, -0.43962049f, -0.07011285f, 
    0.19137347f, -0.56034803f, -0.03107213f, 0.14342891f, -0.07635041f, -0.03798700f, 0.01385237f, -0.27911454f, 
    0.14165093f, -0.19015293f, 0.00454648f, -0.12372159f, 0.11661541f, 0.02978880f, 0.27796373f, 0.01606929f, 
    -0.17186505f, -0.20733880f, -0.41244799f, -0.00250893f, 0.30244413f, 0.06020442f, 0.00055099f, -0.08869152f, 
    -0.27511778f, 0.27141795f, -0.15209438f, 0.30700612f, 0.34490919f, -0.54319662f, 0.21698254f, 0.03882787f, 
    -0.18452558f, 0.04798924f, 0.44357589f, 0.06628300f, 0.02516932f, -0.19541919f, -0.02847389f, 0.00302392f, 
    -0.04958860f, 0.11070219f, 0.06268474f, -0.34740812f, -0.29540274f, 0.25451621f, -0.41079551f, -0.06044063f, 
    -0.19781613f, -0.03612111f, -0.00535416f, -0.47182667f, 0.01201202f, -0.08121496f, 0.00865938f, -0.06810407f, 
    -0.25212801f, 0.15388313f, 0.00115330f, -0.21314818f, 0.05722062f, -0.11287715f, -0.73317081f, -0.26028785f, 
    -0.16838314f, -0.02988795f, 0.06832451f, -0.27545902f, -0.43711999f, -0.08166005f, 0.02700220f, 0.18556830f, 
    0.06398567f, 0.13070276f, 0.05320491f, 0.23503920f, -0.43149191f, 0.02665681f, 0.23704292f, 0.05287930f, 
    -0.58156258f, -0.64014179f, -0.05063109f, 0.11103121f, 0.33175349f, -0.02914026f, 0.10722689f, -0.10609484f, 
    0.10700388f, -0.27352625f, -0.03599563f, 0.10757870f, -0.22568603f, 0.01246977f, 0.23209980f, 0.07298888f, 
    0.12638347f, 0.01873912f, -0.29550162f, 0.10715564f, -0.00601739f, -0.37624788f, 0.04975072f, -0.40302512f, 
    -0.65736467f, -0.06871299f, 0.03889520f, 0.14799744f, 0.24050303f, 0.07535446f, -0.26193264f, -0.05945627f, 
    0.17476326f, 0.05807402f, 0.02063237f, -0.42600256f, 0.06256349f, 0.07820198f, 0.08401608f, -0.10757408f, 
    -0.23646122f, -0.00043914f, 0.39811841f, 0.31140432f, -0.03338328f, 0.16674018f, 0.16822371f, -0.59903365f, 
    -0.42618731f, 0.03759534f, -0.70103532f, 0.20644116f, -0.21276876f, -0.00572527f, 0.09793122f, -0.42591247f, 
    -0.62788075f, -0.30679056f, -0.00229075f, -0.82475549f, 0.62088078f, 0.03227068f, -0.16893108f, 0.01058779f, 
    0.10136107f, -0.22884746f, -0.71128243f, 0.08925736f, -0.22344717f, -0.16234046f, -0.24745589f, 0.05068883f, 
    -0.09655526f, 0.43443221f, -0.15629965f, -0.39892924f, -0.12670633f, 0.27849215f, -0.42998269f, -0.08666550f, 
    -0.11866815f, -0.00910219f, -0.38101026f, -0.20944595f, -0.10313813f, 0.12257043f, -0.05882188f, 0.27048534f, 
    0.14201558f, 0.06369869f, 0.10543103f, 0.40790793f, -0.39485487f, -0.45752048f, 0.05385761f, -0.00489360f, 
    -0.14636350f, -0.04823270f, -0.04387092f, -0.13871744f, 0.00629250f, 0.07221224f, -0.41413662f, 0.07250378f, 
    -0.15546329f, -0.55863976f, 0.01905372f, 0.55331129f, -0.01785215f, -0.44351989f, -0.31071272f, -0.53998685f, 
    0.03466110f, -0.42026272f, -0.37407836f, -0.21005915f, -0.16369137f, -0.08218260f, -0.11389065f, -0.19441406f, 
    0.03911712f, -0.74560249f, -0.00325405f, 0.20490539f, 0.10309919f, -0.00075167f, -0.13600293f, -0.11521384f, 
    -0.42763159f, 0.41187429f, 0.07816023f, -0.05355658f, 0.11234761f, 0.04564067f, -0.19040054f, 0.00773501f, 
    -0.24644580f, 0.04542344f, -0.55635095f, 0.10545605f, -0.35161456f, -0.52815574f, -0.07240872f, 0.19862369f, 
    0.16808997f, 0.05882099f, 0.14415209f, 0.04852888f, 0.04225967f, 0.15846254f, 0.07204649f, 0.09327903f, 
    0.27421027f, 0.06526162f, -0.25973293f, -0.65474743f, -0.24590150f, -0.13373016f, -0.00315314f, 0.08685525f, 
    0.11954315f, -0.04042915f, -0.07517868f, -0.18511315f, 0.01266642f, -0.03737041f, -0.05787146f, -0.90083963f, 
    -0.60355926f, -0.41029873f, 0.17475432f, -0.10520185f, -0.11637049f, 0.05822771f, -0.09544852f, -0.29154423f, 
    -0.01423424f, 0.23410220f, -0.30434310f, 0.11242164f, 0.26598626f, 0.07413600f, -0.09841521f, -0.04574094f, 
    0.07963275f, -0.10989160f, 0.06916036f, 0.18295354f, 0.45021898f, -0.02484798f, 0.05665143f, 0.01991449f, 
    -0.29839304f, 0.32552135f, 0.10067373f, -0.07264886f, -0.03065168f, -0.29630777f, 0.17587134f, -0.01073664f, 
    0.01578749f, 0.05585044f, 0.16776243f, -0.79983437f, 0.12068971f, 0.34034824f, 0.27950451f, 0.02634167f, 
    -0.09618834f, 0.00466352f, -0.37053427f, -0.20196810f, -0.10132007f, -0.50572085f, -0.06037279f, 0.37908062f, 
    -0.12064946f, 0.07074140f, 0.50862867f, 0.20573147f, -0.02832823f, -0.31073454f, 0.15930852f, -0.03713708f, 
    -0.29979697f, 0.02320861f, -0.02277623f, 0.14060794f, 0.05671467f, 0.05050475f, 0.25775045f, -0.75303006f, 
    0.23305361f, 0.28762802f, -0.56903899f, -0.11368413f, -0.06811032f, -0.36737725f, 0.04450648f, 0.17399295f, 
    -0.28295124f, -0.08281165f, 0.34245282f, 0.30825967f, 0.05020939f, -0.09011447f, 0.05540964f, 0.12446430f, 
    -0.23367807f, 0.12442675f, 0.04051105f, -0.03812953f, -0.10379612f, 0.07472499f, -0.48787990f, -0.06242125f, 
    0.12710012f, -0.25272921f, 0.24625342f, 0.02888136f, 0.24520464f, 0.02518167f, -1.19414997f, -0.01789866f, 
    0.02464551f, 0.26131979f, 0.09433442f, 0.12729983f, 0.43454421f, 0.29150781f, -0.21117361f, -0.30312464f, 
    -0.76723993f, -0.04093314f, 0.21781859f, 0.20384432f, 0.11354204f, -0.27934453f, -0.01525834f, -0.41364238f, 
    -0.28950024f, -0.03988843f, 0.55766326f, 0.15754671f, -0.02093801f, 0.32588512f, -0.86891860f, 0.07249184f, 
    -0.12192947f, -0.07939073f, 0.01554123f, -0.37299910f, -0.02135547f, 0.01446081f, -0.59437275f, 0.35428026f, 
    -0.45627379f, -0.25590521f, -0.16945346f, -0.28892085f, 0.07187074f, -0.03649233f, -0.05984076f, 0.29298317f, 
    -0.09189846f, 0.00988569f, 0.18373233f, -0.09046254f, 0.17519614f, 0.13533439f, 0.03692597f, -0.02824537f, 
    0.28477558f, 0.11326794f, -0.05239560f, 0.08155491f, 0.46206501f, 0.05743799f, -0.26223063f, 0.06745402f, 
    0.21816924f, 0.19233781f, -0.08271985f, 0.11223611f, -0.17792235f, 0.04525708f, -0.12969099f, -0.00075172f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.09966740f, 0.12827623f, -0.21846163f, -0.20636128f, 0.11904281f, 0.11059354f, 0.08575319f, -0.44094437f, 
    -0.05249044f, -0.01619604f, 0.38534799f, -0.08223014f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
