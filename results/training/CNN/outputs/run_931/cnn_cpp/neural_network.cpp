#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.01659414f, -0.72248745f, -0.31183425f, 0.00904623f, -0.32767507f, -0.51036680f, 0.75475407f, -0.03171020f, 
    -0.07433422f, 0.22133276f, 0.16465671f, 0.08738928f, -0.03078714f, 0.04470624f, -0.05917655f, -0.24538696f, 
    -0.08621597f, -0.02481047f, 0.16332625f, 0.10933036f, -0.20894380f, 0.23529717f, 0.09777045f, -0.12119298f, 
    0.13047516f, -0.47630641f, -0.25674421f, -0.55273968f, 0.40133688f, 0.28170341f, -0.18305834f, 0.35655770f, 
    -0.06890473f, -0.33998439f, -0.38652614f, 0.32857326f, 0.22509894f, 0.01839785f, 0.03256562f, 0.28864616f, 
    -0.35384494f, -0.09398541f, 0.16644043f, 0.23224379f, -0.12318296f, -0.14992946f, 0.26551086f, -0.38217992f, 
    0.31837818f, 0.19223872f, -0.08961827f, -0.05649714f, -0.16558254f, -0.39007407f, 0.89414012f, -0.33331871f, 
    0.20747523f, 0.41840619f, -0.48823577f, 0.34715906f, 0.12775630f, 0.12572005f, 0.18377583f, -0.20401280f, 
    0.14038713f, 0.27689770f, 0.04953632f, -0.13062245f, 0.15173924f, 0.09273495f, 0.39346489f, -0.41350466f, 
    -0.13978484f, -0.04762076f, -0.04655367f, 0.71398664f, -0.22214833f, -0.05541994f, 0.05762405f, 0.36959893f, 
    0.58799022f, 0.39197370f, -0.19120872f, 0.21631049f, 0.45191553f, 0.09192742f, 0.51936084f, -0.33550814f, 
    0.28294817f, 0.16423048f, 0.01697862f, -0.23858596f, -0.36485717f, 0.30832240f, 0.08003978f, 0.12596177f, 
    0.18200722f, -0.01552829f, 0.14601487f, -0.07126010f, -0.22646308f, -0.09651584f, 0.57048202f, 1.06953681f, 
    0.20160791f, 0.11575856f, 0.48183060f, 0.36105576f, 0.20000868f, 0.48662207f, -0.25835955f, -0.13722810f, 
    0.03740941f, -0.18139996f, -0.03584787f, -0.00841493f, 0.30177543f, -0.11755652f, -0.05599314f, -0.35242218f, 
    0.18409604f, 0.10688531f, -0.26810721f, 0.04204838f, -0.11495055f, -0.09468139f, -0.71042514f, -0.35430759f, 
    0.28165883f, -0.51151842f, 0.28876689f, 0.40199503f, 0.28458363f, 0.74524540f, -0.06276939f, 0.11170023f, 
    0.07179443f, -0.29295102f, -0.10589003f, -0.08939762f, 0.19861692f, 0.06070171f, 0.01136304f, -0.22888620f, 
    -0.07459182f, 0.06288467f, -0.30973354f, 0.14155649f, -0.12644485f, -0.05378896f, 0.74292129f, 0.44552135f, 
    -0.34525448f, 0.17057134f, -0.62769037f, 0.30270943f, 0.38768744f, 0.26319399f, 0.69523084f, 0.20294802f, 
    0.07402299f, 0.15684940f, -0.04337905f, -0.33942842f, 0.14905462f, -0.04243134f, 0.00102305f, -0.03777952f, 
    0.20078701f, -0.05341427f, -0.18180519f, -0.22799321f, -0.00994079f, -0.05306700f, 0.13450938f, 0.84556103f, 
    0.50180483f, 0.89995998f, -0.12725589f, 0.17995009f, -0.32910591f, -0.59933317f, -0.36956781f, -0.02739726f, 
    -0.01775682f, 0.09816835f, 0.31372508f, -0.00720248f, 0.05229019f, 0.15595622f, 0.11590465f, -0.04014952f, 
    0.00714410f, 0.28190434f, 0.44776484f, 0.17243886f, 0.25892401f, 0.14911531f, 0.15619510f, 0.01329495f, 
    0.32930836f, -0.35729247f, -0.19462313f, -0.48077467f, -0.21708605f, 0.36506972f, -0.60363030f, 0.24961811f, 
    0.34135532f, -0.60181612f, -0.47997150f, -0.43728113f, 0.06526827f, -0.21256831f, 0.08830868f, -0.12809859f, 
    -0.07406941f, -0.06354223f, 0.07104716f, 0.00960105f, -0.22228682f, -0.11955529f, -0.13963041f, 0.02051928f, 
    -0.14811380f, -0.41125163f, 0.42028984f, 0.57431591f, 0.08666015f, -0.30301270f, -0.56835407f, 0.18643337f, 
    -0.00226282f, -0.12206546f, -0.47996747f, 0.00196623f, -0.01809160f, -0.35085359f, -0.17623603f, -0.16799819f, 
    0.03934124f, 0.21759480f, 0.24346441f, 0.27214015f, 0.02748200f, -0.12893197f, -0.23712006f, -0.33860579f, 
    -0.28539652f, -0.15733042f, 0.07966704f, -0.04635675f, -0.64864373f, -0.64553881f, -0.04467255f, 0.10155848f, 
    0.33170313f, 0.30727407f, 0.11208546f, -0.06620024f, -0.17459621f, -0.27966681f, 0.04894174f, -0.28082132f, 
    -0.42793241f, 0.15860783f, 0.00816469f, -0.17022637f, -0.37206006f, -0.30649707f, -0.39671299f, -0.32872999f, 
    -0.07229385f, -0.20929770f, 0.08927018f, -0.33544886f, -0.78990859f, -0.47483078f, 0.12748672f, 0.05242476f, 
    0.52903116f, 0.86867976f, -0.10885055f, 0.48640302f, 0.42784539f, -0.13953644f, 0.07496840f, 0.13026644f, 
    0.34575492f, 0.08667364f, -0.08915907f, -0.01476754f, 0.09023340f, 0.13334502f, -0.10842034f, 0.04937958f, 
    0.00571394f, -0.11082672f, 0.04344250f, 0.24302398f, 0.89908183f, 0.25635278f, -0.41885358f, 0.83462232f, 
    0.59775013f, 0.19636562f, -0.12949738f, -0.43374684f, -0.41633418f, -0.03283712f, -0.13134176f, -0.15079305f, 
    -0.24048139f, -0.46742335f, -0.26706743f, -0.05776692f, -0.26313809f, -0.24285911f, -0.23052247f, -0.10319250f, 
    0.07661413f, 0.09656081f, 0.22229049f, -0.16464238f, 0.04625781f, -0.40578854f, -0.33794761f, -0.25248000f, 
    -0.21056403f, -0.19123343f, -0.27586976f, 0.33201265f, -0.04739807f, -0.17422956f, -0.02783789f, -0.19413005f, 
    0.42931283f, 0.31612983f, 0.32986769f, 0.18400949f, -0.35957903f, -0.36716598f, -0.02039986f, -0.38803810f, 
    -0.20739976f, 0.22063327f, -0.01753549f, -0.28064281f, 0.22870113f, -0.01414696f, 0.70750421f, -0.21068868f, 
    -0.21493514f, 0.50884771f, 0.28949183f, 0.32327628f, 0.29963759f, 0.40453660f, 0.63225710f, 0.14412814f, 
    -0.36051342f, -0.17470878f, -0.34391207f, 0.01340073f, 0.09685344f, 0.07116484f, -0.25333732f, 0.03414508f, 
    0.05991798f, 0.12070478f, 0.01563010f, -0.12321789f, -0.09829500f, -0.11515716f, -0.14209679f, 0.72835922f, 
    0.45419112f, -0.11486973f, 0.54644698f, -0.27208522f, 0.23387180f, 0.22005177f, 0.07012855f, 0.02368007f, 
    -0.44735456f, -0.39852148f, -0.15027146f, 0.00857041f, 0.07032004f, -0.13682160f, 0.13381432f, -0.24376991f, 
    0.18500498f, 0.05113304f, 0.10258278f, 0.38000074f, 0.03709336f, -0.21195897f, -0.01052194f, 0.08095971f, 
    0.31624928f, 0.66973716f, -0.60759169f, -0.77636153f, -0.54435241f, 0.20062394f, -0.44523424f, -0.30836031f, 
    -0.00744079f, -0.04871012f, -0.12878911f, 0.34454700f, 0.16240312f, 0.27743647f, 0.14987963f, 0.02375281f, 
    0.08642334f, -0.12059174f, 0.09261778f, 0.42170614f, 0.05313972f, 0.10429888f, 0.16485278f, -0.23018974f, 
    0.15551308f, 0.07062201f, 0.27290210f, 0.42206115f, 0.47505632f, -0.05730198f, -0.08628199f, 0.21039309f, 
    0.16559102f, -0.10385901f, -0.09008863f, -0.30286589f, -0.12347369f, 0.35934016f, 0.17518920f, 0.40204537f, 
    -0.00900988f, -0.49059567f, 0.14411566f, 0.15426533f, 0.36774489f, -0.22417924f, -0.21689923f, -0.18098125f, 
    0.11898201f, -0.13546669f, 0.15170389f, 0.08362804f, 0.11715715f, 0.33835673f, 0.14207403f, -0.11412668f, 
    -0.56085992f, -0.62660414f, -0.27001506f, 0.17554100f, -0.10544751f, 0.72395444f, -0.31206885f, -0.21614638f, 
    -0.05194889f, -0.13296217f, -0.42602155f, -0.10957041f, -0.10381936f, -0.28601798f, 0.14103043f, 0.14467609f, 
    0.07157136f, 0.05438699f, -0.04546267f, 0.29470980f, -0.00858992f, -0.69883299f, -0.38731205f, 0.52814573f, 
    -0.03881381f, -0.66480923f, 0.06943221f, 0.20184949f, 0.33311045f, -0.52375585f, 0.15627067f, 0.35271218f, 
    -0.03949537f, -0.18112978f, 0.07993605f, 0.07057652f, 0.23419170f, 0.34017906f, 0.25229275f, 0.13924289f, 
    0.29677790f, 0.11759032f, -0.21856767f, 0.01506035f, -0.41091374f, -0.20763008f, 0.11831239f, -0.27594543f, 
    -0.52843583f, 0.05052125f, -0.08732048f, -0.04988937f, 0.07639197f, -0.37988418f, 0.22250570f, 0.21707511f, 
    -0.41589808f, 0.29188204f, 0.39223793f, -0.08451492f, -0.15887485f, -0.03691058f, -0.24385141f, 0.09021278f, 
    0.03924956f, 0.36175221f, 0.35529062f, -0.12930205f, -0.00618671f, -0.06921723f, -0.85961038f, -0.59554857f, 
    -0.31521887f, -0.26981404f, -0.56980646f, 0.35137171f, 0.60745561f, -0.14273600f, 0.15736632f, 0.27520698f, 
    -0.12534425f, -0.11538694f, 0.03013097f, 0.23535243f, 0.09028699f, 0.27398381f, -0.01877245f, -0.02775427f, 
    0.01561940f, 0.09080347f, 0.03727649f, 0.03068849f, 0.32991987f, 0.09521208f, 0.62714916f, 0.64705712f, 
    0.73984456f, -0.22807720f, -0.46106443f, 0.27736339f, -0.23344725f, -0.32350206f, -0.14866114f, 0.63775557f, 
    0.47534716f, 0.28768635f, -0.05561889f, -0.13034406f, -0.22160855f, -0.23479253f, -0.11694166f, 0.04055887f, 
    -0.11075923f, -0.55105555f, 0.26010156f, 0.20226757f, -0.23461024f, -0.01688030f, 0.07800245f, -0.82230633f, 
    0.54596037f, 0.43152052f, -0.49368876f, 0.03771852f, 0.72275645f, 0.42070085f, -0.79247630f, 0.05725545f, 
    -0.13289309f, 0.14441608f, 0.42290804f, -0.03182289f, 0.11358047f, 0.13527806f, -0.17821230f, -0.00751211f, 
    -0.13548078f, -0.19358242f, -0.04098521f, 0.18399611f, -0.08899895f, 0.31847197f, -0.17298348f, 0.05971912f, 
    -0.56245387f, -0.00831563f, 0.04138139f, -0.20481652f, 0.00368005f, 0.53780890f, -0.71348196f, -0.42137378f, 
    -0.58014178f, -0.50874478f, -0.16972904f, -0.32060838f, 0.33857718f, 0.31194213f, -0.03917163f, 0.10621430f, 
    -0.02014918f, 0.03189632f, -0.03599980f, 0.25210950f, -0.07568639f, 0.10965893f, 0.02317747f, 0.19389965f, 
    -0.05855704f, 0.07096910f, -0.52442950f, -0.29161650f, -0.10927707f, 0.07729580f, -0.65849507f, -0.82936496f, 
    0.08804428f, -0.37365448f, -0.11737125f, -0.03084528f, 0.24734038f, -0.03040489f, -0.19872442f, 0.27660251f, 
    -0.05935105f, -0.03504916f, -0.09765580f, -0.16636890f, 0.22088882f, -0.00421134f, -0.01113464f, 0.35796577f, 
    -0.05257515f, 0.09488379f, 0.80440938f, 0.53915828f, -0.58178228f, -0.51423973f, -0.85534787f, 0.15220748f, 
    0.11674313f, 0.12078822f, -0.05430160f, 0.21474956f, 0.05923226f, -0.05536849f, 0.00447791f, -0.05004944f, 
    0.26698574f, -0.00395360f, -0.23871456f, 0.03079456f, -0.06381536f, -0.10173663f, 0.16984981f, 0.13742608f, 
    -0.07188035f, 0.05997556f, 0.10762258f, 0.23573315f, -0.72441030f, 0.40493315f, 0.10772329f, 0.07623559f, 
    -0.21153122f, -0.62951553f, 0.37499344f, 0.19244492f, -0.14907798f, 0.34464622f, -0.60376608f, -0.36526239f, 
    0.28411427f, -0.14714944f, 0.37478563f, 0.03013512f, 0.25048390f, -0.12122049f, -0.21280332f, -0.04581213f, 
    -0.22526595f, 0.18651685f, -0.09443649f, -0.14266366f, 0.41052985f, 0.47442836f, 0.24370344f, 0.67793101f, 
    0.47536492f, -0.00835996f, 0.01087610f, 0.33014041f, -0.00835540f, -0.35130811f, -0.24211003f, -0.15512376f, 
    0.03399050f, 0.23054264f, -0.21866542f, 0.22135615f, 0.23172209f, 0.00825317f, -0.00729164f, 0.03966789f, 
    -0.24897137f, -0.07338063f, 0.01356274f, 0.12032142f, 0.09857206f, 0.61580908f, 0.42942849f, 0.70344269f, 
    0.70874447f, 0.25297320f, 0.20190684f, 0.16988203f, -0.79553539f, 0.16223554f, -0.15233399f, 0.11827850f, 
    -0.04883526f, -0.01514547f, 0.10837919f, -0.19911607f, 0.27255723f, 0.30600739f, -0.03762343f, 0.04745791f, 
    0.15226534f, 0.12222932f, -0.23449020f, -0.03776581f, -0.16785374f, 0.36988541f, 0.01856309f, -0.44987461f, 
    -0.28810742f, 0.21615742f, -0.23803928f, 0.13362241f, -0.33085012f, -0.13149589f, 0.45182815f, -0.09165474f, 
    -0.27818957f, -0.37822419f, -0.19558862f, -0.19987632f, -0.40336987f, 0.26901829f, 0.21909146f, -0.34095907f, 
    0.12023024f, 0.14024138f, 0.21663435f, 0.23716334f, -0.09246033f, -0.04099495f, 0.14085144f, -0.27264595f, 
    -0.20967416f, 0.41166967f, 0.06989422f, -0.29615775f, 0.30552712f, 0.66439223f, -0.08723523f, -0.17371075f, 
    -0.16709708f, 0.34018272f, 0.20235758f, -0.33420211f, -0.41339260f, -0.19845314f, 0.31461757f, -0.09443320f, 
    -0.00903095f, 0.14470175f, 0.08694325f, 0.01702724f, -0.03388956f, -0.02144668f, 0.12003385f, 0.21392787f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.11362333f, 0.16317956f, 0.09070640f, 0.11408141f, 0.26834872f, 0.00343290f, 0.16577075f, 0.10238431f, 
    0.19976644f, -0.13320896f, 0.12186317f, 0.18170922f, 0.11702543f, -0.02217767f, -0.04691856f, 0.05023862f, 
    -0.02662004f, 0.14210828f, 0.14211947f, -0.00680364f, -0.02457562f, 0.18520503f, -0.00536250f, -0.00486516f, 
    0.04347346f, 0.05829305f, 0.21103816f, -0.09564460f, 0.06489566f, 0.04632761f, -0.17429340f, 0.00415471f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.22247148f, 0.06413896f, -0.16767968f, -0.03168696f, 0.05413251f, -0.10071646f, -0.00815948f, 0.03932988f, 
    0.03616662f, -0.07461416f, -0.01301851f, -0.04709339f, 0.14495739f, -0.00823714f, 0.09493592f, 0.17999774f, 
    0.07797241f, 0.01470586f, -0.07983205f, -0.03738569f, -0.13865414f, 0.06282621f, 0.19754629f, 0.02312123f, 
    0.25073010f, 0.20278189f, 0.01045676f, 0.02807387f, 0.09316014f, 0.00352727f, 0.14685920f, 0.12466178f, 
    -0.06958780f, 0.17363495f, -0.04080899f, 0.09078664f, 0.10509713f, -0.25260279f, 0.18043914f, 0.13083284f, 
    -0.03663121f, 0.06775764f, 0.18480530f, -0.09286650f, 0.02537774f, 0.07224341f, -0.04894283f, 0.03256010f, 
    0.02629878f, -0.10684101f, -0.02243161f, -0.20766765f, 0.11058538f, -0.06925100f, -0.19579634f, -0.02709568f, 
    0.05057195f, -0.00572716f, -0.04222088f, -0.09054866f, 0.08840076f, -0.04594380f, -0.07126731f, -0.01820189f, 
    -0.05358493f, -0.05900738f, 0.06421404f, -0.03119478f, 0.05497852f, 0.09496713f, -0.04004704f, -0.05630073f, 
    0.06028654f, -0.01067204f, -0.01798619f, -0.03154323f, 0.13446623f, 0.03803584f, 0.05867310f, 0.08382003f, 
    0.03965723f, 0.02081370f, -0.08651458f, -0.05061539f, 0.40889919f, 0.36217850f, -0.09379271f, -0.03342029f, 
    0.03151392f, -0.03116348f, -0.02919688f, -0.01391327f, 0.02836007f, 0.07814445f, 0.12098675f, 0.10770882f, 
    -0.05748089f, -0.05444968f, -0.05052618f, -0.06942210f, 0.03845943f, -0.07109621f, 0.09011735f, 0.13033271f, 
    -0.02596390f, 0.08984277f, 0.02767913f, -0.11139591f, -0.05003205f, 0.01230853f, -0.07934444f, 0.05789598f, 
    -0.19984828f, 0.02366453f, -0.25935671f, -0.05398577f, -0.04227957f, -0.14923409f, 0.02130640f, -0.00122430f, 
    0.03628213f, -0.03570775f, -0.05442300f, -0.08814554f, 0.09793033f, 0.02185114f, 0.05031594f, -0.23573485f, 
    -0.02984317f, -0.13007036f, 0.04506110f, -0.04022121f, 0.40033776f, -0.07382733f, -0.00891669f, 0.01076916f, 
    0.07140812f, -0.01552128f, 0.11186857f, 0.17263317f, -0.00751264f, -0.05016080f, -0.05617208f, 0.05400897f, 
    -0.18771791f, -0.15342246f, -0.01481648f, -0.11856613f, 0.19381431f, -0.10515344f, 0.02900381f, -0.12589900f, 
    0.09528986f, 0.06612146f, -0.01791905f, -0.06482085f, 0.06513862f, 0.11746177f, -0.20224254f, 0.05895970f, 
    -0.08781817f, -0.00109458f, 0.08350056f, 0.07402820f, 0.12082288f, 0.12098818f, 0.07482216f, 0.01813648f, 
    -0.21261898f, -0.14399506f, -0.08169877f, -0.14249325f, 0.05673663f, -0.11819068f, -0.03873716f, 0.03724739f, 
    -0.08966155f, 0.06597412f, -0.10479526f, -0.02908090f, -0.16102274f, -0.25268576f, 0.10600928f, -0.10356157f, 
    -0.00328764f, 0.14328259f, -0.07300267f, -0.00710972f, 0.15679507f, -0.01504929f, 0.15871257f, 0.01781559f, 
    -0.05157236f, 0.18236861f, 0.05383070f, -0.10216808f, 0.13395506f, 0.06410327f, -0.00164726f, -0.02263633f, 
    0.06219416f, 0.14969191f, 0.03439422f, 0.06911910f, -0.14776903f, -0.13742189f, -0.01320002f, 0.11961056f, 
    -0.10401811f, 0.05246994f, -0.07160855f, 0.02558652f, 0.09512199f, 0.02108047f, 0.10384290f, 0.04578187f, 
    0.37332952f, 0.08749465f, -0.06665879f, -0.12723486f, 0.19453338f, 0.01744844f, 0.13162120f, 0.17649196f, 
    0.14700195f, 0.19452548f, -0.01941493f, -0.12767096f, -0.15148593f, 0.29838842f, -0.01591754f, 0.09522218f, 
    0.09695552f, -0.21971172f, -0.03957377f, 0.04160051f, 0.11082048f, 0.08649889f, 0.08122028f, -0.00398106f, 
    0.00864541f, -0.10945304f, 0.12303364f, -0.04890859f, 0.03137409f, 0.04226556f, 0.05233058f, 0.01766749f, 
    0.07457899f, 0.13005073f, 0.09782952f, 0.14611624f, 0.12896119f, 0.19590564f, 0.07031648f, 0.02415329f, 
    0.14254947f, 0.00947532f, 0.00142774f, -0.14050661f, 0.05163112f, 0.04386810f, -0.02611212f, 0.04201803f, 
    0.56385654f, -0.00331871f, 0.18162215f, -0.09803401f, 0.01250880f, 0.07410018f, 0.01813554f, 0.06833944f, 
    0.12231787f, -0.02906156f, 0.02275031f, 0.08274762f, -0.21804453f, -0.16448982f, -0.03405024f, 0.26426262f, 
    -0.03538577f, 0.10380191f, 0.00586522f, 0.05561174f, 0.00334391f, -0.00230382f, 0.12007622f, -0.08679958f, 
    0.01731844f, -0.14777669f, -0.17549571f, 0.09997328f, -0.05316523f, 0.09495841f, 0.06743778f, -0.06709804f, 
    0.12115946f, 0.05436535f, 0.06450801f, -0.00514579f, 0.00924141f, 0.11225863f, -0.03920071f, -0.18549660f, 
    0.00748453f, -0.08661683f, 0.03454546f, -0.04612726f, 0.00001242f, 0.08794367f, -0.00552826f, 0.02140233f, 
    0.23957671f, 0.21020003f, 0.14549610f, -0.05182929f, 0.00794127f, 0.05955505f, 0.02868459f, 0.09530836f, 
    0.06731854f, 0.06228350f, -0.05617221f, 0.09765778f, -0.27698222f, 0.07742774f, 0.01601947f, 0.02910076f, 
    0.16317996f, -0.02261477f, -0.09996243f, 0.03777134f, -0.03284425f, -0.02435135f, 0.22971751f, 0.15576147f, 
    -0.33218151f, -0.32469222f, -0.12307989f, -0.19868095f, 0.12370349f, 0.06970271f, -0.02409852f, -0.08921503f, 
    -0.06811787f, -0.05033377f, 0.07197926f, 0.00356946f, 0.36539984f, -0.49522674f, -0.06519108f, 0.02633616f, 
    -0.02761546f, 0.13523355f, 0.01500488f, -0.06530260f, 0.02419108f, 0.06970632f, -0.01648631f, 0.17961735f, 
    -0.02490653f, -0.29833966f, -0.12818009f, 0.00877134f, 0.01556945f, -0.12711695f, 0.02193796f, 0.04398529f, 
    0.12569650f, -0.05048339f, -0.08031689f, -0.11673874f, 0.02092743f, -0.13587131f, -0.09126073f, 0.10005041f, 
    -0.00871370f, 0.10255896f, 0.01778270f, -0.04767312f, 0.16948636f, -0.01006577f, -0.00084035f, 0.04016740f, 
    -0.05580953f, -0.02649692f, -0.01389422f, -0.02818769f, -0.01749631f, 0.01440118f, -0.03259689f, -0.01162245f, 
    -0.01810592f, -0.03187475f, 0.01785195f, 0.01242119f, 0.03517663f, -0.02855923f, -0.04341221f, 0.02872343f, 
    0.00341774f, 0.02053587f, 0.03051572f, 0.01708912f, 0.04004625f, -0.03575169f, -0.01880712f, -0.01755047f, 
    -0.04278716f, -0.01910401f, -0.02670151f, -0.02391861f, -0.01965018f, 0.03181220f, -0.00256722f, 0.01075481f, 
    -0.03496299f, -0.00184396f, -0.00053404f, 0.01972022f, 0.01731272f, -0.01737189f, -0.05467181f, -0.00659606f, 
    0.04294840f, -0.04699399f, -0.03637366f, -0.05333548f, -0.00349819f, 0.02749061f, 0.02199584f, 0.00554738f, 
    0.00446131f, 0.01762956f, 0.01113801f, -0.02600237f, 0.04633129f, 0.03778699f, 0.01416988f, -0.00238734f, 
    0.02526758f, -0.00659441f, 0.03849996f, 0.00791833f, -0.04352169f, -0.04384550f, -0.04291580f, 0.01944953f, 
    0.04527567f, 0.04222983f, -0.01378289f, -0.04044706f, 0.02417376f, -0.00723123f, -0.05120962f, -0.04721975f, 
    -0.00725914f, -0.04945348f, -0.04105936f, -0.03249789f, -0.02049668f, -0.04676324f, 0.01474581f, -0.04753355f, 
    0.04020785f, 0.02083321f, -0.01439451f, -0.00403581f, -0.02438581f, 0.00075670f, 0.00921275f, -0.03468212f, 
    -0.00005896f, -0.00569932f, 0.00085844f, -0.02105794f, -0.03851143f, 0.00170092f, -0.00996429f, 0.00607855f, 
    0.02448688f, -0.01930386f, -0.04380323f, -0.04753162f, 0.04269664f, -0.04078441f, -0.00736783f, -0.04879893f, 
    -0.03786108f, 0.04462998f, 0.02395095f, 0.04311844f, 0.03682917f, 0.01765804f, 0.01376098f, 0.00842763f, 
    0.01662790f, 0.04238144f, -0.00783529f, -0.02180633f, -0.01716593f, -0.04878085f, -0.01161768f, -0.04309959f, 
    0.04586659f, -0.01482987f, -0.02252821f, -0.03993430f, 0.00162096f, 0.04099332f, 0.02157331f, 0.03898048f, 
    0.00549607f, -0.04120642f, 0.02717217f, -0.02359292f, 0.01766194f, -0.02005933f, 0.02182326f, -0.05561147f, 
    0.00671057f, 0.01742127f, -0.00542382f, -0.05774804f, -0.01150897f, -0.05377946f, -0.03654474f, -0.00144779f, 
    0.03831693f, 0.02098411f, -0.00858840f, 0.03868847f, -0.03146464f, 0.02798220f, -0.04576523f, 0.02876534f, 
    0.00921901f, -0.01575245f, -0.00707326f, -0.00315266f, 0.00150346f, 0.00057767f, 0.05062953f, 0.01478967f, 
    0.03374461f, -0.04826958f, -0.03106538f, -0.03687352f, -0.04871817f, -0.06292380f, -0.03820554f, 0.03244840f, 
    0.03314166f, -0.02991137f, -0.00348866f, 0.02306094f, 0.02390355f, -0.01022501f, 0.04157303f, -0.04490919f, 
    0.02603460f, -0.04665845f, -0.04070150f, -0.03737188f, -0.02142879f, -0.03451306f, -0.00176599f, 0.02032140f, 
    -0.05295188f, -0.04305582f, -0.01260278f, -0.04318051f, -0.00091298f, 0.02715342f, 0.00396875f, 0.03112143f, 
    0.00439631f, 0.03275483f, -0.02960358f, 0.02475217f, 0.02514263f, 0.00935283f, -0.00461760f, -0.05710163f, 
    -0.04525261f, -0.04780388f, 0.02163093f, -0.00325444f, 0.03794040f, -0.06291439f, -0.00317830f, 0.00181542f, 
    0.03737768f, -0.00075813f, 0.00442047f, -0.01666428f, 0.01152260f, 0.01082791f, 0.02860415f, -0.01244323f, 
    -0.05104622f, 0.02567289f, 0.05057163f, 0.00092941f, -0.03007898f, 0.04339263f, 0.00663875f, 0.03664104f, 
    -0.00604085f, -0.02301023f, 0.00177853f, -0.03641012f, -0.04412778f, -0.02770276f, 0.01309841f, -0.00612866f, 
    0.02196424f, 0.03647716f, -0.02118661f, 0.01641535f, 0.02368959f, -0.05194236f, -0.00450015f, -0.00499024f, 
    0.03137926f, 0.01266294f, 0.02005649f, 0.04517910f, -0.03257211f, -0.04210131f, 0.02167605f, -0.02879518f, 
    -0.00828448f, 0.00268048f, 0.01205056f, -0.02068685f, -0.04859687f, 0.02321858f, 0.04511125f, -0.01946865f, 
    -0.00192476f, -0.04851779f, -0.04993941f, -0.04584564f, -0.00465081f, -0.05667307f, -0.06441572f, 0.00583802f, 
    0.01464875f, 0.03891652f, -0.02693864f, -0.06005141f, 0.04462362f, -0.05564195f, 0.00115670f, -0.01857479f, 
    0.04133560f, 0.02739628f, -0.00756337f, -0.04477087f, -0.03514254f, -0.00810689f, -0.03066176f, -0.04284353f, 
    0.00826112f, -0.00126162f, -0.02958002f, -0.04265333f, -0.03412083f, -0.02470367f, 0.00105924f, -0.02686488f, 
    -0.00376118f, 0.00315666f, 0.00802111f, 0.04596779f, -0.04932106f, -0.04665420f, -0.02163763f, -0.02381572f, 
    0.02755943f, -0.03283477f, 0.02832993f, -0.04155750f, 0.00179490f, 0.05636973f, -0.03017392f, 0.05217214f, 
    -0.00694715f, 0.03482815f, 0.02108930f, -0.04637297f, -0.04843815f, 0.05249238f, 0.00243747f, -0.03993294f, 
    -0.01366941f, 0.04293682f, 0.03250460f, -0.04018071f, 0.00728988f, -0.00702068f, -0.05438162f, 0.03392491f, 
    0.01272711f, 0.01029684f, 0.01409109f, -0.05659132f, -0.01710456f, 0.02610296f, 0.02453270f, 0.01362479f, 
    0.01397904f, -0.04930320f, -0.02173060f, 0.03435058f, -0.00749780f, -0.01506941f, -0.00082836f, -0.00544235f, 
    0.04463265f, -0.02726746f, -0.02699983f, 0.01230715f, 0.03350525f, -0.04397907f, 0.03318466f, 0.03752114f, 
    -0.04833325f, -0.02997880f, 0.00731956f, 0.03623226f, -0.02537558f, -0.01521925f, -0.05539339f, 0.02465568f, 
    -0.00544784f, -0.01522000f, 0.00396688f, -0.01049159f, -0.01444621f, 0.02714155f, -0.02064151f, 0.00217298f, 
    -0.03221514f, -0.02716312f, 0.02552075f, 0.04939226f, -0.04794907f, -0.01076996f, -0.00531413f, -0.00943474f, 
    -0.04323785f, 0.00866498f, -0.04452098f, -0.04775305f, 0.03421404f, -0.04018245f, 0.03229276f, -0.01738983f, 
    0.00022102f, 0.01961857f, -0.03108374f, 0.02609345f, -0.01744295f, -0.04388921f, -0.05989125f, 0.03079431f, 
    -0.20247327f, -0.14278676f, -0.22537331f, 0.07923365f, -0.01249179f, -0.04005225f, 0.03325940f, -0.00789450f, 
    0.02080369f, -0.01942148f, 0.20831935f, 0.13007183f, 0.02110023f, 0.18457431f, -0.24046987f, 0.22692108f, 
    0.16567448f, 0.17369995f, 0.11582380f, 0.05757588f, 0.07323842f, -0.09396467f, 0.06167499f, -0.14264140f, 
    -0.07376020f, 0.02270083f, 0.02684609f, -0.10885980f, 0.01343905f, -0.01632409f, -0.00610707f, -0.04318179f, 
    0.14452475f, 0.08572980f, 0.04445706f, -0.00553297f, 0.27912620f, 0.12336606f, -0.00423467f, 0.00334467f, 
    0.16137774f, 0.01074698f, -0.21475248f, 0.00026508f, 0.03312399f, 0.06404972f, -0.01459951f, -0.00233024f, 
    0.27363089f, -0.05979678f, 0.04851046f, 0.40798423f, 0.03326867f, 0.08395663f, 0.01579120f, 0.04452389f, 
    0.10615990f, 0.11411493f, 0.07370175f, 0.06610940f, -0.04082680f, -0.13878304f, -0.29018670f, -0.02519407f, 
    0.11751640f, 0.04992209f, -0.01775214f, -0.03717193f, 0.11737187f, 0.03569189f, 0.13076840f, 0.06653606f, 
    0.30730513f, -0.03531962f, 0.08649042f, 0.13792287f, 0.07658385f, -0.04805231f, -0.02501337f, 0.01053365f, 
    0.09161013f, 0.03660434f, 0.00948284f, 0.08766432f, 0.01853624f, 0.11804582f, 0.38300705f, -0.00319342f, 
    0.05586090f, -0.06669515f, 0.02972770f, -0.00203579f, 0.06854165f, 0.00431710f, -0.07559365f, -0.01956830f, 
    -0.06591603f, -0.15854485f, 0.13241194f, -0.17975499f, -0.10214102f, -0.08611465f, 0.04810492f, 0.04458321f, 
    0.21959308f, 0.03121840f, 0.04453906f, 0.12503035f, 0.09837202f, 0.10420499f, -0.07795365f, -0.19520314f, 
    0.07644424f, -0.05529433f, 0.05586720f, 0.06870151f, 0.15729719f, -0.03122264f, 0.03284416f, -0.04222940f, 
    -0.10723046f, -0.15552641f, -0.04026143f, -0.18491390f, 0.02049387f, 0.00901531f, -0.00682175f, 0.13443573f, 
    0.15661192f, 0.25350547f, 0.03571482f, 0.16947044f, 0.06082371f, -0.25902787f, -0.24108127f, -0.12627539f, 
    0.16367766f, -0.05864150f, -0.14475082f, -0.02553231f, 0.10097944f, 0.19006655f, -0.05989844f, 0.10642400f, 
    0.01556486f, 0.03006112f, -0.14688422f, -0.06365420f, -0.03883563f, 0.11981345f, -0.00064473f, 0.10794011f, 
    0.07379988f, 0.19153596f, -0.03011439f, 0.04781198f, -0.24642536f, -0.03447483f, -0.06416403f, 0.01396855f, 
    0.04982149f, -0.02517026f, 0.05546904f, 0.09442032f, -0.00282090f, -0.09317542f, -0.02484838f, 0.10510166f, 
    0.09965134f, -0.07379351f, 0.15340911f, 0.17593120f, -0.00089810f, 0.01998220f, 0.07634623f, 0.01858780f, 
    0.12476394f, 0.09887148f, 0.01934890f, 0.16642387f, 0.15067080f, 0.14479436f, 0.03115255f, 0.23024462f, 
    0.03969622f, -0.01853122f, 0.01957342f, 0.02639639f, 0.06633271f, 0.01385132f, 0.01424417f, 0.00740556f, 
    0.10472950f, -0.30315381f, 0.20058934f, -0.20450790f, -0.03600019f, 0.03401159f, 0.07463208f, 0.12266404f, 
    -0.02276489f, -0.09008978f, -0.03249323f, 0.05954224f, 0.25337526f, 0.21759382f, 0.02037606f, 0.04554962f, 
    0.03555617f, -0.02473716f, 0.07381320f, 0.03268399f, 0.02251370f, -0.10881825f, -0.03424754f, 0.13265900f, 
    -0.11703594f, 0.06588500f, 0.06420188f, -0.15489742f, 0.02041237f, 0.14269982f, 0.13586521f, 0.06795892f, 
    0.06889904f, -0.01488482f, -0.05994438f, 0.06860711f, -0.18121180f, -0.29640114f, 0.17077433f, -0.04327191f, 
    0.01470487f, 0.02579068f, 0.10493717f, 0.09369534f, 0.03889335f, -0.09136289f, -0.03450342f, -0.01458564f, 
    -0.34178370f, -0.00585906f, -0.08801708f, -0.08684957f, 0.02708144f, 0.14607553f, 0.10763963f, 0.04016023f, 
    0.05585665f, 0.05109679f, 0.03669471f, -0.08736265f, -0.08465006f, -0.17703047f, -0.30855209f, -0.12461902f, 
    0.04042774f, -0.10586120f, -0.00004532f, -0.01707347f, 0.05518816f, 0.00476831f, -0.02328976f, -0.02614771f, 
    0.15539971f, 0.37310997f, 0.08077318f, 0.10627010f, -0.06239042f, -0.03483282f, -0.02195553f, 0.04626759f, 
    -0.02286850f, 0.02469628f, 0.11670966f, -0.01323258f, -0.34407592f, -0.17125301f, 0.03283457f, -0.22552298f, 
    -0.06828751f, -0.05276736f, 0.02200654f, 0.02298803f, -0.01261421f, 0.07127724f, 0.02341028f, 0.01288650f, 
    -0.07869230f, -0.09196136f, 0.11050998f, -0.29110175f, -0.13960487f, -0.01553239f, 0.03987490f, -0.06199275f, 
    0.02486757f, 0.04493394f, 0.00523247f, 0.11804511f, -0.34679228f, -0.11067791f, 0.10014734f, 0.04317162f, 
    0.09405294f, 0.06102571f, 0.04537396f, 0.14796501f, -0.00580219f, 0.04676399f, 0.08208628f, 0.05117590f, 
    0.39099240f, 0.02650719f, 0.03507645f, -0.07431034f, 0.05920203f, 0.03889385f, 0.10312548f, 0.04821815f, 
    0.06246326f, 0.04913443f, 0.06225739f, 0.04993375f, 0.29871258f, -0.01651651f, 0.09133926f, -0.09255705f, 
    0.13419060f, 0.09198588f, 0.11724146f, 0.03455294f, 0.12633407f, 0.01221652f, 0.11380269f, -0.01120785f, 
    0.05639207f, 0.38619438f, 0.01303068f, 0.00009065f, 0.08396248f, -0.04040797f, 0.07842197f, -0.01294726f, 
    0.15546024f, 0.08888279f, -0.02616240f, 0.03445508f, 0.29914898f, 0.37151185f, 0.27129278f, -0.09678859f, 
    0.12044307f, -0.07824815f, -0.01373436f, -0.05361481f, 0.09281407f, -0.01370039f, 0.05986986f, -0.05685732f, 
    -0.10430643f, -0.06834960f, -0.10082909f, -0.20700175f, -0.12466343f, 0.04088820f, 0.05917822f, -0.00120454f, 
    -0.09232843f, 0.09231802f, -0.00857616f, 0.01047072f, -0.09612983f, -0.25469193f, -0.26978651f, -0.00040452f, 
    0.17262124f, 0.00334114f, -0.02608464f, -0.03574228f, -0.02189927f, -0.01604253f, -0.09296305f, 0.00645630f, 
    0.00579657f, 0.28025189f, -0.02896907f, 0.07932474f, -0.03608740f, 0.03430216f, 0.10476170f, 0.01812010f, 
    0.02394395f, 0.03688380f, -0.24239238f, -0.08493491f, -0.12083738f, 0.08920816f, -0.16100287f, 0.21428874f, 
    -0.10609502f, -0.05162221f, -0.10264998f, 0.06420384f, 0.04535274f, 0.04676182f, -0.11384454f, 0.12430151f, 
    0.16317344f, 0.16760981f, -0.04999385f, 0.11883450f, 0.09740679f, 0.00729525f, -0.01220741f, 0.11806844f, 
    0.01041889f, -0.05045886f, 0.02891402f, -0.02476330f, 0.19279124f, -0.27056584f, 0.02510101f, 0.07497142f, 
    0.13477775f, 0.02827452f, 0.09598245f, 0.08228715f, 0.09555351f, 0.03099422f, -0.14037018f, 0.12578769f, 
    -0.24050181f, 0.06696561f, -0.35378733f, 0.13107409f, 0.00124261f, -0.00107522f, 0.05869416f, 0.03837129f, 
    0.05155808f, 0.02339181f, -0.05357460f, 0.02219455f, 0.22743769f, 0.22047628f, 0.19406889f, -0.08181797f, 
    0.10257356f, 0.13139597f, -0.00124065f, 0.08550629f, 0.00525323f, 0.04240913f, 0.01901695f, -0.01956427f, 
    -0.37154016f, -0.31131107f, 0.02642104f, -0.01281762f, 0.04774171f, 0.05670432f, 0.02577338f, 0.06560046f, 
    0.08958126f, 0.06221348f, 0.01854046f, 0.12601115f, -0.06084312f, -0.28700507f, 0.00637790f, -0.00166637f, 
    0.00428097f, -0.16779195f, -0.17435174f, -0.03823943f, 0.25028124f, 0.09876777f, -0.02170571f, 0.08342040f, 
    0.14417395f, -0.09120026f, 0.05984991f, -0.08297729f, 0.06746429f, 0.12170056f, 0.10111211f, -0.03728049f, 
    -0.13683182f, 0.09428875f, 0.14756690f, 0.14187936f, -0.40005276f, 0.10999527f, 0.01358375f, -0.17424980f, 
    0.09936549f, 0.14361985f, -0.03277643f, -0.08959717f, -0.16206633f, 0.05875537f, -0.14012480f, 0.03056664f, 
    0.09020777f, 0.15828286f, 0.14405318f, -0.20612985f, -0.00189070f, -0.09355541f, 0.04113119f, 0.04213943f, 
    -0.24469787f, -0.21881615f, 0.21873952f, -0.14029026f, 0.27826139f, 0.42786995f, 0.06361339f, 0.16681311f, 
    -0.01142013f, 0.00148461f, 0.13735366f, 0.26222551f, -0.01081692f, 0.11859960f, 0.02552415f, 0.02215351f, 
    0.57235575f, -0.14207013f, 0.04926460f, 0.31969187f, -0.07670068f, -0.04673224f, 0.02466944f, 0.07332247f, 
    -0.12729028f, -0.05917966f, 0.03157370f, 0.09934097f, 0.03535483f, -0.10412341f, 0.06631224f, -0.00843131f, 
    -0.06823147f, 0.01076127f, -0.01483383f, -0.05878080f, 0.17211242f, -0.19222277f, -0.02126057f, -0.02376909f, 
    0.26592666f, -0.42461377f, -0.19996640f, 0.24310905f, 0.12195992f, 0.12304984f, 0.18642733f, 0.05079385f, 
    0.13461579f, 0.05915667f, 0.00969407f, 0.09933547f, 0.09685932f, -0.08362108f, 0.03429625f, -0.30015063f, 
    -0.08888248f, -0.04374743f, -0.13078791f, 0.01389225f, 0.10042395f, 0.14745061f, 0.05540220f, 0.16647878f, 
    -0.02181799f, -0.31872761f, -0.09155990f, -0.13864774f, 0.17586868f, 0.04183021f, 0.05659936f, 0.12335566f, 
    0.03582119f, 0.10489319f, 0.11834017f, -0.03310413f, -0.32348508f, 0.03191074f, -0.15001911f, 0.12673992f, 
    0.02049930f, -0.02108268f, -0.03733873f, 0.07256822f, 0.22539702f, 0.04381090f, -0.03570489f, 0.11012810f, 
    0.11055049f, -0.21793742f, 0.16453183f, 0.28355190f, 0.19002084f, -0.04243526f, -0.09607284f, -0.03114709f, 
    0.12222382f, -0.05886435f, -0.11914323f, 0.13272040f, 0.51563919f, -0.13710864f, -0.16796467f, 0.23899174f, 
    -0.01666708f, -0.21841180f, 0.20858973f, 0.00910192f, 0.05346040f, 0.02875740f, 0.10613836f, 0.00109489f, 
    0.06108709f, -0.05514119f, -0.00544952f, 0.07243345f, 0.09802581f, 0.19354947f, -0.10273616f, 0.05651079f, 
    -0.08264519f, -0.06231975f, 0.07892752f, -0.02050306f, 0.11863964f, 0.20186064f, 0.03335779f, -0.04891680f, 
    -0.04376201f, 0.07434412f, -0.01485705f, 0.03031605f, 0.15936770f, -0.03380365f, 0.02829138f, 0.03332536f, 
    -0.37549743f, -0.25765958f, 0.12691645f, -0.32594451f, 0.04095947f, -0.04225191f, -0.07736418f, -0.12079664f, 
    0.04292415f, 0.03776179f, -0.01961087f, -0.02488411f, -0.36058137f, 0.31633854f, -0.17899030f, -0.12655745f, 
    0.05848209f, 0.06632555f, 0.04742798f, -0.08786608f, 0.11427194f, -0.05159016f, 0.03343382f, 0.04796272f, 
    -0.03766206f, 0.15023102f, 0.06085284f, 0.02365212f, -0.08996966f, 0.08436414f, 0.17846215f, 0.01360080f, 
    -0.03598197f, 0.01794513f, -0.03661127f, 0.05371564f, 0.05712407f, -0.09194388f, -0.09236835f, 0.13205829f, 
    0.07337023f, -0.02588407f, -0.03112590f, -0.02031400f, -0.17357612f, 0.08969054f, 0.08630841f, -0.03793088f, 
    -0.26112676f, -0.37762672f, -0.01306562f, -0.19722548f, 0.02982571f, 0.03588126f, 0.00738485f, -0.01839179f, 
    0.02229873f, -0.09033841f, 0.03698982f, 0.09390184f, -0.22449709f, 0.12462974f, 0.03312301f, -0.01123408f, 
    0.18974288f, 0.02702748f, -0.04816819f, 0.04568085f, -0.13806762f, 0.04422345f, -0.06619912f, -0.09693316f, 
    0.28820115f, -0.06556537f, -0.18615232f, -0.07059295f, -0.09390407f, -0.09154618f, -0.09430379f, 0.12485632f, 
    0.01228131f, 0.06947769f, -0.06315999f, -0.07823865f, -0.03836304f, -0.10072409f, -0.19282651f, 0.00490827f, 
    -0.16983064f, -0.13358727f, 0.03496486f, -0.01812002f, 0.12152051f, 0.03594559f, 0.03083472f, -0.01579777f, 
    0.05328567f, -0.09821365f, 0.04275070f, 0.20720029f, -0.02611437f, 0.00172141f, -0.02036262f, 0.08216513f, 
    0.29867449f, 0.01912824f, -0.07461174f, 0.17549060f, 0.00812667f, 0.37771374f, 0.37043345f, -0.18399158f, 
    -0.18039958f, 0.19857328f, -0.23424874f, -0.02324963f, 0.04569041f, 0.03268950f, 0.02216973f, -0.14757127f, 
    -0.01209300f, 0.03394200f, -0.00460215f, -0.00954717f, 0.02251974f, -0.04052407f, 0.01906473f, 0.00422297f, 
    -0.02559794f, -0.01501427f, -0.05153661f, 0.03923014f, 0.04275290f, -0.02420156f, 0.02395665f, -0.03636062f, 
    -0.00899981f, 0.03435341f, -0.01756482f, -0.00428501f, -0.01029122f, -0.04492274f, 0.03097234f, -0.04981637f, 
    -0.00001926f, -0.01009645f, -0.05552805f, 0.01346416f, 0.02043618f, 0.02049423f, -0.00513729f, -0.04734840f, 
    0.04292560f, -0.02993346f, -0.02187490f, -0.02610843f, -0.01188366f, -0.02324084f, 0.00287407f, -0.01773111f, 
    0.01865415f, -0.01492792f, 0.00466505f, -0.02891196f, -0.02139975f, 0.00082886f, 0.03183261f, 0.04148373f, 
    0.00225320f, -0.01489173f, 0.03154217f, -0.05065311f, 0.03536128f, -0.01802636f, -0.04121824f, -0.01539789f, 
    0.00479175f, 0.03788053f, -0.04147535f, 0.00187873f, -0.01099249f, -0.04209740f, -0.00551634f, 0.01215677f, 
    -0.03100484f, 0.00387791f, -0.05533523f, -0.03551028f, -0.02750348f, 0.03641224f, 0.01584550f, -0.05319915f, 
    0.02338341f, -0.03920187f, 0.01452887f, -0.04733434f, 0.00820541f, 0.02028196f, -0.02469674f, 0.02369310f, 
    -0.03688504f, -0.04664110f, 0.00864291f, 0.03652592f, -0.05244677f, -0.03134006f, -0.04890795f, 0.02474735f, 
    0.00458501f, 0.03130863f, -0.00900476f, 0.03780116f, -0.02543351f, 0.04502241f, 0.00551568f, -0.04379085f, 
    0.04197435f, 0.02950075f, -0.00716438f, 0.03626887f, 0.00006227f, -0.02818968f, 0.00567295f, -0.00335828f, 
    -0.03566398f, 0.04017267f, 0.00776026f, -0.01748084f, -0.05477208f, -0.02051070f, 0.02889735f, -0.01820206f, 
    -0.04676129f, 0.02489089f, 0.01581788f, -0.02207418f, -0.02596743f, -0.01750758f, 0.00239531f, 0.03104625f, 
    0.00641330f, -0.00727907f, 0.02073358f, -0.03484711f, -0.02940324f, -0.04672878f, -0.01726990f, -0.01917250f, 
    0.00947339f, 0.04262928f, -0.01979529f, -0.05218107f, -0.04403470f, -0.05219328f, -0.05002681f, -0.00504482f, 
    0.01791565f, 0.00957153f, 0.01941103f, 0.04276957f, -0.01448899f, 0.00957342f, 0.01274291f, 0.00062205f, 
    -0.00884554f, 0.04102497f, -0.04134026f, -0.02670999f, 0.03136213f, -0.00517739f, 0.01791353f, 0.02301466f, 
    0.03970986f, 0.03037984f, 0.01755235f, -0.04397617f, -0.04918258f, -0.02835502f, -0.03569211f, -0.00267793f, 
    0.04075666f, -0.01842501f, 0.01707497f, -0.05263594f, -0.02147467f, 0.00776768f, 0.01484841f, -0.04230033f, 
    -0.05179122f, -0.01583043f, -0.03403905f, -0.00158466f, 0.01232352f, -0.03826448f, -0.02259827f, 0.01377228f, 
    0.02094647f, -0.00203211f, -0.03855608f, 0.00267567f, -0.02779242f, -0.05248163f, -0.00566582f, 0.03499506f, 
    -0.04280810f, 0.03513299f, 0.00181375f, -0.04177060f, -0.02496568f, -0.02704045f, -0.02203331f, 0.02588635f, 
    0.03045148f, 0.02234550f, -0.03701099f, -0.01583668f, 0.02082388f, -0.01602920f, -0.02206130f, 0.02053200f, 
    0.03212408f, -0.04379175f, -0.04704152f, -0.03666240f, 0.03981269f, -0.03589349f, -0.02036960f, -0.00617825f, 
    0.01267400f, 0.00108008f, -0.04669322f, -0.03718986f, -0.04734088f, 0.01546416f, -0.04151623f, -0.03609739f, 
    -0.03532379f, 0.01341251f, 0.03096835f, 0.03557728f, -0.01710839f, -0.00388163f, -0.05090189f, -0.03316962f, 
    0.01920186f, -0.04742066f, 0.04281174f, 0.02589262f, -0.01469213f, -0.04197198f, -0.03296916f, 0.02213235f, 
    -0.02497754f, 0.03245537f, 0.01634288f, -0.00455254f, 0.00130287f, -0.02226960f, 0.03225739f, 0.04148518f, 
    -0.02734650f, 0.02589701f, -0.04436153f, -0.00744966f, -0.00644579f, 0.03970683f, 0.01541820f, -0.00519629f, 
    -0.01992415f, -0.04992248f, 0.01712368f, -0.03104338f, 0.03507130f, -0.05438190f, -0.00959008f, -0.03493082f, 
    -0.00850448f, -0.02516861f, 0.02348562f, 0.00421940f, -0.02230817f, -0.04103436f, 0.01884714f, -0.00263784f, 
    0.01456045f, -0.03858481f, -0.02613677f, -0.03352059f, 0.02928607f, -0.04994082f, -0.02163670f, 0.01269411f, 
    0.01414131f, -0.03236115f, 0.01695079f, 0.02793819f, 0.00940723f, 0.00880512f, -0.02235346f, -0.03296242f, 
    -0.00148955f, -0.03116992f, -0.05062495f, 0.02916192f, -0.05319482f, 0.02194256f, -0.04942059f, 0.02672586f, 
    -0.04528895f, -0.02074322f, 0.00669622f, 0.00405381f, -0.04974787f, 0.00346137f, -0.03320164f, -0.03550815f, 
    0.01260454f, 0.00648470f, 0.00472466f, -0.00358341f, 0.02292678f, 0.04274061f, 0.03966619f, 0.00578035f, 
    -0.01314809f, 0.01244427f, 0.02388742f, -0.03929447f, 0.04433000f, 0.02015854f, -0.00578773f, -0.02077021f, 
    0.02870329f, -0.00975288f, 0.03010624f, -0.01750233f, -0.00518141f, 0.04105789f, 0.02043409f, 0.00092294f, 
    -0.00782000f, -0.03832622f, 0.03054385f, 0.02459322f, -0.00470097f, 0.00578900f, 0.01073715f, -0.03787088f, 
    -0.00579560f, -0.03565774f, 0.01093992f, 0.03853350f, 0.01749500f, -0.01946483f, -0.03858834f, -0.00197462f, 
    0.01172925f, -0.04760025f, -0.00621641f, 0.03451887f, -0.04375197f, -0.02715591f, 0.04708862f, -0.05072951f, 
    -0.05078411f, 0.00795676f, -0.03732467f, -0.00302972f, 0.02987669f, -0.03210428f, 0.01224712f, -0.03654349f, 
    0.02069920f, -0.03363219f, 0.00001497f, -0.04927156f, 0.01975101f, 0.01411578f, -0.01399232f, -0.03549424f, 
    -0.00237066f, -0.02840593f, -0.03322215f, -0.03932251f, 0.00388817f, -0.04053798f, -0.03450755f, -0.01795028f, 
    -0.03770679f, -0.02300916f, -0.04972452f, 0.03065446f, -0.01763204f, -0.05154525f, -0.05600568f, 0.00004959f, 
    0.00749368f, -0.00833864f, -0.01416438f, -0.01339692f, 0.04275131f, -0.00287506f, -0.05625296f, -0.03637421f, 
    0.26376560f, 0.13273542f, -0.04947544f, -0.17227049f, -0.03938166f, -0.06203802f, 0.00391341f, 0.00246721f, 
    -0.01454669f, -0.08058421f, 0.01909663f, 0.06189434f, 0.10984546f, -0.00864943f, 0.16126594f, 0.13271737f, 
    0.03172986f, -0.02892810f, 0.16013058f, 0.10814781f, 0.06793932f, 0.04287203f, 0.00977618f, -0.07027434f, 
    0.01318376f, 0.04370306f, 0.04521922f, 0.05240510f, 0.10698729f, 0.01782496f, 0.16384475f, 0.04010754f, 
    -0.14209157f, -0.06499796f, -0.09188099f, -0.03312998f, 0.03275519f, -0.08235049f, 0.15923865f, 0.01430482f, 
    -0.09039174f, 0.10666895f, -0.04693153f, -0.04741618f, -0.01056037f, -0.04532322f, 0.15549062f, -0.07348704f, 
    0.05118667f, -0.18828562f, -0.03619795f, -0.06548883f, 0.05985823f, 0.02188220f, 0.05059673f, -0.01743541f, 
    -0.06270985f, 0.01275107f, 0.07063911f, 0.04269765f, 0.12694408f, -0.27231827f, 0.21851921f, -0.14717840f, 
    -0.15494432f, -0.13378666f, -0.05500580f, 0.11035775f, -0.00770558f, 0.09382789f, 0.07608080f, -0.05947322f, 
    -0.15734711f, -0.02242158f, -0.05252150f, -0.02121280f, -0.03620370f, -0.03493020f, 0.12317580f, 0.14205156f, 
    0.07427155f, 0.06250484f, 0.03706390f, -0.06453929f, -0.18309344f, 0.15983254f, -0.14912318f, 0.18603176f, 
    0.07674016f, 0.10545183f, -0.00909902f, 0.04093603f, -0.04863289f, 0.01433449f, -0.10812216f, -0.21089269f, 
    -0.20253637f, -0.20119764f, -0.05794244f, 0.10001800f, 0.07806323f, 0.00280630f, 0.09326748f, -0.03209179f, 
    0.02429496f, 0.04687324f, 0.00003050f, 0.10957495f, 0.02867342f, 0.24733932f, 0.05758692f, 0.05571938f, 
    0.03320151f, 0.08283753f, 0.08890387f, 0.09499773f, -0.11990862f, -0.10726356f, -0.09289107f, -0.03548264f, 
    -0.23168376f, -0.20967670f, 0.00614610f, 0.08223133f, -0.05148697f, -0.11007006f, -0.02030605f, 0.10968816f, 
    0.03975642f, 0.14385223f, 0.24633460f, 0.09692023f, 0.49583682f, -0.12895431f, 0.05238231f, 0.03649326f, 
    -0.17485453f, -0.20121644f, 0.13022329f, 0.04786765f, -0.09416640f, -0.01846285f, -0.12086296f, -0.02157657f, 
    0.16424575f, -0.13933621f, -0.06332947f, 0.06727121f, 0.09607767f, 0.00037695f, -0.09143348f, 0.06985337f, 
    0.11017094f, 0.02385918f, 0.13430580f, 0.02796336f, 0.27135378f, 0.29011503f, 0.01643367f, -0.14839931f, 
    -0.12406351f, -0.12579738f, -0.03161401f, -0.18475455f, -0.09298130f, 0.07518883f, 0.00823638f, 0.19823168f, 
    -0.29379669f, -0.09621045f, -0.00619510f, -0.25558171f, -0.01347913f, -0.09487267f, -0.05083023f, 0.16019398f, 
    0.04408787f, -0.08937722f, 0.07494376f, -0.02849899f, -0.10520146f, -0.17887838f, -0.04776323f, -0.00939688f, 
    0.02260065f, 0.00942914f, -0.10983783f, 0.03236422f, -0.00974385f, -0.10150715f, -0.00138786f, 0.05644214f, 
    -0.12511331f, -0.09951475f, -0.13735890f, 0.13466652f, 0.00017821f, 0.10436657f, 0.01838004f, 0.11890399f, 
    0.09899138f, 0.11611201f, -0.06859168f, -0.04813288f, -0.09652348f, 0.11206064f, 0.11040434f, 0.04193417f, 
    -0.15458657f, -0.18746778f, -0.09775992f, 0.04865006f, 0.00921726f, -0.05142476f, -0.05363403f, 0.16422787f, 
    0.19173115f, 0.00686756f, -0.02789802f, 0.16119568f, 0.15413645f, 0.15644108f, -0.04123479f, -0.00181449f, 
    0.24924564f, 0.10269421f, 0.09873218f, 0.08995144f, -0.12852351f, 0.16314745f, -0.15880857f, 0.02351001f, 
    -0.06323465f, 0.08528835f, 0.01795635f, 0.05803825f, 0.01798679f, 0.00340612f, -0.14184132f, 0.05152398f, 
    0.10005070f, -0.00627680f, -0.04812928f, -0.31594512f, -0.06241345f, 0.03055299f, -0.02008547f, -0.19120236f, 
    0.04062750f, -0.10024243f, 0.21820453f, -0.08676696f, 0.22111149f, -0.10008138f, 0.06578519f, -0.07908274f, 
    -0.10273014f, -0.20026767f, 0.07696858f, -0.13959463f, 0.06126421f, -0.07752662f, -0.01414086f, -0.09492820f, 
    0.08999985f, 0.04484968f, 0.10686610f, 0.19728923f, -0.03652874f, 0.01500043f, -0.03854208f, 0.08188328f, 
    -0.02249330f, 0.20730153f, 0.04248851f, -0.03307083f, 0.60189313f, 0.23777685f, -0.07617781f, 0.26756397f, 
    -0.08493290f, -0.06421361f, -0.03756547f, 0.12223595f, 0.07323521f, 0.04830782f, -0.05055433f, 0.03826049f, 
    0.47117236f, 0.02593423f, -0.03637293f, -0.09181055f, 0.12782581f, 0.08822953f, -0.08953382f, 0.09810259f, 
    -0.03648892f, -0.13187170f, -0.10078385f, 0.00130092f, 0.25520116f, 0.22983846f, -0.02106602f, -0.09814306f, 
    0.03745738f, -0.01720608f, -0.02863767f, 0.00868925f, 0.11837482f, 0.14637019f, 0.02606574f, -0.10948647f, 
    0.06199971f, -0.08929522f, 0.03489511f, 0.23255724f, 0.10797565f, 0.10432386f, -0.00188690f, 0.14367950f, 
    0.01841780f, 0.03597742f, 0.02601941f, -0.00857054f, -0.01238094f, 0.01737568f, 0.19571877f, -0.00009167f, 
    0.00166652f, 0.14619687f, -0.05964153f, 0.12202317f, -0.08953967f, 0.06150714f, -0.14444949f, 0.05671253f, 
    -0.22964029f, -0.11407149f, 0.05596671f, -0.00586969f, 0.05719694f, -0.01015841f, -0.01864791f, -0.04180393f, 
    -0.06346575f, -0.05022957f, -0.03800340f, -0.11765534f, 0.22812456f, -0.10875507f, -0.03553753f, 0.11273285f, 
    0.06667331f, 0.03682691f, 0.03964757f, -0.07543639f, -0.02214349f, -0.04916548f, 0.02473781f, -0.18425520f, 
    -0.09051289f, -0.14265877f, 0.10790884f, -0.15585150f, -0.12479993f, -0.06621661f, 0.00629602f, -0.07176845f, 
    -0.03538610f, -0.17755337f, 0.18782163f, 0.02653811f, 0.05129878f, -0.04230065f, -0.12721892f, 0.02213192f, 
    -0.05297101f, -0.01548402f, -0.05711847f, 0.06475463f, -0.06453099f, 0.02486833f, 0.13769241f, -0.11089113f, 
    0.02073785f, 0.12342972f, 0.15986641f, 0.09974714f, -0.07321443f, 0.08208751f, -0.01960733f, 0.02410381f, 
    -0.04310284f, 0.05199284f, -0.21000448f, 0.07836651f, -0.10987067f, -0.07403854f, 0.11658122f, -0.22105010f, 
    -0.09989882f, -0.12907590f, -0.12234666f, -0.04990964f, -0.05765363f, 0.00721565f, -0.05567318f, 0.17192174f, 
    0.15055388f, 0.07749625f, -0.00675470f, 0.06019713f, -0.12204284f, -0.04059330f, -0.06836262f, -0.07914785f, 
    -0.12846285f, -0.00965561f, -0.02731474f, 0.02230981f, -0.01443350f, 0.03785257f, -0.15873827f, -0.04427740f, 
    -0.05114252f, 0.00648930f, 0.02630517f, 0.02963162f, -0.06784471f, -0.05900535f, -0.02972199f, -0.01836293f, 
    -0.14317629f, 0.17244650f, -0.10592300f, 0.19526337f, -0.10222332f, -0.02105678f, 0.06744630f, 0.04604517f, 
    0.08533067f, 0.00623858f, -0.14943986f, -0.01999066f, 0.17038047f, 0.14003195f, 0.22447483f, 0.21700881f, 
    0.11293281f, -0.09666623f, -0.02089735f, 0.04582222f, -0.02760039f, 0.04518311f, -0.00493267f, 0.02664892f, 
    0.13095471f, -0.02214443f, -0.05715833f, -0.02623926f, -0.07253729f, 0.00285033f, -0.09949225f, 0.04179815f, 
    -0.12062588f, 0.00450671f, 0.01747897f, 0.04867810f, -0.25893432f, -0.53577805f, -0.22108264f, -0.01609987f, 
    0.07276998f, 0.04345549f, 0.00073448f, -0.00310850f, 0.09631868f, -0.03638363f, 0.05055922f, -0.02560141f, 
    0.00215851f, 0.21760300f, 0.14212155f, -0.04411757f, 0.09046876f, 0.13891271f, -0.14203794f, 0.10846395f, 
    -0.01125098f, 0.04591134f, 0.10134183f, 0.07843762f, -0.35224050f, 0.15004726f, -0.11886741f, 0.05633746f, 
    0.16817746f, 0.07442374f, -0.11264033f, 0.06425953f, -0.13783671f, 0.17010544f, 0.06938672f, 0.06976905f, 
    -0.01341134f, 0.31976888f, 0.20266391f, 0.09065746f, 0.09255417f, 0.03202303f, -0.01599265f, 0.01618283f, 
    -0.23270378f, -0.11782804f, 0.06831668f, -0.04383984f, -0.19839518f, 0.39510098f, 0.23620585f, 0.30572140f, 
    -0.10363511f, 0.02431619f, 0.02066281f, 0.02090267f, -0.00413032f, -0.04798164f, 0.05563937f, -0.06052259f, 
    0.38647690f, 0.02796979f, 0.12458324f, 0.36043051f, -0.00865274f, 0.00033031f, -0.05943764f, 0.02567004f, 
    -0.06249941f, -0.02101661f, 0.00516883f, 0.01947333f, 0.17729858f, 0.02181344f, 0.19950303f, 0.04522321f, 
    0.00915385f, -0.08573754f, -0.03892325f, -0.00519597f, 0.08009942f, 0.05494355f, -0.06979735f, -0.04478062f, 
    0.40802827f, 0.16234131f, -0.13361381f, 0.22905467f, -0.02617155f, 0.00638767f, 0.05963572f, -0.12217002f, 
    0.08685668f, 0.09189186f, 0.09702484f, -0.09163073f, 0.35405311f, -0.09738193f, -0.10764809f, -0.09148658f, 
    -0.05284640f, -0.02525408f, -0.00877185f, 0.09852318f, 0.03890939f, 0.17734219f, 0.03593102f, 0.01195599f, 
    -0.05818373f, 0.23904479f, -0.18520555f, -0.15539920f, -0.05327260f, -0.00526791f, -0.04297848f, 0.06629853f, 
    0.07350157f, 0.18281530f, -0.00446264f, -0.01703187f, -0.08295684f, -0.12106783f, -0.09294531f, 0.11586010f, 
    0.13006756f, -0.00935779f, 0.04415826f, 0.10144459f, 0.01180593f, 0.10953423f, 0.05100753f, -0.09993815f, 
    -0.20524542f, -0.25590941f, -0.00112144f, 0.38959956f, -0.01946122f, -0.09132712f, -0.15658158f, -0.05073672f, 
    0.04180775f, 0.03489145f, -0.05170856f, 0.05254258f, 0.12376974f, 0.08736008f, -0.09625829f, 0.13107087f, 
    -0.16460972f, -0.00700453f, -0.01472687f, -0.12868282f, -0.00695440f, 0.16352484f, 0.06146536f, 0.13427970f, 
    0.38766363f, 0.02014750f, 0.10552789f, 0.06155626f, -0.00481340f, 0.00577818f, -0.07614892f, 0.06611992f, 
    0.06677047f, 0.01459642f, -0.09538336f, 0.11658446f, 0.15707448f, 0.05612956f, 0.19206120f, 0.18243153f, 
    0.00033389f, 0.06743092f, -0.06241382f, 0.13583302f, 0.01328234f, -0.02928817f, -0.02340745f, 0.14944188f, 
    -0.37204084f, -0.28945521f, -0.06050224f, -0.09101302f, 0.12589252f, 0.08008368f, 0.09530703f, -0.01968817f, 
    0.04438975f, -0.09342867f, -0.10890891f, -0.08989482f, 0.36135808f, 0.34055284f, 0.04649925f, -0.12981746f, 
    0.08891192f, -0.12262850f, 0.04641833f, 0.03800962f, -0.00899803f, -0.01223167f, -0.04188170f, 0.01945104f, 
    -0.07140131f, 0.31971720f, 0.06102043f, 0.11625572f, 0.12457172f, -0.07110506f, 0.02473274f, 0.11328146f, 
    -0.08497022f, 0.11887664f, 0.07426585f, -0.04593824f, 0.30493647f, -0.05662702f, 0.06975549f, 0.15216383f, 
    -0.06376126f, -0.02577688f, -0.12832595f, -0.12272625f, -0.05771010f, 0.04571482f, -0.04322853f, -0.06175949f, 
    -0.30435452f, -0.14246434f, -0.08954144f, -0.17343096f, -0.09414389f, -0.06019117f, 0.01309990f, 0.00011628f, 
    -0.02005312f, 0.04463358f, 0.02715972f, 0.06190543f, -0.24413925f, -0.11386728f, 0.04110334f, 0.19167696f, 
    0.00750052f, -0.02508406f, -0.00913933f, -0.02948885f, 0.06969710f, 0.02711324f, -0.00488627f, -0.02479102f, 
    0.30383465f, -0.24108779f, -0.00408203f, 0.39973286f, -0.10956547f, -0.04417393f, 0.02069466f, 0.00266665f, 
    0.02724449f, -0.09812614f, 0.01414377f, 0.10444824f, -0.19208877f, -0.25063321f, -0.29626513f, 0.48102283f, 
    -0.03442744f, -0.02552305f, -0.00992817f, -0.05826741f, -0.05571141f, 0.09032230f, -0.04144177f, 0.07336997f, 
    0.10931714f, -0.00479279f, 0.11941104f, 0.33515945f, 0.14476325f, 0.09540377f, 0.11354055f, 0.16615887f, 
    0.17274664f, 0.15729341f, 0.02654526f, 0.08575324f, 0.01636398f, 0.37677354f, 0.30125391f, -0.16173927f, 
    -0.05827255f, -0.02918058f, -0.12179246f, 0.00600324f, -0.10694455f, 0.08614967f, 0.02204973f, 0.10266764f, 
    -0.01817308f, 0.01307098f, 0.02255004f, 0.03194377f, 0.01824822f, 0.02516780f, -0.02823124f, -0.04847753f, 
    -0.04493788f, -0.03691666f, 0.03024394f, 0.01164789f, -0.03875474f, -0.01934135f, 0.02709902f, -0.02517286f, 
    -0.00097118f, -0.01897318f, 0.02069433f, 0.02496323f, 0.00697527f, -0.01005999f, -0.02188824f, -0.01854116f, 
    -0.01292781f, -0.04093532f, -0.02660978f, -0.02249546f, -0.01863206f, -0.05470228f, 0.04389304f, 0.02194924f, 
    -0.01232843f, 0.03379508f, 0.03830423f, 0.02891567f, -0.02075846f, -0.02102939f, 0.03519335f, 0.02972921f, 
    0.03647883f, 0.00140197f, 0.03800604f, -0.03835589f, 0.04132611f, 0.03600914f, -0.00773375f, 0.02942656f, 
    0.04296137f, -0.00972446f, -0.01118487f, -0.02736031f, -0.05596872f, 0.00745129f, 0.01929749f, -0.01776169f, 
    0.00119417f, 0.01365443f, -0.05261704f, 0.02180924f, -0.04580662f, -0.01374377f, 0.03056242f, -0.04929592f, 
    -0.04996960f, 0.00650715f, -0.01861478f, 0.00361058f, -0.04620785f, -0.04542027f, -0.00333326f, -0.00727732f, 
    -0.04168557f, 0.04234440f, -0.03643402f, -0.04549833f, -0.03929017f, -0.02666400f, -0.01276389f, 0.04111417f, 
    -0.00372386f, 0.02101643f, 0.04150909f, -0.00207623f, -0.03248550f, 0.03011388f, -0.04846062f, -0.05384241f, 
    0.03966776f, 0.01255292f, 0.04146732f, -0.00584771f, -0.02421614f, -0.05269620f, 0.02904002f, -0.03626662f, 
    0.01277914f, 0.02401575f, -0.04879837f, -0.01766606f, -0.04084207f, -0.03285154f, -0.02859459f, 0.02537344f, 
    -0.04430190f, -0.03097126f, 0.00457069f, -0.05171632f, 0.03008776f, -0.02141516f, -0.02209817f, 0.02610595f, 
    0.02535128f, -0.03717917f, 0.00616487f, -0.02951838f, 0.03177480f, 0.04841910f, -0.05325755f, -0.03527362f, 
    0.00016205f, 0.00146623f, -0.00873047f, -0.01474566f, -0.00386331f, 0.03683203f, 0.02913525f, -0.00693369f, 
    -0.02808213f, 0.04489741f, 0.04016412f, 0.03196117f, 0.00650207f, -0.03130865f, -0.05401113f, -0.01562694f, 
    -0.05103799f, -0.00784463f, -0.04820234f, -0.02576893f, 0.02120685f, -0.03952946f, 0.02723449f, 0.01219185f, 
    -0.01868955f, -0.03174113f, -0.02557559f, 0.04472296f, 0.01280941f, -0.05386433f, -0.02086085f, -0.05434497f, 
    -0.00727282f, -0.01153529f, -0.01226320f, -0.00342268f, -0.02516832f, -0.02287342f, -0.01841262f, -0.04214184f, 
    0.03787358f, -0.00445070f, -0.02805074f, -0.03783369f, 0.00408265f, -0.05466322f, 0.01707717f, -0.03909167f, 
    0.02266883f, -0.04807663f, 0.03780306f, -0.05336822f, 0.01671994f, 0.01632565f, 0.00829549f, -0.05449638f, 
    0.04431591f, -0.01520791f, -0.05530103f, -0.03565048f, 0.00695039f, 0.03278580f, -0.03734635f, 0.02132931f, 
    -0.01537226f, -0.03898555f, 0.00902880f, 0.03360850f, -0.04212028f, -0.04407377f, -0.04887890f, 0.03337330f, 
    0.02712166f, -0.00891724f, 0.01756620f, -0.02655071f, -0.00550428f, -0.00865676f, -0.02390893f, 0.01233781f, 
    0.03654924f, -0.02276413f, -0.05621293f, 0.03516899f, 0.02913977f, 0.02740062f, 0.03789693f, 0.02476323f, 
    0.03470643f, -0.00797420f, -0.01643512f, 0.00918893f, -0.00514283f, -0.01456803f, 0.00500560f, -0.02477929f, 
    -0.04413047f, -0.02849995f, -0.02646513f, -0.00439701f, -0.01445802f, -0.04382208f, 0.01640048f, -0.02189550f, 
    -0.03808170f, -0.04026834f, -0.02048623f, -0.00239848f, -0.02227783f, -0.05645148f, 0.03312042f, -0.04818518f, 
    -0.00024451f, -0.02636794f, -0.02384831f, 0.01082426f, -0.03558583f, -0.01115897f, 0.02376693f, -0.03699435f, 
    -0.00217872f, -0.02617957f, 0.03169551f, -0.05295764f, 0.01152356f, -0.03227128f, 0.00829093f, -0.02587873f, 
    -0.02541034f, 0.00489132f, -0.02699506f, -0.02105305f, -0.03279806f, -0.00347388f, 0.01810670f, 0.02171159f, 
    -0.02358384f, 0.02061819f, -0.03582099f, 0.01604603f, -0.01341757f, -0.02586873f, -0.05129599f, -0.00009155f, 
    -0.01761797f, -0.00773434f, -0.00946756f, -0.03370542f, -0.02540360f, 0.01868675f, -0.02347102f, 0.04320603f, 
    -0.03578780f, -0.03388309f, -0.02732790f, -0.00328759f, 0.02233311f, -0.03887495f, 0.00425218f, 0.01364825f, 
    0.03793155f, 0.02106374f, -0.04828005f, -0.04560355f, 0.00883844f, -0.04927492f, 0.04142611f, -0.01783306f, 
    -0.02617737f, 0.04323586f, 0.03340488f, 0.00000390f, -0.01836294f, -0.04301978f, -0.04691699f, 0.00264628f, 
    0.01886730f, -0.04559243f, 0.03807496f, 0.00646993f, -0.04802347f, -0.01741013f, -0.01860084f, -0.00233992f, 
    0.02098545f, -0.01228245f, -0.02434073f, -0.04243826f, -0.00591864f, -0.03410478f, 0.04415318f, -0.05499439f, 
    -0.03411823f, -0.00425002f, -0.03016974f, -0.03113685f, 0.03550769f, -0.05692685f, 0.01132838f, 0.00104310f, 
    0.02767446f, 0.04012249f, -0.02087307f, -0.05483077f, 0.04145556f, -0.02302526f, -0.05268887f, -0.04912472f, 
    -0.00215946f, 0.01050996f, -0.04414547f, 0.04116055f, -0.00209506f, 0.03258323f, 0.01467748f, 0.02054412f, 
    0.03979336f, -0.03874061f, 0.01042126f, 0.02641106f, 0.00485246f, -0.02217183f, 0.03511291f, 0.00748320f, 
    -0.00424023f, 0.00282712f, -0.04873407f, -0.01941295f, -0.04076963f, 0.03037760f, -0.00704962f, 0.02067202f, 
    -0.04559960f, -0.00385888f, -0.02106594f, -0.03615796f, 0.03765870f, 0.03470382f, -0.01722295f, 0.03308227f, 
    -0.04588331f, 0.03466000f, -0.00631686f, -0.00744489f, 0.03891266f, -0.02254423f, -0.02441053f, 0.00893906f, 
    0.03422294f, -0.05465993f, 0.02276041f, -0.05522814f, -0.00736390f, 0.03202579f, 0.03431173f, -0.02744443f, 
    0.02165551f, -0.02567570f, 0.03342401f, -0.01142192f, 0.03860461f, -0.00397067f, -0.04284641f, -0.01346035f, 
    -0.08064061f, -0.15275306f, -0.03168320f, 0.06098146f, -0.07849336f, 0.12333965f, 0.11640666f, 0.02026845f, 
    -0.06840946f, -0.02832846f, 0.06428099f, 0.11629859f, 0.02789346f, 0.13121477f, -0.00788558f, -0.08807221f, 
    0.05138671f, -0.05597012f, 0.21242742f, 0.06229599f, 0.14161144f, -0.00459017f, -0.04723381f, -0.06821140f, 
    -0.04765711f, -0.03923288f, 0.10093950f, -0.23634791f, 0.09536593f, -0.00397655f, -0.14544220f, -0.03054804f, 
    0.08435597f, -0.14339064f, -0.01471776f, -0.00011624f, -0.08508825f, 0.02697333f, 0.02082743f, -0.19271550f, 
    0.13030756f, -0.10683912f, -0.20494695f, 0.10649712f, 0.03982861f, -0.04111763f, 0.13703470f, -0.05242897f, 
    -0.20714258f, 0.18514869f, -0.03718001f, 0.35669246f, -0.01803043f, 0.26588050f, 0.18321139f, 0.01811199f, 
    0.04763336f, 0.01030320f, 0.08021597f, 0.13944606f, 0.18478811f, 0.13008921f, -0.26023775f, -0.05585399f, 
    0.16110843f, 0.16488567f, -0.07095700f, -0.01883623f, 0.04622055f, -0.01621117f, 0.10393072f, 0.09507173f, 
    0.26566327f, -0.07018866f, -0.05976076f, 0.00716530f, -0.02934893f, -0.04395554f, 0.11425251f, 0.06112277f, 
    0.02698787f, 0.01649880f, 0.10373794f, 0.11059713f, -0.32297274f, -0.17782065f, 0.25726011f, 0.11633993f, 
    0.02052141f, -0.00070198f, 0.10696440f, 0.10378528f, -0.03048905f, -0.08178288f, -0.08760276f, -0.12228068f, 
    -0.14725760f, -0.09259070f, 0.24693286f, 0.05741029f, -0.02438045f, 0.06044052f, -0.11621280f, -0.07039285f, 
    -0.01305388f, 0.02792739f, -0.03468074f, 0.10356673f, -0.09038121f, 0.48344892f, -0.07461112f, 0.18186992f, 
    0.06666008f, 0.11406124f, 0.09768814f, 0.04820902f, 0.00962162f, 0.13541703f, 0.08610953f, -0.07712159f, 
    -0.04370714f, -0.03136422f, 0.03856609f, -0.13013844f, -0.04512320f, 0.04249407f, -0.03942538f, 0.29816717f, 
    0.02703244f, 0.15706241f, -0.02902161f, -0.09472284f, -0.02008689f, 0.07041989f, -0.12406076f, -0.12974876f, 
    0.05202945f, -0.07283376f, -0.01652359f, -0.09985423f, 0.10928025f, 0.23493914f, -0.02380113f, -0.02431209f, 
    0.39190403f, -0.11155739f, 0.09518951f, -0.04262727f, -0.10788535f, 0.08814909f, -0.09252448f, 0.11925848f, 
    -0.08444820f, 0.07279143f, 0.03828005f, 0.03702052f, 0.01261742f, -0.09016120f, 0.04725713f, -0.07514565f, 
    -0.02532943f, -0.09163992f, -0.06337012f, 0.03044642f, -0.02702560f, -0.05942724f, -0.03261203f, 0.01229879f, 
    0.21151951f, 0.32151422f, 0.00337356f, 0.14535998f, -0.06973920f, 0.09565683f, -0.04567419f, -0.03388336f, 
    0.10408808f, -0.09357952f, 0.07787950f, 0.09158707f, 0.05872067f, 0.08238155f, -0.13441743f, 0.08768249f, 
    -0.10048229f, -0.10518785f, 0.09311665f, -0.00792147f, -0.00258450f, 0.02672356f, -0.11018347f, 0.11783017f, 
    -0.24721488f, -0.26110604f, 0.27969664f, -0.24961863f, -0.16386506f, 0.02362363f, 0.22058143f, 0.12653849f, 
    -0.06626737f, -0.13461351f, -0.01118361f, -0.02095931f, 0.01612782f, 0.32600594f, -0.00980149f, 0.03909932f, 
    -0.03080091f, 0.11744594f, 0.04631110f, 0.17823867f, -0.12269312f, -0.05077127f, -0.07758719f, 0.14121062f, 
    -0.25038782f, -0.05502513f, 0.34721655f, 0.28627929f, -0.13659306f, 0.12925304f, -0.07389831f, -0.06902888f, 
    -0.11093198f, 0.03850988f, 0.05605650f, 0.10932472f, 0.01562230f, -0.19676352f, 0.09794763f, -0.12478673f, 
    -0.03386943f, 0.10712352f, 0.21573611f, -0.02018431f, -0.10607526f, -0.04524262f, -0.07404761f, 0.08899070f, 
    -0.16051361f, 0.11450742f, -0.07725130f, 0.02163265f, -0.04091420f, 0.08744411f, 0.00795301f, -0.00412889f, 
    0.03503263f, -0.11043654f, -0.04599411f, -0.04183269f, 0.16417164f, -0.30177572f, -0.25232255f, 0.01009281f, 
    -0.10394307f, -0.03805270f, 0.01099435f, -0.00573989f, -0.09982387f, -0.04726667f, 0.17823766f, 0.06669951f, 
    -0.55182725f, 0.00168068f, 0.08387646f, 0.17508490f, -0.09487773f, 0.01243263f, 0.11135907f, -0.05395155f, 
    -0.13066687f, 0.06156537f, -0.10978770f, -0.00731970f, 0.23639157f, 0.07275075f, 0.24739280f, -0.30783761f, 
    0.00291085f, -0.09109269f, -0.03683056f, 0.00876116f, 0.07399251f, -0.00580706f, 0.01517211f, -0.00005289f, 
    0.17160162f, 0.26949495f, 0.15494244f, -0.12620689f, 0.08322050f, 0.09532241f, -0.03608036f, -0.10346617f, 
    -0.12028026f, -0.01386081f, -0.10130227f, 0.07723325f, 0.45678777f, -0.12957487f, 0.22862481f, 0.17028493f, 
    0.00345317f, 0.07189196f, -0.16411965f, -0.05018236f, -0.02445735f, -0.04283693f, 0.06213643f, -0.10619945f, 
    -0.06493397f, -0.41434932f, 0.09751133f, -0.07684146f, -0.12115753f, -0.10915952f, 0.13592681f, -0.03747129f, 
    -0.09088728f, -0.01931503f, 0.11235557f, 0.02109215f, 0.24225339f, -0.04483896f, 0.04705333f, 0.21297804f, 
    -0.12564397f, 0.12971771f, 0.02835392f, 0.09586852f, 0.13900951f, 0.26055631f, -0.11802095f, -0.12829626f, 
    0.30581805f, 0.21892659f, 0.05009608f, 0.28388795f, -0.08418257f, -0.07524039f, 0.12236048f, 0.13239700f, 
    0.10481060f, -0.08850031f, -0.11630264f, -0.03140045f, -0.02455932f, 0.24808905f, -0.02015432f, 0.17845201f, 
    -0.03536962f, -0.11181540f, 0.04231342f, -0.08837256f, 0.09497673f, 0.05121984f, -0.03761801f, -0.08963232f, 
    0.02314161f, 0.10687248f, -0.16399926f, 0.13958161f, -0.05012532f, -0.00293505f, 0.07498488f, -0.16681550f, 
    -0.08335168f, 0.07237092f, 0.14212987f, 0.16249482f, -0.08267831f, 0.03482386f, 0.15279330f, -0.05178491f, 
    0.01866060f, 0.00056827f, -0.00792687f, 0.09505496f, 0.02531794f, -0.01294097f, -0.01079533f, -0.11741464f, 
    0.01899648f, 0.02730110f, 0.02889276f, -0.01964740f, 0.03784218f, 0.01803384f, 0.00811292f, -0.00060728f, 
    0.02499347f, -0.01752294f, -0.05855175f, -0.02275383f, -0.03047497f, -0.04328949f, 0.02161430f, -0.02201230f, 
    -0.00334307f, -0.04660867f, 0.03720307f, 0.03386882f, -0.03837221f, 0.00883175f, -0.03084196f, 0.03431874f, 
    0.01407032f, 0.04088344f, 0.03774296f, 0.04085572f, -0.01009772f, 0.01316100f, 0.02152462f, -0.05776514f, 
    0.00824588f, -0.00353626f, 0.04276850f, -0.01556127f, -0.03842057f, 0.00092073f, 0.02281113f, -0.03945079f, 
    0.01831159f, -0.03212726f, -0.05469427f, 0.00434463f, -0.03505744f, -0.05592264f, 0.03156263f, 0.01861440f, 
    0.03950093f, -0.01193331f, -0.02285061f, 0.02570472f, 0.00055833f, 0.00672709f, 0.02227847f, 0.01153549f, 
    0.01546441f, -0.00523897f, 0.00755313f, 0.01413863f, -0.00688143f, 0.02724114f, -0.05383109f, 0.04233656f, 
    -0.04819358f, -0.00075292f, 0.02208090f, -0.03018022f, -0.01345065f, -0.05122048f, -0.05668364f, -0.04868689f, 
    0.03925654f, -0.03216757f, -0.02966074f, 0.04194329f, -0.04366433f, -0.05904070f, 0.00990368f, 0.00115654f, 
    -0.00972301f, -0.01169265f, 0.02279241f, 0.04274779f, 0.01790362f, -0.04637658f, 0.01117589f, 0.01137594f, 
    -0.04055494f, 0.04215912f, -0.04175636f, 0.01072803f, -0.05615415f, 0.03886718f, 0.04172741f, -0.03264435f, 
    0.02775559f, -0.05967451f, -0.03393945f, 0.03399581f, -0.03426631f, 0.03092350f, -0.04392847f, -0.04735047f, 
    -0.00438440f, -0.04649065f, 0.02732865f, -0.00228279f, -0.00571533f, 0.00829606f, 0.01292222f, 0.02406860f, 
    0.00417346f, -0.05108151f, -0.04730026f, -0.05413441f, -0.02562662f, -0.05486464f, -0.02516126f, -0.02691931f, 
    -0.01844519f, -0.02272548f, -0.01453950f, -0.03429965f, 0.02392229f, 0.01567486f, 0.03183868f, 0.03265034f, 
    0.02914696f, -0.00424231f, 0.02923875f, 0.01788941f, -0.01417691f, -0.03105725f, -0.04216711f, 0.02047874f, 
    -0.03387746f, 0.01906214f, -0.03696185f, -0.04818257f, -0.01265849f, 0.02918527f, 0.02715952f, 0.03089802f, 
    0.00420501f, -0.04028836f, -0.01401848f, -0.04502181f, 0.00030104f, -0.05254256f, -0.03534459f, 0.01966689f, 
    -0.03098420f, -0.05120995f, 0.03644996f, 0.01888897f, -0.01964143f, 0.00224381f, 0.00359171f, 0.01986776f, 
    0.03629212f, -0.02065674f, 0.01159853f, -0.03560215f, -0.00368949f, -0.03396223f, -0.01488419f, 0.00356909f, 
    0.02234122f, 0.01233585f, -0.05236349f, 0.01657045f, -0.04471724f, -0.04856797f, -0.05108218f, -0.03244755f, 
    -0.05409330f, -0.03855398f, 0.02190070f, 0.01752978f, 0.01956513f, 0.01984325f, -0.05079062f, -0.04258728f, 
    0.01278888f, 0.03814090f, -0.00331776f, -0.01357078f, -0.02659331f, 0.02598353f, -0.04891821f, 0.00282054f, 
    -0.03311336f, 0.02219890f, 0.02342644f, -0.04949552f, -0.03624415f, -0.04280148f, -0.02461736f, -0.05254164f, 
    0.03281502f, -0.02340055f, -0.02770737f, -0.01819533f, -0.03041877f, 0.03296091f, -0.05388109f, -0.03882797f, 
    -0.05734786f, -0.01662389f, -0.02137872f, -0.02753649f, -0.05945256f, 0.01262080f, -0.05350436f, -0.00744174f, 
    -0.04524138f, 0.03405750f, -0.00692194f, -0.01390428f, 0.04203763f, 0.02761897f, -0.02593346f, -0.02609965f, 
    -0.01858081f, -0.04850467f, 0.03639202f, 0.01402884f, -0.05094866f, -0.00324524f, -0.03554377f, -0.05757573f, 
    -0.01976331f, -0.00818706f, -0.00727757f, -0.02095908f, -0.02077335f, 0.01767025f, 0.00598545f, -0.01898097f, 
    0.01101921f, -0.03888106f, 0.03480889f, -0.01334445f, -0.02177095f, -0.00578966f, 0.01249909f, -0.04303534f, 
    -0.04801839f, 0.02343747f, 0.03518059f, 0.01144082f, 0.02973056f, 0.01692468f, 0.04206368f, -0.02563027f, 
    -0.00162199f, 0.00272997f, 0.02691879f, 0.03499749f, 0.04123455f, -0.01524648f, -0.00377250f, 0.00160526f, 
    -0.01552790f, -0.03828969f, 0.03641428f, -0.05577363f, 0.04359204f, -0.00716241f, -0.05304863f, -0.02368412f, 
    0.01848256f, -0.00079623f, -0.00973335f, -0.03114657f, -0.03923945f, 0.03176638f, 0.03531232f, 0.03222273f, 
    -0.03550520f, -0.02307327f, -0.04823334f, -0.03595500f, -0.04407550f, -0.03823027f, 0.01453819f, -0.05177078f, 
    -0.03121014f, -0.00305990f, -0.01513473f, 0.01181300f, -0.04617151f, -0.00503529f, 0.03283828f, 0.02642209f, 
    -0.00157280f, -0.00982739f, -0.00038193f, 0.03618487f, -0.03634357f, -0.01358972f, -0.04042786f, -0.03370893f, 
    -0.00288720f, 0.02706446f, -0.05491731f, -0.03595719f, 0.03389489f, 0.02925042f, -0.05555445f, -0.04783237f, 
    -0.05362798f, -0.01422609f, 0.02113312f, 0.02003046f, 0.02304345f, 0.02135976f, -0.00931541f, 0.01172374f, 
    -0.01010363f, -0.00806290f, -0.00798169f, -0.00770622f, 0.03412311f, -0.03089033f, -0.01266918f, 0.00496993f, 
    0.01104179f, 0.02993207f, 0.01857815f, -0.04579342f, 0.03717210f, -0.00300284f, 0.04191755f, 0.02366394f, 
    -0.01706702f, -0.01076394f, 0.01787759f, -0.03035080f, -0.00306504f, -0.04713012f, -0.01200266f, -0.00810809f, 
    -0.00024497f, -0.01127263f, -0.02921350f, 0.00666405f, -0.02814800f, -0.02924730f, -0.02136093f, -0.01572243f, 
    0.02507610f, -0.05221695f, -0.02709396f, -0.01998675f, -0.05159551f, -0.04312426f, -0.00702199f, 0.03980500f, 
    -0.04102502f, 0.02597234f, 0.01623281f, -0.03393143f, 0.00472782f, -0.04068108f, 0.03029462f, 0.03479131f, 
    0.04237318f, 0.03173722f, 0.04017838f, 0.01387334f, -0.02155951f, 0.02372144f, 0.03547191f, -0.01248983f, 
    -0.04568765f, 0.00838718f, -0.03914065f, -0.04984662f, -0.00408063f, 0.01514673f, -0.05556834f, -0.03630649f, 
    -0.04975043f, -0.05188913f, -0.04024582f, -0.03502857f, 0.00902310f, 0.03898169f, -0.03155508f, -0.01464156f, 
    0.02457064f, -0.03526531f, -0.02810552f, -0.00201840f, -0.04126235f, -0.05114574f, -0.01876973f, 0.03832169f, 
    -0.01384804f, 0.03156850f, 0.00423952f, -0.02814583f, -0.02858209f, -0.03064573f, -0.04317762f, -0.05851013f, 
    -0.03035911f, -0.00136984f, -0.00235599f, 0.03942094f, 0.01097365f, -0.04129651f, 0.02364075f, 0.02658982f, 
    -0.03193645f, 0.01825825f, -0.05090518f, 0.01040287f, -0.02290464f, -0.00602327f, -0.04407801f, -0.01571319f, 
    0.02949631f, 0.02942884f, -0.02457597f, 0.01334425f, -0.04256805f, -0.04483161f, 0.01109077f, 0.02457321f, 
    0.03589929f, 0.00719195f, -0.04129730f, 0.03027166f, 0.02265320f, -0.02520191f, -0.04658079f, 0.04284069f, 
    0.02540621f, -0.04030092f, 0.01460920f, 0.03674270f, -0.01385176f, -0.04255182f, -0.02992448f, -0.04886606f, 
    -0.01404655f, 0.00111915f, -0.03133607f, -0.00325011f, -0.01028982f, -0.02544133f, 0.02356305f, 0.00617417f, 
    -0.03797425f, -0.01113152f, -0.02370310f, 0.03637529f, 0.02587386f, -0.05695184f, -0.05103065f, 0.01544888f, 
    -0.01330703f, -0.01527165f, -0.03387207f, -0.01615936f, 0.04019503f, 0.03667928f, 0.00679018f, 0.04109350f, 
    0.02282796f, -0.00441727f, 0.03723223f, -0.00832860f, 0.04092228f, -0.04665277f, 0.03424007f, -0.00786784f, 
    -0.04021019f, 0.02701975f, 0.04256337f, -0.03564069f, -0.05561411f, -0.00208621f, 0.03789663f, 0.02638896f, 
    0.01892136f, -0.01724851f, 0.01287310f, -0.04645555f, -0.01011509f, 0.04401580f, -0.01123439f, 0.01906328f, 
    -0.04143829f, -0.01514505f, 0.04027666f, -0.04542067f, 0.04667910f, -0.04623355f, 0.04453082f, 0.00743808f, 
    0.03122540f, 0.00778598f, 0.00955838f, -0.04406874f, -0.02339056f, -0.00785872f, 0.02342854f, 0.02386778f, 
    0.01707455f, -0.04917977f, -0.04064825f, 0.02556811f, -0.05238750f, -0.00737104f, -0.03216437f, -0.00367404f, 
    -0.03340431f, 0.03197552f, 0.02223439f, -0.00189388f, -0.01808567f, 0.04759181f, 0.00666283f, -0.01676862f, 
    0.04095687f, 0.00394131f, -0.00850777f, -0.03622203f, 0.01853060f, -0.00909937f, -0.00615883f, -0.01862159f, 
    -0.04747057f, 0.02850391f, 0.04462780f, 0.01817883f, -0.01580627f, 0.04090890f, -0.00899929f, -0.04560242f, 
    -0.04559274f, 0.02494549f, 0.00172625f, -0.02358148f, -0.03398647f, -0.00390336f, 0.02920004f, 0.01920762f, 
    -0.04899466f, 0.02877666f, -0.05215808f, 0.02302370f, -0.04556147f, -0.03521248f, -0.00740948f, -0.00025737f, 
    -0.02727987f, 0.00419405f, -0.02651133f, 0.00315406f, -0.03791188f, 0.02171800f, 0.02083306f, -0.03610789f, 
    -0.00647480f, 0.03464583f, -0.01267928f, -0.04171596f, -0.00190432f, -0.03600652f, 0.03225032f, -0.00610471f, 
    -0.01272683f, -0.04600216f, 0.00517704f, 0.02209428f, -0.00591719f, 0.04065712f, -0.00113036f, 0.04154669f, 
    -0.00509171f, -0.02751601f, 0.05487149f, -0.02952709f, 0.02946926f, -0.00658686f, -0.03685440f, 0.03990416f, 
    0.02946448f, -0.04225798f, 0.02484871f, -0.04939937f, 0.02594259f, 0.03663857f, 0.02670779f, -0.05423564f, 
    -0.04935152f, -0.04763740f, -0.01844178f, -0.04006553f, -0.02238553f, -0.02891335f, -0.02854521f, -0.00683135f, 
    -0.03965550f, -0.02238779f, -0.04742223f, -0.01304885f, 0.04012749f, -0.04845240f, -0.00254457f, 0.02686066f, 
    -0.00600672f, 0.03679594f, 0.04847851f, -0.02131390f, -0.00869827f, 0.04023774f, -0.01894825f, -0.03766864f, 
    0.01170874f, 0.04060420f, -0.04465010f, -0.03441855f, -0.02859841f, 0.01581849f, -0.03314353f, -0.04719084f, 
    -0.05631338f, 0.03736735f, 0.01043516f, 0.01358242f, -0.04416363f, -0.01311655f, -0.05665198f, -0.03955661f, 
    0.04143983f, -0.01669727f, 0.00935222f, -0.00016455f, 0.04164281f, -0.00898571f, 0.01999753f, -0.04815893f, 
    -0.01674788f, 0.00382261f, -0.01128049f, -0.00006605f, -0.02044079f, 0.04057580f, 0.02212574f, 0.03805978f, 
    0.01528379f, -0.04404830f, -0.03514449f, 0.00341579f, -0.01176361f, 0.04228428f, 0.04656431f, 0.03569670f, 
    -0.04938804f, -0.00067079f, 0.01137092f, 0.03580280f, -0.00807842f, 0.03168573f, 0.01701149f, 0.00209187f, 
    0.02818234f, 0.01406637f, 0.00082272f, -0.02209360f, 0.00260251f, -0.04201215f, -0.02046990f, 0.02810524f, 
    -0.03246283f, 0.00338724f, -0.05813216f, -0.01643602f, -0.02421117f, 0.00827370f, -0.02538488f, -0.02133783f, 
    -0.03574428f, -0.00519957f, -0.02543639f, 0.01248174f, -0.04072516f, 0.02999602f, -0.01554975f, -0.04610617f, 
    -0.01815201f, -0.02219676f, 0.02863103f, -0.00060699f, -0.02893524f, 0.00618742f, 0.02174904f, 0.01928764f, 
    0.00136013f, -0.01657830f, 0.03702603f, -0.03273492f, 0.03709033f, -0.01145258f, -0.05222810f, -0.02306722f, 
    0.01200857f, 0.03503974f, 0.02745466f, 0.04027714f, -0.02229503f, -0.04262851f, -0.04423141f, 0.04509934f, 
    -0.05598246f, -0.01781751f, -0.01214777f, 0.01092454f, -0.04078986f, -0.03941810f, 0.01431158f, 0.01833487f, 
    0.02345234f, 0.04150691f, -0.02886649f, -0.03332839f, -0.04979230f, 0.00086672f, -0.01682434f, -0.03203753f, 
    0.02780884f, 0.03268090f, -0.03467670f, -0.02476056f, -0.01953439f, 0.02549240f, -0.00735242f, 0.03700363f, 
    -0.00343236f, 0.04690418f, -0.02579950f, -0.04556547f, -0.02972719f, 0.03913024f, 0.02923658f, -0.02318415f, 
    -0.00600289f, 0.01180622f, -0.01688392f, 0.00922452f, 0.02786580f, -0.02007694f, -0.01902635f, -0.05248864f, 
    0.00039366f, 0.00141403f, -0.05565645f, -0.00154014f, -0.01429616f, -0.05224882f, 0.01542005f, 0.00202634f, 
    -0.12911436f, 0.10375831f, 0.12203468f, 0.10308384f, 0.05005561f, 0.01361817f, -0.02014595f, 0.00309102f, 
    0.05726069f, 0.00674353f, 0.05916796f, -0.06540296f, -0.08168215f, -0.01824421f, -0.14642556f, -0.10601436f, 
    0.07735791f, 0.00427116f, -0.01303095f, -0.11048456f, -0.07501812f, -0.11714891f, -0.05158813f, 0.03774685f, 
    -0.02740455f, -0.03893158f, -0.00318129f, 0.09735426f, 0.01433725f, -0.05398378f, 0.06827547f, -0.00700172f, 
    0.12897037f, 0.03864190f, 0.02631707f, -0.02384596f, 0.26290056f, 0.03947432f, 0.05060984f, 0.05645581f, 
    -0.02956625f, -0.00021375f, 0.02216492f, 0.11049517f, -0.09546079f, 0.00457070f, 0.03666510f, 0.09069604f, 
    0.32100889f, 0.05014092f, 0.12226810f, 0.08216298f, 0.03289146f, 0.01862077f, -0.02870091f, 0.03796654f, 
    0.03904228f, 0.08102848f, -0.06701442f, -0.00419756f, -0.13074763f, 0.16051748f, 0.08150294f, 0.13612488f, 
    -0.10872842f, 0.04327005f, 0.04069335f, 0.07199112f, 0.01909816f, -0.07361063f, 0.00227571f, -0.01840718f, 
    0.20878458f, 0.13023156f, 0.01105449f, 0.20801823f, 0.05641241f, -0.06253930f, 0.03438355f, -0.07244135f, 
    -0.17781307f, 0.00795768f, 0.04652045f, -0.07671117f, 0.32474351f, 0.37673795f, 0.11434956f, -0.07337648f, 
    -0.02262660f, 0.05595396f, 0.01517639f, -0.02008422f, 0.00358728f, -0.11209100f, -0.05002829f, 0.00293477f, 
    0.01816467f, 0.17136821f, -0.09202136f, -0.11969072f, -0.01150095f, -0.09401743f, 0.03943561f, 0.09109236f, 
    0.02795936f, 0.04568447f, 0.02985930f, 0.06148841f, 0.15731409f, -0.32737064f, -0.15624312f, -0.06529371f, 
    0.02378482f, -0.11047794f, 0.12149627f, -0.04652016f, 0.18646641f, 0.11899849f, 0.04469791f, 0.04612477f, 
    -0.07668825f, 0.12408163f, -0.04908199f, -0.03341898f, 0.10374393f, -0.01385879f, 0.08328681f, -0.08261877f, 
    0.19026273f, 0.22699508f, -0.01359663f, 0.07477085f, -0.23719561f, -0.02237814f, 0.20347057f, 0.01218779f, 
    0.00298317f, 0.12695226f, 0.00212339f, 0.03366266f, 0.06342906f, -0.07656985f, -0.03949741f, 0.00460799f, 
    0.02458673f, 0.14241041f, 0.20271775f, 0.15173225f, 0.03969479f, -0.04705025f, 0.02849171f, -0.00562319f, 
    -0.00742209f, 0.11238808f, 0.01291363f, 0.07334346f, -0.24598718f, -0.03527132f, -0.10123531f, -0.00817533f, 
    0.11961774f, 0.09039808f, -0.00585378f, -0.00333753f, 0.00741867f, 0.02173985f, 0.00904932f, -0.05854383f, 
    0.31998035f, 0.05526839f, 0.12470948f, 0.18822211f, -0.00536227f, -0.08160727f, 0.10783036f, 0.06457391f, 
    -0.09802125f, 0.09732816f, 0.07426239f, 0.06823834f, 0.25880045f, 0.51874280f, 0.05420887f, 0.05130693f, 
    0.14390571f, -0.05335570f, 0.14345811f, 0.03488083f, -0.00115572f, 0.03196014f, 0.02632859f, -0.09231196f, 
    0.17548096f, 0.23544301f, -0.11845168f, -0.05554409f, 0.10249692f, -0.02266562f, -0.04416917f, -0.13502111f, 
    0.03421178f, -0.11684064f, -0.03386924f, 0.01915350f, 0.38469315f, 0.16337785f, 0.00087253f, 0.06622700f, 
    0.06781279f, 0.14713493f, 0.01454463f, -0.13899842f, 0.00800672f, 0.07844936f, 0.02006620f, -0.09688453f, 
    -0.04681004f, -0.01171203f, -0.09216619f, -0.23148675f, -0.12090294f, -0.20570731f, -0.01802635f, -0.02832348f, 
    -0.08337864f, -0.06270169f, 0.04730307f, 0.05990993f, -0.03369420f, -0.10699876f, 0.04429641f, 0.07194439f, 
    0.12946022f, -0.00389426f, -0.04110445f, 0.03368447f, 0.03011514f, -0.01818530f, 0.04320280f, -0.09474162f, 
    -0.12066904f, -0.06918507f, 0.00885383f, -0.09094343f, 0.01105802f, -0.01284922f, -0.06839228f, 0.01601490f, 
    -0.08859107f, -0.01358133f, -0.01868438f, -0.10877986f, -0.34086344f, 0.36082062f, 0.00888103f, 0.08522108f, 
    0.13423796f, 0.06325977f, 0.02391693f, 0.01010301f, -0.00769126f, 0.02871169f, -0.09222399f, 0.04828180f, 
    0.41307279f, 0.25921234f, -0.02676674f, -0.16567157f, 0.06209901f, 0.01001838f, 0.03296871f, -0.03016170f, 
    0.04130331f, 0.05973301f, 0.01576559f, -0.01041502f, 0.08654331f, -0.21601243f, 0.03116499f, -0.08019941f, 
    0.07961281f, 0.08210055f, 0.08012249f, -0.05515369f, -0.08512116f, 0.11169986f, -0.06232609f, 0.05154642f, 
    -0.49256784f, -0.09787709f, 0.07329494f, -0.09132142f, -0.09675241f, -0.14419626f, -0.10833818f, -0.05083753f, 
    0.05602875f, 0.01302776f, 0.13380738f, 0.04179479f, -0.47993815f, -0.15561883f, -0.14718774f, -0.09090915f, 
    -0.00992498f, -0.14733936f, 0.05495534f, 0.13923274f, 0.05943566f, -0.05923846f, 0.00952385f, 0.06890239f, 
    0.07271617f, 0.28327319f, -0.26353508f, -0.15497988f, 0.01934703f, -0.07197340f, 0.05326315f, -0.18547440f, 
    0.00311156f, 0.05107884f, -0.00143012f, 0.03315997f, -0.14331797f, -0.06721263f, -0.23380113f, -0.11171085f, 
    0.04844980f, 0.05340320f, -0.00697083f, 0.00604298f, 0.01846498f, -0.09661594f, 0.07781035f, 0.10896937f, 
    0.23515552f, 0.54196125f, 0.09422734f, 0.11238539f, 0.07327582f, 0.00742261f, -0.06529141f, 0.02145665f, 
    -0.01808099f, 0.02792556f, 0.06251944f, 0.06137067f, 0.32385430f, 0.39184394f, 0.26246578f, 0.16755293f, 
    0.01911468f, -0.02943813f, 0.02730271f, 0.00571667f, -0.06604158f, -0.00901387f, -0.09069686f, 0.14543174f, 
    -0.06567523f, 0.04615534f, 0.01654301f, -0.04340868f, -0.10906554f, -0.01656706f, -0.10990342f, 0.09080061f, 
    -0.01618695f, -0.02313018f, -0.03573568f, 0.04426683f, 0.06281314f, -0.13403133f, 0.05801474f, -0.14631915f, 
    -0.03939132f, -0.11721563f, 0.14479338f, -0.06953458f, 0.06550026f, -0.00770946f, -0.04355586f, 0.08147021f, 
    -0.05535422f, -0.05493649f, -0.05531477f, 0.01394471f, 0.04105679f, 0.01007196f, 0.01591337f, 0.04351718f, 
    -0.03498465f, -0.03967822f, 0.01898244f, 0.01887164f, 0.00719458f, 0.02586687f, -0.01886413f, -0.01780419f, 
    -0.00734816f, 0.02931509f, 0.04651960f, 0.00342008f, -0.03722423f, 0.00250607f, -0.04623036f, -0.03935848f, 
    -0.01656915f, 0.02991625f, -0.05475020f, -0.00479288f, -0.00880084f, 0.03805601f, 0.01755368f, -0.04054615f, 
    -0.03897648f, 0.01887020f, 0.02197031f, 0.03360260f, -0.00602567f, 0.03546207f, -0.00604370f, -0.02808606f, 
    0.02665986f, 0.00906860f, 0.00449880f, 0.00111109f, 0.00128974f, -0.04074012f, 0.01137449f, -0.05015067f, 
    -0.02846304f, -0.03208133f, 0.02382473f, -0.02858292f, 0.05216730f, -0.04278142f, 0.02295970f, -0.03015987f, 
    0.02327021f, -0.04406043f, 0.04245871f, 0.03667268f, -0.01075708f, -0.03386768f, 0.00563947f, -0.01308596f, 
    -0.02028877f, -0.02901166f, 0.00386727f, -0.03295402f, -0.00635157f, -0.04694446f, 0.03968808f, -0.05813213f, 
    -0.04670319f, 0.02863506f, -0.03198520f, 0.02420972f, 0.00317232f, -0.04352830f, 0.04600009f, -0.04532321f, 
    0.01193558f, -0.05355100f, 0.04145830f, -0.02111778f, 0.03150133f, 0.04656731f, -0.04599758f, -0.03996634f, 
    -0.04319737f, -0.03847234f, -0.01858323f, 0.02494376f, 0.00756925f, 0.03586343f, -0.02574243f, 0.00977043f, 
    -0.01159877f, -0.04241524f, 0.03137942f, 0.02530820f, -0.02577179f, 0.01375169f, -0.00052036f, 0.00522782f, 
    -0.05626437f, 0.02358659f, 0.01180518f, 0.01952044f, 0.01702412f, 0.02337585f, -0.00431713f, 0.03741896f, 
    0.03327754f, -0.05290681f, -0.01127704f, -0.01507945f, 0.04435011f, -0.01638369f, -0.00137097f, 0.04366988f, 
    -0.05523957f, 0.03197099f, 0.02342660f, 0.03409962f, -0.01052874f, 0.03641297f, -0.00679796f, 0.04096538f, 
    0.04229004f, 0.03318765f, -0.03877299f, -0.05792699f, -0.04005847f, 0.03356999f, -0.05126575f, 0.00203354f, 
    -0.00960677f, -0.02825279f, -0.04412673f, -0.04707563f, 0.01795545f, -0.04433904f, -0.05237735f, -0.02078394f, 
    0.03096136f, -0.00539277f, -0.01409757f, -0.00069376f, -0.03764087f, -0.02654777f, -0.00444409f, 0.02689692f, 
    -0.01353937f, -0.03058619f, -0.01655753f, -0.02528515f, -0.01994627f, 0.00122330f, 0.00797430f, -0.05245243f, 
    -0.00407572f, -0.04509060f, -0.02922482f, -0.04566860f, -0.03570938f, -0.05080695f, 0.03863842f, 0.01949205f, 
    -0.02128675f, 0.00613210f, 0.03140217f, -0.05426283f, -0.02251762f, 0.03950534f, 0.00372452f, -0.01441098f, 
    0.02503216f, -0.00842790f, 0.04561882f, -0.00174230f, -0.03690951f, -0.04050095f, -0.04466197f, -0.00096877f, 
    -0.01870595f, -0.02161502f, -0.03102624f, -0.02517173f, 0.03085232f, -0.05753924f, 0.02649933f, -0.01549506f, 
    0.03640485f, 0.02933619f, 0.01453885f, -0.04710464f, 0.03760710f, -0.02520213f, -0.04828975f, 0.00745866f, 
    0.02990052f, 0.02993599f, 0.01207286f, 0.03563824f, -0.00523897f, -0.01064127f, 0.01282965f, 0.00691426f, 
    -0.04716184f, -0.01668262f, -0.05398136f, -0.02223299f, -0.00050586f, 0.01709710f, -0.03780986f, 0.02911947f, 
    -0.00188900f, -0.03732488f, -0.00498447f, 0.03725205f, 0.02302394f, 0.03393794f, -0.05205353f, -0.00535997f, 
    -0.00797260f, 0.00256900f, 0.01002375f, 0.00373520f, -0.03953955f, 0.00043322f, -0.03342041f, 0.04562109f, 
    -0.00296280f, 0.01942427f, -0.03565577f, 0.00024803f, -0.02064262f, 0.02990040f, -0.00925693f, -0.01125128f, 
    -0.03148495f, -0.05437883f, -0.01582614f, 0.01638278f, -0.00836415f, -0.02938149f, -0.01733260f, 0.01863161f, 
    -0.00840929f, -0.00896167f, 0.03982102f, 0.00318052f, 0.03840626f, -0.01595940f, 0.04665839f, 0.00463005f, 
    0.02702458f, -0.03722500f, -0.00525705f, 0.00401560f, -0.01468172f, -0.05909928f, -0.05315858f, -0.02647918f, 
    -0.04236566f, 0.01263850f, -0.04763788f, -0.04957100f, 0.03705398f, -0.03145219f, 0.00971195f, -0.02446382f, 
    0.00724146f, -0.04362077f, -0.03715179f, -0.04277510f, -0.03914195f, 0.03490224f, -0.05478515f, 0.00018431f, 
    -0.01071782f, 0.02154358f, -0.04627317f, 0.00208986f, 0.02146694f, -0.04879370f, 0.02984033f, -0.03682344f, 
    0.00031221f, 0.03091044f, -0.03806045f, -0.01903813f, 0.00132803f, -0.03567084f, -0.02975033f, 0.03021862f, 
    0.03567953f, 0.01318142f, 0.04133042f, -0.04221819f, -0.04199931f, -0.01937498f, -0.02665886f, 0.01960596f, 
    0.04188239f, 0.01626928f, -0.00644021f, 0.00597544f, -0.05796440f, -0.03256743f, -0.04275728f, 0.03648330f, 
    -0.02544643f, -0.01448830f, -0.01892108f, -0.03794328f, 0.04236219f, 0.05179705f, 0.01451180f, 0.03564609f, 
    0.01493474f, 0.02198859f, -0.04512415f, -0.03202644f, -0.01558479f, 0.02130798f, -0.04754539f, -0.00765109f, 
    -0.05286518f, -0.02811250f, 0.00656499f, -0.03340524f, -0.00256801f, 0.03774453f, 0.01814259f, 0.03172176f, 
    0.03414000f, 0.04210093f, -0.05578525f, -0.03428017f, -0.05072279f, 0.01906007f, 0.01112498f, -0.00635521f, 
    0.00699172f, 0.03797810f, 0.00127102f, -0.03420306f, 0.02066482f, 0.01384086f, -0.00505830f, -0.00960311f, 
    0.01976294f, -0.05300520f, 0.00316687f, 0.02117223f, 0.00105165f, -0.00847697f, -0.05477615f, -0.05305877f, 
    0.01939472f, 0.00775072f, 0.02059265f, 0.03249130f, -0.03386841f, 0.01876882f, 0.04247186f, 0.03388729f, 
    -0.04992688f, -0.02294215f, 0.05038555f, -0.02811248f, -0.04594874f, -0.04358356f, -0.04889304f, -0.01856588f, 
    -0.00008070f, 0.01720997f, -0.04888736f, -0.05688315f, -0.01050859f, -0.02811285f, 0.02206802f, 0.02054522f, 
    -0.06050373f, -0.00924973f, 0.03939586f, -0.02774296f, -0.02467319f, 0.01051453f, 0.01564722f, -0.01580699f, 
    -0.05428976f, 0.02922477f, 0.01326627f, 0.04115277f, -0.01730793f, 0.03080961f, 0.04036909f, 0.03031126f, 
    0.01791186f, -0.04182006f, 0.03142611f, 0.02775652f, -0.00127425f, -0.04231884f, -0.00604959f, -0.00961917f, 
    -0.05341913f, 0.01397911f, -0.01902995f, -0.00444960f, -0.03907089f, -0.02053613f, 0.03946103f, 0.02604172f, 
    0.00383493f, 0.02273108f, 0.02887122f, -0.02114021f, -0.02147060f, -0.01501680f, -0.00886621f, -0.04661953f, 
    -0.05218127f, -0.00066682f, 0.00270253f, 0.00543844f, -0.03487468f, -0.02190268f, -0.03036667f, 0.00087296f, 
    0.03741623f, -0.01513996f, 0.03166360f, -0.01667442f, -0.05690660f, 0.02892743f, -0.01728785f, 0.02366581f, 
    -0.00724005f, 0.00479631f, -0.00296370f, -0.05728105f, -0.00894739f, -0.05422636f, 0.02040978f, 0.03833061f, 
    0.02627658f, 0.01951093f, -0.04619874f, -0.00223891f, -0.01130280f, 0.00086601f, -0.03745390f, -0.02041644f, 
    0.00511652f, -0.02263635f, -0.00824403f, -0.05608236f, -0.00460082f, 0.02660761f, 0.04153474f, -0.03237297f, 
    0.04234409f, -0.04288058f, -0.01786027f, -0.00953467f, 0.03661073f, -0.05658272f, -0.00396125f, 0.03505464f, 
    -0.02373711f, -0.03915982f, -0.05410030f, -0.00456950f, -0.05269592f, 0.03591624f, -0.03073962f, 0.01614751f, 
    0.01045603f, 0.02944771f, -0.05513966f, -0.01335105f, -0.01118204f, -0.02877080f, -0.03774700f, 0.01900442f, 
    0.04100656f, 0.02491135f, 0.03881747f, -0.03980501f, -0.02023065f, -0.01232605f, 0.00364604f, 0.02665494f, 
    0.00550953f, 0.02731489f, -0.05284950f, -0.01729700f, -0.04024819f, 0.01126312f, -0.02981843f, 0.02327039f, 
    0.00303724f, 0.01515277f, -0.00428830f, 0.00390518f, -0.02540849f, 0.01913477f, -0.01384094f, -0.03845102f, 
    0.00830270f, 0.01736401f, -0.05770188f, 0.02882777f, 0.02841992f, -0.01708841f, -0.02047683f, 0.02414560f, 
    0.01512176f, -0.03675591f, 0.02254969f, -0.06058229f, 0.03162916f, -0.03435102f, -0.00686014f, -0.05851220f, 
    -0.03476398f, -0.00985193f, -0.04232462f, 0.00689681f, -0.03740011f, -0.04287127f, 0.02113903f, 0.02732899f, 
    -0.01072992f, -0.04176359f, -0.03601916f, -0.00905981f, -0.02461194f, -0.01875529f, -0.03084612f, 0.01929984f, 
    0.01715790f, -0.03435945f, -0.04590536f, -0.03764130f, -0.02104520f, -0.01718111f, 0.01217099f, -0.01349397f, 
    0.01960120f, -0.00353840f, -0.04280251f, -0.04215919f, -0.04289388f, 0.00437489f, -0.02648691f, -0.05373143f, 
    0.02670573f, -0.04505717f, 0.03027078f, 0.02352169f, 0.03024904f, -0.03155466f, -0.01073496f, 0.01247415f, 
    0.00626258f, -0.03832101f, -0.04302529f, -0.00645483f, 0.04034085f, 0.00372584f, 0.01102202f, 0.03151315f, 
    -0.02808877f, -0.02882079f, 0.01043016f, -0.04534439f, -0.05868032f, -0.05733510f, -0.00493941f, 0.02141075f, 
    0.01018310f, -0.04178973f, -0.05825011f, -0.00756107f, 0.00435617f, -0.02828391f, 0.02662497f, 0.02261765f, 
    0.00920167f, -0.02526595f, 0.03681484f, 0.03094828f, 0.00656714f, -0.04683686f, -0.00207238f, 0.03185895f, 
    -0.02264513f, -0.02031947f, -0.03475530f, -0.04552554f, 0.03734154f, 0.02375070f, -0.00387958f, -0.04465995f, 
    0.02833161f, 0.03700237f, -0.00979936f, -0.00682589f, -0.03668548f, 0.01871145f, 0.02352510f, -0.00513416f, 
    -0.03159533f, 0.00979885f, 0.00287149f, -0.04360697f, 0.00323618f, 0.01345272f, -0.03778216f, -0.02434424f, 
    -0.05493005f, 0.01443613f, -0.01604588f, 0.01388239f, 0.02230240f, 0.02905251f, 0.02166415f, -0.03539526f, 
    -0.00007799f, -0.02306755f, -0.01072635f, 0.02549624f, -0.03910559f, 0.00475343f, -0.01448425f, -0.04011816f, 
    -0.03998157f, -0.04979899f, -0.04004666f, 0.02300458f, 0.01347605f, -0.03721905f, -0.04611827f, 0.03624924f, 
    -0.03627050f, -0.05949114f, 0.03598320f, -0.04224765f, -0.05519800f, 0.03768335f, -0.00450128f, -0.04524956f, 
    0.00599760f, -0.03896562f, -0.04630208f, 0.03814945f, 0.00698025f, 0.02474378f, -0.01873865f, 0.03649475f, 
    -0.04263708f, -0.00773887f, -0.05607186f, 0.00337596f, -0.04168781f, -0.00396242f, 0.03656618f, -0.04856950f, 
    0.01162987f, -0.03909584f, 0.00060973f, 0.02842550f, 0.03942031f, 0.04019278f, -0.01727369f, -0.02565277f, 
    -0.01807830f, -0.01855666f, -0.04372953f, -0.01906967f, -0.05751064f, -0.03159464f, -0.03428118f, 0.03548224f, 
    -0.04344655f, 0.02832204f, -0.01759355f, -0.04579360f, 0.01179757f, -0.02213965f, -0.02412644f, 0.01060301f, 
    0.00326789f, 0.01789081f, -0.02520255f, 0.01578693f, 0.02378534f, -0.05187181f, 0.00341530f, -0.04371417f, 
    0.03865837f, 0.02737552f, 0.01630123f, -0.03550485f, -0.04637438f, -0.00742685f, 0.00005785f, -0.00832312f, 
    -0.04087598f, 0.02547242f, -0.02636924f, -0.02395014f, 0.02644235f, 0.02694472f, 0.01790902f, -0.03157787f, 
    0.01257725f, -0.03431365f, 0.00340314f, -0.03827972f, 0.03285683f, -0.03606868f, -0.00260279f, -0.01105355f, 
    -0.03789312f, 0.00071904f, -0.02582707f, 0.01622722f, -0.01514059f, 0.01851574f, 0.03769214f, -0.03727124f, 
    0.03007382f, 0.02118744f, 0.00162451f, -0.04896739f, -0.04593233f, -0.04874143f, -0.04457828f, -0.00763862f, 
    -0.00439444f, -0.00313041f, -0.05523831f, -0.03306442f, 0.04026954f, 0.01721657f, -0.04929483f, -0.01196370f, 
    -0.05291239f, 0.01868796f, -0.04295677f, -0.02411309f, 0.01750825f, 0.03170986f, 0.02246849f, 0.01268836f, 
    -0.04942520f, 0.02477283f, -0.03690310f, -0.00386106f, 0.00672471f, 0.03802928f, -0.02199468f, 0.01750609f, 
    -0.22711958f, 0.13619614f, 0.20028719f, 0.13149120f, 0.07995695f, 0.23028299f, 0.07606505f, 0.07295042f, 
    -0.04687759f, 0.12620784f, -0.03197056f, 0.01228588f, -0.17230043f, 0.06142930f, 0.14462210f, -0.15503080f, 
    0.03310407f, -0.07895685f, 0.02155476f, 0.04305372f, -0.00796796f, 0.00745821f, -0.05187212f, 0.03514849f, 
    -0.15445375f, -0.19473818f, -0.20633850f, 0.11656756f, 0.07854735f, 0.08123854f, 0.04306374f, -0.04366942f, 
    0.03382360f, -0.15155044f, 0.13326561f, -0.10945138f, -0.38911131f, 0.15947261f, -0.17207778f, -0.13928738f, 
    0.04099843f, 0.04708724f, 0.06704766f, 0.07861242f, 0.10446616f, 0.01299970f, 0.00284721f, -0.03822428f, 
    -0.30896771f, 0.13481370f, -0.09185138f, -0.20299287f, -0.03471845f, 0.04807600f, 0.11771835f, 0.08244848f, 
    -0.04214844f, 0.02920370f, 0.00659437f, 0.15225445f, -0.05762413f, 0.22781803f, 0.03092665f, 0.14747788f, 
    0.05404613f, 0.14349590f, 0.02580879f, 0.13573334f, 0.00041090f, 0.01494291f, -0.00571751f, 0.01767415f, 
    -0.37877858f, -0.02100697f, 0.08608576f, -0.10605480f, -0.11869489f, 0.05356385f, 0.04496342f, 0.02313893f, 
    0.10870977f, 0.05002713f, -0.04844616f, -0.01156946f, 0.13004169f, -0.19797349f, -0.05019531f, 0.05867717f, 
    -0.09216692f, 0.00184421f, -0.06850894f, 0.00461524f, 0.03832619f, -0.01538446f, 0.01327326f, 0.01038428f, 
    0.27487999f, 0.17725521f, 0.02668793f, 0.26323202f, 0.06970029f, 0.11548170f, 0.05977684f, 0.05370635f, 
    -0.02754919f, -0.06852552f, 0.02563558f, 0.07074050f, -0.01728142f, 0.07323419f, 0.17006834f, 0.20464508f, 
    -0.02304550f, 0.14991266f, 0.06258903f, 0.13096738f, 0.12132503f, 0.15426837f, 0.10119489f, 0.06879814f, 
    0.10224321f, 0.09532500f, 0.16730013f, 0.25871676f, -0.01183666f, -0.00342989f, 0.08435542f, 0.24682643f, 
    0.11001726f, 0.14559117f, 0.06380560f, 0.04667697f, -0.45172837f, 0.13225745f, -0.01169342f, 0.02945319f, 
    0.06991193f, 0.00116181f, 0.03753447f, -0.05406679f, 0.04258276f, -0.05149996f, 0.00013318f, -0.03779624f, 
    0.06675109f, 0.13956550f, 0.06237948f, 0.11293157f, -0.05205444f, -0.02216234f, -0.01115453f, 0.02595272f, 
    -0.02257501f, -0.12936656f, 0.15937139f, 0.16030380f, 0.02428401f, 0.02119857f, 0.10678036f, 0.11525597f, 
    0.12206594f, 0.11835848f, -0.04508267f, -0.04685733f, -0.01364664f, 0.01629082f, 0.06244982f, -0.00519258f, 
    -0.07151346f, 0.07377015f, -0.16628772f, -0.09562685f, 0.10019260f, 0.08486995f, 0.11778820f, -0.04458261f, 
    0.11301663f, -0.18858443f, 0.05260742f, 0.06589432f, 0.08215351f, 0.15243958f, 0.00433030f, -0.15555245f, 
    -0.00412347f, -0.06078113f, 0.09038461f, -0.07290006f, 0.00138886f, 0.01267235f, -0.14251429f, 0.04649993f, 
    0.03705345f, 0.08695755f, 0.11864240f, 0.23627536f, -0.01635875f, -0.06880338f, -0.05478325f, -0.02962562f, 
    0.07620744f, -0.00259845f, -0.04295558f, -0.07150139f, -0.02471670f, -0.04215516f, -0.05037726f, -0.02743013f, 
    0.11701265f, 0.12056613f, 0.03803461f, 0.08237138f, 0.06413507f, -0.04099557f, -0.00170667f, -0.03235720f, 
    -0.09951995f, -0.01895972f, 0.03192162f, 0.33965540f, -0.04296346f, -0.16364528f, 0.00451925f, -0.14914541f, 
    -0.07153440f, 0.04306777f, 0.09330418f, 0.11999477f, 0.33733374f, 0.12272523f, -0.16760370f, 0.12152255f, 
    0.00196948f, -0.03613839f, 0.00831326f, 0.00391650f, 0.02994933f, 0.09871445f, -0.10585257f, -0.01544611f, 
    0.21280432f, 0.12607870f, 0.05689010f, 0.18684743f, 0.04014494f, 0.01798143f, -0.06791077f, 0.10747948f, 
    -0.05370220f, -0.05455188f, 0.07826708f, 0.02732846f, -0.00664650f, 0.10002884f, 0.04935005f, 0.07276959f, 
    0.00936476f, 0.08793292f, -0.00357104f, 0.19993944f, -0.05003403f, 0.03340419f, 0.08892079f, -0.07432103f, 
    -0.27413467f, -0.25755215f, 0.07935879f, -0.18082139f, 0.04568029f, -0.03089680f, 0.02846160f, -0.13622850f, 
    -0.03777986f, 0.16472065f, -0.04378335f, 0.04801253f, 0.10384379f, 0.14189927f, 0.01107509f, -0.05539112f, 
    0.06822481f, 0.08690280f, -0.00476593f, -0.09377171f, 0.03143172f, -0.02338781f, 0.04616965f, 0.10589195f, 
    0.05693839f, 0.15990163f, 0.06670041f, 0.25317851f, 0.09262663f, -0.01892443f, -0.05020321f, 0.17295229f, 
    0.05135851f, -0.01020797f, 0.01051631f, 0.12033528f, 0.08534661f, 0.08016637f, -0.08709638f, 0.27320474f, 
    -0.02879912f, 0.12653242f, 0.08972349f, 0.02848791f, 0.02129338f, 0.02947454f, 0.01665079f, 0.02919415f, 
    -0.35037860f, -0.12195817f, 0.16820133f, 0.10844219f, 0.04310240f, -0.03904330f, 0.04338102f, -0.13717683f, 
    0.06575566f, 0.03143937f, 0.17010035f, 0.04042743f, 0.31734580f, 0.02094807f, 0.00780716f, 0.04282920f, 
    -0.09282120f, -0.08340681f, 0.06767115f, 0.11656180f, 0.06005379f, 0.03405409f, -0.00491583f, -0.07845125f, 
    0.20568012f, -0.03354166f, 0.06119870f, 0.00096426f, -0.14026648f, 0.01486785f, -0.05694993f, 0.07447653f, 
    0.06929456f, -0.02553435f, -0.03523854f, 0.04128497f, -0.33779141f, 0.13338873f, -0.15305167f, -0.08160640f, 
    0.00403241f, -0.03298099f, -0.06544094f, 0.07975155f, 0.03310863f, 0.04117970f, -0.06776793f, -0.07188406f, 
    0.28308085f, 0.30922073f, 0.12659538f, 0.12376694f, 0.16460499f, 0.11839327f, -0.10650388f, -0.08926483f, 
    -0.06952842f, -0.01211320f, 0.05282099f, 0.05805442f, 0.07634600f, 0.27019334f, 0.22669518f, 0.10755748f, 
    0.08065676f, -0.03664428f, 0.10764207f, 0.11909870f, 0.00757733f, 0.06162275f, 0.02491098f, -0.07513260f, 
    0.03926422f, -0.01596310f, -0.03277618f, -0.04381074f, -0.02398829f, -0.01041377f, -0.04501870f, 0.02479618f, 
    -0.00981602f, 0.03821839f, -0.03867272f, -0.01685641f, 0.01882740f, 0.00904512f, -0.01719003f, -0.02005970f, 
    -0.01213351f, 0.03685892f, 0.01604155f, -0.05213541f, -0.01538498f, -0.05281488f, 0.04272908f, -0.04334478f, 
    -0.05367080f, -0.03886179f, 0.02462829f, -0.00883140f, 0.03714590f, -0.01012713f, -0.00495925f, -0.01946655f, 
    -0.03746854f, -0.02666269f, -0.05523032f, 0.01593283f, -0.04107071f, -0.03734180f, -0.00277713f, -0.01072872f, 
    -0.00674704f, 0.03323711f, 0.00217597f, 0.02355940f, -0.03968580f, -0.01598091f, 0.02084524f, -0.00817051f, 
    0.03746105f, -0.02491133f, -0.03079289f, 0.00374717f, -0.01907922f, 0.02805111f, -0.02018656f, -0.02431760f, 
    -0.02955377f, -0.01194578f, -0.05086387f, -0.05232651f, -0.00323526f, -0.01053744f, 0.01872949f, 0.00598475f, 
    0.01114584f, -0.05300434f, 0.02047665f, -0.05373681f, -0.01643167f, -0.03875468f, -0.05259286f, 0.01723695f, 
    0.03307063f, 0.00435635f, -0.00479926f, 0.03643297f, -0.05367637f, 0.02955069f, 0.03704299f, 0.00457475f, 
    -0.00255019f, -0.03254038f, -0.00733863f, -0.05034418f, -0.04395237f, -0.05498381f, -0.00093945f, -0.01128035f, 
    0.00312832f, -0.02763209f, -0.03373818f, -0.05612385f, 0.00221293f, -0.05377181f, 0.02660001f, 0.04079784f, 
    -0.04195787f, -0.05388738f, -0.04693387f, -0.03738128f, 0.01423604f, 0.02081577f, 0.03817072f, -0.00771017f, 
    -0.04675145f, 0.02798808f, 0.02103104f, -0.01863634f, -0.00381636f, -0.02537109f, -0.01343223f, 0.01780098f, 
    -0.02399186f, -0.02189673f, -0.00092803f, -0.02396213f, 0.01810997f, 0.03090891f, 0.04261009f, -0.04230285f, 
    -0.03316453f, -0.04184917f, -0.00615981f, 0.04063962f, 0.02044008f, 0.03854891f, 0.01238163f, 0.00505217f, 
    -0.05663798f, 0.00108963f, 0.00524091f, 0.01511277f, 0.03234634f, 0.03811153f, -0.03406442f, -0.03199446f, 
    -0.04409555f, 0.02332928f, 0.01021568f, -0.05478716f, -0.00344886f, 0.01076677f, 0.03197351f, 0.03187406f, 
    0.04477327f, -0.00989681f, -0.04541770f, -0.03913222f, -0.04747346f, 0.01804576f, -0.00623243f, -0.01175115f, 
    -0.01995596f, 0.02794641f, 0.00355440f, 0.00338828f, 0.01196780f, 0.00435427f, 0.03660772f, 0.02577556f, 
    0.00231484f, -0.01930661f, 0.04241714f, -0.03940535f, -0.03644153f, -0.02092727f, 0.04482667f, 0.01712424f, 
    0.03317833f, -0.04855050f, -0.03905701f, -0.01605812f, -0.02485971f, 0.03941485f, -0.03876403f, 0.01757805f, 
    -0.04115007f, -0.05331657f, 0.02022616f, 0.00347530f, 0.00297000f, 0.00445682f, -0.01809263f, 0.00664103f, 
    -0.02702102f, 0.01340661f, -0.03341113f, -0.04746556f, -0.03778907f, -0.00710878f, -0.05634505f, -0.04114785f, 
    -0.00154642f, 0.04211197f, 0.02503960f, -0.03366613f, -0.02543923f, -0.04744101f, 0.04409912f, -0.04363540f, 
    0.03272788f, 0.04270412f, 0.04284054f, 0.01998948f, 0.01201023f, 0.01899484f, -0.03011064f, 0.00091582f, 
    -0.01609900f, 0.01946474f, -0.01365110f, -0.00659658f, 0.04467846f, -0.01647096f, -0.04049483f, -0.02085439f, 
    0.03465629f, -0.01410564f, -0.05322937f, -0.01329783f, -0.02853350f, -0.05260119f, -0.04478214f, -0.02756350f, 
    0.02223782f, -0.03896271f, 0.04418578f, 0.03174187f, 0.03533087f, 0.03253828f, 0.01587455f, -0.00512405f, 
    0.02798815f, 0.01633574f, -0.00291443f, 0.03623665f, -0.03781846f, -0.02721747f, -0.05425253f, -0.04426691f, 
    0.03163623f, 0.04357535f, 0.00516270f, 0.03171878f, 0.01626265f, -0.01676166f, -0.04897227f, -0.03415244f, 
    -0.05233696f, -0.02263010f, 0.02325887f, 0.03980446f, -0.05446640f, -0.04336065f, -0.00817727f, -0.04879412f, 
    0.02090362f, -0.00555501f, 0.00966233f, -0.04845916f, -0.05152859f, 0.01256036f, 0.04448855f, 0.00370659f, 
    -0.01704181f, 0.02752045f, 0.03461226f, -0.02304639f, -0.05139070f, 0.02338446f, -0.01737102f, -0.01834691f, 
    0.02504066f, -0.01118341f, -0.00004853f, -0.00272039f, 0.03139661f, -0.05023459f, 0.04330871f, 0.01834021f, 
    0.02219767f, -0.01122834f, 0.01513285f, -0.04544084f, -0.04876185f, 0.02560483f, 0.00219184f, 0.02948575f, 
    -0.00868688f, -0.00610150f, -0.02519234f, 0.03488116f, -0.00982055f, -0.05702576f, 0.02765996f, -0.03061551f, 
    -0.03993044f, 0.04260320f, -0.00207216f, -0.05321795f, 0.01691796f, 0.01550557f, -0.04788065f, -0.05294237f, 
    0.03368196f, -0.05517019f, 0.03102122f, 0.00451500f, -0.05319618f, -0.05117293f, -0.03697918f, 0.01422994f, 
    -0.04691239f, 0.02640308f, -0.03422684f, -0.04385038f, -0.04096005f, 0.00449269f, 0.00524296f, 0.00445083f, 
    -0.01976315f, -0.04831851f, -0.02096074f, 0.01454682f, 0.01135224f, -0.01491546f, 0.00428995f, -0.01803305f, 
    0.02769900f, -0.04723273f, 0.04492116f, 0.01607673f, 0.01064055f, -0.02912537f, 0.00063488f, -0.00058537f, 
    -0.05247822f, -0.04147708f, 0.03749682f, -0.02489172f, 0.00189794f, 0.01958295f, -0.03220501f, 0.02434885f, 
    -0.05427106f, -0.05487727f, 0.03185704f, -0.00598513f, -0.02618472f, 0.00823619f, 0.00662603f, -0.00140929f, 
    -0.03052265f, -0.01073298f, 0.02402443f, 0.02410869f, -0.04040828f, 0.03952046f, 0.03264653f, -0.02685392f, 
    -0.04508115f, -0.00349168f, -0.01623485f, -0.00228687f, 0.00871311f, -0.03935267f, -0.03447559f, -0.04041864f, 
    -0.01412258f, -0.05059621f, -0.01977403f, -0.02072406f, -0.03400990f, -0.04416149f, -0.00814784f, -0.00818944f, 
    -0.05583453f, -0.04659079f, -0.00642866f, -0.00720166f, 0.03712594f, 0.04143831f, -0.04280115f, -0.00503295f, 
    0.63958913f, 0.20472698f, 0.12684727f, -0.16155656f, -0.11535251f, 0.00910516f, 0.04353028f, -0.06249635f, 
    0.01848024f, -0.08989656f, 0.01729659f, 0.00211250f, 0.27998307f, -0.28153735f, 0.02503664f, 0.18309836f, 
    -0.07595984f, -0.01874589f, -0.00500696f, 0.06667489f, -0.01452549f, 0.17070991f, -0.02380508f, -0.06038836f, 
    0.31576523f, -0.02394561f, 0.09205123f, 0.12020162f, -0.00788665f, -0.13151309f, 0.04631227f, 0.09092886f, 
    -0.09961279f, 0.02749625f, -0.02504027f, -0.00583419f, 0.31601307f, -0.02689757f, 0.18848203f, 0.09770410f, 
    -0.17590885f, 0.06584740f, -0.03255835f, -0.09843724f, -0.08867199f, -0.04274473f, -0.07510687f, 0.02774181f, 
    0.38148409f, -0.18905199f, -0.05388550f, -0.03347653f, 0.05654943f, 0.01349220f, 0.02613192f, -0.00828839f, 
    0.03761798f, 0.04411797f, 0.08907265f, -0.05669074f, 0.23111238f, -0.22090998f, 0.43458691f, 0.05846886f, 
    -0.24738266f, -0.05911059f, -0.09484549f, 0.15007000f, -0.07819205f, 0.12167987f, 0.13104481f, 0.01847175f, 
    -0.18588696f, -0.02321321f, 0.00225855f, 0.20786321f, -0.09753031f, -0.03067623f, 0.05264396f, 0.12613225f, 
    0.02472273f, 0.05670387f, -0.00905131f, -0.12431531f, -0.38727802f, 0.04790439f, -0.10342330f, 0.04591434f, 
    0.02696047f, 0.03471172f, -0.00536054f, -0.00831320f, -0.03515124f, 0.12132344f, -0.08957712f, -0.17544346f, 
    -0.24239752f, 0.12109236f, -0.16711795f, -0.01595646f, 0.02134631f, 0.00313762f, 0.05042052f, 0.01581394f, 
    -0.02223906f, 0.08373345f, 0.03963756f, 0.11871620f, 0.10397224f, -0.11951823f, -0.01187207f, -0.16831160f, 
    0.18456735f, 0.06864683f, 0.17729391f, -0.13502306f, -0.13776945f, -0.19018105f, -0.11717902f, -0.06787042f, 
    -0.10595575f, 0.06501418f, 0.05224077f, 0.00932730f, 0.06602877f, -0.15500781f, -0.02934736f, 0.08661838f, 
    -0.03854793f, -0.03280241f, 0.11973159f, 0.06366556f, 0.52830333f, -0.10192690f, 0.24650569f, 0.15867595f, 
    -0.16055508f, -0.02016094f, 0.03362761f, 0.10672089f, -0.05730742f, 0.01662872f, -0.07934625f, 0.03061029f, 
    0.09446951f, 0.00495988f, -0.01719358f, 0.07982141f, 0.12123656f, 0.04852780f, -0.03546567f, 0.00633505f, 
    -0.02247111f, 0.09992156f, 0.00966036f, -0.03721002f, 0.47362778f, 0.22437769f, 0.19678661f, -0.13357805f, 
    -0.04693239f, -0.00041182f, -0.04821834f, -0.12230465f, -0.00848717f, -0.16922015f, -0.06726176f, -0.01287195f, 
    0.17413977f, -0.08532027f, 0.14202344f, 0.01112325f, -0.06637537f, 0.05149906f, 0.10999852f, 0.09900305f, 
    0.05580259f, 0.10466652f, 0.03281626f, -0.01668353f, -0.05241242f, -0.06143626f, 0.03845612f, 0.06445345f, 
    -0.08096500f, -0.02505269f, -0.03519603f, 0.08181029f, -0.09753789f, 0.01925435f, 0.00714290f, -0.02098287f, 
    -0.10903721f, -0.01155811f, -0.27847779f, 0.06629214f, 0.14320746f, 0.01550590f, 0.01048656f, 0.05729861f, 
    -0.09295723f, 0.11302382f, 0.08574952f, -0.06064394f, -0.07453384f, 0.01259248f, 0.08514035f, -0.02451721f, 
    -0.04728812f, -0.14507046f, -0.09488443f, 0.05949516f, 0.09266526f, -0.00671273f, -0.08572557f, 0.03826086f, 
    0.02087927f, -0.04940198f, -0.03546805f, -0.14020298f, 0.13164218f, 0.14692965f, -0.13778247f, -0.00511863f, 
    0.19905718f, -0.02893079f, 0.02477589f, 0.05086245f, -0.14087336f, -0.06875049f, 0.08908566f, -0.11279816f, 
    -0.06080592f, 0.06831133f, 0.01215612f, -0.02521259f, -0.00873577f, 0.00455202f, -0.01356306f, -0.00079376f, 
    0.21310262f, 0.05250486f, -0.03389506f, -0.08921663f, 0.04107004f, 0.02107355f, -0.01013727f, -0.17226110f, 
    0.00609478f, -0.13457952f, 0.05542011f, 0.07317697f, 0.40399268f, 0.03703969f, 0.29626656f, 0.06006485f, 
    -0.21293904f, -0.05701122f, -0.00380984f, -0.10512032f, 0.15382263f, -0.05936133f, 0.02049998f, -0.14273132f, 
    -0.11006276f, 0.17065464f, -0.01319844f, 0.02210664f, -0.02295609f, -0.04637562f, -0.01085856f, 0.11132544f, 
    -0.00122022f, 0.07985789f, 0.07444114f, -0.09160282f, 0.40899107f, 0.22178279f, -0.32537585f, 0.09064911f, 
    -0.11465085f, -0.08905635f, 0.05812554f, -0.01481709f, 0.02390947f, 0.03955542f, -0.19193110f, -0.00926053f, 
    0.21881241f, 0.23913172f, 0.06534345f, -0.20425977f, 0.10469895f, -0.01923859f, 0.04304944f, 0.01577030f, 
    -0.11875461f, -0.10220506f, -0.01773432f, -0.03526754f, 0.22399309f, 0.19264427f, 0.08435018f, -0.20230187f, 
    0.03389322f, -0.06711114f, -0.09747198f, 0.04820069f, 0.08329424f, 0.07617752f, 0.10347205f, -0.01436262f, 
    0.06102381f, -0.00084805f, -0.07684729f, 0.09807594f, 0.01617425f, -0.01328842f, -0.06760680f, 0.15765485f, 
    -0.06530593f, -0.09941529f, 0.01566753f, -0.02676295f, -0.29383901f, 0.05572914f, 0.07706866f, -0.03161916f, 
    0.05437535f, 0.14814211f, 0.00703490f, -0.04506359f, -0.12912343f, 0.00500645f, -0.17158878f, 0.04827602f, 
    -0.01777160f, 0.03970594f, 0.04105648f, 0.04699824f, 0.06119940f, 0.09559796f, 0.04484612f, 0.03823465f, 
    0.00733168f, 0.03240380f, -0.00978191f, -0.12849440f, 0.06258383f, 0.03463120f, 0.08429359f, 0.03855579f, 
    -0.10440193f, 0.10789910f, 0.02067893f, -0.02789453f, 0.01188349f, -0.01917547f, 0.03092191f, -0.07626429f, 
    -0.09733877f, -0.08640647f, 0.21324597f, 0.04319744f, -0.27032775f, -0.06671029f, 0.00815442f, 0.06815221f, 
    0.02018541f, -0.08712150f, 0.13306683f, 0.08476021f, 0.21080668f, -0.01695327f, -0.09571309f, -0.14074260f, 
    -0.07422409f, 0.07820024f, -0.08705141f, 0.02190886f, -0.14598615f, -0.00620074f, 0.05797602f, -0.07906322f, 
    -0.04677669f, -0.05439264f, -0.03062768f, 0.03883533f, 0.04375437f, 0.00434601f, -0.04556552f, -0.04045779f, 
    -0.03894745f, -0.00159567f, -0.05364062f, 0.00887237f, -0.00575636f, -0.01013759f, 0.00378233f, 0.00408642f, 
    -0.04055886f, 0.02728940f, 0.00435637f, -0.03064567f, 0.01639164f, 0.03806618f, -0.04195946f, 0.00503673f, 
    -0.06138800f, -0.00022768f, 0.02151803f, -0.02297380f, 0.04428557f, 0.01302129f, -0.03597027f, 0.01883018f, 
    -0.02979183f, -0.04253349f, -0.04610193f, -0.00683928f, 0.04068285f, -0.02576262f, -0.00395811f, -0.01938610f, 
    -0.01607335f, -0.02924361f, -0.02911929f, 0.01466565f, -0.04420767f, -0.04675675f, -0.02379272f, 0.03646391f, 
    -0.00085718f, -0.01272332f, -0.03851910f, 0.01317269f, -0.01163291f, -0.01917261f, -0.02499565f, -0.02366226f, 
    -0.04397003f, -0.02006572f, 0.02609709f, -0.02637383f, -0.03294896f, -0.01394342f, 0.00701168f, -0.01668863f, 
    -0.01632906f, 0.01420249f, -0.00958283f, 0.02678299f, -0.05441178f, -0.03554511f, 0.02937782f, 0.02119194f, 
    0.03819558f, 0.00644673f, -0.02575107f, -0.00997939f, -0.00351192f, 0.01301435f, 0.02277345f, 0.02335728f, 
    -0.05582633f, 0.02126035f, 0.01005646f, -0.05640360f, 0.04154143f, -0.05465097f, -0.05942104f, -0.02452018f, 
    -0.01082327f, -0.01155788f, 0.04314719f, -0.04691617f, 0.01696969f, 0.02535863f, -0.01534476f, -0.01220081f, 
    -0.00046730f, -0.01181016f, -0.01889517f, 0.03083150f, -0.00208979f, 0.00771660f, -0.02768956f, -0.03008363f, 
    -0.04002371f, 0.01001402f, -0.03963250f, 0.01324102f, 0.01202709f, 0.00452737f, -0.01622047f, -0.00580614f, 
    0.02105911f, 0.03249874f, -0.02888786f, -0.01391046f, 0.03652371f, 0.03040827f, 0.01961906f, 0.03444638f, 
    -0.02503373f, 0.00678545f, 0.04707036f, -0.05325128f, -0.00979532f, -0.03851043f, -0.02459777f, 0.01528567f, 
    -0.02048879f, -0.02403561f, -0.03484702f, -0.04722739f, -0.02957819f, -0.05605187f, 0.02225020f, -0.01958112f, 
    0.03457930f, 0.03375789f, -0.03003809f, -0.03317003f, -0.03188798f, 0.03744083f, 0.01416290f, 0.02141628f, 
    0.02670055f, -0.01116612f, 0.00246532f, -0.00066229f, -0.05763771f, 0.04092442f, -0.02359922f, -0.05666146f, 
    -0.00521345f, 0.02903925f, 0.04416487f, -0.02122318f, 0.02809879f, -0.01914599f, -0.00421571f, 0.02779528f, 
    -0.00961518f, 0.01505406f, -0.04036386f, 0.02288115f, -0.00898322f, 0.02819060f, -0.02528055f, -0.01240015f, 
    -0.00355083f, -0.04826919f, 0.02094039f, -0.05623430f, -0.02498773f, 0.01755806f, 0.02732885f, -0.05298914f, 
    0.04791706f, -0.04493790f, 0.03679958f, -0.02356980f, -0.03827380f, -0.04824638f, -0.02919246f, 0.02101966f, 
    0.04252113f, 0.02993645f, 0.01330847f, 0.02184038f, -0.04050934f, -0.05589330f, -0.03763756f, -0.00724494f, 
    0.03169375f, 0.03420436f, -0.02853845f, -0.04875058f, 0.03755580f, -0.02314705f, 0.02773895f, -0.05301197f, 
    0.03395615f, 0.04020841f, 0.02171688f, -0.01104040f, 0.03002656f, -0.02237119f, 0.00436565f, 0.02200440f, 
    0.00722224f, 0.02448999f, -0.00306215f, 0.01239331f, 0.04229947f, -0.03532201f, -0.06177443f, -0.03359410f, 
    -0.02547942f, -0.02767051f, 0.01238432f, -0.01530400f, -0.04406034f, 0.02636903f, -0.01717388f, -0.00025224f, 
    0.01017235f, -0.02447465f, -0.04615885f, -0.01495642f, 0.02915500f, 0.02609691f, 0.02965809f, -0.03398728f, 
    -0.02528525f, -0.03796310f, 0.03171726f, -0.05523836f, 0.00510389f, 0.04287474f, 0.00025625f, -0.01639048f, 
    -0.02228653f, -0.04178903f, -0.04124264f, -0.04823634f, 0.00941057f, 0.01864764f, -0.00697987f, -0.00097575f, 
    0.03416876f, 0.00447099f, 0.03566033f, -0.03773456f, -0.05151258f, 0.02519522f, -0.01497053f, 0.03860456f, 
    0.03044569f, 0.01467809f, 0.02992785f, -0.02804227f, -0.05889577f, 0.03415963f, -0.04716509f, 0.02580277f, 
    -0.03398110f, -0.03644470f, -0.00123156f, 0.00889579f, -0.00254893f, -0.02679801f, 0.01223107f, -0.02279067f, 
    0.03162838f, -0.01510178f, 0.03260456f, 0.03145531f, -0.01756867f, -0.01945138f, -0.04256644f, -0.00422182f, 
    -0.01059077f, -0.02341004f, 0.01187046f, 0.03519849f, 0.02351967f, -0.00255307f, -0.02532029f, 0.03972938f, 
    -0.00625934f, -0.02655359f, 0.04014878f, 0.02572821f, 0.03660936f, 0.03383546f, -0.00332244f, -0.01240513f, 
    0.00346031f, -0.00846340f, -0.02438045f, 0.03315892f, 0.01058432f, -0.04834917f, 0.03911963f, 0.02168750f, 
    0.03387593f, -0.00311563f, 0.04093251f, 0.01038410f, -0.01220808f, -0.00963360f, -0.01336572f, -0.02004785f, 
    -0.05094536f, -0.00087447f, -0.04674380f, 0.02154933f, -0.01050855f, 0.00962859f, 0.03378178f, 0.01382065f, 
    -0.05167150f, -0.05144407f, -0.01487953f, -0.05770233f, 0.02554769f, 0.03078678f, 0.02667106f, 0.04424978f, 
    -0.03274474f, -0.03178944f, -0.05212132f, 0.00922374f, -0.01672138f, 0.01767895f, -0.03511929f, 0.00288976f, 
    -0.02259514f, -0.01112805f, 0.01747036f, -0.03119547f, 0.01551078f, 0.03536432f, 0.00370096f, 0.00270400f, 
    -0.00550517f, -0.02915533f, 0.01033565f, -0.02427330f, -0.01401687f, -0.01251359f, -0.04077442f, 0.02159912f, 
    -0.03316518f, 0.01012225f, 0.03611761f, -0.01348255f, -0.01986635f, -0.02553419f, -0.04649966f, -0.01375093f, 
    0.04278293f, 0.00417865f, 0.03231292f, -0.05604656f, -0.01351826f, 0.01608160f, 0.03248421f, -0.02679027f, 
    -0.05859635f, -0.00520254f, -0.05721401f, -0.01472448f, 0.02036923f, -0.01602468f, -0.05488279f, 0.00557084f, 
    -0.02338218f, -0.01515983f, -0.05091604f, -0.05085831f, -0.04510194f, 0.03137784f, 0.03072937f, 0.01639098f, 
    -0.00331012f, -0.03990170f, -0.14097713f, 0.14861779f, 0.07476793f, -0.14849800f, 0.03368913f, -0.01432195f, 
    0.10639515f, -0.05900047f, 0.00163963f, -0.08272267f, 0.13275808f, 0.17014225f, 0.05385802f, 0.01628763f, 
    -0.02032775f, 0.05764265f, 0.04470101f, -0.02225482f, -0.00753897f, -0.03071738f, 0.01708353f, 0.06870309f, 
    -0.03102367f, 0.32314456f, 0.30032608f, -0.26488546f, 0.04272250f, 0.01627318f, -0.07655044f, 0.10709090f, 
    0.03777066f, 0.16038790f, -0.13153484f, 0.14234766f, 0.17385389f, -0.53117085f, 0.16249362f, -0.01945847f, 
    0.13715756f, -0.08157591f, -0.09491306f, 0.08592981f, -0.04511531f, 0.01531335f, -0.04888164f, 0.06674060f, 
    -0.04633551f, 0.09416221f, -0.02065988f, 0.29100591f, -0.05678876f, 0.13563512f, 0.03525623f, 0.07291503f, 
    0.04623521f, 0.05466496f, -0.09730604f, -0.10659295f, 0.11193350f, 0.01338231f, -0.24983884f, -0.16481663f, 
    0.13167572f, -0.04956944f, 0.05216006f, -0.18867908f, 0.09140674f, 0.00764157f, -0.11078475f, 0.04107292f, 
    0.62597466f, -0.10111388f, -0.16938189f, -0.05230486f, 0.09535918f, 0.00015679f, 0.00446478f, -0.12763827f, 
    -0.11170845f, 0.01785560f, 0.04773178f, 0.12645724f, 0.03716291f, 0.26712474f, 0.10158015f, 0.22758000f, 
    0.08236875f, -0.11960725f, 0.06513446f, 0.11344088f, 0.14060135f, 0.10098984f, 0.08636927f, 0.10476620f, 
    -0.19412361f, -0.19383785f, 0.16122027f, -0.04904179f, -0.03214398f, 0.01638947f, -0.06973988f, -0.15253548f, 
    -0.04502003f, 0.04452262f, 0.09815313f, -0.05800564f, -0.13622464f, 0.27802777f, -0.11877439f, -0.01935789f, 
    0.03595779f, 0.06049424f, -0.08760408f, 0.02184038f, -0.07021715f, 0.04600915f, 0.04880624f, 0.05283454f, 
    -0.03203342f, -0.03913213f, -0.13598423f, -0.25770679f, 0.04474578f, 0.08192986f, -0.04932982f, -0.29315150f, 
    -0.07085314f, -0.04610672f, -0.03711635f, -0.04701847f, 0.22462083f, 0.06263626f, -0.21348628f, -0.15322202f, 
    0.09851741f, 0.15328299f, 0.15127407f, 0.08389813f, 0.03913993f, 0.02162541f, 0.02536169f, -0.09652562f, 
    0.50065815f, -0.32029808f, 0.20775957f, 0.09713271f, -0.02043825f, 0.10195003f, 0.03611295f, 0.07552794f, 
    0.08150325f, 0.06195895f, -0.09459130f, -0.12020071f, -0.25013614f, 0.06257773f, -0.04349378f, -0.01507179f, 
    -0.03975556f, -0.01726354f, 0.03304717f, 0.07286365f, 0.00319562f, 0.01678219f, 0.12211700f, 0.04455277f, 
    0.06496951f, -0.00661939f, 0.05078813f, 0.02253307f, -0.01130270f, -0.06706506f, -0.19129607f, 0.07235374f, 
    -0.01820595f, 0.15858944f, -0.19215485f, 0.01000227f, 0.18359977f, -0.20108028f, 0.03623470f, 0.09023492f, 
    -0.04256523f, -0.00853717f, -0.16728753f, 0.16352710f, 0.12183395f, -0.01336186f, 0.14483465f, 0.10665184f, 
    -0.11720549f, -0.14237428f, -0.08661002f, -0.14237691f, -0.03896088f, 0.00801806f, 0.13925546f, -0.01466013f, 
    -0.03847033f, 0.04604426f, 0.00708749f, 0.09847858f, -0.07207572f, 0.11266708f, 0.10164991f, 0.14221892f, 
    -0.01317058f, 0.01405708f, -0.06159307f, 0.06808163f, -0.09492199f, 0.06992357f, 0.03387878f, 0.03215073f, 
    0.25865129f, -0.01293945f, 0.18946460f, -0.01672170f, 0.01144600f, 0.05805299f, -0.07352788f, 0.23165086f, 
    -0.06799909f, 0.04929496f, -0.05149904f, -0.03666734f, -0.14259113f, -0.10057076f, 0.21209013f, -0.16076517f, 
    0.09897940f, -0.04243419f, 0.15404521f, 0.02499009f, -0.03793957f, -0.06338032f, 0.20823480f, 0.07404178f, 
    -0.22037451f, -0.05395081f, 0.03131416f, -0.10020856f, 0.11710697f, 0.13883004f, 0.08286624f, 0.08465781f, 
    0.07281363f, 0.19775480f, 0.01304400f, -0.00062191f, -0.12809975f, -0.05998809f, -0.11921306f, -0.11797997f, 
    0.17754959f, 0.00095437f, 0.04011409f, 0.00348820f, 0.02516032f, 0.06607451f, -0.13660753f, 0.16229200f, 
    -0.15315486f, 0.04290596f, -0.05396641f, 0.23982613f, 0.00852135f, 0.01900438f, 0.03263090f, 0.14218993f, 
    0.08824897f, -0.08551143f, 0.05816047f, -0.02444133f, -0.19970027f, -0.26855147f, 0.24253595f, -0.02317888f, 
    -0.07883158f, -0.01808088f, 0.09510318f, 0.18648121f, 0.08962686f, 0.02590836f, 0.01931399f, -0.11087476f, 
    0.05026267f, -0.10591817f, 0.14996241f, 0.09964111f, 0.03605945f, 0.08856228f, 0.12379801f, -0.21791206f, 
    0.00046199f, 0.12922166f, 0.13735411f, -0.00812137f, 0.12664717f, -0.10585098f, 0.16723412f, -0.02321587f, 
    0.14634396f, -0.00523892f, -0.01526709f, -0.00184222f, -0.13321728f, 0.03342355f, 0.06795470f, 0.09988012f, 
    0.28941485f, -0.12067377f, -0.21685740f, -0.18235256f, -0.00407883f, 0.02628456f, -0.00387141f, 0.07135076f, 
    -0.11339419f, -0.03739183f, -0.15427659f, 0.02759586f, -0.39094427f, 0.07235891f, 0.03082736f, 0.07583324f, 
    0.16867825f, 0.07937925f, -0.10867239f, 0.01140564f, -0.01013379f, 0.02358815f, 0.05982419f, 0.09275888f, 
    0.12649229f, 0.11882472f, 0.00631369f, 0.12910803f, 0.04055557f, -0.02762773f, 0.09185473f, -0.08765392f, 
    0.05795559f, -0.03301016f, -0.00470415f, -0.05530367f, 0.39381149f, -0.27912125f, 0.04122429f, 0.29891467f, 
    -0.03589209f, -0.01940948f, 0.05350702f, -0.09563052f, 0.09201069f, 0.00972213f, -0.00555082f, 0.21041121f, 
    -0.01834862f, -0.17563857f, -0.21601595f, -0.02484687f, -0.06690942f, -0.03522799f, 0.06214850f, 0.11220402f, 
    0.12606032f, 0.04505787f, -0.18744975f, -0.06617198f, -0.23050760f, -0.10916632f, 0.06304840f, -0.03237790f, 
    -0.03639860f, 0.04003719f, -0.08883956f, -0.00702344f, 0.05016243f, -0.08524532f, -0.01619418f, 0.04652051f, 
    -0.18734364f, 0.07209665f, 0.09217221f, -0.00725256f, 0.06144561f, 0.09905075f, 0.02320257f, 0.11574911f, 
    0.01473579f, 0.04154980f, 0.09116822f, 0.01508291f, -0.08074668f, -0.02183898f, 0.12332117f, 0.04331597f, 
    0.08758970f, 0.02910255f, 0.02586342f, 0.11544798f, -0.05194352f, -0.07442313f, 0.05121355f, -0.08998170f, 
    -0.07751545f, -0.22231403f, -0.22764726f, 0.21634018f, 0.07859448f, -0.04816301f, 0.22702686f, 0.01649925f, 
    0.09698243f, -0.11393060f, 0.13451689f, -0.09813269f, -0.23496085f, 0.26665884f, 0.01685553f, -0.00473173f, 
    0.01811475f, 0.06627566f, 0.04620563f, -0.06834878f, 0.08862340f, -0.00985019f, -0.00636228f, 0.06219184f, 
    0.16320957f, -0.08321007f, 0.13379873f, -0.36561295f, 0.08233432f, -0.07661189f, 0.01050593f, 0.07317056f, 
    0.00623011f, 0.07883330f, 0.06342094f, 0.06771078f, -0.36479938f, -0.05429679f, 0.03287806f, 0.07692535f, 
    -0.14504743f, 0.08639643f, 0.00824505f, 0.06794101f, -0.00878731f, -0.03776729f, 0.00784231f, 0.07037802f, 
    -0.44349730f, 0.09387124f, 0.18162353f, 0.01975197f, -0.00275144f, 0.08804483f, 0.17929918f, 0.00017958f, 
    0.11490696f, -0.03236379f, -0.02512366f, -0.08830569f, 0.13110428f, 0.15891811f, 0.04913597f, 0.06045887f, 
    -0.05859296f, 0.03539836f, 0.01275553f, -0.06273524f, -0.04141899f, -0.06943368f, 0.00501755f, -0.06511351f, 
    0.13496642f, 0.07277390f, -0.17581587f, 0.14036311f, -0.06738768f, -0.08662836f, 0.09105191f, 0.08794060f, 
    0.04672992f, -0.00609467f, 0.00666293f, 0.06728241f, 0.29450649f, -0.23953152f, 0.15079974f, -0.07550004f, 
    -0.06307042f, -0.00419349f, 0.13555948f, 0.04686229f, 0.14220309f, 0.00312236f, -0.05191945f, -0.02299115f, 
    -0.01427181f, -0.19331624f, -0.01153062f, 0.30373564f, -0.00345321f, 0.00080033f, 0.14845221f, 0.11138069f, 
    0.26708913f, 0.14246342f, 0.02801286f, 0.10942735f, -0.29741186f, -0.22935623f, 0.02275051f, 0.06757969f, 
    0.03415856f, -0.03031681f, 0.02540201f, 0.00438742f, -0.03005585f, -0.07532016f, 0.01652601f, -0.01509560f, 
    -0.38825604f, 0.14713891f, -0.11256344f, -0.19709453f, 0.14824557f, -0.04648364f, 0.05387652f, -0.04964791f, 
    0.14449468f, -0.08262673f, 0.07464333f, 0.12231970f, -0.11286815f, 0.01548343f, 0.00429864f, 0.02087514f, 
    0.08287706f, 0.05600218f, 0.01596615f, 0.00293350f, -0.09136193f, 0.07933036f, 0.11205681f, 0.07561477f, 
    -0.36951959f, -0.04438162f, -0.03390398f, -0.20458923f, 0.04787670f, -0.00578374f, 0.14951885f, 0.08242329f, 
    -0.04189042f, -0.11657089f, 0.11075991f, 0.13169862f, -0.20636460f, 0.28565261f, 0.19358586f, -0.03326075f, 
    0.16743606f, 0.07669406f, 0.11332203f, -0.18187821f, 0.01879504f, -0.09647414f, -0.11498027f, -0.08705256f, 
    0.25789049f, 0.12230092f, 0.05183629f, 0.36871696f, 0.01906323f, -0.01823193f, -0.12522186f, -0.07212970f, 
    0.08197557f, -0.06515525f, -0.07012512f, -0.03227383f, 0.09118608f, 0.06095258f, 0.06964989f, -0.11753013f, 
    0.02969648f, 0.02807455f, 0.00789021f, -0.05420012f, 0.05220227f, -0.01953014f, -0.02427826f, 0.01171309f, 
    -0.03371382f, 0.10528935f, -0.09334923f, -0.11348139f, -0.01002751f, -0.09347109f, 0.12558793f, -0.06891025f, 
    0.10214891f, -0.07304970f, 0.09788615f, 0.07464039f, 0.09717006f, 0.03281038f, -0.20165668f, 0.19755009f, 
    0.06941254f, 0.04317130f, -0.06653578f, 0.06130453f, 0.07920093f, -0.01741426f, -0.13576935f, -0.04970264f, 
    0.01315062f, 0.04311118f, -0.00639699f, 0.01233782f, -0.09064522f, -0.04578503f, -0.02201964f, -0.01164356f, 
    -0.16858672f, -0.01149622f, 0.13155426f, -0.04629271f, -0.18009026f, 0.09137710f, 0.03541777f, 0.06045344f, 
    0.01072601f, -0.04007382f, 0.00665621f, 0.11870126f, -0.01641854f, -0.04297144f, -0.01161465f, -0.15309839f, 
    0.37398350f, -0.00927682f, 0.08004869f, -0.09252250f, 0.05121166f, -0.04635683f, -0.04990576f, -0.01607859f, 
    0.02277410f, 0.13041002f, 0.04562500f, 0.06529340f, -0.03857243f, -0.05668940f, -0.15569875f, 0.01138922f, 
    0.01691227f, 0.13306147f, -0.09807339f, -0.03262144f, -0.03791524f, -0.00165616f, 0.00227445f, 0.05768883f, 
    0.01676477f, -0.09942932f, -0.01780717f, 0.03221256f, -0.06668004f, -0.09217958f, -0.04773572f, 0.09837134f, 
    0.02288566f, -0.14921361f, -0.00074394f, 0.03096641f, -0.31128365f, 0.18368095f, -0.28111804f, -0.05864433f, 
    0.01178773f, 0.03168059f, 0.09145816f, 0.10064160f, 0.14846142f, -0.00152626f, -0.01625545f, 0.02511202f, 
    -0.06263186f, 0.20046917f, 0.10090302f, 0.26249298f, 0.13272452f, -0.00549708f, 0.07420414f, -0.08006846f, 
    0.12154238f, 0.06847301f, 0.09636153f, -0.10897779f, 0.37345281f, 0.05869745f, -0.01452562f, -0.13314335f, 
    0.03656092f, -0.09302654f, 0.03839158f, 0.09570307f, 0.03636034f, -0.06289983f, 0.00277548f, 0.05240814f, 
    -0.15590230f, 0.13426602f, 0.15608831f, -0.31318086f, 0.01944796f, 0.08223059f, -0.04714596f, 0.02038926f, 
    0.00696672f, 0.12478104f, 0.04852246f, 0.05631830f, -0.07924353f, 0.32332280f, 0.19625209f, -0.36779287f, 
    0.09709351f, 0.03326357f, -0.06677283f, 0.13940926f, -0.02355398f, -0.03328068f, 0.01872082f, -0.06543127f, 
    0.08784197f, 0.16194607f, 0.07410479f, -0.14897890f, -0.01729737f, -0.00022287f, -0.20665744f, -0.07575433f, 
    -0.10566337f, -0.10605361f, 0.06421524f, 0.02624468f, 0.12253200f, -0.05405289f, -0.15696193f, 0.13001648f, 
    0.10545038f, -0.09182807f, 0.12196653f, 0.00834295f, 0.00611653f, 0.12178912f, -0.00583905f, -0.04639577f, 
    0.01528961f, -0.01991530f, 0.03928218f, 0.01660800f, 0.03287309f, -0.00093258f, 0.01174862f, -0.00280605f, 
    0.01690258f, 0.03316512f, -0.01514359f, -0.01210522f, 0.00550279f, -0.04588938f, -0.00747829f, 0.03356811f, 
    0.04030954f, -0.00692548f, -0.02042752f, 0.00214950f, 0.03786099f, -0.01715570f, -0.01876825f, -0.05535563f, 
    0.03501169f, -0.04811310f, -0.06201793f, -0.04275130f, -0.02160221f, 0.04149874f, -0.02236032f, -0.02699957f, 
    -0.05245819f, -0.05918606f, -0.03614149f, -0.01058541f, 0.02590287f, -0.04410907f, 0.02083858f, -0.00036502f, 
    -0.06266189f, 0.00098466f, -0.04280033f, 0.01818430f, -0.03681303f, -0.06204725f, 0.02164229f, -0.03404888f, 
    0.01064941f, -0.01344319f, 0.00472054f, -0.03237615f, 0.02435854f, 0.00581735f, -0.03126474f, 0.03418741f, 
    -0.03593760f, -0.01267974f, -0.03133455f, -0.00619786f, -0.01563295f, -0.05139540f, 0.01136087f, -0.01766889f, 
    -0.02992881f, -0.04893766f, -0.05142277f, -0.03581628f, 0.00344371f, 0.01507549f, 0.02795308f, -0.03378838f, 
    -0.00250174f, 0.01602666f, -0.04398652f, -0.00091444f, 0.03592807f, -0.04927297f, 0.03493105f, 0.00454601f, 
    -0.06273510f, -0.05686937f, 0.01765166f, 0.02732236f, 0.00183361f, -0.03617942f, -0.03693340f, -0.01418045f, 
    -0.05207271f, 0.03513187f, -0.01958431f, -0.01209465f, 0.03458164f, 0.01547923f, -0.01735231f, 0.01885892f, 
    0.02149308f, 0.00149798f, -0.04344994f, -0.03775626f, 0.03401892f, -0.01087964f, -0.02615361f, -0.03547618f, 
    -0.02700159f, -0.01867196f, -0.03039767f, -0.01559256f, 0.00942569f, -0.03914391f, -0.00470460f, 0.01544348f, 
    -0.04016247f, 0.03531744f, -0.02668426f, -0.03456679f, -0.01225299f, -0.02713020f, -0.01138011f, 0.02058511f, 
    -0.02769401f, -0.02978619f, 0.01781928f, 0.00679763f, -0.03713428f, 0.03435735f, 0.00441676f, -0.02818371f, 
    -0.01620212f, -0.00650929f, 0.02757643f, 0.02223812f, -0.02030096f, 0.03334077f, -0.04498202f, -0.02693814f, 
    -0.03496541f, 0.01356701f, 0.03025746f, 0.01312490f, 0.02830379f, 0.01049543f, -0.01871374f, 0.01208369f, 
    -0.00683122f, -0.04227985f, -0.03759813f, -0.05656608f, 0.00138502f, 0.02221123f, -0.01700723f, -0.01073505f, 
    -0.03606126f, -0.05168656f, -0.01158314f, 0.03065865f, 0.02770967f, 0.01746287f, -0.04081273f, 0.03558544f, 
    -0.03040465f, 0.03588974f, -0.01687071f, 0.00687664f, -0.01751377f, -0.01230021f, 0.00218446f, -0.04291401f, 
    -0.03985120f, 0.02991025f, 0.03799789f, -0.01317461f, -0.05317486f, 0.00380855f, -0.05045153f, 0.03132396f, 
    0.03170503f, -0.03999533f, 0.00926876f, 0.02261432f, 0.03050286f, -0.03820717f, -0.01627539f, 0.00163697f, 
    0.01962472f, 0.02828333f, -0.03948160f, 0.03673325f, -0.03224666f, 0.01391802f, 0.02343229f, 0.00964448f, 
    -0.06454252f, -0.00771272f, -0.01303060f, 0.01603880f, -0.01645841f, -0.03208736f, 0.03618769f, -0.04515338f, 
    -0.01985902f, 0.03121211f, 0.02308048f, -0.01044344f, -0.00397676f, -0.02729504f, 0.02186324f, 0.01441497f, 
    -0.02610381f, 0.03096577f, 0.01869311f, -0.04945249f, -0.03956949f, 0.01522259f, -0.00731370f, -0.04999647f, 
    0.03853589f, 0.03797944f, -0.03455928f, 0.01190041f, -0.05958721f, 0.02094397f, -0.01711766f, -0.01667675f, 
    -0.05414756f, -0.02595955f, 0.00293631f, -0.01794292f, 0.04261265f, -0.05172967f, 0.02267746f, -0.03075911f, 
    -0.03465902f, -0.03619761f, -0.04408663f, -0.01091022f, -0.00792009f, -0.04754476f, -0.00039633f, -0.03718220f, 
    -0.04306978f, -0.01551182f, -0.00030168f, 0.00728503f, -0.00300895f, -0.00932750f, -0.04709401f, -0.04186475f, 
    0.03638973f, 0.03000991f, -0.02486084f, 0.00614224f, -0.00726170f, -0.03661476f, 0.01158789f, -0.02777506f, 
    -0.03776695f, 0.02432432f, -0.03519085f, 0.02725383f, -0.02677042f, 0.01199257f, -0.04799536f, 0.02034179f, 
    -0.03616150f, -0.02416389f, 0.02784911f, 0.03548272f, -0.00536911f, -0.04134579f, -0.04257256f, -0.01358641f, 
    -0.03652491f, -0.04447248f, 0.03722988f, 0.02903681f, -0.03498224f, -0.01943528f, -0.04099955f, -0.01770750f, 
    0.02202464f, 0.02146780f, -0.03294189f, 0.01096175f, -0.02834928f, -0.00335159f, -0.03545294f, 0.02373811f, 
    0.03909876f, 0.03390056f, -0.01042421f, -0.00069922f, -0.02252860f, -0.00069316f, -0.00428913f, -0.03747106f, 
    -0.02693646f, -0.03301729f, -0.02447366f, -0.03563835f, -0.04167353f, 0.01117193f, -0.04676253f, -0.04554867f, 
    -0.01781442f, -0.04299625f, -0.00125367f, 0.01954675f, 0.04391624f, -0.04033849f, 0.02889547f, -0.00900508f, 
    -0.00699968f, -0.00679784f, -0.00729685f, -0.05764517f, -0.03754670f, -0.04611179f, 0.02116990f, 0.02978860f, 
    0.02911583f, -0.04334853f, 0.00760021f, 0.01803441f, 0.01291137f, 0.03390384f, -0.02254491f, -0.04026237f, 
    0.01603468f, -0.01497198f, 0.01691885f, 0.01602361f, -0.05374534f, 0.03395941f, -0.04282292f, 0.02360031f, 
    0.01814326f, -0.04253299f, -0.03128730f, 0.02034502f, -0.04509952f, 0.01348034f, 0.03411286f, 0.00727305f, 
    0.03582890f, 0.01666264f, -0.00336832f, -0.03674721f, 0.01319910f, -0.05429828f, 0.02965772f, 0.02899018f, 
    0.02779134f, -0.01044073f, 0.00868892f, 0.03539477f, -0.03887029f, -0.05969436f, 0.00774449f, -0.02986906f, 
    0.04448668f, -0.00672904f, 0.04043303f, -0.00103494f, -0.00485702f, 0.02126644f, 0.00662429f, 0.00565927f, 
    -0.04120917f, -0.01974775f, 0.04111567f, 0.01748143f, -0.02261089f, 0.00052604f, 0.02069420f, 0.02848702f, 
    0.00883522f, 0.03823456f, 0.02411913f, -0.02942335f, 0.01543637f, 0.02946374f, -0.05215717f, -0.02544062f, 
    0.11883588f, -0.38272366f, -0.02792321f, 0.08703498f, -0.01665793f, 0.03017786f, 0.01942080f, 0.07479247f, 
    -0.06752282f, 0.06568222f, -0.02854998f, 0.20339680f, 0.25133419f, -0.09331755f, -0.25808081f, -0.13570945f, 
    0.08408493f, 0.05809492f, -0.11652415f, -0.08343083f, -0.13955404f, -0.00463594f, 0.10594869f, -0.10291793f, 
    0.36155492f, -0.12024630f, -0.21914098f, -0.07340314f, -0.04189761f, -0.04553565f, -0.22449978f, -0.12306360f, 
    -0.00123635f, 0.04444373f, -0.07410914f, -0.02468966f, 0.21612422f, 0.31438348f, 0.00516939f, 0.00677692f, 
    0.01565044f, 0.02567073f, 0.10647898f, -0.02471854f, 0.02440946f, -0.02728165f, 0.08400703f, -0.09516747f, 
    0.16881514f, 0.11995134f, 0.03809376f, 0.24724032f, -0.10416031f, 0.03326780f, -0.03293762f, -0.17072192f, 
    0.10611610f, -0.04782004f, -0.00493633f, 0.13766360f, 0.04224355f, 0.31513804f, -0.26438096f, 0.21463926f, 
    0.08355268f, 0.09196647f, 0.08657053f, 0.07458054f, 0.20865513f, -0.03845640f, 0.02622982f, 0.07994461f, 
    0.50718695f, 0.16125137f, 0.11113827f, -0.02582844f, 0.05995660f, -0.06964184f, 0.01903304f, 0.11673068f, 
    -0.06227746f, -0.02980938f, -0.03288804f, 0.06941567f, 0.16941485f, 0.02911660f, 0.25303462f, -0.26152688f, 
    -0.08225954f, 0.11772906f, -0.03793314f, -0.07009732f, -0.12171055f, -0.19541131f, 0.15228322f, 0.02837386f, 
    -0.20090313f, 0.21067180f, 0.14097184f, -0.17024373f, 0.02381473f, -0.05275667f, -0.04014921f, 0.24384522f, 
    0.11149021f, -0.00859795f, -0.06004087f, -0.03431288f, -0.12002800f, -0.01295905f, -0.26796502f, 0.15594442f, 
    0.04547286f, -0.08683331f, -0.18559362f, 0.04791380f, 0.06143004f, 0.04363564f, 0.03883556f, -0.03339565f, 
    0.11768690f, 0.14400396f, 0.12574583f, -0.07367287f, 0.06652523f, 0.08300086f, -0.03220047f, 0.15239687f, 
    -0.05877580f, -0.00525086f, -0.16685428f, -0.04508617f, 0.09311132f, 0.01691842f, 0.12886479f, 0.09502142f, 
    0.00188540f, -0.04854016f, -0.18207242f, 0.10506983f, 0.15697826f, 0.05232037f, -0.05076699f, 0.04457231f, 
    -0.42576784f, 0.14283744f, -0.01305906f, -0.18450117f, 0.01926080f, -0.06403760f, 0.06175875f, -0.02293796f, 
    -0.10494678f, 0.15276124f, 0.01739058f, -0.00306184f, 0.13803406f, -0.23631711f, -0.11468585f, 0.05416298f, 
    0.04279225f, -0.02272462f, -0.01856429f, 0.20903113f, 0.23464230f, -0.03380724f, -0.21850397f, -0.15103427f, 
    0.30188856f, 0.50337154f, -0.07089006f, 0.21782012f, 0.01030781f, -0.04432110f, -0.02023003f, 0.01248927f, 
    -0.00797443f, 0.07450504f, 0.11632803f, -0.03334846f, -0.07706297f, 0.12772229f, 0.15279853f, 0.05540793f, 
    0.05316468f, -0.03797615f, 0.12640467f, -0.02778445f, 0.00691165f, 0.00452543f, -0.02512739f, -0.01508248f, 
    -0.36465016f, 0.09783215f, 0.42533448f, -0.51408774f, 0.05369034f, -0.03247146f, 0.17472918f, 0.02618496f, 
    -0.05949255f, -0.01629550f, 0.05186095f, -0.02386001f, 0.20054205f, 0.13914707f, -0.26726341f, 0.01932601f, 
    0.00979076f, 0.29144129f, 0.12925987f, -0.06106897f, -0.09826928f, -0.00304444f, -0.03262216f, 0.01630110f, 
    -0.24721909f, 0.11753907f, 0.10985985f, -0.20850752f, -0.12243044f, -0.03170337f, 0.03882941f, -0.04566225f, 
    -0.17500889f, 0.03334065f, 0.06367282f, -0.16309778f, -0.22919053f, -0.11213265f, 0.04564872f, 0.07248361f, 
    -0.05927263f, -0.02099333f, 0.03735863f, -0.02037479f, -0.07403384f, -0.09429135f, -0.06053516f, 0.03995975f, 
    -0.03076361f, -0.03660812f, 0.10970388f, 0.22107346f, -0.03746913f, -0.10953441f, 0.12811482f, 0.14712802f, 
    0.19361922f, 0.06328548f, -0.09499692f, 0.19259872f, 0.29423523f, -0.03511479f, -0.05065759f, 0.27092674f, 
    -0.05153918f, -0.03511757f, -0.08705313f, 0.12632349f, -0.08926833f, 0.02552420f, -0.01379962f, 0.11595974f, 
    0.14825581f, 0.11931405f, 0.27383295f, -0.20247342f, -0.05772193f, 0.10182878f, 0.15265343f, -0.07429457f, 
    -0.07561279f, -0.12990811f, 0.07542045f, -0.00642036f, -0.12474507f, -0.17963795f, 0.19475837f, -0.25701788f, 
    0.14701734f, -0.12158035f, -0.07705351f, -0.01718311f, -0.02671797f, -0.06783202f, 0.08660312f, -0.10896712f, 
    -0.47747183f, 0.02265491f, -0.10220736f, -0.19913077f, -0.01703743f, -0.00639443f, -0.01053690f, -0.04339092f, 
    -0.01521153f, 0.17401843f, -0.08933273f, -0.02441668f, 0.12968442f, -0.32253763f, -0.01595154f, -0.02720753f, 
    -0.05662619f, 0.09498521f, -0.01410260f, -0.02729809f, -0.01128515f, -0.09223035f, 0.02911953f, -0.03751365f, 
    0.09308742f, 0.07688473f, 0.39185765f, -0.25592408f, -0.23679216f, -0.15402243f, 0.21912962f, -0.01989524f, 
    0.03867919f, -0.00359184f, 0.02332196f, 0.16908728f, 0.22897337f, 0.05218403f, -0.18990743f, 0.07860801f, 
    -0.12442336f, 0.03005889f, 0.00346624f, -0.07841479f, 0.21674328f, 0.17866744f, 0.24367759f, -0.02859606f, 
    -0.10509579f, 0.20253026f, -0.14622957f, 0.13159621f, 0.12238684f, 0.02147491f, 0.00684302f, -0.05634170f, 
    0.03780899f, 0.01296539f, -0.08250544f, 0.06041511f, -0.07991522f, 0.01250649f, 0.14933118f, 0.19379115f, 
    0.22276199f, 0.07123262f, 0.00295890f, -0.02581464f, -0.10815576f, 0.07134874f, -0.01406499f, -0.02766133f, 
    -0.13824169f, -0.08921330f, -0.21247885f, 0.28741181f, 0.29375601f, -0.02470335f, 0.10451671f, 0.05409262f, 
    -0.00524513f, 0.20287748f, 0.04904183f, 0.13619715f, -0.07608228f, -0.26588145f, 0.08012362f, 0.02621433f, 
    0.10459472f, -0.02807411f, 0.01725464f, -0.02394555f, 0.05308358f, 0.09183731f, -0.07239103f, 0.04591096f, 
    -0.04629645f, 0.02008703f, -0.03790561f, -0.04338178f, 0.03905666f, -0.02758192f, -0.02376586f, -0.00207845f, 
    -0.03059691f, 0.03166645f, 0.01033108f, 0.04586223f, 0.03150420f, -0.01087721f, 0.04885981f, 0.03539211f, 
    0.02190167f, -0.00351817f, 0.00222764f, -0.02198226f, 0.03675132f, -0.03317774f, -0.03125307f, 0.04740589f, 
    -0.02036531f, -0.04259242f, -0.01124122f, 0.04042311f, 0.00831029f, -0.03403813f, 0.00576058f, -0.05217454f, 
    0.01501037f, -0.00842372f, -0.05584017f, 0.02451314f, 0.02156269f, -0.00739924f, 0.04187386f, 0.00201408f, 
    0.00095382f, 0.02180250f, -0.03343461f, 0.01302011f, 0.01401443f, -0.01219869f, -0.05100486f, 0.02449043f, 
    -0.03623122f, -0.04453161f, -0.04746699f, -0.04176310f, -0.00129805f, 0.01895590f, -0.01207114f, -0.03755126f, 
    -0.05235732f, -0.00327226f, -0.05578049f, -0.02351280f, -0.01209239f, 0.02972656f, -0.00846450f, -0.00791713f, 
    -0.01148806f, -0.02855235f, -0.03792309f, 0.04098896f, -0.03582013f, -0.05266915f, 0.02779112f, 0.02355449f, 
    -0.04533313f, 0.00144362f, -0.00997557f, -0.04979586f, -0.04070454f, -0.02565022f, 0.03556442f, -0.01950833f, 
    -0.00078518f, -0.03200401f, -0.05325168f, -0.02585457f, 0.00239617f, 0.03731887f, 0.02771283f, -0.02201297f, 
    0.04747541f, -0.05557709f, 0.01191443f, 0.01917020f, -0.00118077f, 0.00591777f, -0.01807926f, 0.04079943f, 
    -0.03810800f, 0.00573605f, -0.01980358f, -0.00497035f, -0.01767505f, -0.00970796f, 0.02009296f, -0.05170221f, 
    0.02708566f, 0.01946804f, -0.00259986f, 0.02755841f, -0.03142548f, -0.00942839f, -0.02247006f, 0.00724616f, 
    -0.03553038f, -0.04749949f, -0.00899489f, -0.03849503f, -0.01633732f, -0.04271619f, 0.03601915f, 0.03882347f, 
    -0.03822142f, -0.01359130f, -0.04781102f, 0.03248211f, -0.02137786f, 0.01021401f, -0.03422688f, 0.03571752f, 
    0.03452563f, -0.00750314f, -0.02535130f, 0.00455172f, -0.03059384f, 0.02864289f, 0.02486604f, 0.01497284f, 
    -0.01826916f, 0.02507644f, -0.01488316f, -0.05667795f, 0.00461096f, -0.04538405f, -0.00108777f, -0.02405533f, 
    0.02550819f, -0.01006434f, 0.00928714f, 0.02568883f, -0.02555104f, -0.01687537f, -0.01685894f, 0.01202256f, 
    -0.05657717f, -0.01880984f, 0.02630394f, 0.02603943f, 0.02517126f, 0.03048943f, 0.00394403f, 0.00624208f, 
    -0.04811733f, -0.01278042f, -0.05688441f, -0.04594838f, 0.01536128f, -0.02345341f, 0.02896634f, 0.00937409f, 
    -0.03209808f, -0.00953932f, -0.01234177f, -0.01683905f, 0.01478874f, -0.01348716f, -0.00851301f, -0.02980422f, 
    -0.04287227f, -0.03866554f, -0.02537151f, -0.05511533f, -0.03195898f, 0.00139728f, 0.03140012f, 0.01182946f, 
    0.03942499f, -0.04664240f, -0.04422028f, 0.00160273f, 0.01752950f, -0.02645012f, 0.01780500f, 0.00973449f, 
    0.03753413f, 0.03861569f, 0.02019224f, 0.02856386f, -0.02103710f, 0.01733611f, 0.01735692f, 0.03584599f, 
    0.02704575f, 0.03796919f, 0.00217841f, -0.02623896f, -0.00448507f, 0.03769499f, -0.04593140f, 0.01823468f, 
    -0.05162764f, 0.02478958f, -0.00094207f, -0.05410724f, 0.01720061f, 0.03267546f, 0.00268757f, -0.02175484f, 
    -0.02587083f, -0.02913123f, 0.02888539f, -0.03041304f, 0.03727058f, -0.05764682f, 0.01771685f, -0.01864200f, 
    -0.01276334f, 0.01969503f, 0.01279779f, 0.00886738f, 0.01328091f, -0.04931611f, -0.01577332f, 0.04046332f, 
    -0.03811465f, 0.01296034f, 0.00827456f, -0.01876502f, -0.00981145f, -0.03858871f, 0.01875011f, -0.03420589f, 
    -0.00903156f, -0.03381538f, 0.00544657f, 0.01265058f, -0.04425225f, -0.04799780f, -0.00259828f, -0.00102001f, 
    -0.03882714f, -0.05102678f, -0.01726016f, 0.01117342f, 0.00560720f, -0.01372454f, 0.01517455f, -0.02944382f, 
    0.00528740f, -0.04183172f, 0.02843273f, -0.01866351f, 0.00727282f, 0.03145169f, -0.03592352f, -0.02227415f, 
    -0.01437956f, 0.00230885f, -0.01840488f, -0.03998193f, -0.04634559f, 0.02194608f, -0.02189487f, -0.01961088f, 
    -0.03244731f, 0.02908545f, 0.03043390f, -0.00731150f, -0.03849329f, 0.04043945f, -0.00624959f, 0.02127984f, 
    -0.01037859f, -0.01034005f, -0.05479759f, -0.04111544f, -0.01928783f, -0.02846515f, -0.02357005f, 0.01949835f, 
    -0.03507643f, 0.04167565f, -0.03862466f, 0.02346305f, -0.02521246f, 0.01360827f, -0.04467686f, -0.04433353f, 
    0.03213641f, -0.03411748f, -0.02446679f, 0.01175649f, 0.00525568f, 0.03380697f, 0.00887721f, 0.01672084f, 
    0.03970945f, -0.04552822f, 0.02484977f, -0.02342303f, -0.00515588f, -0.02780284f, -0.01262752f, 0.01996200f, 
    -0.02848082f, 0.01273776f, 0.01787546f, 0.02728743f, -0.05302285f, -0.03138477f, 0.03420784f, 0.00506716f, 
    0.01568604f, -0.00120279f, -0.02409882f, -0.00877189f, -0.02154463f, -0.01390174f, -0.02341474f, -0.04775627f, 
    0.00625990f, -0.02971203f, -0.05759250f, -0.01710945f, -0.02131467f, -0.05372125f, -0.01336269f, -0.02020326f, 
    -0.00650610f, 0.03157981f, -0.04682542f, -0.05427993f, -0.02942835f, -0.04994696f, -0.04287968f, -0.04636873f, 
    -0.03789224f, 0.01331509f, 0.00538224f, -0.01842397f, -0.00811763f, -0.00566402f, 0.02768583f, -0.01895843f, 
    -0.00975078f, -0.00854315f, -0.02996420f, 0.03649241f, -0.04413800f, 0.03221574f, 0.03098154f, -0.03410460f, 
    -0.03292741f, 0.01812729f, -0.03828825f, 0.02093642f, 0.04787586f, 0.02369420f, -0.00134001f, 0.01570502f, 
    -0.04421090f, -0.01121854f, 0.01160996f, 0.04106820f, -0.05757003f, -0.05211566f, -0.01184146f, -0.02193123f, 
    0.02775201f, -0.01960015f, -0.04897629f, 0.02953592f, 0.02849280f, -0.04445716f, -0.05446186f, -0.02424333f, 
    0.02640557f, -0.04677856f, -0.00797995f, -0.01785961f, 0.03630417f, 0.03779818f, 0.03484133f, 0.03654376f, 
    -0.03453590f, -0.02597467f, 0.00540183f, -0.02019195f, 0.02541775f, -0.04795415f, 0.03276101f, 0.03960944f, 
    -0.01753556f, -0.00147218f, 0.01730076f, 0.01112184f, 0.00061455f, 0.00258781f, -0.05087420f, 0.00026518f, 
    0.02592902f, -0.06046581f, -0.06079712f, 0.01328274f, -0.02780246f, -0.00654444f, -0.00453970f, 0.01826972f, 
    -0.04747601f, -0.06776998f, -0.04534269f, 0.03325329f, 0.03793587f, -0.04977018f, -0.04475931f, 0.03589362f, 
    -0.00634290f, -0.00748677f, -0.01457345f, -0.03216060f, 0.03823514f, 0.03535630f, -0.02470569f, 0.00048152f, 
    -0.04205509f, -0.04748572f, -0.01072825f, 0.00479197f, 0.01497130f, 0.01337762f, -0.04841755f, 0.03443801f, 
    -0.05472543f, -0.05387741f, 0.03291989f, -0.02670130f, 0.00393903f, -0.04029987f, -0.03324480f, -0.02475982f, 
    0.04127294f, 0.00921495f, 0.00362963f, -0.03851204f, -0.05103642f, 0.00925636f, -0.03406337f, -0.00024368f, 
    -0.02219334f, -0.01796057f, 0.00822634f, -0.02543416f, -0.02187170f, -0.02325602f, 0.00108028f, 0.00026607f, 
    -0.02322687f, 0.00817483f, 0.02944692f, 0.00866296f, -0.03454352f, -0.01797931f, 0.01926681f, -0.01369348f, 
    0.01891626f, -0.06027676f, -0.05568415f, 0.01693156f, -0.02553646f, -0.04640861f, -0.04448880f, -0.04639924f, 
    -0.00566045f, -0.03207777f, -0.02634800f, 0.01508991f, 0.02229711f, -0.04363925f, 0.03726753f, 0.00033396f, 
    -0.03216985f, -0.03867406f, -0.03703872f, -0.01678864f, -0.03173653f, 0.02577979f, -0.00894535f, -0.01387274f, 
    -0.01027212f, -0.02306868f, 0.04177393f, -0.03830131f, 0.03532049f, -0.01983654f, 0.02309532f, -0.00341805f, 
    -0.04617403f, -0.02680189f, -0.05029172f, 0.01432078f, -0.04852982f, -0.01732596f, -0.00971400f, -0.01535669f, 
    0.04384271f, -0.04300470f, 0.00558980f, 0.01850307f, 0.02254001f, 0.00356726f, -0.03828220f, 0.01559513f, 
    0.01893902f, -0.01072252f, -0.05811194f, 0.00297729f, 0.01897400f, 0.02080961f, 0.01123480f, -0.06060339f, 
    0.02273354f, 0.04573179f, -0.01979282f, -0.04584211f, -0.04400977f, 0.01071150f, 0.02407637f, -0.00036498f, 
    0.02581732f, 0.04035964f, 0.02735445f, -0.01917925f, 0.00356254f, 0.00524777f, -0.02131725f, -0.03206176f, 
    0.02607254f, -0.03533865f, 0.03077379f, -0.04443509f, 0.01596373f, 0.03535584f, 0.02806203f, -0.03483315f, 
    0.01532777f, -0.05250255f, 0.00580538f, -0.02177215f, 0.01389927f, -0.05085253f, 0.03198125f, -0.04722814f, 
    -0.03578607f, 0.01462174f, -0.01141114f, -0.04871497f, -0.03792087f, -0.00631816f, -0.00417998f, -0.03260180f, 
    0.02833111f, 0.00488092f, -0.02219146f, -0.04469769f, 0.03943498f, 0.03453143f, -0.05463010f, -0.04433518f, 
    -0.02543833f, -0.00151875f, -0.03778088f, -0.00717409f, -0.05953858f, -0.02022206f, 0.01679549f, -0.01245453f, 
    -0.04847126f, -0.03238107f, 0.02563605f, 0.03577060f, 0.03008744f, 0.03073625f, -0.04456271f, 0.03168184f, 
    0.03894246f, 0.02004980f, -0.02359830f, 0.01327214f, -0.03512064f, -0.01724429f, -0.03080289f, -0.01892042f, 
    0.00646514f, 0.01553341f, 0.01824500f, -0.02765379f, -0.00483172f, 0.00759035f, 0.03107166f, 0.00952092f, 
    0.03131828f, -0.04331104f, -0.03914635f, 0.04621182f, 0.00578688f, 0.02289651f, 0.02225662f, -0.00093481f, 
    0.01016317f, 0.02884547f, 0.00825192f, 0.01779647f, -0.03859750f, 0.01100353f, 0.02313755f, 0.00118692f, 
    -0.03074169f, 0.00517954f, 0.00389170f, 0.02721375f, 0.00610951f, -0.01265485f, 0.04184812f, 0.04198135f, 
    0.02638773f, -0.02420071f, 0.00708459f, 0.02314747f, 0.01733621f, -0.02963139f, -0.03505223f, 0.00253470f, 
    -0.03967571f, -0.01034299f, 0.03138551f, -0.00785237f, 0.01461898f, 0.01532208f, -0.01325399f, -0.04727718f, 
    -0.00443315f, 0.04358159f, -0.00000256f, -0.02776419f, -0.01521016f, -0.05397350f, -0.04325116f, -0.01374466f, 
    0.02045632f, 0.00542315f, -0.05526330f, -0.00648837f, -0.01073509f, -0.05779404f, -0.04836882f, -0.03951521f, 
    -0.04996833f, -0.00284728f, 0.03597628f, 0.01794041f, -0.01344024f, -0.01253530f, -0.03546578f, -0.02042229f, 
    0.03596338f, -0.06580576f, -0.03126572f, 0.02858193f, 0.04471476f, 0.01318163f, 0.04236237f, -0.05383727f, 
    0.01915176f, -0.04295698f, 0.00285350f, -0.05117077f, 0.03284135f, 0.01756918f, 0.01989545f, -0.05161731f, 
    0.02140657f, -0.04999663f, 0.00367844f, -0.02682130f, -0.00798411f, -0.00508265f, 0.03313085f, -0.02554709f, 
    -0.02733057f, -0.02477727f, -0.03513809f, 0.01618739f, -0.03420563f, -0.03890249f, -0.04962106f, 0.03513929f, 
    0.03093783f, 0.01774552f, 0.01267087f, -0.02066563f, -0.02352814f, 0.00097101f, -0.02428503f, -0.05821523f, 
    -0.03777125f, -0.02267475f, -0.00380319f, 0.01838578f, -0.01165935f, 0.00496605f, -0.03136935f, -0.05996028f, 
    0.01418871f, -0.03767392f, -0.02183596f, -0.02038911f, 0.04051647f, -0.04848789f, 0.02558362f, 0.02343362f, 
    -0.00658143f, 0.02392691f, -0.05540817f, 0.02860533f, -0.04706138f, 0.00664061f, -0.01088995f, 0.01239410f, 
    -0.00914248f, -0.05130211f, -0.03785072f, -0.05644493f, -0.00466487f, 0.00060402f, -0.04596227f, 0.04012112f, 
    0.00190849f, -0.03531350f, 0.03756405f, 0.02837396f, -0.04844967f, -0.03541398f, -0.01264670f, 0.02726174f, 
    -0.01990804f, -0.04760617f, 0.01340518f, -0.04809287f, -0.01629736f, 0.00208332f, -0.02662967f, -0.05812788f, 
    -0.01926796f, -0.06023382f, -0.00720527f, 0.02407813f, -0.00802514f, -0.03986645f, 0.04024355f, 0.01447290f, 
    0.17495231f, -0.16304998f, -0.22479145f, 0.13646211f, 0.01913325f, -0.09861241f, -0.03040435f, 0.04759457f, 
    0.00400190f, -0.05588453f, 0.10418946f, 0.01047898f, 0.19797204f, -0.05522370f, -0.04805819f, 0.08824921f, 
    0.05271776f, 0.11175907f, -0.11377265f, 0.01474250f, 0.05272174f, 0.17790672f, 0.16444428f, -0.06984775f, 
    0.13899677f, 0.03244531f, 0.23342173f, -0.26066646f, 0.02726828f, 0.04349218f, -0.08422196f, 0.13881217f, 
    0.03972875f, 0.19823642f, 0.08488480f, 0.13026220f, 0.14534803f, -0.15439484f, 0.09891041f, 0.01520918f, 
    -0.00156954f, -0.04117745f, -0.15071698f, 0.00297348f, -0.07531228f, -0.01270058f, -0.23095201f, 0.07670242f, 
    0.38283479f, 0.02527773f, 0.20627791f, -0.13547543f, 0.02574716f, 0.05497411f, -0.06215446f, 0.01329017f, 
    -0.00353262f, -0.01586839f, 0.08553728f, -0.11304181f, -0.10889462f, -0.20400251f, -0.09382643f, -0.08118141f, 
    0.02904411f, 0.03054744f, 0.11871830f, -0.22121394f, 0.07480031f, 0.09109715f, -0.04686092f, 0.18644817f, 
    0.26114655f, 0.01173506f, 0.07893588f, -0.00532142f, 0.14775574f, -0.01610445f, -0.05852433f, -0.13107562f, 
    -0.04214567f, -0.02712112f, 0.00059730f, 0.01672828f, -0.24209590f, 0.10543147f, 0.17711875f, 0.17933819f, 
    0.07257108f, -0.12142534f, 0.15340537f, 0.03310154f, -0.06221168f, 0.04001074f, 0.07970020f, 0.13467772f, 
    0.05034512f, 0.01724587f, -0.02781271f, 0.06685442f, -0.13917373f, -0.02173030f, 0.00766325f, 0.00963876f, 
    0.10165178f, 0.02103148f, 0.02833807f, -0.04747082f, 0.17348459f, -0.23964722f, -0.07370221f, -0.10434812f, 
    0.06979083f, -0.01969400f, -0.04039344f, -0.02272990f, 0.02168641f, -0.09837687f, -0.05706023f, 0.09476988f, 
    0.21830533f, -0.15618317f, -0.09117549f, -0.07823676f, 0.06493808f, 0.12976438f, -0.10210796f, -0.22605966f, 
    0.03458868f, -0.24780598f, -0.03386829f, 0.06644288f, 0.12295557f, -0.20278811f, -0.22950061f, -0.22841030f, 
    0.08599371f, 0.18733957f, -0.04137619f, 0.04156579f, -0.00803861f, 0.10397892f, -0.01887469f, 0.01366539f, 
    -0.20982580f, 0.04329175f, -0.00457362f, -0.13961279f, -0.05441959f, 0.12072468f, 0.09621204f, 0.06987147f, 
    0.05171213f, -0.02328268f, -0.17702435f, -0.02202025f, -0.08022734f, 0.04525641f, -0.00216857f, 0.12217832f, 
    -0.00014746f, 0.13792253f, 0.18521143f, 0.21852757f, 0.01962505f, -0.08421290f, 0.03418578f, -0.02205954f, 
    0.08678598f, -0.07373223f, 0.21287069f, -0.14146769f, -0.10300639f, 0.03372881f, -0.14481163f, 0.04546790f, 
    0.05447358f, 0.15287222f, -0.18491055f, -0.02206599f, -0.21468939f, -0.11114955f, 0.29070729f, 0.21860112f, 
    -0.10182144f, -0.00789261f, 0.00975398f, 0.09682560f, 0.04031170f, -0.02773469f, 0.17381321f, 0.03769698f, 
    0.10749601f, -0.20614401f, 0.09465508f, 0.22044533f, -0.02418765f, -0.08324753f, 0.10824107f, -0.04723312f, 
    -0.06934170f, 0.04198673f, -0.00003694f, 0.00169937f, 0.06751770f, -0.04250295f, 0.19820507f, -0.13219327f, 
    -0.05216148f, -0.12125805f, 0.00918218f, -0.01917770f, -0.09116980f, -0.00823640f, -0.09713135f, 0.04080825f, 
    0.06639615f, 0.12526046f, -0.06959119f, -0.28570205f, 0.00754082f, 0.22769086f, -0.02176053f, 0.28598210f, 
    -0.02894630f, -0.12130294f, -0.13881877f, -0.09478304f, -0.04974198f, -0.10319062f, 0.30736899f, -0.29993010f, 
    0.04446280f, 0.04598871f, -0.07937257f, 0.14846422f, -0.06400420f, -0.04335023f, 0.17052785f, -0.03919731f, 
    -0.25304073f, 0.13536423f, -0.11691764f, 0.13502742f, 0.09922858f, -0.00968526f, 0.18388607f, 0.04786915f, 
    -0.03408279f, 0.14212273f, -0.07477941f, 0.04427933f, 0.12153376f, -0.26325864f, 0.01836145f, -0.04375477f, 
    0.07189134f, 0.03705056f, 0.10966764f, 0.02499345f, 0.10776852f, 0.09006048f, -0.03202555f, 0.08332909f, 
    -0.18917532f, 0.09001899f, -0.11909450f, 0.28655660f, 0.05969934f, -0.03141801f, -0.02229006f, 0.15462685f, 
    -0.03094316f, -0.30742791f, 0.11323010f, 0.03981795f, -0.73742235f, -0.25152498f, -0.03756640f, 0.13061193f, 
    -0.09289628f, -0.01673608f, 0.07430892f, 0.05730587f, -0.09480127f, -0.02835003f, -0.05912615f, -0.15807123f, 
    0.16279952f, -0.04222422f, 0.05081264f, 0.10954685f, 0.00363159f, 0.08362711f, 0.20482115f, -0.16228573f, 
    0.01767078f, 0.09645524f, 0.12839513f, 0.04864185f, -0.01438766f, 0.04356992f, 0.26449195f, 0.08595616f, 
    0.02723608f, 0.02055306f, -0.02736840f, 0.06726906f, -0.16980837f, -0.01271195f, 0.09095020f, 0.15610678f, 
    0.45196638f, 0.09267449f, -0.07699240f, 0.12360907f, 0.05873802f, 0.03897859f, 0.03806861f, 0.16156194f, 
    -0.02776342f, -0.07678606f, -0.14845812f, -0.16580516f, -0.14732324f, 0.13511227f, -0.11668365f, -0.06860808f, 
    0.14031911f, 0.05585942f, -0.01786410f, -0.02198932f, -0.04882030f, -0.08025017f, 0.11810969f, 0.14193653f, 
    -0.22276065f, 0.11211146f, 0.17394286f, -0.12070692f, -0.04151291f, 0.04812810f, 0.09805547f, -0.03938243f, 
    0.01866018f, -0.04254912f, 0.00619723f, 0.03860911f, -0.06808922f, -0.01389710f, 0.35837248f, -0.16061023f, 
    0.01184162f, 0.07744434f, 0.00043259f, -0.02525851f, 0.01910958f, -0.05902242f, 0.13070950f, 0.08087828f, 
    -0.02962190f, -0.08303630f, -0.06167072f, -0.14285943f, -0.13632245f, 0.14268962f, 0.08474596f, 0.13736513f, 
    0.06591986f, 0.15389028f, -0.18694286f, -0.00371369f, -0.03642697f, -0.23901497f, -0.37189689f, 0.13416336f, 
    0.11135302f, 0.07418962f, 0.03991782f, -0.07349487f, -0.03781374f, -0.04236971f, 0.09343698f, 0.07201330f, 
    -0.47581044f, 0.00019163f, -0.07737722f, 0.12131194f, 0.03331916f, 0.00329088f, 0.03062980f, 0.02410621f, 
    0.04145511f, 0.05551247f, 0.05596788f, -0.07621405f, -0.20435160f, 0.13179664f, -0.07498914f, -0.07828493f, 
    -0.05147829f, -0.01623096f, 0.04163119f, 0.07977280f, 0.08172761f, -0.03803347f, -0.00171004f, 0.02581957f, 
    -0.18012226f, -0.05496735f, 0.00508249f, -0.05102064f, -0.06457195f, -0.01098655f, -0.04111503f, -0.05660865f, 
    0.09975358f, -0.02924673f, 0.12752481f, -0.00084126f, -0.08276003f, -0.01589119f, -0.08530357f, -0.00246656f, 
    0.17996502f, -0.09424129f, -0.07357959f, 0.16278943f, -0.02404035f, -0.02747319f, -0.07794024f, 0.02821192f, 
    0.04136804f, 0.13037446f, 0.11382604f, 0.08297711f, 0.02551431f, 0.07268177f, 0.06222261f, 0.12509821f, 
    0.03496636f, 0.07550693f, 0.01055661f, 0.03090490f, -0.24046750f, -0.09119681f, -0.07426660f, 0.08555569f, 
    0.07707570f, 0.05560329f, -0.00956889f, -0.08544657f, -0.10448723f, -0.08504765f, -0.04138521f, 0.09231795f, 
    0.06179457f, -0.02011070f, 0.03160533f, 0.12686738f, -0.04729152f, 0.04290517f, 0.04909395f, -0.20892140f, 
    -0.06377535f, 0.03348538f, 0.09872510f, 0.04552902f, -0.24632674f, -0.22537440f, 0.08755058f, 0.25923216f, 
    0.09430711f, 0.08844839f, 0.13218053f, -0.04274139f, 0.07396536f, -0.02813339f, 0.01495860f, 0.08034403f, 
    0.12235476f, -0.08016101f, -0.02455563f, 0.06274709f, -0.10112982f, -0.00258873f, 0.04491943f, -0.02486885f, 
    0.10584240f, -0.00246916f, 0.07564702f, 0.07661902f, 0.02514891f, -0.08986176f, 0.11073040f, -0.14891995f, 
    0.04755051f, -0.03154509f, 0.18350779f, 0.11790843f, 0.09574132f, 0.18593200f, 0.03988220f, 0.04119881f, 
    -0.06472401f, -0.07729924f, -0.07023706f, 0.11811311f, -0.02561856f, 0.09449413f, 0.00682776f, 0.00950659f, 
    0.11704677f, 0.07073367f, 0.02877196f, 0.03436479f, -0.47964773f, -0.04994423f, -0.22438805f, -0.02778679f, 
    0.01171971f, 0.10229071f, -0.07858063f, -0.14798403f, 0.07644709f, -0.04223428f, 0.06643281f, -0.02711902f, 
    0.19869830f, 0.04191703f, 0.13300823f, 0.24671227f, -0.03310530f, 0.09329165f, 0.06890499f, 0.10222930f, 
    0.01557205f, -0.08787674f, -0.02911369f, 0.06683118f, -0.29767370f, -0.08443180f, 0.02603567f, 0.01294782f, 
    0.08436666f, 0.04031102f, 0.06089738f, 0.06195813f, -0.15779865f, 0.03491332f, 0.14764157f, 0.01412887f, 
    0.06907712f, -0.05799234f, 0.11167595f, -0.00432452f, -0.04305308f, 0.01904505f, 0.02719726f, -0.08511442f, 
    0.03763017f, -0.08006187f, -0.04293762f, 0.07993408f, 0.20773163f, 0.12414471f, 0.03874680f, 0.14374794f, 
    0.09104162f, -0.01105660f, 0.16011792f, 0.06481601f, -0.04050102f, 0.04483566f, 0.01872419f, 0.05636964f, 
    0.32067442f, -0.20234832f, -0.16476534f, 0.18862705f, -0.11499433f, -0.09188025f, 0.05039689f, 0.07393795f, 
    0.01562335f, -0.10522156f, 0.00280725f, 0.00217262f, 0.11914800f, 0.05494797f, 0.15443881f, -0.04277615f, 
    0.11320557f, -0.01936933f, 0.14110892f, 0.06546521f, -0.06999400f, 0.06080377f, -0.03676123f, -0.10319559f, 
    -0.13187036f, -0.09537287f, 0.01924303f, 0.14686824f, -0.07483139f, 0.03658160f, -0.03125256f, 0.06137478f, 
    -0.09293602f, -0.14939751f, -0.00917305f, 0.11498071f, 0.22362065f, -0.30868453f, -0.02459666f, -0.02046086f, 
    0.00041217f, 0.05242710f, -0.02865612f, 0.13414104f, -0.01350571f, -0.02692016f, 0.10402399f, -0.05361301f, 
    -0.14715210f, 0.09489349f, -0.08055734f, -0.09630036f, 0.03667749f, -0.07582492f, -0.06228159f, 0.05648194f, 
    -0.19619116f, 0.03540320f, -0.11235661f, -0.08724961f, -0.36318779f, -0.21582034f, -0.21500705f, -0.09819754f, 
    0.09635485f, 0.09010002f, 0.04048150f, 0.16999751f, 0.02337417f, 0.04640126f, -0.04933486f, 0.03613107f, 
    -0.39717180f, -0.02250937f, -0.19012353f, 0.18065225f, 0.05788745f, 0.06951400f, -0.05023553f, 0.12735531f, 
    -0.00991884f, -0.03834781f, 0.08035209f, -0.03719708f, -0.17844959f, -0.00854751f, 0.02715055f, -0.22322087f, 
    -0.03666973f, 0.03598008f, 0.04460402f, 0.03848680f, -0.01322614f, 0.11095636f, -0.04210234f, 0.00844188f, 
    0.04870158f, -0.06125339f, 0.23115624f, 0.02948673f, -0.01108814f, -0.04120685f, -0.03418642f, -0.01846375f, 
    0.00143246f, 0.06961071f, 0.17677115f, 0.08205692f, -0.29328018f, -0.12506898f, 0.05571658f, 0.21173471f, 
    0.01756892f, -0.03116152f, 0.00647006f, 0.15296486f, -0.06248762f, -0.03775189f, -0.02070028f, 0.17275791f, 
    0.06898996f, -0.08850718f, -0.19912089f, 0.10259844f, 0.03793044f, 0.03339264f, 0.03039825f, 0.02484041f, 
    -0.05363683f, -0.01934434f, -0.04767224f, -0.16274129f, 0.01503255f, -0.10380591f, -0.05272160f, -0.07641409f, 
    0.10129945f, -0.05407260f, 0.02069520f, 0.05634393f, 0.03735794f, -0.13160671f, -0.09288008f, 0.07445852f, 
    0.34833375f, 0.33657101f, 0.26084799f, 0.14044590f, -0.00896468f, 0.04170490f, 0.10240615f, 0.08464929f, 
    0.07158498f, 0.01416392f, -0.00790418f, 0.06728926f, -0.15408257f, 0.33175811f, 0.20596184f, 0.06012619f, 
    -0.00848918f, -0.00942468f, 0.06014592f, -0.00969198f, -0.01143222f, -0.03940636f, 0.10052898f, 0.05498606f, 
    0.08565792f, 0.11426026f, -0.08950453f, -0.11789360f, -0.09062255f, 0.11404011f, -0.04081850f, -0.00319649f, 
    -0.07502039f, 0.07311551f, -0.07531279f, -0.04817244f, -0.12444386f, 0.06181628f, -0.06672643f, -0.03697081f, 
    0.00699192f, -0.05244032f, 0.03679779f, 0.00430013f, -0.01297939f, 0.03065116f, 0.03734364f, -0.02978856f, 
    0.00524668f, 0.02669099f, -0.04506926f, -0.04688930f, 0.00680498f, 0.02893816f, -0.01233985f, -0.05441549f, 
    -0.02097524f, -0.03735419f, -0.03658916f, -0.01500290f, -0.02621124f, -0.00817584f, -0.04448155f, 0.04473646f, 
    -0.04379007f, -0.01924742f, -0.05734247f, -0.01465912f, 0.01707955f, -0.01777538f, 0.01700071f, 0.03154462f, 
    -0.04834320f, 0.02848648f, -0.04087431f, -0.00606954f, 0.01515961f, 0.04401738f, -0.05485312f, 0.01030158f, 
    0.02845776f, -0.02348924f, -0.00080932f, -0.00734248f, -0.05002151f, -0.05312988f, 0.02583100f, 0.00753461f, 
    0.02377413f, -0.03658884f, 0.01881589f, 0.03882346f, -0.04447924f, -0.00975079f, -0.02812698f, 0.00834447f, 
    -0.05068281f, -0.01755052f, -0.01511484f, 0.04113043f, -0.00746523f, -0.00751478f, -0.03487545f, -0.04108987f, 
    0.02815460f, -0.04660120f, 0.03817388f, -0.01456881f, -0.03170631f, 0.02265511f, -0.03783833f, -0.02714009f, 
    0.04298332f, -0.04975431f, 0.03916701f, 0.01359156f, 0.01210978f, 0.02460865f, 0.04919610f, -0.01182743f, 
    -0.00249826f, 0.02313552f, 0.00240633f, -0.04517509f, -0.02939288f, 0.00521972f, -0.01412593f, -0.01116460f, 
    -0.01148808f, -0.00494461f, 0.03331857f, -0.01516774f, -0.05043047f, -0.01761190f, -0.05198019f, 0.03307499f, 
    -0.04472817f, -0.00388334f, -0.02268589f, -0.00542597f, -0.04242097f, 0.01615422f, 0.01034834f, 0.01885429f, 
    -0.03344414f, -0.02633984f, -0.02118544f, -0.01707282f, -0.05196761f, -0.01433313f, 0.00807500f, -0.04827017f, 
    -0.01400774f, 0.03594628f, 0.00511022f, -0.02084702f, -0.01727991f, 0.00894457f, -0.03440703f, -0.04493986f, 
    0.00726927f, -0.00558437f, 0.03417753f, 0.00554193f, -0.01713332f, 0.01506072f, -0.02702005f, 0.04399057f, 
    -0.05154779f, -0.01819397f, -0.04595307f, -0.05170612f, -0.01885139f, -0.04922856f, -0.02408524f, 0.00195654f, 
    -0.04097234f, -0.03688570f, -0.02039865f, 0.02372713f, 0.00972639f, 0.00694491f, -0.01688400f, -0.03718114f, 
    0.04218919f, -0.03775575f, 0.04445451f, 0.04662746f, -0.00322233f, 0.01094806f, -0.02093788f, -0.02088689f, 
    -0.02553066f, 0.01846747f, -0.03943010f, 0.03733228f, 0.05001692f, -0.04894441f, 0.01758342f, -0.03520549f, 
    0.03434389f, 0.02027278f, -0.01742544f, -0.01678731f, -0.04963939f, 0.03487338f, -0.00290413f, 0.00622508f, 
    0.01874460f, -0.01010092f, -0.04245933f, 0.00101446f, 0.02042327f, -0.02886808f, -0.04435105f, 0.01319105f, 
    0.00872180f, -0.00248480f, -0.05377816f, -0.00815637f, -0.02605093f, -0.04527399f, 0.03635419f, 0.01029916f, 
    0.02148918f, 0.01052107f, 0.02499156f, -0.02033613f, 0.03196651f, 0.03355587f, 0.03254077f, -0.03257176f, 
    -0.02105583f, 0.00335471f, -0.00529334f, -0.02844053f, -0.04063219f, -0.04887104f, -0.02651517f, -0.00630008f, 
    -0.04621170f, -0.00437052f, -0.01411984f, -0.00294849f, 0.01741686f, 0.02287560f, -0.05585580f, -0.02657880f, 
    -0.00591621f, 0.03236048f, 0.02436237f, 0.01857278f, 0.01864367f, 0.01472706f, 0.00926279f, 0.01924293f, 
    0.00861951f, 0.02794403f, 0.01879084f, 0.02624674f, -0.00815218f, -0.03065606f, -0.01779072f, -0.00201568f, 
    0.01963421f, -0.00963028f, -0.05562098f, -0.05010937f, -0.03267163f, -0.00735523f, -0.03323006f, 0.02513021f, 
    0.01631007f, -0.00178624f, 0.02469649f, 0.00096071f, 0.00010386f, -0.00941638f, -0.03141767f, -0.00335013f, 
    -0.00908663f, 0.04411076f, -0.04280112f, 0.02389820f, 0.03406959f, -0.02807372f, -0.02262237f, 0.03454469f, 
    -0.03965550f, -0.00230876f, -0.05581616f, 0.00691802f, 0.03004879f, -0.00645465f, 0.00434279f, 0.01141023f, 
    -0.04554932f, -0.04667669f, -0.00478002f, 0.01584854f, -0.00960025f, 0.03416505f, -0.02423410f, -0.00273690f, 
    -0.00648043f, 0.00976351f, -0.01652048f, -0.01065770f, -0.02167548f, 0.01395726f, -0.01893207f, -0.02825226f, 
    -0.02591545f, -0.02945764f, -0.00931945f, -0.05052448f, 0.03000922f, -0.03151275f, -0.03579040f, 0.03853036f, 
    0.00487513f, 0.01529973f, -0.05324214f, -0.05926984f, -0.01607815f, 0.01756086f, 0.01042615f, 0.02141958f, 
    0.02703798f, 0.03683827f, -0.01418734f, 0.02796488f, 0.02551908f, 0.00172866f, -0.00330905f, -0.03587594f, 
    0.00037148f, 0.00509227f, 0.02629765f, -0.01450542f, 0.01710935f, 0.02966412f, 0.00203493f, 0.03063129f, 
    -0.01326824f, 0.03710276f, -0.03809686f, -0.02136231f, 0.03588409f, -0.03672839f, -0.04150600f, -0.05488259f, 
    0.00094869f, 0.02946930f, -0.00140842f, -0.03876558f, -0.05458862f, 0.02050020f, 0.02253365f, 0.01652391f, 
    -0.02644725f, 0.03496667f, 0.01077200f, 0.00713024f, 0.03482435f, -0.00214966f, -0.02071401f, -0.00084668f, 
    0.04145507f, -0.02313237f, -0.02154008f, 0.04172838f, -0.04854889f, -0.04697895f, -0.00758862f, -0.03276639f, 
    0.02619824f, -0.01647400f, -0.05161838f, 0.01555561f, -0.02911768f, 0.01072077f, 0.01857721f, 0.03321740f, 
    0.03747400f, 0.03339326f, -0.02374208f, 0.01445990f, 0.02752921f, 0.02269509f, 0.03058719f, 0.01706680f, 
    0.03931810f, 0.04573330f, -0.00617960f, 0.00898682f, 0.02947812f, 0.01077022f, -0.04037038f, -0.02546847f, 
    -0.02874746f, -0.00479165f, 0.03873141f, -0.03152338f, -0.01690073f, 0.01582746f, -0.02616581f, -0.02665100f, 
    0.01937496f, 0.02352973f, -0.01936212f, 0.00308046f, 0.02745200f, -0.03017692f, -0.01875832f, -0.03482105f, 
    -0.02712390f, 0.03801602f, -0.01459710f, -0.03251635f, -0.02092121f, -0.05620125f, -0.03049704f, -0.04821572f, 
    -0.01313262f, 0.03723037f, 0.00707976f, 0.01615923f, 0.03643066f, 0.02374195f, 0.03573382f, 0.02209369f, 
    -0.29791409f, 0.21911606f, 0.17838611f, 0.08259813f, 0.05172111f, 0.10945610f, -0.02770075f, 0.00060276f, 
    0.04377591f, 0.09227137f, 0.05981046f, -0.13062124f, -0.24160983f, 0.07775406f, 0.18140030f, -0.13123530f, 
    -0.02130859f, -0.06651722f, 0.07937785f, -0.06261595f, 0.00067195f, -0.01796653f, -0.06698328f, 0.07174780f, 
    -0.28125578f, -0.07590704f, -0.00481992f, 0.09571031f, 0.00653424f, 0.01198487f, 0.15195979f, -0.03516925f, 
    0.03446709f, -0.00627579f, 0.06577111f, -0.01499942f, -0.16918956f, -0.03772553f, -0.08370054f, 0.01198928f, 
    -0.11597659f, -0.07340886f, 0.00689597f, 0.04904274f, -0.03062999f, -0.01043576f, 0.12936039f, -0.00905920f, 
    -0.14280480f, 0.07801291f, 0.08153438f, -0.14134085f, -0.02188899f, -0.03859412f, 0.05172002f, 0.08318222f, 
    -0.07918652f, 0.04280633f, 0.00533811f, 0.00054559f, -0.25447240f, 0.14154065f, 0.11048988f, 0.00561077f, 
    -0.10372633f, -0.03740919f, -0.03682394f, 0.01166579f, -0.07983069f, -0.03865601f, -0.04642783f, -0.03165276f, 
    0.00699175f, 0.05956722f, -0.02186847f, 0.01546127f, -0.05307712f, 0.09280603f, 0.04922291f, -0.09584037f, 
    -0.11966567f, -0.00134443f, 0.00569474f, -0.05272559f, 0.20326942f, 0.07621253f, -0.23984508f, 0.21401475f, 
    0.03199102f, 0.15004021f, 0.06811565f, -0.01506639f, 0.00960365f, -0.01282565f, 0.04214979f, -0.04097319f, 
    0.13819773f, 0.06620385f, -0.05518734f, 0.12220783f, -0.00485468f, -0.00083255f, -0.03336436f, -0.03257674f, 
    -0.02111075f, 0.02262990f, 0.04767822f, -0.02697382f, 0.09621676f, -0.07059827f, 0.10006736f, 0.08086262f, 
    -0.01568305f, 0.01762102f, 0.07785778f, 0.01433373f, 0.10523774f, 0.15218709f, 0.10225096f, 0.04874369f, 
    0.01951393f, 0.02273308f, -0.01898425f, 0.15014212f, 0.03065796f, 0.05118769f, 0.10413688f, -0.08644131f, 
    0.16414420f, 0.23374654f, -0.00468468f, 0.03946046f, -0.43731019f, 0.11740198f, 0.17036761f, -0.02953801f, 
    -0.06695630f, 0.00807696f, 0.03879517f, -0.13082851f, -0.04975730f, -0.12293980f, 0.11205389f, -0.04013702f, 
    0.20134450f, -0.06872132f, 0.22150220f, 0.22501257f, 0.06242787f, 0.01574042f, -0.02279498f, 0.01927650f, 
    0.05779057f, -0.13591529f, 0.01077144f, 0.04949258f, -0.24387680f, 0.10024694f, 0.03327477f, -0.04545240f, 
    0.13116208f, 0.00913595f, -0.14059852f, -0.11454314f, -0.07067366f, 0.22857785f, 0.16007896f, 0.07543760f, 
    -0.06318058f, 0.03099978f, 0.08313345f, -0.07609575f, -0.00978735f, 0.02421787f, 0.06810886f, -0.03871885f, 
    -0.04545828f, -0.14718205f, -0.00855525f, -0.00664985f, 0.28816783f, 0.22033502f, -0.12066972f, -0.03023387f, 
    0.18250158f, -0.02163304f, 0.07508614f, -0.04103987f, -0.06823260f, 0.06718758f, -0.06521104f, -0.09613089f, 
    0.18462169f, 0.10581216f, -0.23494141f, 0.27338734f, -0.08315023f, -0.08597846f, -0.05669447f, -0.04955828f, 
    0.15320419f, -0.05122617f, -0.07675540f, 0.04986552f, 0.17102903f, 0.05247509f, 0.08548692f, 0.01354584f, 
    0.02667104f, 0.05385251f, 0.06034236f, -0.00523607f, -0.00639793f, 0.12397135f, 0.08545468f, -0.21418712f, 
    0.07192191f, -0.10582184f, -0.08057517f, 0.20814659f, -0.11748257f, -0.14724688f, 0.02657362f, -0.03583539f, 
    -0.10429554f, 0.07515474f, 0.05688220f, 0.11489670f, 0.21767652f, 0.07473408f, -0.11142020f, 0.13191536f, 
    0.05167089f, -0.02781081f, -0.09201321f, -0.02879648f, 0.08967742f, 0.04210519f, 0.07569702f, -0.01290148f, 
    0.07084085f, 0.04402336f, 0.02854009f, -0.07788374f, -0.09727860f, -0.01274666f, -0.14469907f, 0.04787766f, 
    -0.11023407f, 0.01445095f, 0.05942898f, -0.12082510f, -0.45039782f, 0.28711799f, 0.01042874f, 0.05313244f, 
    0.04672383f, 0.00385163f, 0.02767317f, 0.05060500f, -0.06011781f, 0.00723595f, -0.04314429f, -0.03329409f, 
    0.17364872f, -0.14926468f, -0.11204613f, 0.05229250f, 0.07225616f, 0.01903327f, -0.05550584f, -0.02523200f, 
    0.04511452f, 0.15873212f, -0.04711048f, 0.02308294f, 0.47006851f, 0.04284624f, 0.08656163f, 0.01216238f, 
    -0.01836720f, 0.14707556f, -0.04292243f, 0.07762608f, -0.05221870f, 0.10210603f, -0.03024294f, 0.09524857f, 
    -0.11182543f, -0.15551820f, 0.08518492f, 0.20552820f, -0.07696304f, -0.08661042f, -0.07260177f, 0.08393834f, 
    0.03357156f, -0.01761992f, 0.10803398f, 0.00928822f, -0.26120842f, 0.01894407f, -0.13919699f, 0.06858455f, 
    0.00867801f, -0.10817347f, 0.00156240f, -0.00994797f, 0.11986295f, -0.06782855f, -0.08670030f, 0.02884819f, 
    -0.12883633f, 0.02241282f, -0.29673937f, 0.00447001f, 0.07310015f, -0.05757210f, -0.02148717f, -0.14726335f, 
    0.05709367f, 0.07436362f, -0.01935807f, -0.09242405f, -0.14902519f, -0.08986544f, -0.18708299f, 0.00777494f, 
    0.01137186f, -0.02112260f, 0.03736050f, 0.05156325f, 0.04302344f, -0.08550718f, -0.09752381f, 0.06676429f, 
    0.16558552f, 0.20121294f, 0.23540714f, 0.15720545f, 0.01514116f, 0.05010355f, 0.02958971f, 0.01153267f, 
    -0.05100843f, 0.02487592f, 0.09345607f, 0.05235944f, 0.05901600f, 0.08226744f, -0.07705741f, 0.15385979f, 
    -0.00243252f, -0.04778327f, -0.01189301f, 0.01101541f, -0.01908553f, -0.00168971f, -0.14938772f, 0.06135550f, 
    -0.00557216f, 0.14423090f, 0.04104582f, -0.08591260f, 0.00612857f, 0.05177184f, -0.08354808f, -0.01768519f, 
    -0.06858996f, -0.05893015f, -0.01090821f, -0.10465570f, -0.00499953f, 0.13243036f, 0.11039646f, -0.03608733f, 
    -0.02561565f, -0.11217754f, 0.10705771f, 0.09955872f, 0.03408645f, 0.05344660f, 0.06526705f, 0.03223712f, 
    0.03193218f, 0.03071862f, 0.07272258f, -0.09134131f, -0.03836554f, 0.03035736f, 0.03016872f, 0.10402541f, 
    -0.02394032f, -0.03560426f, 0.06770146f, 0.00340529f, -0.03132302f, 0.02523464f, 0.17654091f, 0.06032069f, 
    0.11332907f, -0.07396173f, 0.26830515f, 0.05624461f, 0.07262698f, -0.05516972f, -0.00267076f, -0.08688781f, 
    -0.23062055f, -0.20768464f, -0.13115679f, 0.06718870f, 0.18065917f, 0.17737602f, 0.19314489f, -0.04506369f, 
    -0.03322072f, -0.15225181f, 0.12751354f, -0.06659741f, -0.19893749f, 0.09473979f, 0.10002784f, -0.07430606f, 
    -0.04513441f, 0.12387669f, 0.02075135f, -0.02760103f, 0.09607956f, 0.00984343f, 0.14919339f, -0.11448985f, 
    -0.21210976f, -0.18531050f, -0.02043144f, -0.18351987f, 0.04675846f, 0.01906614f, 0.13365114f, -0.04265644f, 
    -0.05461289f, -0.05855719f, 0.19148389f, 0.21246634f, 0.16044103f, 0.01989820f, -0.05626318f, -0.12005316f, 
    0.01580643f, 0.06472443f, -0.01149341f, 0.13308810f, -0.05927137f, 0.06379212f, 0.09664562f, -0.13091703f, 
    -0.33142045f, 0.01729652f, 0.10164614f, -0.08134132f, -0.02726633f, 0.12022643f, 0.21641028f, 0.19355319f, 
    0.19124959f, 0.03718461f, 0.00067284f, -0.08076721f, 0.30822054f, 0.29784605f, -0.04668395f, 0.03056135f, 
    -0.04741246f, 0.04054739f, 0.03143658f, 0.08075459f, -0.18430288f, -0.04025858f, -0.09920468f, -0.11796427f, 
    0.16605633f, -0.08680715f, -0.03406822f, 0.17629105f, 0.03969458f, -0.02695164f, 0.09872743f, 0.04772883f, 
    -0.00147531f, -0.08697236f, -0.07613394f, 0.02811797f, 0.28887194f, 0.31255579f, 0.25726333f, 0.27560419f, 
    -0.17060134f, 0.09193630f, 0.06686806f, 0.11867520f, 0.03838400f, -0.06926377f, 0.01816229f, -0.13427469f, 
    -0.03946903f, -0.13931206f, 0.05177145f, 0.10114955f, -0.02065540f, -0.11085284f, 0.13853307f, 0.24926022f, 
    0.18929665f, 0.28916469f, 0.01573203f, 0.05221013f, 0.18716198f, -0.13314390f, -0.06556144f, -0.18936826f, 
    0.01141022f, -0.08367916f, 0.05937309f, -0.08375998f, -0.02099319f, 0.13006085f, -0.13258867f, 0.06476510f, 
    -0.27709860f, -0.00701169f, -0.18199928f, -0.18831475f, 0.06540516f, 0.06403512f, -0.07795113f, 0.02798026f, 
    -0.05380315f, -0.01870354f, 0.17489721f, 0.08219024f, 0.13307579f, 0.13470289f, 0.02030036f, -0.06415897f, 
    -0.11657853f, -0.04139480f, -0.06828264f, -0.16051693f, -0.05681203f, 0.04227274f, 0.07092825f, 0.12169435f, 
    -0.28867096f, -0.00268752f, -0.11674973f, -0.24512568f, 0.11377055f, 0.07548402f, -0.00714996f, 0.01671213f, 
    -0.00507674f, -0.23656011f, 0.01364004f, 0.02297977f, -0.18116003f, 0.04830927f, -0.05406744f, -0.01355746f, 
    -0.01139135f, 0.05353603f, 0.03730213f, -0.10390823f, -0.09693003f, -0.09469291f, -0.11977210f, -0.01020470f, 
    -0.01326054f, -0.06093350f, 0.24488683f, 0.07456648f, -0.04335017f, 0.07979184f, -0.02845918f, 0.14118584f, 
    0.06566966f, -0.07557474f, -0.02827914f, -0.08288145f, -0.02735701f, 0.20647968f, 0.01936609f, -0.05916088f, 
    -0.16487387f, 0.02314346f, 0.08054514f, 0.10364779f, 0.09959653f, -0.09194870f, -0.01851863f, 0.11798419f, 
    0.11992371f, 0.17550346f, -0.01756635f, 0.12477060f, 0.07360784f, -0.00261923f, 0.10889690f, -0.18713902f, 
    -0.01706702f, 0.15180875f, 0.20419839f, -0.04926660f, 0.10434790f, 0.20850621f, -0.10202136f, 0.03352281f, 
    0.05671878f, 0.05392532f, 0.02098599f, -0.01755565f, -0.00113520f, 0.02585283f, -0.20810215f, 0.06488656f, 
    0.09777874f, 0.13773939f, -0.02844989f, 0.09010665f, -0.09163716f, 0.03551343f, -0.09547516f, -0.06277858f, 
    0.02323709f, -0.10231466f, 0.24307847f, -0.04446832f, 0.14543758f, -0.03992212f, -0.06257416f, -0.06596792f, 
    -0.09097857f, -0.09229895f, -0.04007205f, -0.17316440f, -0.01659863f, -0.13275078f, 0.20816152f, -0.16753620f, 
    0.25617152f, 0.03602305f, 0.18785910f, 0.01818466f, -0.12112175f, -0.03486235f, 0.09362299f, -0.13334599f, 
    -0.06956598f, 0.30502978f, -0.04268932f, 0.00544655f, 0.52348411f, 0.08788678f, 0.21161033f, 0.18197082f, 
    -0.10374752f, 0.06366150f, -0.05436081f, -0.00308866f, -0.01960130f, 0.04964945f, 0.06178658f, 0.10560263f, 
    0.26357371f, -0.04626836f, -0.08387596f, 0.11013760f, 0.05904864f, 0.06689060f, -0.12067675f, 0.11923397f, 
    0.04072497f, -0.14564615f, -0.19153593f, -0.01351357f, 0.18089774f, 0.27689511f, -0.06442548f, 0.01563376f, 
    -0.03623945f, -0.01860360f, 0.06184869f, -0.09633787f, 0.17948395f, 0.03915257f, 0.04464345f, -0.13288598f, 
    -0.03746154f, -0.14118828f, 0.24311872f, 0.20787242f, -0.03079683f, 0.04515567f, 0.03120066f, 0.03240501f, 
    0.04146787f, 0.12884851f, 0.17711905f, 0.04542840f, 0.48279375f, 0.05704917f, 0.14852433f, 0.02532027f, 
    -0.17860886f, 0.09187733f, 0.08200134f, 0.04475027f, 0.02563127f, 0.10441917f, -0.07400303f, -0.03732724f, 
    -0.19248421f, -0.11107931f, -0.05521437f, -0.27330449f, 0.00521967f, 0.01911834f, -0.01774806f, 0.05725320f, 
    0.01121992f, -0.01093998f, -0.10457025f, 0.00386753f, 0.15574594f, 0.06090356f, -0.11849627f, -0.21387573f, 
    0.02326249f, -0.00389126f, 0.02884660f, 0.09747948f, 0.05996065f, -0.01778789f, -0.08554421f, -0.24907608f, 
    0.15291190f, 0.16379698f, 0.05882301f, -0.08946005f, 0.00625731f, -0.04850975f, -0.02557926f, -0.22400938f, 
    -0.15960675f, -0.13683093f, 0.26912883f, 0.05002310f, 0.11063982f, 0.04025784f, 0.06005099f, 0.17664552f, 
    0.10014265f, -0.04698054f, 0.11760780f, 0.13273387f, 0.08759351f, 0.11851996f, 0.09784004f, -0.04971241f, 
    0.16593392f, 0.05473543f, -0.06962690f, -0.13178605f, 0.02367474f, -0.07806131f, 0.02009868f, 0.01400406f, 
    0.10402746f, 0.01035878f, -0.10424134f, 0.05070615f, 0.19146423f, -0.14614226f, 0.06744025f, 0.10473394f, 
    0.05173749f, 0.03393343f, -0.13038880f, 0.08228949f, -0.07150004f, 0.13274643f, 0.13302968f, 0.05104164f, 
    0.45620194f, 0.05383636f, -0.01956413f, 0.17623897f, 0.02122177f, -0.15767397f, 0.09694786f, 0.10460549f, 
    -0.02662970f, 0.15480970f, -0.01407131f, 0.03462081f, 0.05093827f, 0.16677107f, 0.10230779f, 0.06787387f, 
    0.00317225f, 0.18742985f, 0.15727749f, -0.02700714f, 0.08434884f, 0.00187228f, -0.12033713f, 0.05909376f, 
    0.32419953f, -0.23605633f, -0.06299410f, -0.09762440f, 0.10896479f, -0.11337186f, -0.13396797f, 0.00806251f, 
    0.08538901f, 0.09485399f, 0.09027579f, -0.02761441f, -0.05983618f, -0.24551280f, 0.23711579f, 0.05069478f, 
    -0.08810651f, -0.14380196f, -0.01838391f, 0.10614634f, 0.04893811f, 0.04835432f, -0.05331633f, 0.13546270f, 
    -0.14225145f, 0.02084187f, 0.01569808f, 0.02801429f, -0.01748706f, 0.02707390f, 0.08553676f, 0.03590899f, 
    0.02766571f, -0.03653308f, -0.01646051f, 0.04313578f, -0.31806350f, -0.10161501f, 0.09826396f, 0.08432870f, 
    0.03039652f, -0.01020234f, -0.02630453f, -0.08275530f, 0.09078956f, 0.13413852f, 0.13785347f, 0.01481429f, 
    -0.39411229f, -0.08268523f, 0.00079783f, -0.02338353f, 0.09221420f, 0.07338431f, 0.13262650f, 0.09294739f, 
    0.12496349f, 0.14323623f, 0.12440706f, -0.08238496f, -0.14780225f, -0.01354604f, 0.05035556f, -0.23379990f, 
    0.08025403f, -0.02089964f, -0.17660815f, 0.04219001f, -0.04032281f, -0.07341810f, -0.08585053f, 0.05188771f, 
    -0.14900263f, -0.03983408f, 0.00690715f, 0.06265187f, -0.06244128f, -0.10342125f, 0.03328615f, 0.00693666f, 
    -0.10618804f, -0.20372087f, 0.10129918f, 0.06401782f, 0.33039615f, -0.09595987f, 0.06543820f, 0.26947021f, 
    -0.06121835f, -0.11158612f, 0.03177023f, 0.24023272f, -0.13258871f, -0.03002037f, 0.04415204f, 0.05660191f, 
    -0.13433170f, 0.01850878f, -0.10371807f, -0.03641387f, 0.24704114f, -0.11559773f, 0.03402082f, -0.12283789f, 
    0.25076669f, 0.10457983f, -0.00159501f, 0.05012624f, 0.21830882f, 0.14475384f, -0.10114590f, -0.11949436f, 
    -0.05688390f, -0.10240950f, 0.11285440f, 0.08415199f, 0.03517710f, -0.03515824f, -0.05867628f, -0.00339264f, 
    -0.15833347f, -0.11905546f, -0.11335029f, -0.11591963f, 0.10248567f, -0.02738709f, 0.01802473f, 0.06856972f, 
    0.00354345f, 0.11679252f, 0.01255923f, 0.03444273f, -0.28022546f, -0.20912707f, 0.22519003f, -0.05384833f, 
    0.03022052f, 0.16453010f, -0.14656077f, -0.02504699f, 0.15472667f, 0.08541249f, 0.17462112f, -0.03602576f, 
    -0.13558301f, 0.03599758f, -0.09505712f, 0.10656418f, 0.12949471f, 0.11261165f, 0.04209819f, 0.02975993f, 
    0.01853614f, 0.19727679f, 0.05740201f, 0.05427934f, -0.17162636f, -0.15618384f, 0.02861842f, 0.07253543f, 
    0.02531348f, 0.00244306f, -0.13559280f, 0.04627635f, 0.06833509f, 0.04702206f, 0.04005259f, 0.13389154f, 
    0.03775715f, -0.00349554f, 0.08523592f, -0.04089078f, 0.21890560f, 0.18722638f, 0.05325154f, 0.13216306f, 
    0.28963271f, 0.05299598f, -0.02621362f, 0.00689659f, -0.29770428f, 0.07439964f, -0.07458692f, 0.22680213f, 
    -0.09877365f, -0.11290262f, -0.04476814f, 0.00024466f, 0.11953410f, 0.10194943f, 0.01706872f, -0.02675745f, 
    0.08157287f, -0.08469713f, 0.12227520f, -0.28561959f, 0.02759993f, -0.05897579f, 0.08275982f, -0.02805115f, 
    0.06653967f, 0.11140978f, 0.03857306f, 0.09921288f, 0.17424618f, -0.05510499f, 0.19957031f, 0.03824309f, 
    -0.00468758f, -0.04527038f, 0.08144844f, 0.10089073f, 0.07318704f, 0.08542827f, -0.05273784f, -0.03847021f, 
    0.11256642f, -0.09159188f, 0.12683833f, -0.06166769f, 0.06763373f, 0.09400908f, -0.07904693f, 0.13926563f, 
    0.10676100f, -0.17937914f, 0.12002942f, -0.01891159f, -0.06548220f, 0.14683141f, -0.27907470f, 0.00333324f, 
    0.03298444f, -0.09470180f, -0.00476269f, 0.09093245f, 0.04332657f, -0.02653409f, -0.04536828f, -0.05217751f, 
    0.14874187f, 0.00686180f, -0.13894978f, -0.18088669f, 0.08524156f, -0.00255607f, 0.05106456f, 0.08705678f, 
    -0.02587246f, 0.07901093f, 0.01803485f, -0.03661982f, 0.08023708f, 0.07072600f, -0.09660032f, -0.20259424f, 
    0.07211895f, 0.13656372f, 0.04445724f, -0.01210993f, 0.05916958f, 0.18292797f, -0.04704615f, 0.05944940f, 
    -0.01792798f, 0.06197152f, 0.16232577f, -0.00138721f, 0.07672552f, 0.12447599f, 0.05552652f, 0.09022389f, 
    0.12347864f, 0.01177075f, -0.05642619f, -0.03809483f, -0.27753180f, -0.00620513f, 0.09306524f, -0.01856482f, 
    0.19113618f, 0.01740195f, -0.02093108f, 0.05869254f, -0.09633185f, -0.03334922f, 0.07089292f, 0.08118738f, 
    -0.29821926f, -0.18956107f, -0.09090076f, -0.00891237f, 0.13861604f, 0.07182888f, -0.06469224f, -0.09786053f, 
    -0.06353225f, 0.02323262f, 0.08629569f, 0.10223027f, -0.05772799f, -0.25688282f, 0.21909542f, 0.04491713f, 
    0.08180618f, 0.18095914f, -0.00250533f, -0.00877495f, 0.00823880f, 0.10712869f, 0.20384867f, 0.08106667f, 
    -0.19432399f, -0.38546717f, 0.06520494f, 0.01954451f, -0.02790220f, 0.00507473f, -0.03601008f, 0.09915008f, 
    0.15818417f, 0.02496298f, -0.04582413f, 0.04673830f, 0.02098633f, -0.06884737f, -0.19196831f, -0.09888528f, 
    -0.00737770f, 0.04807909f, -0.06723005f, 0.03474681f, 0.05206672f, 0.03099605f, 0.03823383f, 0.05088694f, 
    0.00477443f, 0.02377073f, -0.05180340f, -0.05513214f, -0.00635595f, -0.00954669f, 0.00838621f, -0.04612201f, 
    0.03666587f, -0.03648209f, -0.03379347f, 0.01169070f, 0.04236696f, -0.04722671f, 0.03272054f, -0.01303440f, 
    -0.05188733f, -0.00658387f, 0.03793523f, -0.03830424f, -0.04772369f, 0.02082076f, 0.01677218f, 0.03741502f, 
    0.00468483f, -0.03490133f, -0.05659628f, -0.01275053f, -0.02830394f, 0.02135393f, 0.00799801f, -0.00703530f, 
    0.03620731f, -0.00831295f, -0.01158136f, 0.03161317f, -0.01606242f, -0.04502057f, 0.03376257f, -0.02277769f, 
    -0.05140744f, -0.00118413f, -0.00934976f, 0.01742596f, 0.01481829f, 0.04360770f, 0.00506080f, -0.00650361f, 
    -0.03249614f, -0.01183225f, 0.01622839f, -0.02901125f, -0.03749144f, 0.02517423f, -0.02095567f, -0.01227561f, 
    -0.02413645f, -0.00637024f, 0.03619397f, -0.00209006f, -0.01487027f, 0.02843149f, 0.03083025f, 0.00395545f, 
    -0.04357157f, -0.05894938f, -0.01508274f, 0.01455617f, -0.05515830f, -0.04612961f, 0.01367232f, -0.04133715f, 
    0.01925566f, -0.02540551f, 0.03154385f, -0.03265733f, 0.01667837f, 0.02450649f, -0.04995900f, -0.03692000f, 
    0.04367790f, -0.03961703f, -0.05518450f, 0.01526629f, 0.03076147f, -0.01379573f, -0.05182572f, 0.01561310f, 
    0.03861620f, 0.03292646f, -0.02934153f, -0.00395917f, -0.02776665f, 0.03426704f, -0.02683513f, 0.04222056f, 
    -0.04515165f, -0.04047329f, -0.05525442f, 0.00181358f, 0.04362033f, -0.04876238f, -0.05657215f, -0.01395689f, 
    -0.05148179f, -0.01296209f, 0.03776842f, 0.01759612f, -0.04206105f, -0.00969134f, 0.02730120f, -0.00801155f, 
    -0.00223066f, -0.05067729f, -0.04214642f, -0.04473330f, -0.00669876f, -0.04810183f, -0.01939958f, -0.04560879f, 
    -0.01284586f, -0.01682145f, -0.03588428f, -0.05584452f, 0.02412879f, 0.04622297f, -0.04326002f, -0.00676215f, 
    -0.00239714f, -0.03547506f, -0.01427446f, -0.01683735f, -0.03362348f, 0.03387619f, 0.03185109f, 0.03666126f, 
    0.02599729f, 0.02933877f, -0.00661148f, 0.03491646f, 0.00221681f, 0.01985334f, 0.02906779f, -0.04283402f, 
    0.04226577f, 0.01075872f, 0.03501158f, -0.01224481f, -0.05274359f, 0.02382621f, 0.04018883f, 0.02401749f, 
    -0.03677114f, 0.01450041f, 0.01058858f, -0.03905836f, -0.05303981f, 0.03743873f, -0.04308854f, 0.03865569f, 
    0.02106929f, 0.02238233f, -0.02767339f, 0.01566432f, -0.00580457f, 0.02682119f, -0.01827527f, 0.02067039f, 
    -0.03883939f, -0.03408636f, 0.01049876f, -0.03769276f, 0.02535602f, -0.02282316f, -0.05675342f, -0.04479370f, 
    0.03422735f, -0.00265372f, 0.04523486f, 0.00003225f, -0.00375962f, -0.00150255f, 0.02267720f, -0.02362355f, 
    -0.05340375f, 0.01530092f, -0.00949388f, 0.01812633f, 0.02881889f, -0.01228096f, 0.04037759f, -0.00113341f, 
    0.01430697f, 0.01432673f, 0.02303946f, 0.00727997f, 0.00953346f, -0.04298443f, 0.01916092f, 0.01274539f, 
    -0.02176244f, 0.03665290f, -0.02478139f, -0.02490307f, 0.04042179f, 0.00048046f, 0.01497223f, 0.00906194f, 
    -0.05232207f, -0.04239924f, -0.02339429f, 0.02464461f, -0.05742678f, -0.02709042f, -0.01271839f, 0.03129048f, 
    0.00978778f, -0.00868253f, 0.02441866f, 0.01926839f, -0.04251742f, 0.01193705f, -0.01296391f, 0.03718425f, 
    0.02866723f, 0.03100376f, -0.03091834f, -0.04246481f, -0.05474878f, -0.04560198f, 0.02000859f, 0.03244445f, 
    -0.04455202f, 0.01716886f, 0.02025557f, -0.03621859f, 0.02970530f, -0.02186072f, 0.00454230f, 0.03642049f, 
    0.00859970f, -0.00281235f, -0.03383792f, 0.02472911f, -0.04722044f, 0.00489146f, 0.02742813f, 0.04043093f, 
    -0.04563184f, -0.02835912f, 0.00581291f, 0.01175271f, -0.03011728f, -0.04050942f, -0.05446493f, -0.05163038f, 
    0.03176945f, -0.04592652f, -0.02633722f, 0.03191407f, -0.01575930f, 0.01675567f, 0.00259799f, 0.01978393f, 
    0.00677381f, -0.05268522f, -0.02881564f, -0.05494446f, 0.03774483f, -0.02717510f, -0.01346234f, 0.01357156f, 
    -0.03149020f, -0.04501415f, -0.02444088f, -0.05348044f, -0.04022042f, 0.02620571f, 0.03163832f, -0.01832180f, 
    -0.01647430f, -0.00084088f, -0.03868790f, 0.03895822f, -0.01162729f, -0.01991004f, -0.03478404f, -0.01470852f, 
    0.00582068f, -0.03577504f, -0.04219525f, -0.01945140f, 0.00422564f, 0.00844791f, -0.00921321f, -0.01286828f, 
    -0.04919915f, -0.00849073f, 0.01542866f, -0.04144970f, 0.02661064f, -0.01594813f, -0.03020017f, -0.03930162f, 
    0.03192919f, -0.00677184f, -0.00956320f, 0.00689446f, 0.03827905f, -0.03101264f, 0.02273598f, 0.01046726f, 
    -0.02447667f, -0.04480901f, -0.02026781f, -0.04693564f, 0.03597978f, -0.04004557f, 0.02653496f, -0.03204538f, 
    -0.01780670f, -0.02065337f, 0.00828449f, -0.00497697f, 0.00277416f, -0.01248362f, 0.00769589f, 0.02911548f, 
    0.03346298f, 0.02681652f, -0.03029348f, -0.03024807f, 0.02746964f, 0.01940365f, -0.04131791f, 0.01762390f, 
    0.03222709f, -0.03283433f, 0.01368674f, -0.04704870f, 0.01111569f, 0.00920104f, -0.03653909f, 0.00035899f, 
    0.02032605f, -0.05066404f, 0.00456631f, -0.02567097f, -0.04797045f, -0.03165583f, 0.00546068f, -0.02117075f, 
    -0.02259141f, -0.00486382f, -0.00901788f, -0.04815494f, -0.02039316f, -0.01024333f, -0.01812296f, 0.04260871f, 
    -0.02730720f, 0.00203496f, -0.00134319f, -0.02367962f, -0.04568329f, 0.00868254f, -0.05238928f, -0.00985775f, 
    -0.05181018f, 0.00682230f, -0.02947615f, -0.05562256f, -0.04995599f, -0.00128444f, -0.02292664f, -0.05172352f, 
    0.04022429f, -0.02599479f, 0.00999885f, -0.01619801f, -0.03145753f, -0.00797440f, -0.00860109f, 0.02409082f, 
    -0.02774959f, -0.00294526f, -0.00779574f, -0.04829071f, 0.01189992f, -0.04720430f, 0.01603137f, 0.00914313f, 
    -0.05235337f, 0.04784923f, 0.02485761f, 0.05349721f, 0.02654046f, 0.03454829f, 0.03152420f, -0.04001511f, 
    0.01551167f, -0.00907129f, -0.04584375f, 0.00765178f, -0.04087668f, -0.00089118f, -0.03970185f, 0.02208280f, 
    -0.04433133f, 0.02163095f, -0.02308744f, 0.02932063f, -0.01097052f, -0.05645102f, 0.02012184f, 0.01830897f, 
    0.01647901f, -0.04183190f, 0.03068826f, -0.03326931f, 0.04021768f, 0.00388067f, -0.03262326f, 0.01246023f, 
    -0.00045263f, 0.01320531f, 0.04141292f, -0.00952672f, 0.01396398f, 0.02098248f, -0.00651230f, 0.03580557f, 
    -0.01572745f, 0.02575547f, 0.02784426f, -0.04441505f, 0.03866326f, -0.00849537f, -0.00320910f, 0.01520191f, 
    0.03715536f, 0.03869002f, -0.00127063f, -0.00656120f, -0.04285523f, -0.02247785f, 0.03254065f, -0.01049380f, 
    -0.01910063f, 0.00580940f, -0.02546685f, 0.00666606f, -0.01694810f, -0.02341775f, 0.04526465f, 0.01037958f, 
    -0.04298571f, 0.04480224f, 0.01783797f, 0.03687883f, -0.04259328f, 0.04494087f, -0.02968596f, -0.02031906f, 
    0.00332076f, -0.04456142f, -0.03126094f, 0.04611096f, 0.04199931f, -0.04202954f, 0.01290246f, -0.05153850f, 
    -0.04600098f, 0.01989184f, 0.02622005f, -0.02815143f, -0.01146530f, -0.04348508f, 0.04084954f, 0.02484488f, 
    -0.01194793f, -0.00208303f, -0.03100203f, 0.02604008f, -0.03937373f, -0.01491133f, 0.01717063f, -0.00852888f, 
    0.00718611f, -0.04568231f, -0.04931836f, 0.02159503f, 0.03691360f, -0.00416611f, 0.04464530f, 0.02336940f, 
    0.00362607f, -0.04944240f, 0.01643463f, 0.02197472f, -0.03240882f, -0.03385878f, 0.02367301f, -0.03982920f, 
    -0.03067248f, -0.02113994f, 0.01388675f, -0.04557958f, -0.01613911f, -0.04603354f, 0.01357188f, -0.04507135f, 
    0.00195084f, 0.00103983f, 0.04243264f, -0.02993597f, 0.02419222f, -0.03969123f, 0.01975651f, -0.02614998f, 
    0.04194067f, -0.04874072f, -0.03312544f, -0.02792219f, 0.02417518f, -0.00446947f, 0.03126376f, -0.02990015f, 
    -0.03411558f, 0.03916024f, -0.04698869f, -0.00638786f, 0.01455251f, -0.02519368f, -0.04871417f, -0.04079319f, 
    -0.00037440f, -0.03955280f, -0.00834922f, 0.03818731f, 0.00056996f, -0.04096843f, -0.01429798f, 0.04380702f, 
    0.03309124f, 0.01043354f, -0.02342614f, -0.00253320f, -0.03030198f, 0.02902848f, -0.01682873f, 0.02581550f, 
    0.00587270f, 0.02193722f, -0.01733403f, 0.02341629f, 0.03910797f, -0.00926762f, 0.00145591f, 0.00368661f, 
    -0.03590790f, 0.02831495f, -0.01697164f, -0.03712033f, -0.05395163f, -0.00828920f, 0.04261632f, 0.00910732f, 
    0.01380748f, -0.03631620f, 0.01832120f, -0.01813876f, -0.04093259f, 0.02151936f, 0.04425117f, 0.01186159f, 
    -0.04200929f, 0.01001317f, -0.03489634f, -0.02764907f, -0.01912029f, -0.04464245f, -0.01204854f, 0.00338129f, 
    0.04709734f, 0.04214606f, 0.04783235f, 0.01001312f, -0.00909049f, -0.04870468f, 0.00265048f, 0.02507337f, 
    -0.01018472f, -0.04789768f, -0.01384968f, -0.03988072f, 0.03429660f, -0.00251528f, -0.03232814f, 0.01752899f, 
    -0.01138916f, -0.02711448f, 0.01481678f, -0.03907683f, -0.01645429f, -0.03533256f, 0.00397053f, 0.01232923f, 
    0.00497224f, 0.02651683f, -0.05215464f, -0.02344070f, -0.04222781f, 0.02516782f, -0.00788788f, 0.02362774f, 
    -0.01114945f, 0.00262865f, -0.00265469f, 0.03670022f, 0.01012964f, -0.01096872f, 0.01461945f, 0.04039084f, 
    -0.00801993f, -0.03301969f, -0.02188759f, -0.04323264f, 0.01979515f, -0.02470393f, 0.03131575f, 0.00729461f, 
    0.03496087f, -0.03475168f, -0.05096653f, 0.00281378f, -0.00714717f, -0.04162073f, -0.05012955f, -0.02816935f, 
    -0.04576029f, -0.04164733f, -0.00632109f, -0.01129034f, 0.03264667f, -0.04590787f, -0.03470942f, 0.00903714f, 
    -0.03888911f, -0.01077673f, 0.02560893f, 0.01186905f, -0.02567400f, -0.03866224f, -0.00962228f, 0.00647072f, 
    -0.01277796f, -0.01704409f, -0.02627193f, 0.00399936f, -0.00260513f, 0.04021350f, -0.02804454f, -0.02452981f, 
    -0.04587178f, 0.00609489f, -0.04116759f, -0.00142882f, -0.02308244f, -0.03820809f, -0.01981044f, -0.04741901f, 
    0.00092992f, -0.03178339f, -0.04900489f, 0.01137102f, 0.02935205f, -0.03969844f, -0.01930482f, 0.03463152f, 
    0.02397586f, 0.05197405f, 0.02606545f, -0.03459309f, -0.02096488f, 0.03468394f, 0.04301333f, -0.01114592f, 
    0.03251757f, -0.05062325f, -0.01356822f, -0.01939275f, 0.03487623f, -0.01576309f, -0.05102693f, 0.02536194f, 
    0.00832656f, 0.00813634f, -0.00989973f, 0.01003794f, 0.01955395f, -0.03842941f, 0.04000509f, 0.03917205f, 
    0.03847633f, 0.04315246f, 0.04977055f, 0.01611567f, -0.00024356f, 0.03370737f, -0.04860895f, 0.00321486f, 
    -0.05373529f, -0.03753132f, 0.01720057f, 0.01746843f, -0.00818131f, -0.00945497f, -0.03342246f, -0.04832130f, 
    -0.00044794f, -0.02413104f, -0.02175496f, -0.04536538f, 0.03188602f, 0.01425934f, -0.01029313f, -0.00348037f, 
    0.00298836f, -0.04637032f, -0.02928000f, -0.03976612f, -0.04461533f, -0.04309339f, -0.04975539f, -0.03271183f, 
    0.02531118f, 0.00347828f, 0.00820720f, 0.04342390f, -0.05213806f, 0.03404758f, 0.04278708f, 0.01904890f, 
    0.02774166f, 0.00186425f, -0.03635285f, 0.01540659f, -0.02901639f, -0.01077476f, 0.04982677f, 0.03900199f, 
    -0.03639627f, 0.03620023f, -0.04151292f, 0.00329360f, 0.01688616f, -0.03247910f, 0.00459755f, -0.04043147f, 
    0.04767814f, -0.01874977f, -0.03080707f, 0.04555129f, -0.05059181f, 0.03116962f, 0.03948635f, 0.04426000f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.14624375f, 0.01281022f, 0.09812684f, 0.12489077f, -0.04728175f, 0.13801177f, -0.08746934f, 0.00360794f, 
    -0.00442832f, 0.01708092f, 0.03378570f, -0.04690689f, -0.04086027f, 0.03023840f, -0.00640590f, 0.02162635f, 
    0.08406146f, 0.02527333f, 0.01528643f, 0.02382326f, 0.03933363f, -0.01031909f, -0.04911339f, 0.00970864f, 
    0.09323563f, 0.02389297f, -0.04536481f, -0.08738914f, 0.00622203f, 0.10903985f, -0.00424832f, -0.00758633f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.17362894f, 0.05264220f, 0.33588427f, 0.07088550f, 0.03693847f, 0.14503507f, -0.04394741f, 0.12652265f, 
    0.22546363f, 0.07736161f, -0.00021740f, -0.18703642f, -0.07548669f, -0.00832096f, -0.04110609f, -0.13548404f, 
    0.05559813f, -0.16353104f, -0.31881145f, 0.34314224f, 0.01972532f, 0.30710977f, -0.02972168f, -0.02801949f, 
    0.26648337f, -0.09480152f, 0.15703280f, -0.58231497f, 0.11577620f, 0.42799845f, -0.16666526f, 0.11612865f, 
    0.06606953f, -0.03826927f, -0.00519412f, -0.49170533f, -0.02042386f, -0.07506207f, -0.13131793f, -0.02955914f, 
    -0.14831123f, 0.09117193f, 0.07965373f, -0.08382943f, 0.01904934f, -0.07176024f, 0.10537579f, 0.03356695f, 
    -0.67614633f, -0.10315227f, 0.23823933f, 0.12623866f, 0.01666764f, 0.19194439f, -0.03156687f, -0.09606782f, 
    0.47579002f, 0.26960659f, -0.13767450f, 0.24558631f, -0.10010103f, 0.04433456f, -0.10699392f, -0.02917856f, 
    0.28865600f, -0.14430034f, 0.17725937f, -0.02892922f, 0.09395125f, 0.13184308f, -0.12755096f, -0.12352394f, 
    -0.06362128f, 0.03509183f, -0.13510139f, 0.33101165f, 0.14546034f, 0.10215367f, -0.36256415f, 0.07579652f, 
    0.38897115f, 0.17719366f, 0.29095933f, -0.16623779f, -0.00378396f, 0.36740556f, 0.01562159f, 0.06850464f, 
    0.31278306f, -0.27652949f, 0.08898384f, -0.30969697f, -0.10990556f, 0.25392434f, 0.07010517f, -0.08061761f, 
    0.26779950f, -0.11518697f, 0.19664903f, 0.10581776f, 0.05623291f, 0.26248795f, -0.04842656f, 0.07854529f, 
    -0.13993590f, 0.00809361f, -0.16736376f, -0.17296250f, 0.08598860f, 0.02769905f, -0.15957719f, 0.03061909f, 
    0.20571774f, -0.10338955f, 0.24773806f, -0.11492673f, -0.09471120f, -0.45811343f, -0.13560848f, -0.14668483f, 
    0.42480287f, 0.01006610f, 0.00813804f, -0.16464643f, 0.03500079f, 0.39196956f, 0.03857921f, 0.03838570f, 
    -0.13084514f, 0.00210290f, -0.01512482f, 0.04947256f, 0.14318742f, 0.10378948f, -0.07100277f, -0.16736025f, 
    -0.05235250f, 0.04768524f, -0.15500242f, -0.10286707f, 0.07534923f, 0.06602266f, -0.15021151f, -0.12395837f, 
    -0.12753952f, -0.08975469f, 0.06621618f, -0.08572730f, -0.09955069f, -0.14472491f, 0.16725294f, 0.17439921f, 
    -0.00509060f, -0.13650090f, 0.04275766f, -0.10389822f, -0.04423925f, -0.12102687f, -0.08414243f, 0.06527714f, 
    0.14558315f, 0.11472083f, 0.41241813f, -0.24998680f, 0.10404459f, 0.30840448f, -0.11202432f, -0.06044751f, 
    0.38523200f, -0.10145844f, -0.00298377f, 0.14867361f, -0.13019192f, -0.16567211f, -0.14174278f, -0.08639244f, 
    -0.18859667f, 0.10403920f, 0.39337185f, -0.04512923f, 0.11978856f, 0.08752788f, 0.01119398f, 0.11273205f, 
    -0.10452233f, -0.25710639f, 0.16293174f, -0.06399120f, 0.26283923f, -0.09338512f, -0.12502418f, -0.06879313f, 
    0.02877661f, 0.00737507f, -0.32018769f, -0.04976350f, -0.15597536f, 0.09020647f, 0.37696683f, 0.07198969f, 
    0.24804512f, 0.08733131f, -0.05514352f, -0.11070442f, -0.14156187f, 0.11296581f, 0.40419710f, 0.02461764f, 
    -0.03985518f, 0.11111065f, -0.14071430f, 0.03357146f, 0.10996109f, -0.14745843f, 0.10723667f, 0.11352394f, 
    -0.22768059f, 0.06227807f, 0.11159164f, 0.41470039f, 0.25700566f, -0.06877527f, -0.08039881f, -0.11822020f, 
    0.33229685f, -0.02706474f, -0.14336278f, -0.13560434f, -0.01716905f, 0.06014299f, 0.00040673f, -0.05509662f, 
    -0.34146020f, -0.16811047f, -0.09312891f, 0.23774996f, 0.04868214f, -0.13002503f, 0.23707652f, -0.04829877f, 
    0.26390731f, -0.12051121f, -0.44797629f, 0.39807844f, -0.00350239f, 0.25166282f, -0.17639282f, 0.01897961f, 
    0.11503100f, -0.44889003f, -0.14692566f, 0.00529326f, 0.18069860f, 0.10101452f, 0.05548938f, -0.14098354f, 
    -0.13904476f, -0.14129692f, -0.16155881f, -0.09465388f, 0.14960064f, -0.02810238f, -0.16228418f, 0.12225211f, 
    0.05492238f, 0.03002162f, 0.03585323f, -0.01064498f, 0.02307652f, 0.10502971f, -0.15476792f, -0.00672955f, 
    0.09684797f, 0.05937069f, -0.15598905f, -0.02198260f, -0.15368848f, 0.13951178f, -0.07586823f, -0.17640060f, 
    -0.08358006f, -0.02179784f, -0.08444519f, -0.04282297f, 0.15428069f, -0.01537506f, -0.14256138f, 0.08826370f, 
    -0.16180062f, -0.13139565f, 0.01873017f, -0.40298188f, -0.04179784f, 0.30209363f, -0.10587363f, 0.13512421f, 
    0.06798632f, 0.13738340f, -0.04336638f, 0.33503979f, -0.11791820f, 0.02020943f, 0.07603081f, -0.12938519f, 
    0.16740657f, 0.02163541f, 0.19776259f, 0.36461511f, 0.11048879f, -0.15584651f, -0.11908453f, 0.03561433f, 
    0.03260054f, 0.24198169f, 0.15324761f, 0.61720473f, -0.03305630f, 0.04716881f, -0.08001667f, -0.00091577f, 
    -0.03409613f, -0.13244660f, 0.16561395f, 0.10902664f, -0.01755149f, -0.45154488f, 0.22069255f, -0.00944548f, 
    0.05984361f, -0.08902672f, -0.07260872f, 0.31836224f, -0.13483229f, 0.00557278f, -0.15703988f, 0.13493961f, 
    -0.20997669f, 0.06383219f, 0.39903563f, -0.41507983f, 0.07586259f, 0.35698271f, 0.10312830f, 0.13722533f, 
    0.30443037f, 0.32282898f, -0.01871444f, 0.09912738f, -0.10087015f, -0.36526740f, 0.17682461f, -0.17674838f, 
    -0.27242982f, -0.01934983f, 0.21380192f, 0.10042051f, -0.08786581f, -0.04330760f, -0.00469216f, 0.10186782f, 
    0.33566102f, 0.11927599f, -0.08156573f, 0.25099593f, 0.04069663f, -0.03212465f, 0.04604758f, 0.12295030f, 
    0.15483056f, 0.11846982f, -0.20935719f, 0.09896417f, 0.13412839f, 0.12454797f, -0.08494855f, -0.17457326f, 
    -0.34040359f, 0.13959602f, -0.14335057f, 0.35409757f, 0.08864180f, -0.16854398f, 0.13827026f, -0.01081133f, 
    -0.08694473f, 0.13552149f, 0.36538693f, 0.01761900f, -0.06723230f, -0.32867143f, 0.14945236f, 0.07441641f, 
    0.18303099f, -0.09167745f, -0.05615123f, 0.26534891f, 0.11481944f, -0.13335402f, 0.09278596f, 0.07928224f, 
    -0.26238951f, 0.07665122f, -0.01889677f, -0.19141290f, 0.01919049f, 0.52385187f, -0.08686037f, 0.12431344f, 
    -0.32952371f, 0.16720377f, -0.11402957f, -0.09863516f, -0.32300866f, 0.05454076f, 0.17170793f, 0.14251195f, 
    -0.10762138f, 0.14364313f, -0.13768201f, 0.00433983f, -0.13139679f, -0.01483170f, -0.18655530f, 0.00467363f, 
    -0.12394042f, 0.11454871f, -0.02909978f, 0.12052065f, 0.12071514f, 0.10283891f, -0.00679640f, 0.01195656f, 
    0.00926120f, 0.13745503f, 0.07905062f, -0.13676566f, 0.15083973f, 0.06798334f, 0.14884339f, -0.05656339f, 
    0.06243082f, -0.03621031f, 0.09165055f, -0.12792020f, -0.06644396f, 0.04329836f, 0.11271300f, 0.15502883f, 
    0.13103986f, -0.05996507f, 0.06303187f, -0.05403806f, -0.10380509f, -0.26412070f, 0.38490415f, 0.14166778f, 
    -0.44819579f, -0.13752295f, -0.15067978f, 0.28595239f, 0.16841200f, 0.02052587f, -0.19750923f, -0.08622447f, 
    -0.02331492f, 0.17292967f, -0.24664283f, 0.03893740f, -0.08493069f, 0.18990621f, 0.01496767f, 0.02193715f, 
    -0.07777846f, 0.07613845f, -0.13728073f, 0.29129025f, -0.27318957f, 0.33848783f, -0.03801500f, -0.16207299f, 
    -0.28422216f, -0.15644324f, 0.29656249f, -0.05362907f, 0.16496733f, 0.00348658f, -0.02942668f, -0.00389195f, 
    -0.00657410f, -0.14862950f, -0.05023529f, 0.17934361f, -0.16739775f, 0.16987686f, 0.12884156f, -0.12934385f, 
    0.32711145f, -0.04282616f, -0.37449077f, 0.32336652f, -0.11319907f, -0.10093209f, 0.01219820f, 0.06812377f, 
    0.19960770f, 0.31734589f, 0.10727203f, 0.02659991f, 0.16465960f, -0.31020403f, -0.08877332f, 0.12166728f, 
    0.22097853f, 0.05768238f, -0.06666366f, 0.29248825f, 0.12210241f, -0.17154239f, -0.15847114f, -0.14939341f, 
    -0.19188836f, 0.02368805f, -0.13729937f, 0.23820613f, -0.00864046f, -0.15619916f, -0.17117733f, 0.01357080f, 
    0.07621410f, 0.05546763f, 0.38365978f, -0.11172356f, -0.15452172f, 0.01499893f, 0.08261005f, 0.00769494f, 
    0.31963727f, -0.13349679f, 0.14935450f, -0.14701584f, -0.23239610f, 0.31609973f, -0.05839693f, 0.13496101f, 
    0.35120815f, -0.04082700f, 0.23237813f, 0.03199566f, -0.07906386f, 0.14182959f, 0.11828986f, -0.00404882f, 
    0.18644322f, 0.07642514f, 0.16290669f, -0.11519544f, -0.16538395f, -0.18131810f, -0.18764026f, -0.11237358f, 
    0.03229873f, 0.04313691f, 0.44354346f, -0.37838125f, -0.03683105f, 0.20536186f, 0.01831797f, -0.16162264f, 
    0.10391089f, -0.17582241f, -0.00261280f, -0.19562355f, -0.00210708f, 0.22938640f, -0.16527039f, 0.15828347f, 
    0.10971063f, 0.08885684f, -0.05535100f, 0.12534222f, -0.02577462f, 0.10595921f, -0.20146364f, -0.01309519f, 
    -0.17780308f, -0.01471805f, 0.16266742f, -0.08404929f, 0.00643009f, 0.03490033f, -0.00323870f, 0.06796501f, 
    -0.06840079f, 0.16613512f, 0.02221659f, -0.12393911f, 0.16068032f, 0.10117582f, 0.15839848f, -0.12182380f, 
    -0.03774843f, 0.05811038f, 0.08925258f, 0.04168772f, -0.16095094f, -0.10936770f, 0.01777273f, 0.03820390f, 
    -0.18763489f, 0.07823698f, 0.08091266f, -0.04845107f, 0.17235915f, 0.10016660f, 0.00381112f, 0.01221466f, 
    -0.08706380f, 0.13085116f, 0.08447644f, -0.06467210f, 0.02572886f, -0.12666459f, -0.01639603f, -0.11119881f, 
    -0.19947703f, -0.02219282f, -0.07715704f, 0.09536469f, -0.00864421f, -0.03166356f, -0.14286958f, -0.01141996f, 
    -0.17502496f, -0.14301085f, -0.08521271f, -0.05842988f, -0.18688875f, -0.03604282f, -0.05419964f, -0.06570312f, 
    0.25735137f, -0.08372396f, 0.29532531f, 0.16857345f, -0.13195045f, -0.21043526f, -0.44092363f, -0.06200042f, 
    0.01808638f, 0.01920352f, -0.11416371f, 0.14537545f, 0.04539748f, -0.16569671f, 0.10386742f, -0.10347841f, 
    -0.48514953f, -0.01375955f, 0.14009249f, 0.27821267f, -0.06020806f, 0.28925130f, -0.10131725f, 0.07361451f, 
    -0.22342348f, -0.30012894f, -0.14192531f, 0.11285173f, 0.38253632f, -0.28322744f, 0.06740339f, -0.12991408f, 
    0.03600400f, 0.02483033f, 0.05006227f, 0.16218415f, -0.02744668f, 0.20725708f, 0.04085783f, 0.14992502f, 
    -0.37417996f, -0.09350753f, 0.01532336f, 0.25348103f, 0.16629185f, -0.03382001f, -0.06324501f, 0.03618442f, 
    0.00880115f, -0.11380005f, 0.14018700f, 0.35698748f, -0.13629602f, -0.61421967f, -0.05855423f, 0.03578342f, 
    -0.11722934f, 0.34111726f, -0.09541100f, 0.53337103f, -0.08049388f, 0.03357371f, -0.12758175f, 0.14794545f, 
    -0.17238405f, 0.08058461f, -0.02649044f, 0.35192740f, -0.04390118f, -0.42294782f, 0.39753237f, -0.01137837f, 
    0.14002362f, 0.06834597f, -0.13913575f, 0.11821426f, 0.01550723f, 0.17386295f, 0.32180250f, -0.09881543f, 
    -0.40443730f, -0.03574639f, 0.29391056f, -0.14624451f, 0.13311616f, 0.01382032f, -0.07879634f, -0.10819152f, 
    0.06550868f, 0.28019273f, -0.06798422f, 0.15831423f, -0.23853883f, -0.23302323f, -0.00541588f, -0.10175142f, 
    0.09072482f, -0.02299955f, -0.28523692f, 0.43051973f, 0.06516919f, 0.30479139f, 0.62269247f, 0.06994189f, 
    0.14879595f, -0.04632664f, -0.01940386f, -0.07188942f, -0.06167235f, -0.10365003f, 0.24555615f, 0.06582896f, 
    0.27285716f, 0.11147034f, 0.12612669f, -0.28527534f, 0.08271145f, 0.21884310f, -0.09008107f, -0.09259091f, 
    -0.46557733f, -0.42671031f, -0.02727783f, 0.00139619f, -0.07915392f, 0.35537705f, 0.11701079f, -0.12722006f, 
    -0.14740264f, 0.15278596f, 0.01304086f, 0.07977007f, 0.08391033f, 0.10088481f, 0.14284217f, -0.05223787f, 
    -0.17640102f, 0.17019798f, -0.10647698f, -0.10060775f, 0.12394233f, 0.03259874f, -0.00670835f, 0.10766385f, 
    -0.10505389f, 0.10893201f, -0.03186974f, -0.17178056f, 0.01297649f, 0.07321912f, -0.07360483f, -0.04659532f, 
    -0.05571762f, 0.07991631f, 0.16033237f, 0.09714827f, -0.15522717f, 0.00081737f, -0.00379939f, -0.02462053f, 
    0.07425512f, -0.12031300f, 0.38234147f, -0.00085239f, 0.00684256f, -0.28090683f, -0.25969800f, 0.09284193f, 
    -0.03881690f, -0.09716094f, -0.03507952f, 0.12170511f, 0.16768514f, 0.03638386f, 0.10395472f, -0.15709998f, 
    -0.01534227f, 0.01473978f, 0.34751716f, 0.12057909f, 0.08089111f, -0.21860789f, 0.05054101f, 0.10398614f, 
    0.56615669f, 0.47843838f, -0.02408156f, 0.12115337f, -0.30587825f, -0.07530090f, -0.16116127f, 0.09338477f, 
    0.16530021f, 0.07408086f, -0.05086628f, 0.26322576f, 0.10928991f, 0.41276798f, -0.22174850f, -0.08688119f, 
    -0.28800699f, -0.01775155f, -0.09876534f, -0.01024606f, -0.12976025f, 0.01492202f, 0.35460806f, -0.11875881f, 
    -0.15543468f, -0.00770695f, -0.30357558f, 0.50022626f, -0.00238998f, -0.40194836f, -0.04614526f, -0.15129802f, 
    -0.34702215f, 0.13930768f, -0.03704915f, 0.27894148f, 0.40131456f, 0.27334747f, -0.15306279f, -0.08566368f, 
    -0.00289138f, 0.04344523f, 0.15083799f, -0.11937324f, 0.06382950f, -0.29818767f, -0.29873949f, 0.16926476f, 
    0.15926297f, -0.17442654f, -0.05140435f, 0.12411254f, -0.14684360f, 0.01097363f, 0.27921569f, 0.05292299f, 
    -0.29771185f, 0.15492782f, -0.15177420f, 0.52890593f, 0.01340352f, 0.37642154f, 0.16569503f, -0.16836324f, 
    0.25359738f, 0.27014801f, -0.12172460f, -0.11220632f, 0.06947187f, 0.05300085f, 0.18018475f, 0.05854377f, 
    -0.18658887f, 0.01438025f, -0.03730836f, 0.36085129f, 0.06991210f, 0.29968148f, 0.09295858f, -0.07461467f, 
    0.47233254f, -0.11538044f, -0.10275082f, -0.13369432f, 0.12250413f, 0.09618507f, 0.21339492f, 0.00511683f, 
    0.21732497f, 0.14403094f, 0.23423035f, -0.36908174f, 0.09896233f, -0.40785664f, -0.16516128f, 0.05141233f, 
    0.32372808f, 0.29491523f, 0.05175990f, -0.12114859f, 0.08003391f, -0.05286638f, -0.01535468f, 0.07730819f, 
    -0.12376370f, 0.05783564f, 0.07644638f, -0.18343033f, 0.08167379f, -0.06024540f, 0.13011549f, 0.00439429f, 
    -0.02422337f, -0.16855562f, -0.07896046f, -0.19353209f, 0.09006619f, 0.11449883f, -0.12002492f, 0.16235170f, 
    -0.11569860f, -0.01089172f, 0.10630691f, -0.03912312f, 0.04384460f, -0.18230231f, -0.13221523f, -0.04192706f, 
    -0.06289069f, -0.04386264f, -0.15131627f, -0.13536894f, 0.04884422f, -0.07572538f, 0.09654085f, -0.04696071f, 
    -0.04972630f, 0.07633774f, -0.01671967f, 0.08067103f, -0.09322859f, -0.07828187f, -0.02080725f, 0.10259278f, 
    0.05716042f, 0.02838280f, -0.06804377f, -0.14768539f, 0.12822627f, -0.08685654f, -0.13788854f, 0.11891394f, 
    -0.14728306f, 0.15307644f, -0.02834839f, -0.01630563f, -0.02145852f, 0.05421724f, -0.09894145f, 0.15765256f, 
    -0.16249250f, 0.10742772f, 0.00928137f, -0.08648150f, -0.04629214f, -0.10637662f, -0.02460571f, -0.15758342f, 
    -0.05225892f, 0.03816600f, -0.13152607f, -0.07785057f, -0.08937317f, 0.08372565f, -0.16832685f, 0.04960115f, 
    -0.20017685f, 0.08451295f, 0.04070545f, 0.11947678f, -0.15048912f, 0.01445061f, -0.11170126f, 0.10902956f, 
    -0.09014935f, 0.15216403f, 0.06534778f, -0.14980020f, -0.16114390f, 0.10726473f, 0.09661666f, 0.01254412f, 
    -0.03225536f, -0.14851014f, 0.13151740f, 0.05311211f, -0.06548350f, 0.09718910f, -0.11745571f, -0.09326687f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.26375747f, 0.00065045f, 0.01905010f, 0.08956280f, -0.16086389f, 0.06848414f, -0.17315733f, 0.13017426f, 
    -0.09064757f, -0.02055060f, -0.07522057f, 0.10360166f, 0.10995387f, -0.07717416f, 0.20453055f, 0.14222965f, 
    0.26975605f, 0.27374491f, -0.18997614f, -0.19128375f, 0.13490911f, 0.18682081f, -0.05423451f, 0.12211584f, 
    -0.05805023f, -0.06803486f, 0.14947589f, 0.17568196f, -0.01366915f, -0.11608788f, -0.10661673f, 0.13460086f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.42766529f, -0.49349529f, -0.19663393f, -0.31307667f, 0.17156000f, 0.22883867f, -0.07154132f, -0.68434304f, 
    0.01051975f, -0.14398982f, 0.28477687f, 0.32559049f, 0.37599200f, -0.07569614f, -0.37894392f, -0.11647221f, 
    -0.01697033f, -0.06883770f, -0.12921466f, -0.02483772f, 0.36014777f, -0.25221631f, 0.51365298f, -0.08729732f, 
    0.14647821f, 0.05881779f, -0.48273093f, -0.16185856f, 0.08747908f, -0.18975121f, 0.01181802f, 0.04698859f, 
    0.14879718f, -0.26415282f, 0.28716862f, 0.13261203f, 0.16078711f, -0.00139567f, -0.45073673f, -0.30699459f, 
    0.08646306f, -0.26928884f, 0.26441351f, -0.22733872f, 0.05265980f, 0.04838980f, -0.15996934f, 0.01324756f, 
    0.12960194f, 0.25907460f, 0.00416929f, 0.13983974f, -0.20526341f, -0.24782658f, 0.02477730f, -0.13611917f, 
    0.12435316f, 0.29770961f, -0.62766576f, -0.05827971f, 0.15391918f, -0.01166830f, -0.10990045f, -0.01315251f, 
    0.10262320f, -0.74349153f, 0.34275696f, -0.13585636f, 0.04987932f, 0.18541318f, -0.06867135f, 0.19432820f, 
    0.08509042f, 0.16342187f, -0.25086346f, 0.09658384f, -0.00253068f, 0.07345004f, -0.24818991f, -0.35350999f, 
    0.01659245f, 0.21729384f, 0.12997106f, 0.12464093f, -0.00893417f, -0.64155245f, -0.70159674f, 0.25258231f, 
    -0.20075350f, -0.45655441f, -0.46456569f, -0.11600008f, -0.26217264f, -0.09605078f, -0.09557027f, -0.06087428f, 
    -0.28884873f, -0.81822938f, -0.49776378f, 0.12746431f, 0.15192454f, 0.21856600f, 0.31769618f, -0.27967414f, 
    0.00401516f, 0.10152458f, -0.53708005f, -0.00001013f, -0.41758662f, 0.01078234f, -0.42219880f, -0.05810414f, 
    -0.51512235f, 0.11238198f, 0.04263539f, 0.11916990f, -0.40007445f, -0.02899375f, -0.06666588f, 0.29419991f, 
    0.05098423f, -0.34716070f, 0.11991421f, -0.49699408f, 0.33685434f, -0.09684900f, 0.16276282f, -0.11833255f, 
    0.09969705f, -0.49846825f, -0.41676316f, -0.14552067f, -0.11837695f, -0.23643805f, 0.05102249f, -0.30985135f, 
    0.08351731f, 0.21515642f, -0.19462182f, 0.33262306f, 0.17424625f, -0.16827950f, 0.16609176f, 0.12455641f, 
    -0.16902538f, -0.28703409f, -0.17915739f, -0.00862721f, -0.12488848f, 0.23630677f, 0.35698953f, -0.05286122f, 
    -0.02973635f, 0.17939921f, 0.11262710f, 0.22070709f, 0.01136839f, -0.02137336f, -0.11017736f, 0.07949725f, 
    -0.32379347f, 0.91817623f, -0.13193586f, 0.01015748f, -0.11870436f, 0.08260992f, 0.05724281f, -0.10428459f, 
    0.16035472f, 0.26854801f, 0.23630250f, -0.22461601f, -0.10183879f, 0.07257139f, 0.06466524f, -0.17503677f, 
    0.00185260f, -0.01363338f, 0.12684606f, -0.07515936f, 0.18293543f, -0.01935570f, 0.23507385f, -0.47511554f, 
    0.01428078f, 0.26426989f, -0.28862002f, 0.25078213f, -0.15836124f, 0.01883326f, -0.00213718f, -0.03650669f, 
    0.16360681f, -0.21141964f, 0.03348562f, 0.17098932f, -0.11934525f, 0.21680392f, -0.37294164f, -0.09103867f, 
    0.09416565f, 0.36535105f, -0.25910258f, 0.21560590f, -0.25362614f, 0.06870667f, -0.76648319f, 0.33817789f, 
    -0.10595337f, -0.26220781f, -0.10858733f, -0.06116896f, 0.03762601f, 0.19550695f, -0.69741124f, -0.74825746f, 
    -0.19139573f, 0.28098637f, 0.04021604f, 0.01207427f, 0.10889812f, -0.00631595f, 0.03093612f, 0.01224549f, 
    -0.38818961f, -0.26925099f, -0.01112384f, -0.29551926f, -0.06268490f, -0.82439816f, 0.39510748f, 0.50482166f, 
    0.16917287f, -0.16961348f, 0.00425423f, 0.14974156f, -0.49969736f, -0.10437035f, 0.24496481f, 0.23308721f, 
    -0.07525497f, -0.62650639f, 0.01046453f, 0.08448057f, -0.33353239f, -0.07393979f, 0.20174177f, 0.20312037f, 
    -0.20485631f, -0.15583652f, 0.09981897f, -0.05103699f, 0.09265684f, -0.04376605f, 0.03659900f, -0.04863471f, 
    -0.51085901f, 0.13776417f, 0.30544674f, 0.11362761f, 0.06317235f, -0.25988007f, -0.36406890f, 0.20983922f, 
    0.12146191f, 0.20467775f, 0.10099973f, -0.22788213f, 0.27843574f, -0.01689424f, 0.64096570f, -0.20002581f, 
    0.29605153f, -0.03610259f, -0.11274809f, -0.15375760f, -0.60615981f, 0.28955022f, 0.00934697f, 0.02837819f, 
    -0.04368819f, 0.02395377f, -0.26385546f, -0.44245687f, -0.53281921f, -0.06181818f, 0.07291873f, -0.06903319f, 
    0.41741487f, 0.13616067f, -0.26922145f, -0.26087028f, 0.16854358f, 0.11858627f, -0.05245437f, 0.38151488f, 
    0.05420331f, -0.09670836f, -0.29808044f, 0.03266400f, 0.22349952f, 0.09341798f, 0.08126279f, 0.18153836f, 
    -0.41173100f, -0.20333104f, 0.06492084f, 0.04855352f, 0.35492960f, -0.54230189f, -0.30720773f, -0.30691880f, 
    0.08227912f, -0.09150253f, 0.14825024f, 0.31369448f, -0.36724958f, 0.12635094f, -0.09944146f, 0.02404674f, 
    0.34890482f, -0.49715373f, 0.02057907f, 0.36896855f, 0.08896472f, -0.14795874f, -0.08958786f, -0.06625925f, 
    0.04024303f, -0.63013947f, -0.58107483f, -0.75022018f, -0.43586180f, 0.03231087f, -0.33254206f, -0.52575636f, 
    0.37909916f, 0.14621678f, -0.16097993f, -0.15179615f, -0.21572337f, -0.15537593f, -0.09366877f, 0.26875153f, 
    0.09825579f, 0.14798254f, 0.09852193f, -0.17404065f, 0.17534146f, 0.06188149f, 0.15805334f, 0.12991801f, 
    -0.59502995f, -0.19782907f, -0.10574773f, 0.11750701f, -0.03593329f, 0.09145273f, -0.06298857f, 0.32833618f, 
    0.12842791f, 0.03071723f, -0.37422642f, -0.18972513f, -0.48275825f, 0.16017435f, -0.07509710f, -0.17344156f, 
    0.07821066f, -0.06126238f, -0.02450553f, -0.20519283f, 0.49163154f, 0.48872602f, -0.32025141f, -0.09638946f, 
    0.17493342f, 0.02222071f, 0.47507125f, -0.15334953f, -0.23119400f, -0.01321570f, 0.03781786f, -0.12357524f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    0.01655341f, -0.05071302f, 0.10082638f, 0.13434257f, -0.07967601f, -0.07447692f, 0.03291366f, -0.04930156f, 
    -0.14333288f, 0.03209859f, 0.12273516f, -0.08709256f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
