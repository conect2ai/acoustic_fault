#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.85568434f, -1.22310293f, -0.11710648f, 1.17166674f, -0.84039742f, 0.39469489f, 0.05488929f, 0.13109605f, 
    -0.12571497f, -1.10143554f, -0.07868924f, 0.17518117f, 0.12789778f, 0.95578635f, -0.15918593f, 0.07138465f, 
    0.08989953f, -0.93384260f, -0.66047126f, -1.19292498f, -0.70202726f, -0.37676919f, -0.55797374f, -0.66335499f, 
    0.04309262f, 0.48544431f, 0.23008275f, -1.20355082f, -0.45047867f, -0.82955593f, 0.49348912f, 1.25739217f, 
    -0.51989049f, -0.15871140f, 0.02664781f, 0.21647066f, -0.44328853f, 0.09288196f, -0.42396152f, -1.41784358f, 
    0.04717271f, 0.50553328f, 0.43234000f, 1.00826740f, -0.46195099f, 1.07090747f, 0.74579936f, 0.70118171f, 
    0.47509336f, 0.66700071f, -0.14107023f, 0.52111894f, 0.59734797f, -0.29712346f, -0.67607373f, -0.89258522f, 
    -1.13992178f, 0.51266462f, -0.37417585f, -0.09463685f, -0.73850578f, -0.61733031f, -0.67605186f, -0.62008715f, 
    0.83137190f, -0.34181264f, 0.99921429f, 0.15083480f, -1.23229444f, -0.19291013f, -0.41079777f, -0.38138956f, 
    0.01322217f, 0.71495271f, -0.15073745f, -0.02092696f, 0.55465710f, 0.96696872f, 0.47595647f, 0.32121727f, 
    0.88562691f, 1.01774085f, -1.82745361f, 0.76697379f, -0.08312616f, 0.38541728f, 0.42069322f, 0.31797591f, 
    -0.22171666f, -0.11216146f, 0.32350576f, -0.72775644f, 0.75030971f, -0.97005022f, 0.01470478f, -0.80715424f, 
    -0.59107423f, -0.31390297f, -0.73671758f, 0.91062081f, 0.69935066f, 0.63153046f, 1.02244520f, 0.58605474f, 
    -0.00550049f, 0.65964282f, 0.51998085f, -0.01071014f, 0.87621433f, 0.29489106f, 1.08657718f, 0.99315619f, 
    -0.22007509f, -0.15828414f, -0.57358027f, -0.20117606f, 0.26345938f, 0.03474574f, -1.07109320f, -1.07390356f, 
    -0.69579786f, -0.80862314f, -0.70485878f, -0.22035819f, -0.02591692f, 0.78621465f, -1.54245424f, 0.08210158f, 
    1.54920471f, 0.27544838f, -0.07733213f, 0.00862865f, 0.04437722f, 0.03417969f, 0.11101075f, 1.59428704f, 
    -0.79420435f, -1.10073888f, 0.05207850f, 0.65635103f, -0.49754232f, -0.36322066f, -0.16568694f, -0.21743070f, 
    -1.31650400f, -0.29667965f, 0.22231384f, 1.21500230f, 1.10125220f, 0.82361382f, 0.13500999f, -0.70051599f, 
    -0.04140099f, -0.68233037f, -1.28729355f, -0.17313224f, 0.49168831f, -0.24183704f, 1.10271859f, 0.01714706f, 
    -0.35487330f, 0.03090742f, -1.00008178f, -1.16691911f, 0.37773678f, 0.82785374f, 0.60077459f, -0.61753857f, 
    0.46402171f, 0.52688611f, 0.42784089f, 1.07570481f, 0.55443674f, 0.40892074f, -1.22517133f, 1.02240098f, 
    -0.77555835f, 0.37997168f, 0.06716263f, 0.26839295f, -1.32652545f, 0.35105112f, -0.89803988f, -0.20444404f, 
    0.33778253f, 0.55131173f, 0.78844088f, 0.00979580f, -0.52033097f, 1.62341249f, -0.01442997f, 0.55820400f, 
    -0.30731109f, -0.72938269f, 0.54783636f, -1.04784763f, 0.59142607f, 0.04964783f, 1.02894950f, 0.82438654f, 
    1.25991344f, 0.53288198f, -1.03715801f, 0.21944873f, 0.10945565f, 0.00857384f, -0.10710474f, 0.77634794f, 
    0.63319486f, -0.46937034f, -0.81014657f, -0.42265794f, -0.04049588f, 0.21446237f, 0.59404516f, 0.67603582f, 
    -0.32124829f, -1.18679500f, -1.10542738f, -0.07073179f, -0.75352633f, 0.52681315f, -0.37056744f, 0.32747319f, 
    -0.46913585f, 0.47353935f, 0.26499766f, 0.66425097f, -1.70740902f, -0.99458528f, -1.30822241f, 0.15187520f, 
    0.71444428f, 0.16428185f, -0.16876557f, 1.33601213f, -1.08084881f, 0.56561565f, -0.47533202f, -0.64598483f, 
    0.03314496f, 0.34908924f, 0.56968117f, 1.13544106f, 0.40461999f, 0.65095723f, 0.76285899f, 0.98119050f, 
    0.56102777f, -0.74372274f, -0.61081320f, -0.49313557f, 0.39521292f, -0.48007745f, 0.71179706f, -0.32329741f, 
    0.74132097f, 1.23845732f, -0.41536078f, -0.64537889f, -1.00121617f, 0.53243303f, -0.94620270f, 0.07759324f, 
    -0.79380673f, -0.43358216f, 0.85818493f, 0.70606655f, 0.13624220f, 0.49315542f, 1.20718575f, 1.16658413f, 
    0.92212576f, -0.49186367f, -0.48797581f, -0.01836551f, 0.11328144f, -0.12389044f, 0.25270694f, -1.12757885f, 
    -0.94755763f, -1.00143814f, -0.71106005f, 0.43910971f, 1.14048421f, 0.17460999f, -0.10783019f, 0.46096605f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.15243858f, 0.15886603f, 0.60050851f, -0.14913422f, -0.22850309f, 0.13259423f, -0.39683232f, -0.09956817f, 
    -0.28484127f, -0.13656007f, 0.28780222f, -0.30973181f, 0.34847465f, 0.02905461f, -0.47717330f, 0.02237980f, 
    -0.13447376f, -0.06806862f, 0.26787737f, -0.01708610f, 0.12743369f, -0.34501612f, 0.28913444f, -0.22545423f, 
    -0.07137470f, 0.09294625f, -0.47679815f, -0.04768674f, 0.04271183f, 0.15245101f, 0.38957646f, -0.00723254f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.08827933f, 0.25925386f, -0.17789634f, -0.16615796f, -0.15093714f, -0.08915488f, -0.06592122f, 0.03668747f, 
    -0.04733651f, -0.06232451f, 0.00422408f, -0.08949645f, 0.15471703f, 0.02689250f, -0.09794616f, -0.08627212f, 
    -0.19043767f, -0.06544695f, 0.20289385f, -0.04874853f, 0.27242082f, 0.13231730f, -0.23181750f, -0.14545956f, 
    -0.01690617f, -0.00215863f, 0.00102428f, -0.56142986f, -0.22488774f, 0.42306381f, 0.26828668f, 0.01634230f, 
    0.09590703f, 0.12298869f, 0.13125983f, -0.02967680f, -0.08492356f, 0.03044551f, -0.07852039f, -0.07838880f, 
    0.03401317f, -0.16580121f, 0.30182597f, 0.01946114f, 0.04611745f, -0.24055892f, 0.10564519f, -0.02563449f, 
    0.03857137f, -0.02875284f, -0.16488940f, -0.06042592f, 0.07636080f, -0.12036880f, 0.06750308f, -0.12300844f, 
    0.38710400f, 0.01897233f, -0.02539608f, 0.06172812f, -0.05709899f, 0.12365137f, 0.04208606f, 0.13987300f, 
    0.05386705f, -0.11387078f, -0.08855803f, 0.02962013f, -0.07982420f, 0.01163630f, 0.07650565f, 0.02640304f, 
    0.12562235f, -0.15609904f, -0.02141651f, 0.15179375f, -0.18889630f, 0.07448541f, 0.09625316f, 0.01622013f, 
    0.17818615f, -0.09641596f, -0.07517646f, -0.07801998f, -0.30048698f, 0.00837577f, 0.09058835f, 0.27952990f, 
    0.21461535f, 0.05028268f, 0.12433551f, 0.06634229f, -0.04705463f, -0.04712810f, -0.00572223f, 0.06121487f, 
    -0.08868139f, 0.09421756f, 0.10332467f, -0.00352575f, -0.09958342f, -0.27220592f, -0.22298387f, 0.17421784f, 
    -0.15136360f, -0.12921339f, 0.08276310f, -0.15806893f, 0.32911214f, -0.13483369f, -0.07783227f, -0.25790066f, 
    -0.03135718f, 0.09941071f, -0.29652536f, 0.04729771f, 0.03510154f, 0.16022207f, -0.02867654f, 0.08098444f, 
    0.08988630f, -0.18913946f, -0.06628036f, 0.02231959f, 0.11210539f, -0.00647025f, 0.42500424f, 0.16363609f, 
    -0.80639815f, 0.04888202f, -0.08190479f, -0.06161059f, 0.19143687f, -0.17311306f, -0.17499827f, 0.25342759f, 
    0.23732938f, 0.09102736f, -0.28251070f, -0.22431144f, 0.03637088f, -0.03297669f, 0.19799778f, -0.05612368f, 
    -0.03275422f, -0.13750738f, 0.11421377f, 0.04570200f, 0.00416348f, 0.29498127f, -0.11464503f, -0.11120468f, 
    0.18834600f, 0.03886154f, -0.12891051f, 0.28885135f, 0.06610851f, 0.04299858f, -0.09173845f, -0.12972291f, 
    -0.11501127f, 0.23664707f, -0.20180975f, -0.11429161f, -0.22863694f, 0.15602019f, 0.03752520f, -0.11581723f, 
    0.23474385f, 0.07892437f, -0.05219078f, -0.33820692f, 0.22111252f, -0.27585045f, -0.26787347f, -0.03123229f, 
    0.15956710f, 0.05172084f, -0.02166725f, -0.22511053f, -0.13042736f, -0.20645607f, -0.03046879f, -0.00863340f, 
    0.06420863f, 0.17763825f, -0.07358026f, 0.19270784f, -0.09022073f, 0.17679395f, 0.19315155f, 0.04178621f, 
    0.01194124f, 0.18157692f, -0.24947432f, -0.22556606f, 0.02395967f, -0.03956938f, -0.01363114f, -0.09345900f, 
    0.17579126f, 0.04698432f, 0.24518059f, -0.13576028f, -0.20766433f, 0.08472958f, -0.16088951f, -0.12125129f, 
    -0.12681071f, -0.26084286f, 0.00571764f, 0.06392711f, -0.15163006f, 0.13319144f, 0.12316698f, 0.00568374f, 
    0.02824716f, -0.07636897f, 0.24760206f, 0.14321566f, 0.12465782f, 0.08588050f, 0.12334067f, -0.29787144f, 
    0.10662752f, 0.14573032f, 0.24004908f, -0.19199629f, 0.04906069f, -0.08112076f, 0.02215787f, -0.15528420f, 
    0.02753933f, -0.14476596f, 0.24925195f, 0.17051421f, -0.11135174f, -0.01729757f, 0.12777667f, -0.12321741f, 
    -0.04584447f, -0.12554544f, 0.19623591f, 0.21855602f, 0.18014999f, -0.21780598f, -0.34635907f, -0.10784788f, 
    0.02668300f, -0.09253383f, -0.03181256f, 0.02556006f, 0.04856817f, -0.03875250f, 0.08849069f, -0.04063440f, 
    0.03285914f, -0.00241411f, 0.03548742f, -0.12325822f, 0.18830633f, -0.07549616f, -0.23924929f, -0.12727605f, 
    -0.21960470f, 0.03826544f, 0.08476970f, 0.14493053f, 0.08505794f, -0.23210357f, -0.21468098f, -0.01666895f, 
    0.31620991f, 0.17171286f, 0.01526084f, -0.09760869f, -0.12848766f, 0.06506379f, -0.02165398f, -0.21557999f, 
    -0.02756961f, 0.25544098f, 0.13550664f, 0.07252859f, 0.27374181f, -0.14492387f, 0.13869530f, 0.04650317f, 
    -0.04801624f, 0.01800827f, 0.02531773f, -0.02234048f, 0.00883582f, 0.04852757f, 0.03813941f, 0.00288767f, 
    -0.01797353f, -0.05624657f, -0.05075792f, -0.00918141f, 0.02571432f, 0.05112575f, -0.05520234f, -0.04167550f, 
    0.03309637f, 0.02537427f, 0.04454730f, 0.01748342f, -0.02444174f, 0.00072958f, -0.03485967f, 0.04618643f, 
    -0.06288343f, -0.06441265f, 0.01665729f, -0.04945865f, -0.06216106f, 0.01065572f, 0.04901046f, 0.03182066f, 
    -0.04179777f, -0.04625421f, -0.01012072f, -0.04620654f, 0.01026262f, -0.00872312f, -0.06189670f, 0.00414681f, 
    0.01900441f, 0.00044564f, 0.00875135f, -0.04142558f, -0.05043298f, 0.01434150f, -0.00616016f, 0.05277891f, 
    -0.04597998f, 0.01510027f, -0.01374441f, 0.00910583f, 0.00325172f, -0.04620214f, -0.04154278f, -0.01168430f, 
    -0.05775614f, 0.01592530f, 0.02637153f, -0.05370400f, 0.01687615f, -0.00157885f, -0.04609955f, -0.00012458f, 
    0.02355419f, 0.04807403f, 0.00242080f, 0.00535584f, -0.00486506f, -0.03335004f, 0.04672949f, -0.02267818f, 
    -0.04582077f, 0.00895869f, -0.01720097f, -0.01946351f, -0.05622098f, -0.01557133f, -0.01201368f, -0.03636704f, 
    0.04629280f, 0.04149209f, -0.00529389f, 0.04937634f, -0.05095640f, -0.02831198f, -0.01563864f, -0.04201073f, 
    -0.05744746f, -0.02790585f, -0.05444308f, 0.03367686f, -0.03085828f, -0.00105496f, 0.02631313f, -0.03451021f, 
    -0.06085512f, -0.03283598f, 0.03909291f, 0.01484733f, -0.00388128f, -0.04253490f, -0.06461775f, 0.04482822f, 
    -0.03705859f, 0.00087413f, -0.04976804f, -0.02021217f, 0.00782057f, -0.02359837f, 0.01356188f, -0.02150776f, 
    -0.05289999f, 0.01731753f, -0.02642524f, -0.00562962f, -0.04317913f, 0.01707507f, -0.06422435f, -0.03672187f, 
    -0.04283387f, 0.04941867f, -0.05335495f, 0.01535275f, 0.05169619f, -0.00825738f, -0.03364492f, 0.02393650f, 
    0.02327573f, 0.01141111f, -0.03424546f, -0.02372024f, -0.04303048f, 0.02609852f, -0.03925315f, -0.03770576f, 
    -0.02894994f, -0.06115688f, -0.06224142f, 0.01443300f, 0.01706718f, -0.03743850f, -0.03667840f, 0.02606911f, 
    0.02145935f, 0.03289928f, -0.03680138f, -0.05936916f, -0.02030174f, -0.03553003f, 0.05122930f, 0.03718707f, 
    -0.00646290f, 0.03355676f, -0.05969448f, 0.01362241f, 0.03064236f, -0.01860635f, -0.05926777f, 0.02693100f, 
    -0.05963826f, 0.04213424f, 0.00358038f, 0.03519240f, 0.00060118f, 0.00747791f, -0.02963491f, 0.01918416f, 
    0.04973406f, 0.02740017f, -0.01722521f, -0.04187243f, -0.05989252f, 0.02662827f, 0.04484164f, -0.02171252f, 
    0.04230051f, -0.05455483f, 0.01277234f, -0.03945957f, -0.00638460f, 0.03308040f, 0.00246549f, -0.00294659f, 
    0.02466553f, 0.04856480f, -0.02656311f, 0.03549130f, -0.04210884f, 0.00190926f, 0.02507068f, 0.03222241f, 
    0.03345616f, 0.01683799f, -0.06386864f, 0.04324865f, -0.05363739f, -0.06175973f, -0.00648041f, -0.02504455f, 
    -0.03495834f, 0.03994975f, -0.05564089f, -0.03954446f, -0.02813393f, -0.04916044f, -0.00837341f, 0.03647413f, 
    0.00850856f, 0.03982266f, 0.02615127f, 0.00181191f, 0.02039495f, -0.06124511f, 0.03080057f, -0.03483946f, 
    0.01205611f, -0.05178745f, -0.05177508f, -0.05198470f, 0.00302402f, 0.05140004f, -0.02257519f, -0.04326895f, 
    -0.03280051f, 0.02883537f, -0.01395723f, -0.02078858f, -0.03195413f, -0.02661832f, 0.02116251f, -0.05992600f, 
    0.02668285f, -0.06337313f, -0.03003268f, 0.04161724f, 0.02805117f, -0.04438448f, -0.01730083f, 0.04580870f, 
    -0.01893410f, 0.02718102f, 0.00409235f, -0.04243778f, -0.03416074f, -0.02387337f, -0.03052807f, -0.06241080f, 
    -0.00642654f, 0.04236034f, -0.05985919f, -0.06069268f, -0.00304820f, 0.03983200f, 0.02370131f, -0.02857621f, 
    -0.02766958f, -0.03185663f, -0.02313700f, -0.06202678f, 0.00718195f, -0.02891100f, -0.06492778f, 0.02149061f, 
    0.01666994f, 0.00057181f, -0.04012654f, -0.00161398f, -0.02368909f, -0.02455324f, 0.00348063f, -0.05420543f, 
    0.04560265f, 0.02334051f, -0.00829629f, -0.03267372f, 0.00769014f, -0.03612145f, 0.02213066f, -0.04026585f, 
    -0.00252137f, -0.06046301f, 0.02516022f, -0.05620580f, -0.00353304f, 0.04301350f, 0.04416340f, 0.04739825f, 
    0.25579771f, 0.19281283f, 0.08302108f, -0.06036014f, 0.22536395f, 0.09515387f, 0.01395304f, 0.14616986f, 
    0.16173141f, -0.27088645f, -0.00198685f, 0.07289652f, 0.09447452f, -0.09865231f, -0.13125522f, 0.15314917f, 
    -0.20587917f, -0.09567290f, -0.07164832f, 0.08104051f, 0.29965746f, -0.03069036f, 0.04368582f, -0.05096114f, 
    -0.05771787f, 0.04881099f, 0.00405059f, -0.31652153f, -0.10215105f, 0.15163505f, -0.06167130f, -0.08834099f, 
    -0.03039538f, -0.07179052f, -0.23582125f, 0.00998566f, -0.61333495f, 0.04564113f, -0.15233263f, 0.00458326f, 
    0.01772320f, -0.12431451f, -0.22275299f, -0.20610473f, -0.24049202f, 0.12050161f, 0.16503322f, 0.03657512f, 
    0.25216693f, -0.10556948f, -0.08902685f, -0.07610855f, 0.07040466f, 0.22225557f, -0.04505678f, -0.07974348f, 
    0.01282521f, -0.00140243f, -0.09302667f, -0.10872470f, 0.03917503f, -0.10975214f, 0.00659024f, 0.21373868f, 
    0.17453128f, -0.44699171f, -0.02328921f, -0.28409934f, 0.01019700f, 0.14335974f, -0.21714571f, -0.05806470f, 
    -0.01755027f, -0.02058560f, -0.04221728f, -0.23964386f, 0.04678345f, -0.00997240f, 0.11411854f, 0.06400356f, 
    0.30366150f, 0.08199010f, -0.34472725f, 0.21726601f, -0.02399506f, 0.31657478f, -0.05095384f, 0.00212503f, 
    0.07211529f, 0.26160172f, -0.37899274f, 0.14369620f, -0.08860528f, -0.08919245f, 0.11936778f, 0.11432067f, 
    0.00875742f, 0.04859092f, 0.17899530f, 0.31587273f, 0.18409315f, 0.09380636f, 0.14821349f, -0.14587754f, 
    -0.18392341f, -0.08616609f, 0.26839620f, 0.29833341f, 0.09236242f, 0.05273728f, -0.44487667f, -0.06644947f, 
    0.00597934f, -0.03375448f, 0.02792670f, 0.02439011f, -0.05335421f, 0.17141934f, 0.07393157f, 0.29615808f, 
    -0.10908253f, -0.10022517f, -0.02077982f, -0.14679128f, 0.05893550f, 0.03973978f, -0.34432271f, 0.11325931f, 
    -0.35893506f, -0.05746404f, -0.04678373f, -0.02025081f, -0.16892770f, -0.18414232f, 0.17235453f, 0.46782726f, 
    -0.14451195f, 0.51779640f, 0.23258848f, -0.15334779f, -0.04867836f, 0.10522573f, 0.02071029f, -0.03719130f, 
    -0.08747864f, 0.01323551f, 0.06494809f, -0.22309749f, -0.09446173f, -0.06840963f, -0.00685927f, -0.02134496f, 
    0.01702717f, 0.43597442f, -0.27028906f, -0.08533796f, -0.07159574f, -0.04232597f, -0.15172443f, -0.10007290f, 
    0.03388796f, 0.14861479f, -0.21320204f, -0.35507578f, 0.13773397f, -0.07513723f, -0.12212818f, 0.00266794f, 
    -0.04272129f, 0.18943566f, 0.16053307f, -0.25404388f, 0.13950512f, -0.41372207f, 0.17143068f, -0.05998283f, 
    0.12451001f, -0.26136243f, -0.01107277f, -0.17959656f, -0.52312827f, -0.03134274f, 0.01635256f, -0.00808759f, 
    0.09991632f, -0.03530872f, 0.04631137f, -0.03635631f, -0.10852217f, 0.09178876f, -0.36432427f, 0.34400046f, 
    0.01149933f, -0.03956240f, -0.06646567f, 0.17699023f, -0.05378044f, -0.34018666f, -0.01561783f, 0.14045046f, 
    -0.48289779f, 0.08331116f, 0.25713071f, -0.02256303f, 0.04597387f, 0.23471743f, 0.09183701f, 0.21445568f, 
    -0.10320916f, -0.04873526f, -0.21771321f, 0.00805365f, 0.02845232f, -0.02153947f, 0.15091971f, -0.04400851f, 
    0.03954538f, -0.15636228f, -0.00433676f, 0.11867286f, -0.03109227f, -0.09254734f, 0.07748953f, -0.03846013f, 
    0.01684877f, 0.02697770f, 0.46415305f, -0.49993894f, 0.17601009f, 0.09425218f, 0.13393050f, -0.01505139f, 
    0.19242896f, 0.03399782f, -0.02521195f, 0.38285765f, -0.13527015f, 0.04626366f, 0.02586157f, 0.05617882f, 
    -0.06278773f, -0.05854033f, -0.05745339f, 0.09859962f, -0.22546709f, 0.14115015f, 0.09073804f, -0.05249409f, 
    0.10276586f, -0.13838978f, -0.09771048f, -0.06535546f, 0.03964647f, -0.05897479f, 0.07711968f, 0.15120809f, 
    0.00959066f, -0.08895198f, -0.04538800f, 0.18699250f, 0.21919414f, 0.15480843f, -0.13564208f, 0.09147440f, 
    -0.00190195f, 0.01348045f, 0.11361605f, -0.03230591f, 0.13982353f, 0.04905329f, -0.05543845f, 0.10835274f, 
    -0.10231529f, 0.08192974f, 0.10433547f, -0.00818910f, -0.07571732f, -0.00766530f, 0.16932501f, -0.00793261f, 
    -0.30893588f, 0.04320342f, -0.20769724f, -0.13558295f, 0.10624934f, 0.07291367f, 0.00715844f, 0.12192109f, 
    -0.01391099f, 0.00802569f, -0.02501706f, -0.01970002f, 0.01231645f, 0.00087300f, -0.04900527f, -0.00690837f, 
    -0.00180345f, 0.05272331f, 0.03189453f, 0.01577052f, 0.04208181f, 0.00781145f, 0.01211717f, -0.00625826f, 
    -0.00814494f, 0.00978182f, -0.06250157f, 0.02978415f, -0.03411135f, 0.03033850f, -0.03743816f, 0.00660669f, 
    -0.01290628f, 0.05085241f, -0.03874397f, 0.00272194f, 0.04437468f, -0.00049579f, 0.02357410f, 0.00829140f, 
    -0.05003908f, 0.04543452f, -0.05057640f, 0.00808387f, -0.02619716f, 0.03659084f, 0.01107467f, -0.02939382f, 
    -0.06240012f, -0.04432410f, -0.02459909f, 0.03600312f, 0.04638321f, 0.03394054f, 0.03132176f, 0.04062479f, 
    -0.05104866f, 0.03378906f, 0.02351193f, -0.00157204f, -0.02039145f, 0.01955156f, -0.01962554f, 0.01655505f, 
    0.03731910f, 0.04407262f, -0.02334568f, 0.02476758f, 0.04606308f, -0.01275585f, 0.01860847f, -0.02844419f, 
    0.01167852f, -0.02591572f, 0.03268905f, 0.03570706f, 0.03521156f, -0.00907429f, -0.04564427f, 0.02988363f, 
    0.02582274f, -0.00187991f, 0.02877134f, 0.04569601f, -0.04569373f, -0.00550551f, -0.03818814f, -0.03900436f, 
    -0.00399681f, -0.02284880f, 0.01675345f, -0.02401260f, 0.01901930f, 0.03186718f, 0.03123352f, -0.06453018f, 
    -0.06543765f, -0.05736028f, -0.00618301f, 0.01970614f, -0.00217943f, -0.01713478f, 0.01821069f, -0.01222122f, 
    -0.05172894f, -0.03160775f, 0.00947542f, 0.01819357f, 0.00929817f, 0.03123214f, -0.03681877f, 0.03676859f, 
    -0.05246592f, -0.00883451f, -0.03538976f, -0.04892844f, 0.01935682f, -0.02554616f, -0.00561320f, 0.01345816f, 
    -0.01011081f, -0.01549178f, 0.04712477f, 0.01525207f, 0.03957825f, 0.04285928f, -0.00220301f, -0.00284313f, 
    -0.04800766f, -0.03765602f, 0.02815820f, 0.03899525f, -0.01528154f, -0.05650308f, -0.00980578f, -0.04562765f, 
    -0.01972139f, -0.05780211f, -0.00617244f, -0.02878018f, -0.03251168f, -0.01035337f, -0.03956238f, -0.00278846f, 
    0.02233827f, 0.03953749f, 0.01069376f, -0.02495535f, -0.05967879f, -0.01114756f, -0.02758249f, 0.04696152f, 
    -0.04002438f, -0.02730640f, 0.01411734f, -0.03260219f, -0.05281545f, 0.02604997f, -0.00591044f, -0.00223570f, 
    -0.04188161f, -0.01396962f, 0.02726645f, -0.01189015f, -0.01683974f, 0.00153626f, 0.04590484f, 0.01602218f, 
    -0.04811061f, 0.01084354f, 0.01357404f, 0.02745233f, -0.02998786f, 0.00724835f, -0.05574621f, 0.04340585f, 
    -0.02980936f, -0.05095108f, -0.02634594f, 0.05116820f, -0.00897526f, 0.01279160f, -0.06701513f, 0.00138969f, 
    -0.06140742f, -0.02512126f, 0.00407853f, 0.00208963f, 0.05381582f, -0.03062209f, -0.04664651f, 0.03493238f, 
    -0.03908488f, 0.01387985f, 0.02061695f, -0.03721016f, -0.04055301f, -0.01873238f, 0.01471411f, 0.00870160f, 
    -0.06355246f, -0.01228890f, 0.03765951f, 0.00835967f, -0.05177928f, -0.06589478f, -0.04012222f, -0.05609538f, 
    -0.04840821f, 0.03395820f, -0.00886959f, 0.03543881f, -0.02594366f, -0.02382289f, 0.00815319f, 0.01318952f, 
    -0.04556966f, -0.01774866f, -0.02905878f, 0.04186589f, 0.00090327f, -0.03458153f, -0.03627754f, 0.03806353f, 
    -0.04310469f, 0.01390122f, -0.03385170f, 0.03348801f, 0.04467732f, -0.05227188f, 0.00812583f, 0.00841008f, 
    0.04873284f, 0.02569922f, 0.01922588f, -0.04089161f, -0.03881931f, -0.05729463f, -0.03403097f, 0.04996507f, 
    0.01496824f, -0.05770104f, -0.05688361f, -0.01752743f, -0.02809688f, -0.03377650f, -0.05335680f, 0.02794858f, 
    0.04766719f, -0.00969815f, 0.03441542f, 0.04264143f, -0.05127276f, -0.03093054f, -0.05730057f, -0.03551153f, 
    0.02891227f, 0.02781741f, 0.02123814f, -0.03090248f, 0.03784928f, -0.01853513f, -0.04211363f, -0.04981004f, 
    -0.00613341f, -0.04328201f, -0.00002160f, -0.00740324f, -0.00385692f, 0.00124994f, -0.02076501f, 0.04447526f, 
    0.03777042f, 0.04226651f, 0.01106636f, -0.01403813f, -0.05247183f, -0.06024931f, -0.05406915f, 0.01145060f, 
    -0.01732866f, -0.02442665f, 0.03056055f, 0.02025647f, -0.05075766f, 0.03171726f, -0.00282429f, 0.05106430f, 
    -0.01360454f, -0.05971194f, -0.01466460f, -0.00319396f, -0.06213147f, -0.03662569f, 0.00003523f, -0.02394068f, 
    -0.05934022f, -0.03117865f, -0.05790831f, 0.01985859f, -0.02638140f, 0.04762610f, 0.04854038f, -0.04222693f, 
    -0.06034008f, -0.01821191f, -0.00367798f, -0.05140963f, 0.02793538f, 0.04382852f, 0.04214071f, 0.04652846f, 
    -0.06092820f, -0.03279858f, -0.05537393f, 0.04172247f, -0.03326792f, -0.04708778f, -0.03319363f, -0.04009754f, 
    0.02249160f, 0.04421876f, -0.00326947f, 0.02017317f, 0.02023940f, -0.03422527f, -0.05902808f, -0.01641222f, 
    -0.01167659f, -0.05007629f, 0.01287667f, 0.00864863f, 0.04037513f, 0.02865522f, 0.02962815f, 0.00576499f, 
    0.04600370f, 0.04812163f, -0.03964121f, -0.06014249f, 0.03780496f, 0.00813760f, -0.04602762f, 0.02076051f, 
    -0.05997598f, -0.00403596f, 0.01908654f, 0.00144573f, 0.04311974f, -0.04197726f, -0.02354410f, -0.04236937f, 
    -0.02126979f, 0.05711693f, -0.06032113f, 0.04638669f, -0.00670242f, 0.03291768f, 0.00415464f, -0.01404519f, 
    -0.06391127f, -0.03122556f, -0.00483655f, -0.06104528f, 0.00986416f, 0.04218395f, 0.01399347f, -0.05552466f, 
    0.00017840f, 0.00341392f, 0.02152115f, -0.02388933f, 0.01211016f, 0.02023163f, 0.04776363f, 0.01977332f, 
    0.02339054f, 0.03207410f, -0.01837813f, -0.01958070f, -0.00294006f, 0.04674273f, 0.05314866f, 0.00546583f, 
    -0.04857402f, 0.01605395f, -0.05631815f, 0.03850549f, -0.01888465f, -0.05447362f, -0.05198116f, 0.01823752f, 
    0.04264127f, 0.02631529f, 0.04012567f, -0.04964241f, 0.02964543f, -0.04071287f, -0.04945977f, -0.02972011f, 
    0.00391131f, 0.02536873f, -0.02099120f, -0.05614446f, -0.06467778f, 0.01616896f, 0.03376950f, 0.04453045f, 
    -0.00226751f, 0.02975454f, 0.02256205f, -0.06199957f, -0.05354032f, -0.01893733f, -0.00109896f, 0.03470533f, 
    -0.02181814f, -0.01595571f, -0.01565879f, -0.01276985f, -0.04405466f, -0.04861452f, -0.00471735f, 0.04378451f, 
    0.04126243f, 0.04883584f, 0.01606501f, -0.05543334f, -0.01198188f, 0.05170242f, -0.05935269f, 0.01447443f, 
    -0.06343243f, -0.04426882f, -0.02988338f, -0.00886872f, 0.04297442f, -0.04354788f, 0.01558981f, 0.03657713f, 
    -0.04165399f, 0.03277830f, -0.04561391f, -0.03887155f, -0.01023617f, 0.05111057f, 0.02234520f, -0.06494203f, 
    0.01484332f, 0.03129869f, -0.06010235f, -0.04448457f, 0.03456341f, -0.01396617f, -0.05315582f, -0.02086469f, 
    0.03468690f, 0.01777245f, 0.04304506f, -0.03506823f, 0.04129216f, -0.04689963f, -0.03204529f, 0.01663729f, 
    -0.05567569f, -0.02344224f, 0.01497447f, -0.01699450f, -0.00614015f, -0.04106915f, -0.04002530f, -0.02183842f, 
    -0.03692319f, -0.02131482f, -0.00762755f, -0.04125682f, 0.03788191f, -0.04290057f, -0.01060655f, -0.06012518f, 
    -0.05537220f, 0.01099914f, 0.02979149f, -0.00461355f, 0.04534740f, -0.03180547f, 0.02027198f, -0.01092396f, 
    -0.00317315f, -0.05748444f, -0.03884099f, -0.00996146f, 0.00327794f, 0.00674302f, -0.05354044f, -0.03342923f, 
    -0.03695004f, -0.04048901f, -0.05415452f, 0.01269515f, 0.04547205f, -0.02995522f, -0.02992103f, -0.04740670f, 
    -0.05387652f, -0.01227449f, -0.02210129f, 0.03265157f, 0.03276777f, 0.00171966f, -0.03163785f, -0.02118815f, 
    -0.02876206f, -0.00550855f, -0.06503084f, -0.04291616f, -0.05228500f, -0.05658162f, -0.06434430f, -0.03506024f, 
    0.05221300f, 0.01638762f, -0.01609010f, 0.01464293f, -0.02258457f, 0.01391156f, 0.02275392f, 0.00670656f, 
    -0.05099247f, 0.00447453f, 0.03074661f, -0.06280425f, 0.04159380f, 0.04981552f, 0.04763240f, -0.05137545f, 
    0.03895888f, -0.05822895f, -0.05491901f, 0.01357685f, -0.00687784f, -0.05818509f, -0.02559067f, -0.01693315f, 
    0.01547535f, 0.00890881f, -0.00823467f, -0.02140594f, 0.01902145f, -0.02568431f, 0.05024535f, -0.01088610f, 
    0.03063938f, -0.01427028f, -0.02114081f, 0.03694525f, -0.04304763f, -0.00307770f, 0.02883441f, -0.00547345f, 
    0.01773170f, -0.01113608f, 0.02157515f, 0.00161880f, -0.04474438f, -0.02382571f, -0.01576773f, 0.03321355f, 
    -0.05441192f, 0.01924276f, -0.06308866f, -0.05390418f, 0.00032947f, 0.03652086f, -0.01865805f, -0.05062030f, 
    0.00473983f, -0.04956001f, -0.01996822f, 0.04202996f, 0.02045726f, 0.00318731f, -0.04532607f, 0.02566851f, 
    -0.02583255f, -0.04882045f, 0.00043791f, -0.03851059f, -0.03820525f, 0.02754823f, -0.00958416f, 0.02710067f, 
    0.02977539f, 0.02053722f, -0.01122570f, -0.03112671f, 0.02840022f, 0.02751958f, 0.01507735f, -0.03631538f, 
    -0.04829929f, -0.02084439f, 0.01777860f, 0.02579633f, 0.03005390f, -0.04913485f, -0.05311305f, -0.05258953f, 
    0.04060346f, 0.04292446f, -0.01958231f, -0.00179271f, 0.02222747f, -0.06230629f, -0.02598786f, -0.04631024f, 
    0.01350041f, 0.03892950f, -0.04748768f, 0.03445500f, -0.05424421f, 0.00006230f, 0.04612293f, 0.00992753f, 
    0.02174678f, -0.02063906f, -0.03091286f, -0.01037111f, -0.03419575f, -0.03903387f, -0.00164049f, -0.05667174f, 
    -0.05074474f, -0.06341175f, 0.04501409f, -0.01912184f, -0.05982698f, 0.01388511f, 0.04696496f, 0.01815041f, 
    -0.00170832f, 0.01899681f, -0.00958680f, 0.02208623f, -0.05930439f, -0.05737817f, -0.01307075f, 0.04844680f, 
    0.04530283f, -0.03823869f, -0.04881588f, -0.04642930f, 0.03325760f, -0.04504917f, 0.03049554f, 0.02980214f, 
    0.00202583f, 0.00645848f, 0.00862867f, -0.04276373f, 0.03605032f, 0.05031393f, 0.00002631f, -0.04938078f, 
    0.03613124f, -0.02085955f, -0.02322985f, -0.05616835f, -0.03914765f, 0.02438647f, -0.05361218f, -0.06503582f, 
    -0.06208512f, -0.02785452f, 0.02728913f, 0.03299767f, -0.00602691f, -0.03935761f, 0.03295514f, -0.05752762f, 
    -0.03515571f, 0.00938920f, 0.01136803f, 0.00016068f, -0.04313584f, -0.05357487f, -0.02973667f, 0.00765097f, 
    0.01023644f, -0.04160290f, 0.00743572f, 0.00292949f, 0.00060349f, -0.00067268f, -0.05224553f, -0.06361011f, 
    -0.01569454f, 0.03001635f, -0.04609056f, -0.04549385f, 0.01118062f, -0.04150499f, -0.04410890f, -0.02937874f, 
    -0.00746434f, -0.06356982f, -0.02118642f, 0.00498376f, -0.03982729f, -0.04456515f, 0.04840233f, 0.02836440f, 
    0.01146171f, 0.00762124f, -0.06447533f, -0.04951662f, -0.06478968f, -0.03571288f, -0.02835470f, -0.00301279f, 
    0.04868496f, 0.02219391f, 0.00094856f, -0.00457442f, -0.01573902f, 0.00215983f, 0.02365273f, -0.05188592f, 
    0.04624670f, 0.02804364f, 0.01425663f, 0.03047610f, 0.02298825f, -0.06641101f, 0.00146707f, 0.01922270f, 
    0.02351310f, 0.00443156f, -0.03386945f, -0.00844722f, -0.04984920f, -0.00217912f, -0.03214785f, 0.02808327f, 
    -0.04048078f, -0.01450981f, 0.02819847f, 0.00842946f, -0.00776616f, 0.01640262f, -0.02393945f, -0.05180340f, 
    0.03702037f, 0.04647678f, -0.04243952f, -0.00469870f, 0.03223761f, -0.03171539f, -0.05369709f, 0.02336773f, 
    -0.05282636f, -0.03476409f, 0.04570193f, 0.03940506f, 0.03621834f, -0.00893686f, -0.02546153f, -0.02768481f, 
    -0.02757347f, -0.04949639f, -0.00922080f, -0.03993178f, -0.01392074f, -0.05938444f, 0.02766885f, 0.04957533f, 
    0.00999608f, -0.05844833f, 0.00080512f, -0.01197199f, 0.03182480f, 0.01612734f, -0.04464515f, -0.02756174f, 
    0.01531517f, -0.02171465f, 0.04965888f, -0.05118277f, -0.04097106f, -0.05519783f, 0.04897316f, -0.04605263f, 
    -0.01200674f, -0.01518250f, 0.00270910f, 0.00588583f, -0.03672070f, -0.06055744f, 0.03702262f, -0.04434590f, 
    -0.03012316f, 0.01289649f, 0.02584310f, -0.02502378f, 0.00528930f, -0.06416122f, -0.01860305f, -0.02655619f, 
    0.02511376f, -0.03637845f, 0.00962942f, -0.02119146f, 0.04194067f, 0.01491300f, -0.01328279f, -0.06531865f, 
    -0.02990356f, 0.01987867f, -0.01947922f, -0.04049356f, -0.03766373f, 0.04477855f, -0.02037800f, -0.06315240f, 
    -0.06319556f, 0.00653438f, 0.01937680f, 0.02122235f, 0.04221029f, -0.05610735f, -0.00208939f, -0.01121887f, 
    -0.01065325f, 0.03888055f, -0.05743355f, 0.02303900f, -0.04520976f, -0.00576063f, -0.03301433f, 0.00169962f, 
    0.00099240f, -0.03493829f, -0.06291255f, -0.04452412f, 0.02023448f, -0.06547444f, 0.03345986f, -0.02265284f, 
    -0.03939902f, -0.00550848f, 0.02295134f, 0.03888554f, -0.03374152f, 0.02301838f, -0.01002990f, -0.02778678f, 
    -0.06223832f, 0.00109750f, -0.06035214f, 0.02285836f, 0.04105942f, 0.00399781f, -0.01147884f, -0.04811833f, 
    0.01584779f, -0.03338684f, 0.04944774f, -0.05651563f, -0.01316875f, 0.02117625f, 0.02744314f, -0.04033295f, 
    0.03300215f, 0.00030459f, 0.03579872f, 0.01043565f, -0.03427869f, -0.05913037f, -0.00227647f, 0.02643001f, 
    -0.01907910f, -0.04426832f, -0.06287128f, 0.03203811f, -0.00863822f, -0.05247581f, -0.02627046f, -0.08987581f, 
    -0.02312153f, -0.02768762f, -0.03320985f, -0.04723842f, 0.03052453f, -0.06845568f, -0.09822708f, 0.02056242f, 
    0.02518263f, -0.02744110f, 0.03131880f, 0.01087336f, -0.01001962f, 0.04793473f, 0.04138746f, -0.00941394f, 
    -0.07030197f, -0.12042516f, -0.01159311f, 0.04537312f, 0.02601757f, 0.02440890f, 0.00700143f, -0.04490043f, 
    0.01192006f, 0.00679734f, 0.01532872f, 0.02591421f, -0.00995322f, 0.07483245f, 0.02813268f, -0.04051818f, 
    0.08839698f, 0.04007308f, 0.01321574f, 0.03647573f, -0.03565179f, 0.03356406f, 0.03130373f, -0.02582322f, 
    0.00423136f, -0.05697798f, -0.08872925f, 0.02949787f, -0.05138269f, 0.01093284f, 0.01931226f, -0.04214003f, 
    -0.02558689f, 0.04056787f, -0.04107550f, -0.05257082f, -0.00191231f, -0.04595900f, 0.03971984f, -0.09245259f, 
    0.03694650f, -0.05443155f, -0.02477719f, 0.01736038f, -0.00053206f, 0.02582392f, 0.01075474f, 0.01873605f, 
    -0.10918083f, 0.07368334f, -0.00110884f, -0.05928772f, 0.01006775f, -0.00175543f, 0.01136266f, 0.00358755f, 
    -0.04269074f, -0.03715241f, -0.07718876f, -0.07913456f, -0.08150954f, -0.08236054f, -0.05924652f, -0.01254195f, 
    0.00608247f, -0.03857622f, 0.02800236f, -0.00500889f, -0.00702947f, 0.02991419f, 0.04330384f, 0.02098756f, 
    -0.03032387f, -0.06494593f, 0.01929798f, -0.05613085f, 0.04595022f, -0.04830178f, 0.00062578f, 0.05271955f, 
    0.03394796f, 0.02084365f, -0.00562711f, 0.04025197f, 0.00332816f, -0.07448423f, -0.04273376f, -0.02242985f, 
    -0.01879425f, -0.06505627f, -0.01677905f, 0.01737525f, -0.04301277f, -0.02285662f, -0.02149798f, 0.01904139f, 
    -0.05544909f, 0.05942408f, -0.02731016f, -0.05589706f, -0.09801602f, -0.04636953f, -0.05503256f, -0.03605652f, 
    0.00970443f, -0.00398569f, 0.02250117f, -0.00307279f, -0.05509735f, -0.03375063f, 0.00217870f, -0.00015296f, 
    -0.06686232f, -0.04428275f, -0.08034577f, 0.03142056f, 0.03399544f, 0.02699476f, -0.05166973f, 0.01943345f, 
    0.02360263f, 0.01900682f, -0.02495535f, -0.01121108f, 0.03645056f, -0.02956104f, -0.04108316f, -0.03416365f, 
    -0.03381101f, 0.02656834f, -0.04796378f, -0.02808434f, -0.00508398f, -0.01722492f, 0.05308874f, -0.04683065f, 
    -0.00355125f, 0.01208410f, -0.00649089f, -0.01423925f, 0.07042027f, -0.00468295f, 0.01813491f, 0.01954874f, 
    0.01255679f, -0.01526739f, -0.04000493f, 0.03785491f, -0.00587118f, 0.02507856f, -0.00564800f, -0.01949605f, 
    -0.00566616f, -0.03508606f, -0.06699509f, -0.02229250f, -0.00333651f, -0.02549334f, -0.03401067f, -0.11252236f, 
    -0.04405500f, -0.04583884f, 0.02370455f, 0.01009878f, -0.01016001f, -0.03422941f, 0.00784138f, -0.07438046f, 
    -0.04340595f, 0.01215164f, 0.03280723f, 0.00802145f, 0.02926491f, 0.02440982f, 0.01325288f, 0.04046922f, 
    -0.01228385f, -0.03477730f, 0.02128414f, 0.03118239f, -0.03429261f, -0.06842659f, -0.03024598f, -0.06634475f, 
    -0.04022064f, -0.07756437f, -0.02639470f, -0.03417208f, -0.06691656f, -0.01458741f, -0.05546333f, -0.02334074f, 
    -0.02786494f, 0.00040534f, -0.07454900f, -0.05979409f, -0.03432153f, -0.03897751f, -0.02013557f, 0.00896159f, 
    -0.03970961f, 0.01747509f, -0.00704881f, -0.05549787f, -0.00904659f, -0.00128638f, 0.04884988f, -0.06081533f, 
    -0.06463812f, 0.01005287f, -0.05862655f, -0.08260154f, -0.07260632f, -0.05691107f, 0.04762290f, 0.02556549f, 
    -0.03858708f, -0.03394742f, 0.03390899f, -0.00378659f, 0.01121170f, -0.08927286f, -0.07344381f, 0.03558026f, 
    -0.05728901f, 0.05696904f, -0.02894266f, -0.06178335f, 0.03900399f, 0.03232710f, -0.02897552f, -0.08961201f, 
    -0.04478963f, 0.00491310f, -0.03793088f, 0.01672079f, -0.04904117f, 0.00531012f, 0.02490792f, -0.05433493f, 
    -0.10287927f, 0.00609083f, -0.05974536f, -0.05691979f, 0.02651844f, -0.03736570f, -0.04379432f, -0.06022934f, 
    -0.03706095f, -0.02758618f, -0.05455041f, -0.00862197f, -0.04332542f, 0.00427214f, -0.02453464f, -0.02177423f, 
    0.09559474f, -0.42738783f, -0.10158864f, 0.11201532f, 0.21815528f, 0.11352677f, -0.37927729f, -0.24572712f, 
    -0.16951013f, -0.16004005f, -0.21557902f, 0.15061520f, 0.04531213f, 0.00210084f, 0.00696961f, 0.04036081f, 
    0.00414474f, 0.25332776f, 0.16846626f, -0.11108708f, 0.21239738f, 0.11710218f, 0.04470691f, 0.07840976f, 
    0.17299522f, -0.19723423f, 0.06911139f, -0.09223419f, -0.33516952f, 0.25907046f, 0.14039491f, -0.17339920f, 
    -0.00900524f, 0.00935358f, -0.29984781f, 0.21254794f, -0.26188281f, 0.08325548f, 0.09984681f, -0.03997773f, 
    -0.07911114f, -0.10903791f, -0.24698834f, -0.04613430f, 0.10616255f, -0.28773919f, 0.07752974f, -0.01679011f, 
    0.24250470f, 0.18103443f, 0.06356316f, -0.24304239f, 0.02876583f, 0.02472892f, -0.31200501f, -0.35801771f, 
    0.00063923f, -0.12280282f, 0.10590102f, 0.12889689f, 0.08556965f, -0.07020039f, 0.50425750f, 0.20979160f, 
    -0.08717605f, 0.03608877f, 0.08921912f, -0.08162412f, 0.04581746f, 0.09918942f, 0.08302616f, 0.11261536f, 
    -0.48512882f, -0.02949224f, -0.12826426f, 0.18675689f, 0.06469341f, 0.11954613f, 0.27410188f, -0.31546810f, 
    -0.53151786f, 0.14290634f, -0.18189999f, -0.00368760f, -0.05886870f, -0.13686578f, 0.14467686f, -0.07483973f, 
    0.13996738f, 0.10312606f, 0.42679876f, 0.19311789f, 0.03106599f, 0.05127618f, -0.08016060f, -0.16971920f, 
    0.46168855f, -0.06192739f, 0.01162897f, -0.32165584f, -0.40842211f, -0.24604508f, 0.22474067f, 0.27436537f, 
    0.11849203f, -0.39890578f, -0.06849408f, 0.04035953f, 0.09197912f, 0.15474407f, 0.01766350f, 0.01354588f, 
    0.02349052f, 0.13513282f, 0.29092246f, 0.18518990f, 0.00848153f, 0.13194820f, -0.13763057f, 0.12585740f, 
    0.14700289f, 0.08996805f, 0.10073561f, 0.17757483f, -0.07246406f, 0.11039337f, 0.31848842f, -0.11613102f, 
    -0.26758352f, -0.25013617f, -0.09483822f, 0.15261628f, 0.10588253f, -0.14237173f, -0.20272487f, 0.09569503f, 
    0.20116365f, 0.17216711f, 0.20648453f, 0.10123734f, -0.00643883f, 0.01948011f, 0.17904465f, 0.02872333f, 
    -0.05025953f, -0.32394937f, -0.03434104f, 0.34720036f, -0.00969920f, 0.23035140f, -0.06132606f, -0.21162245f, 
    -0.01143133f, 0.00481729f, -0.20560893f, -0.27348226f, 0.24773596f, 0.07938958f, -0.07997869f, -0.16753514f, 
    -0.11731983f, -0.33038369f, 0.11169356f, -0.10089698f, -0.05983353f, 0.08998360f, -0.18854578f, -0.02927729f, 
    -0.03185804f, -0.02065353f, -0.37650865f, -0.27043727f, 0.40912452f, 0.26089674f, 0.20366755f, -0.06538818f, 
    0.07141820f, 0.06497468f, 0.02173750f, 0.02628374f, 0.16992083f, -0.16955577f, 0.02315361f, -0.10663847f, 
    0.18707898f, 0.03840432f, -0.04134182f, 0.08304276f, 0.02975442f, -0.14119866f, -0.16342536f, 0.09358848f, 
    0.04322806f, -0.07835238f, -0.02638425f, 0.24820828f, 0.11544054f, -0.34935734f, -0.16229253f, 0.14750619f, 
    0.33476666f, -0.02733464f, 0.13825361f, 0.04571155f, 0.23677123f, -0.06884454f, 0.10528543f, -0.49849772f, 
    -0.28003770f, 0.03581662f, 0.05674592f, 0.00740945f, -0.18941233f, 0.15038165f, -0.04477294f, -0.19056059f, 
    0.17985064f, -0.11605422f, 0.14264695f, -0.01376864f, 0.04541005f, 0.04012568f, 0.05168271f, -0.14707026f, 
    0.14442669f, -0.09621732f, 0.06918377f, 0.20431775f, -0.02743620f, -0.10141125f, -0.44165090f, -0.09697211f, 
    0.18605678f, 0.12209163f, 0.08173639f, -0.04453071f, 0.18759039f, -0.03680826f, -0.13461074f, -0.23167413f, 
    -0.04180472f, -0.21403289f, -0.21838297f, -0.02911910f, 0.07751950f, 0.13579926f, 0.23201644f, 0.01461166f, 
    0.46998161f, 0.20876557f, -0.15324703f, -0.19348069f, -0.11133608f, 0.01574591f, 0.14770898f, 0.05075719f, 
    -0.09184580f, 0.36139330f, 0.19989805f, -0.10669523f, 0.02197904f, -0.24693602f, -0.21717033f, -0.13279346f, 
    0.02231082f, 0.09073218f, 0.00727954f, -0.08605511f, 0.03803241f, -0.36045742f, -0.05826587f, 0.12284363f, 
    0.36121324f, 0.21441647f, 0.11520913f, 0.06764866f, 0.21980907f, -0.05714749f, -0.03255137f, -0.15420625f, 
    0.02747938f, -0.02151034f, 0.01376443f, 0.05781966f, -0.02560685f, 0.13485722f, 0.03246299f, 0.03149172f, 
    -0.63876522f, 0.07290654f, -0.04586421f, 0.16373923f, 0.15140849f, -0.07670882f, -0.03038189f, -0.05828403f, 
    -0.01355470f, 0.42755324f, -0.39792737f, -0.26354226f, -0.07876483f, -0.17989221f, 0.08350355f, -0.14615721f, 
    -0.13506743f, 0.21275891f, -0.07512404f, 0.09782690f, -0.11990836f, 0.17931120f, 0.15495765f, -0.15225650f, 
    0.02026962f, -0.06678773f, -0.01682060f, 0.22186361f, -0.03630089f, -0.17210448f, 0.08953831f, -0.18530643f, 
    -0.17751525f, 0.18666911f, -0.00672951f, 0.03302916f, 0.06485355f, 0.05565789f, -0.22103548f, -0.08603515f, 
    0.00283517f, 0.18383867f, -0.28798011f, 0.29565591f, 0.11724594f, 0.18796258f, 0.07100071f, -0.06173165f, 
    0.08286847f, 0.01391021f, 0.00792111f, -0.07022096f, 0.09588585f, 0.07231984f, -0.57605815f, -0.16548024f, 
    -0.07958033f, 0.05781674f, -0.08016470f, -0.28006837f, -0.18440711f, -0.05627779f, -0.01681471f, 0.30235171f, 
    -0.01681311f, 0.21348995f, 0.04543389f, 0.02414969f, 0.09349596f, 0.03469377f, -0.02785725f, -0.07485960f, 
    -0.15626766f, 0.17159371f, -0.18810345f, 0.07134404f, -0.02626504f, -0.06836734f, 0.06629402f, -0.07823925f, 
    -0.04928209f, 0.24400134f, 0.34649080f, -0.10828419f, -0.26555592f, -0.05858367f, 0.08004513f, 0.06057058f, 
    -0.03546264f, 0.41910115f, -0.26678005f, 0.08719548f, -0.14400861f, 0.15749449f, 0.14503238f, 0.08245451f, 
    -0.09902015f, -0.10926252f, -0.15155147f, 0.13957974f, -0.08414760f, -0.04725191f, -0.07014895f, 0.00341240f, 
    0.00212223f, -0.18640476f, 0.02130621f, 0.06449150f, -0.42892820f, 0.09233506f, 0.24100178f, 0.06547425f, 
    0.09271669f, -0.18242525f, -0.04967724f, 0.07130559f, -0.11280528f, -0.08957266f, -0.00188714f, -0.09598140f, 
    0.07971495f, 0.09917098f, 0.07741975f, -0.01424332f, 0.01754331f, -0.02639545f, 0.88048363f, -0.60814840f, 
    -0.34514508f, -0.20677021f, -0.07074719f, 0.10363386f, -0.17841551f, 0.11315171f, 0.01931787f, 0.23043579f, 
    -0.18199828f, -0.27433199f, -0.04748842f, -0.09788556f, 0.34853235f, -0.04607106f, 0.06126640f, 0.04097055f, 
    0.52354217f, -0.16609995f, -0.21511422f, -0.28879327f, -0.26747981f, -0.16864100f, -0.18902847f, -0.07875238f, 
    0.02626280f, -0.39050499f, 0.11842731f, -0.08435424f, -0.19854622f, -0.22579899f, -0.14973234f, -0.19389257f, 
    -0.17496191f, -0.00754452f, 0.47072390f, -0.26222366f, -0.10191289f, -0.03354529f, 0.02434839f, -0.07640108f, 
    -0.04485505f, 0.20849019f, -0.22125293f, 0.22198786f, 0.40600610f, -0.06477205f, 0.29376921f, 0.00072901f, 
    0.16826116f, -0.19212890f, -0.11374263f, 0.08735303f, -0.21884303f, -0.09297848f, 0.23003985f, -0.15088093f, 
    0.25629073f, 0.02659149f, 0.10981217f, -0.07915695f, 0.12820883f, -0.33707583f, 0.14644374f, -0.01300825f, 
    0.06902052f, 0.07631918f, 0.14347912f, -0.06912381f, 0.20635438f, -0.17764364f, -0.15322503f, 0.35881686f, 
    0.19709252f, 0.15078785f, 0.31307286f, -0.07687590f, 0.06214618f, 0.10690103f, -0.00200411f, -0.03986829f, 
    0.19382660f, -0.20046303f, 0.05368888f, -0.06294354f, 0.00251777f, 0.08152776f, 0.25829783f, -0.12886557f, 
    -0.06017287f, 0.21076398f, 0.07540268f, 0.11828031f, -0.00438140f, 0.06207950f, -0.07639886f, -0.18781734f, 
    -0.00897620f, 0.05207648f, 0.38901043f, -0.08056146f, 0.07122949f, -0.02397735f, -0.05006795f, 0.00236134f, 
    0.03592452f, -0.08856883f, 0.03631419f, 0.29186565f, -0.06233137f, -0.00214191f, 0.06889408f, -0.16809550f, 
    -0.33472899f, -0.00935401f, -0.04548385f, -0.46534193f, 0.02560962f, -0.13304223f, 0.07436904f, -0.13071319f, 
    0.01600409f, -0.28809595f, -0.12447300f, 0.17598028f, 0.08816539f, 0.03603917f, -0.40886101f, 0.01146155f, 
    -0.24145252f, 0.06845488f, 0.06792541f, -0.08582534f, 0.28222108f, 0.55757707f, -0.12417322f, -0.07221988f, 
    -0.10110258f, -0.22597535f, 0.25438729f, 0.18325661f, 0.07316853f, -0.21322764f, -0.09581693f, 0.21317194f, 
    0.15012842f, 0.11495450f, 0.15841193f, 0.02698868f, -0.06656235f, 0.10094833f, 0.13782524f, 0.25959241f, 
    0.29171538f, -0.04852602f, -0.15301427f, -0.01751513f, 0.08431707f, 0.13532509f, -0.02090354f, 0.01988765f, 
    0.04937861f, -0.03951416f, -0.01262729f, 0.04990231f, 0.04894491f, -0.03813606f, 0.04640085f, 0.05406404f, 
    -0.06259883f, 0.00729222f, -0.01385422f, -0.03494032f, -0.03654382f, 0.00931821f, -0.00917764f, 0.02802011f, 
    -0.04278629f, -0.04713789f, 0.00154408f, 0.01750438f, 0.03248858f, -0.01076787f, -0.05872864f, 0.01980572f, 
    0.02377529f, -0.05158327f, -0.03850053f, -0.03998701f, 0.01432076f, -0.02978225f, 0.02300619f, 0.03224668f, 
    -0.03651608f, -0.02873205f, 0.04691270f, 0.05066406f, -0.05185854f, 0.01094065f, -0.00859482f, 0.01817738f, 
    -0.01007479f, 0.04054494f, -0.01231317f, 0.04318747f, -0.00005245f, 0.00266651f, 0.03607918f, -0.04405292f, 
    0.03388871f, -0.05689379f, -0.05680855f, -0.01835858f, -0.03559149f, 0.01884209f, -0.04010468f, -0.01855145f, 
    -0.02687648f, -0.00206773f, -0.02467125f, -0.04366598f, 0.04423811f, 0.01576172f, -0.05479110f, 0.04327303f, 
    0.04541391f, -0.00866810f, -0.01004330f, -0.06238716f, -0.02310671f, 0.01081868f, -0.02916770f, -0.06488221f, 
    -0.04432291f, 0.04712084f, 0.02930745f, 0.03596381f, 0.04776388f, 0.03537932f, 0.05603042f, 0.01762999f, 
    0.04184371f, 0.03092351f, 0.00896139f, 0.03962344f, -0.06128283f, -0.00230394f, -0.01573544f, 0.00127874f, 
    -0.01231922f, 0.03643845f, 0.05383994f, 0.00428727f, -0.03339111f, -0.03713316f, 0.04697934f, -0.03108112f, 
    -0.03474394f, 0.00644507f, 0.04371511f, 0.04814164f, -0.05725516f, -0.00156705f, -0.00114583f, -0.01460631f, 
    -0.02471868f, 0.03402150f, -0.00951477f, -0.03565637f, 0.01500611f, 0.03348151f, 0.00684987f, 0.04259691f, 
    0.04886688f, -0.05848001f, -0.04065029f, 0.04892473f, -0.03855235f, -0.04356981f, 0.04810595f, -0.05443908f, 
    0.00134839f, -0.05475200f, 0.03957029f, -0.00052590f, -0.03127662f, 0.01579441f, -0.02605543f, 0.04596883f, 
    0.05343203f, -0.03386659f, -0.06225837f, 0.02323835f, 0.03516077f, -0.02238961f, -0.02368098f, 0.03613445f, 
    0.01112243f, -0.01921885f, -0.05835831f, -0.03095963f, 0.00083346f, 0.04955205f, -0.05463921f, -0.06100754f, 
    -0.05312974f, 0.01647182f, -0.04120539f, -0.02521736f, -0.05742881f, -0.06026246f, -0.01447672f, -0.03113563f, 
    0.01179714f, -0.00744786f, 0.01978506f, 0.00486726f, -0.05124449f, 0.01730433f, 0.00559092f, 0.00432742f, 
    -0.06695953f, -0.05190468f, 0.03359081f, -0.02061036f, -0.01181414f, 0.00766583f, -0.01618924f, 0.03468966f, 
    0.05307903f, 0.05038271f, -0.00235272f, -0.00471962f, 0.04109513f, -0.01512557f, -0.04813380f, -0.01401368f, 
    -0.06319076f, -0.05227963f, 0.04874266f, -0.04934489f, 0.03350426f, -0.03524816f, 0.04049943f, -0.03655588f, 
    0.02871161f, -0.06353804f, 0.02157136f, -0.03960660f, -0.00149495f, 0.00783741f, 0.01661250f, -0.03362685f, 
    0.02883676f, -0.03741330f, -0.03151785f, 0.02554275f, 0.01514573f, -0.04070391f, -0.00264110f, 0.00118027f, 
    0.03574747f, 0.01815569f, -0.03478182f, -0.05053462f, -0.01883818f, -0.02705240f, -0.02851074f, -0.00096061f, 
    -0.06235452f, 0.04537781f, -0.05596833f, 0.01390800f, -0.00853908f, -0.02659161f, -0.01132024f, -0.00917562f, 
    -0.04429996f, 0.03398503f, -0.06183164f, 0.00070832f, 0.00905379f, -0.02176056f, 0.04179206f, -0.00679216f, 
    -0.01368417f, -0.04281030f, 0.04261693f, -0.01407304f, 0.03544535f, -0.01698274f, -0.06632851f, -0.01694361f, 
    -0.03510014f, 0.03494389f, 0.03728093f, 0.04208996f, 0.03135684f, 0.01773627f, -0.00429838f, -0.01919847f, 
    0.04518592f, -0.03458549f, 0.00537963f, -0.03454964f, -0.01624529f, -0.06550614f, 0.01724858f, -0.03783300f, 
    0.01951345f, 0.00506247f, 0.00103525f, 0.01377845f, -0.04300250f, -0.02789149f, -0.05474610f, -0.01449255f, 
    0.00388765f, -0.01284584f, 0.01774940f, -0.04992900f, -0.02079663f, -0.00102866f, -0.03164193f, 0.04652229f, 
    0.00124823f, -0.04099198f, 0.03085295f, -0.04601069f, -0.01863708f, -0.02575674f, -0.03987658f, 0.05527152f, 
    0.02642512f, -0.02805087f, 0.03519423f, 0.05273751f, 0.01865900f, -0.02014943f, -0.03040779f, -0.03288589f, 
    0.01945046f, -0.06491721f, -0.03609707f, 0.04247957f, -0.06418737f, -0.04126405f, 0.01418074f, 0.02904006f, 
    0.02255128f, -0.02750304f, -0.01927694f, -0.02915505f, -0.04377011f, -0.01454005f, -0.06050696f, -0.05722969f, 
    0.00920330f, 0.01021603f, -0.04967155f, -0.03858756f, 0.04488802f, 0.01542702f, -0.01828151f, 0.04539456f, 
    -0.06365938f, -0.00827624f, 0.02893456f, -0.00309884f, 0.00726550f, -0.03313790f, 0.00749998f, -0.06501581f, 
    0.03465538f, 0.01712786f, 0.02954044f, -0.04080913f, -0.03399479f, 0.02046888f, 0.02005551f, 0.03480293f, 
    -0.01731704f, 0.01797685f, 0.02111406f, 0.03301159f, -0.02562460f, -0.04088279f, 0.04509213f, 0.03667951f, 
    -0.01624281f, 0.03088784f, -0.05833916f, 0.03410312f, 0.03690035f, -0.00241647f, -0.02932603f, -0.03357421f, 
    -0.05897547f, -0.03515921f, 0.04182290f, -0.03954057f, 0.00398250f, 0.04200135f, 0.03886349f, -0.01059036f, 
    0.04804689f, 0.03653716f, -0.03019681f, -0.04752620f, 0.03810696f, -0.01484079f, -0.01954352f, -0.05629808f, 
    0.03547718f, 0.01481425f, -0.03507155f, -0.05043431f, 0.01889856f, 0.04332115f, 0.00743477f, -0.06153650f, 
    0.01603072f, 0.04119502f, 0.05627394f, -0.01323792f, -0.04388947f, -0.03493924f, -0.02716996f, -0.00304852f, 
    0.03734040f, -0.03317862f, 0.03101750f, -0.00916990f, -0.00391283f, -0.02976560f, -0.03543064f, -0.00406524f, 
    -0.00481839f, -0.03021676f, 0.01903749f, 0.04573228f, -0.05630550f, 0.00775866f, -0.01198622f, 0.02954429f, 
    -0.01825280f, 0.00245159f, 0.00015671f, -0.05636839f, 0.01013633f, -0.01558501f, -0.04303006f, 0.01683735f, 
    0.02960293f, 0.04457286f, -0.00723094f, -0.00590346f, -0.04772408f, 0.04660736f, -0.00814173f, 0.04515853f, 
    0.04168649f, 0.02323215f, -0.00035555f, 0.04287288f, -0.04745640f, 0.01654943f, -0.06379989f, 0.05134835f, 
    0.03931761f, 0.02714531f, 0.01771593f, 0.03525311f, 0.00573983f, -0.02352325f, -0.05052003f, 0.02792018f, 
    -0.01506387f, -0.00581772f, -0.05140453f, 0.02414366f, 0.04944401f, 0.02890041f, -0.05391315f, -0.03269542f, 
    -0.05403336f, 0.00316126f, 0.01673551f, -0.04778853f, -0.04666471f, -0.04538230f, 0.02395568f, -0.05047915f, 
    -0.05915371f, 0.00471162f, 0.03894833f, -0.03818654f, 0.01825818f, 0.05178199f, -0.05395774f, 0.03364201f, 
    0.03242211f, -0.05606654f, -0.00112323f, 0.02229415f, -0.01402728f, 0.01272528f, -0.00039387f, 0.04529087f, 
    -0.01967988f, 0.04284420f, 0.02671140f, 0.00553608f, -0.02431547f, -0.04717987f, -0.04275687f, 0.01490938f, 
    0.01725023f, 0.00035034f, -0.02066147f, 0.03897746f, -0.05031083f, -0.04918563f, -0.03585269f, 0.01306325f, 
    0.04066348f, -0.04282085f, 0.04074494f, -0.06091736f, -0.02116084f, 0.01736211f, -0.00348708f, 0.01258846f, 
    -0.04518357f, -0.05950657f, -0.04963238f, 0.03466750f, -0.02120519f, -0.06580339f, 0.04584161f, 0.02136516f, 
    0.02709519f, -0.00252885f, -0.02079150f, -0.03704479f, -0.04983089f, -0.05178370f, 0.00162955f, -0.05224866f, 
    0.00328300f, 0.04976637f, 0.00496271f, -0.05508596f, -0.02848645f, -0.01499806f, 0.02310376f, -0.05725338f, 
    -0.05992965f, 0.01253108f, 0.03218377f, 0.03373525f, -0.05673779f, -0.03115492f, -0.00435825f, 0.02937922f, 
    0.00243572f, 0.02372497f, -0.05184959f, -0.04095917f, 0.05527091f, -0.05358372f, -0.02070463f, -0.04710356f, 
    -0.05841291f, -0.03945433f, -0.06247395f, 0.02827837f, 0.04447505f, -0.03292874f, -0.04563040f, -0.07050487f, 
    0.04243550f, -0.02380390f, 0.02314567f, -0.03238895f, 0.05514325f, -0.03687995f, -0.03211939f, -0.04831541f, 
    -0.02239485f, 0.03682075f, 0.02344829f, 0.04352082f, 0.01082649f, -0.04512173f, 0.03582615f, -0.01586847f, 
    -0.00019180f, -0.01733751f, -0.04519137f, -0.06033363f, 0.04253967f, 0.04499388f, -0.05927797f, -0.04041731f, 
    0.05023211f, -0.01848209f, -0.06331456f, 0.03605045f, -0.01824922f, 0.04008246f, -0.02623459f, -0.00948311f, 
    0.03083109f, 0.02037197f, 0.04053112f, 0.01592061f, 0.01017426f, 0.01331083f, -0.01772974f, -0.00605172f, 
    0.04741100f, -0.05067434f, -0.01186763f, -0.02006590f, -0.02043229f, -0.02407461f, 0.03022239f, -0.00191174f, 
    -0.05608074f, -0.04890280f, 0.02899927f, -0.00561798f, -0.00987933f, -0.06022220f, -0.00177454f, -0.06097771f, 
    -0.17616820f, -0.03218897f, 0.09817829f, 0.15357184f, 0.03838960f, 0.17817223f, 0.22559433f, 0.01648092f, 
    -0.05273153f, 0.28412533f, 0.12305103f, -0.06704854f, 0.18457912f, 0.21806201f, 0.01414592f, 0.16215445f, 
    0.06983185f, 0.01164563f, -0.21017845f, 0.20204993f, 0.28949755f, 0.19683620f, 0.13006933f, 0.19901207f, 
    0.06657303f, 0.17871909f, 0.16098972f, -0.52587032f, -0.16334276f, -0.07855754f, 0.10261048f, -0.02543383f, 
    0.00342727f, -0.12928012f, 0.00941109f, -0.01758478f, -0.23846029f, -0.36250868f, -0.13477120f, -0.00176333f, 
    -0.14377765f, -0.02939378f, 0.00924503f, 0.16959867f, -0.19396386f, -0.08022726f, 0.04423624f, 0.05325100f, 
    0.27517423f, 0.02747042f, -0.17937168f, 0.04182764f, 0.15470521f, 0.11542101f, -0.00010396f, 0.12118414f, 
    0.00245716f, 0.11590900f, -0.06670663f, -0.24628431f, 0.11749281f, 0.16128567f, -0.08768063f, -0.26551840f, 
    -0.27270001f, -0.06940436f, 0.14108768f, 0.13081665f, 0.16194499f, 0.23122577f, 0.03360926f, 0.13541815f, 
    0.28633767f, 0.17551003f, -0.38095495f, -0.21260341f, -0.12167118f, 0.04914926f, 0.01355041f, 0.07804620f, 
    0.15390898f, -0.77037686f, -0.22033869f, 0.04011416f, 0.11046127f, 0.40802547f, -0.04015879f, -0.16735426f, 
    0.03439653f, -0.08722872f, -0.23796645f, -0.01438083f, 0.06664664f, 0.03301327f, 0.34624675f, 0.13007379f, 
    -0.17150775f, -0.05881809f, -0.02506268f, -0.09873962f, 0.16472477f, -0.12949802f, 0.21102849f, 0.04861267f, 
    -0.26935646f, 0.01853561f, 0.22851191f, 0.21637690f, -0.29590955f, 0.00874268f, 0.05710295f, 0.19421683f, 
    0.26778349f, -0.10242535f, 0.14885785f, 0.04995747f, 0.08008783f, -0.28958428f, 0.20078845f, 0.19440261f, 
    -0.04754163f, 0.04407650f, -0.00671626f, 0.14023775f, -0.11663893f, 0.11816163f, -0.32079262f, -0.25847027f, 
    0.02851816f, 0.03455703f, -0.15811870f, -0.14713138f, -0.17272533f, -0.13758364f, -0.02420800f, -0.10548597f, 
    -0.17074181f, -0.17666428f, 0.01018782f, -0.12078805f, 0.00562733f, -0.12334859f, -0.09209333f, 0.01857477f, 
    0.23556830f, 0.35452428f, -0.06307125f, -0.03003880f, -0.17067385f, -0.11438610f, 0.15166618f, -0.17673910f, 
    0.02134759f, -0.32196435f, 0.11810647f, 0.04947731f, 0.27724791f, 0.08845714f, -0.04911134f, 0.02693092f, 
    -0.22744606f, -0.19107766f, -0.24194005f, 0.06943024f, 0.06651130f, 0.00858798f, -0.01083165f, 0.28771979f, 
    0.05420545f, 0.08032973f, 0.12665093f, -0.49306908f, 0.28367877f, -0.08099980f, -0.05205491f, -0.05365772f, 
    0.04067748f, -0.06798709f, 0.14442918f, 0.12663707f, -0.06843204f, -0.18121836f, -0.09130958f, 0.07054313f, 
    0.19023636f, 0.03584690f, 0.30947903f, 0.03444803f, -0.01167601f, -0.35790446f, -0.11692125f, -0.02328703f, 
    0.06492116f, 0.05629631f, 0.08394870f, 0.13185921f, -0.08654137f, -0.05382609f, -0.09341890f, -0.12420235f, 
    0.14497435f, 0.17974684f, -0.14182644f, -0.13064644f, 0.05098489f, 0.06067598f, 0.09311745f, -0.28447434f, 
    -0.02862414f, -0.25106716f, -0.11480002f, -0.26204121f, 0.03264333f, 0.19494611f, -0.06028096f, 0.19566432f, 
    -0.36040628f, 0.09606662f, -0.11603443f, 0.14770679f, 0.03548017f, 0.08443167f, 0.01363016f, 0.16703744f, 
    -0.30095002f, -0.07218964f, -0.01049087f, 0.06391146f, -0.10352423f, 0.01639768f, 0.06276413f, -0.08235603f, 
    -0.04556243f, 0.29270291f, -0.80218655f, -0.33590463f, -0.36582425f, 0.03198707f, 0.30292904f, -0.01662258f, 
    -0.25726268f, -0.23186409f, 0.21999030f, 0.20146731f, 0.13644202f, 0.15137120f, -0.19694696f, -0.12717272f, 
    -0.48422867f, 0.24551302f, 0.17323984f, 0.25341669f, 0.05254959f, 0.24691883f, -0.13684532f, -0.05447991f, 
    0.26598641f, -0.40372315f, 0.11980091f, 0.06452381f, 0.03929722f, 0.05733373f, -0.32453030f, 0.06887079f, 
    0.14481112f, 0.05411275f, 0.14163870f, 0.23526241f, -0.04605015f, -0.00708362f, -0.10249446f, -0.06672281f, 
    0.01418278f, -0.04096266f, -0.11041987f, -0.13252360f, 0.08225523f, -0.09725229f, 0.08181520f, -0.20889679f, 
    0.12163726f, -0.09854302f, 0.20558283f, 0.21978423f, -0.02993344f, -0.10703506f, -0.03764684f, -0.12280945f, 
    -0.13112521f, -0.06514676f, 0.32207927f, -0.16800882f, -0.08640999f, -0.20520455f, 0.07130723f, -0.11071157f, 
    -0.19269948f, 0.13904281f, 0.10903846f, -0.08331737f, 0.08327205f, 0.05909412f, 0.03828413f, -0.10165343f, 
    -0.10891183f, -0.01238505f, 0.14568195f, 0.03291324f, 0.13273376f, 0.16098526f, -0.16447729f, -0.02294059f, 
    -0.05368814f, 0.01874939f, -0.19468297f, -0.11091667f, 0.09928139f, 0.51297832f, 0.13520443f, 0.02481361f, 
    0.13362449f, -0.05321784f, 0.12318283f, -0.02877971f, 0.42373508f, -0.06927370f, 0.04471884f, -0.11275551f, 
    -0.04936501f, -0.17293800f, -0.13643669f, -0.03524607f, 0.14300820f, 0.01673237f, 0.02828081f, 0.15036117f, 
    0.09064241f, 0.14050083f, -0.02816811f, 0.09771050f, -0.10330675f, -0.04742767f, -0.15216823f, -0.07242151f, 
    0.36101711f, 0.35883304f, 0.16979541f, 0.13324790f, -0.07809610f, 0.12516867f, -0.06973375f, -0.13279234f, 
    0.00457337f, -0.33273888f, 0.19062699f, -0.13099505f, 0.14921923f, -0.22415218f, -0.05986239f, 0.00745240f, 
    0.15387805f, 0.05825877f, 0.24310629f, 0.02052713f, -0.27863365f, 0.19275893f, -0.03604292f, -0.01100270f, 
    0.32060078f, 0.02133696f, 0.41663736f, -0.50749737f, -0.31223091f, -0.15180680f, -0.16616993f, 0.31421462f, 
    0.19043596f, 0.00129406f, 0.08167104f, -0.16921438f, -0.03623626f, 0.11623178f, 0.01806345f, 0.17439282f, 
    -0.17454165f, -0.04747977f, -0.26090756f, 0.25952607f, -0.08106271f, 0.06755300f, -0.35989681f, 0.03042463f, 
    -0.04995394f, 0.19727689f, -0.09970760f, 0.05186107f, 0.38043231f, 0.02949630f, -0.12405957f, 0.08058538f, 
    -0.07412668f, 0.23960276f, 0.00166694f, 0.32973558f, -0.07274913f, 0.13134518f, -0.00158405f, 0.06495406f, 
    0.19043131f, -0.04717776f, -0.05261099f, -0.08951039f, -0.00663829f, -0.08368699f, 0.41856974f, -0.25937739f, 
    -0.44560009f, 0.02644981f, -0.12873282f, -0.00906790f, 0.14593498f, 0.15883960f, 0.13116701f, 0.15070559f, 
    -0.21777570f, -0.11294233f, -0.04332015f, 0.24104968f, -0.20471516f, -0.11748121f, -0.09691838f, -0.12465920f, 
    0.18365221f, 0.21964000f, 0.33208284f, -0.01309429f, -0.32599053f, -0.04127136f, 0.04038833f, 0.05597529f, 
    0.24920933f, -0.14783610f, 0.31639087f, 0.40898186f, -0.07563044f, -0.01577113f, -0.16565686f, -0.12205352f, 
    -0.09957460f, -0.12006491f, 0.24540155f, -0.01618361f, 0.05543180f, -0.08564888f, -0.06079146f, -0.16229172f, 
    0.14463170f, -0.06794863f, -0.09356254f, 0.14758639f, 0.00663394f, -0.20122889f, 0.13460723f, 0.17348790f, 
    0.11267950f, -0.08493090f, 0.07723995f, -0.19224326f, 0.20507538f, -0.03835607f, 0.24552844f, 0.11461838f, 
    0.05136526f, -0.07314844f, 0.03039483f, -0.07934017f, 0.05782613f, -0.14653039f, 0.21553822f, -0.24462155f, 
    0.42336425f, 0.11263476f, 0.18170995f, -0.27491352f, 0.16883431f, -0.06698500f, 0.01788972f, 0.14667073f, 
    -0.07414542f, 0.23673300f, -0.04763852f, -0.00281435f, -0.07720555f, 0.15013406f, 0.17500088f, 0.13617793f, 
    0.09313039f, -0.04383574f, -0.10817662f, -0.05608006f, 0.06922211f, -0.22183348f, 0.02356529f, 0.17342041f, 
    0.03366535f, -0.01826591f, 0.44054690f, 0.10230529f, 0.01737212f, 0.05518055f, -0.19557074f, 0.06817017f, 
    -0.05256768f, -0.17442718f, 0.09495874f, -0.32409927f, -0.08125949f, 0.01466957f, 0.01219141f, -0.20257117f, 
    0.00497383f, -0.21670146f, -0.17505734f, -0.07187205f, 0.09662788f, -0.11589326f, -0.29172209f, 0.03146274f, 
    -0.00978489f, 0.02182418f, 0.15716231f, 0.27387428f, 0.02672297f, 0.00927906f, -0.07207684f, 0.07755946f, 
    -0.05551700f, 0.14526750f, 0.15969019f, -0.02327542f, 0.09076334f, 0.18866564f, -0.09014194f, -0.17208427f, 
    0.00083912f, 0.08774424f, -0.12231597f, 0.11198748f, 0.15237793f, 0.48111305f, -0.02868348f, -0.21769427f, 
    -0.35210213f, -0.31174845f, 0.05368927f, -0.01634692f, -0.03502315f, -0.11173262f, -0.36091641f, -0.04865786f, 
    -0.06703653f, 0.28673398f, 0.05697382f, 0.00893625f, -0.06327773f, 0.10237174f, 0.16806266f, 0.38882777f, 
    -0.00297224f, 0.33891198f, -0.17506760f, -0.07779894f, 0.03198624f, -0.12580709f, 0.07635597f, 0.15599078f, 
    0.15114591f, 0.05348273f, 0.19660142f, 0.09063295f, 0.17806457f, -0.11802721f, 0.00576325f, -0.28914994f, 
    -0.19807501f, 0.01286018f, -0.07461377f, -0.27189821f, -0.13408415f, -0.07552391f, -0.09284677f, -0.02513098f, 
    0.12441764f, 0.05237786f, 0.09053775f, -0.27066159f, 0.16774014f, -0.11564194f, -0.09924055f, 0.12729788f, 
    -0.01359904f, 0.06189495f, 0.06012386f, 0.46611509f, -0.07909852f, 0.07436918f, -0.13635488f, -0.29863319f, 
    -0.08312441f, 0.05173961f, 0.22055455f, 0.15193129f, -0.12326314f, 0.40998027f, 0.06439595f, 0.02043141f, 
    -0.03961537f, 0.09163769f, -0.14234769f, 0.19789121f, 0.17766698f, -0.33220336f, -0.04667130f, 0.32846525f, 
    -0.11440945f, -0.03420682f, 0.22087030f, 0.00779124f, -0.10784187f, -0.19173874f, -0.55808252f, -0.47330177f, 
    0.12372603f, -0.14821371f, 0.23860821f, 0.14382519f, -0.10621509f, -0.05989131f, 0.28258985f, 0.21912776f, 
    -0.36509046f, 0.26675507f, -0.09115174f, -0.04379464f, -0.36904597f, -0.06234611f, 0.05929134f, 0.22152422f, 
    -0.14850833f, 0.07327770f, -0.09103486f, 0.11026360f, -0.04503594f, -0.03850648f, -0.32155862f, -0.00742341f, 
    0.03440415f, 0.16272970f, 0.05594670f, -0.22888294f, -0.05635947f, 0.08509311f, -0.09834176f, 0.21699427f, 
    0.28253847f, 0.03923277f, -0.01342720f, 0.06139150f, -0.33007234f, 0.09214695f, 0.24730122f, 0.07728728f, 
    0.14278562f, -0.19619402f, 0.06173826f, -0.34688309f, -0.41110879f, 0.22060037f, -0.24261855f, -0.03004476f, 
    0.19402747f, 0.08533514f, -0.05860129f, 0.07639233f, -0.32525241f, -0.45386630f, -0.05524597f, 0.02475006f, 
    0.34368551f, 0.17245018f, 0.06911352f, 0.04956443f, -0.06871787f, 0.15784918f, -0.31090662f, 0.29002726f, 
    0.04577899f, 0.08753024f, -0.00880241f, 0.16794056f, 0.04616736f, 0.14805238f, 0.28362170f, -0.23341878f, 
    -0.53073776f, -0.29374811f, 0.01791102f, 0.04074335f, 0.02991378f, 0.14628907f, -0.14462543f, 0.08091982f, 
    -0.41130662f, -0.08143673f, -0.18240748f, 0.08811457f, 0.10202665f, 0.02409244f, -0.18474306f, -0.15044676f, 
    0.52672625f, -0.02877769f, -0.07305517f, -0.10849319f, -0.07586648f, -0.06302974f, 0.04494839f, 0.13041390f, 
    -0.14297657f, -0.05828937f, -0.06083198f, 0.01414592f, 0.02030057f, 0.00632523f, -0.14051071f, 0.00242232f, 
    -0.16520180f, 0.10064986f, 0.41443029f, -0.20167142f, -0.00896872f, -0.31497693f, -0.17823184f, -0.14719839f, 
    0.25662318f, -0.11310842f, -0.27284929f, 0.14346974f, 0.44090384f, -0.10347275f, 0.01072431f, 0.11283633f, 
    0.21166965f, 0.04447514f, -0.04510378f, -0.30361411f, 0.26805398f, -0.22018120f, -0.13201822f, 0.13607815f, 
    0.16207279f, -0.09603062f, -0.24933520f, 0.01426530f, 0.22388090f, -0.20238568f, 0.26189461f, 0.05125098f, 
    0.02096789f, 0.03020899f, 0.08556169f, -0.10793551f, 0.04812773f, -0.19021559f, -0.40846136f, 0.19979227f, 
    0.25207791f, 0.11835281f, 0.13962302f, 0.11472418f, -0.19546442f, -0.11332128f, -0.06444331f, -0.17992634f, 
    0.03592955f, -0.06580757f, 0.09302338f, 0.16426019f, -0.10171595f, 0.06970769f, 0.00375415f, -0.14463061f, 
    -0.23527305f, -0.14757942f, 0.25063592f, 0.03273974f, 0.18745853f, 0.14371783f, -0.08786377f, -0.07440676f, 
    0.29673430f, 0.20797269f, 0.22265887f, 0.14255536f, 0.28086588f, 0.21648727f, -0.22132297f, -0.02049024f, 
    0.19365616f, -0.05703769f, -0.30931169f, -0.08582473f, -0.17039368f, -0.02593765f, 0.06086273f, 0.26629013f, 
    -0.26354781f, -0.06655754f, -0.18032190f, -0.32104051f, -0.03045771f, 0.19046740f, -0.05643044f, -0.05150298f, 
    0.10789876f, 0.11549883f, 0.21001327f, 0.13605866f, -0.26040578f, 0.21751468f, -0.02409858f, -0.11012655f, 
    -0.18144177f, 0.08735584f, -0.12535794f, 0.09810100f, -0.16137391f, 0.18928498f, -0.12110952f, 0.14159136f, 
    -0.15735212f, 0.06285576f, -0.13005854f, 0.09549756f, -0.04096439f, 0.00666723f, -0.47798979f, 0.17706302f, 
    0.13077837f, 0.10373789f, 0.21306741f, 0.12042090f, -0.04969811f, 0.04577530f, -0.06362431f, 0.51241887f, 
    -0.20145884f, 0.08889297f, -0.16440186f, -0.00295660f, 0.06462227f, -0.24497695f, -0.20239992f, 0.02454485f, 
    0.02247894f, -0.06248889f, 0.02767555f, -0.05236505f, -0.00480860f, 0.04937094f, -0.04229232f, -0.00754528f, 
    -0.03219759f, -0.02027226f, 0.03292576f, 0.01257032f, -0.02713483f, -0.02572522f, 0.03090503f, -0.05020758f, 
    0.03290153f, -0.05922886f, -0.02889311f, -0.00520674f, -0.03738555f, -0.02563016f, 0.01595625f, 0.00718815f, 
    -0.04905615f, -0.02654848f, 0.00807300f, 0.04279743f, 0.04468135f, 0.00235654f, -0.00923446f, -0.02746057f, 
    0.03353700f, -0.03384724f, 0.01986274f, 0.02853315f, 0.01051404f, -0.02901262f, -0.00576104f, 0.02871391f, 
    0.03931271f, 0.05503566f, -0.02054490f, 0.05008755f, -0.01394221f, 0.04911041f, -0.02961986f, -0.03703898f, 
    -0.04841985f, 0.01304556f, -0.03279976f, 0.01407364f, 0.01657037f, 0.04302888f, 0.03524036f, -0.06473187f, 
    0.00002646f, 0.01242015f, -0.02323738f, 0.03187303f, -0.05473451f, -0.02804032f, 0.01960087f, 0.01267635f, 
    -0.01986549f, -0.05664851f, -0.02834135f, 0.01455308f, 0.02890678f, 0.02734444f, 0.01898069f, 0.04595686f, 
    0.01442109f, -0.04624767f, -0.04318489f, -0.06235410f, 0.01291938f, -0.02341852f, -0.00995932f, -0.04055063f, 
    -0.03885850f, 0.00586880f, 0.01540137f, -0.02253906f, -0.00864221f, 0.00023301f, 0.00900030f, 0.00496233f, 
    0.02585847f, 0.02438893f, -0.01487116f, -0.02728612f, 0.02996815f, 0.05654145f, -0.00057029f, -0.03762643f, 
    -0.02948765f, 0.01245245f, -0.01522645f, 0.03986535f, 0.04228184f, 0.01439802f, -0.04306210f, -0.01211024f, 
    0.00739340f, -0.06227495f, -0.03129952f, -0.01568543f, -0.00893557f, 0.02155704f, -0.00216506f, -0.04103887f, 
    -0.02678094f, -0.03993665f, 0.00328385f, 0.03364534f, -0.05833574f, -0.06167113f, -0.01539624f, -0.05396375f, 
    -0.01625367f, -0.04230991f, -0.01497438f, 0.01082011f, -0.02088961f, -0.05863724f, -0.05385313f, 0.04883468f, 
    0.03695943f, 0.00569629f, -0.01075830f, -0.06308093f, 0.03507226f, 0.00964808f, 0.03857016f, 0.01288810f, 
    -0.01982885f, 0.03770041f, -0.03484392f, -0.02332800f, 0.03211939f, -0.03354038f, 0.01707708f, -0.00823986f, 
    -0.03529328f, 0.01434901f, -0.02025868f, -0.04766595f, -0.03719840f, 0.04792906f, -0.03070891f, -0.03390851f, 
    0.05106892f, 0.02380477f, 0.06314313f, 0.03891500f, -0.04861811f, -0.00131255f, 0.01620538f, 0.00848252f, 
    -0.03021005f, -0.02847745f, -0.00936745f, 0.01290814f, -0.02146220f, 0.04532410f, -0.02556983f, -0.05602584f, 
    -0.04250319f, 0.02985713f, -0.01094158f, 0.01880824f, -0.04025175f, 0.02747350f, -0.04230318f, -0.06038966f, 
    0.03555789f, -0.02094307f, 0.01355140f, 0.02690496f, -0.02178527f, 0.02980340f, -0.01003924f, 0.02579240f, 
    -0.03543841f, -0.01685716f, -0.00253330f, -0.03736159f, 0.02886847f, -0.03145096f, 0.04389076f, 0.04068399f, 
    0.01822742f, 0.02217848f, 0.02537033f, -0.01548869f, 0.02956160f, 0.01073758f, -0.05697239f, 0.00938355f, 
    -0.04088778f, 0.01432055f, -0.00004079f, 0.02544320f, -0.06111735f, -0.06318088f, 0.02826623f, -0.02862565f, 
    -0.03458561f, -0.00676317f, -0.03104833f, 0.01654867f, -0.03096703f, -0.01903590f, 0.01410324f, 0.02062743f, 
    -0.01043470f, -0.01153445f, 0.04622881f, -0.05615254f, -0.00338009f, 0.02637213f, -0.06345498f, -0.05223398f, 
    -0.00460788f, -0.04911424f, 0.01523291f, -0.06611337f, -0.01294413f, -0.02123903f, 0.01806198f, 0.01984365f, 
    0.03080193f, -0.05094427f, -0.06380535f, 0.00407802f, -0.04565154f, 0.04332947f, -0.03447510f, -0.03094043f, 
    0.04771778f, 0.01113318f, 0.03115123f, -0.05473860f, -0.04896605f, 0.03718483f, -0.06323964f, 0.01313642f, 
    -0.02713737f, -0.01331785f, 0.01778628f, -0.02040695f, -0.00681329f, 0.03955850f, -0.01719877f, -0.00941354f, 
    -0.01678565f, -0.03657408f, -0.03394678f, -0.00366389f, -0.05824104f, -0.06020613f, 0.01614074f, 0.01365138f, 
    -0.03127177f, -0.01935229f, -0.02974130f, -0.00944387f, 0.00245901f, -0.00860672f, -0.03667303f, -0.06379118f, 
    -0.01861182f, -0.01548360f, 0.03938333f, 0.03108316f, -0.03657385f, 0.03823552f, 0.05598472f, -0.01514123f, 
    0.02314016f, -0.05589370f, 0.03091368f, -0.02234145f, -0.00772520f, 0.03212397f, -0.00576010f, 0.03463066f, 
    0.00584567f, -0.02105136f, 0.00580113f, -0.03290500f, -0.00960718f, -0.05375060f, 0.02230765f, -0.01547584f, 
    -0.01488029f, -0.01399082f, -0.05537016f, -0.06196418f, -0.01555315f, 0.04240227f, 0.02879265f, -0.04669002f, 
    -0.01061304f, 0.05252638f, 0.00725865f, 0.04319442f, 0.02559250f, 0.00938996f, 0.04323203f, -0.00079190f, 
    -0.05381472f, -0.05238077f, 0.03378819f, -0.02924234f, 0.04314784f, -0.01945811f, 0.02419918f, 0.03402116f, 
    0.02466695f, 0.04026816f, -0.04965452f, 0.04609750f, 0.02244149f, 0.04111217f, -0.01784517f, 0.03167336f, 
    -0.03026316f, -0.03472133f, -0.00510807f, -0.01266298f, -0.03364513f, -0.00786540f, -0.00542061f, -0.00489688f, 
    0.04165541f, -0.00642001f, -0.03810660f, 0.03598436f, 0.00255586f, 0.04113240f, -0.04820703f, 0.00544914f, 
    0.02005456f, 0.01113455f, 0.04099976f, -0.04523464f, 0.00178968f, -0.06036833f, -0.00466782f, -0.01134355f, 
    -0.00176802f, -0.01710572f, 0.00209737f, -0.00988825f, 0.01088887f, 0.02935269f, 0.02370287f, -0.04140009f, 
    -0.03480091f, -0.05540095f, -0.04136671f, -0.05239639f, 0.05773212f, 0.01646249f, -0.03020260f, 0.01126850f, 
    -0.05353776f, -0.01043235f, -0.01290400f, 0.04133049f, -0.04905804f, -0.00515742f, -0.03118052f, 0.02367840f, 
    -0.02449506f, 0.00648432f, -0.05206157f, 0.02380436f, 0.03772621f, 0.02487883f, -0.03276190f, -0.03400141f, 
    0.03912366f, 0.00157679f, -0.06440468f, -0.03975769f, -0.06206528f, 0.03982658f, 0.03106859f, 0.03811681f, 
    -0.05084935f, 0.04097877f, -0.02517914f, 0.03811846f, 0.03168993f, -0.02821333f, -0.06141713f, -0.01585497f, 
    -0.04343154f, -0.04937765f, -0.05141639f, -0.05455803f, 0.01491225f, -0.01516349f, -0.02793291f, 0.03670859f, 
    0.03203699f, -0.04790894f, -0.01221176f, -0.04626482f, 0.03055662f, 0.03147570f, 0.00438803f, -0.03716172f, 
    -0.04014229f, -0.04211936f, -0.05112151f, 0.01637028f, 0.01091663f, 0.00130817f, 0.02152728f, -0.02943630f, 
    -0.06052774f, -0.04308711f, -0.02439884f, -0.00176084f, -0.03162044f, 0.03068013f, 0.05158044f, 0.02720316f, 
    -0.06222907f, 0.04675343f, -0.04591915f, 0.05026427f, -0.04630489f, -0.05171555f, 0.00781542f, -0.03962077f, 
    0.04049284f, -0.06711656f, -0.01961509f, 0.03686332f, 0.04866478f, 0.02582632f, -0.02144025f, 0.04562280f, 
    0.02273496f, 0.02541661f, -0.05885324f, 0.03964670f, 0.03761494f, -0.04574263f, 0.04569662f, -0.04237093f, 
    0.03086754f, -0.05452169f, 0.03532155f, 0.01878610f, -0.05917230f, 0.04183313f, -0.04077897f, -0.04963833f, 
    -0.02250896f, -0.04680547f, -0.00384021f, 0.04911413f, 0.03843485f, 0.00216561f, 0.02268752f, -0.03608041f, 
    0.00031337f, 0.00383608f, -0.05929733f, -0.02918052f, -0.00569638f, -0.00999555f, -0.02277221f, 0.06346930f, 
    0.01547576f, -0.04383378f, -0.00809948f, -0.05721854f, -0.03767138f, -0.04923668f, 0.03795600f, -0.04379169f, 
    -0.00042424f, 0.00857255f, 0.03833183f, -0.02083811f, -0.05153110f, 0.00488526f, 0.00982936f, 0.00790953f, 
    0.01859217f, -0.06696017f, -0.04066892f, -0.03186536f, -0.03658268f, -0.02016231f, -0.01006416f, 0.00737460f, 
    0.02990835f, 0.02314521f, -0.02586125f, -0.05612596f, -0.01327271f, 0.01276071f, -0.03010579f, 0.04609966f, 
    -0.00243884f, -0.04848152f, 0.03338699f, -0.02285184f, -0.03487303f, 0.05812613f, -0.00605345f, 0.03512816f, 
    0.04059232f, -0.05766254f, -0.06478006f, 0.01286243f, -0.02683846f, -0.05770122f, 0.03023471f, 0.01492242f, 
    -0.03166432f, 0.00561617f, 0.05065932f, -0.00438970f, -0.00886536f, -0.00376658f, -0.03564249f, -0.04802224f, 
    0.05590637f, 0.04934225f, -0.00191055f, -0.01946283f, -0.03361492f, 0.02165363f, 0.01354338f, -0.06047096f, 
    -0.05572357f, -0.00779067f, 0.00331342f, -0.02157141f, -0.05769034f, 0.03544449f, 0.01808964f, -0.03990786f, 
    -0.05909314f, 0.01507628f, 0.02050807f, -0.06011602f, -0.05927264f, 0.05390457f, 0.03345568f, -0.02987590f, 
    0.02293922f, -0.01317345f, 0.02417848f, 0.02610269f, -0.03302906f, 0.00130661f, 0.02621243f, -0.04664783f, 
    0.03514113f, 0.01096617f, 0.01482518f, -0.00594241f, 0.03531927f, -0.00530795f, -0.05378469f, -0.05147295f, 
    0.13580316f, 0.08482061f, -0.30918860f, -0.01328380f, 0.06805483f, -0.00506260f, 0.19673046f, 0.07346389f, 
    -0.05173257f, 0.15234870f, 0.37141511f, 0.09448022f, -0.07352438f, 0.02184018f, -0.01177345f, 0.01047285f, 
    0.00453391f, 0.05027986f, -0.33414310f, -0.06735083f, -0.28665853f, -0.07596786f, 0.05826776f, -0.29259399f, 
    -0.03697896f, 0.01899645f, 0.04617643f, 0.36733928f, 0.22895268f, 0.11599505f, -0.01365302f, -0.20961243f, 
    -0.17597519f, -0.14305171f, 0.11018804f, 0.15131235f, -0.37967533f, -0.12751751f, -0.00415908f, 0.05741319f, 
    0.12030752f, 0.15586181f, -0.01488116f, 0.04716328f, 0.16412792f, 0.03899155f, 0.24098189f, 0.09929204f, 
    -0.21434729f, -0.00290916f, 0.18298443f, -0.01001079f, -0.14678420f, -0.00684098f, -0.35623392f, 0.26250249f, 
    0.13869672f, -0.26721579f, -0.23610432f, 0.00613559f, 0.08655874f, 0.06486794f, 0.34199756f, 0.22992949f, 
    0.20819072f, -0.13416684f, 0.03754310f, -0.21647248f, 0.17083560f, 0.03506292f, 0.20653433f, 0.07992727f, 
    -0.26859739f, -0.09271055f, -0.03269924f, -0.10067666f, -0.03465236f, 0.38202786f, -0.10110604f, -0.06198409f, 
    -0.19572315f, 0.04551898f, -0.06002717f, -0.06358197f, 0.02611439f, 0.01447617f, -0.16484758f, -0.11926336f, 
    0.03403827f, -0.26487869f, -0.02317605f, -0.25615013f, 0.11114651f, 0.00825155f, 0.03902178f, 0.02187873f, 
    0.00321115f, -0.01334896f, 0.13385239f, 0.01408754f, 0.03325827f, 0.20239264f, -0.08789972f, 0.07287606f, 
    0.20689449f, -0.12001405f, -0.20551899f, -0.22900851f, 0.06657420f, -0.08569391f, -0.06228177f, 0.05229945f, 
    0.06805105f, -0.04426386f, -0.11569017f, -0.00685965f, -0.14714637f, 0.04870559f, -0.06336259f, 0.00141225f, 
    0.12168235f, -0.17868586f, -0.12631391f, -0.11972807f, 0.18250233f, -0.15478206f, 0.21501023f, -0.12207449f, 
    -0.01687323f, 0.00113214f, -0.00299029f, 0.06160564f, 0.09459178f, -0.04645748f, 0.01653441f, -0.10031916f, 
    0.09963480f, 0.19872686f, -0.17521645f, 0.04235839f, 0.10570526f, -0.26842409f, 0.01322580f, 0.08746208f, 
    0.36594367f, 0.21553940f, 0.05936911f, 0.00526504f, -0.16219284f, 0.11335902f, 0.00079317f, 0.13102166f, 
    0.09213979f, 0.46508902f, 0.00811121f, 0.07462363f, 0.04353473f, -0.05324214f, 0.03415633f, 0.12573285f, 
    -0.06645916f, -0.01056958f, 0.25108019f, 0.06730445f, -0.00670472f, -0.07998853f, -0.01590867f, -0.03662977f, 
    0.16042228f, -0.00122716f, -0.15988524f, -0.08442672f, 0.06399611f, -0.25265086f, -0.08622043f, 0.06127350f, 
    0.00588783f, -0.18689308f, 0.03169670f, -0.10038931f, -0.06154443f, -0.19346134f, 0.20112224f, -0.21333990f, 
    0.02718284f, -0.06375325f, -0.04623457f, -0.00324066f, 0.11798793f, -0.08491249f, -0.04033656f, -0.00581056f, 
    -0.06700502f, -0.11914133f, -0.15040451f, -0.20758386f, -0.09008459f, -0.15148720f, 0.17753889f, -0.07910346f, 
    -0.17106199f, -0.05851394f, 0.00678588f, -0.13551727f, 0.19356067f, 0.06011483f, -0.21400365f, -0.04376706f, 
    0.07277098f, -0.02894678f, -0.11172633f, 0.05839442f, -0.11459685f, 0.08104549f, 0.11911808f, -0.29455781f, 
    0.12342634f, -0.14407375f, 0.08707263f, 0.04447144f, 0.04490650f, 0.31535423f, 0.07627525f, 0.09231522f, 
    0.12974444f, 0.11907861f, 0.07885669f, -0.15740404f, -0.06402472f, -0.02673170f, -0.29242775f, -0.10095068f, 
    0.14861244f, -0.14103988f, 0.07254303f, 0.31556660f, -0.06506688f, -0.08012263f, -0.04248275f, -0.02052797f, 
    -0.13322975f, 0.23367392f, 0.01397563f, 0.09625108f, -0.26013634f, -0.42755371f, 0.01724390f, 0.20488153f, 
    0.09253743f, -0.09163543f, 0.14754081f, -0.08303428f, 0.09686685f, -0.01431167f, -0.22450885f, 0.04344223f, 
    0.08955891f, 0.13210346f, 0.06773680f, 0.21779956f, 0.08888225f, -0.02322159f, 0.06848789f, -0.10143736f, 
    -0.35556695f, 0.12060077f, 0.11645680f, 0.30643174f, -0.20242423f, -0.16066891f, 0.13599375f, 0.05020284f, 
    -0.10917815f, -0.04034189f, -0.00599038f, -0.27459744f, 0.18865812f, 0.09615824f, -0.07022982f, -0.00158134f, 
    -0.12036358f, 0.14386304f, -0.05459416f, 0.16976839f, -0.20646621f, 0.10558090f, 0.04608245f, 0.01722988f, 
    0.09225564f, -0.38485307f, -0.06605262f, -0.10141420f, -0.22534002f, 0.06110374f, -0.12260243f, 0.02340738f, 
    -0.19169536f, 0.00781099f, 0.40432867f, 0.15488438f, 0.10012893f, 0.04824324f, 0.10501650f, -0.15379705f, 
    0.16695668f, 0.04187782f, 0.17612915f, -0.00953189f, 0.24091476f, -0.17763674f, -0.05893725f, 0.08837326f, 
    0.02510867f, -0.03046926f, 0.00132214f, 0.31138980f, 0.31413502f, 0.10809450f, 0.04215031f, 0.06387499f, 
    0.35114855f, -0.06011989f, 0.22683023f, -0.06165260f, -0.38824949f, -0.26729888f, 0.22010572f, -0.10072970f, 
    -0.04521001f, -0.08347005f, 0.01273636f, 0.15105321f, -0.00203277f, -0.31200022f, 0.03907565f, -0.04729075f, 
    -0.27788788f, -0.30302107f, -0.03452235f, 0.15797989f, 0.18664378f, -0.04679703f, 0.13919999f, 0.04207426f, 
    0.20320064f, 0.11590949f, 0.18897964f, 0.11660502f, -0.19315705f, -0.15997458f, -0.36155078f, 0.53684884f, 
    0.01191224f, 0.04983836f, -0.11065714f, 0.02254943f, 0.12115402f, -0.00969391f, 0.13962589f, -0.23220931f, 
    -0.14652288f, -0.16220479f, 0.09016948f, -0.07165325f, -0.00041795f, -0.12953104f, 0.09507377f, -0.03443791f, 
    0.33345196f, 0.04619850f, -0.05137295f, -0.14626610f, -0.16295421f, -0.07726779f, -0.02772059f, -0.13363190f, 
    0.17502460f, -0.19576412f, 0.26075986f, 0.38720530f, 0.23274657f, -0.01258839f, 0.01185168f, -0.02927214f, 
    -0.26279452f, -0.16724782f, -0.36981446f, -0.28896588f, 0.13908789f, -0.02430599f, -0.13942294f, -0.26263869f, 
    0.08008696f, 0.05098430f, 0.13202672f, 0.03860905f, -0.03411014f, -0.09650578f, 0.11257286f, -0.05914398f, 
    -0.18474469f, 0.21394654f, -0.09632711f, 0.07879581f, -0.09315710f, 0.29101041f, 0.15094276f, 0.07538351f, 
    -0.03057080f, -0.10579558f, -0.03253429f, -0.08406726f, -0.05526584f, -0.14119597f, 0.05742956f, -0.08908498f, 
    -0.10174967f, 0.05802024f, -0.23492764f, -0.00237178f, -0.06135482f, -0.04511062f, 0.07487087f, 0.23632658f, 
    -0.18500353f, 0.15989929f, -0.02087571f, -0.02099885f, -0.10553540f, -0.23782443f, 0.08636643f, -0.09523963f, 
    0.26591706f, 0.03021660f, 0.18876028f, 0.17851736f, 0.18318915f, 0.14460593f, 0.09297894f, -0.03833920f, 
    0.23950501f, 0.47013924f, -0.18493989f, 0.29766601f, 0.14581832f, 0.15937784f, -0.23708601f, 0.03794471f, 
    0.20866066f, 0.37863579f, 0.03701129f, 0.18327861f, 0.17999020f, 0.07793775f, -0.07297622f, 0.11487538f, 
    0.10579843f, 0.12489905f, -0.15083745f, -0.20440766f, -0.31276935f, -0.07321675f, 0.18267094f, 0.06999241f, 
    -0.09406592f, -0.03955151f, -0.02254014f, 0.00404096f, 0.40759638f, 0.15239155f, 0.10713608f, 0.09390013f, 
    -0.23475376f, -0.06862634f, 0.17690124f, 0.16541913f, 0.15386219f, 0.46277034f, 0.03106043f, 0.18308611f, 
    -0.16307321f, -0.21294935f, -0.07220935f, -0.07447742f, -0.20726267f, -0.01146560f, -0.33125111f, -0.41340369f, 
    -0.09256488f, -0.24072281f, 0.03444484f, 0.22973277f, 0.11851684f, 0.09598266f, -0.06984248f, -0.05214855f, 
    -0.26238623f, 0.05405742f, -0.13588363f, 0.07075804f, -0.06946415f, -0.07073426f, -0.20307311f, -0.00355999f, 
    0.06708476f, -0.05549248f, 0.34249216f, -0.17126325f, 0.01141810f, 0.05766926f, -0.15812612f, -0.00215969f, 
    0.13579956f, -0.00288107f, -0.28279719f, 0.20910138f, -0.01876262f, -0.01064214f, 0.12286628f, -0.15404369f, 
    -0.22418971f, -0.18020524f, 0.45886728f, 0.35204795f, 0.14883289f, 0.00294644f, 0.01702589f, -0.00107771f, 
    0.11515106f, 0.23419496f, -0.11215408f, 0.09999408f, -0.14874867f, 0.11811624f, 0.11896972f, 0.13793838f, 
    0.24220361f, -0.11345328f, 0.07586675f, 0.34560451f, -0.05102044f, -0.10617623f, 0.08206140f, 0.02256688f, 
    0.12623250f, 0.13677043f, -0.11333314f, -0.20105410f, 0.31908041f, 0.14761892f, -0.13582858f, -0.18441515f, 
    -0.29844669f, 0.09605151f, -0.18503308f, -0.04569452f, -0.28501731f, 0.09908552f, -0.16584092f, -0.53040677f, 
    -0.03520654f, -0.21048687f, 0.02150519f, 0.10806672f, -0.00030211f, 0.01481806f, 0.18770050f, 0.34860840f, 
    -0.15438153f, 0.16476855f, -0.04144993f, -0.11750154f, -0.09935947f, -0.07172436f, 0.02886702f, -0.01084205f, 
    0.04625115f, 0.00310101f, -0.02826234f, -0.00254207f, -0.01051578f, -0.01978332f, -0.05765320f, 0.03021498f, 
    -0.01595122f, 0.04700379f, 0.02779495f, 0.00721506f, -0.03352081f, 0.01432439f, -0.04833097f, 0.01028597f, 
    0.05171214f, 0.03553724f, 0.01024712f, 0.00236955f, -0.00703145f, 0.01180849f, -0.00390007f, -0.05998127f, 
    0.01877267f, -0.01625468f, -0.03644415f, -0.03907837f, -0.03099425f, -0.01498172f, 0.04970342f, -0.03567842f, 
    0.04454899f, 0.05067392f, 0.01288768f, 0.00779331f, 0.03938277f, 0.00888327f, -0.05690061f, -0.00844384f, 
    -0.02546135f, -0.05926410f, -0.03881151f, 0.00637111f, -0.02083820f, 0.02119965f, 0.04466455f, -0.04593679f, 
    -0.05092406f, 0.00914900f, -0.05510889f, 0.00539646f, 0.01969241f, 0.05784394f, -0.02872150f, 0.03283882f, 
    0.02273348f, 0.02471001f, -0.01837764f, -0.03986503f, -0.05266355f, 0.02517628f, 0.00186920f, -0.00630931f, 
    -0.05584820f, -0.02406641f, 0.00724647f, -0.05767950f, 0.00486845f, 0.01911243f, 0.00671227f, 0.02507264f, 
    -0.04182482f, -0.01217606f, 0.03682735f, -0.04258959f, -0.01161474f, -0.00312609f, -0.01308518f, -0.04853540f, 
    0.01890657f, -0.02051799f, -0.03585954f, -0.00390042f, -0.05105843f, 0.01946402f, -0.01285903f, -0.01229472f, 
    0.02983760f, 0.00103681f, -0.05428436f, -0.02849733f, -0.03002614f, -0.03644225f, -0.00835473f, -0.05125146f, 
    -0.05015691f, -0.03306992f, -0.04165962f, -0.00628021f, -0.00908011f, -0.03672823f, -0.04341539f, 0.01307914f, 
    -0.03204579f, -0.03583653f, -0.05918980f, -0.04524564f, 0.00658401f, -0.06147988f, -0.03482977f, -0.01654873f, 
    0.04279175f, -0.04472149f, -0.03886126f, -0.04028706f, 0.03710488f, 0.04214036f, 0.03608879f, -0.04434336f, 
    0.01394937f, -0.03803921f, -0.06008054f, -0.06388333f, -0.01125976f, -0.05269642f, 0.00368007f, -0.01955827f, 
    0.01729491f, 0.03291742f, -0.00695665f, -0.03694276f, 0.05853404f, 0.04618257f, -0.01123267f, -0.03876380f, 
    -0.00218028f, 0.01234997f, 0.01836221f, -0.02746461f, -0.00026314f, -0.01676955f, -0.01716223f, 0.04620357f, 
    0.00722967f, -0.02163365f, -0.05174136f, 0.05120590f, -0.01411755f, -0.01839156f, -0.03431666f, -0.05484701f, 
    -0.02978409f, -0.02187387f, 0.01445662f, -0.00222235f, 0.05946330f, 0.04788893f, 0.03002216f, 0.01246046f, 
    0.05250628f, -0.05384838f, -0.03824151f, -0.03291638f, 0.03987656f, -0.01472309f, -0.02830102f, 0.01904347f, 
    -0.04059350f, -0.04273300f, 0.00075819f, -0.05580860f, 0.00533250f, -0.02917014f, 0.04265893f, 0.00475583f, 
    -0.01407471f, 0.00337099f, 0.00147965f, -0.03469134f, -0.01008917f, 0.04246648f, 0.02106244f, 0.00275546f, 
    -0.04403535f, -0.06328017f, 0.01251850f, -0.05035049f, 0.02639632f, 0.02354829f, -0.00036808f, -0.05909037f, 
    0.01270629f, 0.01956662f, -0.05219034f, 0.02182341f, 0.02766966f, -0.01045909f, -0.03830783f, -0.01135592f, 
    -0.05255653f, -0.06445715f, -0.04577963f, 0.02497743f, -0.00340247f, -0.02917305f, -0.02162621f, -0.02596148f, 
    -0.04916931f, -0.04917527f, -0.01735476f, -0.02178783f, 0.03624872f, 0.00138724f, 0.02280989f, 0.01371170f, 
    -0.06013668f, 0.03833597f, -0.01278436f, -0.00759545f, 0.01571410f, 0.01085070f, -0.05465804f, 0.00521306f, 
    0.00632810f, -0.02536577f, -0.00834208f, -0.04055097f, -0.03576249f, 0.01609251f, -0.06314854f, -0.04119755f, 
    0.03654069f, 0.01136084f, 0.01108545f, -0.00086583f, 0.03865102f, -0.00624000f, 0.02585328f, 0.04945671f, 
    -0.05189623f, 0.02667715f, 0.04456119f, 0.02867952f, 0.03922010f, 0.01150757f, -0.03407905f, -0.03587681f, 
    -0.02760470f, 0.01001163f, 0.01229827f, -0.00735949f, 0.01143779f, 0.03069170f, 0.04731067f, 0.02332289f, 
    -0.01189001f, 0.03001558f, -0.03663146f, 0.05475203f, 0.04761566f, 0.04935937f, 0.03012485f, -0.02706465f, 
    0.05337917f, -0.00604213f, 0.01517085f, 0.01653450f, 0.00179929f, 0.00458043f, 0.02381961f, 0.05683212f, 
    -0.02829679f, -0.03712559f, 0.02843893f, 0.00784062f, 0.00320194f, -0.03541930f, 0.02358894f, -0.04699840f, 
    0.03472166f, -0.03583544f, -0.01793306f, -0.05400497f, -0.02948898f, 0.05144710f, -0.00008263f, 0.02719109f, 
    0.23936799f, -0.50826132f, 0.04227852f, 0.23818451f, 0.20670743f, 0.02852727f, 0.01942929f, 0.01824753f, 
    -0.21981695f, -0.31534418f, 0.06126843f, 0.08754174f, 0.05529899f, 0.00264825f, 0.09020207f, -0.04736700f, 
    0.28496978f, 0.14637886f, -0.15200102f, 0.22167219f, 0.17741375f, 0.10914406f, 0.02544127f, -0.07716267f, 
    -0.06194117f, 0.03940357f, -0.04923955f, -0.09463897f, -0.23582037f, 0.14951281f, 0.28587967f, 0.29305115f, 
    0.33270121f, -0.29132745f, -0.09450521f, -0.19302736f, -0.32421172f, -0.23705144f, 0.02551303f, 0.10642408f, 
    -0.27376729f, 0.05389153f, -0.05643749f, -0.08026628f, -0.15384500f, 0.22452658f, 0.23840894f, 0.12987041f, 
    -0.21707296f, 0.10513008f, -0.21579394f, 0.04813645f, -0.20608307f, 0.20817134f, 0.34713194f, 0.41019738f, 
    0.22511210f, 0.27881655f, 0.16941340f, -0.14295971f, -0.12547606f, 0.01480056f, 0.01139131f, -0.77578098f, 
    -0.18077704f, -0.25422367f, 0.06731759f, -0.05597207f, 0.17496766f, -0.17846651f, -0.08016022f, 0.00072245f, 
    -0.25837034f, -0.19342940f, -0.19018827f, -0.03062763f, 0.06996999f, -0.02927223f, -0.18398471f, -0.01605187f, 
    -0.24253823f, 0.36811402f, -0.32213131f, 0.36926290f, -0.04816605f, -0.18081780f, 0.02428536f, -0.28806058f, 
    0.17584452f, -0.06425738f, 0.02659029f, -0.10293289f, -0.23519102f, -0.05272618f, -0.17328753f, 0.09546950f, 
    0.12890972f, 0.20623972f, 0.16800758f, 0.20885916f, 0.15626065f, -0.07568286f, -0.16694619f, 0.12399823f, 
    -0.17469898f, 0.07797080f, -0.19301936f, -0.12577763f, 0.09683717f, 0.10684635f, -0.11159249f, -0.14320904f, 
    -0.18755259f, -0.09236857f, -0.11464924f, 0.12729466f, -0.04326176f, 0.10185535f, 0.10094662f, 0.07097316f, 
    -0.09531067f, -0.01920412f, 0.00521239f, -0.15230381f, -0.27835098f, 0.10657642f, -0.03949414f, -0.06861985f, 
    -0.09837524f, 0.13824274f, -0.12815735f, -0.12790428f, 0.06601409f, -0.07747014f, 0.01342043f, 0.48324177f, 
    -0.28742188f, -0.12976609f, -0.22392060f, -0.08715072f, -0.24503972f, -0.15501976f, 0.15870497f, -0.07316459f, 
    -0.36730030f, 0.12391663f, -0.12521283f, 0.16095588f, 0.20121272f, -0.06805317f, 0.02764786f, 0.05394812f, 
    -0.01696810f, 0.09596156f, -0.05474146f, -0.01466446f, 0.28631556f, 0.14990114f, 0.14249526f, -0.10202074f, 
    -0.05476331f, 0.09369529f, -0.07923885f, 0.11094279f, 0.37650925f, 0.17715390f, -0.04977664f, 0.23476978f, 
    -0.01336678f, 0.00375070f, -0.01961279f, 0.13269316f, -0.14814407f, -0.24503843f, -0.13770667f, -0.02660964f, 
    0.17607760f, 0.17212932f, -0.19027564f, 0.14583203f, -0.48193115f, -0.13654637f, 0.23632343f, 0.33570343f, 
    0.02832218f, 0.03776036f, -0.00181580f, 0.04981595f, 0.01495449f, 0.36955261f, 0.20663099f, 0.18500757f, 
    -0.24583337f, -0.31373361f, 0.08796612f, 0.00019736f, 0.10656828f, 0.09109286f, 0.05539315f, 0.19520263f, 
    0.14077038f, -0.05056330f, -0.03155356f, 0.07554967f, 0.05092690f, 0.12460879f, -0.11187524f, 0.13799831f, 
    0.25603941f, -0.02909163f, -0.06495052f, 0.02885034f, -0.00481660f, -0.00924412f, -0.04434709f, 0.09732646f, 
    0.05353890f, 0.17351304f, 0.37154979f, 0.09505885f, 0.08818217f, -0.19354594f, -0.08845714f, 0.05538117f, 
    0.03391843f, 0.12073536f, -0.14925097f, -0.60522312f, 0.00704666f, 0.11818362f, 0.23771712f, 0.17666851f, 
    -0.04239139f, 0.16206314f, -0.77151680f, 0.12685472f, -0.03394375f, -0.12156630f, -0.09937328f, 0.05332800f, 
    -0.10620917f, 0.05282033f, -0.02128010f, 0.28881186f, -0.02731160f, 0.05613162f, 0.27455601f, -0.22236159f, 
    0.00336394f, 0.00650714f, 0.04942055f, -0.09503932f, 0.37815765f, -0.27094585f, 0.18739812f, 0.00797238f, 
    -0.11094137f, 0.01497562f, 0.14267802f, 0.05369673f, -0.01335467f, -0.07005875f, -0.20717351f, -0.01211747f, 
    -0.12389284f, -0.14526014f, 0.23129269f, 0.04900798f, -0.01618393f, -0.02229008f, -0.11765324f, 0.30540833f, 
    0.00864693f, -0.14105615f, -0.24094136f, -0.06558161f, 0.01210638f, 0.00400158f, 0.12616295f, -0.12528054f, 
    -0.13899449f, 0.21194439f, 0.12264945f, 0.13199055f, 0.03749220f, -0.04525689f, 0.05234816f, 0.07323070f, 
    -0.01774581f, 0.00351398f, 0.02521611f, 0.01181951f, -0.04893756f, -0.05792923f, -0.04417326f, 0.04234793f, 
    0.00585015f, 0.00382641f, 0.05477363f, 0.01923400f, -0.04821208f, -0.04374101f, -0.01338978f, -0.04022923f, 
    -0.03929840f, -0.04691099f, -0.04581262f, 0.02365657f, 0.04018712f, -0.02152788f, -0.03929080f, -0.04668303f, 
    -0.03448238f, -0.00369642f, 0.02133171f, 0.02586254f, -0.05333527f, -0.03868705f, -0.04618825f, 0.02811318f, 
    0.01386218f, 0.03603458f, 0.02135418f, 0.00299294f, 0.03283026f, -0.03411042f, -0.05415718f, -0.04805849f, 
    -0.05054288f, -0.03412569f, 0.03463761f, -0.05199137f, 0.04423285f, 0.03160590f, 0.00011160f, -0.03062376f, 
    -0.04982257f, 0.03671094f, -0.01222786f, -0.03721352f, 0.03546137f, -0.04590540f, -0.02345299f, 0.03223528f, 
    -0.02551645f, -0.03479731f, -0.01637696f, -0.00119203f, -0.00104483f, -0.01287682f, 0.02333002f, -0.05439110f, 
    -0.05508073f, -0.02206952f, 0.03431320f, -0.05505891f, 0.02873297f, 0.03805176f, 0.02649433f, 0.02247713f, 
    -0.01735047f, -0.04747916f, -0.03604458f, -0.04172077f, 0.00082368f, -0.00374985f, -0.04485606f, -0.04863033f, 
    0.04309710f, 0.03952099f, 0.04810636f, -0.03050765f, -0.02483429f, -0.04948016f, -0.00695428f, -0.05303526f, 
    0.04862759f, 0.01976932f, -0.05382610f, -0.03309890f, 0.00426154f, 0.05591006f, 0.01457795f, 0.00657165f, 
    -0.00591861f, 0.00777488f, 0.03575780f, -0.04328618f, 0.04705935f, 0.00559468f, 0.04460257f, 0.04389020f, 
    0.00887597f, 0.00009770f, -0.01722356f, -0.03481765f, -0.01036211f, -0.01480974f, 0.03537235f, -0.00562951f, 
    0.00513127f, 0.03724064f, -0.04154553f, -0.01581067f, 0.01685682f, -0.00869402f, 0.05459535f, 0.03000658f, 
    0.01183285f, -0.01521787f, 0.05787006f, 0.05696417f, -0.02258277f, 0.03430139f, 0.02793910f, 0.01698089f, 
    0.00166328f, 0.05602040f, -0.03570139f, -0.03224303f, 0.01921346f, -0.02825861f, 0.03436019f, 0.01678631f, 
    0.00406500f, 0.04599499f, -0.02617737f, 0.01805628f, -0.02742818f, -0.00206968f, -0.03162180f, 0.04929797f, 
    -0.04309520f, -0.04735788f, 0.05288545f, -0.02473545f, -0.04407869f, -0.00046735f, -0.01707796f, 0.00895177f, 
    -0.05180351f, 0.00161977f, -0.02671180f, -0.03211767f, -0.01500093f, -0.03314024f, -0.01296722f, -0.04826088f, 
    0.00459233f, -0.01353517f, 0.05260172f, -0.04960493f, 0.05533772f, -0.02346722f, -0.05880987f, -0.04027094f, 
    -0.04994513f, 0.01512127f, -0.00548604f, -0.02075746f, -0.04380165f, -0.02225906f, 0.03874808f, -0.03761955f, 
    0.02016879f, -0.01026999f, 0.01397893f, -0.02812494f, 0.04568538f, 0.00812465f, 0.00242044f, -0.03382623f, 
    -0.03717501f, -0.02648721f, -0.03640784f, -0.01898362f, 0.00150343f, 0.01344736f, -0.03334676f, 0.03295472f, 
    0.03577871f, -0.01944503f, -0.03864341f, 0.03070926f, -0.03910238f, -0.05835391f, -0.02125735f, -0.01745201f, 
    -0.01404179f, 0.01344624f, -0.02027283f, -0.01660622f, -0.00958974f, -0.04181019f, 0.04444496f, -0.03856150f, 
    0.01801718f, -0.01038970f, -0.04934660f, 0.00447125f, -0.01799880f, -0.04182040f, -0.04954253f, 0.01154304f, 
    0.02253494f, -0.00813784f, 0.02570056f, 0.03491713f, -0.02475766f, 0.00677565f, 0.01348753f, -0.00780069f, 
    0.05445265f, 0.00434557f, 0.03180755f, 0.02962891f, 0.00227578f, -0.04279871f, 0.00694162f, 0.00526349f, 
    -0.00580050f, -0.02231037f, -0.04005339f, -0.01105642f, -0.03303840f, -0.01942262f, 0.01261613f, -0.00131863f, 
    0.01751645f, -0.01889099f, -0.03629775f, -0.03136031f, 0.04711982f, -0.04019395f, -0.04039107f, -0.02728217f, 
    0.03627506f, -0.03570712f, 0.05435661f, 0.02903469f, 0.01171097f, 0.03414804f, -0.02035049f, 0.02745044f, 
    -0.03357024f, 0.02651354f, 0.01966900f, 0.02106018f, -0.00879047f, -0.04528431f, 0.04870200f, -0.02169929f, 
    -0.00944362f, 0.04403190f, 0.01275514f, 0.00236747f, 0.05719083f, 0.04736159f, -0.03635376f, -0.02398030f, 
    0.01048337f, -0.05161434f, -0.05491316f, 0.03903663f, 0.04264484f, -0.00819144f, -0.02244566f, -0.05842906f, 
    0.01448221f, -0.05242541f, 0.00867452f, 0.03967463f, -0.03588424f, -0.00791470f, -0.05037190f, -0.03366807f, 
    0.12777606f, -0.30284485f, -0.30517083f, 0.17057112f, 0.01090155f, 0.25037572f, -0.10500174f, -0.09979212f, 
    0.11617001f, -0.40137517f, -0.12830198f, 0.11666301f, 0.00072882f, -0.06474945f, -0.01015959f, -0.15017870f, 
    0.27732271f, 0.01173009f, 0.23060603f, -0.19271165f, -0.17126368f, -0.08749720f, -0.23055488f, 0.06030867f, 
    0.10420320f, 0.20104311f, -0.11899900f, 0.35382685f, -0.15444092f, -0.12119365f, -0.13112213f, 0.14325318f, 
    0.19666006f, -0.14247735f, -0.04887425f, -0.25339657f, -0.09006737f, 0.07165533f, -0.24259686f, -0.05868172f, 
    -0.07687951f, -0.09175545f, -0.05958858f, 0.03854949f, 0.09851801f, 0.62710488f, 0.09507593f, -0.12110589f, 
    -0.07515067f, -0.00306466f, 0.11589353f, 0.11987907f, 0.14331192f, 0.02145040f, -0.00555061f, -0.17100216f, 
    0.07833814f, -0.03513116f, -0.05501622f, 0.17290546f, 0.08159938f, 0.05610893f, -0.08136618f, 0.17509045f, 
    -0.45145908f, -0.00627795f, 0.14540331f, -0.04753333f, -0.14463820f, -0.13696492f, 0.09420997f, 0.00395231f, 
    -0.64143836f, -0.07721386f, -0.09872956f, 0.03702338f, -0.01247849f, 0.00545188f, -0.04328641f, -0.03403786f, 
    0.06026765f, -0.34238580f, -0.05774436f, -0.05204690f, -0.20476612f, 0.08285762f, -0.03726683f, -0.24089627f, 
    0.18838270f, -0.07275705f, -0.05377297f, 0.01562612f, -0.20107625f, 0.00888333f, 0.03710139f, 0.12143844f, 
    -0.06331608f, -0.01358442f, -0.20842417f, 0.20589329f, -0.10818256f, 0.03865723f, 0.01749195f, 0.12342482f, 
    0.07728249f, 0.12861580f, 0.16623804f, -0.06808522f, 0.28321669f, 0.01858822f, 0.15637578f, 0.06829282f, 
    0.04755244f, 0.00652404f, -0.10261922f, 0.14068820f, 0.01665290f, 0.00863010f, 0.11932143f, 0.03942377f, 
    0.08316217f, 0.15958920f, -0.01671157f, 0.34597093f, 0.06865539f, -0.05344398f, -0.55025512f, -0.06601316f, 
    0.06854008f, -0.03634110f, -0.07902806f, 0.11283424f, -0.03694991f, 0.07307531f, 0.06648695f, -0.35731739f, 
    0.26464060f, -0.03737849f, 0.16451326f, -0.08354165f, 0.03307285f, -0.17681117f, 0.07302883f, 0.11633902f, 
    -0.63341230f, -0.14469676f, 0.00020729f, 0.07770716f, 0.06991264f, 0.01828721f, -0.21785480f, 0.02606349f, 
    0.10262211f, -0.49647570f, 0.17983283f, -0.40940461f, 0.06844406f, 0.15918884f, 0.10146569f, -0.17981957f, 
    0.19970275f, 0.09373050f, -0.36848649f, 0.16745938f, -0.02668442f, -0.12991841f, -0.04413983f, 0.15659496f, 
    0.05850375f, 0.12988764f, -0.29119191f, 0.32395595f, 0.32100210f, -0.03087376f, 0.19591619f, 0.07629380f, 
    -0.05956594f, 0.01969194f, -0.08558635f, 0.24582173f, -0.17899625f, 0.04692094f, 0.16860597f, -0.13570642f, 
    -0.03506881f, 0.12616812f, -0.11285938f, 0.15692924f, 0.11174004f, 0.00465649f, 0.24750282f, 0.15593235f, 
    0.18114263f, -0.17877118f, 0.13341844f, 0.17261209f, 0.09916282f, 0.05672422f, 0.72846919f, 0.02024505f, 
    0.13344541f, -0.12612720f, -0.13974535f, 0.16193363f, 0.05643217f, -0.00562295f, 0.09532087f, 0.23980497f, 
    0.29309964f, 0.13506792f, 0.12671331f, -0.05674519f, -0.08589522f, -0.01863513f, 0.05070730f, 0.11927374f, 
    0.12618576f, 0.13141081f, -0.58291155f, -0.16657870f, 0.00359041f, -0.08102246f, 0.00549977f, 0.15644164f, 
    0.08046138f, 0.43074349f, -0.07218120f, -0.08070714f, 0.10907234f, -0.09156061f, 0.16992082f, -0.02696949f, 
    0.01921631f, -0.30930850f, -0.09194551f, 0.04132041f, 0.28881058f, 0.05074666f, -0.06481366f, -0.14409980f, 
    0.18492727f, 0.08321130f, -0.23803772f, -0.14960530f, -0.10494760f, -0.02039167f, 0.15193093f, -0.08167538f, 
    0.11305198f, -0.18297687f, 0.07774277f, 0.09740917f, -0.42075357f, 0.05227628f, -0.31444633f, 0.04193575f, 
    -0.07156321f, -0.11994790f, -0.20969954f, -0.07821933f, 0.24538684f, -0.02328214f, 0.08981922f, -0.13878661f, 
    0.14912550f, -0.01898661f, -0.01157062f, 0.09762012f, 0.06108906f, -0.13328421f, 0.88510877f, 0.54347652f, 
    0.02091035f, 0.00179149f, -0.19115180f, -0.12550002f, -0.00921435f, -0.01952878f, 0.07450007f, -0.38708299f, 
    0.43599299f, -0.20169841f, 0.04097598f, 0.04086346f, 0.11622715f, 0.02856020f, -0.01345582f, 0.15961505f, 
    -0.14066736f, 0.00542258f, -0.39389327f, 0.09219568f, 0.11145601f, 0.00708201f, 0.19397725f, -0.00362538f, 
    0.04407094f, -0.11368424f, -0.05395527f, -0.45136136f, 0.03700820f, 0.09189327f, -0.02774163f, 0.11010025f, 
    -0.13877115f, 0.04440022f, -0.01889364f, 0.38566014f, -0.67544341f, 0.21785463f, 0.08297356f, 0.09843978f, 
    0.10316601f, -0.04902882f, 0.13419439f, -0.66548163f, -0.36516532f, -0.19381040f, 0.17858565f, 0.01924643f, 
    0.09353042f, 0.07653629f, -0.02935562f, -0.11614074f, 0.00085202f, -0.17835389f, -0.43134648f, -0.10481276f, 
    -0.06283753f, 0.02308377f, 0.21277571f, -0.01125426f, -0.23246652f, -0.07593941f, 0.20617454f, 0.29738322f, 
    -0.01106957f, -0.19350235f, -0.02011818f, 0.03418741f, -0.01251793f, 0.01654725f, 0.08530769f, 0.44099641f, 
    -0.34108531f, -0.06995519f, -0.07529540f, -0.17245401f, 0.31819141f, 0.21412228f, 0.06659135f, -0.42328832f, 
    0.14978972f, 0.01869019f, 0.00255438f, 0.21277867f, -0.36957753f, 0.41848871f, -0.05354692f, 0.13709240f, 
    -0.12454502f, -0.09501953f, 0.03832320f, -0.00322749f, -0.05542247f, 0.03983788f, 0.04551332f, -0.17939788f, 
    -0.20007865f, 0.45171267f, -0.06732065f, -0.18351480f, -0.09497713f, 0.00177049f, -0.00029224f, 0.07946473f, 
    0.08486106f, 0.23926710f, 0.25369138f, 0.13911641f, -0.06383493f, -0.10078087f, 0.10545538f, -0.04886167f, 
    -0.08299284f, 0.21877654f, 0.08652765f, -0.15496457f, -0.10941112f, 0.34031948f, 0.06748582f, -0.03851560f, 
    0.09159536f, -0.02843580f, 0.02815943f, -0.23146103f, 0.20592497f, 0.21159935f, 0.17375010f, 0.13903449f, 
    0.02799322f, 0.17183132f, 0.13976474f, -0.20021398f, 0.18193896f, -0.09806316f, 0.12001440f, -0.29715425f, 
    -0.04507084f, 0.04367790f, -0.03090759f, -0.17433724f, -0.07170069f, 0.14467251f, 0.09530844f, -0.58630502f, 
    -0.06394468f, -0.05482174f, -0.29519039f, 0.01508282f, 0.10155251f, -0.05254120f, -0.02254882f, -0.17911482f, 
    -0.47038835f, -0.13935408f, -0.01352186f, 0.00679662f, 0.12392452f, -0.03934714f, 0.18489216f, -0.01424130f, 
    -0.32448941f, -0.45650643f, -0.13797145f, 0.05265427f, 0.12763898f, 0.08199829f, 0.07190830f, -0.14942683f, 
    -0.07437365f, -0.43863699f, -0.24753395f, -0.23943833f, -0.02555881f, 0.08899779f, 0.04671571f, -0.12783591f, 
    -0.33178985f, 0.14867947f, -0.19332512f, -0.12437509f, -0.31806865f, 0.17963713f, -0.12800647f, 0.08883267f, 
    0.04445463f, -0.11782368f, -0.00061982f, 0.10031728f, 0.40233880f, 0.32654706f, 0.05754764f, -0.00957862f, 
    0.17293629f, -0.13191849f, -0.13298129f, -0.10194901f, -0.46029350f, 0.09500097f, -0.27318907f, -0.05980678f, 
    0.03674283f, -0.01249463f, 0.22062238f, -0.03420300f, -0.01801765f, 0.04254179f, 0.27465495f, -0.03863452f, 
    0.08988509f, 0.06832124f, -0.16311374f, -0.14440052f, -0.01919239f, -0.04112045f, 0.18360908f, 0.27398047f, 
    0.41280806f, 0.15507792f, 0.28387749f, 0.08643809f, 0.22137371f, -0.01237293f, 0.17454672f, 0.17773387f, 
    0.01115312f, 0.11504339f, -0.18910089f, 0.02421020f, 0.06440560f, -0.00881351f, -0.06194350f, -0.05098772f, 
    -0.20307165f, 0.33930680f, -0.76474893f, -0.00273639f, 0.09149353f, -0.12265100f, -0.02441689f, -0.01850850f, 
    0.17097484f, 0.30885035f, 0.26527187f, -0.15886904f, -0.07049549f, 0.20150648f, 0.08263629f, 0.08196264f, 
    0.08672559f, -0.04009179f, -0.29942879f, 0.13084713f, 0.41092616f, -0.07309456f, 0.07253359f, -0.21240652f, 
    -0.29401374f, -0.08734354f, -0.02526283f, 0.03211335f, 0.06946315f, 0.13901529f, 0.03831429f, 0.12470473f, 
    0.19755450f, -0.06867792f, 0.09976256f, 0.03146800f, 0.42885327f, 0.09923604f, 0.16453731f, -0.03070683f, 
    0.10259124f, 0.10616294f, 0.07592614f, 0.18074191f, -0.06001091f, -0.27823994f, 0.11381688f, -0.03394755f, 
    0.11247794f, -0.16052811f, 0.05698953f, 0.23093723f, -0.00822040f, 0.12618378f, 0.13363285f, 0.20759775f, 
    0.43362871f, 0.19899783f, 0.11211157f, -0.06558284f, 0.05228505f, 0.06114936f, 0.00107515f, -0.54036552f, 
    -0.42604804f, -0.35397834f, 0.08153750f, 0.13854259f, 0.16360913f, -0.13239147f, -0.09434109f, 0.07119601f, 
    0.48255110f, -0.13318075f, 0.08793846f, -0.06309547f, 0.18521167f, 0.29117009f, -0.10260306f, 0.02031086f, 
    -0.20198548f, 0.10878530f, -0.07154812f, -0.14397426f, -0.05165623f, 0.15156677f, -0.02033165f, -0.00170625f, 
    0.17616655f, -0.16600655f, -0.35205835f, -0.29048714f, 0.14168489f, -0.03860771f, 0.17942740f, 0.17063132f, 
    -0.01489081f, -0.30424196f, -0.00968820f, 0.61748809f, -0.17122914f, -0.12037988f, 0.01159874f, 0.05763794f, 
    -0.06046486f, -0.07944310f, 0.00966851f, -0.14107975f, -0.63725311f, -0.12005693f, -0.08826791f, 0.07125958f, 
    0.15982124f, -0.14064808f, 0.13121858f, 0.27448273f, 0.07517008f, 0.38437480f, 0.20143339f, 0.09970345f, 
    -0.33094984f, 0.03382592f, -0.23596369f, 0.20551649f, 0.17802769f, 0.16153899f, -0.22472969f, -0.02882459f, 
    -0.41517144f, 0.18938482f, -0.05178938f, -0.01137010f, 0.02598339f, -0.01627054f, -0.01467279f, 0.04370694f, 
    -0.64239293f, -0.04795387f, -0.11247707f, -0.23953409f, 0.08811623f, 0.13886932f, 0.10664957f, -0.05560011f, 
    -0.22630249f, -0.13292618f, -0.13059674f, -0.00036639f, -0.08806976f, -0.51221800f, -0.11674945f, 0.17061679f, 
    -0.01442090f, 0.71791321f, -0.31396195f, 0.11024626f, -0.29860219f, 0.25305566f, 0.08630003f, 0.21387774f, 
    0.05581620f, 0.03723156f, -0.22215720f, -0.23427662f, -0.12275632f, 0.11851827f, 0.20515518f, 0.14537814f, 
    0.02428970f, 0.14906530f, 0.15827379f, -0.10947831f, 0.01275739f, 0.13254192f, -0.13598631f, 0.20878433f, 
    -0.13852733f, 0.17761040f, 0.17288409f, -0.06278756f, -0.11882119f, -0.00109614f, 0.17547545f, -0.18875924f, 
    0.10249169f, -0.10236020f, 0.11746418f, 0.15207225f, -0.09710617f, -0.35043722f, -0.23458111f, -0.01037048f, 
    -0.07355642f, 0.29384035f, 0.21592341f, -0.07632113f, 0.10832713f, -0.22898410f, -0.49811074f, -0.35061392f, 
    0.00323338f, -0.09770709f, 0.25812522f, 0.15847853f, -0.05997625f, 0.00337738f, -0.09977443f, 0.09872863f, 
    -0.62172800f, -0.13563147f, 0.02436019f, -0.02768770f, -0.02893487f, 0.07586128f, 0.00987031f, -0.06422804f, 
    0.23044860f, 0.24816781f, 0.06236032f, -0.06703418f, 0.02877205f, 0.09292552f, -0.08827689f, -0.11485822f, 
    -0.07213178f, 0.22162479f, 0.38770327f, -0.40943721f, 0.08757456f, -0.02734417f, 0.06815097f, -0.13795206f, 
    -0.03651929f, -0.21268815f, -0.03196976f, -0.07631058f, 0.16979404f, -0.07170688f, -0.03653993f, 0.18773356f, 
    -0.08928530f, 0.09794880f, -0.10141160f, 0.26612175f, 0.05547760f, -0.05397664f, 0.04972281f, -0.09249602f, 
    0.06930931f, -0.11140791f, -0.18093535f, 0.03719924f, 0.24456060f, 0.16234209f, -0.22862384f, -0.14267300f, 
    0.09755663f, 0.09350826f, 0.03517232f, -0.13458584f, -0.03187486f, 0.34525689f, 0.13776867f, -0.05460137f, 
    -0.19197094f, -0.07441833f, -0.01977546f, 0.10223276f, 0.07566455f, 0.17009771f, 0.05407867f, 0.21316966f, 
    0.12690161f, -0.28980276f, -0.13996936f, 0.03979664f, 0.17683132f, -0.10688163f, -0.13730983f, 0.22851329f, 
    -0.05352997f, 0.13433930f, 0.15417282f, 0.00245437f, -0.15311280f, -0.02115433f, -0.11817724f, 0.20220907f, 
    -0.03941583f, -0.15937299f, -0.25373444f, -0.25372699f, 0.03443685f, 0.00254928f, 0.03245785f, 0.01434145f, 
    0.23349908f, 0.03995222f, 0.00953414f, -0.24391156f, 0.15045358f, 0.08663157f, -0.01476446f, 0.12385596f, 
    0.14508219f, -0.07405084f, -0.07659289f, -0.26388189f, 0.03201047f, -0.06001908f, 0.08375818f, -0.36145538f, 
    -0.26574430f, 0.08830925f, 0.02721382f, 0.24123599f, 0.25377092f, -0.02340440f, -0.20130791f, 0.04906784f, 
    0.04799386f, -0.08996005f, -0.02872794f, 0.15032086f, 0.03426753f, 0.06756289f, -0.23167007f, -0.04332209f, 
    -0.16625364f, 0.04240758f, 0.07934424f, 0.05440652f, -0.11317796f, 0.03547132f, -0.11199270f, 0.20602372f, 
    0.19259502f, 0.14460488f, -0.11569504f, 0.11969870f, 0.18871368f, 0.10198292f, 0.32309705f, 0.20489050f, 
    0.01069949f, -0.25667942f, -0.09967456f, -0.10608950f, 0.06705990f, -0.05436884f, 0.03754219f, 0.27469867f, 
    0.26807946f, -0.36393738f, -0.08077715f, 0.02879987f, 0.09074283f, -0.01546851f, -0.03927481f, -0.09913945f, 
    -0.03031900f, -0.26399356f, 0.17055865f, -0.16521771f, 0.26016140f, 0.10842606f, 0.29015163f, 0.07803319f, 
    0.03143274f, 0.00441357f, -0.17882285f, -0.25342342f, -0.09727358f, -0.06051929f, 0.07219957f, 0.11755285f, 
    0.28882176f, -0.32323834f, 0.06109922f, 0.09139783f, -0.43740749f, 0.20316271f, 0.20197605f, 0.07802378f, 
    0.00559162f, 0.07473015f, 0.05109451f, -0.20636094f, -0.19214211f, -0.63447165f, 0.02336654f, 0.16400957f, 
    0.14380608f, 0.03555161f, -0.12059105f, -0.05299601f, 0.19931534f, 0.08251911f, -0.18195941f, -0.15977135f, 
    -0.41634250f, 0.01384558f, 0.26373658f, 0.01137898f, -0.01062930f, 0.37970376f, -0.22904941f, 0.22624364f, 
    -0.16345215f, 0.03105197f, -0.03136019f, -0.07040790f, 0.15002210f, -0.08388819f, 0.32063383f, 0.15133299f, 
    -0.35445008f, -0.03583717f, 0.28076530f, -0.03048919f, -0.02523701f, 0.22956362f, -0.20598918f, -0.35872242f, 
    -0.37242463f, 0.06530651f, -0.25259063f, -0.11833736f, -0.02277913f, -0.21072933f, -0.01515995f, -0.04587471f, 
    0.34100881f, 0.11135192f, -0.11510730f, 0.21113150f, -0.07471245f, -0.01428627f, 0.03038917f, -0.16225316f, 
    0.05736078f, -0.60698271f, 0.05007559f, 0.17340222f, 0.09482596f, -0.11526117f, 0.05204839f, 0.13668367f, 
    0.22103980f, -0.09378841f, -0.18402284f, 0.05516159f, -0.29491329f, 0.22216350f, 0.03109083f, 0.11156069f, 
    -0.19719757f, 0.00287659f, -0.10305422f, 0.31269172f, -0.15060207f, 0.32110578f, -0.30936867f, -0.00073566f, 
    -0.26087269f, -0.02139734f, 0.02444067f, 0.07284828f, -0.09206011f, -0.05643513f, 0.09203350f, 0.08695112f, 
    -0.05526290f, 0.09448924f, 0.29987201f, -0.07856795f, 0.08727345f, -0.04938852f, -0.10332529f, -0.35473597f, 
    0.22935614f, 0.09605855f, -0.05100710f, -0.18033092f, 0.08375978f, -0.06346915f, -0.18338548f, 0.03014594f, 
    -0.16716123f, 0.02259480f, -0.00340283f, -0.06038320f, 0.02228562f, -0.08651736f, 0.10203312f, -0.24779837f, 
    -0.76603752f, -0.18479355f, 0.17992574f, -0.13771442f, 0.01323292f, 0.08740704f, -0.03797871f, -0.14485312f, 
    -0.21326445f, 0.39992931f, -0.14609852f, 0.05370549f, 0.16447663f, -0.31040454f, 0.16896863f, -0.02411150f, 
    -0.14052588f, 0.12827860f, 0.21239963f, 0.20406121f, -0.02769768f, 0.04201282f, -0.05263214f, -0.07928145f, 
    0.06025272f, -0.12903763f, -0.22282165f, 0.14460252f, 0.10420723f, -0.09178622f, 0.18947655f, 0.10260911f, 
    0.03963936f, -0.10798888f, 0.16892609f, 0.48270923f, -0.23541319f, -0.20939995f, -0.05448177f, 0.08385628f, 
    0.07759243f, -0.08862862f, -0.07204348f, 0.06368847f, 0.27011609f, 0.08552626f, -0.47050041f, 0.13563816f, 
    -0.11627664f, -0.02384146f, 0.08268697f, 0.06201528f, 0.20891435f, -0.54744542f, 0.22231753f, -0.20276442f, 
    0.14952087f, -0.20181221f, 0.08731949f, -0.23659080f, -0.24471447f, 0.24724226f, 0.06286912f, 0.19477412f, 
    0.12484875f, -0.02234329f, 0.06021496f, 0.08058373f, 0.03889346f, -0.01120816f, 0.13372941f, 0.12485055f, 
    0.14276576f, 0.19288127f, 0.20009296f, -0.17980120f, -0.07342124f, -0.10510983f, -0.20022629f, 0.04184666f, 
    0.00845290f, -0.08330377f, 0.21859679f, 0.01592813f, 0.19711113f, -0.13775147f, -0.00065660f, 0.14128669f, 
    0.08853330f, 0.23110284f, 0.08303046f, -0.06630910f, 0.01016464f, -0.14843358f, 0.19648139f, 0.12328196f, 
    0.07450106f, 0.03614394f, -0.07431767f, -0.38077760f, -0.19831756f, 0.23429994f, 0.13426307f, 0.01488959f, 
    -0.05121032f, -0.16068719f, 0.09361256f, 0.07831507f, 0.06310698f, 0.01094439f, 0.04366133f, 0.10128598f, 
    -0.11150654f, -0.03821892f, 0.29294515f, -0.13014516f, -0.10270489f, 0.12384661f, -0.21972877f, 0.10188477f, 
    -0.12632029f, 0.19696847f, 0.05680835f, 0.19051330f, -0.32957548f, -0.33463761f, 0.06097344f, 0.18798429f, 
    0.05545004f, 0.00550362f, 0.03022536f, 0.18915799f, 0.09243506f, -0.13820796f, 0.27660218f, 0.02309204f, 
    0.16734236f, 0.19704095f, -0.08083758f, 0.18040136f, -0.13897787f, -0.06695691f, 0.08923560f, 0.44929066f, 
    0.07355095f, -0.09100308f, 0.08940332f, 0.02946367f, -0.11680840f, 0.00408082f, -0.10415242f, 0.11954718f, 
    -0.05370899f, 0.00605738f, -0.06864311f, 0.01023230f, -0.00284824f, -0.03447959f, 0.00506271f, -0.02476923f, 
    -0.05387682f, 0.03670087f, -0.02997137f, -0.00457489f, -0.05370470f, -0.03279506f, 0.03188430f, 0.01678422f, 
    -0.03948886f, -0.02288415f, 0.03648023f, -0.05594242f, -0.00111038f, 0.02411750f, 0.00616235f, -0.01838876f, 
    -0.04952136f, -0.06209847f, -0.02829570f, -0.02088688f, -0.03803424f, 0.03025961f, -0.05748321f, -0.03424223f, 
    -0.06247363f, -0.03850950f, -0.06826612f, -0.07180684f, -0.05132984f, 0.00743829f, 0.01120615f, -0.05951570f, 
    0.00940898f, 0.01509178f, 0.02652773f, 0.01855150f, -0.04325798f, -0.04748094f, -0.03102466f, -0.04908842f, 
    0.01644502f, 0.05476180f, 0.04188718f, -0.01713739f, 0.00280053f, -0.04520908f, 0.00806543f, -0.02864365f, 
    0.03465887f, 0.03326254f, -0.04322282f, -0.03687699f, 0.00287030f, -0.06773119f, -0.02078388f, -0.01845627f, 
    -0.04261039f, 0.03153734f, -0.06471513f, -0.02183083f, -0.00310905f, -0.00717658f, -0.02183798f, 0.01182261f, 
    0.01376354f, -0.01806026f, -0.00484185f, 0.01035852f, -0.02373221f, 0.00123794f, -0.01146235f, -0.05919931f, 
    0.01290848f, -0.00458890f, 0.02346729f, 0.04118840f, -0.00879247f, -0.06053226f, -0.01791849f, 0.00728567f, 
    0.02151521f, 0.02239563f, -0.03232684f, -0.04096050f, 0.03869727f, -0.04603469f, 0.02448242f, 0.01970285f, 
    -0.00868117f, 0.01339694f, -0.00692924f, -0.01700850f, -0.02232914f, 0.02296017f, 0.02363341f, 0.05379337f, 
    -0.03320818f, -0.05407977f, -0.05444598f, 0.01986052f, -0.05109549f, -0.05617159f, -0.05796619f, -0.02646762f, 
    0.04070400f, -0.05052372f, 0.00590296f, -0.02645500f, 0.00247015f, -0.01249688f, -0.05669311f, 0.03159415f, 
    -0.02361080f, 0.00996589f, -0.06498453f, -0.00921453f, 0.01321325f, -0.02971899f, -0.01352913f, 0.03878847f, 
    -0.01303690f, -0.00753005f, -0.03204010f, -0.04489308f, -0.02186858f, -0.03325424f, -0.00603991f, -0.01835415f, 
    0.01405552f, 0.04076216f, 0.04626632f, -0.01966427f, 0.02251612f, 0.04834625f, -0.02882947f, 0.00087483f, 
    0.03434645f, 0.03593819f, 0.01921258f, 0.01713945f, 0.04222614f, 0.03007530f, 0.00086151f, -0.04653061f, 
    -0.06804042f, 0.02430368f, -0.05107131f, 0.04023575f, 0.00491914f, 0.02370705f, -0.02523618f, 0.02902711f, 
    0.02997351f, -0.05576426f, -0.05277807f, -0.06814272f, -0.01556105f, -0.06376797f, -0.01177208f, -0.03810815f, 
    -0.03875535f, -0.00185275f, -0.01423451f, -0.01995844f, -0.06439034f, -0.02799029f, 0.03162828f, -0.01183403f, 
    -0.03389144f, 0.03422662f, 0.04033315f, -0.04274036f, 0.02278420f, -0.01685987f, 0.01558322f, 0.01802693f, 
    -0.02462346f, 0.00776459f, 0.03527834f, -0.05138985f, -0.06989793f, -0.02167431f, -0.01067146f, -0.00394138f, 
    -0.04828504f, 0.01981018f, 0.03641614f, 0.02034434f, 0.02427734f, -0.01882856f, -0.00996980f, 0.02374890f, 
    -0.04418972f, -0.02399084f, -0.06493986f, 0.02736261f, -0.04592984f, -0.04217773f, 0.02537677f, 0.03921075f, 
    0.01920138f, -0.03093829f, -0.00958534f, 0.03448811f, 0.04762806f, 0.00300317f, 0.00978281f, 0.01102002f, 
    0.02117928f, -0.00731765f, -0.06279460f, 0.01334048f, 0.02810899f, -0.01232487f, -0.01934383f, -0.02615930f, 
    0.01149707f, -0.04745032f, 0.01730224f, 0.00548470f, 0.01801135f, -0.06712545f, -0.00926160f, -0.02687453f, 
    -0.02824139f, 0.00089968f, -0.06091260f, 0.03652434f, -0.06293945f, 0.03448775f, -0.06702643f, 0.03023806f, 
    0.01186689f, -0.01111341f, 0.04296610f, -0.04604135f, -0.04533347f, 0.01333831f, -0.01585772f, -0.04606380f, 
    -0.01948954f, -0.03956876f, -0.00464672f, -0.05293057f, 0.04064691f, -0.05678534f, -0.06199827f, 0.03867649f, 
    -0.03270864f, -0.05316106f, 0.00579575f, 0.01122471f, 0.03596581f, 0.01286017f, -0.01397608f, 0.02321393f, 
    0.02925601f, 0.04059414f, 0.01290199f, -0.01598754f, -0.01313454f, -0.06930808f, 0.02149374f, 0.01897709f, 
    -0.03493309f, -0.04114136f, -0.01591821f, 0.04322617f, 0.02029056f, -0.06348339f, -0.04543284f, -0.03437258f, 
    -0.03406417f, -0.01007463f, 0.01458707f, 0.01214851f, -0.03762500f, -0.01731896f, 0.03362316f, 0.00756218f, 
    0.15678528f, -0.24312146f, -0.47439250f, -0.20164081f, -0.02169919f, -0.03540937f, -0.19780399f, -0.00528722f, 
    0.04244701f, 0.14741445f, 0.28378230f, 0.27976620f, 0.03831182f, 0.00473593f, 0.08077567f, 0.09189315f, 
    -0.27454668f, -0.03836046f, -0.40641731f, -0.23813197f, 0.25962439f, -0.03127270f, -0.00617474f, -0.16700006f, 
    0.08371374f, 0.15458640f, 0.12715390f, 0.33965540f, 0.12216377f, -0.14928527f, 0.11336617f, 0.02857657f, 
    -0.06148680f, 0.26106122f, 0.03492427f, -0.10146695f, -0.27488285f, -0.02657185f, -0.10260953f, -0.08538101f, 
    -0.10234756f, 0.14765425f, -0.03039870f, -0.18579218f, 0.08065514f, -0.18563238f, 0.05431772f, 0.13380674f, 
    -0.06833222f, 0.19602641f, 0.04827692f, 0.00374115f, -0.00929468f, 0.00329496f, 0.08427178f, 0.29505661f, 
    -0.04162237f, 0.29448619f, 0.02411410f, 0.01983224f, 0.30482107f, -0.03296686f, 0.03864750f, 0.62122023f, 
    0.04900443f, 0.13722081f, 0.07351915f, -0.10921298f, -0.00458444f, 0.32947204f, -0.07955878f, 0.07278429f, 
    -0.13062544f, 0.00322098f, -0.17043677f, 0.12361479f, -0.15260039f, 0.04088695f, 0.20477256f, 0.02162926f, 
    -0.05656180f, -0.50899941f, 0.18841100f, -0.16806030f, 0.09866478f, -0.02032937f, 0.20748140f, -0.15109374f, 
    0.04266940f, -0.07724974f, 0.15767993f, -0.01362098f, 0.13307372f, -0.00938676f, -0.05077159f, -0.13552475f, 
    -0.03886491f, 0.39311296f, -0.12839206f, -0.18584511f, -0.06044438f, 0.08196416f, 0.10539039f, 0.23922694f, 
    0.16317430f, 0.04968321f, 0.11222538f, 0.06123957f, -0.03507457f, 0.10607273f, 0.23665197f, -0.05841847f, 
    0.41535109f, -0.14612934f, 0.16580272f, 0.02762513f, 0.03215250f, -0.34723759f, -0.24272323f, 0.52697587f, 
    0.01199157f, -0.00357212f, -0.18345422f, -0.09909462f, 0.16524637f, 0.08490336f, -0.33493719f, -0.28263628f, 
    0.59335637f, -0.04455070f, 0.04178396f, -0.25943798f, -0.14716089f, -0.17538847f, 0.05167570f, -0.10816320f, 
    -0.82628262f, 0.14703663f, -0.31005928f, -0.03287669f, -0.08846193f, -0.24999608f, 0.10271132f, -0.02631756f, 
    0.56438267f, 0.51811814f, 0.26440197f, -0.00996618f, -0.10355593f, 0.03526187f, 0.12567987f, -0.23921622f, 
    0.00520584f, -0.35542420f, -0.12315357f, -0.48018107f, 0.09413052f, 0.15293755f, 0.14753163f, 0.08819048f, 
    -0.13215257f, 0.12695859f, -0.52053392f, 0.18226248f, 0.07126435f, -0.10385703f, 0.03887931f, -0.23894306f, 
    0.15024364f, 0.08516023f, 0.13473716f, -0.12854703f, 0.15041384f, 0.13854407f, 0.03749224f, 0.05631866f, 
    0.01413205f, -0.17000411f, 0.18293181f, -0.00047506f, 0.05071461f, 0.17589313f, -0.17950933f, -0.03388596f, 
    0.10987943f, 0.01853129f, -0.01916749f, 0.13341282f, -0.05029943f, 0.08549368f, -0.07107333f, -0.05628771f, 
    -0.24135554f, -0.05333632f, -0.09922846f, -0.08413769f, 0.09122436f, 0.07526673f, -0.05816944f, 0.10209683f, 
    0.20004889f, -0.10799765f, 0.31609154f, -0.23621827f, -0.21789581f, -0.04481202f, -0.12353445f, -0.04621194f, 
    0.05276521f, 0.05557617f, -0.26045313f, -0.06342725f, 0.14138603f, -0.06639720f, -0.18052714f, 0.11112054f, 
    -0.07255099f, 0.05492811f, 0.02735258f, -0.06975292f, 0.04512187f, 0.19748953f, 0.11328015f, 0.10779377f, 
    0.11872533f, 0.09997685f, -0.03712414f, 0.12753072f, -0.20573585f, -0.05569616f, 0.01338999f, 0.00400176f, 
    0.03659327f, 0.19127771f, -0.11613414f, 0.00521887f, 0.06231694f, -0.20967092f, 0.16933700f, -0.05500584f, 
    -0.04037286f, -0.33388594f, -0.00241646f, 0.22721428f, 0.30081877f, 0.09106827f, -0.18880965f, -0.02608731f, 
    -0.24870495f, 0.29108495f, 0.07834956f, 0.21209522f, -0.05239198f, 0.15819721f, -0.45246035f, -0.05570082f, 
    -0.21781810f, 0.03848736f, 0.09256689f, 0.17550090f, -0.00729648f, -0.13812819f, -0.52892470f, -0.15627570f, 
    0.20387158f, 0.04451894f, -0.00177496f, 0.00925828f, -0.02705965f, 0.21620843f, 0.09393812f, 0.11297254f, 
    0.08935192f, -0.16956255f, 0.09362830f, -0.10662638f, -0.11495155f, -0.11144281f, 0.07041617f, -0.36566418f, 
    0.14037690f, -0.48896247f, -0.14540152f, 0.15754047f, -0.16541031f, 0.11673992f, 0.08950213f, 0.19232608f, 
    0.21871679f, 0.24115393f, 0.05862997f, -0.26837957f, 0.22323218f, -0.06461538f, 0.01694795f, -0.10361158f, 
    0.06762613f, -0.00543640f, -0.33207169f, -0.24406013f, 0.00805256f, 0.31714395f, 0.13882528f, 0.12311415f, 
    0.16348743f, -0.16110472f, -0.18602474f, 0.35277498f, 0.27015391f, 0.11036911f, -0.13408726f, 0.08791974f, 
    0.18795040f, 0.01307442f, 0.02523543f, -0.15857655f, -0.19524737f, 0.02714787f, -0.24186644f, -0.10423344f, 
    -0.03644916f, 0.12611350f, -0.03091051f, 0.19648017f, -0.28302303f, 0.03785834f, -0.57607740f, -0.17441721f, 
    0.22594404f, -0.22455472f, 0.11748175f, -0.02037186f, -0.24705431f, 0.35807565f, 0.28591079f, -0.04980719f, 
    0.17524341f, 0.02747809f, -0.00630971f, -0.07607900f, -0.08679891f, -0.01833104f, 0.15825263f, -0.26481217f, 
    -0.01804585f, -0.02081273f, -0.23111281f, 0.14959189f, 0.32864821f, 0.20730489f, 0.02965715f, -0.72353590f, 
    -0.67134625f, -0.43514198f, -0.10526614f, -0.29344571f, 0.02341633f, -0.00694928f, -0.19276549f, 0.34325033f, 
    0.51983690f, 0.25495195f, 0.08167914f, -0.19239514f, -0.03675077f, -0.04474301f, -0.19517843f, -0.17873572f, 
    0.15272251f, 0.00128198f, 0.07028180f, -0.24038807f, 0.08865377f, -0.19298144f, 0.02376820f, 0.21642905f, 
    -0.04713287f, 0.05713151f, -0.39338312f, -0.37567624f, 0.05330833f, 0.04885343f, -0.03229021f, -0.02359156f, 
    -0.07988966f, -0.35545993f, 0.30382597f, 0.33291703f, 0.42708972f, -0.15929127f, 0.03996443f, -0.24545068f, 
    0.00809800f, -0.05476494f, 0.02540879f, 0.05997095f, -0.22796337f, 0.12624559f, -0.00296100f, -0.15396726f, 
    0.14528924f, -0.09754094f, 0.12482581f, -0.26023352f, -0.07067256f, -0.60902792f, 0.36564559f, -0.07272059f, 
    0.08570196f, 0.00467476f, 0.11551993f, -0.13354406f, -0.11179961f, -0.08045997f, -0.29979536f, -0.43501726f, 
    0.16777493f, 0.03866272f, -0.01908601f, -0.02773915f, 0.08014959f, -0.06663253f, -0.03393051f, 0.03462691f, 
    0.14218228f, -0.50648803f, 0.03204014f, -0.08859421f, 0.04617172f, 0.09402037f, -0.23195843f, 0.00675554f, 
    0.47543737f, 0.08097621f, 0.32494593f, -0.20641869f, -0.00387022f, -0.10702600f, -0.00940834f, 0.01202456f, 
    -0.07309021f, 0.55689281f, 0.18877867f, 0.39484459f, -0.20568483f, -0.06736146f, -0.01302310f, 0.02875511f, 
    0.09092034f, 0.15109828f, 0.14441429f, -0.19855355f, 0.18947510f, -0.00803333f, 0.01888320f, 0.23469375f, 
    -0.00142436f, -0.05227976f, 0.15970223f, 0.00501512f, -0.21939537f, -0.51918525f, 0.09353577f, 0.19558761f, 
    0.02380876f, 0.19936611f, -0.15161620f, 0.00715614f, -0.12771802f, 0.07143157f, -0.16181538f, -0.00885689f, 
    0.15114011f, -0.09456592f, 0.02718617f, -0.03843353f, -0.00645876f, -0.08696812f, -0.26970968f, 0.02093084f, 
    0.14133954f, 0.09259783f, -0.12791443f, 0.16298898f, 0.10405803f, -0.00316520f, -0.17773637f, 0.22012703f, 
    -0.00334347f, 0.03941081f, 0.03727126f, -0.03485787f, 0.00634703f, -0.02490974f, -0.07422872f, 0.33535483f, 
    0.14081173f, -0.06827258f, -0.03237702f, -0.15035711f, -0.12536897f, -0.21842794f, 0.03303592f, -0.16025271f, 
    -0.05438025f, 0.19903411f, 0.27208486f, 0.02778533f, 0.02036944f, -0.12781271f, 0.09993112f, 0.12936741f, 
    0.11869822f, 0.09456698f, -0.27114636f, -0.42262506f, 0.15991281f, 0.15241663f, -0.17309631f, 0.25390452f, 
    -0.05341683f, -0.08237509f, -0.30804428f, 0.01702290f, -1.10055363f, -0.00476098f, -0.10726181f, 0.03687241f, 
    -0.04762777f, 0.09769221f, 0.17327456f, 0.32950383f, 0.02363931f, 0.25873572f, -0.06428035f, -0.00526975f, 
    -0.01121725f, 0.19541390f, 0.15536371f, -0.07592347f, -0.01274477f, 0.04583075f, 0.35088688f, 0.02612234f, 
    -0.04842986f, 0.05315344f, 0.03169808f, 0.08054212f, -0.08769821f, 0.03533524f, -0.06693281f, 0.01922156f, 
    0.14656986f, -0.07720640f, 0.17183584f, -0.17808220f, 0.09578869f, 0.09191470f, -0.05431869f, 0.00737251f, 
    0.20880856f, 0.25972378f, -0.02077902f, -0.15469749f, -0.05459364f, 0.02738034f, 0.10031363f, 0.01152917f, 
    0.27205002f, 0.56629902f, 0.03428853f, -0.14326893f, -0.02924919f, -0.03246639f, -0.08552502f, 0.11226752f, 
    0.03770118f, 0.03170703f, -0.05685407f, 0.00557591f, 0.04700423f, 0.00957575f, -0.02260925f, 0.03526404f, 
    -0.00819441f, -0.04563488f, 0.01050715f, -0.04017355f, -0.00503986f, -0.05785960f, 0.03911612f, 0.02826821f, 
    -0.00912702f, 0.00622603f, -0.02296795f, -0.04048143f, 0.03961580f, -0.03885019f, -0.00263318f, 0.02807732f, 
    -0.05692039f, 0.02530983f, -0.01331308f, 0.04502947f, 0.04678820f, -0.02600014f, -0.04586169f, -0.01324283f, 
    0.02459140f, -0.01352382f, -0.05301306f, 0.05229855f, -0.00870058f, -0.06472138f, -0.01253376f, 0.03597877f, 
    0.02929118f, -0.04614313f, -0.04945213f, -0.03940903f, 0.01417585f, 0.02489467f, -0.05463574f, -0.00096412f, 
    0.05142903f, -0.03193279f, 0.01462494f, 0.00012762f, 0.02949276f, -0.00513971f, -0.00916851f, 0.00357991f, 
    -0.00816498f, -0.04287418f, -0.04409495f, -0.01661852f, 0.02816906f, -0.05615374f, 0.02222117f, -0.00978493f, 
    -0.02764455f, 0.01422209f, 0.03857741f, 0.03114427f, 0.03871689f, -0.05122875f, -0.00092921f, -0.01777247f, 
    -0.00669564f, 0.00791316f, 0.03202358f, 0.00856851f, -0.04337014f, -0.01553557f, 0.04918177f, 0.02510790f, 
    -0.05117695f, -0.03404490f, 0.03399660f, -0.05951328f, -0.06155541f, 0.01193448f, -0.02039236f, -0.01975384f, 
    -0.00762134f, 0.00228389f, 0.02337462f, -0.04556313f, 0.02483926f, -0.05012444f, -0.02321401f, -0.03635725f, 
    -0.00982419f, 0.01290122f, -0.03139012f, -0.01549821f, 0.01198793f, 0.05042810f, -0.00201597f, 0.04883356f, 
    -0.03765176f, -0.00255042f, 0.00010954f, 0.01405386f, 0.03372453f, -0.04879115f, 0.04096720f, -0.04400994f, 
    -0.02291047f, 0.01371715f, 0.00903301f, 0.02986614f, 0.01034406f, -0.05592293f, 0.00268346f, 0.00983031f, 
    -0.02508841f, -0.03493528f, -0.03514109f, -0.02262194f, 0.01972834f, 0.05237114f, -0.03218484f, 0.00313792f, 
    -0.05889962f, 0.02099451f, 0.00008346f, -0.01274918f, -0.01044966f, 0.02503545f, 0.02254719f, -0.01973318f, 
    -0.04389686f, 0.03068527f, -0.01388757f, -0.05811629f, -0.02180074f, 0.05238300f, -0.01683069f, -0.06331575f, 
    0.05195894f, -0.00936195f, -0.05881246f, 0.01582638f, -0.05118003f, -0.01645450f, -0.01422265f, -0.00417185f, 
    0.00889929f, -0.03276794f, 0.03985349f, 0.00548479f, 0.00090014f, -0.05683393f, 0.01068238f, -0.01229746f, 
    -0.02632684f, -0.04914309f, -0.06408147f, -0.01979090f, 0.03230502f, 0.02630170f, -0.00232692f, -0.00093459f, 
    -0.02762735f, -0.02412212f, -0.00708061f, 0.01872003f, -0.03394324f, -0.05280669f, 0.04429986f, -0.04920531f, 
    0.03395412f, -0.05565569f, 0.05126115f, 0.04000204f, -0.02056249f, 0.00420742f, -0.04788592f, -0.01943973f, 
    -0.05134583f, 0.04353296f, -0.01328090f, 0.04171654f, -0.03978538f, -0.00620276f, -0.01326540f, -0.02416979f, 
    0.04292247f, -0.02628283f, 0.04693223f, 0.04571318f, -0.02018256f, -0.05815947f, 0.03228571f, 0.04974231f, 
    -0.04341089f, -0.01844773f, -0.01103303f, 0.01615725f, -0.02005974f, -0.00301727f, -0.06293636f, 0.03226968f, 
    -0.00174649f, 0.01586630f, -0.05684284f, -0.06154329f, -0.04297745f, 0.02525049f, 0.01319701f, 0.03856089f, 
    -0.05696844f, -0.04366492f, -0.04694895f, 0.02004799f, -0.01232202f, 0.00297304f, 0.01497180f, -0.00834718f, 
    -0.05240272f, -0.03237238f, 0.01434504f, 0.00487939f, -0.00764040f, 0.04379020f, -0.04284584f, -0.06006870f, 
    -0.01167156f, 0.01624552f, -0.06189524f, 0.03628071f, -0.06338272f, -0.05743420f, -0.03373016f, -0.00797903f, 
    -0.00976149f, -0.04063835f, 0.03080230f, 0.02356417f, 0.03897213f, 0.01407321f, -0.05125195f, -0.02659380f, 
    -0.05311457f, 0.01619511f, -0.00015823f, -0.03748254f, -0.06436797f, 0.01410184f, -0.00723118f, -0.05967219f, 
    -0.02140626f, -0.00541874f, -0.00261505f, 0.03756744f, 0.01074904f, 0.00314968f, -0.05048339f, -0.06365055f, 
    -0.06484772f, -0.03845158f, 0.02266655f, 0.03536654f, -0.00107049f, -0.02182103f, -0.06425834f, 0.01745860f, 
    -0.03217641f, 0.00783096f, -0.01128786f, -0.04861972f, -0.05800353f, 0.00512448f, 0.00020381f, -0.04829724f, 
    0.03263909f, -0.01726146f, -0.00965150f, -0.02651579f, -0.00281557f, 0.05178729f, 0.03829146f, -0.05481693f, 
    -0.02645869f, -0.06738944f, -0.02439124f, 0.02839496f, 0.04997728f, 0.03778236f, 0.00872213f, -0.04617294f, 
    0.00223828f, -0.04115442f, -0.03197291f, -0.00820222f, -0.03048854f, 0.00839670f, 0.00904461f, 0.00114676f, 
    0.01486843f, 0.01908121f, 0.03924498f, 0.02518518f, -0.00287549f, -0.04665326f, -0.02087723f, -0.01863282f, 
    -0.03414215f, -0.01778147f, 0.02607658f, -0.03853475f, -0.02867922f, 0.02470344f, -0.04348115f, -0.01494348f, 
    -0.06064756f, 0.04272917f, -0.06556366f, 0.03935745f, -0.03536399f, 0.00961162f, -0.04697148f, 0.04995871f, 
    0.02188532f, 0.00607794f, -0.05448769f, 0.05720357f, -0.02995965f, 0.02879231f, -0.05456136f, -0.00674437f, 
    -0.02362569f, -0.00686210f, 0.00265016f, 0.04252589f, 0.00870847f, 0.04302059f, -0.07811455f, -0.02676815f, 
    -0.03125969f, -0.00298703f, 0.00208247f, -0.03833894f, 0.02938700f, 0.04799003f, 0.04536776f, -0.06056428f, 
    -0.07436837f, -0.00023442f, -0.05446174f, 0.03837601f, -0.05845686f, -0.03697395f, 0.02694684f, 0.00151215f, 
    -0.01042427f, 0.02377908f, 0.01052260f, 0.02322636f, -0.01169766f, 0.04966855f, -0.04625119f, -0.03257010f, 
    0.04295979f, -0.07336579f, -0.01937073f, -0.02225278f, -0.06247325f, -0.01436760f, 0.03577143f, -0.01669366f, 
    -0.01359202f, 0.01953340f, 0.02444220f, 0.01420044f, -0.01847715f, -0.00915562f, 0.00834676f, 0.02848756f, 
    0.03168801f, 0.01739944f, 0.03701106f, -0.00556132f, 0.01025182f, -0.00383008f, 0.05832604f, 0.00898427f, 
    -0.00688339f, 0.05790321f, -0.01109316f, -0.06863078f, -0.05026690f, 0.00075192f, -0.02550038f, 0.04400389f, 
    0.04613533f, -0.04725052f, -0.03642575f, -0.00408430f, 0.00401124f, -0.00260645f, -0.01211267f, 0.00426485f, 
    0.03956056f, -0.00773669f, 0.03677322f, 0.04674964f, -0.02341184f, -0.05371970f, -0.06046290f, 0.01195861f, 
    -0.01757224f, 0.01886918f, -0.05125132f, -0.04490717f, -0.04813473f, -0.02983924f, 0.03677627f, 0.03387212f, 
    -0.01287262f, -0.05650901f, 0.01778401f, 0.00902439f, -0.06672181f, 0.03377685f, 0.03720920f, -0.06317428f, 
    -0.07565134f, -0.02157147f, 0.00589705f, 0.01291399f, -0.03625483f, 0.04203542f, -0.01806248f, 0.00331009f, 
    -0.04933902f, -0.06110055f, 0.03372303f, -0.05567164f, -0.04531801f, 0.02637650f, 0.01833772f, -0.05195564f, 
    0.03416132f, -0.07042386f, -0.06454554f, 0.02958708f, -0.06920164f, 0.00112930f, -0.02372180f, 0.02298762f, 
    0.00827114f, 0.00458220f, 0.03065886f, 0.04270696f, -0.05575830f, -0.05961290f, -0.00374466f, 0.04379726f, 
    -0.00778531f, 0.01365181f, 0.05846190f, -0.00787570f, -0.04770387f, -0.02394345f, -0.03956867f, 0.00090667f, 
    -0.03428903f, -0.01588401f, -0.02677849f, -0.00437620f, 0.02016975f, -0.02558601f, -0.00029037f, 0.05719839f, 
    -0.02959140f, 0.02214881f, -0.00293809f, -0.00107177f, -0.00065822f, -0.07650632f, 0.02536300f, -0.03020447f, 
    0.06117062f, 0.00812872f, 0.05148401f, -0.05839835f, -0.02536131f, 0.00294595f, 0.00004102f, 0.00282708f, 
    -0.03264560f, -0.04892040f, -0.00455841f, -0.05594973f, -0.05324451f, -0.01569239f, 0.01425621f, 0.03235236f, 
    0.01753000f, -0.05520879f, -0.01508400f, 0.00126727f, 0.02991370f, 0.04576953f, 0.01707861f, -0.00809055f, 
    -0.03597564f, -0.06529828f, -0.05271090f, 0.05754450f, -0.02348386f, -0.05250785f, -0.04339674f, -0.00925779f, 
    0.05141760f, 0.04034051f, -0.07016803f, -0.00234127f, -0.06701779f, 0.01496993f, 0.01464015f, 0.01261673f, 
    0.05963125f, -0.02168175f, 0.02007291f, -0.03070606f, 0.00625121f, -0.03917203f, -0.06203869f, -0.03841821f, 
    -0.04287793f, 0.00967830f, -0.03072704f, -0.02664729f, -0.03836692f, 0.03679791f, -0.04227647f, 0.02717978f, 
    -0.03845449f, 0.02855247f, 0.04381253f, -0.03584311f, -0.06450252f, 0.01759415f, 0.04497661f, 0.03417963f, 
    -0.01577942f, -0.01946406f, -0.02332487f, 0.05499734f, 0.00823818f, -0.06562050f, 0.00771680f, -0.01162964f, 
    0.05156852f, -0.05305677f, -0.05475165f, -0.01784994f, 0.05767148f, 0.03809199f, -0.04088618f, 0.01026229f, 
    -0.06489243f, 0.02436332f, -0.05561190f, -0.05188706f, -0.01045884f, -0.01346270f, -0.03292863f, 0.05619525f, 
    0.00580122f, 0.02457592f, -0.07148265f, 0.21311048f, 0.16993439f, -0.05124916f, 0.01161174f, 0.08806317f, 
    0.13474514f, 0.07723759f, 0.16344056f, -0.05399040f, -0.03706680f, -0.00628427f, 0.12604137f, -0.00472249f, 
    -0.07445657f, 0.04680691f, 0.20236729f, 0.16943888f, -0.02621084f, 0.10577729f, -0.24049968f, 0.07537083f, 
    -0.00393724f, -0.02246805f, 0.01751293f, 0.47741619f, 0.27276984f, -0.22473043f, -0.38033050f, 0.02858879f, 
    0.26758036f, 0.29165536f, 0.21453989f, 0.10674752f, 0.07918686f, 0.09786650f, -0.38982698f, -0.04963617f, 
    -0.18893406f, -0.28334662f, 0.14484894f, 0.05059830f, -0.10201133f, -0.89285648f, -0.71518362f, -0.43720490f, 
    0.14758115f, 0.07495795f, -0.04325712f, 0.00489136f, 0.10945427f, 0.04751450f, 0.24994364f, 0.13656113f, 
    0.07589710f, 0.06507581f, 0.09767340f, 0.14744544f, -0.06980707f, 0.01694969f, 0.01244741f, 0.01828063f, 
    -0.13023956f, -0.30921602f, -0.11215376f, -0.04607785f, 0.16871114f, 0.08916393f, 0.18417208f, 0.15374509f, 
    -0.41275126f, -0.23527339f, 0.05051601f, -0.02447621f, -0.12961154f, -0.10669784f, -0.16453874f, 0.07742894f, 
    -0.00889246f, -0.13571732f, -0.28873935f, -0.02381597f, -0.08737034f, 0.04754523f, -0.06532363f, 0.01710391f, 
    0.12400369f, -0.15145496f, -0.11335029f, 0.15041897f, 0.29457593f, 0.06801538f, 0.19473460f, 0.23389947f, 
    -0.04877279f, -0.05989495f, -0.12435670f, -0.83040273f, -0.28892785f, -0.43695113f, 0.05685226f, 0.04209861f, 
    -0.12859078f, 0.02353008f, 0.14867049f, 0.03691178f, -0.95116174f, -0.56292462f, -0.01111527f, 0.07851027f, 
    0.34216341f, -0.05997857f, 0.13481450f, -0.15128991f, 0.28048217f, 0.42296341f, 0.30369568f, 0.00843039f, 
    0.10857396f, -0.16166367f, 0.10323890f, 0.09542770f, 0.10739717f, 0.16797088f, -0.47021508f, 0.14661784f, 
    -0.01346362f, 0.10720633f, -0.32449606f, -0.13665977f, -0.02661884f, -0.07251383f, 0.08575780f, 0.00157842f, 
    0.09749060f, -0.27265465f, 0.08574463f, -0.04557995f, 0.02943096f, 0.15105480f, 0.01060851f, -0.12279329f, 
    0.48504257f, 0.20831281f, -0.14082722f, -0.01375911f, 0.11565715f, -0.04923247f, -0.09452763f, 0.26625526f, 
    0.03277491f, 0.29513133f, 0.24083412f, -0.00043993f, -0.09514855f, 0.18694052f, -0.09664563f, -0.24535067f, 
    0.49080673f, 0.05645185f, 0.07717819f, 0.20542561f, -0.13168943f, -0.11873588f, -0.26480240f, -0.18661055f, 
    0.02951128f, 0.14566647f, 0.30352151f, -0.55235225f, -0.14922768f, 0.29624090f, 0.26887673f, 0.17675626f, 
    0.12516892f, 0.12986796f, -0.13361722f, 0.14012012f, -0.11368660f, -0.15456612f, 0.17563276f, -0.05104659f, 
    0.13878694f, -0.38023677f, 0.18954799f, 0.16163412f, 0.20802511f, -0.62540489f, -0.77902907f, -0.11919213f, 
    0.23402862f, 0.23604222f, 0.11603267f, 0.31798726f, -0.10444792f, -0.19749631f, -0.67464942f, -0.51246375f, 
    0.02438042f, 0.31477699f, 0.03117159f, 0.23970503f, -0.09949057f, -0.03194178f, 0.09089271f, 0.03623123f, 
    0.17583054f, -0.16825534f, 0.10464042f, -0.02944316f, -0.06475710f, -0.14105299f, 0.07065260f, 0.19699410f, 
    0.09003087f, 0.06692499f, 0.02113820f, 0.01205135f, 0.05978354f, -0.25275880f, -0.14104277f, 0.04372463f, 
    -0.05068711f, 0.76941001f, 0.40155426f, 0.39232939f, 0.14590462f, -0.01834634f, 0.15903813f, -0.01309477f, 
    -0.04662609f, 0.41016120f, 0.35620627f, -0.12251175f, 0.00145028f, 0.06262573f, -0.11942026f, -0.04663502f, 
    -0.02229552f, -0.12906648f, 0.12085688f, -0.74821794f, -0.68064785f, -0.31129539f, 0.23278940f, 0.31836647f, 
    -0.16738071f, -0.13306084f, 0.00961267f, 0.05709679f, 0.00614932f, -0.38998589f, -0.05789780f, 0.01406566f, 
    0.09760623f, -0.14777490f, -0.03970558f, -0.00831219f, -0.38706073f, 0.03907759f, -0.12674011f, 0.00847491f, 
    0.18445717f, -0.11455695f, 0.30557263f, 0.29594246f, 0.08818492f, -0.07894261f, -0.26920590f, 0.18831046f, 
    0.09053138f, 0.28249955f, 0.04266956f, 0.18677737f, -0.03292758f, 0.11880455f, 0.04456667f, 0.11375529f, 
    0.13711348f, -0.03849062f, -0.02846562f, -0.04518744f, -0.22186571f, 0.18176219f, 0.19987674f, -0.06502843f, 
    -0.04711659f, -0.16827676f, -0.05198457f, 0.00363961f, -0.07032657f, -0.26182136f, 0.11002472f, -0.17675938f, 
    -0.26559889f, -0.03803023f, 0.18291409f, 0.11669369f, -0.00678890f, -0.16262847f, 0.03003248f, -0.37449479f, 
    0.09281983f, 0.11962047f, -0.06206477f, 0.03592234f, -0.01843197f, -0.01149889f, -0.21414116f, -0.27593157f, 
    0.09968000f, 0.15596147f, 0.06709210f, -0.39893109f, 0.18226473f, 0.37879893f, 0.04771636f, 0.11660141f, 
    0.10714304f, -0.14965990f, -0.16439553f, 0.25486287f, -0.12211578f, 0.11456998f, -0.13113610f, -0.06946656f, 
    0.04577901f, -0.02760963f, -0.05360368f, -0.07061500f, -0.20954683f, 0.47320703f, -0.20846361f, -0.19006725f, 
    -0.00101289f, -0.02999545f, 0.00033881f, 0.16330709f, -0.11718757f, 0.00392172f, 0.03597920f, 0.36797249f, 
    0.57332677f, -0.05079892f, -0.24724849f, 0.28571826f, -0.24128376f, 0.11175216f, 0.41533685f, 0.12043216f, 
    -0.15562922f, -0.01720595f, 0.21704401f, -0.03414948f, -0.07852732f, 0.01211030f, -0.13045377f, -0.01002682f, 
    0.03076877f, -0.12477785f, 0.19925484f, -0.03956867f, 0.28427947f, 0.08487227f, -0.06269857f, -0.15302300f, 
    -0.14219552f, -0.24086820f, 0.24809970f, -0.32547113f, 0.05625584f, -0.11650255f, -0.18101306f, 0.12418798f, 
    0.04252740f, 0.02789845f, -0.09774190f, 0.04220219f, 0.03293229f, -0.10253322f, -0.00070593f, 0.08741910f, 
    -0.08615900f, 0.12867868f, 0.18232514f, 0.27740693f, -0.13838941f, -0.31086245f, 0.21038900f, 0.03906472f, 
    0.08905493f, 0.10917136f, 0.03651276f, -0.13128103f, 0.19792542f, -0.07766528f, -0.06091477f, 0.06853453f, 
    0.11911307f, 0.12600046f, 0.02087387f, -0.13880156f, -0.12533171f, 0.41732505f, 0.02499006f, -0.09865653f, 
    0.00326052f, -0.35486561f, -0.13268775f, 0.40817940f, 0.15547676f, -0.00340605f, 0.27090040f, 0.03214329f, 
    -0.07660390f, -0.07181583f, -0.03933616f, -0.02159445f, -0.16009921f, -0.23950462f, 0.00750590f, 0.00740946f, 
    0.31718731f, -0.07156029f, 0.05429114f, -0.02944147f, -0.06651974f, 0.03428946f, -0.01709332f, -0.02201676f, 
    -0.40817523f, 0.26999176f, 0.25555000f, 0.07392446f, 0.06160153f, 0.10739502f, -0.11672850f, -0.01165066f, 
    0.20872037f, 0.30510747f, -0.14644293f, -0.03032654f, 0.05118847f, 0.20362233f, -0.14566700f, -0.05140031f, 
    -0.05270945f, 0.04633617f, -0.18827714f, -0.07455009f, -0.08586631f, 0.27868453f, -0.03804034f, 0.28730682f, 
    -0.05662546f, -0.06069399f, -0.00294394f, 0.20358559f, 0.04523263f, -0.26676038f, -0.11607449f, 0.25245050f, 
    0.00967127f, -0.01673863f, -0.08522595f, 0.14401938f, -0.03583755f, 0.11690903f, 0.02859474f, -0.09651799f, 
    0.09555773f, 0.04593801f, 0.14463539f, 0.04740618f, -0.08002128f, -0.12019701f, -0.12327521f, -0.38940808f, 
    -0.02580550f, 0.01446308f, 0.18754832f, 0.00439000f, 0.28267983f, 0.07373492f, 0.23466209f, -0.21517652f, 
    -0.18921638f, 0.18075210f, 0.11007620f, 0.01918744f, 0.28836781f, 0.07899024f, -0.17869473f, 0.28331232f, 
    -0.01154364f, -0.09429306f, 0.05591684f, -0.01089785f, -0.07762156f, 0.08469289f, -0.07175458f, -0.01487216f, 
    0.28436747f, -0.00404835f, 0.12462231f, -0.03834523f, 0.05494367f, -0.21183935f, -0.09985349f, 0.23157889f, 
    0.03131160f, 0.06656630f, -0.03446851f, -0.19064909f, -0.08680832f, -0.03922730f, -0.07721790f, 0.17357787f, 
    -0.06760794f, 0.10568084f, 0.54826128f, 0.05019990f, 0.38982791f, 0.15527603f, 0.10701302f, -0.34786579f, 
    -0.03206435f, -0.04556748f, 0.14869757f, -0.48046941f, -0.23929849f, -0.10345460f, 0.11302271f, 0.18315662f, 
    0.07017937f, 0.07535157f, 0.22822671f, -0.24682698f, -0.28882304f, 0.19079669f, -0.15307325f, -0.11535544f, 
    0.21309361f, 0.15808351f, -0.06642403f, 0.03012904f, 0.02626783f, -0.00356435f, -0.00018434f, -0.23012434f, 
    -0.18827337f, -0.10104070f, -0.03355445f, 0.25184715f, -0.03914276f, -0.06065956f, 0.45534310f, -0.23822115f, 
    -0.10367400f, 0.07214945f, -0.00451720f, -0.03642987f, 0.14052628f, 0.11974448f, -0.02426831f, -0.09368248f, 
    -0.03176096f, 0.16161872f, 0.04263987f, 0.07396528f, -0.15373601f, -0.07712836f, -0.07938606f, 0.02857846f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.11162402f, -0.03132048f, 0.09022585f, -0.03672755f, -0.01155682f, -0.04268952f, -0.01070503f, 0.29448885f, 
    0.04646222f, -0.01858690f, 0.02342282f, 0.48014504f, -0.03719953f, 0.08483727f, -0.03959733f, -0.01045346f, 
    0.04498079f, -0.05902483f, -0.02916815f, -0.09442242f, -0.02942494f, -0.00471189f, 0.27675197f, 0.11360008f, 
    0.10106121f, 0.04108551f, 0.05517097f, 0.08138301f, -0.06156618f, 0.00708633f, 0.10359577f, -0.17761202f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.41541064f, -0.08584596f, -0.60626835f, 0.07745943f, 0.02369745f, 0.15818591f, 0.04383891f, 0.13617763f, 
    -0.50370538f, 0.08689320f, -0.12978140f, 0.04783008f, -0.18318287f, 0.10948369f, 0.08966875f, -0.15881330f, 
    0.46979165f, 0.23134476f, -0.07245147f, 0.03665936f, -0.06414597f, 0.17044480f, -0.46080953f, 0.65637720f, 
    -0.49527535f, 0.09666900f, 0.80756241f, -0.10319868f, -0.01330100f, -0.06720825f, -0.19763525f, -0.13131398f, 
    -0.35662714f, 0.14801779f, -0.08870494f, 0.14474849f, -0.16695718f, 0.08998463f, -0.08131111f, -0.17919290f, 
    -0.35429898f, -0.17665748f, -0.06774161f, 0.19337121f, -0.09019678f, 0.33649296f, -0.12825820f, -0.14020105f, 
    -0.58560175f, 0.35578445f, 0.04124562f, 0.36814183f, 0.10903843f, -0.40154111f, -0.14652644f, 0.60916764f, 
    0.75461298f, 0.15358204f, -0.13137384f, 0.52820015f, 0.03884935f, -0.06987765f, -0.37591168f, -0.46308565f, 
    0.19316849f, 0.03139164f, -0.26476422f, 0.13375440f, -0.03041725f, 0.10935470f, -0.07303874f, -0.31570613f, 
    0.84007293f, 0.15526673f, -0.09543075f, -0.52449208f, 0.32906312f, 0.74482197f, 0.05592135f, -0.10733137f, 
    0.30647320f, -0.68771607f, -0.01175173f, 0.03329129f, 0.03966583f, -0.19275273f, -0.15788001f, -0.04664405f, 
    -0.05786593f, 0.09705082f, 0.01557959f, 0.11041192f, 0.01692094f, -0.03370846f, -0.23031263f, -0.21732832f, 
    0.16646299f, 0.03030395f, 0.81364393f, 0.06175743f, -0.05923990f, -0.08058516f, -0.10474482f, 0.16215871f, 
    -0.23616999f, -0.16644348f, -0.09555336f, -0.71861082f, -0.40934804f, 0.64381957f, -0.08515652f, -0.11705895f, 
    0.30810452f, 0.50176609f, -0.16195171f, -0.80524147f, -0.17354439f, -0.38007095f, -0.34567153f, -0.31776163f, 
    0.10834395f, -0.04241690f, -0.08675540f, -0.42645150f, 0.14642806f, -0.06024389f, 0.33206007f, 0.30553254f, 
    0.75666225f, 0.09087237f, -0.31739664f, 0.03546995f, 0.11255718f, -0.16356432f, -0.07604099f, 0.53294635f, 
    -0.14930810f, -0.14363670f, 0.09298965f, 0.46092048f, 0.33633018f, 0.20290223f, -0.00852656f, -0.05832006f, 
    0.08276656f, -0.16226523f, -0.13915347f, -0.50970125f, -0.10652852f, -0.34380776f, 0.10040469f, -0.39426753f, 
    -0.64832091f, -0.10257505f, 0.12825368f, -0.12280691f, 0.00341034f, 0.06320195f, -0.18625890f, 0.18027312f, 
    -0.11467543f, 0.02206104f, -0.40859154f, -0.07732534f, 0.02187488f, 0.02123452f, -0.09954716f, -0.03036468f, 
    0.20512581f, 0.13096549f, 0.12482671f, 0.38720268f, 0.04117548f, -0.74860525f, 0.12646799f, 0.07914677f, 
    -0.35002941f, -0.05027112f, -0.14263797f, 0.09647082f, 0.02167467f, -0.33692566f, 0.48971754f, -0.30033171f, 
    0.46495503f, 0.06818482f, 0.67885357f, -0.40572748f, -0.11851013f, 0.08127087f, -0.26143554f, -0.05832581f, 
    -0.36204767f, 0.16900894f, -0.62487721f, 0.07793001f, -0.11766410f, -0.04175565f, -0.15730108f, 0.39450419f, 
    0.49138638f, 0.05927541f, 0.13468957f, -0.21739233f, -0.38889572f, -0.02071916f, -0.02249438f, 0.15285453f, 
    -0.10905863f, -0.27780136f, -0.18107449f, 0.09936508f, 0.05165821f, 0.45310029f, 0.66020727f, 0.22669800f, 
    -0.52380306f, -0.10832154f, -0.34756762f, -0.76183110f, 0.09572496f, 0.05629859f, -0.07723286f, -0.18776746f, 
    0.37737036f, 0.05181284f, -0.60803747f, -0.00672106f, -0.09737662f, -0.12484132f, 0.06396855f, -0.66675109f, 
    -0.58226460f, -0.00200194f, 0.03808041f, -0.90908140f, 0.65153712f, -0.09725583f, 0.09011985f, 0.03469156f, 
    0.51493251f, 0.47563264f, 0.06901192f, 0.08788855f, 0.15935454f, -0.56344414f, -0.12985444f, -0.45398903f, 
    -0.24844150f, -0.16770832f, -0.28222489f, 0.08244903f, 0.05067987f, -0.15825321f, 0.09596962f, 0.27457175f, 
    -0.05706577f, -0.01777031f, 0.23199750f, -0.08538105f, -0.09666561f, 0.08698586f, -0.13877060f, -0.78005970f, 
    -0.07067626f, -0.06064307f, -0.03352953f, 0.44191158f, 0.19813000f, -0.64723194f, 0.08565168f, 0.13564377f, 
    -0.74710649f, -0.32519481f, 0.09181643f, 0.31466526f, 0.16241060f, 0.05166886f, -0.05916214f, -0.06241893f, 
    0.21481372f, -0.02867287f, -0.47874051f, 0.96028614f, 0.15689099f, 0.01921490f, -0.09675722f, 0.01474973f, 
    0.44327787f, -0.02677722f, 1.18669093f, 0.01899676f, -0.06623198f, -0.15655857f, 0.10148983f, 0.19845177f, 
    -0.01592053f, 0.09322646f, -0.04927164f, -0.04860390f, -0.44970822f, -0.10968475f, -0.01881169f, -0.01866246f, 
    0.39444104f, -0.23469761f, -0.03737178f, 0.56854218f, 0.03260495f, -0.33943677f, 0.30528572f, 0.35205129f, 
    -0.43576875f, 0.01942380f, -0.43779388f, -0.21266727f, 0.00841033f, 0.01335305f, -0.36322558f, 0.17918886f, 
    -0.24119322f, 0.14938775f, 0.06227931f, -0.06943808f, 0.06957021f, -0.03182779f, -0.12217527f, -0.33552849f, 
    0.15449931f, 0.10275062f, -0.03270540f, 0.23012032f, 0.28735217f, 0.18478757f, 0.03559562f, -0.15940441f, 
    -0.54000270f, -0.14443806f, -0.10475250f, -0.75955874f, -0.03909622f, 0.26311976f, -0.47855818f, -0.23931214f, 
    -0.12554710f, 0.02505863f, -0.64295071f, 0.01176604f, -0.08199588f, -0.04114684f, 0.86035562f, -0.47138250f, 
    -0.75795394f, 0.05422366f, -0.34217954f, 0.13467982f, -0.09118205f, 0.00464840f, 0.07678749f, 0.10223288f, 
    -0.15709408f, 0.12561654f, 0.10090531f, -0.68758720f, -0.10709794f, 0.05333630f, 0.07993796f, 0.00258817f, 
    -0.06911394f, -0.02816427f, 0.02153627f, 0.19380718f, 0.15197654f, 0.61533374f, -0.37808675f, -0.08750178f, 
    0.44149223f, 0.10576375f, -0.63422304f, -0.13128357f, 0.09857116f, 0.08832038f, -0.01260350f, 0.63291651f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.08221090f, 0.21239831f, -0.33530298f, -0.15376952f, 0.14478533f, 0.16637097f, 0.10272823f, -0.37521547f, 
    -0.25775450f, 0.12673470f, 0.34002167f, 0.06085616f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
