#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.44096208f, -0.74903113f, -0.58789325f, -0.29695860f, 0.08783886f, -0.26644504f, 0.15266845f, 0.03221752f, 
    0.00324487f, 0.12600915f, 0.17439948f, -0.09245405f, 0.13764928f, 0.14309737f, 0.00739509f, 0.07155908f, 
    -0.29096624f, -0.04615478f, -0.03343308f, -0.22893830f, -0.10390384f, -0.10263328f, 0.27890611f, -0.00356311f, 
    0.01082825f, -0.08745316f, 0.40198803f, -0.32472700f, -0.53171521f, -0.30961418f, 0.44269207f, -0.42666802f, 
    -0.23393039f, 0.14052363f, -0.51859325f, -0.22264346f, -0.20380892f, -0.17099829f, 0.02994187f, 0.05389346f, 
    0.11618955f, 0.16773976f, -0.07005954f, 0.09577112f, 0.12909670f, 0.18868393f, -0.18793617f, 0.25771478f, 
    -0.02213783f, -0.14723954f, -0.45882642f, -0.78725761f, 0.19215354f, 0.55571383f, 0.29972818f, -0.26472196f, 
    0.62416667f, 0.51895177f, -0.37845990f, -0.04148496f, 0.15841833f, 0.03550937f, 0.26981089f, 0.08238983f, 
    0.09629319f, -0.12383436f, 0.04186036f, -0.08460986f, 0.00879636f, -0.00942918f, -0.07484525f, -0.02907395f, 
    -0.08536061f, -0.07266624f, 0.00643261f, 0.26381558f, -0.13478148f, -0.55206627f, -0.55833542f, -0.35796684f, 
    0.27759904f, 0.69833750f, 0.13906756f, 0.02014678f, 0.16776358f, 0.36144722f, 0.17137620f, -0.25714016f, 
    -0.11544740f, -0.15701352f, 0.10294535f, 0.22423118f, 0.15046296f, -0.00033933f, 0.11724709f, 0.08964270f, 
    0.03575225f, 0.01200477f, -0.03104405f, -0.05546680f, -0.40643954f, -0.48221120f, -0.06366717f, -0.24382077f, 
    -0.57086849f, -0.23763923f, 0.52635252f, 0.46204203f, -0.01642309f, -0.29309127f, -0.17024554f, 0.32055494f, 
    -0.14337449f, 0.11746499f, 0.11294641f, -0.08484112f, -0.04625478f, -0.21805465f, -0.00649668f, 0.07159439f, 
    0.10615610f, -0.07024265f, 0.28815556f, -0.16103721f, 0.18706349f, 0.78804636f, 0.30943391f, -0.40999550f, 
    0.31746888f, 0.04244938f, 0.53133398f, 0.51979870f, 0.10284327f, 0.44134942f, 0.24139644f, -0.10635152f, 
    0.03309610f, -0.14118111f, -0.16041924f, 0.15455651f, -0.08958516f, -0.15473099f, -0.24601959f, -0.04292771f, 
    0.14238720f, -0.08023378f, -0.07330324f, -0.06735394f, -0.03750575f, 0.06069011f, 0.67366731f, -0.48623538f, 
    0.15703428f, 0.63634819f, 0.56946141f, 0.31332988f, 0.13526304f, 0.26631737f, -0.31421676f, 0.15575810f, 
    0.16151683f, 0.16127564f, 0.00298200f, 0.06031304f, 0.12924138f, 0.09781497f, 0.14010419f, 0.23842721f, 
    0.12065262f, -0.07918049f, 0.12879983f, -0.05840687f, 0.12309271f, -0.05177243f, 0.04615265f, 0.46274197f, 
    0.66917354f, 0.31983638f, 0.34498626f, 0.28846911f, 0.23317339f, -0.05390783f, -0.29312453f, -0.55196631f, 
    -0.37223187f, 0.04955941f, 0.28675535f, 0.17893457f, 0.46319258f, -0.00827408f, -0.09382237f, -0.22127900f, 
    -0.13660634f, 0.08431028f, -0.07475135f, -0.20654972f, 0.12949544f, -0.06890820f, 0.02612710f, 0.21082748f, 
    -0.12243389f, -0.60187882f, 0.49975374f, 0.18664020f, -0.72973627f, -0.32664049f, -0.25994390f, 0.17755052f, 
    -0.16031124f, -0.12871680f, -0.03192036f, -0.13990800f, -0.07023332f, -0.04678599f, 0.40102842f, -0.30629328f, 
    -0.22038418f, 0.06530651f, -0.09036718f, -0.26324600f, 0.07098230f, 0.12520285f, -0.09320222f, 0.16942109f, 
    -0.12679659f, 0.38644609f, 0.03748987f, 0.36768961f, -0.43239954f, -0.12681308f, -0.67470354f, 0.11394259f, 
    -0.24594495f, -0.41015777f, -0.42151278f, 0.03474391f, -0.03559589f, -0.07267763f, 0.13653930f, -0.30766258f, 
    -0.08406220f, -0.27961257f, -0.13132066f, -0.12925635f, 0.11642577f, -0.16356108f, -0.03481786f, 0.09533305f, 
    -0.09926124f, -0.35341045f, 0.45175502f, 0.35683793f, 0.21578901f, 0.56060469f, 0.27347425f, -0.21282068f, 
    -0.54305017f, 0.37284786f, 0.30003902f, 0.08563091f, -0.19745503f, 0.09672988f, -0.25168586f, 0.07745474f, 
    -0.30327022f, -0.07122762f, 0.11215283f, -0.16457374f, 0.10118321f, -0.08450225f, 0.18399940f, -0.11719046f, 
    -0.14135858f, -0.34451306f, 0.00018674f, -0.44416881f, -0.48143622f, -0.24438865f, 0.42554843f, -0.15583825f, 
    -0.07764813f, -0.64517671f, 0.22790109f, 0.05200519f, -0.01761965f, 0.04190721f, 0.08036277f, 0.06616977f, 
    0.03599174f, -0.03736667f, 0.08487874f, 0.36615160f, 0.05643735f, 0.01045846f, 0.21100472f, -0.19260135f, 
    -0.09772035f, 0.20906894f, -0.16531728f, -0.09015620f, 0.59930998f, 0.41026488f, 0.48497933f, 0.35296217f, 
    0.20450477f, -0.34413454f, -0.16427802f, -0.31871220f, -0.01162446f, 0.12139601f, 0.16325165f, 0.07297737f, 
    -0.13931368f, 0.09589820f, 0.26307026f, 0.17388524f, -0.05206116f, 0.09898506f, 0.39646187f, 0.38449264f, 
    0.19471666f, 0.20611607f, 0.20479238f, -0.02623189f, 0.30245289f, 0.83353335f, 0.48415470f, 0.52451319f, 
    -0.27566507f, -0.53369832f, -0.02221612f, -0.56699312f, 0.13732368f, -0.10093540f, 0.32931995f, 0.14723405f, 
    -0.17875093f, -0.20835736f, 0.02862033f, -0.26162302f, -0.10490382f, -0.05204239f, -0.06874096f, -0.15149811f, 
    -0.02830292f, -0.09382890f, 0.16753131f, 0.03109686f, 0.13718021f, -0.02934923f, -0.73043454f, 0.78612167f, 
    -0.22106811f, -0.31071898f, 0.09436500f, 0.16461506f, -0.49900848f, -0.49108225f, 0.07974874f, -0.09868085f, 
    0.19843671f, 0.11681766f, -0.29949939f, 0.14781599f, -0.33114132f, -0.16605999f, 0.05981050f, -0.12264560f, 
    -0.16591109f, 0.07456397f, 0.09043527f, 0.28004524f, 0.17697041f, 0.08248249f, 0.00321568f, -0.38182381f, 
    -0.62847447f, -0.70511472f, -0.34654638f, -0.05215537f, -0.06983226f, 0.48458084f, 0.32350746f, 0.32101133f, 
    0.46771860f, -0.33601880f, -0.28341463f, -0.12529677f, -0.29013872f, -0.26179975f, -0.19566248f, 0.04259658f, 
    0.12736252f, 0.26194698f, -0.26610705f, -0.16877139f, 0.02280694f, -0.30957037f, 0.01372382f, 0.11899292f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.14963071f, 0.00999881f, 0.17216468f, 0.12909719f, 0.05636061f, 0.25815004f, -0.01573923f, 0.01071684f, 
    0.09608239f, 0.09826058f, 0.10278343f, 0.22251000f, 0.07031553f, 0.10743756f, 0.15617217f, 0.07113536f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.21453768f, -0.50314140f, -0.08883582f, -0.29820704f, 0.24312297f, 0.11870965f, -0.06387853f, -0.00990665f, 
    -0.08376049f, -0.07841147f, -0.06208837f, 0.14764789f, -0.16078159f, -0.23653425f, -0.02174121f, 0.10895333f, 
    0.05224529f, -0.00210988f, 0.04312339f, 0.12198530f, 0.13618933f, 0.03037514f, -0.03693117f, -0.06696256f, 
    0.19700538f, 0.02774638f, 0.02259333f, -0.08362402f, 0.02211054f, 0.02147216f, -0.12645704f, -0.05909869f, 
    0.09104829f, -0.02657600f, 0.08629680f, -0.06432519f, -0.01600721f, -0.29935178f, -0.07059366f, -0.00456244f, 
    0.19958296f, -0.04833874f, -0.02545567f, 0.14928803f, 0.10563707f, 0.01819992f, -0.04524517f, 0.04906867f, 
    -0.37738159f, -0.24878387f, -0.29812086f, -0.09456212f, 0.05888558f, -0.00707350f, 0.06297789f, 0.05186492f, 
    -0.03640820f, -0.08091677f, -0.12996149f, 0.00923646f, 0.30671921f, 0.03585569f, 0.09300344f, -0.23609127f, 
    -0.05488197f, -0.14768185f, -0.05089245f, -0.07392085f, -0.06650696f, 0.14019507f, -0.15307379f, -0.01441335f, 
    0.00296589f, 0.10698787f, 0.33556718f, 0.00306618f, -0.10512806f, 0.06312511f, -0.12528570f, -0.10845146f, 
    0.15853876f, 0.04146833f, 0.03960813f, 0.08848386f, 0.02015028f, 0.07262063f, 0.23538357f, 0.29847276f, 
    -0.07002834f, 0.07239486f, 0.17385359f, -0.07401431f, -0.03147533f, 0.04188688f, 0.08022437f, 0.14208102f, 
    -0.13690984f, -0.09887943f, -0.16374026f, 0.04336711f, -0.02556688f, -0.01645803f, 0.04412483f, 0.19398062f, 
    0.03810363f, -0.06872028f, 0.02723856f, -0.08247081f, -0.06194972f, 0.12182438f, -0.04427819f, 0.19397227f, 
    -0.07708411f, -0.00096145f, 0.02695290f, 0.07466119f, 0.08790356f, -0.01264256f, 0.00837287f, 0.10552336f, 
    0.11569936f, 0.27342093f, 0.22157405f, 0.13031097f, 0.06545103f, -0.05152721f, -0.07278165f, -0.18101911f, 
    0.03335214f, 0.00471927f, -0.01041607f, -0.01528102f, -0.29686362f, -0.04942838f, -0.15511811f, 0.08119324f, 
    0.16386852f, 0.02092701f, 0.01502023f, -0.00151096f, 0.00932499f, -0.04122360f, -0.03892284f, 0.08153783f, 
    0.08787540f, 0.06967022f, 0.17406763f, 0.17868832f, -0.06766121f, -0.06397291f, 0.01703124f, 0.11790699f, 
    -0.06439906f, 0.12765035f, 0.17871848f, 0.25354683f, -0.15694505f, 0.21281371f, 0.03287138f, 0.15253237f, 
    0.02115920f, -0.04897674f, 0.11040718f, -0.06229276f, 0.12493488f, -0.17629348f, 0.01242414f, -0.06676874f, 
    -0.14313863f, -0.18498273f, 0.00597522f, 0.20550354f, 0.06343190f, 0.07248013f, 0.11029107f, -0.03795409f, 
    0.07983247f, 0.00979169f, -0.02076419f, -0.01129380f, 0.02758482f, -0.17463498f, -0.10773205f, -0.22614233f, 
    0.25569087f, 0.11844221f, -0.08576065f, -0.01074284f, 0.14874981f, -0.00174016f, -0.05546427f, -0.12477713f, 
    0.06714663f, 0.03786168f, -0.08394378f, 0.16040818f, 0.03135247f, 0.05983199f, 0.05680685f, 0.11286245f, 
    0.01803832f, -0.03372428f, -0.07981190f, -0.07948503f, -0.18189526f, 0.00591587f, 0.04279787f, 0.08630698f, 
    -0.04041855f, 0.03269482f, -0.04586835f, 0.01213382f, 0.07935821f, -0.20459071f, -0.00049866f, -0.05149622f, 
    0.28003091f, -0.02191184f, -0.13740134f, -0.04426959f, -0.10652059f, 0.02795759f, 0.02881557f, 0.03963879f, 
    0.12515061f, -0.05853108f, 0.10096170f, 0.05047306f, -0.11539969f, -0.07422191f, -0.03455934f, 0.09958100f, 
    0.22145443f, 0.08360546f, 0.00410296f, -0.00297347f, -0.01606495f, -0.06381745f, -0.00998890f, -0.00953804f, 
    -0.10929363f, -0.01450655f, 0.05699254f, 0.17991397f, 0.08991785f, 0.10187833f, -0.15995184f, 0.02684264f, 
    -0.10056273f, -0.04759509f, -0.01388877f, -0.10447089f, -0.38321355f, 0.10883783f, 0.09520060f, 0.14685325f, 
    0.01569988f, 0.05547624f, -0.05435364f, 0.05344902f, 0.06549806f, -0.04120190f, 0.08639950f, 0.10523788f, 
    0.15613571f, 0.15406694f, -0.28948748f, -0.24189672f, 0.04744640f, -0.06943100f, 0.14117718f, 0.02356460f, 
    0.01371754f, 0.02389482f, -0.00494842f, -0.04904221f, -0.13180378f, 0.13120100f, -0.19402383f, -0.20950547f, 
    0.16328415f, 0.01052002f, 0.04355636f, 0.03453733f, 0.02402780f, 0.05931054f, -0.04159087f, 0.06105240f, 
    -0.05108744f, 0.06425674f, 0.05243007f, -0.08655573f, 0.15898338f, 0.00833723f, 0.05957620f, -0.04134393f, 
    0.06694625f, -0.09409586f, -0.01045702f, 0.14949146f, 0.23108469f, 0.02544489f, -0.22421055f, -0.00858735f, 
    0.02744058f, -0.06078817f, -0.06844126f, -0.06370834f, -0.05444448f, -0.03238328f, 0.00049169f, 0.18038335f, 
    -0.13099888f, 0.19804004f, 0.17712618f, -0.07041534f, -0.06707273f, 0.02991333f, 0.06292751f, -0.04588211f, 
    0.15652834f, -0.02449660f, 0.05762269f, -0.04530995f, -0.01412153f, 0.19914353f, 0.00824703f, 0.04158454f, 
    -0.07213124f, -0.06782945f, -0.04290799f, -0.05520257f, -0.02652034f, -0.01653659f, 0.11169540f, 0.00808280f, 
    0.09507112f, 0.14718035f, 0.17876548f, -0.06013055f, -0.02492461f, -0.07780060f, 0.02118414f, 0.01142575f, 
    -0.12709172f, -0.01812774f, -0.16437255f, -0.12608728f, 0.49370441f, 0.10665061f, 0.14633252f, 0.08409948f, 
    -0.07206905f, -0.07253826f, 0.07574274f, 0.06765983f, -0.12223242f, 0.04999281f, 0.15397494f, -0.00459000f, 
    -0.12108453f, -0.25585306f, -0.09128373f, -0.06605022f, -0.06692165f, 0.11092666f, -0.10405946f, -0.09977537f, 
    -0.01884989f, 0.02010179f, 0.09262884f, 0.00879683f, -0.01187705f, -0.23602569f, 0.01489450f, 0.14476213f, 
    0.13442333f, -0.01918670f, -0.11111951f, 0.09669986f, 0.02418485f, 0.04001553f, 0.06313085f, 0.10176513f, 
    -0.06595945f, 0.06888352f, -0.13161995f, 0.16416197f, 0.01224513f, -0.09945295f, -0.06623936f, 0.10092560f, 
    0.08401093f, 0.11867879f, 0.05241199f, 0.02646686f, 0.19172482f, 0.11451404f, -0.04704117f, 0.04029006f, 
    0.07313923f, 0.04994438f, -0.00763910f, 0.09531962f, -0.04790336f, -0.02404280f, 0.11937456f, 0.06762182f, 
    -0.03523557f, -0.08521634f, 0.01799215f, -0.01149612f, 0.05304796f, 0.00411802f, 0.16994493f, 0.06827538f, 
    -0.00617241f, -0.07494868f, -0.09978107f, 0.05764031f, -0.26862526f, -0.05384949f, 0.16770227f, 0.17248826f, 
    -0.08417799f, 0.06496318f, -0.01361687f, 0.04436276f, 0.07575046f, 0.09679445f, 0.06324115f, 0.05305533f, 
    0.18263625f, -0.06594396f, 0.09242268f, -0.01422366f, 0.11216100f, -0.02077420f, -0.01058678f, 0.02929089f, 
    -0.07594498f, -0.06956299f, -0.00255279f, -0.01589043f, -0.06151078f, 0.08599794f, 0.00492336f, 0.05235147f, 
    -0.13014641f, 0.13383888f, -0.02509162f, 0.01108876f, -0.01954957f, -0.10384061f, 0.10579650f, -0.03036890f, 
    0.02505687f, 0.02485080f, 0.11816346f, -0.20582476f, -0.02727577f, 0.13133945f, 0.04967605f, 0.01616504f, 
    0.05251237f, -0.05237624f, -0.07451461f, 0.01192382f, -0.00863861f, 0.06047926f, 0.22695692f, 0.07397824f, 
    -0.01964019f, -0.05726855f, 0.11420090f, 0.12109639f, -0.04552342f, -0.10312098f, 0.03447227f, 0.03836824f, 
    0.21396019f, -0.08840065f, 0.00736341f, -0.13497272f, 0.04781269f, 0.00175942f, 0.05071739f, -0.00243103f, 
    0.00529521f, 0.00169372f, 0.04387439f, 0.10169338f, -0.06876777f, 0.02245608f, 0.23071848f, 0.04623779f, 
    -0.12128178f, 0.09759322f, -0.08465490f, 0.00688074f, -0.03318205f, -0.08259805f, -0.02186829f, 0.05353732f, 
    0.09113336f, 0.02842410f, -0.00129723f, 0.14446384f, -0.11735071f, 0.15724732f, 0.20273651f, -0.01926049f, 
    0.02380383f, 0.09503186f, -0.00280684f, 0.12006274f, -0.05645088f, -0.03983545f, -0.14431450f, 0.12360845f, 
    0.05326320f, 0.17128383f, 0.04426354f, 0.04077972f, 0.06506857f, -0.01987011f, 0.09401955f, -0.05205012f, 
    -0.32329246f, 0.07647834f, 0.15773398f, 0.02883372f, -0.05560290f, 0.02312932f, -0.05241468f, -0.04628678f, 
    0.08771997f, -0.07463185f, -0.02803412f, -0.16963361f, -0.33015522f, -0.21558627f, -0.07572532f, 0.14623462f, 
    -0.04352228f, 0.22794302f, -0.04623123f, 0.03845205f, 0.02682427f, 0.10507075f, -0.02212941f, -0.05773897f, 
    0.43258917f, 0.26302099f, 0.11252741f, -0.00741487f, 0.07741516f, -0.08367417f, 0.02042174f, -0.00862010f, 
    -0.05140877f, 0.03530848f, 0.00427287f, 0.02403423f, -0.23234414f, -0.00151457f, -0.03121604f, 0.03141282f, 
    -0.08067203f, 0.02585953f, 0.13661587f, -0.02972916f, -0.06630972f, 0.12160189f, 0.15163174f, 0.06497721f, 
    -0.22735851f, 0.06958549f, 0.02654394f, 0.02248031f, -0.06760549f, -0.04767983f, 0.07137094f, -0.01622020f, 
    0.02041293f, -0.05930752f, 0.07822379f, 0.01030955f, 0.00735782f, 0.12972590f, -0.12830000f, 0.06747718f, 
    0.05683018f, -0.03123929f, -0.04098114f, -0.07315218f, -0.06333481f, -0.03802703f, -0.04743080f, -0.03106456f, 
    -0.17651351f, -0.05795597f, 0.07978000f, -0.13396180f, 0.02167139f, -0.03051421f, -0.02640239f, 0.00008884f, 
    0.06792606f, 0.06213193f, 0.10373960f, -0.03230793f, 0.21284121f, 0.12359303f, 0.01993181f, 0.20135266f, 
    -0.02197069f, 0.09550650f, 0.07327991f, 0.01887030f, -0.00854792f, -0.01361402f, -0.05689958f, 0.14712225f, 
    -0.07860892f, -0.02662011f, 0.11321235f, 0.07368135f, 0.02036611f, -0.03599166f, -0.12319429f, -0.04839898f, 
    0.07920953f, 0.06331185f, -0.01581068f, -0.00480957f, 0.03948956f, 0.02265186f, -0.04716418f, -0.06928419f, 
    0.10126410f, 0.04837676f, 0.04136582f, 0.01764723f, -0.02068774f, -0.02406056f, -0.08864406f, -0.07544114f, 
    -0.25981688f, 0.07658985f, 0.02850466f, -0.00374780f, 0.23828521f, -0.05183936f, -0.00362005f, -0.04084519f, 
    0.05497023f, -0.00848958f, -0.08099397f, 0.04375048f, 0.12555787f, -0.17528552f, -0.13946785f, 0.20616293f, 
    0.21018299f, 0.04684857f, 0.06348832f, -0.13581598f, 0.02613739f, -0.02581608f, 0.10573637f, -0.01242262f, 
    0.18102446f, -0.14052941f, 0.14264780f, -0.35023513f, -0.06885564f, 0.03588495f, -0.08187223f, 0.07782329f, 
    0.09926945f, 0.10040534f, 0.17810600f, -0.00349506f, 0.04712733f, -0.12000450f, -0.00617019f, 0.03358361f, 
    -0.01772446f, 0.14768299f, 0.06548589f, 0.06656780f, 0.13052601f, 0.07802354f, -0.01505302f, 0.02110292f, 
    -0.14516085f, -0.10141640f, -0.25306049f, 0.02334336f, 0.13087998f, 0.05712896f, -0.01841242f, 0.03149100f, 
    0.01868307f, 0.11360252f, 0.03123294f, 0.05029186f, -0.01221039f, -0.11915120f, 0.12435576f, -0.12151843f, 
    -0.10073608f, -0.10453637f, -0.03466716f, -0.09277397f, 0.17742608f, 0.13950422f, 0.03869873f, 0.04474060f, 
    0.18596198f, -0.01819589f, -0.05775761f, 0.02791828f, 0.21260704f, 0.12144339f, 0.03246018f, -0.12233396f, 
    -0.00855660f, -0.05422719f, 0.17964378f, 0.01197572f, 0.28240353f, 0.02070795f, -0.13078330f, -0.18429020f, 
    0.10007082f, 0.14870873f, 0.00634921f, 0.01642473f, 0.19387487f, 0.04054845f, 0.06681266f, -0.02980850f, 
    0.11694876f, 0.10069625f, 0.07649410f, 0.18005492f, 0.00491955f, -0.00086432f, 0.04464016f, 0.10774971f, 
    -0.06012599f, -0.03465654f, 0.05030181f, 0.13148995f, -0.24813059f, 0.11087147f, 0.01055432f, 0.21079093f, 
    -0.13896549f, -0.06456187f, 0.03331086f, -0.00323763f, -0.09883587f, -0.04242251f, -0.04170744f, -0.21483010f, 
    -0.00579327f, -0.05197440f, 0.06509104f, 0.02589350f, -0.01446382f, 0.04945365f, -0.01802761f, 0.04787459f, 
    -0.06897615f, 0.06382917f, 0.00035428f, -0.03014215f, -0.06974718f, 0.00958927f, -0.00362550f, -0.05096321f, 
    -0.00665489f, 0.00130454f, -0.06195816f, 0.03497290f, -0.06306472f, -0.02569544f, -0.07527845f, 0.01291035f, 
    -0.06482814f, -0.01565111f, 0.06270559f, 0.04410661f, 0.06568557f, 0.00788580f, -0.01399386f, -0.07472203f, 
    -0.06722524f, -0.05695201f, -0.03203672f, -0.07489709f, -0.05165771f, 0.02949695f, 0.02453398f, -0.02227525f, 
    -0.05518198f, 0.00055290f, -0.05218636f, -0.07636419f, -0.04161964f, 0.05843016f, 0.01382485f, -0.02411332f, 
    -0.04955276f, -0.00702915f, 0.04985258f, -0.07656431f, -0.02743373f, 0.00674949f, 0.05514838f, -0.07395390f, 
    0.06190214f, -0.04665685f, 0.03090464f, 0.00117572f, -0.00278227f, -0.01653159f, -0.00902989f, 0.01738845f, 
    -0.05459530f, -0.01001792f, -0.06489182f, 0.03975305f, 0.03145786f, -0.01948183f, -0.02926340f, 0.03172560f, 
    0.03516502f, 0.05208550f, 0.04613676f, 0.05114190f, -0.04369901f, 0.05832706f, -0.00408764f, 0.05524659f, 
    0.04067808f, -0.06750175f, -0.03993337f, -0.00327027f, 0.02108861f, -0.01527969f, -0.02157014f, -0.06252012f, 
    -0.04301244f, 0.00465090f, 0.04704800f, -0.07538440f, -0.00311868f, 0.01466971f, -0.07097372f, 0.02340928f, 
    -0.01145153f, -0.07241207f, -0.01158058f, -0.06767353f, -0.07322863f, -0.04855986f, 0.01671641f, 0.02805942f, 
    0.03186456f, 0.01630963f, 0.01552841f, -0.06105205f, -0.03298156f, -0.05287157f, 0.02053992f, 0.02726809f, 
    -0.04101457f, 0.06041262f, -0.06325026f, -0.03071778f, 0.01841311f, 0.00085294f, -0.07499611f, -0.04319708f, 
    0.02577440f, 0.03385007f, 0.02932479f, -0.07430400f, 0.00165688f, 0.05346595f, -0.04744662f, -0.07682878f, 
    0.05742489f, 0.04123854f, -0.03803350f, 0.04153452f, 0.02012740f, 0.04470481f, -0.02678575f, 0.05916907f, 
    0.00362531f, 0.01028899f, 0.00564879f, -0.04154289f, -0.07491806f, 0.05833607f, -0.07319772f, 0.02045996f, 
    0.04824547f, -0.01795717f, 0.05529642f, 0.06434467f, 0.06231764f, -0.00096114f, -0.04254302f, 0.00233081f, 
    0.03846780f, -0.06576229f, -0.02281006f, 0.04822168f, -0.04097011f, 0.00172497f, -0.06325772f, -0.02587669f, 
    0.01682606f, -0.01428064f, 0.04105527f, 0.02393688f, 0.03083533f, -0.04473117f, -0.07954479f, -0.02858132f, 
    -0.06753559f, -0.05292982f, 0.06226449f, 0.00273222f, -0.02027902f, -0.03385319f, 0.02017198f, -0.02631959f, 
    -0.04674984f, -0.00237197f, -0.02450221f, -0.05325510f, 0.04117888f, -0.06549612f, 0.00415750f, 0.00322188f, 
    -0.01171215f, 0.00561342f, 0.02100245f, -0.07169899f, 0.01787402f, 0.04016563f, -0.07275417f, -0.03933968f, 
    -0.27722743f, 0.02806789f, -0.11238299f, 0.07193662f, -0.02963427f, -0.02368128f, 0.03860218f, -0.02179665f, 
    0.06884505f, -0.03645010f, 0.02094941f, -0.01080430f, 0.20708013f, 0.05596615f, 0.01788509f, 0.10712910f, 
    0.00460906f, -0.02329300f, -0.04472519f, -0.04355424f, -0.13496891f, 0.06372769f, 0.09143776f, 0.00510865f, 
    -0.30204812f, 0.05371172f, -0.08681216f, -0.22895840f, 0.17356893f, 0.02397932f, 0.03081965f, 0.06556321f, 
    -0.08043774f, 0.01829050f, 0.01818984f, -0.01524817f, 0.02429911f, 0.04989199f, 0.03542567f, 0.25247830f, 
    0.01835320f, 0.11667921f, 0.08000445f, 0.00599520f, 0.08794209f, 0.09523597f, -0.02801885f, 0.04489377f, 
    -0.17405933f, 0.12180091f, 0.01705417f, 0.13820040f, 0.06216640f, -0.09853102f, -0.08236509f, -0.02701754f, 
    -0.06132372f, 0.07950620f, -0.00934195f, -0.04133225f, -0.19278547f, 0.03041924f, -0.01977197f, -0.05537144f, 
    0.05835015f, 0.00732560f, -0.02301669f, 0.04113452f, -0.03492302f, -0.00820403f, 0.02005289f, -0.05750682f, 
    -0.20845997f, 0.15091157f, 0.12331540f, -0.08708883f, 0.15497430f, -0.04835695f, 0.06779827f, -0.07475432f, 
    0.08214103f, -0.08083959f, -0.07200864f, 0.07330705f, 0.05111687f, -0.10879038f, 0.09074867f, 0.23971276f, 
    -0.00370104f, 0.00923394f, 0.12327544f, 0.06144630f, -0.01025802f, -0.14791383f, 0.12470072f, 0.03492990f, 
    0.15459993f, -0.03043124f, 0.11425821f, -0.25854355f, -0.02284498f, 0.01954395f, -0.07010113f, 0.06826029f, 
    -0.03940396f, -0.01140028f, 0.07311556f, -0.10755613f, 0.09708752f, -0.14960383f, 0.24886261f, 0.20585468f, 
    -0.04670599f, 0.12903664f, 0.02729643f, 0.00472185f, 0.08798239f, -0.02315472f, 0.03632165f, 0.08922994f, 
    -0.04755948f, 0.03559384f, -0.06739341f, -0.01110084f, 0.07745118f, 0.08214057f, 0.04872883f, 0.07650642f, 
    0.03345284f, 0.09523729f, 0.11895841f, 0.15366562f, 0.05680509f, -0.05759527f, 0.05910609f, -0.12317543f, 
    -0.02919229f, -0.00828622f, -0.03208258f, -0.09442942f, 0.15034758f, 0.10755826f, 0.06844558f, 0.04379580f, 
    0.05184148f, 0.07605720f, 0.04875181f, -0.10452788f, 0.08498550f, 0.02167995f, -0.02751510f, 0.02428102f, 
    -0.07006312f, -0.01278357f, 0.13097164f, -0.07175299f, 0.22467166f, 0.02697627f, -0.05919445f, -0.07162675f, 
    0.10767464f, 0.17684782f, -0.09856267f, 0.08465969f, 0.15477727f, 0.04796730f, 0.12386464f, -0.10049179f, 
    0.17557763f, 0.12630628f, 0.06718535f, 0.24693608f, -0.04292209f, -0.01485455f, 0.02880373f, -0.01243606f, 
    -0.04769076f, -0.07678632f, -0.14033867f, 0.14216539f, -0.22199175f, 0.02149761f, -0.12593187f, -0.02184236f, 
    -0.11618540f, 0.00178401f, 0.02942013f, -0.09985100f, -0.07686749f, -0.02843992f, 0.01348474f, -0.10640990f, 
    0.35962391f, 0.08225718f, 0.15431274f, -0.04995761f, 0.02243275f, -0.05016403f, 0.12729086f, -0.01845139f, 
    0.07338031f, 0.02093997f, 0.03481399f, -0.08033124f, -0.05031637f, 0.12625784f, -0.16583107f, -0.05966020f, 
    -0.01278246f, 0.11093962f, 0.13846609f, 0.11200587f, 0.05711553f, -0.04338345f, 0.03542577f, 0.07218195f, 
    0.30704096f, -0.09781302f, 0.18315314f, 0.08536104f, -0.11969657f, 0.04078859f, -0.06233826f, 0.07178858f, 
    0.05693291f, 0.01240907f, -0.00175143f, 0.04598911f, 0.04315775f, 0.15641923f, 0.08795424f, 0.11927204f, 
    -0.07140845f, -0.03315676f, 0.10715988f, 0.07656929f, -0.08533223f, 0.02113088f, 0.13562870f, -0.04452914f, 
    0.31732583f, -0.04248536f, 0.18413372f, 0.02031146f, 0.06452494f, 0.08123250f, 0.01798926f, -0.04794587f, 
    -0.09881283f, -0.08554361f, 0.08421583f, 0.03242905f, 0.13582435f, -0.02243423f, -0.10511703f, 0.20315702f, 
    0.06740890f, 0.07912646f, 0.03045374f, -0.01840492f, 0.07491952f, -0.03283874f, 0.07555098f, -0.01682129f, 
    0.17477965f, -0.12731874f, 0.07550762f, 0.01725627f, 0.02294683f, -0.01662504f, -0.01074176f, 0.02620392f, 
    -0.02753230f, 0.05236005f, 0.03322755f, -0.07353478f, -0.24693391f, 0.00447759f, 0.02631902f, -0.09640539f, 
    0.15150830f, -0.20513296f, 0.01516050f, -0.06926559f, 0.18544745f, 0.10497186f, 0.04521509f, -0.07564393f, 
    -0.12255801f, -0.05757435f, 0.04189087f, -0.19546351f, 0.02206331f, 0.02738204f, 0.02727909f, 0.01289902f, 
    0.06471125f, 0.05283199f, -0.01907830f, 0.17257491f, -0.22423548f, -0.05816651f, 0.05687027f, -0.15838636f, 
    0.17264512f, -0.03715233f, 0.07981198f, 0.05867920f, 0.01719348f, -0.03685614f, 0.06023197f, 0.01070193f, 
    -0.06134438f, -0.09116863f, -0.12397133f, 0.04276500f, 0.00256009f, -0.01703419f, -0.01298812f, 0.00053255f, 
    0.06591896f, 0.07383592f, 0.02589873f, -0.04493061f, -0.06828497f, -0.10743959f, 0.13374785f, -0.12038322f, 
    -0.02545705f, 0.04955923f, 0.00404374f, 0.16590123f, -0.09320277f, -0.03146238f, -0.03683990f, -0.04077574f, 
    -0.11709344f, -0.06826501f, 0.09398881f, 0.03984897f, 0.08176632f, 0.03185566f, 0.01312178f, -0.11385667f, 
    0.17353891f, -0.01496684f, 0.02730756f, -0.03552146f, -0.52299219f, -0.07598533f, 0.07150935f, 0.12740642f, 
    0.04550868f, 0.10994952f, 0.02682609f, -0.05731151f, 0.04758149f, 0.16100501f, 0.01201399f, 0.06575400f, 
    0.18196201f, 0.24725795f, -0.07662991f, -0.33972993f, 0.09087984f, 0.06922159f, -0.01838095f, 0.07692628f, 
    -0.02396026f, 0.16632809f, 0.19527693f, 0.04183457f, 0.12777592f, -0.09518209f, 0.15534398f, 0.26674220f, 
    -0.09762446f, -0.14106493f, 0.10582446f, 0.06753504f, -0.03131000f, 0.02694112f, 0.17060748f, 0.07119142f, 
    -0.29295149f, -0.02456301f, 0.04150624f, 0.10064410f, 0.02132951f, -0.00731013f, 0.07422319f, 0.06592030f, 
    0.07337788f, 0.01110969f, 0.16035661f, -0.02202471f, 0.05775720f, 0.26575601f, -0.04596395f, 0.13172321f, 
    0.07974235f, 0.08828317f, -0.06302678f, -0.06526973f, -0.04268623f, -0.14909294f, 0.05674196f, -0.01262401f, 
    0.02556485f, -0.08524609f, -0.03895602f, -0.13852748f, 0.05556596f, 0.04804482f, 0.08962797f, 0.02498967f, 
    0.08300344f, 0.05389570f, 0.03016357f, 0.16811353f, -0.25007343f, 0.14275153f, 0.08919582f, 0.29959431f, 
    0.05201324f, 0.02458281f, 0.03392219f, -0.00541837f, 0.00881387f, -0.00277872f, -0.03235111f, -0.07738974f, 
    -0.01894239f, -0.07707474f, 0.20271768f, 0.16344380f, 0.15200113f, -0.04399705f, -0.02556684f, -0.04661092f, 
    -0.17401281f, -0.08007481f, -0.02233500f, 0.09023154f, -0.29127118f, 0.28010955f, -0.02551072f, 0.09906536f, 
    0.02673137f, -0.00551285f, 0.02105320f, -0.03931675f, 0.06164613f, -0.03772916f, 0.09476912f, -0.06733087f, 
    0.02756486f, 0.13994351f, 0.01231446f, -0.23535648f, 0.09896415f, -0.11448687f, 0.04478708f, 0.02004493f, 
    -0.07961578f, -0.01904126f, -0.11167083f, -0.05953237f, -0.13592348f, 0.08921658f, -0.02226318f, -0.06293783f, 
    0.10597315f, -0.01700138f, 0.05997108f, -0.02702895f, -0.13110876f, -0.05580287f, 0.06790172f, -0.05948012f, 
    0.20208915f, -0.03374395f, 0.05513224f, -0.40465927f, 0.09017289f, 0.05301384f, -0.05800403f, 0.07195387f, 
    0.08235279f, -0.08438606f, 0.08566381f, 0.03691972f, 0.10288407f, -0.11896406f, 0.01368731f, -0.06244130f, 
    0.00941856f, 0.10658406f, -0.05856113f, -0.04151212f, 0.04424990f, -0.02239080f, 0.08286883f, 0.00284744f, 
    0.02413414f, 0.01685446f, -0.00257757f, -0.08918309f, -0.07215829f, 0.07990407f, 0.22364476f, 0.05648005f, 
    0.01943945f, 0.12480059f, 0.12816460f, -0.00817614f, -0.06918897f, -0.06197752f, 0.11200695f, 0.05162889f, 
    -0.05290865f, 0.01040505f, -0.07633595f, -0.01955164f, 0.15178825f, 0.05152246f, 0.04530901f, -0.11192760f, 
    -0.07957605f, 0.13410933f, 0.19263764f, -0.08414718f, 0.01081827f, 0.03773693f, -0.03289378f, -0.08913624f, 
    0.07564998f, -0.05668402f, -0.02200399f, -0.26923946f, 0.12710187f, -0.11469064f, 0.07515418f, 0.01642975f, 
    0.07012952f, 0.17093743f, 0.01823259f, 0.04338152f, 0.02813593f, 0.06626498f, 0.00846081f, 0.00221781f, 
    0.07186135f, -0.14601515f, 0.07567653f, 0.15852407f, -0.03866267f, -0.09306052f, -0.10154802f, -0.06078114f, 
    -0.00437721f, -0.03637179f, -0.00997965f, 0.06232793f, -0.25357589f, -0.15163040f, 0.07192060f, 0.15437478f, 
    -0.04150166f, -0.00917893f, 0.03228053f, -0.00894739f, -0.07146633f, 0.00591088f, 0.07822860f, 0.16908792f, 
    -0.14370120f, 0.16167739f, -0.19759336f, -0.11887702f, 0.02273706f, 0.02570742f, 0.05799990f, 0.15204735f, 
    -0.02756540f, 0.05283499f, -0.05557743f, 0.06590350f, 0.33752993f, -0.06160920f, 0.09765518f, 0.05528849f, 
    -0.09513862f, -0.14197126f, -0.00081351f, -0.07676040f, -0.05349824f, 0.09947371f, 0.05996022f, 0.09287142f, 
    -0.39346892f, 0.11486848f, 0.00346598f, -0.03218864f, 0.07748503f, 0.01306111f, 0.09465867f, -0.00332348f, 
    -0.04122453f, 0.01697165f, 0.02891763f, 0.03634980f, -0.10978239f, -0.00632774f, -0.04216894f, -0.05216365f, 
    -0.01423911f, 0.14918613f, 0.00216542f, -0.05448300f, -0.05429135f, 0.02551940f, -0.03003225f, 0.02884331f, 
    -0.30763212f, 0.08926708f, -0.12897044f, -0.08282068f, 0.03547172f, 0.04749341f, 0.12554304f, 0.01461465f, 
    0.13844787f, 0.11786362f, -0.04470888f, 0.10065091f, -0.11196581f, -0.04585479f, 0.11584111f, -0.06064939f, 
    -0.08096106f, 0.01932738f, -0.06182267f, 0.11135173f, -0.05758613f, -0.08870445f, 0.03895532f, -0.05400370f, 
    0.12033823f, -0.13927355f, 0.19335872f, 0.10708690f, -0.11080735f, 0.15070932f, 0.00640373f, 0.09154347f, 
    0.13891053f, 0.06590663f, -0.03055385f, 0.08859750f, 0.21052113f, 0.03051626f, 0.21244214f, 0.05671380f, 
    -0.27719751f, 0.05190612f, 0.07233850f, 0.18943153f, -0.05306893f, -0.01124688f, 0.04919245f, 0.10626847f, 
    -0.27325761f, -0.13660620f, 0.11752975f, 0.18640129f, -0.00934773f, -0.01972132f, 0.01582106f, 0.05988783f, 
    -0.04083302f, 0.01904405f, -0.03021945f, -0.03375892f, 0.16775230f, 0.07908741f, 0.21013013f, 0.09848334f, 
    -0.05810241f, -0.07916006f, -0.04359821f, -0.00184329f, 0.03566734f, -0.09007659f, -0.04481618f, 0.05294041f, 
    0.22028950f, 0.11783923f, 0.20234546f, -0.00178038f, -0.00951711f, -0.02801065f, 0.07149967f, 0.04256563f, 
    -0.03677305f, -0.04539173f, 0.05232222f, -0.02408332f, 0.08987271f, 0.08278556f, -0.17258586f, 0.00110992f, 
    0.01877500f, -0.02882844f, 0.12399360f, 0.11849073f, -0.00205382f, 0.01404690f, -0.09632808f, -0.01469561f, 
    0.17650783f, 0.03723841f, 0.06701101f, 0.08897565f, -0.10905648f, -0.05139663f, -0.12634473f, 0.12597030f, 
    0.17529905f, -0.04891328f, 0.03052638f, 0.02569496f, 0.02816244f, 0.06044839f, 0.00106313f, 0.09876738f, 
    -0.06784432f, -0.04730648f, -0.17417537f, 0.01619421f, 0.04334461f, 0.03293857f, 0.08373239f, -0.15112726f, 
    0.10087582f, 0.00740981f, 0.09943564f, 0.23154673f, -0.05266286f, -0.07659173f, 0.11997266f, -0.01258618f, 
    0.11134360f, 0.03899531f, -0.07339271f, -0.02771508f, -0.10881149f, 0.14122891f, -0.20778869f, -0.27409631f, 
    0.06899590f, 0.17672256f, 0.06376903f, -0.07226676f, -0.06728885f, -0.04421425f, 0.09093930f, 0.04248052f, 
    -0.43849817f, 0.03564113f, 0.01189670f, -0.18718408f, 0.13412626f, 0.03588737f, 0.20028685f, 0.12466336f, 
    0.02357022f, 0.10418420f, 0.17834495f, 0.01435721f, 0.13639703f, -0.01422433f, 0.01790352f, -0.04306564f, 
    -0.02086989f, -0.07848281f, -0.11136781f, -0.10111462f, -0.03307612f, -0.01998134f, 0.07776652f, 0.11611706f, 
    -0.38126627f, 0.03636285f, -0.01615100f, 0.02350636f, 0.05818846f, -0.00181868f, 0.01424797f, 0.09465298f, 
    -0.04708420f, 0.06849383f, 0.02247982f, 0.13302848f, -0.15635529f, 0.24361680f, -0.00396100f, 0.05902675f, 
    0.04297115f, 0.16397409f, 0.02252171f, -0.10771016f, 0.04011527f, 0.01055705f, 0.14535199f, 0.00045667f, 
    -0.38460675f, 0.02390317f, -0.01035963f, -0.14847702f, 0.11167356f, 0.02291865f, 0.12901717f, -0.09304491f, 
    0.07598998f, 0.04180688f, -0.06284475f, 0.07467367f, 0.09901996f, 0.18019177f, 0.08709721f, 0.23609199f, 
    -0.09006882f, 0.08760153f, -0.13577439f, -0.05685946f, -0.01532086f, -0.05084722f, -0.01644756f, 0.02989262f, 
    0.02913509f, 0.11423549f, 0.04642620f, 0.05783495f, -0.05671517f, -0.06651156f, 0.01164632f, -0.02668842f, 
    0.14183478f, 0.04645488f, -0.02765905f, 0.01755880f, 0.00052418f, 0.08878326f, 0.13998191f, 0.05530722f, 
    -0.07398149f, -0.03136988f, 0.04111723f, 0.03782290f, 0.10363755f, -0.08154210f, 0.13183849f, 0.07045220f, 
    -0.34271640f, -0.27152291f, 0.06511248f, -0.16570553f, 0.10463800f, 0.01754043f, -0.01763903f, -0.01037588f, 
    -0.04857019f, 0.04029775f, 0.01245858f, 0.01932113f, 0.04037923f, -0.14127156f, 0.20622617f, -0.03861326f, 
    0.00247758f, -0.02925467f, 0.00961311f, -0.03623265f, 0.05933210f, -0.11475457f, -0.06537741f, 0.00968337f, 
    0.04161370f, -0.03384229f, 0.20504971f, 0.07473090f, -0.01923650f, 0.04082201f, 0.08635627f, 0.02569779f, 
    0.02670710f, -0.00544500f, 0.12773229f, 0.01141055f, -0.22209686f, -0.15375368f, 0.03872452f, -0.12221255f, 
    0.06383184f, 0.05548155f, 0.04447299f, 0.07114112f, 0.00219855f, 0.13157678f, -0.06217783f, 0.09046126f, 
    -0.06707147f, 0.01835400f, 0.28246984f, 0.18621098f, 0.03434461f, 0.04158968f, -0.00912025f, -0.02873169f, 
    0.21561787f, 0.09401268f, 0.05428385f, -0.14350300f, -0.16754848f, 0.05500321f, 0.05357811f, -0.09353186f, 
    0.00094140f, 0.08314969f, -0.17153224f, -0.09194513f, 0.13713312f, 0.08491032f, -0.00145099f, -0.05423038f, 
    0.17257443f, -0.02250558f, 0.02684980f, -0.06755526f, -0.00180360f, 0.05480019f, -0.02317999f, 0.07584720f, 
    0.16274184f, 0.03084225f, 0.07180992f, 0.08579314f, -0.35897082f, 0.07596288f, 0.05313109f, 0.08084811f, 
    0.05559815f, -0.02073388f, -0.08003970f, -0.17362475f, 0.06345445f, -0.01030692f, 0.14216001f, -0.10143624f, 
    0.25876927f, 0.10414439f, 0.08850334f, 0.13870004f, 0.11819339f, 0.07169878f, 0.04737658f, -0.04899170f, 
    0.01575454f, 0.01828190f, -0.07355811f, 0.01506283f, -0.15390632f, 0.01366932f, -0.04598311f, -0.01199787f, 
    0.06502550f, 0.08605027f, 0.07041908f, 0.06724118f, 0.00158523f, -0.16407841f, -0.09952658f, 0.05109321f, 
    0.00579660f, 0.07219499f, -0.06166864f, -0.00056771f, 0.00770468f, 0.05488080f, -0.02780765f, -0.06704500f, 
    0.02649932f, 0.08069737f, 0.10539018f, -0.06976936f, 0.09308934f, -0.00919092f, -0.08137509f, 0.05161237f, 
    0.07362200f, 0.02567315f, 0.11656818f, 0.08710027f, -0.00753408f, -0.10450446f, -0.06092332f, -0.02783108f, 
    -0.21576293f, 0.13578194f, 0.05298188f, 0.06782311f, -0.05826916f, 0.00553729f, -0.12609735f, 0.03768697f, 
    -0.05327285f, 0.00128749f, 0.01917876f, -0.12653163f, -0.14010322f, -0.06513846f, 0.11748963f, 0.19214758f, 
    0.17269590f, -0.03625616f, 0.11925287f, 0.09406101f, 0.04535377f, 0.00724870f, -0.06252268f, 0.00564667f, 
    0.09799621f, -0.10490420f, -0.12027075f, 0.01050236f, 0.07092399f, -0.07063304f, 0.01450458f, 0.02455494f, 
    -0.07221227f, 0.04858251f, -0.02113995f, -0.08257561f, -0.01321383f, 0.19507688f, -0.10842695f, -0.12391742f, 
    0.09426696f, -0.08582729f, -0.03088718f, -0.12496093f, 0.06813727f, 0.05064840f, -0.11708852f, 0.05241714f, 
    -0.23829047f, -0.01988868f, 0.09748136f, -0.09118268f, 0.01395555f, -0.01021708f, 0.08327950f, -0.08194781f, 
    0.11137036f, -0.02112735f, 0.00263252f, 0.15624852f, 0.10600595f, -0.02007056f, -0.16690391f, 0.07882617f, 
    0.10149858f, -0.01176596f, -0.08203918f, 0.01191351f, 0.03129864f, 0.03277774f, 0.09492390f, 0.04799956f, 
    0.05733155f, 0.04775206f, -0.00012376f, -0.11878796f, 0.00115570f, -0.02546048f, -0.07177990f, -0.08083689f, 
    0.15489130f, -0.22002935f, -0.01433208f, -0.02574239f, 0.04704171f, 0.28860316f, 0.03320218f, -0.03621980f, 
    -0.06154088f, -0.15725043f, 0.00899426f, -0.06332222f, 0.02438084f, 0.08876093f, 0.08637527f, 0.02714427f, 
    0.23527753f, 0.02512584f, -0.12068719f, 0.09978765f, 0.08715111f, -0.07135941f, -0.05233226f, 0.00428436f, 
    -0.15827963f, -0.04484784f, -0.07870104f, -0.10913009f, 0.57965386f, 0.06868087f, 0.06049955f, -0.12435840f, 
    -0.03026539f, -0.06166457f, -0.00564641f, 0.04164888f, -0.01134462f, 0.05431341f, 0.13646545f, 0.05338101f, 
    -0.15516816f, -0.19265650f, -0.14136492f, -0.01324645f, -0.08699331f, 0.19099990f, -0.10251389f, 0.09728771f, 
    -0.00588200f, 0.05361893f, 0.09587238f, 0.01387391f, -0.03576829f, -0.10131843f, 0.09538673f, 0.10352518f, 
    0.04863974f, -0.19934914f, -0.04549849f, 0.11881948f, 0.00493730f, 0.03065781f, 0.08138539f, -0.00570690f, 
    0.14781091f, -0.08389927f, 0.06545459f, 0.08848342f, 0.10252484f, 0.09023875f, 0.17839707f, 0.05537734f, 
    0.03963826f, -0.05276232f, 0.06181642f, 0.10897017f, -0.07302629f, -0.11540685f, 0.07726886f, -0.03318600f, 
    -0.05334925f, 0.03242423f, 0.02408783f, 0.07001735f, 0.08762645f, 0.05005378f, -0.06586699f, -0.08647843f, 
    -0.19869123f, 0.09608003f, -0.16657974f, -0.14304562f, 0.01277222f, -0.15312329f, -0.07324318f, 0.12808511f, 
    -0.01118328f, 0.09674119f, 0.07442941f, 0.02212680f, 0.08950169f, -0.03768968f, -0.18803331f, 0.17259961f, 
    0.14727180f, 0.03516736f, 0.10441712f, -0.02720450f, 0.11990819f, 0.11628917f, 0.07725203f, -0.03193701f, 
    -0.10856476f, -0.18462729f, -0.04424784f, 0.10320526f, 0.05856313f, 0.02008883f, -0.02043718f, 0.00625970f, 
    -0.02129832f, 0.10380429f, -0.08810810f, -0.02917191f, -0.37270454f, 0.03451226f, -0.03422399f, 0.02226926f, 
    0.18592182f, 0.16399097f, 0.05448031f, -0.09351801f, 0.12140283f, 0.02237632f, -0.02436342f, 0.06381606f, 
    -0.29462761f, 0.10895528f, -0.21866606f, -0.09189290f, 0.16736601f, -0.08069576f, 0.06585207f, -0.03936636f, 
    0.18197241f, 0.08406320f, 0.08808675f, 0.12367309f, -0.27308699f, -0.12821619f, 0.05902353f, 0.05541913f, 
    -0.01477075f, 0.04162158f, 0.07541236f, 0.01138835f, 0.01842024f, -0.04838331f, 0.07545352f, -0.01088147f, 
    -0.26587683f, -0.00470715f, 0.20795669f, -0.03413104f, 0.01989575f, 0.04923230f, 0.11628341f, 0.01586639f, 
    -0.00579470f, -0.10758767f, -0.02203299f, 0.10945347f, 0.07348703f, -0.21586865f, 0.12622491f, 0.13814479f, 
    0.07563378f, -0.13452868f, 0.06963754f, -0.00818549f, 0.00583122f, -0.00868229f, 0.02835405f, 0.08657663f, 
    -0.23992279f, -0.14509816f, 0.12432125f, -0.19279194f, 0.07157113f, -0.02449265f, 0.06145110f, 0.08004300f, 
    0.05945917f, -0.01659871f, -0.03114707f, 0.04829907f, 0.02556977f, 0.21585928f, 0.09763431f, -0.06068783f, 
    0.06821619f, -0.05130200f, 0.05257099f, -0.06426282f, 0.14130707f, 0.20286657f, 0.10788399f, 0.20991974f, 
    -0.14715084f, 0.06742907f, 0.25679433f, -0.07632592f, 0.09458739f, -0.09493838f, -0.01307984f, 0.00825435f, 
    -0.03631278f, 0.23537406f, 0.06370298f, 0.04230909f, 0.13565810f, -0.00633453f, 0.27883211f, 0.14231679f, 
    0.11904902f, -0.00574581f, 0.06427790f, -0.00558559f, 0.21030311f, -0.00145301f, 0.01126491f, -0.04389514f, 
    -0.01636473f, -0.13415210f, -0.07764091f, 0.01503355f, 0.08112788f, 0.06967708f, 0.03523399f, 0.11752065f, 
    0.01658965f, 0.14014590f, 0.00639863f, 0.10452584f, -0.05928671f, -0.19333400f, -0.12727527f, 0.12590162f, 
    0.00999490f, -0.12685487f, -0.08157057f, 0.02333767f, 0.17945278f, -0.00290184f, -0.03833544f, -0.12507573f, 
    0.04958345f, 0.16848327f, 0.10314172f, 0.01917550f, -0.03775105f, 0.02459791f, 0.02391395f, -0.12982884f, 
    -0.09191538f, 0.05329812f, -0.05356699f, -0.02421633f, -0.03783755f, 0.12199984f, 0.08848919f, -0.01263371f, 
    0.05285138f, 0.07152423f, 0.02593013f, 0.04343561f, -0.00875095f, 0.06430117f, 0.02245327f, 0.07585224f, 
    0.10361993f, 0.02121965f, -0.03580623f, -0.00230373f, -0.07111739f, -0.03294158f, -0.08076747f, -0.04817828f, 
    -0.09567945f, -0.00120224f, -0.00335413f, 0.04427864f, 0.26297936f, 0.16984548f, -0.03232290f, -0.15266648f, 
    -0.02713771f, -0.05381390f, -0.05765170f, 0.03015982f, 0.03501596f, 0.07842549f, 0.08684592f, 0.06899475f, 
    0.26747671f, -0.04345686f, 0.10912476f, 0.05075176f, -0.00866504f, 0.17717053f, 0.16153297f, 0.04633066f, 
    0.23456213f, -0.00564699f, 0.01203440f, 0.11758991f, 0.00780511f, 0.04947120f, -0.09713101f, -0.05246591f, 
    -0.05315828f, 0.00944413f, 0.10509739f, 0.01231754f, 0.11127725f, 0.08857685f, -0.11733740f, 0.09594882f, 
    0.01900367f, 0.11226737f, -0.16418631f, 0.21290004f, -0.06125749f, -0.07479008f, -0.01201474f, -0.01460683f, 
    -0.06000585f, 0.06932905f, 0.15627734f, -0.02142065f, -0.00381096f, -0.19381537f, -0.17071842f, -0.18277735f, 
    -0.05101799f, 0.12922077f, -0.08157241f, -0.03707754f, 0.08689758f, 0.12664114f, -0.12268353f, 0.04231865f, 
    0.09943032f, 0.15750149f, 0.07239127f, 0.38156486f, 0.04635206f, -0.06836398f, 0.00810977f, 0.01541684f, 
    -0.06409504f, 0.08964626f, 0.04724825f, 0.01468856f, 0.05761110f, -0.17024548f, -0.00528755f, -0.05848134f, 
    -0.10868955f, 0.05187136f, -0.03252179f, -0.02966884f, -0.09150543f, 0.03254727f, -0.02323801f, -0.04878054f, 
    0.01985076f, -0.15394837f, 0.00186772f, -0.05986616f, 0.03899869f, -0.08150339f, -0.10765000f, -0.02166227f, 
    0.00312343f, -0.03857628f, -0.06172521f, -0.06435585f, 0.00519190f, 0.00437376f, 0.03371976f, 0.07146945f, 
    0.07298624f, -0.04108363f, 0.09336514f, -0.05014057f, -0.03887903f, 0.08281663f, -0.10898366f, 0.03108866f, 
    -0.05937194f, -0.11534428f, -0.19777590f, -0.20677233f, -0.00723253f, -0.07797687f, -0.00383027f, 0.01277683f, 
    0.05885972f, 0.07440437f, 0.03933414f, 0.21192238f, -0.21853893f, -0.06049498f, -0.02204503f, -0.12657277f, 
    0.00287867f, -0.11924043f, -0.08508381f, -0.01908001f, -0.03060229f, 0.05279654f, -0.08547812f, 0.10791887f, 
    -0.23344968f, -0.03376959f, 0.01871405f, 0.05441025f, 0.07701081f, -0.00034287f, 0.08223884f, 0.07704467f, 
    0.04117808f, 0.13891464f, 0.09333710f, 0.02449757f, 0.32110009f, 0.23347862f, 0.12816162f, -0.10978904f, 
    0.03181500f, 0.08857352f, 0.02468775f, -0.04722837f, 0.08484091f, -0.06300225f, -0.08865655f, -0.10412571f, 
    -0.25876528f, 0.16381426f, -0.02997210f, -0.17095119f, -0.03439644f, 0.18260014f, 0.01835281f, -0.06325871f, 
    0.08987374f, 0.02499538f, 0.00002029f, 0.00082969f, 0.08939352f, -0.07408462f, -0.15906349f, 0.25809553f, 
    -0.08155119f, 0.06860718f, -0.09646103f, -0.18445837f, 0.05350162f, -0.00592476f, 0.09548410f, -0.04813397f, 
    0.25026283f, -0.14615633f, -0.02318144f, -0.02853815f, 0.00883611f, 0.07940209f, -0.00420404f, 0.12879059f, 
    0.11746584f, 0.01086655f, 0.11250401f, 0.10433441f, -0.09573945f, 0.13480163f, -0.10021965f, 0.24615969f, 
    0.23731680f, 0.08212972f, 0.07930347f, -0.10779756f, -0.07591604f, 0.03797754f, -0.08747073f, -0.05850275f, 
    0.00978430f, -0.09052831f, -0.04324595f, 0.12852819f, 0.00690710f, 0.07854612f, -0.06712840f, -0.11859868f, 
    -0.02500802f, -0.02145446f, 0.09021070f, 0.02504815f, -0.50285894f, 0.10323390f, -0.00285260f, 0.01308249f, 
    0.07175872f, 0.02121755f, -0.01814613f, -0.03897517f, 0.05356864f, -0.05452065f, 0.00955541f, 0.02206215f, 
    0.18608381f, 0.06196090f, -0.04577844f, -0.33193335f, 0.10380504f, -0.02283755f, 0.03680363f, 0.06899329f, 
    0.00189323f, 0.07295558f, 0.02160148f, -0.08050107f, 0.11423407f, 0.06406084f, -0.09187393f, 0.01743386f, 
    -0.01374878f, -0.07957119f, 0.09738703f, 0.11764458f, -0.04242358f, -0.06428162f, 0.06527290f, 0.01267356f, 
    -0.06579585f, 0.10614549f, 0.13952431f, -0.08138400f, 0.22255962f, -0.02549938f, 0.05851610f, 0.09052812f, 
    -0.05646599f, -0.01857878f, 0.04500910f, -0.02195178f, 0.29843086f, -0.01426038f, -0.01787217f, 0.05836396f, 
    -0.03218937f, 0.11909656f, -0.13218598f, -0.01430654f, -0.00987009f, 0.03348181f, 0.02014076f, 0.08296636f, 
    -0.08397694f, 0.19378696f, 0.11617625f, -0.31015787f, 0.07495337f, 0.05722512f, 0.10450410f, 0.07038535f, 
    0.02681463f, 0.06206563f, 0.07822526f, -0.08483903f, -0.07775375f, 0.17518410f, 0.14245424f, -0.13012615f, 
    -0.05364123f, -0.09102014f, -0.00742582f, 0.03733400f, 0.01226729f, 0.08834960f, 0.08545416f, -0.00193812f, 
    0.10950621f, 0.26537326f, 0.16108443f, -0.24623716f, 0.03268020f, 0.03917925f, -0.10307904f, 0.11105274f, 
    0.04348698f, -0.04727283f, -0.04108937f, -0.06876716f, 0.20148022f, 0.23195168f, 0.05250131f, 0.26666567f, 
    0.06695970f, 0.09162546f, -0.07296944f, -0.03508666f, -0.01032733f, -0.10660608f, 0.07476786f, -0.04380568f, 
    -0.18288298f, -0.25985456f, 0.10946671f, 0.21681559f, -0.03285034f, -0.05398582f, -0.01994379f, 0.06684574f, 
    -0.05966252f, -0.05333620f, 0.02686596f, 0.19223028f, -0.19423836f, -0.11216123f, -0.04255814f, -0.15244751f, 
    -0.02117981f, 0.10753714f, -0.02571432f, -0.02352504f, 0.05685367f, -0.00090326f, 0.10490958f, 0.20477238f, 
    -0.00207027f, 0.03019183f, -0.06503863f, -0.07191863f, 0.03304027f, -0.03422743f, 0.11220070f, 0.04358894f, 
    0.04462019f, 0.11251361f, 0.07490478f, 0.05400803f, 0.07358365f, -0.18255089f, 0.01021164f, -0.03776566f, 
    -0.06553628f, -0.05498500f, 0.00757133f, -0.13007168f, -0.02810692f, 0.02006589f, 0.01384797f, 0.03477382f, 
    -0.33183903f, 0.20702368f, -0.04613246f, -0.01066253f, 0.14285631f, -0.07897379f, -0.02351059f, -0.07384904f, 
    -0.11374208f, 0.09268794f, 0.14052573f, 0.02732046f, 0.12328542f, -0.02270727f, -0.08900474f, -0.06037467f, 
    0.10843067f, 0.02943047f, -0.02825417f, 0.01869669f, 0.02308751f, 0.07732462f, -0.11504427f, 0.03865470f, 
    -0.33092573f, 0.09500924f, -0.09907686f, -0.02216303f, -0.01620427f, -0.10877556f, -0.11607772f, 0.02315886f, 
    0.03340958f, 0.11154190f, -0.05186980f, -0.05274162f, -0.09854960f, -0.15090877f, 0.18720910f, -0.10019524f, 
    0.05822853f, 0.04651702f, -0.07074706f, 0.06773268f, -0.06014746f, 0.10280129f, -0.00335972f, -0.06825834f, 
    0.06160552f, -0.08242533f, 0.11350130f, 0.08976153f, 0.00318404f, 0.04585756f, 0.03724373f, -0.07493404f, 
    0.02685217f, 0.07497027f, -0.04618016f, 0.00809140f, 0.25431427f, 0.11791333f, 0.02395902f, 0.12681749f, 
    -0.12084368f, 0.01209785f, 0.06750666f, 0.01401395f, 0.00126718f, -0.03517975f, 0.04149311f, 0.05944837f, 
    -0.24385691f, -0.02994279f, 0.09830281f, 0.23805690f, -0.06680924f, 0.01276290f, 0.01558484f, 0.03063591f, 
    -0.07311308f, -0.00692583f, -0.03805573f, -0.08024466f, 0.05826950f, 0.04117100f, 0.08140690f, 0.18851614f, 
    0.03545056f, 0.01199136f, -0.06961159f, -0.01340878f, 0.01195754f, 0.01682372f, -0.01096767f, 0.07153745f, 
    0.07627089f, -0.01329992f, 0.08247414f, -0.05862715f, 0.11141107f, 0.11307372f, -0.05704912f, 0.08323518f, 
    0.00424242f, -0.05500714f, 0.00338813f, 0.05616040f, 0.19918434f, 0.14074440f, -0.04973379f, -0.07966130f, 
    0.00832873f, -0.06437015f, 0.02753914f, 0.01895270f, 0.15561633f, 0.05936358f, 0.03840730f, 0.09395155f, 
    0.27478898f, -0.00910906f, -0.11545475f, -0.00750177f, 0.04796993f, -0.03330385f, -0.04436648f, 0.09867355f, 
    -0.09297837f, -0.03170005f, 0.05930728f, 0.03346374f, 0.44541174f, 0.12810595f, -0.02539579f, -0.10794877f, 
    0.01524821f, -0.01881773f, -0.06435603f, 0.04654873f, -0.00778221f, -0.07410290f, 0.09681713f, 0.04636662f, 
    -0.10537779f, -0.11169259f, 0.06315853f, 0.27817732f, -0.02311583f, -0.06366047f, 0.03739210f, 0.02349268f, 
    0.10019132f, 0.00348632f, -0.03008485f, 0.00275965f, -0.11158046f, 0.05967930f, -0.11553293f, -0.17856020f, 
    0.05398915f, 0.00286877f, -0.02479088f, -0.00922792f, 0.06688670f, -0.05911106f, -0.02714965f, -0.07186802f, 
    -0.40603429f, 0.04242845f, -0.06864300f, 0.04825782f, -0.03146145f, 0.04381982f, -0.01896196f, 0.06301637f, 
    0.04732185f, 0.02912072f, 0.05987622f, 0.03472470f, -0.03563955f, -0.03370564f, 0.13917293f, 0.14375640f, 
    -0.04702763f, -0.03225864f, -0.16621508f, 0.01085736f, -0.09089831f, -0.12705179f, 0.10137039f, 0.01853665f, 
    0.24649996f, -0.11409276f, -0.13233119f, -0.07567677f, 0.10812351f, 0.08330435f, 0.12100713f, 0.03516908f, 
    0.07968736f, -0.07444169f, 0.07399090f, 0.07124554f, -0.26730791f, -0.10214902f, -0.00502868f, 0.07028992f, 
    0.07271310f, 0.11007484f, 0.06787710f, 0.01125668f, 0.06000646f, -0.03626967f, -0.08150164f, -0.10011162f, 
    -0.06893834f, 0.01272217f, 0.03528770f, 0.16297145f, 0.16054395f, 0.03019778f, 0.05993939f, -0.02669365f, 
    -0.03585692f, -0.00510196f, 0.10122161f, -0.04486910f, -0.28793484f, 0.26765192f, 0.05558603f, -0.08602943f, 
    0.04062742f, -0.08311206f, -0.02427211f, 0.06379818f, 0.03749826f, -0.05283920f, 0.18616256f, 0.02941464f, 
    0.16331586f, 0.12459894f, -0.03836156f, -0.20997313f, 0.07000485f, 0.05600832f, 0.16198315f, -0.03284131f, 
    -0.03986285f, 0.01058409f, -0.03928309f, -0.03915497f, 0.00918383f, 0.08873411f, -0.01934580f, -0.17129973f, 
    0.02555439f, 0.05605745f, 0.03622190f, 0.07821745f, -0.04076837f, -0.05870201f, -0.04950210f, 0.08327437f, 
    0.32488731f, 0.11152854f, -0.00781512f, -0.14438239f, 0.13037677f, 0.01026331f, -0.00177284f, 0.09807805f, 
    0.02368802f, -0.01647595f, 0.05479987f, -0.06085838f, 0.25680199f, -0.03433429f, 0.00114926f, 0.05987567f, 
    -0.11371918f, 0.08775696f, -0.02184828f, 0.01201197f, -0.04827623f, -0.00658488f, 0.04970210f, 0.11961599f, 
    -0.11463067f, 0.14853834f, 0.00262301f, -0.06851743f, -0.01231082f, 0.02187868f, 0.11288784f, -0.02579271f, 
    0.01615736f, 0.09809183f, 0.05700571f, 0.08852694f, -0.06007660f, -0.03528555f, 0.04728364f, 0.03327332f, 
    -0.04013688f, 0.17163062f, 0.01983992f, -0.05661584f, 0.07721177f, -0.01471296f, 0.04672727f, -0.11495417f, 
    -0.07476952f, 0.13587199f, 0.13435952f, -0.09524324f, 0.00738204f, 0.03249223f, 0.02081187f, 0.06479184f, 
    -0.01209056f, -0.13196740f, -0.08727454f, -0.01798111f, 0.23302312f, 0.08801287f, 0.14267164f, 0.09672958f, 
    0.07302469f, 0.04835662f, 0.03781277f, -0.01930482f, -0.03337168f, -0.06665792f, 0.05115319f, -0.14867127f, 
    -0.02095134f, -0.22174266f, 0.22525947f, 0.21315385f, -0.03838103f, -0.05409085f, -0.03691667f, 0.01637798f, 
    -0.13090286f, -0.06130005f, 0.02091575f, 0.12632371f, -0.07283645f, -0.00340936f, -0.04957182f, -0.03272952f, 
    0.05997229f, 0.11078382f, -0.02280722f, 0.05711609f, 0.00899648f, 0.02170430f, -0.03192909f, 0.20732191f, 
    -0.19996202f, 0.04557722f, -0.17131627f, 0.03196464f, 0.05289328f, 0.01311618f, 0.02419873f, 0.09741712f, 
    0.12023546f, 0.15067089f, 0.08619954f, 0.04257286f, 0.18391919f, 0.06528065f, -0.09995560f, 0.05728189f, 
    0.07747322f, 0.02869357f, 0.02714735f, 0.07865519f, 0.00397349f, -0.13960010f, 0.08640837f, 0.01955034f, 
    -0.14473332f, 0.11774629f, -0.14728259f, 0.06275871f, -0.00443818f, 0.04139111f, 0.13601479f, 0.03046902f, 
    0.06360321f, -0.09592769f, -0.05506545f, 0.07685539f, -0.16917594f, -0.08123622f, 0.10258516f, 0.06106884f, 
    -0.10921647f, 0.19556902f, 0.06921805f, -0.02636315f, -0.01019010f, 0.07596571f, -0.03369550f, -0.01247230f, 
    -0.16795692f, 0.11956355f, 0.04475880f, -0.06201166f, 0.01461571f, -0.01735204f, -0.09543048f, -0.02269688f, 
    -0.05105311f, 0.04557950f, 0.10658328f, -0.04891928f, -0.13797206f, -0.02857556f, 0.06590953f, 0.08594231f, 
    -0.04287383f, 0.11390994f, 0.01525606f, 0.03953784f, 0.03727972f, -0.01434558f, 0.09213652f, 0.07511144f, 
    0.11821848f, -0.04330018f, -0.07104412f, -0.15469815f, 0.06970830f, -0.01638535f, 0.12147354f, 0.01447149f, 
    -0.04609564f, -0.09820224f, -0.12390652f, -0.11325929f, -0.02311606f, 0.07307315f, 0.10298967f, -0.12856609f, 
    0.04147320f, -0.10438739f, -0.02817990f, 0.03716258f, -0.04444191f, 0.02051176f, 0.04458432f, 0.02229157f, 
    -0.04961098f, -0.07229104f, 0.03473321f, -0.15402919f, 0.01975054f, 0.07013385f, -0.07259063f, -0.14595687f, 
    -0.01363660f, -0.07344081f, -0.02746423f, 0.10716857f, 0.03770088f, 0.08871266f, 0.17511244f, -0.03460930f, 
    -0.02303357f, 0.08271071f, -0.04634678f, 0.00651871f, 0.01095581f, -0.02035736f, 0.08580902f, 0.05021577f, 
    0.02090457f, -0.07699121f, -0.04812355f, 0.09237193f, -0.00398298f, 0.07372336f, 0.17605755f, 0.04532745f, 
    -0.03612702f, -0.03348326f, 0.03494622f, -0.03922153f, -0.02718400f, -0.01983174f, -0.18708897f, 0.17700876f, 
    0.01368786f, -0.01007004f, -0.05137182f, 0.15974791f, 0.15716766f, -0.03667905f, 0.03888409f, -0.18102752f, 
    -0.02936354f, 0.01415534f, 0.14856993f, 0.03083406f, -0.00984223f, 0.02496537f, 0.02612376f, -0.02706363f, 
    0.12221190f, -0.08421320f, -0.02980771f, -0.27007285f, 0.10344332f, -0.18675488f, 0.08786903f, -0.03891826f, 
    0.06174729f, 0.14404297f, -0.05135243f, -0.06526226f, 0.00676525f, 0.07697845f, 0.00780701f, -0.00505071f, 
    0.28480700f, 0.04260460f, 0.07385337f, -0.02036246f, -0.03287165f, -0.06961829f, -0.11110950f, -0.04989804f, 
    0.03854299f, -0.03960554f, 0.03424689f, 0.03606617f, -0.24767125f, -0.11815853f, -0.07044406f, 0.12807465f, 
    -0.04423788f, -0.03047952f, 0.07476600f, -0.02164274f, -0.03834455f, 0.10910885f, 0.19641382f, 0.20695835f, 
    0.11490931f, 0.19193281f, -0.09177532f, -0.16279183f, -0.12068097f, -0.00740280f, -0.11741058f, 0.02823409f, 
    0.05993010f, 0.08285754f, 0.01373248f, -0.03938539f, 0.24414554f, -0.14923577f, -0.09292477f, 0.22988708f, 
    -0.04527807f, -0.00255573f, -0.14579071f, -0.11991398f, -0.04895377f, -0.00550550f, 0.06821881f, -0.01440625f, 
    0.21529153f, -0.05630889f, 0.00981787f, 0.05582446f, 0.00624207f, 0.05754864f, 0.08170936f, 0.00258468f, 
    0.12028289f, 0.00671181f, -0.10575983f, 0.03362083f, -0.11601589f, -0.02574828f, 0.02747998f, 0.00942329f, 
    -0.04128519f, 0.04749444f, -0.00711933f, 0.01636848f, -0.03962199f, -0.02124716f, -0.02322030f, -0.11570475f, 
    0.30189341f, 0.06029171f, -0.03795778f, -0.08071332f, -0.09625414f, 0.07159067f, -0.02174809f, -0.09459396f, 
    0.05470290f, -0.00822380f, 0.01655619f, 0.06004471f, -0.23988959f, -0.13769886f, -0.13718992f, -0.07986977f, 
    0.01666288f, -0.03776215f, 0.00947227f, 0.07552852f, 0.15059525f, -0.11202554f, 0.11863995f, -0.03453182f, 
    0.21387036f, -0.12883300f, 0.06669401f, -0.13830766f, -0.03460994f, -0.04702771f, 0.05900332f, 0.13384344f, 
    -0.03404436f, -0.02419047f, -0.03040370f, -0.00506066f, 0.03062346f, -0.14928412f, 0.17260222f, -0.07773341f, 
    0.06669427f, -0.14898539f, -0.04069468f, -0.04473947f, 0.12302483f, 0.07138833f, -0.04424306f, -0.03240625f, 
    0.23462838f, 0.14211261f, 0.04504745f, 0.02228739f, 0.04876823f, 0.05660223f, -0.07287973f, -0.03688253f, 
    -0.07182939f, 0.04367270f, 0.08542771f, 0.04528357f, -0.01704814f, 0.28105342f, 0.17684895f, -0.06895760f, 
    0.01233734f, 0.13767909f, -0.07389124f, 0.03226801f, -0.04594808f, -0.05308210f, 0.03438577f, -0.05014540f, 
    -0.06598937f, 0.07333750f, -0.14168784f, -0.21346265f, 0.09683038f, 0.09103129f, 0.11807655f, -0.02427371f, 
    0.05086740f, 0.06600437f, 0.11463100f, -0.00150186f, 0.12146259f, 0.00906149f, -0.10748079f, 0.00051725f, 
    -0.13030358f, 0.05986440f, 0.00348697f, 0.05076407f, 0.00263496f, 0.01503906f, -0.02368085f, -0.15311976f, 
    0.04875446f, 0.21803193f, -0.02786448f, -0.13131268f, 0.08104329f, 0.05551820f, -0.06918454f, 0.00836400f, 
    0.04809591f, -0.01535994f, -0.00680528f, -0.06174645f, -0.26211101f, -0.08009811f, -0.01207005f, 0.21982263f, 
    0.02760352f, 0.04059064f, -0.12091665f, 0.04580193f, -0.03385957f, 0.10734213f, -0.03146185f, 0.05932762f, 
    0.37300116f, 0.17992200f, 0.10085158f, 0.22089379f, 0.09970436f, -0.01798818f, -0.11060334f, -0.00795456f, 
    0.03518420f, 0.10251684f, 0.05586329f, 0.08974274f, 0.07215995f, 0.05637586f, -0.07272100f, -0.11379045f, 
    -0.12328102f, 0.02171127f, 0.06323098f, -0.00792322f, -0.05821891f, 0.07928959f, -0.01880040f, 0.09355904f, 
    0.11459187f, -0.13909778f, -0.04801884f, 0.03160518f, 0.13217677f, 0.10888915f, -0.01310803f, 0.10674553f, 
    -0.01523745f, -0.14134666f, -0.00231223f, 0.05869925f, -0.12704253f, -0.15082221f, 0.14310135f, -0.09614866f, 
    0.07246157f, -0.02410277f, 0.05758675f, -0.07203881f, 0.15680537f, 0.09021934f, 0.07612163f, 0.03831497f, 
    -0.03660522f, 0.02699908f, -0.02672696f, 0.06927051f, 0.09168993f, 0.06420441f, 0.05800072f, -0.01966193f, 
    -0.00947409f, -0.07603142f, 0.03736357f, 0.05557714f, 0.01613953f, -0.12022167f, 0.03789710f, -0.10725640f, 
    0.14793602f, -0.10462970f, 0.02692195f, -0.03080346f, 0.03002415f, -0.08987641f, -0.00596029f, -0.07505702f, 
    -0.19326864f, 0.10250014f, -0.13353330f, -0.05516631f, -0.03691867f, -0.05663305f, -0.08825116f, 0.03006140f, 
    -0.06047865f, 0.03046970f, -0.04558572f, -0.08365007f, 0.20255141f, -0.16204007f, 0.06020864f, 0.09744081f, 
    0.03777742f, 0.01519368f, 0.05515226f, 0.09278441f, 0.01579434f, 0.10099644f, 0.03770752f, 0.02152657f, 
    0.08269650f, -0.04087453f, 0.07817113f, 0.05063488f, 0.01671490f, -0.03667836f, 0.01533948f, 0.08919556f, 
    0.14805529f, 0.00151510f, 0.07234976f, 0.07301039f, 0.08767644f, 0.20733805f, -0.00527766f, -0.08844058f, 
    0.00822617f, 0.06236877f, 0.09315547f, 0.01380481f, 0.03673769f, 0.02522290f, 0.04297554f, 0.06363232f, 
    -0.20378296f, 0.00771839f, -0.09869086f, 0.02600306f, -0.00886701f, 0.07210258f, 0.01127719f, 0.05430370f, 
    0.05879709f, -0.03323165f, 0.07503958f, -0.00506730f, -0.09630730f, 0.23733632f, -0.10225666f, 0.00777085f, 
    0.02731871f, -0.05539980f, 0.14523615f, -0.09999155f, -0.02166133f, -0.03926864f, 0.02989173f, 0.07820041f, 
    0.01130854f, 0.06766652f, 0.00604945f, 0.01386867f, 0.05200431f, -0.02003056f, 0.04476666f, 0.10230798f, 
    0.03517210f, -0.08909241f, -0.07881438f, -0.04268495f, 0.06657138f, 0.12156411f, -0.02144730f, 0.01045776f, 
    0.00015345f, -0.06495151f, -0.08712094f, 0.03562434f, 0.06564401f, -0.03408419f, -0.01573552f, 0.06264159f, 
    0.08862679f, 0.02342267f, 0.18367134f, 0.21089280f, -0.03289176f, -0.00122139f, 0.05478217f, -0.00001360f, 
    -0.03113429f, 0.07840234f, -0.04538181f, -0.01040215f, 0.20864125f, 0.11483787f, 0.18876994f, 0.00877672f, 
    -0.09238414f, -0.07785879f, 0.01731990f, 0.04422824f, 0.05699357f, -0.08609289f, 0.07732713f, 0.07098433f, 
    -0.03760934f, -0.10572263f, -0.10656490f, -0.12322558f, 0.04714662f, 0.15428051f, 0.02201892f, -0.04681975f, 
    0.01908811f, 0.01577273f, 0.07644690f, -0.04054996f, 0.02623167f, -0.08296452f, -0.06144179f, 0.15451542f, 
    0.05393627f, 0.01622012f, 0.03821062f, 0.17732930f, 0.07885548f, -0.00405149f, 0.03209115f, 0.05713985f, 
    -0.05162933f, 0.12237716f, 0.15225105f, 0.04886160f, 0.02933783f, 0.10177985f, -0.05148192f, -0.05555886f, 
    0.00708623f, 0.15989451f, -0.00224185f, -0.04834244f, -0.03994159f, 0.26087978f, 0.01677529f, 0.00385331f, 
    0.06106804f, 0.10890111f, 0.09029542f, 0.01962253f, -0.05887390f, -0.11393698f, -0.01297015f, -0.04184354f, 
    0.35559097f, -0.05657033f, -0.06039834f, 0.10163258f, -0.03505260f, 0.05359754f, 0.00559008f, 0.03513870f, 
    0.08676390f, 0.01277461f, -0.02895861f, 0.08354358f, 0.06757473f, 0.16515848f, 0.13707353f, -0.08220556f, 
    -0.02951444f, 0.00814989f, 0.07532262f, 0.13070200f, -0.09511476f, -0.06801670f, 0.05541792f, -0.01197051f, 
    0.03522877f, 0.21842712f, 0.21429780f, 0.05915495f, 0.02702979f, 0.07128277f, 0.03411862f, 0.10436987f, 
    0.03258712f, -0.07095783f, 0.10722385f, -0.12370478f, -0.06855028f, 0.16191646f, 0.11036086f, 0.09060750f, 
    0.03113652f, -0.10369725f, 0.07853816f, 0.03753051f, -0.04529374f, 0.09600976f, 0.01085117f, 0.01030242f, 
    0.19085076f, 0.11862878f, -0.18880582f, 0.13254733f, 0.09210648f, -0.09924711f, 0.09018974f, -0.02992007f, 
    -0.19775455f, -0.01346082f, -0.00899893f, -0.06393767f, 0.03395543f, 0.10338163f, -0.25580707f, -0.19243053f, 
    0.15391046f, -0.10448643f, -0.04399966f, -0.13604997f, 0.11284663f, 0.11688639f, -0.20661728f, 0.01684787f, 
    0.16020715f, 0.03600227f, -0.12883112f, -0.03811431f, 0.06328987f, 0.06160026f, 0.02092833f, -0.18585137f, 
    0.13796388f, 0.01525111f, 0.01134582f, 0.06058583f, 0.04617329f, -0.06691971f, -0.27861947f, -0.04700056f, 
    -0.06871568f, 0.09053423f, -0.08204343f, -0.04291783f, 0.06956521f, 0.15887362f, 0.05598445f, -0.09204885f, 
    0.09095407f, 0.11583845f, -0.11089539f, 0.00282247f, -0.04515887f, -0.03029246f, -0.09073831f, -0.06852221f, 
    0.08514052f, 0.03227178f, 0.15194136f, -0.02289961f, 0.05202361f, 0.05981205f, 0.04011226f, 0.04510950f, 
    -0.10026143f, 0.05286987f, -0.10934376f, -0.00582439f, -0.02534233f, -0.06719118f, -0.04415257f, -0.24323413f, 
    0.28187585f, 0.07828960f, -0.14935915f, 0.02905582f, 0.09310972f, -0.01517240f, 0.01962006f, 0.02468523f, 
    -0.03753096f, -0.10063487f, -0.06760482f, -0.05847831f, 0.41659904f, 0.11534600f, 0.11850798f, -0.26002684f, 
    -0.04198358f, -0.13842557f, -0.12787017f, 0.00925304f, -0.03770943f, 0.13438681f, 0.02978441f, 0.09132054f, 
    -0.19419694f, -0.30332631f, 0.02158700f, -0.05630644f, 0.08585685f, 0.06305025f, -0.03216843f, -0.13599615f, 
    0.11556562f, -0.03847280f, 0.14362772f, -0.02855336f, 0.11730091f, 0.19214155f, 0.23135369f, 0.17215395f, 
    0.01050757f, -0.03429545f, 0.07150366f, 0.05589299f, -0.13002874f, 0.06781109f, -0.04210514f, 0.10923924f, 
    -0.19532241f, 0.02857558f, 0.31603399f, -0.16062234f, -0.20242228f, -0.02646938f, -0.02353002f, -0.13646545f, 
    0.07906027f, 0.00400740f, 0.13381249f, 0.04274197f, -0.25237724f, 0.29429328f, 0.03818649f, -0.10712320f, 
    0.04886770f, -0.09828401f, -0.13670303f, -0.01099415f, 0.08012833f, 0.10466571f, 0.03783657f, -0.07014037f, 
    0.12498732f, -0.11398733f, -0.03605748f, -0.14922804f, 0.03749732f, -0.01376881f, -0.00967393f, 0.04025929f, 
    -0.04110680f, 0.09893062f, 0.06165249f, 0.03297224f, 0.24394596f, 0.32156569f, -0.09436926f, 0.05561266f, 
    -0.08652911f, 0.02068232f, 0.06093961f, 0.09743021f, 0.16143943f, 0.03312273f, 0.00133804f, 0.11277556f, 
    0.02886857f, -0.11007702f, 0.09431785f, 0.10195186f, -0.12615377f, -0.06627031f, 0.05937415f, -0.05541113f, 
    0.05079694f, -0.06617914f, 0.05572554f, 0.05945520f, 0.20617463f, 0.17568576f, -0.15078317f, 0.07013065f, 
    0.03439360f, 0.11082100f, 0.01353482f, -0.04338961f, 0.00368588f, 0.01882738f, -0.08540134f, 0.11759535f, 
    -0.01980784f, 0.19054931f, -0.04564666f, -0.07036193f, 0.08751919f, -0.06086263f, 0.00522418f, 0.05868647f, 
    0.08068173f, -0.00921047f, 0.04014581f, -0.00306001f, 0.06728940f, -0.07961071f, -0.25086805f, -0.00501078f, 
    0.05065932f, 0.09209769f, -0.09124087f, -0.07427540f, 0.12951407f, -0.07278058f, 0.06410496f, 0.12569228f, 
    -0.20499244f, -0.07397325f, -0.05408536f, -0.07482883f, 0.03497832f, -0.09244112f, -0.07860214f, 0.08200917f, 
    -0.08007530f, 0.16030253f, 0.16310398f, -0.01275560f, -0.09443916f, -0.29059574f, -0.21063857f, -0.20790948f, 
    0.08240403f, 0.06316805f, 0.14744613f, -0.08843676f, -0.00813971f, 0.12012772f, 0.00404870f, 0.00335215f, 
    -0.00094855f, -0.06523181f, -0.06489818f, 0.14331453f, 0.23300375f, -0.03921333f, -0.09026198f, 0.01937271f, 
    -0.01192571f, 0.03239626f, 0.18703237f, 0.02106076f, -0.22086655f, -0.05311256f, 0.14296308f, -0.08895392f, 
    -0.02768585f, -0.13811302f, -0.02954474f, -0.08730301f, 0.04379999f, 0.17041220f, -0.07429699f, 0.19695117f, 
    0.00921154f, -0.09205525f, -0.12965149f, 0.02487213f, 0.01532780f, -0.00742633f, 0.02675317f, -0.00290774f, 
    -0.02160324f, -0.00007924f, 0.02519121f, 0.16470359f, 0.07110692f, 0.00640286f, -0.06804574f, -0.23142685f, 
    0.15877973f, 0.00370414f, 0.01985183f, -0.10375173f, 0.09940206f, -0.00220201f, -0.03368995f, -0.05426062f, 
    -0.34368080f, -0.01587226f, 0.04269942f, -0.10944430f, 0.12689832f, -0.03942115f, -0.00524364f, 0.16271265f, 
    0.07588018f, 0.04314301f, -0.07585508f, 0.02204469f, -0.12043614f, 0.04126010f, 0.16644777f, 0.04360216f, 
    -0.15316391f, -0.04696878f, -0.04590013f, 0.05554729f, 0.15022789f, -0.18043627f, -0.17463687f, -0.07435180f, 
    -0.05342969f, -0.00792408f, 0.05191849f, 0.02903464f, 0.01902797f, -0.04939075f, 0.05824327f, 0.02486990f, 
    0.04498933f, 0.03054959f, -0.06332535f, 0.06594747f, -0.00285388f, 0.00311933f, -0.07058723f, 0.00691042f, 
    0.05338895f, 0.00064701f, 0.03910785f, 0.03143556f, -0.00570721f, -0.07269856f, -0.07421076f, -0.06935596f, 
    -0.01808418f, -0.01075000f, -0.01420697f, -0.03257842f, -0.04414841f, 0.00957240f, 0.05505642f, 0.05928854f, 
    -0.05031477f, -0.07293559f, 0.01575604f, 0.01536297f, -0.01255846f, -0.01761310f, -0.02988170f, -0.03092564f, 
    0.02523984f, -0.03474730f, -0.04764314f, 0.01438452f, 0.04654064f, 0.05280882f, -0.00540669f, 0.02271382f, 
    -0.08658583f, 0.02736490f, 0.04616844f, -0.03823351f, -0.00886941f, -0.02829140f, 0.05979315f, -0.04150967f, 
    -0.00128169f, 0.05914667f, -0.07311780f, -0.04407330f, 0.00679537f, 0.05412110f, -0.05663565f, 0.02662075f, 
    0.04929078f, 0.00761762f, 0.03187872f, 0.04814040f, -0.04171004f, 0.05401419f, -0.03346286f, -0.03706174f, 
    0.01318259f, -0.03978655f, 0.02101397f, -0.02786149f, -0.02400940f, -0.03797579f, -0.01259549f, -0.05457034f, 
    0.01777458f, -0.04100998f, 0.01382319f, 0.02340437f, 0.05158696f, -0.00720853f, -0.05243193f, -0.04324860f, 
    -0.00494205f, -0.07665805f, -0.00301081f, 0.06417193f, 0.00724095f, -0.05210423f, -0.00474703f, -0.07176530f, 
    -0.07338098f, -0.03366027f, -0.06381182f, 0.03691069f, -0.03334335f, 0.00371735f, -0.02211611f, -0.02700922f, 
    0.05863268f, 0.02038112f, -0.03505037f, 0.05413206f, 0.02131488f, 0.06446987f, 0.06091014f, 0.01439348f, 
    0.01662994f, 0.02231532f, -0.02144291f, 0.00347547f, 0.04398588f, -0.04810334f, -0.04100211f, 0.04213894f, 
    -0.06833129f, -0.05752886f, 0.03344204f, -0.03194873f, 0.04025693f, 0.00965893f, 0.04154483f, 0.02545721f, 
    0.04527748f, 0.04014690f, -0.07598781f, 0.05488095f, 0.04878327f, 0.04248782f, -0.01295086f, -0.04341068f, 
    -0.00142430f, 0.03416748f, 0.00919417f, 0.05253526f, -0.00963386f, -0.02900741f, -0.03630283f, -0.00637055f, 
    -0.07142594f, 0.05416143f, 0.03679058f, -0.06693245f, -0.05169423f, 0.03706616f, -0.06644093f, -0.03077858f, 
    -0.07025075f, -0.07225578f, -0.04371477f, -0.05898662f, -0.02448259f, -0.04224294f, -0.02398160f, -0.07498232f, 
    -0.02045835f, 0.03587173f, 0.00017573f, 0.04349405f, -0.07463987f, -0.02893505f, -0.00041038f, 0.00415693f, 
    -0.02067237f, -0.07015478f, -0.01945736f, -0.02307040f, 0.05188778f, 0.00126664f, 0.03179431f, -0.03927744f, 
    0.04669720f, -0.02328679f, -0.01018433f, -0.01685898f, 0.03518939f, -0.01002710f, -0.02401928f, -0.00277053f, 
    -0.07345659f, -0.03253068f, -0.07960028f, 0.01743653f, -0.03045687f, -0.04426774f, -0.03725850f, -0.06220916f, 
    0.12488157f, 0.08017974f, 0.15048675f, -0.00456914f, -0.05867476f, -0.06748831f, -0.10868729f, -0.00503491f, 
    -0.02692724f, 0.05780236f, -0.09426101f, 0.04337385f, -0.16886118f, -0.00900218f, 0.19291325f, -0.16909313f, 
    -0.04579703f, -0.01269805f, 0.05826341f, 0.10913333f, 0.00622130f, 0.03776401f, -0.10270315f, 0.01505417f, 
    0.02565422f, 0.18358138f, -0.08172197f, 0.18013683f, 0.01658507f, 0.06406094f, -0.13341881f, -0.06339766f, 
    0.03134716f, -0.01887358f, 0.02790801f, 0.07785312f, 0.19429584f, 0.14891145f, 0.08950113f, -0.30844840f, 
    -0.08149593f, -0.03547078f, 0.00796536f, 0.11704838f, -0.05342260f, 0.01371093f, 0.06390524f, 0.00270976f, 
    0.08306778f, 0.05380091f, -0.05290556f, -0.15344538f, -0.13287088f, 0.04118689f, 0.14525948f, 0.07654323f, 
    0.21113902f, 0.15252978f, 0.05834707f, -0.01468937f, 0.01549984f, -0.02106199f, -0.03549415f, -0.01077912f, 
    0.04358517f, 0.11157913f, 0.14766307f, 0.08808491f, 0.08133345f, 0.08197702f, -0.02902939f, 0.04371580f, 
    0.04808332f, 0.08617067f, -0.31035855f, 0.36965263f, 0.02131838f, -0.01268020f, -0.08493690f, -0.01425871f, 
    -0.05889567f, 0.08242074f, 0.18584408f, -0.05269623f, -0.00786654f, 0.10958546f, -0.17019044f, -0.26106876f, 
    -0.04318097f, 0.12554848f, -0.09136186f, 0.04228510f, 0.08427241f, 0.10631309f, -0.11809588f, 0.06645418f, 
    -0.16688076f, 0.08602653f, -0.13751569f, 0.43092465f, -0.06269732f, 0.03194034f, 0.10495616f, -0.06871364f, 
    -0.05012812f, 0.02054185f, -0.04614780f, 0.10002829f, -0.00574358f, -0.02425248f, -0.00324500f, -0.10675619f, 
    -0.03206773f, -0.08602381f, -0.01387723f, 0.00417336f, -0.00528371f, 0.09999630f, -0.09312337f, -0.07137962f, 
    -0.03593408f, -0.05967026f, -0.01668324f, 0.01827666f, 0.10777719f, -0.01349670f, -0.17123473f, 0.06234575f, 
    0.10139199f, -0.10661031f, 0.04130071f, 0.01025210f, 0.11662783f, 0.08526749f, -0.09161673f, 0.20487119f, 
    -0.03524224f, -0.09531236f, 0.06340128f, 0.07358488f, -0.07002565f, -0.01671691f, -0.09105907f, 0.07405473f, 
    0.10435795f, -0.01312402f, -0.13416676f, -0.12122937f, 0.09530298f, -0.04084447f, -0.02155733f, 0.01504437f, 
    -0.00457847f, 0.09091214f, 0.00883603f, 0.17633601f, -0.06468257f, 0.07339974f, 0.11695231f, -0.18414181f, 
    0.01018701f, -0.16601150f, 0.07907357f, -0.07469419f, 0.00590656f, 0.02024229f, -0.11340413f, 0.10027744f, 
    -0.36148480f, -0.10289980f, -0.08942550f, -0.12794156f, 0.05926150f, 0.09320024f, 0.04554224f, 0.08886443f, 
    0.00452347f, 0.06875961f, 0.10254738f, -0.07829830f, 0.36383417f, 0.18415488f, 0.07431117f, -0.15956901f, 
    0.05824214f, -0.04007588f, -0.01993806f, 0.06619801f, 0.04065594f, 0.00592684f, 0.02120257f, -0.06787697f, 
    0.13100500f, -0.04857359f, -0.19460455f, 0.19580984f, 0.06239583f, -0.08213897f, -0.05946149f, 0.03624910f, 
    0.04507719f, 0.03405047f, 0.05786023f, -0.10902216f, -0.15541688f, -0.02608338f, 0.00846541f, -0.03160632f, 
    0.13212578f, 0.08370687f, 0.06573384f, 0.06198085f, -0.02612215f, -0.19613963f, -0.02235882f, -0.01614610f, 
    -0.00486097f, 0.15270311f, -0.14377788f, 0.08383962f, 0.07166637f, 0.08548900f, 0.07402959f, 0.03661388f, 
    0.02156216f, 0.03459949f, 0.01074392f, -0.03540597f, -0.00967903f, -0.21074700f, 0.01905792f, -0.05117389f, 
    -0.06472464f, 0.09631023f, 0.13750196f, 0.05564944f, -0.02404327f, -0.12202230f, -0.04885524f, -0.05935215f, 
    -0.09809498f, 0.09649108f, -0.00384911f, -0.06359186f, -0.01986563f, -0.07982613f, -0.16946185f, 0.02087556f, 
    -0.14908472f, -0.12305272f, 0.06833430f, -0.09409806f, -0.07725625f, -0.05635225f, -0.01162351f, -0.01803755f, 
    0.15769643f, 0.01502054f, 0.12233708f, 0.12061460f, 0.02922185f, -0.00837067f, 0.20185742f, -0.00423482f, 
    0.06793609f, -0.01070493f, -0.15213430f, 0.03547519f, 0.10990841f, 0.04179984f, 0.09804358f, -0.04920331f, 
    -0.07140578f, 0.06858509f, -0.00521438f, -0.02958983f, 0.01031566f, 0.07310145f, -0.02027137f, -0.10795887f, 
    0.04500051f, 0.03610969f, 0.09119416f, -0.03723110f, 0.08519375f, -0.02977676f, -0.07598771f, -0.05591766f, 
    0.04027416f, 0.06582181f, -0.11374222f, -0.07125369f, -0.06119727f, 0.14947529f, 0.02595370f, -0.10477056f, 
    0.12186345f, 0.04272924f, 0.00976501f, 0.11798721f, -0.03562270f, 0.14338739f, -0.04430771f, -0.06797704f, 
    -0.00496746f, 0.11912601f, -0.12371749f, -0.02229528f, 0.08737221f, 0.01132597f, 0.09027542f, 0.07690295f, 
    -0.03036222f, -0.03033352f, -0.03756896f, 0.01627281f, -0.01616253f, -0.02434877f, 0.12349597f, -0.03745843f, 
    0.02581938f, 0.02175321f, 0.06133678f, 0.10766049f, 0.13039723f, 0.05602735f, -0.03839181f, 0.09114230f, 
    -0.09209697f, -0.02869817f, -0.06418017f, 0.07055729f, 0.12463900f, -0.08256814f, 0.10225829f, -0.09199937f, 
    0.20810683f, 0.10267184f, 0.01260707f, -0.00216938f, 0.06182253f, -0.00574117f, 0.03538819f, -0.08049165f, 
    -0.04413948f, -0.16692390f, -0.02289950f, -0.08987393f, 0.46320957f, -0.09274695f, 0.18807983f, -0.10363708f, 
    0.01637702f, 0.02872671f, 0.10600348f, 0.06027154f, -0.06168009f, 0.03114440f, 0.14634648f, 0.02782771f, 
    0.16331476f, -0.07843293f, 0.04596979f, -0.06226253f, -0.03134350f, 0.08515397f, -0.09187818f, -0.08092529f, 
    -0.02483805f, 0.08266830f, 0.04502033f, -0.03120934f, -0.03322157f, -0.14659186f, -0.04644105f, 0.15260889f, 
    -0.04485421f, -0.10343630f, 0.05235994f, 0.19865070f, -0.02883844f, 0.08678038f, 0.00646617f, 0.17499177f, 
    0.16023210f, -0.02888360f, -0.07972895f, -0.20929046f, -0.03674816f, -0.05461319f, -0.02380854f, 0.05986099f, 
    -0.08521353f, 0.04371148f, -0.11579712f, 0.07241748f, -0.15766691f, -0.22568153f, 0.14745979f, -0.21386762f, 
    -0.03036738f, 0.05449326f, 0.10279602f, 0.03459082f, 0.12029804f, 0.14658801f, 0.06838492f, -0.03695924f, 
    -0.09765229f, 0.15594760f, 0.01298419f, 0.15464602f, 0.03100402f, 0.05860433f, 0.08279425f, -0.02820356f, 
    0.04235861f, 0.03104935f, 0.00293530f, 0.01977575f, 0.10800567f, -0.09624267f, -0.04984187f, -0.30125389f, 
    -0.00107468f, -0.05435908f, 0.01508730f, 0.09300664f, 0.07276654f, -0.07414179f, 0.00120223f, -0.02062911f, 
    -0.16914831f, 0.02155205f, -0.12502851f, -0.10420198f, -0.04089478f, 0.02218483f, 0.03632548f, 0.10959989f, 
    0.19530061f, 0.13781878f, 0.11746878f, 0.01584714f, 0.07322422f, -0.11600818f, 0.03135933f, -0.00780995f, 
    0.04741320f, 0.01553804f, -0.00317087f, 0.09362872f, -0.05481676f, -0.00296510f, 0.05447907f, -0.00697742f, 
    -0.01301749f, -0.09122105f, 0.13042389f, 0.34438738f, -0.08468813f, 0.10306823f, -0.10044124f, 0.08233463f, 
    0.02889764f, 0.15098222f, 0.06157495f, 0.01861648f, 0.29942158f, -0.01550267f, -0.05283272f, 0.01886875f, 
    -0.04026613f, 0.10102215f, -0.09515356f, 0.04070573f, 0.08039856f, 0.13597377f, -0.04262297f, 0.08047077f, 
    -0.23648901f, -0.01380838f, -0.03290978f, 0.23215252f, -0.00992886f, 0.04867465f, 0.09584140f, -0.00980509f, 
    0.00554898f, 0.02973679f, 0.06168767f, -0.05340058f, 0.03896907f, 0.25738448f, -0.03515024f, 0.03496023f, 
    0.03722525f, 0.02667668f, 0.09200503f, 0.06054435f, 0.02397601f, -0.00430327f, 0.01003404f, 0.04219595f, 
    0.12174175f, 0.08037089f, 0.05330698f, 0.14392240f, 0.04552092f, -0.07320406f, -0.04378504f, 0.01410097f, 
    -0.05490348f, -0.11872335f, -0.01656396f, -0.00419765f, -0.01064121f, 0.09111085f, -0.10001875f, 0.07351831f, 
    -0.01470629f, -0.07290602f, 0.06335157f, 0.00478243f, -0.06295905f, -0.02196820f, 0.06084726f, 0.06286979f, 
    0.21974011f, 0.04456212f, -0.05982118f, 0.12041337f, 0.01246706f, 0.04467472f, 0.05909433f, 0.17258763f, 
    -0.06035239f, 0.12509464f, -0.02461288f, 0.08656941f, 0.24331126f, 0.23450975f, 0.02956776f, -0.07719330f, 
    -0.01776627f, -0.02229946f, -0.06983777f, 0.07655443f, -0.06694976f, -0.07070114f, 0.05620402f, 0.03562186f, 
    -0.02801041f, -0.05310459f, 0.06885619f, 0.01537383f, 0.04480984f, 0.19060791f, 0.03435140f, 0.09328458f, 
    0.03293429f, 0.07029779f, 0.02419735f, 0.08283281f, 0.19788340f, 0.02938031f, -0.04796638f, -0.11680789f, 
    0.02288209f, 0.01105949f, 0.11042823f, -0.02419951f, 0.06745350f, 0.01359784f, -0.00898961f, 0.01191891f, 
    0.00604809f, -0.03239213f, 0.00162314f, 0.04909215f, -0.06593505f, 0.05625980f, 0.05560086f, 0.00784216f, 
    0.01835171f, -0.03036609f, 0.05870932f, -0.04755879f, -0.00297102f, -0.01742060f, -0.04589832f, 0.04801545f, 
    -0.04207694f, -0.01534719f, -0.06926783f, -0.05994987f, -0.03013032f, 0.05415259f, -0.02180480f, -0.06756774f, 
    -0.05121779f, -0.02731024f, 0.00867301f, -0.02001020f, 0.01724305f, -0.06742102f, 0.04404426f, -0.04884765f, 
    -0.00790060f, 0.04594116f, 0.01797433f, -0.06688084f, -0.07154670f, 0.01711074f, 0.02167979f, -0.05725608f, 
    0.04392535f, -0.02484781f, -0.02116963f, 0.04250932f, 0.06307960f, 0.03147810f, -0.04834806f, 0.04979551f, 
    -0.03113244f, 0.02351165f, -0.02322063f, -0.05446543f, 0.02603601f, -0.07676922f, -0.02256457f, -0.01232741f, 
    -0.07719794f, -0.04673609f, 0.04202356f, -0.08061600f, -0.01806465f, -0.01047114f, -0.04544183f, -0.06479044f, 
    -0.00033288f, -0.06620068f, -0.06436881f, 0.03797296f, 0.02409977f, -0.01262222f, -0.01636419f, -0.01009129f, 
    -0.07204892f, 0.04117414f, -0.02393029f, -0.05152529f, -0.05824000f, -0.01884571f, 0.00900058f, 0.00436394f, 
    0.03911588f, 0.02823464f, 0.07512351f, 0.01003899f, -0.03953333f, 0.05565498f, -0.01947090f, -0.05154801f, 
    -0.01281361f, 0.04664071f, -0.01983145f, -0.05777445f, 0.03044883f, 0.05941383f, -0.06182537f, -0.03068238f, 
    -0.00241333f, 0.04902056f, 0.01449762f, 0.02477592f, -0.03875310f, -0.04095514f, 0.05008152f, 0.01018712f, 
    -0.02915861f, -0.03971539f, 0.06555165f, 0.04012649f, -0.02436459f, 0.00980142f, -0.01336818f, 0.01020825f, 
    -0.04791970f, 0.00313256f, -0.07482357f, -0.07017691f, -0.04617238f, -0.06595058f, -0.02684127f, 0.02098566f, 
    0.02099209f, -0.03102556f, 0.03723218f, 0.01836012f, 0.01563215f, -0.04837629f, 0.02385305f, -0.06359460f, 
    -0.07522588f, 0.01606133f, 0.03702299f, 0.03223596f, -0.02150612f, -0.00243501f, 0.03853488f, 0.05819419f, 
    -0.06754690f, -0.02010117f, 0.04124770f, -0.07820281f, 0.03544493f, -0.04760453f, 0.01094160f, -0.03129600f, 
    -0.00210493f, -0.00913865f, 0.02516330f, -0.03356891f, -0.05241142f, 0.03619142f, -0.03200614f, 0.01578289f, 
    -0.04199408f, -0.03008692f, -0.02052049f, -0.01579172f, -0.01578558f, -0.03222428f, -0.02709073f, -0.00805055f, 
    0.03254818f, 0.03665774f, 0.03498991f, -0.01874242f, -0.03020195f, 0.02987891f, 0.04085295f, 0.06903901f, 
    -0.04718706f, 0.05440172f, 0.00781119f, -0.01667843f, -0.06367943f, -0.00848056f, -0.01727679f, -0.06519133f, 
    0.05325460f, -0.02963449f, -0.04355616f, -0.07051881f, -0.02284534f, -0.06320877f, 0.02206898f, -0.06583492f, 
    -0.05707288f, 0.01480552f, -0.04984558f, -0.05660476f, -0.03944733f, 0.03148014f, -0.06232738f, 0.04468419f, 
    0.10512844f, -0.02160196f, 0.14057820f, -0.14578409f, 0.18549486f, 0.12164605f, 0.03863817f, -0.04974992f, 
    -0.07207443f, -0.08769481f, 0.08421151f, 0.11271048f, -0.01589367f, -0.14846970f, -0.05841038f, -0.06254758f, 
    -0.06610947f, 0.01481962f, 0.10553945f, -0.07840151f, 0.00953159f, 0.10125530f, 0.05277713f, -0.03591621f, 
    -0.15226796f, -0.05090389f, 0.09837588f, 0.03730699f, -0.02170707f, 0.02142664f, -0.00627571f, -0.10462464f, 
    -0.06433251f, 0.08887894f, 0.07853364f, -0.02685877f, 0.14462733f, -0.07728893f, -0.24554038f, -0.02309187f, 
    0.05914579f, -0.00410342f, -0.08999708f, -0.02899066f, -0.01458485f, 0.04261592f, -0.07418838f, 0.08635850f, 
    -0.15898336f, -0.03526893f, -0.09318931f, -0.10673021f, -0.02066067f, 0.01888406f, 0.00338922f, 0.07163163f, 
    0.03535834f, 0.01621154f, -0.02906412f, 0.03053241f, 0.08105335f, -0.23227221f, 0.09789001f, 0.00183599f, 
    -0.01946581f, 0.00391027f, -0.12246531f, -0.03422039f, -0.00695616f, 0.01873890f, -0.14292382f, -0.00130286f, 
    0.01194420f, -0.16755454f, 0.25477278f, 0.09507184f, -0.07025012f, 0.12625492f, -0.02823902f, -0.03092085f, 
    0.13015074f, 0.07700359f, 0.03260862f, 0.12023354f, 0.00034682f, -0.10877603f, 0.21670701f, 0.22908883f, 
    -0.08642591f, 0.03712448f, 0.03343068f, -0.02847491f, -0.01843186f, 0.02278075f, 0.13862431f, 0.00275850f, 
    -0.41250131f, -0.02501263f, 0.18361069f, 0.17155425f, -0.15206298f, -0.11002300f, 0.03012471f, 0.12523249f, 
    -0.08808874f, -0.01086072f, -0.04516235f, 0.04536357f, 0.04913903f, 0.01689493f, -0.06966739f, 0.08274591f, 
    0.09577716f, 0.00486355f, 0.16134088f, 0.08491572f, 0.03804738f, -0.10874045f, -0.02605269f, -0.02521302f, 
    0.08867771f, 0.04593054f, 0.05741329f, -0.12693545f, 0.03788406f, 0.01416671f, -0.12478334f, 0.04898633f, 
    0.00531998f, -0.08797871f, -0.03363958f, -0.01825885f, -0.01359736f, 0.26274839f, -0.00033091f, -0.14203583f, 
    0.12847377f, -0.07619248f, 0.06656527f, 0.03329442f, -0.08236920f, 0.08562630f, -0.00338347f, 0.05755807f, 
    0.17351283f, -0.01402219f, -0.08797801f, 0.06857830f, -0.06126197f, -0.02961911f, 0.01403780f, 0.17133141f, 
    -0.02711445f, 0.11496200f, 0.06691401f, 0.06431976f, 0.01173379f, 0.07405607f, -0.02412397f, 0.04442772f, 
    -0.00105063f, -0.06058994f, 0.05345687f, 0.02209243f, 0.04229727f, 0.01247951f, -0.00313084f, 0.06980626f, 
    -0.04135383f, 0.01945929f, -0.14582878f, 0.02049045f, 0.12189865f, 0.11164121f, 0.06308819f, 0.13741954f, 
    0.01367587f, -0.01051266f, 0.02785247f, -0.06457421f, -0.03477267f, -0.06498080f, -0.04315491f, -0.20740700f, 
    0.10873245f, 0.09029156f, -0.05807541f, -0.07579035f, 0.18568896f, -0.14692172f, -0.00844584f, -0.02172498f, 
    0.15044506f, -0.05763219f, -0.10668772f, 0.20029208f, 0.07327466f, -0.02093116f, -0.00808647f, 0.24122904f, 
    -0.00548271f, -0.02208853f, 0.00851420f, 0.02956298f, -0.10638980f, -0.20083876f, 0.12262142f, -0.13594979f, 
    0.08146448f, 0.07307347f, 0.13711192f, 0.01055897f, 0.05505804f, -0.00060582f, 0.02624425f, 0.01310714f, 
    -0.16405509f, 0.16576402f, -0.08198940f, 0.05439780f, 0.00962342f, 0.00611805f, 0.10819478f, 0.04075633f, 
    0.00603475f, 0.01509535f, 0.00227068f, 0.06217751f, -0.11298853f, -0.22914775f, 0.13856241f, -0.02963829f, 
    0.05081323f, -0.06585564f, 0.00881692f, -0.00570678f, 0.10713843f, -0.00587584f, 0.02963803f, 0.00961184f, 
    -0.20399888f, 0.13900431f, -0.06062222f, -0.07444207f, -0.06922849f, -0.07253549f, -0.05265313f, 0.04200082f, 
    -0.08615580f, -0.00688773f, -0.08646939f, -0.11860289f, -0.02823375f, -0.11757041f, 0.16460776f, 0.01520885f, 
    0.03144760f, 0.07433611f, 0.08598483f, 0.14301074f, 0.00548197f, -0.10075238f, 0.13059664f, 0.13066883f, 
    0.02331205f, -0.09536924f, 0.09940113f, -0.01082995f, -0.05341500f, 0.09705880f, 0.01235014f, 0.04086726f, 
    0.02443695f, 0.03103886f, 0.05452067f, 0.04445538f, 0.03620954f, 0.23931035f, 0.20718476f, -0.01491685f, 
    0.00309422f, -0.09267615f, 0.07477888f, 0.05750027f, 0.06081591f, 0.03311251f, -0.06615111f, 0.04517798f, 
    -0.29230368f, -0.00247670f, -0.08907645f, -0.09228385f, -0.06425219f, 0.18207109f, 0.12023696f, -0.10897986f, 
    0.06846142f, -0.12327185f, -0.00192415f, 0.10302100f, -0.12759808f, 0.22615537f, 0.03488257f, -0.04802957f, 
    0.10676280f, -0.02455841f, 0.05667565f, -0.06354520f, 0.10142569f, -0.05002268f, 0.04805899f, 0.06006016f, 
    0.16960996f, 0.04344806f, 0.11347612f, 0.06820776f, -0.07930960f, 0.02837743f, 0.17183648f, -0.00069110f, 
    0.15106413f, -0.15839814f, -0.01250571f, 0.04141030f, 0.13215695f, 0.12481173f, -0.15717921f, 0.06589219f, 
    0.04973933f, 0.06975409f, -0.00401696f, -0.02068755f, 0.01974175f, -0.02137752f, 0.05863052f, -0.05446503f, 
    0.08930732f, -0.03259708f, 0.25413135f, 0.21959341f, -0.00849212f, 0.06704908f, 0.09029052f, -0.07083277f, 
    -0.01197647f, -0.04779488f, -0.14698020f, -0.13105179f, 0.23616435f, -0.04295992f, 0.25314555f, 0.00467578f, 
    -0.05209707f, -0.05039454f, 0.03831461f, 0.13067913f, -0.06190884f, 0.00578060f, 0.20792036f, 0.00729506f, 
    0.14650568f, -0.11682051f, -0.16214682f, -0.12365092f, -0.05524829f, 0.13661851f, 0.07504965f, -0.08833046f, 
    0.10950803f, 0.10975488f, 0.14324369f, -0.01487848f, -0.02410107f, -0.26539490f, -0.04169558f, 0.12259044f, 
    0.00592078f, -0.10207779f, 0.02518479f, 0.14649956f, 0.06120194f, 0.12966281f, 0.08736886f, 0.16049165f, 
    0.18946381f, 0.18079926f, 0.02888128f, 0.03627239f, -0.09835479f, -0.10272365f, 0.09981720f, -0.08410207f, 
    0.05404499f, 0.03673566f, 0.09261128f, 0.08378989f, 0.21721180f, -0.05101106f, -0.01458907f, -0.01185552f, 
    0.05798525f, 0.01498315f, -0.00827876f, -0.01534586f, -0.10218838f, 0.04363301f, 0.00412440f, -0.02597069f, 
    -0.15817082f, 0.01477978f, 0.08847959f, 0.19827922f, 0.07812918f, -0.13652138f, 0.04908921f, 0.02024521f, 
    0.02243947f, 0.00427238f, -0.08604677f, 0.02764490f, 0.14061107f, -0.05350696f, -0.02320413f, 0.11537888f, 
    -0.12369552f, 0.01619128f, -0.05731526f, -0.07416382f, -0.10885791f, 0.07301030f, -0.01954910f, 0.07521141f, 
    0.18488225f, -0.00047836f, -0.00958399f, 0.02618255f, -0.09417388f, -0.15238249f, 0.06753414f, -0.03773885f, 
    0.08008648f, -0.08974049f, 0.10591659f, -0.02351148f, 0.02427057f, -0.28399727f, -0.21907520f, -0.10563174f, 
    0.05471906f, 0.07730565f, 0.04955580f, 0.00759927f, 0.00175682f, -0.08774641f, 0.04549813f, -0.08416511f, 
    -0.35492504f, -0.37342477f, 0.02605509f, 0.06750903f, 0.08531689f, 0.06837803f, -0.10972492f, -0.09027260f, 
    -0.07837863f, -0.07186206f, -0.00149323f, 0.05782262f, 0.12876002f, -0.33718583f, 0.01838502f, -0.03426857f, 
    0.11894721f, -0.01587864f, 0.02806007f, -0.03815956f, 0.09438974f, 0.04027988f, 0.12201264f, -0.07176425f, 
    0.12240914f, 0.06097807f, 0.18999486f, -0.03111163f, -0.05873891f, 0.03674486f, -0.08028878f, 0.12485646f, 
    0.02100459f, -0.05661993f, 0.15369958f, -0.03585137f, -0.08318123f, 0.26689053f, 0.25526714f, -0.03348377f, 
    0.09980828f, 0.14266101f, 0.05840954f, 0.22381483f, 0.08624732f, 0.05813168f, 0.02501614f, -0.03446668f, 
    0.01671132f, -0.18191779f, -0.43352643f, -0.06132667f, 0.04045867f, 0.02500111f, 0.06592526f, -0.03585363f, 
    -0.06587808f, 0.04433993f, -0.08912770f, 0.03407683f, 0.11447130f, -0.06544401f, -0.05854372f, 0.05643244f, 
    -0.06313238f, 0.06250847f, 0.11117504f, 0.00652635f, 0.12271939f, 0.04284034f, 0.01458602f, -0.01739893f, 
    -0.02887637f, -0.02681856f, -0.24266775f, -0.11052533f, 0.14059791f, 0.06328986f, 0.01114274f, 0.03059832f, 
    0.08576602f, 0.03276940f, 0.00614799f, 0.00172934f, -0.04883534f, -0.06634237f, -0.16346431f, -0.06986844f, 
    0.13479267f, 0.21510276f, -0.01648412f, 0.03090661f, 0.03850840f, 0.15757275f, 0.02198648f, 0.15033244f, 
    0.44251347f, 0.38731390f, 0.08064449f, 0.06474119f, 0.07605742f, 0.00904378f, 0.07035388f, 0.09478237f, 
    -0.00483679f, 0.03771731f, 0.00536453f, 0.05167928f, -0.03695605f, 0.10814279f, -0.05621755f, 0.07088694f, 
    -0.15876356f, -0.05352551f, 0.07739002f, -0.07322791f, -0.02689821f, -0.00476416f, -0.06628036f, -0.09358583f, 
    -0.07843480f, 0.18406041f, -0.07846481f, 0.01080073f, 0.00875042f, -0.06235368f, -0.06474467f, 0.07913817f, 
    0.04388390f, 0.18892741f, 0.03701329f, -0.02103284f, 0.17725189f, 0.20880032f, 0.00249074f, -0.02844927f, 
    -0.15101255f, -0.03158456f, 0.03564428f, 0.03456485f, -0.08971628f, -0.03384202f, 0.13444011f, 0.12472872f, 
    -0.05955363f, -0.04097755f, 0.02066800f, 0.07827034f, -0.07603133f, -0.02284834f, 0.16150261f, -0.09410559f, 
    0.01342490f, -0.04426277f, -0.00577294f, 0.01985207f, -0.15089405f, 0.01895691f, 0.05178157f, -0.09593450f, 
    0.01104397f, 0.10817451f, -0.07663559f, 0.10324050f, -0.10189147f, -0.00621474f, -0.03251011f, 0.07494644f, 
    0.00680354f, 0.04595449f, 0.05469089f, 0.07899041f, -0.06065730f, 0.05368702f, 0.04929192f, 0.14724697f, 
    0.11030046f, -0.01047155f, 0.08781836f, 0.05532909f, 0.00092430f, 0.08994631f, 0.10679173f, 0.12479693f, 
    -0.15035932f, -0.02471654f, -0.17174917f, -0.03750527f, -0.09664410f, 0.01631494f, 0.10353926f, 0.06594475f, 
    0.32848325f, 0.06739289f, 0.09471676f, 0.12894009f, -0.09070886f, 0.16163376f, 0.02128708f, 0.01924713f, 
    -0.00636288f, 0.04694992f, -0.03886390f, -0.07037160f, 0.14744024f, 0.16765821f, 0.14547993f, 0.07109171f, 
    -0.15436977f, 0.01450873f, 0.02375348f, 0.13571483f, 0.03170652f, 0.05579478f, -0.08757048f, -0.00379648f, 
    0.18440650f, -0.02234632f, -0.06764631f, 0.14127897f, 0.09999928f, -0.04598831f, 0.03913186f, -0.08937682f, 
    -0.04887876f, -0.02503954f, -0.08291611f, 0.14611764f, 0.11575507f, -0.09700982f, -0.00362486f, 0.02039668f, 
    -0.04940246f, 0.02506760f, -0.15374741f, 0.10482619f, 0.04364821f, -0.05696773f, 0.12708336f, 0.02178505f, 
    0.35972035f, 0.15366682f, 0.11808573f, 0.17446050f, -0.17150286f, 0.08051547f, -0.01693212f, -0.06101064f, 
    0.03826212f, -0.00703139f, 0.07296402f, 0.05006158f, 0.11884400f, -0.08007640f, -0.13219704f, 0.18871689f, 
    -0.04513443f, 0.01505615f, -0.03222631f, 0.10057858f, -0.12072796f, -0.05777422f, 0.01497677f, -0.10150627f, 
    0.15043777f, -0.01426951f, -0.13538028f, 0.00650110f, -0.05819191f, -0.01605170f, -0.03840639f, 0.03054089f, 
    0.06459264f, -0.17168783f, -0.05874114f, -0.08944099f, 0.22321123f, -0.04485732f, -0.22899768f, 0.09976676f, 
    -0.12950049f, 0.06692959f, -0.20054556f, 0.07698961f, -0.10740370f, 0.01358259f, -0.01236521f, -0.03302189f, 
    0.06752508f, -0.04982992f, 0.09211216f, 0.02313747f, -0.07075278f, -0.06634065f, 0.04668745f, -0.00946693f, 
    0.03170720f, -0.02142970f, -0.02002024f, -0.06759226f, 0.01451452f, 0.14883220f, -0.07687654f, -0.31794000f, 
    0.10189458f, 0.20015442f, 0.04694708f, -0.14245887f, 0.02373512f, 0.12209339f, 0.06075644f, 0.08164110f, 
    -0.04611799f, -0.06461677f, 0.03228143f, -0.01006606f, -0.00132444f, -0.01994778f, 0.04477850f, -0.07110434f, 
    -0.07489473f, 0.00329063f, 0.05754453f, 0.05167163f, -0.03476340f, -0.07994478f, 0.06238785f, -0.03202309f, 
    -0.00302551f, 0.01591497f, 0.03130430f, 0.02457990f, -0.02676922f, -0.07171080f, 0.00382396f, -0.05448041f, 
    -0.01687798f, -0.02286480f, 0.05241551f, -0.01613031f, -0.05550063f, 0.04886760f, 0.06183733f, 0.01256887f, 
    -0.02882414f, 0.03830441f, 0.04693017f, -0.04584311f, -0.00179405f, -0.03391082f, -0.05968086f, 0.00055523f, 
    0.00463500f, -0.06859660f, 0.05703862f, -0.00218260f, -0.08040196f, -0.05725804f, 0.02892230f, 0.00891490f, 
    0.00344121f, -0.01367782f, 0.01362996f, -0.07442017f, 0.05785953f, 0.00410689f, 0.04704823f, -0.00971315f, 
    -0.03952128f, 0.03095397f, -0.00318424f, -0.06887708f, -0.04843092f, -0.03989416f, -0.04055291f, -0.03392158f, 
    0.05028851f, 0.05758133f, 0.06194063f, -0.06948503f, -0.06424102f, -0.07177808f, -0.04571467f, 0.04552145f, 
    -0.03856574f, 0.00752644f, -0.00416923f, -0.06072306f, -0.08180157f, 0.02495788f, -0.05377123f, -0.05307678f, 
    0.02419509f, -0.05715259f, 0.01921000f, 0.00285479f, 0.05233302f, 0.05346372f, -0.07047366f, -0.05298562f, 
    -0.02748808f, 0.04977469f, 0.03131242f, 0.00355148f, 0.03939056f, 0.04450075f, -0.05610727f, -0.07652865f, 
    0.00987980f, -0.00234357f, 0.01637818f, 0.02394841f, 0.01554282f, -0.05483090f, -0.05721486f, 0.00010552f, 
    -0.03815641f, 0.04212235f, -0.06403152f, 0.01723034f, -0.07914174f, 0.01945178f, -0.07803112f, 0.06181205f, 
    -0.05276828f, -0.04914589f, 0.04349222f, 0.03041046f, 0.00570889f, 0.00671619f, 0.03005316f, 0.05539335f, 
    -0.03336406f, -0.02763216f, -0.05758904f, 0.02777755f, 0.06295300f, -0.06369807f, -0.07544815f, 0.00891786f, 
    0.04804397f, 0.05179460f, -0.08123890f, 0.02740009f, -0.03007355f, 0.00009403f, -0.03501414f, 0.05265066f, 
    -0.04106971f, -0.00193742f, -0.07076136f, -0.01769445f, -0.04471966f, -0.04203294f, 0.02062204f, 0.05880241f, 
    -0.01738355f, 0.00412321f, -0.04632327f, 0.05240479f, 0.01508758f, -0.04009058f, 0.01419573f, -0.05728948f, 
    -0.04837097f, -0.05159939f, 0.03936705f, -0.05814705f, -0.00510329f, 0.05341901f, -0.00414812f, 0.00565609f, 
    0.02036685f, 0.01785724f, -0.06316500f, -0.06936909f, 0.01199550f, -0.06709874f, -0.01108063f, -0.04647971f, 
    -0.04632837f, -0.07530074f, -0.03290898f, 0.00427598f, -0.04545109f, -0.06261458f, 0.01709834f, 0.01845524f, 
    -0.04195027f, -0.04928472f, -0.07783448f, -0.06841458f, 0.01927727f, -0.00475581f, 0.01156158f, -0.00468418f, 
    0.01868558f, 0.02337062f, 0.04868953f, 0.01625133f, -0.03792415f, -0.00103478f, 0.02332012f, 0.02509676f, 
    0.25773722f, -0.16937791f, -0.01660134f, 0.01716666f, -0.06184771f, -0.06565415f, -0.02657720f, 0.00422209f, 
    0.02874875f, 0.03537417f, 0.05346689f, -0.00076679f, -0.28610241f, -0.25995561f, -0.02254398f, -0.04217536f, 
    -0.03059750f, 0.06243233f, 0.04660643f, 0.05961621f, 0.06841954f, 0.08156850f, -0.06075327f, 0.02406232f, 
    0.32707387f, 0.07250885f, -0.04320191f, 0.05340825f, 0.11364403f, -0.04112668f, 0.00477090f, 0.05700639f, 
    0.12908575f, 0.09793475f, -0.02135308f, -0.01626883f, -0.00714303f, -0.10166679f, 0.02437831f, -0.04903181f, 
    -0.00647993f, -0.02868211f, 0.08768255f, 0.11071844f, 0.07372883f, -0.06719787f, 0.01843186f, -0.03286204f, 
    0.18852049f, -0.06960428f, -0.00728271f, -0.16660748f, -0.05697023f, -0.04431804f, -0.03218516f, -0.00500774f, 
    -0.06886987f, 0.04243930f, 0.04922502f, -0.03311858f, -0.13803472f, -0.04651413f, -0.05091692f, -0.05498334f, 
    0.14625855f, 0.07469412f, 0.15704007f, -0.00070582f, 0.12183106f, 0.02917171f, 0.12858149f, 0.11118563f, 
    -0.01168303f, -0.03768719f, -0.10883860f, -0.13872299f, 0.16436502f, -0.04550394f, 0.04259118f, 0.11026873f, 
    0.00957306f, 0.05328352f, 0.10057698f, -0.04171367f, -0.04469125f, 0.03757964f, -0.12690619f, -0.21091586f, 
    0.19592576f, -0.03025762f, -0.00320155f, 0.01253502f, 0.15121807f, 0.13610001f, 0.00153953f, 0.02258182f, 
    0.02952468f, 0.08636302f, -0.06052192f, -0.04864937f, -0.03487129f, 0.10250968f, 0.06587491f, -0.06693421f, 
    0.10855433f, -0.02087656f, 0.06526372f, 0.14837012f, -0.01990008f, 0.18681221f, -0.00377475f, -0.19899991f, 
    0.20884094f, 0.10662825f, 0.03915705f, -0.03429914f, 0.08326799f, 0.02299684f, -0.04579610f, 0.11026233f, 
    -0.21034212f, -0.02068205f, -0.05563489f, -0.03558029f, 0.13339163f, 0.05042651f, 0.12875284f, 0.08069158f, 
    0.18583801f, 0.12151539f, -0.07089311f, 0.05554897f, -0.02590186f, 0.11417260f, -0.03474713f, 0.05473582f, 
    -0.00379778f, -0.02618346f, 0.00322328f, 0.14664114f, 0.08025816f, 0.04198479f, 0.17728169f, 0.04281880f, 
    -0.12305336f, 0.03079852f, 0.25447667f, 0.06699409f, 0.04856940f, 0.07142407f, 0.13116039f, 0.03053691f, 
    0.03145898f, 0.08466759f, -0.10272610f, -0.04680284f, -0.16847679f, 0.01017598f, 0.28113908f, 0.17557094f, 
    0.09762197f, 0.07073287f, 0.27452704f, 0.03799000f, 0.05394959f, 0.08157935f, 0.03140032f, 0.12440509f, 
    0.14197727f, -0.03736500f, -0.02362283f, -0.06278253f, 0.06574430f, 0.22681668f, 0.05687636f, 0.00928349f, 
    -0.00313028f, 0.13174945f, 0.15399633f, 0.09887721f, 0.08488613f, -0.37187985f, -0.05057103f, 0.17426546f, 
    -0.07936831f, -0.08258253f, 0.09741949f, 0.15899892f, 0.06259071f, 0.07976098f, 0.00127220f, 0.10909284f, 
    -0.34078109f, 0.00853797f, -0.09037306f, 0.20057110f, 0.09060394f, 0.01292000f, -0.01952776f, 0.16697317f, 
    0.05837126f, 0.07491360f, 0.15691079f, -0.03671334f, -0.00099839f, 0.22149140f, 0.18171978f, 0.09744840f, 
    0.08829249f, 0.04102157f, -0.04874971f, 0.21403877f, -0.04616749f, 0.01273923f, 0.07019072f, -0.01696098f, 
    -0.00961442f, 0.00829640f, -0.21016076f, -0.19988178f, 0.01357474f, -0.04780155f, -0.09559431f, -0.00598398f, 
    0.03444521f, 0.03155104f, -0.00327955f, 0.04888392f, -0.23736826f, 0.04011254f, 0.02380512f, -0.06851973f, 
    0.03134283f, 0.22703721f, 0.01998586f, 0.13277517f, 0.05168534f, 0.10061046f, -0.04380538f, 0.03873388f, 
    -0.01557247f, 0.02218094f, -0.07552816f, 0.05149130f, 0.16712412f, 0.07276877f, -0.01148218f, 0.16285329f, 
    -0.00817597f, -0.01623750f, 0.06879033f, 0.11021387f, -0.31817684f, 0.40818787f, -0.01204936f, -0.23420015f, 
    0.01528962f, 0.18856201f, 0.06229239f, -0.00661698f, 0.15260087f, -0.03774413f, 0.00587245f, 0.01593316f, 
    0.05006670f, 0.28759739f, -0.25895274f, -0.31307936f, 0.12942889f, -0.06361443f, 0.04241426f, -0.07786479f, 
    0.03019373f, -0.08513137f, 0.01242745f, -0.10282477f, -0.22831036f, 0.12076634f, -0.01706732f, -0.20074864f, 
    -0.04040180f, 0.00263040f, -0.02177255f, 0.13656114f, -0.07856674f, -0.13335077f, -0.21613340f, -0.02710754f, 
    0.46444547f, 0.05724321f, 0.00393211f, 0.09562311f, 0.10302879f, 0.06630050f, 0.07560457f, 0.08774676f, 
    0.04086645f, 0.00796775f, -0.03712250f, 0.12917942f, 0.12990114f, -0.15322943f, 0.22284238f, 0.03688276f, 
    -0.00688004f, 0.12962578f, 0.07631666f, -0.01765834f, -0.07414593f, 0.03703417f, 0.10210831f, 0.13975947f, 
    -0.06369971f, -0.03785640f, -0.05077504f, 0.12138496f, -0.04842114f, 0.04699438f, 0.14433292f, -0.13301240f, 
    -0.03334768f, 0.09191103f, -0.00816078f, 0.03192360f, 0.12025708f, -0.16763212f, -0.07605309f, 0.21587227f, 
    0.06204544f, 0.10886776f, 0.00294020f, -0.01377182f, 0.07266220f, 0.03365141f, 0.11600093f, -0.07531846f, 
    -0.14699590f, 0.04025606f, 0.06408472f, -0.15071693f, 0.06836821f, -0.01293437f, 0.05045506f, -0.16096860f, 
    0.01975347f, -0.14952104f, -0.09499600f, 0.01758120f, -0.08695487f, -0.11476083f, 0.05387725f, 0.14920215f, 
    0.08462124f, 0.14148447f, 0.13171312f, -0.12797071f, -0.00779075f, -0.19748478f, -0.03870669f, 0.04624542f, 
    -0.06981248f, -0.19154947f, 0.15689123f, 0.11031149f, 0.05367253f, -0.11269720f, -0.01117300f, -0.00004625f, 
    -0.16954379f, 0.00457823f, -0.00867416f, 0.06579743f, -0.08671100f, 0.04682892f, -0.06878613f, -0.09421817f, 
    0.09381033f, 0.09385831f, 0.03064008f, 0.18916455f, -0.09465514f, 0.22203322f, 0.05110736f, 0.07736181f, 
    -0.01179448f, -0.09552053f, 0.10148649f, -0.16561143f, 0.00503271f, 0.10825287f, 0.05605449f, -0.06834989f, 
    -0.12096223f, -0.11418444f, -0.00001157f, 0.13451821f, -0.24084567f, -0.15049078f, 0.10804155f, -0.15112671f, 
    -0.02611172f, 0.01969009f, 0.09851763f, 0.09898958f, 0.10094454f, 0.09083970f, -0.02678538f, -0.03629339f, 
    0.18517752f, -0.09503084f, -0.02182031f, -0.04958108f, 0.05283383f, 0.10236577f, 0.05107245f, 0.01153120f, 
    0.04341459f, 0.01571188f, -0.03686806f, -0.01579982f, -0.06199151f, 0.04481886f, 0.04027164f, -0.04339140f, 
    0.03110484f, -0.07683215f, 0.04093308f, 0.08678259f, 0.10513698f, 0.07876468f, 0.00217420f, 0.02136920f, 
    0.10627828f, -0.17546147f, -0.18364665f, -0.08321551f, 0.07525955f, 0.12549058f, 0.15450436f, 0.05157195f, 
    0.08176772f, 0.07380939f, -0.00711917f, 0.04480090f, 0.25779343f, 0.08178410f, -0.01536041f, 0.02972352f, 
    -0.04842766f, 0.01182139f, -0.03746009f, -0.08719667f, -0.00549237f, 0.04421893f, -0.06307810f, 0.07662051f, 
    0.08441509f, 0.07609537f, -0.00115460f, 0.04110489f, -0.03182972f, -0.10830580f, -0.08773487f, 0.12763785f, 
    0.10615776f, 0.02644590f, 0.05763271f, 0.09510081f, -0.06937400f, 0.08440771f, -0.07480516f, -0.04935585f, 
    0.02072013f, 0.13907355f, -0.01234166f, 0.00368220f, -0.00039324f, 0.02084692f, -0.03063620f, -0.02665658f, 
    -0.12861688f, -0.00065655f, -0.02915914f, 0.09610882f, 0.03609154f, -0.04742553f, 0.02678166f, 0.10200052f, 
    0.01603858f, 0.05226294f, -0.05628812f, -0.04779936f, -0.05804234f, 0.11153495f, -0.12541148f, -0.03644284f, 
    0.11272261f, -0.03165979f, 0.12765598f, 0.00724766f, -0.10941612f, -0.01047956f, -0.09233999f, 0.06551223f, 
    -0.03192794f, 0.09036566f, 0.16695791f, 0.06532972f, -0.00209207f, -0.06880290f, -0.12042292f, 0.11406706f, 
    0.11432619f, -0.01600615f, -0.08478516f, -0.08845036f, -0.17974499f, 0.00765226f, 0.12433383f, 0.03942156f, 
    0.11945389f, -0.01488581f, 0.06706154f, -0.04321023f, -0.00752056f, 0.00563248f, 0.02271872f, 0.10843921f, 
    -0.19623317f, -0.01386389f, 0.25225779f, 0.08050018f, -0.02118869f, 0.06376866f, 0.09732816f, 0.14798190f, 
    0.03417191f, 0.21948160f, 0.09744459f, 0.22523481f, -0.26773861f, 0.10633604f, 0.03849078f, 0.18559320f, 
    0.10680998f, -0.03123340f, 0.07572148f, -0.02228496f, 0.08132038f, -0.05833568f, -0.05056076f, 0.03621140f, 
    -0.18744853f, 0.01741932f, -0.05558436f, -0.16729802f, 0.08925430f, 0.10496148f, 0.13317886f, 0.12666903f, 
    0.05426884f, 0.10512970f, 0.00655126f, 0.00135172f, 0.20564164f, -0.11559221f, 0.07861128f, -0.03010182f, 
    0.13543275f, 0.09577399f, -0.06536320f, 0.03709933f, 0.07866272f, -0.02942963f, -0.08163548f, -0.02933320f, 
    -0.04807852f, 0.18364857f, 0.01258476f, 0.11234926f, 0.23783167f, 0.10590928f, 0.15658189f, 0.04036808f, 
    0.11586560f, -0.01825483f, 0.03310014f, 0.08889803f, 0.20349157f, 0.24200435f, 0.05996060f, 0.12384890f, 
    0.12305073f, -0.01371289f, 0.09165540f, 0.11441934f, -0.09973931f, 0.03957765f, 0.07706920f, -0.11219210f, 
    -0.21271616f, 0.02737200f, -0.03062766f, -0.16228886f, 0.05021919f, 0.05684633f, -0.01390406f, 0.01450708f, 
    -0.13301988f, 0.05328233f, -0.17499247f, 0.00098875f, -0.02653301f, 0.04852886f, 0.02408679f, -0.02249585f, 
    -0.05309589f, 0.03532163f, 0.01691190f, -0.08140361f, 0.04440238f, 0.08581687f, -0.03470533f, 0.13071503f, 
    0.17363945f, -0.03028965f, 0.03857979f, -0.01076820f, 0.11129913f, 0.02787028f, 0.25285229f, 0.15741304f, 
    -0.02743152f, -0.07536831f, -0.12694822f, -0.13622019f, -0.07513533f, -0.00437942f, -0.02067472f, -0.13255346f, 
    -0.05196025f, 0.03687007f, -0.00098263f, -0.18317406f, -0.02883955f, -0.03257392f, -0.09157643f, -0.01097545f, 
    -0.32327616f, -0.18959516f, -0.06930894f, -0.08659250f, -0.08395736f, -0.01985284f, -0.03847659f, -0.06575915f, 
    -0.03544966f, -0.08071886f, -0.10762674f, 0.02153640f, -0.05622611f, -0.11742894f, 0.04358911f, 0.03735247f, 
    -0.11450373f, -0.05258349f, 0.01327161f, -0.02970163f, -0.03763235f, -0.07894991f, -0.00023196f, 0.03142046f, 
    0.37682909f, 0.12987293f, 0.08481697f, 0.03467625f, 0.00361313f, 0.14084724f, -0.01280276f, 0.04585170f, 
    0.03756747f, 0.06564417f, -0.13118409f, -0.08339863f, 0.25146648f, 0.08516092f, 0.46296573f, 0.04660824f, 
    -0.07116114f, -0.09267905f, -0.01541988f, -0.05951034f, 0.01982870f, 0.10857890f, -0.10191286f, -0.04050558f, 
    -0.10712069f, -0.14758770f, 0.05360901f, 0.00270867f, 0.00015767f, 0.00446559f, -0.01418856f, -0.01860601f, 
    -0.09456965f, 0.01572307f, -0.00319186f, 0.05418117f, 0.22107744f, -0.09683327f, 0.11574028f, -0.04549333f, 
    0.07216758f, 0.15176749f, -0.04900984f, -0.04760618f, 0.07821597f, 0.04036821f, -0.11002678f, 0.01757819f, 
    -0.24840415f, 0.08449681f, -0.07969340f, -0.12939550f, -0.02692244f, -0.07356226f, -0.04870324f, -0.02676796f, 
    0.04512668f, -0.00183084f, -0.04273199f, -0.02159813f, -0.40203542f, -0.03632072f, 0.02408398f, -0.00525997f, 
    0.00777409f, -0.10569447f, 0.12330837f, -0.04867390f, -0.07619919f, 0.02291343f, -0.09514885f, -0.10263736f, 
    0.12723683f, 0.36815524f, -0.08433990f, 0.14035286f, 0.05296463f, -0.14632095f, 0.14942147f, -0.05012058f, 
    -0.07601269f, -0.05017157f, -0.22961560f, -0.01141190f, 0.22564444f, 0.22343981f, -0.04591940f, -0.07434309f, 
    0.19846839f, 0.19848990f, 0.13111465f, 0.02065174f, 0.08941539f, -0.00775983f, 0.05594528f, 0.05277357f, 
    -0.03746714f, -0.03222787f, 0.03302733f, 0.03244280f, 0.00571705f, -0.01687816f, 0.00078702f, -0.07653176f, 
    -0.02510000f, -0.04473090f, -0.10015018f, -0.06274790f, -0.10612617f, -0.08349582f, -0.00320496f, 0.02396522f, 
    0.02819854f, -0.01443861f, -0.07454006f, -0.00789630f, -0.08446874f, -0.09560684f, 0.00925634f, -0.06702730f, 
    -0.09797310f, -0.04778987f, -0.03137577f, -0.02849190f, -0.09161145f, -0.02808441f, -0.00140933f, -0.00367236f, 
    -0.08907887f, -0.02427723f, -0.03826291f, -0.08863806f, 0.03513458f, 0.01321904f, -0.01120195f, -0.03413365f, 
    -0.08094028f, -0.07952864f, -0.02604433f, -0.09505202f, -0.00511885f, 0.02026723f, -0.07067982f, 0.03331352f, 
    -0.04526016f, 0.02861903f, -0.06004889f, -0.05724883f, 0.01641038f, -0.03569000f, -0.09184443f, 0.02083422f, 
    0.02403676f, 0.00299398f, -0.04972477f, 0.01397705f, -0.07326022f, -0.00530068f, -0.05219299f, -0.07131357f, 
    -0.02581939f, -0.02881867f, -0.03443087f, -0.04356931f, -0.07105818f, 0.03743816f, -0.07520060f, -0.06898206f, 
    -0.02030125f, -0.03931960f, 0.03203972f, -0.09052592f, -0.03655132f, 0.02309207f, -0.00124000f, -0.05860395f, 
    -0.02300195f, -0.09230389f, -0.03883694f, 0.01648315f, -0.10429733f, 0.02433096f, -0.00147329f, -0.01656429f, 
    -0.04933394f, -0.07688897f, 0.02418484f, -0.01001366f, -0.07581629f, -0.00175257f, -0.06896523f, 0.00189379f, 
    -0.02979132f, -0.07227731f, -0.10813207f, -0.02130277f, 0.02434486f, -0.01671076f, -0.02175495f, 0.00202870f, 
    -0.06961054f, 0.02072930f, -0.02057892f, -0.01265288f, 0.01685352f, -0.05840229f, -0.07558586f, 0.03537264f, 
    -0.00890823f, -0.09021323f, -0.02241507f, 0.03178596f, -0.09929498f, 0.03625198f, -0.05864497f, -0.05531235f, 
    0.02030944f, -0.07876020f, -0.05245963f, 0.03557491f, 0.01586781f, -0.01968774f, -0.01983437f, -0.04662826f, 
    -0.01099467f, -0.05913909f, -0.02685401f, -0.06678141f, 0.00475922f, -0.09507939f, -0.02916922f, -0.06721634f, 
    -0.09005894f, 0.02132939f, -0.09455991f, 0.03215098f, -0.08284094f, -0.03997736f, -0.06059274f, -0.05174687f, 
    0.01758471f, 0.02867705f, -0.04741755f, -0.05909423f, -0.05241721f, 0.00085461f, 0.03400681f, 0.01440123f, 
    -0.00399028f, -0.02608973f, -0.08485056f, -0.02337361f, -0.02651478f, -0.02686693f, -0.07755430f, -0.00648538f, 
    -0.03787686f, 0.03167842f, -0.08939067f, -0.07951033f, 0.03148688f, -0.01085218f, -0.04628257f, -0.02541823f, 
    -0.01140981f, 0.04325096f, -0.02535089f, 0.01986228f, -0.06294525f, -0.10543296f, -0.01030353f, 0.02371699f, 
    0.02315309f, -0.05831063f, -0.10370681f, -0.09044199f, -0.09875496f, -0.02132190f, 0.00445383f, -0.03159856f, 
    0.03094726f, 0.00192917f, -0.07622129f, 0.05563810f, -0.03142297f, -0.06518026f, -0.05603756f, 0.03301822f, 
    -0.09932230f, 0.00433114f, 0.01389767f, 0.14772089f, -0.08618482f, -0.05410881f, -0.12380723f, 0.06190848f, 
    -0.06566989f, -0.01314087f, -0.15559839f, 0.06399100f, -0.07439332f, 0.09587528f, 0.23655351f, -0.05557933f, 
    -0.02724550f, -0.08331984f, 0.08214957f, 0.10560358f, -0.01121214f, 0.15798773f, -0.03638326f, 0.01810599f, 
    -0.16264643f, 0.26331201f, -0.07237552f, 0.06141356f, 0.00756003f, 0.07766061f, -0.06511499f, -0.01423371f, 
    -0.00277229f, -0.07112198f, 0.03015582f, 0.09206571f, 0.15678564f, 0.01678549f, 0.09567659f, -0.34483832f, 
    -0.09580649f, 0.03204133f, -0.02562935f, 0.09461337f, 0.04604961f, 0.10349303f, 0.03146488f, 0.05253867f, 
    -0.21343526f, 0.13662061f, -0.02158923f, -0.01742324f, 0.00807003f, 0.10403976f, 0.11143892f, 0.09763531f, 
    0.10523409f, 0.04904143f, 0.02889011f, 0.03598756f, 0.16035868f, 0.11223083f, 0.18951228f, -0.08559567f, 
    0.04173687f, -0.05801831f, -0.03784731f, 0.00430055f, -0.02893089f, 0.18651862f, -0.01244160f, 0.04282664f, 
    0.00155327f, 0.14600055f, 0.00519954f, 0.33528927f, -0.14977114f, 0.08755612f, 0.02751185f, -0.03767198f, 
    0.02994389f, 0.05505677f, 0.07504811f, 0.04822886f, 0.16738656f, 0.13763011f, 0.02501435f, -0.08557597f, 
    -0.12481090f, 0.06243135f, -0.03792546f, 0.03077646f, 0.00438337f, 0.10886426f, -0.00123508f, 0.09648756f, 
    -0.03080851f, 0.11469515f, -0.12129368f, 0.34792992f, -0.07644388f, 0.02879064f, 0.07666866f, 0.04069446f, 
    -0.06315353f, 0.01573630f, -0.10039179f, -0.06021444f, 0.01594252f, 0.00884482f, 0.00915327f, 0.15077376f, 
    -0.01102747f, -0.06125263f, -0.06966366f, 0.02944940f, -0.06276216f, 0.02439303f, 0.02038490f, 0.07777631f, 
    0.16406500f, 0.10243130f, 0.12086845f, 0.14543013f, 0.01716800f, -0.03178567f, -0.02654878f, -0.02664035f, 
    -0.00344847f, -0.09258287f, -0.06576286f, 0.00788815f, 0.10716706f, -0.05226810f, -0.14078261f, 0.20013691f, 
    0.04831575f, 0.00897011f, -0.01795298f, -0.04667052f, -0.06514538f, -0.09749611f, -0.05086375f, 0.12309644f, 
    0.14424723f, -0.06336532f, -0.00298226f, -0.04065869f, -0.02461050f, 0.07729929f, -0.03990988f, 0.01546753f, 
    -0.04669858f, 0.05218512f, 0.00608593f, 0.15826836f, 0.23190133f, 0.05446749f, 0.04324937f, -0.11849543f, 
    -0.07313249f, -0.15094301f, 0.01275254f, 0.09489838f, -0.12556301f, 0.00817387f, -0.00866756f, 0.03315217f, 
    -0.36258227f, -0.17025244f, 0.10630345f, 0.05239436f, -0.07942463f, -0.05160429f, 0.11356756f, 0.03608859f, 
    0.05004884f, -0.00972533f, -0.08006816f, -0.03360621f, 0.26288378f, 0.20626587f, -0.04909951f, -0.09183101f, 
    0.15548502f, 0.04963951f, -0.03310073f, 0.03329679f, -0.00986274f, 0.01135857f, 0.00249934f, 0.04969171f, 
    -0.05148311f, -0.19808467f, 0.05975550f, 0.21241659f, -0.00502390f, 0.06416316f, -0.00824149f, -0.07047314f, 
    -0.14227733f, 0.03319813f, 0.01736630f, 0.00063195f, -0.34846002f, 0.05021438f, 0.19508141f, -0.36708227f, 
    0.04959169f, -0.06547908f, 0.14789565f, 0.14261077f, 0.08163393f, 0.06563351f, -0.03963440f, 0.00791179f, 
    0.25961408f, 0.08152694f, -0.04736128f, -0.01363780f, -0.01902649f, 0.05786167f, -0.11217732f, -0.05390073f, 
    -0.08516046f, -0.03094325f, -0.03159635f, 0.00619350f, 0.08389033f, -0.02796875f, 0.21040706f, -0.13010652f, 
    -0.00263314f, -0.05158355f, -0.03408518f, 0.18742451f, 0.06375615f, 0.04376822f, 0.00279731f, 0.12696290f, 
    -0.09222828f, -0.04345766f, -0.04111049f, -0.05720456f, -0.02044196f, 0.04979189f, 0.01773439f, 0.07406624f, 
    -0.00485712f, 0.05298615f, -0.09245627f, -0.06948216f, 0.47126845f, 0.21562694f, 0.11861531f, 0.01405565f, 
    0.13141212f, -0.04384167f, -0.00245615f, -0.07350529f, -0.04658522f, 0.15943052f, 0.02456476f, 0.03889494f, 
    0.04503839f, 0.16378343f, -0.12764221f, 0.10573307f, 0.12799583f, -0.01797383f, -0.03685199f, -0.05034226f, 
    0.06732894f, -0.02822385f, 0.03697725f, -0.06878829f, -0.01478006f, 0.23906407f, -0.06284451f, -0.05289221f, 
    0.09527669f, 0.05584241f, -0.00232534f, -0.10392412f, 0.01933890f, 0.03767751f, -0.01533275f, -0.04370410f, 
    0.03785704f, -0.01379688f, -0.21315877f, 0.06272643f, -0.03056871f, 0.06132933f, -0.02393963f, 0.06931113f, 
    0.07098369f, -0.05738237f, -0.01502935f, -0.02108894f, -0.23341149f, -0.15124671f, -0.14749050f, -0.09880321f, 
    0.12258142f, 0.05250514f, 0.18465851f, -0.08018769f, 0.04401192f, 0.11038565f, 0.00403249f, 0.03018901f, 
    0.01927046f, -0.06179630f, 0.07550506f, 0.36083418f, -0.04334871f, 0.02305554f, -0.07070030f, -0.04449990f, 
    -0.05186862f, -0.07671201f, -0.09052270f, 0.05666349f, -0.01002724f, -0.13279386f, -0.01065238f, 0.29276201f, 
    0.10864013f, -0.02657780f, -0.06561594f, 0.01096139f, -0.05190433f, -0.09236735f, 0.04201885f, 0.14153755f, 
    -0.18285224f, -0.05813256f, 0.12883474f, 0.04052922f, -0.01540834f, 0.01241019f, 0.10196278f, -0.02951674f, 
    0.01267608f, -0.03729455f, 0.11513555f, 0.13322155f, 0.01652325f, -0.06487752f, 0.13816124f, -0.21204807f, 
    0.06077544f, -0.04986906f, 0.18975489f, -0.07295439f, 0.01340636f, -0.03898521f, -0.01897392f, 0.07866789f, 
    -0.30840895f, -0.16424547f, -0.08715739f, -0.36668202f, 0.07371158f, -0.02200113f, 0.04374425f, 0.05313564f, 
    -0.04533534f, -0.01759232f, 0.06231634f, -0.09767462f, 0.24261425f, -0.06179486f, 0.15189424f, 0.21780957f, 
    0.07291812f, -0.06149791f, -0.05251450f, 0.13452841f, 0.05504633f, 0.01137861f, -0.01248753f, -0.09552199f, 
    -0.11261992f, 0.06073233f, -0.10922731f, -0.22855243f, -0.02976838f, 0.12180167f, 0.18057153f, 0.00843483f, 
    0.14318340f, -0.05870607f, -0.01262325f, -0.05301066f, -0.16582170f, -0.18179637f, -0.09809849f, 0.13851136f, 
    0.12104985f, -0.06376111f, -0.07544822f, -0.19478759f, -0.08817668f, -0.05003510f, 0.05945760f, -0.08469468f, 
    0.07559209f, 0.08722281f, -0.08363967f, 0.00468790f, 0.08696516f, 0.07364216f, -0.04016114f, 0.19680806f, 
    0.08545455f, 0.03338812f, 0.17232254f, 0.03568234f, 0.03246914f, 0.12913971f, 0.02336099f, 0.08551223f, 
    0.08088593f, -0.01611152f, 0.10956044f, -0.06510656f, -0.00257475f, -0.04999266f, 0.04868538f, -0.14610250f, 
    0.01382757f, 0.14050214f, -0.04748026f, -0.00058187f, -0.04175491f, 0.09041078f, -0.10893038f, -0.12075877f, 
    0.00031038f, 0.06993917f, 0.15210086f, 0.05900391f, -0.45598388f, -0.12080199f, -0.06351531f, -0.05711938f, 
    0.02496880f, 0.06880292f, 0.12920851f, 0.04639971f, 0.11405179f, -0.13541503f, 0.14289340f, -0.02943884f, 
    0.08865032f, -0.01058386f, -0.11080798f, -0.17217651f, 0.18622671f, -0.12614073f, 0.01682126f, 0.10040104f, 
    -0.11565998f, 0.03740085f, 0.03709974f, 0.15105648f, 0.06638993f, 0.11409386f, -0.11162259f, -0.16360126f, 
    0.18583030f, -0.05122105f, -0.02977513f, -0.12162210f, 0.03055072f, -0.00928704f, 0.05900314f, -0.10020444f, 
    -0.09889048f, 0.09717980f, 0.07223061f, -0.20469579f, 0.15975337f, 0.09945944f, -0.01054105f, 0.02955348f, 
    0.02228094f, 0.09940583f, 0.24008124f, -0.09480497f, 0.14744303f, 0.18699652f, -0.08899799f, -0.06293144f, 
    0.06460765f, 0.06415075f, 0.08254504f, -0.11174987f, 0.06808070f, 0.11083680f, 0.00143341f, 0.04557553f, 
    -0.25851125f, 0.13519141f, -0.10661305f, -0.32748410f, 0.07763979f, -0.03775043f, 0.08150356f, 0.10369437f, 
    0.14519562f, 0.09707905f, 0.09813787f, -0.01359630f, 0.02745649f, 0.17586720f, 0.11793391f, -0.25587994f, 
    0.01214925f, 0.03202949f, -0.04421107f, 0.08664738f, 0.13256590f, 0.06543291f, -0.05837999f, 0.07645311f, 
    0.22234279f, 0.27983719f, 0.10216811f, -0.10675659f, 0.20112301f, -0.02233157f, 0.04504139f, 0.03675124f, 
    0.01317331f, 0.12769645f, 0.02012191f, 0.13605875f, 0.14596553f, 0.22686252f, 0.31852239f, 0.01217747f, 
    0.14389516f, -0.03104033f, -0.04619206f, 0.03970736f, 0.11235846f, 0.08572125f, 0.06230302f, -0.03651733f, 
    -0.11821543f, -0.18225102f, -0.10807998f, 0.22772405f, 0.02866855f, 0.10121393f, 0.03439060f, 0.08614331f, 
    0.00359311f, -0.03442686f, 0.02943953f, 0.19412015f, -0.05398632f, -0.04852551f, -0.06816062f, 0.17207956f, 
    -0.13755897f, -0.06239041f, -0.07743759f, 0.16321871f, -0.07200146f, -0.03989882f, -0.07070895f, -0.01134089f, 
    0.03018807f, -0.16329990f, -0.01670204f, -0.29392537f, -0.11781095f, -0.01813598f, -0.07890231f, -0.10762759f, 
    0.05056047f, 0.01062830f, 0.05483243f, 0.11176179f, -0.17105915f, -0.15519139f, -0.04633985f, 0.18179181f, 
    -0.17382325f, 0.04175595f, -0.07267862f, -0.02668164f, 0.23004586f, 0.00264316f, -0.00711717f, -0.03916769f, 
    0.42272314f, -0.25698557f, 0.19193928f, 0.01449616f, -0.01026317f, 0.05029731f, 0.06095738f, -0.06680751f, 
    0.14902376f, -0.02269413f, 0.07695726f, -0.03221829f, 0.16388877f, -0.13602115f, -0.25200969f, 0.10758000f, 
    0.16382983f, -0.01105859f, -0.00968826f, 0.07947842f, 0.07780530f, -0.00410131f, -0.06294023f, -0.04217289f, 
    0.02075786f, -0.19423598f, -0.12352346f, -0.01721379f, -0.06849267f, -0.03295778f, -0.02079497f, 0.02982116f, 
    0.05092636f, 0.04062179f, 0.15179254f, 0.02437163f, 0.05588540f, -0.07196841f, -0.07227208f, -0.19378996f, 
    -0.04533115f, -0.06255389f, -0.07327860f, -0.06106491f, -0.02559792f, -0.03989645f, -0.08486869f, -0.00687585f, 
    0.11159041f, 0.00192900f, 0.25496709f, -0.17483212f, 0.00601820f, -0.01742287f, 0.03315104f, 0.01670831f, 
    0.02815806f, 0.01687490f, 0.08253111f, 0.12443271f, 0.13259216f, 0.08372258f, -0.04979274f, 0.09463929f, 
    0.04079062f, 0.08909626f, 0.07480548f, 0.00660566f, -0.09550607f, -0.10844181f, -0.01565917f, -0.00272001f, 
    0.05607494f, 0.15667780f, 0.04615009f, -0.02592422f, -0.03947201f, -0.09329334f, -0.00098940f, 0.21185909f, 
    0.02286112f, -0.06651366f, 0.02265966f, -0.08713704f, 0.10325136f, 0.15163986f, -0.20615071f, 0.12255634f, 
    0.11471482f, 0.01107725f, 0.17522021f, -0.03526397f, 0.01454714f, 0.11875689f, 0.02802548f, 0.11729109f, 
    -0.06684637f, 0.31682715f, 0.00964221f, -0.12255329f, 0.13165280f, 0.03398574f, 0.01895400f, 0.15255049f, 
    -0.02682813f, -0.09883557f, 0.08289536f, -0.03797335f, -0.11113082f, 0.15727979f, 0.16712327f, -0.10721786f, 
    0.03460852f, -0.05696033f, -0.00253558f, -0.00539505f, 0.01593087f, 0.04902025f, 0.05145561f, 0.05826203f, 
    0.15709291f, 0.25053632f, -0.04047490f, -0.12127241f, 0.06555649f, 0.19780046f, 0.10564291f, 0.11401499f, 
    -0.22844249f, 0.06287053f, -0.02460678f, 0.11033987f, 0.21626803f, 0.34795237f, -0.18212326f, 0.23155008f, 
    0.01094076f, 0.01234233f, 0.08572314f, 0.07008285f, 0.05824601f, -0.15009114f, 0.02630507f, -0.08429765f, 
    -0.15933351f, -0.18245646f, 0.05953510f, 0.39595777f, 0.06656739f, -0.01237321f, 0.04065626f, -0.01787519f, 
    -0.08624277f, -0.07898650f, -0.01588962f, 0.14400433f, 0.06094065f, -0.15333344f, -0.10411397f, -0.25425619f, 
    -0.00109369f, 0.07838251f, -0.03915220f, -0.04144040f, 0.02432674f, -0.00784068f, -0.01119021f, 0.08579405f, 
    -0.20213778f, -0.25580496f, 0.08919682f, 0.07610927f, 0.04659253f, 0.08449803f, 0.05869763f, -0.11692598f, 
    -0.13628124f, -0.09104971f, 0.00405239f, 0.05285921f, -0.15010066f, 0.10047925f, 0.08921178f, -0.09600351f, 
    -0.04230954f, -0.10706452f, 0.01731150f, 0.03127677f, 0.07394706f, 0.20269172f, -0.03401381f, -0.01042217f, 
    -0.23982882f, 0.10522207f, 0.02789901f, -0.15443343f, 0.10778837f, -0.09439366f, -0.06815952f, 0.01930364f, 
    -0.11365516f, 0.10779957f, -0.00113475f, -0.03215349f, 0.17429122f, -0.02176370f, -0.10025805f, 0.03371713f, 
    0.04904200f, 0.05169070f, -0.03217148f, -0.02417484f, 0.15969133f, 0.05362828f, -0.09644032f, 0.13347961f, 
    -0.41251642f, 0.06144289f, -0.12678191f, 0.07197987f, 0.08470883f, -0.00521608f, 0.02579823f, 0.06382206f, 
    0.08456381f, 0.08717033f, -0.01931863f, 0.02487528f, 0.28221321f, 0.09952163f, 0.04576887f, 0.03692614f, 
    0.07021581f, -0.10059982f, -0.08010113f, -0.00476752f, -0.11479200f, 0.12183409f, -0.17807595f, -0.01728807f, 
    -0.15194213f, 0.18405597f, 0.06182519f, 0.22694241f, 0.06665879f, 0.01411439f, -0.04768265f, -0.14567775f, 
    0.15675350f, -0.02655447f, -0.00378947f, 0.05183410f, 0.11979666f, 0.10710395f, 0.05530835f, 0.26739815f, 
    -0.02845906f, 0.05483234f, 0.00746999f, -0.05383718f, 0.02310784f, 0.02387905f, 0.06167958f, 0.08503358f, 
    -0.13210078f, -0.16343109f, -0.00951422f, 0.08622151f, -0.05467562f, -0.02187165f, -0.08040189f, 0.17380787f, 
    0.05373985f, 0.05623351f, 0.05187406f, -0.12551942f, -0.10667760f, -0.01995470f, -0.09428231f, 0.20358677f, 
    0.07368597f, -0.05613487f, 0.03585424f, -0.01916969f, 0.00110072f, 0.11670895f, 0.01787723f, 0.03179603f, 
    0.02740177f, -0.03326672f, 0.09463445f, 0.23052233f, -0.00820680f, -0.01421612f, -0.04979755f, -0.08259580f, 
    -0.05166355f, -0.07385439f, -0.01620126f, 0.09244224f, -0.08378477f, -0.12087293f, 0.12158611f, 0.02732807f, 
    0.05388143f, -0.08652588f, 0.06111793f, -0.11030407f, 0.11479200f, 0.02713284f, 0.02581972f, 0.20922056f, 
    0.02269495f, -0.08128481f, -0.06805024f, 0.18149725f, 0.01472735f, 0.01554549f, 0.07126553f, -0.11949968f, 
    -0.08781993f, 0.09510117f, 0.11379129f, 0.11059826f, 0.16307509f, 0.10708374f, -0.15116820f, -0.13283128f, 
    -0.01816248f, -0.05797832f, 0.03587268f, 0.04549136f, 0.08186527f, -0.09069092f, 0.08907398f, 0.04014773f, 
    -0.22449253f, -0.02657428f, -0.01706646f, 0.07483090f, -0.05534376f, 0.08975933f, 0.12084453f, -0.06351879f, 
    -0.00787693f, -0.07366953f, -0.07193398f, 0.03202655f, -0.03325417f, 0.02343341f, -0.01861053f, -0.01973510f, 
    0.04536706f, 0.10456421f, -0.05687457f, -0.08672997f, 0.05303399f, -0.03191094f, -0.00007516f, -0.15694052f, 
    0.18156892f, 0.00953253f, -0.01478892f, -0.20953426f, 0.05729477f, 0.07935930f, -0.10767196f, -0.02511769f, 
    0.07235228f, -0.02231706f, 0.04876319f, -0.04437259f, -0.02180762f, 0.16059108f, -0.14589253f, 0.11337525f, 
    0.00482602f, 0.09722923f, 0.03429383f, 0.10236266f, 0.11094353f, 0.07544230f, 0.04416119f, 0.09963012f, 
    0.34444451f, -0.28997678f, 0.22875109f, 0.15245636f, -0.18596104f, 0.11572549f, 0.01250748f, -0.20571299f, 
    0.01659772f, -0.00152574f, 0.04176357f, 0.01377806f, 0.06130349f, -0.03151938f, -0.08123527f, -0.11874206f, 
    0.08957344f, 0.01411336f, -0.00136883f, 0.18484004f, 0.02371122f, -0.10516488f, 0.00889633f, -0.04792181f, 
    0.26437709f, -0.16380446f, 0.01406739f, -0.05149202f, 0.00523754f, 0.06395404f, 0.11471820f, -0.01671326f, 
    0.02709501f, -0.04446713f, -0.04088903f, 0.12141031f, 0.21198432f, -0.10121960f, -0.01978121f, 0.03053357f, 
    -0.05072936f, -0.09452055f, 0.01657489f, 0.06066041f, -0.16055995f, 0.01169287f, -0.09228892f, -0.03871496f, 
    0.33653912f, -0.06683133f, 0.25794196f, 0.12830986f, -0.11345292f, 0.10258100f, -0.11007556f, -0.04459441f, 
    -0.05321602f, 0.02373458f, -0.01917395f, -0.07575257f, 0.06824777f, -0.00796904f, 0.16504627f, 0.08828039f, 
    -0.08259535f, -0.14368241f, 0.02188734f, -0.02363470f, -0.02662210f, -0.04558446f, 0.01591438f, -0.04502032f, 
    0.14308664f, 0.08920935f, -0.03507229f, -0.05641163f, -0.06269459f, -0.12813148f, 0.04103905f, 0.01017334f, 
    -0.07136953f, 0.04493177f, -0.07142649f, 0.08399877f, 0.02213073f, 0.10455640f, -0.21030043f, 0.03102575f, 
    0.06024307f, -0.06651305f, 0.05321471f, 0.04949767f, -0.12657189f, -0.04072612f, 0.02853397f, -0.05415094f, 
    0.21666113f, 0.19689143f, -0.01701490f, -0.00304132f, -0.09528483f, -0.04613104f, -0.06993991f, 0.02220852f, 
    -0.01891667f, -0.03474929f, 0.03769644f, -0.08510613f, -0.02901572f, 0.05878984f, 0.09794512f, -0.06197559f, 
    0.03053302f, -0.07840746f, -0.07246689f, -0.08000429f, -0.16201593f, -0.05405504f, 0.01035423f, -0.10069082f, 
    0.04648241f, -0.04578860f, -0.08718426f, 0.15237164f, 0.06297132f, 0.09318779f, 0.00738914f, 0.12731928f, 
    0.04065910f, -0.16770639f, -0.12190719f, -0.04602445f, -0.22514573f, 0.11314441f, -0.14096881f, 0.09721756f, 
    -0.06696279f, -0.02560592f, 0.00607263f, 0.15155724f, -0.05885909f, -0.07272066f, -0.04899842f, -0.01462240f, 
    -0.03245533f, 0.02420907f, -0.04299558f, 0.03176301f, 0.13087861f, 0.06110834f, -0.00515379f, -0.02328001f, 
    0.00885541f, 0.05449886f, 0.00824336f, -0.07946279f, 0.10913622f, -0.13789770f, 0.08070825f, -0.15530664f, 
    0.02171361f, 0.05308270f, 0.13193733f, 0.11097133f, -0.05499855f, -0.07899181f, -0.03600317f, 0.15210280f, 
    -0.05251847f, 0.05142352f, -0.00564089f, 0.02835530f, 0.02607624f, 0.05357480f, -0.01559947f, -0.00812359f, 
    0.05134541f, -0.01655889f, 0.03025855f, 0.05260568f, 0.04235847f, 0.04035104f, -0.05275521f, 0.00679016f, 
    0.02055278f, 0.03709329f, 0.02254762f, 0.01158604f, 0.03149196f, 0.00441926f, 0.00162507f, -0.04606923f, 
    -0.05570488f, 0.03451448f, -0.00098462f, 0.05951504f, -0.07601666f, -0.03418546f, -0.00192153f, -0.01821554f, 
    0.03444451f, -0.07463247f, -0.04866157f, -0.01245170f, 0.00531011f, 0.04385206f, -0.01209292f, 0.02924591f, 
    -0.04268611f, 0.04013584f, -0.03444964f, -0.06861861f, -0.00338832f, -0.00317246f, -0.02258657f, -0.00174835f, 
    0.04655753f, -0.04835658f, 0.05704373f, -0.05233533f, -0.03854546f, -0.07647316f, 0.04332815f, 0.05479203f, 
    -0.02450408f, -0.02577513f, 0.04301272f, 0.04673808f, 0.05817512f, -0.06405772f, -0.04241870f, -0.04938922f, 
    -0.02120509f, -0.01605796f, 0.05612371f, -0.06921047f, -0.07630011f, -0.03459299f, 0.00898654f, 0.06157374f, 
    0.04421865f, 0.00966784f, -0.03964754f, 0.03690406f, -0.05909197f, 0.03192426f, -0.04453822f, -0.04071245f, 
    0.04753214f, 0.01581386f, -0.07034469f, -0.01085109f, -0.04629365f, 0.03259156f, -0.04777975f, -0.07372513f, 
    -0.05743488f, 0.06175146f, -0.03386588f, -0.03411978f, 0.00440552f, 0.02395404f, -0.03888374f, -0.01338952f, 
    0.04312105f, -0.03253721f, 0.03186911f, 0.03975238f, 0.03077269f, 0.03508645f, -0.06209564f, -0.04723473f, 
    -0.07290139f, -0.01120153f, -0.02640462f, -0.03911478f, -0.00742109f, -0.02558167f, -0.04563221f, -0.07111981f, 
    -0.01108158f, -0.02269913f, -0.04226443f, -0.05208635f, 0.02161942f, 0.01110801f, -0.02875824f, -0.03260282f, 
    0.01950466f, 0.03303495f, -0.01869551f, -0.05385074f, -0.00782022f, 0.03661750f, 0.01723257f, -0.07507251f, 
    -0.02545463f, -0.00883003f, 0.02404832f, 0.05115901f, -0.03511402f, -0.06440808f, -0.01547134f, -0.04808991f, 
    0.03473123f, -0.00279516f, -0.00549291f, -0.00331175f, -0.00629604f, 0.02110509f, -0.02571173f, -0.06937702f, 
    -0.04195442f, -0.07313669f, -0.01655445f, 0.05154080f, -0.01935625f, 0.03129724f, -0.07399915f, 0.02264126f, 
    0.05588825f, -0.06390319f, -0.03546998f, -0.03176538f, -0.05941679f, 0.01258934f, -0.03175375f, -0.01256390f, 
    -0.03418723f, -0.02035753f, 0.01209582f, -0.07483695f, -0.06854779f, -0.03688503f, -0.01252048f, 0.01825286f, 
    -0.00862449f, -0.05466241f, -0.02617853f, -0.01221607f, -0.01319180f, 0.04248085f, -0.04304956f, -0.05652710f, 
    -0.06645871f, 0.05389480f, -0.01360279f, -0.03244205f, -0.00345099f, 0.04330967f, 0.01693098f, 0.00725261f, 
    0.05284179f, -0.07772416f, -0.04380156f, -0.07582981f, -0.01528776f, 0.03867769f, -0.00861116f, -0.01813060f, 
    -0.07947384f, 0.17090672f, 0.05440060f, -0.18298315f, 0.15203814f, -0.03989502f, 0.06984107f, 0.19636640f, 
    0.12571660f, 0.14900486f, 0.12961024f, 0.03149844f, 0.21636988f, -0.00767645f, -0.06192829f, 0.04895330f, 
    0.00164563f, 0.03587176f, 0.13808733f, 0.00742374f, -0.00050179f, -0.16239510f, -0.03169705f, -0.00299904f, 
    -0.52642560f, 0.03775581f, -0.04878422f, 0.04043112f, 0.16773941f, 0.06057905f, 0.02499987f, 0.08698414f, 
    0.01527712f, -0.06132199f, -0.00188170f, -0.01623568f, -0.08572870f, 0.06726240f, -0.01372800f, -0.13348897f, 
    -0.10086649f, 0.12814863f, 0.12581202f, -0.01435838f, -0.07708924f, -0.07316399f, 0.02577230f, -0.14442091f, 
    -0.30088061f, 0.25262064f, -0.08329817f, -0.15411986f, -0.03350218f, 0.05209608f, -0.04974239f, 0.04798507f, 
    0.10079256f, -0.07075956f, 0.06658596f, 0.03666478f, -0.02439990f, -0.40706697f, -0.12909131f, -0.04166348f, 
    0.01216015f, -0.02320964f, 0.08919051f, 0.09336963f, 0.05288722f, -0.10109258f, 0.08815466f, 0.04867524f, 
    0.02939044f, -0.25314626f, -0.05476466f, 0.11831675f, -0.04553264f, 0.00164713f, -0.12398303f, -0.00054179f, 
    -0.05901509f, -0.00011581f, -0.08246963f, 0.04517074f, 0.22594652f, 0.05523339f, 0.18577254f, -0.08602352f, 
    -0.10587082f, -0.08634407f, -0.08570440f, -0.01761622f, 0.10173126f, -0.01773571f, -0.12337290f, 0.05079756f, 
    -0.30628762f, -0.15263030f, 0.03832774f, -0.00805331f, -0.03302338f, 0.06188258f, -0.07825796f, -0.15144432f, 
    0.09083779f, -0.01597105f, 0.05525482f, 0.09999391f, -0.10535762f, 0.31140223f, 0.13333927f, -0.03554235f, 
    0.00401108f, 0.03483878f, -0.03839872f, -0.07889158f, 0.09826095f, 0.02938466f, -0.06636918f, -0.05346994f, 
    0.31697088f, -0.07683249f, -0.16105719f, -0.04369586f, -0.06408402f, 0.02926339f, 0.04791126f, -0.04881656f, 
    0.04288464f, -0.03098755f, 0.27165705f, 0.06416862f, 0.03689222f, -0.04872328f, -0.13216710f, 0.01606843f, 
    0.02057821f, 0.02424044f, -0.06145020f, 0.21472733f, 0.12821898f, 0.03703606f, -0.09932992f, -0.13352174f, 
    0.24494825f, 0.00150809f, -0.01468529f, 0.21688704f, 0.06361309f, 0.01924882f, -0.00853226f, -0.04029918f, 
    0.03409515f, -0.14529529f, -0.11811285f, -0.16843608f, 0.25292692f, 0.02770002f, -0.08666493f, -0.05551308f, 
    -0.09420817f, 0.03911513f, -0.18614504f, -0.05337482f, -0.00765749f, 0.13765113f, 0.09855064f, 0.15039150f, 
    0.30289909f, 0.09502212f, -0.00460670f, 0.03409546f, -0.08766711f, 0.02188176f, -0.11330779f, -0.05960030f, 
    0.16319211f, 0.00638844f, 0.02934069f, -0.05092581f, -0.30534950f, 0.05648156f, -0.08255337f, -0.03414545f, 
    0.04603529f, -0.05175424f, 0.19208813f, -0.05306374f, 0.00494514f, 0.06705745f, 0.04178692f, 0.05886123f, 
    -0.01971836f, -0.06804433f, -0.06735677f, -0.05967711f, -0.04712069f, -0.04809453f, -0.05430280f, -0.05335995f, 
    -0.04058462f, -0.01977090f, -0.04336059f, -0.06426058f, -0.03318515f, -0.02115517f, 0.04431908f, 0.01148857f, 
    -0.06036969f, 0.03277573f, -0.03858046f, 0.02629425f, -0.02120292f, 0.04899492f, -0.05088282f, -0.02959121f, 
    -0.03126613f, 0.04509384f, -0.06080330f, -0.01501060f, -0.06603906f, 0.06139254f, -0.01095035f, 0.06059276f, 
    -0.06137982f, -0.06932056f, 0.03389864f, -0.07241766f, -0.00063770f, 0.01265419f, 0.05981413f, -0.01332693f, 
    -0.05123113f, 0.03588360f, 0.05228769f, -0.04908751f, -0.04547248f, 0.04607715f, 0.02685002f, 0.01333383f, 
    0.05852712f, 0.03548376f, -0.07723539f, -0.06954315f, -0.05880442f, 0.02574870f, 0.05938967f, -0.04164974f, 
    0.02140625f, -0.07014983f, 0.01808575f, -0.01048549f, 0.05966803f, -0.02781824f, 0.02708355f, 0.03646009f, 
    -0.05397480f, 0.06050071f, -0.00707224f, 0.03747116f, 0.00761641f, -0.05030571f, -0.07401228f, -0.05386430f, 
    -0.00176596f, 0.04036845f, 0.06241787f, -0.07271282f, -0.08019686f, -0.00440505f, 0.05971549f, -0.08063394f, 
    0.01835460f, -0.05456347f, 0.00924666f, 0.00144390f, 0.01332864f, -0.03102051f, 0.04474209f, -0.05861858f, 
    -0.01048176f, -0.02620642f, 0.05625456f, 0.00690417f, 0.06344543f, -0.07931130f, 0.05486350f, 0.03850398f, 
    0.04456651f, 0.00422411f, 0.04493893f, 0.04338473f, -0.00736073f, -0.04009424f, 0.03926546f, -0.05282922f, 
    -0.03458319f, 0.01502324f, -0.01457020f, -0.03867909f, -0.01484533f, -0.00696335f, -0.03307204f, -0.06318150f, 
    0.06239831f, -0.07224797f, 0.06013869f, 0.02028126f, 0.02578586f, -0.05842427f, -0.06690619f, 0.00568475f, 
    0.00953363f, 0.04080334f, 0.05299819f, 0.03233660f, -0.03974032f, -0.02215135f, 0.02439577f, 0.00572737f, 
    -0.01386002f, -0.01784011f, 0.04314242f, 0.05685848f, 0.03958508f, -0.07711074f, 0.00654995f, 0.00190065f, 
    -0.01628015f, -0.06515227f, -0.06873592f, 0.01294859f, -0.01244090f, 0.02950699f, -0.07471143f, 0.02104055f, 
    -0.05231049f, -0.07754942f, -0.05498216f, 0.05684453f, 0.00220782f, -0.04460420f, 0.06009082f, -0.06884313f, 
    -0.05605555f, -0.06570480f, 0.02341811f, 0.04900474f, -0.03304017f, -0.03299480f, 0.01588124f, 0.05480774f, 
    -0.01437151f, -0.03684589f, 0.03420087f, -0.01769473f, -0.00337407f, -0.05923074f, -0.06313477f, -0.03971474f, 
    -0.05354295f, -0.06586032f, 0.02104624f, -0.03223762f, 0.04043050f, 0.05871485f, -0.07362739f, -0.03034539f, 
    -0.02445296f, -0.02425062f, -0.01263910f, -0.07777420f, 0.02860128f, -0.04798621f, -0.01918706f, 0.00642133f, 
    -0.03295237f, 0.00153425f, 0.02733618f, 0.02019999f, 0.02669989f, 0.00222157f, 0.01761031f, -0.06104724f, 
    0.02527531f, 0.06419428f, 0.03534203f, -0.07465502f, -0.00760177f, -0.05339419f, -0.00238461f, -0.07490633f, 
    -0.04781509f, -0.04027339f, 0.00292752f, -0.02102193f, 0.02477523f, 0.01837604f, 0.03122032f, 0.06219051f, 
    0.00268789f, 0.04935553f, -0.03086041f, -0.00547895f, 0.04924085f, -0.05687866f, 0.05034065f, 0.02482493f, 
    -0.00009940f, 0.05545870f, 0.01738950f, -0.00018695f, -0.06546210f, -0.05672043f, 0.03448502f, -0.07699821f, 
    -0.00395834f, 0.03589517f, 0.04234553f, 0.04846995f, -0.03245497f, -0.06501662f, -0.00215529f, -0.03488072f, 
    -0.05863899f, -0.08135228f, 0.00547558f, -0.03964737f, 0.05429878f, -0.03733578f, 0.03621182f, -0.05009554f, 
    -0.00680348f, 0.00165515f, 0.04818964f, -0.03940943f, -0.03529647f, 0.01980550f, -0.07063143f, -0.02439366f, 
    0.01193540f, -0.00606504f, -0.02959632f, -0.01678855f, 0.03896223f, 0.00506875f, 0.01347552f, -0.03746098f, 
    -0.01763273f, 0.03327736f, 0.02940006f, -0.04809340f, -0.01196167f, -0.01636435f, 0.06136808f, -0.02340108f, 
    -0.01928581f, -0.07476992f, -0.07149096f, -0.06516722f, -0.05306679f, 0.00911751f, -0.06888947f, -0.00899103f, 
    -0.01928106f, 0.02936211f, -0.03388473f, -0.02342346f, -0.02249145f, 0.05293372f, 0.03200359f, -0.03365214f, 
    -0.02718468f, -0.07387682f, 0.02801279f, 0.01138970f, -0.03772032f, 0.01310294f, 0.01126380f, -0.06351822f, 
    0.05878867f, -0.05323449f, 0.05655217f, -0.01848585f, 0.00442793f, 0.03856588f, -0.04706097f, -0.04063888f, 
    -0.03899878f, -0.03383944f, 0.01140559f, -0.04239904f, 0.04300537f, -0.05050781f, -0.00260000f, 0.06397067f, 
    -0.07505680f, 0.04789842f, 0.03022294f, -0.01906546f, 0.03360730f, -0.00359637f, 0.02710867f, 0.05424130f, 
    0.04214033f, -0.03383910f, -0.07356227f, 0.02399263f, 0.01481809f, 0.06302851f, -0.07824940f, -0.04868045f, 
    0.03223661f, 0.05292171f, -0.06030176f, 0.02743399f, -0.05746509f, -0.06692438f, -0.03034292f, -0.03427967f, 
    -0.02894814f, -0.04308091f, 0.02182507f, 0.03150833f, -0.04216007f, 0.01468984f, 0.02223838f, -0.01801028f, 
    -0.02300389f, -0.00314056f, 0.02410163f, 0.04896311f, 0.05336278f, -0.05231322f, -0.07288374f, -0.00257552f, 
    -0.04056175f, -0.03865590f, 0.00647250f, 0.01352322f, 0.01134273f, -0.04606532f, -0.06597716f, -0.05221888f, 
    -0.01622783f, -0.05653862f, 0.02951629f, -0.07511723f, -0.06219126f, -0.00517782f, 0.01699803f, -0.03635033f, 
    0.02642933f, 0.04051801f, -0.01586130f, 0.05583918f, 0.01596043f, 0.02829136f, -0.07272621f, 0.04454366f, 
    -0.00962992f, 0.00455035f, -0.02436879f, 0.01424637f, -0.00286946f, -0.06380299f, -0.00050459f, 0.06417634f, 
    -0.05305566f, -0.03262126f, -0.03671721f, 0.04176182f, 0.03697385f, -0.07475137f, 0.05304042f, 0.02357291f, 
    -0.17604953f, 0.24198411f, 0.06078168f, -0.15919633f, 0.00887025f, 0.11437581f, -0.01511715f, -0.05436723f, 
    0.16359013f, 0.12357509f, 0.03570334f, -0.06646804f, 0.20085582f, 0.28727916f, -0.15876578f, 0.22383164f, 
    -0.02144632f, 0.05168394f, -0.07370605f, -0.06889740f, -0.04993671f, -0.09669869f, 0.02919384f, 0.11414427f, 
    0.27341789f, -0.33445609f, 0.18072020f, -0.09710279f, -0.10330514f, -0.10193715f, 0.02046557f, -0.03224384f, 
    0.12486079f, -0.01793893f, 0.01395744f, 0.00458915f, -0.16649060f, 0.27427915f, 0.01721552f, 0.21054888f, 
    -0.02181972f, 0.13465452f, 0.02446713f, 0.00012098f, -0.13065273f, 0.05201773f, -0.02980378f, 0.05855051f, 
    0.23011442f, -0.11856969f, 0.11181769f, 0.08335564f, 0.15847090f, 0.12584931f, 0.03451220f, -0.04627595f, 
    -0.02161572f, 0.00097236f, 0.06122534f, 0.07678662f, -0.17195460f, 0.17454132f, -0.07367051f, 0.15855925f, 
    -0.10528643f, 0.03460296f, -0.17655742f, -0.01674094f, -0.07588833f, -0.07191639f, 0.04036501f, -0.05030162f, 
    0.25606471f, 0.14371632f, 0.11419684f, -0.12643449f, -0.10608270f, -0.01121748f, 0.04103706f, 0.01612929f, 
    -0.03647481f, -0.00449697f, -0.09574825f, -0.07024401f, -0.06522625f, 0.01452800f, -0.03572989f, 0.11255570f, 
    -0.05795720f, -0.16050042f, -0.04214164f, -0.05963670f, 0.04644717f, -0.00495856f, 0.07820566f, 0.02440462f, 
    0.18655273f, 0.00871908f, 0.13960665f, -0.31213513f, 0.20244853f, -0.02957385f, -0.04594336f, 0.09111749f, 
    -0.07945427f, 0.04118508f, -0.00551449f, 0.00577198f, 0.12204065f, -0.35646126f, -0.03199277f, -0.06665727f, 
    -0.01229955f, 0.10048395f, -0.13330065f, -0.01294618f, -0.08287642f, 0.02994157f, -0.08200132f, -0.00249383f, 
    0.18618621f, 0.21705376f, 0.11855882f, 0.02132100f, 0.01759492f, 0.01536227f, 0.07214955f, -0.07527602f, 
    -0.02912020f, 0.17540169f, 0.11909302f, -0.05552637f, -0.09508025f, -0.06826500f, 0.14382324f, -0.09805734f, 
    -0.00528253f, 0.06963666f, 0.00763530f, 0.04723752f, 0.02109941f, 0.04754111f, -0.03693470f, -0.16017129f, 
    -0.15863062f, 0.10021213f, 0.05551738f, -0.03967152f, -0.05387793f, -0.07437525f, -0.03520786f, -0.00109577f, 
    0.06435041f, 0.00481686f, -0.00442084f, -0.13190730f, -0.32401374f, -0.04140514f, -0.06067009f, 0.07405160f, 
    0.01653153f, 0.12539287f, -0.11821315f, -0.05693492f, -0.00870858f, 0.10191618f, -0.13473590f, -0.02354887f, 
    0.03395415f, 0.13920014f, 0.08043944f, -0.00817329f, 0.12290964f, -0.11508208f, -0.05113959f, -0.01413192f, 
    0.04407991f, -0.09841476f, 0.07344770f, 0.07684934f, -0.13255298f, 0.00827806f, 0.15700842f, -0.15312482f, 
    0.06120644f, 0.13145931f, 0.07588672f, -0.06265622f, 0.00866797f, 0.07722051f, 0.03075772f, 0.13590202f, 
    -0.21438958f, 0.15439184f, 0.09291260f, 0.07593812f, 0.00106175f, -0.03211168f, 0.00217680f, -0.00266275f, 
    0.08084797f, 0.04210785f, 0.04966018f, 0.07411080f, 0.22861019f, 0.23288919f, -0.04050002f, 0.02069685f, 
    0.07261527f, 0.01650557f, -0.09900024f, 0.01230020f, -0.07951982f, -0.05235364f, -0.02658634f, 0.05766059f, 
    -0.34731343f, 0.13121435f, -0.09029934f, -0.08075888f, 0.07089506f, -0.07078611f, 0.05238145f, 0.03673188f, 
    -0.05628054f, 0.03345613f, 0.01313478f, 0.15877950f, -0.03540733f, 0.07405046f, 0.03019727f, 0.12309320f, 
    0.00370360f, 0.10261716f, 0.07357471f, -0.05789732f, 0.01405097f, 0.16837226f, 0.08313093f, 0.12382956f, 
    -0.07734566f, 0.19365108f, 0.01890785f, 0.12719594f, 0.16343503f, 0.00016459f, -0.05403076f, 0.03238350f, 
    0.02340348f, 0.00358957f, -0.07844323f, -0.00146092f, -0.16865349f, 0.18168977f, 0.02543469f, 0.04610681f, 
    0.04200045f, 0.06205523f, -0.02185855f, 0.02016161f, 0.10840944f, 0.03163562f, 0.03208696f, -0.00281456f, 
    -0.16860212f, 0.20018944f, -0.06366994f, -0.07288396f, 0.07787661f, -0.03765777f, 0.10551037f, -0.00085444f, 
    0.06156436f, -0.00517714f, -0.07316673f, 0.01761780f, -0.15702970f, -0.02041493f, -0.01796124f, 0.08851334f, 
    -0.06544374f, 0.00031202f, 0.03754148f, 0.04566910f, -0.04431710f, -0.06889063f, 0.09021714f, -0.01924372f, 
    0.16263399f, -0.06372115f, -0.00924281f, -0.12821332f, 0.00009097f, 0.03437596f, 0.02908671f, 0.01804709f, 
    0.00573809f, -0.01569813f, -0.05967193f, -0.00118191f, 0.04891105f, -0.16254701f, 0.18828410f, 0.11262288f, 
    -0.16396801f, -0.02781289f, -0.14036646f, -0.00295617f, -0.00565553f, -0.04848258f, 0.00605030f, 0.06788760f, 
    0.01450790f, -0.16434243f, -0.00231662f, -0.08964001f, -0.10009246f, -0.02192260f, -0.03868292f, 0.05827586f, 
    -0.00343501f, -0.00450043f, -0.00575456f, 0.14425333f, 0.02365949f, -0.04777399f, 0.03473617f, 0.02448945f, 
    0.06592050f, 0.08780526f, -0.04873268f, -0.01279572f, 0.19523801f, 0.10061735f, 0.02704257f, 0.06763025f, 
    0.01439526f, -0.11806623f, -0.00386529f, -0.06405096f, 0.03058106f, -0.07927800f, 0.03311300f, -0.07916514f, 
    0.11328781f, 0.01341740f, 0.00624186f, -0.00698240f, -0.00657775f, -0.16013694f, 0.08061203f, -0.11247475f, 
    0.01287593f, -0.02567415f, -0.05996990f, -0.06602082f, 0.11646763f, 0.08874661f, 0.01704318f, -0.02915448f, 
    0.11985994f, 0.03403659f, 0.04549201f, 0.11883681f, 0.01442881f, -0.18555054f, -0.00259039f, 0.03916143f, 
    0.03634328f, -0.03422912f, -0.00997095f, 0.09791483f, -0.11541118f, 0.08676296f, -0.09005958f, 0.12660496f, 
    -0.03910916f, 0.06866708f, -0.01713050f, 0.00256787f, -0.02710523f, -0.02259631f, -0.03858322f, -0.12234882f, 
    0.28705066f, 0.13126136f, 0.15222184f, -0.12412997f, 0.09608262f, 0.06908955f, 0.03201821f, 0.03638509f, 
    -0.09695030f, -0.07256141f, -0.00599236f, 0.05597901f, 0.05181935f, -0.02384175f, 0.02905549f, -0.00217982f, 
    0.04457723f, -0.02477780f, 0.04032065f, 0.02131189f, 0.08819504f, 0.05127212f, -0.07047881f, 0.06256067f, 
    0.09204564f, -0.08744278f, 0.22751421f, 0.14732175f, -0.02045456f, 0.02054840f, 0.09228054f, 0.02296721f, 
    0.08085871f, 0.05305652f, -0.01443680f, -0.08438183f, 0.07163482f, 0.11980172f, 0.04439232f, -0.13341007f, 
    -0.13475132f, -0.09337732f, 0.03602139f, 0.09940261f, 0.00476810f, -0.05665806f, 0.07573535f, 0.05698308f, 
    0.21238036f, -0.03617965f, -0.02062399f, -0.17524956f, -0.06036700f, 0.03496558f, 0.10894948f, -0.01875709f, 
    0.05715540f, -0.05707821f, 0.03586751f, 0.06072817f, 0.36067382f, -0.25537491f, -0.11365908f, -0.00488894f, 
    -0.09646611f, -0.00283753f, 0.01212114f, 0.10735077f, -0.04870650f, -0.04669460f, -0.06505259f, 0.07376412f, 
    0.04074424f, -0.21918836f, 0.26494941f, 0.24137411f, -0.12554385f, 0.12638853f, -0.05866239f, 0.10313521f, 
    -0.01223256f, -0.01853369f, -0.01361142f, 0.03109515f, 0.08127919f, -0.00478784f, 0.19207388f, 0.17042603f, 
    -0.10192387f, -0.08955015f, -0.06768921f, -0.12853585f, 0.14739214f, 0.05822098f, 0.07123031f, -0.00238825f, 
    -0.08730937f, -0.06370071f, -0.02749579f, 0.06090437f, -0.06467283f, -0.04538924f, 0.07324431f, -0.02702240f, 
    -0.04870893f, 0.03524707f, 0.00571183f, 0.00354250f, -0.13398595f, 0.16164784f, 0.02177706f, -0.02510450f, 
    0.02268515f, 0.03678393f, 0.04507265f, 0.03928129f, 0.00008932f, 0.02977987f, -0.01220828f, -0.11175467f, 
    0.11359712f, -0.01739112f, -0.00361110f, 0.10037751f, 0.07182530f, -0.02920817f, -0.03155103f, 0.01399957f, 
    0.07994302f, 0.02540271f, -0.01265523f, 0.04162597f, -0.06885273f, -0.00279550f, 0.10014338f, -0.04635857f, 
    0.02798388f, 0.06142946f, 0.01524782f, 0.02545651f, -0.04992241f, 0.01322670f, -0.09989963f, 0.02188912f, 
    -0.03867200f, -0.01631654f, 0.02740437f, 0.16278861f, 0.00324710f, 0.07468036f, 0.07790209f, 0.09919997f, 
    0.10619757f, 0.03117295f, 0.05224238f, 0.10727966f, -0.46124101f, 0.07619186f, -0.08109978f, -0.02762887f, 
    -0.06418779f, 0.04155517f, 0.03118947f, 0.07362432f, -0.00207027f, 0.04963656f, -0.03657578f, 0.08154496f, 
    0.15697284f, 0.27679551f, 0.01955854f, -0.14124769f, 0.19910713f, 0.08216521f, 0.03617673f, 0.03080713f, 
    0.15633920f, 0.12165255f, 0.11208264f, 0.00494405f, 0.17803922f, 0.05850829f, 0.06699736f, 0.07399014f, 
    0.03554785f, 0.02746384f, 0.03832689f, 0.04601757f, 0.09160352f, -0.02720946f, 0.02024270f, 0.05592692f, 
    0.27673298f, -0.10880247f, 0.17148976f, 0.02948223f, -0.05615677f, -0.05887107f, 0.06203877f, 0.01962356f, 
    -0.05761254f, -0.06096499f, 0.03108260f, 0.06331423f, -0.31535435f, -0.06299961f, 0.02550839f, -0.21912789f, 
    0.09216452f, 0.11757474f, 0.12355579f, 0.13132544f, 0.11647151f, 0.08734416f, 0.01712202f, 0.05804247f, 
    0.24546872f, -0.10848431f, 0.15747723f, 0.15655534f, -0.06679962f, -0.08798286f, 0.05357940f, -0.03375677f, 
    0.12283609f, 0.08946199f, -0.01521727f, 0.03993743f, 0.11251047f, 0.08124200f, 0.02276339f, 0.00106559f, 
    -0.11192126f, 0.01802279f, -0.09468442f, 0.15787356f, 0.05172366f, -0.08847694f, 0.06956860f, 0.09273615f, 
    0.24296668f, -0.14370644f, -0.02364066f, -0.10359837f, -0.06071642f, 0.04657415f, 0.12781945f, 0.01789326f, 
    -0.01258308f, 0.00040602f, 0.13373066f, 0.13040784f, 0.37892053f, -0.04858887f, -0.21319893f, 0.09731065f, 
    0.05241273f, -0.05258104f, 0.00850137f, 0.01692190f, -0.02171857f, 0.00422284f, -0.01657393f, 0.04017674f, 
    0.00645799f, 0.04962822f, 0.03067196f, 0.06888283f, 0.06621060f, 0.00729219f, -0.05215395f, -0.02898896f, 
    -0.00510782f, 0.07375634f, 0.07826278f, -0.02041542f, 0.04628067f, -0.00479033f, -0.22281881f, -0.03354632f, 
    0.17369518f, -0.03913990f, -0.01038876f, -0.04703961f, 0.13374315f, 0.14512078f, 0.02516966f, -0.05562431f, 
    0.05606675f, 0.01802443f, 0.02596768f, -0.02844542f, -0.00296505f, -0.05168968f, 0.04743407f, 0.11084799f, 
    0.12200548f, 0.02400735f, 0.06822035f, 0.14699657f, -0.17203958f, 0.21385033f, -0.12831494f, -0.21669984f, 
    0.16316783f, 0.06612260f, 0.09968568f, 0.03450748f, -0.00199234f, 0.13435924f, -0.03455278f, 0.01680996f, 
    -0.02166983f, -0.06999646f, -0.08549155f, 0.30277073f, 0.05781283f, -0.04213406f, -0.04437554f, 0.02264336f, 
    0.02645941f, 0.00341444f, -0.00455028f, 0.05827198f, -0.13046417f, -0.18003589f, 0.09711839f, 0.15795888f, 
    -0.04654361f, -0.03160352f, -0.03140349f, 0.07713120f, 0.04783870f, -0.01531105f, -0.00837098f, 0.05620193f, 
    -0.05080131f, -0.05268037f, 0.06587118f, 0.06775209f, 0.02264390f, 0.12362450f, 0.11169273f, 0.04138699f, 
    0.04978904f, 0.06921169f, 0.06588580f, 0.02763370f, -0.13835654f, 0.04710914f, -0.05141826f, 0.05718767f, 
    0.00367132f, 0.10240392f, 0.16213576f, -0.03473459f, 0.02349754f, -0.00611529f, -0.09690718f, 0.11380035f, 
    0.08078665f, 0.10210545f, 0.10699839f, -0.19383267f, 0.14503902f, 0.04460881f, 0.00937271f, 0.11021220f, 
    0.09020130f, 0.18212745f, 0.17667143f, 0.04655658f, 0.15815604f, -0.08015756f, 0.16065770f, 0.16316794f, 
    -0.04532239f, -0.11740221f, 0.03210318f, 0.18021195f, 0.10565475f, 0.02671151f, -0.03669157f, -0.00450877f, 
    0.01147056f, -0.02851555f, -0.00933941f, 0.02348318f, -0.06629140f, 0.06659462f, 0.00985533f, -0.03224928f, 
    0.03487892f, -0.01760842f, -0.07147758f, -0.06725416f, -0.04298937f, -0.02334721f, 0.04444221f, -0.01544742f, 
    0.05555022f, -0.07381073f, -0.05968971f, -0.05789261f, -0.06557883f, -0.01029039f, -0.03059486f, 0.03139457f, 
    0.01492466f, -0.07421567f, -0.00696852f, -0.03041890f, -0.06057766f, 0.04858214f, 0.04087380f, 0.04127140f, 
    -0.05225772f, -0.06045263f, 0.03338341f, -0.02547332f, -0.02685747f, -0.01934819f, -0.04190896f, -0.03557036f, 
    -0.00058882f, -0.02687316f, -0.03027734f, 0.01889689f, 0.00843881f, -0.00635022f, -0.04250956f, -0.00871507f, 
    -0.06948634f, -0.06257648f, -0.05636220f, 0.04143029f, -0.05667705f, -0.05019308f, -0.02289569f, 0.00324444f, 
    0.04589576f, 0.02592599f, 0.04880689f, -0.05892561f, -0.04033863f, 0.03915835f, -0.06695306f, 0.02976036f, 
    0.04902675f, 0.01898724f, 0.01391175f, -0.03306634f, 0.01309917f, -0.04710509f, 0.05815893f, -0.01517700f, 
    -0.02070139f, 0.04045714f, -0.02036620f, -0.06674965f, 0.03646738f, 0.05621981f, 0.03117646f, -0.01465061f, 
    0.05211373f, -0.01666274f, 0.02582484f, 0.03725030f, 0.03685500f, 0.01639679f, -0.06939943f, 0.00909507f, 
    0.03083583f, 0.04663303f, 0.00667060f, -0.03614089f, 0.01021240f, -0.02350667f, -0.02854425f, -0.05807054f, 
    -0.06049916f, -0.06842430f, -0.07001189f, -0.02652293f, -0.01248864f, -0.04865867f, 0.02640812f, -0.00824262f, 
    0.01011176f, 0.00902100f, 0.04690156f, 0.05449820f, -0.03040588f, 0.01987330f, -0.08332826f, -0.08646624f, 
    -0.01680728f, 0.00509616f, -0.06032600f, -0.06418739f, 0.06075317f, 0.00317408f, -0.00197196f, 0.05022458f, 
    -0.05592374f, 0.04603481f, -0.03405824f, -0.02296502f, 0.01553321f, 0.02279421f, 0.06290253f, 0.04465805f, 
    -0.04494823f, 0.04202072f, 0.00758395f, -0.01385345f, -0.01553941f, -0.03001985f, -0.03928044f, -0.04232050f, 
    0.01286860f, 0.05175240f, -0.02473472f, 0.03711319f, 0.03679252f, -0.01119088f, 0.03018468f, -0.02725030f, 
    0.04352893f, 0.00782112f, 0.01845193f, -0.04516125f, -0.02939373f, -0.04652176f, 0.03856652f, 0.04839630f, 
    -0.07538150f, -0.00697139f, -0.07012415f, -0.06713147f, -0.05497124f, 0.03865976f, -0.07057134f, -0.05489391f, 
    0.01449878f, 0.03233926f, -0.05079318f, 0.05099049f, -0.02177911f, -0.04979730f, -0.04534234f, 0.00524865f, 
    -0.04144324f, -0.07617222f, 0.00644471f, 0.01010104f, -0.01344659f, 0.05309960f, -0.06969609f, 0.03748786f, 
    -0.04730034f, -0.00917280f, 0.02322938f, -0.06292557f, 0.03429359f, 0.00667820f, -0.07074849f, 0.05320495f, 
    0.05488786f, -0.00056980f, -0.02934267f, -0.07549255f, -0.01871879f, 0.06658536f, 0.06328305f, 0.00092051f, 
    0.05718195f, 0.06106550f, -0.06267561f, 0.32803914f, -0.03044320f, -0.09669343f, 0.00323576f, 0.17134745f, 
    -0.07971296f, 0.00121408f, -0.03856052f, 0.03945191f, 0.14204697f, 0.15910104f, 0.23523439f, -0.09084075f, 
    0.08361267f, 0.01513529f, 0.14797495f, 0.14333227f, -0.06431065f, -0.07380715f, -0.04411491f, 0.06826227f, 
    -0.37658638f, 0.37446880f, -0.15193249f, -0.10506716f, 0.03631923f, 0.05441837f, 0.00738842f, 0.04819641f, 
    -0.13119113f, 0.01516617f, -0.05572216f, 0.02121916f, 0.02976137f, -0.05206697f, 0.23886648f, -0.10119075f, 
    -0.13061804f, -0.01949684f, 0.01753974f, 0.02821951f, 0.14528158f, 0.05993162f, 0.14181694f, -0.00000292f, 
    -0.08516219f, 0.06264868f, 0.01848407f, 0.01602297f, 0.03505586f, -0.05087838f, 0.00434309f, 0.18645433f, 
    -0.05178514f, -0.01630906f, -0.02046975f, -0.07397863f, 0.02223241f, 0.19352975f, 0.12319712f, 0.01359734f, 
    0.10711981f, 0.04379984f, 0.04791430f, -0.01571312f, 0.05512560f, 0.08040104f, 0.11482923f, 0.04123589f, 
    -0.21585454f, 0.11543068f, -0.17394197f, 0.17826582f, 0.09151141f, 0.14624692f, 0.02405701f, 0.06767662f, 
    0.00034180f, -0.00961449f, -0.01701690f, -0.03569418f, -0.12368397f, 0.03277568f, 0.13321532f, -0.03380872f, 
    -0.05257834f, 0.05830028f, -0.00612917f, 0.07236797f, -0.06750803f, 0.10485067f, -0.09790283f, 0.06362896f, 
    0.11383216f, 0.00605287f, -0.09844682f, 0.21046099f, -0.10486745f, 0.01625724f, 0.07571629f, -0.14048773f, 
    -0.04394705f, -0.00582847f, -0.17006058f, 0.06224786f, -0.04365755f, -0.09896118f, 0.18943542f, -0.01250372f, 
    -0.10722719f, -0.06672200f, -0.07666496f, 0.04908438f, -0.02686678f, -0.17219821f, 0.04140868f, 0.02462753f, 
    0.03809177f, -0.19933559f, 0.04836626f, 0.13410722f, -0.03436276f, 0.04114705f, -0.04474532f, -0.01025556f, 
    0.06073833f, 0.05390962f, -0.12943047f, 0.07122400f, 0.29013741f, 0.02922969f, -0.12267623f, 0.27501345f, 
    -0.00833733f, 0.05619265f, 0.02728399f, 0.01355135f, 0.08576187f, 0.08167255f, -0.05613697f, 0.01445957f, 
    -0.14501540f, -0.16568287f, 0.00585063f, 0.06309465f, -0.02592495f, -0.05408183f, -0.02786475f, -0.06095733f, 
    0.04696187f, -0.05080984f, 0.05462169f, 0.08802249f, -0.09360072f, -0.33709246f, 0.23463587f, -0.10586034f, 
    0.03355251f, 0.03170629f, 0.07518586f, 0.01976463f, -0.00093264f, 0.04309229f, 0.08774864f, 0.12038643f, 
    -0.00743702f, 0.10988539f, -0.04574967f, -0.10042208f, 0.01045031f, -0.03072917f, 0.12891865f, -0.07282441f, 
    -0.04697030f, -0.00095047f, 0.03794754f, -0.05346761f, 0.17031218f, 0.19385079f, 0.00827762f, 0.11260961f, 
    0.06179566f, 0.00353096f, 0.02764426f, 0.01367421f, -0.04119810f, 0.03398180f, 0.00833657f, -0.13687333f, 
    0.08482341f, -0.12807466f, 0.08492313f, -0.11461125f, 0.10933130f, 0.14495637f, 0.05777901f, -0.06775848f, 
    0.02968999f, -0.13374963f, -0.01343436f, 0.09421593f, -0.09109123f, -0.16697863f, 0.22160517f, -0.11906663f, 
    -0.01285702f, -0.08270843f, 0.03243375f, -0.01083463f, 0.19371296f, 0.16416243f, -0.00770155f, -0.05731300f, 
    -0.11394618f, -0.06279360f, 0.07390152f, -0.05110146f, 0.01482881f, 0.02411016f, 0.01159194f, 0.05361360f, 
    0.00172783f, 0.03393314f, 0.05490113f, 0.02205663f, 0.11846829f, -0.05929267f, -0.16095698f, 0.04759891f, 
    0.12045312f, -0.09475915f, 0.02632996f, -0.05287356f, 0.05750512f, 0.05026161f, -0.00506954f, 0.03300305f, 
    0.00722709f, -0.13201797f, -0.15751192f, -0.06844173f, 0.03903054f, 0.09657168f, 0.10340932f, 0.02080872f, 
    -0.01843227f, 0.14491525f, -0.09238362f, 0.15167758f, 0.14645998f, -0.12371662f, 0.00024967f, 0.03721849f, 
    -0.01090695f, 0.08787601f, -0.08094676f, -0.12612414f, 0.03882986f, 0.03093478f, -0.11330680f, 0.02641816f, 
    -0.05165664f, 0.07331222f, 0.09708843f, -0.02152869f, -0.06954090f, -0.09358303f, -0.01018673f, 0.10137139f, 
    0.16289844f, 0.06043525f, 0.08324997f, 0.10850874f, -0.13820985f, -0.07107238f, 0.15463854f, 0.11066731f, 
    -0.06174857f, 0.06616013f, 0.05539837f, 0.02774724f, -0.01892036f, -0.08963334f, 0.17846455f, 0.03970341f, 
    -0.36724916f, -0.04037969f, 0.05135754f, 0.11930111f, 0.01267011f, -0.06390329f, 0.12133156f, 0.18585162f, 
    -0.04662967f, -0.04836091f, -0.02751380f, -0.04242324f, -0.04308638f, -0.01901309f, 0.14742945f, 0.07910968f, 
    0.04332290f, -0.17379397f, 0.17790242f, -0.05997631f, -0.04658984f, -0.00927892f, 0.01931877f, 0.06111438f, 
    -0.12608343f, -0.03376834f, 0.11078455f, -0.00436602f, 0.08876946f, -0.06439453f, -0.10878848f, 0.01595324f, 
    0.00792906f, -0.10864558f, -0.11457073f, -0.01636609f, -0.21718031f, 0.04875631f, 0.09851813f, 0.04209683f, 
    0.07921813f, -0.02893500f, 0.10380871f, 0.03079505f, 0.00905961f, 0.05014046f, 0.00804376f, 0.22814918f, 
    -0.13046697f, 0.04898195f, 0.19771209f, 0.04100033f, 0.02200316f, -0.11049889f, 0.08118423f, -0.00919965f, 
    0.03257778f, 0.15202157f, 0.08085226f, 0.20975322f, -0.42656025f, 0.17792378f, 0.05613779f, 0.15536632f, 
    0.07292748f, 0.06260142f, 0.12331067f, -0.04540044f, 0.15800390f, -0.13440241f, -0.04520489f, -0.06622864f, 
    -0.10953299f, 0.01823783f, -0.09430093f, 0.02672885f, 0.01559896f, -0.00021168f, 0.00405751f, 0.16116332f, 
    -0.04606222f, 0.07810359f, -0.03521864f, 0.04918814f, 0.03766153f, -0.03932068f, 0.05978452f, -0.10321730f, 
    0.07256278f, 0.08475745f, -0.11972115f, -0.03745148f, 0.15318616f, -0.13035560f, 0.00558643f, -0.13436615f, 
    0.28296456f, 0.26067752f, 0.05808420f, 0.17298868f, -0.05386166f, -0.03603386f, 0.04833223f, -0.05436118f, 
    0.11565819f, 0.05382000f, 0.04348848f, 0.09523445f, 0.14527969f, 0.03474130f, -0.05834661f, 0.22057559f, 
    0.02959280f, 0.04183061f, -0.02689992f, -0.02361521f, -0.02450373f, -0.07375288f, -0.05314768f, -0.00306782f, 
    -0.12291413f, -0.02090459f, 0.13158567f, -0.03690521f, -0.07081352f, -0.01967780f, -0.04436683f, 0.12918806f, 
    0.06965508f, 0.02061893f, -0.04436248f, -0.05355576f, 0.11190867f, -0.04926232f, 0.02107191f, 0.16835673f, 
    -0.17297764f, -0.02679911f, 0.02970323f, 0.03914618f, -0.08313166f, 0.02009012f, -0.05888054f, 0.00438939f, 
    0.14220068f, 0.08583822f, 0.18014297f, 0.12345574f, -0.03315877f, -0.15358366f, -0.07071701f, 0.01384364f, 
    -0.11886583f, -0.01944270f, 0.07170768f, 0.10403603f, -0.15615439f, -0.23867962f, -0.11924515f, -0.10799196f, 
    0.04186572f, -0.02775343f, -0.03888204f, 0.00461442f, 0.05607904f, -0.08688025f, -0.01182307f, 0.00968999f, 
    -0.19252791f, -0.18119228f, -0.00963651f, -0.11008330f, 0.07063006f, 0.05059271f, -0.06178046f, -0.09576027f, 
    -0.11275149f, -0.12619610f, -0.06111556f, 0.01811310f, -0.07216072f, -0.18694754f, 0.06679301f, 0.06045215f, 
    0.11144499f, -0.04670399f, 0.01335710f, 0.01076714f, -0.03800485f, 0.07484310f, 0.08596040f, 0.03917733f, 
    0.12046231f, 0.07442056f, 0.11787897f, -0.00104423f, -0.08995244f, -0.06981786f, 0.05107175f, -0.06954806f, 
    -0.00403336f, -0.04469690f, 0.00170185f, 0.09871234f, 0.00385268f, 0.00522780f, 0.17825766f, 0.11769419f, 
    0.01216444f, 0.07046468f, -0.00095655f, 0.15974663f, 0.03360051f, -0.05977924f, 0.02980084f, 0.04837567f, 
    0.01243229f, -0.05900493f, -0.28715175f, -0.11422243f, -0.02839448f, 0.11888267f, 0.02727841f, -0.05156564f, 
    -0.04105952f, -0.02468381f, -0.03951273f, 0.06250414f, 0.23818740f, 0.12025034f, -0.07285403f, 0.04758988f, 
    -0.05249765f, -0.03326552f, 0.05152247f, 0.05120244f, 0.01703444f, 0.10147274f, 0.20413399f, 0.01353927f, 
    -0.07974111f, -0.09109012f, -0.19345140f, -0.08250590f, 0.10793471f, -0.04417374f, -0.01011492f, -0.02742978f, 
    -0.02019791f, -0.19908069f, 0.00902324f, -0.12246878f, 0.04539705f, -0.24952486f, -0.12981312f, -0.03579062f, 
    0.00848458f, 0.23481877f, 0.01531146f, -0.03857509f, 0.07788644f, 0.13374645f, 0.11259568f, 0.13558082f, 
    0.15695085f, 0.33252791f, 0.04187014f, 0.12192138f, 0.12816757f, 0.06537286f, 0.01322914f, 0.03193922f, 
    0.05908113f, -0.04815244f, 0.05590120f, -0.02253423f, 0.03444870f, 0.12866864f, 0.02268445f, 0.07335784f, 
    -0.15409315f, -0.06943211f, 0.12704526f, -0.00903059f, 0.05182261f, 0.05689205f, 0.04351568f, 0.05851496f, 
    0.09388842f, -0.03514558f, -0.07285652f, 0.11833209f, 0.02886716f, 0.04545325f, 0.11623157f, -0.05696218f, 
    -0.01498874f, -0.04331057f, 0.00815913f, 0.14317958f, 0.13486075f, 0.08688094f, 0.11895659f, 0.15779155f, 
    0.18059802f, -0.06790897f, -0.05476907f, 0.06277163f, -0.09657937f, 0.03026057f, -0.09133844f, -0.05799116f, 
    -0.26357329f, 0.17869784f, -0.20432772f, -0.16972272f, -0.08737914f, -0.03427454f, -0.02866161f, 0.13400279f, 
    0.00629023f, -0.01448546f, 0.01274545f, 0.05916348f, 0.10600289f, -0.07086583f, 0.02175803f, 0.17275116f, 
    -0.02297221f, -0.08990537f, 0.10325507f, 0.04925532f, 0.13107786f, 0.09030312f, 0.03337606f, 0.01444883f, 
    0.05969661f, 0.04891557f, 0.00245167f, 0.05686349f, -0.06624646f, -0.03374959f, 0.08692514f, -0.02617267f, 
    0.10933129f, 0.05726283f, -0.08183236f, -0.00330710f, -0.30022705f, -0.01195861f, -0.08755030f, -0.16952474f, 
    0.05494401f, 0.03114894f, 0.10242897f, 0.05749572f, 0.13949572f, 0.00339841f, -0.07897257f, 0.04973407f, 
    -0.49928349f, -0.04987751f, -0.14316168f, -0.09560589f, -0.02544021f, -0.09482161f, 0.06211255f, 0.07850254f, 
    0.04108446f, 0.01456884f, 0.06340908f, 0.10325982f, -0.27074865f, -0.24904941f, 0.08140633f, -0.05576756f, 
    -0.02096834f, -0.05929546f, 0.08558697f, 0.00195379f, -0.00080306f, -0.05174316f, 0.12938084f, 0.11647251f, 
    0.08560180f, 0.23045976f, 0.16539001f, 0.14178161f, 0.02404146f, -0.01815252f, -0.03970585f, -0.00709018f, 
    -0.04780162f, 0.08207624f, 0.07630379f, -0.07001848f, 0.08595067f, -0.03582919f, 0.29279462f, 0.14056665f, 
    -0.09244458f, -0.03853808f, -0.06873591f, -0.07598887f, -0.01996158f, -0.00768860f, -0.12187071f, 0.01449546f, 
    -0.21606620f, -0.24480540f, -0.08667994f, -0.29034010f, 0.08285845f, 0.04895980f, -0.10802794f, 0.08154591f, 
    -0.14437030f, 0.01111192f, -0.01437907f, 0.06695326f, 0.14890696f, 0.08428127f, 0.04631378f, -0.04254237f, 
    0.08084311f, 0.00019339f, 0.08277123f, 0.08266511f, 0.07963543f, 0.18030529f, 0.01809024f, 0.08432324f, 
    -0.00145478f, -0.01245414f, -0.01735791f, -0.10796205f, -0.03775622f, -0.12935217f, -0.08331901f, 0.08308429f, 
    -0.11083896f, 0.19673972f, 0.14676295f, 0.19656889f, -0.37429076f, -0.13495910f, 0.13152455f, -0.02855145f, 
    0.15727511f, 0.08516326f, 0.03523779f, -0.05277486f, 0.13129136f, 0.01007716f, -0.02164170f, 0.04561079f, 
    0.02375721f, 0.09088911f, -0.02410007f, 0.27199370f, 0.08680061f, -0.16471563f, -0.02134465f, 0.08207072f, 
    -0.03390221f, 0.11672688f, -0.05124356f, 0.11572738f, 0.11945870f, 0.09304118f, -0.03782606f, 0.05343844f, 
    -0.04260254f, 0.04154868f, -0.04638707f, -0.02540067f, -0.04468388f, 0.01233282f, -0.09553923f, -0.16027674f, 
    -0.02405420f, -0.05899440f, 0.04403837f, -0.05533332f, 0.02861062f, -0.06672558f, 0.05729076f, -0.03491034f, 
    0.01399131f, -0.02529474f, -0.07663192f, -0.02262158f, -0.02015936f, 0.03161939f, -0.04631382f, 0.03487827f, 
    -0.05742921f, -0.05760374f, -0.00934896f, -0.07090330f, -0.07978340f, -0.00579719f, 0.01252834f, 0.01329718f, 
    0.05965243f, -0.06050509f, 0.06161803f, 0.05563189f, 0.06000692f, -0.05376268f, 0.04763193f, 0.00856683f, 
    0.00210906f, 0.02243869f, -0.06128646f, -0.07398601f, -0.06148992f, 0.00531140f, 0.03858180f, -0.01151354f, 
    -0.06869248f, 0.03675478f, 0.03525027f, 0.04489545f, -0.07481956f, -0.04019764f, 0.05334635f, 0.00931904f, 
    0.00238872f, -0.01698829f, 0.02903770f, -0.06443075f, -0.00056142f, -0.07115613f, -0.01969561f, 0.03781578f, 
    -0.05825262f, -0.06821297f, -0.00886290f, -0.04551179f, -0.07468612f, 0.04824378f, 0.01526772f, -0.02780731f, 
    -0.06027803f, -0.04191670f, -0.06181683f, 0.03714152f, 0.04427273f, -0.02079766f, 0.01297622f, -0.00736935f, 
    -0.04906264f, -0.02128395f, -0.01400722f, -0.01250686f, -0.07981285f, -0.02013029f, 0.02008082f, -0.00297782f, 
    0.00987096f, -0.02280763f, -0.00219755f, 0.05590251f, 0.01839885f, 0.03690106f, 0.04499255f, 0.04295589f, 
    0.05967972f, -0.02895950f, -0.03671177f, 0.00253272f, -0.06781489f, -0.02963971f, -0.05532406f, -0.06440814f, 
    -0.07639606f, -0.01828986f, -0.02361310f, 0.03374512f, -0.06331311f, 0.04606493f, -0.04319439f, 0.04451811f, 
    -0.05865662f, -0.06730318f, 0.00249287f, 0.02348194f, -0.02775239f, 0.00810932f, 0.04729573f, -0.05147793f, 
    -0.06019735f, -0.02701521f, -0.07967553f, 0.05475438f, -0.02069080f, 0.06063970f, -0.07331717f, -0.00980285f, 
    -0.06134318f, -0.02847784f, 0.06089323f, -0.07543778f, -0.04695594f, -0.02403836f, -0.05297107f, -0.03324151f, 
    0.05569588f, -0.07936718f, 0.03311093f, -0.00339189f, -0.03031373f, -0.00544063f, 0.00162413f, 0.05505708f, 
    0.01337027f, -0.02778122f, 0.02824386f, -0.06218098f, -0.02556277f, -0.01972437f, 0.03966253f, -0.06011293f, 
    -0.06189764f, 0.06151675f, 0.06187424f, -0.07080336f, 0.05294537f, 0.00201014f, 0.03665176f, 0.00450898f, 
    -0.06218194f, 0.04078556f, 0.00439663f, 0.04147568f, 0.05240953f, -0.00615307f, 0.04685711f, 0.02573883f, 
    -0.02223714f, -0.06177084f, 0.06180032f, -0.03444026f, 0.02011362f, 0.05249591f, -0.07817084f, 0.04325478f, 
    0.03734675f, -0.02734254f, -0.07042865f, -0.00358188f, -0.02884831f, 0.02050189f, 0.01720501f, -0.01881900f, 
    0.04470822f, -0.07846195f, -0.00847962f, -0.04627682f, -0.07099838f, 0.00978572f, 0.05435035f, 0.01314049f, 
    0.04974317f, 0.04535843f, -0.04560725f, -0.04058724f, 0.03016590f, -0.04503926f, -0.02602821f, 0.02627055f, 
    -0.32832733f, -0.15045311f, 0.12215674f, -0.02289533f, 0.00172347f, 0.12787449f, 0.07352491f, -0.04624759f, 
    -0.09455302f, -0.05736285f, -0.00318284f, 0.06562728f, 0.02512871f, 0.10530146f, 0.12243954f, 0.01110022f, 
    0.05420899f, -0.09002488f, -0.07280385f, -0.02710224f, 0.05484417f, 0.20009296f, 0.05441287f, -0.02819787f, 
    -0.11791227f, 0.01788173f, 0.06448314f, -0.20215222f, 0.00049652f, 0.00672321f, 0.03840495f, 0.06462318f, 
    -0.06239236f, 0.04139145f, -0.02008545f, 0.00824668f, 0.14840645f, 0.09853522f, -0.03248492f, 0.09820645f, 
    0.08809815f, 0.03146290f, -0.04955254f, -0.05681369f, 0.11497091f, 0.10385409f, -0.05523863f, 0.08280427f, 
    -0.26299021f, -0.03268411f, -0.14396159f, 0.07801569f, 0.12750393f, 0.05252599f, 0.09906963f, 0.05721181f, 
    -0.00296873f, 0.10708316f, -0.14261684f, 0.02039978f, 0.33215305f, 0.16632660f, 0.11530355f, -0.08602063f, 
    -0.04997384f, -0.02415543f, -0.14416783f, -0.15178412f, -0.05193216f, 0.06832849f, -0.10447507f, 0.00653302f, 
    -0.12110257f, 0.14691323f, 0.21785510f, -0.04300405f, 0.04840313f, 0.02256757f, -0.03736247f, -0.05442795f, 
    0.20689256f, -0.02859909f, 0.05881108f, 0.02326106f, -0.03476152f, -0.04130164f, -0.02630940f, 0.13038982f, 
    -0.17638153f, 0.04922702f, 0.02169322f, 0.03553345f, -0.12201782f, -0.17445232f, 0.08310885f, 0.04244660f, 
    0.04038463f, -0.12877466f, -0.01195095f, -0.05807788f, -0.03754612f, 0.01643230f, -0.06848333f, 0.22790505f, 
    -0.08517071f, -0.02299600f, 0.07203647f, -0.21301617f, 0.10501944f, -0.14353102f, 0.06382956f, 0.13713805f, 
    -0.08978446f, -0.07495216f, 0.08398129f, 0.00058171f, -0.02132694f, 0.06997956f, 0.01360882f, -0.04134477f, 
    -0.01441955f, -0.01289043f, 0.06422632f, 0.11875524f, 0.00917160f, 0.04377068f, -0.07141002f, 0.07160658f, 
    -0.03291148f, 0.07171667f, -0.10205588f, 0.04948074f, -0.21904543f, -0.09665535f, 0.09443136f, -0.04102807f, 
    0.08908216f, 0.09168516f, -0.01104492f, -0.12249945f, 0.04366142f, 0.02776955f, -0.02005041f, 0.18045036f, 
    0.03279920f, -0.07071809f, 0.01238134f, -0.03425791f, -0.00845368f, -0.04925935f, -0.08029795f, -0.05942380f, 
    0.01168244f, 0.07438851f, 0.14628543f, 0.10860219f, 0.07129803f, 0.09248265f, -0.01746884f, 0.03384611f, 
    0.05075358f, -0.07157710f, -0.02903552f, -0.07908833f, 0.14368075f, -0.12693463f, -0.03314320f, -0.13159196f, 
    -0.21911252f, 0.01951382f, 0.02189657f, 0.13637437f, -0.02961597f, -0.09096375f, 0.03793574f, 0.06991015f, 
    -0.00696958f, -0.10654711f, -0.12806791f, 0.12462927f, 0.04066200f, 0.14997518f, 0.04128029f, 0.03708139f, 
    0.10335418f, 0.19512939f, -0.13540606f, -0.08332845f, 0.08748982f, -0.14514659f, -0.05448647f, -0.04223462f, 
    0.15890990f, 0.08006666f, 0.00713042f, 0.18580824f, 0.08992529f, -0.15764056f, 0.09326969f, 0.08955941f, 
    0.06899999f, 0.08547760f, 0.05374762f, 0.02310549f, 0.24707866f, 0.16131118f, -0.01182715f, 0.06247104f, 
    0.19193314f, -0.10317801f, 0.12889346f, 0.10133800f, -0.10698120f, -0.00455146f, 0.06556369f, 0.06287839f, 
    -0.56387556f, 0.20673259f, 0.04649011f, -0.00523308f, 0.06919620f, 0.05116154f, 0.01380823f, -0.06213298f, 
    -0.16218390f, 0.02234952f, 0.00852329f, 0.04921596f, 0.05011866f, 0.07900364f, 0.16027452f, -0.03057610f, 
    -0.19663316f, -0.06101875f, 0.03978740f, 0.10976021f, 0.01786332f, 0.02163360f, -0.00825577f, 0.11988725f, 
    -0.07226065f, 0.28033692f, 0.05749229f, 0.03715502f, 0.02315225f, -0.02328685f, -0.06400550f, 0.12413371f, 
    0.02274286f, -0.08402930f, 0.02925893f, -0.00915537f, 0.32730338f, -0.13233948f, 0.00133692f, 0.04174480f, 
    -0.13165808f, 0.04083137f, -0.06053765f, 0.00890264f, -0.11706064f, 0.02537570f, -0.07130559f, -0.01165094f, 
    -0.17853470f, -0.11469159f, 0.14568268f, 0.17621139f, -0.08284450f, 0.13988003f, -0.00129027f, -0.04240828f, 
    -0.09127819f, -0.05888415f, -0.13609436f, 0.05081880f, 0.03262697f, -0.00241563f, 0.36391836f, 0.18691526f, 
    -0.08108640f, -0.08165096f, 0.02692887f, -0.03749194f, -0.05781831f, -0.06198936f, 0.06376937f, 0.02035828f, 
    0.03092651f, -0.10390547f, -0.02638219f, 0.00829185f, -0.06843961f, -0.00066930f, -0.05732574f, -0.03229080f, 
    0.02917101f, 0.02142669f, 0.01870543f, 0.01106491f, -0.15932634f, 0.04062629f, 0.17878433f, 0.02192508f, 
    0.03051258f, -0.03830826f, 0.07131502f, 0.02209303f, 0.00231471f, -0.05949724f, -0.03820146f, -0.09580259f, 
    0.22841252f, -0.20037614f, -0.09957721f, 0.15905033f, -0.11990573f, 0.03087873f, 0.01145606f, -0.01772312f, 
    -0.03030576f, -0.08718163f, 0.01446414f, 0.07243355f, 0.06100380f, 0.04852793f, -0.11841352f, 0.02778728f, 
    0.01684154f, 0.01270664f, 0.10550075f, 0.01839373f, 0.07337677f, 0.03833158f, 0.06514388f, -0.09218144f, 
    0.06474034f, -0.18916649f, -0.17901246f, 0.27546215f, -0.05336989f, 0.01493507f, -0.07332640f, -0.11816065f, 
    0.02530251f, -0.19671322f, -0.10079025f, -0.19400270f, 0.10222479f, -0.22547871f, -0.07152446f, -0.10405418f, 
    -0.04315681f, 0.00498615f, -0.01817637f, 0.06666800f, -0.01928055f, 0.16162434f, 0.17576440f, 0.05883000f, 
    0.25313053f, 0.19711713f, -0.01295819f, -0.01512392f, 0.06903383f, 0.02630184f, 0.09897580f, -0.02327741f, 
    0.01444655f, -0.00822946f, -0.11862676f, 0.01984583f, -0.12374549f, 0.20063034f, -0.00800213f, 0.12121372f, 
    0.02807999f, -0.05218895f, 0.18210962f, -0.04505052f, 0.00299310f, -0.01172927f, 0.00936365f, -0.06576489f, 
    0.27076048f, -0.08273989f, 0.16229346f, 0.00556893f, -0.09056160f, -0.04775843f, 0.04144312f, 0.06728788f, 
    -0.00195023f, -0.10278642f, -0.03671815f, -0.01215773f, -0.20386100f, -0.16833991f, 0.13828309f, -0.15133381f, 
    0.06464019f, -0.04244261f, 0.11477544f, 0.04072283f, 0.09448822f, 0.08590310f, 0.05597980f, 0.04808431f, 
    -0.07704996f, 0.14297326f, 0.10357320f, 0.01508741f, 0.07141978f, 0.04092241f, -0.09309460f, -0.00989759f, 
    0.00300976f, 0.07735615f, -0.03630625f, -0.10330673f, 0.37259895f, 0.05805309f, 0.11584266f, -0.12876232f, 
    -0.05881517f, -0.02467673f, 0.01550114f, 0.08996038f, 0.03307643f, -0.09772456f, -0.00132174f, 0.14034387f, 
    -0.00417682f, 0.18869232f, -0.05963813f, -0.09601519f, -0.04957904f, -0.10192806f, -0.01455093f, 0.14952429f, 
    0.08914948f, 0.08271803f, -0.03563586f, 0.00639852f, 0.48812926f, -0.24748816f, -0.14186895f, -0.04123858f, 
    0.04552909f, 0.06659855f, 0.22267164f, 0.00271718f, -0.00916227f, 0.05499789f, 0.03270546f, 0.03988280f, 
    -0.17843917f, -0.06648467f, 0.05925888f, 0.20943573f, 0.11352541f, -0.01590387f, 0.01122241f, 0.08114528f, 
    0.05794393f, 0.02671570f, 0.13598059f, 0.03922658f, 0.10818120f, 0.01932308f, -0.09845111f, -0.04158542f, 
    0.03254984f, 0.00690511f, 0.07105866f, -0.06065968f, -0.03280764f, 0.07827700f, 0.09164029f, 0.01614921f, 
    -0.12180976f, -0.06873183f, -0.10573497f, 0.09250401f, -0.08828618f, 0.08284833f, 0.00917749f, 0.15185320f, 
    0.08561101f, 0.07108166f, 0.08631376f, 0.02880237f, -0.17706649f, 0.27470127f, 0.00540848f, 0.01787097f, 
    0.07410473f, 0.01593040f, 0.17359254f, 0.05902755f, 0.09200224f, 0.01693613f, -0.01678391f, 0.04130974f, 
    0.08194990f, -0.15971039f, -0.16430664f, 0.18495156f, 0.12233023f, 0.08084792f, -0.08225208f, -0.00259210f, 
    0.00323737f, -0.06559262f, -0.06981791f, 0.17055747f, 0.10411993f, -0.03235446f, -0.01785526f, 0.12895699f, 
    -0.06643997f, -0.10100043f, -0.07254007f, 0.02382691f, -0.00989253f, -0.09467264f, -0.01536539f, 0.12242500f, 
    0.10541236f, 0.00373888f, -0.08241739f, 0.01276549f, 0.18997912f, 0.12666771f, 0.04010019f, 0.03277291f, 
    0.04642026f, 0.04639057f, 0.14099197f, 0.18722717f, 0.18578887f, 0.10682759f, -0.06171509f, -0.17953880f, 
    0.02325716f, 0.01218533f, 0.02680687f, 0.00263414f, 0.03585950f, 0.06910627f, 0.10943072f, 0.20302342f, 
    0.00209464f, 0.05135956f, 0.17159796f, 0.05335643f, 0.04611168f, 0.03663827f, 0.01573320f, 0.05087260f, 
    0.08092520f, 0.10845373f, 0.09257318f, 0.16721617f, 0.22991392f, 0.15872647f, 0.01829560f, 0.19446215f, 
    -0.06367386f, -0.14021215f, 0.11985197f, 0.11722232f, 0.01624265f, -0.14540349f, -0.07134399f, 0.02705416f, 
    0.04244104f, -0.04185697f, -0.00047993f, -0.03933496f, 0.02962702f, -0.06619594f, -0.07306963f, -0.06868970f, 
    0.04150660f, -0.03113026f, -0.03762597f, -0.04428236f, -0.06871638f, 0.06720195f, 0.03416905f, -0.04152091f, 
    -0.00804584f, 0.04496037f, -0.04262764f, -0.07937989f, 0.00433230f, 0.03451609f, -0.00081677f, -0.01548773f, 
    -0.03138595f, -0.01038898f, -0.06428123f, -0.05739434f, 0.01604229f, 0.03340594f, -0.02424259f, 0.00804269f, 
    0.04937150f, -0.07158463f, -0.06503105f, 0.00656865f, -0.05083112f, 0.01752958f, -0.05892612f, -0.05762962f, 
    -0.04612180f, -0.00039511f, -0.03322062f, 0.03896541f, -0.07253058f, 0.04312329f, -0.06875621f, 0.05724229f, 
    0.03659674f, -0.06227854f, -0.06819265f, -0.05604552f, 0.00080578f, -0.04405456f, 0.05448030f, 0.05781958f, 
    -0.04686318f, 0.02108835f, -0.03981213f, -0.03990505f, 0.02764506f, -0.06423936f, 0.03436574f, -0.01250419f, 
    -0.05592886f, 0.03188863f, 0.01377687f, 0.02645541f, -0.01432613f, -0.05520158f, 0.04122115f, -0.06134239f, 
    0.03670369f, 0.06318901f, 0.05255313f, 0.03575045f, 0.02339094f, -0.03565535f, 0.02718312f, -0.05541538f, 
    0.04657829f, 0.03261241f, -0.06439204f, 0.06191262f, 0.05330430f, -0.04549854f, -0.04406703f, -0.00503950f, 
    0.02351426f, -0.03897044f, 0.01173167f, -0.06689530f, 0.05618773f, -0.04237766f, -0.03428116f, -0.03903781f, 
    0.04041982f, -0.04039848f, -0.03990994f, 0.00233145f, -0.03121878f, 0.04096198f, 0.06106575f, -0.06100967f, 
    -0.06505094f, -0.06010155f, 0.02487082f, -0.00022721f, -0.02648729f, 0.04745718f, -0.06771151f, 0.06753872f, 
    -0.06608320f, 0.06712051f, 0.05217559f, -0.04149923f, 0.01338178f, -0.00563167f, 0.02723883f, 0.05704487f, 
    -0.06910855f, 0.04431904f, 0.04178743f, -0.03598978f, 0.06150386f, 0.00332769f, 0.04124481f, -0.05398283f, 
    -0.04862282f, 0.00125090f, 0.02357179f, 0.00022063f, 0.02225154f, -0.05780223f, -0.04899306f, 0.02252133f, 
    -0.02677072f, -0.02910761f, 0.02879331f, 0.01916610f, -0.01895454f, -0.04662214f, -0.02916037f, -0.02300923f, 
    0.00929939f, 0.04948624f, -0.06789399f, 0.05220892f, 0.00616252f, -0.07583712f, -0.00218882f, 0.03339723f, 
    -0.07271259f, 0.00054755f, 0.05666152f, -0.02853720f, -0.02210180f, 0.02821923f, -0.05589905f, -0.02268890f, 
    0.05296250f, -0.03436149f, 0.05209325f, 0.00038139f, 0.01792541f, -0.06585512f, -0.06254778f, -0.07942332f, 
    -0.00653740f, 0.02173779f, 0.00088857f, 0.00048699f, 0.03480492f, -0.01055824f, -0.06213514f, -0.00455649f, 
    -0.05392728f, -0.06550831f, -0.06748585f, -0.02204915f, 0.05849305f, 0.00362516f, -0.06123668f, -0.03248743f, 
    0.02360766f, 0.04680745f, -0.07305122f, -0.01684461f, 0.02671077f, -0.03690341f, 0.03536031f, 0.05156843f, 
    0.12215127f, -0.05378679f, -0.03594401f, -0.02520066f, -0.06129795f, -0.05360108f, 0.10792534f, -0.13896792f, 
    -0.02167031f, 0.01208051f, 0.00991221f, 0.15512119f, 0.22434679f, -0.12149620f, -0.03448398f, 0.04636998f, 
    -0.09449372f, -0.02330878f, -0.09877535f, -0.05347642f, 0.00248260f, 0.13448270f, -0.06894591f, -0.08442091f, 
    -0.10984193f, 0.03623325f, 0.02872179f, 0.09339311f, 0.05626756f, -0.04204489f, -0.02719611f, 0.07071514f, 
    0.02885523f, 0.03192886f, -0.06441053f, -0.05664914f, 0.02326206f, -0.08304219f, -0.12401085f, 0.03082084f, 
    -0.03004581f, -0.05782274f, -0.10763142f, -0.03161190f, 0.02456941f, 0.02176575f, -0.12171820f, 0.06646723f, 
    0.19521590f, -0.05023599f, -0.10846940f, 0.09643375f, -0.06092523f, -0.17956179f, 0.13498351f, 0.06538629f, 
    0.08205077f, -0.01175182f, -0.00907517f, 0.07527033f, -0.16321179f, -0.05768646f, -0.13384528f, -0.27821872f, 
    0.00650790f, 0.02397709f, -0.02296824f, 0.04155901f, -0.02829018f, -0.13043118f, -0.00507228f, -0.08547343f, 
    -0.21774174f, -0.19883914f, 0.00214973f, -0.00529501f, 0.00693210f, 0.13951758f, 0.06173659f, -0.04982698f, 
    0.01294671f, -0.01942214f, -0.00493776f, 0.14346382f, 0.04203879f, -0.38448277f, 0.13537765f, 0.11069828f, 
    0.05293883f, 0.11735088f, 0.00478282f, 0.04774725f, 0.00707818f, 0.04365983f, 0.12786320f, 0.02912868f, 
    0.24036907f, 0.14691956f, 0.05738023f, 0.15585433f, 0.01069220f, -0.15694332f, -0.01150275f, 0.05307512f, 
    -0.05793549f, 0.03080810f, 0.05747845f, -0.08004055f, 0.03553590f, 0.14812565f, 0.12028603f, 0.05996263f, 
    0.00473912f, 0.08345471f, 0.01126401f, 0.09522646f, -0.00877994f, 0.17748204f, 0.00222158f, -0.03514981f, 
    0.03062637f, 0.01878393f, -0.16071837f, -0.06159776f, 0.06774466f, -0.00810197f, 0.01896564f, 0.05693260f, 
    -0.12042436f, 0.13363926f, 0.02646903f, 0.07881768f, 0.22821888f, 0.03633732f, -0.06946690f, -0.04772445f, 
    0.01726718f, 0.08101814f, 0.17226009f, -0.00878616f, 0.06048702f, 0.00773556f, 0.02300947f, -0.01099766f, 
    -0.06297524f, -0.01835790f, -0.25012937f, -0.09431468f, 0.08147614f, 0.03451268f, -0.00516579f, 0.10095911f, 
    0.02474658f, 0.04928621f, 0.03629052f, 0.06304771f, -0.20227817f, -0.04870147f, -0.19865884f, 0.06214749f, 
    0.19031936f, 0.14811756f, -0.04566561f, 0.08141632f, 0.10955752f, 0.09310121f, -0.06969339f, 0.09386755f, 
    0.27542683f, 0.29554793f, -0.00936847f, 0.14801618f, 0.09694197f, -0.05129934f, 0.02237237f, -0.01060668f, 
    0.04932866f, 0.07759395f, -0.16339782f, 0.00392684f, 0.08918303f, 0.03897534f, -0.19041219f, -0.15778643f, 
    -0.12228173f, 0.05743818f, 0.15264630f, -0.14647409f, -0.02596059f, -0.00089765f, -0.03395311f, -0.11308087f, 
    -0.09831282f, 0.25048590f, 0.06092475f, -0.11514495f, 0.00324514f, -0.04207982f, -0.05707296f, 0.12081634f, 
    0.01101967f, 0.16817752f, -0.01082586f, 0.02999367f, 0.29539126f, 0.08885946f, 0.08228478f, -0.04151758f, 
    -0.13336210f, -0.02138445f, 0.07738350f, 0.02814176f, -0.09132402f, 0.00252191f, 0.08285648f, 0.04347094f, 
    -0.19603968f, 0.12276429f, -0.02442615f, 0.15284477f, -0.03547192f, 0.03025309f, 0.10646938f, -0.05864540f, 
    -0.01711934f, -0.11718187f, -0.05154371f, 0.10728085f, -0.03381724f, 0.09963326f, 0.03255967f, -0.23136255f, 
    0.01065905f, 0.16614850f, 0.00860151f, -0.02630341f, -0.10535906f, -0.02891004f, 0.04724516f, -0.07891472f, 
    -0.10953248f, 0.05021136f, 0.10493589f, -0.06192954f, -0.01677926f, 0.06003975f, 0.00349877f, 0.03824184f, 
    0.16218375f, -0.00637392f, 0.07602496f, 0.08067634f, -0.03782097f, 0.02583215f, 0.05256154f, 0.16346389f, 
    -0.07804075f, -0.02965021f, -0.06154753f, 0.04698072f, -0.01725813f, -0.02035059f, 0.09399702f, 0.04531512f, 
    0.28713426f, 0.00336471f, -0.03667167f, 0.13882734f, -0.15303680f, 0.09768229f, 0.08291998f, -0.05044615f, 
    -0.11707055f, 0.12669410f, -0.03763953f, -0.09480511f, 0.19029063f, 0.09559307f, -0.02530258f, -0.06160287f, 
    -0.12641479f, -0.03746154f, -0.03215446f, 0.18534236f, 0.00662401f, 0.01277276f, -0.03782127f, 0.01009009f, 
    -0.16782604f, -0.02551620f, 0.13939461f, 0.34353444f, 0.11163866f, -0.06969723f, 0.07007906f, -0.11968854f, 
    -0.01796372f, -0.00415743f, -0.02794746f, 0.06186979f, 0.09184472f, 0.16398679f, -0.05392601f, -0.06635684f, 
    -0.03954813f, 0.03125443f, -0.18641070f, 0.10721443f, -0.00288595f, -0.09643539f, 0.08978960f, -0.03553689f, 
    0.27954668f, 0.00533504f, 0.16527474f, 0.09610025f, -0.04553615f, -0.07209152f, 0.04650918f, 0.01348234f, 
    -0.00199714f, 0.00875252f, 0.13871352f, 0.01339531f, 0.08658769f, -0.01655603f, -0.08105905f, 0.12487456f, 
    0.01656909f, -0.00336728f, -0.01648991f, 0.12265201f, -0.04881028f, -0.07965154f, -0.01135253f, -0.02472841f, 
    0.26068786f, -0.03885951f, -0.09148600f, -0.07435483f, 0.01002877f, -0.04941238f, -0.14797458f, 0.12944680f, 
    0.02893574f, -0.03299074f, -0.17853051f, -0.13443908f, 0.22187178f, 0.10900825f, -0.05699942f, -0.00216066f, 
    -0.04017879f, -0.10585110f, -0.22756654f, 0.13058481f, -0.14122678f, 0.01916655f, -0.01553531f, 0.06701623f, 
    -0.14233641f, -0.07832562f, 0.11730338f, -0.01494434f, -0.06275760f, 0.04599204f, 0.03049896f, -0.00902417f, 
    0.13159417f, -0.01556467f, 0.06808181f, -0.00777449f, 0.00669598f, 0.15149952f, 0.00556793f, -0.31082186f, 
    0.04745954f, 0.09904169f, 0.08398652f, -0.10211227f, 0.01247766f, -0.01609633f, 0.12687324f, 0.13822234f, 
    0.15435755f, 0.18357418f, 0.08987970f, 0.04659209f, -0.04465993f, 0.05006836f, 0.13204820f, -0.09107982f, 
    0.04049455f, -0.01391063f, -0.04342699f, 0.00331105f, 0.20523646f, 0.25106746f, 0.01345792f, 0.10988265f, 
    0.09759595f, 0.03075262f, -0.12481936f, -0.07178213f, -0.18582958f, -0.00136550f, 0.01291129f, -0.06563292f, 
    -0.29573581f, 0.29342553f, -0.08909039f, -0.04935768f, 0.03989653f, -0.14291933f, -0.01301962f, 0.05864945f, 
    -0.03150887f, 0.01023777f, 0.01781187f, 0.04707270f, 0.10982248f, 0.18316992f, -0.06816121f, -0.06126710f, 
    0.06045992f, 0.07090776f, 0.05955806f, -0.06053390f, 0.04575376f, 0.04547533f, 0.01497160f, 0.00126230f, 
    -0.01312547f, 0.11343084f, 0.04785827f, 0.30393627f, 0.10373097f, 0.10443944f, 0.02573620f, 0.01388379f, 
    0.16030148f, 0.01543669f, 0.08303468f, 0.03616968f, -0.27739364f, 0.13193560f, 0.05728472f, -0.07724553f, 
    -0.00258209f, -0.03178373f, -0.07772742f, -0.02587779f, 0.02230745f, -0.05435798f, -0.13899098f, -0.14569230f, 
    -0.16508746f, -0.03804241f, -0.18598770f, 0.13597582f, 0.08664128f, -0.06811158f, 0.02552774f, -0.04608130f, 
    -0.11800008f, -0.02378698f, -0.05510547f, 0.05070158f, -0.00114905f, -0.27767432f, -0.12298075f, 0.10793150f, 
    -0.06481764f, -0.03039850f, -0.15500247f, -0.02666541f, -0.00128455f, -0.01054892f, -0.06758064f, 0.11694417f, 
    0.12439457f, 0.14796744f, 0.14286688f, 0.19452991f, 0.11325657f, -0.04395574f, -0.04629353f, -0.04566733f, 
    -0.02113306f, -0.03947386f, -0.03227541f, 0.13274795f, 0.22675315f, 0.00156873f, 0.14135531f, 0.07720225f, 
    -0.10831103f, 0.05260282f, -0.10775064f, -0.00861553f, 0.08069930f, -0.02608954f, -0.05670396f, 0.03738810f, 
    0.08564916f, -0.11747520f, 0.00263554f, -0.03718263f, -0.07949822f, -0.11306334f, -0.09168268f, 0.00075919f, 
    0.00498216f, 0.00305102f, -0.04051045f, 0.03720319f, 0.30822349f, 0.21225064f, 0.11449549f, -0.01429035f, 
    0.00777964f, -0.17038032f, -0.02961591f, -0.02169754f, -0.01677278f, 0.23245896f, -0.07593188f, 0.12997822f, 
    0.31219420f, 0.01234792f, -0.26240119f, -0.10030799f, 0.15676564f, -0.10898172f, -0.11129145f, -0.01845841f, 
    -0.07698120f, -0.01782947f, 0.10138969f, 0.06725058f, 0.40267396f, -0.02312105f, 0.06285266f, -0.16089649f, 
    0.01067689f, -0.03986887f, -0.17459264f, -0.01066224f, -0.01200294f, 0.12274732f, 0.01751316f, 0.04779690f, 
    -0.22277851f, 0.02382389f, -0.05416650f, 0.03826147f, 0.11503013f, -0.04905463f, 0.00913771f, 0.10250206f, 
    -0.03273759f, -0.00313040f, 0.06756569f, -0.00503442f, 0.15381494f, 0.29904887f, 0.09319224f, -0.00561173f, 
    -0.03100244f, 0.00447887f, -0.03423420f, -0.08013315f, 0.06507401f, -0.12512584f, -0.10107214f, -0.10671578f, 
    0.15331632f, 0.26004839f, 0.09588725f, 0.25867414f, -0.04086288f, -0.06044521f, -0.00568841f, 0.14564356f, 
    0.02516558f, -0.07275215f, -0.01694903f, -0.04393103f, 0.26078767f, 0.29830065f, 0.06060537f, 0.18415335f, 
    -0.04086054f, -0.01204747f, 0.01931725f, -0.06354462f, -0.05466538f, -0.04484961f, 0.02808720f, 0.03928576f, 
    -0.08001921f, -0.11877944f, 0.08848823f, -0.12681012f, -0.16015281f, -0.02249904f, -0.06866009f, 0.16576557f, 
    -0.12940249f, -0.08789413f, -0.04569916f, -0.08022423f, 0.20488797f, -0.05841945f, 0.00896896f, 0.23542678f, 
    0.06998792f, 0.09937884f, -0.05850450f, 0.07152904f, -0.10439764f, 0.11062162f, -0.11433214f, 0.00399351f, 
    0.05044831f, 0.07341744f, 0.23200741f, 0.35269701f, 0.22116441f, 0.00042462f, -0.06779539f, 0.07506431f, 
    -0.19479387f, -0.01595922f, -0.11734146f, 0.14204103f, 0.01620247f, 0.09385718f, -0.04029839f, 0.00398947f, 
    -0.01741021f, -0.04396059f, -0.12685460f, 0.06497456f, 0.05513232f, 0.03384423f, -0.04758561f, -0.00677520f, 
    0.01629902f, 0.08182608f, 0.06550889f, -0.22512981f, 0.07093702f, 0.11388618f, 0.08002428f, -0.02718642f, 
    -0.01040645f, -0.02923604f, -0.05536418f, -0.21251585f, -0.12768140f, -0.10489763f, 0.02319345f, 0.21399459f, 
    0.10235005f, -0.03207119f, 0.04396925f, 0.03401387f, -0.03115879f, -0.04180740f, -0.02247711f, 0.12648576f, 
    0.21875162f, 0.07547643f, 0.05500768f, -0.00772282f, -0.23655516f, -0.04727548f, -0.07323223f, 0.06297089f, 
    -0.05258688f, -0.16773015f, -0.14449561f, 0.21765132f, 0.03793542f, -0.17581896f, 0.09377316f, 0.13866633f, 
    -0.06732295f, 0.08508597f, -0.02454021f, 0.03294212f, -0.07247370f, 0.04388518f, 0.17334978f, 0.16983806f, 
    -0.05936957f, -0.05768442f, 0.00554348f, 0.08262185f, -0.17226313f, 0.10585220f, 0.13154936f, -0.11212116f, 
    0.08544500f, -0.02829846f, -0.07543074f, 0.13659641f, 0.04550984f, 0.08185489f, 0.01133294f, 0.13323493f, 
    0.07740884f, 0.08129904f, -0.00565278f, -0.01409721f, -0.16435921f, -0.07975048f, 0.04168678f, -0.06774728f, 
    -0.00912927f, -0.09475473f, -0.22781910f, -0.04271073f, -0.06718361f, -0.11641098f, 0.06322901f, -0.08598686f, 
    -0.18741783f, -0.30653101f, 0.03235161f, -0.22342499f, 0.14833911f, -0.11073218f, -0.27570242f, -0.17508069f, 
    -0.07710141f, 0.03662753f, 0.01855676f, 0.02382756f, 0.01549072f, 0.05555784f, 0.13299449f, 0.06812041f, 
    0.04431645f, 0.04602004f, -0.00402743f, 0.05792227f, -0.09276961f, -0.18296765f, -0.15880348f, -0.02298713f, 
    -0.09066415f, -0.04836769f, 0.00675316f, -0.05480961f, 0.06741048f, 0.17455401f, 0.06201284f, 0.13340113f, 
    0.05923036f, -0.01244351f, 0.08722673f, -0.02222728f, -0.02792980f, 0.00989324f, 0.12208866f, 0.01138597f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.04026722f, -0.03529416f, -0.01966354f, 0.10451227f, 0.05026651f, 0.08999366f, 0.01255167f, -0.03146150f, 
    0.00896718f, 0.07136734f, 0.03229954f, 0.07404852f, -0.02047509f, 0.02502720f, -0.03849431f, 0.07760791f, 
    -0.00093400f, 0.03633850f, 0.01432431f, -0.06847259f, 0.08743086f, 0.00553361f, 0.06852526f, 0.10353807f, 
    0.08800497f, -0.02425837f, -0.03979166f, 0.03941202f, 0.10519375f, -0.03191060f, -0.02311596f, 0.08094095f, 
    0.06748692f, -0.02348983f, 0.00092876f, -0.00137541f, -0.06584018f, 0.07671744f, 0.04664113f, -0.02541928f, 
    -0.02705882f, -0.02921205f, 0.03995431f, 0.05330989f, -0.04989617f, -0.03235213f, -0.12206020f, -0.00818359f, 
    0.04256379f, 0.00955308f, -0.01696866f, 0.04657271f, 0.07966416f, 0.00306325f, 0.09294711f, -0.04266866f, 
    0.04864030f, -0.01226791f, 0.13480279f, -0.02741511f, -0.00967550f, 0.00739862f, 0.02819767f, -0.04360759f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.05620585f, 0.24364680f, 0.16249152f, 0.10395806f, 0.00263974f, 0.06138256f, 0.09134051f, 0.20645288f, 
    -0.22055873f, -0.11095014f, 0.27434671f, 0.12284079f, -0.16579792f, -0.02135228f, 0.05384371f, -0.04215957f, 
    0.23161983f, -0.17099158f, -0.05707029f, 0.18416841f, 0.11681328f, -0.00182639f, -0.14074831f, 0.27342388f, 
    -0.02847043f, 0.02710325f, -0.06936507f, 0.19255650f, -0.00801938f, -0.08864175f, -0.04632163f, 0.12033547f, 
    0.03882629f, -0.19249843f, 0.21841219f, -0.09016955f, -0.14132948f, 0.13546453f, 0.04764729f, -0.08574923f, 
    -0.08644636f, 0.07767913f, -0.00200093f, -0.09022480f, 0.03396542f, 0.01458612f, -0.06097182f, 0.00351061f, 
    -0.11418197f, 0.02343566f, -0.08390174f, 0.12765691f, -0.22363883f, 0.30942318f, -0.10776319f, 0.06052703f, 
    -0.08148953f, 0.06162251f, 0.12708774f, 0.04957303f, -0.01903866f, -0.20449969f, 0.12915164f, 0.64228302f, 
    0.34335479f, -0.03858081f, -0.16826832f, 0.03557508f, -0.10775970f, -0.27450544f, 0.28372979f, -0.28028318f, 
    -0.04097456f, 0.33595642f, 0.17552476f, 0.06091059f, 0.22056550f, -0.12358973f, -0.15445240f, -0.29984868f, 
    -0.22359043f, -0.20299071f, 0.02832737f, 0.14108080f, 0.31830776f, 0.11811827f, 0.28121054f, -0.18901299f, 
    0.17028897f, 0.06183267f, 0.14349328f, 0.07465526f, -0.12253506f, -0.05123164f, 0.02910168f, 0.12804437f, 
    -0.35278490f, 0.19537903f, -0.13157791f, 0.12545271f, -0.06454036f, 0.36983010f, 0.10336328f, -0.15877104f, 
    0.07604001f, 0.01949751f, 0.00182574f, 0.01810366f, -0.04856652f, 0.02458772f, 0.17275667f, -0.18957062f, 
    0.25213528f, 0.03882326f, -0.03221829f, -0.00522000f, 0.17290139f, -0.06724790f, -0.21629544f, -0.04817578f, 
    0.09513711f, 0.04641990f, 0.04038002f, 0.01961993f, -0.26641804f, -0.04619041f, -0.06791496f, -0.07432637f, 
    0.04699953f, 0.05943757f, -0.09424563f, -0.10048451f, 0.09766904f, 0.08909997f, 0.03857274f, -0.09279308f, 
    -0.04586212f, 0.01133421f, 0.07735259f, -0.03689237f, -0.00819499f, -0.13121887f, -0.06820484f, 0.01582721f, 
    -0.04176495f, -0.11422309f, 0.03104849f, 0.03095967f, 0.02386308f, 0.11199275f, 0.00658623f, -0.02702256f, 
    -0.09074918f, 0.08385402f, 0.02786452f, 0.09354811f, -0.10586646f, -0.00728736f, 0.11024230f, -0.12825453f, 
    -0.07145792f, -0.09874807f, -0.09739104f, 0.09326861f, 0.11189105f, 0.07252473f, -0.02574749f, -0.08395282f, 
    -0.01929974f, -0.02715511f, 0.00860553f, -0.02274706f, -0.04724070f, -0.03766406f, -0.00265834f, -0.12023081f, 
    -0.07814725f, -0.03006765f, -0.03395507f, -0.11515458f, 0.07067611f, -0.02584653f, 0.00675651f, 0.10969969f, 
    0.08523827f, -0.07378238f, 0.05849415f, 0.10659743f, -0.11621182f, -0.00452690f, -0.09336633f, -0.03399622f, 
    -0.11302166f, 0.10443071f, -0.00580222f, -0.00645027f, -0.07011480f, -0.03710568f, 0.03535691f, -0.18429099f, 
    0.02257788f, -0.18853599f, 0.18832533f, -0.09991983f, -0.20137568f, -0.16947198f, 0.04359965f, 0.01614634f, 
    0.17503497f, 0.16383806f, 0.14578436f, 0.23505849f, -0.35143468f, -0.11464497f, 0.17062207f, 0.33900505f, 
    0.19812076f, -0.06133161f, -0.08396178f, 0.29826012f, 0.07288583f, -0.00115902f, 0.05700848f, 0.18862791f, 
    -0.14346911f, -0.11757806f, -0.17848082f, -0.09925262f, 0.01769288f, 0.02816102f, -0.07650480f, 0.03830880f, 
    -0.01985098f, 0.07709385f, -0.02296204f, 0.45741308f, 0.01592218f, 0.10715231f, -0.41613153f, -0.01082791f, 
    0.03017268f, 0.05615452f, 0.01562043f, 0.31234440f, -0.26066917f, 0.21475825f, -0.08919091f, 0.09085381f, 
    -0.16358979f, 0.16860062f, 0.07500533f, 0.04305606f, 0.06814227f, -0.00522997f, 0.14740117f, -0.00996366f, 
    -0.05135591f, -0.06438269f, 0.01508665f, -0.10684863f, -0.06793486f, -0.09243673f, 0.10864883f, -0.02050173f, 
    -0.08904687f, -0.11021961f, 0.01856549f, -0.07696676f, -0.12110800f, 0.07181187f, 0.05046590f, 0.04255563f, 
    0.01763846f, -0.06469537f, 0.00838395f, -0.07844023f, 0.07186374f, 0.00092115f, 0.01931846f, 0.07267949f, 
    -0.08551655f, -0.07926603f, -0.00332004f, -0.09886408f, -0.12707438f, -0.01227073f, 0.11488546f, -0.10580809f, 
    0.08971832f, 0.04527907f, -0.10138288f, -0.06559438f, -0.12278741f, -0.00519468f, -0.03297555f, -0.09978209f, 
    0.03399359f, -0.09598289f, 0.10751829f, 0.02594749f, 0.00475103f, -0.00670690f, -0.08742964f, -0.02240059f, 
    -0.00174659f, -0.10791017f, 0.07900260f, -0.05196077f, -0.10349021f, -0.04452927f, -0.12258481f, 0.11244203f, 
    -0.02440918f, -0.00204086f, 0.01697081f, -0.01275885f, -0.10220426f, 0.08588718f, 0.07226130f, 0.09199651f, 
    -0.01354581f, 0.09255412f, 0.14739165f, -0.11304263f, 0.04092449f, -0.00053387f, 0.04943469f, 0.07226791f, 
    0.11474577f, -0.12988339f, 0.13376047f, -0.37572327f, -0.10202587f, -0.20381226f, 0.00841727f, 0.20339441f, 
    0.32955712f, 0.11264514f, -0.03408831f, 0.35108656f, -0.30650944f, 0.04772481f, 0.03581643f, 0.32724342f, 
    0.01275440f, -0.04384726f, -0.10165448f, 0.05003143f, 0.13255845f, 0.45173234f, 0.04366475f, 0.02754766f, 
    0.06991524f, -0.10472841f, -0.05395035f, -0.02233257f, 0.26802400f, 0.01994109f, -0.08159598f, -0.05868114f, 
    -0.14961991f, 0.10441731f, 0.03670210f, 0.24257924f, -0.02257021f, 0.11562040f, 0.10755251f, 0.00679884f, 
    -0.05869896f, -0.01596602f, -0.08711483f, 0.12010264f, -0.41275349f, 0.11652689f, -0.37867463f, 0.04109792f, 
    -0.05114963f, 0.31979507f, 0.14261611f, -0.09537752f, 0.01338495f, 0.30121833f, -0.07034359f, 0.27428430f, 
    -0.25480944f, -0.40912881f, 0.21557133f, -0.08575441f, -0.09472562f, 0.04461272f, 0.04934854f, -0.20139082f, 
    0.13760920f, 0.09526624f, -0.26745188f, -0.10063587f, 0.20123562f, -0.28423113f, -0.06874862f, -0.10572717f, 
    0.16030295f, 0.13510709f, -0.13963811f, -0.09544732f, -0.30940914f, 0.12394789f, 0.25507024f, -0.08654746f, 
    0.12026862f, -0.01732358f, 0.07724049f, -0.13591932f, 0.27105895f, 0.12200577f, -0.07981509f, 0.04903675f, 
    0.13028814f, 0.13030124f, 0.34787628f, -0.03328758f, 0.21592151f, -0.07271556f, 0.00120432f, -0.16546120f, 
    -0.16715832f, 0.00038961f, 0.04323621f, 0.29294381f, 0.04477439f, -0.02606074f, 0.05226443f, 0.16708107f, 
    0.14808910f, 0.00473166f, 0.01077201f, 0.19823985f, -0.04749595f, 0.17834482f, 0.18023601f, -0.03734012f, 
    -0.05348649f, 0.24299972f, 0.11003996f, 0.05680596f, 0.30867404f, 0.12406454f, 0.21032000f, -0.02218151f, 
    -0.29890198f, 0.19495969f, 0.03718129f, 0.05069368f, 0.08888645f, 0.08668184f, -0.06314533f, 0.14640678f, 
    0.00177268f, 0.06565734f, 0.17096937f, -0.17524993f, -0.01641811f, 0.20963918f, -0.09456346f, 0.32682285f, 
    0.11725315f, 0.15573789f, 0.08974530f, 0.33135021f, -0.22894146f, 0.08520766f, 0.06100745f, 0.20597300f, 
    0.14408529f, -0.00223020f, -0.22435448f, 0.16009016f, -0.04505211f, 0.10772189f, -0.06779605f, 0.17251270f, 
    0.19459526f, -0.03149861f, -0.35492679f, 0.00151392f, -0.04648879f, -0.04449760f, 0.20183028f, 0.00135347f, 
    -0.28198245f, -0.02025027f, 0.02679435f, 0.12030536f, 0.06295011f, 0.09425604f, 0.21888956f, 0.02229550f, 
    -0.07978877f, 0.04007062f, 0.09156838f, -0.15722699f, -0.26922390f, -0.15343672f, -0.18562123f, -0.09880701f, 
    -0.15770207f, -0.10045534f, -0.10163537f, -0.01932431f, -0.11104579f, 0.31380212f, -0.09317701f, -0.28565130f, 
    -0.08421387f, -0.10731027f, 0.15409182f, 0.21102007f, 0.01846033f, 0.10418519f, 0.15463728f, 0.13323863f, 
    -0.14899905f, -0.05482274f, -0.17277439f, 0.02609796f, 0.10986696f, -0.26454234f, -0.22602151f, -0.02009839f, 
    -0.03817115f, -0.20049889f, -0.08323263f, 0.15453392f, 0.19362481f, 0.09223025f, 0.04408069f, 0.11715794f, 
    -0.04921386f, -0.07263800f, -0.24774276f, 0.06484202f, 0.06637792f, 0.10392486f, 0.00463420f, 0.05579815f, 
    0.12903091f, 0.14050241f, 0.43852890f, 0.02058995f, 0.09047543f, 0.38957104f, -0.10733142f, -0.05475032f, 
    0.36691931f, 0.08122927f, -0.10425436f, -0.10103658f, -0.10359071f, 0.10279094f, -0.03638313f, 0.12392966f, 
    0.18365824f, 0.14256963f, 0.09663095f, 0.27334702f, -0.15796892f, -0.07535048f, -0.01775622f, 0.08739590f, 
    0.23612057f, 0.26982883f, -0.02998218f, -0.05666298f, 0.02381097f, -0.07738345f, 0.11560081f, 0.22380590f, 
    -0.07001914f, 0.04635969f, -0.00891748f, -0.01245449f, -0.07134503f, -0.11662282f, -0.02871980f, -0.12071902f, 
    0.04651268f, 0.07251221f, -0.06133993f, -0.05296966f, 0.05180250f, 0.11241551f, -0.12203784f, -0.05932248f, 
    0.10136731f, 0.00427711f, -0.01943895f, 0.04670796f, 0.00835340f, 0.11889642f, 0.08341625f, -0.04746273f, 
    -0.06471585f, -0.01055755f, -0.02506793f, -0.05879150f, -0.09341732f, -0.12449795f, -0.01420921f, 0.03620277f, 
    -0.11668724f, 0.06279521f, 0.00592656f, 0.11055173f, 0.04652295f, 0.01053879f, 0.11339989f, -0.10667527f, 
    0.01439269f, -0.08081807f, 0.02433497f, -0.08353154f, -0.00403723f, 0.05628361f, 0.01266766f, 0.08279921f, 
    -0.11100550f, -0.06827886f, 0.00413020f, -0.02098073f, -0.04885229f, 0.03518382f, -0.09436962f, -0.03214236f, 
    -0.07570483f, 0.00029582f, -0.07696615f, -0.01193933f, 0.05440652f, -0.05715556f, -0.08841310f, 0.02288499f, 
    0.10388827f, -0.08836165f, 0.07702973f, 0.10676140f, 0.07236017f, 0.27013919f, -0.08079939f, 0.33310702f, 
    0.10807582f, 0.06283923f, -0.23003583f, 0.02387379f, 0.07214845f, 0.15868217f, -0.00516212f, 0.11532187f, 
    0.14941791f, 0.00846863f, -0.11641212f, 0.00038101f, 0.36149153f, -0.04666498f, -0.21838765f, -0.08318017f, 
    -0.21072784f, 0.12871961f, 0.02205690f, -0.06425184f, 0.03335094f, -0.03571904f, -0.01239778f, -0.14789775f, 
    0.31319007f, -0.02559669f, 0.34428427f, -0.02263645f, -0.00043948f, -0.10289837f, 0.03585396f, 0.05736740f, 
    0.22028275f, 0.01253733f, -0.00266136f, -0.14057863f, 0.00871606f, 0.01395413f, 0.35070261f, 0.12029383f, 
    0.12605099f, -0.03545732f, -0.10633089f, -0.03014793f, 0.19116832f, -0.02382307f, 0.17380920f, 0.03478577f, 
    0.37888655f, 0.02426878f, 0.01572976f, -0.09264418f, 0.11148624f, -0.15207721f, 0.01356607f, 0.09551034f, 
    0.12972443f, 0.15764233f, 0.23642616f, 0.03310443f, -0.05513230f, 0.12692840f, -0.06983632f, 0.22607854f, 
    0.15975592f, 0.01855326f, -0.19234756f, -0.25356829f, -0.12475532f, 0.29063177f, -0.09680307f, 0.29218030f, 
    0.17107362f, 0.12337495f, 0.07383479f, -0.05729765f, 0.01357492f, -0.00299038f, -0.07848240f, 0.00935199f, 
    0.10568208f, -0.07510660f, -0.04014598f, -0.03150753f, 0.09695095f, 0.11507472f, -0.00600134f, -0.01557336f, 
    0.19252236f, 0.03254495f, -0.00754037f, -0.04400959f, -0.12818225f, -0.08988544f, 0.02864750f, 0.16737607f, 
    -0.14174692f, 0.15635148f, -0.02912594f, 0.02124575f, -0.12185195f, -0.07397021f, 0.17642954f, -0.12784603f, 
    -0.01658114f, 0.21399635f, -0.10360665f, -0.23209320f, 0.04515712f, -0.20467572f, -0.36528900f, -0.04769337f, 
    0.17218442f, -0.15058792f, 0.15017626f, -0.04597969f, -0.10683430f, 0.15488535f, -0.19198675f, -0.07564651f, 
    -0.37147880f, -0.03520327f, -0.28100476f, 0.06542320f, 0.02967506f, -0.03542871f, -0.09376905f, -0.26270968f, 
    0.07063465f, -0.16966006f, 0.23859571f, -0.00103315f, 0.18053757f, -0.00330108f, 0.29744166f, -0.22878204f, 
    -0.16187018f, 0.08431845f, -0.01227393f, 0.02582662f, -0.16210444f, 0.03798113f, 0.30303541f, 0.16469419f, 
    0.30014664f, -0.06949254f, 0.23199491f, 0.11428107f, 0.20347293f, -0.00807448f, 0.11827816f, 0.13721751f, 
    -0.30541766f, -0.14187951f, -0.17973074f, 0.04249460f, 0.20637684f, -0.03725543f, 0.18222307f, 0.08193342f, 
    0.10196614f, 0.13654916f, -0.04616647f, 0.17852521f, 0.01877074f, 0.04429966f, -0.39973754f, -0.12049223f, 
    0.09351110f, 0.05742346f, 0.06316765f, -0.00879671f, -0.04915500f, 0.13586885f, 0.10757814f, -0.11779048f, 
    -0.34502164f, -0.07993157f, 0.24550873f, 0.08517063f, 0.28757012f, 0.13751419f, 0.23435806f, -0.32205248f, 
    0.20814916f, -0.30489171f, 0.15520626f, 0.15096468f, 0.09506103f, 0.01172597f, -0.14429647f, -0.02886701f, 
    0.08506984f, 0.12194025f, -0.17240892f, 0.11332072f, 0.15305090f, -0.13506201f, -0.10092966f, 0.11364727f, 
    -0.16515639f, 0.07866586f, 0.01548914f, -0.16170773f, 0.21250398f, -0.00725521f, -0.01289427f, -0.23224036f, 
    -0.02839434f, -0.06367227f, -0.06771892f, -0.19887012f, 0.03165817f, -0.02373032f, -0.00621090f, -0.07647416f, 
    0.31756285f, 0.04669162f, 0.44728762f, 0.01890238f, 0.05699770f, 0.13852051f, -0.09939450f, -0.04281013f, 
    0.06197944f, -0.06068622f, 0.09197114f, -0.17738441f, 0.07363856f, 0.00055735f, 0.06724060f, 0.23796751f, 
    0.12152598f, -0.00785305f, -0.07886903f, 0.13413709f, 0.21731479f, -0.00066900f, 0.31659719f, -0.01716469f, 
    0.28535011f, 0.00852055f, 0.03842422f, 0.05769678f, 0.27232766f, -0.13909550f, 0.16184276f, 0.13736044f, 
    0.25661725f, -0.03047996f, 0.19368927f, -0.19498433f, 0.03886918f, 0.02216620f, -0.16203290f, -0.00430292f, 
    0.19672188f, 0.09632476f, -0.07849345f, -0.16424496f, -0.17140543f, 0.22217654f, 0.23729883f, 0.18349029f, 
    0.22231616f, 0.13798960f, -0.03263469f, -0.18609504f, -0.22754304f, 0.11020315f, -0.13777262f, 0.19966067f, 
    0.19280107f, 0.11350663f, 0.17408767f, 0.17455545f, -0.04034208f, 0.25376832f, -0.06741080f, 0.11739133f, 
    0.15424487f, 0.04180219f, -0.14372714f, -0.07063441f, 0.14499299f, -0.16458938f, -0.16151756f, 0.23498294f, 
    0.03793060f, 0.07861160f, 0.02053403f, 0.16450012f, 0.11497831f, 0.10256954f, 0.10947137f, -0.15424220f, 
    0.07238314f, 0.05023321f, -0.03251206f, -0.12263481f, 0.09520825f, 0.02876231f, -0.22032054f, 0.09151486f, 
    -0.00829674f, -0.07309303f, -0.07697692f, -0.05165584f, 0.08681280f, 0.13613980f, -0.11648326f, 0.03525480f, 
    0.06706157f, -0.13579093f, -0.06650907f, 0.44108543f, -0.11698963f, 0.23419714f, 0.03812241f, 0.21918868f, 
    -0.26627252f, -0.04745289f, -0.12760565f, 0.00033499f, -0.12165523f, -0.16468327f, -0.01705856f, 0.06358632f, 
    -0.12643106f, -0.05064384f, 0.11197878f, 0.17837670f, 0.39511171f, 0.07156540f, -0.07386643f, 0.10165295f, 
    -0.03425844f, 0.10543162f, -0.21458431f, -0.02973951f, 0.18688571f, -0.22141033f, -0.05062405f, 0.14324328f, 
    0.04264336f, -0.07623968f, 0.02935635f, -0.11738055f, 0.07486132f, 0.28025305f, 0.20816587f, 0.10906652f, 
    0.26598930f, -0.06287679f, 0.09252819f, -0.14120595f, 0.05543502f, 0.05017529f, -0.13449262f, -0.05641369f, 
    -0.05158755f, 0.14940716f, -0.02295956f, -0.10751098f, -0.00226262f, -0.05609073f, -0.01970781f, -0.03587174f, 
    0.14718510f, -0.09485187f, 0.18959117f, -0.05665228f, 0.08626806f, -0.43201560f, -0.14848602f, -0.02079831f, 
    0.16639775f, 0.12271044f, 0.01720879f, -0.02896608f, -0.10806160f, -0.12762077f, 0.01861552f, -0.07947031f, 
    0.05959935f, -0.13031085f, 0.27016667f, 0.05108477f, 0.02618985f, 0.13636389f, -0.03561263f, -0.07415670f, 
    -0.08962481f, 0.21588242f, 0.04149992f, 0.15845565f, -0.27503282f, -0.06600192f, -0.03637348f, -0.03122594f, 
    0.20312105f, 0.06652837f, 0.21716337f, 0.15105157f, 0.19900472f, 0.08369587f, 0.04913331f, 0.00757451f, 
    -0.45984781f, -0.04153236f, -0.52585804f, -0.05541987f, -0.04560218f, -0.28519773f, 0.09622522f, 0.20115967f, 
    -0.22874543f, 0.36901504f, 0.10249643f, 0.21042141f, 0.03735275f, 0.11215987f, -0.01222108f, -0.28034836f, 
    0.15046895f, 0.05191962f, 0.00250919f, -0.20340222f, -0.05258218f, 0.25912482f, -0.23928343f, -0.02833830f, 
    -0.18630834f, -0.00237579f, 0.13121216f, -0.03267635f, 0.17711383f, 0.06328650f, -0.09711853f, 0.12432832f, 
    0.32018325f, -0.15208258f, -0.13851832f, -0.11401251f, -0.07697427f, -0.04932541f, -0.13066617f, -0.27384061f, 
    0.15307038f, -0.10490108f, -0.09538474f, -0.12886928f, 0.12847361f, -0.13038862f, -0.05556359f, 0.00061434f, 
    -0.15560967f, -0.03848248f, 0.18776715f, -0.04293196f, -0.02599314f, -0.06922334f, 0.23378687f, 0.11280528f, 
    0.16985013f, 0.08266369f, -0.00228915f, -0.02184773f, -0.21299472f, 0.12264331f, 0.06353981f, -0.07139272f, 
    0.03141652f, -0.02680273f, -0.05498593f, -0.04421850f, 0.33883959f, 0.37102988f, -0.09268852f, 0.02884591f, 
    0.35723731f, 0.25360930f, 0.03213863f, 0.12654060f, 0.02014318f, -0.00138640f, -0.14914030f, -0.19361053f, 
    0.24763829f, 0.12525304f, -0.05978540f, 0.04089377f, 0.11565576f, -0.20119250f, -0.18544126f, 0.00554174f, 
    0.15099172f, 0.15721227f, 0.24459310f, 0.07382627f, -0.17378585f, 0.17746109f, -0.08281585f, 0.00445493f, 
    -0.35375056f, -0.05904571f, 0.19915436f, 0.24296209f, 0.01877600f, 0.30358803f, -0.09691573f, 0.14060628f, 
    0.24159163f, 0.07671885f, -0.01456106f, 0.20443763f, -0.19103687f, -0.13902640f, 0.34617472f, 0.05888457f, 
    0.33410907f, -0.07472058f, 0.05017462f, -0.19092584f, -0.31074861f, 0.00947865f, -0.13233684f, 0.18965794f, 
    0.12790895f, 0.04765622f, -0.15248197f, 0.24776010f, 0.18243998f, 0.04873646f, -0.09537072f, 0.06761444f, 
    0.10467774f, -0.11364481f, -0.03796885f, -0.06177932f, 0.16489780f, -0.22664231f, -0.04312602f, -0.09861237f, 
    -0.02933614f, -0.31600073f, -0.06933737f, 0.47568464f, -0.05597184f, -0.02037625f, -0.13917102f, 0.16220836f, 
    -0.12596542f, -0.02850099f, 0.08449452f, 0.17001626f, -0.03788528f, 0.07081831f, 0.06482910f, 0.11699935f, 
    -0.10977783f, 0.31602150f, 0.10569051f, 0.11627632f, -0.02487686f, 0.13020916f, 0.11154564f, 0.03762599f, 
    0.21995619f, 0.02928158f, -0.06247630f, 0.17249475f, 0.03327639f, 0.03045879f, 0.10368970f, -0.18865804f, 
    -0.08326375f, -0.03310759f, -0.04481475f, 0.25302613f, -0.07120927f, 0.14014399f, -0.06191213f, 0.01570270f, 
    -0.28959912f, -0.04093202f, 0.09099475f, -0.19464895f, 0.34611169f, 0.11659224f, -0.01051525f, -0.06919096f, 
    0.02331621f, 0.00661612f, 0.22658691f, -0.07458794f, 0.18730587f, -0.10999162f, -0.08292153f, 0.21238708f, 
    -0.14746326f, 0.20078105f, -0.06740717f, 0.11165006f, -0.04129978f, -0.04878925f, -0.03221419f, 0.34524006f, 
    0.13694939f, 0.17880905f, -0.05316318f, -0.20114085f, -0.05623119f, -0.04616696f, -0.03173376f, -0.04810486f, 
    0.02470979f, 0.21341413f, -0.05720395f, -0.23396116f, 0.33592010f, 0.00038626f, -0.10663961f, 0.05463788f, 
    0.15544529f, -0.02556386f, 0.17922413f, -0.12077828f, 0.04212778f, -0.13637325f, 0.01879773f, 0.04622116f, 
    0.29286882f, -0.10503064f, -0.02773382f, 0.08873918f, -0.08330856f, -0.05422016f, 0.21167623f, 0.07991295f, 
    -0.35366517f, 0.24235931f, 0.09176413f, -0.09375962f, -0.13570341f, -0.23739390f, -0.37937415f, -0.09510043f, 
    0.05489005f, -0.37995160f, 0.08420451f, 0.03086477f, 0.44138816f, -0.05292663f, -0.11627557f, 0.07470420f, 
    0.11044263f, 0.10617097f, -0.04091449f, 0.10722453f, 0.02207844f, -0.18609560f, -0.05161957f, 0.10805507f, 
    -0.35834569f, 0.17975880f, -0.15355526f, 0.12407561f, 0.00216989f, 0.47816324f, -0.08688951f, -0.14252007f, 
    0.36083353f, 0.03340594f, -0.07740748f, -0.19600576f, 0.03590790f, -0.02418838f, -0.00327689f, -0.10928141f, 
    0.09069677f, 0.30917019f, 0.03194924f, -0.07565916f, 0.07472139f, -0.20753711f, -0.36232179f, -0.05005039f, 
    0.19561575f, 0.12820961f, 0.24329703f, -0.00073105f, -0.41939983f, -0.18778750f, -0.35273272f, 0.15477180f, 
    -0.30176118f, -0.04213160f, 0.26785862f, 0.06488150f, -0.00839826f, 0.26781440f, 0.02006138f, 0.16578320f, 
    0.16994232f, 0.29895356f, -0.11370391f, 0.20686866f, -0.09364250f, 0.00244287f, 0.13162588f, -0.03388381f, 
    0.16273583f, -0.10996302f, -0.10965132f, -0.11188161f, 0.06016141f, -0.03826173f, -0.08063838f, 0.03547433f, 
    -0.08898182f, 0.11071966f, 0.00083370f, 0.03835995f, 0.03851624f, 0.14924939f, -0.11735102f, -0.09287088f, 
    0.42224744f, 0.09901529f, 0.32612142f, -0.02819313f, -0.03581343f, 0.12295116f, -0.12391958f, -0.28666329f, 
    0.18681833f, -0.27717897f, 0.08210939f, 0.23521128f, -0.02268904f, -0.07162669f, 0.05015809f, 0.34473884f, 
    -0.07548264f, -0.07336449f, -0.06257441f, 0.29523811f, 0.00968679f, 0.00571603f, 0.34008822f, 0.00710982f, 
    0.01173242f, 0.24785358f, 0.08953906f, -0.00237025f, 0.00715301f, 0.13910033f, 0.23283021f, 0.07308946f, 
    -0.09744906f, -0.12429840f, -0.01431327f, 0.06746369f, 0.00966223f, -0.11577314f, -0.05191509f, -0.03917921f, 
    0.00830946f, -0.09292564f, -0.14737979f, 0.07796916f, 0.08893227f, 0.05843145f, 0.00742979f, -0.01079002f, 
    -0.15531959f, -0.09737620f, -0.08427381f, 0.00150511f, -0.08677880f, -0.11824580f, -0.08951693f, -0.09854061f, 
    -0.08475889f, -0.05246140f, -0.08848757f, 0.05422094f, -0.13665517f, -0.11045097f, -0.04748911f, 0.03792208f, 
    -0.08755509f, -0.01070181f, -0.10140712f, 0.01044303f, -0.06636500f, 0.08305727f, -0.14522061f, -0.12437817f, 
    -0.05778774f, 0.07237919f, -0.10886813f, 0.10375311f, -0.11696656f, -0.02318396f, -0.05047301f, -0.03335040f, 
    0.08331005f, 0.05509790f, -0.13037892f, 0.05097042f, 0.07912074f, 0.08725417f, -0.12983496f, 0.05592563f, 
    -0.11921735f, -0.01134699f, 0.05558702f, -0.02762310f, 0.05077327f, 0.05442983f, 0.01560154f, -0.04584378f, 
    -0.09484601f, 0.11567161f, -0.18446362f, 0.16077222f, 0.12743463f, 0.16375957f, 0.05976502f, 0.18238351f, 
    0.18860894f, 0.22855027f, 0.09232618f, 0.21336479f, 0.06901468f, 0.46785086f, 0.20827480f, 0.16366705f, 
    0.03397388f, 0.14036626f, 0.09584083f, 0.11389908f, -0.00027720f, -0.00855922f, 0.19471705f, 0.06443679f, 
    0.08339203f, 0.07524778f, -0.09739703f, -0.07395305f, -0.07365745f, -0.16831192f, 0.07426570f, 0.14529909f, 
    0.00758707f, 0.16495235f, -0.13388503f, -0.09267534f, -0.07810795f, -0.23983306f, 0.30653331f, 0.16376176f, 
    -0.08292042f, -0.14415118f, 0.08935983f, 0.06213984f, 0.08993010f, -0.01729961f, -0.01803500f, 0.09751667f, 
    0.05752613f, 0.07148249f, -0.03641204f, -0.22402228f, 0.17359617f, -0.18225177f, 0.13915071f, 0.00097973f, 
    0.01810085f, -0.26377165f, 0.00599367f, 0.06261741f, -0.15696284f, 0.17676137f, 0.07639476f, -0.50344610f, 
    0.20995598f, 0.33014363f, 0.07512053f, -0.05153871f, -0.01348632f, 0.20800830f, -0.06342708f, 0.02839012f, 
    0.13874438f, -0.00404032f, 0.23046088f, 0.24036188f, -0.32221493f, 0.14794083f, 0.11920649f, 0.02891512f, 
    0.10284573f, -0.23484115f, 0.21558596f, -0.12630287f, -0.12530553f, 0.11645236f, -0.12262725f, 0.28727335f, 
    -0.06446730f, -0.01195529f, 0.17704645f, 0.28849369f, 0.01299709f, 0.04642878f, 0.03675937f, -0.04336483f, 
    -0.25646308f, 0.01921029f, -0.07308032f, 0.09236201f, 0.05367228f, 0.07787636f, 0.09546060f, 0.06624812f, 
    0.07305078f, -0.08079608f, -0.08891046f, 0.17849514f, -0.01736915f, -0.01864803f, -0.24390572f, 0.12759721f, 
    -0.04237572f, -0.07857583f, -0.02997299f, -0.06871603f, 0.08411352f, 0.09961951f, -0.06446099f, -0.06481861f, 
    0.05876386f, 0.05191571f, 0.04893665f, -0.03894472f, -0.30347720f, -0.12039360f, -0.11078963f, 0.31308547f, 
    0.03834043f, -0.14811493f, -0.12270482f, 0.09582963f, -0.06090316f, 0.07852871f, 0.01018006f, -0.12862977f, 
    -0.07357574f, -0.00128525f, 0.02209031f, -0.09784086f, 0.03225390f, 0.15164798f, 0.03248680f, -0.10484164f, 
    -0.10049123f, 0.06789390f, -0.04496370f, 0.08163899f, 0.09708536f, 0.09352538f, 0.01571090f, -0.03812931f, 
    -0.09339871f, 0.10603698f, 0.01343016f, -0.04656626f, -0.01841978f, 0.09041280f, -0.08577520f, -0.10651723f, 
    0.09312238f, -0.12615114f, -0.02158900f, -0.11945412f, -0.05508696f, 0.04339447f, -0.04948328f, 0.03727851f, 
    -0.07842790f, 0.04377568f, -0.11993141f, -0.11494338f, 0.09437865f, -0.02802953f, -0.02665033f, 0.04077464f, 
    -0.04726779f, 0.07944134f, 0.07782255f, -0.01279212f, -0.01670737f, -0.00182728f, -0.14756507f, -0.09278511f, 
    0.03629589f, 0.06779719f, -0.06495647f, -0.06746645f, -0.08531783f, -0.10426322f, -0.01445255f, 0.02190365f, 
    -0.00885567f, 0.08352082f, -0.08113932f, -0.04136148f, 0.01778295f, 0.08755129f, 0.06053417f, 0.10470092f, 
    -0.31085131f, -0.24251652f, 0.06201705f, 0.13417092f, 0.19632289f, 0.07881191f, -0.23695081f, 0.22308043f, 
    -0.18662031f, 0.03234974f, -0.02539828f, 0.20636334f, 0.31612384f, -0.03890473f, 0.25005221f, 0.04723214f, 
    -0.06171313f, -0.06433741f, -0.22246446f, -0.04375292f, 0.05371833f, -0.35339868f, 0.07690749f, 0.19760653f, 
    0.35550708f, 0.17459281f, 0.26307160f, 0.06941431f, 0.05131850f, 0.37195545f, 0.29373875f, 0.18087809f, 
    -0.07780815f, -0.25044194f, 0.08867058f, -0.63463342f, -0.08169007f, 0.10495633f, -0.05777107f, -0.03904612f, 
    -0.03789666f, 0.07485985f, -0.03281989f, -0.04652816f, 0.08949250f, -0.01873410f, 0.44419429f, 0.03356227f, 
    0.17415242f, -0.25855222f, 0.09192116f, -0.12198427f, 0.02461839f, -0.39863858f, 0.10283205f, -0.17788787f, 
    -0.29046622f, 0.05289176f, 0.26006472f, -0.25924689f, -0.03751985f, -0.16366002f, 0.18325281f, 0.16129544f, 
    0.14347757f, 0.11118120f, -0.10818429f, 0.06345145f, -0.12645121f, 0.00403177f, -0.19393522f, -0.04935008f, 
    0.30137283f, 0.13502166f, 0.21061678f, 0.03745956f, -0.49085560f, 0.10851914f, 0.03328736f, 0.21376783f, 
    0.00005352f, -0.08274490f, -0.16756354f, 0.09272192f, -0.01336671f, 0.04405776f, -0.01905174f, 0.04580658f, 
    0.07226142f, 0.07104611f, -0.07612709f, -0.04521234f, 0.04581012f, 0.04621109f, 0.09705145f, -0.20009236f, 
    -0.37468269f, -0.09805547f, 0.11680205f, 0.27921751f, -0.03817154f, -0.04598825f, 0.03887264f, 0.04210626f, 
    0.21622844f, 0.06893084f, 0.09808280f, 0.08979770f, -0.05461071f, -0.00520969f, -0.09033167f, -0.10481970f, 
    -0.27411798f, 0.04511977f, 0.13925740f, 0.09632243f, -0.17388479f, 0.10605517f, -0.16843638f, -0.41619822f, 
    0.35759458f, -0.07958310f, -0.12362163f, -0.00329437f, -0.00893233f, 0.14720885f, -0.07072932f, -0.13725311f, 
    0.10930427f, -0.20867169f, -0.03902778f, -0.03852122f, -0.09154991f, -0.04494486f, 0.28338847f, -0.13626219f, 
    -0.25266835f, 0.05657827f, 0.07306769f, -0.21697433f, 0.03337751f, 0.02849175f, -0.13729301f, -0.06185642f, 
    0.15803580f, -0.11114485f, 0.16076426f, 0.03775656f, 0.21961991f, -0.14390911f, 0.00933218f, 0.10065282f, 
    -0.09876020f, 0.12585750f, 0.15394898f, -0.08608709f, 0.08444448f, -0.01853733f, 0.00991893f, 0.26272959f, 
    0.02446353f, 0.17446721f, 0.06532135f, -0.08184367f, 0.02976582f, -0.06761089f, -0.12654480f, -0.09888288f, 
    0.12811825f, -0.07519615f, -0.03470697f, 0.10236467f, 0.06297402f, 0.16027047f, 0.08346961f, 0.01302985f, 
    0.10812171f, 0.18362959f, 0.12203600f, 0.02585971f, 0.36902139f, -0.18677409f, -0.01092697f, 0.20849724f, 
    0.07065422f, -0.05067644f, -0.12983918f, -0.07842711f, -0.09744619f, 0.07630672f, -0.05343108f, -0.06454598f, 
    -0.05591670f, 0.09614055f, -0.11479608f, -0.13315247f, -0.10428662f, -0.13206166f, 0.08366216f, -0.12531173f, 
    -0.08892088f, 0.06127034f, -0.04170932f, 0.00729606f, -0.12118202f, 0.09071952f, 0.11276751f, 0.09127633f, 
    -0.02631817f, -0.07553026f, 0.10959648f, 0.00264697f, -0.10622469f, -0.12789616f, -0.08756731f, -0.03737056f, 
    0.10275723f, 0.07435396f, 0.00291662f, -0.10273162f, -0.09285662f, -0.08647378f, 0.05019783f, -0.03556356f, 
    0.04660233f, 0.01087943f, 0.01071762f, -0.05580636f, -0.03972521f, 0.01945664f, 0.00976515f, -0.09806602f, 
    -0.04892641f, 0.08912902f, 0.09867445f, -0.05871965f, 0.08320468f, -0.11565448f, -0.08577948f, -0.05172276f, 
    0.03849713f, 0.06769022f, -0.12435090f, 0.03420559f, -0.07510246f, 0.01141953f, -0.10845528f, -0.00322898f, 
    -0.13692926f, -0.09862789f, 0.25060356f, 0.08490868f, -0.07369098f, 0.18502037f, 0.27732915f, 0.33737755f, 
    -0.03304288f, 0.13606994f, -0.18004990f, -0.13658887f, -0.18784061f, 0.07452139f, -0.21536630f, 0.06246350f, 
    0.09088144f, 0.38740191f, -0.02448972f, 0.05941005f, -0.24424954f, -0.10032072f, -0.08511636f, -0.01026754f, 
    -0.03508219f, -0.01041889f, -0.14348212f, 0.08076066f, 0.17297237f, 0.01996261f, -0.00548976f, 0.10918133f, 
    0.10870622f, -0.06243542f, 0.14013511f, -0.01099815f, -0.12708719f, -0.22037780f, 0.02350814f, 0.02591531f, 
    -0.26806587f, 0.07136731f, 0.04475312f, 0.26087332f, 0.12992145f, -0.02608578f, 0.34021521f, 0.05088014f, 
    0.15959944f, 0.15742560f, -0.07239714f, -0.12472014f, -0.11731219f, 0.26708388f, 0.00449184f, -0.10596997f, 
    -0.15072361f, 0.19942696f, 0.01716785f, 0.06102428f, 0.29606107f, -0.16501249f, -0.23730777f, -0.04007734f, 
    -0.00908664f, -0.27649751f, 0.08653004f, -0.08689519f, 0.08079835f, -0.07602742f, 0.29155117f, -0.13209744f, 
    -0.06094135f, 0.14570235f, -0.13605917f, -0.05340289f, 0.12030424f, -0.42005897f, -0.28212878f, -0.22820744f, 
    0.02413525f, 0.10014533f, 0.20159091f, -0.12357278f, -0.02006688f, -0.10016812f, 0.09656918f, 0.00162141f, 
    0.10003248f, -0.08736590f, -0.01209612f, 0.12488272f, 0.10297204f, -0.11840168f, -0.05587181f, 0.15682951f, 
    -0.12200940f, 0.15301242f, 0.22662829f, 0.10476260f, 0.12821466f, 0.23968889f, -0.15207170f, -0.37039134f, 
    0.00531479f, -0.07616893f, 0.00658980f, 0.32601777f, 0.12364857f, -0.02880436f, -0.15069282f, -0.00343200f, 
    0.31510928f, 0.26147622f, -0.03347352f, 0.34128162f, 0.22866850f, 0.02049600f, 0.23522592f, 0.05657145f, 
    -0.01116687f, 0.24828549f, 0.10416321f, -0.07951973f, 0.15577088f, -0.12517723f, -0.17797425f, -0.07669911f, 
    0.34029040f, 0.20768811f, -0.04863032f, -0.28368714f, -0.01543392f, -0.09351894f, -0.06239168f, -0.01250199f, 
    0.05920825f, -0.03528730f, -0.04330129f, 0.15928762f, 0.25234890f, -0.11308860f, -0.04884462f, 0.08160383f, 
    -0.05088677f, -0.15850340f, 0.07500269f, -0.03970134f, 0.32237843f, 0.00786071f, 0.18269199f, -0.16859350f, 
    -0.00795925f, -0.09632400f, 0.03018324f, 0.02479074f, -0.24225575f, 0.19451603f, 0.07645702f, 0.01918066f, 
    0.29148406f, 0.01787952f, 0.27249363f, -0.11217237f, 0.21149148f, 0.35369307f, -0.10987587f, -0.01354125f, 
    0.28888240f, -0.21331306f, -0.09170777f, -0.37499687f, -0.05768769f, 0.00532352f, 0.07498945f, 0.10639392f, 
    -0.12664577f, 0.01312886f, -0.12253897f, 0.19973414f, 0.21081197f, -0.04843403f, 0.09984060f, -0.04035745f, 
    0.30299646f, -0.21752700f, 0.00587816f, 0.01785973f, -0.18659784f, 0.14997509f, 0.15810244f, 0.30705193f, 
    0.06562856f, 0.13878517f, 0.01282535f, -0.00042274f, 0.02345432f, -0.00817456f, 0.21110649f, 0.17763633f, 
    -0.21570580f, -0.07359831f, 0.19437268f, 0.06542675f, -0.16073091f, 0.00596257f, -0.02437978f, -0.08930141f, 
    0.08264784f, -0.05142106f, 0.12489892f, -0.11860755f, -0.14110200f, 0.01401526f, -0.03372829f, 0.10558403f, 
    -0.11803324f, 0.09632932f, 0.17629096f, 0.14681764f, 0.23275757f, -0.17517465f, -0.08728617f, 0.16103809f, 
    -0.36885774f, 0.12026905f, -0.23568417f, 0.09757783f, -0.21978843f, 0.02396924f, 0.04391122f, 0.09267081f, 
    -0.07942863f, 0.13309474f, 0.09602696f, 0.12387773f, -0.07361611f, -0.09631984f, 0.04662323f, -0.10422368f, 
    0.18096073f, 0.24263930f, -0.05356647f, -0.18191788f, 0.15958555f, 0.34364188f, -0.23045035f, 0.00747275f, 
    -0.26508209f, 0.15952912f, 0.14867322f, 0.08907047f, -0.07396450f, -0.01824655f, -0.24953824f, 0.11598201f, 
    0.10390148f, -0.00256385f, 0.09959102f, -0.10349584f, -0.04685774f, -0.14611663f, 0.11559784f, -0.12529927f, 
    -0.11465175f, -0.34024909f, -0.13570169f, 0.16134208f, 0.16739307f, 0.08423799f, -0.30619285f, 0.19594684f, 
    -0.09563485f, 0.30678508f, 0.02566993f, -0.14649637f, -0.21426253f, 0.04969070f, 0.09361620f, 0.01896792f, 
    0.09234620f, 0.10329852f, -0.10582601f, -0.02431267f, 0.21733786f, 0.04032819f, -0.04932027f, 0.29536083f, 
    0.15239109f, 0.23840152f, -0.08971816f, -0.06174053f, 0.06174980f, -0.17722827f, 0.19260862f, 0.32424954f, 
    -0.47838157f, 0.20272616f, -0.00217216f, -0.35756767f, -0.05665830f, 0.10383710f, -0.12195472f, -0.21143624f, 
    0.08085918f, 0.07019890f, 0.00705809f, -0.03261127f, 0.07763977f, -0.02708452f, 0.12422165f, -0.12004340f, 
    -0.12846860f, -0.29193300f, 0.09101556f, -0.10139254f, 0.17924657f, -0.14473641f, -0.19427671f, -0.23114830f, 
    0.03742367f, 0.08229157f, 0.08347802f, -0.08583739f, -0.02910747f, -0.00099573f, -0.11981299f, -0.05140855f, 
    -0.06603063f, 0.01412378f, -0.03619609f, -0.10890287f, 0.06265296f, 0.06032555f, 0.08926462f, -0.06995281f, 
    -0.03096817f, -0.06260356f, 0.02564851f, -0.00293359f, -0.07051840f, 0.10493482f, -0.11384320f, -0.01810788f, 
    -0.10950445f, 0.04979070f, 0.09225892f, -0.09603364f, 0.00660618f, -0.09653606f, -0.05475155f, 0.01140543f, 
    -0.11525512f, 0.07016244f, -0.04172938f, -0.06608318f, 0.03853893f, 0.05587550f, -0.05971073f, -0.05519624f, 
    -0.06158358f, 0.04274747f, 0.02796875f, -0.12094862f, 0.08036390f, 0.00129879f, 0.00601356f, -0.03007228f, 
    0.03524242f, -0.12351862f, 0.00036021f, 0.02125377f, 0.12129353f, -0.09057222f, -0.03182947f, -0.04944770f, 
    0.09774883f, -0.04532351f, -0.04603185f, -0.09102151f, 0.07877336f, -0.07031021f, -0.09071621f, -0.08863626f, 
    -0.03601752f, 0.20329882f, 0.24606358f, -0.11680085f, -0.11081252f, -0.13872278f, 0.32149985f, 0.26654655f, 
    -0.15001807f, -0.06068726f, 0.05967885f, -0.06449282f, -0.04418051f, 0.00570911f, -0.32490781f, -0.03453229f, 
    0.07108847f, 0.16474082f, -0.03900988f, 0.22790295f, -0.00373360f, 0.02863841f, -0.01878716f, 0.05811016f, 
    -0.03080223f, -0.05195884f, -0.12493191f, -0.04403877f, -0.03431584f, 0.10688047f, 0.08517156f, 0.14141659f, 
    0.11432900f, 0.14142910f, -0.11171758f, -0.06453908f, -0.08001094f, 0.22972529f, 0.11308896f, 0.00965070f, 
    -0.27269658f, 0.32796967f, -0.03208160f, -0.21256131f, -0.05311246f, -0.12065060f, 0.33757597f, 0.02060495f, 
    0.16698591f, 0.10001731f, 0.09203959f, -0.13708726f, 0.02308895f, 0.10605889f, -0.21647952f, -0.09876239f, 
    -0.17062816f, -0.09488785f, -0.12298758f, -0.10418407f, -0.18587634f, -0.09915836f, -0.28616378f, 0.27600610f, 
    -0.01344518f, 0.01053244f, -0.05793395f, 0.08986735f, 0.08002502f, -0.05398998f, -0.05050511f, -0.03554564f, 
    -0.02820185f, 0.09491207f, -0.06865828f, -0.12449485f, -0.09056769f, 0.09549884f, -0.06826799f, 0.07899337f, 
    0.08733979f, 0.03472116f, 0.07506330f, 0.05584711f, 0.01762453f, -0.09126464f, 0.00600151f, -0.11303909f, 
    -0.03919518f, -0.10925297f, 0.01958415f, -0.07508655f, -0.09193913f, 0.04259472f, -0.08147110f, -0.05508846f, 
    -0.11805347f, 0.01803495f, -0.06353376f, 0.11268982f, -0.10882972f, 0.03746278f, -0.00378715f, -0.01501174f, 
    0.04748996f, -0.11144309f, -0.00550711f, 0.02253222f, -0.05515489f, 0.07474439f, -0.01664826f, 0.02650525f, 
    0.11142165f, -0.06193142f, 0.05475035f, -0.10317317f, -0.07891899f, -0.05589376f, -0.04770236f, -0.07346738f, 
    0.03963138f, 0.04858297f, -0.09545396f, 0.02998377f, -0.13035829f, -0.07141052f, 0.05303361f, 0.04501006f, 
    -0.13275157f, 0.43149775f, -0.15753226f, 0.16086797f, -0.10209686f, 0.06037876f, -0.00943897f, 0.15606549f, 
    -0.16384616f, -0.06890558f, 0.34519130f, 0.22203706f, 0.15462300f, 0.13438457f, -0.05729739f, 0.20377278f, 
    -0.07080055f, -0.22721791f, 0.07163373f, 0.28237680f, 0.40902853f, 0.00053987f, 0.18079771f, 0.10987373f, 
    -0.03851590f, -0.09684024f, -0.26724932f, -0.04821301f, -0.14861685f, 0.11940576f, 0.11684939f, -0.04863155f, 
    0.14054683f, -0.05990151f, 0.07183906f, -0.06903695f, 0.16777141f, 0.23324652f, 0.00240242f, 0.08647823f, 
    0.07168300f, -0.12650484f, 0.02470728f, -0.34407809f, 0.00057274f, 0.02723375f, -0.01574262f, 0.14440849f, 
    -0.24966012f, -0.05531196f, -0.01739104f, 0.01178201f, -0.27952951f, 0.18726017f, 0.09291850f, -0.02484023f, 
    -0.08267525f, -0.00413040f, -0.11995953f, 0.06702082f, -0.20002803f, -0.06343371f, 0.28377622f, 0.44347632f, 
    0.41932508f, 0.26771140f, 0.04986581f, -0.11685666f, -0.02514125f, -0.08361007f, 0.12410622f, 0.07523672f, 
    -0.24262679f, -0.05248710f, 0.09597401f, -0.04370216f, 0.08456241f, 0.09381250f, -0.25268129f, 0.08999068f, 
    -0.19511876f, -0.19647877f, 0.10355396f, 0.15983285f, 0.33333370f, 0.02703692f, 0.22884686f, 0.11218657f, 
    0.02102825f, -0.11070129f, -0.03129081f, -0.03279216f, -0.29505047f, 0.15608925f, -0.06476905f, 0.20237401f, 
    0.20005162f, 0.20766032f, -0.13682206f, 0.04591553f, 0.20854525f, 0.25466552f, -0.08875906f, 0.17867421f, 
    0.13556522f, 0.27209106f, 0.09557642f, -0.50939071f, -0.12962085f, 0.07395794f, -0.04167084f, -0.09382217f, 
    0.01174592f, 0.15093033f, 0.00197117f, 0.06544073f, 0.06560046f, -0.22977908f, -0.29448715f, -0.06947522f, 
    -0.04856833f, -0.29871443f, 0.14239132f, 0.12397212f, -0.16324256f, -0.01844367f, -0.22158606f, 0.15220381f, 
    -0.08921294f, -0.31975377f, 0.17031725f, 0.36563987f, 0.09048615f, 0.21184701f, -0.04885396f, -0.15331139f, 
    0.08679094f, 0.05323210f, 0.02880615f, 0.19819511f, -0.05312789f, -0.27847311f, 0.14704557f, -0.31191766f, 
    -0.06649915f, -0.07559449f, 0.03736733f, -0.05565490f, 0.31863382f, -0.06885363f, -0.00338430f, -0.03052668f, 
    0.07579289f, -0.12353688f, 0.14632243f, -0.10851727f, 0.36197287f, -0.15252694f, -0.01909530f, 0.06309536f, 
    -0.09514111f, -0.10410716f, 0.27662918f, -0.05715913f, -0.19382106f, -0.09432691f, 0.06592361f, -0.22586615f, 
    0.27436924f, -0.20974657f, 0.03460919f, 0.19452992f, -0.08681303f, 0.12657550f, -0.07012922f, 0.20322782f, 
    0.17833070f, 0.13448776f, 0.03653351f, 0.10446369f, 0.02620228f, 0.32645833f, 0.36840981f, 0.10058620f, 
    0.14457105f, 0.36060566f, 0.15754774f, 0.11909136f, 0.24261215f, -0.16499417f, 0.27971554f, 0.11307587f, 
    -0.17140855f, -0.06204150f, -0.04405165f, -0.09286957f, -0.06095120f, 0.09656997f, -0.00604225f, -0.08869033f, 
    -0.03565837f, -0.02041395f, -0.03372382f, 0.10016165f, -0.01743956f, 0.06524762f, -0.12163908f, 0.05728338f, 
    -0.05435036f, 0.04063130f, -0.13478081f, 0.08035365f, -0.10916859f, 0.07592425f, -0.08003255f, 0.06109486f, 
    -0.10880815f, -0.04663761f, 0.01764315f, 0.05649660f, -0.05387264f, 0.01611256f, -0.11857300f, 0.02536922f, 
    0.01289983f, -0.19544984f, -0.11223111f, 0.04170285f, -0.03728544f, -0.06871671f, -0.04451642f, 0.08360707f, 
    -0.04284687f, 0.01606390f, -0.10018023f, 0.02941124f, -0.11170015f, 0.11245986f, -0.07122620f, 0.03306450f, 
    -0.14661977f, -0.15364908f, 0.00129235f, -0.09581533f, -0.22405131f, -0.03776137f, -0.03525515f, 0.04614250f, 
    -0.01041276f, 0.09832323f, 0.00914529f, -0.02953267f, 0.06709895f, 0.09732336f, 0.08112452f, -0.01597763f, 
    0.56360728f, 0.10392196f, 0.03867413f, -0.32495624f, -0.00133631f, -0.11478826f, -0.14380090f, -0.10654917f, 
    0.15613648f, 0.11832381f, -0.11169523f, 0.21134311f, -0.32237804f, 0.05657487f, 0.18769069f, 0.02981195f, 
    -0.00350559f, -0.03395251f, 0.05415356f, -0.18951267f, -0.07921477f, 0.02657093f, 0.00741515f, 0.01062052f, 
    0.12464964f, -0.10852109f, 0.32222602f, 0.08385878f, -0.36336288f, -0.04569179f, 0.04526688f, 0.16398986f, 
    -0.32102212f, 0.18401703f, -0.38068882f, -0.02442530f, -0.12070953f, -0.00613118f, -0.09271740f, 0.28671241f, 
    0.07407815f, 0.09199707f, 0.03364134f, -0.06103531f, -0.03514450f, 0.04022668f, -0.07555865f, -0.16037831f, 
    0.13563934f, -0.07904588f, -0.07196499f, -0.09019475f, 0.25029182f, 0.10203947f, -0.17416982f, 0.00833612f, 
    0.03478796f, -0.27933395f, -0.16904135f, -0.02672766f, 0.07898624f, -0.12676734f, -0.47877133f, 0.17697707f, 
    0.12696421f, -0.03279540f, -0.06023158f, -0.04667554f, 0.11635088f, 0.06004443f, 0.02386067f, -0.20226924f, 
    0.01804313f, -0.35923412f, -0.05592769f, -0.16113424f, 0.25715548f, 0.02929195f, 0.11979129f, -0.15005468f, 
    -0.10162165f, 0.25955182f, 0.11467575f, 0.23136888f, -0.27904424f, -0.02006698f, 0.12220152f, 0.14988904f, 
    0.07723503f, -0.07750628f, 0.10251740f, -0.00642078f, 0.15170388f, 0.19199535f, 0.05968832f, -0.05324015f, 
    -0.20338936f, -0.02337568f, -0.06768616f, 0.00877307f, 0.10549434f, -0.08691337f, -0.01355514f, 0.26455674f, 
    -0.09879597f, 0.26154312f, -0.04991513f, 0.10383454f, 0.00252394f, -0.09301672f, 0.02674950f, -0.26472953f, 
    0.24707115f, 0.08155334f, 0.09839850f, -0.02210899f, -0.14228298f, 0.32501215f, -0.02424754f, 0.00579246f, 
    -0.23546816f, 0.09998404f, 0.17676213f, 0.11445581f, 0.24980921f, 0.13394982f, -0.01300263f, 0.17833750f, 
    -0.11854755f, -0.06183799f, 0.19217677f, 0.08065213f, -0.00951463f, 0.12536800f, 0.12775239f, 0.13966087f, 
    0.12164568f, -0.01031152f, -0.11104339f, 0.04556581f, 0.09449844f, 0.36638102f, -0.16072765f, 0.14446756f, 
    -0.06760330f, 0.17045066f, -0.10021764f, -0.01245286f, 0.29906905f, -0.05341252f, -0.19518195f, -0.14781140f, 
    -0.09044553f, -0.09090866f, 0.13861455f, -0.23052898f, 0.17697379f, 0.22370863f, 0.00096871f, -0.02525741f, 
    0.13633692f, -0.00709217f, -0.13035133f, 0.01561734f, -0.02199922f, -0.27046961f, -0.03478558f, 0.16876873f, 
    -0.22891168f, 0.24290198f, -0.07022220f, 0.01533317f, 0.06018229f, -0.05797214f, 0.44629452f, -0.06115601f, 
    0.08084378f, 0.17556672f, 0.08101080f, -0.28478649f, 0.06194101f, 0.13661064f, -0.10437076f, 0.08533581f, 
    -0.00639647f, -0.14088388f, -0.04648346f, 0.00831787f, 0.22465879f, 0.11385568f, 0.02313917f, 0.11444853f, 
    -0.03211350f, 0.37466508f, -0.16454709f, -0.35168800f, 0.04034275f, -0.17319044f, 0.06585116f, -0.04452531f, 
    -0.00858605f, 0.13098837f, 0.05469054f, 0.33390197f, 0.25231209f, 0.11351231f, -0.04553111f, 0.03969534f, 
    0.02654176f, 0.07100669f, 0.04799796f, 0.11196609f, -0.37679994f, 0.11261108f, 0.37787375f, 0.09515839f, 
    0.18290775f, 0.03360363f, -0.07673749f, 0.20396875f, -0.08214385f, -0.01817834f, -0.08034592f, 0.15938534f, 
    0.14527324f, 0.12743536f, -0.02079119f, -0.07599076f, 0.12201984f, 0.09813669f, 0.28388983f, -0.11353062f, 
    -0.10113455f, 0.02287106f, 0.01696703f, 0.00311824f, 0.08395553f, 0.01339241f, -0.15866035f, -0.11945666f, 
    -0.04652385f, 0.08336762f, 0.06949117f, 0.05555222f, 0.26163328f, -0.13465053f, 0.11943214f, -0.08620726f, 
    -0.01869527f, -0.19895664f, 0.01172880f, -0.07720370f, -0.25864765f, 0.10038619f, 0.04265488f, -0.28741580f, 
    -0.05410033f, -0.06192764f, 0.28740743f, 0.22077896f, -0.11922923f, 0.24140291f, 0.09035633f, 0.36785623f, 
    0.18825346f, 0.28973326f, -0.04328267f, 0.03100112f, -0.12624353f, 0.29551074f, 0.02245514f, 0.22720377f, 
    0.13710834f, 0.28416455f, -0.05929319f, -0.07739554f, -0.03541378f, 0.01342378f, -0.20568329f, -0.18387757f, 
    0.00695988f, -0.04809486f, -0.00440145f, -0.08902664f, 0.26231763f, 0.24594042f, -0.11139940f, -0.09665281f, 
    0.13752846f, -0.12314419f, 0.11356527f, -0.01293645f, -0.13651371f, -0.37562466f, 0.12094803f, 0.12555304f, 
    -0.11497463f, 0.10676708f, -0.04884680f, 0.35396263f, 0.06280240f, 0.03269331f, 0.36074772f, 0.13904352f, 
    0.10052608f, -0.13417837f, -0.06449063f, -0.17703475f, -0.01113513f, -0.09781418f, -0.02172116f, 0.03663424f, 
    0.22451372f, 0.16481423f, 0.03749991f, -0.07947255f, 0.10882261f, 0.18175162f, -0.03060460f, -0.07608241f, 
    -0.07248883f, 0.09364766f, 0.03754375f, 0.10666374f, 0.07498953f, -0.10601228f, 0.04695436f, 0.06344224f, 
    -0.06209918f, -0.06678388f, -0.02503551f, -0.03473419f, 0.08569556f, 0.08931329f, -0.06574802f, -0.13753882f, 
    0.00195321f, 0.09519781f, -0.10488454f, -0.11040869f, 0.01451705f, -0.11021261f, -0.05734960f, -0.09820641f, 
    0.03741443f, -0.12251875f, 0.06506264f, -0.11100928f, -0.09530591f, 0.01501791f, -0.01043635f, -0.00058728f, 
    -0.07500762f, -0.08527923f, -0.07976840f, 0.03936947f, -0.08115479f, -0.07234843f, -0.00416091f, -0.06847776f, 
    -0.10477574f, 0.03596063f, -0.07848801f, -0.00135759f, 0.05048456f, 0.08894702f, -0.10521902f, 0.02487962f, 
    0.07587341f, 0.05068721f, -0.02438290f, -0.07562082f, -0.10214553f, -0.09270685f, 0.02489595f, -0.05040564f, 
    -0.03799704f, -0.02311525f, -0.08709981f, -0.06001308f, -0.01123783f, 0.05017189f, 0.10219815f, 0.06175908f, 
    -0.05296292f, -0.23145588f, -0.00241679f, -0.07922704f, 0.03309458f, 0.08437745f, 0.01857038f, -0.08637090f, 
    0.17657045f, -0.05569604f, -0.17373626f, -0.27792549f, 0.07453004f, -0.04465114f, 0.10259763f, -0.04016293f, 
    0.07621317f, 0.31957328f, -0.09530391f, -0.03345511f, -0.22235008f, 0.08090335f, 0.19616377f, -0.10285041f, 
    0.03794694f, 0.06770395f, -0.02687889f, -0.07200545f, 0.14689811f, 0.20802344f, 0.00992040f, -0.05556549f, 
    0.28438866f, -0.04956564f, 0.47687921f, 0.10603348f, 0.13689201f, -0.00773262f, 0.02668246f, -0.07753120f, 
    -0.05922526f, 0.04188500f, 0.11740721f, 0.22905037f, -0.07333074f, 0.06395394f, -0.08419215f, 0.16868101f, 
    -0.00983537f, 0.01439583f, 0.08394025f, 0.13444044f, -0.06830307f, -0.18002501f, 0.11295021f, -0.10029372f, 
    0.17576772f, 0.13476065f, -0.04961607f, -0.05982358f, 0.36447734f, 0.22835760f, 0.11975058f, -0.35565248f, 
    0.07359926f, 0.15816768f, -0.28303525f, 0.14176975f, -0.00235108f, 0.16763677f, -0.00701675f, -0.00098471f, 
    0.06141020f, 0.02624132f, 0.22670710f, 0.26718777f, 0.28323916f, 0.39040321f, 0.16873898f, -0.03568850f, 
    -0.21459588f, -0.11143932f, 0.00001428f, 0.07347621f, 0.41814604f, 0.05269987f, 0.14432651f, -0.13649352f, 
    0.10683644f, 0.02129543f, 0.19234429f, -0.09614359f, -0.14492317f, -0.12531105f, -0.09173920f, -0.03393574f, 
    -0.05752405f, 0.08822608f, 0.02088128f, -0.08309676f, 0.07688088f, -0.05892383f, 0.23665024f, 0.33033723f, 
    0.28671578f, -0.07724885f, 0.07882631f, -0.24255183f, -0.09296329f, 0.04814877f, 0.14272717f, 0.00114046f, 
    -0.02957980f, -0.05209688f, 0.04887184f, -0.18732235f, 0.07191908f, 0.00394058f, 0.11063280f, 0.02796460f, 
    0.30551457f, -0.08267502f, 0.01413294f, 0.06838255f, 0.10273731f, 0.10576732f, 0.36373514f, -0.10157160f, 
    -0.11340508f, 0.36912170f, -0.00647822f, -0.05393665f, 0.08220621f, -0.14794362f, 0.00254806f, 0.31530342f, 
    0.07349772f, 0.05249616f, 0.07709865f, 0.09444221f, 0.09889522f, 0.25361437f, -0.03789768f, 0.16098438f, 
    0.26217586f, -0.03066271f, 0.03465746f, 0.28308308f, -0.27571782f, 0.08974565f, 0.12223114f, 0.04101639f, 
    -0.12505460f, 0.04190097f, -0.29885396f, 0.02734461f, -0.23870321f, 0.03522436f, 0.09766921f, 0.14659697f, 
    0.35712001f, -0.02681799f, -0.13550265f, -0.05468462f, 0.09041919f, 0.15069342f, 0.03748046f, -0.15843391f, 
    -0.22410792f, 0.03190532f, 0.01773816f, 0.07357673f, -0.07856971f, 0.01440527f, 0.22945701f, 0.03001238f, 
    0.04249646f, -0.07763332f, -0.10143479f, 0.15607041f, -0.19092025f, -0.16707408f, -0.04510128f, 0.10026293f, 
    -0.12161010f, -0.10669199f, 0.06851375f, -0.11435644f, -0.40397200f, 0.20004588f, 0.03998251f, 0.06167836f, 
    0.08524591f, -0.07764062f, -0.04449353f, -0.14660588f, -0.01124413f, 0.09948017f, 0.19238952f, -0.09833675f, 
    0.16314679f, 0.30959964f, 0.15302688f, 0.00414537f, -0.01735983f, 0.04651257f, 0.17010769f, -0.12459096f, 
    0.05379802f, -0.02287541f, -0.03229740f, 0.12028553f, -0.04940564f, 0.11016012f, 0.15472078f, -0.10157315f, 
    -0.06849097f, 0.06709152f, 0.32815263f, 0.07062811f, 0.06852803f, 0.16525406f, -0.01351484f, -0.01264715f, 
    -0.22979955f, -0.06345098f, -0.24561700f, -0.01045539f, 0.13820508f, -0.16869088f, -0.02213819f, -0.16612794f, 
    0.02887150f, 0.24202564f, 0.01212726f, 0.48382145f, -0.06322937f, 0.04843618f, 0.19853744f, 0.12297224f, 
    0.02881429f, -0.11222205f, 0.04623190f, 0.06630363f, 0.07769335f, 0.23390488f, -0.07403355f, 0.02237885f, 
    -0.11177319f, 0.23043270f, -0.05094431f, 0.09018053f, -0.07881891f, 0.15578133f, -0.01587254f, 0.17585418f, 
    -0.37087053f, 0.04480375f, 0.06196473f, -0.01045579f, -0.06690110f, 0.12415694f, -0.06018665f, 0.09322269f, 
    0.05129006f, -0.20909582f, 0.23972063f, 0.11569607f, 0.15379402f, -0.01586423f, 0.05833731f, 0.17787340f, 
    0.13715453f, 0.25602266f, -0.03863638f, 0.14247020f, -0.20668693f, 0.00912039f, 0.28881401f, 0.26332313f, 
    0.07011422f, -0.01552490f, -0.17598526f, 0.07470375f, 0.12528172f, 0.11088539f, 0.06306545f, 0.04145978f, 
    0.02962790f, -0.19532044f, 0.23996361f, -0.01381236f, 0.05972945f, -0.07298841f, 0.18315589f, -0.18766485f, 
    -0.24081625f, -0.09640453f, -0.08313300f, 0.04315963f, 0.11537366f, 0.09156720f, -0.08197148f, 0.18051524f, 
    -0.06542813f, -0.04113959f, -0.00007636f, 0.33181286f, -0.28204486f, 0.15415479f, 0.48328361f, 0.07362667f, 
    -0.27473280f, 0.17598386f, 0.08996708f, -0.02144533f, 0.15525535f, 0.11361317f, 0.30894282f, 0.03045861f, 
    -0.16304687f, 0.15606962f, 0.31306782f, 0.01921767f, 0.11099326f, 0.24299049f, -0.01849777f, 0.30205166f, 
    -0.00591181f, 0.12719502f, -0.04595245f, 0.14445312f, -0.01881101f, 0.09752282f, -0.06378147f, 0.27829564f, 
    0.17468965f, 0.09587323f, -0.07794352f, -0.19980031f, 0.11625063f, -0.00868879f, -0.02298574f, 0.11718389f, 
    0.02187567f, 0.06141639f, -0.15698329f, 0.07673621f, 0.00223233f, 0.15365036f, -0.02215165f, 0.10211101f, 
    0.49375764f, -0.02423934f, 0.30044869f, -0.07043934f, -0.16031832f, -0.04697435f, 0.03295477f, -0.04222724f, 
    -0.11788894f, -0.12442058f, 0.11771209f, -0.09186638f, -0.07222823f, 0.05947128f, 0.31627113f, 0.23177704f, 
    -0.14654347f, 0.02822771f, -0.01592624f, 0.18380491f, -0.09521777f, 0.16175704f, 0.18454583f, 0.02130320f, 
    0.03074123f, 0.03222938f, -0.14493346f, 0.12635174f, 0.26018062f, -0.08736568f, 0.09359173f, 0.28156000f, 
    0.29573327f, -0.00713304f, 0.18130735f, -0.05012688f, -0.06244256f, 0.16811468f, 0.05895708f, 0.04228348f, 
    0.21745853f, 0.23419954f, -0.01320647f, 0.34109986f, -0.17981267f, 0.23835824f, -0.06300609f, 0.05340031f, 
    0.05202928f, 0.10817911f, 0.16001320f, -0.44622952f, -0.14877805f, 0.09021918f, -0.22330390f, -0.06156194f, 
    0.03312106f, -0.11185198f, -0.01186820f, 0.22627516f, 0.00753546f, -0.08166718f, -0.10176580f, 0.09184061f, 
    0.17632170f, -0.06440900f, 0.36993608f, 0.04100258f, -0.10146365f, -0.00233473f, 0.15958525f, 0.02533325f, 
    -0.11512546f, -0.27589360f, -0.02835349f, -0.24314833f, -0.06013735f, -0.07087859f, -0.06148344f, 0.01396774f, 
    -0.17888838f, -0.17742167f, 0.08936271f, 0.01111694f, 0.32406664f, -0.08195865f, 0.28390813f, -0.01154865f, 
    0.07820739f, -0.01009114f, -0.09286460f, -0.11685827f, 0.23139614f, -0.18284585f, -0.22363906f, 0.09646174f, 
    -0.24227537f, 0.37623298f, -0.07895448f, 0.01617965f, -0.08837023f, 0.05633876f, -0.08726574f, 0.14334464f, 
    0.00405010f, 0.15055573f, 0.40342507f, 0.36264628f, -0.18172540f, 0.18420596f, 0.27743050f, 0.14337617f, 
    0.04019150f, 0.00898329f, 0.21452579f, 0.01121608f, -0.05625958f, 0.00683239f, 0.09385032f, 0.25426838f, 
    0.13580491f, -0.10204351f, 0.11940357f, 0.24009664f, -0.08741227f, -0.30474961f, -0.11573514f, 0.28670317f, 
    -0.14802019f, -0.00292437f, -0.12107070f, -0.09938975f, 0.03735403f, -0.12884350f, 0.37377238f, -0.02479892f, 
    -0.04780295f, -0.33478987f, 0.00991619f, 0.08041356f, -0.01607453f, 0.01792301f, -0.12997679f, 0.03850106f, 
    -0.04591286f, 0.12244577f, -0.04491241f, 0.03532521f, 0.20359647f, -0.12388142f, 0.09907545f, -0.01218655f, 
    -0.07524303f, -0.04881469f, 0.14213820f, -0.02389556f, -0.26104036f, -0.06588896f, 0.14873996f, -0.16216369f, 
    0.40013313f, -0.24382874f, 0.23141704f, -0.25734213f, 0.04805347f, -0.01655794f, 0.09175142f, -0.18212578f, 
    0.24115805f, -0.00310676f, -0.12842585f, 0.12627783f, 0.03095193f, -0.22969452f, -0.09855146f, -0.12167190f, 
    0.06937284f, -0.01045717f, -0.04529507f, -0.31656981f, -0.18446504f, -0.06215271f, 0.20670305f, -0.16506416f, 
    0.08998124f, -0.07213130f, 0.18708894f, 0.18063453f, 0.10403711f, -0.05390371f, -0.02485910f, 0.07643431f, 
    0.02544626f, 0.15438679f, 0.08346803f, 0.11149903f, 0.10688530f, 0.17314318f, -0.11568788f, -0.21925521f, 
    -0.11383941f, 0.06685104f, 0.06252730f, -0.01448632f, 0.06123258f, 0.00875960f, -0.25610694f, -0.01239969f, 
    0.19741128f, 0.08143000f, -0.01776211f, 0.16356176f, 0.25691980f, -0.05732217f, -0.11232228f, 0.03987212f, 
    0.14312883f, 0.18973757f, 0.04520293f, 0.06725831f, 0.19778080f, 0.15465191f, -0.17122895f, 0.03866075f, 
    0.39085516f, -0.17574564f, -0.20340897f, 0.10471537f, 0.05317188f, -0.06824523f, -0.00077048f, -0.05828305f, 
    0.22167490f, 0.17824222f, 0.13100725f, -0.17953184f, 0.11068376f, -0.10148304f, 0.19572814f, 0.01657651f, 
    -0.26785851f, -0.19066861f, 0.10129992f, 0.13054648f, 0.38255313f, -0.08913750f, 0.10459175f, -0.23700538f, 
    0.22278088f, -0.10020509f, 0.34561980f, 0.05564501f, 0.02388992f, 0.16512631f, 0.03127032f, -0.18501259f, 
    -0.24916400f, 0.18504573f, -0.24211338f, -0.05600002f, 0.20523475f, -0.03146032f, 0.14683942f, 0.31076685f, 
    0.40019944f, 0.30056673f, -0.01653551f, 0.06329882f, -0.09852094f, -0.08635618f, -0.06472640f, -0.00723119f, 
    0.19382122f, -0.00483940f, 0.09603924f, -0.22078602f, 0.05141062f, -0.20544949f, -0.35542458f, 0.09253114f, 
    0.35314706f, 0.01948579f, 0.11189311f, -0.01628004f, -0.11754182f, 0.12592271f, 0.14681843f, -0.13557841f, 
    0.25340739f, 0.02832746f, -0.07112353f, 0.07437981f, 0.06467487f, 0.21360078f, -0.25518170f, 0.02442724f, 
    0.27118170f, 0.28710052f, 0.20185077f, 0.03580192f, -0.13240135f, -0.10752054f, 0.52599561f, -0.07106141f, 
    0.06696098f, -0.29687721f, 0.14732195f, 0.10121010f, 0.00012013f, -0.05106153f, 0.15676033f, 0.09421802f, 
    0.22851062f, -0.02129319f, 0.18241771f, 0.00507909f, -0.21854417f, 0.26498508f, 0.10097048f, -0.17046294f, 
    0.11046058f, 0.00833484f, -0.22790864f, 0.11925162f, 0.35164177f, 0.17882130f, -0.03399893f, -0.05241042f, 
    0.53062588f, -0.05456949f, -0.04244808f, 0.32608032f, 0.06211811f, -0.02834371f, -0.26035920f, 0.02788090f, 
    -0.05067605f, -0.01809244f, -0.09423839f, 0.15679292f, 0.01370858f, -0.23751852f, -0.12907921f, -0.10583486f, 
    0.08502117f, 0.24871920f, 0.07857052f, 0.06826431f, -0.13010171f, 0.24833190f, 0.29439375f, 0.17871910f, 
    -0.35951069f, -0.01583572f, -0.11745234f, 0.12409202f, -0.04787336f, -0.07780038f, 0.19777270f, 0.01394343f, 
    -0.16414827f, -0.23405990f, 0.13073893f, 0.04684623f, 0.34697774f, 0.01000708f, 0.00518361f, -0.23275279f, 
    -0.33045000f, -0.00160535f, -0.16710043f, 0.02542495f, 0.23096102f, 0.07079770f, 0.23935756f, 0.00838175f, 
    -0.10490872f, 0.10508975f, 0.10016403f, -0.11130690f, 0.19622476f, -0.06104197f, -0.00301915f, -0.08180946f, 
    -0.04602715f, -0.12294773f, 0.22933821f, 0.08153180f, 0.07060967f, 0.13273668f, -0.16894795f, -0.25152537f, 
    -0.13798203f, -0.11203308f, -0.04847488f, -0.30064234f, 0.01838019f, -0.03125763f, 0.08436925f, 0.22970115f, 
    0.08841708f, 0.10965132f, -0.03991060f, 0.29068685f, 0.07436358f, 0.39027759f, 0.35310456f, 0.02987941f, 
    0.10463511f, 0.03635924f, 0.13584971f, 0.02714453f, 0.13202125f, 0.14752412f, 0.34505948f, 0.40913665f, 
    0.30201456f, 0.05174581f, 0.01614283f, -0.21748494f, 0.10181919f, -0.01305864f, -0.10230431f, -0.16061871f, 
    0.05860440f, -0.07257417f, 0.01315381f, -0.14813322f, 0.26617801f, 0.06884456f, 0.16471373f, 0.08730395f, 
    -0.15867040f, -0.21771830f, 0.10849915f, 0.24189152f, 0.34055677f, -0.08991046f, 0.22106986f, -0.08687969f, 
    0.14784786f, -0.10485938f, -0.06022960f, 0.14606650f, -0.27252528f, 0.19828652f, 0.03321255f, -0.09767764f, 
    0.09940059f, 0.21008232f, 0.05246514f, -0.02412491f, 0.29454583f, 0.40743348f, -0.11672611f, 0.08925471f, 
    0.28206173f, 0.02596023f, 0.06950365f, -0.26930693f, 0.08838895f, 0.01922361f, -0.09939113f, -0.01978875f, 
    -0.08840178f, 0.12365672f, 0.07229776f, 0.13402642f, 0.05075211f, -0.30181372f, -0.18463656f, -0.05238795f, 
    0.22044797f, -0.01135232f, 0.07505367f, -0.03534415f, -0.19168784f, 0.05608635f, 0.05281984f, -0.10288633f, 
    0.08056915f, -0.04997740f, -0.05810210f, -0.08309475f, -0.08097108f, -0.12325434f, -0.10796140f, 0.06812751f, 
    -0.07838469f, -0.00551695f, -0.11647233f, 0.00070389f, -0.11887871f, 0.01281747f, 0.07803449f, -0.12453096f, 
    0.01190839f, -0.05900500f, -0.04500729f, 0.08192757f, 0.05828430f, 0.02875906f, 0.06230872f, 0.04148001f, 
    -0.05148402f, 0.08833513f, -0.07747325f, -0.06654549f, 0.08688581f, 0.07250679f, -0.05840472f, -0.05998153f, 
    0.00936920f, 0.08662891f, -0.03744529f, -0.01781972f, -0.05182900f, 0.09146012f, 0.10446264f, 0.09259818f, 
    0.03428419f, -0.03585601f, -0.12051937f, -0.04482793f, -0.09112360f, 0.00554402f, 0.03476538f, 0.09999601f, 
    -0.11758190f, -0.01405326f, 0.03532900f, 0.04076684f, 0.10070107f, -0.01896927f, -0.11247473f, 0.05767789f, 
    -0.12163012f, -0.04153094f, -0.09077584f, 0.02623281f, 0.07032881f, 0.06131003f, -0.05147707f, -0.12494971f, 
    0.00745566f, -0.01820344f, 0.02815007f, -0.08267806f, 0.12953523f, -0.04710312f, 0.09342873f, -0.08521145f, 
    -0.07216341f, -0.06321183f, -0.00356118f, -0.08667017f, -0.07733419f, 0.08898833f, -0.04867967f, -0.08832797f, 
    -0.03071521f, -0.08039143f, 0.11205295f, 0.06605832f, -0.04969208f, 0.04804053f, 0.07178041f, -0.00861683f, 
    0.02529959f, -0.01089895f, -0.01086578f, 0.07056919f, -0.08111892f, -0.11630257f, -0.02836717f, -0.07514212f, 
    -0.07246108f, -0.04822983f, 0.11813005f, -0.11653437f, 0.03650681f, -0.10513882f, -0.02654312f, -0.03946736f, 
    -0.05988562f, -0.11309340f, -0.02500192f, 0.03712353f, 0.01697475f, 0.06784778f, -0.00492813f, -0.07681818f, 
    0.05096433f, 0.00338678f, -0.04008658f, 0.04113311f, 0.05335050f, -0.09729934f, 0.03114908f, 0.08344949f, 
    -0.06912744f, 0.02084147f, -0.14064558f, 0.11525486f, -0.07269097f, -0.02319380f, -0.05987754f, -0.01146433f, 
    0.17678457f, 0.21526842f, 0.09267413f, 0.16364846f, 0.00149760f, 0.27015069f, -0.05226364f, 0.15379812f, 
    0.22623461f, 0.01280170f, -0.03108004f, -0.00507164f, -0.37135389f, 0.29576474f, 0.07541797f, 0.22231771f, 
    0.19275831f, 0.15544502f, 0.08792739f, -0.07579553f, -0.02642660f, 0.06227990f, -0.38533717f, 0.09963338f, 
    -0.11546995f, 0.02604193f, 0.04834472f, 0.16224782f, -0.18384199f, -0.09169126f, 0.07361273f, -0.00476784f, 
    0.05231050f, -0.04822909f, -0.02276406f, 0.08821980f, 0.07618983f, -0.22590628f, 0.28715059f, -0.00866977f, 
    0.08248292f, -0.21612686f, 0.09031291f, 0.08111263f, 0.05242416f, -0.06225327f, -0.02629511f, 0.21650068f, 
    -0.02781978f, -0.28057694f, -0.11152895f, 0.08530372f, 0.03612961f, -0.11749773f, 0.30191436f, 0.00536553f, 
    0.19415794f, 0.00570516f, 0.05405580f, 0.03691573f, -0.11959331f, -0.14296873f, -0.13114838f, 0.14382191f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.06159740f, 0.07046020f, -0.01766930f, 0.13395154f, -0.08048383f, -0.10594971f, 0.01081589f, 0.11481069f, 
    -0.09462336f, -0.01853961f, -0.04314888f, 0.14322002f, 0.07039865f, 0.13810472f, 0.12057997f, 0.04469288f, 
    0.04000884f, -0.01859729f, -0.00992795f, 0.06382409f, -0.04475363f, 0.13782881f, -0.00398251f, 0.09480601f, 
    0.06984212f, -0.07977217f, 0.10767014f, 0.13916138f, 0.09966945f, -0.08269354f, 0.14579391f, 0.05952217f, 
    0.01053012f, 0.15267394f, 0.03915017f, 0.08299972f, 0.04455701f, -0.08268886f, -0.08211982f, 0.02348642f, 
    0.15915808f, 0.00715085f, 0.14575973f, -0.05724314f, -0.06364056f, 0.16223800f, -0.01383822f, -0.08134063f, 
    -0.08839914f, -0.08504012f, 0.07926233f, 0.05575735f, -0.00669122f, 0.00752806f, 0.04149438f, 0.15282862f, 
    0.14613882f, 0.01301544f, -0.06987232f, -0.07362148f, -0.01346229f, 0.03122230f, -0.09322897f, -0.01184171f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.50210035f, -0.01709763f, 0.06227802f, 0.12773405f, 0.09522262f, 0.20001210f, 0.18142757f, 0.15903702f, 
    0.00282669f, 0.11180468f, -0.31012160f, -0.01736841f, 0.13659136f, -0.11595166f, 0.07255704f, -0.58422500f, 
    -0.01279079f, 0.28641281f, 0.05326486f, -0.26101866f, -0.27432901f, 0.00973363f, -0.10795837f, -0.02196412f, 
    -0.17269981f, 0.08560731f, -0.56366289f, 0.14915211f, -0.14787848f, 0.00057428f, -0.18752240f, 0.09065485f, 
    0.09251005f, -0.26566139f, -0.18351385f, -0.01895986f, -0.18630837f, -0.05433717f, -0.25890917f, -0.01932975f, 
    -0.18561439f, -0.05594148f, -0.51180232f, 0.12314688f, -0.16518694f, 0.14729646f, -0.04136680f, 0.01775701f, 
    0.32397482f, -0.08351061f, 0.18347934f, 0.14577127f, 0.04738963f, -0.23128319f, -0.32808918f, -0.03164155f, 
    0.17356773f, 0.15249127f, 0.25809970f, -0.51962531f, 0.23862557f, -0.10548779f, -0.09550073f, -0.18673368f, 
    0.05606958f, 0.20191051f, -0.08137194f, 0.05531640f, 0.07426815f, -0.05842264f, -0.20941061f, -0.31764987f, 
    -0.05285101f, 0.02629784f, -0.35208395f, -0.16936646f, 0.04411190f, -0.17691024f, 0.06767505f, -0.17976353f, 
    0.19612463f, 0.17996801f, -0.11549892f, 0.17575993f, 0.16640688f, -0.18225713f, -0.10632748f, -0.18762505f, 
    0.19979273f, -0.10741643f, -0.32675353f, -0.19465773f, 0.12411810f, -0.01594153f, -0.44344291f, 0.10992533f, 
    0.17196234f, 0.14446282f, -0.10268982f, 0.07777184f, 0.03012502f, -0.06565332f, 0.09225600f, 0.18107268f, 
    0.06835697f, 0.01063247f, 0.49538708f, 0.10246215f, -0.32311034f, 0.06849406f, -0.43514946f, -0.04913392f, 
    -0.40174419f, 0.02893846f, -0.14648189f, 0.15674646f, -0.16062224f, -0.31321499f, -0.04606018f, 0.04485058f, 
    0.23918386f, 0.09856888f, 0.15884025f, 0.30260804f, 0.09942031f, -0.02958903f, 0.12311042f, -0.15373689f, 
    0.10614688f, 0.00401789f, 0.01013857f, 0.17759278f, -0.09094087f, 0.08921375f, -0.22170825f, 0.14329761f, 
    0.15930459f, 0.07820354f, -0.35093215f, 0.09054728f, -0.02616569f, -0.19884890f, -0.16153939f, 0.28001133f, 
    0.19904593f, 0.19263920f, -0.33232194f, 0.05801839f, 0.31176993f, -0.56032014f, 0.10592607f, -0.09036663f, 
    -0.06240609f, -0.05992582f, 0.26663980f, 0.14036180f, 0.03880312f, 0.02585322f, 0.21989357f, 0.21279997f, 
    -0.21119462f, 0.23643292f, 0.26188505f, -0.04880699f, 0.36621073f, -0.03687486f, -0.10509334f, 0.20777492f, 
    -0.20877163f, 0.03199497f, -0.43871295f, 0.20604394f, -0.23058559f, 0.01262711f, -0.19498339f, -0.05993885f, 
    -0.12823826f, -0.27645084f, 0.04599284f, -0.38306704f, -0.13071764f, -0.24753648f, -0.36560878f, 0.02508992f, 
    -0.02173312f, -0.03466143f, -0.40408695f, -0.47212312f, -0.01698875f, 0.03276283f, -0.01997522f, -0.07179040f, 
    0.06976034f, -0.47547016f, 0.11519913f, 0.11005105f, 0.06139260f, 0.17215765f, 0.21813913f, -0.09448505f, 
    0.16338733f, -0.05771971f, -0.04064688f, -0.02993118f, 0.13256216f, 0.02846256f, 0.05117183f, 0.17634551f, 
    0.18912025f, -0.12304717f, 0.19915983f, 0.02239530f, -0.21271615f, 0.08427456f, -0.02516923f, -0.27897900f, 
    -0.23045428f, -0.05063795f, -0.39870837f, -0.05209863f, 0.08171774f, 0.06804892f, 0.26609153f, 0.15183790f, 
    -0.29584634f, 0.04567061f, 0.01095957f, 0.03037107f, -0.01590746f, -0.01993799f, -0.30850154f, -0.37865192f, 
    0.20388573f, -0.12139396f, -0.16523588f, 0.21218549f, 0.14094083f, -0.52562612f, 0.08447394f, -0.05524137f, 
    0.07668933f, -0.25446376f, -0.40048903f, -0.06902642f, 0.04064525f, 0.13668981f, -0.05327961f, -0.20167960f, 
    0.11251234f, -0.23045123f, -0.20943199f, 0.07663509f, -0.49288791f, 0.08884925f, 0.10284845f, -0.32190108f, 
    0.09813472f, 0.11329402f, -0.06248882f, 0.04424988f, 0.07054812f, -0.01769707f, -0.01400766f, -0.01759242f, 
    0.05716952f, 0.00594643f, 0.11877801f, -0.04939208f, -0.31045383f, 0.01779653f, -0.03705354f, 0.00793690f, 
    -0.29223639f, -0.21180613f, 0.23332193f, -0.18646643f, 0.29087728f, 0.26627675f, 0.07609671f, -0.05448583f, 
    0.14842017f, -0.13882478f, -0.23209116f, 0.22771467f, -0.22054768f, 0.01554285f, 0.20575148f, 0.22230899f, 
    -0.05655741f, 0.07123831f, -0.35425386f, -0.11070780f, 0.03963055f, 0.01746607f, -0.12275517f, -0.19822653f, 
    0.08117505f, -0.13575593f, -0.47268972f, -0.40272531f, -0.17128377f, -0.04555140f, 0.15633777f, -0.07533757f, 
    -0.01365710f, -0.29176617f, 0.10618025f, 0.12004406f, -0.01912056f, 0.09817272f, 0.19465756f, 0.10810041f, 
    0.09473113f, -0.24361622f, 0.02426643f, -0.26444951f, -0.28289974f, -0.00551052f, 0.06976621f, 0.20396665f, 
    -0.22817251f, -0.14179327f, -0.06638669f, -0.13651364f, -0.08408772f, -0.10073210f, -0.08573305f, -0.20794001f, 
    -0.03781695f, 0.09701917f, 0.25840846f, 0.11430342f, -0.13903281f, 0.29295930f, 0.18512283f, 0.23185030f, 
    -0.19940633f, 0.08817345f, 0.01261031f, 0.10741352f, -0.10863012f, 0.03088935f, 0.01255755f, -0.00804288f, 
    0.09347513f, -0.00068794f, 0.24839549f, -0.28039336f, 0.22066991f, -0.09716157f, -0.23666750f, -0.28457245f, 
    0.17094363f, -0.24840027f, 0.01525203f, -0.10168825f, -0.41213125f, -0.10786075f, -0.14377025f, 0.04282490f, 
    0.01483635f, -0.07372496f, 0.02687593f, -0.09993222f, -0.08425897f, -0.09927851f, 0.08285552f, 0.08466518f, 
    0.20187671f, 0.17353399f, -0.19481298f, -0.16656582f, -0.22653790f, -0.00254529f, 0.22141750f, 0.00010254f, 
    0.09017307f, 0.13577317f, 0.16554202f, 0.13469577f, 0.16134837f, 0.12031689f, 0.05790384f, 0.22958367f, 
    -0.16418412f, -0.06411154f, -0.04294600f, -0.13413990f, -0.05082940f, -0.01494729f, -0.23743570f, 0.23422433f, 
    -0.40620217f, 0.02680545f, 0.01799737f, 0.24807578f, -0.13899039f, -0.33587870f, 0.23914018f, -0.25718278f, 
    0.37453574f, -0.25561374f, -0.11590331f, 0.09254724f, -0.40472806f, -0.20819302f, -0.01494549f, 0.16694102f, 
    -0.00325268f, -0.04377007f, -0.23955734f, 0.11897105f, -0.11246944f, -0.05561232f, 0.24070975f, -0.40058160f, 
    -0.12906989f, 0.14642668f, 0.23494588f, 0.08778083f, 0.31273055f, -0.12362892f, -0.19880660f, 0.08389524f, 
    -0.38334766f, -0.12637424f, 0.13041714f, 0.05470338f, 0.35375148f, 0.02818880f, 0.27254364f, 0.07890642f, 
    -0.24332175f, 0.05947663f, 0.10507346f, 0.14599678f, -0.22587323f, 0.03500658f, 0.07991587f, 0.04491372f, 
    -0.05360468f, 0.03777255f, -0.20715840f, -0.01154504f, -0.18378311f, -0.05686132f, 0.08459513f, 0.07150055f, 
    0.10657499f, 0.04488894f, 0.09667202f, -0.16701113f, -0.04617257f, 0.05667435f, 0.10186726f, -0.23676306f, 
    0.15610729f, 0.08417021f, 0.29643387f, -0.28843316f, -0.28941074f, 0.22067556f, -0.33874917f, -0.00494512f, 
    -0.17851353f, -0.07426055f, -0.18339823f, -0.35202414f, -0.10389698f, 0.10328992f, 0.01723166f, -0.38638774f, 
    -0.28447574f, 0.04321940f, 0.20708890f, -0.38753948f, -0.03900355f, 0.11110533f, 0.09311014f, -0.16393030f, 
    0.18512371f, -0.28765953f, -0.23844118f, 0.10436681f, 0.27816874f, -0.10886460f, 0.28159407f, 0.22475256f, 
    0.04409754f, -0.12052831f, 0.10325779f, 0.09014682f, 0.22413425f, -0.29974234f, 0.02820952f, -0.12634534f, 
    0.09806018f, 0.07078699f, 0.11292175f, 0.09321292f, 0.12119409f, 0.19066082f, -0.07808392f, -0.41521490f, 
    -0.29606283f, -0.19156361f, -0.26702902f, 0.27662030f, 0.15717222f, -0.11328874f, 0.00493476f, 0.08811875f, 
    -0.18061545f, 0.32429755f, -0.04675550f, -0.38353536f, -0.09435671f, -0.53595078f, -0.09984980f, -0.24512228f, 
    0.14385416f, 0.08298096f, 0.19155827f, -0.04565139f, 0.00482500f, 0.19737235f, -0.37628251f, 0.27343938f, 
    -0.23439193f, 0.04887136f, -0.32939571f, 0.24235396f, 0.33054781f, -0.00652902f, -0.03908989f, 0.14322926f, 
    -0.30747065f, 0.03792193f, 0.19564101f, -0.48992273f, -0.15914652f, -0.01231176f, -0.16792312f, 0.16231123f, 
    0.15218152f, -0.03368560f, -0.32970998f, -0.02701405f, 0.02655825f, -0.02796528f, 0.05351760f, 0.17537831f, 
    0.16786630f, -0.09393496f, -0.53787267f, -0.29059327f, 0.22291492f, -0.11404541f, 0.04415384f, 0.05419613f, 
    -0.12869714f, 0.34119070f, -0.29868713f, -0.05335488f, -0.44470742f, -0.19200356f, -0.32919434f, -0.00087094f, 
    -0.15932254f, 0.31384200f, 0.00773280f, 0.11723318f, 0.08727194f, -0.05483679f, -0.07912465f, -0.41007033f, 
    0.17764340f, -0.33324176f, -0.08969311f, 0.03550533f, 0.10852654f, -0.01149415f, -0.31598991f, 0.22914155f, 
    0.01876934f, -0.06850107f, -0.07081071f, 0.00257857f, 0.04276152f, -0.09752011f, -0.01061487f, 0.03674430f, 
    -0.28902030f, -0.22147815f, 0.04072528f, -0.07017834f, -0.18981734f, 0.07694986f, 0.10554665f, 0.12847461f, 
    0.05237210f, 0.08696261f, 0.37765121f, -0.02132167f, -0.30450815f, 0.06554782f, -0.12418111f, -0.42510521f, 
    0.22852847f, -0.16860591f, 0.19708769f, -0.06786331f, 0.06166084f, -0.08628640f, 0.45170054f, 0.22937791f, 
    -0.43267778f, -0.07116543f, -0.41590753f, -0.29694340f, -0.13127203f, 0.17549193f, -0.15485302f, 0.09170602f, 
    -0.25857273f, 0.08660862f, 0.31854659f, -0.36566943f, 0.10827592f, 0.18454254f, 0.06322579f, 0.18035699f, 
    -0.26545224f, -0.28733835f, 0.00327870f, -0.16838020f, 0.08094200f, -0.03176841f, 0.08588491f, 0.00959529f, 
    -0.27346474f, 0.11422195f, 0.10602759f, -0.01797663f, 0.05831931f, -0.36309594f, 0.21250303f, -0.31032693f, 
    -0.08851414f, -0.01050510f, -0.09284991f, -0.34528318f, 0.20859028f, 0.14631267f, -0.28420642f, -0.07466700f, 
    -0.00743111f, -0.19337498f, -0.10499688f, 0.10726219f, -0.15078907f, -0.02864810f, 0.01357479f, 0.14411353f, 
    -0.34265044f, 0.01519776f, 0.36877301f, 0.09405157f, 0.07056694f, -0.10646220f, -0.01080784f, 0.26441500f, 
    0.02159640f, -0.05279305f, 0.36333019f, -0.08299492f, -0.10832266f, 0.01923584f, -0.40043131f, -0.06477662f, 
    0.17346320f, -0.19819400f, -0.00730032f, 0.03478405f, -0.05828455f, 0.23668854f, -0.19735794f, -0.06976510f, 
    0.16074410f, 0.10996410f, -0.28931364f, -0.12524158f, 0.09819923f, -0.03368683f, 0.17369084f, 0.10508756f, 
    0.24148023f, -0.23141018f, -0.53556651f, 0.20410785f, -0.27080053f, -0.06172854f, 0.09435285f, -0.20837034f, 
    0.09309166f, -0.23744215f, -0.13028321f, 0.20936911f, 0.07223903f, 0.04567089f, -0.12216314f, 0.18475236f, 
    -0.18931574f, -0.10219872f, -0.15389906f, -0.13665666f, 0.36267692f, -0.31267801f, -0.05970494f, 0.14529173f, 
    0.30317256f, -0.23042238f, 0.21638574f, -0.03291355f, -0.47104254f, -0.03801483f, -0.07642566f, 0.16764009f, 
    0.16461773f, 0.03493924f, -0.11707509f, -0.13673595f, 0.05951240f, 0.03180894f, -0.02333946f, -0.32414326f, 
    -0.44406343f, 0.02875015f, -0.35708559f, 0.05875903f, -0.39113209f, -0.10154999f, 0.11671606f, -0.49217832f, 
    0.13495094f, -0.01840382f, -0.28271613f, 0.13437064f, -0.08564695f, -0.03524899f, 0.08909065f, -0.02458354f, 
    -0.11143892f, 0.27860668f, -0.08601577f, 0.14461571f, 0.19465379f, -0.14148593f, -0.12942103f, 0.24760811f, 
    -0.46319658f, 0.08150040f, 0.20196855f, -0.16489819f, -0.38698888f, 0.04172280f, -0.00756828f, 0.16415721f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.03379527f, -0.02857648f, -0.02361329f, -0.00180163f, 0.06291702f, 0.05045286f, 0.08738649f, -0.20918824f, 
    0.05957865f, 0.13087733f, 0.18513392f, 0.07584681f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
