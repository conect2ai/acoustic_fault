#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -1.24839473f, 0.89736921f, -0.22622935f, -0.60158306f, -0.35004279f, 0.38691470f, 0.61363882f, -0.27983725f, 
    0.30491242f, -0.19373998f, -0.47854853f, 0.02982584f, 0.09769046f, 0.20121077f, -0.07596539f, -0.10916200f, 
    0.01940098f, -0.08070716f, -0.16311879f, -0.51512164f, 0.16885757f, 0.05559538f, 0.16178003f, 0.21376179f, 
    0.31052783f, -1.21200800f, 0.59537429f, 1.10377908f, -0.32595536f, -0.20060678f, -0.00096386f, 0.51457196f, 
    0.05323898f, 0.11814509f, -0.26298422f, -0.19251439f, -0.00665079f, -0.25245711f, 0.08146721f, -0.00664570f, 
    0.15494515f, -0.15116777f, -0.20144856f, -0.17575625f, -0.08128696f, 0.20212646f, 0.06634352f, 0.01933294f, 
    0.05372304f, -0.20903580f, -0.15160722f, 0.70464015f, 0.59406352f, 0.25895944f, 0.30742058f, 0.66309619f, 
    -0.04297923f, 0.23141752f, 0.15315768f, -0.14034402f, -0.33862144f, 0.13174598f, 0.00236876f, -0.39395365f, 
    0.03738556f, -0.10421149f, -0.34115532f, 0.26232532f, 0.06190119f, -0.53567898f, 0.13929974f, 0.22322673f, 
    -0.38399744f, 0.36483207f, 0.30834168f, -0.30309591f, -0.78977144f, 0.24253315f, 0.00324896f, -0.02233144f, 
    0.57864815f, 0.07676483f, 0.52060270f, 0.21819353f, -0.51003289f, -0.42113355f, 0.10141933f, -0.41558939f, 
    -0.00766284f, 0.18528911f, 0.13800284f, -0.08756667f, -0.27435318f, -0.14981675f, 0.09087808f, -0.25541654f, 
    -0.03393921f, 0.32442370f, 0.27273664f, 0.05926979f, -0.52133143f, 0.77134109f, -0.43378213f, -0.21573058f, 
    0.76215804f, -0.19151810f, 0.24624316f, 0.68524569f, -0.15958336f, -0.19478089f, -0.02992201f, 0.20770738f, 
    0.12513179f, 0.04437791f, 0.27305946f, -0.23601668f, 0.06479073f, -0.31805345f, 0.05454293f, -0.03914799f, 
    -0.16423343f, 0.34003782f, 0.17634667f, 0.39181152f, 0.04012661f, -0.60313594f, -0.79588455f, -0.41680959f, 
    -0.08527136f, -0.12264643f, -0.36843646f, 0.20578383f, 0.43965980f, 0.14580800f, 0.09245196f, 0.24712500f, 
    0.01489604f, -0.09492953f, -0.02670336f, -0.09026213f, 0.40812522f, 0.12298243f, -0.01319221f, 0.26665106f, 
    -0.32323611f, 0.33440572f, 0.04805870f, 0.07787114f, 0.34997952f, 0.29885352f, -0.00926679f, 0.26255929f, 
    -0.53346556f, -0.66061038f, -0.53009731f, 0.28875694f, -0.55430520f, -0.43105298f, -0.27092132f, 0.21822147f, 
    0.21862750f, 0.11169405f, 0.21837579f, 0.20532529f, -0.22542903f, -0.24800584f, 0.39759743f, 0.36625969f, 
    0.30013281f, -0.40996924f, -0.30179465f, -0.18484409f, 0.18287240f, 0.09145922f, 0.30224556f, 0.85959631f, 
    0.73877305f, -0.72211140f, 0.34503904f, -0.12395371f, 0.86182499f, -0.19499773f, 0.40223053f, 0.69164705f, 
    0.54164058f, -0.30708981f, -0.11289929f, -0.20702247f, 0.00411500f, 0.08754973f, -0.12026179f, -0.32510713f, 
    -0.07362456f, -0.01780738f, 0.14538060f, 0.00715567f, -0.13733107f, -0.00438960f, 0.05909531f, -0.14748266f, 
    -0.54828727f, -0.74768490f, -0.67547357f, 0.06324878f, 0.39339921f, -0.74667114f, 0.19671789f, 0.39430958f, 
    -0.15379071f, -0.37312803f, 0.21852167f, -0.17632420f, -0.00405888f, 0.00481342f, 0.22469603f, 0.22895904f, 
    0.29101896f, -0.35157904f, -0.18413118f, -0.27113494f, -0.15031248f, -0.35369131f, 0.28799441f, 0.32575274f, 
    -0.10319225f, 0.41779855f, 0.88198453f, 0.47832116f, 0.18668140f, -0.08488416f, 0.24521612f, -0.13663934f, 
    0.27939045f, 0.19743221f, 0.52806658f, -0.52681589f, 0.43935609f, 0.37637013f, -0.36158392f, -0.21016416f, 
    -0.17006141f, 0.23150383f, -0.11197260f, -0.13705689f, 0.03091187f, -0.32328123f, -0.11529233f, -0.27463788f, 
    -0.14866094f, 0.03557906f, 1.06763327f, 0.09392171f, 0.38938576f, -0.71167868f, -0.79796314f, -0.29347488f, 
    0.47770178f, 0.35155362f, 0.06924204f, -0.30427918f, 0.20103373f, -0.02914497f, -0.10929760f, 0.09452049f, 
    -0.14006464f, -0.13440867f, 0.11284954f, 0.10887194f, -0.09483396f, -0.11369451f, -0.26025185f, -0.18765061f, 
    -0.01686603f, -0.32165131f, -0.38079333f, -0.13599354f, -0.79812241f, -0.37648183f, -0.41329983f, -0.39773142f, 
    -0.24787146f, 0.54506004f, 0.52611721f, 0.45037797f, -0.03541559f, -0.09813172f, -0.37335068f, 0.11373413f, 
    -0.01866245f, -0.43192980f, 0.35608244f, -0.22670761f, -0.28102672f, -0.25048628f, -0.07923556f, -0.13312654f, 
    -0.16028811f, 0.13912414f, -0.03136949f, 0.39944869f, 0.66268253f, 0.11755291f, 0.41165587f, 0.55970407f, 
    0.93748027f, 0.76087379f, 0.03046947f, 0.37056682f, -0.27802685f, 0.14464797f, -0.13365671f, -0.31550199f, 
    -0.29950440f, 0.01333443f, -0.08595023f, -0.15534227f, -0.01673236f, -0.26663697f, -0.17199582f, -0.32829854f, 
    -0.10013194f, 0.19562225f, -0.36326542f, -0.14678305f, 0.07688024f, -0.19086060f, -0.50673854f, 0.58205736f, 
    -0.76873839f, -0.71376771f, -0.23134921f, -0.19681560f, -0.12910540f, -0.03136886f, -0.11255524f, -0.07791433f, 
    0.31698680f, -0.32085636f, 0.24778110f, -0.03005107f, -0.17908666f, 0.00978259f, 0.10944537f, -0.10377580f, 
    -0.19396755f, 0.33785284f, -0.01081970f, -0.13031520f, 0.20296355f, 0.33818913f, -0.37377885f, -0.33766624f, 
    -0.04898955f, 0.92062646f, 0.23459126f, 0.25728238f, 0.43580124f, -0.33543271f, 0.33764556f, -0.06497712f, 
    0.39651901f, -0.03222927f, 0.15386438f, -0.13850702f, 0.01594757f, -0.00210036f, 0.27765417f, 0.12124734f, 
    0.11516046f, 0.35737208f, 0.38221222f, -0.05414400f, -0.41621423f, -0.31374857f, 0.03774827f, 0.95687574f, 
    -0.19312075f, -0.71191037f, 0.60091215f, -0.57741582f, -0.72019839f, 0.03485142f, -0.31788486f, 0.41910705f, 
    -0.18901069f, 0.00144606f, -0.23082590f, 0.42864025f, -0.12726073f, -0.02365879f, 0.05945958f, 0.33954158f, 
    -0.12360349f, -0.16787116f, 0.30270404f, -0.14863695f, 0.03287718f, 0.14105128f, 0.13308853f, 0.30365866f, 
    0.31567010f, -0.60192841f, -0.34205991f, -0.53103840f, 0.01907580f, 0.53252923f, 0.10203761f, 0.34497479f, 
    0.43232784f, 0.51720852f, 0.19015107f, 0.26051265f, -0.02026534f, 0.36310616f, 0.23184541f, -0.15807225f, 
    0.14410500f, 0.05176636f, -0.21485829f, -0.00795647f, -0.00279692f, 0.00190989f, 0.10394508f, -0.01589778f, 
    0.08849470f, -0.76150775f, -0.14136018f, -0.16839373f, -0.81068623f, -0.51811635f, 0.17893212f, 0.14712657f, 
    0.28316265f, 0.39693701f, 0.65227759f, -0.28294119f, -0.06319544f, -0.44026929f, 0.00734281f, -0.33449611f, 
    0.05766427f, -0.01052784f, -0.09580219f, 0.27061072f, 0.38234019f, -0.33575767f, 0.03322317f, -0.17718673f, 
    -0.14387996f, -0.21783921f, -0.40164199f, -0.68087250f, -0.85090023f, -0.59153938f, 0.10117927f, -0.02165948f, 
    0.38626680f, 0.07819279f, -0.06698435f, 0.46562511f, -0.03696933f, 0.05410035f, 0.19542800f, -0.07163452f, 
    -0.00598366f, -0.12745224f, 0.18874352f, 0.10575491f, 0.08185262f, 0.10816460f, 0.02336642f, -0.31953114f, 
    -0.17458500f, -0.25796211f, -0.24771419f, 0.13331912f, 0.46305498f, -0.35075378f, -0.44127831f, -0.46293551f, 
    -0.38291991f, -0.47952166f, 0.15607291f, 0.62459189f, -0.37095785f, -0.63947731f, -0.08245102f, -0.01633187f, 
    -0.13940321f, 0.30075571f, -0.08059478f, -0.06203201f, -0.03906065f, 0.03178663f, -0.25499853f, 0.35150588f, 
    -0.30687469f, -0.11165259f, -0.21023339f, 0.13643219f, -1.11479008f, 1.01773751f, -0.70355469f, 0.30168125f, 
    0.25031427f, -0.21936348f, 0.34729755f, -0.43354070f, 0.37890065f, -0.16812092f, 0.12079394f, -0.06887705f, 
    -0.21643437f, -0.01643683f, -0.18370578f, -0.07034580f, 0.00736262f, -0.31924036f, 0.03678572f, -0.25064307f, 
    0.07698715f, -0.01105385f, 0.03372626f, 0.03769802f, -0.01163466f, -0.25426105f, 0.60883570f, -0.20585565f, 
    0.36469591f, -0.74520004f, -0.28864905f, 0.01324857f, -0.23765187f, 0.00996509f, -0.11607170f, 0.34220394f, 
    0.12000508f, 0.34451935f, -0.24914294f, -0.01162091f, -0.08184878f, 0.30754775f, 0.28511515f, 0.34358230f, 
    0.08088426f, -0.09467476f, -0.13140719f, -0.05024372f, 0.16973326f, 0.11778387f, -0.28084353f, -0.51163512f, 
    -0.01714169f, 0.12841804f, -0.40425462f, -0.63526094f, 0.13321082f, -0.03058277f, -0.18866429f, -0.37092763f, 
    -0.39375028f, -0.05942148f, 0.19439600f, 0.26420748f, -0.59357989f, -0.12072347f, -0.31670833f, -0.24431673f, 
    -0.39375526f, -0.51794487f, -0.15982391f, -0.05615088f, -0.22655088f, -0.33373529f, 0.40735537f, 0.58808237f, 
    -0.17538509f, 0.59531206f, 0.66439533f, 0.32418469f, -0.37876204f, 0.45467484f, -0.34016934f, -0.00118468f, 
    0.59392416f, -0.25378317f, 0.42825028f, -0.01562082f, 0.24800113f, -0.24343765f, -0.03981936f, 0.00742795f, 
    -0.35599613f, -0.31458968f, 0.10246283f, 0.02939128f, 0.32884687f, 0.33076394f, 0.38306251f, -0.01265800f, 
    0.39697045f, 0.35925215f, -0.46332496f, -0.47703883f, -0.11438570f, 0.67702800f, 0.07367245f, 0.02554600f, 
    -0.07122919f, -0.26085475f, -0.04367217f, -0.43974295f, -0.60942876f, -0.52718705f, -0.56320900f, 0.39481422f, 
    -0.30306220f, -0.23770700f, -0.28831583f, -0.31096530f, -0.04863681f, -0.04582468f, -0.42499545f, 0.08070385f, 
    0.00867330f, -0.11337119f, -0.55468649f, -0.64462966f, 0.15106227f, 0.00746185f, -0.48926488f, -0.02739871f, 
    0.43312088f, 0.18057360f, -0.36675027f, 0.08879569f, 0.29667601f, 0.18153693f, -0.26309204f, 0.46470237f, 
    -0.22955480f, -0.04770574f, 0.58520430f, 0.37425238f, -0.23185085f, 0.49492279f, -0.16578217f, -0.10879824f, 
    0.07853808f, -0.30159053f, 0.31677517f, 0.45776635f, 0.51453358f, -0.51017493f, 0.27464747f, -0.20624693f, 
    0.36764079f, 0.60501218f, 0.30807364f, 0.30726609f, -0.23575220f, -0.06653183f, 0.11334139f, 0.05586147f, 
    0.33356100f, -0.26582026f, 0.30186498f, -0.13052306f, 0.24641067f, 0.15826982f, -0.29471806f, 0.15294254f, 
    -0.14971247f, -0.04632026f, -0.22321346f, -0.80314130f, 0.66653478f, 0.49272102f, -0.35635531f, 0.64420545f, 
    -0.53295916f, 0.00698788f, -0.77801520f, -0.44445983f, -0.50159752f, -0.04728603f, 0.09546570f, 0.46487805f, 
    -0.09123441f, -0.00265154f, -0.25592473f, -0.10526827f, 0.08507881f, -0.14707547f, 0.23471035f, 0.12249564f, 
    0.01955445f, -0.12187437f, -0.17340419f, -0.02787668f, 0.17651063f, -0.91062611f, -0.54111648f, -0.19822124f, 
    -0.40763998f, 0.47731471f, 0.52519029f, 0.07092672f, 0.54228610f, 0.42043385f, -0.08853874f, 0.13796821f, 
    -0.12736881f, -0.16715343f, -0.07307039f, -0.24793653f, -0.12344456f, -0.19430450f, 0.32013422f, -0.16804874f, 
    0.14998630f, 0.23123759f, -0.21196216f, 0.28922927f, 0.22356787f, 0.95743024f, 0.53373724f, 0.36112845f, 
    0.68527102f, 0.36992833f, -0.12329558f, -0.78009444f, 0.16986001f, 0.14080599f, 0.34580937f, 0.01731477f, 
    0.19659749f, -0.04882563f, -0.38776806f, -0.00671110f, 0.12346949f, -0.10846408f, -0.03651969f, -0.03418187f, 
    0.26580960f, 0.47147644f, 0.28066897f, 0.16655831f, -0.28094435f, 0.35639217f, 1.11165071f, 0.10431821f, 
    -0.91362882f, -0.08431222f, 0.27347523f, 0.16617435f, -0.00308041f, -0.06064472f, -0.02883922f, 0.19956338f, 
    -0.14734213f, 0.30264625f, 0.30088550f, -0.03737097f, -0.20687652f, -0.25506422f, -0.36725751f, -0.04974915f, 
    0.12221434f, -0.06885497f, -0.01371613f, 0.00413380f, 0.22236222f, 0.03809910f, 0.16106819f, -0.50473958f, 
    -0.39262673f, -0.04310134f, -0.31044757f, -0.40745240f, -0.52319586f, -0.76814467f, -0.51361018f, 0.28640985f, 
    -0.21350253f, 0.33276540f, 0.13031287f, 0.11547691f, 0.02067760f, -0.34980792f, -0.18541479f, -0.03536420f, 
    -0.19227196f, -0.15344170f, -0.39833409f, 0.11096524f, 0.31570700f, 0.20170665f, 0.06716461f, -0.04241848f, 
    -0.45576370f, -0.29195991f, 0.09817197f, 0.48414856f, 0.05582435f, -0.83068776f, 0.16891231f, 0.01333656f, 
    -0.53956592f, -0.21372667f, 0.31729320f, 0.17186855f, 0.19006528f, -0.16439505f, 0.36246654f, -0.08425869f, 
    0.36803526f, 0.34055951f, -0.50608057f, 0.41231313f, 0.18533108f, -0.21122122f, -0.15692729f, 0.10152572f, 
    0.13325933f, -0.15561289f, -0.82287043f, 0.68920082f, 0.41078115f, 0.26407510f, 0.10513011f, -0.42112190f, 
    -0.33742079f, -0.26142940f, -0.36757404f, 0.36485186f, 0.05193444f, 0.42231864f, 0.06464642f, 0.09409422f, 
    0.34931630f, 0.50679815f, 0.29663309f, -0.08521346f, -0.02640890f, 0.04531098f, -0.14402440f, 0.08513762f, 
    -0.20611565f, 0.09782613f, 0.01061283f, -0.67468649f, -0.42508435f, -0.41577351f, -0.18080056f, 0.68389982f, 
    -0.65017569f, 0.26167160f, 0.04691613f, -0.47184741f, 0.04567562f, -0.25120804f, 0.13077264f, 0.06736014f, 
    -0.03739311f, 0.20047781f, 0.25748795f, -0.24919826f, -0.23476475f, 0.19832042f, -0.24615330f, 0.11471646f, 
    0.29360712f, -0.09481149f, 0.31426290f, -1.00784731f, 0.19551703f, 0.76768982f, -0.67575347f, 0.41823772f, 
    0.54241574f, -0.08143051f, -0.06198014f, -0.38354138f, -0.04246272f, -0.25971854f, 0.27088991f, 0.38443074f, 
    0.06950032f, -0.25828713f, -0.58064425f, -0.29194257f, -0.00791381f, -0.27792570f, -0.56460243f, 0.14417948f, 
    -0.03823240f, -0.01773968f, 0.13406909f, -0.02199531f, -0.38233036f, -0.19903995f, -0.13237348f, -0.06006259f, 
    0.61677492f, 0.43612990f, 0.48655483f, -0.25760692f, -0.28631607f, -0.35262379f, 0.05805109f, 0.37904227f, 
    0.27221662f, -0.09533224f, -0.25454623f, 0.04288147f, -0.47795701f, -0.28582874f, -0.20218077f, 0.03081822f, 
    0.10568502f, -0.40077558f, 0.33072191f, -0.08866930f, -0.02327622f, -0.15707031f, 0.20343561f, -0.74229735f, 
    0.79371393f, -0.49699619f, 0.66277599f, 0.72783512f, -0.64907575f, -0.07455793f, -0.18099679f, 0.28620502f, 
    -0.33986256f, -0.22814643f, -0.23580942f, -0.07078114f, -0.13635141f, 0.26610497f, -0.06824572f, 0.05490390f, 
    -0.07913616f, 0.05496280f, -0.31852371f, -0.05674366f, -0.08258377f, 0.27626219f, -0.32734048f, -0.92293638f, 
    -0.61530554f, -0.24084930f, 0.00235215f, -0.07388948f, 0.63580519f, -0.42539126f, 0.42689639f, 0.52660871f, 
    -0.15282990f, -0.12000908f, -0.43237221f, 0.15855300f, -0.01605880f, -0.15122117f, 0.25665075f, 0.19761722f, 
    -0.02749025f, 0.04005111f, -0.01961065f, 0.08027287f, 0.11826914f, 0.17446518f, 0.21274023f, -1.17912650f, 
    -0.14964813f, 0.20772509f, -0.20590933f, 0.17732991f, 0.76509929f, 0.78910297f, -0.21491387f, 0.26412034f, 
    0.18285351f, 0.40116978f, -0.31107974f, 0.53915280f, -0.37680194f, 0.21858563f, 0.01891000f, -0.07161638f, 
    0.08769871f, -0.13102455f, -0.15236813f, 0.12099397f, 0.06727751f, 0.12093852f, 0.18316488f, -0.06863747f, 
    -0.62514305f, -0.42597324f, -0.58354473f, -0.48587847f, -0.49966866f, 0.50525618f, 0.30029109f, -0.51973963f, 
    -0.00291805f, 0.49599627f, -0.42926785f, -0.27217960f, 0.36174053f, 0.06814336f, 0.26385954f, 0.17559850f, 
    0.30189708f, 0.15951353f, 0.19505396f, 0.08803048f, 0.12461594f, -0.06987660f, -0.33520108f, -0.19282734f, 
    0.26396295f, 0.87248236f, 0.32730120f, -0.86199081f, -0.81291878f, -0.33839780f, -0.23917679f, 0.53039676f, 
    0.16862184f, 0.30296242f, 0.13661957f, 0.12379637f, -0.13377270f, -0.24949011f, -0.36993453f, 0.11186165f, 
    0.27158579f, -0.17977406f, -0.01776800f, 0.00661108f, 0.21614566f, -0.16254468f, 0.19804931f, -0.12359720f, 
    -0.28187248f, -0.00709021f, 1.09641874f, -0.04728215f, -0.38710871f, 0.40998685f, 0.46869913f, 0.10956827f, 
    0.31502047f, 0.01720753f, -0.18723990f, 0.08773179f, -0.31162411f, 0.03889718f, 0.09274969f, 0.12091146f, 
    -0.04193413f, -0.02143498f, -0.08565150f, 0.25162888f, -0.26642466f, 0.01489337f, 0.09587011f, 0.11863630f, 
    0.23553227f, 0.43557996f, -0.16827363f, -0.78343379f, -0.60054982f, -0.59520137f, 0.89555389f, 0.59367359f, 
    0.84472573f, 0.55936497f, 0.16818269f, 0.35806364f, -0.52093077f, -0.11364868f, 0.00591907f, -0.09691706f, 
    0.04829908f, 0.04254030f, -0.22504938f, 0.13689376f, -0.17276649f, -0.09948428f, 0.06942853f, -0.14485861f, 
    -0.07512086f, 0.08030117f, -0.17916805f, -0.04612777f, 0.58869261f, 0.34117076f, 0.13710041f, 0.47288498f, 
    -0.09529614f, -0.75386995f, -0.88360095f, -0.48373377f, -0.12911011f, -0.33659920f, -0.20343123f, -0.02435631f, 
    0.39537126f, 0.36011124f, -0.06074239f, -0.04997951f, -0.03150942f, 0.01474691f, 0.14387134f, 0.18247114f, 
    0.31764132f, 0.10487219f, 0.11313588f, 0.35156316f, 0.01244253f, -0.57190400f, -1.12485135f, -0.51665169f, 
    -0.00980422f, -0.03659982f, -0.54774177f, 0.97380561f, 0.72216743f, -0.80969644f, 0.05735466f, -0.10350147f, 
    -0.06893892f, 0.24276483f, -0.05849359f, 0.08200146f, -0.51860058f, -0.10147347f, -0.22211267f, -0.05432840f, 
    -0.27904323f, 0.14087172f, 0.19975598f, -0.09687801f, -0.06685316f, 0.04826208f, 0.43948781f, 0.88001639f, 
    0.21969959f, 0.13090050f, 0.81732678f, -0.37199870f, -0.05162774f, 0.49046922f, -0.19933474f, 0.17679535f, 
    -0.57805967f, -0.17878948f, 0.58567053f, 0.14845464f, 0.01396863f, 0.19455858f, -0.00894634f, 0.20866275f, 
    -0.28533924f, -0.04290129f, 0.26337543f, -0.22787213f, 0.15731335f, -0.08344748f, -0.01505688f, 1.00040102f, 
    -0.74795020f, 0.19133684f, 0.21699332f, 0.31726611f, 0.02708345f, -0.01528464f, -0.13547672f, -0.34186834f, 
    -0.09053922f, -0.19472909f, 0.04893146f, -0.37390837f, 0.14180921f, 0.00143224f, -0.08811014f, 0.00793468f, 
    0.45119596f, 0.60189903f, -0.14013018f, 0.07173573f, -0.09450975f, -0.32210213f, -0.42319512f, 0.16675170f, 
    0.52015978f, 0.72978169f, 0.90521091f, 0.69536102f, 0.80779898f, 0.70637172f, 0.11724635f, -0.66471970f, 
    -0.56804484f, -0.08466137f, 0.08340829f, 0.09174570f, -0.17822514f, 0.18108562f, -0.24840318f, 0.07898851f, 
    0.05034636f, 0.22837280f, -0.03006103f, 0.08862226f, 0.27150670f, 0.16809624f, -0.18859705f, -0.26008239f, 
    0.09717146f, 0.50210887f, -0.16474526f, 0.31883582f, 0.97110802f, 0.09450355f, -0.28377694f, 0.34251365f, 
    0.12198960f, 0.56445336f, 0.02718198f, 0.26922303f, -0.02676731f, -0.09590432f, -0.10954434f, -0.14848787f, 
    -0.17853786f, -0.39671794f, 0.24458952f, 0.32434344f, -0.41321799f, 0.06963792f, 0.54721558f, -0.04022183f, 
    0.24224582f, 0.14389718f, 0.89504391f, 0.74209678f, 0.33784714f, 0.59608883f, 0.74080539f, 0.66968644f, 
    0.25215951f, -0.41536307f, 0.38923144f, -0.07901215f, 0.11792906f, 0.14301971f, 0.09870287f, 0.00946357f, 
    -0.09672176f, 0.08951031f, -0.05127129f, 0.29947460f, 0.06085889f, -0.08586244f, 0.10377020f, -0.22606197f, 
    0.20582512f, -0.10762446f, 0.11031483f, -0.46351805f, -0.14101036f, -0.26684940f, -0.55771309f, -0.37823972f, 
    0.23635958f, -0.19442753f, -0.11432784f, -0.51528215f, -0.06903906f, 0.51338130f, 0.09962530f, -0.29198939f, 
    -0.05505529f, -0.35110313f, -0.09716751f, -0.33445430f, 0.20866236f, -0.14897335f, 0.01717963f, 0.31738174f, 
    0.45624655f, 0.32444474f, 0.39232388f, 0.45907187f, -0.54112065f, 0.22750078f, 0.83667809f, 0.55246288f, 
    0.04471073f, 0.27786776f, 0.74203622f, 0.46090421f, 0.15771829f, 0.42476684f, -0.34182250f, -0.04571143f, 
    0.29930720f, -0.20426300f, -0.32608911f, -0.35753602f, -0.20168528f, -0.26477280f, 0.10641833f, -0.40272865f, 
    -0.01088146f, -0.11069601f, -0.23196582f, 0.24521787f, -0.38083315f, 0.78554338f, 0.47947720f, -0.20655331f, 
    -1.05986202f, -0.35494483f, 0.32805383f, -0.14521898f, -0.39982194f, -0.46245897f, -0.48479107f, 0.21198052f, 
    0.08295869f, -0.24375725f, 0.48515311f, -0.23960927f, 0.02800783f, 0.11622252f, -0.19052841f, -0.24033488f, 
    0.26222506f, -0.05069643f, 0.00354960f, 0.19345516f, -0.21499245f, -0.00577918f, 0.20405515f, 0.64282662f, 
    -0.30265594f, -0.87359709f, 0.21670476f, 0.03697202f, -0.75972956f, -0.58030725f, -0.40469971f, -0.15855503f, 
    -0.17900062f, -0.15141018f, -0.15112543f, -0.16716768f, -0.42374253f, -0.38885450f, 0.01297884f, -0.33325839f, 
    -0.03561836f, 0.44143775f, 0.24885376f, 0.41425785f, -0.10126204f, -0.03106673f, 0.25241572f, -0.28317350f, 
    0.59741288f, 0.54911005f, -0.17730582f, -0.13358267f, 0.63168174f, -0.24159807f, -0.70881343f, -0.73194706f, 
    -0.49401033f, -0.00427397f, 0.27917239f, 0.11021796f, 0.52323151f, -0.09958088f, -0.13218896f, -0.03465780f, 
    -0.12120299f, -0.09854887f, 0.29130551f, -0.10242850f, 0.18524694f, 0.04748023f, 0.25332314f, 0.25474557f, 
    -0.18469042f, -0.49556693f, -0.10656755f, -0.23471716f, -0.14236389f, -0.34106058f, 0.27881363f, -0.36700234f, 
    -0.12662908f, -0.55668306f, 0.17400984f, 0.60054588f, 0.16972841f, 0.22669622f, 0.14237635f, -0.04709563f, 
    -0.16746901f, -0.36426431f, -0.23086591f, -0.25674906f, 0.01123351f, 0.31246510f, 0.01915681f, 0.31050518f, 
    -0.20888016f, 0.50146091f, 1.06166685f, 0.08033693f, -0.19459678f, -0.21192746f, -0.57643360f, -0.69426912f, 
    0.15238108f, -0.19538072f, 0.36888355f, -0.08047100f, -0.16280222f, -0.23814298f, 0.22166376f, -0.23652571f, 
    -0.16012546f, 0.09962346f, -0.17385134f, -0.04078862f, 0.01677806f, 0.04031442f, 0.44286293f, 0.03354702f, 
    0.17916793f, -0.14851473f, 0.22492547f, 0.39553195f, 0.77036554f, 0.36772707f, 0.28586900f, -0.52646089f, 
    0.10249408f, -0.60055149f, -0.61744690f, -0.00810847f, 0.52069980f, 0.41499409f, 0.20473486f, 0.24125479f, 
    -0.40836006f, -0.01850886f, -0.19071750f, 0.18074477f, 0.07351574f, 0.38258654f, 0.04265187f, 0.13551836f, 
    0.17289428f, 0.37658280f, -0.11179467f, 0.58446342f, 0.66170770f, 0.58321065f, 0.53647125f, 0.10218179f, 
    0.05498717f, -0.09949740f, -0.03770713f, 0.33060461f, 0.38306606f, -0.07682790f, -0.16784407f, -0.34845155f, 
    -0.21055089f, 0.28386366f, 0.29465148f, 0.23209101f, 0.18192041f, -0.18537955f, 0.15050623f, -0.29915652f, 
    0.18184647f, 0.34808794f, -0.22973487f, 0.36130983f, 0.87641680f, 0.90564269f, -0.62935656f, -0.41431731f, 
    -0.91494465f, 0.06057451f, 0.25076613f, -0.35956416f, -0.10851277f, -0.13781072f, 0.19789876f, 0.06367952f, 
    0.19584240f, 0.16756250f, -0.29620558f, 0.16909353f, -0.26265034f, -0.04231587f, 0.20754036f, -0.08553501f, 
    0.33715782f, 0.09873950f, 0.02231877f, 0.11668296f, 0.07788093f, -0.17123720f, -0.26356494f, 0.86389184f, 
    0.59114039f, 0.02708783f, 0.24603367f, -0.42221722f, -0.12099846f, 0.05440523f, 0.06901362f, -0.08653030f, 
    0.10401571f, -0.24900647f, 0.61403948f, 0.05412803f, 0.60028327f, 0.05511925f, -0.11975951f, -0.01342067f, 
    -0.20937613f, -0.41246167f, 0.05345018f, 0.30391267f, -0.08089326f, -0.25994810f, -0.52702224f, -0.56990832f, 
    0.90937907f, 0.13082977f, 0.29173005f, 0.54662949f, 0.35407969f, 0.61421281f, -0.47931325f, -0.52687621f, 
    0.25476301f, -0.51982296f, -0.24904829f, 0.13772610f, -0.27841511f, 0.18444270f, 0.32473439f, 0.16984494f, 
    -0.32095608f, 0.26211092f, -0.22121750f, 0.20848991f, -0.19674389f, -0.17088298f, -0.38808322f, -0.52454436f, 
    0.54485160f, 0.05938936f, 0.84057164f, 0.08786257f, 0.52630436f, -0.06408674f, -0.46910942f, 0.52255207f, 
    -0.17659639f, -0.32870966f, -0.45193949f, -0.47736907f, 0.39464867f, -0.65018916f, -0.14341338f, 0.17631115f, 
    0.14719974f, -0.24406575f, -0.34990871f, -0.08981518f, 0.08393639f, -0.20749941f, 0.07649749f, 0.03561182f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.06029801f, -0.05696057f, 0.07435633f, 0.11867731f, 0.04435319f, 0.07993963f, 0.22494631f, 0.07552310f, 
    0.02089797f, 0.19201434f, 0.14316550f, -0.05200444f, -0.01880695f, 0.10286901f, 0.11541624f, -0.08406185f, 
    -0.01725402f, -0.12546447f, 0.23648813f, 0.23449267f, 0.02857276f, 0.16468213f, 0.24033983f, 0.39054069f, 
    -0.21758886f, -0.01301187f, 0.19379671f, 0.22863045f, 0.11339765f, 0.24871492f, 0.14658825f, 0.01196395f, 
    0.20323151f, 0.25716808f, 0.23495775f, 0.11889044f, 0.08845353f, 0.04062864f, 0.09091153f, 0.00513747f, 
    0.17023943f, 0.16243653f, 0.25262916f, 0.27986109f, 0.17746489f, 0.24756050f, 0.12532370f, -0.00625179f, 
    0.15732801f, 0.23509909f, 0.20782140f, 0.07618382f, -0.08256783f, 0.21706095f, 0.10964638f, -0.08578471f, 
    0.15047203f, 0.13943987f, 0.09463637f, 0.29492617f, 0.19053416f, 0.08210580f, -0.03175604f, 0.04168913f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.43092179f, 0.07099396f, 0.06318123f, -0.13770854f, 0.06317225f, 0.01693807f, 0.02588454f, 0.03207603f, 
    0.03335373f, -0.07594673f, -0.11286938f, 0.08225044f, -0.16288152f, -0.06607652f, 0.36913127f, 0.24714951f, 
    -0.00775442f, 0.08574086f, 0.07004643f, 0.01329231f, 0.06246123f, -0.07326072f, 0.08080766f, 0.01715631f, 
    -0.07848857f, 0.03653319f, 0.07172512f, 0.04614652f, -0.07422055f, -0.12658431f, 0.12681752f, -0.15046372f, 
    -0.16368368f, -0.04215838f, -0.14325868f, -0.05228275f, 0.03965047f, 0.01470949f, 0.09088806f, -0.02046540f, 
    0.02648222f, 0.03900702f, -0.01157144f, -0.02038671f, -0.00123411f, -0.03859282f, 0.08239847f, -0.06498984f, 
    -0.10807470f, 0.17145634f, -0.01590776f, -0.16836570f, -0.00968508f, 0.00684224f, -0.10241268f, -0.00234713f, 
    0.01523106f, -0.00890593f, -0.06829228f, -0.00370690f, -0.17840657f, 0.15322420f, -0.09803914f, -0.05262528f, 
    0.17161234f, -0.03620956f, -0.01255011f, 0.12958299f, 0.07622442f, 0.04072435f, -0.08876551f, -0.01889630f, 
    -0.12429893f, -0.13306960f, 0.09621849f, -0.18444434f, 0.01877169f, 0.00151640f, 0.02543580f, -0.00719391f, 
    -0.04201461f, 0.12946761f, -0.10291936f, -0.07758532f, 0.24525818f, -0.06162208f, -0.01131270f, 0.10552876f, 
    -0.11959850f, -0.03763790f, 0.01634411f, -0.01747767f, -0.04752434f, -0.05491449f, -0.00071692f, 0.04179401f, 
    -0.23886746f, 0.20265026f, -0.08264757f, 0.15415296f, 0.02696722f, 0.03249456f, -0.07809654f, -0.06916890f, 
    0.05550449f, 0.06997836f, 0.00508051f, -0.06590158f, 0.03230438f, 0.10364704f, -0.05043411f, 0.04037838f, 
    0.02564853f, -0.10965437f, 0.05529576f, 0.05100581f, 0.06791604f, -0.06996422f, -0.08768390f, 0.06707945f, 
    -0.18620935f, 0.14189486f, -0.10651956f, -0.15096663f, -0.09971891f, -0.07766221f, -0.07474858f, -0.08928749f, 
    -0.01860093f, 0.05975768f, 0.01258573f, -0.01033594f, -0.01276614f, 0.32149768f, -0.01530907f, -0.23823026f, 
    -0.00662957f, 0.05235912f, 0.07211896f, -0.00670436f, 0.10905089f, 0.02371367f, -0.12797254f, -0.13436823f, 
    0.14616328f, -0.13270637f, 0.13924563f, 0.10591038f, -0.16288491f, -0.00581391f, 0.06068341f, 0.09444039f, 
    -0.19863202f, 0.01268879f, 0.10237924f, -0.15921777f, -0.39537811f, -0.03372628f, 0.03261220f, -0.00187127f, 
    -0.09658729f, 0.07780303f, -0.09029147f, 0.04876785f, 0.04575723f, 0.13095021f, -0.13832493f, 0.02097043f, 
    -0.06695191f, 0.09111292f, -0.03260700f, 0.19863993f, -0.00200814f, 0.09489760f, 0.03278469f, 0.02648462f, 
    0.08806571f, 0.02039956f, -0.12667511f, 0.00373007f, -0.01755152f, -0.12671193f, 0.14110370f, 0.23602052f, 
    -0.04056454f, -0.06373543f, -0.00825265f, 0.04024439f, 0.01860924f, 0.03022557f, 0.09081388f, 0.05598148f, 
    0.18647584f, -0.03307862f, -0.08554213f, -0.17044500f, 0.10899481f, 0.02919835f, 0.01332157f, -0.08911861f, 
    -0.06680813f, -0.00806952f, -0.02294629f, 0.08724511f, 0.16937475f, -0.00631618f, -0.07044250f, -0.17750157f, 
    -0.02187190f, 0.02079785f, 0.04954545f, 0.00992663f, -0.01527275f, 0.03451629f, 0.01850658f, 0.02063948f, 
    -0.01618488f, 0.03464975f, -0.02261669f, -0.21023206f, 0.10783099f, -0.00363607f, 0.01608824f, -0.00333833f, 
    -0.00589085f, -0.00497806f, -0.01003817f, 0.03449061f, -0.06095012f, 0.05299915f, -0.19186249f, -0.12260227f, 
    0.06879428f, -0.09187034f, -0.12228764f, -0.09898619f, -0.01253269f, -0.05123420f, 0.04022165f, 0.03631404f, 
    0.34730428f, 0.08851147f, 0.01109037f, -0.20297523f, 0.06048407f, -0.06641004f, 0.00965114f, 0.02271464f, 
    -0.02003798f, -0.07035705f, -0.06677347f, -0.01927010f, 0.02612785f, 0.08565547f, 0.00091436f, -0.00096027f, 
    -0.09948396f, 0.06182140f, 0.05221985f, -0.14099404f, 0.05191046f, -0.07149999f, -0.06014160f, -0.03174030f, 
    -0.01286864f, -0.08038446f, -0.00971738f, 0.15370247f, -0.10836444f, 0.09928347f, 0.01398674f, 0.01287002f, 
    -0.01220292f, 0.04576283f, -0.08936652f, -0.04591241f, 0.16454607f, -0.01526030f, -0.04305517f, 0.12390101f, 
    -0.16567293f, -0.15016522f, -0.10640207f, 0.01831687f, -0.12716439f, 0.02182341f, 0.07421526f, -0.00224400f, 
    0.02098021f, -0.01327425f, 0.10153884f, -0.17313249f, -0.16864108f, -0.15168293f, 0.13013165f, 0.12137408f, 
    -0.07768685f, -0.00305280f, 0.10762203f, -0.06078723f, -0.30566958f, 0.11026525f, -0.16507098f, -0.03929742f, 
    0.08633130f, 0.07279906f, 0.08457721f, 0.09770199f, 0.03448489f, -0.07610319f, -0.03207307f, 0.05373985f, 
    -0.02016558f, -0.04094381f, -0.06533684f, -0.01664457f, -0.03204991f, 0.02438016f, -0.04603615f, -0.00052018f, 
    -0.00387379f, -0.21337497f, 0.00831576f, 0.07131661f, -0.29740980f, 0.03148965f, 0.03341630f, -0.04944394f, 
    -0.08171622f, -0.01225101f, 0.03373965f, -0.00545603f, 0.01102724f, -0.15934956f, -0.02408808f, -0.00765698f, 
    0.10297484f, 0.08504035f, -0.13677451f, -0.17210092f, 0.09125664f, -0.05551436f, 0.12020611f, -0.05303265f, 
    0.06824060f, -0.04186908f, 0.06769565f, 0.03102224f, 0.21661045f, -0.06680606f, -0.01386258f, 0.08008068f, 
    -0.06096036f, -0.02698733f, -0.11850532f, 0.04058295f, -0.04808681f, -0.01565593f, 0.04156717f, -0.05798568f, 
    0.08899494f, -0.19982801f, 0.07889196f, -0.02672084f, -0.04611761f, -0.08688816f, 0.03026122f, 0.10531536f, 
    -0.07309525f, 0.04322148f, -0.00427778f, -0.07417332f, -0.22629900f, -0.25744355f, -0.11513998f, 0.05173157f, 
    -0.06904519f, -0.00733875f, -0.05482725f, 0.03609462f, 0.06358942f, 0.04891080f, 0.04530329f, -0.07049805f, 
    -0.05169618f, -0.03874592f, -0.27462643f, 0.14636379f, 0.04830686f, -0.04498539f, 0.02773451f, -0.09193560f, 
    -0.06455268f, -0.02347258f, -0.05586561f, -0.03017850f, 0.01809400f, -0.14846827f, -0.03730920f, 0.10467381f, 
    -0.00982469f, -0.02152430f, 0.08298337f, -0.05738483f, 0.01805916f, 0.11598476f, -0.06156470f, -0.06990997f, 
    0.17631459f, -0.26732776f, -0.05175659f, -0.14424001f, -0.00204902f, 0.09369145f, 0.04124780f, 0.03655118f, 
    -0.12057787f, -0.09102862f, -0.02718588f, -0.12197534f, -0.32932943f, 0.01770292f, 0.18660435f, 0.00041430f, 
    -0.05875794f, -0.07299258f, -0.01258201f, -0.07789654f, -0.02617189f, -0.01685354f, 0.11928887f, 0.00732744f, 
    -0.19171794f, 0.00116387f, 0.07187354f, -0.11317557f, -0.02920501f, 0.06289229f, -0.03592142f, -0.07875441f, 
    0.03445974f, 0.06000264f, 0.00160228f, -0.07120417f, 0.30634952f, 0.16946940f, 0.03752835f, -0.03180646f, 
    -0.15231194f, 0.05243893f, -0.11275775f, 0.05191977f, -0.02760192f, 0.09549505f, -0.09946977f, 0.04188430f, 
    -0.06845241f, 0.06967133f, 0.05352088f, -0.19888130f, 0.04018061f, 0.05030514f, -0.01143271f, 0.00344361f, 
    0.02896394f, 0.08708032f, -0.00370496f, -0.00459158f, 0.44097191f, -0.08801559f, 0.20006311f, -0.03989743f, 
    -0.03107992f, 0.03596519f, -0.04902741f, -0.05760136f, 0.01641746f, 0.02431013f, 0.07284736f, -0.01593294f, 
    0.34087014f, -0.05360853f, 0.08736268f, -0.12875952f, 0.02015288f, -0.05743150f, 0.02120518f, 0.05316269f, 
    0.15156756f, -0.06408367f, -0.03999624f, 0.15447059f, -0.20390339f, 0.08017349f, 0.09418596f, -0.52949208f, 
    -0.04082949f, -0.06887452f, 0.03145668f, 0.00668754f, 0.03145565f, -0.04793479f, -0.04713895f, 0.05449947f, 
    0.21395522f, -0.01001650f, 0.00069353f, 0.13849385f, -0.03478032f, 0.02316867f, -0.14142163f, 0.06758760f, 
    -0.17671251f, 0.03393805f, 0.03046110f, -0.09444798f, -0.20221235f, 0.06758726f, -0.04221265f, 0.11959130f, 
    0.06546571f, 0.07883625f, -0.08218738f, 0.00031007f, 0.00940873f, 0.03975845f, -0.03175662f, -0.02264762f, 
    0.16472352f, 0.01535066f, 0.13247204f, 0.11691974f, -0.03113649f, -0.00490500f, -0.10566720f, -0.00704737f, 
    -0.08971490f, -0.11137584f, 0.01619019f, 0.00864173f, -0.48424563f, 0.17262608f, -0.01344526f, -0.04517126f, 
    0.04339506f, 0.01054281f, -0.08373860f, 0.03303081f, -0.00382595f, 0.00525385f, 0.04636308f, 0.05308434f, 
    0.08105878f, -0.02287782f, 0.05569360f, -0.13776164f, -0.16921002f, -0.05155740f, -0.00169482f, 0.09245050f, 
    0.02829229f, 0.02945216f, -0.01572176f, -0.01557719f, 0.18361750f, -0.15948988f, 0.01623815f, 0.10920951f, 
    -0.17967749f, -0.07100246f, 0.13172001f, 0.01890032f, -0.01209518f, 0.07676500f, -0.11063501f, 0.06443085f, 
    0.04694794f, 0.02501697f, 0.04874974f, 0.05075458f, -0.19445305f, -0.14081727f, 0.12932345f, -0.00834826f, 
    -0.01956514f, 0.05861361f, -0.04270233f, 0.01647993f, 0.00286493f, 0.02662419f, -0.18503848f, 0.16948190f, 
    -0.01699225f, -0.03234147f, 0.04473652f, -0.12013830f, -0.04500548f, -0.06282281f, -0.13900121f, -0.01239747f, 
    0.05039854f, -0.03446522f, 0.00562434f, 0.09021920f, -0.16607797f, 0.03657534f, 0.04022385f, 0.03015767f, 
    0.06449109f, -0.00286530f, -0.05401463f, -0.02968214f, -0.04923305f, -0.18788740f, 0.05932021f, -0.08617327f, 
    -0.01999000f, 0.03071400f, 0.07966911f, 0.12227875f, -0.01868184f, 0.02314386f, 0.00046799f, 0.05170449f, 
    0.01198865f, 0.06242044f, -0.01209815f, 0.26943985f, -0.00618761f, 0.04993213f, 0.08555651f, -0.07606726f, 
    0.00845127f, -0.10735556f, -0.02373401f, 0.05496732f, -0.30903545f, 0.25069368f, 0.13071220f, -0.40450364f, 
    -0.06917889f, 0.01574059f, 0.03563982f, 0.06021367f, -0.05457116f, 0.00946294f, -0.05812283f, 0.03730147f, 
    -0.01472948f, 0.01308756f, 0.27166468f, -0.26487279f, 0.02804372f, 0.05783119f, 0.04797555f, 0.03610947f, 
    0.03661947f, -0.13022280f, 0.07733070f, 0.08292855f, -0.44681835f, 0.28190044f, 0.09599444f, -0.13150951f, 
    -0.08962332f, 0.03897275f, 0.09864087f, -0.07810771f, 0.00250637f, -0.01267094f, -0.09039653f, 0.13128036f, 
    -0.31874111f, -0.09855283f, 0.02925734f, 0.05135851f, 0.04849505f, 0.00345819f, -0.07314791f, -0.00792978f, 
    -0.00071379f, 0.04672030f, 0.07853226f, -0.06405440f, 0.08137067f, 0.09506705f, 0.02626533f, -0.18035312f, 
    0.07216336f, -0.01604552f, -0.04974549f, 0.01742231f, -0.11058917f, -0.02710504f, 0.00692738f, 0.00242808f, 
    0.08762157f, -0.02157269f, -0.03527556f, 0.13159305f, -0.10048367f, 0.00458999f, -0.05783483f, 0.03489943f, 
    0.06196325f, -0.03427476f, -0.03088463f, -0.02418324f, 0.09254959f, -0.09449236f, -0.03054872f, 0.14440544f, 
    -0.12696646f, -0.07519463f, -0.01205212f, 0.09347834f, 0.05742728f, 0.08946051f, 0.01165995f, 0.06196159f, 
    -0.26359817f, 0.17082405f, 0.10105553f, -0.34537080f, -0.04709269f, 0.03008792f, -0.03080081f, -0.00569072f, 
    -0.10636654f, -0.06552038f, 0.03367257f, 0.06483489f, -0.04267025f, 0.00239907f, -0.29373321f, 0.19125746f, 
    0.03835279f, -0.04832641f, 0.00257802f, 0.14462854f, 0.07841329f, 0.07518086f, -0.00113260f, -0.23855422f, 
    -0.35666832f, 0.07102448f, 0.10065127f, 0.00389228f, -0.04627931f, 0.01481501f, 0.13570200f, -0.11812656f, 
    -0.01769226f, -0.18118030f, 0.10391805f, -0.10708880f, -0.00265114f, 0.02374643f, -0.13559452f, 0.19434050f, 
    0.07369413f, -0.05885756f, 0.01061008f, -0.10863401f, -0.03446119f, -0.05117976f, -0.06435607f, 0.02393978f, 
    -0.60655183f, -0.03693595f, -0.08610601f, -0.19108665f, -0.04170880f, -0.04147013f, -0.00177230f, 0.03398227f, 
    0.14807846f, -0.12923200f, 0.01299226f, -0.07768685f, -0.45832619f, 0.13170518f, -0.32643384f, -0.07445842f, 
    -0.05900329f, 0.05388816f, -0.03222549f, -0.08806916f, -0.04273753f, 0.00515961f, 0.04183649f, -0.08794619f, 
    0.14258419f, 0.06172993f, -0.03169857f, 0.07962675f, -0.07853790f, 0.08698533f, -0.03952609f, 0.01416541f, 
    -0.00775467f, 0.01704939f, 0.18257336f, 0.04100788f, -0.02942576f, 0.03320953f, -0.05366836f, -0.04113534f, 
    -0.05793035f, 0.05487065f, 0.06478130f, -0.06484417f, 0.06913940f, 0.10318461f, -0.17119515f, 0.08269822f, 
    0.10864432f, 0.13943455f, 0.05410721f, -0.10327059f, 0.01154821f, 0.04843295f, 0.03855749f, -0.03749058f, 
    0.06502209f, 0.05113764f, 0.08524452f, -0.01997553f, 0.12940253f, -0.14868291f, -0.12171260f, 0.18275505f, 
    -0.17187516f, 0.00632508f, -0.01411219f, 0.00901779f, 0.06717886f, -0.03317017f, -0.12505744f, 0.12672463f, 
    -0.04294512f, -0.11360928f, -0.08849809f, -0.08685440f, -0.04203741f, -0.05520069f, 0.08378133f, 0.04782890f, 
    0.09824613f, -0.07189907f, 0.17984977f, -0.04682464f, 0.03955102f, -0.08862358f, 0.10197017f, 0.00946683f, 
    -0.05442702f, -0.09722153f, -0.10195434f, -0.01997458f, 0.06592036f, 0.09370244f, -0.04604786f, 0.02759885f, 
    0.14766292f, -0.04253482f, 0.08519474f, 0.03977564f, 0.01453815f, 0.12320207f, -0.13540182f, 0.03764154f, 
    -0.08872220f, 0.02349476f, -0.06122823f, 0.13378413f, 0.14770807f, 0.15252997f, 0.04589223f, 0.08441750f, 
    0.00715774f, 0.02653083f, 0.03634976f, -0.04299907f, -0.02645961f, -0.07143451f, 0.08053356f, -0.16321088f, 
    0.20822538f, -0.05216278f, -0.07917087f, -0.06863690f, 0.14299352f, -0.18916400f, -0.05060676f, -0.09230631f, 
    0.00472375f, -0.07795945f, -0.00267789f, 0.06996264f, 0.02432898f, -0.25770891f, -0.07709501f, -0.10160967f, 
    -0.04390305f, -0.02932934f, -0.11481830f, 0.13537934f, -0.10022887f, -0.00863994f, -0.05963818f, 0.06949359f, 
    0.20396578f, -0.04188837f, 0.06703816f, 0.15607160f, -0.07724380f, 0.09996686f, 0.03249273f, 0.05253867f, 
    -0.00952966f, -0.01482057f, -0.06736570f, 0.13677795f, -0.13488823f, 0.05842698f, -0.08795467f, 0.07760528f, 
    0.08135957f, 0.03714674f, 0.09156927f, 0.06621242f, 0.10205894f, -0.00281697f, 0.04085035f, 0.01922509f, 
    -0.06804089f, 0.01606178f, -0.17614241f, 0.12015014f, 0.12731223f, -0.07948875f, -0.07050703f, 0.01348375f, 
    -0.09203530f, 0.07873451f, 0.09204449f, 0.02023022f, 0.31514764f, -0.48046198f, -0.27746290f, -0.16484214f, 
    -0.00702157f, -0.03963335f, -0.00578913f, 0.02732128f, -0.14620185f, 0.04263435f, 0.01027262f, -0.02857413f, 
    0.15373448f, -0.12721740f, 0.01223778f, -0.12196705f, 0.03403164f, 0.10822319f, -0.08982043f, 0.06873047f, 
    -0.07537039f, -0.06927355f, 0.00054028f, 0.01434633f, -0.26269042f, 0.00259354f, -0.02789482f, -0.12734891f, 
    0.11766392f, -0.08616777f, 0.06100883f, -0.00267846f, 0.04555826f, 0.10804951f, -0.09260515f, -0.03361902f, 
    0.26586679f, -0.04908359f, 0.09504467f, -0.15768437f, 0.02692250f, -0.02754584f, 0.01707381f, 0.10081058f, 
    0.02058749f, -0.04431407f, 0.01275993f, -0.03614187f, -0.21141554f, -0.10178225f, 0.05280385f, -0.22336873f, 
    -0.06077176f, -0.01988282f, -0.03914661f, 0.16589420f, -0.04444633f, -0.09766373f, -0.04641077f, -0.13304366f, 
    -0.29772094f, -0.09836270f, -0.39968237f, -0.11829058f, 0.07464659f, 0.07378344f, -0.02643129f, 0.04054040f, 
    0.04451275f, 0.01254610f, -0.09997679f, 0.01952938f, 0.04220471f, -0.21921581f, -0.21731758f, -0.01137015f, 
    0.08020172f, 0.00206929f, -0.10926264f, 0.01444302f, -0.04342282f, 0.04856942f, 0.06235281f, 0.08215186f, 
    -0.16185291f, 0.02314323f, -0.02016077f, -0.13724139f, -0.05862013f, -0.12461293f, -0.10083084f, 0.16264792f, 
    -0.00945066f, -0.18267633f, -0.01371640f, -0.13777080f, 0.17876698f, 0.05350181f, 0.09182835f, 0.15282182f, 
    0.04692171f, 0.09826058f, 0.04091104f, 0.06413393f, 0.05150328f, -0.09740551f, 0.04137656f, -0.12671585f, 
    0.09189945f, -0.22371525f, 0.10822194f, -0.11429440f, -0.07091426f, 0.12087059f, -0.16194868f, -0.03689021f, 
    -0.01478588f, -0.15941872f, -0.28352219f, 0.03456075f, 0.05645059f, -0.10636345f, 0.01480352f, 0.10274325f, 
    0.02996894f, -0.10370553f, 0.01702875f, 0.00044748f, -0.01207951f, -0.09656541f, 0.11414558f, 0.15126893f, 
    -0.01142889f, 0.16417392f, 0.04568138f, 0.03542860f, 0.03950283f, -0.19053774f, 0.05521582f, -0.02544600f, 
    0.03832578f, 0.10470578f, -0.08828417f, -0.01508151f, -0.13461071f, -0.04704205f, -0.19871059f, -0.18491080f, 
    -0.04043758f, 0.08157268f, 0.02058738f, -0.16408189f, -0.14023761f, -0.00125885f, 0.10788489f, -0.00975363f, 
    0.13816652f, -0.23533316f, -0.06001119f, -0.08621491f, 0.08424886f, -0.01589966f, -0.11537000f, 0.01054218f, 
    0.03598410f, -0.02719257f, -0.06762444f, 0.12397730f, 0.07260136f, 0.00168895f, 0.14353596f, 0.30285245f, 
    -0.06224389f, -0.11785761f, 0.06531972f, 0.01654608f, 0.06624806f, -0.08992922f, 0.00756432f, 0.14978585f, 
    0.26245901f, -0.27576882f, 0.16482373f, -0.13782942f, -0.00341806f, -0.19771443f, -0.04250087f, -0.00361892f, 
    0.01312665f, -0.09432648f, -0.10983586f, 0.02577954f, -0.18640889f, -0.14588402f, -0.00155021f, 0.01134074f, 
    0.11490879f, 0.08959498f, 0.09341105f, 0.12205898f, 0.04138689f, -0.09741080f, -0.04052961f, -0.00566663f, 
    -0.15554814f, 0.03789365f, -0.11740094f, 0.10528482f, 0.10902415f, 0.08434573f, -0.09854281f, -0.04462647f, 
    0.05501650f, -0.04664099f, 0.23972706f, 0.11655725f, -0.36618131f, 0.21504593f, 0.03293395f, -0.00410953f, 
    0.00534218f, 0.03056082f, -0.01370949f, -0.01339629f, 0.08787761f, -0.03317577f, 0.05582580f, 0.06297274f, 
    -0.10890333f, 0.00301691f, -0.01289732f, -0.01713070f, -0.05694484f, -0.06570744f, 0.08690329f, 0.02536747f, 
    0.04646557f, 0.07373729f, 0.03397782f, 0.06598092f, 0.05231743f, 0.12873217f, -0.21120450f, -0.03200952f, 
    -0.04337223f, 0.08837482f, 0.09135420f, 0.07766018f, -0.02219035f, -0.05518322f, -0.09576017f, -0.11161400f, 
    0.06468088f, -0.10011018f, -0.05689488f, -0.06980283f, 0.00621697f, -0.05473396f, 0.05181320f, 0.05864391f, 
    -0.05732033f, -0.08599225f, -0.04810404f, 0.05176126f, -0.31372240f, -0.43252009f, -0.22710097f, 0.04229078f, 
    0.14237154f, 0.03892721f, 0.01929142f, 0.07589643f, 0.01485456f, 0.03643309f, -0.11191636f, -0.09698170f, 
    0.25892684f, -0.12276739f, -0.20256662f, -0.12565380f, 0.03935090f, -0.07465067f, -0.03584710f, 0.03061218f, 
    0.08723823f, -0.02405803f, 0.03107430f, -0.04219486f, -0.24738340f, 0.12400703f, -0.08968376f, -0.01088512f, 
    0.03712565f, -0.01122104f, -0.00790613f, -0.06692455f, 0.02294870f, 0.03206635f, -0.04316321f, 0.04915869f, 
    -0.14312190f, -0.00125370f, -0.00998783f, -0.08547975f, 0.02683056f, -0.06656356f, 0.13524897f, 0.10334008f, 
    -0.09056790f, 0.13727444f, -0.01105049f, -0.07596003f, 0.37070686f, -0.29740915f, -0.02120215f, -0.32022116f, 
    0.02996671f, -0.12626892f, -0.00076185f, 0.03567188f, -0.08379544f, -0.02218220f, -0.02002895f, 0.11387021f, 
    0.20951450f, -0.11511306f, 0.15181693f, 0.02514371f, -0.04679280f, -0.03605245f, -0.01281545f, -0.00790681f, 
    0.16833723f, -0.03417207f, -0.03850594f, 0.16314076f, 0.15320463f, 0.19240600f, -0.29033315f, 0.09011041f, 
    0.07506908f, 0.09956570f, -0.05842326f, -0.01911683f, -0.12551384f, 0.07398510f, 0.04306776f, -0.00862361f, 
    -0.06197616f, -0.16448444f, -0.09545077f, -0.04772093f, -0.03461749f, -0.00902139f, 0.10036863f, 0.09862335f, 
    0.04237609f, 0.08203872f, 0.00407122f, 0.03224858f, 0.33094257f, -0.02240715f, -0.06154777f, 0.13777100f, 
    -0.12518731f, -0.06199956f, 0.04537448f, -0.00586810f, 0.03750160f, -0.12768054f, -0.02633033f, -0.17625579f, 
    0.27366275f, 0.21644662f, 0.00002810f, 0.03449043f, 0.06870684f, -0.03658830f, -0.05255924f, -0.03471278f, 
    -0.00891238f, -0.04368863f, -0.04894940f, 0.00745317f, 0.22981143f, -0.22651449f, 0.05860553f, -0.01267790f, 
    0.11534828f, 0.01278090f, -0.14172032f, -0.00387348f, 0.07185180f, -0.05726764f, 0.13605125f, -0.04513853f, 
    0.21314691f, -0.06951142f, 0.20155258f, 0.01429570f, -0.14761478f, 0.03480691f, 0.01033120f, -0.00367060f, 
    -0.07845688f, -0.03564603f, 0.04198993f, -0.04054398f, 0.15409489f, -0.08706520f, 0.02984597f, 0.27315199f, 
    -0.10607988f, -0.01175914f, 0.03241882f, 0.06638487f, 0.02495866f, 0.01433088f, 0.01736786f, 0.09426571f, 
    0.14418688f, -0.07307990f, 0.20811628f, 0.19354384f, -0.10592005f, -0.05504579f, -0.05186960f, 0.02663440f, 
    -0.10465626f, -0.01775288f, -0.02431863f, 0.00518382f, -0.09851114f, 0.03178816f, -0.25123265f, -0.04021686f, 
    -0.05091736f, 0.12942205f, 0.01060787f, -0.01701548f, 0.17540286f, -0.06005481f, -0.03094061f, 0.00756517f, 
    -0.02011964f, 0.22030099f, 0.01665895f, 0.15170725f, 0.00906779f, 0.13070406f, -0.02784713f, 0.00789959f, 
    -0.05721468f, 0.04179389f, 0.09835707f, -0.10821725f, 0.13834158f, -0.07150923f, -0.00606949f, -0.20792404f, 
    0.07065966f, -0.04781075f, 0.08643689f, -0.06234915f, -0.16860019f, 0.05103498f, 0.07148887f, 0.04968014f, 
    -0.04004867f, -0.02106769f, -0.10185575f, -0.32558095f, -0.00694020f, 0.07427626f, 0.10126204f, -0.00389248f, 
    -0.13004014f, 0.09587900f, 0.04955293f, -0.08294243f, -0.04376224f, -0.14415941f, -0.05554855f, -0.09467406f, 
    -0.09370139f, 0.01546741f, 0.04345334f, -0.03941045f, 0.00691124f, 0.07454106f, 0.02896606f, -0.15243824f, 
    -0.03564233f, -0.09163722f, -0.12201057f, -0.02524801f, -0.11265432f, 0.01215788f, 0.00046202f, -0.01022840f, 
    0.11609598f, -0.06313682f, -0.17640227f, -0.02640998f, -0.05818267f, -0.01427172f, -0.09875245f, -0.05297430f, 
    -0.04408003f, -0.00145705f, 0.08329389f, 0.09755521f, 0.04091992f, -0.03445254f, -0.05314777f, 0.00823531f, 
    -0.03667697f, -0.00293994f, 0.12275381f, 0.00102736f, -0.07766175f, -0.11568394f, 0.01388071f, -0.06162181f, 
    0.03225925f, 0.03362323f, 0.10454722f, -0.09141164f, 0.19855569f, 0.05919918f, 0.10345161f, 0.15643945f, 
    -0.04618654f, -0.06900317f, 0.09007514f, 0.00553577f, -0.05599117f, -0.02724343f, 0.07353251f, -0.05646215f, 
    0.29874104f, -0.06435241f, 0.07443897f, -0.20201606f, -0.07562295f, -0.04803082f, 0.00924342f, 0.14003481f, 
    0.00153510f, 0.04680880f, 0.01248218f, 0.06781476f, 0.01150799f, 0.15009834f, -0.01988084f, 0.02425162f, 
    -0.09310775f, 0.00724242f, 0.03363514f, -0.17233819f, 0.09056213f, -0.16477159f, -0.08279398f, 0.12055505f, 
    -0.10464213f, 0.16820833f, -0.11248706f, 0.06250293f, 0.02997966f, 0.02217212f, -0.10127284f, -0.06672276f, 
    0.00112444f, 0.13816786f, -0.09952205f, -0.10948563f, -0.06338197f, 0.02391305f, -0.16965066f, 0.14358485f, 
    0.03447705f, 0.00693424f, -0.03492463f, 0.11379523f, -0.00200737f, 0.02198159f, 0.09941173f, -0.30685613f, 
    0.21336663f, 0.10941792f, -0.07171699f, 0.02207612f, -0.03557015f, 0.05869842f, -0.10532454f, -0.01441309f, 
    -0.01778086f, 0.01609220f, -0.05902762f, 0.03756130f, 0.39491534f, 0.03515869f, -0.36690792f, -0.07398883f, 
    -0.05220494f, -0.02713181f, 0.06678359f, -0.00654964f, 0.04803063f, -0.02462754f, 0.06638005f, -0.06602056f, 
    0.02838039f, -0.06076550f, 0.01282880f, 0.01084073f, -0.04232859f, -0.04010214f, 0.05746091f, -0.03655956f, 
    0.02196957f, 0.06923387f, -0.07853334f, 0.07013549f, -0.01922583f, 0.03399269f, 0.01225827f, 0.05784069f, 
    -0.02292208f, -0.00153672f, -0.13298032f, 0.01650848f, -0.03175467f, -0.03301435f, -0.01767404f, -0.03119254f, 
    0.04598147f, -0.00371920f, -0.05639936f, 0.02195723f, -0.03703513f, 0.05498245f, -0.01233312f, -0.17111152f, 
    -0.03020168f, -0.03369176f, 0.04418179f, 0.01239815f, 0.25662762f, -0.06607927f, 0.12558663f, 0.10017111f, 
    -0.08397838f, -0.04964807f, -0.08245138f, 0.00284873f, -0.00224599f, 0.00759910f, -0.02795974f, -0.02894688f, 
    -0.33486000f, -0.11619405f, 0.08661994f, -0.15228279f, -0.04810635f, 0.02772286f, 0.03727721f, -0.01388660f, 
    -0.11198165f, 0.04497912f, -0.00056677f, -0.09044183f, 0.23024888f, -0.00239730f, -0.03748733f, 0.04995908f, 
    -0.02050237f, -0.11319961f, 0.09514741f, 0.02706498f, -0.10663051f, -0.09016090f, 0.01909439f, -0.06759133f, 
    0.45115808f, -0.15671454f, -0.16917959f, -0.09611999f, -0.12703100f, 0.01187349f, -0.11736923f, -0.03859535f, 
    0.04180389f, -0.01581402f, 0.09323234f, -0.05458045f, 0.14017205f, 0.00866976f, -0.01637776f, 0.00980308f, 
    -0.09839444f, 0.02760667f, 0.04686738f, -0.03769603f, 0.01787184f, 0.06115764f, -0.00077176f, 0.01200401f, 
    -0.27555418f, 0.05820901f, -0.18225425f, -0.03382615f, -0.04789361f, -0.07135750f, 0.12172531f, 0.08588620f, 
    -0.12162676f, 0.03760043f, -0.03445656f, -0.01544852f, 0.04412897f, 0.06916306f, -0.05332500f, 0.22061574f, 
    -0.11888705f, -0.18312877f, -0.01252078f, 0.06621776f, -0.00863659f, 0.06730969f, -0.01862918f, -0.05446212f, 
    -0.30014420f, 0.06176561f, 0.10123137f, -0.09703991f, 0.15508254f, -0.04532476f, -0.04957921f, -0.00181819f, 
    0.12823105f, -0.00935111f, 0.01800680f, -0.00644829f, -0.27462885f, -0.07921024f, -0.11850875f, -0.23557036f, 
    0.02980861f, 0.06225608f, 0.00298928f, 0.00680614f, 0.00738529f, -0.13567477f, -0.02478587f, 0.00545350f, 
    0.16180858f, -0.15840696f, 0.06443342f, 0.07877299f, 0.02706124f, 0.08815809f, -0.01496171f, -0.00952211f, 
    -0.04109353f, -0.00137643f, 0.01680904f, -0.05630822f, 0.01413791f, -0.03929470f, -0.15398484f, -0.03425797f, 
    -0.05375243f, 0.03569195f, 0.02467818f, 0.07225054f, -0.01858644f, -0.00167809f, 0.00383232f, -0.02795271f, 
    0.03307692f, 0.19874738f, 0.16131631f, 0.16452920f, -0.00395593f, -0.09550668f, 0.01794153f, 0.02353728f, 
    -0.02072763f, 0.00724440f, -0.02532929f, -0.06381258f, 0.28038529f, 0.08038274f, 0.01031719f, 0.13939999f, 
    -0.04765259f, 0.01326789f, -0.00638638f, 0.05877883f, -0.11889260f, -0.01876118f, 0.04470979f, -0.05729650f, 
    0.17351241f, -0.01929539f, 0.10923848f, 0.09594359f, -0.14588174f, -0.01301897f, 0.02679518f, 0.02483980f, 
    -0.02443878f, -0.06542050f, -0.05033096f, 0.01419250f, -0.17375630f, 0.03740909f, -0.18966490f, 0.05364207f, 
    -0.05769845f, -0.00716435f, 0.02999633f, 0.00192237f, 0.04758120f, 0.02037500f, -0.04218123f, 0.01933440f, 
    0.10903361f, 0.01187737f, -0.15603630f, -0.27522102f, 0.00766275f, 0.01301726f, -0.04648857f, -0.14041531f, 
    -0.07417960f, -0.02396946f, 0.01085051f, -0.00749249f, -0.05107449f, -0.00503091f, -0.03463200f, -0.10787095f, 
    0.00535639f, -0.00814962f, -0.02945389f, -0.04097510f, -0.05894707f, -0.04623161f, 0.06416991f, -0.03450890f, 
    0.07650418f, 0.02473428f, -0.28938633f, -0.01424709f, -0.03684213f, 0.00665343f, -0.02378409f, -0.01530185f, 
    0.05907132f, 0.11492191f, -0.05404004f, -0.07305092f, 0.00441752f, 0.10238339f, -0.08167557f, -0.04922212f, 
    -0.02036500f, -0.00428142f, -0.00556437f, 0.00901804f, -0.06566008f, 0.06657967f, -0.01712995f, 0.00439799f, 
    -0.08139768f, -0.11350299f, -0.08739918f, 0.04207199f, 0.05070447f, -0.01157222f, 0.03164440f, 0.05814666f, 
    0.00564377f, 0.02589500f, 0.05150451f, -0.08988295f, 0.34393534f, 0.01121218f, -0.04050670f, 0.14906803f, 
    -0.08237816f, 0.06022380f, 0.08023577f, 0.00253476f, -0.07214197f, -0.06658435f, 0.04932273f, -0.06549967f, 
    -0.02974009f, 0.05446531f, -0.00415919f, 0.01377138f, -0.02825071f, -0.03972222f, 0.03601311f, 0.04208759f, 
    0.04467126f, -0.01160439f, -0.06737691f, -0.06468695f, 0.18362963f, -0.08685378f, -0.19666176f, -0.03091030f, 
    0.10422964f, -0.04971664f, 0.07412379f, -0.05677405f, 0.02353984f, 0.03973229f, -0.07247121f, 0.00727164f, 
    0.12001452f, 0.08266069f, 0.21195082f, 0.15068744f, -0.06452007f, 0.01745836f, 0.06507721f, 0.04964680f, 
    -0.01362814f, -0.04613547f, 0.04192559f, 0.04978162f, -0.06210495f, 0.10266389f, -0.05724029f, -0.04504856f, 
    0.04181411f, 0.06024299f, 0.06998784f, -0.04157088f, -0.00211703f, 0.00603118f, 0.09200227f, -0.06023661f, 
    0.03900708f, 0.04841074f, 0.06396081f, -0.09718763f, -0.01457570f, 0.05088460f, 0.07099217f, 0.00097337f, 
    -0.14823034f, 0.08367432f, 0.07452906f, -0.02804144f, -0.32138711f, -0.15182890f, -0.06859065f, -0.18771291f, 
    -0.04193840f, 0.04516559f, -0.17147635f, -0.05832758f, 0.00162640f, 0.10176760f, 0.02364835f, -0.02188651f, 
    0.40070871f, -0.13687323f, -0.24562429f, 0.04850077f, -0.05806568f, 0.00451938f, -0.05010458f, 0.07177823f, 
    -0.07758082f, 0.01665589f, -0.03626622f, -0.11943109f, 0.10292089f, -0.14948964f, -0.05170555f, -0.00838698f, 
    -0.15029381f, 0.00643374f, 0.00843581f, 0.01474166f, -0.03642081f, -0.11584577f, -0.04048585f, -0.06925809f, 
    -0.33444175f, 0.00082513f, 0.00990846f, 0.13085707f, -0.04228921f, -0.10245154f, -0.08387712f, -0.01295859f, 
    -0.09851272f, 0.08046915f, -0.01822442f, -0.01916770f, 0.27598011f, -0.05475734f, -0.09144263f, -0.00803561f, 
    -0.09081486f, 0.00981023f, -0.03529675f, -0.01569995f, 0.00782538f, 0.15710880f, -0.04641541f, 0.05557461f, 
    0.09493469f, -0.09486994f, 0.05008605f, -0.00960707f, 0.06628609f, -0.01190037f, -0.06716232f, -0.03086316f, 
    0.00567808f, 0.01549619f, -0.00881808f, -0.09092378f, 0.11069113f, -0.26535955f, -0.01948583f, -0.18313798f, 
    0.11143805f, 0.04218480f, -0.13219145f, 0.01821576f, -0.05817468f, -0.04561336f, 0.00342459f, -0.00670525f, 
    0.21517938f, -0.23364405f, 0.14804749f, 0.05188472f, -0.08806051f, 0.00227130f, -0.05804428f, -0.02083108f, 
    -0.02259756f, -0.07005385f, 0.04509186f, 0.09122285f, 0.28635871f, -0.09028239f, 0.13152176f, -0.02161298f, 
    -0.06308550f, -0.00447182f, -0.02349753f, 0.04626682f, -0.00310192f, 0.03933060f, -0.04140868f, -0.07964043f, 
    0.19356433f, 0.04033228f, 0.11031181f, -0.01043231f, -0.01796099f, -0.04770539f, -0.00704335f, 0.01192573f, 
    0.02695657f, -0.03490576f, -0.06885165f, 0.01321251f, -0.02074475f, -0.00278242f, 0.01791453f, 0.13755064f, 
    -0.03763606f, -0.06419456f, 0.03873337f, 0.10893153f, 0.00246015f, -0.03045991f, 0.06941769f, -0.05470902f, 
    -0.13174000f, -0.01346616f, -0.00798170f, -0.08629002f, 0.06374250f, 0.01361948f, 0.01077868f, 0.01608674f, 
    -0.07527000f, 0.03426397f, 0.01047576f, -0.07296752f, 0.06363328f, -0.17864512f, 0.12533067f, 0.02187040f, 
    -0.06493374f, -0.01301346f, -0.08995557f, -0.03271994f, 0.03610484f, -0.08648219f, -0.14611450f, 0.09618109f, 
    -0.28583038f, 0.09575600f, -0.17471416f, -0.15464076f, 0.01370380f, 0.03653874f, 0.01084022f, -0.06717990f, 
    -0.04373989f, -0.01536159f, -0.01061788f, -0.06212481f, 0.47228846f, 0.03511309f, -0.04388481f, 0.16519412f, 
    -0.04015527f, -0.04120056f, 0.00709157f, 0.05637994f, 0.09087240f, 0.02001437f, -0.03612855f, 0.06089769f, 
    -0.07204330f, -0.04096282f, -0.12619238f, 0.04923119f, 0.12240512f, 0.05098395f, 0.04985099f, -0.18635599f, 
    -0.01983137f, -0.04290741f, -0.02123733f, 0.02804113f, -0.25044316f, -0.08156795f, -0.01765368f, -0.07862959f, 
    0.06013782f, 0.05346121f, 0.01142992f, 0.05742355f, -0.06592796f, -0.04658003f, -0.11546499f, -0.08279298f, 
    0.10739557f, -0.22169212f, 0.01800310f, 0.04377835f, 0.10098027f, -0.00896718f, 0.01603455f, -0.07287795f, 
    0.06856868f, 0.05708807f, -0.06658207f, -0.00210216f, 0.00168638f, 0.12690960f, -0.02465304f, -0.03671614f, 
    0.03398635f, 0.08407062f, 0.00305374f, 0.01239601f, -0.04777182f, 0.01930014f, 0.04020281f, 0.01252709f, 
    0.23150449f, -0.09582674f, 0.04817986f, -0.06350527f, 0.16676793f, -0.00295439f, 0.08079074f, 0.01432617f, 
    -0.10171882f, 0.05757603f, 0.02379343f, 0.01790510f, -0.23886485f, -0.19237061f, 0.07309835f, -0.17155933f, 
    -0.03904356f, -0.02735505f, -0.08283628f, -0.04664527f, -0.00116272f, 0.01250875f, 0.11252313f, -0.00000981f, 
    0.21808636f, -0.03957547f, -0.11437177f, 0.01307668f, -0.10507414f, 0.03965780f, 0.02320376f, 0.00304720f, 
    -0.08455683f, 0.11559134f, 0.07704983f, -0.00971802f, -0.32770631f, -0.02121114f, -0.04091225f, -0.26929992f, 
    0.02173857f, 0.01737764f, 0.14433071f, 0.01058997f, 0.07025768f, 0.03665700f, -0.00933638f, -0.02742180f, 
    -0.31112954f, -0.12710603f, -0.08160475f, -0.14602068f, 0.12322561f, -0.03050776f, 0.03374587f, -0.12233842f, 
    0.03467915f, 0.10465495f, 0.05080342f, 0.03971015f, 0.08581255f, 0.15072520f, -0.15958203f, -0.18831642f, 
    0.03614445f, 0.15029863f, -0.04592967f, 0.08879303f, 0.01156995f, 0.08286081f, -0.15125862f, -0.04057498f, 
    0.16223589f, -0.00534958f, 0.04243610f, -0.22175361f, -0.14189027f, 0.07610074f, -0.03902814f, -0.03764163f, 
    0.01089887f, -0.11700492f, -0.01422799f, -0.17695940f, -0.20752247f, -0.00796490f, -0.00244285f, -0.14111637f, 
    -0.06426179f, 0.04970780f, 0.08202296f, -0.01847799f, -0.06084323f, -0.02123486f, 0.05790092f, 0.00922691f, 
    0.06248407f, 0.16892827f, -0.01171315f, 0.09760610f, 0.04236753f, 0.08812514f, -0.05996351f, -0.02752170f, 
    -0.00073748f, -0.04820857f, -0.06227392f, 0.00627210f, -0.00818882f, 0.00149400f, 0.01564473f, -0.09159518f, 
    0.02109084f, 0.04905073f, 0.01021347f, 0.04660391f, -0.04322024f, 0.01826688f, 0.00442383f, -0.02990020f, 
    0.02447303f, -0.04238583f, -0.06385736f, -0.18520014f, 0.00457799f, 0.01129629f, 0.03079573f, -0.10958912f, 
    -0.00609841f, 0.04626926f, 0.03018824f, -0.05863388f, 0.17597608f, 0.03614188f, -0.11972970f, 0.03763571f, 
    -0.03714607f, 0.11215244f, -0.15436247f, -0.01776914f, -0.04257008f, -0.00214901f, -0.06629726f, -0.08714900f, 
    -0.03018025f, -0.04005567f, 0.02294456f, 0.02073997f, -0.12640630f, -0.01532490f, -0.00018563f, 0.09000391f, 
    0.10459343f, 0.01515404f, -0.07030790f, -0.09858719f, 0.09411620f, -0.19036947f, -0.15192750f, -0.02773201f, 
    0.06730882f, -0.00652509f, -0.02364812f, -0.08459191f, 0.00366558f, 0.08734736f, -0.10034383f, 0.04130040f, 
    0.11813551f, 0.31956735f, 0.07781680f, -0.00615219f, -0.05841207f, -0.02485226f, 0.02201082f, 0.00822618f, 
    -0.06495702f, 0.05277027f, -0.05883831f, -0.00282088f, -0.28230175f, 0.30349386f, 0.16799988f, -0.05051068f, 
    -0.02778873f, -0.02108707f, 0.03714211f, 0.07380524f, 0.03694755f, -0.00250627f, 0.08589482f, -0.00677016f, 
    -0.25270316f, -0.27819565f, -0.14159645f, -0.04973420f, -0.06313564f, -0.06893814f, -0.02817543f, 0.02599323f, 
    0.04500273f, 0.03996557f, -0.08766431f, -0.06863140f, 0.05682832f, -0.03083849f, -0.03438588f, -0.05066571f, 
    0.00616681f, -0.02766425f, -0.05397557f, -0.07630522f, -0.00776838f, -0.07768866f, 0.07875595f, -0.06119744f, 
    -0.21733117f, 0.16112065f, 0.03813952f, -0.06552968f, 0.02727235f, 0.00075683f, 0.02688183f, 0.04530093f, 
    0.01640240f, 0.08390380f, -0.05942163f, 0.03510150f, 0.05772112f, 0.00109992f, -0.01030934f, -0.12921494f, 
    -0.14212130f, -0.12923609f, -0.01314926f, 0.01641967f, -0.01908027f, -0.00621986f, -0.08668172f, -0.12363745f, 
    0.13953003f, 0.09881339f, -0.00592550f, 0.01048991f, -0.11883508f, -0.05222034f, -0.01287963f, -0.08517719f, 
    0.07788135f, -0.02146690f, -0.05247420f, 0.04013215f, -0.18838418f, -0.00195901f, -0.13069510f, -0.09253675f, 
    -0.02252360f, 0.01251237f, 0.05196200f, -0.04798981f, -0.07074780f, -0.03013543f, -0.00124244f, -0.07060520f, 
    0.08887812f, 0.12198311f, 0.08366424f, 0.07331652f, -0.02783868f, -0.12557092f, -0.04905786f, -0.02519944f, 
    0.00696316f, -0.01277201f, -0.02903463f, -0.10449497f, -0.16839759f, -0.22307493f, -0.28679726f, 0.08549459f, 
    -0.06226175f, -0.04523734f, 0.07277656f, 0.08492585f, 0.00568748f, 0.10974409f, -0.14201255f, 0.15333307f, 
    -0.10145379f, -0.02470304f, -0.04263678f, 0.04934907f, 0.01357977f, 0.00616038f, -0.03968677f, 0.14912744f, 
    0.01659713f, 0.01876237f, -0.05207996f, 0.02090387f, 0.00034371f, -0.11391070f, -0.10534393f, 0.05756544f, 
    -0.11468140f, -0.00465528f, -0.01057966f, -0.05664045f, -0.15044554f, 0.10552976f, 0.01527893f, -0.01318948f, 
    -0.46040261f, -0.33513108f, -0.20227641f, 0.02503240f, -0.10552905f, 0.06624942f, 0.01598606f, -0.09608304f, 
    0.02337139f, -0.07273698f, 0.06143802f, -0.07364313f, 0.23181102f, 0.07179932f, 0.11723650f, -0.09282151f, 
    0.00906959f, -0.08763910f, 0.05716475f, -0.10414923f, 0.00378121f, -0.01295672f, -0.05317715f, 0.08192942f, 
    -0.19560415f, 0.02519465f, -0.10214843f, -0.05770181f, 0.04888583f, -0.13999926f, 0.15243821f, -0.00750514f, 
    -0.05045284f, 0.11951568f, -0.06866187f, -0.11151017f, 0.25929090f, -0.21453869f, 0.09410775f, -0.10330148f, 
    -0.01618646f, 0.05812037f, 0.01594112f, -0.07758924f, 0.06607251f, -0.07660975f, -0.02383066f, -0.00029451f, 
    0.02293424f, -0.01149608f, -0.11571548f, -0.08131055f, -0.02414961f, 0.01558456f, -0.07863817f, -0.06960157f, 
    -0.03243326f, 0.03870703f, 0.07329541f, 0.03970125f, -0.09177111f, -0.00706161f, 0.05058663f, -0.24063307f, 
    -0.11865177f, -0.00842738f, -0.02437157f, 0.07501632f, 0.07249940f, -0.17066653f, 0.05678553f, 0.03603273f, 
    -0.02692400f, -0.03763648f, -0.11434618f, -0.06783564f, -0.05675197f, -0.07887748f, 0.03992444f, 0.02271664f, 
    -0.04096655f, 0.03944464f, -0.00976159f, -0.01529828f, 0.00091844f, 0.00963452f, 0.10898892f, -0.00746240f, 
    -0.01997732f, -0.02577530f, -0.02226369f, -0.01691158f, 0.00326446f, 0.05012944f, 0.04627271f, 0.06430084f, 
    0.45163751f, 0.46363127f, 0.02828827f, -0.00820950f, 0.11228523f, 0.05488799f, 0.07278040f, 0.10187908f, 
    -0.05973813f, 0.05644400f, 0.02279130f, -0.03587601f, -0.00108023f, 0.00878365f, -0.14354512f, -0.02795883f, 
    -0.09335425f, 0.04912538f, -0.02436350f, 0.08319627f, -0.08772788f, -0.05876933f, -0.03332997f, -0.04477448f, 
    0.03759960f, 0.14491381f, 0.05765071f, 0.01769172f, -0.02672968f, 0.02082597f, 0.03615507f, 0.04972032f, 
    -0.03790590f, 0.04655330f, 0.00398108f, 0.10170782f, -0.54876202f, -0.10303176f, -0.08357971f, 0.06695909f, 
    -0.01179977f, 0.01225815f, -0.07999324f, -0.00427046f, 0.01348773f, 0.01001332f, -0.01080732f, 0.08263194f, 
    -0.10493360f, 0.07187303f, -0.01103394f, 0.09709001f, -0.16539963f, 0.05074156f, 0.05374890f, 0.02462102f, 
    -0.01314074f, 0.05884057f, -0.01798918f, -0.06778826f, 0.11784908f, -0.11523895f, 0.04994873f, -0.10274616f, 
    -0.08879657f, 0.05521281f, 0.03526276f, -0.00633646f, -0.10138339f, -0.01392859f, -0.05945181f, 0.06177970f, 
    -0.26557195f, -0.25992733f, -0.00706971f, -0.22638917f, -0.05763894f, -0.08092783f, 0.06701092f, -0.04796376f, 
    -0.05173660f, -0.05022191f, 0.07066376f, 0.10511506f, 0.17076087f, 0.15965028f, 0.18898001f, 0.02535371f, 
    0.08003660f, 0.09784286f, 0.08186516f, 0.00460247f, 0.01643844f, 0.04902854f, -0.04672723f, -0.04880765f, 
    0.03280561f, -0.02374649f, -0.05817727f, -0.04834534f, -0.12863323f, -0.04038741f, 0.05669613f, -0.06929716f, 
    0.02093967f, -0.05401146f, 0.05588739f, -0.07062506f, 0.21239319f, -0.35409391f, -0.18493761f, 0.25739700f, 
    -0.02699359f, 0.05610237f, -0.04915534f, -0.13258781f, -0.01836415f, -0.00391245f, -0.09959196f, -0.07157636f, 
    0.14233060f, 0.06128572f, 0.02729021f, -0.00118065f, 0.02307303f, 0.08063906f, 0.05769168f, 0.05820888f, 
    -0.03604265f, 0.01248829f, -0.04835929f, -0.02458391f, -0.00767893f, 0.10719631f, -0.01725046f, 0.10278159f, 
    -0.08104332f, -0.05063540f, 0.01301302f, 0.00764700f, 0.06763750f, -0.00021262f, 0.13250546f, 0.02525152f, 
    -0.11879823f, 0.12222994f, 0.05625519f, 0.02561853f, -0.03349162f, -0.14840110f, 0.03586151f, -0.01762077f, 
    -0.03181335f, 0.02000619f, -0.05457303f, -0.00132428f, -0.03213985f, -0.11406382f, 0.12788841f, 0.15611951f, 
    0.04181530f, 0.04372399f, 0.05830479f, -0.01454996f, 0.01960807f, 0.13807578f, -0.14777999f, -0.10586047f, 
    0.11850333f, 0.04773568f, -0.13380438f, 0.09729379f, -0.14852346f, 0.03095339f, -0.05343277f, -0.03272573f, 
    -0.02726754f, -0.01637113f, -0.07543210f, -0.03910224f, 0.15751576f, 0.05425432f, 0.09097986f, -0.07295629f, 
    -0.02859609f, -0.01643403f, 0.05812346f, -0.05637101f, 0.00586990f, 0.09141647f, -0.09916221f, 0.02475391f, 
    0.09047352f, 0.11843272f, 0.14142188f, 0.08611746f, 0.04854514f, -0.03047117f, -0.00292383f, 0.05105599f, 
    0.02630722f, 0.02969100f, -0.02981245f, -0.02578881f, 0.17371877f, -0.02867883f, -0.07314397f, 0.09040436f, 
    0.00494637f, -0.00774120f, 0.11157512f, -0.00878471f, 0.02293394f, -0.02564048f, 0.05948862f, -0.04979450f, 
    -0.00297172f, 0.06770081f, -0.09307043f, 0.05167442f, -0.16560034f, -0.07533667f, 0.01222696f, -0.07481699f, 
    0.00813327f, -0.06109301f, -0.00852910f, 0.03660277f, -0.13728341f, 0.07357877f, 0.02061735f, 0.01131058f, 
    -0.00828049f, -0.10087198f, -0.01428461f, 0.09340407f, 0.07906730f, -0.13048774f, -0.03738431f, 0.01829759f, 
    -0.09314457f, -0.04207783f, -0.13272561f, -0.13167723f, -0.05091270f, -0.05998819f, 0.02075050f, 0.01236730f, 
    -0.05251399f, -0.04881318f, -0.08499628f, 0.04314765f, 0.01935894f, -0.14359349f, 0.04378749f, -0.12401801f, 
    -0.12350175f, 0.05498764f, 0.02317678f, -0.00238231f, -0.05052281f, 0.06929831f, -0.05422452f, 0.06100982f, 
    -0.02692160f, -0.16865340f, -0.14075187f, -0.00046499f, 0.01770446f, 0.06844987f, 0.02263332f, 0.05960150f, 
    -0.05477991f, -0.01455518f, -0.03334614f, 0.00450717f, 0.00610981f, -0.04842749f, -0.15409291f, 0.02875707f, 
    0.00581328f, -0.06937001f, 0.07196033f, 0.04505035f, -0.05010892f, -0.07535792f, 0.08418557f, -0.00977910f, 
    0.18579213f, -0.22583544f, -0.00335858f, 0.04385393f, 0.05045751f, 0.05059764f, -0.03534504f, -0.00246461f, 
    0.04382057f, -0.05427950f, -0.00099930f, -0.05728829f, 0.10813374f, 0.01131024f, 0.06892128f, 0.01602384f, 
    0.04011621f, 0.01899713f, 0.03980009f, 0.04765234f, -0.03020327f, 0.04995583f, -0.05346271f, 0.07543911f, 
    -0.29600063f, -0.50917947f, -0.08056568f, 0.06663455f, -0.10747019f, -0.05739965f, 0.01205845f, -0.13552254f, 
    0.10683946f, -0.03391549f, -0.07006662f, 0.02215337f, -0.08994304f, 0.05199665f, 0.20916517f, 0.05180925f, 
    -0.00234956f, 0.12703650f, 0.05825059f, -0.04825545f, 0.05170879f, -0.01981711f, 0.05796260f, 0.07741701f, 
    0.01453238f, -0.48833272f, 0.03062150f, 0.32562724f, -0.07344957f, 0.05804149f, -0.03072519f, -0.06933268f, 
    -0.00035946f, -0.08221791f, -0.09297454f, -0.03706391f, -0.13769381f, -0.30143785f, -0.02633393f, -0.10475800f, 
    -0.07983706f, 0.01315209f, -0.01870326f, -0.00866260f, -0.06948929f, -0.01201351f, -0.03593799f, -0.13684297f, 
    0.01202194f, -0.40107217f, -0.03311216f, -0.04008792f, -0.11928447f, -0.02530493f, -0.00439631f, -0.02107433f, 
    -0.01878094f, -0.01964205f, 0.00017943f, 0.10316996f, 0.08843515f, 0.11098665f, 0.07861446f, 0.05306672f, 
    0.01853819f, -0.07015768f, 0.05483126f, -0.02012234f, 0.01428778f, -0.02686453f, -0.08698654f, 0.06354104f, 
    -0.48488054f, -0.02470705f, -0.12285792f, -0.14987175f, -0.06524254f, -0.01662284f, 0.03739014f, 0.03391591f, 
    0.02772002f, 0.04413891f, 0.10834979f, 0.01703214f, 0.13203898f, 0.04203558f, 0.09764786f, -0.03904845f, 
    -0.04043163f, -0.07974876f, -0.05238976f, 0.05696887f, 0.04872609f, -0.02264317f, -0.00200074f, -0.12556344f, 
    0.21892159f, 0.10627078f, 0.11168709f, -0.08432553f, 0.02294876f, 0.00239921f, 0.00277918f, 0.00123126f, 
    0.03415249f, 0.05354306f, -0.12271149f, 0.05322477f, 0.32593244f, 0.01506600f, 0.21616313f, 0.15069701f, 
    0.09320997f, -0.10561144f, 0.04838580f, 0.07124308f, 0.01738798f, -0.04309004f, -0.12514122f, -0.01357486f, 
    -0.00578287f, 0.16493386f, 0.08459288f, 0.10155578f, -0.10225386f, 0.04470338f, -0.05036213f, -0.04689309f, 
    0.01121436f, 0.12058560f, 0.06017008f, 0.05994802f, 0.00926822f, -0.12579440f, -0.14590061f, 0.05385162f, 
    -0.04449818f, 0.15098315f, -0.03774769f, 0.03311374f, 0.04791996f, 0.01421083f, -0.00958170f, 0.05873198f, 
    -0.54273534f, 0.06445393f, 0.09969485f, 0.18864976f, 0.03071843f, 0.05418268f, -0.04562677f, 0.01646452f, 
    -0.09793826f, 0.07854864f, -0.04395312f, -0.10640197f, -0.31225702f, -0.26350185f, -0.20155631f, 0.01024627f, 
    -0.12520364f, 0.03119321f, 0.03670835f, 0.07680503f, 0.02809019f, -0.07137749f, -0.04806687f, 0.02206582f, 
    0.07555892f, -0.19659106f, -0.07520764f, 0.03054222f, -0.01796579f, -0.02870460f, -0.01547252f, 0.03714635f, 
    -0.04841639f, 0.09291971f, -0.06885167f, 0.03371030f, -0.08904170f, -0.24682558f, 0.09737661f, 0.16561760f, 
    0.05418588f, 0.03388613f, 0.02708462f, -0.02287182f, 0.08946353f, 0.05394729f, 0.06899445f, 0.10724135f, 
    0.00333128f, -0.22571293f, 0.20866401f, 0.04455093f, -0.03138485f, -0.05377143f, 0.01871302f, 0.09879734f, 
    0.03253433f, -0.12242410f, 0.00421209f, -0.00650978f, 0.34586927f, 0.20846918f, -0.24929322f, 0.10014948f, 
    0.02787492f, -0.03158445f, 0.07965878f, 0.07784354f, -0.10395034f, -0.00134930f, 0.14505659f, 0.04423463f, 
    0.18100336f, -0.05297519f, -0.07891830f, -0.11163672f, 0.02594037f, -0.06826854f, 0.07425933f, 0.08572086f, 
    0.10416895f, 0.01494837f, -0.18688591f, 0.01878622f, 0.29063353f, 0.26255003f, -0.28256354f, -0.26908478f, 
    -0.11303949f, -0.03942732f, 0.08170525f, -0.05300214f, -0.05417651f, 0.02560839f, -0.04730804f, 0.05736088f, 
    0.15495619f, 0.15660612f, -0.10045370f, -0.03478856f, 0.02364422f, -0.15480280f, 0.07830218f, 0.02543770f, 
    0.01710902f, -0.00841046f, -0.00316405f, 0.04629836f, -0.18959604f, -0.06968605f, -0.14006820f, -0.05921159f, 
    -0.01687209f, -0.06797846f, 0.04028477f, -0.01087195f, -0.01273132f, -0.16194843f, -0.03622971f, 0.00285561f, 
    0.19337763f, -0.13004948f, -0.09559483f, -0.03403160f, -0.05369179f, -0.04364043f, 0.04451571f, -0.14357486f, 
    -0.15237235f, -0.09828012f, 0.00433613f, -0.03803714f, -0.16807289f, 0.02536009f, 0.01758775f, 0.05902257f, 
    0.10369239f, 0.01231082f, 0.03150640f, 0.13051873f, -0.05357813f, 0.09309822f, 0.03418120f, -0.09050877f, 
    0.14998977f, -0.06103151f, 0.01271184f, 0.09483677f, 0.01025550f, 0.05187310f, 0.10281465f, 0.07169805f, 
    0.09768841f, 0.02532801f, -0.05144810f, 0.02193862f, -0.18169287f, -0.18799222f, -0.06066902f, 0.20844866f, 
    0.11069990f, 0.10495764f, 0.09071591f, -0.01133466f, 0.01124400f, -0.13060948f, 0.01834870f, -0.02715416f, 
    -0.14693971f, -0.04584228f, -0.17123085f, 0.12744588f, 0.05558895f, -0.10728789f, 0.02659672f, 0.17743117f, 
    -0.02246774f, -0.06994893f, 0.05716864f, -0.05501175f, -0.18005630f, -0.25689718f, 0.04825449f, -0.11296607f, 
    -0.01775157f, 0.07155380f, 0.05860704f, 0.08663511f, 0.01666822f, 0.06792426f, 0.11450388f, -0.03009118f, 
    -0.07215630f, -0.15873376f, 0.28683549f, -0.21930757f, -0.04922678f, 0.19669385f, 0.09431363f, 0.13673544f, 
    0.05318442f, 0.01864080f, 0.08713575f, 0.07005293f, -0.33013073f, -0.06264106f, 0.02379334f, 0.14275558f, 
    -0.01382320f, 0.00640820f, -0.00381564f, 0.07889974f, -0.07433842f, -0.06706763f, 0.15201430f, 0.07847175f, 
    0.09756424f, -0.02308555f, -0.06103072f, 0.10365725f, 0.17022102f, 0.00255400f, -0.01239841f, 0.00427319f, 
    -0.03492033f, 0.12272506f, 0.00924295f, 0.02938330f, 0.18364052f, -0.09444752f, 0.05508070f, -0.10745060f, 
    0.01451420f, 0.00038094f, -0.08432493f, 0.09612288f, -0.07575494f, -0.08480193f, 0.02215874f, 0.00358614f, 
    -0.18267766f, 0.05672441f, -0.05731810f, -0.21729718f, 0.07521728f, 0.07966425f, 0.03621404f, 0.01025027f, 
    0.08605082f, -0.04687902f, 0.01976511f, -0.24873377f, -0.00516537f, 0.16715947f, -0.18599938f, 0.08638923f, 
    0.00317399f, -0.02284180f, -0.01859197f, 0.03138069f, 0.01227786f, 0.00803405f, 0.00622114f, -0.09325145f, 
    -0.18563758f, 0.08182659f, -0.02329526f, 0.09392269f, 0.09843937f, -0.04865376f, -0.04781419f, -0.00971150f, 
    0.10400324f, -0.05150671f, -0.01928533f, 0.02678188f, 0.13752329f, -0.08172362f, 0.10693427f, 0.25601006f, 
    -0.12623020f, 0.05451650f, -0.06123995f, 0.07855309f, -0.00295926f, 0.03875406f, 0.08436131f, 0.07405677f, 
    -0.13399428f, 0.09766740f, 0.07680511f, 0.28346455f, 0.01240913f, -0.02558237f, 0.10337362f, 0.02817088f, 
    0.08735599f, 0.03357142f, 0.04363875f, 0.01185093f, 0.17688012f, -0.12396529f, -0.00846919f, -0.06987498f, 
    0.00187337f, 0.05644972f, 0.12705314f, -0.02794193f, -0.05857383f, 0.01837280f, -0.02705495f, 0.09103655f, 
    0.12578221f, 0.11258091f, 0.17765018f, -0.08507088f, 0.02981981f, 0.11543275f, -0.04579108f, -0.06342176f, 
    0.06549556f, 0.02984678f, -0.00811318f, -0.03122037f, -0.00372192f, -0.17851585f, 0.01239879f, -0.15248938f, 
    0.11888302f, 0.07588564f, 0.00235873f, -0.02008897f, 0.02207198f, 0.07908080f, -0.07351252f, -0.12562446f, 
    0.00228499f, -0.01419970f, -0.01879338f, -0.10247879f, 0.05789254f, -0.01894728f, -0.04157568f, -0.00736853f, 
    -0.00883740f, 0.00497881f, 0.03666015f, 0.12226119f, -0.20410012f, 0.17549045f, 0.08797671f, 0.00046663f, 
    0.06877118f, -0.04810515f, -0.09173072f, 0.05423068f, 0.01891739f, 0.06296957f, -0.07277235f, 0.04614216f, 
    -0.03816851f, -0.07091647f, 0.03453228f, 0.08364507f, 0.09473289f, -0.08869605f, 0.00522388f, -0.01401900f, 
    -0.13547058f, 0.02662848f, 0.05200334f, 0.17118503f, 0.02713960f, -0.00326527f, -0.09509481f, -0.06109533f, 
    -0.00196654f, -0.08022460f, -0.09626614f, 0.01313592f, 0.00422070f, -0.03484952f, -0.05845252f, 0.00853408f, 
    -0.02019251f, -0.07929460f, -0.01878743f, -0.05274097f, -0.08442583f, 0.05002762f, -0.00683874f, 0.01649734f, 
    -0.04597837f, 0.03083888f, 0.09378035f, 0.01870415f, -0.44644845f, 0.19023024f, 0.14172958f, 0.06681131f, 
    -0.00482393f, 0.08224749f, -0.01851966f, 0.01519161f, 0.10705162f, 0.02874538f, -0.09782331f, 0.11952306f, 
    -0.60287887f, 0.16867736f, 0.06834109f, 0.18864056f, 0.07238434f, 0.05275901f, -0.02439201f, 0.02985528f, 
    -0.16052222f, 0.01366108f, 0.00463149f, -0.05199194f, 0.01547831f, -0.20983577f, 0.16415842f, 0.10719859f, 
    -0.15669274f, -0.01580258f, 0.00810682f, -0.06348584f, 0.13736741f, 0.02117296f, 0.00709423f, -0.05414549f, 
    0.07444862f, -0.05641079f, -0.24581976f, -0.03788348f, -0.06270708f, 0.08237538f, 0.03817901f, -0.12106799f, 
    -0.11490271f, -0.11217970f, -0.02300403f, -0.01617884f, 0.25543776f, -0.00040028f, 0.06012385f, 0.06571639f, 
    0.04676231f, 0.04006174f, -0.02552505f, -0.02537910f, -0.03729080f, 0.07425833f, -0.05995005f, 0.17634675f, 
    -0.16449028f, -0.06048429f, 0.10124771f, -0.05229403f, -0.04841636f, -0.05854584f, -0.06740254f, -0.02686752f, 
    -0.03059050f, 0.05066365f, -0.16373722f, -0.04480989f, -0.07419666f, 0.06947961f, 0.15937662f, -0.12500748f, 
    -0.00255254f, -0.02417070f, -0.04288839f, -0.03537449f, 0.08366394f, 0.03468896f, -0.12134732f, -0.00849964f, 
    -0.18161179f, 0.06648709f, -0.09612595f, 0.08308306f, 0.06914642f, 0.02461602f, 0.01846603f, -0.00144617f, 
    0.03001774f, -0.01262191f, -0.01227694f, -0.11273511f, 0.14728141f, 0.19889468f, -0.01803072f, -0.21403494f, 
    -0.00156690f, -0.07375006f, -0.02575379f, -0.00540020f, 0.05246929f, -0.00608104f, -0.11538250f, 0.02646188f, 
    -0.23163332f, 0.15765570f, -0.10627519f, -0.21485735f, -0.06745780f, -0.04094880f, 0.00895444f, 0.00483535f, 
    -0.07375520f, 0.00142861f, 0.03958124f, 0.03035836f, -0.09544230f, 0.00551437f, -0.08904576f, -0.05828092f, 
    0.05531166f, -0.03656251f, -0.00591732f, -0.08887123f, -0.04453269f, -0.00185923f, 0.12127329f, 0.03467759f, 
    -0.33560231f, 0.09419527f, 0.08105367f, 0.20602277f, 0.01617207f, -0.05358559f, -0.12321798f, 0.17395703f, 
    -0.04842798f, -0.05694200f, 0.03486280f, 0.02013537f, -0.33234468f, 0.32092309f, -0.24654408f, -0.09570203f, 
    0.06992242f, 0.04196178f, 0.07341310f, -0.06359085f, -0.03844936f, 0.03145147f, 0.00163957f, 0.02673721f, 
    -0.17695479f, -0.08954458f, 0.12740946f, 0.20769534f, 0.00458201f, -0.03497589f, -0.03005340f, 0.00354280f, 
    -0.05401229f, 0.03501697f, -0.01237611f, 0.02918172f, -0.04155049f, -0.03248638f, 0.13957976f, 0.09274864f, 
    -0.07272674f, 0.01542599f, 0.05755064f, 0.02471557f, 0.02907213f, 0.05587603f, 0.05222970f, -0.07690978f, 
    0.27161101f, -0.01670589f, -0.04310828f, 0.01082195f, -0.06275741f, -0.06921942f, -0.06648502f, -0.00194363f, 
    -0.04443151f, -0.02532166f, -0.09787429f, 0.00949488f, -0.32509872f, -0.07792995f, -0.13717808f, -0.22871543f, 
    -0.00158465f, 0.03963396f, 0.08824141f, -0.00045171f, 0.13026747f, -0.07265650f, 0.00239404f, 0.04267439f, 
    -0.15293315f, -0.11474066f, 0.12949486f, 0.19677316f, -0.13670734f, -0.02039089f, -0.08576059f, -0.15484554f, 
    0.12019626f, -0.02595254f, 0.04274375f, -0.06301952f, -0.54498792f, 0.12162254f, 0.01547222f, -0.08137612f, 
    0.01043454f, -0.06505221f, 0.02201579f, -0.02847553f, -0.04476683f, -0.05133206f, -0.02920288f, 0.08064333f, 
    0.23083007f, -0.04555390f, 0.05917940f, 0.29393685f, -0.21233425f, 0.01894481f, 0.03266786f, -0.01717847f, 
    0.03269601f, 0.02333474f, -0.07307342f, -0.06201509f, -0.11482006f, 0.14116830f, 0.15443245f, 0.00986644f, 
    0.03880887f, 0.05660705f, 0.01077394f, -0.00139891f, 0.08591776f, -0.06399998f, -0.02619165f, -0.12950788f, 
    -0.23000272f, 0.14963360f, -0.00897188f, 0.04284316f, 0.05008742f, 0.00422263f, 0.00586849f, 0.06663091f, 
    0.06178808f, -0.06889499f, -0.04587423f, 0.01263396f, -0.03548643f, 0.14746313f, 0.11006426f, 0.00559051f, 
    -0.06600555f, 0.05229181f, 0.14562216f, -0.04779353f, 0.02353862f, 0.00001076f, 0.01160619f, 0.02725288f, 
    0.10605254f, 0.02520863f, -0.09897733f, -0.07757681f, -0.13056557f, 0.01462128f, 0.05406597f, 0.09778796f, 
    -0.08643398f, -0.04625999f, 0.01633362f, -0.00247210f, 0.00137374f, 0.08462796f, -0.11969633f, -0.18640932f, 
    0.09575064f, -0.08571032f, 0.02282066f, 0.14948942f, -0.09684270f, -0.02091079f, 0.05679084f, -0.04909908f, 
    -0.20816915f, 0.14035022f, 0.01204169f, -0.00264279f, 0.07163808f, -0.08434865f, 0.07941400f, 0.12242115f, 
    -0.02487563f, -0.03924361f, -0.01682098f, 0.00073979f, -0.05007726f, -0.03148153f, 0.19545509f, -0.05158662f, 
    -0.02014773f, 0.03083677f, 0.04971698f, 0.06747717f, 0.00230826f, -0.00743720f, 0.00429535f, -0.02371729f, 
    0.01517431f, -0.08152281f, -0.04185242f, 0.14646676f, -0.00700446f, -0.04160158f, 0.02666760f, 0.06248290f, 
    -0.00033900f, -0.01000172f, 0.00599439f, -0.01811797f, -0.15249357f, 0.06257234f, 0.09152417f, -0.19710931f, 
    0.10192744f, 0.02077760f, -0.06135544f, -0.01752983f, -0.07197896f, -0.02241542f, 0.12532571f, 0.05290600f, 
    -0.09364151f, -0.00828618f, 0.06533497f, 0.01528557f, 0.06371276f, -0.06782877f, 0.05755470f, 0.03722711f, 
    -0.11783894f, 0.04569888f, 0.02536764f, 0.07716727f, -0.00077131f, -0.27921942f, 0.06903838f, 0.12016121f, 
    -0.28052011f, 0.01029966f, 0.04066239f, -0.17453785f, 0.03821232f, 0.04672890f, 0.01457773f, -0.03865951f, 
    -0.40918717f, -0.14313479f, 0.13865137f, -0.00861359f, -0.04868538f, -0.02185452f, -0.02572389f, 0.03534202f, 
    0.02506425f, -0.08769725f, -0.02760634f, -0.10811881f, 0.00684478f, 0.01839867f, 0.04605246f, -0.10902791f, 
    -0.05772038f, -0.01071720f, -0.10221789f, 0.02230835f, -0.02279459f, -0.02370515f, 0.05209812f, -0.02038035f, 
    -0.15686068f, -0.19025946f, -0.08369096f, -0.06647816f, -0.04310939f, -0.08412129f, 0.01995419f, -0.01959749f, 
    0.05143508f, -0.01547248f, -0.07712857f, -0.08581606f, -0.08714095f, 0.01676062f, 0.05063684f, -0.02879803f, 
    -0.05404159f, 0.04479739f, -0.13257073f, 0.11427516f, 0.06495931f, -0.01948816f, -0.05264366f, 0.01867370f, 
    0.00984700f, 0.10672818f, -0.24656652f, -0.30589214f, -0.03168967f, -0.04608754f, 0.04374928f, 0.04627130f, 
    -0.09972209f, 0.03894809f, 0.05117648f, 0.07550104f, 0.25372073f, 0.22530897f, -0.11067533f, -0.02221484f, 
    -0.09485614f, 0.15113659f, 0.01010982f, 0.01221659f, -0.00309381f, -0.06746829f, 0.08142035f, 0.16621941f, 
    -0.27532732f, -0.24499770f, 0.04794186f, 0.15336202f, -0.00633158f, 0.04494443f, -0.02921004f, -0.09077906f, 
    0.01507955f, -0.07793656f, 0.16925971f, -0.16565605f, -0.35975897f, -0.13225228f, 0.07166186f, 0.16189674f, 
    0.02376059f, -0.12597129f, 0.01088008f, 0.02600657f, 0.02426406f, 0.13238762f, -0.13039127f, 0.00534359f, 
    -0.02355264f, -0.16652928f, 0.19809365f, 0.09771692f, 0.05936943f, 0.25180918f, 0.00431607f, 0.11216103f, 
    0.05216537f, -0.07822494f, 0.03182872f, -0.07232864f, -0.27548492f, 0.12801036f, 0.03483576f, 0.06978668f, 
    0.01131535f, 0.06529266f, 0.13953009f, -0.03033562f, 0.00896129f, 0.12097234f, -0.18548059f, -0.10491310f, 
    -0.16391848f, -0.00778309f, 0.13375655f, -0.02283126f, -0.14712787f, -0.04063266f, 0.07918344f, -0.03882013f, 
    0.08919998f, -0.07921756f, 0.02493775f, 0.16180408f, -0.27782497f, -0.10323603f, -0.14629479f, -0.12749653f, 
    0.11224033f, 0.12388619f, 0.03659825f, -0.03861535f, 0.05934629f, -0.01927276f, -0.10600188f, 0.09353921f, 
    -0.29323611f, 0.05639054f, -0.04503703f, 0.03027897f, 0.16452610f, 0.08869789f, -0.08820628f, -0.00953530f, 
    0.06941140f, -0.25706103f, 0.04162815f, 0.11078560f, 0.31747472f, 0.10895505f, -0.00134403f, -0.33627090f, 
    -0.00957949f, -0.05193112f, -0.15903790f, -0.09067247f, -0.12382219f, 0.03783058f, 0.05912825f, -0.02363375f, 
    -0.26453233f, -0.12728293f, -0.13715640f, -0.34241131f, 0.09035385f, 0.04638661f, 0.16942313f, -0.04755340f, 
    0.02844948f, -0.01790407f, -0.16010313f, 0.10886180f, 0.15564191f, -0.00458340f, 0.06145267f, 0.00288350f, 
    0.02983586f, 0.05359738f, -0.03053029f, -0.07266586f, -0.09572309f, -0.09297076f, 0.00411188f, -0.03502947f, 
    0.07104187f, 0.03394518f, -0.03202617f, 0.17434277f, -0.02090389f, -0.04547102f, 0.02871172f, 0.03520787f, 
    -0.07134752f, 0.06616374f, -0.01807553f, -0.10022224f, -0.04304980f, -0.14258002f, -0.23285702f, -0.00475969f, 
    0.10922691f, 0.11415248f, 0.08062723f, -0.20540181f, 0.01054053f, -0.04662070f, -0.08129506f, 0.05217962f, 
    -0.06889145f, 0.11635686f, 0.12751380f, 0.02649455f, -0.02537897f, -0.07148894f, -0.08612398f, -0.02246129f, 
    0.09986285f, -0.16149266f, -0.19536148f, -0.02358383f, -0.10266998f, -0.12471040f, -0.10625625f, 0.19208321f, 
    -0.07832815f, -0.12539862f, -0.02947296f, 0.00549435f, -0.03076009f, 0.01156619f, 0.05562370f, -0.00215471f, 
    -0.19098443f, 0.10485144f, 0.15078902f, -0.30617633f, -0.01970656f, 0.04585353f, -0.10247747f, 0.00371870f, 
    0.05338760f, -0.01107597f, 0.18097892f, 0.12158228f, 0.03106352f, 0.00735955f, 0.08552226f, -0.04478327f, 
    -0.14611281f, -0.01559314f, -0.06804249f, -0.09760482f, 0.00261545f, -0.19976281f, -0.13940856f, 0.16299725f, 
    -0.31834009f, -0.08899868f, -0.14672428f, -0.06776152f, -0.08903329f, -0.16163373f, 0.05427214f, -0.10194045f, 
    0.07156644f, 0.08009091f, -0.02997979f, -0.01078857f, 0.27861980f, 0.01102864f, -0.17280765f, -0.01851499f, 
    0.10632470f, -0.03472059f, -0.09282287f, -0.21096259f, -0.07620587f, -0.15338059f, -0.07559423f, -0.06789282f, 
    -0.28969955f, -0.15625818f, -0.32709357f, -0.04711960f, 0.06007810f, 0.11209608f, -0.08641830f, -0.08792882f, 
    0.07039951f, -0.00625062f, 0.00328102f, -0.07237664f, 0.18357538f, -0.09895552f, 0.02449144f, 0.09981883f, 
    0.15372966f, -0.01549184f, -0.01830907f, -0.06170241f, -0.08494125f, 0.04191302f, -0.03044268f, -0.03149600f, 
    -0.14289835f, -0.12442899f, 0.17360668f, 0.06284585f, -0.13159384f, 0.00655700f, 0.15705398f, -0.06151534f, 
    0.01647020f, -0.01196657f, 0.00990957f, 0.00807115f, -0.07646719f, 0.22173777f, 0.09760740f, -0.06339186f, 
    -0.02609986f, -0.04396923f, -0.01812211f, 0.09736052f, 0.17673059f, -0.12885666f, 0.16850990f, 0.07126592f, 
    -0.10678571f, -0.02820767f, 0.00156073f, 0.25075307f, 0.10410069f, 0.11535475f, 0.08374011f, -0.09190343f, 
    -0.04813404f, -0.09378738f, 0.07049479f, -0.05164446f, -0.06426262f, -0.02970631f, 0.04872952f, -0.15792689f, 
    -0.03679876f, -0.00535491f, 0.12462609f, -0.03198624f, 0.09457123f, 0.02915837f, -0.10245989f, 0.05189365f, 
    0.28167987f, 0.08518383f, -0.13489187f, 0.04666591f, 0.31007034f, 0.15589145f, -0.02257655f, -0.05885962f, 
    0.10236309f, 0.01911693f, -0.28269759f, -0.17908978f, -0.18411730f, -0.13377362f, -0.06422724f, -0.10233232f, 
    0.05174650f, -0.06136975f, -0.25900996f, -0.05133520f, 0.05903668f, 0.03926036f, 0.06357523f, -0.12375075f, 
    0.30420253f, 0.04984368f, 0.18298396f, -0.04981384f, 0.02552125f, -0.05697660f, -0.00805146f, -0.07195655f, 
    0.01092119f, 0.05880089f, 0.14484653f, -0.00422776f, 0.07985089f, -0.04596689f, -0.02507806f, 0.21459550f, 
    0.05219185f, -0.03875152f, 0.00105739f, 0.03599805f, -0.11901312f, 0.11321963f, 0.06675542f, 0.02863288f, 
    -0.10045145f, -0.06135306f, -0.26287982f, -0.03737791f, 0.00546208f, 0.04971293f, -0.08603363f, -0.01990549f, 
    0.04967737f, 0.00896458f, 0.02360586f, -0.06851818f, 0.03222672f, -0.00353535f, 0.03139702f, -0.08132531f, 
    -0.05362510f, -0.00298580f, -0.00687656f, 0.09241948f, -0.03877522f, 0.07196539f, -0.07544764f, 0.05463705f, 
    -0.05075449f, -0.03220255f, 0.00569592f, 0.00842296f, -0.04479490f, -0.02071224f, -0.04557265f, -0.05046327f, 
    0.06745931f, -0.05567321f, 0.00761566f, -0.08406536f, -0.13543674f, 0.11662516f, -0.00856803f, 0.05649231f, 
    0.08124126f, -0.02922017f, 0.04548349f, 0.04391955f, -0.03683379f, -0.02183672f, -0.07960574f, 0.04200947f, 
    -0.00397395f, -0.06200387f, -0.02113088f, -0.14833349f, 0.05555764f, 0.02074156f, 0.00930505f, 0.10352014f, 
    0.06063675f, -0.02014972f, -0.03807431f, 0.24285404f, 0.03181991f, -0.06258320f, 0.00077336f, 0.05952036f, 
    0.06081878f, 0.02496083f, -0.04556742f, -0.01840560f, 0.00259005f, 0.05037558f, 0.23319422f, 0.27682590f, 
    -0.16864401f, -0.15820171f, -0.05728801f, 0.01871603f, 0.01808670f, 0.04401005f, 0.01207214f, -0.07118797f, 
    0.10911854f, 0.10256092f, -0.00440218f, 0.04794364f, -0.36468858f, -0.22176021f, 0.14589390f, 0.15447073f, 
    0.04563266f, 0.02682962f, 0.00625990f, -0.01081090f, -0.14346832f, -0.09156765f, 0.02889315f, -0.17204002f, 
    0.06131507f, -0.10868722f, 0.16808327f, -0.05418359f, 0.03787384f, 0.13261591f, 0.03428216f, 0.02452952f, 
    0.11545390f, 0.02556138f, 0.06222766f, 0.08168343f, -0.05141902f, 0.39321977f, 0.15443379f, -0.17977840f, 
    -0.01388399f, 0.09847456f, 0.00271463f, 0.03773418f, 0.02351572f, -0.20612594f, 0.00958188f, -0.07888263f, 
    -0.11184846f, 0.04892297f, -0.15608676f, -0.06402266f, 0.10054726f, 0.15132405f, 0.13619877f, -0.13144314f, 
    0.03907423f, -0.06985063f, -0.13841058f, -0.06172554f, -0.52388883f, -0.13776697f, 0.00779151f, -0.00260160f, 
    0.02220321f, -0.07272569f, 0.01453150f, -0.00531697f, 0.03540565f, -0.04999289f, -0.11332527f, -0.07072745f, 
    -0.30543128f, -0.00925752f, -0.22310111f, -0.02453866f, 0.04026758f, 0.13827258f, -0.16255634f, -0.07978785f, 
    0.06411759f, -0.01463475f, 0.19452077f, -0.05952692f, 0.05867647f, -0.15442891f, -0.13401656f, -0.01505408f, 
    0.01553700f, 0.00027930f, -0.11869699f, -0.18485890f, -0.08338137f, 0.05823846f, -0.15339448f, -0.02266948f, 
    -0.08000163f, -0.05800652f, 0.10376305f, -0.18131059f, 0.07941703f, -0.11691148f, 0.14855756f, -0.08726224f, 
    0.10682769f, 0.00823085f, 0.08122812f, -0.00578816f, -0.32621035f, 0.18980786f, 0.21531045f, -0.34313542f, 
    0.02073217f, -0.00355000f, 0.05233834f, -0.15510163f, -0.00609584f, 0.03105379f, -0.02704707f, -0.11327210f, 
    0.18775859f, 0.07796509f, 0.02502721f, 0.06064440f, 0.01882377f, -0.14135139f, 0.01591069f, -0.01925881f, 
    -0.06257337f, -0.00040002f, 0.09158714f, 0.15895766f, -0.45366171f, -0.07366371f, -0.31896564f, -0.19257133f, 
    0.11915280f, 0.00823243f, -0.00799823f, 0.14524592f, -0.04569882f, 0.08567780f, 0.08918283f, -0.18539818f, 
    0.00293404f, -0.00155378f, 0.17995755f, -0.13521525f, 0.04938213f, -0.07872082f, 0.07420246f, -0.02189292f, 
    -0.04555717f, -0.05829138f, 0.09785768f, 0.04021850f, -0.07163116f, 0.01016138f, -0.10076865f, 0.10112814f, 
    -0.06341739f, -0.04233093f, -0.13226064f, 0.13756903f, 0.01315507f, 0.01773348f, 0.05169951f, 0.08589309f, 
    -0.00371019f, 0.01599281f, 0.17562190f, 0.13490930f, 0.08946148f, 0.08082753f, -0.00607527f, 0.03408863f, 
    -0.06574638f, 0.17202839f, 0.03508034f, 0.15224276f, -0.13942385f, -0.03187682f, 0.03150603f, -0.06402850f, 
    0.00030774f, -0.02432857f, -0.07549957f, 0.09575064f, 0.12632611f, -0.08591412f, 0.06913240f, -0.15013269f, 
    0.05004833f, 0.04761343f, 0.10369676f, 0.04150994f, 0.07573724f, 0.01976257f, 0.01107801f, -0.03937085f, 
    0.16155645f, 0.02302905f, -0.00284982f, 0.09960755f, -0.08926958f, -0.19832936f, -0.03886556f, 0.24891916f, 
    0.08872825f, -0.02410305f, 0.04293798f, 0.01973299f, 0.15270072f, 0.07392309f, -0.04019053f, 0.01401013f, 
    -0.05222528f, 0.01616138f, 0.04048558f, -0.12210516f, 0.05174376f, -0.15294497f, -0.00341244f, 0.04888980f, 
    0.00230515f, -0.01858398f, -0.05770422f, -0.12402888f, -0.14324804f, 0.02670630f, 0.07792657f, 0.23228674f, 
    -0.05462076f, -0.08880156f, -0.01266421f, 0.02598107f, 0.08737727f, 0.03164062f, 0.00065683f, -0.02899673f, 
    -0.01274645f, -0.03026658f, 0.11233391f, 0.25610378f, -0.04213709f, -0.12058756f, -0.06738372f, -0.03445206f, 
    -0.05578216f, -0.04165196f, -0.14006537f, -0.10752471f, -0.15722522f, -0.15108928f, 0.09759447f, 0.25333577f, 
    -0.20245144f, -0.00309480f, 0.04884145f, -0.01301923f, -0.11972699f, -0.00093300f, -0.00054929f, 0.07559109f, 
    -0.16082066f, 0.06132120f, 0.09932910f, 0.10287879f, -0.03709198f, -0.08002870f, -0.06184294f, 0.16893986f, 
    -0.08432363f, 0.08854883f, -0.01981194f, 0.12948209f, 0.08269861f, 0.07986765f, 0.07111717f, 0.04603630f, 
    0.06310496f, -0.05492229f, -0.06926477f, 0.09785516f, 0.09273690f, -0.04522167f, -0.02238345f, -0.07220791f, 
    0.09073738f, -0.01393967f, 0.06488700f, 0.05489715f, -0.04485440f, -0.00536005f, 0.15962054f, -0.06167439f, 
    -0.02139731f, 0.04742760f, -0.00259468f, 0.18798824f, 0.11073449f, 0.04839427f, -0.04478468f, 0.00716731f, 
    0.03403502f, -0.03591173f, 0.06279362f, -0.03982058f, 0.03039915f, 0.06259315f, 0.00621825f, 0.15940836f, 
    0.00312372f, 0.08410336f, -0.04097013f, 0.06301936f, -0.00025523f, 0.08221754f, 0.01680676f, 0.00993475f, 
    0.09964753f, -0.00172485f, 0.10480266f, -0.01619385f, -0.02823059f, 0.06457323f, 0.00740235f, 0.12412857f, 
    0.00669664f, 0.02609099f, 0.10050977f, -0.00341725f, -0.07341702f, 0.06907403f, 0.06805925f, 0.09908381f, 
    -0.24150376f, -0.18921705f, 0.02977066f, 0.09643481f, 0.16091537f, 0.01357302f, 0.05817576f, -0.21903631f, 
    0.13501528f, -0.00938082f, 0.04953451f, 0.15238136f, -0.08068877f, -0.12905963f, 0.23644763f, 0.01570951f, 
    -0.01756613f, 0.00513278f, 0.05606668f, -0.17457621f, 0.03863679f, -0.06612017f, -0.15227826f, 0.00004924f, 
    0.17235950f, -0.07439267f, 0.04282864f, 0.05476975f, -0.01858037f, -0.00389453f, 0.01208363f, -0.01141731f, 
    -0.21398126f, 0.11406732f, -0.08593448f, -0.00476310f, 0.38855985f, -0.26632842f, -0.03043621f, 0.01559153f, 
    0.12053069f, 0.04849782f, -0.05366023f, 0.04728544f, -0.13179395f, -0.05533732f, -0.00097898f, -0.09829485f, 
    -0.01723831f, 0.10500842f, -0.07915601f, -0.00102816f, -0.03700850f, -0.10023821f, 0.00458060f, 0.07980517f, 
    -0.04825032f, 0.11100005f, -0.01754277f, 0.04489812f, -0.05721755f, -0.22332285f, 0.00029453f, -0.00451265f, 
    0.00289273f, 0.02088642f, 0.03495656f, -0.09169935f, 0.04767968f, 0.03254957f, 0.00611183f, 0.01874781f, 
    -0.24285880f, -0.06787556f, -0.04316465f, 0.14488834f, -0.09276833f, -0.10811277f, -0.01849220f, 0.05128350f, 
    -0.03045158f, 0.08341265f, -0.11264598f, -0.03116836f, -0.03473947f, -0.04472984f, 0.02223102f, -0.24266325f, 
    -0.07513574f, -0.06148807f, -0.01852637f, -0.17846018f, -0.10551224f, -0.10240671f, 0.11085496f, -0.03281970f, 
    0.14212498f, -0.01359183f, -0.09751906f, 0.22598247f, -0.09012875f, -0.01992508f, -0.02252561f, -0.04014303f, 
    -0.07224915f, 0.08611294f, -0.09752578f, -0.06599635f, -0.35468137f, 0.12950800f, -0.00740560f, 0.16330191f, 
    -0.09625794f, 0.01864702f, 0.03336434f, 0.06546789f, 0.05470413f, -0.04509503f, -0.10917409f, -0.00205372f, 
    -0.04503173f, 0.00303762f, -0.07444714f, -0.05692459f, -0.01845293f, -0.07683945f, 0.10889424f, -0.06380508f, 
    0.07503340f, 0.07010234f, 0.05794497f, -0.14187928f, -0.24865231f, 0.29812065f, 0.12392446f, 0.10295560f, 
    0.00979026f, -0.05993058f, 0.01252182f, 0.07155333f, 0.00070306f, 0.10953785f, 0.02379918f, -0.00924703f, 
    -0.16425623f, -0.08559539f, -0.11389467f, 0.24145374f, 0.08872261f, 0.03379452f, -0.02743874f, -0.00408479f, 
    -0.01250384f, 0.00820212f, -0.05905335f, 0.06599394f, 0.04155086f, -0.20919751f, -0.07434823f, -0.07994162f, 
    0.02267675f, -0.05600967f, 0.04721097f, -0.05691000f, 0.15737709f, -0.06677376f, 0.22151801f, 0.05385998f, 
    -0.02478494f, -0.05523688f, 0.15789858f, -0.14651877f, -0.12382081f, -0.06503213f, 0.07137312f, 0.08381620f, 
    0.02152365f, 0.07658581f, 0.11327965f, 0.08403023f, -0.26797444f, 0.02237570f, -0.20696861f, 0.02844085f, 
    -0.06234234f, -0.04261268f, -0.05864375f, -0.22451052f, -0.01398341f, -0.00494427f, 0.04855672f, -0.15116306f, 
    0.25073054f, -0.17944956f, -0.05104018f, -0.00210423f, -0.12787496f, 0.08188134f, 0.04855836f, -0.06608699f, 
    0.09387441f, -0.12458174f, -0.08738305f, -0.16442163f, -0.24243097f, -0.05290952f, 0.00850674f, 0.01135445f, 
    0.07757513f, 0.01130108f, -0.04315402f, -0.00160891f, 0.03625213f, -0.04220575f, 0.08854975f, -0.05197462f, 
    -0.29091078f, -0.03631219f, -0.06195037f, -0.05786235f, 0.02618447f, 0.07710833f, -0.00779376f, -0.11790683f, 
    -0.01687641f, -0.00956245f, 0.01947009f, -0.04165405f, -0.22993410f, -0.06577586f, -0.23382659f, -0.04767737f, 
    -0.10232317f, 0.01305059f, 0.10762414f, -0.01893513f, 0.04813423f, -0.00602245f, 0.04287927f, 0.10139795f, 
    -0.39715958f, -0.04585590f, -0.11307421f, -0.19786912f, 0.00993595f, -0.05626833f, -0.03028997f, 0.04107965f, 
    0.02935339f, 0.05928495f, 0.02816256f, 0.18077788f, -0.00140027f, 0.09215935f, 0.00678880f, 0.22181900f, 
    0.00565094f, -0.03457619f, 0.04294664f, -0.10261212f, 0.09257570f, -0.03601765f, 0.13900195f, 0.00076132f, 
    -0.06352945f, 0.03975611f, 0.16047528f, 0.40131930f, 0.15847607f, 0.00093186f, 0.01775551f, 0.02077545f, 
    -0.09622191f, 0.03339960f, 0.02434612f, 0.06026944f, 0.06569467f, 0.01158913f, 0.11728670f, 0.23636481f, 
    0.04000793f, -0.05887599f, 0.08296238f, 0.00934643f, -0.01599668f, -0.03835003f, -0.21134058f, -0.08970364f, 
    0.09990323f, -0.03825288f, -0.10381640f, -0.17842685f, 0.05647839f, -0.11500721f, 0.03793953f, -0.04409396f, 
    0.07135069f, 0.08987334f, 0.14844434f, -0.02425332f, 0.19116259f, 0.02883379f, 0.07025311f, 0.04117499f, 
    -0.04896129f, -0.04346460f, -0.02042954f, -0.11276104f, -0.06943815f, -0.00619413f, 0.11893868f, 0.00178758f, 
    -0.19914146f, -0.05434559f, -0.21880028f, 0.15467623f, -0.10814884f, 0.06268204f, 0.00407989f, -0.00414253f, 
    -0.04286066f, -0.03486541f, 0.06490032f, 0.03183793f, -0.09132231f, -0.10328071f, 0.11155308f, 0.02484420f, 
    0.06420171f, 0.10064737f, 0.20385586f, 0.16058858f, -0.01068204f, 0.09504627f, -0.11093991f, 0.06676678f, 
    -0.20333794f, 0.08336382f, -0.01821022f, 0.20964165f, -0.02288651f, -0.00184857f, 0.04220255f, 0.05413736f, 
    -0.07522934f, -0.06112716f, -0.15589535f, 0.01876914f, 0.21759088f, -0.04057711f, 0.07439567f, -0.10666679f, 
    0.00267510f, -0.02940304f, -0.01739405f, 0.01889087f, 0.00504374f, -0.11155991f, -0.05846279f, 0.09360102f, 
    -0.00566762f, -0.04908090f, -0.06516634f, -0.22700074f, -0.07013640f, -0.00099239f, 0.01612886f, -0.21252134f, 
    -0.11827714f, 0.08000753f, 0.03163972f, 0.05243178f, -0.14327309f, 0.28171951f, 0.15893234f, -0.31777966f, 
    -0.04617063f, 0.16861899f, -0.03038870f, 0.01362098f, -0.04655536f, 0.00036245f, 0.06927319f, -0.09723923f, 
    -0.00275507f, -0.12586361f, -0.06533305f, 0.03004848f, -0.06370541f, 0.11967903f, -0.03317146f, -0.01382781f, 
    0.03219661f, -0.01751685f, -0.01747809f, 0.05246278f, -0.06125977f, -0.06415237f, -0.11395331f, -0.24633387f, 
    -0.00145923f, -0.00450581f, -0.14507136f, -0.18570071f, -0.12474427f, 0.10155952f, -0.01136042f, -0.01261573f, 
    0.14257595f, -0.02956437f, 0.03461637f, 0.01846100f, -0.03226319f, -0.02953514f, 0.12228806f, 0.06496860f, 
    0.00825987f, 0.00760980f, -0.03858801f, -0.13823363f, 0.13682030f, -0.03803259f, -0.00834401f, -0.13333015f, 
    -0.05009235f, 0.03863595f, 0.10164016f, -0.01296284f, 0.09594785f, 0.04164284f, -0.05478704f, -0.19626623f, 
    -0.01908058f, 0.00991337f, -0.19966984f, -0.11022153f, -0.04574504f, -0.05887917f, 0.03253707f, -0.15210189f, 
    -0.05156122f, -0.01709802f, -0.06689874f, -0.00444502f, 0.14749090f, -0.10682303f, -0.09596363f, 0.17726509f, 
    -0.03174391f, -0.01936277f, -0.05675869f, -0.02385032f, -0.02734085f, 0.12797362f, -0.05745037f, 0.20798318f, 
    0.02747518f, -0.15502353f, -0.24534595f, 0.07072519f, -0.11603554f, 0.02887788f, -0.00129158f, 0.07102415f, 
    0.07242328f, -0.03726031f, -0.06050071f, 0.06135881f, 0.16519195f, -0.09161595f, 0.10434180f, 0.27733144f, 
    -0.07183031f, -0.00255736f, 0.04707294f, 0.04477293f, 0.14062323f, 0.06206337f, 0.09606866f, 0.06484990f, 
    0.00392943f, -0.08890168f, -0.02241334f, -0.26631194f, -0.07946635f, -0.04902849f, -0.06318105f, -0.06102296f, 
    -0.07745611f, 0.00584885f, 0.00124275f, 0.03696272f, 0.25004321f, -0.32663238f, -0.22020452f, -0.00005322f, 
    -0.09517495f, 0.03858710f, -0.01159786f, 0.02147408f, -0.06645335f, 0.11242853f, -0.03865421f, 0.03767592f, 
    -0.01413172f, -0.02678763f, -0.10167165f, -0.09309322f, -0.10329977f, -0.03130014f, 0.01471318f, -0.04503601f, 
    -0.00935692f, -0.00580352f, -0.03331051f, 0.01707814f, -0.38677114f, -0.14929256f, -0.25179502f, 0.27122006f, 
    0.11778402f, -0.02094384f, 0.08133250f, 0.05328880f, 0.13463366f, -0.08843800f, 0.11120083f, -0.03258585f, 
    0.00122758f, -0.00563425f, 0.07788573f, -0.12008709f, -0.03580735f, -0.01108248f, -0.13645759f, 0.08992204f, 
    -0.06648044f, 0.10769554f, -0.05817847f, 0.02382920f, 0.10401256f, -0.29365355f, 0.00769210f, 0.10744508f, 
    -0.09352903f, 0.03240962f, -0.06667151f, 0.08808511f, 0.13923234f, -0.01073007f, -0.02574697f, 0.04263614f, 
    -0.07953856f, 0.08599038f, 0.00579100f, -0.12703234f, 0.14220500f, 0.06504061f, 0.05210162f, 0.00390490f, 
    -0.10291278f, -0.05874680f, 0.01445029f, -0.03673302f, 0.14381169f, -0.24728921f, 0.04865962f, -0.12629996f, 
    -0.03893846f, -0.00424977f, 0.07386575f, -0.16775666f, 0.01701459f, -0.05386780f, 0.16514374f, 0.13765962f, 
    -0.24062254f, 0.16847216f, 0.17710645f, -0.18774430f, 0.01419737f, 0.08896530f, -0.02137390f, 0.02032156f, 
    -0.04500691f, 0.00057251f, 0.07263952f, -0.03144770f, 0.30784830f, 0.02318081f, 0.06554954f, -0.23236108f, 
    -0.14403990f, 0.01173292f, 0.08756872f, 0.05248073f, -0.09426983f, 0.09321773f, -0.14101551f, 0.01769346f, 
    0.06773452f, 0.12494645f, 0.02418625f, -0.34784341f, -0.07923876f, 0.00700051f, 0.08634222f, 0.07087032f, 
    0.01378080f, -0.11318918f, 0.05741980f, -0.08092465f, 0.18769720f, 0.01731719f, 0.18839562f, -0.23270553f, 
    0.05034737f, 0.01048625f, 0.07062412f, 0.05129643f, -0.09777508f, 0.07868714f, 0.10605723f, 0.06487427f, 
    -0.32544503f, 0.19084062f, 0.03190195f, -0.20305556f, -0.05300271f, -0.04926522f, 0.09483530f, 0.00291444f, 
    0.08627169f, 0.04575529f, -0.03078476f, -0.02462732f, 0.08109090f, 0.10234977f, -0.22298028f, -0.07401709f, 
    -0.14079276f, -0.06837033f, -0.01891130f, -0.13395759f, -0.20278241f, 0.04877783f, -0.00154712f, -0.10980643f, 
    0.22905986f, -0.21110733f, 0.07891049f, 0.01109488f, -0.05573970f, -0.04609139f, 0.11519478f, -0.00972502f, 
    0.04964485f, 0.08077634f, 0.00528929f, 0.14606915f, 0.04914752f, -0.10940547f, -0.36961916f, 0.23026101f, 
    -0.00568106f, 0.11450441f, -0.01368434f, -0.03341964f, -0.08028187f, -0.10795447f, -0.03883051f, -0.01635297f, 
    -0.13135092f, -0.09465887f, -0.20372142f, -0.02181345f, -0.10949039f, 0.09210229f, 0.01520262f, -0.02557168f, 
    0.01312626f, -0.11586235f, 0.00128311f, 0.01324915f, 0.12797479f, -0.15921317f, -0.00801013f, 0.03494367f, 
    0.04964073f, 0.01365191f, -0.00193973f, 0.09924889f, 0.06827576f, -0.16747533f, -0.00628906f, -0.12000289f, 
    0.15863833f, -0.01966236f, -0.00868969f, -0.07454038f, 0.10451666f, 0.08854108f, 0.00356318f, -0.07443327f, 
    0.02173130f, -0.10197186f, 0.07215914f, -0.04132719f, -0.28728440f, 0.22560604f, -0.12861137f, 0.08821719f, 
    0.05039258f, 0.04247273f, 0.11412720f, -0.03973430f, -0.12210567f, 0.11466539f, -0.00145623f, -0.01011448f, 
    0.06616652f, 0.09946781f, 0.03804354f, -0.09126350f, 0.07563361f, 0.11373626f, -0.09815016f, -0.04785514f, 
    0.01433306f, -0.07904208f, -0.10108069f, -0.05219192f, -0.17137994f, 0.19768596f, 0.09423316f, -0.01746148f, 
    -0.04616812f, 0.04898320f, 0.09937592f, 0.08324575f, 0.09447452f, 0.00514774f, -0.04665073f, -0.15724263f, 
    0.02958008f, -0.04604738f, -0.05518081f, 0.34779987f, 0.12022490f, 0.12388472f, 0.01688509f, 0.02993263f, 
    0.00268433f, 0.06204313f, -0.01292012f, -0.02933445f, 0.01907969f, 0.01855605f, 0.04635903f, -0.18397512f, 
    -0.01009531f, -0.03621718f, 0.09496871f, -0.03872791f, -0.01518315f, 0.20151597f, 0.08144915f, -0.12434686f, 
    0.09615534f, -0.30284527f, -0.08410180f, 0.09415831f, -0.06269288f, 0.13922694f, 0.01852960f, 0.09762904f, 
    -0.06210489f, -0.05333339f, -0.00908697f, -0.09887713f, 0.17688376f, -0.13607353f, 0.06029599f, -0.13049681f, 
    -0.04519645f, 0.10998192f, 0.12255642f, 0.07632764f, -0.02658867f, 0.07411421f, 0.08473194f, 0.08653368f, 
    -0.04504658f, 0.03322424f, 0.06969531f, 0.07059295f, 0.13772269f, 0.00218607f, 0.01592242f, 0.03775109f, 
    0.01330359f, -0.00375435f, -0.00761311f, 0.01077865f, 0.31772774f, -0.08126396f, 0.18426862f, 0.12746619f, 
    0.15114561f, -0.01422620f, 0.00088854f, -0.06183648f, -0.04989171f, -0.03775626f, -0.08765426f, -0.03717139f, 
    -0.02733078f, 0.10446901f, -0.06685680f, -0.15588017f, 0.05753179f, -0.04492058f, -0.04844408f, -0.07587604f, 
    0.02323281f, 0.04802911f, -0.08224056f, 0.00396928f, 0.07491468f, 0.02688486f, 0.02488534f, 0.03436480f, 
    0.05961067f, 0.04963816f, 0.00411136f, 0.04912805f, 0.04286340f, -0.06560083f, -0.01497846f, -0.05809717f, 
    -0.01821803f, -0.03205510f, 0.05212636f, 0.08165563f, 0.03968633f, -0.05329632f, -0.02967025f, 0.02868536f, 
    -0.03986873f, -0.01077002f, -0.07011309f, -0.03148568f, 0.10566133f, 0.02392040f, 0.19328627f, 0.05718769f, 
    0.11394645f, 0.07003963f, 0.02294702f, -0.06728975f, -0.01698934f, 0.00564365f, 0.06541724f, 0.00117959f, 
    -0.06414995f, 0.13635814f, 0.06277805f, 0.05764765f, 0.08758519f, -0.03588758f, -0.01984582f, 0.04333603f, 
    0.03334663f, 0.09816681f, 0.01592589f, -0.08143872f, 0.00575322f, 0.15619516f, -0.00934382f, -0.11304177f, 
    -0.01420862f, 0.05735540f, -0.00052313f, 0.01249841f, -0.04650296f, 0.04978622f, 0.04268175f, -0.06024728f, 
    0.18715161f, 0.00376392f, 0.16542768f, -0.06887660f, 0.07771642f, 0.08011797f, -0.02488871f, -0.02932404f, 
    0.01448686f, -0.00184979f, 0.01133190f, 0.01011716f, -0.09359156f, 0.05150382f, -0.02099281f, -0.16046801f, 
    -0.00861185f, -0.07252948f, 0.00892659f, 0.02858844f, -0.02382327f, -0.01900122f, -0.07441921f, -0.09609988f, 
    0.01414507f, -0.06955680f, -0.02993294f, -0.03591699f, -0.08599073f, -0.03385825f, -0.01055848f, -0.01873759f, 
    -0.01069368f, -0.09035830f, -0.06786805f, 0.00748401f, 0.17092909f, 0.09287004f, 0.13399425f, 0.07375915f, 
    0.01512259f, 0.14544864f, -0.00980851f, 0.05357495f, 0.00117340f, -0.01781318f, 0.01604431f, -0.00942003f, 
    -0.07139679f, 0.00220358f, -0.22487919f, -0.06255575f, -0.09539808f, 0.04919808f, -0.01526274f, -0.10040924f, 
    0.01557035f, -0.01298248f, -0.06091764f, -0.06310308f, 0.10562579f, 0.08630657f, 0.07616132f, 0.19548377f, 
    0.09457733f, 0.03605062f, 0.07569493f, 0.03346776f, 0.01218118f, -0.10652736f, -0.00741205f, -0.01034686f, 
    -0.19534823f, -0.10691779f, 0.19221720f, -0.09819680f, 0.00672547f, 0.02286134f, -0.00637255f, -0.09892420f, 
    -0.00932984f, 0.00385587f, 0.06650665f, 0.00353470f, 0.16312666f, 0.31583419f, -0.01892309f, -0.07680823f, 
    -0.14716117f, 0.07098994f, -0.00287753f, 0.02085234f, 0.00061382f, 0.03460972f, 0.01708333f, -0.11711130f, 
    -0.11182788f, 0.06345636f, -0.00761230f, 0.02748516f, -0.10685917f, 0.01364691f, -0.09546208f, -0.06715313f, 
    0.03774774f, 0.01843523f, 0.01457668f, -0.04603429f, 0.04940017f, 0.21134435f, 0.12742457f, 0.20258550f, 
    0.16905412f, 0.06573712f, 0.12166234f, -0.07326722f, -0.06961893f, 0.01940852f, 0.03235538f, -0.00831035f, 
    -0.01331908f, 0.09679100f, 0.14519376f, 0.08326030f, -0.00942935f, 0.04883286f, -0.00486193f, -0.07600935f, 
    -0.04648073f, -0.00275727f, -0.04319205f, 0.02042069f, 0.14024055f, 0.05631472f, -0.12933224f, 0.10818733f, 
    0.02017225f, -0.04828147f, -0.04000045f, -0.04346728f, -0.00794857f, -0.01867154f, -0.02803761f, -0.01217166f, 
    -0.37294510f, -0.17095616f, 0.08784094f, -0.10062139f, 0.04035554f, -0.09283689f, -0.06757452f, 0.01307286f, 
    -0.05708459f, -0.05018982f, 0.06495231f, -0.01735783f, -0.04357009f, -0.02377327f, 0.07867967f, 0.02290794f, 
    -0.00570304f, -0.06313377f, -0.00087108f, -0.00138059f, 0.01007015f, 0.02486096f, -0.00877953f, -0.06545869f, 
    0.09895491f, -0.04916374f, 0.10866463f, 0.01698934f, -0.06066215f, 0.06226728f, 0.04102092f, -0.03236391f, 
    -0.02624419f, 0.01275939f, -0.13062595f, 0.01100772f, 0.06822047f, -0.16672873f, -0.16619179f, -0.14733267f, 
    -0.04480231f, 0.01420036f, -0.07962364f, -0.02112605f, -0.00879320f, -0.00820264f, -0.02727302f, -0.03592705f, 
    0.08240317f, 0.15059048f, -0.11394179f, 0.02844248f, 0.03094942f, -0.03704535f, -0.06538054f, -0.03571391f, 
    0.01894469f, -0.01882974f, 0.04961405f, -0.02061865f, 0.18096830f, 0.04279426f, 0.13066353f, -0.01764700f, 
    -0.09172048f, 0.00937066f, -0.06502366f, -0.05112339f, -0.02618803f, 0.08661421f, -0.06951875f, 0.00233137f, 
    -0.00578884f, -0.04058513f, -0.01312610f, -0.04545199f, -0.04422205f, 0.04536007f, -0.03841300f, -0.02144485f, 
    -0.07541581f, -0.08183296f, -0.02673546f, -0.05469601f, 0.10231455f, -0.21535926f, 0.05271370f, 0.16823581f, 
    -0.01050791f, -0.05883935f, -0.05633871f, -0.01560455f, -0.07577285f, -0.05753876f, -0.03993455f, -0.12899694f, 
    0.05720104f, 0.15585768f, 0.12100446f, 0.05612130f, -0.06461285f, 0.02197661f, 0.06311267f, 0.00354366f, 
    -0.01442642f, -0.02623005f, -0.03129425f, -0.08101761f, -0.29474771f, 0.07486971f, -0.17606953f, -0.25625718f, 
    0.04806939f, 0.00974086f, -0.08938403f, -0.02304467f, -0.07599066f, 0.01301219f, 0.05247277f, -0.10621075f, 
    -0.06169663f, 0.13025366f, -0.13229318f, 0.02579128f, -0.08291143f, 0.03487886f, -0.10125942f, -0.03477391f, 
    -0.11795513f, 0.07987388f, -0.02489261f, -0.05990494f, 0.10747578f, 0.13987079f, 0.07785345f, 0.16978797f, 
    -0.05716135f, -0.00762348f, -0.01004787f, -0.08466881f, -0.09666801f, 0.02339946f, 0.03358969f, -0.07625701f, 
    0.20739327f, -0.23659305f, 0.16950655f, -0.04024651f, -0.05389111f, -0.09653988f, -0.03377311f, -0.06986143f, 
    -0.00399547f, 0.07790969f, 0.01635570f, -0.02751635f, -0.02883391f, -0.09086943f, -0.01511416f, -0.03767881f, 
    -0.07777116f, -0.07211436f, -0.01561400f, 0.00856252f, -0.02375379f, 0.03971393f, -0.00936273f, -0.08058550f, 
    0.11090250f, 0.19781204f, 0.05325313f, 0.11970280f, 0.09455597f, 0.02007069f, -0.04490716f, 0.06724525f, 
    -0.02920632f, -0.04047176f, -0.05451809f, 0.02968784f, 0.05759791f, -0.18853086f, 0.03108847f, -0.00605793f, 
    0.05681353f, -0.01675075f, -0.03090105f, -0.07763308f, -0.02920672f, 0.05977863f, -0.04790581f, -0.07229295f, 
    -0.07686773f, -0.05331018f, 0.01253894f, -0.00331361f, -0.05556569f, 0.00079172f, -0.00924023f, -0.02962108f, 
    -0.08385265f, 0.03068223f, -0.00345364f, 0.04994042f, -0.22086851f, 0.13621692f, 0.03179640f, 0.00466821f, 
    -0.08123121f, -0.02508345f, -0.06966719f, 0.01643807f, -0.04140985f, 0.06331571f, 0.04549734f, -0.03279807f, 
    -0.21749362f, 0.21346775f, 0.17927447f, 0.04883971f, 0.09121396f, 0.07475689f, 0.00485775f, 0.00302821f, 
    -0.08285490f, -0.03331414f, 0.02777172f, -0.00818933f, -0.02312759f, 0.11087101f, 0.07468807f, -0.02972947f, 
    0.00599482f, 0.04930899f, -0.01888691f, 0.02919167f, -0.03872234f, 0.01306928f, 0.03531162f, -0.07631170f, 
    -0.02556317f, 0.11884535f, 0.07104997f, 0.13411893f, 0.13502415f, 0.09330237f, 0.02276204f, -0.04971560f, 
    -0.03145092f, -0.01024055f, -0.01779107f, -0.06435780f, 0.02280806f, 0.10378192f, -0.00117474f, 0.09347114f, 
    0.05207190f, 0.05797776f, -0.05400610f, -0.03661371f, 0.05574353f, 0.00057761f, 0.01466600f, -0.13153762f, 
    -0.22365004f, 0.04902295f, -0.05112819f, -0.08406476f, 0.00058912f, 0.00262436f, -0.13111833f, -0.03353493f, 
    -0.10528768f, 0.00950763f, -0.02913922f, -0.11532191f, -0.13741750f, 0.06833491f, 0.15939680f, -0.09851655f, 
    -0.06706955f, 0.00435352f, 0.01233852f, -0.01920634f, -0.00393116f, 0.03214541f, 0.04126476f, -0.06560906f, 
    0.05886666f, 0.09619932f, -0.10274013f, -0.01991609f, -0.10326392f, -0.03364655f, -0.07752629f, -0.05520019f, 
    -0.06825992f, 0.01661271f, -0.01079975f, -0.03378630f, 0.21088657f, -0.03354672f, 0.20805623f, -0.05143346f, 
    -0.03491477f, 0.05336742f, -0.01750243f, 0.01185629f, -0.00460311f, 0.07417288f, -0.06964490f, 0.02061364f, 
    -0.07435254f, -0.00601939f, -0.03831216f, 0.01798722f, -0.00004548f, 0.02326369f, -0.05187938f, -0.02539207f, 
    -0.14982031f, -0.08117022f, 0.00251053f, 0.02713576f, 0.02976257f, -0.00093902f, -0.02455302f, 0.04206915f, 
    -0.04295935f, -0.04479450f, 0.13133667f, -0.05305273f, -0.12294079f, -0.01034175f, -0.10257833f, -0.11636354f, 
    -0.23790056f, 0.07726569f, -0.17458819f, -0.08868480f, -0.01868121f, -0.04436741f, -0.00580386f, -0.02778127f, 
    0.01118870f, 0.06051768f, -0.05451741f, -0.03658047f, 0.06747946f, 0.06225168f, -0.11374987f, -0.14054807f, 
    -0.01617735f, -0.02145494f, -0.03690684f, -0.11585817f, -0.02685721f, -0.11824924f, 0.07633911f, -0.06256250f, 
    -0.38272673f, 0.24993764f, 0.00737263f, -0.05726442f, -0.06185702f, -0.00470797f, 0.03480435f, -0.04264191f, 
    -0.05993651f, -0.00060866f, -0.04679517f, -0.09643786f, 0.14104733f, 0.11945794f, 0.09186774f, 0.21740738f, 
    0.06985186f, -0.02012740f, 0.02567275f, 0.05526406f, -0.01795076f, -0.03895073f, 0.07125524f, -0.07520431f, 
    -0.03230352f, -0.11009972f, -0.00028716f, -0.14000300f, 0.03200713f, -0.06680418f, -0.04176543f, -0.09376490f, 
    0.06261496f, -0.01928285f, -0.08619501f, -0.00987158f, -0.13864662f, 0.02656296f, -0.15210238f, 0.10279817f, 
    0.00366899f, -0.10277385f, -0.09784646f, -0.04406041f, 0.05506855f, -0.05151408f, 0.03091647f, -0.03360827f, 
    0.05685665f, 0.09871234f, -0.12132625f, 0.11485181f, -0.05613650f, -0.10506530f, -0.10606040f, -0.04074375f, 
    -0.02253301f, -0.06698170f, -0.01394561f, -0.03733018f, 0.06589697f, -0.12294866f, 0.03617629f, 0.20970675f, 
    -0.03862387f, -0.08841344f, -0.04606388f, -0.10223678f, -0.00469430f, 0.11312471f, -0.03676524f, 0.03057270f, 
    0.07717558f, -0.01944123f, 0.08665699f, 0.01973576f, -0.07275023f, -0.01944624f, -0.01067533f, -0.07093243f, 
    -0.02170182f, 0.01256507f, 0.00843957f, 0.02764008f, -0.05247296f, -0.03393296f, -0.04987555f, -0.06693433f, 
    -0.02185808f, -0.10738842f, -0.12710837f, -0.09115371f, -0.09903692f, 0.03340930f, 0.02343125f, -0.07066801f, 
    -0.01003939f, -0.21773553f, -0.13016813f, -0.04632520f, -0.08614371f, 0.00669230f, -0.07208902f, -0.01956072f, 
    -0.02403343f, -0.05706989f, -0.04569163f, 0.01995916f, -0.18805870f, -0.03782155f, -0.09097359f, -0.18311155f, 
    -0.03362026f, -0.02454883f, -0.03827659f, -0.06410465f, -0.08965360f, -0.03555638f, -0.04456441f, -0.00501653f, 
    -0.22872348f, -0.00992140f, -0.06135453f, 0.02086380f, -0.07660057f, -0.01830465f, -0.01407195f, -0.03426946f, 
    -0.02286400f, 0.02786723f, -0.01089901f, -0.01072587f, -0.05481074f, -0.11286908f, -0.04561305f, -0.02635961f, 
    -0.04095655f, -0.00361691f, -0.00410633f, -0.05251503f, -0.08746948f, 0.03677797f, 0.00518692f, -0.04441610f, 
    0.07829688f, -0.04431474f, 0.10068815f, 0.08589091f, -0.01714304f, 0.02231507f, -0.08722857f, 0.00616288f, 
    0.03693082f, 0.00488466f, 0.03874170f, -0.04615221f, -0.23982471f, 0.13218236f, 0.03359332f, -0.03760693f, 
    -0.02122631f, -0.04740639f, -0.00596000f, -0.08089362f, -0.09980341f, 0.01835754f, 0.06466583f, 0.01879387f, 
    0.05316130f, 0.05519896f, -0.08931274f, -0.03813159f, -0.08390868f, 0.05001396f, -0.08481459f, 0.02323902f, 
    -0.03084586f, -0.02042914f, 0.03864485f, -0.06793769f, 0.02775567f, -0.05081077f, -0.00346486f, -0.02889819f, 
    -0.03095516f, -0.06468900f, 0.00444443f, -0.00280833f, -0.00405916f, 0.08842137f, -0.05196194f, 0.01925181f, 
    0.09003551f, -0.04517265f, 0.02555475f, 0.07850550f, 0.04423860f, 0.03221356f, -0.06970352f, 0.05405430f, 
    0.06022257f, -0.11603877f, 0.06043879f, -0.08671971f, 0.02286349f, -0.00525598f, 0.02863876f, -0.06962353f, 
    -0.01937802f, 0.03113396f, 0.03212612f, -0.10949071f, -0.04758643f, 0.01648406f, -0.16428736f, 0.02944184f, 
    0.10907049f, 0.03747144f, 0.01075001f, 0.10712671f, 0.05197133f, 0.06784004f, 0.00609052f, -0.01384417f, 
    0.05563071f, 0.05654949f, 0.02590136f, 0.01896175f, -0.17167063f, -0.07862885f, 0.19307445f, 0.01915105f, 
    -0.03225918f, 0.10795084f, 0.02980739f, -0.00892099f, 0.02605600f, -0.13219479f, 0.03605399f, 0.11670601f, 
    -0.06052201f, 0.19694935f, 0.00565178f, -0.07702059f, -0.07230620f, 0.00067144f, -0.03707440f, -0.00732411f, 
    -0.04034900f, -0.20793544f, 0.08309963f, 0.07623846f, 0.15132499f, 0.06140369f, 0.01428099f, 0.03797258f, 
    0.00011518f, -0.01190372f, -0.08221731f, 0.05035038f, -0.03689052f, 0.02229487f, -0.04616385f, -0.07724088f, 
    -0.30138072f, -0.04423407f, 0.08694497f, -0.22017297f, -0.03656435f, -0.05845855f, 0.11862996f, -0.15533814f, 
    -0.02336770f, 0.08662970f, -0.04949635f, 0.12463548f, 0.09872374f, 0.00036597f, 0.07156067f, 0.00872348f, 
    0.08779035f, -0.07642279f, -0.11264148f, 0.00401928f, -0.06978249f, -0.05212186f, 0.03613846f, 0.08454642f, 
    0.18333602f, 0.05935140f, -0.15445490f, -0.16012526f, 0.07107480f, 0.11829869f, -0.04716327f, -0.03497026f, 
    0.07660312f, 0.02536677f, -0.03173301f, -0.13960589f, -0.13278027f, -0.13539477f, 0.12038462f, -0.03366198f, 
    -0.01373515f, 0.05760884f, 0.07383224f, -0.07309996f, -0.09712324f, -0.09569566f, -0.11945129f, -0.01218302f, 
    0.07475393f, 0.13141294f, 0.10779266f, 0.14825347f, 0.01920812f, -0.01573595f, -0.01468431f, 0.00167893f, 
    0.11591937f, 0.01366424f, -0.06395049f, -0.09836504f, 0.10296872f, -0.11046224f, -0.00082509f, -0.20921677f, 
    -0.07476221f, -0.01836834f, 0.02401380f, 0.08113260f, -0.01629000f, -0.01531352f, 0.05490837f, 0.00374217f, 
    0.14165668f, -0.15668111f, 0.10127090f, 0.08506934f, 0.00100022f, -0.03526248f, -0.07119838f, 0.04580694f, 
    0.02820484f, 0.02530783f, -0.07870691f, 0.10734963f, -0.23406433f, -0.12323920f, -0.00870826f, -0.09039122f, 
    -0.03988730f, -0.03345219f, 0.12132903f, 0.06774653f, 0.09074637f, 0.09161142f, -0.00146791f, 0.11245051f, 
    0.05000826f, 0.12082570f, 0.12646207f, 0.11359052f, -0.08042342f, 0.02042805f, -0.01757201f, 0.02413740f, 
    -0.05320979f, -0.00618488f, 0.06732919f, 0.02097031f, -0.12323801f, -0.08418593f, 0.13864505f, 0.09504241f, 
    -0.00659100f, -0.07318687f, 0.05661916f, 0.02497994f, 0.02026782f, -0.09836267f, -0.05176689f, -0.10295131f, 
    -0.21618672f, 0.12877199f, 0.14283565f, 0.02214948f, -0.05470818f, 0.00080868f, -0.08105202f, -0.13562353f, 
    -0.01024483f, 0.07169052f, 0.00453342f, -0.05973889f, -0.17477429f, -0.08816761f, -0.22694851f, -0.21264072f, 
    0.04584872f, -0.00694476f, -0.06431950f, 0.04197840f, -0.03232465f, -0.00645240f, -0.00117441f, -0.05756950f, 
    0.06569811f, 0.06205604f, -0.33901316f, 0.05048890f, 0.01537318f, -0.05457116f, -0.19580324f, -0.10555694f, 
    0.10594324f, -0.10345393f, -0.01944500f, -0.04715319f, 0.15727659f, 0.06220306f, -0.13847362f, -0.07537187f, 
    -0.00768522f, -0.01364906f, 0.00354413f, -0.09291399f, -0.04200495f, 0.03838180f, 0.06671228f, 0.05089024f, 
    -0.18812755f, -0.23301893f, -0.03407384f, -0.07241016f, 0.05583079f, 0.02868780f, 0.00461562f, 0.02419800f, 
    -0.04825727f, -0.13286425f, -0.03670257f, -0.12730291f, 0.04425555f, -0.04900282f, -0.00697533f, 0.06653072f, 
    -0.00485553f, 0.00412039f, 0.06401274f, -0.05026722f, 0.08848784f, -0.04504077f, 0.05235289f, 0.00659356f, 
    -0.02081592f, 0.20107900f, -0.13205326f, -0.13161151f, 0.02399001f, -0.00345113f, -0.00754157f, -0.01798313f, 
    0.06609823f, -0.03102070f, -0.04987597f, 0.02743720f, -0.08743504f, 0.10157823f, -0.03774538f, -0.05719199f, 
    -0.08199746f, -0.04830685f, -0.11484221f, 0.11578848f, -0.09639428f, 0.07141782f, 0.08298781f, -0.00066699f, 
    0.19627282f, 0.02996149f, -0.02512587f, 0.01730517f, 0.05232788f, 0.02241750f, -0.06099136f, -0.01353918f, 
    -0.02517773f, -0.02609295f, 0.00195144f, -0.22302040f, -0.07456858f, -0.15223348f, -0.05227413f, -0.21852759f, 
    0.06588809f, -0.02972499f, -0.07256262f, -0.04878232f, 0.04233077f, 0.07544808f, -0.02921955f, -0.14614606f, 
    0.01058393f, 0.06826872f, 0.12325560f, 0.12034664f, -0.08369949f, 0.10065834f, -0.07107436f, 0.24921003f, 
    -0.04548371f, 0.02832943f, 0.01049358f, -0.10603465f, 0.02172025f, -0.11347024f, 0.00032985f, 0.07703122f, 
    0.17201555f, -0.01438035f, -0.04056853f, 0.00678699f, 0.07375572f, 0.08932966f, 0.04286486f, -0.06797985f, 
    -0.05457480f, 0.09924347f, -0.05547168f, 0.04242101f, -0.02028362f, 0.01476659f, -0.01960817f, 0.00094575f, 
    0.06952450f, -0.00738786f, 0.00329433f, 0.07637226f, -0.11711526f, -0.14907254f, 0.13023949f, -0.21422598f, 
    -0.02609377f, -0.06990064f, 0.01283243f, 0.01172323f, -0.01745772f, -0.02428760f, 0.03960564f, 0.03737753f, 
    -0.00920541f, -0.17619413f, 0.05210382f, -0.15558456f, -0.06774041f, -0.03431966f, 0.03571573f, -0.01072626f, 
    0.04021493f, 0.09945083f, -0.09469276f, 0.06972866f, -0.12070402f, -0.20153196f, -0.05155680f, -0.11427671f, 
    -0.02430351f, -0.03968229f, -0.00526842f, -0.08440974f, -0.09638049f, -0.05491954f, -0.01706082f, 0.11145791f, 
    -0.20368421f, 0.15788923f, 0.13717559f, -0.18889087f, -0.05561184f, 0.08321539f, -0.06762363f, -0.06336544f, 
    0.05837914f, -0.02566968f, 0.01682900f, 0.03259910f, 0.05279127f, -0.07613896f, 0.02460473f, 0.01198580f, 
    -0.00389577f, 0.02868108f, -0.00928728f, -0.03462401f, 0.02917490f, -0.12065548f, 0.00052529f, -0.14375076f, 
    0.03182337f, -0.02674674f, -0.01656839f, 0.05317104f, 0.05948175f, 0.00177093f, 0.01138456f, -0.06998660f, 
    -0.06338014f, -0.07720152f, -0.02905275f, 0.05399095f, 0.29256645f, -0.03137093f, -0.15171136f, -0.05368656f, 
    -0.15894702f, -0.09089559f, -0.09357187f, -0.08567356f, 0.00570393f, -0.03241305f, -0.10964774f, 0.16944571f, 
    -0.11674450f, 0.04387652f, 0.18079300f, 0.09536112f, -0.02539448f, 0.03149358f, -0.05568850f, -0.17442335f, 
    0.10109297f, -0.04709968f, -0.04481122f, -0.01373574f, -0.02538588f, -0.05646121f, 0.04780688f, 0.07144944f, 
    -0.03325882f, -0.10691066f, -0.00137083f, -0.02907628f, 0.03628382f, -0.00065805f, 0.03658146f, 0.03991476f, 
    -0.17464750f, 0.00293380f, 0.11129702f, -0.21563430f, -0.07198990f, -0.03064516f, -0.10457406f, -0.02038961f, 
    0.02805688f, 0.04021150f, 0.06741391f, -0.01773479f, -0.10321127f, 0.36652571f, -0.19193007f, 0.03611180f, 
    0.01651010f, 0.06878222f, -0.27843487f, -0.02398876f, 0.03385447f, 0.05538649f, -0.11574162f, 0.03096138f, 
    0.01434199f, 0.06543484f, -0.01095547f, 0.07555995f, -0.08549643f, -0.03935344f, 0.08815742f, -0.00286526f, 
    0.05660857f, 0.00520472f, 0.02149091f, -0.02711947f, 0.00696066f, -0.12426437f, 0.15053248f, 0.07568363f, 
    -0.10994319f, -0.12507387f, -0.06077407f, 0.02696400f, -0.03566674f, 0.03246899f, -0.04276092f, -0.00668985f, 
    -0.10399865f, -0.22879969f, -0.11322076f, -0.09805419f, -0.01906925f, -0.00189672f, 0.04043530f, 0.04029166f, 
    0.09660136f, 0.04196062f, 0.08283298f, -0.08933349f, -0.08921319f, -0.06175830f, 0.04452646f, -0.17167895f, 
    0.06342293f, 0.05841536f, -0.03121103f, 0.06923587f, 0.08713578f, -0.03223301f, -0.07336248f, -0.07946609f, 
    0.02602582f, -0.05072902f, -0.07531245f, 0.06151653f, 0.02899949f, -0.03272618f, -0.13761806f, 0.01146365f, 
    -0.00422992f, -0.00950970f, 0.08786564f, -0.13107489f, -0.24356738f, 0.06076222f, -0.09502067f, -0.04302083f, 
    -0.05007733f, 0.00574424f, -0.01640509f, -0.08949827f, 0.14924490f, -0.07912941f, 0.20566067f, -0.02038950f, 
    0.00131520f, 0.03356157f, 0.03525759f, 0.25583500f, 0.12127829f, -0.01924367f, -0.12091824f, 0.00391557f, 
    0.03537746f, 0.01608898f, 0.08777505f, -0.00243955f, 0.12334493f, -0.10716231f, 0.03149100f, 0.10978597f, 
    0.07917520f, 0.00808379f, -0.02219211f, 0.05927632f, -0.00935538f, 0.01999919f, 0.04225617f, -0.05251511f, 
    0.16284661f, -0.02286275f, 0.05705106f, 0.17005371f, 0.16487783f, 0.08113915f, -0.04960344f, -0.09060679f, 
    0.01080043f, -0.04893098f, 0.04246614f, -0.05087683f, -0.15752342f, 0.12248714f, 0.12982136f, -0.16369693f, 
    0.07126374f, 0.03770412f, 0.10570525f, 0.00703886f, -0.01944254f, -0.03567380f, -0.04813809f, 0.08765075f, 
    0.17673381f, -0.03306806f, 0.03948953f, 0.09994789f, -0.03953311f, -0.01165935f, -0.04567064f, -0.04496996f, 
    -0.04414313f, -0.13832696f, -0.02215171f, -0.21281482f, 0.14368333f, 0.15998171f, -0.31698796f, -0.17245112f, 
    -0.12074927f, -0.00085424f, -0.09699776f, 0.01292423f, 0.02259432f, 0.03889946f, -0.02347266f, 0.05318961f, 
    -0.18976066f, 0.02181883f, -0.25925753f, -0.15898862f, -0.03277102f, -0.03275004f, -0.05976121f, 0.10011481f, 
    0.13340673f, 0.04862338f, 0.09170190f, -0.09086244f, 0.16936216f, -0.08042133f, -0.24658267f, -0.15413973f, 
    0.02322528f, -0.04776863f, 0.05290648f, -0.08333363f, 0.08505849f, -0.00159409f, 0.04196882f, -0.01129146f, 
    0.06462266f, 0.05282881f, -0.07225422f, -0.18882100f, 0.00550966f, -0.08153721f, 0.06041859f, 0.00705574f, 
    0.01299042f, -0.03509596f, 0.05809132f, 0.07289053f, -0.06075676f, -0.15802884f, -0.21599160f, -0.19267508f, 
    0.03733227f, -0.04332724f, -0.02645402f, 0.03202512f, 0.09953129f, 0.02969620f, -0.00826012f, -0.13282889f, 
    0.04006943f, -0.04770913f, -0.23316413f, 0.08277993f, 0.13336723f, 0.01410404f, 0.10060322f, -0.01406446f, 
    -0.01440150f, 0.08777347f, 0.10090566f, 0.06428707f, 0.04009996f, 0.03930138f, 0.04321443f, 0.10726409f, 
    0.11318424f, 0.04143660f, -0.08495342f, -0.04301423f, 0.03863705f, -0.04260425f, -0.04642796f, 0.03036647f, 
    0.12044466f, 0.17493492f, -0.33744225f, 0.00394547f, 0.00922569f, -0.08587735f, 0.01482807f, -0.05765583f, 
    0.02488849f, -0.00704197f, 0.11605342f, 0.02171383f, 0.01391860f, -0.27348539f, 0.07620566f, 0.01556204f, 
    0.00011895f, -0.01438264f, 0.01630333f, -0.08323165f, 0.03630027f, -0.05538620f, 0.07896587f, 0.09503315f, 
    0.09996039f, 0.03104599f, 0.08198356f, 0.02965808f, 0.08291868f, -0.23074999f, -0.06055458f, -0.02317985f, 
    -0.05720305f, 0.02825121f, 0.03779807f, 0.10482343f, 0.11792947f, -0.29877114f, 0.12685308f, 0.05699970f, 
    0.00353524f, -0.06487483f, -0.22468817f, 0.01293338f, 0.09143751f, -0.09440684f, 0.06089510f, -0.14709030f, 
    0.03312648f, -0.28364328f, 0.19439782f, 0.15935923f, 0.07792507f, -0.04371332f, 0.03094665f, -0.04464511f, 
    -0.06536940f, 0.04236276f, 0.13830818f, 0.16219898f, 0.11845054f, -0.33014482f, 0.23687392f, -0.02609343f, 
    0.07356775f, 0.01757365f, 0.04854100f, 0.01762746f, 0.03661554f, -0.08369359f, 0.02197517f, 0.09027170f, 
    -0.12044135f, -0.04270879f, 0.05011605f, -0.00392981f, 0.11825402f, 0.01642659f, 0.02224507f, -0.18021028f, 
    -0.03599091f, 0.04578522f, -0.01225580f, -0.06094989f, 0.30514076f, 0.07180710f, -0.04961841f, 0.12892109f, 
    0.13758793f, -0.16056369f, -0.06778495f, 0.17803088f, -0.03283841f, -0.04217838f, 0.18316157f, 0.15491858f, 
    0.34096453f, -0.38810223f, -0.19425446f, -0.02740848f, -0.05838560f, 0.00230450f, -0.01387076f, 0.25396469f, 
    -0.04238505f, 0.07671218f, 0.08851756f, -0.08273418f, 0.14050402f, -0.15637958f, -0.12717977f, 0.10173274f, 
    -0.03915729f, -0.11723857f, 0.00617427f, -0.06332582f, -0.12795165f, 0.05462125f, 0.05486094f, -0.07802142f, 
    -0.12263750f, -0.02229103f, 0.16726738f, -0.17275721f, 0.03223989f, -0.07264416f, -0.01962511f, 0.03775328f, 
    -0.02736274f, 0.04857218f, -0.04134127f, 0.00029186f, -0.24114202f, 0.27189338f, 0.25512132f, -0.12532054f, 
    0.06485158f, 0.05371617f, 0.02220076f, 0.03932044f, 0.07867112f, -0.01240233f, 0.12044969f, 0.05585001f, 
    0.16181575f, -0.09093042f, -0.17478801f, 0.26295772f, -0.13128777f, -0.02901493f, -0.02974187f, -0.00693553f, 
    -0.06292108f, -0.04061298f, 0.10843116f, -0.01890406f, 0.12706427f, -0.08190098f, -0.05335180f, -0.00753870f, 
    -0.05309880f, 0.05065594f, 0.03554455f, -0.00718735f, 0.05952895f, 0.09601010f, -0.06693587f, 0.06949190f, 
    0.29972661f, 0.05493888f, 0.03613392f, 0.18275292f, -0.04317776f, 0.06764083f, -0.01150153f, 0.04269958f, 
    0.05417500f, 0.00501569f, -0.02931410f, -0.00164711f, 0.23610608f, 0.04049004f, -0.03108063f, 0.11184931f, 
    0.02337980f, -0.03585910f, -0.07268489f, 0.07686759f, -0.09186327f, 0.09865233f, -0.09826496f, -0.03472729f, 
    -0.00324261f, 0.26254034f, -0.26373681f, -0.16312082f, 0.06691466f, 0.00045050f, 0.02777961f, -0.03411522f, 
    -0.08999602f, -0.06127378f, 0.00962166f, 0.01883541f, 0.31652719f, -0.13139415f, 0.00311479f, -0.02987272f, 
    0.02831225f, -0.02880696f, 0.06333192f, -0.13228317f, -0.15020265f, 0.07708482f, 0.00199422f, 0.13622294f, 
    0.00315515f, 0.21263976f, -0.09787863f, 0.13017133f, -0.01507818f, -0.08859932f, -0.06204556f, -0.00805868f, 
    -0.03086354f, 0.07369860f, -0.20184092f, 0.12240829f, -0.32342461f, 0.14319816f, 0.05382521f, -0.08325268f, 
    0.06499898f, -0.06254344f, -0.00520680f, -0.15232436f, -0.07355874f, -0.05366384f, -0.06164271f, -0.02555576f, 
    0.10321754f, -0.03138701f, -0.04922368f, 0.14393659f, -0.00153445f, 0.00584778f, -0.07554710f, 0.07959439f, 
    0.05684968f, 0.03356440f, -0.03066802f, -0.06658241f, -0.16939940f, -0.21316226f, 0.01218368f, -0.17842826f, 
    0.19524804f, 0.11198486f, -0.07539615f, 0.09917063f, 0.05039992f, -0.08333418f, 0.12815328f, 0.02036236f, 
    -0.08747999f, -0.33849719f, -0.01011005f, -0.00775182f, 0.02051450f, 0.01428040f, -0.08235565f, -0.02854757f, 
    -0.02208029f, -0.02606496f, -0.10650719f, -0.05001465f, 0.03829167f, -0.05715307f, 0.16841249f, 0.03881501f, 
    -0.07218020f, -0.03437254f, 0.11546362f, 0.08731070f, 0.12125336f, 0.00504725f, -0.04041547f, 0.01220054f, 
    0.05327659f, -0.45396939f, -0.09728527f, 0.10928737f, -0.17976211f, -0.01797748f, 0.11115214f, 0.03649038f, 
    -0.06858341f, 0.00065251f, -0.04574542f, -0.04730868f, -0.05050921f, 0.14687295f, 0.03643013f, -0.02641000f, 
    -0.07234871f, -0.00889650f, 0.14098045f, -0.00982171f, -0.02324739f, -0.07586158f, -0.00644344f, -0.03144519f, 
    -0.00939927f, -0.09503229f, 0.02082492f, 0.05139491f, -0.04531002f, -0.02742499f, -0.02946384f, 0.02906037f, 
    -0.01195591f, 0.13589539f, -0.06945997f, 0.08250215f, -0.17057112f, 0.03988067f, -0.01471858f, -0.27925298f, 
    0.01492974f, 0.06889869f, -0.05469228f, -0.00461235f, 0.00836502f, -0.11255693f, 0.01573058f, -0.08954807f, 
    -0.16590890f, 0.13558450f, 0.12468578f, 0.01598722f, -0.06810610f, -0.09434582f, 0.06126069f, 0.02518764f, 
    0.01219504f, 0.07678237f, 0.21348508f, 0.01391093f, -0.12918966f, -0.03172120f, 0.02562391f, 0.22831982f, 
    0.01350690f, 0.06917329f, 0.00795534f, -0.11189909f, 0.17937788f, -0.06287917f, -0.07918360f, -0.04285745f, 
    0.07675061f, -0.18757086f, 0.08225693f, 0.04982234f, 0.07362959f, 0.10246941f, 0.04134455f, 0.02065176f, 
    0.00780618f, 0.08632769f, 0.07549732f, 0.05790870f, 0.13986146f, -0.24453020f, -0.17692026f, -0.28670546f, 
    -0.10676434f, -0.03454446f, 0.06759168f, 0.07818915f, -0.01187100f, 0.00070010f, 0.03177966f, -0.13106215f, 
    -0.17380145f, -0.12631431f, 0.04415896f, -0.03715630f, 0.11790261f, -0.06622744f, -0.00253744f, 0.02465988f, 
    0.09767378f, -0.00011275f, -0.00947753f, 0.06432436f, -0.12258973f, 0.02595689f, -0.09265574f, -0.19005702f, 
    0.02169617f, -0.02196340f, 0.05072912f, -0.14673902f, -0.05120437f, -0.04208389f, -0.00939721f, -0.07876217f, 
    -0.38326707f, 0.41267473f, 0.07655036f, 0.16718416f, 0.03868175f, 0.02918990f, 0.02621065f, 0.00803586f, 
    0.06314442f, 0.05758003f, 0.15020497f, -0.00006037f, -0.09356653f, -0.00913735f, -0.18102537f, 0.05996121f, 
    -0.02194793f, -0.03258153f, 0.08037783f, 0.01831022f, 0.07816371f, -0.05237270f, -0.00924262f, -0.09535179f, 
    0.06285081f, -0.00175713f, -0.00958645f, -0.11351275f, 0.00596361f, 0.09002791f, 0.11492324f, -0.05668561f, 
    0.08752967f, -0.04778206f, -0.03260606f, -0.19153132f, 0.22371288f, 0.22034128f, -0.18662211f, -0.21994142f, 
    0.12274394f, -0.06804030f, -0.06361265f, 0.09242496f, -0.17522217f, -0.04819440f, -0.05679241f, -0.06485713f, 
    0.20542811f, -0.01982142f, 0.05719819f, 0.07335471f, 0.03264816f, -0.01240036f, -0.00284781f, 0.12507056f, 
    -0.06505327f, -0.13438502f, 0.05888991f, 0.03578637f, -0.03616481f, -0.15679131f, -0.05173239f, -0.15815543f, 
    0.09979803f, 0.04833321f, -0.01682839f, -0.03549282f, 0.05770359f, -0.09281301f, 0.13000254f, 0.10198032f, 
    -0.00480773f, 0.02597760f, -0.09675810f, 0.25935277f, 0.02613596f, -0.07968730f, -0.03953606f, 0.00021071f, 
    0.10742225f, 0.04531722f, 0.04878933f, -0.18795866f, -0.57995307f, 0.02999965f, -0.05180078f, -0.01147732f, 
    0.14302769f, 0.00648785f, 0.04487279f, -0.10298070f, -0.02597358f, 0.06655563f, -0.00854702f, 0.03658237f, 
    -0.26219144f, -0.33068871f, -0.05756301f, -0.08874495f, 0.02616978f, 0.01525568f, -0.00216504f, -0.01919524f, 
    0.00702958f, 0.04043573f, 0.08449849f, 0.00995210f, 0.09711224f, -0.12436517f, 0.09485544f, 0.04560050f, 
    0.02087515f, 0.07024383f, -0.03047265f, 0.08941001f, 0.06919364f, -0.03359289f, 0.12309805f, 0.01919189f, 
    -0.18043709f, -0.18629155f, 0.11992101f, -0.17383449f, 0.06356531f, -0.06261723f, 0.06975826f, -0.01603781f, 
    -0.02141157f, -0.09819978f, -0.08043043f, 0.06916829f, -0.12891091f, 0.26207262f, 0.17160375f, 0.10903681f, 
    0.00810589f, -0.02521572f, -0.04801876f, 0.17239085f, -0.04152547f, 0.03422259f, 0.08066610f, -0.03980901f, 
    -0.32102618f, 0.31260899f, -0.26631010f, 0.12627068f, 0.00959275f, 0.10434771f, 0.02290164f, 0.10220624f, 
    -0.09640100f, -0.09786680f, 0.02719858f, -0.07418919f, 0.07397886f, 0.14306238f, -0.15207994f, 0.29072571f, 
    0.09452876f, -0.04178426f, -0.02029209f, -0.02213395f, -0.10603248f, -0.04727618f, 0.04188483f, 0.05398221f, 
    -0.19496889f, -0.01318108f, -0.01169464f, -0.15842755f, 0.04090304f, 0.05890155f, -0.00956790f, -0.00005844f, 
    0.02433367f, -0.08182041f, -0.11470999f, -0.07398111f, 0.10346762f, -0.18065034f, -0.10139133f, 0.02916808f, 
    -0.03965775f, 0.01923526f, -0.05951776f, -0.01719855f, -0.12834975f, 0.18547145f, -0.06685612f, -0.01346832f, 
    0.08277696f, -0.24974130f, -0.25711215f, -0.07440057f, -0.03675875f, 0.03504217f, 0.01855485f, -0.01200539f, 
    0.06100675f, 0.03551843f, 0.09708576f, 0.01637788f, 0.06076925f, 0.16833313f, -0.33226082f, 0.04981170f, 
    0.06587718f, -0.12705101f, 0.16403508f, -0.09739583f, -0.13152954f, 0.03643097f, 0.08409675f, 0.04748838f, 
    -0.25307485f, 0.25216424f, -0.17682557f, -0.33687359f, 0.09578031f, 0.00746913f, -0.11616834f, 0.05236476f, 
    -0.07213488f, 0.07282362f, -0.11151949f, -0.10516832f, -0.17842156f, 0.04104990f, -0.07611631f, -0.02476970f, 
    0.05528309f, -0.06228182f, -0.15668063f, -0.10740000f, -0.05496427f, 0.14210851f, -0.16362612f, 0.14786275f, 
    -0.35349023f, 0.29438305f, -0.09091538f, -0.23153366f, 0.05420682f, 0.02165877f, -0.05363897f, 0.04279350f, 
    -0.04436658f, -0.02255310f, -0.10575288f, -0.11896188f, -0.11604183f, -0.11591056f, 0.11678078f, 0.03763565f, 
    0.05715804f, -0.04335168f, -0.08834331f, -0.12059056f, -0.07012151f, -0.07027695f, -0.03864348f, 0.12693937f, 
    0.10569873f, -0.14897203f, 0.14114726f, -0.19040598f, -0.01901181f, 0.16287401f, 0.03434325f, -0.05011705f, 
    -0.02820177f, 0.01518778f, -0.02575634f, 0.15232304f, -0.01636085f, 0.01645149f, 0.14042753f, 0.06690309f, 
    0.06979982f, 0.10432224f, -0.08762072f, 0.01401178f, -0.02907046f, -0.07482459f, 0.03941220f, -0.00377088f, 
    -0.05721124f, -0.03165838f, 0.03115952f, -0.16696870f, -0.12905544f, -0.04710987f, -0.05085754f, -0.10316668f, 
    -0.08849698f, 0.00204886f, -0.00653103f, 0.08944131f, -0.01030068f, 0.04035187f, -0.23066530f, -0.21369618f, 
    0.09439624f, -0.04102309f, -0.15319099f, 0.02915501f, 0.05593110f, -0.04144656f, -0.01558351f, 0.01244658f, 
    -0.09701398f, -0.16164327f, -0.16341923f, 0.22812873f, -0.04485797f, 0.06397681f, -0.07729575f, -0.01155827f, 
    -0.00615969f, -0.00205626f, -0.01933007f, 0.03683006f, 0.21220456f, -0.29879621f, 0.15897647f, 0.02077669f, 
    0.11654717f, -0.09275223f, -0.01567420f, -0.09986177f, -0.07825574f, -0.04602064f, 0.07795683f, 0.06616069f, 
    -0.04546468f, 0.18405066f, -0.02087728f, -0.36229351f, 0.01610161f, -0.02431505f, -0.06237262f, 0.03720081f, 
    -0.09977529f, 0.04313762f, -0.19776881f, -0.03905613f, -0.04201285f, -0.05913167f, 0.10248473f, -0.13603984f, 
    0.06772970f, 0.13895953f, -0.13753200f, -0.13190685f, -0.00166840f, 0.03711814f, 0.02823735f, -0.03677475f, 
    -0.13211888f, 0.12402793f, 0.31269768f, -0.05387358f, 0.07127135f, -0.01826975f, 0.05872431f, -0.13896163f, 
    -0.00709917f, 0.02548005f, -0.00054343f, 0.01838412f, 0.21934737f, 0.01232530f, 0.06709955f, -0.25564954f, 
    0.06847917f, 0.02326964f, -0.11436523f, 0.07426185f, 0.00353239f, -0.01950910f, -0.02840459f, 0.03841693f, 
    0.49076834f, 0.16850331f, -0.26933372f, -0.12234811f, 0.03627148f, 0.08426098f, 0.01754375f, 0.08543583f, 
    0.10685246f, -0.01718180f, 0.03918891f, 0.10112748f, -0.46862301f, 0.05343176f, 0.09546464f, 0.03354035f, 
    -0.09938695f, -0.09907866f, -0.08931565f, -0.03932721f, 0.05328286f, 0.02814005f, -0.03160946f, -0.00242259f, 
    -0.07458811f, -0.00828877f, -0.13345860f, 0.02774797f, -0.12932923f, 0.00953215f, 0.00898835f, -0.01563998f, 
    0.00888770f, -0.01447352f, 0.06399607f, -0.11624016f, -0.48449144f, 0.06503472f, -0.22666168f, -0.14802261f, 
    0.06077651f, 0.03311970f, -0.04025123f, 0.03150121f, 0.02023137f, -0.02179027f, -0.06177527f, -0.00380712f, 
    -0.16182333f, 0.00859799f, -0.08606281f, -0.18948525f, 0.02405832f, 0.07683352f, -0.07080653f, 0.00182766f, 
    0.09081738f, 0.02800903f, 0.06650274f, 0.02097705f, 0.15043965f, 0.02266440f, 0.11104039f, -0.09325130f, 
    -0.07870200f, 0.09631380f, 0.04813847f, 0.02105060f, 0.07072740f, 0.09473278f, -0.07048924f, -0.08171658f, 
    0.06121195f, -0.04474986f, -0.05278640f, -0.01991723f, 0.02746069f, 0.08611999f, -0.02105676f, -0.02945815f, 
    0.07989735f, 0.07352409f, 0.04199531f, 0.05200184f, 0.08151031f, 0.05705182f, 0.02926959f, -0.01479004f, 
    -0.04534108f, 0.11051589f, -0.01303526f, 0.01733484f, -0.01769547f, 0.03899792f, 0.16472468f, 0.03918219f, 
    -0.02533104f, 0.08220110f, -0.08852338f, -0.00240522f, 0.04805113f, 0.03194292f, 0.00543141f, 0.00989647f, 
    -0.09298443f, -0.04352986f, 0.08309701f, 0.04899349f, -0.41890508f, -0.30938011f, -0.18432209f, -0.01104709f, 
    0.02606804f, 0.04617759f, 0.09966447f, -0.05390589f, 0.01883435f, 0.07785516f, -0.06451633f, 0.05805758f, 
    0.08295619f, -0.13474976f, -0.04715184f, 0.11768003f, -0.04540555f, 0.06946434f, -0.01952655f, 0.05271034f, 
    -0.02644252f, -0.06088727f, -0.08180618f, 0.05918042f, -0.48248121f, -0.16452995f, -0.14594892f, -0.11363221f, 
    0.09000777f, 0.04902249f, -0.18717949f, -0.10926962f, -0.03128715f, -0.11446249f, 0.05554358f, -0.04915917f, 
    -0.09719703f, -0.17358963f, 0.21564192f, -0.02403605f, -0.01232100f, 0.05691320f, 0.10716911f, -0.14453612f, 
    -0.03287186f, -0.07776757f, 0.06140413f, -0.09808975f, 0.23702826f, -0.03848232f, 0.11347217f, -0.26671919f, 
    -0.07381494f, -0.00794441f, -0.00809052f, -0.06235423f, 0.09920530f, -0.13264659f, -0.08196911f, -0.02639063f, 
    -0.19150545f, 0.02597784f, -0.08895879f, -0.18088438f, 0.04116098f, -0.09154550f, -0.10349604f, 0.03413718f, 
    0.01775262f, -0.08960418f, -0.12771605f, 0.00204839f, -0.03709703f, -0.00356738f, -0.01404054f, 0.02891506f, 
    0.16654372f, 0.08378766f, -0.05692148f, 0.04417085f, -0.06008631f, 0.11719762f, 0.00717724f, -0.12764479f, 
    0.11623572f, 0.09819578f, 0.04150154f, 0.02247386f, -0.02795783f, -0.00210167f, -0.09879514f, 0.16999419f, 
    -0.04010025f, -0.02172881f, 0.07069696f, 0.08789574f, -0.36971700f, -0.37438825f, 0.26501590f, 0.03362500f, 
    0.09085205f, 0.02162867f, 0.05860887f, 0.01933148f, 0.07889566f, 0.03601150f, -0.01359337f, 0.14338107f, 
    0.05765182f, 0.02942244f, -0.00886494f, -0.01350335f, -0.14684173f, -0.04117110f, 0.07122082f, 0.03221083f, 
    0.04353665f, 0.00052789f, -0.02744812f, 0.00915629f, 0.06584453f, 0.04574756f, -0.04465761f, -0.07255054f, 
    -0.18117735f, -0.10802764f, -0.04553643f, -0.09923066f, -0.04575187f, 0.09295968f, -0.16176629f, 0.03814264f, 
    0.25687379f, 0.06551019f, 0.02566478f, -0.07923088f, -0.00488140f, -0.06583110f, -0.01357782f, 0.03894491f, 
    -0.04006073f, -0.04059743f, -0.05917999f, 0.11203733f, 0.04013752f, -0.07736358f, 0.16617517f, 0.05258885f, 
    0.03830807f, 0.13877688f, -0.08985731f, 0.06257234f, -0.01697705f, 0.00837367f, -0.10239626f, 0.01865814f, 
    -0.16619179f, -0.11448958f, -0.01656381f, 0.16116977f, 0.00160205f, -0.05418356f, -0.06459931f, 0.09732992f, 
    0.03449410f, 0.03042139f, 0.00602469f, 0.08468897f, -0.13732605f, 0.02841439f, 0.14109841f, 0.04704337f, 
    -0.00119254f, -0.01024429f, -0.00486043f, -0.05528304f, 0.00632720f, 0.11719740f, 0.13759059f, 0.11498632f, 
    0.16908976f, 0.03217361f, 0.01065976f, 0.02292885f, 0.03959353f, 0.06301745f, -0.03014096f, 0.06657600f, 
    -0.03436749f, -0.12236039f, -0.10275587f, -0.08460256f, -0.09840310f, -0.22325860f, 0.00707878f, -0.05806142f, 
    0.03007166f, 0.02252999f, 0.10335134f, 0.02526597f, 0.14209604f, 0.03910250f, 0.05279930f, 0.07243443f, 
    -0.11562368f, -0.17473383f, 0.00675754f, -0.08964673f, -0.03143730f, 0.00130896f, -0.03525316f, -0.09469073f, 
    0.00555223f, -0.20991643f, -0.19461007f, -0.04956425f, 0.16552764f, -0.08276808f, 0.01161734f, -0.02007916f, 
    -0.03532788f, 0.06917693f, -0.05394875f, 0.05574440f, -0.04677596f, 0.10242893f, 0.06373614f, 0.06391744f, 
    -0.05366312f, 0.05580983f, -0.05898782f, 0.05339791f, -0.02888915f, 0.09317640f, -0.05393001f, 0.01420075f, 
    0.07191696f, 0.07898310f, 0.02076946f, -0.06336360f, 0.12530516f, 0.19983858f, -0.10477302f, -0.11658093f, 
    0.06606130f, -0.03633517f, -0.05098918f, 0.08692492f, 0.06010069f, 0.05775358f, 0.04846068f, 0.02945847f, 
    0.14064725f, -0.05198807f, -0.05052908f, -0.01137325f, -0.11651468f, -0.02271731f, -0.00322131f, -0.02392098f, 
    0.14258075f, -0.02697240f, -0.08312581f, 0.01044256f, -0.44119576f, -0.20471694f, -0.06989177f, -0.10477456f, 
    0.08263341f, -0.02225327f, 0.07483243f, 0.06056190f, 0.00211456f, 0.07931199f, 0.01578019f, 0.20449594f, 
    -0.26150745f, -0.38041696f, -0.10351507f, 0.04249952f, -0.00603759f, 0.05312333f, 0.04088775f, -0.01448874f, 
    0.10813929f, -0.02508273f, 0.05651271f, 0.04332326f, 0.26039523f, 0.14241762f, 0.12037348f, -0.14359164f, 
    0.09128046f, 0.08252785f, 0.03157103f, 0.04661947f, -0.07236043f, -0.04332045f, 0.02654798f, -0.04316864f, 
    0.05020291f, 0.22540238f, 0.03145950f, 0.03332640f, 0.06953605f, 0.11676060f, 0.00306664f, 0.02892354f, 
    -0.05752524f, 0.09759617f, 0.09465138f, 0.13899106f, -0.09372156f, 0.17821002f, -0.09129711f, 0.04259322f, 
    -0.00104019f, -0.02893031f, -0.04741727f, 0.06204795f, -0.15401179f, -0.06913809f, 0.20866191f, 0.04879025f, 
    0.08218135f, 0.03591685f, 0.09870481f, -0.12432302f, 0.07236888f, 0.04645342f, 0.11418097f, -0.03128228f, 
    0.05062171f, 0.09613726f, -0.02703592f, 0.00142491f, -0.06421254f, 0.20517036f, -0.05680484f, 0.02888276f, 
    0.04012350f, 0.06648889f, -0.05805175f, 0.08662758f, 0.16670607f, -0.07404480f, 0.09681443f, -0.13574575f, 
    0.18715282f, 0.10309718f, -0.04077286f, 0.00330930f, -0.07153060f, -0.02284219f, -0.06416009f, -0.04358054f, 
    0.04370289f, -0.02595539f, -0.04950793f, 0.03103653f, 0.05262848f, 0.12607497f, 0.02237866f, 0.06906110f, 
    -0.03486734f, 0.02132734f, -0.04431802f, -0.04053345f, 0.18725538f, -0.10228831f, -0.04106885f, 0.00098766f, 
    0.25148264f, 0.00724715f, -0.15279333f, 0.04040590f, -0.08220366f, -0.01284847f, -0.00167000f, -0.05146626f, 
    0.08428762f, 0.07708125f, 0.00257623f, -0.01305463f, 0.11002211f, 0.16274182f, -0.15097372f, 0.08565893f, 
    0.04944361f, -0.11532135f, 0.09190442f, -0.07984812f, -0.04623615f, -0.07046389f, 0.00870689f, -0.07074661f, 
    0.18861136f, 0.13420603f, -0.09545837f, 0.11207972f, -0.08477664f, -0.00496596f, -0.00820516f, -0.00243508f, 
    -0.05837603f, -0.00223612f, 0.10883375f, -0.01303363f, -0.06369568f, -0.24847284f, 0.12095432f, -0.02106230f, 
    -0.05436492f, 0.00854126f, 0.06521276f, -0.16771698f, 0.02797563f, -0.11612678f, -0.09886231f, -0.03918232f, 
    -0.23120479f, -0.30510253f, 0.05039980f, 0.06927292f, 0.00094155f, 0.01179745f, 0.09551746f, -0.04935031f, 
    0.15628757f, 0.04595638f, 0.08714148f, 0.03828372f, 0.31415120f, 0.03720737f, 0.05994562f, 0.14538376f, 
    -0.07510521f, -0.05541912f, -0.00329804f, 0.07234265f, 0.03858510f, 0.05858237f, -0.17247583f, -0.10713797f, 
    -0.01222065f, 0.01346721f, 0.18428142f, -0.03130819f, 0.00466299f, -0.04363453f, 0.05079807f, 0.02711755f, 
    0.02843400f, 0.09948695f, 0.05401554f, 0.05216530f, 0.26629931f, 0.01013994f, -0.02234407f, 0.04168214f, 
    -0.08796396f, 0.03844520f, -0.05738750f, -0.01556470f, 0.01980344f, 0.01325961f, -0.06221923f, -0.18463437f, 
    -0.37285459f, -0.06006320f, -0.08708242f, -0.21742286f, 0.09860823f, -0.01503968f, -0.06967975f, 0.09601232f, 
    0.03035618f, 0.02635705f, 0.09404702f, 0.06511480f, -0.27337968f, -0.14673047f, 0.00196306f, 0.03262992f, 
    -0.08667450f, 0.09892320f, -0.19258276f, 0.04422347f, -0.04166717f, 0.11823233f, 0.16102892f, -0.09189703f, 
    -0.54069501f, -0.09938686f, -0.26325098f, -0.37343919f, 0.11739382f, -0.02653169f, -0.07457878f, 0.04950793f, 
    0.04974979f, -0.07467546f, 0.14015478f, 0.05190675f, -0.05178502f, -0.16853963f, -0.05181719f, -0.07051239f, 
    0.04752049f, 0.05178737f, 0.01558124f, 0.06172420f, 0.04207240f, 0.08521640f, 0.02580456f, 0.06091337f, 
    -0.67937261f, -0.35772941f, -0.22192311f, -0.22747223f, 0.05523198f, 0.06220793f, -0.05886517f, -0.03370827f, 
    0.04870107f, -0.02767300f, 0.11079046f, 0.02986311f, 0.06707978f, 0.05563364f, -0.01592415f, -0.04595848f, 
    -0.06666887f, 0.03251274f, -0.04765536f, 0.08704060f, 0.14169711f, 0.13672680f, 0.10213344f, -0.00251706f, 
    -0.05991121f, -0.02108524f, -0.10253834f, -0.08535203f, -0.01363800f, -0.00750623f, -0.20550169f, -0.02295944f, 
    0.03929205f, -0.07474136f, -0.07534260f, -0.13132206f, -0.18092816f, -0.12786205f, -0.00115638f, 0.06934985f, 
    0.13112050f, 0.02182694f, -0.04386263f, -0.02708755f, 0.01679413f, 0.08745994f, -0.02998499f, 0.03236125f, 
    -0.04428892f, -0.03319540f, 0.03412442f, 0.03310069f, 0.06560308f, 0.17790942f, -0.00373368f, 0.09229533f, 
    0.09256099f, 0.03298661f, -0.00612970f, 0.00894917f, -0.27699348f, 0.04554709f, -0.07227951f, -0.00956942f, 
    0.06202040f, 0.02716108f, 0.01734816f, -0.03035722f, 0.06302531f, 0.09495049f, 0.02147416f, -0.03280808f, 
    0.12796229f, 0.03750889f, -0.04492700f, -0.07356651f, 0.07947728f, -0.01932595f, 0.07852571f, 0.04272754f, 
    -0.00104992f, -0.18456177f, -0.00838230f, 0.03188737f, -0.43712205f, 0.17364863f, 0.05878437f, 0.12756644f, 
    0.09284022f, 0.01942920f, 0.06781277f, -0.06776031f, 0.03498920f, -0.04696573f, 0.00278674f, -0.00382840f, 
    0.10286721f, -0.01749714f, 0.03521026f, -0.17231312f, 0.00328454f, -0.04503817f, 0.00531259f, 0.04302731f, 
    0.08211775f, 0.07691836f, 0.09795007f, 0.06281126f, -0.40121865f, -0.14058465f, -0.05904397f, 0.02345074f, 
    0.06325917f, -0.03704969f, -0.01932197f, -0.10253660f, 0.01457109f, -0.04332626f, 0.04542238f, 0.14048965f, 
    -0.40728733f, -0.17247857f, 0.20401922f, 0.01872693f, 0.08091667f, 0.02331846f, 0.01206055f, 0.03652522f, 
    0.06189820f, -0.03505646f, 0.07849416f, 0.06041190f, -0.16512795f, 0.03373158f, 0.03334913f, 0.15591303f, 
    0.03512581f, -0.24594487f, -0.01259304f, -0.01274824f, -0.03816626f, -0.11791381f, 0.08282243f, -0.01889751f, 
    -0.10767731f, 0.11705781f, -0.07705142f, -0.04913562f, 0.03716856f, -0.08289956f, -0.13363053f, 0.09298357f, 
    -0.10944727f, -0.03669432f, 0.06933131f, -0.01438799f, -0.09150246f, -0.16167529f, 0.01448417f, -0.11162990f, 
    -0.04036649f, -0.05804279f, -0.06901693f, 0.11715022f, 0.03362990f, -0.21206191f, -0.07083037f, -0.07575352f, 
    -0.13415419f, -0.05988906f, -0.01336998f, 0.07689389f, -0.03928214f, 0.08728707f, -0.10061746f, -0.01559047f, 
    -0.02805815f, -0.01185965f, 0.01020401f, 0.12593123f, -0.20919527f, 0.01075149f, 0.10915619f, 0.04965499f, 
    -0.04502365f, 0.06148420f, -0.18515638f, 0.06641410f, -0.05948824f, 0.06968918f, 0.16049404f, 0.13486707f, 
    0.03994228f, -0.10669924f, 0.08170533f, -0.03467366f, -0.04530815f, -0.01248191f, 0.00584773f, -0.00126934f, 
    0.08030603f, 0.01946378f, -0.10234006f, -0.08474618f, -0.09087605f, -0.06471691f, 0.08997186f, 0.01665825f, 
    -0.04087545f, -0.04747431f, -0.12890238f, 0.08989087f, -0.06354813f, -0.00923132f, 0.11112849f, -0.00981085f, 
    -0.30871934f, -0.07964712f, 0.07587460f, 0.18835227f, 0.16323024f, 0.01911080f, -0.00241458f, 0.02837448f, 
    -0.12566319f, -0.17682916f, -0.00774732f, -0.10088596f, -0.15088579f, 0.20560049f, -0.06815480f, -0.02230749f, 
    -0.08482802f, -0.02696325f, -0.00039505f, -0.17904375f, -0.00262596f, 0.01520597f, 0.02011708f, -0.15797018f, 
    0.18666327f, -0.17037585f, -0.07992677f, 0.05449938f, -0.11484844f, 0.05280796f, -0.12960836f, -0.08928528f, 
    -0.01242157f, 0.09793600f, -0.02712969f, -0.05628635f, -0.10799681f, -0.16252553f, -0.02821649f, 0.00526660f, 
    0.13069123f, 0.00853981f, -0.00846101f, 0.10373971f, 0.09247404f, -0.00856967f, 0.06193848f, 0.04339294f, 
    -0.14076142f, 0.20787153f, 0.13259318f, -0.21740945f, 0.00243573f, -0.05229985f, 0.02343096f, 0.00718651f, 
    -0.06348427f, 0.00887178f, -0.03558097f, -0.05187459f, -0.03884022f, -0.05330142f, -0.00943748f, -0.11091116f, 
    -0.04619477f, 0.05884709f, 0.00219287f, -0.00895470f, 0.07666913f, -0.06044913f, -0.01648596f, -0.00640120f, 
    -0.13879320f, 0.16832872f, 0.12053853f, -0.07053316f, 0.00624191f, 0.00282323f, -0.01425199f, -0.05753627f, 
    0.05349116f, 0.05022156f, 0.04294724f, -0.03503203f, -0.29205629f, 0.20225114f, 0.08929633f, 0.02001319f, 
    0.12320849f, -0.18453516f, -0.02103597f, 0.00079706f, 0.02678522f, 0.03477972f, 0.08932567f, -0.16226125f, 
    -0.05405981f, -0.36617076f, -0.17099252f, -0.19823062f, -0.04806048f, -0.01563765f, 0.03539985f, -0.01345326f, 
    0.01378090f, 0.14973459f, 0.09329774f, 0.02718168f, -0.17393632f, 0.05561506f, -0.04541438f, -0.04139717f, 
    -0.24871813f, -0.07922728f, -0.04337073f, 0.04567790f, -0.00847974f, -0.06844646f, -0.02729832f, -0.02361266f, 
    0.11037730f, -0.06014690f, 0.12966746f, -0.10044573f, -0.03607520f, -0.03440903f, 0.05695610f, -0.02093104f, 
    -0.01700849f, -0.05900275f, 0.00677650f, 0.04148008f, -0.22468160f, 0.28235999f, 0.10543839f, -0.03615718f, 
    0.13272333f, 0.00764022f, -0.05693106f, 0.07061565f, 0.10904606f, 0.06563564f, -0.02595261f, -0.11103997f, 
    -0.03586604f, -0.18557218f, -0.01491220f, -0.00506203f, -0.01548170f, 0.00942720f, 0.04176491f, 0.10345923f, 
    -0.09514051f, -0.04528151f, 0.00760874f, -0.09111324f, -0.15486029f, 0.08740027f, -0.02960594f, -0.00989868f, 
    -0.04450063f, 0.02882561f, -0.09127007f, -0.05505885f, -0.01829857f, 0.09450112f, -0.04203639f, -0.09356784f, 
    0.19837433f, -0.04622684f, -0.09752554f, 0.06924377f, -0.01108985f, 0.01921086f, 0.04557969f, -0.07903300f, 
    -0.00386782f, 0.03906714f, -0.01362389f, -0.01291275f, -0.15004079f, 0.29566687f, -0.03377816f, -0.01770464f, 
    -0.02388329f, 0.11361630f, -0.06988658f, -0.01877607f, 0.00328218f, 0.04568898f, 0.02212048f, -0.02101027f, 
    -0.24593288f, 0.04111113f, 0.01206671f, -0.10863639f, -0.14615041f, -0.00667094f, 0.03328839f, 0.02032896f, 
    -0.04294153f, -0.07982718f, 0.10378364f, 0.03519145f, 0.11430880f, -0.13608210f, 0.03130007f, 0.02450835f, 
    -0.04411675f, -0.04435339f, 0.00342995f, 0.04404690f, -0.03778844f, 0.01250610f, -0.06004525f, -0.00989154f, 
    -0.08749878f, 0.12309744f, -0.02647407f, 0.00609108f, -0.00289373f, -0.03341394f, -0.00814513f, -0.04190771f, 
    0.13569196f, 0.04446101f, 0.02981996f, -0.01166673f, 0.16834794f, 0.01789601f, -0.18255126f, -0.03949257f, 
    0.07133572f, 0.00574496f, -0.01109647f, 0.01788534f, -0.03642277f, -0.00777670f, -0.02436765f, -0.04841988f, 
    -0.04860900f, -0.18104142f, -0.06549761f, 0.01266382f, 0.07500120f, 0.01124423f, 0.08125749f, -0.03761477f, 
    0.01604709f, 0.03328609f, 0.10283570f, 0.10689677f, -0.14108792f, 0.23245710f, 0.14519769f, 0.00559138f, 
    0.09434421f, -0.01852316f, 0.06753909f, -0.27408737f, 0.02751624f, -0.00466092f, -0.05323781f, -0.11231942f, 
    -0.18815272f, -0.03715617f, -0.13455316f, 0.01839202f, -0.00097358f, 0.03601296f, 0.09562282f, 0.10650060f, 
    0.06211120f, -0.07302212f, -0.07210881f, 0.01810347f, 0.02391277f, -0.02683630f, -0.06875652f, 0.28565678f, 
    -0.11961583f, 0.10439746f, -0.03374383f, 0.00823817f, 0.01439242f, -0.01657487f, 0.03899498f, -0.03823982f, 
    -0.18968007f, -0.13179614f, -0.01331607f, 0.00084357f, 0.02537789f, -0.06911469f, -0.05145231f, 0.04807755f, 
    0.00593344f, -0.03189697f, -0.06820793f, -0.04447411f, 0.17326252f, 0.26473394f, -0.21823467f, -0.16234042f, 
    0.06035999f, -0.08530941f, 0.00594294f, 0.07956224f, -0.00086265f, -0.05320008f, 0.07904594f, 0.05638431f, 
    -0.10740740f, 0.17399421f, -0.08834126f, 0.11772410f, 0.13649680f, -0.03245256f, -0.02219876f, -0.03101931f, 
    0.09735693f, -0.04174341f, -0.04122806f, 0.07776476f, 0.01509799f, -0.03930392f, -0.06481522f, -0.29027200f, 
    -0.05885928f, 0.02040664f, 0.02439442f, -0.07342977f, -0.00154113f, -0.05766885f, -0.00882655f, -0.01944362f, 
    -0.24000143f, 0.21771541f, 0.02477631f, -0.08224349f, -0.06593688f, 0.05486254f, -0.02953920f, -0.09316472f, 
    -0.02860327f, -0.08552602f, -0.00953926f, -0.14115471f, -0.05004056f, -0.08151941f, 0.09077766f, 0.06706627f, 
    -0.04232280f, -0.01275814f, -0.01199863f, 0.09776910f, -0.01522151f, -0.10640152f, 0.00350012f, -0.05251689f, 
    0.15870552f, -0.21990253f, 0.04294246f, 0.00578669f, 0.03873841f, -0.04341214f, -0.09050895f, 0.04389808f, 
    -0.01054933f, -0.07029865f, 0.05736610f, 0.01737618f, -0.30623156f, -0.09966937f, 0.06715135f, 0.15145698f, 
    -0.02124914f, 0.00999365f, 0.10740234f, -0.01428819f, 0.07851908f, 0.03404109f, 0.01716318f, 0.07925098f, 
    -0.00910850f, -0.04001906f, -0.03381460f, 0.03849418f, 0.07918708f, 0.08334479f, 0.02218484f, -0.06192228f, 
    -0.13000654f, -0.04253831f, 0.08503623f, 0.05759019f, 0.15621288f, -0.32580864f, 0.06972874f, -0.10973641f, 
    0.01737060f, -0.04929597f, 0.07217428f, -0.03281900f, -0.17079568f, 0.08530527f, -0.02435545f, 0.01556885f, 
    0.19241713f, 0.08004229f, -0.07973216f, -0.01337879f, -0.10079321f, -0.12130492f, 0.11428300f, 0.04183494f, 
    -0.08334298f, 0.05858389f, 0.00085515f, -0.12860480f, 0.09615397f, -0.21305066f, 0.07340983f, 0.07953038f, 
    -0.13188389f, 0.12632626f, 0.03156639f, 0.09420532f, -0.03604238f, 0.01930221f, 0.08676570f, -0.02198276f, 
    0.28536046f, -0.08764768f, -0.07044530f, 0.08382550f, -0.04511691f, 0.05827873f, 0.00829429f, 0.00901645f, 
    0.06764761f, -0.07943904f, -0.04028361f, -0.10028382f, -0.05084781f, 0.14404257f, -0.04144543f, 0.12974566f, 
    0.13396613f, 0.09524922f, -0.03308032f, -0.10732326f, -0.02903506f, 0.05503103f, 0.00321032f, 0.01298277f, 
    -0.13238876f, 0.12265678f, 0.01576264f, 0.01504397f, 0.12826975f, -0.01878421f, 0.07687331f, 0.02510321f, 
    0.04769182f, -0.03825149f, -0.02980867f, -0.06722751f, 0.14845940f, -0.18938187f, 0.23958451f, -0.07214501f, 
    -0.01642506f, -0.04229035f, 0.11227914f, -0.05509061f, 0.02589426f, 0.00720530f, 0.10205286f, 0.13955329f, 
    0.20080282f, 0.17556392f, -0.15029562f, -0.04796590f, 0.09049860f, 0.07188383f, 0.00786527f, 0.10046612f, 
    0.02193679f, 0.00864324f, -0.08219710f, -0.03408613f, -0.30096492f, 0.10583112f, 0.01582359f, 0.09903366f, 
    0.07015663f, -0.00665617f, 0.09448840f, -0.03304659f, 0.07829197f, -0.08748028f, 0.10520530f, 0.03919096f, 
    -0.24739407f, 0.16795911f, -0.14961579f, -0.00264059f, 0.09701094f, -0.03265170f, -0.02298948f, 0.03469664f, 
    0.03169851f, 0.03250736f, -0.04101864f, 0.07254848f, -0.18403384f, -0.06090304f, -0.05798659f, -0.00655264f, 
    0.08901573f, -0.04436569f, -0.05833287f, -0.06339411f, -0.03246262f, 0.02963835f, -0.19883686f, 0.08185582f, 
    0.36722317f, -0.18649003f, -0.26040244f, 0.02731291f, -0.01367307f, 0.01380036f, -0.01194273f, -0.04404400f, 
    -0.03408268f, 0.02561152f, 0.02699271f, -0.02001820f, -0.03475254f, 0.08126111f, -0.08300357f, -0.23693576f, 
    0.11036537f, -0.01164045f, -0.03562377f, -0.01694982f, -0.00530193f, -0.03889034f, -0.06334992f, -0.05671501f, 
    0.26406512f, -0.32376572f, -0.20256561f, 0.07251973f, 0.03764988f, -0.01243631f, -0.06855226f, -0.01585193f, 
    -0.05921408f, 0.05745160f, -0.01173862f, -0.08197849f, 0.08375213f, -0.16466112f, -0.08251909f, 0.04055757f, 
    -0.19466935f, -0.06149719f, -0.02949204f, -0.17318310f, -0.06080986f, 0.04003417f, 0.00034689f, -0.07260128f, 
    -0.39727104f, -0.07962587f, -0.06794728f, -0.31918657f, 0.04799558f, -0.04416452f, -0.04006162f, 0.05129724f, 
    -0.00781590f, 0.06010709f, -0.06762207f, 0.02243401f, 0.28987369f, -0.16327092f, -0.14635168f, 0.09358643f, 
    0.07191233f, -0.03060609f, -0.02967772f, -0.10015917f, 0.08091564f, -0.00935031f, 0.00749176f, 0.10014017f, 
    0.28499928f, 0.08531013f, -0.10518488f, 0.28143567f, 0.10429993f, -0.01443853f, -0.02892912f, -0.06746955f, 
    0.09251888f, 0.07199071f, 0.01011827f, 0.05884674f, 0.18632427f, -0.21862304f, 0.00284149f, 0.23782203f, 
    -0.07882851f, 0.01143964f, -0.09241904f, -0.02407075f, 0.05443040f, -0.02333856f, 0.00425558f, 0.04838212f, 
    -0.02609330f, -0.02379978f, -0.05340159f, 0.01267689f, 0.05058496f, 0.03797302f, 0.03229242f, 0.03528517f, 
    0.02897883f, 0.03379289f, 0.06333880f, -0.08352579f, 0.45155254f, 0.18413092f, -0.11679464f, -0.07555735f, 
    0.04639555f, 0.04789152f, -0.14247629f, 0.10364720f, 0.10498990f, 0.00217494f, 0.03710102f, 0.09449609f, 
    0.35429847f, -0.05053989f, -0.32774454f, 0.08130419f, 0.02993204f, -0.01187955f, -0.09568165f, 0.04480138f, 
    -0.05094532f, -0.03748612f, 0.08390645f, -0.00020365f, 0.20045263f, -0.05656113f, -0.06236597f, -0.19200233f, 
    0.01965839f, 0.01077504f, 0.06384522f, 0.07911275f, -0.08112983f, -0.03846393f, 0.02784520f, -0.08050239f, 
    0.28816965f, 0.03328976f, -0.14734447f, 0.06756028f, 0.02682120f, -0.01307070f, -0.11596115f, -0.03056949f, 
    0.01179529f, 0.07056291f, -0.04854178f, 0.03199612f, -0.02899269f, -0.09420726f, 0.09369476f, -0.13098787f, 
    0.00810435f, 0.02900556f, 0.05677563f, -0.02134765f, -0.06214026f, -0.04796004f, -0.06610081f, -0.02305397f, 
    -0.37113839f, -0.05014071f, 0.05692662f, -0.06336392f, -0.05784985f, -0.00224934f, -0.01905614f, -0.02967790f, 
    -0.07347076f, 0.07917861f, 0.08032190f, 0.05520823f, -0.11166000f, -0.15585032f, -0.00468439f, -0.42927152f, 
    0.01817267f, -0.03943113f, 0.04149193f, -0.02652734f, -0.00580715f, 0.10368711f, -0.08373396f, -0.00615990f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.03841607f, 0.00873273f, -0.05118123f, 0.01706968f, 0.04236146f, -0.00741320f, 0.02054339f, -0.07702061f, 
    -0.03762439f, -0.01833359f, 0.08307402f, 0.02026779f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
