#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.24931723f, -0.93222964f, -1.23346424f, -0.91712785f, -0.77988315f, -0.10684264f, -0.38439763f, -0.14375418f, 
    -0.46727639f, -0.43036687f, -0.23964986f, -0.72929037f, -0.25713983f, 0.51591867f, -0.12755604f, -0.32885182f, 
    -0.51617116f, -0.22749114f, 0.28375012f, -0.40166357f, -0.48769403f, -0.36690149f, -0.75151926f, -0.14795206f, 
    -0.19407509f, 0.22596298f, -2.11177063f, 0.45352316f, 1.86386335f, 0.52440274f, -0.58916837f, -1.01468349f, 
    -0.53917795f, -0.48053452f, -0.15639804f, 0.26161152f, 0.15995105f, 0.28199089f, 0.03578186f, 0.38321915f, 
    -0.21545939f, 0.01489881f, 0.11327595f, -0.30089250f, -0.18760803f, -0.09921194f, 0.20024383f, -0.05983039f, 
    -0.04751581f, -0.06337810f, -0.72989964f, 0.72436106f, -0.44852591f, -0.18870832f, 0.43040946f, -0.59627312f, 
    -0.01192987f, 1.32240701f, 0.26623398f, -0.94160497f, -0.25106680f, 0.18043096f, -0.05893484f, 0.43535298f, 
    -0.86671591f, 0.13494126f, -0.28344116f, -0.72541696f, -0.27908391f, 0.00132891f, 0.10492917f, 0.13044205f, 
    -0.10813867f, -0.08826036f, -0.25014660f, 0.03878953f, -0.69342494f, -0.59637576f, -0.46554339f, -1.19682705f, 
    -0.24139845f, -0.40963942f, 0.21668559f, 0.40243521f, 0.82829434f, -0.03715487f, 0.35868046f, -0.10712009f, 
    -0.00531267f, -0.26313987f, -0.16048418f, 0.41159090f, 0.32035464f, 0.02568758f, 0.33330825f, 0.14722259f, 
    -0.10951954f, -0.04870145f, -0.47093755f, -0.45887977f, 0.99330211f, 0.38413346f, -0.64641857f, -1.01198685f, 
    -0.73972213f, 0.11412381f, -0.25394705f, -0.08757627f, -0.38727945f, -0.44328204f, 0.80825782f, 0.69499660f, 
    0.17857794f, 0.33987269f, 0.22738734f, 0.23144087f, -0.13774464f, 0.04238673f, -0.13176045f, -0.12049240f, 
    -0.02028043f, -0.32517716f, 0.03387301f, 0.13035750f, 0.02749597f, 2.01715922f, -0.59936410f, -1.13062215f, 
    -0.53733158f, -0.44896224f, 0.29454958f, 0.20349954f, 0.20758455f, -0.07123210f, 0.37068412f, -0.64066607f, 
    0.93543816f, -0.71275872f, -0.34291369f, 0.51446402f, 0.05493611f, -0.09175283f, 0.27436703f, -0.13161713f, 
    -0.25805369f, 0.06830022f, -0.30964836f, 0.08255170f, 0.07858019f, 0.27291694f, 0.09991671f, -0.50387836f, 
    -1.53162789f, -1.04200494f, -0.63221890f, 0.76200396f, 0.73202163f, 0.33137321f, -0.30635923f, -0.54172862f, 
    -0.62348825f, -0.26214302f, -0.09394649f, -0.31023759f, -0.53552228f, -0.10819039f, -0.08870102f, 0.63583499f, 
    0.00913572f, -0.17082506f, 0.12729862f, 0.34790036f, 0.36110184f, 0.42647439f, 0.27883792f, 1.29340482f, 
    0.46967635f, -0.00340740f, -0.61679405f, -0.50564849f, -1.04543984f, -0.79155391f, -0.62197679f, -0.84190351f, 
    -1.25100648f, -0.02682268f, 0.11399425f, 0.39311826f, -0.12372221f, 0.03142695f, -0.01818515f, 0.56411862f, 
    -0.19306421f, -0.02253274f, 0.03081267f, -0.00911638f, -0.17672646f, -0.18545726f, -0.15969151f, -0.13064496f, 
    -1.75638592f, -0.70602393f, -1.15346575f, -0.09743805f, 0.27998272f, 0.36381581f, 0.30651200f, 0.43142974f, 
    0.66588998f, 0.77629244f, 0.21275559f, 0.41926286f, -0.40701798f, -0.52150691f, -0.46980941f, -0.27726787f, 
    -0.02813389f, -0.35862717f, -0.32402176f, -0.56478763f, 0.09320363f, -0.12671362f, -0.37938142f, -0.10359828f, 
    0.07952210f, -0.45995784f, -0.57657748f, -0.92867428f, -0.80861783f, -0.02213142f, -0.51046866f, -0.67687386f, 
    -0.73636675f, -0.29674041f, -0.73866761f, 0.73081249f, -0.11614682f, 0.19495255f, -0.29437870f, -0.62333399f, 
    -0.78460425f, -0.07108635f, -0.33539280f, -0.67430592f, -0.40314522f, -0.21741207f, 0.38728026f, 0.45644435f, 
    -0.29167530f, -0.16990559f, 0.15793854f, -0.24530578f, -0.46572524f, 0.05902551f, 0.25681862f, 0.34266180f, 
    0.03057983f, -0.03599278f, 0.32414839f, 0.15654443f, -0.19888596f, 0.29319328f, -0.23929413f, 0.23267311f, 
    0.37068549f, -0.13303947f, -0.42453769f, -0.35537136f, 0.46367380f, 0.27371687f, 0.71638072f, 0.33241525f, 
    -0.25340256f, 0.33968535f, 0.38963327f, 0.40122235f, 0.34558970f, -0.10396998f, 0.25767660f, -0.41421887f, 
    0.00512933f, -0.58234668f, 0.12962514f, 0.00352871f, 0.54751360f, 0.02380007f, 0.13254562f, 0.21767293f, 
    0.06593872f, -0.44443172f, -0.47354516f, -0.16943522f, -0.02526453f, 0.09362894f, 0.23662765f, 0.03716075f, 
    -0.06188328f, -0.16025902f, -0.34649432f, 0.62402380f, -2.02673650f, -1.22588778f, -0.57416236f, -0.01756236f, 
    -0.22362703f, 0.93853247f, 0.38417429f, 0.60145164f, -0.06433271f, -0.29121858f, 0.08002385f, 0.08716949f, 
    0.01645186f, 0.67459381f, -0.19572817f, -0.10583907f, -0.11937522f, -0.05913645f, 0.28428271f, 0.04748781f, 
    0.14459312f, -0.11321334f, 0.32776573f, -0.14996468f, -0.18017028f, -1.26604533f, -0.19121246f, -0.17744868f, 
    -0.56125510f, -0.73911160f, -0.70232522f, -0.98731947f, -0.26780963f, -0.97358942f, -0.45548332f, 0.05220311f, 
    -0.46553269f, -0.25339183f, -0.92506957f, -0.24428870f, 0.40055242f, 0.36940053f, 0.13612567f, 0.13292427f, 
    0.28961349f, -0.02876105f, -0.14274971f, 0.01241734f, -0.08678967f, 0.43173543f, -0.80338866f, 0.16219121f, 
    0.16632140f, 0.77150571f, 0.73109794f, 1.10480714f, 0.15435955f, 0.22783346f, 0.39931679f, 0.62992823f, 
    0.34018797f, 0.16760302f, -0.01148453f, -0.04536176f, 0.01587361f, -0.12817945f, -0.24859343f, 0.00881262f, 
    0.01625222f, -0.14619665f, -0.07566141f, 0.12298096f, 0.03197648f, 0.11780266f, -0.23009707f, 0.28035000f, 
    0.55668557f, 0.86199236f, -0.06026484f, -0.04189945f, -0.49820021f, -0.68012732f, -0.38745421f, -0.11707396f, 
    -0.69468427f, 0.71691012f, -0.66813642f, -0.26276168f, 0.44388849f, 0.30755967f, 0.66852510f, 0.10581890f, 
    -0.05423656f, 0.23925450f, -0.43873632f, -0.46375328f, 0.22456068f, 0.15267915f, 0.41806933f, 0.30068615f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.33860898f, 0.26110277f, 0.71470648f, 0.14337280f, 0.21349801f, 0.60868132f, -0.06927201f, 0.02490567f, 
    0.37683690f, 0.33506465f, 0.68132001f, 0.76036429f, 0.60731685f, -0.30752191f, -0.12407995f, 0.33685195f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.52865106f, 0.13702762f, -0.00147584f, -0.07294814f, 0.29653844f, 0.09982105f, -0.12721373f, 0.12069578f, 
    -0.29272243f, -0.22964747f, -0.15597208f, -0.06967776f, 0.15951449f, 0.04136303f, 0.18286686f, -0.90416807f, 
    -0.22612192f, 0.19763029f, 0.01684704f, -0.30701795f, 0.02145252f, -0.00726271f, 0.01253109f, -0.13495834f, 
    -0.38941523f, -0.24261233f, -0.06191155f, 0.19958408f, -0.16074996f, -0.01760979f, 0.06568766f, 0.08480649f, 
    -0.00328483f, -0.16036949f, -0.05269830f, -0.03791139f, 0.29636142f, 0.13952544f, 0.22802588f, 0.04622437f, 
    0.02694023f, 0.08477922f, -0.17818227f, 0.11530706f, -0.02164014f, 0.15695934f, 0.20010957f, 0.26217946f, 
    0.42408308f, -0.03154699f, -0.36553824f, 0.19073619f, 0.03060873f, -0.00205789f, -0.21177343f, -0.25261229f, 
    -0.17748868f, -0.16272192f, 0.03213462f, -0.00845512f, -0.66004950f, -0.16279307f, -0.67093915f, 0.25251797f, 
    -0.27209622f, -0.11614518f, -0.13475613f, -0.34088612f, -0.17693561f, 0.00937552f, -0.19168751f, -0.16106643f, 
    0.58410788f, -0.08046317f, -0.34597731f, 0.14036430f, 0.13049215f, 0.33059654f, -0.04270767f, -0.11241902f, 
    0.05036718f, -0.06587689f, -0.02562792f, 0.08049370f, 0.14024183f, -0.01944899f, -0.19919612f, -0.15129846f, 
    -0.12000716f, 0.04502587f, 0.03061251f, 0.17087913f, 0.01690230f, 0.05695945f, 0.05216369f, -0.02019732f, 
    0.05563224f, 0.05691563f, 0.08478294f, -0.14221367f, 0.05339583f, 0.09170011f, 0.14821756f, 0.02002420f, 
    -0.11794703f, 0.06728031f, -0.08491739f, -0.16206771f, 0.45964223f, 0.36137882f, -0.17461708f, -0.43260288f, 
    0.12820426f, 0.14059605f, -0.11362730f, 0.00366818f, -0.19983234f, -0.13654210f, -0.22745828f, -0.15422094f, 
    -0.11984732f, 0.20051797f, -0.03075720f, 0.13309167f, 0.09167562f, 0.02291124f, -0.12165428f, -0.02638091f, 
    -0.43193734f, -0.11082929f, -0.25561869f, -0.26908118f, -0.59860671f, -0.62758559f, -0.25492784f, -0.19530699f, 
    -0.11232005f, -0.09710806f, -0.03542061f, -0.08988240f, -0.13864666f, -0.13025118f, -0.15548287f, 0.03157369f, 
    0.70567060f, -0.40969798f, -0.26000437f, -0.15936269f, 0.06333378f, 0.20046712f, -0.02933546f, -0.16878037f, 
    -0.15006115f, -0.13448805f, -0.11302282f, 0.02296125f, 0.46376646f, 0.55866170f, -0.14172775f, -0.49780950f, 
    0.33837777f, 0.23268683f, -0.05298422f, 0.33265373f, 0.01940826f, 0.09171721f, 0.09638780f, -0.06415100f, 
    -0.03938654f, 0.08555070f, 0.09413362f, 0.10086981f, 0.09933835f, 0.08182432f, 0.06412578f, 0.07585862f, 
    -0.18764392f, -0.04071843f, -0.25386372f, -0.12823538f, -0.04098504f, 0.03158765f, 0.15096568f, -0.18541004f, 
    0.00235719f, 0.22403611f, -0.20911510f, -0.23978078f, -0.04450731f, 0.00940642f, -0.03337411f, -0.07138179f, 
    0.18825546f, 0.15920074f, 0.25121176f, -0.02348870f, 0.07070071f, -0.03591539f, 0.11706956f, -0.20758301f, 
    0.12712158f, -0.13431191f, 0.02507250f, -0.16757761f, -1.07329977f, 0.35498458f, -0.65731603f, -0.11108706f, 
    -0.29931197f, 0.14865009f, 0.05673102f, 0.04932922f, -0.05581105f, 0.05879285f, -0.05881920f, 0.09963318f, 
    -0.61637306f, -0.53427023f, 0.11358460f, 0.27651879f, -0.01470977f, -0.03548793f, -0.00818348f, 0.07981248f, 
    -0.05386472f, 0.07219254f, 0.03454267f, 0.22358976f, -0.16054939f, 0.20094773f, 0.14252205f, -0.17497523f, 
    -0.16985208f, -0.10635283f, -0.31610608f, -0.33259544f, 0.02413658f, -0.23601770f, -0.07818086f, -0.08815037f, 
    -0.05385565f, -0.37289616f, -0.09780192f, -0.21737066f, -0.06534296f, 0.06055376f, 0.26482326f, -0.08039656f, 
    0.36476964f, 0.20944457f, -0.17630599f, 0.14521950f, 1.51874864f, 0.15931919f, 0.08610629f, -0.27611709f, 
    -0.00461258f, 0.12934108f, -0.02767031f, -0.22930193f, 0.18285227f, 0.08782239f, -0.20959584f, -0.08980770f, 
    0.40727004f, 0.25108841f, 0.38181832f, -0.21928541f, -0.11063722f, 0.10110935f, 0.37137806f, 0.01307673f, 
    -0.04405488f, -0.00164929f, -0.06860084f, -0.10226414f, 0.21277760f, 0.09198903f, -0.50729156f, -0.15917912f, 
    -0.14411421f, -0.27563739f, -0.22962199f, -0.08829995f, -0.13928945f, -0.06873418f, 0.09574719f, 0.17495550f, 
    0.14165872f, -0.27457604f, -0.58981729f, -0.38419622f, -0.01865286f, 0.04422238f, 0.02216787f, -0.07114320f, 
    0.11592921f, -0.28490603f, -0.40905225f, 0.10085343f, -0.16386151f, 0.04368041f, -0.08921593f, 0.17110619f, 
    0.10795558f, -0.01037693f, 0.15590976f, 0.16574584f, 0.00213418f, 0.01402666f, -0.15836933f, 0.17637828f, 
    0.10485984f, -0.07512216f, -0.03970383f, -0.00684779f, -0.01633027f, -0.22360021f, -0.01669697f, -0.01849809f, 
    -0.06537344f, 0.02432480f, 0.13129517f, 0.00739692f, 0.28613105f, 0.28686729f, 0.17653705f, -0.31785253f, 
    0.12494771f, 0.09795254f, -0.06520067f, 0.00458897f, 0.08199595f, -0.00450194f, 0.15274788f, 0.02085182f, 
    -0.41373360f, -0.34552971f, -0.26077417f, -0.25930125f, 0.02445836f, 0.13106708f, 0.25840548f, 0.10375254f, 
    0.03505249f, 0.03274309f, 0.08376446f, 0.06577293f, 0.07757288f, 0.14339946f, -0.05579123f, 0.00707565f, 
    0.10084636f, 0.02856454f, -0.18364169f, -0.36909670f, -0.01126987f, 0.06315622f, -0.18026461f, 0.06503645f, 
    0.28111532f, 0.23365694f, 0.01144330f, 0.26812541f, -0.13398749f, -0.18441013f, -0.04615083f, -0.02169594f, 
    -0.16891433f, 0.01128318f, 0.06660973f, 0.04104276f, 0.19084640f, -0.02960031f, -0.04624951f, -0.19887619f, 
    -0.11825091f, -0.01690666f, 0.05747033f, 0.02674237f, -0.04205365f, 0.10835046f, -0.02794190f, -0.03048576f, 
    -0.64001060f, 0.25246885f, 0.81599355f, 0.17865027f, 0.10272333f, -0.18915616f, -0.04836069f, 0.10673928f, 
    -0.11186823f, -0.02120595f, 0.14407036f, -0.23380040f, -0.29891959f, 0.56588972f, -0.91227090f, 0.10543164f, 
    -0.12760761f, -0.25516799f, -0.36332268f, 0.05144572f, -0.03134574f, 0.09601296f, -0.12148327f, -0.07369654f, 
    0.33433878f, -0.02034210f, -0.47662860f, 0.15039039f, -0.10660572f, 0.09390306f, 0.04471227f, 0.00432021f, 
    0.01884608f, -0.02318937f, -0.14147136f, 0.21461235f, 0.03636460f, 0.50383759f, -0.08682902f, 0.22760309f, 
    -0.04037054f, 0.21770784f, 0.13408050f, -0.22319241f, 0.06021211f, 0.15293787f, 0.00322243f, 0.15145829f, 
    -0.33685225f, 0.08010424f, 0.06886636f, -0.17420299f, -0.15122478f, -0.11474858f, 0.12502031f, -0.24703793f, 
    0.09983930f, -0.01837070f, -0.14517285f, 0.08623021f, -0.68808144f, 0.55791080f, 0.35348314f, -0.28955126f, 
    -0.08336654f, 0.05194753f, -0.20529312f, -0.26620147f, -0.06795880f, 0.17193587f, -0.26122585f, 0.16023327f, 
    -0.52426457f, 0.14932346f, 0.81377655f, -0.24167033f, -0.21476613f, -0.02705873f, 0.09207590f, -0.21170060f, 
    0.05781135f, -0.08775356f, -0.00932148f, -0.10412250f, -1.06307554f, -0.26230153f, 0.27266335f, -0.36614567f, 
    -0.03682497f, 0.03395384f, -0.27116489f, -0.45268795f, 0.13419077f, -0.07737433f, -0.12532516f, 0.03585878f, 
    0.13799343f, 0.28636479f, 0.44426054f, 0.31906256f, 0.10988644f, 0.03518691f, -0.01073563f, 0.01688302f, 
    0.04252857f, -0.13620946f, -0.11317497f, 0.12141504f, -0.19234313f, 0.10524978f, -0.08032537f, -0.05999823f, 
    -0.00466227f, -0.04712152f, 0.16208386f, -0.06619859f, 0.08852430f, -0.13401867f, -0.00879336f, 0.01446461f, 
    0.07476679f, 0.02681603f, 0.08540937f, 0.09946685f, 0.24474101f, 0.02165451f, 0.01288233f, 0.16658691f, 
    0.01956173f, -0.09327351f, -0.17670795f, 0.06523833f, -0.20158219f, 0.27005398f, 0.14148623f, -0.05475893f, 
    0.07168215f, 0.16284086f, -0.13251691f, 0.11421984f, 0.22621629f, -0.04796648f, 0.18039989f, -0.10156030f, 
    0.06194446f, 0.26845732f, 0.67759079f, 0.35859621f, -0.05843316f, -0.09457747f, 0.06571486f, 0.32422116f, 
    0.24111904f, -0.05355773f, 0.15331042f, -0.09153305f, -1.18245709f, -0.43703604f, -0.63840115f, -0.19374625f, 
    -0.15073720f, -0.00699710f, 0.05897490f, -0.12438659f, -0.09225000f, -0.04471559f, -0.07605198f, 0.00148177f, 
    -0.22643372f, -0.12598971f, -0.20514022f, 0.06960400f, -0.05323031f, -0.04497331f, 0.04812825f, 0.19625086f, 
    -0.26214319f, -0.16049358f, 0.14969182f, -0.29703024f, -0.43508816f, -0.09458860f, 0.04479940f, 0.03125740f, 
    -0.03171068f, -0.24404679f, -0.00317268f, 0.19623987f, -0.00007806f, -0.08045065f, -0.10086027f, 0.02873476f, 
    -0.17477496f, -0.26889277f, -0.17661011f, 0.47747019f, 0.06470030f, 0.10821328f, 0.12759712f, -0.01904152f, 
    0.17317487f, 0.02326732f, 0.21272801f, -0.02412207f, 0.00213281f, 0.61931264f, -0.50657111f, 0.59450245f, 
    -0.05775386f, -0.34834099f, -0.05671455f, 0.11727880f, -0.07939894f, 0.15877591f, 0.10938910f, 0.10561886f, 
    0.83154458f, -0.43072790f, 0.06995771f, -0.37786984f, -0.09132590f, -0.29468283f, -0.09629194f, -0.00523640f, 
    -0.10377274f, 0.02849969f, -0.02714733f, -0.24732296f, 0.09102393f, -0.36646903f, -0.15570574f, 0.26266715f, 
    -0.02921082f, 0.04405478f, 0.07609755f, -0.17742699f, -0.10483461f, 0.02563010f, -0.07687709f, 0.22177707f, 
    -0.86371440f, 0.18221816f, -0.02015284f, 0.59739327f, 0.21730243f, 0.17029485f, 0.03093747f, 0.07688208f, 
    -0.04486525f, -0.10968135f, 0.26251772f, 0.02653866f, -0.67489392f, -0.02866055f, -0.15743133f, 0.34564957f, 
    -0.03289750f, -0.08066352f, 0.03412748f, -0.36307654f, 0.03602192f, 0.20534576f, 0.16458270f, -0.14652076f, 
    0.19136880f, 0.10935228f, -0.16705084f, 0.27507335f, 0.38406026f, -0.02370535f, -0.08602300f, 0.03619764f, 
    0.01443304f, 0.15894245f, 0.08247148f, 0.30193216f, -0.20569453f, -0.45178533f, 0.26171863f, 0.42796084f, 
    0.04390011f, 0.22351106f, 0.35399574f, 0.12569356f, -0.04652808f, 0.14459458f, -0.35827681f, -0.11248918f, 
    0.36831656f, -0.07215044f, -0.21282808f, -0.09024930f, 0.33544692f, -0.08733209f, 0.02280005f, -0.08894216f, 
    -0.23337430f, 0.20935558f, -0.18818557f, 0.12035868f, 0.04563994f, -0.10222948f, -0.00258228f, 0.19189121f, 
    0.04277083f, -0.06318074f, 0.07070217f, -0.03454627f, -0.07807744f, 0.09917720f, 0.00231613f, -0.07100031f, 
    -0.27215630f, 0.24725056f, -0.12618355f, -0.31214860f, 0.22961970f, -0.19064182f, -0.02892976f, -0.12291522f, 
    -0.11175085f, -0.23836388f, 0.05329929f, -0.12767674f, -0.52773106f, -0.40982065f, -0.67440230f, -0.19257066f, 
    -0.18511954f, -0.00570242f, -0.67128354f, -0.22638175f, -0.11064693f, -0.02656676f, -0.21320513f, -0.39799178f, 
    -0.12603527f, 0.29129559f, -0.02342348f, -0.09309867f, 0.34707981f, 0.12787704f, -0.01798221f, 0.07077519f, 
    -0.22313064f, -0.03137999f, 0.08152662f, -0.02807881f, 0.17561378f, -0.45108372f, -0.10533714f, 0.03035250f, 
    -0.03078633f, -0.02705067f, -0.04003257f, -0.05843158f, -0.01222771f, 0.09352207f, -0.17434029f, -0.07310794f, 
    -0.79634416f, 0.73570132f, 0.19764003f, -1.27711773f, 0.23800939f, 0.19196412f, -0.05970622f, 0.00300075f, 
    -0.15169631f, -0.04832906f, 0.10777062f, -0.21860495f, 0.36682540f, -0.43365327f, 0.79562086f, 0.04532543f, 
    -0.02611635f, 0.03319148f, -0.16279204f, -0.02470943f, -0.01061011f, -0.04475879f, 0.31906512f, -0.08901015f, 
    -0.14235175f, 0.31989864f, 0.09524918f, 0.04709328f, -0.17208426f, 0.09832667f, -0.09509102f, 0.05935840f, 
    -0.05985624f, 0.15333238f, -0.03835469f, 0.29487649f, 0.12056599f, -0.61764520f, 0.88493341f, 0.00694638f, 
    0.02776042f, -0.06139608f, -0.08676638f, -0.04434584f, -0.07617281f, 0.05252389f, 0.06247414f, 0.01211199f, 
    -0.48859355f, -0.41160810f, 0.18500490f, -0.46543214f, -0.01543773f, -0.07064367f, -0.20727888f, 0.00608244f, 
    -0.00168385f, -0.12948920f, -0.18997301f, -0.13133492f, -0.25425801f, 0.02670841f, 0.12960015f, 0.11675646f, 
    0.18693259f, -0.11895345f, -0.02863274f, -0.06367153f, 0.15449941f, -0.08641654f, -0.03053898f, 0.15524855f, 
    0.23347475f, 0.13975199f, 0.17870085f, -0.02000105f, 0.19151308f, 0.14726546f, 0.06796902f, -0.20736109f, 
    -0.01351527f, 0.12216692f, 0.12815188f, -0.06335127f, -0.16706418f, -0.38322932f, -0.50581032f, -0.37070233f, 
    0.00230042f, -0.05220716f, -0.13965458f, -0.12166123f, -0.08785830f, -0.05547193f, -0.14739411f, 0.11788410f, 
    -0.39754391f, -0.14463712f, 0.19942126f, 0.13838921f, -0.13508058f, -0.10344598f, -0.20475098f, -0.22203782f, 
    -0.00911297f, 0.00634107f, 0.07301657f, -0.09474901f, 0.21837866f, 0.65382391f, 0.26029301f, 0.00611162f, 
    -0.00214624f, 0.06174435f, -0.18182817f, 0.07543439f, 0.13099684f, -0.14501373f, 0.04490140f, -0.14803962f, 
    0.25811192f, 0.01490438f, -0.12393770f, 0.36970696f, -0.28462991f, -0.04298528f, -0.07775248f, 0.12751321f, 
    -0.03386901f, -0.11791106f, 0.10302873f, -0.03250247f, 0.00684174f, 0.00426807f, 0.31866542f, 0.20121422f, 
    -0.03592068f, 0.05489063f, -0.15758313f, 0.01384416f, 0.14090358f, -0.13105309f, 0.07134208f, -0.07240012f, 
    0.22038214f, -0.01835202f, 0.00485981f, 0.05961532f, -0.16089424f, 0.02990249f, -0.07560461f, 0.21154855f, 
    -0.04916206f, -0.23111501f, -0.34314260f, -0.08414321f, -0.41986045f, -0.23358779f, -0.21797489f, -0.05237781f, 
    0.07045790f, -0.04612399f, 0.02550686f, 0.13173175f, -0.09265692f, 0.02558003f, -0.10908892f, -0.14394255f, 
    0.06489537f, -0.33957356f, 0.17411114f, 0.07254886f, -0.33864048f, -0.26169732f, -0.04314958f, -0.28742245f, 
    0.04899752f, 0.16666745f, -0.26117611f, 0.04864910f, -0.01405891f, 0.13347921f, 0.08722422f, 0.28489667f, 
    -0.17124540f, -0.02835901f, 0.19415225f, 0.15344495f, -0.00523038f, -0.07861149f, 0.00516264f, 0.00209332f, 
    0.20655146f, -0.07456370f, -0.00698705f, -0.06495880f, 0.20353551f, 0.08475313f, 0.06889524f, 0.10122214f, 
    -0.04001711f, -0.01693287f, -0.19887638f, 0.15460429f, 0.01618734f, 0.24269785f, -0.11628529f, 0.54949200f, 
    0.01049730f, 0.16639966f, 0.02405396f, 0.25679526f, 0.00481459f, -0.00929008f, -0.36459553f, -0.15307701f, 
    0.16696826f, 0.17911209f, 0.03626744f, -0.31602854f, 0.07134868f, -0.09889124f, -0.12412471f, -0.16734640f, 
    -0.06563015f, -0.09250555f, -0.20648618f, -0.06035216f, 0.76298678f, -0.27839005f, 0.48776197f, -0.14071903f, 
    0.23173966f, 0.16324803f, 0.24442163f, -0.13155276f, 0.12817152f, -0.14598364f, -0.08873501f, 0.04907258f, 
    -0.07174273f, 0.55996370f, -0.41914624f, 0.45242757f, 0.08538193f, 0.02628295f, 0.01422307f, -0.24169886f, 
    0.06237721f, 0.07805833f, -0.08750880f, -0.09869233f, 0.32369488f, -0.27305603f, -0.13404520f, -0.13088834f, 
    -0.16602443f, 0.03000858f, -0.10784970f, 0.47399372f, -0.24050799f, 0.04394183f, 0.14093716f, -0.10703717f, 
    -0.00621203f, 0.38082680f, -0.20558649f, -0.30933750f, 0.07112130f, -0.00397633f, -0.13305515f, 0.03249190f, 
    -0.20607133f, -0.12342052f, -0.04081716f, -0.01525160f, -0.11947437f, -0.09206335f, -0.17096709f, -0.34783486f, 
    0.01836437f, 0.06043053f, -0.03023935f, 0.27919269f, 0.29235467f, -0.16944313f, 0.04783486f, -0.06995930f, 
    -0.04731332f, 0.25526917f, -0.37848330f, -0.32476860f, 0.06122535f, -0.14874643f, 0.15239374f, -0.13738309f, 
    -0.01009860f, -0.03829322f, 0.04506309f, 0.01230101f, 0.23877947f, -0.00718284f, -0.00485508f, -0.13237257f, 
    -0.06294092f, -0.21254826f, -0.31081158f, -0.24080878f, 0.00636641f, -0.12255355f, -0.01119989f, -0.17387465f, 
    -0.76606870f, -0.11048471f, 0.08840661f, -0.06749420f, -0.06638611f, 0.03214165f, 0.04664565f, 0.12147790f, 
    0.09840640f, -0.38013393f, 0.10006594f, 0.06650374f, 0.10002579f, 0.23731576f, 0.21351545f, -0.23409541f, 
    -0.08082699f, 0.14439443f, 0.21209483f, -0.11231744f, 0.12891728f, -0.08861803f, 0.19715233f, 0.06341538f, 
    -0.17097086f, -0.35231838f, 0.03492843f, -0.02846528f, -0.16983664f, 0.24338101f, 0.00134688f, -0.25461963f, 
    0.21329568f, 0.30110136f, 0.15496066f, 0.16802570f, 0.34672534f, -0.39188838f, -0.15522209f, 0.56391746f, 
    -0.11538482f, 0.08522100f, 0.13122679f, 0.12360148f, -0.06240898f, 0.01222433f, 0.08795594f, 0.31284717f, 
    -0.53070784f, -0.00665987f, -0.70314437f, -0.18730031f, 0.14534418f, -0.07983731f, -0.10118999f, -0.16466194f, 
    0.18080893f, -0.08821068f, -0.05485127f, -0.19052096f, -0.12804325f, 0.28434604f, 0.29667535f, 0.13547666f, 
    0.25871912f, 0.07764928f, 0.05274763f, 0.00013688f, 0.01693641f, -0.00013436f, 0.16483349f, 0.19235294f, 
    -0.43608904f, -0.20292857f, 0.15741837f, 0.00994443f, 0.01836333f, -0.09944965f, -0.15056476f, 0.04396925f, 
    0.08065148f, -0.04025865f, 0.19451633f, 0.08144782f, -0.34728044f, -0.15192150f, -0.17675394f, -0.16582608f, 
    0.04766546f, 0.04025998f, 0.06351686f, -0.24622487f, 0.07073408f, -0.05783664f, 0.17818101f, 0.29081118f, 
    -0.88779598f, -0.70211381f, -0.18384783f, 0.23665179f, -0.15712671f, 0.05553634f, 0.27339542f, -0.15804139f, 
    -0.01681241f, 0.01024165f, 0.13277207f, 0.21862949f, -1.11483002f, -1.04099751f, -0.61245680f, 0.61801970f, 
    0.14807609f, 0.20733178f, 0.06397006f, -0.04357418f, 0.05379142f, -0.05147377f, 0.11046696f, -0.03306244f, 
    0.02153095f, 0.13915835f, 0.13650146f, -0.92636508f, 0.11177279f, 0.15313654f, 0.01796380f, -0.02602249f, 
    0.09373225f, 0.09592804f, 0.35012466f, 0.00807199f, -0.00465242f, -0.00284629f, 0.00000614f, 0.24916226f, 
    -0.07584094f, 0.31771082f, 0.28673145f, 0.31516662f, 0.08640431f, 0.14614160f, -0.16009451f, -0.00315520f, 
    0.52159530f, 0.42661813f, -0.08210987f, -0.28013763f, -0.12905596f, -0.27922463f, -0.46986112f, -0.24591680f, 
    0.06982534f, -0.26293069f, -0.02118838f, -0.11602356f, 0.62841547f, 0.28663012f, -0.41632193f, 0.00287971f, 
    0.19871297f, 0.01198663f, 0.33498660f, 0.26562387f, 0.07101753f, 0.07506680f, 0.25381142f, -0.13569689f, 
    -0.67021525f, -0.39720407f, 0.14926736f, -0.27062139f, -0.02809091f, -0.29419678f, -0.17086475f, 0.02938991f, 
    -0.05922484f, 0.08251939f, -0.05334794f, -0.15290129f, 0.09575381f, -0.49169567f, -0.89682895f, -0.42838103f, 
    0.00001247f, 0.31820813f, 0.38980269f, -0.30356553f, 0.16984887f, 0.10241288f, -0.07083984f, 0.18954450f, 
    -0.29424125f, 0.39301577f, 0.40269423f, 0.30088934f, 0.02080247f, 0.01837163f, -0.03220118f, 0.18447627f, 
    -0.11582233f, 0.45555270f, 0.32218096f, 0.10878596f, -1.22709715f, -1.30896747f, 0.31686163f, -0.40555009f, 
    -0.22330703f, -0.00624416f, -0.54276448f, -0.26442975f, -0.12824231f, -0.01750926f, 0.04788780f, -0.14165471f, 
    -0.02438458f, 0.15652941f, -0.04477309f, 0.02739189f, 0.15942974f, -0.24472865f, 0.06031284f, 0.07971781f, 
    0.16443343f, -0.19257194f, 0.00493477f, 0.03511932f, 0.06687436f, -0.05763972f, 0.20351040f, 0.15234086f, 
    0.06561720f, -0.11166864f, 0.23198424f, -0.03275396f, 0.13864125f, 0.04301260f, -0.27164274f, 0.16274424f, 
    -0.86649811f, 0.37068450f, 1.08629465f, 0.06269102f, -0.31052971f, -0.00539109f, 0.04379452f, -0.38204899f, 
    -0.15041339f, 0.14038099f, 0.00948122f, 0.08369424f, -0.82013494f, -1.19372392f, -0.51488072f, -0.11485306f, 
    -0.30021647f, -0.30126432f, 0.12657398f, -0.35456309f, -0.10891204f, 0.08754365f, 0.09670450f, -0.22454552f, 
    -0.24121006f, -0.22876836f, 0.09790044f, -0.03744689f, 0.08732082f, -0.02155999f, -0.12956114f, 0.03664885f, 
    0.13919552f, 0.01803054f, 0.02188952f, -0.11678238f, 0.11011662f, -0.42256150f, -0.27377608f, -0.37402514f, 
    0.05434098f, 0.03254382f, -0.02184458f, -0.31426197f, -0.10279105f, -0.10327400f, -0.04973337f, -0.19073576f, 
    -0.67853916f, -0.21565485f, -0.54597551f, -0.44532502f, -0.04356771f, -0.22598279f, 0.08574186f, 0.21836030f, 
    -0.19012199f, 0.13132012f, -0.05080060f, 0.08983885f, -0.23611069f, -1.76758158f, 0.65126985f, -0.11091378f, 
    -0.04881011f, 0.02546684f, 0.16101408f, 0.09093152f, 0.19756791f, 0.06612122f, -0.08568121f, -0.15057142f, 
    0.05732021f, 0.39071357f, -0.57784003f, 0.17980666f, -0.15424198f, 0.01285952f, 0.18388246f, 0.03707276f, 
    0.01585442f, 0.06344254f, -0.50179511f, -0.16580544f, -0.53326482f, -0.12346420f, -0.10016876f, -0.16114147f, 
    0.17433868f, 0.34670946f, 0.30081141f, -0.18728027f, 0.08025536f, 0.03983739f, 0.04094849f, -0.09875292f, 
    -0.10438766f, 0.14898798f, -0.00657687f, 0.18120240f, 0.15981305f, -0.13132542f, 0.06819342f, 0.11347955f, 
    0.02588737f, 0.14008877f, 0.16964523f, 0.14776298f, -0.44446176f, -0.52442491f, 0.47394571f, -0.31379041f, 
    0.19652537f, -0.05132686f, 0.30040613f, -0.12214471f, -0.15751328f, 0.04705645f, 0.09936894f, -0.01004871f, 
    -0.79591084f, -0.28834733f, -0.29084927f, -0.76879585f, 0.10796122f, -0.26785493f, 0.36583808f, 0.29147196f, 
    0.15161473f, 0.04425194f, 0.05687274f, -0.08704111f, -1.61304867f, 0.66449213f, -0.19620666f, 0.17764971f, 
    0.21465357f, -0.12375609f, 0.09291344f, 0.03655637f, 0.10452272f, -0.10174471f, 0.01345831f, -0.08162811f, 
    0.74837142f, -0.33872399f, -0.57680368f, -1.15602303f, 0.14140722f, 0.11253161f, -0.08300854f, -0.09077013f, 
    0.11857852f, 0.40493724f, 0.08539037f, -0.26220301f, -0.20379117f, -0.75267035f, 0.46196598f, 0.58157516f, 
    -0.11710777f, -0.03060621f, -0.04725088f, -0.04113801f, 0.02995977f, -0.18151644f, 0.05542286f, -0.11729509f, 
    0.15251888f, 0.01960675f, 0.06637273f, -0.14689507f, -0.04431084f, -0.01128723f, 0.10240483f, 0.03605004f, 
    -0.13197809f, -0.00310419f, -0.05648725f, 0.04519874f, 0.02105199f, 0.00355381f, -0.11213794f, -0.21694954f, 
    -0.12389545f, -0.06319266f, -0.10469206f, 0.02689098f, 0.00156935f, 0.08775827f, -0.00935989f, -0.03027802f, 
    0.76795775f, 0.04096826f, -0.64210200f, -0.35949358f, 0.19365546f, -0.22050552f, -0.41432673f, 0.23601598f, 
    0.03526359f, 0.05560058f, -0.03693646f, -0.04555506f, -0.33472353f, -0.60603684f, -0.21886408f, 0.56253821f, 
    0.29854470f, -0.11765857f, -0.15674761f, 0.28810123f, 0.07044029f, 0.00427815f, -0.15761416f, -0.16288951f, 
    0.31658968f, 0.05160288f, 0.00519245f, -0.42550927f, -0.04445096f, 0.03432414f, 0.00589611f, -0.08698376f, 
    -0.02123267f, -0.00469364f, -0.18283376f, -0.60657603f, -0.28198537f, 0.35206866f, 0.09130340f, 0.09775405f, 
    -0.42637628f, -0.08543965f, -0.26072451f, -0.16183595f, -0.05732262f, -0.01302141f, -0.04682838f, -0.03648007f, 
    0.23378599f, -0.44559762f, -0.33455518f, -0.18260454f, -0.08287820f, 0.10840970f, 0.13966377f, -0.28582016f, 
    0.01113168f, -0.22009547f, 0.06256227f, -0.24615249f, 1.51754248f, 0.20795462f, -0.24189445f, -0.46730930f, 
    0.04756020f, -0.14190243f, -0.16486757f, -0.36931649f, 0.22718915f, 0.09679191f, 0.04589698f, 0.06404136f, 
    0.28434503f, 0.02171089f, -0.01545937f, 0.15177162f, -0.17499346f, 0.17440812f, -0.02383341f, 0.09491465f, 
    0.03355508f, 0.09256580f, 0.12909622f, 0.10778297f, -0.29246563f, -0.42170811f, -0.41204944f, 0.37545538f, 
    0.40431044f, -0.01346300f, 0.13975412f, 0.20819516f, -0.11053726f, -0.31008482f, -0.18883680f, -0.18846768f, 
    -0.43005386f, -0.28579539f, -0.06766569f, 0.13861141f, -0.19393431f, -0.08729903f, -0.11326990f, 0.11691644f, 
    -0.15345810f, -0.17213571f, -0.08328764f, -0.11214408f, -0.85345185f, -0.56822401f, 0.34334776f, 0.19634524f, 
    0.01801591f, 0.19740608f, -0.03190473f, -0.14742540f, -0.01690903f, -0.10104913f, 0.00154395f, 0.24749655f, 
    -0.49036711f, -0.79714757f, -0.11902823f, 0.46090841f, -0.20560852f, -0.08775210f, -0.00418901f, 0.16633633f, 
    -0.03008568f, -0.00233600f, 0.02804125f, 0.28532687f, -0.13516434f, 0.11998638f, 0.11647663f, 0.46243811f, 
    0.21533576f, 0.04374928f, -0.30234653f, -0.10765990f, -0.01471799f, -0.06277756f, 0.11230312f, -0.05131745f, 
    -0.13811059f, -0.36413229f, -0.29573897f, -0.36319488f, 0.01139575f, 0.04213871f, 0.24343900f, -0.02493787f, 
    0.28102413f, 0.01441737f, 0.05327059f, -0.16249467f, -0.00121301f, -0.92782152f, -0.75916255f, -0.35406443f, 
    -0.17650582f, -0.03426820f, 0.08555062f, -0.13960500f, -0.08048546f, 0.21007168f, 0.04805120f, 0.13743287f, 
    -0.15850782f, -0.12053625f, 0.08361508f, -0.16945399f, -0.13882811f, 0.10566712f, 0.20104110f, -0.01176743f, 
    0.04882510f, 0.24277526f, 0.41783753f, 0.17368878f, -0.18943806f, -0.00602926f, -0.10486475f, 0.15656264f, 
    0.08071937f, -0.13998410f, 0.03982997f, -0.07259779f, -0.07049862f, -0.00329750f, 0.28522718f, 0.20055719f, 
    0.16598904f, -0.60410291f, -0.85851634f, -0.28935781f, -0.06356344f, 0.07402476f, 0.16589871f, 0.33511192f, 
    0.13236207f, -0.31832865f, 0.12685290f, 0.00990407f, -0.11029830f, -0.05727281f, -0.64451617f, -0.05142035f, 
    -0.05289447f, 0.08533427f, 0.09798139f, -0.25956649f, 0.05271778f, 0.00331273f, -0.02223041f, 0.01454395f, 
    0.04564113f, -0.21419381f, -0.32321221f, -0.63588381f, -0.25938824f, -0.20689274f, 0.09822626f, -0.10948776f, 
    0.06110841f, 0.26961085f, 0.05144266f, 0.29866174f, -0.26477015f, 0.14689745f, 0.20267636f, -0.01707819f, 
    0.18501529f, -0.60851306f, -0.12136718f, -0.03469656f, 0.23787266f, 0.22393858f, 0.23593672f, 0.09420662f, 
    -0.33676848f, -0.05711168f, 0.10738167f, -0.07997370f, -0.28353995f, 0.07218332f, 0.17985792f, 0.20527193f, 
    -0.07027411f, 0.14894335f, 0.15272988f, 0.11944332f, 0.51402432f, -1.52961791f, -0.17419413f, -0.15089430f, 
    0.23098405f, -0.06339666f, -0.05122666f, -0.05413776f, -0.11484520f, -0.04308806f, 0.06124780f, -0.09071779f, 
    -0.96533126f, 0.13558993f, -0.20349704f, 0.19982934f, 0.07910635f, -0.31188580f, 0.02078407f, -0.11236150f, 
    0.04837124f, 0.02352705f, 0.17547855f, -0.05537627f, -0.19466522f, 0.30020985f, 0.43994185f, -0.43582192f, 
    -0.16400746f, -0.27249876f, 0.06589032f, -0.31890348f, 0.10732464f, 0.05627583f, 0.10125436f, 0.17108645f, 
    0.20638625f, 0.34122601f, 0.56484526f, -0.48662403f, 0.03887019f, -0.05198466f, 0.03596602f, 0.29417965f, 
    -0.08269793f, 0.14040637f, -0.00038101f, -0.11520983f, 0.14581633f, -0.83279115f, 0.71969289f, -1.60325015f, 
    0.05897078f, -0.45178863f, -0.07183945f, -0.06725717f, -0.36833465f, -0.07333651f, -0.07597449f, -0.13766140f, 
    0.00103722f, -0.36785063f, 0.02763505f, -0.63537598f, 0.03863275f, 0.19426915f, -0.45300987f, 0.37232751f, 
    -0.07674555f, 0.03381470f, 0.04697531f, 0.09996103f, 0.09592665f, 0.40871921f, -0.48353770f, -0.35021499f, 
    0.10189945f, -0.14275102f, 0.31909034f, 0.15890297f, -0.09923776f, 0.24236178f, -0.08395420f, -0.10573388f, 
    0.33531055f, 0.31457967f, 0.59855789f, 0.35991958f, 0.16878477f, -0.12248655f, -0.18485090f, -0.22617395f, 
    -0.09669761f, 0.26463544f, 0.12622827f, -0.10171635f, -0.24736623f, 0.16832779f, 0.12605323f, -0.41893721f, 
    0.04214515f, -0.40714762f, 0.01758400f, 0.13462363f, 0.11939439f, 0.14607123f, -0.05511745f, -0.14590621f, 
    0.21010505f, -0.03195610f, 0.12304944f, -0.13600469f, 0.09939374f, 0.02739994f, 0.10549198f, 0.09602635f, 
    0.00189938f, 0.03193932f, -0.10172846f, 0.04173116f, -0.06777888f, -0.00413986f, -0.16206937f, 0.00099591f, 
    0.16364048f, -0.00971077f, 0.23672654f, -0.03702731f, -0.08368848f, 0.09676991f, -0.10964409f, -0.11418366f, 
    -0.09882928f, 0.00179044f, -0.02439380f, 0.62032819f, 0.12250292f, -0.06144533f, -0.56245553f, -0.07844267f, 
    0.25195974f, -0.40996861f, 0.04985140f, 0.26547128f, -1.08108592f, -0.01327610f, 0.40942961f, 0.09318406f, 
    -0.24255413f, -0.53894204f, -0.06374177f, 0.13406381f, 0.14968495f, 0.02470553f, 0.20816182f, 0.01521293f, 
    -0.34454128f, -0.28271905f, 0.35563043f, 0.41382587f, 0.00759293f, 0.16718329f, -0.25430048f, -0.10179846f, 
    -0.01540910f, 0.10775712f, 0.18278173f, -0.05897593f, 0.01485893f, -0.33217847f, -0.58749366f, -0.00360123f, 
    0.26387221f, 0.14157192f, 0.30659452f, 0.29033610f, -0.04942924f, -0.23786786f, -0.20270339f, -0.28736505f, 
    -0.10708264f, -0.06791206f, -0.47258028f, 0.25363111f, -0.21252896f, 0.02731214f, -0.16646655f, -0.36082953f, 
    0.23727387f, 0.10649148f, -0.21716644f, -0.61761916f, -1.29475439f, 0.51885331f, -0.12911232f, 0.26427475f, 
    -0.10221164f, 0.32812560f, -0.38354978f, 0.27803582f, -0.17185603f, 0.02165099f, -0.11147503f, 0.01596565f, 
    0.33288252f, 0.54222238f, 0.43430308f, -0.12920234f, -0.08524595f, -0.00622742f, 0.26697606f, 0.17396455f, 
    0.03974148f, -0.21887203f, -0.03409860f, 0.01375779f, -0.49807471f, 0.05524369f, -0.15229025f, 0.15136696f, 
    0.08824161f, -0.24838315f, -0.27914184f, 0.06864296f, -0.05740128f, 0.15830681f, -0.37276930f, -0.53486532f, 
    -0.04274292f, -0.97215551f, 0.28249884f, 0.16924538f, -0.24009991f, -0.18499610f, -0.08087891f, -0.08732264f, 
    -0.22456934f, -0.16945630f, 0.07026115f, -0.03868559f, -0.36793002f, 0.78226817f, 0.38807791f, 0.22068793f, 
    0.26191166f, 0.26449925f, -0.07505924f, 0.25821736f, 0.02290487f, -0.14208058f, 0.14144833f, 0.09914138f, 
    0.07371174f, -0.32717389f, 0.15726642f, 0.31515226f, -0.03916426f, 0.02477017f, -0.00347127f, -0.01866974f, 
    0.19556192f, 0.29709059f, 0.00594301f, 0.13757582f, -0.09102424f, -0.32754013f, -0.13110504f, 0.16528377f, 
    -0.18789378f, -0.01460630f, -0.18941359f, 0.26588374f, -0.01747829f, 0.05150734f, -0.05332319f, -0.22275016f, 
    -0.27942592f, -0.00760784f, 0.14175729f, -0.52555299f, 0.09727164f, 0.01558133f, 0.04504519f, -0.04834418f, 
    -0.05313391f, -0.34918267f, -0.07206506f, -0.41620764f, -0.46720785f, -0.22711475f, -0.24199192f, 0.31698135f, 
    -0.09824799f, -0.02457945f, -0.08477659f, 0.01604725f, -0.04292947f, 0.09429508f, 0.04173421f, 0.18710643f, 
    -0.20683488f, 0.26614609f, 0.14597481f, 0.06126578f, -0.19700341f, 0.02711560f, 0.09985159f, 0.08206618f, 
    0.26793721f, 0.17790933f, 0.38490999f, 0.05853706f, -0.27651346f, 0.25770357f, -0.23475929f, 0.28644499f, 
    -0.25163105f, -0.08438216f, 0.40869844f, -0.04538402f, 0.10627998f, 0.02123464f, 0.22091660f, 0.07922212f, 
    0.26113459f, 0.66273701f, 0.17212501f, 0.16853464f, 0.10598495f, -0.10244265f, -0.03786261f, 0.15693630f, 
    -0.34374395f, 0.32334849f, -0.07529658f, -0.08885022f, -0.10535267f, -1.05824006f, 0.40657571f, 0.02130614f, 
    -0.11429083f, 0.41475582f, -0.22577557f, 0.04577477f, -0.00356862f, -0.07729033f, 0.25366259f, 0.23254897f, 
    -0.60044163f, -0.57536381f, -0.89153486f, -0.10372619f, -0.10999672f, 0.10947225f, 0.04277191f, -0.26936892f, 
    -0.05941522f, 0.09943871f, -0.22359063f, 0.14919171f, -0.10679565f, -0.36523435f, -0.47706991f, 0.06802189f, 
    -0.10925856f, -0.14669667f, 0.09918863f, -0.33779338f, -0.27687135f, 0.34228998f, -0.26586068f, 0.18814114f, 
    -0.16169180f, -0.23425169f, 0.02947250f, -0.36076823f, 0.07506642f, -0.35175654f, -0.17951332f, 0.23026419f, 
    0.09115086f, 0.16923434f, 0.12275432f, 0.25840691f, -0.32818246f, 0.38765728f, -0.49263054f, 0.23996955f, 
    0.01317776f, -0.38098776f, 0.15168154f, 0.26794070f, -0.09498443f, 0.08653522f, 0.31993273f, -0.11571619f, 
    0.66351718f, -0.14415158f, 0.54859716f, -0.21456683f, 0.19828883f, 0.34309429f, -0.23217918f, 0.17297018f, 
    0.07349782f, -0.04404953f, 0.13949086f, 0.16371518f, 0.34132749f, -0.08159757f, -0.13388963f, -0.66285115f, 
    -0.03989385f, 0.10697220f, 0.45312592f, -0.16539809f, 0.03017702f, 0.16378641f, 0.14895503f, -0.10498201f, 
    -0.37710500f, -0.27401948f, 0.55187660f, 0.16123731f, -0.14428793f, 0.11169697f, -0.00478620f, 0.01721780f, 
    -0.12648994f, 0.14610530f, -0.03393869f, 0.04128447f, -0.43065450f, 0.02939886f, -0.49928802f, 1.23273504f, 
    -0.16480137f, 0.16639484f, -0.02590020f, 0.56232321f, -0.68166709f, -0.10980299f, 0.08610591f, 0.01343497f, 
    -0.34441787f, 0.53995955f, -0.15815853f, -0.28491822f, -0.00966955f, 0.15268561f, -0.26574638f, 0.04922274f, 
    -0.26686105f, 0.00711431f, -0.25262710f, -0.31768233f, 0.25327566f, -0.75839460f, 0.74095529f, -0.27862442f, 
    -0.07366856f, -0.04521750f, -0.25983256f, 0.14487128f, 0.04710970f, 0.11629982f, 0.25423071f, 0.21173522f, 
    -0.61632812f, -0.01295919f, -0.44617468f, -0.18157618f, 0.09189790f, -0.15529108f, -0.20513861f, -0.14755906f, 
    -0.14269125f, 0.20953764f, 0.16312994f, 0.03651624f, -0.31326956f, -0.45786184f, -0.22524595f, 0.07287108f, 
    -0.43790206f, -0.12326381f, -0.00501547f, -0.13521422f, 0.17957161f, 0.07848897f, 0.00638588f, -0.10521870f, 
    -0.18730827f, 0.03279812f, -0.15345344f, -0.02039059f, 0.24888122f, 0.01624440f, -0.08407333f, 0.01605009f, 
    0.11256479f, -0.33041877f, -0.24966247f, -0.23095979f, 0.62477589f, -0.00078432f, 0.57191300f, -0.10687661f, 
    -0.03328620f, 0.11267700f, 0.07609277f, 0.15026011f, 0.05697830f, 0.16909067f, -0.27612787f, -0.15680930f, 
    -0.46176121f, -0.45014089f, 0.10278150f, 0.51454473f, 0.05406735f, -0.09313807f, 0.01190118f, -0.08659795f, 
    -0.20877573f, -0.11281554f, 0.01488932f, -0.09453718f, -0.04385788f, -0.30667147f, 0.42586470f, -0.34839782f, 
    -0.12237934f, -0.47044158f, 0.03611943f, -0.16981404f, 0.09322844f, -0.08380856f, -0.16833460f, -0.19126493f, 
    -0.55948615f, 0.23856881f, -0.54176825f, 0.30621204f, -0.09540991f, -0.01411163f, 0.14065564f, -0.03868427f, 
    0.07154212f, -0.11899214f, 0.01077807f, -0.26430279f, 0.78877926f, 0.21927594f, 0.40647846f, 0.33496502f, 
    0.26069722f, 0.19178815f, -0.11563426f, -0.21494563f, 0.01805029f, -0.32509935f, -0.02700215f, -0.13766681f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.36799726f, 0.23604728f, 0.29307035f, -0.18105781f, -0.28829995f, 0.19194259f, 0.05929049f, -0.20317887f, 
    0.14442946f, 0.02912474f, -0.03641916f, 0.04143509f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
