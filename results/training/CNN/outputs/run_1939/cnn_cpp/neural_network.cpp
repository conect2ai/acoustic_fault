#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.76201451f, 0.21910214f, 0.64290297f, -0.77861571f, -0.18323082f, -0.38948175f, -0.09432108f, 0.64920866f, 
    0.41419390f, 0.03418887f, -0.39383522f, -0.17285757f, -0.17701325f, 0.04298358f, 0.04532480f, 0.39208212f, 
    -0.31828257f, -0.02950027f, 0.07848814f, -0.03199600f, -0.10458897f, 0.07823924f, -0.12082214f, -0.02858871f, 
    -0.19237365f, 0.23591627f, -0.68911457f, -0.20716438f, 0.36156410f, 0.30974013f, 0.25124544f, 0.19591303f, 
    -0.35304081f, -0.32089534f, -0.29831651f, -0.07956907f, 0.01577681f, 0.22403748f, 0.05661485f, 0.11604615f, 
    -0.30351722f, -0.23603079f, 0.10815113f, 0.23834716f, 0.23489618f, 0.24926090f, -0.13003336f, -0.39238065f, 
    -0.00498391f, 0.33958957f, -0.48285842f, -0.16352060f, -0.16823614f, 0.13232556f, 0.45940042f, 0.37509468f, 
    -0.67139602f, -0.54338968f, -0.32409877f, -0.20181732f, -0.35093006f, 0.06902719f, 0.12603615f, -0.30906060f, 
    -0.04346563f, 0.04474148f, -0.33884439f, -0.04802287f, -0.08341897f, -0.02794593f, 0.16423389f, -0.24156478f, 
    -0.19408359f, -0.00688252f, 0.12468998f, -0.56211793f, 0.09627006f, 0.14417279f, 0.40229785f, 0.50496280f, 
    0.11244838f, -0.09578833f, 0.37047762f, 0.30995488f, 0.17579754f, 0.32219094f, 0.07558100f, 0.08457522f, 
    -0.33977526f, -0.13319248f, -0.06040632f, -0.05320679f, 0.17528076f, 0.02948818f, -0.11785951f, -0.21521866f, 
    -0.21116596f, -0.01132996f, 0.21967937f, 0.10465866f, 0.02338059f, -0.17800941f, -0.79054087f, -0.62707496f, 
    0.00851939f, 0.24751699f, 0.22492580f, 0.44589603f, 0.11009371f, -0.29290065f, -0.18152691f, -0.14632773f, 
    0.08113983f, 0.04780087f, -0.31905827f, -0.04200316f, 0.04094633f, 0.18086565f, -0.13132086f, 0.37693882f, 
    0.10468206f, -0.14998583f, -0.32564849f, 0.10273213f, 0.13813022f, -0.04065046f, 0.27282631f, 0.19775534f, 
    0.32042018f, -0.56651103f, -0.26167285f, -0.11367097f, -0.00825034f, -0.10277062f, -0.15856887f, 0.06931634f, 
    0.11873177f, -0.23046938f, 0.13364659f, -0.06838220f, -0.02872355f, 0.05704762f, 0.12575920f, 0.06635374f, 
    -0.11043766f, 0.01579650f, -0.08569538f, -0.08206496f, 0.34547219f, 0.01188733f, 0.27093631f, -0.01435113f, 
    0.24786279f, 0.10160410f, 0.13207436f, 0.01604714f, -0.48941192f, -0.15453696f, 0.59934241f, -0.46199831f, 
    0.06569558f, -0.10349272f, -0.04870791f, -0.11392993f, -0.21874113f, -0.06395597f, -0.14653163f, 0.25542849f, 
    0.18981622f, -0.07289737f, 0.14461040f, 0.00181408f, -0.18243772f, 0.12711053f, 0.17852047f, -0.13433598f, 
    -0.42880821f, -0.10330783f, 0.44076991f, 0.37320915f, -0.19105485f, -0.03506387f, -0.36861092f, -0.35818049f, 
    -0.26280317f, -0.26909184f, -0.29415956f, -0.03219254f, -0.12671210f, -0.23667677f, -0.06072773f, 0.04905206f, 
    0.25764146f, 0.28510088f, 0.01022864f, 0.04889676f, 0.11645215f, 0.13038376f, -0.14333488f, -0.03923457f, 
    0.96846849f, -0.24253774f, -0.40277353f, -0.56414640f, -0.60680312f, 0.24440709f, 0.11532316f, 0.26554343f, 
    0.19952226f, 0.13495392f, -0.05698718f, -0.04155396f, 0.06735187f, 0.14826573f, -0.12584125f, -0.30845872f, 
    0.19202109f, -0.15783854f, -0.20552124f, 0.17830040f, 0.28856996f, -0.02088607f, -0.13863994f, 0.11251805f, 
    0.06547486f, 0.34105128f, 0.16260155f, -0.51376891f, -0.26664415f, -0.02815090f, 0.09637374f, -0.45581537f, 
    -0.03185949f, -0.28260493f, -0.28598404f, -0.01321516f, -0.13451749f, -0.00984581f, -0.06415416f, -0.00313716f, 
    0.24353462f, -0.34165648f, -0.14805910f, 0.20776486f, -0.38318866f, 0.16412328f, -0.02646958f, 0.14500099f, 
    0.20659994f, 0.24630602f, 0.64176428f, -0.19605727f, -0.28529021f, -0.26321578f, 0.06674004f, -0.05229348f, 
    -0.12698129f, 0.14670549f, 0.45156118f, 0.22902894f, 0.22511809f, -0.10868287f, -0.04533780f, -0.17483622f, 
    0.14115335f, -0.10400320f, 0.19037504f, -0.05818127f, -0.05977322f, -0.11354505f, 0.24622668f, -0.09249471f, 
    0.19838369f, -0.06324438f, -0.18052167f, -0.71804994f, -0.24216762f, 0.27509898f, 0.14487934f, 0.31014144f, 
    0.38094705f, 0.48400018f, -0.01966244f, 0.07332287f, 0.30635652f, 0.09789226f, 0.05241631f, 0.05596338f, 
    -0.33835012f, -0.49175799f, 0.01298778f, 0.09588159f, -0.17519179f, 0.07841252f, -0.08306563f, 0.14702281f, 
    -0.20938089f, 0.21435469f, 0.08937153f, -0.14262961f, 0.29917797f, -0.01249183f, -0.19979446f, 0.11342022f, 
    0.43782702f, -0.30275252f, 0.05067144f, 0.28578928f, -0.11324877f, -0.40433204f, -0.07408392f, -0.14142559f, 
    -0.31504387f, -0.01501446f, 0.25311512f, -0.04067365f, 0.38161305f, 0.14097717f, -0.01030814f, 0.10937174f, 
    -0.18830121f, 0.10296379f, -0.16646862f, -0.34499815f, -0.26673630f, -0.29976636f, 0.20564866f, 0.17922834f, 
    -0.31767040f, -0.05862929f, 0.15306237f, 0.01825392f, 0.14487216f, -0.42671877f, -0.10272867f, -0.09284148f, 
    0.33340403f, -0.26361403f, 0.09100167f, 0.08105590f, 0.04639995f, 0.01007520f, 0.06358919f, -0.12964056f, 
    -0.09866874f, -0.04717576f, 0.05031441f, 0.04387468f, 0.01565134f, 0.35495281f, 0.55278969f, 0.19393179f, 
    -0.14078215f, -0.18755610f, -0.16503999f, 0.09129661f, -0.07446748f, -0.04261248f, -0.16522907f, 0.19362424f, 
    -0.06864366f, 0.01875919f, -0.27680731f, 0.10546873f, 0.30357790f, -0.17893255f, 0.17831703f, 0.09297457f, 
    -0.11568484f, 0.04378303f, 0.09203378f, -0.04978963f, 0.22997494f, 0.07647030f, -0.05613105f, -1.00220430f, 
    -0.14790423f, 0.19078280f, 0.18127300f, 0.26984042f, 0.18211314f, -0.14492154f, 0.47154608f, 0.08983802f, 
    0.07913294f, -0.40850535f, -0.15519454f, -0.32688007f, 0.63036734f, -0.08023213f, -0.02984483f, -0.03761045f, 
    -0.28309742f, -0.19263811f, 0.20884228f, -0.08198769f, 0.22494382f, 0.31358999f, 0.18575777f, -0.12002442f, 
    -0.36896846f, -0.25388473f, 0.09282345f, -0.18751256f, -0.12580428f, 0.25026897f, 0.14078000f, -0.16588505f, 
    0.30177197f, 0.38042757f, 0.02185418f, 0.25154236f, -0.19628245f, 0.06680291f, -0.26692918f, -0.13709240f, 
    -0.16835758f, -0.21789078f, -0.28983894f, 0.25303543f, -0.20967998f, 0.15131178f, 0.12276932f, 0.27536637f, 
    0.25110483f, -0.35654593f, -0.33547866f, 0.08603683f, 0.34193024f, -0.37243271f, -0.00975104f, 0.19698286f, 
    -0.36080655f, -0.21713465f, -0.16974461f, 0.11048000f, 0.36581433f, -0.23832414f, -0.24173816f, -0.21560743f, 
    -0.16111405f, 0.01152490f, 0.28350297f, -0.18462740f, -0.11246191f, -0.16291463f, -0.27045515f, -0.19130403f, 
    0.14994447f, -0.18060662f, -0.87852150f, -0.41044340f, -0.67212600f, 0.55599374f, 0.42241126f, -0.12793492f, 
    -0.07528945f, 0.05399998f, -0.04607375f, 0.40151116f, 0.23196682f, -0.08383070f, -0.29421470f, 0.20093641f, 
    0.35041630f, -0.06700900f, -0.30062264f, 0.27935860f, 0.23030709f, -0.10088053f, 0.11429034f, -0.19761680f, 
    0.20790449f, -0.05811505f, -0.20195258f, -0.33955789f, -0.44750550f, 0.09360488f, 0.16622815f, 0.29172707f, 
    0.08311365f, 0.30265358f, -0.04205254f, -0.31131703f, -0.03506525f, -0.01044669f, 0.47215071f, -0.65206373f, 
    0.11994860f, -0.20209965f, 0.24338320f, 0.05819545f, -0.22849359f, 0.16461433f, -0.25094113f, 0.09990343f, 
    -0.06454112f, -0.10878751f, 0.10331511f, -0.08871546f, 0.02546557f, 0.46972710f, 0.50653809f, -0.46815655f, 
    -0.29500806f, -0.52437329f, -0.41404027f, -0.00411794f, -0.20839594f, 0.23125987f, 0.05573146f, -0.29096842f, 
    -0.27215126f, -0.07472142f, 0.28796995f, -0.18975298f, 0.31391591f, 0.05606804f, 0.10407268f, 0.07643612f, 
    -0.39465651f, 0.26990509f, 0.22402531f, -0.28283975f, -0.18204679f, -0.16547075f, 0.62469876f, -0.32378715f, 
    0.35026407f, -0.17078036f, 0.14265028f, -0.37649205f, -0.00506915f, 0.32019103f, -0.16206998f, 0.09913889f, 
    -0.02568464f, -0.01140800f, -0.25392655f, 0.15782121f, -0.02266723f, 0.00171709f, -0.00024102f, -0.13609737f, 
    -0.03609296f, -0.13567702f, 0.01889310f, -0.00476774f, -0.08710611f, -0.29739043f, 0.35689136f, -0.32006127f, 
    -0.18135805f, -0.42456511f, -0.41221201f, 0.09673411f, -0.34749410f, 0.02401791f, 0.00269672f, 0.12699099f, 
    0.09963322f, -0.00334812f, 0.23418032f, 0.41502780f, -0.21178687f, 0.03435671f, -0.17902090f, 0.04027684f, 
    0.17707174f, -0.19337392f, -0.18126453f, -0.25279653f, 0.03394811f, -0.08347049f, -0.23899139f, 0.28887716f, 
    0.94134027f, 0.02976141f, -0.39163795f, -0.18228032f, -0.57402891f, -0.40480283f, 0.31991032f, 0.29695216f, 
    -0.16955465f, -0.29574439f, -0.00130108f, 0.40862316f, 0.17857884f, -0.25375769f, -0.01317465f, 0.19801052f, 
    0.34014168f, -0.36511448f, -0.18456988f, 0.00459962f, 0.01418409f, 0.07558171f, 0.00281056f, -0.15420340f, 
    0.45283851f, -0.11589137f, -0.29294351f, -0.02524542f, -0.10295411f, 0.42019254f, 0.01779937f, -0.14789392f, 
    -0.23593411f, 0.44084838f, -0.25246924f, 0.05661972f, -0.28286368f, 0.09933750f, 0.40162957f, 0.01051055f, 
    -0.09740445f, 0.02294323f, 0.10829421f, -0.20517331f, 0.14156301f, 0.38292328f, -0.04666683f, -0.11493760f, 
    -0.37317064f, -0.28019258f, -0.23540103f, -0.40268245f, 0.01571350f, 0.24569111f, 0.00312740f, 0.62304366f, 
    -0.16856474f, -0.07794227f, -0.15325612f, -0.05269698f, -0.02415790f, 0.13784748f, -0.36434382f, -0.28321925f, 
    0.11437410f, 0.31195876f, 0.11708133f, 0.06190404f, 0.19582960f, 0.01676534f, 0.16218297f, 0.11692431f, 
    -0.18814440f, -0.06083534f, 0.18728577f, -0.35380003f, -0.52886266f, -0.59920800f, -0.37079883f, 0.49174142f, 
    0.23146851f, 0.44692138f, -0.04171989f, -0.09323999f, 0.08408055f, 0.29582772f, 0.18573059f, -0.18059258f, 
    0.03008289f, -0.26216173f, -0.12709181f, -0.23862201f, -0.04913059f, -0.23885442f, 0.00178321f, -0.15932606f, 
    0.32410040f, 0.41191804f, -0.01009006f, 0.12688737f, -0.36226812f, -0.48548689f, 0.01342398f, -0.16802688f, 
    -0.12053031f, 0.01668069f, 0.07628514f, -0.24060854f, 0.22435723f, -0.25909212f, -0.38356072f, -0.13166814f, 
    -0.34365591f, 0.08491199f, 0.12076584f, -0.04356246f, -0.07261027f, 0.08243707f, 0.01207890f, -0.30726895f, 
    -0.18481861f, -0.26165330f, -0.24408963f, -0.22674738f, 0.49142402f, 0.22149310f, -0.33818209f, -0.19934218f, 
    -0.59340429f, 0.23623285f, 0.11543027f, 0.17827472f, -0.09949370f, -0.12475162f, 0.33674446f, -0.09421052f, 
    -0.19088145f, -0.11313320f, 0.14151113f, 0.07344130f, -0.10093148f, 0.14170098f, -0.01363680f, -0.27163318f, 
    -0.16646828f, 0.06282780f, -0.15062180f, 0.05353136f, 0.07115783f, 0.31936824f, 0.09335280f, -0.01100516f, 
    0.04228689f, 0.11609078f, 0.21202011f, -0.21026699f, -0.07289071f, 0.12892322f, -0.18111178f, 0.48462561f, 
    -0.40289223f, -0.30360603f, -0.05861336f, -0.00487490f, 0.02220763f, 0.28401658f, 0.14569345f, -0.15252122f, 
    0.02168364f, 0.17225535f, -0.03489801f, -0.06318302f, -0.22030993f, -0.27274644f, 0.55477554f, -0.62523341f, 
    -0.45784494f, -0.08191784f, -0.22968768f, 0.17844036f, 0.16652292f, 0.72603363f, -0.35036290f, -0.36900949f, 
    -0.22297110f, -0.16742198f, 0.05415330f, -0.04431925f, 0.19966802f, 0.12995732f, -0.25127715f, 0.24121679f, 
    -0.09777458f, -0.26873994f, -0.02210885f, -0.10527539f, -0.23183402f, 0.03167963f, -0.03089868f, 0.31924608f, 
    0.28745368f, 0.14752714f, 0.13213864f, -0.01743237f, 0.03702383f, -0.52334589f, -0.21108067f, 0.25649911f, 
    0.06703558f, -0.15546474f, -0.27729300f, 0.15828209f, -0.04115794f, -0.10276783f, 0.19980809f, 0.35600996f, 
    0.00170233f, 0.08864619f, -0.20330271f, -0.17262815f, -0.11393763f, -0.15872180f, -0.10393891f, -0.32890293f, 
    -0.60871565f, 0.06150670f, 0.44905204f, 0.08557343f, 0.20579906f, -0.11279417f, -0.19253595f, -0.24148695f, 
    -0.04027553f, 0.12898672f, -0.34101260f, -0.10623067f, 0.30066702f, -0.43803254f, -0.13945079f, 0.43555394f, 
    0.35436222f, -0.25114861f, -0.23631582f, -0.02245752f, -0.15307134f, 0.00257128f, -0.08380354f, -0.10909249f, 
    0.39170128f, 0.64296943f, 0.55265588f, 0.02703061f, -0.56161922f, 0.07355369f, -0.04049562f, -0.15998434f, 
    0.16426265f, -0.51243490f, -0.18365958f, -0.06674304f, -0.04829692f, 0.24801385f, -0.10701561f, -0.26584819f, 
    0.17250696f, 0.23031175f, -0.31911317f, 0.17272955f, -0.03997860f, -0.22749183f, 0.05327653f, -0.16898918f, 
    0.19844833f, 0.17160212f, 0.15902786f, -0.26464278f, -0.06709589f, 0.10880215f, -0.67947817f, -0.00630670f, 
    -0.26684448f, -0.13883194f, -0.30388454f, -0.52868843f, 0.40534529f, -0.10731936f, -0.18899952f, -0.13196085f, 
    -0.28515294f, -0.12066270f, -0.11789788f, -0.04462183f, -0.27438211f, -0.27464500f, -0.11066998f, -0.02769019f, 
    -0.22685234f, 0.23635001f, 0.08448655f, -0.61884183f, -0.60411000f, -0.64731079f, -0.30765501f, -0.33911443f, 
    0.55283558f, 0.02721472f, 0.35839853f, 0.35784718f, 0.53275484f, 0.27652016f, -0.08704326f, -0.01110150f, 
    0.21646959f, 0.13393784f, -0.18497469f, -0.04264271f, 0.10411826f, 0.12297603f, 0.02003787f, -0.06730767f, 
    -0.10483260f, 0.05823012f, 0.05864709f, -0.11594456f, -0.64519620f, -0.26654416f, 0.46318454f, -0.29076004f, 
    -0.33070806f, 0.11368744f, -0.16851731f, 0.36560899f, -0.29995105f, 0.27494511f, 0.24003796f, 0.04890306f, 
    0.10747092f, -0.07422603f, -0.01212580f, -0.25287959f, -0.03538428f, -0.23390324f, 0.26273981f, 0.07072493f, 
    0.02486221f, 0.19951858f, 0.21210454f, -0.17400476f, -0.05826277f, 0.65893334f, -0.00596434f, -0.03550684f, 
    -0.12539601f, -0.17642692f, 0.09608579f, 0.03045439f, 0.24020053f, 0.29096496f, -0.01787736f, -0.36031604f, 
    0.01109858f, -0.16321301f, -0.09419881f, -0.15247869f, 0.18067588f, -0.10056619f, -0.13881664f, -0.12566367f, 
    -0.03430900f, -0.11620183f, -0.24621998f, -0.24273971f, -0.41361710f, -0.45069757f, 0.22189003f, -0.12306770f, 
    -0.69517612f, -0.34620574f, 0.16981365f, -0.48711500f, -0.27416408f, -0.34934580f, -0.23440203f, -0.16838644f, 
    0.38815495f, -0.02724044f, 0.55286944f, -0.30704987f, -0.38297316f, 0.14680350f, 0.19089022f, -0.13337693f, 
    0.08536008f, 0.19186351f, 0.25058267f, -0.04932789f, 0.10062152f, -0.16902868f, -0.07709173f, 0.54438138f, 
    0.58204365f, 0.32912576f, -0.03868524f, -0.03196012f, -0.30405116f, -0.34330562f, -0.17810392f, -0.36526427f, 
    -0.45081580f, 0.06633534f, 0.36442527f, -0.10045601f, -0.17643560f, 0.00486405f, -0.21027365f, 0.13617769f, 
    -0.18999699f, 0.10721279f, 0.09973142f, -0.06889374f, 0.25447664f, 0.16412145f, -0.10617201f, -0.08081017f, 
    0.59831971f, 0.25400853f, 0.15639423f, -0.20327924f, 0.06814702f, -0.66379625f, -0.02856515f, -0.37287799f, 
    -0.29325470f, -0.49651018f, 0.04941573f, 0.21175662f, 0.20851527f, -0.19082417f, 0.36680672f, 0.09985214f, 
    -0.29221979f, -0.07299434f, 0.24952516f, 0.15850499f, 0.23312350f, -0.03242958f, -0.12606059f, -0.25819379f, 
    0.00400277f, 0.18575352f, -0.34577867f, 0.10524815f, 0.67607719f, -0.59406590f, 0.09371766f, 0.10817280f, 
    -0.37249735f, -0.28722981f, -0.16447408f, -0.14469743f, 0.11870033f, -0.08494952f, 0.06838508f, 0.39733225f, 
    -0.39306331f, 0.29069537f, -0.05850513f, 0.01379902f, -0.12995189f, -0.10453543f, -0.14612141f, 0.26381084f, 
    0.21014982f, -0.28455430f, -0.79254872f, -0.40961596f, -0.16747320f, -0.08782319f, -0.08875971f, 0.00415231f, 
    0.07063798f, 0.28881505f, 0.33716938f, 0.28366929f, 0.09466153f, 0.09777302f, 0.25797686f, 0.01679956f, 
    0.00258123f, 0.09595462f, 0.10066307f, -0.29476023f, -0.29734907f, -0.11055762f, -0.00159776f, 0.03060552f, 
    0.08402964f, 0.01007378f, -0.01336274f, 0.45459735f, 0.19511853f, 0.10414165f, 0.15842089f, 0.14828423f, 
    0.01047649f, 0.21387109f, 0.02783042f, 0.03921684f, 0.05235944f, 0.00759249f, 0.20002915f, -0.00076728f, 
    -0.06196190f, -0.09051216f, 0.13741025f, 0.06248835f, -0.11730985f, -0.16737524f, 0.10430226f, 0.11181354f, 
    -0.11040324f, 0.16119453f, 0.11694318f, -0.20799984f, -0.27955088f, -0.32383063f, -0.44532096f, 0.34481555f, 
    -0.26193503f, 0.39024299f, 0.13980351f, 0.28733870f, -0.15152578f, 0.02004737f, -0.28644049f, -0.02901116f, 
    -0.26093656f, -0.02526364f, -0.25319138f, 0.04075276f, 0.39784202f, 0.06774074f, -0.31119156f, 0.20748855f, 
    -0.05012342f, -0.17782353f, 0.03847679f, -0.10526370f, -0.01973510f, 0.39291498f, 0.29760706f, 0.39892536f, 
    0.21133648f, 0.11925033f, -0.27942795f, 0.03021901f, -0.12809871f, -0.12757690f, -0.03704122f, 0.13570164f, 
    -0.09051129f, 0.26744977f, -0.22131665f, -0.01875846f, 0.10534995f, 0.08628578f, -0.14988354f, 0.03864795f, 
    0.07341500f, -0.21287116f, 0.29098168f, -0.10938279f, -0.12613903f, 0.03694467f, 0.13926986f, -0.42331409f, 
    -0.16814779f, 0.17892511f, 0.48741201f, 0.27942291f, -0.27394301f, -0.26427305f, 0.13381462f, 0.30578026f, 
    -0.05791475f, 0.14305770f, -0.13104855f, -0.05743351f, 0.43528217f, -0.27718362f, 0.00677640f, 0.12530072f, 
    -0.18737289f, -0.10260619f, 0.13665581f, -0.22028638f, 0.02784928f, -0.03205471f, 0.01066161f, 0.02042585f, 
    0.07585268f, 0.12756635f, 0.00872906f, 0.15046637f, -0.04058461f, -0.30902308f, 0.03727004f, -0.07515794f, 
    0.20177235f, 0.00313150f, -0.26882637f, 0.65024835f, -0.59420043f, 0.20442301f, -0.06204277f, -0.10623787f, 
    0.06934322f, -0.07140756f, 0.04499822f, 0.04024797f, -0.07400502f, -0.03164319f, 0.05903572f, 0.07899629f, 
    -0.23191281f, -0.24273777f, -0.05134668f, 0.22776169f, 0.03392056f, -0.24735592f, -0.32992193f, -0.42367747f, 
    -0.26374224f, -0.24735387f, 0.34998780f, 0.10802960f, -0.03900302f, 0.38925856f, 0.29516828f, -0.30748698f, 
    0.01422053f, -0.14521313f, 0.04936558f, -0.03807136f, -0.19546816f, -0.15852278f, -0.03541240f, -0.18280879f, 
    -0.38511324f, -0.49208969f, -0.17782721f, -0.21036698f, -0.22696798f, 0.07234228f, -0.04728235f, 0.11753350f, 
    -0.37763441f, -0.23943216f, -0.16023733f, 0.17680620f, -0.02991630f, -0.05124219f, -0.13540809f, 0.07558734f, 
    -0.12778382f, -0.02717590f, -0.13280420f, 0.20260955f, -0.02547926f, -0.01002085f, -0.11973013f, -0.14055768f, 
    -0.20327066f, -0.16893819f, 0.25653112f, 0.06467727f, 0.16157807f, 0.06429361f, 0.06698999f, 0.03893282f, 
    0.13623214f, -0.09938176f, -0.27417612f, 0.15139335f, -0.23489170f, -0.25184697f, 0.20563103f, 0.02538069f, 
    -0.12121210f, -0.26732674f, 0.13727917f, 0.13911864f, -0.10530028f, -0.14191177f, 0.12486070f, -0.03625912f, 
    -0.15899353f, 0.19995208f, 0.20791768f, -0.11754782f, -0.46611714f, -0.26247516f, 0.34343958f, 0.01179712f, 
    -0.28155726f, 0.09654471f, -0.10789445f, 0.15805835f, 0.14812070f, -0.23300403f, -0.16690625f, 0.06291885f, 
    0.54958749f, -0.07873557f, 0.27516428f, -0.08651666f, -0.34990716f, -0.01608471f, -0.35674617f, -0.00768573f, 
    -0.16928518f, 0.26759353f, 0.19666074f, -0.12101912f, -0.77448505f, -0.22704633f, -0.35676593f, -0.04261054f, 
    0.25082192f, 0.40098327f, -0.13142738f, -0.29699987f, -0.14513838f, -0.20857829f, 0.28273594f, -0.12108865f, 
    -0.06761468f, -0.22483332f, -0.12528972f, 0.07695841f, -0.19235346f, 0.03750327f, -0.01559579f, -0.07072445f, 
    0.18218978f, -0.13229352f, -0.29068449f, 0.06273376f, -0.39869678f, 0.53657454f, 0.37566894f, 0.35378721f, 
    -0.09138998f, -0.89405417f, -0.51094568f, 0.02858221f, 0.24493077f, -0.11405826f, -0.10896232f, 0.20930190f, 
    0.19781446f, 0.09261856f, -0.19835715f, -0.19379131f, 0.00116144f, -0.27307311f, -0.21434760f, 0.22257286f, 
    -0.01212829f, 0.06596702f, 0.19417986f, -0.17157371f, -0.13541940f, 0.42707700f, 0.00978377f, 0.09833129f, 
    -0.11277065f, 0.23256606f, -0.10887036f, 0.27380544f, 0.03185237f, 0.14879416f, 0.28162038f, 0.00726860f, 
    0.13414197f, 0.10824456f, -0.02847791f, -0.09816569f, -0.16666718f, 0.00772859f, 0.13632075f, 0.07496367f, 
    -0.13448375f, -0.07473067f, 0.06084950f, -0.12789041f, 0.17613450f, 0.18828644f, 0.15478319f, 0.61228138f, 
    -1.01334870f, -0.26612872f, 0.63473588f, 0.20004703f, 0.68128496f, 0.54251558f, -0.13719022f, -0.46860528f, 
    -0.29877785f, -0.17903265f, -0.10295091f, -0.05185089f, -0.12536329f, -0.03376807f, 0.15358011f, -0.16164494f, 
    0.06641767f, 0.00623542f, -0.27045095f, -0.01408871f, 0.16042458f, 0.06585027f, 0.08999822f, -0.13672215f, 
    -0.34693751f, -0.65848851f, 0.09237581f, 0.38849780f, 0.71920806f, 0.45906326f, -0.08297300f, -0.14772674f, 
    -0.21835802f, 0.32552192f, 0.29607511f, -0.22780004f, 0.19463439f, -0.29366511f, -0.14913192f, 0.01586461f, 
    -0.06657527f, -0.06788500f, 0.05523935f, -0.10724875f, 0.15400533f, -0.22398862f, 0.00419001f, 0.02632111f, 
    -0.01563311f, -0.44991085f, -0.29532847f, -0.39368802f, -0.07706877f, 0.04998078f, -0.07822046f, -0.34329948f, 
    -0.12812935f, 0.05997850f, -0.24014241f, -0.02804505f, 0.04236503f, -0.10625229f, 0.05652823f, -0.15093128f, 
    0.06387818f, -0.13972120f, 0.09220691f, -0.05219403f, -0.41795355f, 0.13273688f, 0.49421808f, 0.16349603f, 
    0.04396507f, 0.32219690f, -0.40745515f, -0.12307910f, -0.35382050f, -0.33420688f, -0.25677380f, 0.02592597f, 
    0.08268693f, -0.18159673f, -0.17029573f, 0.04622952f, 0.02802154f, -0.12982422f, -0.26065072f, -0.07609845f, 
    0.22992906f, 0.14665096f, 0.05324411f, -0.28601035f, 0.06311402f, -0.38885504f, -0.11326645f, -0.31366473f, 
    0.16501105f, 0.11634564f, 0.27840245f, 0.35013503f, -0.45697367f, -0.10481703f, 0.16667961f, -0.22524905f, 
    0.36399868f, -0.06976586f, 0.01680224f, 0.27108854f, 0.12573706f, -0.01943114f, 0.41921234f, -0.35645545f, 
    -0.18612045f, -0.00140075f, -0.54090041f, -0.04757952f, 0.06983659f, 0.23452851f, 0.02948422f, 0.13724051f, 
    0.13286707f, -0.47326726f, 0.22688861f, 0.36489099f, 0.75546139f, -0.32484177f, -0.19076884f, -0.15565103f, 
    -0.36649534f, 0.33471948f, 0.18849513f, 0.34860075f, 0.15541570f, -0.10719796f, -0.10907548f, 0.39689070f, 
    0.01765341f, 0.13976665f, -0.35194278f, -0.06573306f, -0.11630117f, 0.05483393f, -0.13796185f, 0.04688935f, 
    0.00649756f, 0.08714071f, -0.09688607f, 0.10781436f, 0.21167979f, -0.54099602f, 0.34559768f, -0.20628357f, 
    0.11475797f, 0.25465879f, -0.07880002f, -0.16759752f, -0.04126526f, -0.02337036f, 0.38241276f, 0.04807414f, 
    -0.22390211f, 0.08895779f, 0.09073351f, 0.03400591f, -0.23394164f, 0.01495555f, -0.25873172f, 0.23699757f, 
    0.08388060f, 0.24320658f, -0.24971348f, -0.16356644f, 0.30509129f, 0.03697629f, 0.34622651f, 0.14783981f, 
    0.25188327f, -0.09435207f, -0.63441193f, -0.01244308f, 0.46800035f, -0.27822104f, 0.23096487f, -0.33730668f, 
    0.40094149f, -0.29057378f, 0.03824651f, -0.13649595f, -0.18792464f, 0.05073341f, -0.25822765f, 0.31816429f, 
    0.26108205f, -0.22870480f, 0.12936841f, -0.02978663f, -0.22677252f, 0.19092573f, -0.31801978f, -0.08163495f, 
    -0.34621850f, 0.16810371f, 0.31416062f, 0.08058257f, -0.43708929f, -0.49256894f, 0.27192867f, 0.19768947f, 
    0.11540081f, 0.24588765f, -0.15224145f, -0.12236760f, -0.14422052f, 0.39462706f, -0.30692533f, -0.01021731f, 
    0.19216083f, -0.10486670f, -0.30548993f, -0.09484157f, 0.05083631f, 0.19454022f, 0.12901314f, 0.26359385f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.02169388f, -0.05305392f, -0.20399883f, -0.35991311f, -0.16235033f, -0.08796719f, -0.23431413f, -0.22508262f, 
    0.04881695f, -0.13762124f, 0.07440113f, -0.04107753f, -0.09909125f, -0.01379343f, 0.09584111f, -0.10430487f, 
    0.10313674f, -0.02945405f, 0.13623740f, 0.00062145f, 0.13006273f, 0.16965418f, -0.22254789f, 0.18207037f, 
    0.21948914f, -0.24816149f, 0.07342789f, -0.36956114f, 0.22019689f, -0.21225815f, 0.26135489f, 0.04759142f, 
    0.02519666f, 0.15400513f, -0.29830724f, 0.09396149f, 0.21779011f, -0.16050008f, 0.05154667f, -0.08359792f, 
    -0.09830801f, -0.06159710f, 0.04964914f, -0.17132348f, -0.20978874f, -0.25337732f, -0.13132843f, 0.15968157f, 
    -0.24314186f, -0.09710010f, -0.13544241f, 0.00859550f, -0.23486570f, 0.00393125f, -0.20482858f, 0.10762361f, 
    0.11971851f, -0.25577894f, -0.04934711f, 0.04178426f, -0.18871450f, 0.11010366f, 0.09491662f, 0.23406616f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.53354853f, 0.20015262f, -0.01458155f, -0.20392813f, 0.20604129f, -0.05701175f, -0.03406029f, -0.09066802f, 
    0.08314712f, 0.03114264f, 0.14457829f, 0.03100219f, 0.08793697f, -0.16138528f, 0.15640284f, -0.09240454f, 
    0.00554160f, -0.07114605f, 0.01284862f, 0.02794276f, 0.01553879f, -0.00948238f, -0.09553086f, 0.00849793f, 
    0.14382783f, 0.06767351f, 0.19643521f, 0.05410782f, 0.15573329f, 0.05066958f, -0.00377945f, 0.00859266f, 
    0.00396925f, -0.05549239f, -0.07218941f, -0.04383267f, -0.13799523f, -0.01132359f, 0.04482570f, 0.22106329f, 
    0.00327612f, 0.02681596f, 0.01191332f, -0.02131825f, 0.01135833f, 0.08418452f, 0.14921583f, 0.00481176f, 
    -0.22336745f, -0.01184040f, 0.02650416f, -0.13162345f, 0.04573622f, 0.03288570f, -0.01715057f, 0.12278827f, 
    -0.15452966f, -0.15408856f, -0.06231423f, 0.01112130f, -0.00036616f, 0.10609853f, -0.11010312f, 0.00333096f, 
    0.08433955f, 0.07610336f, -0.00342559f, 0.08180396f, -0.10435578f, -0.01695392f, -0.13248648f, 0.01312621f, 
    0.44855213f, -0.31798917f, 0.04163492f, 0.20103510f, 0.04015901f, 0.05237438f, 0.01093230f, 0.12904796f, 
    -0.07842913f, -0.04950880f, -0.05171108f, -0.06360886f, 0.28143561f, -0.07194979f, 0.16102007f, -0.20580761f, 
    0.06734977f, 0.02955522f, 0.13183668f, 0.12183329f, -0.00905709f, -0.02933718f, 0.02863448f, -0.10231541f, 
    0.12317106f, -0.13231550f, -0.05040636f, -0.33667874f, -0.08705076f, 0.00958905f, -0.06443651f, 0.00238315f, 
    -0.06446207f, -0.03434623f, 0.04548725f, -0.06369890f, 0.19169466f, 0.22202449f, 0.20940731f, -0.08191121f, 
    -0.01391447f, 0.02542531f, 0.06605525f, -0.06902647f, -0.19100060f, -0.02910949f, -0.13883129f, -0.05405782f, 
    0.14505196f, -0.12302390f, 0.19356020f, -0.09239216f, -0.01503389f, -0.02152265f, 0.01960312f, -0.06083744f, 
    0.03395667f, 0.05324445f, -0.00106226f, -0.05744084f, -0.01298993f, 0.04281036f, 0.01491131f, 0.32565060f, 
    -0.06927539f, 0.01068778f, 0.04562117f, 0.02280720f, 0.08926854f, -0.00529372f, 0.00461897f, 0.02605719f, 
    0.16516100f, -0.06859054f, 0.01738237f, 0.06062669f, 0.13177100f, 0.01644009f, 0.18775044f, 0.17828001f, 
    0.33234531f, 0.17447597f, 0.16563040f, 0.20480485f, -0.13120748f, 0.07312027f, -0.21376339f, -0.01513495f, 
    0.02424198f, 0.01526491f, -0.02208607f, -0.14674939f, -0.01875062f, -0.23191646f, -0.18412390f, -0.10921324f, 
    0.13613471f, -0.06075247f, -0.09011143f, -0.07918173f, -0.02416279f, 0.00743625f, 0.00135260f, 0.02016889f, 
    -0.06784684f, -0.11855473f, -0.12168963f, -0.14421238f, -0.04042557f, -0.44761804f, 0.06164912f, 0.14435305f, 
    0.02849339f, 0.10408053f, -0.02423353f, -0.11573368f, 0.09936104f, -0.07069926f, 0.22237830f, 0.00746646f, 
    -0.02244667f, -0.00044853f, -0.02810792f, 0.02951959f, 0.01462897f, -0.01539275f, -0.02989418f, -0.03334970f, 
    0.09617765f, 0.01084882f, -0.10690663f, -0.02718914f, 0.14491585f, -0.06793195f, -0.02429722f, -0.00158674f, 
    0.05177654f, -0.07752560f, 0.05057365f, -0.01475292f, 0.14345191f, 0.08438852f, -0.03435446f, 0.16484760f, 
    0.09174059f, 0.01072821f, 0.18593511f, 0.23281509f, 0.06123693f, -0.11173771f, 0.07035949f, -0.02021270f, 
    0.06481393f, 0.00437194f, 0.02411706f, 0.09133034f, -0.04835075f, -0.10522386f, -0.08862483f, 0.22779325f, 
    -0.06792264f, 0.03018217f, 0.19691765f, -0.03488386f, 0.17664535f, 0.06942400f, 0.02932703f, 0.16197771f, 
    0.13819954f, 0.33123234f, -0.05544299f, 0.10311407f, 0.03735843f, 0.12958814f, -0.00207813f, 0.15568767f, 
    -0.01894749f, 0.00119714f, 0.04869772f, -0.03032356f, 0.04630417f, 0.00472881f, 0.08219160f, -0.02777976f, 
    -0.02506820f, -0.08870924f, -0.06677521f, 0.07429262f, 0.14015882f, 0.16204405f, 0.14720772f, 0.07935368f, 
    0.03424684f, -0.11766162f, 0.16473080f, -0.03079902f, 0.01689429f, 0.11356639f, 0.10382450f, -0.20040025f, 
    0.16183391f, 0.32247081f, 0.18494391f, 0.10317710f, 0.13999154f, 0.06878065f, 0.05963560f, 0.04856526f, 
    0.10477799f, -0.01889046f, -0.04102890f, 0.07668474f, 0.04240818f, -0.01911321f, 0.03988544f, -0.06358094f, 
    0.12903242f, 0.05340958f, -0.07086477f, -0.08148003f, 0.03789118f, -0.06027356f, -0.06089434f, 0.11922583f, 
    0.09892371f, 0.00626939f, 0.14625874f, 0.01799663f, -0.11179969f, -0.17755882f, -0.17265995f, 0.11247309f, 
    0.17559080f, 0.09532125f, 0.09274545f, 0.07755539f, 0.04211316f, -0.11453363f, -0.01153721f, -0.03214265f, 
    0.10244828f, -0.03097966f, -0.11175861f, -0.21666092f, -0.04324604f, -0.16743670f, 0.00287848f, -0.11880969f, 
    -0.09475865f, 0.06601440f, -0.00473065f, -0.06013351f, 0.03076245f, -0.10429236f, -0.04531089f, -0.12982859f, 
    0.08137133f, -0.02729895f, 0.07260302f, 0.16173381f, 0.06248032f, 0.14286327f, 0.08195119f, 0.27074680f, 
    0.04371791f, 0.05593163f, 0.02845164f, -0.23785950f, -0.04058165f, -0.01515865f, -0.08101598f, 0.08159490f, 
    -0.00333168f, 0.10678831f, 0.14460386f, 0.05337049f, 0.12523082f, -0.09851337f, 0.05133761f, -0.03474999f, 
    -0.01160557f, -0.06454102f, 0.01754590f, 0.17891285f, 0.09614962f, 0.16495138f, 0.02502885f, -0.01822497f, 
    0.08049525f, -0.04636572f, -0.09882928f, -0.16976452f, 0.04686503f, -0.12837413f, 0.07875755f, -0.10271179f, 
    -0.00357910f, 0.02455433f, 0.05164429f, 0.00541012f, 0.19023860f, -0.08903145f, 0.11736847f, 0.01096314f, 
    0.04701120f, 0.01627227f, -0.01992293f, 0.05293433f, 0.17243700f, 0.20201530f, 0.19865066f, 0.18969002f, 
    -0.24539663f, 0.10375152f, -0.22704594f, -0.13753150f, 0.28434712f, 0.00526364f, -0.02980890f, 0.17908448f, 
    0.16510670f, 0.01806131f, 0.00935770f, -0.00810801f, 0.26231682f, 0.21617199f, -0.10180187f, -0.13270766f, 
    0.12639056f, -0.02750081f, 0.00168354f, 0.06798965f, -0.05721595f, -0.07490939f, 0.02185687f, 0.01057070f, 
    0.20031843f, 0.21279806f, 0.17589082f, -0.11460730f, -0.03001888f, 0.04813042f, 0.00592620f, 0.05353726f, 
    0.01857448f, -0.00815488f, 0.09870631f, 0.02375439f, 0.15154667f, -0.03771736f, 0.11032385f, -0.01344928f, 
    -0.15195636f, -0.07065809f, 0.00635306f, -0.05794510f, 0.00151073f, -0.10797443f, 0.03521486f, 0.12717897f, 
    -0.19963492f, 0.19487417f, -0.05530610f, -0.09444743f, 0.06500114f, -0.04907336f, -0.04242121f, -0.02116861f, 
    0.11286426f, 0.07060152f, -0.05524038f, -0.02023873f, 0.19178678f, -0.08310385f, -0.01346799f, -0.02787410f, 
    0.00848320f, 0.01108656f, 0.10643143f, 0.01538682f, 0.26909605f, 0.06789602f, -0.00384280f, 0.21021405f, 
    0.13113913f, 0.22959039f, 0.26944917f, -0.23591109f, -0.01027107f, -0.01949268f, -0.03186201f, -0.01756942f, 
    0.03207610f, -0.03311596f, 0.07758804f, -0.02183232f, 0.41240501f, 0.29162350f, -0.17711242f, 0.07278107f, 
    0.05405679f, -0.01873369f, 0.09905854f, 0.18741074f, -0.05761524f, -0.09512625f, -0.11895771f, -0.03194133f, 
    0.22717658f, 0.21765517f, -0.15823734f, -0.16851230f, -0.09302806f, -0.06032348f, -0.08986595f, -0.04303909f, 
    0.10437806f, 0.00243649f, -0.05498867f, 0.07151913f, 0.35962415f, -0.03046559f, 0.08253375f, -0.06184522f, 
    0.08562635f, -0.16276596f, 0.12708002f, 0.03234700f, -0.00492387f, 0.03343431f, -0.02451598f, 0.06414578f, 
    -0.02982541f, 0.11022391f, -0.04577039f, 0.24563265f, -0.06080690f, -0.06303268f, 0.03122409f, 0.04042516f, 
    0.02320269f, 0.12482217f, 0.10984888f, 0.06375009f, 0.19308741f, -0.00711769f, -0.01353756f, 0.19526626f, 
    0.01618781f, -0.05474925f, -0.01264957f, 0.01572525f, -0.02688277f, -0.13330688f, -0.00627386f, -0.07491643f, 
    0.03610606f, -0.10989869f, 0.06270069f, -0.00377901f, 0.10371968f, -0.13616042f, 0.12995788f, 0.06613189f, 
    0.15282822f, -0.01944856f, 0.01687345f, 0.06642911f, 0.10124817f, 0.05883450f, -0.10964534f, 0.01161927f, 
    0.01741800f, -0.07572542f, -0.03065932f, 0.10163946f, 0.02524095f, -0.10214908f, -0.03700418f, 0.00926228f, 
    0.17548026f, -0.25379759f, 0.15425661f, 0.13818595f, 0.04612506f, -0.03627399f, -0.05392677f, -0.04634895f, 
    0.10260765f, -0.01406024f, 0.11520424f, 0.05430355f, 0.05008608f, 0.16648641f, -0.17572284f, -0.19786033f, 
    -0.06824537f, 0.03935635f, 0.05768097f, 0.02454509f, 0.03802692f, -0.04160536f, -0.17087950f, -0.11058018f, 
    0.12417955f, -0.05270913f, 0.16116421f, 0.12459702f, 0.15412998f, -0.07427222f, -0.05111538f, -0.07613616f, 
    0.14618997f, 0.11640778f, 0.04207896f, 0.02239460f, -0.00313064f, 0.02884817f, 0.06708997f, 0.03921981f, 
    0.04276252f, 0.07441041f, -0.03376578f, 0.01829749f, 0.16290060f, 0.00489969f, 0.07627728f, 0.13964120f, 
    0.19170721f, 0.04620522f, 0.07758933f, -0.08088060f, 0.02685575f, -0.07509810f, -0.04395564f, -0.01498814f, 
    -0.07454130f, -0.13233840f, -0.05937452f, -0.16300452f, 0.18882605f, -0.26236451f, 0.02648748f, 0.25618067f, 
    0.18686792f, -0.14072944f, 0.10735655f, -0.07520930f, 0.08931287f, -0.02413701f, 0.11227487f, 0.10370885f, 
    0.06407920f, 0.01843677f, 0.23162815f, 0.04424245f, -0.03085343f, 0.15376644f, -0.00620163f, 0.03620274f, 
    0.21523641f, -0.00590226f, 0.09927314f, 0.17514019f, 0.11682061f, 0.10222100f, -0.05402739f, 0.03986660f, 
    0.00083025f, 0.03197902f, -0.05159627f, -0.01140217f, -0.05694168f, -0.02376212f, -0.17992134f, -0.10360248f, 
    -0.01825619f, -0.08865419f, 0.02393280f, 0.05602099f, -0.09777302f, -0.06750891f, -0.03963333f, 0.00011061f, 
    -0.08798870f, -0.08897906f, -0.10599449f, -0.14157830f, 0.36058050f, -0.40244076f, 0.04903352f, 0.02607043f, 
    0.02515897f, -0.10425618f, 0.05016568f, 0.08695339f, -0.04013219f, 0.04365421f, 0.14686579f, -0.08676329f, 
    0.17601155f, -0.08471387f, 0.01055176f, 0.13297214f, -0.07398979f, -0.04653500f, 0.09129383f, -0.00855856f, 
    0.05417385f, 0.17223898f, -0.03724308f, 0.02633733f, 0.13137786f, -0.03758429f, 0.26582050f, 0.10747688f, 
    0.03949675f, 0.01347150f, 0.03156113f, -0.10207951f, -0.07417655f, -0.24536897f, -0.12471187f, -0.19004887f, 
    0.08315739f, 0.16533734f, -0.00070599f, -0.05818622f, 0.06992009f, 0.08786267f, 0.00422595f, -0.12159257f, 
    -0.09348845f, -0.08350549f, -0.14412566f, -0.00125081f, 0.03700722f, -0.16784161f, 0.06292006f, -0.15532888f, 
    -0.00659315f, 0.04098541f, -0.04166416f, 0.06641307f, -0.05939943f, 0.05452450f, -0.18040311f, -0.01258572f, 
    0.21884993f, -0.09608687f, -0.12205542f, -0.11117539f, -0.15972790f, -0.06132298f, -0.13056006f, -0.04567678f, 
    -0.04126758f, 0.01470851f, -0.01368549f, -0.06634417f, -0.05599422f, -0.00095987f, 0.12975755f, 0.10961384f, 
    0.06486087f, -0.01393867f, -0.11336811f, 0.02457176f, -0.06408424f, -0.11716791f, -0.14518702f, -0.04049572f, 
    -0.02498829f, -0.21243264f, -0.23283532f, -0.27250418f, 0.01539868f, 0.12248277f, 0.23524040f, -0.00870056f, 
    0.02034944f, -0.08588082f, 0.10874549f, 0.19592805f, -0.08835448f, 0.03224598f, 0.20741405f, 0.11720114f, 
    0.07243584f, 0.09806717f, 0.05240710f, -0.08899179f, -0.09527287f, -0.10110843f, -0.23969078f, -0.21355817f, 
    0.00696295f, 0.00550916f, -0.02990263f, 0.01238033f, -0.00417480f, 0.00893935f, -0.00160245f, 0.00522073f, 
    0.02800233f, 0.02139147f, -0.04442054f, -0.04006267f, -0.03519830f, 0.01034873f, -0.03755153f, -0.00511179f, 
    -0.03588487f, 0.02330314f, -0.01264692f, -0.02977811f, 0.02377141f, 0.01723395f, 0.02867298f, -0.00906830f, 
    0.00688944f, -0.01461979f, 0.00664217f, 0.02913848f, -0.00797497f, -0.04038626f, 0.02493387f, 0.02428169f, 
    -0.00292825f, 0.00731243f, -0.00135328f, -0.01810098f, -0.02850182f, 0.01593547f, 0.02310211f, 0.01341691f, 
    -0.01270946f, -0.00514328f, -0.00492741f, 0.02667557f, -0.02550564f, -0.03197878f, -0.00205490f, 0.00605164f, 
    -0.01085087f, -0.01495715f, -0.03880871f, -0.00461606f, -0.03627788f, 0.01298433f, -0.02733145f, 0.03193674f, 
    -0.00168877f, 0.02578695f, -0.01786062f, 0.02735653f, 0.01216557f, -0.02294971f, 0.01623902f, -0.04038666f, 
    -0.02198546f, -0.00305461f, -0.02656857f, -0.01033396f, -0.01255820f, 0.01021395f, -0.00868822f, -0.03783970f, 
    0.00159620f, 0.00465068f, 0.02063658f, -0.02261679f, -0.00033027f, 0.02120845f, -0.00986522f, 0.02684329f, 
    0.02018590f, 0.01758842f, -0.03827391f, -0.00085705f, 0.00474347f, -0.03506027f, -0.02533999f, 0.02028839f, 
    -0.00283642f, -0.02092823f, -0.01974191f, 0.01377085f, -0.01463832f, -0.03046297f, -0.00283609f, -0.00314561f, 
    -0.01197278f, -0.02992311f, 0.01835506f, -0.01498085f, -0.02867543f, 0.00189086f, 0.00262088f, 0.02221029f, 
    0.02297703f, -0.02800212f, -0.03724874f, 0.00655768f, 0.02800204f, -0.02604586f, -0.01393112f, 0.01008291f, 
    0.00606306f, -0.03062068f, -0.03012767f, -0.01830473f, -0.01631078f, -0.02630764f, -0.01801606f, -0.03244564f, 
    -0.03542550f, -0.02235664f, -0.03469854f, 0.02632308f, -0.02756316f, -0.03708911f, 0.01024763f, 0.01266584f, 
    0.01569759f, -0.00976024f, 0.00837155f, -0.02293328f, 0.02481047f, 0.02695323f, 0.03065399f, 0.03283877f, 
    0.01932943f, -0.03680316f, -0.02056467f, 0.01510466f, 0.02535350f, -0.01363678f, 0.01247502f, -0.03303621f, 
    -0.01046715f, -0.02747361f, 0.00103501f, -0.03154130f, 0.00128654f, 0.02658594f, 0.00606193f, 0.00647974f, 
    -0.03480320f, -0.01773641f, 0.02326057f, 0.00877298f, -0.03504016f, 0.00617103f, 0.01604058f, -0.03248960f, 
    -0.01011096f, -0.00139122f, 0.01224064f, -0.01350598f, -0.01708523f, 0.00039315f, -0.00985437f, 0.01322722f, 
    -0.00795603f, -0.01488431f, -0.01870203f, -0.02415209f, 0.01466105f, 0.01167836f, 0.01518714f, 0.01152559f, 
    -0.03918337f, 0.01149590f, -0.03207104f, 0.00649261f, -0.02301963f, 0.00757825f, 0.00883986f, -0.01712362f, 
    0.01450934f, 0.02187585f, 0.01108489f, -0.01180686f, 0.00606732f, -0.00608820f, -0.03917575f, -0.04410448f, 
    -0.00593356f, -0.00062799f, -0.00351691f, 0.00579129f, 0.02793580f, -0.00200691f, 0.02309666f, -0.00271261f, 
    0.03134511f, 0.00516763f, 0.01162531f, -0.02350529f, 0.01486777f, 0.01777626f, -0.02963948f, -0.00627791f, 
    -0.02353377f, 0.02404263f, -0.03882200f, -0.02407716f, -0.02889781f, 0.02502517f, -0.02128522f, -0.00753630f, 
    -0.01578840f, 0.01963267f, 0.02076172f, -0.00785697f, 0.00757024f, -0.02399472f, 0.00268840f, 0.02027086f, 
    -0.03754903f, -0.01517088f, 0.02220685f, 0.00068655f, 0.02347728f, 0.02808413f, -0.04230451f, -0.02917698f, 
    -0.00126239f, -0.01693804f, 0.01111624f, -0.01265525f, 0.00040252f, -0.02133203f, -0.01861602f, 0.02590267f, 
    0.02968249f, -0.00461827f, 0.01008229f, 0.00549311f, -0.04281136f, 0.00668547f, -0.01705102f, -0.03900137f, 
    -0.01978411f, -0.03905499f, 0.01553431f, -0.00620167f, -0.00707616f, -0.01236835f, 0.02827400f, 0.00868316f, 
    -0.04053972f, -0.00341046f, 0.01562815f, 0.00885188f, 0.00633978f, 0.00697664f, 0.00085010f, 0.01325644f, 
    -0.01631882f, -0.00743362f, -0.01235935f, 0.01483869f, -0.01056794f, -0.02176306f, -0.03914906f, 0.01941101f, 
    0.00997489f, -0.03437195f, -0.01506405f, 0.00297637f, 0.01891033f, 0.00171997f, 0.00442401f, 0.01834513f, 
    -0.03286891f, 0.02683839f, -0.02794237f, 0.02122894f, 0.00787097f, -0.02804278f, -0.02605769f, 0.01910943f, 
    0.00647411f, -0.03326930f, -0.01846446f, -0.00453970f, -0.00751022f, -0.03350616f, -0.03931752f, -0.02928079f, 
    -0.02700086f, -0.02982634f, -0.03663603f, 0.01517961f, 0.01207852f, 0.01172915f, 0.02410012f, 0.01876182f, 
    -0.01717761f, 0.02676663f, 0.00620757f, 0.02462887f, -0.03222294f, 0.00661087f, 0.02706090f, -0.03786612f, 
    -0.02674026f, 0.02198963f, 0.00981266f, 0.00253674f, 0.01297111f, 0.01360599f, -0.02493937f, 0.01089646f, 
    -0.00026675f, -0.02929396f, -0.02225564f, -0.03910545f, -0.01976696f, -0.01430011f, -0.00641864f, -0.01404669f, 
    -0.00533543f, 0.01237592f, -0.00654019f, 0.01875494f, -0.02331313f, -0.01592814f, 0.01257546f, -0.02967892f, 
    -0.01634085f, -0.03606119f, -0.01665537f, -0.02618907f, 0.02562618f, -0.00013535f, 0.01085100f, -0.02227660f, 
    -0.01086055f, -0.00883298f, 0.02543349f, 0.00995549f, -0.01832015f, 0.02201685f, -0.00550912f, 0.02765545f, 
    -0.03251419f, 0.01402071f, 0.02853985f, -0.02203190f, 0.01385839f, -0.01290345f, 0.02100068f, 0.00103473f, 
    -0.00002057f, 0.01317505f, 0.01054204f, 0.00854393f, -0.03452514f, -0.03505955f, 0.00766113f, 0.00384153f, 
    -0.02860426f, 0.01621197f, -0.01928889f, -0.03483209f, 0.00616469f, 0.00551702f, -0.03422218f, 0.01539681f, 
    -0.00899818f, -0.02995288f, -0.02407355f, 0.01079084f, 0.01527240f, 0.02486749f, -0.00332169f, -0.01480010f, 
    0.01401377f, 0.02267237f, -0.01698114f, -0.01111021f, 0.00582394f, 0.00132227f, -0.02977590f, 0.00269077f, 
    -0.00260448f, -0.03047036f, 0.01341139f, 0.00444403f, -0.04400526f, -0.00158320f, -0.03172131f, -0.02346083f, 
    0.03001280f, -0.00643364f, 0.02334326f, -0.02702057f, -0.01066252f, 0.02245595f, -0.01197279f, -0.02990074f, 
    -0.02990309f, 0.01414591f, 0.03467437f, 0.01800014f, -0.03981586f, -0.02959367f, 0.00483436f, 0.02176897f, 
    -0.03318413f, 0.01446511f, -0.03201782f, -0.01030905f, 0.02599787f, 0.02567028f, 0.00348702f, -0.00648236f, 
    -0.02095729f, -0.03004387f, 0.01452727f, 0.01010475f, 0.01486900f, 0.00410403f, 0.01031255f, -0.04320211f, 
    0.01542495f, 0.00650873f, -0.02467996f, -0.00068528f, -0.02844067f, -0.01148138f, -0.03353683f, -0.03455158f, 
    0.02166605f, -0.02149790f, 0.01259488f, 0.01001010f, -0.00108385f, -0.00817869f, 0.03042021f, 0.02714905f, 
    -0.01418103f, 0.00515017f, -0.02531734f, 0.00848836f, -0.00553373f, -0.02684783f, 0.00489725f, -0.02873269f, 
    -0.03836108f, -0.00893028f, 0.00029151f, -0.04114918f, -0.01925388f, -0.02235832f, -0.03257656f, -0.01896044f, 
    -0.00211512f, 0.01993997f, 0.00917590f, -0.03488218f, -0.03154513f, -0.00060413f, 0.00019378f, -0.01274868f, 
    0.02616781f, -0.03795520f, -0.03283640f, -0.02663470f, -0.02112457f, -0.03914330f, -0.01745478f, -0.03167759f, 
    -0.01303458f, -0.00549992f, 0.02682779f, -0.01031676f, 0.02049007f, -0.02803571f, 0.01090270f, -0.02584898f, 
    0.01181153f, -0.00224262f, -0.00604261f, -0.02623932f, 0.00266092f, -0.03870767f, 0.01425968f, 0.02139708f, 
    0.00597564f, 0.00277617f, -0.00259361f, 0.00660924f, -0.01971344f, -0.02260748f, 0.01666388f, 0.02282035f, 
    0.01261639f, 0.03435878f, 0.00147589f, -0.02681361f, -0.02180194f, 0.00553515f, 0.01863388f, 0.00592920f, 
    -0.04001339f, -0.00081878f, -0.00237167f, -0.01718177f, 0.01739419f, 0.01534096f, -0.02563322f, -0.02736829f, 
    0.03296210f, -0.02439447f, 0.00734778f, -0.04223492f, 0.02455570f, 0.02201864f, 0.01095595f, -0.02780903f, 
    0.02333766f, -0.02419944f, -0.03926852f, -0.02165065f, 0.01176703f, 0.02029346f, -0.00303797f, -0.00454220f, 
    -0.00142424f, -0.02982282f, -0.04291563f, -0.00099969f, -0.01113631f, -0.03657764f, 0.01291881f, 0.02239211f, 
    -0.03488133f, 0.01220946f, -0.02527088f, 0.01779800f, 0.01791406f, 0.01772588f, -0.00261007f, 0.01951886f, 
    -0.00924992f, -0.02175949f, 0.01653048f, -0.01663708f, -0.02186032f, 0.01241481f, -0.00854576f, -0.03777782f, 
    -0.01719415f, 0.00595663f, -0.00168721f, 0.02277991f, -0.02002401f, 0.00540237f, -0.02052790f, -0.03870266f, 
    -0.03385673f, -0.00337872f, 0.00546192f, 0.02436200f, -0.03035456f, 0.02743033f, -0.03327580f, 0.01511932f, 
    0.02633071f, -0.03875417f, 0.00468180f, 0.02448345f, 0.02406930f, -0.02125606f, 0.02557365f, 0.00643797f, 
    -0.00146569f, 0.00615075f, -0.00919151f, -0.00555657f, -0.02734238f, 0.01358480f, -0.02914713f, -0.03851952f, 
    0.01383956f, 0.01966704f, -0.02734014f, -0.00891243f, 0.02722366f, 0.01322779f, -0.01457083f, -0.02326735f, 
    -0.00888579f, 0.01145871f, -0.03159420f, -0.00780047f, 0.02664821f, -0.03161845f, 0.01052365f, -0.03022611f, 
    -0.02387678f, 0.01072163f, -0.01439535f, -0.01801367f, 0.00657111f, 0.00445100f, 0.02260381f, -0.00041354f, 
    -0.03356123f, -0.02424224f, -0.03192130f, -0.00384654f, 0.03393875f, -0.03988631f, -0.00334080f, -0.00503692f, 
    0.00520360f, -0.02315585f, 0.01476450f, 0.02269376f, -0.01219645f, -0.02687467f, -0.01090666f, 0.01685227f, 
    -0.00882700f, 0.00405110f, 0.01070679f, -0.03592115f, 0.00182218f, 0.00214276f, 0.02307017f, -0.00998180f, 
    -0.01361864f, 0.01701272f, 0.01564755f, -0.03557034f, -0.02700706f, -0.01956399f, -0.02557024f, -0.02118942f, 
    0.00145814f, 0.00397364f, -0.02930121f, -0.03933100f, 0.02517829f, 0.00846861f, -0.04284419f, -0.00945490f, 
    -0.02835981f, -0.02371783f, -0.01162547f, -0.03609579f, 0.01076485f, -0.03638996f, -0.03313814f, -0.01730947f, 
    -0.00819392f, -0.01189975f, 0.01956220f, -0.02109400f, 0.00536863f, -0.03769528f, -0.02702950f, -0.02969325f, 
    -0.03558712f, -0.01927486f, 0.00269015f, 0.01583372f, 0.01554021f, 0.02009004f, -0.00926972f, 0.01396663f, 
    -0.03111456f, 0.01052452f, -0.03079127f, -0.02899670f, -0.01854522f, 0.00228497f, -0.02645156f, -0.03905877f, 
    -0.02500918f, -0.02297099f, 0.03357263f, 0.01658833f, -0.00147524f, 0.00072942f, -0.00698759f, 0.01481174f, 
    0.01826376f, -0.01407288f, -0.03242338f, -0.03189943f, -0.01505856f, 0.00946311f, 0.00111737f, 0.00317519f, 
    -0.03450447f, 0.00023117f, 0.01678769f, -0.03788050f, 0.00493934f, 0.01507825f, 0.00600151f, 0.02401430f, 
    -0.01590820f, 0.00926345f, -0.01096132f, -0.02155418f, -0.03034402f, 0.01044529f, 0.00591189f, 0.01653037f, 
    0.01425077f, -0.00586944f, 0.01064856f, 0.01458307f, -0.02435863f, 0.01845143f, 0.02653935f, -0.02897521f, 
    0.01746828f, 0.01507634f, 0.02925997f, -0.03237413f, -0.00024314f, 0.01801178f, -0.03771107f, -0.01753350f, 
    0.02105855f, -0.02463217f, 0.00221902f, 0.01931892f, 0.02238061f, -0.01235501f, 0.01911538f, -0.01128676f, 
    0.01885462f, -0.02738031f, 0.01311865f, -0.00116421f, -0.03159598f, -0.03277402f, 0.00278250f, -0.04312899f, 
    -0.01428921f, -0.00733368f, 0.02418944f, 0.00187603f, -0.03066686f, 0.00628975f, -0.01933386f, 0.02133788f, 
    0.01021343f, -0.03214699f, 0.01563603f, -0.04068479f, -0.00293199f, -0.02930558f, -0.04222602f, -0.02247234f, 
    0.05554689f, -0.13743517f, 0.10084997f, -0.15901071f, 0.08552345f, 0.00194210f, 0.10795388f, -0.06592814f, 
    0.06348795f, -0.00543408f, 0.09391826f, 0.11535785f, -0.07442833f, -0.15723845f, 0.00142908f, 0.01513505f, 
    0.06809501f, 0.02452925f, -0.11626817f, 0.08769593f, -0.03002024f, -0.02018810f, -0.09599026f, -0.14397843f, 
    0.10483088f, 0.03128034f, 0.09808847f, 0.20208098f, 0.00693653f, 0.05521523f, -0.07512197f, 0.01917646f, 
    -0.06330526f, -0.03677879f, -0.01622591f, 0.05599228f, -0.30481037f, -0.06563184f, -0.13878715f, -0.03066666f, 
    0.14945565f, 0.03258322f, -0.05921584f, 0.03615280f, -0.05438852f, 0.12391032f, -0.05371588f, 0.05468799f, 
    -0.02536250f, 0.02032936f, 0.18317664f, 0.09086212f, -0.02404517f, 0.10154466f, -0.26801082f, 0.04684914f, 
    -0.09880269f, 0.07159513f, -0.06718784f, 0.00782862f, -0.07571879f, -0.08043221f, 0.15720193f, 0.25318024f, 
    0.07158714f, 0.18120660f, 0.07680855f, 0.01376990f, 0.01772566f, 0.04062908f, -0.14006548f, -0.09371106f, 
    0.20760933f, -0.18952349f, 0.09965815f, 0.19588298f, -0.02916889f, 0.01983958f, -0.04923828f, 0.11378566f, 
    -0.02988668f, -0.04830989f, -0.01491312f, 0.03506078f, 0.12133903f, -0.02497099f, 0.22916514f, 0.29056999f, 
    -0.02954027f, 0.12351578f, -0.00959611f, -0.10219447f, -0.01789013f, -0.07351848f, -0.08183962f, -0.04220205f, 
    -0.02771892f, -0.20473628f, 0.04741599f, 0.00354067f, -0.05772769f, 0.04730691f, -0.05470045f, 0.16457933f, 
    -0.11621777f, -0.14337657f, -0.07361404f, -0.06997206f, 0.08373302f, 0.06701870f, 0.10750875f, 0.24421345f, 
    0.02792012f, 0.09379378f, -0.08218993f, 0.19398476f, 0.00841575f, -0.01746362f, -0.13484381f, 0.03316230f, 
    0.04928536f, 0.02718316f, -0.26473260f, -0.08490677f, -0.10543514f, 0.07493522f, 0.00332117f, 0.15242858f, 
    -0.03042607f, -0.19422919f, -0.02675457f, 0.07979800f, -0.12759177f, -0.01165888f, 0.04316356f, -0.20209679f, 
    0.12610652f, -0.03691870f, 0.11462847f, -0.00946200f, -0.03144225f, 0.12147675f, -0.10687579f, 0.01662467f, 
    0.01826471f, 0.16052374f, -0.07798436f, 0.03991081f, 0.10780737f, 0.03170632f, -0.01637652f, 0.01020659f, 
    0.10003150f, 0.06532733f, 0.16665594f, 0.03668128f, 0.13407168f, 0.07367784f, 0.09314296f, 0.04115731f, 
    0.01494843f, 0.08388977f, 0.17348610f, 0.01598610f, -0.02070488f, -0.15288968f, -0.00569608f, -0.13822937f, 
    0.08457685f, -0.11500689f, -0.18623739f, 0.06366806f, 0.02270911f, 0.03925414f, 0.08604366f, -0.01863808f, 
    -0.15311915f, -0.00226435f, -0.00305070f, -0.04958472f, 0.04360720f, -0.03279260f, 0.23902731f, -0.18909657f, 
    0.09998836f, 0.11061428f, -0.01486922f, -0.00785439f, 0.05511633f, 0.03065855f, -0.22340567f, 0.10917488f, 
    0.13308254f, 0.21247599f, 0.05303993f, 0.05543146f, 0.11887287f, -0.11634751f, 0.04091819f, -0.03015811f, 
    -0.06802163f, -0.14894795f, 0.05607400f, -0.07378761f, 0.10958602f, 0.03652617f, 0.04703078f, 0.10859515f, 
    0.08091071f, 0.08200770f, 0.04084357f, -0.03736423f, 0.00000258f, 0.06261688f, 0.06869479f, -0.02579987f, 
    -0.24276318f, 0.06115854f, -0.13887605f, 0.05910987f, -0.05264680f, -0.03618478f, -0.07505993f, 0.06557358f, 
    -0.08204459f, 0.06751891f, -0.06802770f, 0.10935483f, -0.20889977f, 0.03868312f, 0.13233994f, 0.03874998f, 
    0.06877200f, 0.11151720f, -0.12049154f, -0.10201614f, -0.09173192f, 0.07951668f, -0.01105199f, 0.15920834f, 
    0.12896359f, 0.06617612f, -0.09711272f, 0.31160522f, -0.00578837f, 0.01852720f, 0.00339234f, -0.13284494f, 
    0.14869833f, -0.03797324f, 0.04746996f, -0.04852477f, 0.05969357f, 0.02361269f, -0.15984169f, 0.15289131f, 
    -0.03497536f, 0.03949590f, 0.03846717f, -0.07556246f, 0.02677296f, 0.02216551f, 0.20542595f, 0.11411761f, 
    0.00547587f, 0.13878991f, 0.06061031f, 0.16978216f, 0.12149725f, -0.04122894f, 0.17271870f, 0.06673119f, 
    0.06119364f, 0.10374762f, -0.16768557f, 0.15406758f, 0.30101776f, -0.26026976f, -0.07329885f, -0.02897741f, 
    -0.11360122f, 0.05046793f, -0.08724330f, -0.09130122f, -0.14023185f, -0.06618798f, 0.04738642f, -0.10975721f, 
    -0.26271605f, 0.30838600f, -0.37115732f, 0.07914151f, -0.00838116f, -0.08683853f, 0.12279686f, -0.01491642f, 
    0.02607522f, -0.07181056f, -0.04922632f, 0.10287511f, -0.03095804f, -0.07907967f, 0.21887228f, 0.33166036f, 
    -0.13776198f, 0.02890143f, -0.02665462f, -0.11718324f, -0.04603342f, 0.02045687f, 0.08174959f, -0.06372748f, 
    0.20468822f, 0.15519620f, 0.11306943f, 0.22147606f, -0.04101778f, -0.02889200f, -0.11756850f, 0.01699455f, 
    -0.11319005f, -0.05454688f, -0.03586931f, -0.00956740f, -0.06721986f, 0.19366397f, 0.09345513f, -0.03208350f, 
    0.01908424f, 0.12707509f, 0.18733111f, 0.07121553f, 0.14951457f, 0.23370501f, 0.24609278f, 0.10833474f, 
    -0.19183312f, 0.06541863f, -0.08464979f, 0.18204829f, 0.05468658f, 0.01374599f, 0.02008031f, -0.07707555f, 
    -0.08925180f, -0.03292888f, 0.08619287f, 0.01891631f, 0.09158313f, 0.11354354f, -0.13757579f, 0.31883043f, 
    -0.03649094f, 0.05838027f, 0.00330848f, -0.02878274f, 0.07770412f, 0.03583290f, -0.04359124f, -0.02712182f, 
    -0.33080024f, 0.02520786f, 0.12126019f, -0.13081567f, -0.04172643f, -0.00316476f, 0.00360310f, 0.08029217f, 
    -0.05761813f, 0.00243289f, 0.09996647f, 0.15510307f, 0.19428991f, -0.07961757f, -0.08859747f, 0.04804439f, 
    -0.10627460f, 0.07421223f, -0.01802936f, -0.00899329f, 0.08357409f, 0.09726254f, 0.02413375f, 0.02866532f, 
    0.03736748f, -0.12916541f, 0.21051593f, -0.02540427f, -0.12605178f, -0.03566471f, 0.10326648f, 0.03888960f, 
    0.02637444f, -0.09838666f, 0.07969326f, -0.17305936f, 0.04634856f, -0.14928395f, -0.01082311f, -0.03789688f, 
    -0.06134024f, 0.22153567f, -0.11560673f, 0.01341482f, -0.06395918f, 0.04301797f, -0.02941669f, -0.13565873f, 
    0.11037979f, 0.08816768f, 0.21385707f, 0.35371375f, 0.02081129f, 0.00581849f, 0.00970835f, -0.09127123f, 
    0.03366020f, 0.10392566f, 0.10843328f, 0.00461613f, -0.09849273f, 0.21915781f, 0.01885513f, 0.10835163f, 
    0.00347999f, -0.02317845f, -0.03761366f, 0.12227919f, -0.01972272f, 0.02528887f, -0.15952179f, 0.03533027f, 
    0.10021280f, 0.26618654f, 0.30743724f, -0.00863573f, -0.07267731f, -0.08261314f, 0.18216784f, -0.08869137f, 
    0.05995747f, 0.05077134f, -0.01723514f, -0.09553546f, -0.04122847f, 0.14156008f, -0.11544972f, -0.12250634f, 
    -0.00276292f, -0.06574789f, 0.00732070f, 0.08741349f, 0.24148297f, 0.08973105f, 0.00080145f, 0.31990933f, 
    0.10835328f, 0.16626772f, 0.27553755f, 0.09321027f, -0.02505586f, -0.00972948f, -0.16397414f, 0.05909444f, 
    0.05047904f, -0.00879854f, 0.02272794f, -0.09402566f, 0.14812495f, 0.07431661f, 0.25069711f, 0.25079870f, 
    0.10084192f, 0.21712717f, 0.19272491f, -0.01609862f, -0.02462483f, -0.03746216f, 0.02690071f, -0.09120585f, 
    0.07821141f, 0.28318998f, 0.28084114f, 0.08773018f, 0.11814775f, 0.13210981f, 0.14160642f, 0.08505850f, 
    0.10362148f, -0.00121468f, 0.09604035f, -0.04874503f, 0.04587834f, 0.14558446f, -0.05514693f, 0.21709417f, 
    0.14552712f, 0.09413607f, 0.07067300f, 0.09902687f, -0.01005130f, -0.06240035f, -0.00331194f, 0.02888091f, 
    0.12262614f, 0.01154489f, 0.10177483f, -0.10172569f, -0.03609141f, -0.03210089f, 0.08472158f, 0.06839585f, 
    0.07358418f, 0.00732313f, 0.02676884f, -0.03318319f, 0.03503903f, -0.06183743f, -0.15268897f, -0.09540751f, 
    0.05919328f, 0.09783559f, 0.01037168f, 0.02717196f, -0.05663573f, -0.04014590f, -0.02389214f, -0.01596100f, 
    0.00437137f, -0.07518373f, 0.25861245f, 0.10273716f, -0.00650052f, 0.06892757f, 0.20432565f, 0.03077199f, 
    -0.10795299f, 0.12979653f, 0.13955477f, 0.11969157f, 0.05665782f, -0.07160725f, 0.10267180f, 0.01131977f, 
    0.02212899f, 0.14050411f, -0.02294858f, -0.01096497f, 0.01233917f, 0.03687778f, 0.02184839f, 0.01610849f, 
    -0.12858035f, 0.22720605f, -0.28814504f, 0.08840571f, 0.03576273f, -0.07120927f, -0.00375052f, 0.02868122f, 
    -0.03091628f, -0.04666514f, 0.08757224f, 0.20396073f, -0.22203760f, 0.04228175f, 0.43431205f, -0.23013790f, 
    -0.08157473f, 0.06604655f, -0.06585108f, 0.02876843f, -0.09651636f, -0.10991660f, -0.09492843f, -0.04157511f, 
    0.13933454f, 0.13790233f, 0.08365160f, 0.19527608f, 0.17716004f, 0.00448938f, -0.06619666f, 0.08879676f, 
    0.18385607f, 0.17064954f, 0.06019200f, 0.20939443f, 0.03918596f, 0.05425178f, 0.08200738f, 0.16857858f, 
    0.01738956f, -0.01614860f, -0.08554395f, 0.07909901f, 0.04760858f, 0.04260054f, 0.07002120f, 0.08525807f, 
    -0.06353047f, -0.10136881f, -0.12185938f, -0.05149797f, 0.11755136f, -0.00061705f, -0.08325204f, 0.04047736f, 
    -0.04786920f, 0.05378657f, -0.11452483f, -0.24585518f, 0.04274321f, 0.15821667f, -0.02575324f, 0.16206549f, 
    -0.11063510f, 0.05405998f, -0.02980205f, 0.18059736f, 0.04690007f, 0.04897220f, -0.04957444f, 0.20882435f, 
    0.12498773f, -0.06697301f, 0.00379480f, 0.19890088f, 0.00072162f, 0.05707151f, -0.09345531f, 0.01450299f, 
    -0.06047257f, 0.07900573f, 0.14581901f, 0.07719778f, -0.17941038f, -0.33765918f, 0.27427396f, 0.01383740f, 
    0.02413360f, 0.09091075f, 0.22256996f, -0.05309409f, 0.00565744f, -0.08867709f, -0.14817479f, -0.14884627f, 
    0.10191334f, 0.01914894f, -0.07425289f, 0.04233565f, 0.05970179f, -0.07309014f, -0.01094542f, 0.11908169f, 
    0.01868270f, 0.04578525f, 0.00562714f, -0.18249416f, -0.49842131f, 0.01499869f, -0.19063750f, 0.06212981f, 
    0.17816646f, 0.14190766f, -0.13315052f, -0.08556190f, -0.01436288f, -0.06316553f, -0.12725896f, 0.06398882f, 
    -0.32228595f, -0.07669188f, 0.03418523f, 0.04865499f, 0.13899115f, 0.00297432f, -0.06605455f, -0.11414693f, 
    -0.12522423f, 0.09160438f, 0.00995093f, 0.12517393f, 0.27161065f, 0.18531290f, 0.17935011f, 0.21210797f, 
    0.04580688f, 0.09529056f, -0.03158202f, -0.05462940f, -0.00034812f, -0.06379025f, 0.01890556f, -0.08073328f, 
    0.12535991f, 0.12887999f, -0.09529111f, 0.22090231f, -0.06573848f, -0.11262135f, -0.06840567f, -0.02611470f, 
    -0.09618462f, -0.01486369f, 0.00181265f, 0.02852860f, -0.08482268f, 0.10102910f, 0.08045343f, 0.25040123f, 
    -0.08529539f, 0.02784601f, -0.07761767f, 0.08231069f, -0.15218744f, -0.10106917f, -0.13791160f, -0.19480784f, 
    -0.03889368f, 0.07782452f, 0.15617365f, 0.20565906f, -0.03361037f, -0.06101089f, 0.00836554f, 0.14177662f, 
    -0.05128373f, -0.12756217f, 0.06692778f, -0.10885791f, -0.11928144f, 0.10704302f, 0.03719792f, -0.01118208f, 
    -0.00151443f, 0.01338310f, -0.18285131f, 0.12942447f, -0.05167371f, 0.14677154f, -0.30737144f, 0.02981797f, 
    -0.03385729f, 0.08222394f, 0.25895712f, 0.24410653f, 0.04248846f, 0.06028348f, 0.00706693f, -0.04068078f, 
    0.12488018f, 0.01979618f, -0.07506204f, 0.06415492f, -0.02412913f, 0.07664513f, 0.15554692f, -0.07508095f, 
    0.02125099f, -0.04494295f, 0.03893746f, 0.01881367f, -0.13067593f, -0.08788871f, -0.04633996f, -0.17092778f, 
    0.01317426f, -0.03746093f, -0.00747836f, 0.01182687f, -0.01396682f, -0.00538711f, -0.02940266f, -0.00294122f, 
    0.00371425f, -0.00905526f, -0.03186012f, 0.01964289f, -0.02685872f, -0.04148766f, -0.03695355f, -0.01785494f, 
    -0.01374395f, 0.02896116f, 0.00637958f, -0.03851385f, 0.00045689f, -0.04199359f, 0.02541343f, -0.00167098f, 
    -0.01856570f, 0.00930019f, -0.04585595f, -0.04486734f, 0.01509070f, -0.03327649f, -0.00599492f, 0.01099168f, 
    -0.03917443f, -0.00088008f, -0.03753433f, -0.01540268f, -0.00221025f, -0.01426317f, -0.02887371f, -0.03226018f, 
    -0.00584340f, 0.02165671f, -0.03262857f, -0.04243274f, -0.01994288f, 0.01143378f, 0.01663531f, -0.00524189f, 
    -0.00515054f, 0.02578936f, 0.00962952f, -0.04333312f, -0.01948007f, 0.00083456f, 0.00524164f, -0.01549436f, 
    0.01682882f, -0.04177459f, -0.03499845f, 0.01886582f, 0.00141975f, -0.00394799f, 0.00460482f, -0.04039158f, 
    -0.02274418f, -0.02852931f, -0.02911024f, 0.02207639f, -0.03899213f, -0.02870343f, -0.03551074f, 0.01456367f, 
    -0.01304963f, 0.01657570f, 0.00729289f, 0.03611551f, -0.03883629f, -0.01838978f, -0.02933831f, 0.00831486f, 
    -0.02023056f, -0.00199319f, 0.02492365f, -0.03333179f, 0.00968813f, 0.01929944f, 0.01393942f, 0.00082712f, 
    -0.01571501f, 0.01039786f, -0.00424640f, -0.00003888f, 0.02202867f, -0.01794413f, -0.03061661f, 0.01998708f, 
    0.00962054f, 0.01654721f, -0.03091027f, -0.04050083f, -0.02852467f, -0.01317355f, -0.02187531f, -0.00645072f, 
    0.01363592f, 0.02426988f, -0.00479786f, -0.01649210f, 0.00302177f, -0.01923721f, 0.02338857f, -0.03449781f, 
    0.01979577f, -0.03874738f, 0.02368511f, 0.02299050f, -0.00624083f, 0.01931727f, -0.04284592f, 0.00327420f, 
    0.03740279f, 0.02227450f, 0.00919899f, -0.03150430f, -0.01522308f, -0.03768246f, -0.00539528f, -0.00339873f, 
    -0.00153599f, -0.00819782f, 0.00153854f, 0.00050502f, -0.01786542f, 0.02334449f, 0.02930932f, -0.03626951f, 
    -0.00112269f, 0.01484348f, -0.00105295f, -0.00409950f, 0.02133641f, -0.01765135f, 0.00517846f, -0.00399312f, 
    -0.02336412f, 0.00161924f, -0.01267197f, -0.03742859f, -0.03042585f, -0.03507493f, 0.01493082f, -0.03356051f, 
    -0.02414981f, -0.03729650f, 0.02117441f, -0.04398147f, 0.02209920f, -0.01209764f, 0.00342356f, 0.01446813f, 
    0.02185456f, -0.03493217f, 0.02490339f, -0.01898775f, -0.02179957f, -0.02717976f, -0.01844808f, -0.02418589f, 
    0.02520278f, 0.01379609f, 0.00336677f, 0.01048714f, -0.03571139f, 0.00013019f, 0.00051989f, -0.03727224f, 
    -0.00497144f, -0.01899376f, 0.01377945f, 0.00413218f, 0.00785120f, 0.00332535f, 0.02501072f, -0.00805745f, 
    0.02848023f, -0.04200950f, -0.01061915f, -0.03838861f, 0.01395902f, 0.03255587f, 0.01815944f, -0.03989024f, 
    -0.00772838f, -0.04367771f, -0.03626426f, -0.00522215f, -0.04218711f, -0.00003940f, -0.03533809f, -0.02739689f, 
    0.00171388f, -0.03811363f, -0.01478254f, 0.01171978f, 0.00371296f, -0.01427169f, 0.02099169f, -0.00299099f, 
    0.01025276f, 0.00434270f, -0.00216640f, -0.02310716f, -0.03446438f, -0.02790944f, 0.00220776f, 0.01870165f, 
    0.01922018f, -0.03572291f, -0.04099956f, 0.01986418f, -0.03009407f, 0.01622518f, -0.01456690f, 0.01841227f, 
    -0.01972008f, 0.02884161f, 0.02142634f, 0.00266727f, 0.00010422f, 0.02834115f, 0.00617448f, 0.02343957f, 
    0.02198958f, 0.00145964f, 0.01206702f, -0.00929384f, 0.01544482f, 0.00548784f, -0.02842205f, -0.00634665f, 
    -0.03869327f, 0.00419214f, -0.00720510f, -0.04506978f, -0.02617350f, -0.01952475f, -0.00841804f, -0.01800523f, 
    -0.03172562f, 0.02162663f, -0.00840412f, -0.01697321f, 0.03881989f, 0.00251973f, -0.03220876f, 0.00335933f, 
    0.02047241f, -0.00906443f, -0.01335426f, 0.02369818f, -0.02239292f, -0.01036839f, -0.02156271f, -0.02992830f, 
    0.00977412f, 0.00830371f, 0.00035908f, -0.01192177f, 0.01092852f, 0.02859189f, -0.03238704f, 0.00067921f, 
    0.02205097f, -0.04132814f, 0.02480049f, -0.00132312f, 0.02397976f, -0.00596705f, -0.02298254f, -0.01562621f, 
    -0.04297321f, 0.02089541f, -0.02998629f, -0.01988054f, -0.03452490f, -0.03946101f, -0.01053477f, -0.02904757f, 
    -0.00260083f, -0.00974759f, 0.01017448f, -0.00658927f, -0.03138011f, -0.01757285f, 0.01728322f, -0.02471074f, 
    -0.04166279f, 0.00847645f, 0.02332351f, -0.03126127f, 0.00629243f, 0.01082643f, -0.00885305f, -0.00395243f, 
    -0.04394672f, -0.03281954f, -0.03116920f, -0.00441011f, 0.02223800f, -0.00113600f, -0.03775269f, 0.00038353f, 
    -0.03911631f, -0.01119716f, -0.01072020f, -0.04448856f, -0.02358859f, -0.01805882f, 0.01243597f, -0.02489770f, 
    -0.03870261f, 0.02224205f, -0.02855731f, -0.02335835f, -0.04056659f, -0.00579190f, -0.04425095f, -0.00831065f, 
    -0.00652775f, -0.03200885f, -0.03916137f, -0.00617170f, 0.00081704f, 0.02052494f, 0.01407091f, -0.04484195f, 
    0.02324583f, -0.01612030f, 0.01667969f, -0.01135885f, -0.00915475f, 0.01937808f, -0.00553008f, -0.04185830f, 
    0.00342964f, -0.03519921f, 0.02084169f, -0.01782818f, -0.01821060f, 0.00446488f, 0.03640725f, -0.03131987f, 
    -0.03419315f, -0.04432033f, -0.03097202f, 0.01992494f, 0.01100905f, -0.04169232f, 0.01021716f, -0.03695775f, 
    -0.03819998f, -0.03330575f, -0.02640508f, 0.01541744f, -0.03740851f, -0.03993309f, 0.02535453f, -0.00963558f, 
    -0.02523090f, -0.02798802f, -0.00912584f, 0.01240464f, -0.03601647f, 0.01767610f, -0.00790553f, 0.02213380f, 
    -0.02715810f, 0.00360474f, 0.02793642f, 0.01109784f, -0.03159577f, 0.00455118f, 0.01119327f, -0.00088275f, 
    -0.00071709f, 0.00506822f, 0.02627010f, -0.00854278f, -0.01702096f, -0.01975327f, -0.00265344f, 0.02139665f, 
    0.01639947f, 0.00325338f, -0.02520261f, -0.03067563f, -0.00933215f, -0.01332080f, -0.02548354f, -0.03189015f, 
    0.00433458f, 0.02835711f, -0.04242193f, 0.01620784f, 0.01310981f, 0.01887949f, -0.01676369f, 0.00751496f, 
    -0.02179104f, 0.00895345f, 0.01507075f, -0.04193063f, -0.02349610f, 0.01835461f, 0.01645934f, 0.02080871f, 
    -0.02942270f, -0.00662769f, 0.02187490f, 0.02506613f, -0.02522110f, -0.03122632f, 0.01378219f, -0.03944746f, 
    0.00767544f, -0.03997312f, -0.01076823f, -0.01088518f, 0.01783911f, 0.02112581f, 0.02559542f, -0.01351697f, 
    -0.03919185f, 0.00359163f, -0.02955933f, -0.01582884f, -0.04196997f, -0.02598054f, 0.01803829f, 0.01635358f, 
    -0.01918064f, 0.01901072f, 0.02009778f, -0.01105141f, -0.01285825f, 0.01561135f, -0.00301923f, 0.00756066f, 
    0.02516182f, -0.03988747f, -0.01314586f, 0.00849540f, -0.03494468f, 0.01152044f, 0.02622656f, 0.00210299f, 
    -0.00656642f, 0.00127752f, 0.02409011f, 0.02263541f, -0.03032198f, -0.03272996f, 0.01146517f, -0.03525884f, 
    0.01225729f, -0.01140033f, -0.04227125f, 0.02624939f, -0.01412987f, -0.01509377f, 0.02120133f, -0.01365180f, 
    0.01769368f, 0.00764567f, 0.03264389f, -0.03478936f, 0.02049126f, -0.01258579f, -0.04496848f, 0.02087648f, 
    0.01212651f, -0.01756160f, 0.00981001f, 0.01956249f, -0.04396427f, 0.01286114f, 0.01473545f, 0.01279081f, 
    0.02450256f, -0.02020843f, 0.01354092f, 0.00697063f, -0.03510945f, 0.00033161f, 0.01269081f, -0.02235111f, 
    -0.00980296f, 0.01756920f, -0.01538443f, 0.01699688f, -0.04537550f, 0.01986922f, -0.01802864f, -0.02854471f, 
    0.02074856f, 0.01553406f, -0.00538330f, 0.00282422f, -0.03098735f, 0.01831533f, 0.01261679f, -0.03361911f, 
    -0.04414126f, -0.03044589f, 0.02845309f, -0.02700831f, -0.01557013f, -0.02314770f, -0.00986544f, 0.03037057f, 
    -0.01842916f, -0.02437274f, -0.00463727f, -0.02185967f, -0.02460408f, -0.02830060f, -0.01006797f, 0.03205663f, 
    -0.03790801f, -0.01289458f, -0.04466569f, 0.00280145f, -0.03752786f, -0.00092079f, -0.02255668f, -0.02535516f, 
    -0.01385883f, -0.01224197f, -0.02128449f, -0.00065345f, 0.00898959f, -0.00152888f, 0.01943963f, -0.02779258f, 
    -0.03139989f, -0.01321595f, -0.00999987f, 0.02127336f, -0.01551875f, -0.02117685f, -0.03602201f, -0.04494087f, 
    -0.00352444f, -0.01429483f, -0.02263650f, -0.04426304f, -0.00472387f, -0.03751832f, 0.00166576f, -0.04173459f, 
    -0.02283925f, 0.00316969f, -0.00375014f, -0.02237414f, -0.01931299f, -0.02956484f, 0.02642042f, -0.03011134f, 
    0.00967876f, 0.00607470f, 0.01182296f, -0.03454758f, 0.02202052f, 0.02469830f, -0.02238615f, -0.01754124f, 
    0.02097957f, -0.04204401f, 0.01930698f, 0.00920183f, -0.02287637f, 0.02708320f, 0.02159159f, 0.01810953f, 
    0.00303703f, -0.01408040f, 0.02127135f, -0.00344252f, 0.02657619f, -0.02104296f, -0.04079111f, 0.00898707f, 
    -0.03815935f, 0.02205384f, 0.01415693f, -0.04151871f, 0.01969443f, 0.01826956f, 0.02374752f, -0.02379046f, 
    -0.01978512f, 0.03159531f, 0.01205428f, 0.03275394f, 0.03383139f, -0.03565254f, 0.02096680f, -0.01208854f, 
    -0.02897666f, -0.00430665f, -0.02336950f, -0.03602171f, -0.03462486f, -0.01241611f, -0.03545394f, 0.01312736f, 
    0.02492321f, -0.02179176f, -0.01831406f, 0.00502816f, -0.00986255f, -0.01650398f, 0.00030747f, -0.00643164f, 
    -0.00302681f, -0.02040629f, 0.02215917f, -0.00549170f, -0.01535667f, -0.02824695f, -0.01171508f, -0.00987644f, 
    -0.02883516f, -0.03894769f, 0.00412452f, 0.02683458f, -0.02852941f, -0.00677913f, 0.02574655f, -0.01842452f, 
    0.00544400f, 0.00887396f, 0.01234128f, 0.01497819f, -0.03784883f, -0.02420301f, -0.03133095f, -0.01759197f, 
    -0.02512192f, -0.01204385f, 0.02026665f, 0.02360766f, -0.00126058f, -0.00773868f, -0.03271428f, 0.01733500f, 
    0.00536761f, -0.03451769f, 0.02738148f, -0.00337250f, 0.00093255f, -0.00049700f, -0.02699850f, -0.02898244f, 
    -0.01068897f, 0.01359404f, -0.01402256f, -0.00784762f, 0.00973108f, 0.02337572f, -0.00781246f, -0.01407486f, 
    -0.01024981f, -0.03654636f, 0.03852759f, 0.02527422f, 0.02837900f, -0.00572772f, -0.03721358f, 0.03028353f, 
    -0.03245998f, 0.00838576f, 0.00865733f, -0.03616346f, -0.04413608f, -0.03567880f, -0.02955098f, 0.00992882f, 
    -0.00190100f, -0.00573779f, 0.01053868f, 0.02105713f, -0.00975890f, -0.02948768f, 0.02915904f, -0.03974784f, 
    -0.03406199f, -0.03167978f, -0.00524664f, -0.04530262f, 0.02654671f, 0.00319102f, -0.04038215f, -0.00782882f, 
    0.02072719f, 0.00529175f, -0.02390902f, -0.01726575f, 0.01805949f, -0.02703279f, 0.02095913f, -0.00415339f, 
    0.02495775f, -0.01909439f, -0.01269413f, 0.00756134f, -0.00603848f, 0.01310406f, 0.00038937f, -0.02070400f, 
    -0.00746167f, -0.02332520f, -0.02286903f, 0.02772912f, -0.03646334f, -0.03736354f, -0.02883462f, -0.02631291f, 
    -0.02816255f, 0.02151463f, 0.01324475f, 0.01470630f, 0.01133704f, 0.02710254f, -0.02802197f, -0.01362099f, 
    0.00268586f, -0.00230143f, 0.02406544f, 0.01225988f, 0.02282610f, -0.02714747f, -0.03301314f, 0.01447862f, 
    -0.02744000f, -0.00546207f, -0.00099588f, -0.00145719f, -0.02416988f, -0.00140539f, 0.02465458f, -0.03308947f, 
    0.01955904f, 0.01101112f, -0.03941336f, 0.01775219f, -0.02224033f, -0.02594438f, 0.00491034f, -0.03262218f, 
    -0.01450895f, 0.00335041f, 0.01218302f, 0.01704603f, -0.03959322f, -0.02824983f, 0.00278577f, -0.00890341f, 
    0.21628785f, 0.02629881f, -0.13010511f, 0.23747651f, 0.13119401f, -0.02768667f, -0.06731039f, 0.08624062f, 
    -0.12408731f, -0.11630128f, -0.08517496f, 0.03743606f, 0.02008159f, -0.12199445f, -0.03102656f, 0.03536444f, 
    -0.03308690f, 0.20286401f, 0.09206811f, 0.10006455f, -0.01055235f, 0.12425166f, -0.03722294f, -0.04688124f, 
    -0.01370523f, 0.01501403f, 0.27380678f, -0.21954681f, 0.07821515f, -0.01475113f, -0.05798726f, 0.01451506f, 
    0.06284156f, 0.07366798f, -0.01310988f, 0.06670855f, 0.07365991f, -0.17624360f, -0.38127509f, -0.27937499f, 
    -0.08731501f, -0.21798454f, -0.02242332f, -0.00291748f, -0.05819098f, -0.03808539f, 0.01614091f, 0.06670220f, 
    -0.24415290f, 0.13365360f, 0.22274455f, 0.27389970f, -0.03813286f, -0.03537621f, 0.12811032f, -0.00393634f, 
    -0.06791653f, -0.01784610f, -0.07392059f, 0.08360784f, -0.11585392f, 0.06214164f, -0.08793435f, 0.14426902f, 
    0.15312900f, -0.09516022f, 0.05954678f, 0.15386957f, -0.04107146f, -0.00433595f, -0.05386315f, -0.04492055f, 
    -0.05794324f, 0.03344055f, 0.38626832f, -0.19788650f, -0.05738437f, -0.15850714f, -0.06797159f, 0.04927145f, 
    -0.09099180f, -0.10852454f, 0.02733260f, 0.10596344f, -0.05690593f, 0.19445357f, 0.13573425f, 0.20110002f, 
    -0.05992709f, -0.05853832f, 0.08042511f, 0.01811300f, -0.02343613f, 0.03087351f, 0.03335670f, -0.06565744f, 
    -0.13861051f, 0.36738920f, 0.09438015f, 0.04427979f, 0.06314741f, 0.02458940f, -0.05457373f, -0.12829050f, 
    0.03064991f, 0.09491088f, 0.03169173f, 0.12240590f, -0.18816631f, -0.01994921f, 0.32912660f, -0.08583865f, 
    0.15239468f, 0.17142145f, -0.09920927f, 0.01891161f, 0.06835418f, -0.06848503f, 0.08532448f, -0.03138209f, 
    -0.09096916f, 0.15637988f, -0.14121860f, -0.14612710f, -0.05892949f, -0.08491455f, -0.16918521f, -0.12086497f, 
    0.11069316f, 0.00267107f, 0.07328436f, 0.10978480f, -0.02735281f, -0.02156399f, -0.14354675f, -0.15205370f, 
    -0.08058336f, -0.08270866f, -0.04952260f, 0.01676493f, 0.16631837f, 0.02030279f, 0.12534282f, -0.01587028f, 
    -0.24326140f, -0.05395920f, -0.10846066f, 0.01594881f, -0.02256936f, -0.09170505f, 0.04248424f, -0.01666886f, 
    0.10056201f, -0.01605062f, -0.02384500f, -0.00972811f, -0.06210645f, 0.01939985f, -0.20410186f, 0.05246605f, 
    0.11756154f, 0.04375711f, 0.00906566f, 0.00380596f, -0.00955361f, -0.02355218f, -0.02943713f, 0.04753757f, 
    -0.27096200f, -0.06156160f, 0.02651472f, 0.04297953f, 0.01234278f, 0.07482310f, -0.12076566f, 0.07407043f, 
    0.17514642f, -0.10042137f, -0.02693047f, 0.06090754f, 0.12481581f, -0.26645148f, -0.22417293f, 0.04289959f, 
    -0.12117124f, -0.07551589f, -0.06041905f, -0.07537734f, -0.00219524f, 0.19931138f, 0.02529810f, -0.08625037f, 
    -0.10664491f, -0.00124978f, -0.03007914f, 0.27998924f, 0.03770433f, 0.02630178f, -0.10170754f, -0.03787955f, 
    0.21509738f, -0.02048511f, 0.01106094f, 0.18138508f, 0.00018451f, 0.07067522f, 0.04230847f, 0.10165924f, 
    0.04829746f, 0.10280303f, 0.15787943f, -0.08207454f, 0.07256567f, 0.09835352f, 0.08256458f, -0.04172069f, 
    -0.06483880f, -0.19810532f, 0.06750298f, 0.00838488f, -0.01773809f, -0.00600420f, 0.13699937f, 0.24605882f, 
    0.01989926f, 0.01710434f, -0.03934406f, -0.11012903f, 0.18896316f, -0.04264281f, 0.00990309f, -0.09294767f, 
    0.11337136f, -0.08126339f, 0.03806068f, 0.15916455f, 0.04077811f, 0.03521717f, 0.02127553f, 0.21180128f, 
    -0.01941389f, 0.05100589f, 0.19778281f, 0.26963258f, 0.26073119f, 0.16257057f, 0.06540480f, 0.12066675f, 
    -0.00813706f, 0.10632943f, 0.04514251f, -0.04637877f, 0.26424709f, -0.00934723f, -0.11190129f, -0.11447667f, 
    0.03189125f, 0.04525281f, -0.04341492f, 0.02983372f, 0.28441018f, 0.04356322f, 0.04615997f, 0.17131633f, 
    -0.05148756f, 0.07361695f, 0.03906089f, 0.04778794f, 0.09032779f, 0.22558929f, 0.13377650f, -0.08729123f, 
    -0.03845987f, -0.05334909f, 0.07666302f, -0.06571489f, 0.26644543f, 0.14821686f, 0.11205541f, 0.11009166f, 
    0.06834381f, 0.23783655f, -0.12608799f, 0.03522800f, 0.00328020f, -0.10663421f, 0.07209431f, -0.13493507f, 
    -0.12481674f, -0.14911135f, 0.31225497f, -0.07690518f, 0.11875484f, 0.09006802f, -0.02650890f, 0.21084446f, 
    0.27898350f, 0.12639458f, 0.07822393f, 0.22061905f, -0.15279631f, 0.03703525f, 0.08480530f, -0.03691911f, 
    -0.02460467f, -0.03109375f, 0.09867194f, 0.11433250f, -0.05898611f, -0.07999069f, 0.07161061f, 0.03798654f, 
    -0.22088273f, 0.22073172f, 0.19787528f, 0.11690506f, -0.07906204f, 0.10481417f, 0.15126027f, -0.03640957f, 
    0.22614908f, 0.06006732f, 0.04017913f, -0.07819039f, -0.12039819f, -0.08690498f, 0.01566673f, -0.00691514f, 
    -0.17047174f, -0.09870642f, 0.01056069f, 0.04178943f, -0.03522525f, -0.06656883f, -0.10276563f, -0.29420882f, 
    -0.04242151f, 0.55869216f, 0.07521130f, -0.20479788f, 0.10318694f, 0.04378058f, -0.01049164f, 0.03602530f, 
    0.18346052f, 0.12314133f, 0.04714963f, 0.10813227f, -0.17967099f, 0.23037544f, -0.00763601f, -0.43059018f, 
    0.10098464f, -0.15752141f, -0.16070719f, -0.05767578f, 0.21809234f, -0.08152635f, -0.02616613f, 0.10577250f, 
    0.00518049f, 0.13473848f, 0.05332382f, -0.02161159f, 0.11195499f, 0.11017863f, 0.06316677f, 0.07535705f, 
    0.08343789f, -0.06536637f, 0.05040768f, 0.15278015f, -0.06070288f, -0.10259710f, -0.01779934f, -0.18558498f, 
    -0.03509045f, 0.04778010f, -0.11462306f, -0.01121394f, 0.21724798f, -0.02637152f, 0.10397141f, -0.11557901f, 
    0.07866397f, -0.02770247f, 0.19488321f, 0.21949710f, 0.05019074f, 0.02856118f, -0.02962374f, 0.09840313f, 
    -0.04821631f, 0.04030080f, -0.03295897f, 0.05479155f, 0.06235487f, 0.12788747f, 0.26802358f, -0.09154664f, 
    0.12687917f, 0.12216635f, -0.18702206f, -0.07167460f, 0.16794558f, -0.05296798f, 0.08692241f, -0.09309472f, 
    -0.16221134f, 0.15220572f, 0.05781231f, 0.06738284f, -0.02769356f, 0.08490618f, 0.06845462f, -0.07824374f, 
    0.10472897f, -0.02463539f, 0.02562508f, 0.01809649f, -0.42805833f, 0.02806470f, 0.10470311f, 0.06317457f, 
    -0.02134434f, 0.02328755f, 0.17412785f, 0.24076992f, 0.01150486f, 0.00194126f, 0.06695016f, 0.01109365f, 
    0.07377293f, 0.07699689f, 0.00002237f, 0.25764969f, 0.17965746f, 0.14562964f, 0.08340690f, 0.15100460f, 
    0.10474463f, 0.13371706f, 0.25829116f, 0.04003242f, -0.16945305f, -0.04365938f, -0.16272105f, -0.08183684f, 
    -0.01559166f, 0.00133251f, -0.12678452f, -0.04459997f, 0.08647978f, -0.12141050f, -0.11260717f, -0.06549001f, 
    0.00303033f, -0.08513144f, 0.10961177f, 0.09645035f, 0.18167472f, 0.24847403f, -0.05439026f, -0.06373353f, 
    0.04865342f, 0.01191128f, -0.03649341f, 0.07504160f, -0.13294004f, 0.20109588f, 0.24718694f, -0.00478448f, 
    0.20859697f, -0.01999265f, -0.20638549f, -0.11869402f, -0.00417921f, -0.11830572f, -0.09247006f, -0.06916805f, 
    -0.14796858f, -0.06658614f, 0.15276965f, 0.17284265f, 0.03025699f, 0.07030496f, -0.14165102f, -0.05891607f, 
    -0.06367826f, -0.06724929f, -0.12204456f, -0.04564462f, -0.03522279f, 0.20678800f, 0.08497877f, 0.20648134f, 
    0.13318889f, -0.08822323f, 0.17672943f, -0.12966470f, 0.19085772f, 0.00564875f, -0.05764917f, 0.01899559f, 
    -0.08059011f, -0.15002415f, -0.05461442f, 0.24978964f, -0.02719750f, -0.05787572f, 0.05544085f, 0.09803599f, 
    0.25397226f, 0.04120161f, 0.03861367f, 0.06587573f, -0.25383645f, -0.04224593f, -0.02581663f, -0.09222534f, 
    -0.07568030f, -0.09503472f, -0.16035657f, -0.09880142f, -0.07672774f, -0.21444698f, -0.09990845f, -0.09699494f, 
    -0.14854518f, -0.04434972f, 0.14520122f, 0.11451508f, -0.11687259f, -0.12101918f, 0.09216212f, -0.08957512f, 
    -0.10980318f, -0.00781393f, -0.06175013f, 0.03257724f, -0.31418714f, 0.00472879f, 0.00168347f, 0.04485888f, 
    -0.06925365f, -0.15044598f, -0.14497942f, -0.07803965f, 0.03390237f, -0.18409717f, -0.16029492f, -0.09281018f, 
    -0.06891408f, -0.26012737f, -0.02088936f, -0.07106636f, -0.05953396f, -0.07583579f, -0.02057410f, 0.12854038f, 
    0.05376249f, 0.07328674f, 0.01904383f, 0.06301813f, 0.21754318f, -0.11139473f, -0.02735383f, 0.09210927f, 
    -0.06513571f, 0.00765118f, -0.01158255f, 0.14188582f, -0.02082871f, 0.14018987f, 0.05563389f, 0.04567631f, 
    -0.10434780f, 0.01145178f, 0.17293954f, 0.14163122f, 0.01974036f, 0.02048202f, 0.05604880f, -0.11874491f, 
    -0.04157497f, -0.06099934f, -0.05926465f, 0.00789024f, -0.12824826f, 0.02946640f, 0.12906791f, 0.10350218f, 
    0.02592816f, -0.05147192f, 0.00138774f, -0.07440641f, -0.01281346f, 0.02832069f, -0.03592558f, 0.03275830f, 
    -0.15876184f, 0.05991137f, 0.14205907f, -0.13186851f, -0.06565613f, -0.09667501f, -0.09147622f, -0.04680430f, 
    -0.05782812f, -0.06655806f, -0.05386595f, -0.09599300f, 0.07119554f, -0.20926997f, 0.12124586f, -0.00524404f, 
    0.02345899f, 0.11516424f, 0.01929777f, 0.03323374f, 0.11112828f, 0.04282482f, 0.04009582f, 0.14841574f, 
    -0.22646546f, 0.00477162f, 0.23371916f, -0.06321198f, 0.07153688f, -0.13744502f, 0.01320386f, -0.00556492f, 
    0.07675337f, -0.00542805f, -0.08140335f, 0.05735690f, 0.09464107f, 0.15762839f, -0.20856810f, 0.04992428f, 
    0.19912523f, 0.00014580f, -0.15005578f, -0.03692221f, 0.03921146f, -0.02888180f, -0.10454606f, -0.00086819f, 
    -0.14137802f, -0.04146873f, -0.09147932f, -0.21417037f, -0.01572797f, -0.11708714f, -0.17518763f, -0.12042024f, 
    0.03143997f, -0.07216112f, -0.16891016f, 0.07364004f, -0.00640718f, 0.37553358f, 0.07518531f, -0.28800884f, 
    -0.03419919f, -0.06324748f, -0.01212963f, -0.07484523f, 0.13579316f, -0.03419546f, -0.17653526f, -0.11594579f, 
    0.19007601f, 0.05137721f, -0.04714972f, -0.19708349f, -0.03707808f, -0.17958786f, -0.03102365f, 0.16694593f, 
    0.12936588f, 0.05910371f, -0.03267022f, 0.12529950f, -0.23380299f, -0.24166708f, 0.03873976f, -0.05315566f, 
    0.05602792f, -0.07223117f, -0.03379648f, 0.06458094f, 0.06136821f, -0.04791491f, 0.02435363f, 0.07402448f, 
    -0.11700220f, -0.01279681f, 0.10070995f, 0.22946905f, 0.08790904f, 0.12711434f, 0.05803881f, 0.03754861f, 
    0.06925344f, -0.01129267f, -0.06807638f, 0.10418747f, -0.08967115f, -0.09977882f, -0.01430681f, 0.01138736f, 
    -0.15471151f, -0.00158800f, -0.01601719f, -0.15375018f, 0.14950149f, -0.24837422f, 0.00592495f, 0.03967071f, 
    -0.33458385f, 0.19355972f, -0.15426324f, -0.20496789f, -0.10615702f, -0.02795973f, -0.13198254f, -0.22399838f, 
    0.08231800f, -0.07871676f, 0.05828480f, 0.14282508f, 0.22865792f, -0.18455790f, -0.13562572f, 0.02592342f, 
    -0.01190772f, -0.04245218f, -0.05024834f, 0.11653581f, 0.13736431f, 0.13232286f, 0.09367950f, -0.02486446f, 
    0.07272728f, 0.37732989f, -0.23735033f, -0.06079601f, 0.21269631f, 0.01687150f, 0.04368006f, -0.00917889f, 
    0.08861162f, 0.09639166f, 0.17841198f, -0.05818054f, 0.24180484f, -0.13750477f, -0.18490830f, 0.21503691f, 
    0.09687758f, -0.02468963f, 0.10381377f, 0.16414227f, -0.01984447f, 0.21305341f, -0.02024173f, 0.07585298f, 
    -0.46888936f, 0.20408061f, 0.02550111f, 0.02475458f, -0.01368933f, 0.05555233f, -0.03721409f, 0.16069789f, 
    0.03612838f, -0.00040358f, -0.16836560f, -0.12887827f, 0.28010234f, -0.09325923f, -0.00255345f, -0.14025584f, 
    -0.05387598f, 0.03859578f, 0.14230420f, -0.01440093f, 0.10392338f, 0.10730471f, -0.03784648f, 0.13522653f, 
    0.15662591f, 0.28707758f, 0.09192584f, -0.25021455f, 0.00484683f, -0.05050860f, 0.07947355f, 0.02199219f, 
    0.02757222f, -0.05282785f, 0.06090644f, -0.07382921f, 0.17249401f, 0.04261029f, 0.16236238f, 0.19614021f, 
    -0.02065700f, 0.02240447f, -0.01957704f, -0.02284618f, -0.05090221f, -0.25851712f, 0.16121975f, 0.11783426f, 
    0.00732852f, -0.14014661f, -0.33775178f, -0.11966836f, 0.00174137f, 0.10193248f, 0.06071471f, -0.09784435f, 
    0.00236478f, -0.04039493f, 0.00984854f, 0.11581785f, -0.02968345f, 0.02747827f, -0.07501255f, -0.12369926f, 
    0.10311110f, 0.19726689f, -0.02600690f, 0.05242463f, -0.00445576f, 0.04288048f, 0.12214305f, -0.00584284f, 
    -0.09699366f, 0.15751484f, -0.12627664f, 0.15756232f, 0.11943441f, -0.01841992f, -0.02701339f, -0.01362555f, 
    0.06137717f, 0.05282453f, 0.03750972f, 0.04309366f, 0.19748653f, 0.08345289f, 0.04543561f, -0.34951237f, 
    0.18566597f, -0.00865061f, 0.03762232f, 0.11673482f, -0.03249216f, 0.07773798f, 0.01111230f, 0.02557007f, 
    0.07117801f, -0.05549756f, -0.29647607f, -0.12337237f, 0.04088583f, -0.03702081f, -0.01096623f, 0.02028983f, 
    0.22322997f, 0.16638309f, 0.06296761f, -0.03592133f, 0.09242243f, 0.10949070f, -0.11550024f, -0.21669354f, 
    0.10067443f, -0.00840125f, 0.14116734f, -0.11193344f, -0.04002079f, 0.01784836f, 0.04214923f, 0.11935430f, 
    0.02094642f, 0.03557605f, 0.13314524f, -0.05074528f, 0.02458899f, -0.17844640f, -0.06093278f, 0.05823912f, 
    0.07773882f, 0.00962964f, -0.00444226f, -0.12999555f, 0.12552537f, 0.04841490f, 0.15680689f, 0.26513338f, 
    -0.11026480f, -0.07886608f, 0.05530288f, 0.05402123f, -0.00309509f, -0.00889740f, 0.01258785f, -0.07214464f, 
    -0.07280293f, -0.13583237f, 0.22942682f, -0.05746500f, 0.01122228f, -0.11632710f, 0.05927089f, -0.06686889f, 
    -0.10612511f, 0.03925837f, 0.06424952f, -0.00600076f, -0.03624845f, 0.06533159f, -0.09809105f, 0.03404595f, 
    -0.00715488f, -0.08554853f, -0.06733540f, 0.04416363f, 0.05401769f, -0.01605618f, 0.08833455f, 0.08842140f, 
    -0.06035151f, 0.02103103f, 0.02575989f, -0.02606489f, -0.06323737f, 0.06405719f, -0.12209528f, 0.14087123f, 
    0.02086829f, 0.08377492f, 0.06057221f, -0.08897378f, 0.01123784f, -0.11627296f, 0.12682450f, 0.22473013f, 
    -0.06115848f, -0.18157476f, 0.08900449f, -0.01142124f, 0.06885669f, 0.16235124f, 0.03032644f, -0.07063255f, 
    -0.09343914f, -0.07832257f, 0.08213659f, -0.06895422f, -0.23213030f, 0.09794157f, 0.09865008f, 0.00802020f, 
    0.10044663f, 0.08638260f, 0.04374637f, 0.15577829f, 0.21178302f, 0.06894580f, 0.05254485f, -0.21452618f, 
    0.08397264f, -0.01442644f, 0.03932251f, 0.07680330f, -0.02201573f, -0.09550364f, 0.01526207f, -0.00673721f, 
    0.15815444f, 0.05090545f, 0.15522876f, -0.09207383f, 0.03934202f, -0.08564266f, 0.06700665f, 0.08682524f, 
    -0.00150087f, -0.12370529f, -0.09356972f, -0.07530621f, 0.12687299f, -0.18767732f, 0.24773438f, -0.02795192f, 
    -0.04468747f, -0.06173446f, -0.01673711f, 0.03807371f, -0.09759107f, -0.05021599f, 0.01741158f, -0.15011936f, 
    -0.23216131f, 0.18965539f, -0.03015243f, 0.02555056f, 0.09483575f, -0.03015486f, 0.07006712f, 0.18026939f, 
    -0.06610592f, 0.11344775f, 0.10253778f, -0.00963441f, -0.02238574f, 0.00317692f, 0.01705728f, 0.06868768f, 
    -0.00199696f, 0.03465499f, 0.07161524f, 0.02273295f, 0.02520269f, -0.11457338f, -0.08017333f, -0.04657479f, 
    0.19326542f, -0.06884363f, -0.01427893f, -0.20056367f, -0.00364294f, 0.05117591f, -0.02418835f, -0.01955536f, 
    -0.02827670f, -0.00373202f, -0.03458651f, -0.13779785f, -0.34279707f, 0.34674084f, -0.23935243f, 0.47168204f, 
    0.05881416f, 0.09350733f, 0.03257466f, -0.02818175f, 0.10378243f, 0.03941735f, -0.01002140f, 0.08819168f, 
    0.22918770f, -0.11292835f, 0.26232314f, -0.16856426f, -0.03043794f, 0.06034311f, 0.01995304f, 0.10423625f, 
    0.00833685f, 0.07330137f, 0.01226995f, -0.13957456f, 0.11004546f, 0.10028524f, -0.18702705f, -0.16772804f, 
    0.15430947f, 0.00578789f, 0.16565208f, 0.07722222f, -0.03280919f, -0.00709951f, -0.04101881f, 0.06829543f, 
    0.17787740f, -0.18110059f, -0.26050705f, -0.18466488f, 0.03719255f, 0.13046092f, 0.03124315f, 0.02237410f, 
    0.22384445f, 0.04893147f, 0.04046502f, -0.03790591f, 0.16061182f, -0.04358023f, 0.07378102f, -0.06110285f, 
    0.02217924f, -0.03841648f, -0.05912878f, 0.05117538f, -0.11633381f, -0.19989735f, -0.25442314f, -0.05423052f, 
    0.18114066f, -0.06552041f, -0.14261913f, -0.10141864f, 0.01314797f, 0.09788575f, 0.03358397f, 0.07029651f, 
    0.19084741f, -0.02270295f, -0.13148130f, -0.07716465f, -0.03244968f, -0.05107129f, 0.07303744f, -0.05658419f, 
    0.11975191f, -0.17339538f, 0.03356983f, 0.00085861f, -0.00680492f, 0.04922621f, 0.02275515f, -0.00715912f, 
    0.31968570f, -0.26771399f, -0.13909271f, -0.01231952f, 0.14272785f, 0.00751097f, -0.04739115f, -0.05146759f, 
    0.09830313f, -0.02401845f, -0.16938515f, -0.04269007f, -0.19566908f, 0.03197533f, 0.07010338f, 0.15239494f, 
    0.08977529f, 0.06412952f, -0.05967317f, -0.01694541f, 0.02001543f, -0.03246462f, 0.18457462f, 0.07319269f, 
    -0.06615675f, 0.24133833f, -0.04434723f, -0.02153377f, 0.31471416f, -0.02031974f, -0.04824961f, 0.03287075f, 
    -0.02654209f, 0.01353686f, 0.04640115f, 0.08468372f, -0.13028735f, 0.11141203f, -0.43066132f, 0.37351808f, 
    0.05166613f, -0.00457454f, 0.05943216f, -0.05161157f, 0.02468375f, -0.02278041f, 0.09681792f, 0.11851831f, 
    0.30185157f, 0.12724045f, -0.14132726f, -0.21658005f, 0.03329598f, 0.17422523f, 0.01764504f, 0.11835279f, 
    -0.09547263f, -0.16312292f, 0.02501283f, 0.06045453f, 0.05327950f, -0.28994069f, -0.15933540f, -0.20118243f, 
    -0.06818946f, 0.01362546f, 0.00851279f, -0.00606153f, -0.05698892f, -0.09666452f, 0.04394030f, -0.04422108f, 
    -0.10392879f, -0.03206776f, -0.09593918f, -0.05938670f, 0.05319991f, 0.02196330f, -0.09295456f, 0.20328496f, 
    -0.04391459f, 0.04659196f, 0.03026967f, -0.00752262f, 0.02223792f, -0.19459805f, 0.01034805f, 0.04228473f, 
    0.01345179f, 0.05464397f, 0.10390910f, 0.00758108f, -0.03263080f, -0.21084043f, -0.12032296f, -0.28824213f, 
    0.18521053f, 0.22270450f, 0.01389764f, -0.13459989f, 0.11826597f, 0.02461442f, 0.08471662f, 0.02367457f, 
    -0.03405347f, 0.01506341f, 0.05277333f, 0.14693807f, -0.05658531f, -0.09092495f, -0.34356338f, 0.14217772f, 
    0.14817104f, 0.01780451f, -0.06464095f, 0.13062575f, -0.01401507f, 0.04495971f, 0.04977936f, -0.05270566f, 
    0.03510257f, -0.04253788f, -0.30743814f, -0.07375030f, 0.01832261f, -0.01125851f, 0.07017898f, 0.08030783f, 
    -0.06411427f, 0.12727524f, 0.04234857f, -0.10677490f, 0.25584415f, -0.14977740f, 0.08251511f, -0.30314669f, 
    0.10052663f, 0.11880456f, -0.13581990f, 0.08230288f, 0.02422941f, 0.06489377f, 0.04646730f, -0.10185085f, 
    -0.07977608f, -0.00658550f, -0.09988896f, 0.00879542f, 0.03836224f, 0.02859568f, -0.02186748f, 0.00815760f, 
    0.00968689f, -0.04683040f, -0.05741121f, 0.02416003f, -0.01090644f, 0.06036641f, 0.11289943f, 0.14455672f, 
    0.04987863f, 0.03603833f, -0.02063409f, -0.05972511f, 0.04533562f, -0.08234228f, 0.11903981f, 0.03485482f, 
    0.21271642f, 0.03362430f, -0.21391626f, -0.12391232f, -0.02384970f, 0.09585126f, -0.01459982f, -0.01290995f, 
    -0.02179927f, -0.02638453f, -0.05963928f, -0.00717163f, -0.04115353f, -0.02930619f, -0.06024939f, 0.29816076f, 
    0.16253544f, 0.00909887f, -0.02645907f, -0.14474933f, -0.02524038f, 0.01576822f, 0.06424528f, 0.04643429f, 
    0.11767012f, -0.11400880f, 0.27864429f, -0.05258835f, 0.01810825f, -0.02760113f, 0.02096654f, -0.04376306f, 
    0.03825021f, -0.09902578f, 0.08648898f, -0.08178196f, -0.04531131f, 0.05361420f, -0.17917912f, 0.35352612f, 
    0.06091574f, 0.04519080f, -0.07311769f, -0.05560217f, -0.00380569f, -0.00780922f, 0.09016631f, 0.20512168f, 
    0.18400452f, 0.10517481f, 0.09564200f, -0.19892865f, -0.00231597f, -0.00257978f, 0.08187805f, 0.08445888f, 
    -0.18548532f, -0.04081916f, -0.16236082f, -0.19245499f, 0.13429087f, 0.20899329f, 0.00275540f, -0.13769686f, 
    0.09633249f, 0.13461174f, 0.02622251f, 0.04699373f, -0.00790638f, -0.10953218f, -0.03697871f, -0.04342341f, 
    0.10808653f, 0.02886368f, 0.07514852f, 0.27978432f, 0.01031077f, 0.02194648f, -0.03456239f, -0.01751351f, 
    0.08102510f, -0.08243749f, 0.04225424f, 0.11662892f, 0.09540847f, 0.01836585f, 0.05424710f, -0.16923437f, 
    0.19278178f, -0.00912415f, -0.01411332f, -0.13927349f, 0.19036114f, 0.06414030f, -0.04685044f, -0.08542309f, 
    0.13307174f, 0.28580993f, -0.00804633f, -0.12897870f, -0.00383882f, 0.07815838f, 0.06666678f, 0.04371404f, 
    0.03985127f, -0.11783469f, -0.07444882f, -0.04005204f, -0.09156762f, -0.06344908f, -0.09882534f, 0.41521615f, 
    -0.01707505f, -0.11607638f, -0.07066358f, -0.01211406f, -0.02667659f, 0.04677673f, 0.01717302f, 0.14552367f, 
    0.09691330f, 0.08180843f, 0.08972331f, 0.02439296f, -0.05033351f, 0.04411703f, -0.02207107f, -0.11460260f, 
    0.01821368f, -0.18152702f, 0.01860578f, 0.12309618f, 0.60179782f, -0.29860342f, 0.37586248f, -0.12530899f, 
    -0.19289875f, -0.14362964f, 0.12067753f, 0.01112811f, 0.04671298f, 0.17074662f, -0.10107696f, 0.00366904f, 
    0.38738751f, -0.15813667f, 0.38327807f, 0.06436824f, -0.04940721f, -0.06245977f, 0.02608204f, -0.01384175f, 
    0.15088663f, -0.00515328f, -0.06505348f, 0.08718564f, -0.03062349f, 0.17157294f, 0.08576640f, -0.17038460f, 
    0.11579944f, 0.25494465f, 0.24631959f, -0.04532227f, -0.00783776f, 0.04599000f, 0.07136906f, 0.11851796f, 
    0.05227309f, 0.13393156f, -0.01856554f, -0.16431277f, 0.11836971f, 0.12540972f, 0.03339254f, 0.13885917f, 
    -0.00000761f, -0.02288873f, 0.04432852f, 0.04561707f, 0.14377975f, -0.28005731f, 0.03254460f, -0.13968691f, 
    -0.06669477f, 0.13273588f, -0.03456485f, -0.03364392f, 0.19204192f, 0.17588326f, 0.02193031f, 0.00387547f, 
    0.13983175f, 0.01588771f, -0.06029507f, -0.02222862f, -0.08660834f, 0.02344759f, 0.01303858f, -0.08890608f, 
    0.15965706f, -0.02360068f, -0.04503435f, -0.07864905f, -0.08475347f, 0.05878663f, 0.16490705f, 0.05345462f, 
    -0.09988565f, -0.00470000f, 0.04872209f, 0.06489293f, 0.01303330f, -0.09793305f, 0.22125046f, -0.09097941f, 
    0.09168524f, 0.06083144f, -0.35438010f, -0.11224407f, 0.05154356f, 0.00464782f, 0.00045778f, -0.05440919f, 
    -0.07686079f, -0.16568998f, -0.03051604f, 0.01756900f, -0.10113530f, -0.04436065f, 0.33660665f, -0.05857538f, 
    -0.03760494f, 0.11789573f, 0.03241565f, -0.05821125f, 0.03598353f, -0.01223379f, -0.05762291f, 0.15539581f, 
    -0.02348122f, -0.02880857f, 0.00748443f, 0.00421179f, -0.02148804f, -0.00583757f, 0.03972347f, 0.01473104f, 
    0.01610007f, -0.01631934f, -0.02531761f, -0.02890272f, 0.02589625f, 0.02637583f, -0.02443347f, 0.01998841f, 
    -0.03842708f, -0.01738762f, -0.02742537f, 0.03634039f, 0.03290914f, 0.02804195f, 0.00664980f, -0.03441678f, 
    -0.03421263f, -0.01007210f, -0.04110230f, 0.03274452f, -0.00367806f, -0.03013023f, 0.01657536f, 0.02919115f, 
    -0.01367711f, 0.00626153f, 0.03107432f, 0.00122824f, -0.01484226f, 0.02278985f, -0.03018265f, 0.02822296f, 
    -0.00170395f, 0.02772707f, 0.01728069f, -0.03459145f, 0.01788246f, -0.03033031f, 0.02329894f, -0.03133064f, 
    -0.00425071f, 0.00184030f, -0.00931715f, -0.01139599f, -0.01516246f, 0.03335836f, -0.03309790f, 0.01479120f, 
    0.03035348f, -0.02344256f, -0.00118087f, 0.00159375f, 0.02157987f, -0.01607005f, 0.01934507f, -0.02083103f, 
    0.01144138f, -0.02682957f, 0.01266898f, 0.01467854f, 0.00243474f, -0.03887799f, -0.01591277f, -0.02380296f, 
    -0.02179150f, -0.01886050f, -0.02133061f, 0.01438174f, 0.03427738f, -0.02386026f, -0.01356366f, 0.01593201f, 
    -0.02091909f, -0.00226842f, 0.02747120f, 0.02460637f, -0.02378266f, -0.02525760f, -0.00300413f, -0.01353797f, 
    -0.03000665f, 0.00560619f, -0.02444449f, -0.02911466f, 0.00693793f, 0.00768040f, -0.01935801f, 0.02291850f, 
    0.02024139f, -0.02411596f, 0.01080909f, -0.00402274f, 0.03356339f, -0.03125817f, -0.00584370f, 0.03577672f, 
    0.02015535f, -0.01244739f, 0.02049541f, -0.03322885f, 0.01508364f, 0.01358121f, -0.04398414f, -0.00930788f, 
    -0.01944524f, -0.02010416f, -0.00253632f, 0.02105749f, -0.02864159f, -0.00135814f, -0.03147845f, -0.02029843f, 
    0.02764742f, 0.01657824f, -0.02595561f, -0.00392125f, -0.02634168f, 0.02686677f, -0.01333157f, -0.00765401f, 
    0.02421380f, -0.03870656f, -0.00314389f, 0.02585764f, -0.02279585f, -0.02933587f, -0.03866397f, 0.03077745f, 
    0.01161254f, -0.00227389f, -0.03373162f, -0.03884258f, 0.02771835f, -0.01362858f, 0.03046193f, -0.03717988f, 
    0.01895358f, -0.02320605f, -0.00515343f, -0.04435571f, 0.02424416f, 0.01400383f, -0.01085257f, -0.00969671f, 
    -0.00176943f, 0.02518150f, 0.00171325f, -0.03411231f, -0.00653890f, -0.00095693f, -0.00860379f, -0.02757415f, 
    -0.03073317f, 0.02599386f, -0.02786742f, -0.01577912f, 0.02854471f, 0.00949340f, -0.01712963f, 0.00805995f, 
    0.02796137f, -0.02779939f, 0.02003349f, 0.00400154f, -0.03216899f, 0.01608050f, 0.00335136f, -0.02193897f, 
    0.01341010f, 0.00779785f, -0.00765149f, -0.00093216f, -0.03544999f, 0.02208182f, 0.02757127f, -0.00580864f, 
    -0.02515707f, -0.01006838f, 0.00728261f, -0.04349758f, 0.01292295f, 0.01710571f, -0.02477115f, -0.00476181f, 
    0.00910301f, -0.00765531f, -0.03886183f, -0.02732921f, 0.00264304f, -0.03569857f, -0.04435626f, 0.02733346f, 
    0.02207837f, -0.03958132f, -0.02875863f, 0.00160294f, -0.00940571f, -0.00843576f, -0.01359269f, -0.01394734f, 
    -0.03152793f, 0.01623131f, 0.01214081f, 0.01010935f, -0.01314014f, 0.02637446f, -0.00949073f, 0.01162871f, 
    0.00541879f, 0.01680122f, -0.00685850f, 0.01124002f, -0.00332437f, 0.01376071f, 0.01657945f, -0.00562810f, 
    0.00085044f, -0.01395122f, 0.00440021f, -0.03395197f, 0.00975082f, 0.01004989f, -0.01502096f, 0.00674290f, 
    -0.01524106f, 0.02560194f, -0.00790473f, 0.00278047f, 0.02976115f, 0.02699046f, 0.01800252f, -0.02684361f, 
    -0.03382224f, -0.02879095f, 0.00463630f, 0.01966199f, 0.00462766f, -0.01049071f, 0.01025722f, -0.04164427f, 
    0.01149190f, -0.04221808f, -0.03631112f, -0.00642794f, -0.02911071f, -0.00697292f, -0.01060368f, -0.01728939f, 
    -0.02609231f, -0.00514403f, -0.02710146f, -0.02002094f, 0.00845428f, 0.03069564f, 0.00184450f, 0.01006188f, 
    -0.00932402f, 0.03318374f, 0.02827189f, -0.01975110f, -0.00426337f, -0.02667172f, -0.01990795f, -0.01480505f, 
    0.01033061f, -0.00406775f, -0.01864648f, -0.02240137f, -0.00146298f, -0.02704661f, 0.02106867f, -0.00938753f, 
    -0.01911942f, 0.00869753f, 0.01698914f, -0.00220255f, 0.00349213f, 0.02020773f, -0.00411165f, 0.02478141f, 
    -0.02745476f, 0.03516813f, -0.03950002f, -0.02894715f, 0.02070455f, 0.03475348f, 0.01430900f, 0.00247658f, 
    0.03417591f, -0.01188567f, 0.02614260f, -0.01058319f, -0.02542586f, -0.04551696f, 0.03529551f, -0.02217953f, 
    -0.00541626f, -0.01412229f, -0.03228336f, 0.02478548f, -0.00688032f, 0.01202124f, -0.02697253f, -0.01820115f, 
    -0.00518334f, -0.01793387f, 0.03749966f, 0.01893493f, -0.01814233f, -0.03609379f, -0.03716210f, -0.04155634f, 
    -0.00701752f, -0.04550180f, 0.01098495f, -0.00773353f, 0.00124734f, -0.03932966f, -0.01025237f, 0.00151784f, 
    -0.02438783f, -0.02497033f, -0.01340491f, 0.02184244f, 0.00669272f, 0.00639675f, -0.01641127f, -0.03814897f, 
    0.02723278f, -0.03757423f, 0.02366420f, -0.01420564f, -0.01109769f, -0.01912019f, 0.00508607f, -0.02692613f, 
    -0.04016196f, -0.01762873f, -0.03509177f, -0.01291862f, 0.02133361f, 0.00848505f, -0.02345327f, 0.02959810f, 
    -0.00937444f, -0.01518703f, -0.00846889f, -0.01390297f, -0.00261372f, 0.01477465f, 0.02855905f, -0.02541846f, 
    0.00477538f, -0.03486696f, 0.03409496f, -0.01956437f, -0.01117186f, -0.02692056f, 0.01776419f, 0.01002047f, 
    0.00989984f, -0.03447135f, 0.00929189f, -0.02071585f, -0.02353371f, 0.01444845f, -0.00134592f, 0.01156673f, 
    -0.00910379f, 0.00408007f, -0.00807973f, -0.01617456f, 0.02964233f, 0.01702642f, -0.04117292f, 0.01269229f, 
    -0.01430355f, -0.01003018f, -0.02016497f, 0.02281055f, -0.02805889f, -0.00609890f, -0.01115001f, 0.00482858f, 
    -0.01803723f, 0.02044967f, 0.00484817f, -0.03163659f, -0.02719986f, -0.02232718f, -0.01416404f, -0.01427432f, 
    -0.00219248f, 0.00200205f, -0.01676875f, -0.02729614f, 0.02722024f, -0.00371983f, -0.02424527f, -0.00894787f, 
    0.03849937f, -0.03133283f, -0.02660012f, -0.00880807f, -0.02415455f, 0.01334382f, -0.01928010f, 0.02098049f, 
    -0.01583721f, -0.00218622f, -0.01658983f, -0.02316999f, -0.03694891f, 0.03944969f, -0.03577822f, 0.01664755f, 
    0.02720973f, -0.03563571f, -0.03524569f, 0.01691791f, 0.00924878f, 0.03342830f, -0.01768685f, -0.02900969f, 
    0.00567243f, -0.01792750f, 0.02926103f, 0.01779532f, -0.03074525f, -0.00662679f, -0.00876519f, 0.01753689f, 
    0.00159902f, 0.01459482f, 0.02311803f, -0.01627370f, 0.00546041f, 0.00324096f, -0.01519868f, 0.00451897f, 
    0.01814890f, -0.01077157f, -0.02104467f, -0.01493479f, 0.02736723f, -0.03187230f, -0.02917055f, 0.00437094f, 
    -0.01607695f, -0.03277776f, -0.01883728f, 0.00636168f, -0.03386753f, -0.01184487f, -0.00707822f, 0.03657355f, 
    -0.01430683f, -0.01795354f, -0.00438374f, -0.00160575f, 0.01212286f, -0.01269090f, -0.01162872f, -0.01133048f, 
    -0.00028064f, -0.03493894f, 0.03250674f, 0.01746149f, -0.02006469f, 0.02359845f, -0.02059713f, 0.02763587f, 
    0.00051927f, -0.04096482f, 0.01598437f, 0.02304397f, 0.00299717f, 0.00518173f, -0.00351864f, -0.03076346f, 
    -0.03850323f, 0.01054105f, -0.01170631f, -0.03828854f, 0.03358285f, 0.02790079f, -0.03189221f, 0.00962598f, 
    0.03350274f, -0.00349055f, -0.01416444f, -0.03539917f, -0.03143270f, 0.00274112f, 0.01349680f, -0.02498912f, 
    -0.02332851f, 0.02955521f, -0.01720955f, 0.00065004f, 0.02389354f, 0.00653152f, -0.00103099f, -0.03389947f, 
    -0.02923859f, -0.00679848f, 0.01321295f, -0.00551407f, -0.04013189f, 0.02486843f, -0.04546336f, 0.00311613f, 
    -0.02103261f, 0.02341809f, -0.03009686f, -0.02692099f, 0.02167131f, -0.03411515f, 0.00582939f, -0.01907714f, 
    -0.03129085f, 0.02113580f, 0.03300231f, 0.01605203f, -0.02101957f, 0.01450527f, -0.02286055f, -0.03774894f, 
    0.02729874f, -0.01962165f, 0.01760464f, -0.02024921f, -0.02634663f, -0.04063899f, -0.02525750f, 0.01452434f, 
    0.01066393f, 0.00587445f, -0.03846767f, 0.01962164f, 0.00859548f, 0.03346381f, -0.00152491f, 0.00703027f, 
    0.01594320f, 0.00223775f, 0.02468381f, -0.00739218f, 0.02025335f, -0.00130487f, 0.00114178f, -0.03895723f, 
    0.00585969f, -0.01307821f, 0.00669530f, 0.01723217f, -0.02336036f, -0.01163244f, -0.00698273f, 0.01910401f, 
    -0.01619876f, 0.02263162f, -0.00957139f, -0.00236553f, -0.00398386f, -0.03404772f, 0.01694386f, 0.02826573f, 
    0.00647521f, 0.00123731f, 0.01500139f, -0.00872893f, -0.01100224f, 0.02372027f, 0.00964777f, 0.01128441f, 
    0.02115675f, -0.02838441f, 0.01762594f, -0.01192307f, -0.01477428f, 0.00954990f, -0.00481776f, -0.02820461f, 
    0.01939051f, 0.00850839f, -0.01617614f, -0.01329631f, 0.02098239f, 0.00647927f, 0.01856279f, -0.03202001f, 
    -0.01387237f, 0.01656326f, 0.01924699f, -0.00996408f, 0.00747627f, 0.01074988f, -0.00194292f, -0.02901659f, 
    -0.03152167f, 0.01361010f, -0.02315627f, 0.03062942f, 0.03108095f, 0.00027430f, 0.00577877f, -0.02669113f, 
    0.03319877f, -0.00309291f, -0.02558053f, 0.02400324f, 0.01156896f, -0.02383939f, 0.00269930f, -0.02459631f, 
    0.00075660f, 0.00810782f, -0.02822213f, 0.04436367f, -0.01421083f, -0.00521448f, -0.01651740f, -0.01688565f, 
    0.02861924f, -0.03341753f, -0.03017669f, -0.02894072f, -0.03899442f, 0.00094151f, 0.02021009f, -0.00721450f, 
    -0.00399293f, 0.00205692f, 0.02803161f, -0.01020006f, -0.02991154f, -0.02078135f, 0.03339725f, 0.02028997f, 
    -0.01902918f, -0.03052412f, -0.00396551f, -0.01778090f, 0.02331544f, 0.03414450f, -0.04027875f, 0.00642350f, 
    -0.00364322f, 0.00844349f, 0.02805671f, -0.01255940f, -0.00961303f, -0.03995806f, 0.01505047f, 0.00317832f, 
    -0.00548208f, -0.03189445f, 0.02544643f, -0.02532613f, 0.02622963f, -0.02958978f, -0.00652198f, -0.03226631f, 
    0.01785606f, -0.01590339f, -0.01407812f, -0.00747922f, -0.00074037f, 0.02408871f, -0.01399350f, 0.01685534f, 
    -0.03729225f, 0.00379378f, 0.00913905f, -0.01111914f, -0.02304135f, 0.01999081f, 0.01226543f, -0.00152245f, 
    -0.02593572f, -0.02161693f, 0.02411245f, -0.02979805f, 0.01505421f, -0.02859552f, -0.00404632f, -0.03266096f, 
    0.00207177f, 0.00191505f, -0.02296579f, 0.02131727f, -0.00165744f, 0.01160729f, 0.02866194f, -0.00742091f, 
    -0.03600422f, -0.02928025f, -0.00275386f, -0.00886687f, -0.00918230f, -0.00427441f, -0.00191634f, -0.03692188f, 
    -0.03587495f, 0.01962993f, -0.02168693f, 0.00710029f, 0.00428935f, -0.03300333f, -0.01220618f, -0.01487744f, 
    -0.01448105f, -0.03292955f, -0.02309625f, 0.01160787f, -0.02128886f, -0.01824366f, 0.01332368f, -0.01267404f, 
    0.00981870f, 0.00560773f, 0.01166621f, 0.01237063f, -0.02416094f, -0.01872677f, 0.01906856f, 0.02164784f, 
    -0.01025445f, 0.00849518f, -0.03976252f, -0.00138716f, 0.00569910f, -0.03242054f, 0.00320338f, 0.00075740f, 
    0.00263173f, 0.02262309f, 0.02060397f, -0.00512615f, -0.02816937f, 0.00521884f, 0.02295499f, -0.02359589f, 
    0.00478038f, -0.03537602f, 0.00664479f, -0.02990011f, 0.01494268f, 0.00842529f, -0.04462954f, -0.02376878f, 
    0.00303812f, -0.02686085f, -0.03659327f, 0.01602795f, -0.03296459f, -0.01767807f, 0.02082663f, -0.00050611f, 
    -0.20816894f, 0.19081008f, -0.10675468f, 0.24288367f, 0.10387723f, 0.09449220f, 0.07517423f, 0.02391078f, 
    0.04948078f, 0.00908620f, 0.13154344f, 0.16757183f, 0.00143514f, -0.08053028f, 0.27620125f, -0.48536605f, 
    0.08398268f, 0.03220697f, 0.02960881f, 0.08465754f, -0.13517396f, 0.01246107f, -0.20982167f, -0.18276857f, 
    0.20497923f, 0.21929254f, 0.24759009f, -0.08175923f, 0.03062772f, 0.11073463f, 0.03837229f, 0.12557238f, 
    -0.15233853f, 0.01034135f, 0.02282733f, -0.21129169f, 0.03025979f, 0.00479641f, -0.03840929f, -0.01274289f, 
    -0.23685050f, 0.26322347f, 0.01997320f, -0.15515429f, -0.00194941f, 0.08836637f, 0.17748384f, 0.00692408f, 
    0.05870038f, -0.01531029f, -0.07188942f, -0.00331094f, 0.02371717f, -0.05885841f, 0.04328716f, 0.25780010f, 
    0.01929508f, 0.01876520f, 0.01060589f, -0.05884859f, -0.16802625f, 0.08808532f, -0.04675937f, 0.15239574f, 
    -0.01878972f, 0.09431119f, 0.02798598f, 0.11032349f, -0.11651804f, -0.05781615f, -0.14665310f, -0.08882683f, 
    0.15056257f, -0.00322268f, 0.11540011f, 0.04566265f, 0.00717269f, -0.01517298f, 0.12128050f, 0.15284038f, 
    -0.04829337f, -0.06029153f, -0.08703317f, -0.22265252f, -0.05717953f, 0.02304671f, 0.16535446f, -0.11128019f, 
    0.10522218f, 0.10369509f, -0.14094324f, 0.11216702f, -0.07741832f, -0.13564248f, -0.07302333f, 0.05339342f, 
    -0.48306790f, 0.06951759f, 0.15546687f, -0.15858972f, -0.09346290f, -0.04016607f, 0.03128406f, -0.09645236f, 
    -0.10973806f, -0.05612690f, -0.13451719f, 0.01931097f, -0.14764625f, 0.09736104f, -0.14070392f, 0.15230523f, 
    0.01342414f, -0.02492308f, 0.16789104f, -0.00529865f, -0.24164952f, -0.16697541f, -0.05386837f, -0.17105599f, 
    -0.12440853f, 0.02932772f, 0.10560784f, -0.30128762f, -0.10125796f, -0.08372956f, 0.00799239f, -0.41128430f, 
    -0.10512131f, 0.06337368f, -0.00468471f, 0.18342054f, 0.03295712f, 0.10428538f, 0.14747930f, 0.13970964f, 
    -0.26330265f, -0.01067848f, -0.08513024f, -0.06151651f, 0.12858465f, 0.02175933f, 0.01990367f, -0.05406353f, 
    0.13883898f, -0.19101687f, 0.13363585f, 0.03763416f, 0.02731911f, 0.07983353f, 0.03125615f, 0.04095655f, 
    0.23543604f, 0.10865956f, 0.05206661f, 0.24658291f, 0.04055899f, 0.21365349f, -0.17340997f, -0.22317505f, 
    -0.01706430f, 0.03817067f, 0.10685877f, 0.07895238f, -0.06306859f, -0.16472861f, -0.14722842f, -0.23511060f, 
    -0.25877351f, 0.04721767f, -0.06747366f, -0.16329370f, -0.04241135f, 0.05530662f, -0.04693159f, -0.19190826f, 
    -0.08234238f, -0.11427238f, -0.15561558f, -0.19544794f, 0.17810461f, 0.15624191f, 0.04208797f, 0.18444014f, 
    -0.02001564f, 0.03092436f, -0.17237662f, -0.12009328f, 0.16028205f, -0.05246946f, 0.12463096f, -0.09676709f, 
    0.14059827f, 0.04630620f, 0.15051560f, -0.11801166f, -0.12216432f, -0.08611835f, -0.17654046f, -0.08051478f, 
    -0.00433521f, -0.12680447f, -0.01781149f, -0.13843161f, 0.18824567f, 0.04170304f, -0.01512492f, -0.00025105f, 
    0.21336064f, -0.05963524f, 0.04285165f, 0.13145036f, -0.05033226f, 0.16636676f, -0.03813585f, 0.07393119f, 
    0.48358336f, 0.05715162f, 0.27094266f, 0.19940515f, 0.06203263f, -0.04283449f, -0.15988223f, -0.09325442f, 
    0.04235740f, 0.02636543f, 0.02618591f, -0.03416786f, -0.11445461f, 0.17245802f, 0.02731391f, 0.09599272f, 
    -0.03198485f, -0.07437329f, 0.04215421f, -0.06768105f, 0.01829270f, 0.10361941f, 0.01298157f, 0.08289003f, 
    -0.08001354f, 0.36960551f, -0.08597194f, 0.10424407f, 0.03335191f, 0.06988547f, 0.02815489f, -0.07193298f, 
    0.05153733f, -0.15007456f, 0.03503355f, 0.17602772f, 0.16836993f, -0.04448380f, -0.01093376f, 0.04063712f, 
    -0.10791036f, -0.03281669f, -0.14928527f, -0.07421406f, 0.15901537f, -0.00963699f, 0.09787676f, 0.11481430f, 
    -0.11358139f, -0.03360103f, 0.29101285f, 0.02425851f, -0.18362264f, -0.08149652f, 0.07899264f, -0.04613421f, 
    -0.03772471f, 0.07790356f, 0.19100247f, 0.26659906f, -0.41423386f, 0.28071710f, -0.13504666f, 0.40367022f, 
    -0.03988395f, -0.13203809f, -0.01621647f, -0.12110837f, 0.08128413f, -0.06163910f, 0.15238596f, -0.06718050f, 
    0.02881782f, -0.15294124f, 0.08859035f, -0.06257462f, -0.20347081f, -0.04216411f, -0.12747237f, -0.14821313f, 
    -0.09592483f, -0.13366795f, 0.10941655f, 0.10273916f, 0.09174792f, -0.13622493f, -0.07153405f, -0.31558433f, 
    0.19191454f, -0.02491830f, 0.01090964f, 0.17619568f, 0.04570465f, 0.03342913f, 0.00927410f, 0.02812136f, 
    0.16158132f, 0.06456120f, 0.02989664f, 0.03906791f, -0.05767365f, -0.08566356f, 0.10391591f, -0.14614026f, 
    -0.05635008f, 0.01187286f, -0.19052592f, 0.00987845f, -0.03044334f, 0.02624756f, 0.02323359f, 0.04590582f, 
    0.22523917f, 0.06078212f, 0.05990350f, 0.05248746f, 0.02418691f, 0.06918457f, 0.10070965f, 0.11481936f, 
    -0.09048936f, -0.01078184f, 0.04298134f, -0.14758414f, 0.06121912f, 0.03208169f, -0.05091503f, -0.14875905f, 
    -0.03896765f, 0.02500065f, 0.03826758f, -0.02340922f, 0.11692740f, -0.10453415f, 0.15981078f, -0.00879556f, 
    -0.11740047f, 0.04446756f, 0.17059273f, 0.12241966f, 0.05791611f, 0.07203022f, -0.05806936f, 0.21089998f, 
    -0.15316154f, -0.04858432f, -0.13309167f, 0.12972513f, 0.04869358f, -0.01355106f, 0.06446183f, 0.12299588f, 
    -0.05542788f, 0.05777263f, 0.09592353f, 0.14578746f, -0.09113792f, -0.03525048f, 0.03949249f, 0.07871916f, 
    0.01748490f, 0.01016997f, 0.11755045f, -0.13029948f, 0.06928251f, 0.02697648f, 0.11858518f, 0.04957146f, 
    -0.08521520f, 0.19010700f, -0.11335584f, -0.00701954f, 0.13185151f, 0.08912344f, 0.01485993f, 0.06603839f, 
    -0.02698039f, -0.13328691f, -0.10175918f, -0.11588604f, -0.31018925f, 0.23323524f, -0.08573043f, 0.17460299f, 
    0.12733014f, -0.14156617f, 0.11475542f, 0.12483059f, -0.20324692f, 0.01649741f, 0.04006547f, -0.10003048f, 
    -0.05044076f, 0.12724507f, -0.14075853f, 0.07790895f, 0.00903512f, 0.14522628f, 0.11057749f, 0.28003302f, 
    0.04829648f, 0.07684896f, 0.03824247f, -0.01102637f, 0.48460171f, -0.07113405f, 0.24759667f, 0.14988399f, 
    -0.09007271f, -0.11535813f, -0.15185213f, -0.11200619f, 0.11087563f, 0.04121801f, 0.01943806f, 0.20273663f, 
    0.31820485f, 0.06605487f, -0.04310557f, 0.05134008f, 0.07481352f, -0.10758604f, -0.08967699f, 0.07950862f, 
    -0.01862724f, -0.11784925f, -0.03328645f, -0.13153137f, -0.12358476f, -0.09778216f, 0.01231906f, 0.15787114f, 
    0.10634734f, -0.01616355f, 0.11351924f, -0.10896382f, 0.31144699f, 0.14810358f, 0.16582413f, 0.26523405f, 
    0.08507065f, 0.36297056f, 0.08695213f, -0.18125848f, 0.04931924f, -0.10770347f, 0.07862677f, 0.16464736f, 
    -0.01127820f, 0.04774529f, 0.12197924f, -0.01729481f, -0.33489627f, 0.16816117f, -0.14266567f, 0.24176514f, 
    0.04652121f, -0.02789568f, 0.05651057f, 0.23018086f, 0.01092006f, -0.13240445f, -0.12483728f, -0.14635214f, 
    -0.43029547f, 0.31425276f, 0.26952845f, -0.14861555f, 0.04072986f, -0.10220277f, 0.01888763f, 0.10083511f, 
    0.09120732f, 0.04055259f, -0.01184828f, -0.00729948f, 0.30745563f, 0.07691999f, 0.02876365f, 0.00273058f, 
    0.06821938f, 0.11689707f, -0.07218762f, 0.11628486f, -0.09068089f, 0.07924637f, -0.05678333f, 0.13951057f, 
    0.40525329f, 0.20395657f, 0.15728807f, 0.31856164f, -0.01393018f, -0.08823320f, -0.11951194f, -0.12614392f, 
    0.10428686f, -0.03255006f, -0.07541889f, 0.15453747f, -0.05888713f, -0.00055761f, -0.08964109f, -0.07640622f, 
    0.10895528f, -0.18895680f, -0.08413478f, -0.04203397f, 0.14061171f, -0.14711258f, 0.07592838f, 0.18216898f, 
    0.17202283f, -0.13572027f, -0.04366368f, -0.06860666f, 0.04539238f, -0.07529024f, 0.01884542f, 0.18624632f, 
    0.14264950f, 0.11245165f, 0.03540105f, 0.04755151f, -0.22768639f, -0.04943320f, -0.00257597f, -0.03293106f, 
    0.08945514f, -0.10708170f, 0.11036289f, 0.12421402f, 0.09451181f, -0.06470533f, 0.06410339f, 0.06205286f, 
    0.05013247f, -0.24708715f, 0.27791500f, -0.16307536f, -0.06847727f, 0.01591130f, -0.13034125f, -0.24610732f, 
    0.09024255f, 0.10603901f, 0.03722239f, -0.00176202f, -0.13146740f, 0.07043993f, -0.16543871f, -0.12014215f, 
    0.02154878f, -0.04088029f, -0.00009348f, -0.05607708f, 0.00641786f, -0.20795734f, 0.01734689f, -0.13127181f, 
    0.24998710f, 0.05001567f, 0.09842923f, 0.14341204f, 0.04084042f, 0.00722089f, 0.07066381f, 0.24958397f, 
    0.14937720f, 0.13468529f, 0.13752086f, 0.09724568f, 0.10928149f, 0.05272620f, 0.03560315f, 0.01571524f, 
    0.06773318f, -0.04094139f, -0.07198346f, 0.20113115f, 0.17854618f, -0.00199812f, 0.10899612f, 0.05796657f, 
    0.13563347f, -0.07180741f, 0.07423729f, 0.08105209f, -0.05123137f, -0.07402091f, -0.19852383f, -0.05488005f, 
    -0.22993600f, -0.11884031f, -0.11560926f, -0.20510210f, 0.14174558f, 0.01131650f, 0.05366615f, 0.23730195f, 
    -0.00730967f, -0.02834690f, 0.04248997f, -0.06646515f, 0.02413199f, -0.12936865f, -0.10110673f, -0.01299037f, 
    0.21723494f, 0.09115761f, -0.05010555f, 0.05454031f, 0.06904098f, 0.18768321f, -0.11914451f, 0.22776490f, 
    0.10017095f, 0.06881385f, 0.16187595f, 0.19927102f, -0.49405035f, 0.13043208f, -0.10879464f, 0.14348553f, 
    0.05881535f, 0.08027349f, -0.01970894f, 0.06532504f, 0.02016831f, -0.04281188f, -0.16364947f, -0.02939873f, 
    0.17384063f, 0.08631946f, 0.00142170f, -0.25786236f, -0.11418720f, 0.05003183f, -0.01710805f, -0.14964701f, 
    -0.14504740f, -0.00806501f, -0.09418257f, -0.26678872f, 0.16368613f, -0.09104536f, 0.14311711f, 0.02144998f, 
    -0.03473292f, -0.02013805f, 0.04053041f, 0.06384142f, -0.06904037f, -0.06865501f, 0.02662914f, -0.01516723f, 
    0.04425162f, 0.07921966f, 0.01930850f, -0.00418615f, -0.16846313f, 0.10890885f, -0.12628342f, -0.14147232f, 
    0.04956003f, 0.10315422f, 0.07138756f, 0.01843172f, 0.11561563f, -0.12805533f, 0.01986383f, -0.08962344f, 
    0.00825712f, 0.01052947f, 0.00191709f, 0.05970274f, -0.09244101f, -0.18790576f, -0.05582710f, -0.08939335f, 
    0.03399928f, 0.10729803f, -0.02332906f, 0.00841656f, -0.00233242f, 0.11839398f, 0.08874667f, 0.07400971f, 
    -0.06780069f, -0.05925588f, -0.01399399f, 0.08694570f, -0.01335280f, -0.09267285f, 0.27820861f, -0.52635562f, 
    -0.05017155f, 0.05206682f, -0.03806122f, -0.00275343f, -0.14702758f, 0.04277153f, -0.21131742f, -0.28466785f, 
    -0.08993553f, 0.01662482f, -0.03355486f, -0.14080511f, -0.00496156f, -0.07577990f, -0.10732604f, -0.06973524f, 
    0.00605627f, -0.04861813f, -0.09146743f, -0.11774947f, 0.07009204f, -0.02380550f, -0.09893522f, -0.09596549f, 
    0.03255537f, -0.04844974f, -0.08658139f, -0.21652204f, -0.03081240f, -0.03341391f, -0.18566442f, -0.20978002f, 
    -0.31628755f, 0.14062244f, 0.02407814f, -0.04147505f, -0.01645879f, 0.06854822f, 0.06615610f, 0.13438064f, 
    0.16420226f, -0.06701288f, 0.13265558f, 0.09235927f, 0.04842687f, -0.14125524f, 0.17012326f, -0.02173327f, 
    0.01673985f, 0.01693023f, -0.10140418f, -0.16818003f, -0.08166152f, -0.05224270f, -0.12138703f, -0.23841757f, 
    0.56293613f, -0.12482298f, 0.14369248f, -0.01497561f, 0.02911961f, 0.06449256f, 0.11834371f, 0.13710932f, 
    0.01952425f, -0.03826994f, -0.04992176f, 0.02972233f, 0.03511247f, 0.29725930f, -0.25113434f, 0.03425224f, 
    0.06856307f, 0.03461188f, 0.03569555f, 0.02800083f, 0.01808583f, 0.06295382f, 0.11351746f, -0.04121771f, 
    -0.07916775f, 0.13932112f, -0.11904180f, -0.06027539f, -0.04678750f, 0.00757422f, -0.00650237f, -0.06886807f, 
    -0.00327934f, -0.00786832f, -0.02588993f, -0.00051936f, 0.23608916f, -0.00063004f, -0.15788367f, -0.30705926f, 
    -0.18818609f, -0.08809152f, -0.00506297f, -0.16159593f, 0.16299230f, -0.05929998f, -0.05268034f, 0.03471173f, 
    0.29273990f, -0.01831613f, -0.00353933f, 0.08474148f, 0.08437608f, 0.04318981f, 0.00959289f, 0.03781829f, 
    0.02478885f, 0.04391521f, 0.15365709f, 0.07815113f, 0.05201431f, 0.00805525f, 0.10692755f, 0.08381313f, 
    -0.04119144f, -0.11676189f, 0.12353792f, 0.01367723f, 0.04965072f, 0.00029466f, 0.08796757f, 0.09304938f, 
    -0.05124591f, 0.22451366f, 0.23316042f, 0.00477017f, -0.07304721f, -0.08583835f, -0.08664638f, -0.07979504f, 
    -0.06091992f, -0.04550900f, -0.03405616f, -0.02826091f, 0.00592828f, 0.20385265f, -0.12968567f, 0.16919051f, 
    -0.02843308f, -0.09324139f, 0.08204042f, -0.01320860f, 0.02016309f, 0.11315822f, 0.01209347f, 0.03952530f, 
    -0.23186176f, -0.11887307f, 0.12220331f, 0.28470841f, -0.02365366f, -0.04368233f, 0.02539454f, 0.05444877f, 
    0.03679319f, 0.12224383f, 0.11634391f, 0.15628609f, -0.12105007f, -0.08260866f, -0.04108785f, 0.01037756f, 
    -0.00473789f, 0.02804947f, -0.00967397f, 0.14327316f, 0.08415543f, 0.02918009f, 0.15811823f, 0.10312497f, 
    -0.26293561f, 0.02976054f, -0.16036110f, 0.07241500f, -0.19197388f, 0.04043429f, -0.04965796f, 0.01880661f, 
    -0.07605348f, 0.04476241f, 0.16532926f, 0.06997899f, -0.16617478f, 0.10619562f, -0.17322782f, -0.28165630f, 
    -0.03292299f, -0.01867637f, -0.12083979f, -0.07260102f, 0.04127006f, -0.02001799f, 0.07570651f, 0.05564763f, 
    -0.05957259f, 0.10728937f, 0.07498228f, 0.00773379f, -0.06710392f, -0.03745394f, -0.03195102f, -0.05486990f, 
    -0.04081465f, 0.05241042f, -0.19353864f, -0.12981239f, -0.10821570f, -0.11843155f, 0.07923453f, -0.03243506f, 
    0.06608635f, 0.03401444f, 0.01694296f, 0.08497106f, -0.02303274f, 0.17716093f, 0.01872158f, 0.08296480f, 
    -0.37983373f, 0.00189017f, 0.02986876f, 0.05820188f, 0.03820204f, 0.05975326f, -0.11879262f, 0.01894290f, 
    0.01888377f, 0.04594022f, 0.01796088f, 0.15857249f, 0.17433731f, 0.20975614f, -0.13561638f, -0.17180614f, 
    0.06108400f, -0.10493758f, 0.05173961f, -0.05979574f, -0.01819383f, 0.12806946f, -0.01004593f, 0.09303598f, 
    -0.12576009f, -0.07618967f, -0.01055525f, -0.02813210f, 0.01160187f, 0.04894780f, 0.00104433f, 0.01303299f, 
    0.18640448f, 0.14135604f, 0.05808211f, 0.08145910f, -0.19671205f, 0.04074584f, -0.14214191f, 0.01497810f, 
    0.09504103f, 0.05854856f, 0.00902019f, -0.05125628f, 0.05885012f, -0.05259202f, 0.04861118f, -0.03069465f, 
    0.13313656f, 0.08602978f, -0.31083596f, -0.30310649f, 0.15812255f, 0.10228897f, 0.07630520f, -0.12220926f, 
    0.04792203f, -0.06063512f, 0.06936052f, -0.04165098f, 0.09415642f, 0.28612512f, -0.11565556f, -0.12920511f, 
    0.10556146f, 0.02016729f, 0.03679353f, 0.03903235f, 0.09948799f, -0.05053021f, 0.07826212f, 0.01572604f, 
    -0.08691529f, -0.09112226f, 0.30175120f, -0.06362002f, 0.08657043f, -0.10359021f, -0.00394922f, -0.01718227f, 
    0.03697265f, 0.06484202f, -0.06719807f, 0.07127164f, 0.02766088f, 0.02572897f, 0.06241005f, 0.05711115f, 
    0.06108542f, 0.03205441f, -0.00139719f, 0.02465094f, 0.02491880f, 0.04976664f, -0.17790918f, -0.00819336f, 
    -0.11485996f, -0.20956884f, -0.11668788f, 0.00215841f, 0.05334799f, 0.02450714f, -0.09234888f, 0.20780359f, 
    -0.15039887f, -0.15433832f, 0.08766804f, -0.08003424f, 0.24209149f, -0.12846170f, 0.45697382f, -0.03476610f, 
    0.05077509f, 0.10438997f, 0.04808568f, 0.18964031f, -0.07132083f, 0.04086869f, -0.08309043f, 0.08755638f, 
    -0.24683805f, 0.16420579f, 0.11889016f, 0.13057470f, 0.06883947f, -0.08561771f, 0.03668086f, -0.00846902f, 
    -0.04410829f, 0.15246354f, 0.01512213f, -0.02067675f, 0.07486031f, 0.19414298f, -0.01131311f, 0.06755488f, 
    0.00486292f, 0.04957186f, -0.02754973f, -0.02628840f, -0.11487541f, 0.05296068f, -0.02219251f, -0.00953414f, 
    -0.31020868f, -0.18803774f, 0.03893097f, 0.13888370f, -0.07153539f, 0.03762060f, 0.04164984f, 0.15519336f, 
    0.02377781f, 0.01144813f, 0.06245676f, 0.01928193f, 0.01980102f, 0.04001372f, -0.03324346f, 0.13857234f, 
    0.03151279f, -0.00627112f, -0.07197741f, -0.05595271f, 0.09118918f, 0.05888657f, -0.08307549f, -0.30018476f, 
    -0.17387749f, -0.00237338f, 0.04527407f, 0.26245058f, 0.00505108f, -0.00394370f, 0.02300533f, 0.05757197f, 
    0.04847892f, 0.02451118f, -0.02963410f, 0.09976563f, -0.27580744f, 0.14281379f, 0.10219281f, 0.07188264f, 
    -0.15980038f, -0.07778213f, 0.00061549f, -0.09922547f, -0.09863905f, -0.08517119f, -0.00975445f, -0.02174811f, 
    0.05293934f, 0.09705061f, 0.07793912f, 0.13208994f, 0.11447998f, 0.05172279f, 0.06871669f, 0.24468358f, 
    0.00912777f, 0.07034221f, 0.02379231f, -0.01642556f, -0.16210681f, 0.03780104f, 0.06527577f, -0.02750191f, 
    -0.03081541f, -0.12262757f, -0.03841768f, 0.02009537f, -0.12764981f, -0.11305906f, -0.06052785f, -0.09731730f, 
    0.18845358f, 0.07210279f, 0.19707052f, 0.10075779f, -0.09396247f, 0.01696833f, 0.02105907f, -0.03818895f, 
    -0.06901588f, 0.07193290f, 0.08288395f, 0.14136805f, -0.16236871f, 0.05954762f, 0.42052096f, 0.18682536f, 
    -0.12180465f, 0.05533005f, -0.06120868f, 0.05607840f, -0.01099808f, 0.03240753f, 0.00355501f, 0.06010789f, 
    -0.12681316f, -0.17340949f, -0.13001922f, 0.14587605f, -0.01961205f, 0.00930790f, 0.05461149f, -0.13564870f, 
    -0.01980738f, 0.00880026f, -0.03645553f, 0.17250088f, -0.18171327f, -0.22562858f, -0.27483132f, -0.12031107f, 
    0.06557022f, 0.01906746f, 0.07070292f, 0.00314925f, -0.07695905f, 0.01259935f, 0.04012565f, -0.03412823f, 
    0.10508370f, -0.24024796f, -0.06703625f, 0.16230913f, -0.00584403f, 0.11533631f, 0.05010498f, 0.07615110f, 
    -0.05216829f, -0.00296653f, -0.00454257f, 0.01559127f, -0.17305337f, -0.11926055f, 0.04374260f, 0.06026290f, 
    -0.04502426f, -0.01288641f, -0.03282527f, 0.02296123f, -0.18456019f, -0.13024800f, -0.10130113f, -0.21834426f, 
    -0.02778512f, -0.26510850f, -0.16881086f, 0.18426098f, 0.09930607f, 0.11584867f, 0.15139809f, 0.04870395f, 
    -0.11800534f, 0.04229207f, 0.06750872f, 0.05886472f, -0.25458664f, -0.01946521f, 0.24765635f, -0.00702256f, 
    -0.09379147f, 0.01193686f, -0.11687128f, 0.08086893f, -0.08805300f, -0.05029549f, 0.00978976f, 0.08046287f, 
    -0.28734165f, -0.33603954f, 0.15652336f, 0.08419496f, 0.04364903f, 0.05948155f, -0.12169536f, 0.17855348f, 
    -0.26968676f, 0.01647335f, -0.03575496f, -0.02517697f, -0.17541027f, 0.20720011f, -0.04046649f, 0.23927510f, 
    0.06061016f, 0.07263156f, 0.12220211f, 0.11040631f, 0.05655551f, 0.13639621f, 0.00928996f, 0.05806715f, 
    -0.04133004f, -0.32237187f, -0.09059486f, -0.28659534f, -0.00646598f, 0.02984508f, -0.01883837f, -0.01801253f, 
    0.00537453f, -0.03198922f, 0.04582912f, 0.02103954f, -0.12576325f, 0.15352234f, 0.04231639f, -0.11541659f, 
    -0.25234565f, -0.10016664f, -0.12539634f, -0.04593883f, -0.22713044f, -0.06340972f, -0.09431566f, -0.09723067f, 
    0.08824579f, 0.14350456f, -0.22983457f, -0.04338657f, 0.00161334f, 0.06314652f, -0.08699573f, 0.00157506f, 
    -0.07390383f, -0.02825032f, -0.00027097f, -0.00297241f, -0.01078985f, 0.18405525f, 0.13275686f, -0.07612166f, 
    -0.18263726f, -0.11321519f, -0.11451200f, -0.04056849f, -0.12382647f, -0.08457590f, -0.08736330f, -0.00084058f, 
    -0.02808952f, 0.26667687f, -0.11478208f, -0.05025877f, -0.03448005f, 0.03787169f, -0.02868306f, -0.07663528f, 
    0.08572744f, 0.16730972f, 0.00242565f, -0.02691717f, 0.22292103f, -0.04351746f, 0.23496060f, -0.00060934f, 
    0.06179477f, -0.10633343f, -0.00960254f, 0.04093195f, 0.01167003f, 0.09027459f, 0.13869168f, -0.09318983f, 
    -0.09356720f, 0.00978992f, -0.09384356f, -0.00268672f, -0.05282917f, 0.08767457f, 0.04778134f, -0.03638201f, 
    -0.12554041f, -0.14188923f, 0.00957142f, -0.01767082f, 0.04906064f, -0.03472997f, -0.11148068f, -0.06621590f, 
    -0.02269455f, -0.08407771f, 0.03713667f, -0.08817694f, -0.03447814f, -0.01183891f, -0.10269179f, -0.08459127f, 
    -0.04924136f, 0.09565269f, 0.02861238f, -0.00916001f, -0.09304920f, -0.01874211f, -0.01513061f, -0.05224704f, 
    -0.07965004f, 0.07931506f, 0.10677901f, 0.02198617f, -0.09032674f, -0.00311970f, 0.02822771f, -0.17249289f, 
    0.05134681f, 0.04739561f, 0.09614310f, 0.09303660f, 0.16871659f, -0.00569975f, -0.01852048f, 0.04132942f, 
    -0.06109505f, 0.03937347f, -0.12214807f, -0.17993174f, 0.00560315f, -0.10253993f, 0.04768839f, -0.06303793f, 
    -0.06219946f, -0.01347943f, -0.08454984f, -0.03396203f, -0.14322242f, 0.08821411f, 0.14104536f, 0.13420595f, 
    0.08314802f, 0.06082347f, -0.06537866f, 0.16571905f, -0.07823326f, 0.00099457f, 0.11516792f, 0.06854299f, 
    -0.23689164f, -0.10442288f, -0.07629082f, -0.01359314f, -0.19430839f, -0.05385264f, -0.10115132f, -0.06041237f, 
    -0.02880626f, 0.00884389f, 0.04504635f, 0.05048933f, -0.30266312f, 0.59598523f, -0.20306434f, 0.12342290f, 
    -0.16958971f, -0.03755632f, 0.05692262f, 0.02410141f, -0.09071815f, -0.01323440f, 0.04224965f, 0.01951224f, 
    -0.07396880f, 0.41647336f, -0.16371714f, -0.19233331f, -0.02404667f, 0.01001955f, 0.01294075f, -0.14668179f, 
    0.07784355f, -0.15136625f, 0.16479419f, 0.06162550f, -0.07000789f, -0.06968427f, -0.17535134f, -0.10374746f, 
    0.05766831f, -0.05690951f, -0.02713327f, 0.07363751f, 0.06511595f, 0.07144894f, 0.05770203f, 0.17708395f, 
    -0.04211700f, -0.14240456f, -0.08011898f, -0.06506836f, -0.07151140f, 0.01878240f, 0.00827884f, 0.07682836f, 
    0.03917402f, -0.05413178f, 0.04567450f, 0.11992864f, -0.13162863f, -0.03796399f, -0.10441819f, 0.16296180f, 
    -0.06781518f, -0.05518735f, 0.02745165f, -0.06681145f, 0.06818966f, -0.07297354f, 0.25989428f, 0.09836558f, 
    -0.32677841f, -0.06387334f, 0.04515155f, 0.08503813f, -0.06804527f, -0.03344235f, 0.02117344f, 0.07688957f, 
    0.07958867f, 0.08516180f, 0.06521917f, 0.06002228f, 0.24659003f, 0.00593519f, -0.01762900f, -0.20493975f, 
    0.06847225f, 0.06360687f, 0.18098146f, -0.03840178f, 0.12880386f, 0.03411514f, 0.15547855f, 0.00547027f, 
    -0.05976793f, 0.18918495f, 0.12584759f, 0.37126207f, -0.10392474f, 0.02209889f, -0.09647669f, 0.18945576f, 
    -0.06196976f, 0.10399465f, 0.10476755f, -0.06580154f, 0.32713369f, 0.15254968f, -0.15316692f, -0.03087381f, 
    0.08632541f, 0.05809847f, 0.01494601f, 0.12890176f, 0.18406218f, 0.12538087f, 0.16568962f, 0.21519823f, 
    0.01640785f, 0.00882083f, 0.10092982f, 0.09859157f, 0.07775084f, -0.13164224f, 0.15253623f, 0.02232839f, 
    0.10156963f, 0.01009001f, -0.05980174f, -0.05486152f, -0.20263955f, 0.08806252f, -0.03318955f, -0.00433973f, 
    -0.06109897f, 0.19757277f, -0.09192895f, 0.05266274f, 0.03023585f, 0.10637338f, 0.06513588f, 0.03137445f, 
    -0.19907641f, -0.16816224f, 0.07266414f, 0.00967242f, -0.06501553f, 0.00466654f, 0.11595412f, -0.00436673f, 
    0.06501836f, 0.06796386f, -0.03335394f, 0.08296379f, -0.20050211f, -0.11262330f, -0.08069946f, 0.02083120f, 
    -0.06808908f, -0.09573959f, -0.17561734f, -0.06843437f, 0.08531840f, -0.05698606f, 0.00157672f, -0.04393925f, 
    -0.05522208f, 0.12580286f, 0.03727388f, -0.08450056f, 0.06746224f, -0.02090282f, 0.13817972f, -0.06803077f, 
    -0.13926195f, -0.02154315f, -0.00743209f, 0.13323285f, -0.01648215f, -0.02658235f, -0.04044784f, -0.15326126f, 
    0.12479066f, 0.06727085f, 0.18620977f, 0.01131770f, 0.01935602f, 0.00776947f, 0.06424008f, -0.01889677f, 
    -0.17061229f, -0.09621756f, -0.09873424f, -0.04192235f, -0.12778147f, -0.01770759f, 0.01142011f, 0.01129284f, 
    -0.04567490f, -0.01874130f, -0.01736164f, -0.03622535f, -0.11007955f, 0.02127647f, -0.07720432f, -0.02679645f, 
    -0.03552061f, -0.07160928f, 0.17161883f, 0.02407804f, 0.09861119f, 0.04690247f, 0.03631511f, -0.08269969f, 
    0.34074709f, 0.05810994f, 0.06194643f, -0.28513762f, 0.06610115f, -0.09981783f, -0.04847925f, 0.05438092f, 
    0.14850171f, 0.12794425f, 0.10737147f, 0.06062074f, 0.09002549f, -0.00989561f, 0.15303969f, -0.23154075f, 
    -0.10675914f, 0.01807065f, -0.02640799f, 0.12775895f, 0.19366950f, 0.07137378f, 0.01573507f, 0.16966981f, 
    0.02508934f, -0.01975494f, 0.03792472f, 0.14628342f, -0.05530973f, -0.04203746f, -0.07737171f, 0.01140785f, 
    0.23053154f, 0.12589940f, 0.09794248f, -0.07400987f, -0.42457494f, -0.29968724f, -0.17032449f, 0.09969858f, 
    0.01650508f, -0.11711621f, -0.18558262f, -0.07978892f, 0.11143093f, -0.03802183f, 0.10091632f, 0.02918737f, 
    -0.14198072f, -0.08309873f, -0.11647422f, -0.21150866f, -0.06496610f, -0.07358979f, 0.03165351f, 0.02811808f, 
    -0.02077691f, -0.04867861f, 0.00962028f, -0.16867940f, -0.06802360f, 0.05081928f, 0.13856244f, 0.01909721f, 
    0.07783382f, 0.05588238f, 0.14978564f, 0.09258336f, 0.03325128f, -0.00906426f, 0.08652075f, 0.12199138f, 
    0.07893413f, -0.05647515f, 0.08915383f, -0.13981241f, 0.07966290f, 0.04449594f, -0.02809331f, 0.04822862f, 
    0.13505326f, 0.09184629f, 0.08699188f, 0.08981098f, -0.38599911f, 0.02762349f, -0.04478838f, 0.42819753f, 
    -0.01738217f, -0.22300601f, -0.01834479f, -0.07005178f, 0.03799023f, 0.12618926f, 0.02311431f, -0.03684036f, 
    -0.11150862f, -0.02001128f, 0.00708591f, 0.07375307f, 0.06600887f, -0.03713996f, -0.05648026f, -0.01410914f, 
    0.18723831f, 0.07764213f, 0.00791927f, 0.12351011f, -0.02197246f, -0.00376700f, 0.10932732f, 0.03567778f, 
    0.03000738f, 0.12768422f, 0.05902975f, 0.03380200f, 0.16543770f, -0.10667631f, 0.19694525f, -0.02434038f, 
    -0.38542825f, -0.02955650f, 0.10092554f, 0.20730443f, 0.14184804f, -0.01039242f, 0.01068841f, 0.19702062f, 
    0.09230096f, 0.03471181f, -0.00242994f, -0.12226869f, 0.01853669f, 0.03890073f, 0.26564738f, 0.07594453f, 
    0.16517776f, 0.07893557f, -0.00837130f, 0.17489572f, 0.22521248f, -0.03365935f, 0.07041666f, 0.09392759f, 
    0.10550924f, -0.09407073f, 0.12621592f, 0.05143635f, 0.10924737f, -0.16138385f, 0.16505273f, 0.20425539f, 
    0.02973736f, 0.19040476f, 0.00295738f, -0.01160503f, 0.03879518f, 0.01438974f, 0.01538116f, 0.08888735f, 
    0.02588540f, 0.11658479f, 0.03131821f, 0.06815973f, 0.09148092f, -0.05759985f, 0.04456203f, -0.02232145f, 
    0.03797420f, -0.02390454f, -0.00175014f, -0.09659149f, -0.06846447f, -0.03749180f, 0.04374875f, 0.01327478f, 
    0.01090203f, -0.05463256f, -0.05498756f, -0.14597443f, 0.41038325f, -0.00741296f, -0.04107190f, -0.07559592f, 
    0.23532076f, 0.02125634f, 0.05673764f, -0.02988330f, -0.05057831f, -0.02607541f, -0.03495271f, -0.05751196f, 
    0.20529665f, 0.18210037f, 0.00492063f, 0.05050059f, 0.12237882f, 0.05700475f, -0.13733988f, 0.05226953f, 
    0.22978577f, 0.18634096f, -0.00634089f, -0.01852365f, -0.21010965f, 0.07827514f, 0.07530798f, 0.02328467f, 
    0.07665449f, 0.00780568f, 0.11493757f, 0.12465577f, -0.02147743f, -0.17024237f, 0.06403989f, 0.07403818f, 
    -0.02621771f, 0.08745407f, 0.18345916f, -0.16525151f, -0.04392126f, 0.00118403f, -0.00071629f, 0.22575733f, 
    -0.02060570f, 0.12417701f, 0.06687465f, -0.07583996f, 0.01639861f, -0.03402806f, 0.08240407f, -0.11337935f, 
    -0.18853858f, -0.10499043f, -0.04905720f, 0.05871607f, 0.00571872f, -0.00106265f, -0.18428293f, -0.18594129f, 
    0.34727532f, 0.12424453f, 0.01448955f, -0.10956421f, -0.04146485f, 0.06027224f, 0.07381473f, 0.11301370f, 
    0.09645105f, -0.05995000f, -0.06329980f, 0.10056203f, 0.11652539f, 0.02099794f, -0.19716208f, -0.04906505f, 
    -0.04628969f, -0.05654844f, 0.00842865f, -0.04487481f, 0.03086353f, -0.04702977f, 0.03718429f, -0.13724431f, 
    0.19364488f, 0.08306240f, 0.23062588f, 0.06912514f, 0.15746054f, -0.02334258f, -0.02918915f, 0.14107499f, 
    0.00072897f, 0.02239158f, 0.09044428f, -0.06310952f, 0.20163894f, -0.00123442f, -0.16401154f, -0.09894671f, 
    0.03808537f, -0.08712450f, 0.00452593f, 0.01302189f, 0.06265562f, -0.01743899f, 0.04543785f, -0.23334199f, 
    -0.06294106f, -0.16469277f, 0.08302823f, 0.24798425f, 0.15977012f, 0.12232615f, 0.02439756f, 0.14206792f, 
    0.07353420f, 0.12337060f, 0.04698284f, 0.17507543f, 0.45257473f, -0.10094348f, 0.25486645f, -0.17619891f, 
    -0.12647626f, -0.01481706f, 0.04159578f, 0.05403642f, 0.14658271f, -0.06402057f, -0.03021369f, 0.12934020f, 
    -0.00220590f, 0.04732797f, -0.00511913f, 0.01886526f, -0.01258942f, 0.02106515f, 0.02341833f, -0.13050580f, 
    0.07160224f, -0.04733014f, 0.01745593f, 0.03080740f, -0.40068057f, -0.00953484f, -0.03119153f, -0.03268994f, 
    -0.07037698f, -0.05755818f, -0.05454328f, 0.00890454f, 0.01623058f, 0.05572067f, 0.13207567f, -0.04121066f, 
    -0.01596297f, -0.00037991f, 0.12213896f, 0.13104157f, 0.03366446f, 0.13350797f, 0.10632022f, 0.06144451f, 
    0.00523277f, 0.04990211f, 0.10337467f, 0.08030951f, 0.05873090f, -0.05175116f, -0.03648019f, -0.16694990f, 
    -0.03541524f, -0.05676357f, -0.03777803f, 0.03002717f, -0.16750048f, -0.24230693f, -0.17201240f, -0.31083643f, 
    0.03569113f, -0.15221918f, 0.21924572f, 0.20945169f, -0.02426418f, 0.09963173f, 0.06135225f, 0.03660697f, 
    0.03903828f, 0.03150484f, -0.04530304f, 0.20723279f, 0.16058293f, -0.22731444f, -0.04627695f, -0.19974409f, 
    -0.11180870f, -0.12546758f, -0.08053497f, 0.00621693f, 0.01171926f, -0.07900249f, -0.02442693f, -0.05166085f, 
    -0.02534484f, -0.18380992f, -0.14289452f, 0.03219222f, -0.02056804f, -0.04170463f, -0.01537942f, 0.08503059f, 
    -0.16507003f, -0.10396217f, -0.08496583f, 0.01350655f, -0.06467759f, 0.01835461f, 0.02583815f, 0.08380652f, 
    0.09381289f, 0.04149454f, 0.02038000f, -0.01152799f, 0.10391484f, 0.01296875f, 0.15631716f, -0.06434101f, 
    -0.30988944f, -0.07162200f, 0.09738019f, 0.15429121f, 0.05547251f, -0.06618571f, -0.12566498f, -0.03089450f, 
    0.00214023f, -0.02263943f, 0.15936199f, -0.04776026f, 0.07331595f, -0.05050430f, -0.01583618f, -0.03906390f, 
    -0.14149411f, -0.00569628f, -0.08219859f, 0.01805606f, -0.02116741f, -0.01311505f, 0.05698909f, -0.11943036f, 
    -0.22594135f, 0.16146453f, 0.04588374f, 0.06313675f, 0.06286225f, -0.03317831f, -0.07480917f, 0.09732167f, 
    -0.04375793f, -0.10918173f, 0.07329795f, 0.00564373f, 0.01203016f, -0.05525254f, -0.03453600f, -0.09697432f, 
    -0.11451892f, -0.09764436f, -0.01705103f, 0.03618769f, -0.05998399f, -0.05791279f, -0.11340591f, -0.12126406f, 
    -0.08192457f, 0.07132112f, -0.14959894f, 0.28185233f, -0.09095816f, -0.05746393f, -0.10702986f, 0.09064256f, 
    0.03533168f, -0.01594288f, 0.01325913f, 0.06098681f, 0.17671750f, -0.12265824f, 0.11705024f, 0.24607505f, 
    -0.11094715f, 0.09075563f, -0.10019464f, -0.00628455f, 0.00021542f, 0.19683747f, 0.04798164f, 0.03923841f, 
    -0.16757761f, -0.02399722f, 0.03907460f, 0.03610755f, -0.04305460f, 0.00920296f, 0.02335465f, -0.12349162f, 
    -0.20739850f, -0.01668058f, -0.03171724f, -0.15880884f, -0.15217127f, 0.05081980f, 0.16843030f, -0.00054976f, 
    -0.00570380f, 0.05228560f, 0.09129322f, -0.00128303f, -0.01284678f, 0.04368340f, 0.00970105f, -0.04020074f, 
    -0.10002860f, -0.11730881f, 0.00325815f, -0.31420073f, -0.17147930f, 0.02140084f, -0.05730573f, -0.12926988f, 
    -0.01828354f, 0.03626460f, 0.01622883f, -0.00363510f, -0.17988366f, 0.01912631f, 0.11396367f, -0.06222949f, 
    0.09470808f, -0.05307530f, 0.04345197f, 0.11984631f, 0.13822994f, 0.15404417f, 0.02287922f, 0.08827833f, 
    -0.32840735f, 0.10082030f, 0.14715488f, 0.01950715f, -0.02004192f, -0.07495767f, 0.07329886f, -0.00431704f, 
    0.09458430f, -0.06473976f, -0.16214721f, -0.12790382f, 0.29074308f, -0.03569680f, -0.05954583f, -0.08082403f, 
    0.06452595f, -0.01700011f, 0.09491894f, 0.07860400f, 0.02760094f, -0.00364577f, -0.00413349f, 0.11826538f, 
    -0.18781607f, -0.19326420f, -0.07767192f, 0.09294970f, 0.00696882f, -0.03984673f, -0.06130426f, -0.11800171f, 
    0.22242095f, 0.09016035f, 0.16200656f, 0.20709090f, -0.12784997f, 0.16853206f, -0.02775872f, -0.06854504f, 
    -0.05756896f, -0.04607800f, -0.03479024f, 0.14139768f, -0.02515475f, -0.05295449f, -0.05235736f, -0.13188615f, 
    -0.21922384f, -0.16849647f, 0.07164244f, 0.24098304f, -0.05915798f, 0.01647981f, -0.05930382f, 0.10876381f, 
    0.03563332f, -0.10316384f, -0.12467917f, 0.01817195f, -0.10358396f, 0.03000439f, 0.04381967f, 0.04982273f, 
    -0.14504151f, 0.00217927f, 0.07739066f, 0.20211630f, 0.07917740f, 0.01652134f, -0.00327986f, -0.02412961f, 
    -0.03032537f, 0.10923593f, 0.20591247f, -0.08045022f, 0.04496124f, 0.02397833f, 0.17594062f, 0.12938997f, 
    0.11955162f, -0.03888214f, -0.03328383f, -0.02021725f, -0.03619295f, -0.23226129f, -0.14094625f, 0.16514395f, 
    -0.01851529f, 0.09028028f, -0.04971239f, -0.02601529f, 0.08862426f, -0.01120479f, 0.08087976f, 0.24020524f, 
    -0.10762448f, -0.10038479f, 0.15667982f, -0.15634805f, -0.08190117f, -0.05318543f, -0.10416191f, -0.05237538f, 
    0.09139834f, 0.01014972f, 0.14646478f, 0.04579792f, -0.12486959f, -0.05477852f, 0.05357757f, 0.07613233f, 
    -0.03379762f, 0.12843071f, 0.04161844f, 0.13759518f, 0.10825612f, 0.03932291f, 0.03610490f, 0.05908718f, 
    0.19209169f, 0.13662526f, 0.00035616f, 0.01697885f, -0.05116756f, 0.01748057f, 0.19456431f, -0.06021119f, 
    -0.09796561f, -0.00340218f, -0.01035205f, 0.07550055f, 0.04569713f, 0.04072305f, -0.24327220f, 0.15167132f, 
    0.02320690f, 0.07912866f, 0.04138811f, 0.06845617f, 0.12919986f, 0.12967221f, 0.08966079f, 0.09264895f, 
    0.59486502f, -0.06319824f, -0.09200954f, 0.15180132f, 0.01631733f, 0.13257806f, 0.02633072f, 0.03677096f, 
    -0.12436394f, -0.08498887f, 0.07030209f, 0.16123237f, -0.09298415f, 0.32961455f, -0.07381489f, 0.23102657f, 
    0.10828287f, -0.03095124f, 0.08966199f, -0.03091935f, -0.16151425f, -0.03514147f, -0.00035038f, -0.18686275f, 
    -0.04042500f, -0.00093891f, 0.01635372f, 0.10151714f, 0.05702356f, 0.06390655f, -0.04796493f, 0.06204258f, 
    -0.06715940f, -0.00224694f, -0.10570452f, -0.00593468f, 0.17735173f, 0.07698622f, -0.20229256f, -0.54968297f, 
    -0.13412228f, -0.03473733f, 0.11966608f, -0.07359613f, 0.00455792f, 0.02027598f, -0.24845022f, -0.08084060f, 
    0.18649827f, 0.08085361f, -0.02898233f, 0.20292786f, 0.05879952f, -0.05019307f, 0.03566635f, 0.13462146f, 
    0.08599399f, 0.04979923f, 0.03829995f, 0.00788628f, 0.11365929f, 0.02496939f, 0.06794138f, 0.20945269f, 
    -0.15752047f, -0.14486836f, 0.01193917f, -0.01656633f, 0.00565786f, -0.13797098f, -0.04352080f, 0.00836461f, 
    -0.02205692f, 0.01251085f, 0.25256068f, -0.07574558f, -0.07333192f, -0.17929290f, -0.11456717f, -0.15723218f, 
    -0.08037589f, 0.04206512f, -0.06568456f, 0.03805958f, -0.17353916f, 0.13420635f, -0.10954141f, 0.36165935f, 
    -0.00725523f, 0.06082528f, -0.05006399f, 0.05845490f, 0.03626535f, -0.03615087f, -0.12636718f, -0.00333207f, 
    -0.28229398f, 0.15461995f, 0.18098930f, 0.42904964f, -0.07051722f, -0.10435116f, 0.12700772f, -0.17123188f, 
    -0.06100324f, 0.08728512f, -0.04430657f, 0.12198713f, -0.14008471f, 0.00446460f, -0.00731185f, 0.14290719f, 
    0.07547674f, 0.08406604f, 0.02587780f, 0.03399611f, 0.00978208f, -0.09881414f, 0.06932202f, -0.17836110f, 
    -0.13525426f, 0.08757618f, -0.17691982f, -0.10078241f, -0.07898714f, 0.03559523f, 0.05209666f, -0.26681164f, 
    -0.05491674f, 0.02370581f, -0.01701051f, 0.10140592f, 0.04667526f, 0.22906207f, -0.02951456f, -0.44569486f, 
    0.12578809f, 0.25542638f, -0.02324468f, 0.04253306f, -0.07288387f, -0.02250223f, 0.04165881f, 0.03803993f, 
    0.12270002f, 0.09601120f, 0.06140341f, 0.31288591f, -0.13869289f, -0.04470694f, -0.14223106f, -0.06422184f, 
    0.16570741f, 0.13971238f, -0.08856729f, 0.04537279f, 0.05672527f, 0.02369291f, -0.02760689f, -0.08999421f, 
    0.02801385f, 0.06773607f, -0.00067612f, -0.07412417f, -0.04811296f, 0.02805661f, -0.19748591f, -0.13386095f, 
    -0.27983192f, -0.04139405f, 0.05089687f, 0.02398636f, 0.01734842f, -0.04630537f, -0.07881874f, -0.13345306f, 
    0.04693534f, -0.14076398f, -0.17005979f, 0.08264656f, 0.36439618f, 0.50681871f, -0.17858128f, -0.20932606f, 
    0.00348773f, 0.19644037f, -0.12123974f, 0.12666242f, -0.09406199f, -0.04813783f, 0.09013789f, -0.02653636f, 
    0.09928764f, -0.02957143f, 0.02960811f, 0.03296307f, 0.04780975f, 0.08760444f, -0.20084214f, 0.00158931f, 
    -0.02575907f, 0.14515470f, 0.05068878f, -0.02121625f, -0.16194415f, 0.01010047f, -0.10023382f, 0.17882478f, 
    0.07633107f, 0.00550001f, 0.01088339f, -0.02194255f, 0.00697532f, 0.12207624f, -0.05354792f, 0.00010048f, 
    0.24117480f, 0.02302951f, -0.13857216f, -0.34912246f, 0.07946038f, 0.11448959f, -0.11153309f, -0.18865538f, 
    -0.11349827f, -0.04126967f, 0.12903593f, -0.08289721f, -0.07158133f, 0.37407348f, -0.28918192f, -0.08342659f, 
    0.13322893f, -0.07282632f, 0.01360521f, 0.01560189f, 0.02430494f, 0.06030084f, -0.01097758f, 0.06996488f, 
    0.11694431f, -0.06961431f, 0.16601725f, -0.07547519f, -0.00322220f, 0.12520087f, -0.04438557f, -0.05326103f, 
    0.00283204f, -0.07214650f, -0.09370638f, 0.02353915f, 0.16167435f, -0.07293738f, -0.01031360f, -0.18433255f, 
    0.00947512f, 0.00158620f, -0.16424572f, -0.03981189f, 0.09846112f, 0.22241794f, -0.02321832f, 0.02764624f, 
    -0.26373124f, -0.15141861f, -0.01318852f, 0.08066916f, 0.00521811f, 0.10215341f, -0.07946214f, 0.05782600f, 
    -0.05728114f, -0.01882379f, 0.19884460f, 0.11739864f, 0.07193635f, -0.07541718f, 0.31983396f, -0.08141815f, 
    -0.12443107f, -0.05679768f, -0.01596537f, 0.04889832f, 0.06715590f, 0.06875377f, 0.07965267f, 0.06106654f, 
    -0.16915093f, -0.10819924f, 0.18206809f, 0.15052325f, -0.04283824f, -0.04266372f, -0.09326187f, -0.05274207f, 
    0.00095190f, -0.03890745f, 0.07626482f, 0.09367356f, 0.07206969f, 0.07963043f, -0.12312582f, -0.12111142f, 
    0.12848759f, 0.00005264f, -0.10375334f, 0.05571281f, -0.09687922f, 0.01683181f, -0.05330434f, 0.04464786f, 
    -0.26083109f, 0.12342100f, 0.03206547f, 0.20160875f, -0.08508261f, -0.03553032f, 0.07574318f, -0.04017222f, 
    0.02370808f, 0.02870928f, 0.11110015f, 0.08210297f, -0.10686851f, 0.07981111f, -0.03460702f, 0.16734125f, 
    0.05374965f, 0.00658125f, 0.01684829f, -0.02169245f, 0.09460704f, 0.13474309f, 0.12135763f, 0.00266085f, 
    -0.29647687f, 0.14920290f, 0.07255446f, 0.15497230f, 0.05414805f, -0.06472401f, -0.02035526f, -0.07312748f, 
    -0.01132588f, 0.07064019f, 0.15514402f, 0.05873056f, -0.07615103f, 0.19537872f, 0.14694180f, -0.14181194f, 
    -0.14676553f, 0.00990214f, -0.09202331f, -0.04528813f, 0.12950914f, 0.04051708f, 0.00796561f, 0.16096133f, 
    -0.16308153f, 0.28732663f, -0.06828459f, 0.13408375f, 0.04290122f, 0.11463799f, 0.08582291f, 0.10176805f, 
    0.03421918f, 0.00052573f, 0.08006286f, 0.00516539f, -0.05541594f, -0.00036833f, 0.11930184f, -0.14488967f, 
    -0.15515637f, -0.11695414f, -0.02555483f, 0.03327556f, 0.12554444f, 0.12479595f, 0.05152548f, -0.01733876f, 
    0.19547829f, 0.02233689f, 0.08979185f, 0.06316143f, -0.14681408f, 0.01417342f, -0.09783579f, -0.03429624f, 
    -0.12432070f, 0.04243103f, -0.10552094f, -0.02372936f, -0.24955361f, 0.15402709f, 0.36233658f, 0.14727509f, 
    0.01107412f, -0.05539346f, -0.12521535f, -0.14730160f, 0.01562547f, 0.04657988f, 0.02123441f, -0.00198984f, 
    -0.23258111f, -0.09626036f, 0.01041748f, 0.19454665f, 0.01945043f, 0.00381045f, 0.11753611f, 0.08387952f, 
    0.10553199f, 0.06162499f, -0.04144582f, -0.01722032f, 0.13895562f, -0.06904184f, 0.03960650f, 0.01589594f, 
    0.13776042f, 0.01911842f, 0.01729452f, -0.00055388f, -0.04353724f, 0.09765242f, 0.05397648f, -0.00427060f, 
    0.24424230f, -0.13338539f, -0.01095270f, 0.12864067f, 0.04957626f, -0.00072909f, -0.10035630f, 0.10965827f, 
    0.02002573f, -0.01874842f, 0.06864278f, -0.01161249f, -0.06653845f, 0.10833519f, -0.07360401f, 0.06901730f, 
    0.02709305f, 0.13468862f, -0.04783651f, -0.08192018f, 0.06307762f, 0.10916550f, 0.16663550f, 0.07586672f, 
    -0.07588032f, -0.10093303f, -0.19508073f, 0.09817215f, 0.16145250f, 0.08914671f, 0.07153028f, -0.01678697f, 
    -0.01392926f, 0.01315154f, -0.03122907f, -0.15486656f, -0.30499527f, -0.01707517f, 0.37064943f, 0.13793121f, 
    -0.00215421f, 0.06293209f, -0.09382669f, -0.03539458f, -0.02524948f, -0.11219747f, -0.04257770f, 0.09443928f, 
    -0.34883049f, -0.23856579f, 0.30105752f, 0.16902317f, 0.11010443f, 0.16321084f, -0.01934127f, -0.04531664f, 
    -0.01496204f, 0.04954395f, -0.03722037f, 0.06869234f, -0.22514391f, 0.06677118f, -0.04116435f, 0.33155468f, 
    -0.04299653f, 0.01639995f, 0.06342703f, 0.01726891f, -0.00653419f, 0.10395355f, -0.07682191f, 0.08157703f, 
    0.34767708f, 0.01042354f, 0.03286508f, -0.05486926f, 0.01773749f, -0.02617675f, -0.05967287f, -0.01826849f, 
    0.01142435f, 0.16525269f, 0.00449461f, 0.09182128f, -0.18742308f, -0.05991055f, -0.03993035f, -0.16735709f, 
    -0.18323775f, -0.23774403f, -0.15129568f, -0.01589423f, -0.06546879f, 0.02178602f, -0.07652138f, 0.04232278f, 
    0.03838844f, 0.03927962f, -0.07349623f, -0.00222747f, 0.03125348f, 0.06613988f, 0.06359670f, 0.05766502f, 
    -0.10154432f, 0.04653699f, -0.06350339f, 0.05031173f, -0.18757942f, 0.02869126f, -0.04776518f, -0.24397829f, 
    -0.22080654f, -0.24951516f, -0.13308592f, -0.04007203f, 0.08265533f, 0.02499975f, 0.08801679f, -0.02976502f, 
    -0.13979773f, 0.01894770f, -0.05287352f, -0.28648451f, 0.05373176f, 0.09188021f, -0.00281781f, -0.03568815f, 
    0.03151427f, 0.22151196f, -0.11115073f, -0.05000705f, 0.03697543f, 0.07715167f, 0.04128777f, -0.18076277f, 
    0.02548189f, -0.22218780f, 0.00141461f, -0.01404969f, 0.03215462f, 0.00741559f, 0.09791054f, -0.19901460f, 
    -0.14790866f, -0.06036151f, -0.12573792f, 0.16293460f, 0.11164067f, 0.13588665f, -0.00701392f, 0.02924282f, 
    0.11139115f, 0.00870026f, 0.15585156f, 0.09270180f, -0.06530157f, -0.11150398f, -0.08365060f, 0.05157241f, 
    0.04854975f, -0.04789312f, 0.05419270f, 0.05263424f, 0.05117720f, -0.01452810f, -0.03428107f, 0.05119811f, 
    -0.07181090f, 0.05922952f, -0.03377942f, 0.01426756f, 0.05726251f, -0.15157463f, -0.05916693f, -0.09039446f, 
    -0.13821055f, 0.01338881f, 0.07786049f, -0.00747782f, -0.01035436f, 0.01173218f, -0.03186564f, 0.05783396f, 
    -0.11892681f, 0.03582637f, 0.00258570f, -0.00034615f, -0.10722087f, -0.02131235f, -0.00257626f, -0.00902908f, 
    -0.07762267f, -0.05514546f, -0.06232119f, -0.04848290f, 0.13207766f, 0.03564367f, -0.00043219f, 0.05573925f, 
    0.00894531f, 0.10882135f, 0.07889699f, 0.10434657f, -0.15272391f, 0.22283357f, 0.00587241f, 0.00379222f, 
    0.10128886f, 0.05674322f, -0.11716530f, -0.05512999f, -0.03322798f, -0.01804690f, 0.01521726f, -0.08239935f, 
    -0.11836904f, -0.09766964f, -0.03941504f, -0.24623019f, 0.04662276f, 0.06548310f, -0.07414360f, -0.00328375f, 
    -0.19013104f, -0.00217481f, -0.15243164f, -0.16579424f, -0.30618775f, 0.68858445f, -0.14278743f, 0.11435179f, 
    0.12575719f, 0.03167519f, 0.01135538f, -0.06826153f, -0.07967278f, -0.05379445f, -0.00618968f, 0.02105749f, 
    -0.16513525f, 0.51454431f, -0.19325045f, -0.40923357f, 0.14613788f, -0.01581527f, -0.03199311f, -0.10241928f, 
    -0.02091728f, 0.02383061f, 0.07829045f, -0.04315278f, 0.05875528f, -0.05910749f, -0.10656046f, -0.03836333f, 
    0.03420436f, -0.09016795f, -0.05451645f, 0.04915408f, 0.05530218f, 0.07512165f, 0.01233167f, 0.01073835f, 
    -0.05021314f, -0.13580339f, -0.03794890f, 0.14279868f, 0.01652847f, 0.06189387f, -0.04263064f, -0.09446622f, 
    0.07250360f, 0.05476213f, 0.03747418f, 0.11604905f, -0.11222837f, 0.22684272f, 0.11698264f, 0.00358923f, 
    0.00502179f, -0.09382044f, 0.05416891f, -0.16514172f, -0.12226128f, -0.06645965f, 0.08420697f, -0.09492608f, 
    -0.15015513f, 0.14805308f, -0.02273989f, 0.07643875f, 0.09936814f, 0.00358855f, 0.01849947f, -0.10720586f, 
    0.00982527f, 0.13452053f, 0.06881439f, 0.02603348f, 0.39896595f, 0.01024866f, -0.12955563f, -0.21035545f, 
    0.06074770f, -0.00040781f, 0.06189341f, -0.19910520f, -0.01584230f, 0.01213929f, 0.01755418f, -0.02329695f, 
    -0.14957741f, 0.14673382f, 0.13995539f, 0.17436513f, -0.03569070f, 0.07093447f, -0.09223980f, 0.12930477f, 
    0.13640334f, 0.11562883f, 0.13727504f, -0.11449369f, 0.30820179f, 0.02660630f, -0.05190142f, -0.04250357f, 
    0.09646866f, -0.00757018f, -0.07007007f, 0.09521011f, -0.09875087f, 0.04476994f, 0.03319936f, 0.02107869f, 
    0.00973393f, 0.00544893f, -0.03041343f, 0.01337575f, -0.02859886f, 0.00578562f, 0.00151898f, 0.00036376f, 
    -0.03084861f, 0.02328439f, -0.01708455f, 0.01916108f, -0.02407501f, -0.00569956f, -0.03992413f, -0.03096544f, 
    -0.00370335f, -0.02717542f, -0.02768450f, 0.02468238f, 0.01081104f, 0.02678300f, -0.02049395f, -0.03410312f, 
    -0.02419858f, 0.02169891f, -0.01554701f, -0.01629734f, 0.02762538f, -0.00182521f, 0.01947509f, -0.00651842f, 
    0.02547773f, -0.01538652f, -0.02575526f, -0.02299366f, -0.02386689f, 0.02899094f, -0.03232176f, -0.02069557f, 
    0.00839925f, -0.03892260f, -0.00294758f, -0.00846285f, -0.03867849f, 0.00146124f, -0.00501153f, -0.02627591f, 
    -0.00737422f, -0.01429023f, -0.01826334f, -0.00883207f, -0.00211988f, -0.01166013f, -0.02639907f, -0.03325960f, 
    0.03351596f, -0.00043305f, 0.01122582f, 0.03197341f, -0.03053173f, -0.02983194f, -0.03586485f, -0.04042546f, 
    -0.00887909f, -0.02164473f, -0.00930865f, 0.00568812f, -0.01721566f, 0.01292805f, 0.00893422f, -0.03707547f, 
    -0.02865090f, 0.02544616f, -0.01769810f, -0.03361610f, 0.00732390f, 0.02677216f, -0.00538318f, -0.02446929f, 
    -0.00557747f, 0.02009248f, -0.02958052f, 0.02649791f, 0.02784669f, -0.01223208f, 0.01091853f, -0.03986396f, 
    0.00584157f, -0.02549508f, 0.02627670f, -0.00258220f, 0.01081956f, -0.01550072f, 0.01674832f, -0.03159306f, 
    -0.03275910f, 0.00371198f, 0.00074360f, -0.01530918f, -0.02263522f, 0.01195968f, 0.01058440f, -0.00435650f, 
    -0.03411592f, -0.02124978f, 0.01003077f, -0.01384919f, -0.01694976f, -0.02236732f, -0.01916862f, 0.01431904f, 
    -0.01059129f, -0.01310811f, -0.02367760f, 0.00625701f, 0.01421797f, 0.01319527f, -0.00756300f, -0.01507359f, 
    -0.01295176f, -0.00613954f, -0.00216436f, -0.03452330f, -0.02222930f, 0.00072648f, 0.00727921f, -0.01392913f, 
    0.00976894f, 0.00089871f, 0.02393941f, 0.02462062f, -0.01012542f, 0.01456311f, -0.01830604f, -0.00823725f, 
    0.00384624f, -0.04252414f, 0.02525477f, -0.00677630f, 0.02569730f, 0.02044722f, -0.00635834f, -0.00182318f, 
    0.02306890f, -0.01020842f, -0.03626491f, 0.02570440f, -0.03434801f, -0.03393891f, -0.00239973f, 0.00363178f, 
    -0.01598553f, -0.02697265f, -0.03236979f, -0.03426445f, -0.01125376f, 0.02441694f, -0.00939745f, -0.00188217f, 
    -0.00677249f, -0.01652147f, 0.01879116f, -0.01939935f, 0.01219964f, 0.01238076f, -0.00325535f, -0.02791402f, 
    -0.02853516f, -0.00003857f, -0.00148782f, -0.00758767f, 0.00174022f, 0.01678324f, 0.00082793f, 0.01287733f, 
    -0.02449552f, -0.02574410f, 0.00353597f, 0.01404304f, 0.02918990f, 0.00390802f, 0.01337356f, -0.03461673f, 
    -0.00888356f, 0.00352907f, 0.00446625f, -0.01108431f, -0.04026591f, -0.02909967f, 0.00805947f, -0.00651403f, 
    -0.02719053f, -0.03994998f, 0.00178106f, 0.00962288f, 0.02340722f, -0.02324262f, -0.02117293f, -0.04249835f, 
    -0.01437266f, 0.00114452f, 0.02869746f, -0.02879648f, -0.03592037f, 0.01592164f, 0.02485847f, -0.02828748f, 
    -0.02807037f, 0.02092807f, -0.02861372f, 0.01615653f, 0.01141838f, -0.03318456f, 0.02435402f, -0.03572926f, 
    0.02533957f, 0.00421831f, -0.00820779f, -0.03102989f, 0.02682477f, 0.00391923f, -0.04036304f, -0.04113856f, 
    -0.00592027f, -0.03872718f, -0.01871091f, -0.03244355f, 0.00025897f, 0.02668959f, -0.00404771f, 0.01014735f, 
    -0.00842610f, -0.02366648f, -0.02846656f, 0.01933849f, 0.02051559f, -0.02420649f, 0.02351162f, -0.00011218f, 
    0.01253600f, 0.00017695f, -0.03722162f, 0.01722336f, 0.00696749f, -0.02913390f, 0.00314724f, 0.02601751f, 
    -0.02692976f, -0.01008034f, -0.00738889f, 0.01248026f, -0.02510937f, -0.03260664f, -0.02876970f, -0.03575378f, 
    -0.02096630f, -0.02509894f, -0.03180714f, 0.01197971f, -0.00306043f, -0.03276668f, 0.01055353f, 0.02645865f, 
    -0.02789808f, -0.03110684f, -0.03454088f, 0.00347095f, 0.00764941f, -0.00766313f, 0.02426194f, 0.00410497f, 
    0.01699871f, 0.01917893f, -0.03409554f, 0.01053696f, 0.02478165f, -0.00034297f, 0.00352486f, 0.01352617f, 
    -0.02616351f, -0.02120484f, -0.01967808f, -0.01487879f, -0.02356203f, -0.02372553f, 0.01897958f, 0.03026163f, 
    0.02362932f, -0.00931426f, 0.00713793f, -0.01811363f, -0.00784212f, -0.01916215f, 0.01801975f, 0.02038968f, 
    -0.01426138f, 0.01825883f, -0.02789592f, -0.01233858f, -0.03384862f, 0.01799737f, -0.01610262f, -0.03561065f, 
    -0.00754581f, -0.02979713f, 0.00719409f, -0.01186879f, -0.02036164f, -0.02995916f, -0.03824953f, -0.02086432f, 
    0.00303200f, 0.01740519f, 0.00348714f, -0.02571621f, -0.04103291f, -0.03956777f, -0.01996294f, -0.03593022f, 
    -0.03918376f, 0.01724146f, -0.00258718f, -0.03415044f, -0.03520745f, -0.03403717f, -0.01555656f, -0.02393858f, 
    -0.01324893f, 0.02158156f, 0.00450245f, 0.03491355f, -0.03179299f, -0.02876637f, 0.00644836f, 0.01088058f, 
    -0.00985957f, 0.02784226f, 0.02156739f, 0.01900884f, 0.01149111f, -0.02331585f, -0.03705993f, 0.03430021f, 
    -0.02288283f, 0.01387749f, -0.01654698f, 0.01968603f, -0.00493867f, -0.03817424f, -0.03812418f, -0.01927835f, 
    0.03035737f, -0.03986315f, -0.03159301f, -0.00499528f, -0.03130896f, -0.00316437f, 0.02064946f, 0.02226965f, 
    -0.03967739f, -0.00066852f, 0.01423887f, -0.00610617f, 0.02088888f, -0.03003456f, -0.01126142f, -0.00317118f, 
    -0.01697591f, -0.01123363f, 0.02232371f, 0.01606883f, -0.02358647f, 0.02664988f, -0.01966801f, -0.02275955f, 
    -0.00222229f, 0.01177587f, 0.02261488f, -0.03311167f, 0.01637944f, 0.01363313f, 0.00304519f, -0.00285790f, 
    0.01290107f, 0.02215117f, -0.04120296f, -0.02864538f, 0.02231125f, 0.00806341f, -0.00989823f, -0.01807857f, 
    0.03385543f, 0.02304560f, -0.03307033f, -0.01560794f, 0.01575318f, 0.02046489f, -0.01611745f, -0.03890201f, 
    0.00430745f, -0.01467135f, -0.02685722f, -0.00874379f, -0.00606831f, -0.01421323f, -0.00426972f, 0.01745100f, 
    0.00596373f, -0.02895989f, -0.02845559f, -0.03693535f, -0.03070457f, 0.03552050f, 0.00217965f, 0.01547944f, 
    -0.02207931f, -0.00204049f, 0.00820678f, -0.02231233f, -0.00981079f, 0.01551270f, -0.03226496f, 0.02196216f, 
    -0.01694081f, -0.01318646f, -0.02487249f, 0.02592048f, -0.00393667f, 0.00126951f, 0.02563792f, -0.02851840f, 
    -0.00263359f, 0.02628640f, -0.00873927f, -0.00186552f, -0.02968450f, -0.02799805f, -0.03675099f, -0.02175165f, 
    -0.00861799f, 0.00328778f, -0.01398673f, 0.00584080f, -0.02240139f, 0.03432218f, -0.04014619f, 0.00878822f, 
    -0.00246333f, 0.01874492f, -0.00258095f, -0.00300198f, 0.01678909f, -0.01667024f, 0.00110980f, 0.01664407f, 
    -0.02381007f, 0.00697605f, -0.00624993f, 0.02259516f, -0.02966581f, 0.01092653f, -0.03858525f, -0.00761883f, 
    -0.03877393f, -0.00449005f, -0.03663599f, -0.01952901f, 0.01148478f, 0.02800252f, -0.00269940f, -0.01513930f, 
    -0.01165748f, -0.00726714f, 0.01777172f, -0.01801522f, -0.00190847f, -0.02308351f, 0.02603298f, -0.01055707f, 
    -0.01113463f, 0.01882474f, -0.00829995f, -0.03996325f, 0.01095054f, -0.00624243f, -0.02456205f, -0.01163389f, 
    -0.00541478f, -0.02465173f, 0.01059866f, -0.02027834f, 0.00880478f, 0.00374320f, 0.00604563f, 0.01412521f, 
    -0.03530800f, 0.01627264f, 0.01965613f, 0.02134714f, -0.02766949f, -0.03195129f, 0.00413476f, -0.01457886f, 
    0.00113334f, -0.02378616f, 0.00487554f, -0.02104866f, -0.00538677f, 0.00128035f, -0.00330363f, 0.02588163f, 
    0.01512914f, 0.01736738f, -0.04085268f, -0.04259750f, -0.03704922f, -0.01641369f, -0.03899543f, -0.02577035f, 
    0.01404101f, -0.03001782f, -0.00441317f, 0.02195266f, -0.02498530f, -0.01813282f, -0.00365911f, -0.03576089f, 
    0.02419189f, -0.01166473f, 0.00629883f, 0.01918961f, -0.04279713f, 0.01755705f, 0.00099977f, -0.01454095f, 
    -0.02543715f, -0.01960010f, 0.02334576f, 0.01220483f, 0.02719665f, 0.02255068f, -0.03623006f, -0.00183737f, 
    0.03077459f, 0.00940075f, 0.00442998f, -0.00342380f, -0.01927031f, -0.01205969f, 0.00154787f, 0.02252431f, 
    0.02732898f, -0.01135968f, 0.00872767f, -0.00392441f, 0.01619705f, 0.01416728f, -0.01483617f, 0.02802654f, 
    0.01444917f, -0.02197914f, -0.01941125f, -0.02237852f, -0.03841206f, -0.00387113f, -0.00785248f, -0.02938267f, 
    -0.04247459f, -0.01438637f, 0.01447612f, -0.02315448f, 0.00295185f, -0.04093741f, -0.02054035f, 0.00011000f, 
    -0.01771681f, -0.02947873f, -0.01485622f, -0.00972157f, -0.01777741f, -0.01997891f, -0.02807859f, -0.01458061f, 
    -0.00832602f, -0.01522769f, 0.03466203f, -0.01014720f, 0.00962130f, -0.00558304f, -0.03853125f, -0.02322722f, 
    -0.00441903f, -0.04048371f, 0.00671619f, 0.01218346f, -0.03449481f, 0.01449164f, -0.01328283f, -0.01591098f, 
    0.01223828f, -0.01770813f, -0.03055245f, 0.02355505f, 0.00049587f, -0.02544612f, 0.02885053f, 0.02544080f, 
    -0.01190038f, 0.02183062f, 0.00372220f, -0.01959805f, 0.01467443f, -0.02164614f, 0.02192737f, 0.01623601f, 
    -0.02983569f, -0.03646811f, -0.01816925f, 0.00589003f, -0.02316548f, -0.03057172f, -0.00978800f, 0.00140708f, 
    0.01384744f, -0.00185984f, -0.01265129f, -0.03952238f, 0.02331342f, 0.01282369f, 0.02774455f, 0.01537257f, 
    -0.00333608f, -0.00036816f, 0.00829055f, 0.02010486f, -0.02916924f, 0.00559417f, -0.01934204f, -0.03174442f, 
    -0.01765102f, -0.03116000f, -0.03570705f, -0.03638270f, -0.02574258f, -0.01674525f, 0.01866408f, -0.04083883f, 
    -0.01279623f, -0.00753634f, -0.00820865f, -0.03721454f, -0.00250682f, 0.01015865f, -0.02138103f, -0.00909417f, 
    -0.03104142f, 0.01817336f, 0.00020599f, 0.00291130f, 0.00449452f, -0.01854341f, -0.03705241f, 0.00512045f, 
    0.02770568f, -0.03066154f, -0.01167826f, -0.01331269f, -0.03183736f, 0.02254401f, -0.02701902f, 0.01989484f, 
    -0.00875923f, -0.00819627f, -0.04228555f, 0.00639809f, -0.03325477f, -0.02807563f, -0.03615761f, 0.01323875f, 
    -0.00662702f, -0.03782404f, -0.03016895f, 0.01940045f, -0.01278574f, 0.00871458f, -0.03144853f, -0.04078653f, 
    0.01601113f, -0.00012918f, 0.01668838f, -0.02847503f, -0.02732321f, 0.02747810f, 0.00690235f, -0.01520059f, 
    -0.00622688f, -0.03034414f, -0.04193488f, -0.02222164f, -0.02079760f, -0.04141140f, 0.00746850f, 0.00000080f, 
    -0.02031970f, -0.01821752f, 0.02418796f, -0.00910020f, 0.01219354f, 0.02636002f, -0.02421610f, -0.02205401f, 
    -0.01690863f, 0.00184674f, 0.02003419f, 0.01652411f, -0.00043542f, 0.01983265f, -0.02619496f, 0.00166130f, 
    -0.03514833f, -0.02047174f, 0.01945128f, -0.01237336f, -0.04112008f, -0.03013122f, 0.01546794f, -0.00024458f, 
    0.00271633f, 0.01302709f, -0.02887106f, 0.02822923f, -0.03164633f, -0.03242466f, -0.01380497f, -0.02426034f, 
    -0.03840403f, 0.01056375f, 0.01729323f, -0.03608984f, -0.01157390f, 0.01755201f, -0.04204145f, -0.00503804f, 
    0.00972731f, 0.02579722f, 0.01694994f, -0.03823494f, -0.02690398f, -0.00690170f, -0.00629979f, -0.00947448f, 
    0.01670367f, 0.02177632f, -0.03320811f, 0.01259417f, -0.03197760f, -0.02047262f, 0.01159652f, 0.01448117f, 
    -0.01641568f, -0.01689174f, -0.01255869f, -0.03243540f, -0.04184133f, -0.03635972f, -0.01034949f, -0.01399555f, 
    0.10762652f, 0.27515420f, 0.18906708f, 0.14321026f, 0.02436676f, 0.11266051f, -0.06716121f, 0.11763313f, 
    0.03166629f, 0.11791877f, -0.00471170f, -0.10429296f, 0.18207529f, 0.18061960f, -0.18227647f, 0.04190301f, 
    0.02581684f, -0.12425840f, 0.16358317f, 0.06731901f, 0.10494179f, 0.11546161f, 0.07788248f, 0.00747163f, 
    0.06811174f, 0.33357599f, -0.26564646f, -0.06773342f, 0.12307930f, -0.10070867f, 0.13847314f, 0.04162770f, 
    -0.02463161f, 0.01851805f, 0.03888308f, -0.16377550f, 0.09221289f, -0.07008824f, 0.00462536f, -0.09913579f, 
    -0.04651359f, -0.00690683f, 0.04818743f, 0.01877606f, 0.07399049f, 0.00579748f, 0.13325886f, 0.14571154f, 
    0.41597211f, 0.20306928f, 0.03662203f, 0.18159778f, -0.02565254f, 0.09200753f, 0.17994544f, 0.01366843f, 
    0.01492243f, -0.02143537f, 0.02565474f, -0.10763651f, -0.18345658f, -0.00845464f, 0.18775383f, -0.13699879f, 
    0.04885171f, -0.05500946f, -0.17689073f, -0.01814138f, 0.02791915f, -0.01209126f, 0.12488227f, 0.03473730f, 
    -0.49436653f, 0.44040895f, 0.00437254f, -0.01811995f, -0.15465979f, 0.05622397f, -0.10146377f, 0.00495131f, 
    0.09096151f, -0.04223054f, 0.02198506f, -0.04984213f, 0.05958813f, 0.09599249f, -0.09535910f, -0.35820144f, 
    0.02467434f, -0.05462981f, 0.08618703f, 0.14482634f, 0.00888777f, 0.00615468f, -0.00840257f, -0.01205580f, 
    0.15188289f, 0.00721050f, -0.15296060f, 0.22072414f, -0.02267224f, 0.12349436f, 0.10678950f, -0.01585776f, 
    -0.02454991f, 0.16358933f, 0.03422303f, -0.01023881f, -0.03000107f, 0.04414000f, -0.19680505f, 0.08877857f, 
    0.01833103f, 0.12841453f, 0.15781340f, -0.12946458f, -0.10246743f, -0.03864077f, 0.00377124f, -0.03380501f, 
    -0.14934897f, 0.01800425f, 0.01366537f, 0.13534044f, -0.10000259f, -0.07242149f, -0.05532350f, 0.11078211f, 
    -0.05123171f, 0.04750433f, 0.02703375f, 0.07617006f, 0.04134049f, -0.01490724f, 0.06567795f, -0.13036622f, 
    -0.11523559f, -0.03895794f, 0.00424237f, 0.06475952f, -0.00326377f, 0.04506119f, 0.00536418f, 0.08135402f, 
    -0.09443075f, 0.00840023f, 0.07082459f, -0.11078444f, 0.02492851f, -0.13171670f, -0.13372125f, 0.08543816f, 
    -0.07285842f, -0.00756708f, -0.19969785f, 0.01519977f, 0.06709540f, -0.14473294f, 0.06419174f, 0.05902468f, 
    0.09742793f, -0.08538064f, -0.04033303f, 0.16339110f, -0.01544932f, 0.04060563f, 0.00892727f, 0.04084622f, 
    -0.19632107f, -0.03661567f, 0.08419345f, 0.03229493f, 0.01845611f, 0.05962026f, 0.07044835f, 0.10449316f, 
    -0.07387916f, 0.12603062f, 0.08042650f, 0.08017547f, 0.00041359f, -0.04371122f, 0.22161107f, -0.13434789f, 
    0.04817937f, -0.06037981f, 0.04641046f, 0.02219049f, 0.04350597f, 0.07569803f, 0.11677064f, 0.07017791f, 
    0.13917108f, 0.06286906f, -0.06689180f, -0.07729346f, -0.16740978f, 0.10347044f, 0.06828026f, 0.11643635f, 
    0.06728390f, 0.14140196f, -0.00728307f, 0.07431653f, 0.14446431f, 0.12438741f, 0.02643890f, -0.16137642f, 
    -0.02161341f, -0.02674577f, -0.05021389f, 0.16455305f, 0.15023552f, -0.00652780f, 0.00186969f, 0.20170909f, 
    0.12579198f, 0.25270137f, 0.00336473f, -0.07655098f, -0.02398890f, 0.07550105f, 0.11329889f, 0.16244482f, 
    -0.05934530f, -0.03603235f, 0.07561003f, -0.04084138f, 0.28450614f, -0.15084921f, 0.13174336f, -0.06750418f, 
    -0.11776543f, -0.03920492f, 0.08412011f, -0.02868302f, 0.06436349f, -0.06669926f, -0.03341812f, -0.01226848f, 
    -0.18544625f, 0.08548853f, 0.19252461f, -0.24870878f, 0.11276357f, -0.02375079f, 0.01445686f, 0.12960924f, 
    -0.09085610f, 0.12163640f, -0.03749203f, -0.02300698f, -0.31814483f, -0.07374792f, 0.03942708f, -0.08667661f, 
    0.05987411f, -0.05052401f, 0.00525296f, 0.01105501f, -0.17309010f, -0.11284164f, -0.19176021f, -0.03908979f, 
    0.07522990f, 0.00348018f, -0.12071121f, 0.07088881f, 0.09062968f, 0.06719417f, -0.13802232f, 0.00257547f, 
    0.05473001f, 0.07240608f, 0.11813608f, -0.18057664f, -0.44478437f, -0.34188265f, 0.44759688f, -0.00837760f, 
    0.07658313f, -0.02138523f, -0.05178851f, 0.02416775f, 0.05007257f, 0.03157774f, 0.06933749f, 0.21041362f, 
    -0.07199022f, 0.09015149f, -0.00227804f, 0.16095723f, 0.00667146f, 0.04335501f, -0.06875206f, 0.06994745f, 
    -0.04086045f, -0.07772721f, -0.00051881f, -0.03888583f, 0.22231616f, 0.11601431f, -0.03237151f, 0.05231529f, 
    0.05540059f, -0.03910428f, 0.09886876f, -0.02987330f, -0.07440234f, 0.00409045f, -0.11443444f, 0.00938209f, 
    0.20639414f, -0.16807444f, -0.13047713f, 0.09948482f, -0.02523997f, 0.16223787f, 0.14563130f, 0.05131407f, 
    0.11965112f, 0.00252955f, -0.12849683f, -0.10529892f, 0.16643377f, 0.04647387f, 0.06763869f, 0.21810965f, 
    0.09151426f, 0.09104785f, -0.08577462f, -0.13716114f, 0.14130920f, 0.01649538f, -0.03157846f, 0.01818801f, 
    0.01935529f, -0.13372710f, 0.05330875f, 0.17526086f, -0.05262373f, 0.03928813f, -0.07302774f, -0.03637540f, 
    0.02647502f, 0.00257623f, -0.19605209f, -0.02857257f, -0.26457912f, -0.02886217f, -0.02867748f, -0.04023387f, 
    0.00380931f, -0.17836873f, -0.12044881f, 0.18248075f, -0.18531254f, 0.03105760f, -0.13920985f, -0.01658014f, 
    0.41725832f, -0.00891260f, 0.21699874f, 0.15814914f, 0.04119275f, 0.15086937f, -0.00707945f, -0.13776672f, 
    0.19531816f, -0.06734964f, -0.03889978f, -0.05116459f, -0.50939852f, -0.00331987f, 0.02668689f, -0.04586741f, 
    -0.00958555f, -0.03295318f, -0.14695209f, 0.02342508f, -0.20369795f, -0.10907853f, 0.00369158f, -0.04514764f, 
    0.19355753f, 0.34288862f, -0.05501842f, 0.01429464f, 0.12240327f, 0.01267561f, 0.00057195f, 0.01615455f, 
    0.06936742f, 0.15605885f, -0.12691775f, 0.06856997f, -0.35007447f, -0.28561917f, -0.12411998f, 0.42028335f, 
    -0.01003169f, -0.13913238f, 0.04795662f, -0.05322452f, -0.03946304f, -0.07560054f, 0.04448787f, 0.05890528f, 
    0.08628706f, 0.02145188f, -0.03275484f, -0.24225129f, 0.12347373f, 0.11590537f, -0.02028092f, -0.00107328f, 
    -0.08115920f, -0.02966855f, -0.06732413f, 0.14359918f, 0.14702849f, 0.00794106f, -0.16076843f, -0.02730639f, 
    0.03061828f, 0.14138862f, 0.07710663f, 0.08654674f, 0.04609586f, -0.03050431f, 0.05541332f, -0.15019135f, 
    0.20590006f, -0.02050107f, -0.17196780f, -0.08546168f, 0.06269799f, 0.08939836f, 0.02332605f, 0.20195907f, 
    -0.06043955f, 0.02268913f, -0.02986347f, 0.05897276f, -0.11041888f, -0.26909208f, -0.07227542f, 0.04650285f, 
    -0.04200813f, -0.00165241f, -0.10712628f, -0.04009261f, -0.14138420f, 0.03573771f, -0.04516172f, -0.14393592f, 
    0.13052556f, 0.08378068f, -0.31647223f, 0.10886420f, 0.14792328f, -0.00166159f, 0.22292121f, 0.05920041f, 
    -0.03278555f, -0.04492536f, 0.06728029f, 0.05658710f, -0.34686503f, -0.18250164f, -0.16144180f, -0.04971602f, 
    0.01139224f, -0.16525382f, -0.23904954f, 0.01262466f, -0.11433852f, 0.04107302f, 0.00453618f, 0.05115121f, 
    -0.04758536f, -0.05033141f, -0.00784443f, -0.08711502f, -0.06895171f, -0.09899125f, -0.11582716f, 0.06887767f, 
    -0.07077862f, 0.05822149f, -0.00527010f, -0.09652346f, -0.08006964f, 0.13615914f, 0.14099814f, -0.30064037f, 
    0.06439292f, -0.02475492f, -0.03850270f, 0.01663383f, -0.00905965f, 0.14067456f, 0.01089677f, -0.03832782f, 
    0.09629697f, -0.05127961f, -0.04021391f, -0.13339883f, -0.05846760f, 0.10660853f, 0.07317055f, 0.04839233f, 
    -0.05626017f, -0.01992507f, -0.09547094f, -0.01438894f, -0.20020472f, -0.05716480f, 0.01268512f, -0.03844556f, 
    -0.09292820f, -0.01441158f, 0.04094537f, -0.01709034f, -0.04241640f, 0.04539482f, 0.11134525f, 0.17262128f, 
    0.30130094f, 0.18491538f, -0.01516402f, -0.02599229f, 0.02642941f, 0.05974039f, -0.03821528f, -0.05093295f, 
    0.02435595f, -0.01279492f, -0.14842212f, 0.01596433f, -0.19898944f, 0.00767755f, 0.03500909f, 0.09581988f, 
    -0.09275743f, -0.07264120f, -0.10015601f, -0.03158145f, -0.10314512f, 0.04715642f, 0.04771112f, 0.02155232f, 
    -0.10288610f, 0.17234026f, 0.02177508f, -0.07958783f, -0.05944923f, 0.03766324f, -0.04170348f, -0.04563455f, 
    -0.00511119f, -0.01205626f, -0.02765910f, -0.09971687f, -0.13079615f, -0.01342682f, -0.13459416f, 0.20293944f, 
    0.12759563f, -0.00252011f, -0.05504368f, -0.05672122f, 0.04206455f, 0.00839916f, 0.12572891f, 0.07823741f, 
    0.10853997f, 0.16970581f, -0.09493829f, -0.22703722f, -0.05948674f, -0.12144154f, 0.08054429f, 0.09261288f, 
    -0.09132647f, 0.01263243f, -0.07697723f, -0.02217477f, 0.22690073f, 0.06624629f, -0.07167738f, 0.01298957f, 
    0.09760549f, 0.07558283f, 0.04234470f, -0.00766180f, 0.01793270f, -0.00643686f, -0.10028163f, -0.08208144f, 
    -0.14492652f, 0.00647086f, -0.02833641f, 0.18244825f, -0.02768191f, -0.04240279f, -0.03399117f, 0.02016424f, 
    0.03121079f, 0.00285780f, 0.09485931f, 0.11232504f, 0.08221798f, 0.13183318f, 0.16274278f, -0.08831545f, 
    0.00366485f, 0.13988265f, 0.14117122f, -0.15315180f, 0.20047796f, -0.05963428f, 0.17469537f, -0.19621587f, 
    0.27301532f, 0.21252243f, -0.21697275f, -0.03258337f, 0.13747638f, -0.01382689f, 0.07010528f, -0.03753733f, 
    0.09130491f, -0.06764478f, -0.04406498f, -0.00058336f, -0.21505089f, -0.07552256f, 0.16434000f, 0.20472586f, 
    -0.08248720f, 0.06628235f, -0.23955621f, -0.00284376f, -0.01539377f, -0.05364058f, 0.09885079f, 0.11020730f, 
    -0.05534453f, 0.02091497f, -0.04900464f, -0.03999234f, -0.05050641f, 0.00919217f, 0.04572003f, -0.03298159f, 
    0.06159577f, 0.03575083f, 0.23591125f, 0.17424545f, 0.40210137f, -0.13953654f, 0.13694099f, 0.01534057f, 
    -0.16687036f, -0.06767822f, 0.15074767f, -0.05049907f, -0.10357585f, 0.08973386f, -0.03375386f, 0.12657329f, 
    0.09033679f, 0.11899257f, -0.10198770f, -0.10133772f, -0.06726423f, 0.00864265f, 0.08643787f, -0.01968095f, 
    0.10881987f, 0.01613940f, 0.12639625f, 0.03544488f, 0.04993653f, 0.31025285f, -0.00658191f, -0.02044410f, 
    0.12944278f, 0.20182560f, 0.24646488f, 0.03345698f, -0.10168965f, -0.02575469f, -0.01617246f, 0.04612264f, 
    0.22828124f, 0.06485946f, 0.19338499f, 0.03852548f, 0.11071860f, 0.14161468f, -0.00214906f, 0.04196434f, 
    0.01853082f, -0.04849011f, 0.02084587f, -0.11839934f, -0.04670631f, 0.20004022f, -0.21430503f, -0.07353795f, 
    -0.06535625f, 0.17470126f, -0.00909161f, 0.04978056f, 0.04057512f, 0.31322506f, 0.17671664f, 0.02246188f, 
    0.26732740f, 0.00826913f, -0.34215668f, -0.10416762f, -0.11455273f, 0.05913739f, 0.08180636f, 0.01767576f, 
    0.08014520f, 0.13273053f, -0.07438881f, 0.04722436f, -0.24926494f, 0.09726901f, -0.06282610f, 0.01276773f, 
    0.01261549f, 0.04203019f, 0.10029476f, 0.06611874f, 0.11523306f, -0.07221171f, 0.34604767f, -0.01275542f, 
    0.03884440f, -0.13313486f, -0.08719292f, -0.02580431f, -0.12961535f, -0.03432142f, -0.20481251f, 0.01180230f, 
    -0.12939668f, -0.09765781f, -0.02238856f, -0.07089024f, -0.36606804f, 0.29139951f, 0.16869944f, -0.20603378f, 
    -0.08628555f, 0.23752862f, 0.02288591f, 0.00624218f, 0.08680072f, 0.04537890f, 0.06854450f, 0.23996966f, 
    0.08167430f, -0.03999921f, 0.06030506f, -0.14280242f, 0.21241209f, 0.04078688f, 0.07820350f, -0.04559145f, 
    0.07839733f, 0.11397611f, 0.05289086f, -0.10288823f, 0.08563764f, 0.14100614f, -0.05038758f, 0.15475985f, 
    0.00428128f, -0.10863125f, 0.04128245f, -0.01560281f, 0.06768842f, -0.10985353f, 0.04525365f, 0.04702627f, 
    -0.19398245f, -0.17091495f, -0.21055630f, 0.14145306f, 0.07573733f, -0.06073787f, -0.02393946f, -0.02835085f, 
    0.03463479f, -0.02386386f, -0.02856663f, 0.05646763f, 0.10170687f, 0.08281932f, 0.06532921f, 0.09741285f, 
    -0.07478104f, -0.02652778f, 0.00704561f, -0.05793326f, 0.24847136f, 0.12148827f, 0.03716706f, 0.15809235f, 
    0.07474035f, 0.02577117f, 0.07975984f, -0.08926993f, 0.06238497f, -0.09423834f, 0.00206414f, -0.12896298f, 
    -0.10810123f, -0.13080285f, 0.00648980f, -0.15605006f, 0.08045343f, 0.10501159f, 0.09771094f, -0.03806353f, 
    -0.07487202f, -0.07235453f, -0.03029065f, -0.19908883f, -0.07135082f, -0.04944552f, -0.05699638f, 0.00386887f, 
    0.28574744f, 0.19614685f, 0.10012852f, 0.13523248f, -0.05849543f, 0.04942080f, -0.15806583f, -0.12711099f, 
    0.00246285f, -0.10348072f, -0.02109718f, -0.03320245f, -0.01982139f, 0.02119241f, -0.25155306f, -0.29697394f, 
    0.06133296f, -0.11895386f, 0.19356729f, -0.02046009f, -0.07987070f, -0.00928311f, -0.09205993f, -0.12807371f, 
    0.46721625f, -0.13271765f, 0.21443911f, -0.04729771f, -0.01782490f, 0.07196706f, -0.00580423f, -0.01296897f, 
    -0.00423423f, 0.11064096f, 0.08944144f, -0.08443895f, 0.17731808f, 0.04433395f, 0.10855504f, -0.11942969f, 
    -0.04300717f, 0.02348388f, -0.07840398f, 0.00461912f, -0.14018252f, 0.02817673f, -0.08187584f, -0.04013770f, 
    0.14901397f, -0.00685700f, 0.20329757f, 0.13640378f, -0.01225004f, 0.04821532f, 0.04727982f, 0.05126834f, 
    0.08455947f, 0.06950637f, 0.00093389f, -0.07029495f, 0.01745426f, 0.00600232f, -0.06204702f, 0.17691480f, 
    -0.07584930f, 0.03323518f, -0.00394812f, -0.04999224f, 0.11173452f, -0.04243543f, 0.03586429f, 0.25684455f, 
    0.02735073f, 0.14965560f, -0.11137278f, 0.00480400f, 0.06103915f, -0.01351197f, 0.05300752f, 0.20072374f, 
    0.06543031f, 0.10139485f, -0.15577419f, 0.00579638f, -0.02300823f, -0.13299140f, 0.02287125f, 0.03343953f, 
    0.05883667f, 0.01062989f, -0.10311607f, -0.14379837f, 0.01142508f, -0.11629581f, -0.16065694f, -0.01584392f, 
    0.05334126f, 0.04292891f, 0.02007535f, 0.04152436f, 0.10452366f, 0.09612061f, 0.02295548f, 0.01280992f, 
    -0.09964301f, -0.05935732f, -0.01260109f, -0.01498978f, -0.29381567f, -0.37720796f, 0.05936015f, 0.15755373f, 
    0.00035037f, 0.06233198f, -0.00489613f, -0.00180727f, 0.15316172f, -0.11778645f, 0.15648943f, 0.08798942f, 
    -0.16034058f, 0.04234212f, -0.08088230f, 0.09377054f, 0.00998862f, 0.00626250f, -0.08961349f, 0.03060189f, 
    0.13608339f, 0.22252890f, -0.25363478f, -0.00749064f, -0.17341746f, -0.03629848f, -0.06463633f, 0.04254957f, 
    -0.15639104f, -0.01194688f, -0.02119776f, 0.08280394f, 0.28698951f, -0.07039240f, 0.09364670f, 0.14797138f, 
    -0.24664424f, 0.09560587f, -0.21035379f, -0.03681097f, 0.09703538f, 0.01729252f, 0.06544645f, 0.08603197f, 
    -0.03029730f, -0.01397079f, 0.16315854f, -0.09768694f, 0.17741349f, 0.02016417f, -0.20140994f, 0.09253290f, 
    -0.08780451f, 0.12258714f, 0.18877718f, 0.03782665f, 0.37605920f, -0.01183882f, -0.05362219f, 0.13419405f, 
    0.24494469f, -0.06749982f, 0.20900661f, -0.14572170f, -0.03749725f, -0.08260775f, -0.05310501f, 0.08227262f, 
    -0.04602490f, 0.09582113f, -0.03918387f, -0.07453547f, -0.15809013f, 0.02141242f, 0.22209018f, -0.05880504f, 
    0.05557995f, 0.02079176f, 0.01160855f, 0.01650139f, 0.05610701f, 0.16399947f, -0.06842044f, 0.03560172f, 
    0.02039565f, -0.23506108f, -0.20832150f, -0.10374761f, 0.02575665f, 0.08101928f, 0.08491785f, -0.03173086f, 
    0.02436541f, -0.07317042f, 0.01391643f, -0.28506243f, 0.40524217f, -0.12739444f, 0.52648425f, -0.19769512f, 
    0.22016725f, 0.05544221f, 0.04697144f, 0.11750810f, -0.01458728f, 0.01546568f, 0.00647982f, 0.10785019f, 
    0.08861679f, 0.27709925f, -0.10392849f, 0.08177592f, 0.13897817f, 0.00368359f, -0.02929580f, 0.11075430f, 
    0.10772065f, 0.13044788f, 0.03476041f, 0.00205022f, -0.17474018f, -0.13892588f, -0.22490393f, 0.10979859f, 
    0.02757389f, 0.04863629f, 0.01608321f, -0.02835944f, -0.08407738f, -0.16656798f, -0.16556419f, -0.09597301f, 
    -0.12023482f, -0.26165211f, -0.01162678f, -0.16708636f, -0.05887386f, 0.00413311f, 0.12742063f, 0.10722146f, 
    0.09851225f, 0.20070910f, -0.06690166f, -0.10970020f, 0.14683156f, -0.06723764f, 0.00339574f, 0.11242563f, 
    0.12440870f, 0.13591219f, 0.04032491f, 0.02355003f, 0.03984106f, 0.10055940f, 0.00577364f, 0.18203688f, 
    0.05924876f, -0.07249383f, 0.22643249f, 0.05338392f, -0.11633781f, 0.05151785f, 0.01262600f, 0.09867864f, 
    0.01988997f, 0.12131064f, 0.02099101f, 0.06890348f, 0.06298006f, 0.14404407f, 0.04446358f, 0.04331502f, 
    -0.01927947f, 0.01882884f, 0.02860610f, 0.03029071f, 0.03851444f, 0.14274529f, -0.06276516f, -0.01045045f, 
    0.35693714f, 0.13048944f, 0.09794732f, 0.02426150f, 0.11331933f, 0.05170264f, 0.04165364f, -0.15453964f, 
    0.15418349f, 0.02954783f, 0.10262322f, -0.21301323f, 0.04912890f, 0.00152153f, 0.16153875f, -0.00957169f, 
    -0.02242256f, -0.02826532f, 0.00956986f, 0.12841088f, 0.11527292f, 0.27736992f, 0.04000404f, 0.07510131f, 
    -0.01222330f, 0.03391737f, -0.07403103f, -0.00492381f, 0.17709175f, -0.02766223f, -0.06489374f, -0.01302465f, 
    0.08803409f, 0.20602825f, -0.09369168f, 0.05660533f, 0.45220569f, 0.16695526f, 0.37563577f, -0.10557062f, 
    -0.05722749f, -0.22239494f, 0.03027535f, -0.05511747f, -0.02309969f, -0.06486009f, 0.03153912f, 0.09424590f, 
    -0.08357014f, -0.14087316f, 0.05480697f, -0.14300472f, -0.01302543f, -0.14689632f, -0.07411477f, 0.01604820f, 
    0.01612577f, 0.16642614f, 0.04638239f, 0.07149516f, -0.14576945f, -0.18571085f, -0.21711501f, -0.09935734f, 
    -0.05329539f, -0.00902480f, -0.00945659f, -0.09329178f, -0.07879283f, -0.05750868f, 0.04659010f, -0.14842619f, 
    -0.24251938f, -0.14009103f, -0.19683461f, -0.05044172f, -0.00682552f, 0.09492663f, 0.12700681f, 0.08596244f, 
    -0.01172149f, 0.13509794f, -0.11070090f, 0.01988483f, 0.22506836f, -0.02793772f, 0.01230718f, -0.01663604f, 
    -0.01983513f, 0.01820333f, -0.10197428f, 0.04675245f, -0.27381691f, -0.09463219f, -0.13641980f, -0.17373258f, 
    -0.00181023f, -0.20691545f, -0.05974995f, -0.05677123f, -0.02516619f, -0.02455996f, 0.13510159f, -0.06371612f, 
    -0.11803254f, -0.05845835f, -0.01936536f, -0.05103843f, 0.38633856f, 0.24943283f, 0.08679243f, -0.11728071f, 
    -0.03400500f, -0.08685598f, -0.20224355f, -0.23006801f, -0.15327646f, -0.05543932f, -0.07965334f, 0.10896698f, 
    0.16385499f, 0.01516742f, -0.08942771f, 0.04754841f, 0.01649379f, 0.00520544f, -0.20282148f, -0.01687521f, 
    -0.14902957f, -0.16489553f, -0.02095339f, 0.05954182f, -0.13716987f, -0.01797448f, 0.11358979f, -0.05576590f, 
    -0.12501144f, -0.13417706f, 0.24882218f, -0.04103011f, 0.03336367f, 0.02648197f, -0.08909236f, 0.12173217f, 
    -0.41140172f, -0.16923170f, -0.25594738f, -0.12698138f, -0.07594702f, 0.04497830f, 0.00258629f, -0.04232228f, 
    -0.06545695f, 0.02711106f, 0.04944949f, -0.14206910f, 0.16568938f, 0.12921022f, 0.17134687f, 0.17247482f, 
    -0.01949922f, -0.02260164f, 0.00470537f, -0.05306704f, -0.06507680f, 0.05767670f, 0.00438929f, 0.02927785f, 
    -0.12772562f, 0.12078754f, -0.09196154f, -0.06554762f, 0.20204912f, -0.12826155f, -0.06730884f, -0.03930645f, 
    0.12295616f, -0.22332112f, -0.05351158f, -0.03989740f, 0.21700267f, 0.22285900f, 0.11369926f, 0.07749242f, 
    -0.06660523f, -0.01906718f, -0.10166614f, -0.01449767f, -0.06372993f, -0.02079653f, -0.01222945f, 0.00836475f, 
    0.12046723f, 0.00800612f, -0.03767401f, 0.09410746f, -0.03435473f, -0.03345808f, -0.03732745f, -0.01203410f, 
    0.27970752f, 0.12173198f, 0.01932557f, 0.05722596f, 0.28037134f, 0.18939802f, 0.00445204f, 0.05754052f, 
    0.01471114f, 0.01763152f, -0.03044279f, -0.09462456f, 0.02530389f, 0.10578120f, -0.04201837f, -0.00462517f, 
    -0.08487216f, -0.06509753f, -0.08403956f, -0.12371669f, -0.00107647f, -0.02495503f, 0.16441867f, 0.08097447f, 
    -0.18085971f, -0.14032046f, -0.08602385f, -0.00972447f, -0.01143334f, -0.07330719f, 0.01524793f, -0.03258925f, 
    -0.04957983f, 0.01958986f, 0.12978728f, 0.02226374f, 0.06997324f, -0.00379852f, 0.00848440f, 0.03697575f, 
    0.17853357f, 0.19752800f, 0.20218095f, 0.04560113f, -0.08470153f, -0.11426409f, 0.03519351f, -0.07309246f, 
    -0.01648021f, 0.02490850f, 0.01216743f, 0.02507954f, -0.06795719f, -0.21645597f, 0.00588524f, -0.10743725f, 
    0.09077645f, -0.02180837f, 0.15593031f, 0.06749577f, 0.22743669f, -0.06694759f, 0.28555533f, 0.10427338f, 
    -0.10872131f, -0.10056409f, 0.14076026f, 0.02407316f, -0.01691739f, -0.14987840f, 0.17332312f, 0.00024326f, 
    0.14767499f, -0.00291445f, 0.09285507f, -0.04641411f, 0.35599107f, 0.21001057f, 0.11341488f, -0.09994946f, 
    0.00474096f, 0.09265072f, -0.03083615f, -0.06216512f, -0.11947982f, -0.05205985f, -0.01448694f, -0.10061676f, 
    -0.01382897f, 0.04466754f, 0.04715820f, 0.10519437f, 0.00178271f, -0.03435875f, 0.00714095f, -0.04603719f, 
    0.03349599f, -0.03622586f, 0.00035173f, 0.01764731f, 0.36147761f, 0.00965357f, 0.05480025f, 0.18204285f, 
    -0.11640322f, -0.02909376f, -0.02710883f, 0.02763815f, -0.16364679f, 0.14553502f, 0.05251084f, -0.01338271f, 
    0.06787696f, 0.11159217f, -0.04193991f, 0.08671854f, -0.05061890f, 0.01817623f, 0.03118945f, -0.01038142f, 
    0.12086896f, 0.07920268f, 0.16504328f, 0.11341202f, -0.10416223f, -0.01468108f, 0.02748233f, 0.08304720f, 
    -0.07079424f, -0.16269654f, 0.04841409f, 0.02390294f, -0.13616106f, -0.11701298f, -0.06487747f, -0.08252879f, 
    -0.03665121f, -0.06156696f, 0.08788978f, -0.09098589f, 0.05722258f, 0.05062389f, -0.01208587f, 0.04051922f, 
    0.01265110f, -0.09184308f, -0.05137495f, -0.02881860f, 0.04072745f, 0.07319208f, -0.12701590f, 0.13628206f, 
    -0.00258394f, -0.04196144f, 0.02281279f, 0.05223686f, 0.02768449f, 0.09638970f, -0.03198972f, 0.08734163f, 
    0.30623034f, -0.00521087f, 0.04482916f, 0.02862071f, -0.06507534f, -0.03536746f, -0.01427032f, -0.01428635f, 
    0.09371416f, 0.16463923f, -0.06465482f, 0.03400637f, -0.06200022f, 0.09280872f, 0.10800447f, 0.06008244f, 
    0.07346892f, -0.01892659f, 0.04645627f, 0.01050101f, 0.11903919f, -0.09112570f, 0.13650338f, 0.06286708f, 
    0.16623160f, -0.27876067f, -0.02322660f, 0.02658345f, -0.15191595f, 0.13970028f, 0.10785238f, -0.00435237f, 
    -0.18903546f, 0.16623014f, 0.11180678f, -0.04952452f, -0.00708152f, 0.21361780f, -0.00169428f, 0.00039307f, 
    -0.02737954f, 0.09937479f, -0.03318933f, 0.10104061f, 0.00874689f, -0.03651217f, -0.01219008f, 0.08531444f, 
    -0.25907138f, 0.02492973f, -0.06685556f, -0.08152159f, 0.01481701f, -0.10990568f, -0.07472587f, -0.11099963f, 
    -0.05811715f, 0.03212846f, 0.17926899f, 0.10007469f, -0.07321285f, -0.26757386f, 0.19993602f, 0.05166447f, 
    0.08159256f, 0.03816646f, -0.02311118f, -0.07908218f, 0.05492738f, -0.01790062f, -0.02187025f, -0.01495205f, 
    0.03820313f, -0.30887508f, -0.03790407f, 0.17621017f, 0.01745730f, 0.08304809f, 0.08838028f, 0.03099841f, 
    -0.02052642f, -0.05378584f, 0.04064904f, 0.04494666f, -0.29254469f, -0.15992336f, -0.01083647f, 0.14804319f, 
    0.13193879f, 0.06300762f, -0.02328460f, 0.06178194f, -0.02062315f, 0.17406411f, -0.04573606f, -0.04468868f, 
    -0.23054148f, 0.13745977f, 0.29863438f, -0.01535402f, -0.08641747f, -0.07562768f, -0.01914313f, 0.09451925f, 
    -0.00307961f, -0.02929803f, 0.01485622f, -0.10533065f, 0.01948917f, -0.08294480f, -0.15785986f, 0.06235060f, 
    0.07485975f, -0.01730174f, 0.02598982f, 0.09925884f, 0.06144565f, -0.00670525f, -0.03454223f, -0.00157516f, 
    -0.02407494f, -0.32993215f, -0.16678244f, -0.08564762f, -0.00750193f, 0.07640912f, 0.13195580f, 0.12113404f, 
    -0.02208514f, 0.01590150f, 0.03442340f, -0.01192098f, 0.00832584f, -0.22456281f, 0.02185923f, 0.02902936f, 
    -0.05385126f, 0.08029614f, -0.00501212f, -0.05581362f, 0.05088966f, -0.06307057f, 0.01670025f, -0.01259676f, 
    0.19671743f, 0.37008193f, 0.15121633f, -0.16333756f, 0.03848462f, -0.07946325f, -0.16059187f, -0.04131333f, 
    -0.08265131f, -0.06961589f, -0.06539381f, -0.04806339f, 0.04403984f, -0.07725959f, 0.13152257f, -0.00794490f, 
    -0.03307467f, -0.00786552f, 0.01390984f, -0.00822899f, -0.03228111f, -0.03403980f, -0.10754903f, -0.07698791f, 
    0.08980490f, 0.01474743f, -0.00221035f, -0.01410063f, 0.11092337f, 0.14019230f, 0.00984305f, -0.04809527f, 
    0.03622221f, -0.06594126f, -0.13316818f, 0.01279262f, -0.07052891f, -0.23002511f, -0.08109224f, 0.12676056f, 
    0.04503190f, 0.05645798f, -0.01105526f, 0.00169939f, 0.06821094f, 0.05475101f, -0.04165464f, 0.06746159f, 
    -0.03318480f, -0.06906270f, -0.18754828f, 0.03368428f, 0.13043237f, 0.12578250f, 0.09622371f, 0.07287712f, 
    0.12719545f, -0.01061851f, 0.09121413f, 0.15385276f, 0.00495690f, -0.07304506f, -0.03728697f, -0.00334778f, 
    -0.02166590f, 0.07490949f, -0.00557440f, -0.01355577f, -0.02742989f, -0.12374598f, -0.06263092f, -0.11246918f, 
    0.25815934f, -0.00030150f, -0.07255726f, -0.06002187f, -0.00673293f, -0.06136012f, 0.09480204f, -0.09929932f, 
    -0.04314403f, -0.03789834f, 0.00014650f, -0.06272462f, -0.12400518f, -0.15546314f, 0.03981173f, 0.14306475f, 
    0.07010873f, 0.13781482f, -0.00073751f, -0.00626329f, 0.08089763f, -0.15352720f, 0.15402709f, 0.10344757f, 
    0.12064612f, 0.17583470f, -0.02452444f, 0.22261271f, 0.08719315f, -0.07521764f, 0.00887064f, 0.03438396f, 
    -0.12978335f, -0.19224069f, 0.01230569f, -0.06633316f, 0.11697971f, -0.04949547f, 0.04752373f, 0.14999479f, 
    -0.04844512f, 0.01455081f, 0.03896217f, 0.03068921f, 0.01128915f, 0.04299408f, -0.00757402f, 0.00568064f, 
    -0.18409476f, -0.03488704f, 0.24341716f, 0.38266647f, -0.04732664f, 0.00528546f, -0.00094449f, 0.01626011f, 
    0.03358445f, 0.10878103f, -0.01486038f, 0.14826290f, 0.00784792f, -0.14137988f, 0.01874993f, 0.16401453f, 
    -0.06358790f, 0.17423370f, -0.06289428f, -0.06251308f, 0.07394762f, 0.08374518f, 0.04318516f, 0.04452028f, 
    0.29502380f, 0.03184122f, -0.26096764f, 0.08829765f, 0.00694957f, 0.18599141f, -0.01301254f, 0.09334194f, 
    0.02709305f, -0.05825914f, 0.03758355f, 0.06038924f, -0.12244374f, 0.00130457f, -0.07459766f, -0.00212428f, 
    -0.02434485f, -0.04746167f, -0.00588681f, -0.02046840f, 0.08723513f, 0.01410160f, 0.23125328f, 0.20662130f, 
    0.03244878f, 0.22545362f, 0.15673484f, 0.10633992f, -0.02876186f, -0.06509725f, 0.06955977f, -0.22680333f, 
    0.07374576f, 0.13997276f, -0.11213014f, 0.10839150f, 0.02438982f, 0.00895423f, -0.23113097f, -0.23102580f, 
    0.02213063f, -0.09815372f, -0.03702552f, -0.01681700f, 0.01601384f, -0.04645852f, -0.07639122f, -0.01173505f, 
    0.10793804f, 0.07840083f, -0.12992458f, -0.01314766f, 0.00509461f, 0.00341799f, -0.00523616f, 0.02715611f, 
    0.12830696f, -0.04900863f, 0.05965804f, 0.19451374f, -0.09825791f, -0.17631179f, 0.10134403f, 0.18678255f, 
    -0.13600989f, 0.07428092f, -0.06288657f, 0.04393042f, 0.07565875f, -0.04365051f, -0.00211411f, -0.00527601f, 
    0.22978027f, 0.30665636f, 0.26537663f, 0.03607899f, -0.02708341f, -0.11101571f, -0.16862828f, -0.24928401f, 
    -0.09192257f, 0.02831054f, -0.00642061f, 0.04811900f, -0.01939782f, 0.03105010f, 0.06818075f, -0.09733124f, 
    -0.02378110f, 0.01480694f, 0.07572712f, 0.05250314f, -0.04641560f, -0.03465893f, 0.18379824f, 0.22891757f, 
    0.08284726f, 0.00433351f, 0.25877440f, -0.10078976f, 0.00064464f, -0.03971515f, -0.09339353f, 0.00372073f, 
    -0.11406672f, 0.13660499f, 0.12468304f, 0.02968534f, 0.08430605f, -0.09860030f, -0.26055408f, 0.06771917f, 
    0.05579587f, 0.10239623f, 0.02621359f, 0.03797496f, 0.07758370f, 0.02507396f, -0.00239108f, -0.00681065f, 
    -0.09447461f, -0.05660391f, 0.12501995f, -0.04646685f, -0.07104590f, -0.05008629f, 0.04391605f, -0.05953531f, 
    -0.04815918f, -0.02105864f, 0.13390467f, 0.11981032f, 0.11265720f, -0.09170070f, -0.12264176f, -0.07436568f, 
    0.02623355f, 0.06923214f, 0.11246923f, -0.02791783f, 0.02522117f, 0.13229489f, -0.06400639f, 0.07765344f, 
    -0.09748591f, -0.15651917f, -0.24440846f, 0.04206705f, 0.03349608f, 0.09360359f, 0.08646004f, 0.10011856f, 
    0.11177708f, 0.00022399f, -0.02588013f, -0.06133415f, 0.17091188f, -0.12876460f, -0.02321143f, -0.43765831f, 
    0.04962953f, 0.04405476f, 0.01831621f, 0.08622375f, -0.04307133f, 0.08469123f, -0.07196447f, -0.07585747f, 
    -0.03875104f, 0.10367303f, 0.16521080f, -0.05377322f, 0.01884755f, -0.04377520f, 0.02406498f, -0.00068104f, 
    0.02205373f, 0.02070585f, 0.00777352f, -0.25392473f, 0.09660228f, 0.41680467f, 0.44715598f, 0.28656706f, 
    -0.02851579f, -0.10065824f, -0.01342292f, -0.07855635f, 0.05884720f, 0.04554954f, 0.03610079f, 0.19459155f, 
    0.01334656f, 0.39132333f, 0.16765533f, 0.02134049f, -0.00817096f, -0.02373705f, 0.03805470f, -0.22936997f, 
    0.03099459f, 0.01757349f, -0.04340484f, 0.05782378f, -0.03879497f, 0.12167435f, 0.01128974f, -0.07568652f, 
    0.00966268f, 0.00198701f, 0.02320307f, 0.03640147f, 0.18205161f, 0.29139391f, 0.15846632f, 0.40231463f, 
    -0.00238630f, 0.19938639f, 0.16616330f, -0.07431660f, -0.22078051f, -0.06995047f, -0.20302071f, 0.01459603f, 
    0.05896915f, -0.01603610f, 0.02183919f, -0.04555697f, 0.35921106f, 0.03934706f, -0.13831247f, -0.09096959f, 
    -0.03363935f, 0.15127958f, 0.17362946f, -0.03970346f, 0.01276966f, -0.02728575f, -0.02413558f, -0.04082265f, 
    0.15412393f, 0.17921589f, -0.02654573f, -0.12092854f, -0.03652790f, 0.11177986f, 0.05457622f, -0.13470523f, 
    0.16916840f, -0.02116125f, 0.04411872f, 0.07263912f, 0.16520208f, -0.12716763f, -0.04211107f, 0.09312012f, 
    0.00643084f, -0.09655955f, 0.08957049f, 0.01149099f, -0.03059083f, -0.08836734f, -0.03973599f, -0.00980017f, 
    0.02330486f, 0.43658140f, 0.19070037f, 0.32696265f, -0.07663486f, -0.03217687f, 0.01391700f, -0.03884577f, 
    0.03989092f, 0.14586915f, 0.13059403f, 0.14425576f, -0.06848618f, -0.24246059f, -0.16809645f, -0.09765910f, 
    0.08070913f, 0.04539853f, 0.03398043f, 0.00824416f, 0.07848675f, 0.07160448f, -0.09207399f, 0.02109507f, 
    -0.09529124f, -0.10960694f, 0.28159112f, 0.13153319f, 0.06565315f, -0.06473346f, 0.18921390f, 0.07255874f, 
    0.06643230f, 0.01529518f, 0.07794472f, 0.07599695f, -0.08446339f, -0.27138409f, -0.13638288f, -0.15170151f, 
    0.04796062f, 0.14062519f, 0.08990314f, 0.08874164f, -0.00396797f, 0.01557722f, -0.04876262f, 0.00049028f, 
    0.04486852f, -0.09782620f, 0.02509031f, 0.12385271f, -0.00428673f, 0.02800239f, 0.05271934f, 0.06005889f, 
    -0.06298640f, -0.11227315f, 0.05430977f, 0.00810787f, -0.04437764f, -0.07496516f, -0.08621181f, -0.13867226f, 
    -0.07594635f, 0.09830972f, 0.10494571f, 0.10288839f, 0.00165033f, -0.07564415f, -0.13004979f, -0.00713980f, 
    0.00192226f, -0.07118046f, 0.00452893f, 0.11484847f, -0.03109203f, -0.09629877f, -0.13121964f, -0.07588622f, 
    0.16948766f, 0.02946289f, -0.04603032f, 0.05497542f, -0.11579186f, -0.05516634f, 0.08984336f, 0.09307223f, 
    -0.08228324f, 0.01087562f, -0.04811513f, 0.04377853f, 0.03624351f, 0.00975080f, 0.00307922f, 0.03580096f, 
    -0.12617195f, -0.20150523f, -0.11794072f, -0.28221896f, 0.07435828f, 0.06291338f, 0.04800848f, 0.04664711f, 
    -0.02390519f, 0.02026812f, -0.08142599f, -0.10086705f, 0.10461063f, -0.00160725f, 0.01203839f, 0.23339029f, 
    -0.04614526f, 0.01093363f, 0.01277083f, 0.02271905f, -0.17161261f, -0.06658562f, 0.07319394f, -0.00949031f, 
    0.02562763f, -0.20719789f, 0.13330828f, 0.22818010f, -0.06400581f, 0.02337972f, -0.08280410f, -0.03575350f, 
    0.02186135f, 0.02521728f, 0.08400191f, -0.00482303f, 0.14955887f, -0.00886947f, -0.06918999f, -0.29440394f, 
    -0.00933504f, 0.00420168f, 0.03867988f, 0.07450373f, 0.09713744f, -0.02355971f, -0.09359688f, -0.06325001f, 
    0.01925082f, -0.11460686f, -0.05362317f, 0.01037238f, 0.09174670f, 0.05773141f, 0.05399728f, 0.05384716f, 
    0.05202224f, 0.10261638f, -0.00973459f, -0.10355108f, -0.15124358f, -0.52024603f, 0.01598660f, -0.07126608f, 
    0.11667794f, 0.13179678f, -0.07921321f, -0.02485077f, 0.05977430f, -0.04737961f, 0.10974245f, 0.05010942f, 
    -0.07821837f, -0.39791226f, -0.04492444f, 0.15903306f, 0.05835681f, 0.08265979f, 0.00833191f, 0.03887801f, 
    -0.07195660f, 0.12809823f, 0.00882444f, -0.01713861f, 0.11108202f, -0.06529511f, 0.10105153f, 0.24994011f, 
    0.00485718f, -0.08575203f, -0.08429853f, -0.09443386f, -0.03192990f, -0.10898202f, -0.04140312f, -0.13335970f, 
    0.03874747f, 0.03231416f, 0.09350947f, 0.15277675f, 0.01058158f, -0.07496002f, -0.00280671f, -0.07279301f, 
    -0.12563314f, -0.00171317f, -0.02348860f, -0.12986229f, -0.01552933f, 0.17423488f, 0.06263293f, -0.03986850f, 
    0.11053289f, 0.03061746f, -0.02172790f, 0.11383102f, -0.11155114f, -0.00846249f, -0.03657198f, -0.12064645f, 
    -0.04992911f, 0.08335908f, 0.09002946f, 0.02834256f, 0.06360540f, -0.07412951f, -0.13185728f, -0.01622091f, 
    -0.11095973f, -0.05118033f, -0.07961843f, 0.07014201f, -0.10968378f, -0.06371855f, 0.01283594f, 0.14949147f, 
    0.09835756f, -0.06664915f, -0.04352533f, 0.03267179f, 0.07295819f, -0.00318088f, -0.09838754f, -0.02887458f, 
    0.00411323f, -0.14306624f, 0.05746823f, -0.27363420f, 0.19639972f, 0.06336241f, 0.09466768f, 0.02249729f, 
    0.09637698f, 0.09258512f, -0.12341502f, 0.08677784f, -0.15423396f, 0.08656550f, -0.05607446f, 0.07823480f, 
    0.00428097f, -0.08459489f, 0.11071099f, 0.04528251f, -0.06117871f, -0.08630011f, 0.02339810f, -0.10735426f, 
    -0.06591953f, -0.07014325f, 0.10706784f, -0.16746806f, 0.06159224f, -0.03075758f, 0.09272740f, -0.00456453f, 
    0.17522964f, -0.03355401f, 0.05242839f, -0.02976925f, 0.23281732f, -0.04782265f, 0.05945963f, -0.23891975f, 
    0.04152578f, -0.01225062f, 0.04942969f, 0.02665066f, -0.02413961f, 0.06030805f, -0.06726974f, 0.12632716f, 
    0.10462807f, 0.21444708f, 0.47584996f, -0.02834953f, -0.10234928f, 0.12285212f, -0.05099939f, 0.03878505f, 
    -0.01321018f, 0.02744367f, -0.02321865f, -0.04071430f, 0.10069449f, 0.02458256f, 0.07311112f, 0.12620285f, 
    -0.11167294f, 0.03781059f, -0.03471671f, -0.07079011f, 0.07845948f, 0.02042859f, 0.09715882f, 0.06055949f, 
    0.13419770f, -0.07607704f, -0.20951836f, -0.25440422f, 0.15111955f, 0.13400830f, -0.18148747f, 0.11701729f, 
    -0.08951102f, -0.05375415f, 0.06694447f, 0.26964724f, 0.08552980f, 0.14840540f, -0.07814158f, 0.25600269f, 
    -0.05463912f, 0.13716882f, 0.11096284f, 0.05018925f, -0.05771523f, 0.01734603f, -0.05951910f, 0.04249416f, 
    0.49457932f, -0.34140572f, -0.01736406f, 0.20717636f, 0.14193538f, 0.03791029f, -0.00116436f, -0.12824228f, 
    -0.08878663f, -0.06174497f, -0.10556497f, 0.01893430f, 0.31322598f, 0.22567858f, 0.26143155f, 0.05163074f, 
    0.05118340f, -0.08403977f, -0.03169564f, 0.11344334f, -0.04975168f, 0.06968185f, 0.07165664f, -0.04392167f, 
    -0.09140327f, -0.52829230f, 0.09306985f, -0.18130460f, -0.01511970f, 0.01601487f, -0.02259021f, 0.02713717f, 
    0.05624508f, 0.11398010f, 0.13153292f, 0.02884785f, 0.18686634f, 0.32825834f, 0.19040842f, 0.11790536f, 
    -0.05282141f, -0.01022322f, 0.01418566f, 0.13765103f, 0.00570996f, 0.02125954f, 0.12131351f, 0.01058885f, 
    0.06516065f, -0.36819500f, 0.11584745f, -0.25143832f, 0.01154620f, 0.02879985f, -0.03587902f, -0.07611138f, 
    0.00695054f, -0.02101100f, 0.06710740f, -0.01347322f, -0.32954130f, 0.11908649f, -0.17159662f, 0.22532120f, 
    -0.10266736f, 0.06617361f, -0.07701326f, 0.00623079f, 0.00525012f, 0.01584999f, 0.04906142f, -0.02337349f, 
    0.16969402f, -0.18103413f, 0.04812701f, -0.07034864f, 0.01685618f, 0.02375877f, 0.05762034f, 0.08705990f, 
    0.05243456f, 0.13188235f, 0.12016110f, -0.07429133f, -0.20292650f, 0.31477383f, -0.12396956f, -0.00216551f, 
    0.07615782f, 0.04936205f, 0.05200937f, -0.04197994f, 0.07720099f, -0.18589188f, -0.10762442f, -0.02244449f, 
    -0.18248540f, -0.00715386f, -0.19345774f, -0.03923542f, 0.04875187f, 0.05146379f, -0.01249021f, 0.13512647f, 
    0.01385684f, 0.02589186f, 0.01940401f, 0.04672745f, 0.02157071f, -0.17972718f, -0.18713892f, 0.01356982f, 
    0.05469564f, -0.01313128f, -0.04393130f, -0.15616673f, 0.10696346f, 0.03280279f, 0.07263388f, 0.03284372f, 
    -0.14124489f, -0.19441150f, 0.11215203f, -0.06165782f, 0.03528027f, 0.00983484f, -0.09333523f, -0.15841885f, 
    0.13406062f, 0.12842727f, -0.02521286f, 0.06766734f, 0.04801074f, 0.03207282f, -0.06094348f, 0.10752503f, 
    0.11834352f, 0.07362768f, 0.08471370f, -0.06695695f, 0.06186412f, 0.01099048f, 0.01467421f, -0.03660063f, 
    0.35603607f, 0.00274607f, -0.15721470f, -0.00014779f, 0.18072715f, 0.02327972f, -0.05399443f, -0.11920174f, 
    0.03977662f, 0.00611040f, 0.04348066f, -0.02475524f, -0.21147287f, 0.25144207f, -0.14777999f, 0.04945473f, 
    0.08828019f, 0.00082409f, -0.06189779f, -0.10085731f, -0.00925160f, -0.03805805f, 0.00278169f, 0.08936431f, 
    0.01846603f, 0.28607559f, 0.08094035f, 0.10945706f, 0.03236898f, -0.02883326f, 0.10150109f, 0.11804428f, 
    -0.13005914f, -0.00316224f, 0.03939467f, -0.05147277f, 0.18124667f, -0.10752796f, -0.09660675f, -0.01587005f, 
    -0.00230068f, -0.03151177f, -0.10417498f, 0.01013527f, 0.05492192f, 0.09870322f, 0.08253763f, 0.01951917f, 
    0.12107337f, -0.25229350f, 0.13112779f, -0.16682483f, -0.03662639f, 0.00880126f, 0.00819707f, 0.14942840f, 
    -0.08756468f, 0.06745714f, 0.02168098f, 0.01414422f, 0.13166273f, 0.12722832f, -0.08433472f, 0.17761467f, 
    0.07229079f, -0.12115110f, 0.05199218f, 0.07870042f, 0.02942495f, 0.02054557f, 0.05212716f, -0.01876829f, 
    -0.16894631f, -0.05967151f, -0.13789298f, -0.22400878f, 0.09569316f, -0.11301420f, -0.00258008f, -0.14247118f, 
    0.07071245f, 0.08177001f, 0.02497785f, -0.05096389f, 0.04561169f, 0.28091210f, -0.07742965f, -0.10804741f, 
    0.13286509f, 0.04983004f, -0.00877189f, 0.08737066f, 0.00484865f, -0.04570178f, 0.05363859f, 0.05022084f, 
    -0.05712928f, -0.20905997f, -0.10533235f, -0.03260010f, 0.08606599f, -0.00891720f, 0.05474261f, 0.05485395f, 
    -0.05100931f, 0.08983863f, 0.07124443f, -0.02894883f, 0.12151029f, 0.07210279f, 0.06575854f, -0.06623783f, 
    0.05095717f, -0.01416592f, 0.05125094f, 0.23846029f, -0.00451983f, 0.07975458f, -0.05211495f, -0.05246020f, 
    -0.10648655f, 0.03331079f, -0.18104465f, -0.06084087f, 0.01869083f, 0.04620817f, -0.04401512f, 0.11757493f, 
    0.02839730f, -0.03281963f, 0.10307494f, 0.07039520f, 0.02952584f, -0.13222726f, 0.04420088f, -0.09363231f, 
    -0.06237026f, 0.07122845f, 0.11547914f, -0.03327555f, 0.07304198f, 0.08033642f, 0.11448670f, -0.08143963f, 
    -0.01982358f, -0.00333484f, -0.21969686f, -0.15172985f, 0.09731241f, -0.12853971f, 0.00113352f, 0.13813913f, 
    -0.01368812f, -0.05606595f, -0.02617838f, -0.02858813f, 0.15422805f, -0.13132152f, 0.03112720f, 0.06367535f, 
    -0.02882255f, 0.01824904f, 0.02445227f, 0.01654648f, -0.09330063f, -0.05242117f, 0.07618700f, -0.06544179f, 
    -0.13772801f, 0.03062849f, 0.18139143f, -0.13157575f, 0.23539847f, -0.00690002f, -0.08771989f, 0.03518116f, 
    -0.05327836f, -0.12263075f, 0.16096461f, -0.07021504f, -0.12503517f, 0.32795179f, -0.05729757f, 0.20593886f, 
    0.07952406f, 0.01518371f, -0.01281539f, 0.12039320f, 0.03416728f, -0.00560201f, 0.02190993f, 0.01521383f, 
    0.22029293f, 0.16893530f, 0.18055135f, 0.40301308f, -0.01804450f, 0.20284101f, 0.17347492f, 0.23857947f, 
    -0.01678723f, 0.02878094f, -0.02929121f, 0.00383342f, 0.13833429f, -0.44363111f, -0.31388643f, -0.24289756f, 
    0.07636072f, 0.00558761f, -0.07959903f, -0.07146773f, 0.03063603f, -0.07485820f, -0.01941429f, 0.02754913f, 
    -0.18556155f, -0.08190189f, -0.04019930f, 0.05366309f, 0.06245039f, -0.02103261f, 0.04451320f, 0.07568641f, 
    0.04624349f, 0.04389746f, -0.06437183f, -0.02934153f, -0.06117956f, -0.28883877f, -0.05721807f, 0.06766712f, 
    0.07477223f, 0.01831616f, 0.09652601f, 0.02406146f, 0.02465857f, -0.25523502f, -0.07372330f, -0.16367139f, 
    0.19759217f, 0.20549800f, 0.40000820f, -0.13735192f, 0.03299261f, -0.00872183f, 0.05668702f, 0.10252177f, 
    -0.08501783f, 0.00273250f, -0.01105267f, -0.04339704f, 0.11072184f, 0.13689338f, -0.13104251f, 0.28754583f, 
    -0.00755676f, 0.05940712f, 0.03740223f, 0.24757977f, 0.06438735f, -0.05284209f, -0.06112485f, -0.09642046f, 
    0.09481876f, 0.12043338f, -0.03787282f, -0.04663828f, 0.09715171f, 0.08065785f, 0.12263396f, 0.16508093f, 
    -0.08152933f, 0.08946454f, -0.01826307f, 0.01187967f, 0.35038912f, -0.02048446f, -0.15251327f, 0.27454066f, 
    0.05327269f, 0.06701726f, 0.08508003f, 0.30355406f, -0.03502150f, 0.09606439f, -0.08275414f, 0.00036772f, 
    -0.01074545f, -0.23119920f, -0.21930808f, -0.15693948f, 0.19943051f, 0.01849271f, -0.04366771f, -0.11180089f, 
    0.10643078f, 0.00183493f, 0.01553383f, -0.03758033f, 0.02573745f, -0.02345763f, -0.12728287f, 0.12124222f, 
    0.05714414f, -0.00901304f, -0.12118787f, 0.03394878f, 0.05305614f, -0.04715993f, 0.11444434f, 0.05964043f, 
    0.12939781f, 0.09433842f, -0.21310227f, -0.04938712f, 0.07053646f, -0.01137950f, -0.05734902f, 0.17165428f, 
    0.04247953f, -0.04292716f, 0.09366965f, 0.04765207f, 0.11460424f, 0.12252361f, -0.12601890f, -0.10762298f, 
    0.13448752f, -0.04821759f, 0.04296019f, 0.02509014f, 0.06848183f, -0.04343290f, 0.11144072f, 0.10192586f, 
    0.25253615f, -0.29757908f, 0.10379463f, -0.11104298f, 0.08282426f, -0.09067194f, -0.08594558f, -0.20323230f, 
    0.10931173f, 0.12550840f, 0.08158431f, 0.12728977f, 0.01258210f, 0.09750397f, -0.09510616f, -0.17330238f, 
    -0.09083817f, -0.04129193f, -0.07762134f, -0.11459196f, 0.03059376f, -0.00888575f, -0.17257917f, 0.00739473f, 
    0.39579320f, 0.16527742f, 0.13478361f, 0.17124879f, 0.04885531f, 0.05720567f, 0.03923976f, 0.07852232f, 
    0.01395699f, 0.04826936f, 0.01719934f, 0.00052023f, 0.13075538f, 0.13861004f, 0.06049896f, 0.02058914f, 
    0.09224758f, -0.01022927f, -0.01098717f, 0.04306171f, 0.11634683f, -0.03346062f, 0.01942826f, 0.01226045f, 
    0.12773670f, -0.03216472f, 0.09704531f, -0.05128776f, 0.10341140f, -0.15716937f, -0.02830063f, -0.08259517f, 
    0.00718398f, -0.03869784f, -0.05520356f, -0.06513528f, 0.12592441f, -0.11528603f, -0.06540623f, 0.01151158f, 
    0.17061128f, -0.22493462f, -0.03628902f, 0.05862341f, 0.12638228f, 0.01030101f, -0.09710085f, 0.06410453f, 
    -0.01279979f, 0.27463830f, 0.14572905f, -0.10404237f, 0.04063297f, 0.19162235f, 0.02309277f, 0.08889864f, 
    0.08654608f, -0.01602449f, 0.01610642f, 0.16839311f, -0.18782702f, 0.04540607f, -0.07606252f, 0.46359318f, 
    -0.02300877f, -0.04303185f, 0.08367704f, 0.08427551f, -0.11804647f, 0.02022159f, -0.08514942f, 0.03774858f, 
    -0.00686139f, -0.18872863f, -0.02348939f, -0.05562722f, -0.01338146f, 0.04007629f, -0.07791135f, -0.04890520f, 
    -0.01659421f, -0.00214777f, -0.01296006f, 0.00514898f, 0.01522352f, 0.07449689f, -0.11223862f, -0.05067969f, 
    -0.13299245f, 0.04417012f, -0.04408356f, 0.15999480f, -0.12559156f, 0.02405381f, -0.01413445f, -0.11283352f, 
    -0.08453080f, 0.00365731f, 0.05566006f, -0.09726574f, -0.14388829f, -0.03760327f, -0.03687083f, -0.13063133f, 
    0.05522885f, 0.02579575f, 0.03359328f, 0.05952493f, 0.27924633f, 0.09404237f, 0.30404189f, 0.10786200f, 
    0.05886275f, 0.04535284f, 0.00926340f, 0.02221909f, 0.09871146f, -0.06527893f, 0.05403043f, 0.01880259f, 
    0.01552648f, 0.17110255f, -0.14387311f, 0.03423345f, -0.03160730f, 0.13186029f, -0.00746556f, 0.04117173f, 
    0.04500104f, -0.01902748f, -0.00440655f, 0.16663331f, 0.00643005f, -0.46134821f, 0.03901768f, -0.09042267f, 
    -0.15158954f, 0.00027903f, -0.05296625f, -0.04715537f, 0.03828261f, 0.14517806f, -0.00079439f, 0.04209976f, 
    -0.05738584f, -0.41554826f, 0.03303311f, 0.01136983f, 0.02391510f, 0.03569763f, -0.12979613f, 0.02164428f, 
    0.10053006f, 0.08445951f, 0.11644900f, -0.13494498f, 0.04195872f, 0.05828252f, 0.09591115f, -0.10009903f, 
    -0.01476232f, 0.04704217f, -0.07499208f, -0.06386931f, 0.00252135f, 0.05147440f, -0.07550779f, 0.02243637f, 
    -0.06210784f, 0.09443488f, -0.21399127f, 0.15123858f, -0.06684685f, 0.01541605f, 0.04173310f, 0.03923132f, 
    0.03977657f, -0.01325203f, 0.00075081f, -0.01637812f, 0.28496769f, -0.08714791f, 0.32479385f, 0.08667021f, 
    0.08974032f, -0.04389496f, -0.07846968f, -0.07611357f, 0.00909355f, 0.00520153f, -0.03936357f, -0.01033495f, 
    -0.32290688f, 0.09152070f, -0.29275778f, 0.19780661f, 0.07595424f, 0.02846444f, -0.08911297f, 0.06475318f, 
    0.05818232f, -0.12190583f, 0.03156660f, 0.08556214f, -0.11950687f, -0.29907608f, 0.40078172f, -0.24062459f, 
    0.04191423f, 0.15994723f, 0.05676361f, 0.04676140f, -0.05730069f, 0.12358689f, -0.13704190f, 0.00979078f, 
    0.13181557f, 0.00203997f, 0.35690662f, -0.20284787f, 0.07089910f, 0.08146390f, 0.00755477f, 0.01845036f, 
    0.04709110f, -0.03023257f, 0.04054071f, -0.02132838f, 0.04105570f, 0.00314040f, -0.13341764f, -0.15268429f, 
    -0.06717797f, 0.12879477f, -0.04806054f, 0.07944867f, -0.06118839f, -0.00667140f, 0.15442842f, 0.05479915f, 
    -0.42048347f, 0.02116212f, 0.04051588f, 0.07488175f, 0.01328509f, -0.05091650f, 0.07596872f, 0.05040968f, 
    -0.07764031f, -0.00770085f, -0.09315613f, 0.17385870f, -0.09054935f, 0.03281733f, -0.22226314f, 0.21703078f, 
    0.03739476f, 0.15533704f, -0.02743848f, 0.17166820f, -0.02790046f, -0.03647969f, -0.07890559f, -0.14098118f, 
    -0.07158349f, -0.06085396f, -0.10880271f, -0.15977859f, 0.03245901f, -0.18273884f, 0.19112813f, 0.02803967f, 
    -0.06639498f, -0.09828055f, 0.01786374f, 0.10825056f, -0.01307438f, -0.09460475f, 0.26409051f, 0.19386597f, 
    0.06832923f, 0.05440946f, -0.13063669f, -0.01116079f, -0.02179759f, -0.04343164f, -0.04058713f, 0.06612790f, 
    -0.29727584f, 0.42769977f, -0.03365011f, -0.17924760f, 0.00802740f, -0.18308364f, -0.00795566f, -0.03349785f, 
    0.01004974f, 0.04079677f, -0.03338390f, 0.07124700f, -0.17101060f, -0.07379198f, 0.07315084f, -0.08031964f, 
    0.13718875f, -0.00951836f, -0.01338269f, -0.08939380f, -0.04923292f, -0.08135931f, 0.02146850f, 0.02911002f, 
    0.02484450f, 0.12857483f, -0.14653705f, -0.35997555f, 0.04068976f, -0.08224130f, -0.06577432f, -0.10482252f, 
    0.09548000f, -0.01288328f, 0.04129160f, 0.06202084f, 0.13173579f, 0.01100455f, 0.15148322f, -0.00250214f, 
    -0.15765576f, -0.07332562f, -0.06183208f, 0.05672938f, 0.07299617f, 0.07786734f, 0.15045801f, -0.10794536f, 
    -0.25388446f, -0.29500294f, -0.00513454f, 0.00148610f, 0.06673723f, 0.05705377f, 0.17279683f, -0.09378013f, 
    0.16987979f, 0.01656906f, 0.11327803f, 0.10806668f, -0.04804831f, 0.23151307f, -0.07418155f, -0.07875925f, 
    0.01927510f, 0.08504955f, 0.05785261f, 0.04020057f, -0.06400570f, -0.15105844f, -0.01599409f, -0.04185306f, 
    -0.04291807f, 0.03357434f, 0.01660580f, -0.13458203f, -0.03700605f, 0.07938182f, -0.17864606f, 0.01025413f, 
    0.04206844f, -0.07913262f, 0.00377577f, -0.07933666f, 0.23129946f, 0.06477027f, -0.14430605f, 0.20428963f, 
    -0.12041494f, 0.02709848f, -0.07181999f, -0.04889670f, 0.17263679f, 0.07804210f, 0.09797065f, -0.05112984f, 
    0.06554224f, 0.03663557f, 0.15731439f, 0.13966438f, -0.09750789f, -0.04265052f, -0.14850959f, -0.11418552f, 
    0.15471341f, -0.07166260f, 0.18334223f, 0.10097385f, 0.10921062f, -0.05260687f, 0.13232978f, -0.00043808f, 
    0.15271355f, 0.00032131f, 0.14338571f, -0.00028504f, -0.01223859f, 0.15607151f, 0.03803964f, -0.06145595f, 
    0.22997430f, -0.11642641f, 0.36237553f, 0.14413518f, -0.04548997f, -0.02605650f, -0.04201562f, 0.13507523f, 
    0.08993423f, -0.01199681f, -0.08787736f, -0.09886388f, -0.03489063f, -0.05855182f, 0.21549246f, -0.02305393f, 
    0.07531267f, -0.13878457f, -0.03255136f, 0.00681474f, -0.12040541f, 0.14163806f, 0.11635301f, 0.00049956f, 
    -0.07627454f, 0.17990613f, -0.16896941f, 0.30264440f, 0.11882335f, 0.22741254f, 0.02937691f, 0.02639269f, 
    0.02258196f, -0.02332791f, 0.07389061f, 0.09603870f, 0.30312577f, -0.04911834f, -0.21831809f, 0.00376032f, 
    -0.12189525f, 0.08689618f, -0.03833685f, 0.06734656f, 0.18762702f, 0.02364321f, 0.21367790f, 0.05597518f, 
    0.03708441f, 0.20530999f, 0.20246580f, -0.05792911f, -0.11926824f, 0.10146415f, 0.05631713f, -0.00954107f, 
    0.00357416f, -0.02810651f, 0.00188712f, 0.15206271f, -0.24970423f, 0.45071855f, -0.48256212f, 0.34823352f, 
    -0.04251484f, 0.02806330f, -0.03370226f, -0.09059628f, -0.00526440f, -0.07648313f, 0.05875967f, -0.14321496f, 
    0.13539639f, -0.16207567f, 0.25526223f, -0.23863801f, -0.10236493f, 0.04523773f, -0.01360410f, 0.10350610f, 
    0.07601617f, -0.00289733f, 0.08299202f, 0.07052647f, -0.30300361f, -0.05726464f, 0.22944760f, -0.04420524f, 
    0.00195041f, -0.01246342f, -0.00981050f, 0.12519690f, -0.05570079f, -0.01232541f, 0.11311959f, 0.06817301f, 
    0.05089685f, 0.32429633f, 0.07442026f, -0.07718536f, -0.07189780f, -0.05858324f, -0.02934853f, -0.17300664f, 
    0.03646731f, 0.00891077f, 0.01876999f, -0.01676886f, -0.08582732f, -0.11731119f, -0.07532858f, -0.15782458f, 
    0.03259924f, -0.03770795f, 0.04958407f, 0.16156225f, 0.06359927f, -0.05841317f, -0.00630054f, 0.00065943f, 
    0.12898260f, 0.12070001f, -0.01587750f, -0.28157395f, 0.01744588f, -0.06841820f, -0.00353546f, 0.06050435f, 
    0.08511003f, 0.04147524f, 0.09010024f, 0.00979170f, -0.00722258f, -0.16436167f, 0.05862487f, -0.15479599f, 
    -0.01864768f, -0.05602216f, 0.01967802f, 0.00337631f, 0.06746198f, -0.07915886f, -0.04169025f, 0.09184499f, 
    -0.17763412f, -0.04740809f, -0.14030361f, -0.04874878f, 0.04778031f, 0.03113608f, 0.05267605f, 0.17563172f, 
    -0.07017553f, -0.06233336f, 0.03924366f, 0.22067171f, -0.03782914f, -0.10695612f, -0.24143413f, -0.09428333f, 
    -0.05037796f, 0.13039693f, 0.09587531f, -0.00038339f, 0.18399054f, 0.04896409f, 0.06783041f, 0.02314822f, 
    -0.14775255f, -0.12975375f, 0.04110504f, 0.10355978f, 0.10741527f, 0.09360263f, -0.03275957f, 0.06909709f, 
    -0.00873996f, -0.07110324f, -0.00925934f, -0.03940145f, -0.16753343f, 0.15673174f, -0.25302991f, -0.04389234f, 
    0.09596941f, -0.03750199f, -0.01865443f, 0.03811618f, -0.04060262f, -0.00773155f, 0.09660002f, -0.13577600f, 
    -0.04665349f, 0.16636768f, -0.04800833f, -0.05056253f, -0.00425877f, 0.10282394f, 0.08357759f, 0.09378695f, 
    0.04278881f, -0.14100367f, 0.09437243f, -0.04917396f, 0.07623300f, 0.14064516f, 0.35478625f, 0.10146943f, 
    -0.06916602f, -0.05171804f, 0.03895702f, 0.28562126f, -0.01551041f, -0.00545795f, -0.02027303f, 0.10363939f, 
    0.11652659f, 0.15199554f, 0.04857381f, 0.08917387f, 0.07056165f, -0.00678392f, 0.03262859f, 0.08188707f, 
    0.03069003f, -0.04531229f, 0.10850750f, -0.06234708f, -0.19041191f, -0.03083454f, -0.12978171f, -0.09546153f, 
    0.00517739f, 0.00384049f, 0.18067026f, 0.11512411f, 0.26287326f, 0.06688961f, 0.04958992f, 0.07745277f, 
    0.00332620f, 0.16465126f, 0.14636731f, -0.10497117f, 0.09078532f, 0.09315626f, -0.06183978f, 0.02173707f, 
    0.02276394f, 0.05689362f, -0.00576366f, 0.01153324f, -0.20307775f, -0.00857634f, -0.14708488f, 0.06591398f, 
    0.14243086f, 0.06097206f, 0.01608301f, 0.05598985f, 0.09351151f, -0.14156385f, -0.04714831f, -0.12226526f, 
    -0.41153923f, 0.10466465f, -0.09165252f, -0.07446729f, 0.16390310f, 0.04278684f, 0.09189458f, -0.07634197f, 
    0.10540547f, 0.02369349f, -0.04213700f, 0.03112572f, 0.22098622f, -0.13540938f, 0.00110251f, -0.01479013f, 
    0.12702610f, 0.10830146f, -0.03432375f, -0.03983824f, 0.03961537f, 0.06043996f, -0.00736427f, -0.00466871f, 
    0.22935402f, 0.21707039f, 0.16036628f, 0.31139773f, -0.10754308f, -0.09108341f, -0.05228110f, 0.13872884f, 
    0.14991245f, 0.03460264f, -0.06672719f, 0.04720459f, -0.26912531f, -0.17926010f, -0.12212765f, -0.15308219f, 
    -0.00037203f, -0.06625606f, -0.04044203f, -0.03843285f, 0.09038868f, -0.11384007f, 0.02303010f, 0.01112587f, 
    -0.23593004f, -0.16636080f, 0.09083697f, 0.07981481f, -0.19290093f, -0.07530530f, 0.04354063f, 0.10041970f, 
    -0.05612875f, 0.17003879f, 0.04856386f, 0.08513106f, -0.41486105f, -0.27732876f, -0.19507416f, 0.00759022f, 
    0.12578274f, -0.03605660f, 0.14252065f, 0.03070167f, 0.07392095f, -0.03009431f, -0.03669455f, 0.07095313f, 
    0.02770024f, -0.37241709f, 0.20957407f, -0.22995305f, -0.02213490f, -0.07538781f, 0.00324058f, 0.12411117f, 
    -0.04077487f, 0.04611618f, 0.12338833f, -0.01378026f, -0.09528304f, 0.00250026f, -0.10647088f, 0.01457071f, 
    -0.02857782f, -0.00951190f, 0.00970679f, 0.12550315f, -0.04406236f, -0.06602514f, 0.00543160f, 0.12717648f, 
    -0.04869046f, -0.09720957f, 0.15330106f, 0.17260039f, 0.10045426f, -0.00157703f, -0.00165423f, 0.04275752f, 
    0.13263527f, 0.08902558f, -0.00070397f, -0.01610587f, -0.20081073f, 0.07151528f, 0.11855070f, 0.03446130f, 
    0.05686069f, 0.01752518f, -0.05904942f, 0.05572551f, 0.08794548f, 0.00923646f, 0.01682636f, 0.03669995f, 
    -0.12854578f, -0.09568691f, 0.11494597f, -0.04967022f, -0.08246691f, -0.12852147f, -0.11268903f, 0.08510377f, 
    -0.08288269f, -0.04615772f, -0.12866420f, 0.03892750f, 0.09165185f, -0.03237156f, 0.02936918f, 0.07119370f, 
    -0.00279693f, 0.03911083f, -0.15072443f, -0.08517627f, 0.05122728f, -0.02850159f, -0.12623766f, 0.04179341f, 
    -0.20303287f, 0.03513653f, 0.12757522f, -0.02047550f, 0.02214869f, 0.04328388f, -0.06976796f, 0.09247795f, 
    0.12905279f, 0.04285007f, -0.01781664f, 0.06037265f, -0.20180769f, 0.15804052f, -0.37464830f, 0.15733759f, 
    0.05989765f, -0.10570003f, 0.05195966f, 0.01796831f, 0.12164355f, -0.00970360f, -0.09363380f, 0.11129624f, 
    0.05424994f, 0.04242997f, -0.01034323f, -0.20074618f, -0.03052747f, -0.01805832f, -0.04800817f, -0.01112236f, 
    0.05050299f, 0.06083881f, -0.01225298f, 0.02315238f, 0.15652941f, -0.18059029f, 0.17240269f, -0.22313689f, 
    0.05839626f, -0.05411077f, -0.08829279f, -0.10092735f, 0.12695237f, 0.10354024f, -0.03640396f, 0.00151626f, 
    0.17646492f, -0.14838918f, 0.12067858f, 0.00547885f, 0.02726601f, 0.01542848f, -0.16224751f, 0.08770989f, 
    -0.00348642f, 0.16483416f, -0.02138115f, 0.02879726f, -0.19637483f, -0.29324061f, -0.03700863f, -0.12526561f, 
    0.01825012f, 0.00957697f, -0.10962970f, -0.06285725f, 0.03331932f, -0.13413668f, -0.06601225f, 0.10967093f, 
    -0.14528319f, -0.01276790f, -0.00126860f, 0.07362411f, -0.00550814f, -0.00208777f, 0.05687999f, 0.07863229f, 
    -0.02237919f, -0.09378859f, -0.02688860f, 0.12297836f, -0.01760094f, -0.13360789f, 0.25405419f, -0.25991797f, 
    -0.06614174f, 0.03316627f, 0.06549022f, -0.10893995f, 0.02812099f, -0.07754055f, 0.02189900f, 0.03485896f, 
    -0.25369835f, 0.21724214f, -0.04768855f, -0.11872380f, -0.01556784f, -0.11271676f, -0.10061383f, -0.12104467f, 
    0.06196141f, -0.07761061f, 0.00241470f, 0.02820115f, 0.18595515f, -0.04444732f, -0.00375743f, 0.02325728f, 
    0.08993544f, 0.00854397f, -0.04546729f, 0.04309579f, 0.00895158f, 0.08255547f, 0.04529699f, -0.12869503f, 
    -0.12303141f, 0.17041667f, -0.02406064f, -0.13725756f, 0.12760015f, -0.06282483f, 0.16507842f, -0.07153200f, 
    0.17758450f, 0.03588673f, -0.01961395f, 0.02346666f, 0.11142167f, -0.22344166f, -0.02115145f, 0.16467525f, 
    0.05145428f, 0.05095710f, 0.03829942f, -0.06837175f, -0.01542616f, 0.00392469f, 0.01509639f, 0.04440010f, 
    -0.19026747f, -0.37044734f, 0.12098413f, -0.17468295f, -0.08968568f, 0.08267047f, 0.07527780f, 0.09750280f, 
    -0.10149952f, -0.08611937f, 0.01546665f, 0.06324258f, -0.19913097f, -0.05341904f, 0.06875768f, 0.06096424f, 
    -0.02990344f, 0.07331493f, 0.15210256f, 0.05458704f, -0.25695089f, -0.05667369f, 0.07081980f, -0.00191422f, 
    -0.05120560f, -0.34701064f, 0.07926900f, 0.15244144f, 0.05417340f, 0.05365187f, 0.00472990f, 0.06675232f, 
    -0.09894311f, -0.09055144f, -0.07610001f, -0.01516815f, 0.17976405f, 0.09948723f, 0.00891929f, -0.18482339f, 
    0.00365706f, -0.01370843f, -0.01200301f, -0.03135400f, 0.00214423f, -0.09728154f, -0.08696814f, -0.03733046f, 
    -0.33243397f, -0.33199131f, -0.06737805f, -0.19230632f, 0.05692780f, -0.01041860f, 0.06051975f, 0.00611056f, 
    -0.10069570f, -0.07776136f, -0.07764768f, 0.10432310f, 0.17926200f, -0.03903139f, -0.01826902f, 0.08736159f, 
    -0.17564552f, -0.04881448f, 0.13338281f, -0.03293753f, -0.00951575f, -0.07115053f, -0.08370826f, -0.03404093f, 
    0.23560344f, 0.00341671f, 0.20578316f, 0.03864257f, -0.00118571f, -0.04666495f, -0.06850468f, -0.04924712f, 
    -0.03821290f, 0.04124432f, -0.01667602f, 0.00558833f, 0.04437787f, -0.09228306f, 0.11640029f, 0.14341263f, 
    0.12450894f, -0.01750696f, -0.05477347f, -0.07923131f, -0.05296158f, -0.10677111f, -0.03823075f, -0.01346551f, 
    0.09593192f, -0.09684710f, -0.11220495f, 0.06560934f, -0.03289025f, 0.01999554f, 0.27852470f, 0.06685981f, 
    -0.20076329f, -0.07010599f, 0.07710357f, 0.20871207f, -0.11356997f, -0.09672676f, -0.16556945f, -0.17924824f, 
    0.12297349f, -0.13563271f, -0.25380668f, 0.05620652f, 0.00729437f, -0.08740278f, -0.07123006f, -0.09409190f, 
    0.21802358f, 0.00617024f, -0.07428846f, 0.01411220f, 0.05317315f, 0.07861443f, 0.04644374f, 0.07324887f, 
    0.02930882f, 0.00584648f, 0.08547670f, -0.11524291f, 0.34637478f, 0.24952576f, 0.06113828f, -0.24911827f, 
    0.00950967f, 0.04949445f, 0.03347484f, 0.01343741f, 0.12272727f, 0.09791647f, 0.08806441f, 0.09611848f, 
    0.08867618f, 0.10530191f, 0.03743543f, 0.09097364f, -0.00368468f, 0.10279109f, 0.18053626f, 0.00055654f, 
    -0.03481501f, -0.06292772f, 0.18921974f, -0.07388029f, -0.05023800f, 0.03014148f, 0.03514965f, 0.01992119f, 
    -0.07731708f, -0.04081922f, 0.02166520f, -0.02057018f, -0.00783901f, 0.01038364f, -0.00050969f, -0.06340465f, 
    0.17037390f, 0.07573919f, -0.01428545f, 0.09080166f, 0.02718332f, 0.08641846f, 0.06393907f, 0.13111122f, 
    0.02758980f, 0.05163907f, -0.01843041f, -0.08812918f, 0.39134726f, -0.12220277f, -0.12523033f, -0.20014462f, 
    0.04236290f, 0.06826343f, -0.07158299f, 0.03162931f, -0.04595717f, 0.03918073f, 0.00035273f, 0.18986833f, 
    0.12027729f, -0.16199847f, -0.02108854f, 0.06709684f, 0.06260013f, 0.08932101f, 0.11899423f, -0.00787150f, 
    0.01852409f, 0.05663712f, 0.09586657f, 0.00905918f, -0.29228094f, -0.21422897f, -0.11633630f, 0.11551762f, 
    -0.12722735f, 0.04828948f, 0.03865291f, 0.01654814f, 0.07658103f, 0.13392872f, 0.14436230f, 0.01509274f, 
    0.17629831f, -0.10401350f, -0.25625104f, -0.26188487f, 0.02208979f, 0.05508760f, 0.05304481f, -0.05356969f, 
    0.11215850f, 0.03930736f, -0.03072221f, -0.00194374f, 0.11624577f, 0.00396176f, -0.09493844f, 0.05330862f, 
    -0.07593892f, 0.06004154f, 0.06179131f, -0.02240523f, 0.08328176f, 0.08048199f, 0.16640568f, -0.05117086f, 
    0.17345400f, -0.18764116f, -0.04221947f, 0.09524986f, -0.07896486f, 0.13666758f, 0.13122387f, 0.07392967f, 
    -0.02740696f, -0.13271081f, 0.04053939f, -0.05879223f, 0.05828160f, 0.04777524f, 0.08862183f, -0.04741883f, 
    -0.03655037f, -0.05101155f, 0.02219248f, 0.03300362f, 0.09371430f, 0.10052484f, 0.05411678f, -0.00547730f, 
    -0.14210883f, -0.31109729f, -0.17949724f, -0.24480742f, -0.00454910f, 0.03817793f, -0.14399604f, 0.25031281f, 
    0.02176650f, -0.03534077f, -0.11447145f, -0.01769388f, 0.42085084f, 0.07889683f, 0.03164516f, -0.09602913f, 
    0.02717850f, -0.15729566f, 0.06198878f, 0.27432427f, 0.07913757f, 0.05988171f, -0.00423020f, -0.03374469f, 
    -0.12851515f, 0.10034472f, -0.05543277f, 0.21068630f, 0.07856897f, -0.05112914f, 0.16524582f, 0.05622047f, 
    -0.02866086f, 0.19672698f, 0.12845793f, 0.01098625f, 0.02402606f, -0.00776973f, 0.04740236f, 0.12435060f, 
    -0.05213842f, -0.01068490f, -0.03275147f, -0.02223425f, -0.02569224f, -0.04268787f, -0.04708977f, -0.07239799f, 
    -0.41375759f, -0.11711079f, -0.17496167f, -0.04554465f, -0.07536760f, -0.05768653f, 0.11300093f, 0.26986846f, 
    -0.04888623f, -0.13400793f, 0.06988415f, 0.05603384f, 0.01197359f, -0.25366798f, -0.25307578f, 0.03510676f, 
    -0.10347743f, -0.11959875f, 0.16470522f, 0.13989164f, 0.07238612f, 0.02046123f, 0.23054384f, 0.17483579f, 
    0.08155337f, 0.14955351f, -0.07100481f, 0.19484858f, 0.01309017f, -0.02228085f, 0.13623811f, 0.08820504f, 
    0.08239105f, -0.04817255f, 0.22353336f, 0.11776061f, -0.01748291f, 0.11737031f, 0.21833308f, 0.18769385f, 
    0.02691509f, -0.01616555f, -0.01146566f, 0.02633110f, 0.12492038f, -0.01530180f, 0.14584212f, -0.02011997f, 
    -0.04377569f, 0.18154047f, -0.08351631f, 0.06295592f, -0.07736172f, -0.10726182f, 0.08346866f, 0.08365340f, 
    -0.09858065f, 0.04135799f, 0.10400020f, 0.08119295f, 0.20068067f, 0.04858579f, 0.04995143f, -0.01933987f, 
    -0.00766664f, -0.04330664f, 0.06588966f, 0.04655607f, 0.05857651f, 0.03818923f, -0.04198032f, 0.11904019f, 
    0.09578635f, -0.02686599f, 0.18913759f, -0.03025923f, -0.09328067f, -0.08310362f, 0.00509721f, -0.10069600f, 
    -0.00042658f, 0.00781763f, 0.10539723f, 0.02975498f, 0.18901180f, 0.20104259f, 0.21746111f, -0.07564703f, 
    -0.06387912f, -0.04790422f, -0.02550894f, -0.03916229f, 0.03735796f, 0.11288908f, -0.02194321f, -0.02210371f, 
    -0.21113954f, -0.53578681f, -0.20828111f, 0.09700610f, -0.02005204f, -0.12773527f, 0.06660394f, 0.00945005f, 
    -0.10455105f, -0.06871761f, -0.04173020f, 0.05337969f, -0.01127109f, -0.09064445f, -0.18565772f, -0.22707717f, 
    -0.00884375f, -0.05982419f, 0.02261397f, 0.09902637f, 0.08949666f, -0.04170547f, -0.11080663f, 0.01130741f, 
    -0.06579521f, -0.24598141f, -0.00774505f, 0.08067527f, -0.06659690f, 0.05933419f, 0.01256643f, -0.00161954f, 
    0.09863428f, -0.00914230f, 0.07844706f, -0.05698156f, 0.04807266f, -0.05996842f, -0.04371098f, -0.08194236f, 
    0.00971730f, -0.05506941f, -0.04545921f, -0.03555984f, 0.04809041f, 0.10715678f, 0.13014817f, 0.11383413f, 
    -0.24176019f, -0.22550514f, -0.03264267f, -0.02868000f, -0.01704352f, 0.06250402f, -0.11881446f, -0.06352735f, 
    0.01785791f, -0.03735800f, -0.15804829f, -0.09021816f, 0.19751243f, 0.21821664f, 0.16964333f, -0.05386232f, 
    -0.13082229f, -0.01200984f, 0.12650104f, -0.07587375f, 0.01173730f, 0.03848992f, 0.01456242f, -0.04244781f, 
    0.09382556f, -0.02565818f, -0.02521195f, 0.14145777f, -0.05144848f, -0.09671488f, 0.08669882f, -0.00071160f, 
    0.06247852f, 0.01034415f, 0.00351339f, 0.05168057f, -0.05868281f, -0.19468206f, 0.05372149f, 0.05748761f, 
    -0.03448902f, 0.02096107f, 0.22363693f, 0.08214152f, 0.03764841f, -0.16629958f, 0.06780680f, -0.04434201f, 
    0.01435503f, -0.19504412f, -0.12094866f, -0.32881913f, -0.13532256f, 0.00564497f, 0.00392146f, 0.01998530f, 
    0.11533992f, 0.00021984f, 0.11541582f, -0.08185210f, 0.16350776f, 0.12901273f, 0.08193263f, 0.05603039f, 
    0.03595462f, 0.06161010f, 0.04097225f, 0.02578673f, 0.04585773f, 0.08777226f, -0.00661649f, -0.04409900f, 
    -0.09885228f, -0.30639461f, -0.16366909f, -0.04286880f, -0.00827220f, -0.00437563f, 0.00468338f, -0.01246586f, 
    -0.07479709f, -0.12154496f, -0.05555975f, -0.04299466f, 0.21187818f, 0.10171126f, 0.05779694f, -0.01661944f, 
    -0.05594815f, -0.02489630f, 0.04702249f, 0.00204433f, 0.05349940f, 0.08400068f, 0.01296665f, 0.00677752f, 
    0.05814206f, -0.03268515f, -0.10890367f, 0.04121011f, 0.02435584f, 0.02753671f, -0.00825817f, 0.05733665f, 
    0.04511825f, -0.04788964f, 0.01409007f, 0.06347536f, 0.20608009f, 0.10114891f, 0.20426247f, -0.00251768f, 
    0.03183196f, -0.12796988f, 0.03914571f, 0.12797621f, 0.04013606f, 0.03261293f, -0.12363080f, -0.06986640f, 
    -0.40245476f, -0.51877570f, -0.28319380f, -0.02648209f, 0.09412651f, 0.17388742f, -0.10941903f, -0.19596763f, 
    0.25551343f, 0.09427199f, 0.13247831f, 0.05282479f, -0.03945430f, -0.32921803f, -0.20831934f, -0.19281709f, 
    -0.03325060f, 0.05860506f, 0.17020996f, -0.00743872f, -0.10230793f, -0.10943672f, -0.06144225f, 0.01511958f, 
    0.11714862f, 0.12780303f, 0.14439791f, 0.03166623f, 0.00022520f, 0.01816757f, -0.03853457f, -0.04817963f, 
    -0.01100065f, 0.02931435f, -0.07382100f, 0.03014910f, 0.09123903f, -0.08366106f, -0.05425591f, -0.12829900f, 
    0.00720952f, 0.18190148f, 0.02281955f, 0.09131348f, -0.02114140f, 0.21202616f, 0.04755849f, -0.01741710f, 
    0.11416635f, -0.46000919f, 0.09735750f, -0.07748722f, -0.09075256f, 0.04613758f, 0.16750056f, 0.08528018f, 
    -0.14496556f, -0.04742447f, 0.11842350f, -0.09594307f, 0.27514172f, 0.08171964f, 0.01108507f, 0.06842533f, 
    0.08352344f, -0.10350657f, 0.11827368f, -0.16945490f, -0.04399000f, 0.02589737f, -0.01328896f, 0.01196656f, 
    0.07624185f, 0.04964120f, 0.06596106f, 0.05181891f, 0.05510549f, 0.05405390f, 0.01445502f, 0.06655729f, 
    0.08788968f, 0.00928830f, -0.05176108f, -0.01876563f, -0.17757981f, -0.02907179f, 0.05033619f, 0.16492243f, 
    0.08624111f, 0.15397553f, 0.08718114f, 0.03268180f, 0.02273607f, -0.01673354f, 0.01328311f, 0.05217272f, 
    0.26648876f, 0.16359280f, -0.01074045f, -0.23115698f, 0.04757510f, 0.00664893f, 0.03194141f, -0.01698823f, 
    0.03849412f, 0.01473956f, 0.09927832f, 0.01131130f, 0.03672152f, -0.42426410f, -0.25373679f, -0.33799908f, 
    -0.00184794f, -0.31365031f, -0.31046048f, -0.05396091f, 0.00194167f, -0.03460065f, -0.06269822f, -0.13137160f, 
    -0.44073218f, -0.35056910f, -0.44881451f, -0.38987908f, -0.10653965f, -0.06209801f, -0.01593556f, 0.16893706f, 
    -0.02270907f, -0.00717041f, -0.00803850f, -0.11225494f, 0.07729720f, -0.00494742f, 0.06846881f, 0.16242842f, 
    0.14131831f, -0.00151800f, 0.15039469f, -0.01528505f, 0.11031942f, -0.13045311f, -0.10165942f, 0.13012104f, 
    0.01601911f, 0.06546218f, 0.00215954f, -0.01247188f, 0.03312210f, 0.07267753f, 0.12432199f, -0.01900806f, 
    -0.00875305f, 0.04814829f, -0.07549625f, 0.15427436f, 0.18611388f, 0.03347259f, 0.02632354f, -0.11191103f, 
    0.16650784f, -0.05840528f, 0.01002943f, -0.01738520f, -0.13788620f, 0.06630082f, 0.00332519f, 0.16375728f, 
    0.17666596f, -0.07150878f, 0.21562895f, 0.27996108f, 0.03058763f, -0.09017774f, 0.06030119f, 0.06230795f, 
    -0.00251466f, 0.22813500f, 0.01606441f, 0.05174996f, 0.35537013f, -0.13476816f, -0.00222006f, 0.07005770f, 
    0.07769927f, 0.01410800f, -0.04310614f, 0.01982036f, 0.01754956f, -0.08753049f, 0.03765589f, -0.14253557f, 
    -0.02421637f, -0.00492044f, -0.00686987f, 0.00319487f, -0.00651292f, 0.03105109f, 0.01018313f, 0.03123367f, 
    0.01493157f, -0.04082144f, -0.02939235f, -0.01961576f, -0.00415167f, -0.02751753f, 0.01502588f, -0.03873987f, 
    -0.01688676f, -0.03343110f, -0.00412996f, -0.01196977f, 0.02324058f, -0.01108762f, 0.02562192f, -0.02274152f, 
    0.01122733f, -0.02517967f, -0.00824995f, 0.00339873f, -0.04089888f, -0.01284847f, -0.00884946f, -0.01431859f, 
    -0.02030884f, 0.00942202f, 0.01826110f, -0.01290253f, 0.01002894f, -0.01196277f, 0.00446605f, 0.01727784f, 
    0.01771390f, 0.01375922f, 0.00563793f, -0.02655563f, 0.01880228f, -0.01417755f, 0.02365296f, -0.01547224f, 
    0.02737820f, -0.02497025f, 0.01721660f, 0.00638585f, -0.00566795f, 0.00602345f, -0.00278388f, -0.01790353f, 
    0.02966524f, 0.00800087f, 0.02044150f, 0.02288529f, -0.01077036f, -0.01666706f, -0.01170669f, 0.03099713f, 
    0.02394467f, -0.03000109f, -0.01182910f, 0.00796359f, -0.02004233f, 0.02808891f, 0.03231068f, 0.02134868f, 
    -0.01985455f, -0.00074061f, -0.02243456f, 0.00871713f, 0.00315570f, 0.01705233f, -0.00176589f, -0.00283252f, 
    0.00120715f, 0.00948242f, 0.01340143f, -0.03446440f, -0.02183775f, -0.02365240f, -0.02103201f, -0.02477280f, 
    0.01995916f, -0.03625592f, 0.00595071f, -0.03075829f, 0.02930722f, 0.00501368f, 0.02839657f, -0.01666163f, 
    -0.03059942f, -0.01088730f, 0.00411215f, 0.03357366f, -0.00001627f, 0.00027724f, -0.00505802f, 0.00693078f, 
    -0.01256234f, 0.01434796f, 0.00100319f, -0.01749171f, 0.02621691f, -0.00142435f, -0.01016358f, -0.01805777f, 
    -0.03340982f, -0.02726479f, -0.02780411f, -0.02872595f, -0.02042001f, 0.02435682f, 0.02874266f, -0.01720198f, 
    0.00262081f, -0.03572045f, -0.02605638f, -0.00790729f, -0.03593216f, -0.02659244f, -0.01879673f, 0.03265888f, 
    0.03249938f, -0.00353272f, 0.00090432f, -0.00117975f, -0.00844362f, 0.02758145f, 0.03209143f, -0.02513148f, 
    -0.01644857f, -0.01768720f, 0.03170958f, -0.00831824f, 0.02056903f, -0.00679960f, -0.00641358f, -0.00097452f, 
    0.02065491f, 0.01408403f, -0.00500235f, 0.01967801f, -0.03273272f, -0.01685176f, -0.01085777f, 0.01581263f, 
    0.02372033f, -0.00709996f, 0.02307920f, -0.03136383f, -0.01043704f, -0.00023530f, -0.02237887f, 0.01109932f, 
    -0.01274969f, 0.02590302f, -0.01964402f, 0.02142400f, -0.01499097f, -0.02579558f, -0.00512903f, -0.03154847f, 
    0.01329718f, 0.01060256f, -0.00089396f, -0.03148242f, -0.00113245f, -0.02726836f, -0.00028334f, 0.02131383f, 
    0.00401376f, -0.03211994f, 0.01311984f, 0.01579424f, 0.03780197f, -0.00400855f, -0.03230400f, -0.02656982f, 
    -0.01196152f, -0.03442330f, 0.02495079f, 0.02242162f, -0.04019045f, -0.02355779f, -0.03312832f, -0.02485204f, 
    0.01217096f, -0.01999904f, 0.00538652f, -0.00853120f, 0.01382117f, 0.00265884f, -0.01917487f, 0.01199079f, 
    -0.03850568f, 0.00069624f, 0.02620393f, -0.02440492f, 0.01905994f, -0.00620747f, -0.02716104f, -0.01935836f, 
    -0.02478464f, -0.02650736f, 0.00075845f, 0.01775042f, 0.01567337f, -0.00777521f, -0.01913993f, -0.02437262f, 
    0.03384161f, 0.00088530f, 0.01225998f, 0.00788245f, 0.00100615f, -0.03960477f, -0.01630998f, 0.02612295f, 
    -0.01406526f, -0.02727940f, -0.01796613f, 0.00082794f, -0.00957902f, -0.01627562f, -0.01855675f, -0.00797173f, 
    0.02875947f, -0.00662269f, -0.00942448f, -0.03277375f, -0.02345748f, 0.02786980f, -0.01070042f, 0.02596892f, 
    -0.03309379f, 0.02323139f, -0.02468261f, -0.00965978f, -0.02927558f, -0.03610907f, -0.01644444f, 0.02024343f, 
    -0.00328933f, -0.01558379f, -0.02611136f, -0.01669351f, 0.00058065f, -0.01760231f, 0.01636348f, -0.03602440f, 
    0.02225157f, -0.01786320f, 0.00464456f, -0.00938058f, 0.03394781f, -0.02944165f, -0.03635197f, -0.03604302f, 
    0.01201110f, -0.00627614f, -0.01604307f, 0.00226403f, -0.00447337f, 0.01049719f, -0.03583347f, -0.02322401f, 
    -0.01820120f, 0.03275133f, 0.00958541f, 0.02032259f, -0.01236731f, -0.00361846f, 0.01753510f, 0.03838022f, 
    0.03008569f, -0.03345086f, 0.00061815f, 0.02052145f, -0.02631657f, 0.00293879f, -0.03655497f, -0.00434933f, 
    -0.00232068f, 0.00560028f, -0.01014957f, 0.01714854f, 0.01178902f, 0.02273753f, 0.03110878f, 0.02302705f, 
    0.00046948f, 0.02635736f, 0.02099988f, 0.01905054f, -0.02365262f, -0.02654822f, 0.02074866f, 0.01093593f, 
    -0.01053788f, -0.03279871f, -0.00563251f, -0.00654991f, -0.03171360f, 0.00681769f, -0.00825485f, -0.01352433f, 
    0.00825043f, -0.00647113f, -0.03910118f, -0.01999161f, 0.02761143f, 0.01292703f, 0.00331920f, 0.02934155f, 
    0.02735568f, 0.02138773f, 0.00969526f, 0.00169597f, 0.02087661f, -0.00258884f, -0.00960910f, 0.01539369f, 
    -0.00592744f, -0.03578312f, -0.03164302f, -0.02890507f, 0.01554147f, -0.00082846f, 0.02801792f, -0.00960154f, 
    -0.00593926f, -0.03055800f, -0.03693362f, 0.00217072f, 0.02719417f, 0.00296750f, -0.01643591f, 0.02669035f, 
    -0.01466021f, 0.01785322f, 0.01934134f, 0.02484828f, -0.00757791f, 0.01760738f, -0.00698483f, 0.00328916f, 
    0.00053758f, 0.01937355f, -0.01293371f, -0.03627235f, -0.01908898f, -0.02737956f, -0.02680984f, 0.01358260f, 
    -0.02288769f, -0.03522735f, -0.00655444f, 0.00906080f, 0.02576710f, 0.00720234f, -0.03530367f, -0.02457878f, 
    -0.03319137f, -0.02892237f, 0.00917650f, -0.01510247f, -0.01778681f, 0.00246780f, 0.01649383f, -0.02684500f, 
    -0.00378475f, 0.02759212f, -0.00403848f, -0.03202938f, -0.03525281f, -0.01288004f, 0.01301568f, 0.02074805f, 
    -0.03216304f, 0.02119784f, 0.03485505f, -0.01292353f, -0.00677859f, 0.00630453f, -0.00816125f, 0.02533535f, 
    -0.01066507f, -0.00969073f, -0.01737968f, -0.01943209f, 0.01808340f, -0.03002734f, -0.03135046f, -0.02459059f, 
    -0.00252891f, -0.03223500f, -0.02635975f, -0.00286671f, -0.03363570f, 0.01627851f, -0.03391285f, 0.01098347f, 
    -0.03465550f, -0.02518480f, 0.01235428f, -0.03461422f, -0.00793374f, -0.00363550f, -0.01957907f, -0.02551312f, 
    -0.00367161f, -0.02207784f, 0.01817224f, -0.03513959f, -0.01622917f, -0.02765936f, -0.02036497f, -0.03857660f, 
    0.00968599f, -0.03780055f, -0.01362836f, 0.01216198f, -0.01702635f, -0.00785550f, -0.00985778f, 0.01506703f, 
    -0.00653574f, -0.02919361f, 0.00077063f, 0.00172664f, 0.02668062f, 0.01947266f, -0.00194099f, 0.00598021f, 
    -0.02171106f, -0.00043704f, -0.02846533f, 0.00223316f, -0.03309333f, 0.03410032f, 0.01101237f, -0.01025572f, 
    -0.02855086f, -0.02713523f, -0.00994287f, 0.00639109f, -0.01332591f, 0.02527877f, 0.01982979f, -0.02641460f, 
    -0.01390382f, -0.00313684f, -0.04002136f, 0.02299928f, 0.02925898f, 0.01868397f, -0.00671223f, 0.00532614f, 
    -0.02808503f, -0.02499363f, -0.03208308f, 0.02079495f, 0.01773969f, 0.03200196f, 0.02260266f, -0.00476184f, 
    -0.01271490f, 0.00560666f, -0.02027473f, -0.02833533f, 0.02983053f, -0.03116845f, -0.01455921f, 0.01131780f, 
    -0.02079437f, 0.02131154f, 0.01661121f, 0.00312455f, 0.00328346f, 0.00965078f, 0.02425322f, -0.00569883f, 
    0.01278608f, 0.01172119f, -0.03066366f, 0.00366448f, 0.01033410f, 0.03314367f, 0.02715479f, -0.01952265f, 
    -0.01948256f, 0.00011307f, -0.02295467f, -0.03042324f, -0.02092987f, -0.00728616f, -0.01107616f, 0.02077762f, 
    0.01557137f, 0.02051498f, 0.00918001f, -0.02942809f, -0.02460514f, -0.00553228f, 0.02248246f, -0.03487746f, 
    -0.01790537f, -0.00063273f, -0.00151927f, -0.01389557f, -0.02876396f, 0.00050194f, 0.00012326f, 0.03188232f, 
    -0.00774648f, 0.01961236f, -0.00672394f, -0.03804951f, 0.03412308f, 0.02245227f, -0.04029692f, -0.00964117f, 
    -0.02252185f, -0.01406835f, -0.01320114f, -0.02745721f, -0.01863383f, -0.02066220f, -0.02248488f, 0.01363090f, 
    -0.02577137f, 0.02747199f, -0.00004194f, -0.00798277f, 0.00957850f, -0.00958672f, -0.00076435f, -0.03341492f, 
    -0.03592801f, -0.00407773f, 0.02981035f, -0.03937669f, 0.00455826f, -0.02222414f, -0.03113225f, -0.02879888f, 
    0.01404584f, -0.01120084f, 0.02038144f, -0.02418008f, -0.01144707f, 0.03304441f, 0.02368363f, 0.00530089f, 
    -0.00992325f, 0.01850460f, 0.01617351f, 0.02624922f, 0.00744059f, 0.01985181f, -0.00437935f, -0.03758119f, 
    -0.00826557f, 0.00958065f, -0.02388886f, -0.01576314f, -0.02300485f, -0.03467377f, 0.02091541f, -0.03504828f, 
    0.01552314f, -0.04051119f, 0.00650859f, -0.04088828f, 0.02116461f, 0.01055185f, 0.01492930f, 0.02678549f, 
    -0.00390666f, -0.03455301f, 0.03552964f, -0.04055855f, -0.03117924f, 0.02705227f, -0.03508059f, -0.03483966f, 
    0.02554012f, -0.02562627f, -0.00610422f, -0.00821839f, -0.00769460f, -0.01165770f, -0.01729455f, 0.01654382f, 
    0.00134549f, -0.02250744f, -0.00657347f, -0.01296633f, 0.01745364f, -0.03482447f, -0.02695547f, 0.00873144f, 
    0.00646114f, 0.02673081f, -0.00151191f, 0.03063588f, 0.03734201f, -0.01004824f, 0.00718400f, 0.02200297f, 
    -0.01300562f, -0.02778457f, 0.00448077f, 0.02478135f, -0.03482246f, 0.01758396f, -0.03287738f, 0.01548198f, 
    0.02786740f, -0.01889485f, 0.00525340f, 0.00477780f, 0.00420395f, -0.00171784f, 0.00354539f, 0.02094994f, 
    -0.02127196f, -0.00536936f, 0.00952663f, -0.03298199f, -0.03771975f, -0.01991162f, -0.00928556f, -0.02120784f, 
    -0.00721781f, -0.02905309f, 0.02533744f, -0.03129751f, -0.03099143f, -0.01689079f, -0.00321374f, 0.02721485f, 
    0.02971580f, -0.00623626f, -0.02715844f, -0.03610311f, -0.01566694f, 0.01918454f, -0.02467103f, -0.02577034f, 
    0.00071689f, 0.01314473f, 0.01514714f, 0.01750209f, 0.00069564f, 0.00769512f, 0.02018549f, -0.03677227f, 
    -0.01532494f, 0.01692701f, 0.03542772f, 0.01685564f, 0.00756406f, -0.01840663f, -0.03625896f, -0.01026144f, 
    0.03517731f, 0.00572980f, 0.01886228f, 0.03289174f, 0.00127697f, 0.02480185f, 0.02234641f, -0.01973709f, 
    0.03094614f, 0.02942086f, -0.01696428f, -0.00092716f, 0.00772386f, 0.02607426f, 0.00991616f, -0.02982228f, 
    0.01644399f, 0.03279105f, -0.02024013f, -0.03357801f, 0.00875959f, -0.01826905f, -0.01593439f, 0.01961967f, 
    0.02181980f, -0.01295177f, -0.03782624f, 0.02996476f, 0.03221441f, -0.02912675f, 0.00589070f, 0.02409155f, 
    -0.00833713f, -0.01930016f, -0.03285789f, -0.01701811f, -0.01596065f, -0.03445315f, -0.00780593f, 0.02626127f, 
    0.01295219f, 0.01006526f, 0.02420494f, -0.00547492f, -0.02351584f, 0.02560212f, -0.03526764f, 0.00709197f, 
    0.00289548f, -0.01196205f, 0.01620618f, -0.03682989f, 0.03176374f, 0.02304845f, -0.01649719f, -0.03242117f, 
    0.00626173f, -0.00391530f, -0.00987548f, -0.01412865f, 0.01800455f, 0.01194695f, -0.01157044f, -0.02019843f, 
    -0.00362158f, -0.01619155f, 0.02488980f, 0.02902512f, 0.01394874f, -0.02153915f, 0.03220516f, -0.03189126f, 
    0.01657740f, 0.01353228f, 0.00496474f, -0.00442251f, -0.02912268f, 0.00521386f, 0.01635749f, -0.01195265f, 
    -0.03492039f, 0.01904407f, -0.02084653f, -0.00810360f, -0.01272088f, -0.01346294f, -0.01112178f, -0.00470701f, 
    0.01884636f, -0.01106945f, 0.03276740f, -0.00077743f, -0.01322980f, -0.03429905f, -0.03359420f, -0.00638138f, 
    0.30925053f, -0.04360215f, -0.09238362f, 0.19911438f, -0.02083617f, 0.09873831f, -0.07716615f, 0.12705748f, 
    -0.12173101f, -0.06017232f, 0.01780402f, 0.03939396f, 0.12495923f, 0.04429642f, 0.02578963f, 0.06195609f, 
    0.04928672f, 0.08558729f, 0.09181026f, -0.09844401f, -0.08794715f, -0.02004827f, -0.04245304f, 0.01543133f, 
    0.10419087f, 0.09385751f, 0.11025190f, -0.06590987f, 0.06528331f, 0.11848322f, -0.05358033f, 0.06501548f, 
    0.00914411f, -0.02936626f, -0.07421458f, 0.08209725f, 0.27285665f, 0.05640629f, -0.08160809f, -0.23842981f, 
    -0.05344303f, -0.05054665f, 0.02422565f, -0.05138801f, -0.00436930f, -0.01960680f, -0.02866370f, 0.08514296f, 
    0.09068250f, -0.08636332f, -0.08912592f, 0.23457392f, 0.09419250f, -0.01926484f, 0.00833482f, -0.01964361f, 
    0.09183490f, 0.00531194f, 0.01590414f, 0.02951842f, 0.10656215f, 0.03826419f, -0.16195872f, 0.18877211f, 
    -0.17114288f, -0.12252446f, 0.05169833f, 0.05997235f, 0.02297649f, -0.02478339f, -0.01039017f, -0.05785068f, 
    0.06451609f, 0.02551363f, 0.14900565f, -0.02744997f, 0.08244627f, -0.05807569f, -0.01178020f, -0.10148055f, 
    -0.02417500f, 0.07277312f, -0.00684572f, 0.06383298f, -0.05530437f, 0.09018838f, -0.02298415f, 0.25327843f, 
    0.05873370f, -0.02713009f, -0.03691801f, 0.04421014f, -0.01591004f, -0.01511952f, -0.05042138f, 0.02947197f, 
    -0.35145158f, 0.13763905f, 0.10950296f, 0.38514954f, 0.03104262f, -0.02345878f, 0.20315905f, -0.15196183f, 
    0.01945631f, 0.06525551f, 0.01173470f, 0.06889660f, -0.22051571f, 0.02053501f, 0.02459173f, 0.09321489f, 
    0.09921890f, 0.07234903f, -0.03544793f, -0.00985219f, 0.07769489f, -0.04984354f, 0.09493658f, -0.09278657f, 
    -0.06997696f, 0.05315458f, 0.00113035f, -0.24857321f, 0.02616491f, -0.06788824f, -0.03804438f, -0.07867489f, 
    -0.01962769f, 0.00092524f, 0.01536910f, 0.15493023f, 0.28886458f, 0.20618857f, 0.18818012f, -0.14640146f, 
    -0.01612007f, 0.05188519f, -0.01442477f, 0.02527800f, -0.00235469f, 0.03804898f, 0.05896570f, -0.05321071f, 
    0.01086889f, -0.03938388f, 0.11261025f, 0.09476492f, -0.16842437f, -0.08172076f, -0.10813570f, -0.10842189f, 
    0.03148763f, 0.04511049f, 0.06426381f, 0.02109533f, -0.04546240f, 0.15516596f, -0.17712910f, -0.08174867f, 
    -0.00090718f, 0.05406010f, -0.05537933f, -0.03842628f, 0.01051184f, 0.04402933f, -0.04747018f, -0.00450817f, 
    -0.25133872f, -0.01286310f, 0.03151220f, 0.01806243f, -0.04012121f, 0.04496228f, 0.06220384f, 0.05891640f, 
    0.13911150f, -0.06108623f, 0.00325515f, 0.05761661f, 0.50741369f, 0.22731455f, -0.28047433f, -0.34532222f, 
    0.03600433f, 0.12655622f, -0.05591352f, 0.05301083f, -0.12376782f, 0.13935091f, 0.03215056f, -0.11372979f, 
    0.10815970f, -0.06382420f, -0.03549651f, 0.11177327f, -0.00623018f, 0.17654863f, -0.06467180f, -0.00726310f, 
    -0.02752169f, 0.12583743f, 0.10704906f, -0.03397734f, -0.16172637f, 0.03754511f, -0.10566518f, 0.09653145f, 
    0.15614462f, 0.04050925f, 0.06305787f, -0.09922790f, -0.00964396f, 0.05481137f, -0.02404797f, 0.08657293f, 
    0.44315693f, -0.23667181f, -0.20836566f, -0.37823749f, 0.06772950f, 0.05004194f, -0.02008879f, -0.19422893f, 
    0.02666233f, 0.00385720f, 0.12770484f, -0.01705263f, 0.08488864f, 0.17771101f, -0.34404373f, -0.08357801f, 
    0.05891231f, -0.17485943f, 0.03977749f, 0.04579368f, -0.08806247f, 0.03393565f, -0.03402651f, 0.01538300f, 
    -0.14314844f, -0.00760923f, 0.04836479f, -0.05201409f, 0.05971061f, 0.08373297f, -0.04285174f, -0.00507942f, 
    -0.17209324f, -0.04471876f, 0.06714885f, -0.03219533f, 0.13568725f, 0.01354099f, -0.02026089f, -0.17116426f, 
    0.03068634f, -0.03393419f, -0.16562949f, 0.02317095f, 0.11889260f, 0.09855650f, -0.11493569f, -0.05269011f, 
    -0.10201596f, -0.09902848f, 0.03525589f, -0.00368795f, -0.00085712f, 0.11242857f, 0.00463008f, 0.11612129f, 
    -0.06102749f, -0.06773185f, 0.20817658f, 0.06560786f, -0.11003980f, 0.27807787f, 0.05474910f, -0.02053933f, 
    -0.17023475f, 0.06656528f, -0.08589540f, 0.06514554f, 0.11058485f, -0.05532908f, 0.14605738f, -0.05317106f, 
    -0.17148595f, -0.33199918f, 0.24612814f, -0.08738784f, -0.00078916f, 0.01038110f, -0.12699205f, -0.00783968f, 
    0.00669384f, -0.02483889f, -0.05958778f, 0.08147251f, 0.09036828f, 0.20213969f, -0.00892682f, -0.15546130f, 
    0.05570998f, 0.00178474f, -0.07239570f, 0.00096935f, -0.01182699f, -0.00336244f, -0.01423305f, 0.03788890f, 
    -0.37649822f, -0.00301035f, -0.09776907f, 0.15150277f, -0.04496398f, 0.03327255f, 0.22650693f, 0.04893464f, 
    0.05820422f, -0.09848019f, 0.17075539f, 0.10364411f, -0.01245768f, -0.07821076f, -0.07915224f, 0.12271940f, 
    0.02050893f, -0.03621879f, 0.01390162f, 0.07483435f, 0.05331614f, -0.05500555f, -0.02057468f, -0.04999490f, 
    -0.29688612f, 0.24914709f, 0.06218731f, -0.00639821f, 0.01651946f, -0.09177850f, 0.02813377f, 0.02451543f, 
    0.04447203f, 0.01174897f, 0.06991372f, -0.04391897f, -0.09510388f, 0.09416103f, 0.21149410f, -0.25396505f, 
    -0.02528248f, -0.07569441f, -0.02246781f, 0.04699246f, 0.16240232f, -0.03177923f, 0.03356569f, 0.11047558f, 
    -0.10137412f, 0.09568175f, -0.19365633f, 0.08365589f, 0.03371375f, 0.15707308f, 0.04088360f, 0.06164132f, 
    -0.00143622f, -0.03175423f, 0.04648567f, -0.03332940f, -0.06661636f, 0.05818978f, 0.03143281f, -0.11266220f, 
    -0.09310875f, -0.12344846f, -0.13456725f, -0.02719705f, 0.03207472f, -0.07493528f, 0.11413897f, 0.06435639f, 
    0.18660954f, 0.03216784f, 0.03019892f, -0.12611303f, -0.01884655f, -0.04887935f, -0.09023976f, -0.03336107f, 
    -0.19628213f, -0.06260081f, -0.04339276f, 0.03710213f, -0.42281565f, 0.25890455f, 0.14180844f, 0.14345185f, 
    0.03502502f, 0.06047336f, -0.08310533f, -0.14440535f, 0.09242060f, 0.02855477f, 0.08931194f, -0.06873279f, 
    -0.14325623f, -0.03997356f, 0.02981382f, 0.11694143f, 0.06461108f, 0.00364894f, 0.09583268f, 0.04977484f, 
    0.02682072f, -0.05905711f, 0.00306437f, 0.13621499f, 0.15968415f, -0.09594687f, -0.05165839f, -0.15288337f, 
    0.06677575f, 0.04393215f, 0.00743693f, 0.08731106f, 0.00927906f, 0.07692780f, 0.08501465f, 0.02610360f, 
    0.12184105f, -0.13127734f, -0.12139986f, 0.10239243f, 0.12580009f, 0.05772484f, -0.10159834f, 0.15923928f, 
    0.09103347f, 0.01235124f, 0.17443082f, -0.03325961f, -0.05213667f, 0.12364940f, 0.10208672f, -0.02934012f, 
    -0.04633490f, -0.08121676f, -0.10002238f, -0.11244053f, 0.10679835f, -0.02280869f, 0.11035164f, -0.08509231f, 
    -0.05926596f, -0.10696017f, -0.20633700f, -0.02145818f, 0.10735326f, 0.03495359f, 0.01333505f, -0.09297165f, 
    -0.01812148f, -0.03491928f, 0.05262912f, -0.04045651f, -0.43309975f, 0.00127176f, 0.24175648f, 0.15803802f, 
    0.04146943f, 0.01976708f, -0.01144352f, 0.12989126f, 0.03929047f, -0.01309863f, -0.03047552f, -0.05343638f, 
    -0.16610549f, -0.13811849f, 0.13493197f, 0.16287246f, -0.02081955f, 0.05323195f, -0.14656128f, -0.09840708f, 
    0.09187948f, 0.11007914f, -0.07286134f, -0.01243965f, -0.01429287f, -0.00704744f, -0.05830721f, 0.19072393f, 
    0.01719171f, -0.09238612f, 0.03927902f, 0.00481059f, 0.02445023f, 0.01429051f, -0.02269711f, -0.01918947f, 
    0.23415083f, -0.11566372f, -0.03026105f, -0.00615444f, 0.00176143f, -0.06864627f, -0.06061907f, 0.00191232f, 
    0.17733541f, 0.14085940f, -0.00983640f, 0.07838639f, -0.07070031f, 0.09417201f, 0.11247204f, -0.00710480f, 
    -0.00881183f, -0.04802509f, 0.02347947f, 0.00236889f, 0.08248850f, -0.02457041f, -0.02136466f, 0.06946452f, 
    0.01801797f, 0.01756920f, -0.13070367f, -0.02945544f, -0.01465400f, 0.03147130f, 0.00853334f, -0.07876765f, 
    -0.09554675f, -0.04791914f, -0.14536747f, 0.02068184f, -0.04479493f, 0.07536689f, -0.07374749f, -0.00372201f, 
    -0.01577889f, -0.07314751f, -0.00710767f, 0.06368233f, 0.05910692f, 0.02130858f, 0.00860243f, -0.02356827f, 
    0.01927285f, -0.31656405f, 0.11295068f, -0.33799601f, 0.09618115f, 0.04172724f, 0.02063073f, -0.05114758f, 
    0.08500595f, 0.18137118f, -0.05440325f, -0.09916517f, 0.09482656f, -0.03930795f, -0.19360115f, -0.05589991f, 
    0.03032120f, -0.09490884f, 0.01474048f, -0.00277495f, 0.00114023f, 0.02828003f, 0.02488981f, -0.10877936f, 
    -0.05921579f, -0.05462030f, 0.00479427f, 0.16529781f, 0.14023131f, 0.18462922f, 0.00877751f, 0.07473493f, 
    0.02956566f, -0.02554066f, 0.11449189f, 0.07126737f, -0.06755589f, -0.07247921f, -0.03052292f, 0.02876607f, 
    0.10988402f, 0.01970811f, 0.03899020f, -0.00071471f, -0.00980219f, -0.03023486f, -0.05690029f, 0.12467580f, 
    -0.05699229f, 0.15981284f, 0.01204668f, 0.05007137f, 0.07543760f, -0.03321967f, 0.02510222f, -0.06776853f, 
    -0.02569662f, 0.00526490f, -0.01605372f, 0.02317584f, 0.09291492f, -0.13129173f, -0.12242816f, -0.08052070f, 
    -0.00651943f, 0.04763010f, -0.07786290f, -0.01615981f, -0.02596447f, 0.14393832f, 0.10302044f, -0.01975805f, 
    -0.09435310f, 0.03531216f, 0.01540769f, -0.14578578f, 0.15159607f, 0.05160284f, 0.06721440f, 0.03366788f, 
    -0.04343824f, 0.06710570f, -0.05978524f, 0.26976657f, -0.14745119f, 0.14827994f, -0.03731635f, 0.14842719f, 
    0.15621105f, 0.03228309f, -0.06104532f, -0.06624014f, -0.02193957f, -0.00583333f, 0.08342513f, -0.05700566f, 
    0.00625094f, 0.07733047f, 0.00863511f, -0.06908928f, 0.10153065f, 0.11787704f, -0.01751804f, 0.01591335f, 
    -0.01066596f, -0.00171257f, 0.00746201f, 0.11435498f, -0.16863362f, 0.45896447f, 0.02517690f, -0.11019407f, 
    0.12336726f, -0.06167646f, -0.00444014f, -0.14579934f, 0.06683275f, -0.09332201f, -0.25297332f, -0.05622036f, 
    0.22966757f, 0.20628129f, -0.04849436f, -0.37643301f, 0.04153459f, -0.10284679f, -0.03010356f, -0.06620416f, 
    0.14145930f, 0.06635089f, -0.03981972f, -0.04072613f, 0.03933442f, -0.26052755f, -0.13852838f, -0.17597994f, 
    0.05935574f, -0.10700016f, -0.11557614f, 0.05465906f, 0.02978086f, -0.00042950f, -0.02263979f, 0.06175339f, 
    -0.08759143f, -0.15910700f, -0.11690995f, 0.10243110f, -0.00223856f, 0.07903927f, -0.03795108f, -0.09687281f, 
    0.01508415f, 0.04459620f, -0.01475308f, 0.14238910f, 0.03615033f, -0.05402879f, 0.07847851f, -0.09074766f, 
    0.12995182f, -0.04539744f, 0.10527660f, -0.15160963f, 0.08778467f, -0.05334070f, 0.04980076f, -0.01287256f, 
    -0.11682552f, 0.12412255f, -0.00244986f, 0.02284726f, 0.07246792f, 0.05648514f, 0.02144690f, -0.12142245f, 
    0.09503543f, 0.12643504f, 0.08956947f, 0.18356608f, 0.49130657f, -0.02290769f, -0.16800837f, -0.09175852f, 
    0.07916670f, 0.04024150f, 0.01519063f, -0.13193063f, -0.01773289f, 0.12799983f, 0.08545887f, -0.04029840f, 
    -0.06385429f, 0.14108689f, -0.15514229f, -0.00673618f, 0.00448230f, -0.07232665f, -0.07964768f, 0.04177670f, 
    0.10016043f, 0.00392658f, 0.16898283f, -0.09907319f, 0.41909334f, -0.24979691f, -0.13452959f, -0.01344981f, 
    0.23891836f, -0.03774443f, -0.03912092f, 0.04150900f, -0.03378114f, 0.10551064f, -0.01461917f, -0.01038595f, 
    0.15280370f, -0.11724148f, -0.00499105f, 0.08524968f, -0.00505007f, 0.16218996f, 0.03520826f, -0.04482819f, 
    -0.00708274f, 0.06598467f, -0.03386037f, 0.06989158f, -0.10019549f, 0.17317185f, -0.08084136f, 0.12640300f, 
    0.09039422f, -0.01075021f, 0.21535964f, 0.01541582f, 0.07897617f, -0.10269369f, -0.06621125f, -0.02161808f, 
    -0.17385143f, -0.21186827f, 0.04649741f, 0.12964331f, 0.04543037f, -0.09959567f, -0.11535479f, -0.13111372f, 
    0.13440405f, 0.08700139f, -0.04928713f, 0.04727614f, 0.03395383f, 0.12460519f, 0.02210308f, -0.01953948f, 
    -0.04427828f, -0.13655123f, 0.00087523f, -0.02590820f, 0.13736849f, 0.10628463f, -0.01215240f, -0.07135779f, 
    -0.08207732f, 0.10009021f, -0.08146765f, -0.07744071f, 0.11377755f, -0.03856318f, 0.09084168f, -0.08176252f, 
    -0.02735337f, 0.04301512f, -0.12475863f, 0.05329869f, 0.12306372f, 0.03659227f, -0.01632429f, -0.06378680f, 
    0.01054070f, -0.09213009f, 0.14790924f, -0.08318442f, -0.04557440f, -0.02505258f, -0.12544109f, 0.03523220f, 
    0.06889883f, 0.05682461f, 0.12502651f, -0.09050200f, 0.14149311f, -0.03083607f, -0.06958421f, -0.05712540f, 
    -0.08489646f, -0.04460344f, -0.02731351f, 0.02019161f, -0.05470559f, 0.17356469f, -0.09138357f, 0.03404938f, 
    -0.01473570f, -0.06493264f, 0.17639843f, -0.05766245f, 0.01302409f, 0.03647677f, 0.00639044f, 0.00457905f, 
    0.26172784f, -0.09156848f, -0.00225215f, 0.13557057f, 0.05114314f, 0.08360865f, 0.17143674f, -0.10778164f, 
    0.14958353f, -0.01276359f, -0.01083851f, 0.04250064f, -0.03513653f, -0.06028967f, 0.12009719f, -0.26618811f, 
    0.08700464f, 0.05516471f, -0.12816311f, 0.03391179f, -0.02207705f, 0.04316318f, -0.07886373f, -0.03830028f, 
    0.14775024f, -0.11869045f, 0.05763237f, 0.20487767f, 0.01061124f, 0.00933779f, 0.00719276f, -0.07136837f, 
    0.14548081f, 0.11016503f, 0.15474434f, -0.03595715f, -0.11901686f, 0.14011644f, -0.02073283f, 0.04756480f, 
    -0.00091214f, 0.00670950f, -0.18286549f, -0.02051993f, -0.01888284f, 0.04584899f, 0.21624263f, 0.18219249f, 
    0.06068381f, 0.05276069f, -0.05689203f, 0.06988478f, 0.04578454f, 0.07339218f, 0.17942348f, 0.03939018f, 
    0.17502862f, -0.09908788f, -0.04022001f, 0.00630082f, -0.16060407f, -0.03446728f, -0.01081009f, -0.05228530f, 
    0.05580283f, 0.10353111f, -0.03255037f, -0.09466767f, -0.04106702f, -0.03250568f, -0.09106776f, 0.01233876f, 
    0.13622959f, -0.05804333f, -0.01831620f, 0.02664479f, 0.08975890f, -0.01401938f, 0.06507634f, -0.04189890f, 
    0.01783465f, -0.23125061f, -0.08657216f, 0.02130587f, -0.26508385f, -0.16320620f, -0.02369959f, 0.03775565f, 
    -0.02677633f, 0.08844656f, -0.09739560f, 0.01482912f, -0.07683843f, -0.07354845f, 0.05758123f, 0.07604944f, 
    -0.19878960f, -0.06221089f, -0.04252776f, 0.12614302f, 0.18529432f, -0.01324330f, -0.04085946f, 0.11228598f, 
    0.11847641f, 0.03656576f, -0.00815495f, -0.09224368f, -0.23906964f, -0.10807515f, -0.09761713f, 0.07312408f, 
    -0.03071398f, -0.01376482f, -0.03019564f, -0.13008738f, 0.10887033f, 0.10943024f, 0.13605559f, 0.10461669f, 
    -0.20799226f, -0.09844478f, -0.10958029f, -0.00753027f, 0.06701931f, -0.00406360f, 0.12809621f, 0.08215895f, 
    0.04350407f, 0.06323372f, 0.18348601f, -0.04669140f, -0.00558465f, 0.12855324f, -0.18368751f, 0.04265362f, 
    0.16038443f, -0.10908924f, 0.18859339f, 0.12899587f, 0.10275802f, 0.13075759f, 0.09472819f, 0.05299856f, 
    0.10007049f, -0.22733738f, 0.28148684f, 0.03085765f, 0.04628359f, 0.10242001f, -0.00324244f, 0.07043404f, 
    0.14142200f, -0.02642569f, -0.04187651f, 0.00615535f, 0.11475384f, 0.09633780f, 0.14380804f, -0.03202770f, 
    0.03758322f, 0.01272669f, -0.01984408f, 0.09054075f, 0.11231989f, 0.21108431f, 0.03442102f, -0.01523464f, 
    0.01760856f, -0.03545976f, -0.04074124f, -0.05948245f, 0.05552663f, 0.18012513f, 0.06518733f, 0.04094322f, 
    0.14623182f, 0.01808219f, 0.09913726f, 0.04477036f, 0.53638333f, -0.11776675f, 0.19757259f, -0.25615951f, 
    0.08670280f, 0.32533637f, 0.12807643f, 0.27623227f, -0.13347460f, 0.09186273f, -0.07860727f, -0.01114116f, 
    0.15757871f, -0.15720005f, 0.01660844f, 0.11450575f, 0.15507932f, 0.02739994f, 0.05645603f, -0.07915514f, 
    0.15123568f, 0.02717362f, 0.09932727f, 0.00154452f, -0.05086323f, 0.07216921f, -0.14647958f, -0.09956860f, 
    0.08207072f, 0.09754883f, 0.11011808f, 0.07461789f, -0.01833730f, -0.02008795f, -0.04679969f, -0.10572080f, 
    -0.34603804f, 0.05117314f, -0.00607161f, -0.09437222f, 0.04499023f, 0.08197120f, 0.17480634f, 0.21712053f, 
    0.04146644f, 0.12744315f, 0.01832202f, -0.01920917f, -0.12726623f, -0.15529631f, -0.18736376f, -0.08699176f, 
    -0.02355012f, 0.01322598f, 0.10200198f, 0.04150066f, 0.14615762f, 0.14392738f, 0.16401070f, -0.04371801f, 
    0.09491777f, 0.16751748f, 0.02716967f, -0.11432137f, -0.03548351f, 0.01764528f, 0.05750760f, 0.02365840f, 
    0.03416452f, 0.04060642f, 0.23510702f, 0.09883572f, -0.02190903f, 0.04402101f, 0.16239889f, -0.00275471f, 
    -0.01675665f, 0.14812179f, -0.03402449f, -0.16386162f, -0.00044247f, -0.03762882f, 0.07735512f, -0.03627698f, 
    0.04498209f, 0.32361746f, 0.00118048f, -0.03625928f, 0.03293893f, 0.06062971f, 0.15395269f, -0.01862315f, 
    0.06435762f, 0.15430211f, 0.00798212f, -0.09007050f, 0.18811195f, 0.02020910f, 0.12348672f, -0.02443426f, 
    -0.00513361f, 0.07306099f, 0.01528672f, 0.16514157f, 0.10680703f, 0.17931204f, 0.00250626f, -0.01436651f, 
    -0.09428056f, 0.01861168f, 0.03365458f, 0.04965570f, -0.10194400f, 0.02803510f, -0.10621697f, 0.06438367f, 
    -0.05584551f, 0.07235290f, 0.03989153f, 0.00240138f, 0.39616880f, 0.09097616f, 0.36211178f, -0.29697222f, 
    0.11037862f, 0.01311426f, -0.00067866f, 0.00070206f, -0.02928615f, -0.07445634f, -0.01344403f, 0.05145270f, 
    -0.09800747f, -0.05375852f, 0.02077423f, -0.05843760f, -0.08046557f, -0.19882238f, -0.09433465f, -0.20629266f, 
    0.04504132f, 0.08615561f, 0.03680273f, 0.06939188f, -0.31854257f, -0.15957569f, -0.09276616f, -0.08337394f, 
    0.06238423f, 0.05876981f, 0.11311992f, -0.04391364f, -0.03750749f, 0.09603777f, 0.12972215f, 0.03608697f, 
    -0.32048261f, -0.16126618f, -0.08685375f, 0.16327806f, 0.01406089f, 0.25952169f, 0.01349885f, 0.04806769f, 
    0.02427685f, 0.26502442f, 0.07079088f, 0.07421771f, 0.21934277f, 0.04264326f, 0.02202993f, 0.07316522f, 
    -0.04639030f, -0.02205306f, -0.01023586f, -0.08458748f, -0.00229676f, 0.01277484f, 0.05986295f, -0.09862188f, 
    -0.18301974f, -0.26371557f, -0.01370408f, -0.05079200f, -0.02962332f, 0.12298414f, 0.00881909f, -0.07496969f, 
    -0.01014581f, 0.13148689f, -0.07803807f, -0.04195312f, 0.22579712f, -0.06858204f, 0.10438839f, -0.23206492f, 
    0.04763738f, -0.00077187f, -0.12779775f, -0.20444228f, -0.01290143f, -0.10172250f, -0.04306533f, 0.05922111f, 
    0.13074929f, -0.14109056f, -0.12462141f, 0.18477702f, -0.01846737f, 0.07570780f, -0.06120561f, -0.12492386f, 
    -0.08730005f, -0.10788739f, -0.03840969f, 0.07969247f, -0.15884443f, 0.04892503f, 0.05982708f, 0.09485015f, 
    -0.05609754f, -0.06692623f, 0.14497146f, -0.08858778f, 0.24042617f, -0.05250483f, 0.03222618f, 0.18772805f, 
    -0.34154236f, -0.18604186f, -0.07739402f, 0.07886275f, 0.07314980f, 0.01437381f, -0.05647406f, 0.03318556f, 
    0.06585249f, 0.17539710f, 0.17021281f, 0.01972888f, 0.17874946f, 0.06543452f, 0.03549999f, 0.07334507f, 
    -0.06642127f, -0.02137629f, -0.02271022f, -0.01023547f, -0.11187649f, -0.08581610f, -0.07115813f, -0.17374694f, 
    -0.16293739f, 0.04927503f, -0.10561652f, -0.04670019f, 0.01962795f, -0.11172447f, -0.01201701f, 0.01913255f, 
    0.00269286f, -0.00059146f, 0.15044935f, 0.06637503f, 0.23974207f, 0.13808298f, 0.03002575f, -0.02180457f, 
    -0.01328941f, -0.01455766f, -0.04624584f, 0.05221933f, -0.00543178f, -0.09041731f, -0.03995926f, -0.04843075f, 
    0.10899694f, -0.00138253f, -0.06596283f, 0.04107667f, -0.03979911f, 0.01873983f, 0.01715688f, -0.00661943f, 
    0.11782510f, 0.14887841f, -0.01227323f, 0.04407322f, 0.19200160f, 0.05256464f, -0.05059073f, 0.03598906f, 
    0.01977020f, -0.04298707f, 0.01005269f, -0.00035006f, -0.04449994f, 0.14910428f, -0.12557368f, -0.10694119f, 
    -0.08932298f, -0.10734995f, 0.01613665f, -0.03078293f, -0.06179459f, 0.10744251f, 0.09595933f, -0.04816056f, 
    0.08916172f, -0.05595996f, 0.18222360f, 0.07768045f, -0.18358104f, -0.09340371f, -0.05493978f, -0.08766568f, 
    -0.05946897f, -0.00847534f, 0.04651622f, -0.16109432f, 0.04667388f, 0.10631685f, 0.16112834f, -0.02586069f, 
    -0.02076012f, 0.20511571f, 0.04000596f, -0.12072492f, 0.03138327f, -0.03950470f, 0.00761691f, -0.03625242f, 
    -0.04041066f, 0.00799921f, -0.11575571f, -0.01702263f, -0.04365893f, -0.27347064f, -0.01988100f, -0.05607667f, 
    0.19947179f, -0.02762935f, 0.12969835f, 0.11176115f, 0.06035267f, 0.00491929f, 0.07938030f, 0.31855839f, 
    -0.21816701f, -0.12082024f, 0.17401212f, -0.10986359f, -0.04308622f, -0.14418913f, 0.13124363f, -0.02916162f, 
    0.00665615f, 0.22501938f, 0.11252648f, -0.05699192f, 0.41686168f, 0.14327286f, -0.12127154f, -0.18013588f, 
    0.05619041f, -0.00870500f, 0.17192289f, -0.08795652f, -0.04797210f, -0.01764476f, -0.03369640f, -0.05250020f, 
    -0.11243980f, -0.05614864f, 0.02555665f, 0.05440690f, 0.03902018f, -0.11913814f, -0.01903789f, -0.00617867f, 
    -0.12788703f, -0.01885819f, -0.14781068f, 0.00429420f, -0.20421401f, 0.26788911f, -0.11596326f, 0.06680568f, 
    0.03614069f, -0.07273201f, 0.03027042f, 0.02442016f, -0.06164370f, -0.08126184f, -0.06692942f, -0.17986780f, 
    -0.18102853f, 0.24081691f, 0.04104749f, -0.08228774f, -0.00070684f, -0.11077877f, 0.13322134f, 0.07358259f, 
    -0.04878855f, 0.05311347f, 0.02690612f, -0.02079959f, -0.17718795f, -0.20475388f, -0.03748459f, -0.08694916f, 
    -0.05652265f, -0.27770552f, -0.04905448f, 0.05181186f, 0.02753898f, 0.00275629f, -0.05613891f, -0.12262041f, 
    -0.14335389f, -0.13771932f, -0.01437309f, -0.16781452f, 0.01450320f, 0.01763445f, 0.00355653f, -0.00912787f, 
    0.09243762f, 0.01741946f, 0.01120012f, 0.02831751f, -0.06793974f, -0.06044427f, -0.15415801f, 0.21558432f, 
    0.06130366f, -0.22042938f, 0.13465980f, -0.04725859f, 0.13958339f, -0.11794373f, -0.10913985f, 0.24850871f, 
    -0.02115787f, -0.00825236f, -0.11017103f, 0.02716239f, 0.02379363f, 0.02731911f, 0.01511833f, -0.01409117f, 
    0.04619283f, 0.11755831f, 0.09954036f, 0.14914963f, 0.06085353f, -0.08563465f, 0.08249307f, 0.00584617f, 
    0.09211009f, -0.10109375f, 0.04469511f, 0.07567042f, 0.07612044f, -0.04608975f, 0.00583150f, 0.30402100f, 
    0.14251655f, 0.02965351f, -0.11187427f, 0.09564076f, 0.00234680f, 0.11188978f, 0.12944680f, 0.02269772f, 
    -0.07044299f, 0.16509975f, 0.01890901f, 0.09464639f, 0.24907027f, 0.04399275f, -0.05981838f, 0.22394712f, 
    0.08232622f, 0.06957664f, -0.02087279f, 0.06016287f, 0.02745198f, 0.10592046f, 0.06126122f, -0.03747836f, 
    -0.00165433f, 0.06562009f, -0.06971521f, 0.18575928f, -0.04092468f, 0.03478123f, -0.05280243f, 0.18731795f, 
    0.08119681f, 0.03406532f, -0.17040704f, -0.05933784f, -0.11152448f, -0.11347599f, -0.15561156f, 0.06946085f, 
    -0.06117534f, 0.18541348f, -0.04230919f, 0.00620409f, 0.09096123f, 0.01597139f, 0.04857735f, 0.08268828f, 
    -0.01759453f, -0.01216480f, -0.03881736f, -0.16230631f, 0.00241179f, -0.09072544f, 0.04720771f, -0.04699470f, 
    0.18084876f, 0.00353365f, 0.12551348f, 0.06369440f, 0.11161157f, 0.00218958f, -0.08865009f, -0.13871430f, 
    -0.08660950f, -0.11430097f, -0.10185251f, -0.04483148f, 0.01533177f, -0.19104943f, 0.09518450f, 0.14896707f, 
    -0.11699931f, -0.03779766f, -0.01590493f, 0.03623977f, 0.02493306f, -0.01019739f, 0.06734290f, -0.21308206f, 
    0.02056242f, 0.00235135f, -0.02094358f, 0.13059539f, -0.09104127f, -0.17935948f, -0.14202754f, -0.23637751f, 
    0.04256292f, 0.14590649f, 0.05554923f, 0.02288213f, -0.00138544f, 0.06661074f, 0.08096528f, 0.03414468f, 
    -0.48225918f, 0.37043747f, -0.18648814f, -0.25702131f, -0.06742501f, -0.08527979f, -0.07957299f, -0.09987055f, 
    0.00541685f, -0.01053676f, 0.08426608f, 0.10133782f, -0.02689318f, 0.02426407f, -0.14348263f, -0.01788659f, 
    0.14858614f, -0.00092981f, 0.07798100f, -0.09710371f, -0.00725959f, 0.08563077f, 0.03516344f, 0.04184039f, 
    0.22677772f, 0.34811705f, -0.11075962f, 0.05869827f, 0.01434880f, -0.16445699f, -0.10641838f, 0.09304215f, 
    0.06817807f, 0.03244993f, 0.05476614f, 0.02039831f, -0.06368895f, -0.13237128f, -0.05199700f, -0.17356637f, 
    0.10373183f, 0.04758175f, 0.03173099f, -0.01882525f, 0.15106075f, 0.07533903f, 0.06911119f, 0.13458723f, 
    -0.03027127f, 0.16963062f, -0.14399177f, 0.02591165f, -0.06472456f, -0.21093290f, -0.14435166f, 0.09276664f, 
    0.09995788f, 0.01996061f, 0.14128366f, -0.05758786f, 0.12323076f, -0.17856264f, 0.05538109f, -0.13172263f, 
    -0.05508411f, -0.20027095f, -0.11067439f, -0.10369492f, 0.11925346f, 0.10970987f, 0.18863592f, 0.07222649f, 
    -0.21419764f, -0.04076668f, -0.07756566f, -0.19051352f, -0.01033983f, -0.05658374f, 0.23975086f, -0.08009537f, 
    -0.18651976f, -0.14036614f, -0.10469814f, -0.20214650f, -0.02027536f, -0.16096351f, 0.11045869f, 0.05601745f, 
    -0.00071182f, -0.03588245f, 0.04266432f, 0.11685077f, 0.00534662f, 0.13527426f, 0.12257633f, 0.17085558f, 
    -0.03368358f, -0.05761655f, -0.00777121f, -0.01917018f, 0.03388121f, -0.07061741f, -0.10034931f, 0.00579527f, 
    0.06577149f, 0.06542060f, 0.04022797f, 0.05210482f, 0.03306312f, 0.14636476f, -0.02841714f, 0.10794917f, 
    -0.16334279f, -0.11979069f, -0.00414964f, -0.01053979f, 0.03474801f, 0.25540653f, -0.08919817f, 0.01405890f, 
    0.01938733f, -0.02640688f, 0.12366770f, 0.11531169f, -0.13442875f, -0.02335210f, 0.05999783f, 0.03434927f, 
    0.20215665f, -0.02868580f, 0.09172081f, 0.11233371f, 0.03333735f, 0.00190075f, 0.06844615f, -0.13544382f, 
    0.06743291f, 0.12780054f, 0.07459639f, 0.05089284f, 0.00543398f, -0.01465274f, 0.14397913f, -0.07992584f, 
    -0.17461836f, 0.01531507f, 0.05029782f, -0.11919945f, -0.06100699f, 0.03840015f, 0.09262788f, 0.24267372f, 
    0.07180897f, 0.04084932f, -0.16082223f, -0.10378072f, 0.29334229f, -0.16406262f, 0.34103623f, -0.11677252f, 
    0.15258352f, -0.05422962f, 0.00292343f, 0.12017962f, -0.04250564f, 0.08295574f, 0.19319406f, -0.14744304f, 
    -0.09457967f, -0.20324852f, -0.00035141f, 0.05063773f, 0.17546050f, -0.01549327f, 0.17728752f, 0.08458829f, 
    0.12387994f, 0.16745974f, 0.03089190f, 0.06921790f, 0.11669801f, 0.11460687f, 0.00070655f, 0.10233328f, 
    -0.00456813f, 0.14296272f, 0.14576128f, 0.02062900f, 0.06172100f, -0.04854313f, -0.01554606f, -0.06422795f, 
    0.04850116f, 0.13952909f, -0.15246879f, -0.11357568f, 0.06474735f, 0.06245801f, 0.00805726f, 0.18523335f, 
    -0.03086854f, -0.12386888f, -0.09895586f, -0.05344208f, 0.02690294f, 0.12262450f, -0.26484331f, -0.08963346f, 
    -0.03765210f, 0.08195839f, 0.11370769f, -0.05509865f, -0.06733377f, -0.02725665f, -0.08618385f, -0.02617078f, 
    0.17703588f, -0.06223923f, 0.19670480f, -0.01952111f, -0.03178634f, 0.01613779f, 0.05553926f, 0.05670004f, 
    0.04359818f, 0.20243137f, -0.04689460f, -0.05106978f, -0.08356386f, -0.03273875f, 0.14501980f, -0.13752410f, 
    0.01311873f, -0.02455221f, 0.03340300f, 0.02746428f, -0.06317938f, 0.05360992f, 0.08418562f, 0.00732414f, 
    -0.04143563f, 0.11107113f, 0.05861838f, 0.01966139f, -0.03674019f, 0.09656104f, -0.08289392f, 0.21027680f, 
    0.19617839f, 0.01257476f, 0.00087766f, -0.00525489f, 0.09881454f, -0.04260775f, -0.04563657f, -0.01824060f, 
    -0.04381823f, 0.02073076f, 0.00879010f, -0.07055568f, 0.06619437f, -0.11131533f, -0.11844071f, -0.18083644f, 
    0.32037681f, 0.09619316f, -0.02332420f, 0.01004132f, -0.02926941f, -0.03322570f, 0.06070980f, 0.02387883f, 
    0.19118540f, -0.04266325f, -0.07977202f, 0.06091294f, -0.09142062f, 0.00316759f, -0.13898239f, -0.17678013f, 
    0.05565403f, -0.10023074f, -0.09172112f, -0.19345632f, -0.15041858f, -0.23078100f, -0.00354790f, -0.01414941f, 
    0.19766627f, 0.05723687f, 0.01378998f, 0.08700766f, 0.00846275f, 0.04850233f, -0.04785402f, 0.08408153f, 
    0.12518327f, 0.10826974f, -0.04801875f, 0.06586266f, -0.03104075f, 0.06715022f, -0.18970944f, -0.10747253f, 
    -0.01353900f, 0.00402839f, -0.01757643f, 0.06527545f, -0.02203252f, -0.13110861f, -0.04282834f, -0.11892769f, 
    0.12046237f, -0.20851621f, 0.18197280f, 0.15107985f, -0.01654639f, 0.09442411f, 0.06567139f, 0.06484898f, 
    -0.06943929f, -0.01092294f, 0.10760524f, 0.14302669f, 0.14612521f, -0.13749160f, -0.01268028f, -0.01020618f, 
    -0.07598186f, -0.00118710f, 0.07502243f, -0.13260975f, 0.11528172f, -0.05482001f, -0.02739822f, 0.01642985f, 
    0.02451826f, -0.08834466f, -0.16557267f, -0.21288286f, 0.04063329f, 0.05469871f, 0.00645113f, -0.14922333f, 
    0.04053601f, -0.06158333f, 0.08900767f, 0.14299767f, -0.40244329f, 0.08210149f, -0.02368066f, -0.02769518f, 
    -0.08441800f, -0.03828841f, -0.03763714f, 0.08804879f, 0.01335719f, 0.04622036f, -0.02355660f, -0.03848223f, 
    -0.02515236f, -0.07038646f, 0.13815287f, 0.09234621f, 0.03212558f, 0.10083277f, 0.09743155f, 0.06279786f, 
    -0.03253336f, 0.00389374f, 0.02434817f, 0.11657614f, 0.02373023f, 0.08685364f, 0.02246648f, -0.02021585f, 
    -0.01256375f, -0.06932861f, -0.04769177f, -0.02696115f, -0.16511279f, -0.08996640f, -0.03452721f, -0.17649978f, 
    -0.04284078f, -0.23494530f, -0.10258902f, 0.15175883f, 0.13133217f, 0.16839482f, 0.01751698f, -0.06156266f, 
    0.02306316f, 0.03376823f, -0.02738841f, 0.16400513f, -0.20399217f, -0.52238572f, -0.17392318f, -0.29295930f, 
    0.05059202f, -0.05499949f, -0.06838002f, -0.28606921f, 0.02367285f, -0.00446245f, 0.03402279f, -0.02033735f, 
    -0.17437392f, -0.37817979f, -0.31662038f, 0.09443408f, 0.08730430f, -0.02506665f, 0.00621329f, -0.03495616f, 
    -0.08382550f, -0.08943716f, -0.07460020f, -0.03335990f, -0.12349162f, -0.06280016f, 0.01802203f, -0.22996265f, 
    0.01946390f, 0.16395779f, -0.08825794f, -0.09506924f, 0.10420405f, -0.02183598f, 0.10362358f, -0.04647924f, 
    -0.19035742f, -0.02437749f, 0.09294962f, -0.01339186f, -0.04330243f, 0.01433660f, -0.10712869f, 0.05773355f, 
    0.08883428f, -0.01730974f, 0.02693625f, -0.02468266f, -0.19857228f, -0.08027648f, 0.07973643f, -0.12144569f, 
    -0.19969238f, -0.12024334f, -0.10039737f, -0.12021404f, -0.09321479f, -0.05547316f, -0.06738979f, -0.10979766f, 
    -0.10442619f, -0.01710819f, -0.03758194f, 0.05473530f, -0.05020186f, 0.10387161f, -0.09252682f, -0.15196925f, 
    -0.11404002f, 0.01281229f, 0.04161418f, -0.04493617f, -0.19241798f, -0.15891093f, -0.05902260f, 0.04865773f, 
    -0.12244300f, -0.12473118f, -0.01244439f, -0.16728504f, -0.03127098f, -0.00994045f, -0.08690298f, -0.07418227f, 
    -0.05688570f, 0.11909073f, -0.12349108f, -0.04305192f, -0.04631681f, -0.04440616f, -0.01214243f, 0.13820280f, 
    -0.07626227f, -0.04103362f, 0.07926043f, -0.02334506f, 0.12604712f, -0.15661359f, 0.08895647f, 0.37600651f, 
    -0.03363293f, 0.00523110f, 0.00324933f, 0.08846734f, -0.05824677f, 0.11735496f, 0.13117115f, 0.11489735f, 
    -0.23092487f, -0.07234383f, 0.02229887f, -0.17136763f, -0.04112028f, 0.12680270f, 0.12847564f, 0.01135949f, 
    -0.13530023f, -0.05458864f, -0.06223226f, -0.06990690f, -0.08397144f, 0.03028226f, 0.01394537f, -0.08055727f, 
    -0.00982256f, 0.07806738f, 0.13769181f, -0.08182655f, -0.03480258f, 0.04075202f, 0.06176867f, -0.02504173f, 
    -0.21536629f, -0.01341209f, -0.01276423f, -0.06388764f, -0.21690716f, 0.00791541f, -0.07655331f, -0.02176532f, 
    0.00964929f, -0.01273313f, -0.01947434f, 0.20775415f, -0.12680390f, 0.18221182f, 0.09001318f, -0.30679044f, 
    0.06297456f, 0.22159950f, -0.03049456f, 0.08355037f, 0.10158356f, 0.18128303f, -0.08350022f, 0.03405757f, 
    -0.12267464f, 0.06010541f, 0.01107658f, -0.09364901f, 0.00653507f, -0.15236260f, 0.08924947f, -0.03695754f, 
    -0.02264000f, 0.00933285f, -0.09446483f, -0.21662794f, 0.22846568f, -0.09373052f, -0.21058422f, -0.04384314f, 
    -0.00573386f, -0.19771041f, 0.07127696f, -0.00478188f, 0.09659467f, -0.05941978f, 0.08442330f, 0.20892954f, 
    -0.17832844f, -0.03740268f, -0.01369553f, 0.00303520f, -0.15104632f, -0.17264608f, -0.12865283f, -0.12427231f, 
    0.15799259f, -0.07689255f, 0.02022699f, 0.18208323f, 0.03349417f, -0.00268988f, 0.07333470f, -0.06821154f, 
    -0.06356684f, -0.03794428f, -0.01235408f, -0.11112552f, 0.12716097f, 0.09136682f, -0.07736234f, -0.03463982f, 
    0.22170776f, -0.05802855f, 0.22857615f, 0.06700847f, -0.01212046f, 0.00742189f, -0.04567263f, 0.12078592f, 
    0.05921102f, -0.06143931f, -0.00905955f, 0.01252054f, -0.20774049f, 0.01863888f, -0.08632897f, -0.12030137f, 
    -0.01798271f, 0.11462356f, 0.10751206f, 0.13582157f, 0.06316566f, 0.15155733f, 0.03054167f, 0.08269300f, 
    -0.09644715f, -0.03805006f, 0.05223678f, -0.11506764f, 0.04378369f, 0.02492195f, 0.09378731f, 0.15001135f, 
    0.09216142f, -0.01844662f, 0.05922011f, 0.00082890f, -0.08867113f, 0.00116160f, -0.08086862f, 0.17083585f, 
    -0.01702999f, -0.01235056f, 0.06042819f, -0.08106407f, 0.19775239f, -0.16533327f, 0.14495254f, 0.18132696f, 
    -0.17212485f, 0.21015739f, 0.02677613f, -0.05979881f, -0.12185124f, -0.11041645f, -0.01076284f, -0.04601035f, 
    0.11016925f, -0.09377250f, 0.04456568f, 0.12260144f, 0.02142070f, -0.00771171f, 0.04408816f, -0.05202235f, 
    -0.09197270f, 0.02982103f, 0.11883758f, 0.11574525f, 0.03402776f, 0.07276222f, 0.18457806f, 0.04110113f, 
    0.17414352f, 0.09429106f, 0.02384786f, 0.00894260f, 0.08508033f, -0.05800176f, -0.00836548f, -0.09246613f, 
    -0.11830799f, 0.02949147f, -0.08448005f, 0.00943826f, 0.03949447f, 0.01451334f, -0.20979431f, 0.05029112f, 
    -0.00569806f, 0.12882744f, -0.01585765f, 0.04940830f, 0.11935239f, 0.10676383f, 0.16236760f, 0.22788472f, 
    0.00963837f, -0.00043484f, -0.02027066f, -0.00635000f, -0.03478758f, 0.02685252f, 0.03334326f, -0.03152216f, 
    -0.01582913f, 0.01969795f, -0.00005474f, -0.01504718f, -0.00538920f, -0.01143636f, 0.00083963f, 0.02999250f, 
    -0.03084674f, -0.01373487f, -0.03840117f, 0.01803825f, 0.00636307f, -0.00320638f, 0.02586172f, 0.01740361f, 
    -0.04041447f, 0.00234335f, -0.03006823f, -0.01750759f, 0.01520284f, -0.00447292f, 0.02470894f, -0.02387226f, 
    -0.03167172f, 0.02783612f, 0.01454229f, -0.01839626f, -0.00882215f, 0.01369832f, 0.02591693f, 0.02331980f, 
    -0.00103288f, -0.02427637f, 0.03553700f, -0.03128291f, 0.00244932f, 0.01512614f, -0.01912721f, 0.02962604f, 
    0.02552966f, 0.02497716f, 0.01713888f, -0.03207282f, 0.00409414f, -0.01788042f, -0.03337529f, -0.04130071f, 
    -0.03553103f, -0.01670765f, -0.02173541f, -0.02593074f, -0.00245537f, -0.01837279f, -0.02767078f, -0.03603096f, 
    0.02797818f, -0.02705182f, 0.02459308f, -0.03911950f, 0.01236388f, -0.02217770f, -0.03065138f, -0.01738383f, 
    0.02492301f, 0.00661842f, -0.01020004f, -0.02066821f, -0.00954584f, -0.01012515f, 0.01031241f, 0.01758128f, 
    -0.00106935f, -0.02342007f, -0.01187820f, -0.00565201f, -0.01788345f, -0.02909984f, -0.01551492f, -0.02634427f, 
    0.02191242f, 0.02263408f, 0.01072096f, 0.01126741f, 0.03004749f, -0.01637011f, -0.01527705f, -0.00105517f, 
    -0.02530926f, 0.00705563f, -0.04007741f, 0.01650114f, -0.01612893f, -0.01622905f, -0.00467141f, 0.02409548f, 
    -0.01221938f, -0.01961564f, 0.01679956f, -0.00427993f, -0.02053132f, -0.02229607f, -0.01238452f, 0.02041416f, 
    0.02618249f, -0.00011959f, 0.00598925f, -0.03208449f, 0.01878942f, -0.02874695f, 0.02191846f, 0.02702578f, 
    0.03023537f, -0.02981501f, 0.00979302f, -0.02897288f, 0.02446842f, 0.01467671f, -0.00846382f, 0.02319635f, 
    0.01157726f, 0.00450270f, -0.01641854f, -0.00130757f, 0.02567289f, -0.03789880f, -0.00164221f, 0.01340393f, 
    0.00739338f, -0.01338627f, -0.00351506f, 0.01720461f, 0.01874799f, -0.02439587f, -0.02799396f, 0.01827467f, 
    -0.00804383f, -0.03226110f, -0.01241991f, -0.02716051f, -0.02217051f, -0.00639941f, -0.02148262f, 0.01077765f, 
    -0.00143391f, -0.00046214f, -0.01193427f, 0.00756685f, -0.02307415f, 0.02049029f, -0.00606273f, -0.02354607f, 
    0.02506555f, -0.04010063f, -0.02734198f, -0.00483302f, 0.01904103f, -0.02283725f, -0.03878884f, 0.00532147f, 
    -0.03283827f, 0.01578228f, -0.03550548f, -0.00016702f, 0.02318043f, 0.01218943f, -0.03242609f, -0.01857469f, 
    -0.01958358f, -0.00471196f, -0.04078999f, -0.01661386f, 0.02568837f, -0.00367932f, -0.03480913f, 0.02438029f, 
    -0.01143785f, 0.03167891f, 0.00166266f, -0.02041467f, -0.04114166f, -0.01485041f, 0.01046025f, -0.03374703f, 
    -0.02833121f, -0.01525781f, -0.03406282f, -0.00567791f, 0.02799723f, 0.02811797f, -0.00440614f, 0.03065034f, 
    -0.03204118f, -0.00087337f, 0.00617822f, -0.03281056f, -0.02609558f, -0.03400414f, -0.01998904f, -0.01541333f, 
    -0.01885499f, -0.02034262f, 0.01076883f, -0.00510410f, 0.00807819f, -0.00467704f, -0.01870072f, -0.00302974f, 
    -0.03920853f, -0.03004560f, 0.00261590f, -0.00762753f, -0.03661685f, -0.01323195f, -0.02312071f, -0.00566083f, 
    -0.02976811f, -0.01877598f, -0.03396610f, 0.01424314f, 0.00670660f, 0.00179004f, 0.00824346f, 0.00575893f, 
    0.01943225f, 0.01489749f, -0.02407813f, -0.02809982f, -0.00335353f, -0.03866987f, -0.01405836f, -0.01427169f, 
    0.02397383f, 0.01607837f, -0.03374930f, 0.01953749f, -0.03459168f, 0.01480096f, -0.03014982f, -0.02084233f, 
    0.00986716f, -0.00639736f, -0.01635084f, -0.01872721f, 0.01577348f, -0.00323350f, -0.01955277f, 0.00023808f, 
    0.02619669f, 0.00960072f, 0.00015821f, -0.03714295f, 0.01588417f, 0.02333569f, 0.02439364f, 0.02633437f, 
    -0.00753803f, -0.01906905f, -0.02680141f, -0.02808108f, -0.02437820f, -0.03017529f, 0.01926902f, -0.00476187f, 
    -0.00232101f, -0.03164543f, 0.02010785f, 0.02187678f, 0.00467087f, -0.02972203f, -0.03851935f, -0.02009275f, 
    -0.02703827f, 0.01039137f, -0.03396138f, -0.03252842f, -0.02297424f, -0.03779588f, -0.01481747f, -0.00898655f, 
    -0.01088266f, -0.03122169f, -0.01059653f, 0.00114097f, -0.02434594f, 0.01194738f, 0.01544625f, 0.00152617f, 
    0.02327033f, -0.00150825f, 0.00378911f, 0.01520945f, -0.02929704f, 0.00829878f, -0.02878178f, -0.01420373f, 
    -0.02193378f, 0.00684221f, 0.00566297f, 0.02935697f, 0.00419827f, 0.02624129f, -0.01907023f, -0.04002485f, 
    -0.02799627f, -0.01342986f, 0.00202593f, 0.02766351f, 0.02261817f, 0.00011018f, -0.01954705f, -0.00187152f, 
    -0.01929262f, 0.01081833f, -0.00421809f, -0.03347288f, -0.01843162f, 0.01223952f, -0.00447740f, -0.03213050f, 
    0.00347664f, -0.01551368f, 0.00516707f, 0.00434828f, 0.00063014f, 0.02001531f, -0.02130258f, -0.01203814f, 
    -0.00455376f, -0.00654072f, -0.00143463f, -0.01078514f, -0.03472109f, 0.02626270f, -0.00494875f, -0.00250086f, 
    -0.02037567f, 0.02099952f, -0.03980730f, -0.00825684f, 0.00909741f, -0.02311914f, 0.01221349f, -0.00605627f, 
    -0.03482629f, 0.01724470f, 0.02942908f, -0.01014756f, 0.00676604f, -0.01951759f, 0.01420911f, -0.02361029f, 
    -0.03987893f, 0.00540463f, 0.02966288f, 0.03025561f, -0.01997878f, 0.03007440f, -0.00012548f, -0.02857840f, 
    -0.01566920f, 0.00903641f, -0.00207693f, -0.00706439f, -0.00956386f, 0.02517250f, 0.02326752f, -0.03316459f, 
    0.02185140f, -0.03508172f, -0.00752333f, -0.00200778f, -0.03254196f, -0.02171700f, -0.00854375f, 0.02951333f, 
    0.00762827f, 0.00221241f, -0.01373915f, -0.01764145f, -0.02373337f, -0.03487641f, -0.01446774f, 0.01368110f, 
    -0.03328148f, -0.02254743f, -0.03350237f, -0.02381533f, 0.01835716f, -0.00566669f, -0.01824582f, 0.00311262f, 
    0.01146367f, -0.02303616f, 0.03022784f, -0.03941682f, -0.03955892f, -0.02951253f, -0.01395199f, 0.00348909f, 
    -0.01203914f, -0.00878684f, -0.02683961f, 0.00320281f, -0.02482071f, 0.01862992f, -0.02467469f, -0.01436368f, 
    0.02775987f, -0.02351782f, 0.02564341f, 0.02659384f, 0.01081167f, 0.02274541f, -0.02332108f, 0.01806704f, 
    -0.03421734f, -0.01221739f, -0.04044892f, 0.00670997f, -0.00351207f, -0.02294858f, 0.01215240f, 0.01029197f, 
    -0.00241907f, 0.02320546f, 0.00897527f, -0.02931933f, 0.01707399f, -0.02012276f, -0.01944068f, -0.03833770f, 
    0.01923634f, 0.01844318f, 0.00591908f, -0.00129088f, -0.03950712f, 0.02154106f, -0.03404620f, -0.02813231f, 
    0.03279325f, 0.02919222f, -0.01001980f, -0.01418067f, 0.01034577f, -0.01489392f, 0.00350231f, -0.00300639f, 
    -0.00624671f, -0.04028888f, 0.00599926f, -0.01302306f, -0.03763973f, -0.03825992f, -0.01872945f, -0.03822784f, 
    -0.01113515f, -0.01631392f, 0.01523004f, 0.00363139f, -0.03259591f, 0.00668844f, 0.03024368f, -0.02594494f, 
    -0.01436010f, 0.02963150f, 0.03057368f, 0.00120361f, -0.00289650f, 0.02847903f, 0.00447613f, -0.01328166f, 
    -0.00675565f, 0.03115898f, 0.00328093f, 0.02005150f, -0.00699677f, -0.00721534f, 0.01306783f, -0.04064751f, 
    -0.03873709f, -0.02110977f, 0.02090800f, -0.03236343f, 0.00356505f, 0.01293055f, 0.02142357f, -0.00020693f, 
    0.02923638f, 0.01793763f, -0.02643943f, -0.02830851f, -0.02214937f, 0.02647262f, -0.02483013f, -0.01466927f, 
    -0.00638766f, -0.01760997f, 0.01859283f, 0.02901682f, -0.02505554f, 0.00297845f, 0.01414450f, -0.01438467f, 
    0.01874603f, 0.02871921f, 0.01401772f, 0.01021749f, -0.03826551f, -0.02042224f, -0.00348457f, 0.01661137f, 
    0.00635553f, 0.00407215f, 0.00688951f, -0.00744151f, 0.00845093f, -0.00869758f, 0.02790833f, -0.01177400f, 
    0.01091529f, -0.01814940f, -0.02301661f, -0.03083673f, -0.01904342f, 0.01724000f, 0.02280804f, 0.01697538f, 
    -0.00817002f, -0.01167195f, -0.02117671f, 0.02116010f, -0.01061467f, 0.01310465f, -0.03294075f, -0.03128329f, 
    -0.01756577f, -0.02925547f, -0.02794769f, -0.00679037f, -0.03259847f, -0.00351415f, 0.01426176f, -0.00589332f, 
    0.01113291f, -0.03389568f, -0.03256369f, -0.02478124f, 0.01017623f, 0.00343041f, -0.03951607f, -0.00770315f, 
    -0.01556510f, -0.01799025f, -0.03796366f, -0.00533148f, 0.02873176f, 0.02913936f, -0.01672604f, -0.00931610f, 
    0.01004520f, -0.00311384f, 0.02047285f, 0.00503761f, -0.01289395f, -0.02901531f, -0.03600706f, -0.03580905f, 
    0.01543692f, 0.02794686f, 0.01231026f, -0.03152505f, 0.01165371f, 0.02014120f, -0.00501662f, 0.02406714f, 
    0.02334034f, 0.02381192f, -0.01581947f, 0.00199018f, -0.03405915f, 0.02394575f, 0.00198576f, 0.00531625f, 
    -0.03601351f, -0.00119431f, -0.02185354f, -0.00099455f, -0.02182057f, 0.00507104f, 0.00026394f, 0.01299149f, 
    -0.02359712f, -0.00029634f, -0.01651419f, 0.02493716f, 0.00799508f, 0.01878731f, -0.02734286f, 0.02710349f, 
    -0.02543637f, 0.02303398f, -0.00894912f, -0.00216157f, -0.01224394f, 0.02238149f, -0.01316849f, 0.01037452f, 
    0.00573391f, 0.02482619f, 0.01613418f, -0.01522071f, -0.01484214f, 0.02862788f, 0.01287653f, -0.01569047f, 
    -0.03651585f, -0.01876020f, -0.00260800f, 0.02812553f, 0.01431033f, -0.00378165f, 0.00811955f, -0.00740335f, 
    0.02866413f, -0.02661994f, 0.01512619f, -0.01217772f, 0.01662884f, 0.00274153f, 0.03252047f, -0.01604445f, 
    -0.00600369f, -0.03339609f, 0.01151092f, -0.01638836f, -0.01936198f, -0.00247522f, -0.03593560f, 0.03197252f, 
    -0.04129809f, -0.04004154f, -0.02540427f, 0.00298458f, 0.00946352f, -0.03383246f, -0.01770437f, 0.03016689f, 
    -0.03753856f, -0.03660947f, -0.03841324f, 0.00267379f, -0.03265475f, 0.02216927f, -0.00782022f, -0.02403576f, 
    -0.00153511f, -0.03291131f, -0.00595638f, -0.03319077f, -0.02694693f, 0.02135597f, -0.02858060f, -0.03440183f, 
    -0.02291939f, 0.00454896f, -0.00335700f, 0.03003646f, 0.02516504f, -0.02208013f, 0.02459882f, 0.00387726f, 
    -0.02389568f, -0.02194885f, -0.00610743f, -0.03182233f, -0.02634176f, -0.03093801f, -0.03972442f, -0.03115567f, 
    0.01699202f, 0.02864784f, -0.00855725f, 0.01590972f, 0.00723318f, -0.01015066f, -0.01461224f, -0.03086468f, 
    -0.02316483f, -0.02612189f, 0.02237527f, -0.03373921f, 0.00053403f, -0.02714062f, -0.02302442f, 0.01266439f, 
    0.01147179f, 0.02362281f, -0.03480390f, -0.03914389f, 0.00400149f, 0.01779387f, -0.01402078f, 0.01643086f, 
    0.01087375f, -0.03410076f, 0.00085696f, -0.01561974f, -0.01741919f, 0.02457734f, -0.01967947f, -0.00611012f, 
    0.00321940f, 0.02775925f, -0.01435189f, -0.01524646f, 0.01143248f, 0.01756465f, -0.01612126f, 0.00796749f, 
    0.00105253f, 0.03023192f, 0.00114922f, -0.02814551f, -0.01128929f, -0.02006069f, 0.02779128f, -0.03515051f, 
    -0.02709527f, -0.01609888f, -0.03432804f, 0.02845459f, 0.00703059f, -0.00103308f, 0.01514410f, 0.01160277f, 
    -0.03183166f, -0.02522558f, 0.01420354f, -0.03287419f, -0.02033815f, 0.02288297f, -0.01334356f, -0.00264091f, 
    0.00621156f, -0.02788988f, 0.01115006f, -0.01414226f, -0.03170384f, -0.00075710f, -0.04005968f, 0.00758516f, 
    0.01643806f, 0.02816468f, -0.02124216f, -0.01104131f, -0.04090777f, -0.01205280f, 0.00125536f, 0.02952297f, 
    0.07804234f, 0.19876209f, 0.15569657f, 0.18415681f, 0.01274490f, 0.12547833f, 0.10077199f, -0.05788795f, 
    -0.01772249f, 0.11848284f, -0.14290945f, 0.00920296f, 0.14010371f, 0.17029512f, -0.20377430f, -0.32634884f, 
    0.04520565f, -0.02542527f, -0.00603983f, 0.09758253f, 0.18822224f, -0.01371795f, 0.09016281f, -0.12299829f, 
    0.00137966f, 0.15130320f, -0.24439795f, 0.05580106f, -0.00183528f, -0.01361170f, -0.00105945f, 0.09015768f, 
    -0.04501161f, 0.03962187f, -0.09766828f, -0.07531837f, -0.36619207f, -0.27918181f, -0.10122072f, 0.00418359f, 
    -0.01315988f, -0.07806765f, -0.11451489f, -0.21050574f, -0.00646130f, 0.01322245f, -0.02726996f, -0.06145718f, 
    0.31709853f, 0.27748087f, 0.16066919f, 0.08301928f, -0.03985139f, 0.16302434f, 0.17605136f, 0.09992480f, 
    0.10545743f, 0.03907461f, -0.03021877f, -0.15149027f, -0.24595931f, -0.08451681f, 0.20321320f, -0.36648539f, 
    0.05828445f, -0.06766242f, -0.16614388f, -0.00144055f, 0.07723903f, 0.07603604f, 0.10391491f, 0.08710971f, 
    -0.35507068f, 0.12302290f, -0.04454478f, 0.01491726f, -0.18939286f, -0.07542627f, -0.15921254f, 0.09490533f, 
    0.10233021f, -0.06876914f, -0.05269878f, -0.28699055f, -0.08960427f, 0.01966588f, -0.04364773f, -0.26233560f, 
    -0.04727007f, -0.07453253f, -0.04545772f, 0.13286978f, 0.02757286f, -0.03019801f, 0.01055207f, -0.09114639f, 
    0.17904855f, -0.00042386f, -0.02037544f, 0.03564980f, -0.12468099f, 0.18158862f, 0.08297743f, -0.01300263f, 
    0.08895627f, 0.04515119f, -0.01985099f, -0.00658387f, 0.05647182f, 0.12559329f, -0.00790902f, 0.23168369f, 
    -0.14272469f, 0.00869076f, 0.15465836f, 0.04076574f, -0.06031236f, 0.11602580f, -0.02456870f, 0.05631955f, 
    -0.23776755f, -0.05371478f, 0.14440486f, 0.23021767f, -0.15885703f, -0.10167368f, -0.04943846f, -0.05134124f, 
    0.07858877f, 0.04951690f, -0.05695812f, 0.08135588f, -0.15771163f, -0.18175025f, 0.08796697f, 0.06070068f, 
    0.00121015f, -0.12169888f, 0.03461669f, -0.02218204f, 0.00056830f, 0.02768620f, -0.13520683f, 0.07266499f, 
    0.07155502f, 0.02123184f, -0.04987887f, -0.08423290f, -0.08390298f, 0.00202589f, -0.18537226f, 0.19191536f, 
    -0.08199567f, 0.02556143f, -0.09170581f, 0.11243816f, 0.24171387f, -0.19757496f, 0.13596970f, -0.03532207f, 
    0.08940325f, -0.03793263f, 0.01927351f, 0.20701295f, 0.01108460f, 0.12148593f, 0.07530144f, -0.02066054f, 
    -0.16125026f, -0.04180812f, -0.00231688f, -0.14983128f, 0.02693099f, -0.05762637f, 0.09475765f, -0.02493969f, 
    0.04123074f, 0.12568480f, 0.07305626f, 0.10757207f, -0.28096178f, 0.16745378f, 0.26457530f, 0.19531158f, 
    0.02402524f, -0.10459071f, 0.01239013f, 0.00731720f, -0.01248171f, 0.00668922f, -0.02498823f, 0.00210386f, 
    0.24388517f, 0.16376685f, -0.03578949f, -0.12847582f, 0.06179366f, 0.12189890f, 0.05193278f, 0.13307616f, 
    -0.09926302f, -0.01521368f, 0.02379607f, 0.05357428f, 0.14765345f, 0.12621984f, 0.03808766f, -0.09948631f, 
    0.04521484f, 0.03580882f, -0.13966408f, 0.25426233f, -0.03677080f, -0.13611850f, -0.04200473f, 0.18323043f, 
    -0.11673203f, 0.00380433f, 0.10296312f, 0.15403672f, 0.11867025f, -0.09316050f, -0.08043040f, -0.02744971f, 
    -0.01560692f, 0.07267505f, 0.04613436f, 0.05203201f, 0.05609259f, -0.21535392f, 0.16388671f, 0.14642251f, 
    -0.17362310f, 0.01408116f, -0.08499836f, 0.05385496f, 0.10356983f, 0.01966078f, -0.13224421f, 0.19235361f, 
    0.01559151f, 0.07366718f, 0.11334250f, -0.08271891f, 0.09289380f, -0.09183110f, -0.01728870f, 0.00915769f, 
    0.11939342f, 0.06335068f, -0.05521703f, 0.02725874f, -0.37545153f, -0.05061662f, 0.12544405f, 0.03775550f, 
    0.11484694f, -0.04936930f, 0.04485524f, -0.15201239f, -0.18772604f, -0.09316257f, -0.02693860f, -0.00558273f, 
    -0.14584605f, 0.03058641f, -0.02601839f, 0.17067967f, 0.03299156f, -0.17463742f, 0.04901846f, -0.05305789f, 
    0.04301646f, -0.05291918f, 0.11144463f, -0.05296843f, -0.30765903f, -0.26473457f, 0.25205228f, 0.13344225f, 
    -0.04870099f, -0.04093384f, -0.06516524f, -0.16578344f, 0.03628213f, -0.00005849f, -0.01483662f, 0.22190842f, 
    0.10497333f, 0.10838705f, -0.02347645f, 0.08451626f, -0.01257502f, 0.09759176f, -0.14236873f, -0.10432015f, 
    0.01929126f, -0.07981477f, -0.00086224f, -0.05329813f, 0.14694859f, -0.04831078f, 0.01857721f, -0.01542758f, 
    0.03411640f, -0.12939483f, 0.12452001f, 0.02207262f, 0.04844101f, -0.01524550f, -0.17253870f, 0.08870342f, 
    0.38417742f, -0.01329831f, 0.03477774f, 0.03537819f, 0.11125816f, 0.09900676f, 0.09588899f, 0.05852727f, 
    -0.06636657f, -0.04458852f, -0.03481993f, 0.09954239f, 0.13647497f, 0.19594263f, 0.17683773f, 0.21918878f, 
    0.09358686f, 0.06585404f, -0.08580936f, -0.15860163f, -0.05522660f, -0.01764996f, -0.15271696f, 0.12280502f, 
    0.06132376f, -0.13881586f, 0.13309051f, 0.10802562f, -0.08652880f, 0.03211891f, -0.06469852f, -0.16937982f, 
    -0.01225847f, 0.08059922f, -0.15308143f, 0.04676544f, -0.07405301f, -0.06596106f, -0.21400644f, 0.13473660f, 
    -0.15144752f, -0.16452140f, -0.00169911f, 0.24167672f, -0.16627784f, 0.07794481f, -0.14283180f, -0.04825599f, 
    0.32719380f, 0.04981820f, 0.31648174f, 0.20778628f, 0.03876035f, 0.09549191f, -0.01269884f, -0.10027035f, 
    0.17269877f, 0.06498529f, -0.08477395f, 0.03619160f, -0.30927843f, 0.09270934f, 0.13544063f, 0.14041297f, 
    0.04774178f, -0.06125215f, -0.18678792f, -0.11045291f, -0.03574450f, -0.16948682f, 0.05654039f, -0.00664928f, 
    0.11814344f, 0.18175919f, -0.06075466f, 0.13855384f, 0.08266521f, 0.04106222f, 0.11890741f, -0.01278608f, 
    0.06509452f, 0.11891596f, -0.05015763f, 0.00310934f, -0.07889242f, -0.29792285f, -0.13198149f, 0.23174246f, 
    -0.16824022f, -0.15250443f, 0.08012612f, -0.00848521f, -0.02990971f, -0.01729029f, -0.06447225f, 0.05760743f, 
    -0.00142200f, 0.04399013f, 0.09833308f, -0.15346622f, 0.02288475f, 0.09419613f, -0.08708460f, 0.04544776f, 
    -0.01524722f, 0.03735659f, -0.07612457f, 0.09476012f, 0.28808492f, 0.03695396f, -0.10231379f, 0.00860511f, 
    -0.05640463f, -0.04350804f, -0.04138882f, -0.20103517f, 0.02006705f, 0.09660465f, 0.05487549f, -0.00372271f, 
    0.24724820f, 0.17552944f, -0.00540944f, -0.01802352f, 0.08421024f, 0.04933682f, 0.04825072f, 0.12647069f, 
    -0.06319329f, -0.04252217f, 0.01010556f, 0.04330078f, 0.06266534f, -0.03279589f, 0.00650049f, 0.11853825f, 
    -0.10409743f, -0.02674622f, -0.15149724f, -0.14454466f, -0.02751811f, 0.11698610f, -0.00997244f, -0.00138102f, 
    0.10197736f, 0.13274033f, -0.03118372f, 0.20901291f, -0.01976787f, -0.14734685f, 0.17802869f, 0.04826015f, 
    0.04659229f, 0.04099099f, 0.05285726f, 0.08896493f, -0.13554727f, -0.00769851f, -0.14899230f, -0.01947746f, 
    -0.02451486f, -0.10269121f, -0.10907242f, 0.15007420f, -0.06306497f, 0.07513312f, -0.09215724f, -0.06164959f, 
    0.05354108f, 0.04329235f, 0.19630262f, -0.20584752f, -0.10529397f, -0.04699145f, 0.03077079f, 0.07374220f, 
    0.01725275f, 0.09439323f, 0.01354631f, -0.09547134f, -0.05528211f, 0.28142038f, 0.25115791f, -0.16243714f, 
    0.06408743f, -0.04085448f, -0.12521155f, 0.07709865f, -0.01038764f, -0.03403867f, 0.12939726f, -0.08879291f, 
    0.19449404f, 0.00702526f, 0.05022960f, 0.09101587f, 0.02318696f, 0.06501719f, -0.03106107f, -0.04430423f, 
    -0.11712169f, -0.04150856f, 0.01378953f, 0.13102305f, 0.00739458f, -0.11248522f, -0.08395511f, -0.09645583f, 
    -0.23885684f, -0.07785453f, -0.14486378f, -0.15063062f, 0.03144106f, 0.02886774f, 0.04910602f, -0.08126769f, 
    0.22717789f, 0.23488806f, 0.19915427f, 0.00116842f, 0.09309951f, 0.05891010f, 0.05281472f, 0.09494841f, 
    0.11046515f, -0.10014098f, -0.14962196f, 0.03159386f, -0.11719940f, -0.06682618f, 0.11133886f, -0.03273112f, 
    -0.28016487f, -0.12498303f, -0.18262000f, -0.19218478f, -0.16660771f, -0.02472199f, -0.00321863f, -0.18910241f, 
    -0.16656148f, 0.18377690f, 0.01242341f, 0.14154483f, -0.10219547f, -0.02385732f, -0.15372485f, -0.16856804f, 
    0.00216249f, -0.05751055f, -0.00768226f, -0.12220728f, -0.15454097f, -0.09454754f, 0.00889234f, 0.08979478f, 
    0.00512223f, 0.11543345f, -0.10594107f, -0.21183853f, 0.10536559f, -0.04616246f, 0.10636166f, -0.01416794f, 
    0.10138010f, 0.18699618f, -0.05427308f, -0.09672476f, -0.00310827f, -0.12255128f, 0.05719507f, 0.09378599f, 
    -0.15956074f, 0.00134832f, -0.01929994f, -0.16824976f, 0.21321224f, 0.07836172f, 0.10464177f, 0.07149572f, 
    0.07762294f, 0.04691510f, -0.05901651f, 0.10595424f, -0.03446608f, 0.01813972f, -0.04146301f, -0.08318558f, 
    -0.05846990f, -0.20788804f, -0.26904806f, 0.10313749f, -0.17965816f, -0.07006720f, -0.09752420f, -0.04744395f, 
    0.03269896f, -0.07172839f, 0.09493589f, -0.05399195f, -0.05425808f, 0.16027176f, 0.16472191f, 0.14925088f, 
    0.03173412f, 0.03567750f, 0.12237284f, -0.03224967f, -0.01256493f, -0.16530699f, 0.13925523f, -0.14694680f, 
    0.23700197f, 0.11589802f, -0.10153161f, 0.17662865f, 0.11083790f, -0.01989381f, -0.04681790f, 0.02832299f, 
    0.00909027f, -0.07628071f, -0.06144464f, -0.03376216f, -0.19329409f, -0.14871795f, 0.35847861f, -0.07861302f, 
    -0.13380606f, 0.15396868f, -0.10433852f, 0.11698774f, -0.03347715f, -0.04311479f, -0.06928060f, 0.08819710f, 
    -0.11497720f, -0.13783555f, -0.24891481f, -0.18420292f, -0.05631828f, -0.17762811f, -0.00746154f, -0.16509369f, 
    0.03295882f, 0.10443198f, 0.25485668f, 0.12425674f, 0.27409708f, -0.03280715f, 0.16956678f, 0.02982455f, 
    -0.10463163f, -0.03188211f, 0.05867910f, 0.08813070f, 0.05696226f, -0.02709953f, 0.14708427f, 0.17319800f, 
    -0.20943639f, -0.08433979f, -0.08695126f, 0.24285263f, -0.07566422f, -0.01529864f, 0.00849675f, -0.12654330f, 
    -0.00418825f, -0.11221709f, -0.00865100f, 0.03376744f, 0.12118047f, 0.28265497f, 0.09911232f, 0.21343488f, 
    -0.06895027f, 0.21803100f, 0.25229338f, 0.20509635f, -0.04200054f, 0.01012118f, 0.05680073f, 0.01459049f, 
    0.25877231f, 0.14766066f, 0.25050083f, 0.13301221f, 0.09405155f, 0.02401770f, 0.05566960f, -0.05567624f, 
    -0.01183899f, 0.01151878f, -0.02923003f, -0.08577915f, -0.00843365f, 0.18243580f, -0.14331336f, -0.24191523f, 
    0.09577581f, 0.15068085f, -0.04354687f, 0.16535431f, -0.04644305f, 0.25841597f, 0.04473967f, 0.02594835f, 
    0.38870719f, -0.03329249f, -0.11174865f, -0.24979594f, -0.15746380f, -0.05886411f, 0.03921902f, -0.06618416f, 
    -0.07634225f, 0.03044341f, 0.00021979f, -0.05435337f, -0.30855921f, -0.03876808f, -0.02320195f, 0.03783771f, 
    -0.17079346f, 0.05919843f, -0.01245577f, -0.10236523f, -0.03638585f, 0.01325470f, -0.01708199f, -0.00799427f, 
    0.01279157f, 0.05883813f, 0.14235812f, -0.09787675f, -0.09897000f, 0.04607400f, -0.07139874f, 0.14776842f, 
    -0.01250100f, -0.12178037f, 0.08365981f, 0.10882350f, -0.47564143f, 0.17687280f, 0.11761133f, -0.08969264f, 
    -0.08116303f, -0.01402585f, 0.05339830f, -0.10528353f, -0.01847485f, -0.07224700f, 0.01172557f, 0.12057766f, 
    -0.02517391f, 0.00492252f, -0.01459070f, -0.02700156f, -0.01521576f, -0.04184486f, 0.01816791f, 0.01525097f, 
    0.01922782f, 0.01201556f, 0.00993623f, 0.02411450f, 0.00847844f, 0.01771524f, -0.03533342f, -0.00065711f, 
    -0.03304508f, 0.02197166f, -0.03097698f, 0.01472665f, -0.01936667f, -0.02668975f, 0.01324313f, -0.00062671f, 
    0.03478529f, -0.00827445f, -0.00956467f, 0.00046798f, 0.01652033f, -0.01920634f, -0.03188609f, 0.03014643f, 
    -0.00991865f, -0.03264625f, -0.00875931f, -0.02154291f, -0.03072106f, -0.01274855f, 0.01899680f, 0.01663365f, 
    -0.01116774f, 0.00372332f, -0.00702531f, -0.02210742f, -0.02641130f, -0.03093036f, 0.01310809f, 0.01002231f, 
    0.03518550f, 0.02659842f, -0.02012735f, -0.02338734f, 0.02681655f, 0.01351125f, -0.00443769f, -0.01221811f, 
    0.01407096f, 0.01719102f, 0.02149671f, 0.01247538f, -0.00680401f, -0.01810076f, -0.03597688f, -0.02596344f, 
    0.00794408f, -0.00973306f, -0.02004028f, -0.00962703f, 0.02384607f, -0.02373968f, -0.01990731f, -0.00855217f, 
    -0.02241493f, 0.01617236f, -0.01766501f, -0.02604036f, 0.01672894f, -0.01287667f, -0.01526852f, -0.01044618f, 
    -0.01526146f, -0.01145777f, -0.01905129f, 0.01423357f, 0.02923040f, -0.02143498f, 0.02333396f, -0.02415244f, 
    0.02022044f, -0.00032247f, 0.00670876f, -0.02179894f, -0.00671678f, -0.00386419f, -0.00041302f, 0.00949417f, 
    -0.03075695f, -0.00144057f, 0.00915105f, -0.03681685f, -0.01916678f, -0.01620768f, 0.00008153f, -0.00300618f, 
    -0.02047453f, -0.01239606f, 0.01911778f, -0.04285622f, -0.02483752f, -0.00537938f, -0.01555694f, 0.00010026f, 
    -0.01758065f, 0.01679199f, 0.02020398f, -0.04287749f, -0.01261032f, 0.00159715f, -0.00338656f, -0.02434691f, 
    0.01365125f, -0.01762494f, -0.01439260f, -0.00264235f, 0.01978719f, 0.02340640f, 0.00435369f, -0.00643289f, 
    -0.02946287f, 0.01207534f, -0.03372582f, 0.01585320f, -0.02372599f, 0.01447907f, -0.00184046f, -0.04510783f, 
    0.02262397f, -0.02833629f, 0.01535935f, -0.00516534f, -0.01314957f, -0.00382188f, -0.01445305f, 0.00332398f, 
    0.01758070f, -0.03003786f, 0.01406800f, -0.01811211f, 0.01011437f, -0.00581988f, 0.01855065f, -0.02370388f, 
    0.01577490f, -0.04399718f, -0.03785322f, -0.02975732f, -0.00960213f, 0.02023786f, -0.02723177f, 0.02640262f, 
    -0.03997352f, 0.02491637f, -0.00658394f, -0.01909352f, 0.01601207f, 0.01075725f, -0.04038291f, 0.01195690f, 
    0.01814981f, -0.01085079f, 0.02481211f, 0.00549159f, -0.02762766f, -0.02131997f, -0.00719466f, 0.02328027f, 
    -0.01941646f, -0.03288693f, 0.00389521f, -0.00045250f, 0.02683501f, -0.02234846f, -0.02580704f, 0.02215587f, 
    0.00962927f, 0.00281077f, 0.02747270f, 0.00156828f, 0.00080954f, -0.02205398f, 0.00545452f, -0.04297667f, 
    0.02068963f, 0.00895608f, -0.04375839f, 0.00226255f, 0.01772011f, -0.02496062f, -0.01663829f, 0.00677126f, 
    -0.00504466f, -0.01562184f, -0.03655883f, -0.04208324f, -0.02598595f, -0.01555323f, 0.00356056f, -0.01024340f, 
    0.00796745f, -0.02136252f, -0.00929447f, -0.02199957f, 0.02260628f, 0.02074886f, 0.02933627f, -0.02351065f, 
    0.01359401f, -0.02958666f, -0.03986471f, -0.00299744f, 0.00923005f, -0.01585992f, -0.01914291f, -0.02291245f, 
    -0.04323493f, -0.03375262f, -0.01933051f, -0.01589942f, 0.03146757f, 0.01216481f, 0.00623887f, 0.00033398f, 
    0.02378660f, -0.01897392f, 0.00639041f, -0.01684145f, 0.02576514f, 0.02691142f, -0.01007631f, -0.03727308f, 
    0.02189123f, 0.03658273f, -0.02920558f, -0.02407566f, 0.00811139f, -0.01177977f, -0.01331935f, 0.00163759f, 
    0.00804093f, 0.02568396f, 0.02044857f, -0.03275510f, -0.02137423f, -0.04141148f, 0.02128654f, -0.02963251f, 
    0.01309053f, -0.01279306f, -0.01341121f, 0.01749456f, 0.01404581f, -0.02371320f, -0.04086609f, -0.02359803f, 
    0.03294224f, 0.02576965f, 0.02279140f, 0.00828765f, -0.01581555f, -0.03995760f, -0.03063007f, 0.00535374f, 
    0.02838090f, 0.01592129f, -0.02157716f, -0.01337921f, 0.00427879f, 0.01466184f, -0.02249332f, -0.02789429f, 
    0.01834267f, -0.02428612f, -0.03378002f, -0.01130827f, -0.00462894f, -0.04104231f, -0.00622239f, -0.04319128f, 
    0.01273725f, -0.01132304f, -0.00820723f, -0.01153981f, -0.01096789f, -0.01649346f, 0.01270132f, 0.00742157f, 
    0.02753012f, 0.02800580f, 0.02364912f, -0.00637718f, 0.01946600f, -0.00573160f, -0.01130925f, -0.02578793f, 
    -0.00919170f, -0.03417726f, 0.02744583f, -0.01719002f, 0.01849187f, -0.00176941f, -0.00985411f, -0.03008831f, 
    -0.03403612f, 0.01661246f, 0.00655464f, -0.03176013f, -0.02676700f, -0.00746824f, -0.02717434f, -0.03117493f, 
    -0.01880592f, -0.03715486f, -0.01237193f, 0.00688661f, 0.04032687f, 0.00980570f, 0.00571553f, 0.02125121f, 
    0.01746860f, -0.01945768f, -0.00714621f, 0.00176607f, 0.00127225f, 0.02673756f, 0.00700587f, -0.00068434f, 
    0.00864533f, 0.00828896f, -0.01514375f, -0.01411314f, -0.03730084f, -0.01698363f, -0.00044607f, 0.00724214f, 
    -0.02545056f, 0.01389475f, 0.01480589f, -0.00158627f, -0.03495839f, -0.01227932f, 0.02593545f, -0.03956509f, 
    0.00258445f, -0.02140279f, -0.01911031f, 0.02436194f, -0.01750395f, 0.02445262f, -0.03081268f, -0.02278812f, 
    0.02403374f, -0.03533695f, -0.03117395f, 0.01363276f, -0.04156705f, -0.02538757f, 0.00861459f, -0.03265848f, 
    -0.01111809f, 0.00411279f, 0.00738928f, -0.00789992f, 0.00331916f, -0.02645093f, -0.00958165f, -0.01544311f, 
    -0.02715943f, -0.01639516f, -0.03120636f, 0.01563808f, -0.00416868f, 0.00555910f, -0.03210165f, 0.00715875f, 
    0.04035747f, -0.02845421f, 0.01557623f, 0.02161256f, -0.03412712f, 0.02228890f, -0.04055168f, 0.00086151f, 
    -0.01106326f, -0.02616913f, 0.02286917f, -0.04348433f, -0.02576064f, -0.03013290f, -0.02153336f, -0.01836958f, 
    -0.00780750f, 0.01827277f, -0.01281837f, -0.01067146f, 0.01914333f, -0.00034312f, -0.02079356f, 0.01404348f, 
    -0.02001927f, -0.01427808f, -0.01562975f, -0.02546570f, 0.02713934f, 0.02525784f, 0.01541717f, -0.01402272f, 
    0.02108118f, 0.00784108f, 0.00702417f, 0.00094447f, 0.01638427f, -0.04243146f, -0.00038943f, -0.01290429f, 
    0.02260005f, -0.00929464f, 0.00825395f, -0.04250092f, -0.04287066f, -0.02209164f, -0.00332508f, -0.02718858f, 
    -0.01742726f, -0.00931313f, -0.01707637f, 0.01532559f, -0.00155601f, 0.02674904f, 0.02327577f, -0.00704900f, 
    -0.04140024f, 0.01190894f, 0.01961943f, 0.00522417f, -0.02917738f, -0.00963436f, -0.03325649f, -0.00316287f, 
    0.00446966f, 0.01337831f, -0.00841753f, 0.00846332f, 0.00575461f, -0.00147489f, -0.03091761f, 0.00959818f, 
    -0.01001959f, -0.00551150f, -0.00079082f, -0.04016224f, -0.02142076f, 0.03154250f, -0.03370693f, -0.03784035f, 
    0.02401649f, 0.02236921f, 0.02147120f, 0.00284862f, -0.03163059f, -0.01815475f, -0.02075322f, 0.03179068f, 
    -0.03291445f, -0.03197908f, -0.04414847f, -0.03399243f, 0.00283702f, -0.01776386f, 0.00156998f, 0.01337929f, 
    -0.03473564f, -0.02764626f, -0.03731782f, 0.02037766f, 0.02364477f, -0.00993361f, 0.00140091f, -0.03657321f, 
    -0.00233911f, 0.00980745f, -0.03352082f, -0.02820306f, 0.01402593f, 0.02759141f, -0.01907077f, -0.03569201f, 
    -0.00706576f, -0.04362741f, -0.00816025f, 0.02253646f, 0.02744176f, 0.00700728f, 0.01868997f, -0.01767873f, 
    -0.04071862f, -0.04472980f, -0.04283763f, 0.00903357f, 0.01171289f, -0.01311912f, -0.01123901f, -0.01769414f, 
    0.02352946f, 0.01106760f, 0.01859277f, 0.01626861f, 0.00883794f, -0.03901510f, 0.00668432f, -0.01527608f, 
    -0.04019976f, -0.01949849f, 0.01609290f, 0.00315639f, -0.01759354f, -0.03463335f, 0.01405923f, -0.03100075f, 
    -0.02493123f, 0.02796418f, -0.00946836f, -0.01475887f, -0.02765769f, -0.02805905f, -0.02912525f, 0.01034989f, 
    0.02395945f, 0.01026008f, 0.03349804f, -0.01588799f, -0.01321971f, -0.00528279f, 0.02373914f, -0.02581514f, 
    -0.04383622f, -0.03698175f, -0.01920193f, -0.01199058f, 0.02926827f, -0.03435754f, -0.02912472f, 0.00282719f, 
    -0.00868953f, -0.02469663f, 0.02733490f, -0.02196080f, -0.04247693f, 0.02168017f, -0.03495476f, -0.00729005f, 
    -0.01967917f, 0.00453480f, -0.01315722f, 0.02638833f, 0.02661353f, -0.02777518f, -0.03143164f, -0.04108032f, 
    -0.03242176f, 0.01048274f, 0.02174336f, 0.00066413f, 0.00048759f, 0.02794230f, -0.03749305f, 0.01234410f, 
    0.02375922f, -0.00166975f, -0.02346284f, -0.02554496f, -0.00611077f, -0.03521561f, -0.00581216f, -0.03712334f, 
    -0.04367342f, 0.00183868f, 0.00976469f, 0.02490902f, -0.01286784f, -0.01140397f, 0.01106527f, 0.01905535f, 
    -0.00744498f, 0.01067487f, -0.02649209f, -0.02061644f, -0.00002422f, -0.00701877f, 0.01274821f, 0.01382830f, 
    -0.00855637f, -0.03927487f, -0.04151499f, -0.01138141f, -0.00470435f, 0.01390263f, -0.03731190f, -0.02120711f, 
    -0.01576353f, -0.00074997f, 0.02325059f, -0.01822706f, 0.01624662f, 0.00786083f, -0.02764388f, 0.02511130f, 
    0.00554686f, 0.02151797f, 0.00838470f, 0.02036110f, -0.00677876f, 0.02443144f, 0.02188402f, -0.02213207f, 
    -0.00399125f, 0.01144409f, -0.03108695f, 0.04173820f, 0.03472328f, -0.00501260f, 0.00717422f, 0.02947037f, 
    -0.02839943f, 0.01597708f, 0.02566627f, 0.00276989f, -0.00354357f, -0.03807069f, -0.02907603f, 0.00871625f, 
    0.02503506f, -0.00686099f, -0.02285724f, 0.01899975f, 0.01470457f, -0.00229998f, -0.00966000f, 0.01029471f, 
    0.01121456f, -0.04041335f, -0.01840270f, 0.01672247f, -0.02013474f, -0.00179931f, 0.02006148f, 0.00047240f, 
    0.01363750f, 0.01261813f, -0.03849285f, -0.03736173f, -0.02899915f, 0.00964779f, -0.02974254f, -0.02157507f, 
    -0.03029616f, 0.02700444f, -0.04636344f, -0.03625016f, 0.00738549f, -0.02258485f, 0.02451528f, 0.02195822f, 
    -0.04377113f, 0.00725112f, 0.02153415f, 0.01991634f, -0.03239012f, -0.02321226f, 0.01445005f, 0.00959992f, 
    -0.03161055f, -0.02573898f, 0.01246138f, -0.01220992f, -0.01086589f, 0.03017244f, -0.00135173f, -0.03385474f, 
    -0.01630695f, -0.01822729f, -0.02633826f, 0.02656880f, -0.01026113f, 0.00565771f, -0.02884555f, 0.00917517f, 
    0.03467467f, -0.02034312f, 0.02815502f, -0.02472954f, 0.00590237f, -0.00681701f, 0.02616875f, -0.02624715f, 
    -0.03661923f, -0.02107660f, 0.02166544f, 0.03493176f, -0.01359515f, -0.02971513f, -0.04062044f, 0.00451454f, 
    0.02000123f, -0.01051412f, -0.02012317f, -0.03044489f, -0.00697618f, 0.00522275f, 0.02422792f, -0.02195879f, 
    -0.02773029f, -0.01767985f, 0.02013876f, -0.02613337f, 0.01874591f, 0.00371416f, -0.02149123f, 0.00602954f, 
    0.01334617f, -0.03516261f, -0.03184298f, 0.02421031f, -0.03014793f, 0.01987221f, 0.00502182f, -0.01028786f, 
    -0.01844299f, -0.03971352f, 0.02906695f, -0.03978821f, 0.01008457f, -0.03803064f, -0.04409086f, -0.01826769f, 
    -0.02856405f, -0.03884751f, 0.00219476f, -0.01552175f, -0.04014871f, -0.02352576f, -0.03831422f, -0.02250425f, 
    -0.00275272f, 0.01958075f, 0.02669347f, 0.02458694f, 0.01497005f, 0.01580438f, -0.02511972f, 0.02344824f, 
    -0.01174184f, -0.01849094f, -0.00261209f, 0.00988114f, -0.01332382f, -0.00156721f, -0.00563671f, -0.00983198f, 
    -0.08858807f, 0.14504749f, 0.18051590f, -0.02251860f, 0.01017620f, 0.21911661f, 0.03075592f, 0.03921972f, 
    0.02589005f, 0.04008841f, 0.13105811f, 0.02686790f, 0.13068384f, 0.04391306f, -0.04701319f, -0.07209935f, 
    0.08407879f, -0.18570077f, 0.15716113f, -0.19295307f, 0.12854576f, -0.17296693f, -0.03336003f, 0.07295537f, 
    0.09975341f, 0.17726226f, -0.01101946f, 0.15444486f, 0.01688899f, -0.01581327f, 0.02680968f, -0.00323146f, 
    -0.02779442f, -0.02968641f, -0.04278176f, 0.04935225f, -0.47171450f, -0.27645823f, 0.04177350f, -0.03425355f, 
    -0.09652988f, -0.01524180f, 0.05207650f, -0.09129506f, 0.07737364f, 0.11616310f, -0.07844484f, 0.09422679f, 
    0.32305568f, 0.15094194f, -0.12879151f, -0.00039601f, 0.07713933f, 0.21089451f, 0.09703839f, 0.10830905f, 
    0.05265573f, -0.02519347f, -0.07228300f, 0.00331299f, -0.05484324f, -0.10662962f, -0.05722213f, -0.07928931f, 
    -0.07255147f, -0.00949133f, -0.10523326f, 0.00350922f, 0.02399212f, 0.01909548f, -0.06895177f, 0.06684252f, 
    -0.24821827f, -0.38320929f, -0.33640879f, -0.01881143f, -0.07493877f, 0.03429998f, -0.03820473f, -0.10746542f, 
    -0.03767021f, -0.00968844f, -0.05907265f, -0.01043153f, 0.20912966f, 0.00965585f, 0.14133981f, -0.13467404f, 
    -0.05362642f, -0.00264700f, -0.08399512f, 0.10312790f, -0.03929846f, -0.01705871f, -0.04882041f, -0.04153037f, 
    0.28201604f, -0.37171322f, -0.13655961f, 0.17050472f, 0.00877941f, -0.01787446f, 0.12622438f, -0.10996056f, 
    0.01477586f, 0.04542780f, 0.05719806f, 0.05441738f, 0.21220009f, 0.28974596f, 0.03143773f, 0.25576094f, 
    -0.09671124f, -0.05212702f, 0.06822468f, 0.02159539f, -0.15139532f, 0.04965289f, -0.02819844f, -0.02487393f, 
    -0.01371650f, -0.57367909f, 0.08058912f, -0.09632412f, 0.04723306f, 0.05334984f, 0.09874447f, -0.01007195f, 
    0.03773272f, 0.07125940f, -0.06626013f, -0.02840628f, -0.13417244f, 0.06892498f, -0.02056716f, 0.02627764f, 
    -0.04072870f, 0.08456773f, 0.08094445f, 0.04968030f, -0.02629087f, 0.19457322f, -0.07001597f, 0.08878934f, 
    0.13574997f, -0.16280305f, -0.04618023f, -0.01013347f, 0.05907324f, 0.09906799f, -0.02097139f, -0.00538894f, 
    0.03051389f, 0.02770801f, 0.01603188f, 0.09456526f, -0.00284698f, -0.02613175f, -0.13755110f, 0.01714336f, 
    -0.00510781f, -0.06780253f, -0.02600292f, -0.01057220f, 0.12125119f, -0.02869026f, -0.04974953f, -0.12307293f, 
    0.06281206f, -0.23463701f, -0.18279871f, -0.07360305f, 0.05497294f, -0.06696567f, 0.16823085f, 0.00934875f, 
    -0.00837477f, -0.00617420f, -0.03367506f, -0.03280844f, -0.13148578f, -0.28705075f, 0.12549700f, -0.15406471f, 
    0.01763418f, 0.12150624f, -0.07751289f, 0.01612095f, -0.00525336f, -0.00461679f, 0.15340273f, 0.13947862f, 
    0.12361056f, 0.00940155f, 0.00955036f, -0.02936256f, 0.05864485f, 0.05304161f, 0.03703097f, -0.03473924f, 
    -0.05428147f, 0.08507115f, -0.03098714f, 0.04837697f, 0.13472357f, 0.10775170f, 0.03011096f, 0.04591998f, 
    -0.01759097f, -0.01787824f, 0.00555419f, 0.09564247f, 0.02187461f, -0.09631931f, -0.09754576f, 0.07974184f, 
    0.16518585f, 0.10284703f, -0.06084124f, -0.02533150f, 0.05981310f, -0.00263588f, -0.04604010f, -0.14565636f, 
    0.10491168f, -0.02811096f, 0.06525418f, -0.01693769f, -0.01858303f, -0.04345197f, -0.17854092f, 0.09499276f, 
    -0.09753429f, 0.01780192f, 0.06540434f, -0.04595429f, -0.01567928f, -0.01065868f, -0.03339769f, 0.01219443f, 
    0.10283148f, 0.08446996f, 0.01312193f, 0.01256594f, 0.02867595f, 0.05656880f, -0.14977099f, 0.04042771f, 
    -0.00869173f, -0.10888881f, 0.11003001f, -0.07584300f, -0.42970872f, -0.24373932f, 0.01895944f, -0.11291517f, 
    -0.09625603f, -0.15058285f, -0.03810292f, -0.04137779f, -0.13228607f, 0.00062302f, -0.02486537f, -0.06897493f, 
    0.10122005f, -0.11820791f, 0.04514971f, 0.04786919f, 0.07178352f, 0.05639484f, 0.00850338f, 0.07792864f, 
    -0.04349297f, 0.08552154f, -0.01309138f, 0.08670671f, -0.23062921f, -0.18368709f, 0.00620278f, -0.11155299f, 
    -0.07739957f, -0.02194661f, 0.05522159f, 0.06305676f, 0.17019226f, 0.06527749f, -0.07758009f, 0.10521440f, 
    -0.03191302f, -0.24014744f, -0.13539559f, -0.04354122f, 0.04778808f, 0.02110347f, -0.01993351f, -0.12911722f, 
    -0.04810946f, -0.10580494f, 0.10292369f, -0.10531023f, 0.33154303f, 0.11873721f, -0.08459820f, -0.09521598f, 
    0.11562808f, 0.01348805f, 0.00647353f, 0.07298863f, 0.11792948f, 0.04842066f, -0.04428982f, 0.01070678f, 
    0.28854474f, -0.03196252f, -0.19818163f, 0.13034104f, 0.13631164f, -0.02209789f, 0.08830888f, 0.01527992f, 
    -0.04016928f, 0.02640344f, 0.00417687f, 0.15083738f, 0.18233657f, 0.14398302f, 0.07939711f, 0.20901330f, 
    0.10520207f, 0.08647328f, 0.10213208f, 0.05896043f, -0.10641041f, -0.00998855f, 0.10667752f, 0.23919648f, 
    -0.00314024f, -0.15686940f, 0.00065552f, 0.04801387f, -0.02446524f, -0.06662922f, -0.04470757f, -0.05905009f, 
    -0.04005890f, 0.01077648f, 0.09084812f, -0.01564300f, -0.26036051f, -0.35077691f, -0.13503821f, -0.04724833f, 
    -0.16560149f, 0.01094977f, 0.07781890f, 0.10285276f, -0.04418218f, 0.09603367f, 0.01283099f, -0.10540555f, 
    0.30832708f, 0.16286668f, -0.09076484f, 0.08089945f, 0.00222770f, 0.07101725f, 0.07619683f, -0.08726950f, 
    0.02457438f, 0.00488290f, -0.07468141f, -0.00904524f, -0.25059393f, -0.23324466f, 0.10698234f, -0.02904058f, 
    -0.02201128f, -0.04000660f, -0.07301922f, -0.01630448f, -0.09174039f, -0.00303304f, 0.05242503f, 0.15816946f, 
    -0.05866337f, 0.22403109f, -0.02688043f, -0.17075062f, 0.08629829f, -0.16559432f, 0.08064625f, -0.06740914f, 
    0.03194458f, 0.00517426f, -0.01027155f, -0.07190687f, -0.23477672f, -0.10149211f, -0.33908525f, 0.10897011f, 
    -0.00889685f, 0.00558747f, 0.04491620f, -0.08508065f, -0.11340110f, 0.02562508f, -0.07381440f, -0.04399379f, 
    0.22965613f, 0.12059156f, 0.20466979f, -0.01212049f, 0.07849829f, 0.04398145f, 0.09467418f, 0.15517737f, 
    -0.08300597f, 0.01202367f, 0.01019954f, 0.08686309f, 0.26387581f, -0.17712812f, -0.20791939f, -0.13442396f, 
    0.15368505f, 0.10741321f, 0.03906378f, -0.14410353f, 0.04440295f, -0.10185412f, -0.02708831f, 0.04707574f, 
    -0.03140847f, 0.15229779f, -0.01938633f, 0.00311309f, 0.04031053f, -0.00177696f, -0.12855858f, -0.04477547f, 
    -0.06054894f, 0.03243390f, -0.08935582f, -0.02255332f, 0.00600183f, -0.30710053f, -0.03362960f, 0.10711855f, 
    -0.09492430f, 0.05631458f, 0.04035411f, -0.09877823f, 0.08576035f, 0.07009703f, 0.02406347f, 0.01484853f, 
    0.19606729f, 0.21710740f, 0.12901738f, 0.02981800f, -0.02753255f, -0.19962478f, 0.05519007f, -0.04343082f, 
    -0.03059459f, 0.00508284f, 0.01607815f, -0.03012026f, 0.12378551f, -0.20478304f, -0.33992314f, 0.02662721f, 
    0.04838318f, 0.14500339f, 0.22003642f, 0.19929691f, -0.02451946f, 0.03059006f, -0.01130143f, 0.03151288f, 
    0.32732415f, 0.07135747f, -0.11523185f, -0.14696372f, -0.04361571f, 0.01335193f, 0.19392581f, -0.15132056f, 
    0.12403841f, 0.06771242f, 0.09566694f, 0.06339507f, 0.22101086f, -0.03133961f, 0.10917927f, 0.02101077f, 
    -0.03821073f, -0.11990492f, 0.02991051f, 0.11207066f, -0.03161808f, -0.02865851f, 0.02854631f, 0.11382081f, 
    -0.01464031f, 0.01024859f, -0.07534809f, -0.04153270f, 0.08366410f, 0.12462331f, -0.01393153f, -0.05081332f, 
    -0.03236938f, 0.10650692f, -0.04058916f, 0.11592432f, -0.25537568f, -0.58450836f, -0.51731920f, -0.13706295f, 
    0.01952872f, -0.09336449f, 0.03171612f, -0.13335784f, -0.08246065f, 0.04386073f, 0.05608665f, 0.01152242f, 
    0.43111110f, 0.21415739f, 0.04761992f, -0.00259941f, 0.22016147f, 0.15450625f, 0.18597832f, 0.05366106f, 
    0.14207588f, -0.07962552f, -0.08903965f, 0.01589477f, -0.01810913f, -0.50094920f, -0.39871234f, -0.16991954f, 
    -0.01159527f, 0.03225013f, -0.09682140f, -0.17753200f, -0.10872611f, -0.05093137f, 0.07861228f, -0.01176491f, 
    0.02596906f, -0.27662528f, 0.08795970f, -0.16738386f, 0.01916414f, -0.00058772f, -0.02120374f, -0.17683747f, 
    0.06583684f, -0.02346526f, -0.05802264f, 0.00711081f, -0.22294220f, 0.10640645f, -0.40544006f, -0.12226600f, 
    0.07288618f, 0.01288937f, 0.07220946f, -0.19235665f, -0.00148775f, -0.03095177f, -0.18739952f, -0.06208669f, 
    0.30190524f, 0.16302466f, 0.04260764f, 0.08211315f, 0.05776389f, 0.05783133f, 0.02758814f, 0.09184081f, 
    0.04988747f, -0.02661381f, -0.01266275f, 0.05291164f, 0.28307328f, 0.08992498f, 0.01417632f, 0.12488317f, 
    0.14522824f, 0.13470265f, 0.03606408f, 0.01256891f, -0.01362606f, -0.08744152f, -0.00175350f, 0.01037264f, 
    -0.25699136f, -0.20951232f, -0.38915783f, -0.01407440f, 0.11463530f, -0.17616752f, -0.02418069f, -0.04306496f, 
    -0.04469492f, -0.03591312f, -0.11498805f, 0.07681146f, 0.22491001f, -0.02404693f, 0.06018936f, 0.14151110f, 
    0.11028054f, -0.08263817f, 0.07916786f, 0.04968748f, 0.00717605f, -0.00746867f, 0.13077052f, -0.05238595f, 
    0.26208568f, 0.15235761f, -0.00231873f, 0.08096512f, 0.09671955f, 0.23251767f, 0.16310826f, -0.02268918f, 
    -0.03874697f, -0.02125119f, 0.09073338f, 0.07131032f, -0.03738522f, -0.13942492f, -0.00347381f, 0.07622086f, 
    -0.10516662f, 0.10367005f, 0.04614872f, 0.01187776f, -0.08249925f, 0.05599584f, 0.00843190f, -0.07045109f, 
    -0.10550772f, -0.30781251f, -0.22941391f, -0.08935349f, -0.01611725f, -0.01400920f, 0.06371889f, 0.01255668f, 
    -0.03644195f, 0.10215050f, 0.05976092f, 0.01061207f, 0.18463850f, -0.39896062f, 0.15350361f, -0.01453021f, 
    -0.04289969f, 0.04019635f, 0.03526165f, -0.07558136f, -0.12926307f, 0.08817405f, 0.16366072f, -0.02109199f, 
    -0.17425218f, -0.14024134f, 0.01256960f, -0.20226958f, -0.03550292f, -0.07041984f, 0.08507284f, -0.14971940f, 
    -0.01809420f, 0.06247255f, 0.06375012f, -0.06994490f, 0.28481087f, 0.27805036f, 0.23993276f, 0.12960725f, 
    -0.01061340f, -0.06641988f, 0.19705586f, 0.01340905f, -0.04712256f, -0.01764794f, -0.01239018f, -0.01770436f, 
    0.21881136f, 0.15941025f, 0.04374756f, 0.08305994f, 0.02355385f, 0.03472877f, -0.06098036f, -0.05949505f, 
    -0.05773043f, -0.03608920f, 0.08019127f, -0.05373129f, 0.06633316f, 0.02621149f, -0.07510704f, -0.22152521f, 
    0.04865986f, -0.04843616f, 0.06893098f, -0.00364618f, -0.04566260f, 0.22406626f, 0.08606888f, 0.03462935f, 
    0.27675140f, -0.32254928f, -0.36861065f, 0.01129278f, -0.04851682f, -0.02243128f, 0.12889929f, -0.13773881f, 
    -0.00421738f, 0.22796214f, -0.04841714f, 0.02798852f, -0.26392981f, -0.02454727f, 0.03541001f, -0.04237933f, 
    0.01242773f, -0.03167876f, -0.05283519f, -0.16225474f, -0.06559095f, -0.08172546f, 0.09251460f, 0.00752529f, 
    -0.01933368f, -0.13289975f, -0.16083430f, -0.02607552f, -0.00745754f, 0.05663851f, -0.00039394f, 0.07359452f, 
    0.04679615f, -0.07025959f, -0.00586635f, -0.00613709f, -0.10765879f, 0.03624426f, 0.33061171f, -0.19022809f, 
    -0.08691863f, 0.02361979f, 0.02340677f, -0.00256831f, -0.05818164f, -0.09595454f, -0.01433311f, -0.05096184f, 
    -0.04468893f, 0.02623946f, 0.02468762f, 0.02397746f, -0.02271149f, 0.02897425f, -0.00626819f, 0.03287693f, 
    -0.02658451f, -0.02145290f, -0.02393050f, -0.03399734f, 0.01377917f, -0.00754908f, 0.01968803f, -0.03246461f, 
    0.01271557f, -0.03913267f, 0.00823601f, -0.00464490f, -0.01840650f, 0.02245833f, -0.00543151f, -0.03023687f, 
    -0.01319176f, 0.01069851f, 0.02902008f, 0.00573740f, -0.03710237f, 0.01287683f, 0.02206364f, 0.00682375f, 
    0.02023759f, -0.03823592f, -0.03576563f, -0.03753910f, 0.00251350f, 0.02908341f, 0.00468825f, 0.01389281f, 
    0.01572496f, -0.00086929f, -0.03067740f, -0.02133442f, 0.02663695f, -0.03060681f, -0.00646023f, -0.01225652f, 
    0.01339700f, -0.02243087f, -0.00964807f, 0.00609331f, -0.02973157f, -0.02508805f, 0.02967601f, 0.00691471f, 
    0.02174020f, 0.03270229f, 0.01456223f, -0.02431217f, -0.03850169f, -0.00424717f, 0.00708173f, -0.03086516f, 
    0.00774167f, -0.00371787f, 0.00824309f, -0.03518181f, -0.04118442f, -0.00867700f, -0.00827104f, -0.03666856f, 
    0.02013493f, 0.00163025f, -0.00913829f, -0.01601821f, 0.00140919f, -0.00987576f, -0.01124224f, -0.03264773f, 
    -0.00660805f, 0.00402355f, 0.00617615f, -0.02216007f, -0.02020487f, -0.03091569f, -0.02023675f, -0.03008675f, 
    0.02136648f, 0.03578749f, 0.01486131f, 0.01225708f, -0.01873468f, -0.02791208f, 0.00702660f, -0.00507003f, 
    -0.00096839f, -0.00776073f, 0.01875852f, -0.00517404f, -0.00091659f, 0.01069733f, -0.00246251f, -0.02400491f, 
    0.01566249f, -0.03645229f, -0.02866319f, 0.02955861f, 0.03488088f, 0.01085106f, -0.03745867f, 0.01511875f, 
    -0.02637323f, 0.01375848f, 0.02386138f, -0.02326627f, 0.00686454f, 0.01367007f, -0.01914335f, 0.02796973f, 
    -0.00691569f, 0.02721355f, -0.02380827f, -0.03057974f, 0.02900173f, -0.02580618f, 0.00585150f, -0.00286539f, 
    -0.03068770f, -0.01631216f, -0.00732150f, -0.02845071f, -0.00451180f, -0.02369180f, -0.02355913f, -0.03206227f, 
    -0.03155766f, 0.00798779f, 0.00892514f, 0.02292869f, 0.01936964f, -0.04234635f, -0.01204400f, 0.00559217f, 
    0.00446566f, 0.00905074f, 0.01618165f, -0.00192901f, 0.01048483f, -0.02487757f, 0.00992597f, 0.00538708f, 
    0.01387108f, 0.01250772f, -0.01355969f, 0.01157214f, -0.03979773f, -0.03037469f, -0.01868908f, -0.01121383f, 
    -0.03498978f, 0.01398098f, -0.01185990f, -0.01879062f, -0.03254350f, -0.04736143f, -0.02419078f, 0.00547912f, 
    -0.03317156f, -0.03652293f, 0.00872379f, -0.02440204f, 0.00594096f, -0.03913449f, 0.00984167f, 0.01543780f, 
    0.02040912f, 0.01191775f, -0.02134176f, -0.04273520f, 0.02687234f, 0.02097880f, 0.00524392f, 0.02192373f, 
    -0.01095620f, -0.00657874f, 0.02503292f, -0.00271538f, -0.02101341f, -0.01730685f, -0.00490640f, 0.02898389f, 
    0.01850615f, 0.02000180f, 0.01201678f, -0.00492304f, 0.02022072f, -0.03692697f, -0.02727978f, 0.02694583f, 
    -0.03144522f, -0.03506332f, -0.00133370f, -0.00890453f, -0.01731853f, -0.01935111f, -0.01270524f, -0.02419450f, 
    0.01050442f, -0.00741525f, -0.01078796f, -0.00657606f, 0.00700817f, 0.00112979f, -0.02870877f, -0.03198068f, 
    -0.01532311f, -0.02134682f, -0.02548918f, -0.00613894f, -0.00143345f, -0.03443515f, -0.00080524f, 0.00305057f, 
    -0.01093453f, 0.01628208f, -0.00397698f, 0.01894262f, -0.02329298f, -0.00343994f, 0.01529376f, -0.02917034f, 
    0.01155832f, 0.01032559f, -0.02129449f, 0.02592634f, -0.01808893f, -0.04001101f, 0.03125010f, -0.00278169f, 
    -0.02696295f, 0.01977775f, -0.04387022f, 0.00372038f, 0.00509094f, -0.01356904f, 0.02882070f, 0.00391435f, 
    -0.03951477f, -0.02822655f, -0.01800716f, -0.01880459f, -0.01791457f, 0.03139110f, 0.03230601f, -0.02825582f, 
    -0.00832982f, 0.00912339f, -0.01349876f, -0.04368849f, -0.02887869f, 0.01268424f, 0.01757693f, 0.01894572f, 
    0.03065794f, -0.04043214f, -0.02978800f, 0.01840292f, 0.00972731f, -0.03203639f, -0.01565029f, 0.01139509f, 
    0.02905589f, 0.01420772f, -0.02340564f, 0.03121000f, -0.04412137f, -0.01684654f, -0.00411513f, 0.03007236f, 
    0.00632942f, 0.01293471f, -0.01877915f, -0.01760372f, 0.00196349f, -0.02001821f, 0.02143015f, -0.00183873f, 
    -0.00902694f, -0.00324314f, 0.02358740f, -0.01146355f, -0.02211232f, 0.02033731f, 0.00050750f, -0.02872548f, 
    -0.01033151f, 0.01959047f, -0.02667083f, -0.01133913f, -0.00244375f, -0.00375493f, -0.00675743f, -0.03791168f, 
    -0.01404463f, -0.03270736f, 0.01446285f, -0.00379776f, 0.00369921f, -0.00075051f, -0.02612333f, -0.03129504f, 
    -0.00264548f, -0.01736437f, 0.01740016f, -0.02233753f, -0.01237087f, -0.03675140f, 0.02213912f, -0.02418255f, 
    -0.00334617f, -0.04303289f, 0.00882794f, -0.01678123f, -0.00788578f, -0.02763667f, -0.02415903f, 0.01739148f, 
    -0.01957626f, 0.03493892f, 0.01045743f, 0.02588386f, -0.03856967f, 0.02019734f, -0.01121452f, -0.02119116f, 
    0.00142108f, 0.00546959f, 0.00408358f, 0.00009426f, -0.02386920f, -0.00653432f, -0.02102821f, -0.00488132f, 
    -0.02536603f, -0.01035089f, -0.02028435f, 0.03350332f, -0.00871983f, 0.01003659f, -0.02679423f, -0.03699008f, 
    0.01184568f, 0.01870424f, -0.01100147f, 0.02086765f, 0.00752554f, 0.01074002f, -0.02274234f, 0.00933725f, 
    0.00536343f, -0.03035353f, -0.03245398f, -0.02992789f, 0.02737876f, 0.00354617f, 0.01182102f, 0.00915777f, 
    0.02743628f, 0.02519204f, 0.01801488f, -0.03502130f, -0.00214042f, -0.02295943f, 0.00969537f, -0.02600313f, 
    0.00615821f, -0.03439677f, -0.02413485f, 0.00753214f, 0.02906415f, 0.01517740f, 0.02357537f, -0.00153483f, 
    0.02987565f, 0.01038918f, 0.00230657f, 0.00434107f, 0.00850997f, -0.02633831f, -0.02010021f, 0.01290780f, 
    -0.03620645f, -0.02604847f, -0.01123060f, -0.02425130f, -0.04542737f, -0.03849943f, -0.00680612f, -0.00120839f, 
    -0.03440434f, 0.00625518f, 0.03224064f, -0.00307814f, -0.00765963f, 0.01183335f, 0.02030720f, 0.02030185f, 
    -0.03012464f, 0.01847016f, -0.02337556f, -0.02243717f, 0.02957621f, 0.01013891f, 0.01365762f, -0.00602963f, 
    0.02298144f, 0.02829910f, -0.01985429f, -0.03510476f, -0.02165917f, -0.02326996f, 0.02730713f, 0.02269723f, 
    -0.02808193f, -0.00806388f, 0.01973046f, -0.00805150f, -0.03675549f, 0.03332246f, -0.02452120f, 0.01656117f, 
    -0.01956618f, -0.01366501f, -0.01263047f, -0.02382496f, -0.02059046f, 0.01738662f, 0.03261163f, -0.03802859f, 
    0.02089832f, -0.03057207f, -0.00827414f, -0.01159655f, -0.02018648f, -0.01829006f, 0.02004346f, -0.00879138f, 
    -0.03726092f, -0.02469002f, 0.02073549f, -0.00370451f, 0.03627361f, -0.01518496f, -0.02520719f, -0.01502527f, 
    -0.02980653f, 0.00724177f, -0.02051966f, 0.00026803f, 0.02178517f, -0.01681591f, -0.03527276f, -0.01440643f, 
    -0.01142064f, 0.01406665f, 0.00007174f, 0.02968639f, 0.01011928f, -0.00922969f, -0.02458484f, -0.00394735f, 
    -0.03206870f, -0.02913196f, 0.03760932f, -0.01360026f, -0.02575359f, 0.01325766f, -0.03754945f, -0.01923307f, 
    -0.02757830f, -0.01131596f, 0.01054288f, -0.02721668f, 0.02706910f, 0.01741790f, 0.01812372f, -0.00659547f, 
    0.00256053f, -0.02581665f, -0.01084486f, 0.02225768f, 0.01863306f, 0.00095240f, -0.03944413f, 0.02195781f, 
    -0.00451624f, -0.03436843f, 0.01916432f, -0.01802023f, -0.03125293f, -0.01786611f, -0.00265726f, -0.03695452f, 
    -0.03800586f, -0.01434793f, -0.03132579f, 0.03583903f, 0.01498987f, -0.02815698f, -0.00424925f, 0.00247391f, 
    0.02564010f, -0.02793286f, -0.00077617f, 0.00793085f, 0.01517976f, 0.01801812f, -0.01292332f, 0.01756317f, 
    -0.01111907f, 0.02643966f, 0.02122380f, -0.01835296f, 0.00851575f, -0.02084554f, -0.02420316f, -0.03440316f, 
    0.02914629f, -0.02682702f, 0.02884680f, -0.04043709f, 0.01019573f, 0.00191893f, 0.02343166f, -0.02575484f, 
    -0.04095851f, -0.03047168f, -0.00436285f, -0.00310035f, -0.01694745f, 0.00372172f, -0.02253687f, -0.02460652f, 
    -0.02208052f, -0.01847058f, -0.01862095f, 0.01269243f, -0.03804764f, -0.00390419f, -0.01754503f, -0.02121131f, 
    0.00899703f, 0.00182931f, 0.00941829f, 0.02086630f, 0.02997548f, 0.02207861f, 0.02854149f, 0.02274641f, 
    -0.01412463f, 0.00916247f, -0.04385464f, -0.03214966f, -0.03432005f, -0.04018584f, -0.02973056f, -0.01280003f, 
    -0.00416268f, 0.00179237f, 0.02203763f, -0.00159198f, -0.00232628f, 0.01330822f, -0.00511362f, 0.00122773f, 
    -0.00902881f, 0.00380389f, 0.01317630f, 0.02592387f, -0.00221870f, 0.02434026f, 0.02496248f, 0.00518289f, 
    0.00462602f, 0.03162886f, -0.01218188f, 0.00460468f, -0.03386718f, -0.03733347f, -0.00137924f, 0.02852350f, 
    0.01321505f, -0.02474840f, -0.01030648f, -0.02221115f, -0.02238490f, -0.01001453f, -0.00914022f, 0.01530985f, 
    0.02758829f, -0.02824293f, 0.02585935f, 0.02541259f, 0.02752165f, -0.00319039f, -0.02835821f, 0.02683683f, 
    -0.00953477f, -0.03610593f, 0.01634232f, -0.00440330f, 0.01832206f, -0.00857082f, 0.01033073f, 0.01898381f, 
    0.00915068f, -0.00507416f, -0.03312011f, -0.02770861f, 0.02570995f, -0.01818494f, -0.02252960f, -0.01038923f, 
    -0.02983463f, 0.00784586f, 0.00405822f, 0.03369562f, 0.01326122f, -0.00764534f, -0.03206255f, -0.00391987f, 
    -0.03059839f, 0.00765383f, 0.01809926f, -0.03222137f, 0.01722012f, 0.02473292f, -0.00130289f, 0.00591762f, 
    -0.03691081f, 0.01626306f, 0.03090644f, -0.00193743f, 0.02899617f, -0.02884337f, 0.00554393f, -0.01407320f, 
    -0.02682251f, -0.00315063f, 0.01932111f, 0.00377534f, -0.02344087f, 0.00399868f, -0.01469534f, -0.04355023f, 
    0.02758848f, 0.00756320f, 0.02186594f, -0.02497451f, -0.03066884f, -0.00771541f, 0.02393427f, 0.02684035f, 
    -0.01037972f, -0.02802041f, 0.01448601f, 0.02620157f, 0.02765797f, -0.03958306f, 0.00346716f, 0.01999034f, 
    0.03188050f, 0.00460180f, -0.01314159f, -0.03491012f, -0.01780448f, 0.01179022f, -0.04094247f, -0.02450919f, 
    -0.03237245f, -0.00248457f, -0.01231758f, -0.03793740f, 0.03684408f, 0.02412868f, 0.00312630f, -0.03463998f, 
    0.01441934f, -0.02561465f, 0.03136918f, -0.02294463f, -0.00708498f, -0.00559579f, -0.02001740f, -0.01786264f, 
    -0.02369065f, -0.00568403f, 0.00563969f, -0.01809689f, 0.02642085f, -0.02070082f, 0.00406536f, 0.02564238f, 
    0.02873987f, -0.01056646f, -0.03703551f, -0.00105424f, 0.00128108f, -0.01076571f, -0.03688674f, -0.01474416f, 
    0.02264464f, -0.00119639f, 0.00669231f, -0.02401654f, -0.00813782f, -0.00580883f, -0.02086273f, -0.01664876f, 
    0.02747373f, -0.02980725f, 0.01145447f, 0.00162404f, -0.03239526f, -0.02916619f, -0.03004624f, 0.01190563f, 
    0.02171489f, 0.00119162f, -0.03079375f, 0.00101318f, -0.02544226f, -0.00587628f, 0.01125662f, -0.02612873f, 
    -0.02376444f, 0.02523369f, 0.01301166f, -0.03049721f, 0.00875376f, -0.01391593f, -0.02700086f, 0.00147829f, 
    0.02758149f, -0.01882491f, -0.01276846f, -0.01425643f, -0.04341872f, 0.03355674f, 0.01845901f, 0.03155791f, 
    -0.03596783f, 0.02086379f, 0.01674378f, 0.03200100f, -0.03177977f, -0.01246816f, 0.02674328f, -0.00334455f, 
    0.02558946f, -0.02804287f, -0.04245198f, -0.03983657f, -0.02618823f, -0.01335756f, 0.01642988f, 0.03069927f, 
    -0.14518163f, -0.07135700f, -0.20873231f, 0.02734085f, -0.10039736f, 0.03185444f, -0.05175307f, -0.01226769f, 
    0.06574804f, 0.04465679f, 0.07653425f, 0.04136501f, -0.21383019f, -0.02554613f, 0.07393090f, -0.03691829f, 
    -0.00125437f, 0.10170390f, -0.05458345f, 0.04289731f, 0.07126148f, -0.03405478f, 0.15082501f, 0.00222259f, 
    -0.23656121f, -0.55310261f, -0.23963208f, 0.20495245f, -0.06534944f, 0.08112311f, 0.11517952f, -0.04125567f, 
    0.03979293f, -0.00220108f, 0.05359411f, 0.01281685f, -0.05825394f, 0.02091025f, 0.14176142f, 0.06792911f, 
    -0.01311065f, 0.02534174f, 0.00920037f, -0.07567863f, 0.07293426f, 0.23383953f, -0.01491209f, -0.15698102f, 
    -0.21383220f, 0.01612843f, 0.34875774f, 0.00927943f, -0.12850319f, -0.15546310f, 0.12196950f, 0.01687115f, 
    0.09072620f, 0.01656073f, 0.02013087f, -0.14477549f, -0.00184508f, -0.06153155f, -0.05468008f, -0.10956180f, 
    -0.09084059f, 0.00681258f, 0.22236067f, 0.05552510f, -0.03358492f, -0.01028422f, 0.01843300f, 0.01790984f, 
    -0.06577834f, 0.15074246f, -0.32696456f, -0.09553080f, -0.08298932f, 0.09519455f, 0.12324137f, -0.03568037f, 
    0.01861102f, 0.01482892f, -0.04525968f, -0.09616811f, -0.44302464f, -0.46035898f, -0.12307188f, 0.15019327f, 
    0.03747711f, 0.08829068f, -0.11151846f, -0.09108531f, 0.01541337f, -0.03767021f, 0.01825606f, -0.00053609f, 
    0.37584245f, 0.35253927f, 0.23125367f, -0.21645534f, -0.00365604f, -0.07747691f, 0.08268656f, 0.18346070f, 
    -0.04215831f, -0.04783847f, -0.02400040f, -0.12061593f, -0.01965108f, -0.26666775f, -0.01404019f, 0.00970100f, 
    -0.12336540f, -0.08928254f, -0.01065588f, 0.08680294f, 0.03253811f, 0.00857694f, -0.07856002f, -0.04913851f, 
    0.11880132f, 0.06127700f, 0.08735669f, 0.02950683f, 0.09772208f, -0.01397135f, 0.01122888f, 0.00744594f, 
    0.01436791f, 0.02073173f, -0.03480717f, 0.03692104f, 0.33659697f, -0.11649530f, 0.25138885f, 0.29661071f, 
    0.02295250f, 0.00437088f, -0.14555115f, -0.13995080f, -0.02167621f, -0.01661366f, -0.00868022f, -0.00903185f, 
    -0.01045529f, 0.07396637f, -0.13093537f, 0.05756147f, 0.07354401f, 0.07236349f, 0.12830165f, 0.20653768f, 
    0.21366355f, -0.01006091f, -0.04519526f, 0.09977435f, -0.01724244f, -0.16096002f, 0.07989901f, -0.02208188f, 
    -0.11647878f, 0.05796601f, -0.00257429f, 0.06356075f, 0.02226012f, 0.06063788f, -0.01283561f, -0.00787681f, 
    0.16414490f, 0.06326856f, 0.05577749f, -0.10512646f, 0.08690068f, -0.04334186f, 0.26821256f, -0.00120681f, 
    -0.09143986f, 0.07378151f, -0.00325334f, -0.00738956f, 0.09764943f, 0.38064602f, -0.00979399f, 0.10891731f, 
    -0.10084963f, 0.15511626f, -0.07006971f, 0.00493994f, -0.07422016f, -0.06495021f, 0.31356952f, 0.01757053f, 
    0.25558108f, 0.19166997f, -0.04074502f, 0.05737895f, 0.09182965f, 0.04564677f, -0.01380349f, 0.02562367f, 
    -0.17856020f, 0.08361223f, 0.10046478f, -0.09457310f, -0.17386216f, -0.13516210f, 0.09716644f, 0.07532915f, 
    -0.09901048f, 0.01900468f, -0.09660649f, 0.10608274f, 0.11161052f, 0.00292176f, -0.07315108f, -0.04326881f, 
    -0.10976747f, -0.10592170f, 0.07511543f, 0.20015265f, -0.02215065f, 0.08121513f, -0.10031907f, -0.02258124f, 
    -0.05608341f, 0.16017100f, 0.17516990f, 0.05961451f, 0.03816590f, -0.13171402f, 0.14945069f, 0.18413141f, 
    -0.01180560f, 0.12861018f, 0.01877361f, -0.00296236f, 0.12463637f, 0.03966627f, 0.07032651f, -0.07867625f, 
    0.34638295f, -0.21673052f, -0.34508559f, -0.05146718f, -0.05426187f, 0.06401173f, -0.01821421f, -0.01967210f, 
    0.01222063f, 0.05115322f, -0.04647455f, 0.11608263f, -0.00793565f, 0.10383529f, 0.13107917f, 0.02509446f, 
    -0.02059418f, 0.05614357f, -0.01397437f, -0.00968600f, 0.07803757f, -0.05478393f, 0.04654258f, 0.01610802f, 
    -0.15501469f, 0.15530972f, 0.06517700f, 0.08641826f, -0.07362787f, -0.14761905f, 0.01214335f, -0.06324009f, 
    0.05770892f, -0.01645163f, 0.00918122f, 0.05598126f, 0.01038437f, 0.30624545f, -0.12051200f, -0.26512191f, 
    0.07050239f, -0.05538265f, 0.11980367f, 0.03768037f, 0.00637559f, -0.11893323f, 0.01259574f, 0.05623152f, 
    0.38514534f, 0.30521920f, -0.03266070f, 0.06273719f, -0.01145702f, 0.02596858f, -0.07049789f, 0.02133477f, 
    -0.00610771f, 0.00076624f, 0.01635910f, 0.13785610f, -0.15652905f, -0.26597285f, 0.16883168f, 0.07981128f, 
    -0.08882879f, 0.03706499f, -0.12411842f, 0.05791499f, 0.01096801f, -0.12515375f, 0.01282199f, -0.01089441f, 
    0.09487434f, 0.22800106f, 0.26685625f, -0.06517975f, -0.08142811f, -0.19429936f, 0.03805383f, 0.31287196f, 
    -0.11482436f, 0.07650098f, -0.06143589f, 0.12909570f, -0.08742929f, -0.08539306f, -0.10016926f, 0.02834506f, 
    0.13270812f, 0.12935455f, -0.05330283f, 0.00731930f, 0.16986491f, 0.11018177f, 0.11696088f, 0.23076113f, 
    0.31584045f, -0.01599106f, 0.45400724f, -0.00722390f, -0.05165324f, -0.03313203f, 0.09397961f, 0.02673731f, 
    -0.07439233f, 0.18393900f, 0.05618369f, -0.02397124f, 0.27560306f, -0.08470080f, -0.11972074f, 0.15053959f, 
    -0.02262649f, 0.04487576f, 0.10932196f, 0.06115050f, -0.06950849f, -0.04980869f, -0.06349818f, 0.03078999f, 
    -0.02339482f, 0.14868538f, 0.11758165f, 0.20624906f, -0.08360732f, 0.08849841f, 0.18246962f, -0.04080962f, 
    0.10994565f, 0.12449318f, 0.02798742f, 0.03199147f, 0.21240890f, 0.08274999f, -0.10604046f, -0.02276141f, 
    -0.03548685f, 0.00253212f, 0.02868848f, 0.02655398f, 0.07124937f, 0.19346398f, -0.12364858f, 0.14261530f, 
    -0.08354907f, -0.38720158f, -0.24494675f, 0.20114809f, -0.03036229f, 0.36715189f, 0.13093932f, -0.03323223f, 
    0.11421859f, 0.05046012f, -0.09389500f, 0.04276540f, 0.34914309f, -0.12567107f, 0.27410036f, -0.43425590f, 
    0.06485794f, -0.03939104f, 0.22175805f, 0.07420106f, 0.00717499f, 0.01388760f, -0.07566373f, -0.04457426f, 
    -0.27849406f, -0.14721200f, -0.03231037f, 0.00887767f, 0.00400838f, -0.13023573f, -0.12104411f, 0.05833840f, 
    0.07189807f, 0.08082186f, -0.04206042f, -0.11815836f, 0.18864194f, 0.28119177f, 0.22855665f, 0.09897807f, 
    -0.12651043f, -0.10921063f, -0.12638880f, -0.13892779f, -0.09109775f, 0.21233189f, 0.10061646f, 0.09275475f, 
    0.12491131f, 0.09662944f, 0.06581239f, -0.05150729f, -0.03775603f, -0.06592848f, 0.06141060f, -0.05548597f, 
    -0.11021656f, 0.04479597f, 0.02330204f, 0.13531032f, 0.21741870f, 0.33425683f, 0.09004391f, -0.07085595f, 
    -0.07703027f, -0.09470883f, -0.03861323f, -0.02370636f, -0.00456103f, 0.27350464f, 0.13473657f, 0.25426206f, 
    -0.36542290f, -0.24404208f, -0.02058241f, 0.10790627f, -0.09532440f, -0.04468463f, -0.08145580f, -0.06669936f, 
    0.03817281f, 0.01051265f, -0.00258963f, 0.02815405f, 0.16872479f, -0.00923154f, -0.09011720f, -0.32027364f, 
    -0.06583990f, 0.09223405f, 0.30905649f, 0.01559401f, -0.03816653f, -0.08020724f, -0.04273008f, 0.01889618f, 
    -0.01161944f, 0.04167217f, -0.11002825f, -0.09609148f, 0.00523991f, 0.04447801f, 0.04692072f, -0.00898096f, 
    0.02550490f, -0.12301266f, 0.04391406f, 0.04041894f, -0.00917688f, -0.07094954f, -0.01289187f, -0.08560596f, 
    -0.16081966f, 0.01041165f, 0.03056366f, -0.02759463f, -0.16369410f, 0.05075125f, 0.06724863f, 0.07184268f, 
    0.19560711f, 0.29027453f, 0.19153738f, 0.19036917f, -0.09090524f, -0.04199496f, -0.08298448f, -0.09217409f, 
    -0.10376752f, 0.02436228f, 0.16479364f, 0.08124958f, 0.15491372f, 0.01583567f, 0.09381118f, -0.05698762f, 
    -0.02890105f, -0.00806195f, 0.06517509f, 0.00373548f, 0.01439438f, 0.04210135f, -0.11488073f, -0.06816241f, 
    -0.32533631f, -0.11078620f, 0.17717925f, 0.15426660f, 0.06198427f, -0.02118641f, -0.10473517f, 0.05219006f, 
    0.07303700f, -0.01645362f, -0.00679053f, -0.11595492f, 0.04443398f, -0.08218057f, 0.03034951f, -0.12979522f, 
    -0.06334829f, 0.07903420f, 0.04719858f, 0.06498504f, -0.09023235f, -0.06611301f, -0.06004021f, -0.13549720f, 
    0.14980282f, -0.00300721f, -0.01364167f, 0.06392790f, -0.02367165f, -0.00002795f, 0.01259146f, -0.01944122f, 
    -0.04423938f, -0.00897831f, -0.01490016f, -0.05575355f, 0.01032261f, -0.02919248f, 0.02719106f, 0.06047506f, 
    -0.06773673f, 0.03100793f, 0.14269035f, 0.05552943f, 0.00852685f, -0.04610813f, -0.01513668f, -0.03019298f, 
    -0.24151944f, -0.20270680f, -0.07792412f, 0.12396452f, 0.11289953f, 0.10804052f, 0.03036177f, 0.01928885f, 
    0.03302817f, 0.07268877f, 0.12176445f, 0.13931842f, -0.24785829f, -0.23635678f, 0.06668483f, 0.08679987f, 
    -0.10594538f, 0.04918379f, 0.01033483f, 0.04185066f, -0.00408642f, 0.11778588f, 0.07743005f, 0.11833146f, 
    -0.12024576f, -0.05212945f, -0.06838789f, -0.15457673f, -0.09022136f, 0.00915553f, 0.09007558f, -0.07728475f, 
    -0.00173462f, 0.01432016f, -0.01758272f, -0.06174552f, -0.11973014f, 0.16155709f, 0.04507292f, 0.19099425f, 
    -0.07026984f, 0.22314410f, -0.02882511f, 0.07793534f, -0.18050559f, -0.08860074f, 0.22973005f, -0.03100255f, 
    -0.12637116f, -0.41285369f, 0.02373295f, 0.24340478f, -0.11314827f, -0.05227435f, -0.11211997f, 0.02101172f, 
    0.02728478f, 0.12821153f, -0.12245285f, -0.06832184f, 0.38819951f, 0.20558159f, -0.04935956f, -0.59230351f, 
    -0.07591490f, 0.07712425f, 0.17674953f, 0.15179001f, 0.04189002f, -0.02493999f, -0.03934379f, -0.07004187f, 
    -0.00200138f, 0.03059306f, 0.04514408f, 0.03719784f, -0.00627590f, 0.01029857f, 0.07884323f, -0.03521142f, 
    -0.04741691f, 0.10693315f, 0.05939250f, -0.03487537f, 0.06369755f, -0.26970086f, 0.16407955f, 0.09240214f, 
    0.26117453f, 0.06704591f, -0.12313890f, 0.05655164f, -0.02219347f, -0.00731974f, 0.06204888f, 0.19145304f, 
    0.14645542f, -0.18235362f, -0.04477268f, 0.48493174f, 0.10251566f, 0.12827300f, -0.01987193f, -0.05908294f, 
    -0.07032762f, 0.07853368f, -0.05421096f, -0.17603514f, -0.22836319f, -0.20034006f, -0.26687765f, 0.18368712f, 
    -0.08527279f, -0.16752487f, -0.17252880f, 0.16137575f, -0.11820764f, -0.04583846f, -0.04756629f, -0.02737101f, 
    -0.03775692f, -0.16898534f, 0.12627377f, -0.00024896f, -0.00637601f, -0.14305474f, 0.13542005f, 0.01289758f, 
    0.01006219f, 0.04052861f, -0.02081163f, -0.15935050f, 0.09749613f, 0.21292432f, -0.08798596f, -0.00909164f, 
    0.12947774f, -0.01417738f, 0.03259262f, 0.06072242f, -0.15298727f, 0.01471972f, 0.06141094f, -0.00036385f, 
    0.21550491f, 0.16872358f, 0.26825324f, -0.11138801f, 0.02195151f, -0.13052812f, 0.01061029f, 0.00786828f, 
    -0.08600713f, 0.02726194f, -0.02710087f, 0.19072150f, 0.05344357f, 0.05901322f, -0.04162218f, -0.00010812f, 
    0.02262074f, 0.03723209f, 0.02504732f, -0.08057819f, 0.07853403f, -0.00190542f, 0.06897418f, -0.06066716f, 
    0.14828315f, -0.14408487f, 0.44552228f, -0.10087113f, -0.01389067f, 0.02960889f, 0.19799419f, 0.12371235f, 
    -0.00704166f, 0.21421559f, -0.00808103f, 0.16215999f, -0.09224916f, 0.01938460f, -0.26582745f, 0.18489686f, 
    0.04953279f, 0.02616870f, 0.09900618f, 0.04637193f, -0.09646257f, 0.04251127f, 0.10438579f, 0.00959577f, 
    0.29238915f, -0.09668996f, -0.09524911f, 0.03808032f, 0.08506083f, -0.15827931f, 0.09396440f, 0.03509946f, 
    0.12195155f, -0.09088961f, 0.06823792f, 0.04531172f, -0.14334276f, 0.02792630f, -0.02473055f, -0.04307687f, 
    0.07556705f, 0.17499678f, -0.06278252f, -0.05512798f, -0.03892931f, 0.13018987f, -0.10670845f, 0.00514248f, 
    -0.08108324f, -0.10975928f, 0.18548024f, 0.00744090f, -0.15819687f, 0.14552306f, 0.05706685f, -0.01166179f, 
    0.07112531f, 0.01604258f, 0.03117798f, 0.02771732f, -0.21516919f, -0.09258005f, -0.06291814f, 0.08072587f, 
    0.02881381f, 0.02653343f, -0.06885081f, -0.00697136f, 0.17792514f, 0.07302734f, 0.08969580f, 0.00356968f, 
    0.02156768f, 0.04011682f, -0.07499976f, -0.11053634f, 0.09782675f, -0.02557752f, -0.11089128f, 0.03830199f, 
    -0.16331038f, -0.02403093f, -0.04822969f, 0.15157385f, 0.02468694f, -0.06584065f, -0.14265922f, 0.07800591f, 
    0.17003411f, 0.10909984f, 0.21412241f, 0.08817690f, 0.06891476f, 0.05366974f, -0.09171768f, -0.11553857f, 
    -0.16699179f, -0.38831294f, -0.07108989f, 0.15880354f, 0.10439928f, -0.05463898f, 0.18713221f, -0.09260207f, 
    -0.08304489f, -0.00423902f, -0.05603765f, 0.02636581f, -0.07752478f, 0.03904972f, 0.01766008f, 0.29423600f, 
    -0.13524745f, -0.05231730f, 0.00821465f, 0.07088330f, 0.04364302f, 0.02927183f, -0.01414760f, -0.02004341f, 
    -0.20481397f, 0.18282185f, 0.20020817f, -0.21739346f, 0.06843796f, -0.04379469f, -0.04136969f, 0.00587001f, 
    0.13816027f, 0.08186673f, 0.00509008f, 0.08475223f, 0.02829914f, -0.10415182f, 0.16001137f, -0.11391059f, 
    -0.05970463f, 0.02213627f, 0.03972442f, 0.05232065f, 0.11025725f, 0.00921932f, 0.08936797f, -0.00386835f, 
    -0.07358100f, 0.08825400f, -0.01732595f, -0.09802753f, 0.02991397f, 0.08336466f, -0.08328296f, -0.08179276f, 
    0.06766772f, 0.06322594f, 0.12948970f, 0.06653196f, -0.44950306f, 0.00127579f, 0.03188470f, 0.16177350f, 
    0.03712765f, 0.02406209f, -0.16880529f, -0.03665541f, 0.00187465f, 0.02742358f, 0.11463545f, -0.04322935f, 
    -0.07077423f, -0.14372650f, -0.08870116f, -0.12523323f, -0.16186871f, 0.10929935f, 0.03746819f, -0.01819295f, 
    0.08145656f, 0.12699920f, 0.02228675f, -0.09893481f, -0.04106249f, 0.23152092f, -0.03485946f, -0.07911216f, 
    0.10468145f, 0.10640559f, 0.12787986f, 0.05441585f, -0.02195541f, -0.05870316f, -0.04097294f, 0.00060878f, 
    -0.01134592f, -0.02513161f, -0.01871563f, -0.10204110f, 0.09151357f, 0.14846529f, -0.08231076f, 0.01449427f, 
    0.20083372f, 0.01263661f, -0.04037565f, 0.14351407f, -0.05033078f, 0.38462704f, -0.20755623f, 0.32741621f, 
    0.07171063f, -0.02967619f, -0.10078023f, -0.03966691f, 0.13968536f, 0.00204686f, 0.08075929f, -0.07372110f, 
    -0.12367921f, 0.06548308f, 0.22840065f, 0.08231919f, 0.06757102f, -0.10741422f, -0.14179926f, -0.12076781f, 
    0.07656907f, 0.00314174f, 0.05862457f, 0.05222474f, -0.06555688f, 0.01156878f, -0.01603296f, 0.10270069f, 
    0.07668862f, 0.10254633f, 0.04301871f, -0.05876315f, 0.05049678f, 0.10698061f, 0.14438024f, -0.01173589f, 
    -0.11415588f, -0.06589334f, 0.11870243f, 0.16070762f, 0.07079624f, -0.10383051f, -0.12644586f, 0.10084705f, 
    0.07630758f, -0.09664105f, 0.07862902f, -0.09302016f, -0.29430884f, 0.38665777f, 0.05672966f, -0.06933911f, 
    0.22952759f, -0.03253997f, -0.18787338f, 0.06052526f, -0.01099029f, 0.03694915f, 0.07945219f, 0.02429977f, 
    0.16196373f, -0.02711634f, -0.00741263f, 0.07688504f, 0.06376939f, -0.02046517f, 0.09768164f, 0.09226330f, 
    0.00744530f, 0.05022457f, -0.04393085f, 0.00884285f, 0.21594723f, -0.07409669f, -0.25513068f, 0.07149433f, 
    -0.01023928f, 0.11574285f, -0.08628611f, 0.00379330f, 0.25156036f, 0.12672383f, 0.10576048f, 0.06044375f, 
    -0.03058986f, -0.02597692f, 0.03863009f, -0.11217881f, -0.08111273f, -0.13518868f, 0.01496762f, 0.01414124f, 
    -0.07747816f, 0.03884988f, -0.02440477f, 0.08231628f, 0.17823295f, 0.22579719f, -0.30033728f, 0.23563308f, 
    0.08166839f, 0.05624870f, -0.02958413f, -0.04765279f, -0.07011242f, 0.00879919f, -0.05141876f, -0.10040208f, 
    0.02652761f, -0.01064750f, 0.02597831f, -0.15748309f, 0.01982161f, 0.01055171f, -0.05025867f, 0.01178817f, 
    0.23226862f, 0.14843507f, 0.05448496f, 0.13999481f, -0.18125571f, 0.23082842f, 0.03107899f, -0.10712489f, 
    -0.01058124f, 0.05689351f, -0.03965754f, 0.10526425f, -0.06087002f, 0.01557711f, 0.02541065f, 0.10060417f, 
    -0.00608576f, 0.21345107f, 0.31868443f, -0.02049859f, -0.03479193f, -0.04803935f, -0.07601938f, 0.05395053f, 
    -0.05579341f, 0.06176535f, 0.09065977f, -0.05089664f, -0.08386681f, 0.03873324f, 0.02231359f, -0.14932445f, 
    -0.09263827f, -0.10318837f, -0.01038329f, 0.15479964f, 0.09794489f, 0.09803183f, 0.07005536f, -0.13458045f, 
    0.00592658f, 0.03243477f, -0.11842709f, -0.07090089f, 0.08683906f, 0.07392613f, 0.03738875f, 0.10319076f, 
    0.05875551f, 0.03670290f, 0.10697029f, 0.09028722f, 0.09197869f, -0.02035030f, -0.15943491f, -0.05733251f, 
    -0.11132413f, 0.09845114f, 0.15845746f, -0.11211348f, 0.06594658f, -0.01024593f, 0.06905925f, -0.05357834f, 
    -0.19894356f, -0.02356948f, -0.02729450f, -0.05630568f, 0.16965267f, -0.02018091f, -0.00140090f, 0.37528026f, 
    -0.03448017f, 0.00893211f, 0.07020529f, 0.02784774f, 0.17283493f, -0.13464546f, -0.22371618f, -0.06555904f, 
    -0.06820111f, -0.00135879f, 0.04154854f, 0.00847306f, 0.11772306f, 0.13947591f, 0.10952885f, -0.20005836f, 
    -0.16638495f, -0.17363152f, 0.09997134f, 0.17305918f, 0.04134876f, 0.07886398f, -0.03278267f, 0.09937836f, 
    -0.06736350f, -0.09234596f, 0.01254481f, -0.07673571f, -0.03248608f, 0.01435025f, 0.11390283f, -0.04235661f, 
    -0.00177269f, 0.09795512f, -0.06638071f, 0.08594554f, 0.05716381f, 0.02011420f, 0.04445056f, -0.05476695f, 
    -0.07724269f, 0.02200305f, 0.02819533f, 0.22874333f, -0.01049997f, 0.08492174f, 0.16265786f, 0.01213097f, 
    0.09669356f, 0.04717083f, 0.03649550f, -0.07434782f, -0.20597872f, -0.06484304f, 0.13409373f, 0.09741012f, 
    0.07464434f, -0.09843438f, -0.08694492f, 0.03546643f, -0.00959683f, 0.01747443f, 0.06710143f, 0.02005843f, 
    0.01664667f, 0.08280008f, 0.22776049f, 0.23538692f, -0.00041820f, -0.06628430f, 0.09654915f, 0.03910260f, 
    0.07361612f, -0.04050417f, 0.07622760f, -0.06948765f, -0.23895761f, -0.00357947f, -0.09591747f, -0.15304750f, 
    0.05068699f, 0.01094007f, 0.06558025f, 0.03183035f, 0.03815197f, -0.09969662f, -0.01486094f, -0.09684333f, 
    0.04076780f, 0.05953996f, 0.20743147f, 0.02481584f, -0.02027302f, 0.06073600f, -0.04657742f, 0.04945092f, 
    -0.04020952f, 0.04000395f, -0.03554523f, -0.00988538f, -0.05117007f, -0.20145068f, 0.06048813f, 0.18312944f, 
    0.11946195f, 0.30261391f, 0.08153830f, 0.08068132f, 0.05677386f, -0.12298698f, -0.05061999f, -0.06994933f, 
    -0.23660903f, -0.05854004f, 0.04423616f, 0.07026970f, 0.22690895f, 0.23405220f, 0.15201780f, 0.08833463f, 
    -0.03862184f, -0.04338125f, -0.03838803f, -0.06353316f, 0.04940233f, -0.06490368f, -0.17462865f, 0.43153867f, 
    0.13104020f, 0.13190821f, -0.03476235f, 0.11036593f, 0.03164944f, 0.03847145f, -0.01851521f, 0.04223667f, 
    -0.05646202f, 0.12878077f, 0.17535242f, 0.17682561f, 0.05896467f, -0.14505999f, -0.11513712f, -0.03718140f, 
    0.02410690f, 0.04323296f, 0.00738275f, -0.04359093f, -0.07691784f, -0.11898163f, -0.10238813f, -0.05973649f, 
    0.02441231f, 0.10544638f, -0.11172805f, 0.04447636f, 0.04910370f, -0.01211843f, 0.09260763f, 0.03599203f, 
    -0.15051563f, 0.14163850f, -0.00652953f, 0.04916669f, -0.00478576f, 0.00162616f, -0.07570151f, 0.12553118f, 
    -0.14024848f, 0.01627257f, 0.06480329f, 0.05110623f, -0.19949320f, -0.15739965f, -0.09520623f, -0.03709729f, 
    0.07693563f, 0.12566340f, 0.17704211f, 0.10948797f, 0.06984124f, 0.03167040f, -0.02524077f, 0.02998116f, 
    -0.03278092f, -0.00448749f, -0.01249469f, -0.01141976f, -0.00612943f, -0.05456454f, -0.05825176f, 0.02105166f, 
    -0.02837491f, 0.07589288f, 0.05737453f, 0.19449268f, -0.00725156f, -0.10028296f, 0.17216668f, 0.02967088f, 
    -0.07621351f, 0.04824571f, -0.03178385f, -0.00065089f, -0.01337284f, 0.03812076f, -0.00326579f, 0.06049814f, 
    -0.07038919f, -0.01788621f, 0.07247028f, 0.15703806f, 0.00514829f, 0.04613883f, -0.07032091f, -0.01636170f, 
    0.05437652f, 0.08844883f, 0.07761832f, -0.03050462f, -0.15048030f, 0.02010681f, 0.07845795f, 0.05480329f, 
    0.00248053f, -0.00348225f, 0.00064339f, 0.02031997f, 0.11979937f, -0.00106067f, 0.05775149f, -0.03599388f, 
    -0.21940771f, -0.24952002f, -0.04476264f, -0.14406098f, 0.04110336f, -0.01531589f, 0.01293351f, -0.04596975f, 
    -0.11091278f, 0.03742206f, -0.09620908f, -0.05791115f, -0.04894457f, 0.07940857f, 0.03956053f, 0.06220444f, 
    0.04178645f, -0.18421914f, -0.14777134f, 0.12924415f, 0.13862713f, 0.02979014f, -0.13220163f, 0.15816341f, 
    -0.36289504f, 0.06870795f, 0.10223938f, -0.05321639f, 0.07698630f, 0.02917496f, -0.00631482f, -0.03511724f, 
    0.08259137f, 0.07356805f, 0.06523011f, 0.04557396f, -0.16783802f, 0.01199997f, -0.19518371f, 0.16653937f, 
    0.16210319f, -0.04651813f, 0.13569251f, 0.09385678f, 0.02973994f, -0.05491702f, -0.02868704f, 0.03799384f, 
    -0.01218568f, -0.07523966f, -0.03339482f, 0.06594573f, 0.10949706f, 0.10555731f, -0.05132701f, -0.06254620f, 
    0.11113969f, 0.14415523f, 0.12322280f, 0.03886963f, -0.48286393f, 0.45833054f, -0.18950397f, -0.08725762f, 
    0.03280871f, 0.02607974f, -0.26073036f, 0.04227282f, -0.05596403f, -0.05732024f, -0.18476722f, -0.14277683f, 
    -0.31649697f, -0.07255970f, 0.24374786f, 0.07674672f, 0.05454025f, 0.01735612f, -0.16349185f, 0.06269934f, 
    -0.02130696f, 0.02004538f, -0.06363644f, 0.02278631f, 0.00145144f, -0.06597310f, 0.05909551f, -0.00124362f, 
    -0.06748211f, -0.10622216f, -0.06032071f, -0.03473113f, 0.09354590f, -0.01153982f, -0.01977153f, 0.05444476f, 
    -0.04268389f, -0.01475173f, -0.05399003f, 0.04502407f, -0.09219647f, -0.03936270f, 0.05280801f, 0.06935646f, 
    0.03310154f, -0.04854093f, -0.03003199f, 0.09599521f, -0.15031552f, -0.26010159f, 0.15041773f, 0.14083822f, 
    0.00948291f, -0.01420397f, -0.04568183f, -0.15677620f, 0.09009941f, -0.07013262f, 0.02734303f, 0.12264462f, 
    -0.36452600f, 0.01795878f, 0.35062861f, 0.01794920f, 0.09723464f, -0.01108350f, -0.10575967f, -0.00598521f, 
    0.09169947f, 0.07958147f, 0.20188068f, -0.04657861f, 0.14308614f, -0.10925441f, 0.02776832f, 0.03833300f, 
    0.06641302f, 0.11722232f, -0.01375697f, 0.01257212f, 0.17073606f, 0.06161032f, -0.14028637f, 0.00419299f, 
    -0.02461803f, 0.28263238f, -0.04741022f, 0.12031546f, 0.02352630f, 0.09427024f, 0.18056139f, -0.08238979f, 
    0.10233900f, 0.05731419f, 0.01495107f, 0.00010279f, 0.39688432f, -0.10625986f, -0.11843835f, 0.16051465f, 
    0.15819335f, -0.04915465f, 0.00479243f, 0.00669983f, 0.07866671f, 0.06309760f, 0.05557357f, 0.00432810f, 
    0.01568400f, -0.00300372f, 0.02446406f, -0.01668301f, 0.02694206f, 0.03515320f, -0.02964472f, -0.01340082f, 
    -0.02178127f, -0.03363169f, 0.00454806f, -0.02770025f, 0.01807798f, -0.03933726f, 0.01995938f, -0.02319379f, 
    0.00990973f, 0.00085055f, -0.03762662f, 0.02942237f, -0.02113747f, -0.02597785f, 0.01067918f, -0.02908939f, 
    0.01202911f, 0.01195436f, 0.00619024f, -0.00442695f, -0.02559946f, -0.01369807f, 0.02619534f, 0.02547775f, 
    0.01220844f, -0.02081795f, -0.03815520f, -0.01041767f, -0.03390252f, -0.02322135f, 0.01695899f, 0.01634792f, 
    0.00532081f, -0.02607746f, -0.03478525f, -0.02139973f, 0.02660205f, -0.01603760f, -0.00664202f, 0.02002770f, 
    -0.02481616f, -0.02525352f, 0.02359816f, -0.00190155f, 0.02365843f, 0.02789270f, -0.00518484f, -0.02192503f, 
    -0.04429264f, -0.04468456f, -0.02342919f, -0.00600385f, -0.02938811f, 0.00600136f, -0.01738679f, -0.03049647f, 
    -0.00877204f, -0.01616058f, 0.01692658f, 0.01939834f, -0.00602984f, -0.04098527f, -0.00068153f, -0.03850632f, 
    -0.01000895f, 0.03644144f, 0.01641521f, 0.01940871f, 0.00104133f, -0.00067790f, 0.01934719f, 0.01517841f, 
    -0.02351160f, 0.01925011f, 0.02305346f, 0.01822555f, 0.00925393f, -0.00667217f, 0.02813473f, 0.01058470f, 
    -0.02612566f, -0.02183394f, 0.02282992f, -0.00482985f, 0.01615122f, 0.02506942f, -0.00140183f, 0.01930713f, 
    0.02584329f, -0.03723878f, 0.01880928f, -0.00276018f, -0.00650238f, 0.02811550f, -0.00003102f, 0.01243383f, 
    -0.01879765f, -0.02098878f, -0.01860571f, -0.01936721f, 0.01493175f, -0.03104173f, -0.01296528f, 0.03735401f, 
    -0.01519801f, -0.00161546f, 0.02696279f, -0.03298354f, -0.02011708f, 0.01254354f, -0.00272893f, -0.01700755f, 
    0.02491194f, -0.02507165f, -0.02633264f, 0.02596143f, -0.02288927f, 0.01297617f, -0.03554079f, 0.00442645f, 
    0.01083627f, -0.02911741f, 0.00797712f, 0.02007285f, -0.02510538f, 0.02419065f, -0.01616304f, -0.02276581f, 
    -0.01355700f, -0.01415644f, -0.02788226f, 0.00042942f, -0.01766494f, -0.01008186f, -0.01902994f, 0.02453898f, 
    0.02756595f, 0.01891032f, 0.01228272f, -0.02584716f, -0.02166677f, -0.03502568f, 0.00078064f, -0.00507232f, 
    -0.02219751f, -0.01691099f, 0.02675275f, 0.00841790f, -0.03789118f, -0.03421818f, -0.02999685f, -0.00433385f, 
    0.02097128f, -0.01650757f, -0.00383813f, 0.01572489f, -0.00279011f, -0.01057251f, -0.02458853f, -0.00992247f, 
    -0.03504827f, 0.00553743f, 0.03025225f, 0.01581880f, 0.02404587f, -0.02385713f, -0.00364282f, 0.02385700f, 
    -0.01738777f, -0.02282259f, 0.01122948f, -0.03386902f, 0.00369600f, -0.01099649f, 0.02390704f, 0.00187728f, 
    -0.03102844f, 0.00594736f, -0.02416238f, 0.00380440f, -0.00333383f, -0.03601637f, 0.00297622f, -0.00038519f, 
    -0.04023378f, -0.02648221f, -0.00965139f, -0.02995263f, -0.00984412f, 0.01784889f, 0.02400956f, 0.01921094f, 
    0.03199004f, 0.01733330f, 0.03793875f, -0.01295509f, -0.01010047f, 0.03010446f, 0.01172173f, 0.01056373f, 
    0.03791657f, 0.00230309f, 0.01750854f, -0.03236938f, 0.02006598f, -0.04012688f, -0.02039355f, -0.03073956f, 
    0.02824754f, 0.03000987f, -0.04080600f, -0.00675766f, -0.02497919f, -0.01221434f, 0.00969358f, -0.00331283f, 
    0.02314950f, -0.02286682f, -0.01909726f, -0.00498630f, -0.03787408f, -0.00087468f, -0.03403816f, -0.01561240f, 
    0.02052636f, 0.00239858f, -0.00822975f, -0.02148370f, 0.00788615f, 0.01582286f, -0.03136719f, 0.01865975f, 
    -0.03221978f, -0.01679675f, 0.01470922f, 0.01967724f, -0.00970355f, 0.02237848f, -0.03436922f, -0.00881452f, 
    0.02010743f, -0.02782549f, -0.01632860f, -0.01751015f, -0.03431759f, -0.02838081f, -0.04120479f, -0.02802587f, 
    0.01954174f, -0.00073515f, 0.00217706f, -0.03469298f, 0.01430226f, 0.00087714f, -0.03006464f, -0.03226325f, 
    -0.00934416f, -0.02456035f, -0.00035641f, 0.00633188f, -0.00038906f, 0.02010473f, -0.00848196f, 0.02932384f, 
    -0.03557769f, 0.02313546f, -0.03450879f, -0.02910875f, -0.00582473f, -0.02745886f, 0.02211635f, 0.01386252f, 
    -0.03503542f, -0.01109225f, -0.00667427f, 0.00964938f, -0.02307508f, -0.02070346f, 0.02409759f, 0.01582097f, 
    -0.00017899f, 0.02555795f, -0.01543880f, -0.02753241f, 0.03070180f, 0.00612317f, 0.02351914f, -0.00593937f, 
    -0.03354388f, -0.01947188f, -0.03620968f, -0.02229943f, 0.02867682f, -0.00725767f, -0.02638453f, -0.02006837f, 
    0.02546184f, 0.00049927f, 0.02963229f, 0.01419667f, -0.01482207f, -0.02343701f, -0.01586669f, 0.00145964f, 
    0.01446078f, 0.02437354f, 0.01554508f, 0.00941285f, 0.01467043f, 0.01951713f, -0.02403116f, 0.00592581f, 
    -0.01854492f, -0.02991745f, -0.01126171f, -0.03318238f, 0.00743490f, -0.02366358f, 0.00966072f, 0.01331526f, 
    0.01698484f, -0.02546665f, -0.00926879f, -0.00895693f, -0.02891185f, 0.01314658f, -0.02171413f, -0.02636890f, 
    0.01549955f, 0.02789596f, 0.03293399f, 0.02394964f, 0.00786267f, -0.01998112f, 0.02568393f, -0.01026215f, 
    -0.00043136f, 0.00215781f, -0.00512353f, 0.00617548f, -0.02682073f, -0.00406300f, -0.00310916f, -0.01327900f, 
    -0.00425290f, -0.01747130f, 0.00076548f, -0.02491267f, -0.02416829f, 0.02892990f, 0.01126612f, -0.02766368f, 
    0.03046601f, 0.03885014f, 0.00085119f, -0.03645044f, -0.02096725f, 0.03323600f, -0.01248668f, 0.00904495f, 
    -0.00404057f, -0.01658763f, 0.01491664f, 0.00856928f, -0.01313655f, 0.00447872f, 0.02337902f, 0.02332911f, 
    -0.01612939f, -0.01973381f, 0.02332321f, 0.00187353f, -0.01091984f, 0.00941436f, 0.01375015f, -0.00156116f, 
    0.01757846f, -0.01765782f, 0.01268138f, 0.00735268f, -0.04005623f, -0.01693558f, -0.01360522f, 0.00614345f, 
    -0.00834158f, -0.01458842f, -0.00370232f, 0.00194604f, -0.01248219f, -0.02506493f, 0.03258378f, -0.03373326f, 
    -0.02551491f, 0.01713414f, -0.03911025f, 0.02569593f, -0.02111934f, 0.03039329f, -0.01207171f, -0.00702436f, 
    -0.02890368f, 0.01169865f, -0.01919019f, 0.01905576f, -0.00007145f, 0.02962332f, -0.01574435f, 0.00879422f, 
    0.01503222f, -0.01893581f, 0.00895415f, 0.03570091f, -0.02269384f, -0.00332165f, -0.01601255f, -0.00716521f, 
    0.01232539f, -0.01115091f, 0.02312569f, 0.01903342f, -0.01714084f, -0.03385967f, -0.02374822f, -0.03756092f, 
    0.00420850f, -0.02577601f, 0.00538454f, 0.01629247f, -0.03474810f, -0.00898095f, 0.01801628f, 0.01340288f, 
    0.01104230f, -0.01314683f, -0.01928866f, 0.02938279f, 0.00349282f, 0.01298750f, -0.03523995f, -0.01473962f, 
    -0.03766362f, 0.00308687f, -0.03599510f, -0.03858560f, -0.01851543f, 0.02689725f, -0.01304026f, -0.00080087f, 
    0.00488974f, 0.00550105f, -0.02871281f, -0.00465856f, -0.01239982f, 0.01156126f, 0.02948620f, 0.02186948f, 
    -0.02238821f, 0.00526237f, -0.03653883f, 0.00739136f, 0.02359084f, 0.02429522f, -0.00735349f, -0.02078375f, 
    -0.02314822f, -0.01234804f, -0.03416441f, -0.01380864f, -0.00598408f, -0.03748685f, -0.02590342f, 0.00232444f, 
    -0.00870658f, -0.00476083f, 0.01196770f, 0.01043960f, -0.00429299f, 0.00264690f, -0.00144436f, 0.00241009f, 
    0.01142833f, 0.00117204f, -0.00980795f, -0.03877448f, -0.00782387f, -0.04051070f, 0.02013299f, 0.00000096f, 
    -0.01494446f, -0.00418755f, 0.01700872f, -0.01441191f, -0.03257095f, 0.00880349f, -0.03793358f, -0.04374210f, 
    -0.01394319f, -0.00187711f, -0.03114771f, -0.03630805f, -0.02060114f, 0.02640726f, 0.01764523f, -0.01477295f, 
    -0.02794772f, -0.03185340f, 0.01707942f, 0.00547099f, 0.02739839f, 0.01791093f, 0.00188306f, -0.02545658f, 
    0.00595287f, -0.00707057f, -0.02501163f, 0.02951645f, 0.01654894f, -0.03675566f, -0.00032515f, -0.01015254f, 
    0.01230961f, -0.02997722f, -0.00396428f, -0.03621878f, 0.01264741f, 0.02618745f, 0.02461296f, 0.02612105f, 
    -0.01423386f, 0.00944816f, -0.01428209f, -0.01695567f, 0.02878843f, 0.00756423f, 0.02735624f, 0.00953942f, 
    -0.03908921f, 0.02754656f, -0.03748772f, 0.03216637f, -0.01046068f, 0.02497504f, 0.02952652f, 0.02094225f, 
    0.00072020f, 0.02760546f, -0.02908834f, 0.01197766f, 0.00431166f, -0.03357244f, -0.00174321f, -0.02066837f, 
    0.01186454f, 0.02975042f, -0.01142683f, 0.03112261f, -0.03915223f, 0.03102771f, 0.02509924f, -0.02673214f, 
    0.02422590f, -0.02969525f, 0.01312330f, -0.00792140f, 0.02009025f, 0.02729626f, 0.01540105f, -0.04019721f, 
    0.00740988f, 0.01777410f, -0.00584287f, -0.01945866f, 0.03561006f, 0.01051358f, 0.02377995f, -0.02083853f, 
    -0.03986337f, -0.02906703f, 0.03123281f, 0.02239403f, -0.00870600f, -0.02838884f, -0.00744347f, 0.02780469f, 
    -0.01896020f, 0.03608143f, -0.01213803f, 0.00104489f, -0.02627347f, 0.00227428f, -0.01872787f, 0.00715088f, 
    -0.02518110f, 0.01058977f, -0.02807041f, -0.00323284f, -0.03517149f, -0.02153867f, 0.00033691f, 0.01274524f, 
    -0.01509755f, 0.02074120f, 0.02747563f, -0.02199272f, -0.00816632f, 0.01936777f, -0.02113985f, -0.03450662f, 
    0.00573600f, 0.01565007f, 0.00192757f, -0.00523815f, -0.01788760f, -0.02036539f, -0.01063316f, 0.01340027f, 
    0.00720909f, -0.02779541f, -0.03398735f, 0.02334074f, -0.02248952f, -0.02407848f, -0.00618057f, -0.03052356f, 
    0.01499729f, -0.00185849f, 0.02697601f, 0.00304839f, -0.02448529f, -0.02662465f, 0.02173034f, -0.00226973f, 
    0.01472665f, -0.00280279f, -0.01123856f, -0.00047482f, 0.02263903f, 0.00298712f, -0.00075210f, -0.01723874f, 
    -0.02329018f, -0.02121758f, 0.01014990f, 0.01790752f, 0.00841851f, 0.03091878f, -0.01473684f, 0.00749026f, 
    0.00772664f, 0.00820495f, 0.01004616f, -0.03014543f, 0.00612615f, -0.01086083f, 0.00981191f, -0.03229243f, 
    0.00317025f, -0.03806031f, 0.01390851f, 0.01640517f, -0.02337323f, 0.02728777f, -0.00412142f, -0.03905744f, 
    0.03012683f, -0.01852581f, -0.01063045f, -0.03045910f, -0.01205415f, 0.01049514f, 0.00810834f, -0.02397691f, 
    -0.03226444f, 0.03153748f, -0.01240641f, 0.02032223f, 0.01708400f, 0.02641648f, -0.04331304f, -0.01449027f, 
    -0.01220653f, 0.01206636f, 0.02120255f, 0.00604116f, 0.00749435f, 0.02145344f, 0.01437103f, 0.02638329f, 
    -0.03215525f, 0.00487823f, 0.01283957f, -0.03106337f, -0.02460783f, -0.00769192f, 0.02605761f, -0.03657508f, 
    -0.02997522f, 0.01723777f, -0.03221318f, -0.01093205f, -0.02748333f, -0.02604064f, 0.00510651f, 0.00495422f, 
    -0.01992498f, 0.02193730f, -0.03149239f, -0.01501732f, 0.01624215f, -0.00649713f, 0.02854007f, 0.02907099f, 
    -0.00685474f, 0.01936293f, -0.01161903f, -0.03138575f, 0.02421584f, 0.02892656f, 0.00706021f, -0.03673508f, 
    0.02798448f, 0.01497085f, 0.02552117f, 0.03083501f, 0.00851114f, -0.01551236f, 0.00722846f, -0.03319207f, 
    0.00386969f, 0.02109640f, -0.04115620f, -0.01133826f, 0.00784384f, 0.02266591f, -0.02708218f, -0.03707293f, 
    0.00144925f, 0.02137223f, 0.01469996f, -0.02478175f, -0.00441877f, 0.00227815f, -0.03030523f, 0.01791526f, 
    -0.00887251f, -0.03406041f, -0.00134050f, -0.03206542f, -0.00113824f, 0.00577102f, -0.02041550f, -0.02854433f, 
    -0.02530918f, 0.01116279f, -0.03241183f, -0.00974592f, -0.03636519f, -0.00922870f, -0.02820813f, -0.00170981f, 
    -0.05166211f, 0.03593698f, 0.10725226f, -0.06632878f, 0.02863067f, 0.06217168f, 0.03484454f, -0.07628238f, 
    0.00778133f, 0.11762275f, 0.01261289f, -0.10071088f, -0.04157580f, 0.04195351f, -0.08666923f, 0.09580788f, 
    0.00182726f, -0.04201009f, -0.12936555f, -0.02872431f, 0.11742613f, -0.14697181f, 0.06257793f, -0.02939858f, 
    -0.05452958f, -0.09452701f, -0.34614801f, 0.20372522f, 0.10583032f, 0.02231567f, 0.11298158f, -0.02059940f, 
    -0.05361992f, -0.05479901f, -0.06971575f, -0.06823695f, -0.14959155f, -0.01867577f, 0.14134741f, 0.15328486f, 
    0.02623235f, -0.01754837f, 0.04216626f, -0.00461008f, 0.09992475f, 0.10599010f, -0.07372626f, 0.06421626f, 
    0.10754964f, 0.10840185f, 0.13530451f, 0.07337775f, -0.06442785f, 0.00940819f, -0.02104878f, -0.02625259f, 
    -0.03426001f, -0.02141450f, -0.03385231f, -0.19019879f, -0.08829870f, -0.17778131f, 0.16515054f, -0.21503082f, 
    0.13499311f, 0.05756590f, -0.04167873f, -0.12246513f, -0.00984717f, 0.02715189f, -0.00061236f, 0.01336635f, 
    -0.09979726f, 0.13671201f, 0.01245906f, 0.12940677f, -0.08251322f, 0.04736780f, -0.00691158f, -0.02352112f, 
    0.05496091f, -0.03481245f, -0.02222081f, -0.05902823f, -0.07651260f, -0.19522807f, -0.10649560f, -0.13212188f, 
    0.02936707f, 0.16177253f, 0.03956252f, -0.04457325f, -0.08794424f, -0.09339622f, -0.05793723f, -0.05548314f, 
    0.48310116f, 0.10038751f, -0.04327928f, -0.01901194f, -0.04084110f, 0.05560179f, -0.02199339f, 0.10487504f, 
    0.04871747f, -0.03674066f, -0.00805955f, -0.08535679f, 0.19178142f, -0.09585004f, -0.16557017f, 0.17852856f, 
    -0.05366143f, 0.05206480f, 0.10760313f, 0.05101655f, -0.11106657f, -0.01453170f, -0.17762035f, 0.02104550f, 
    0.06783240f, 0.10177987f, 0.08162423f, 0.18134148f, -0.02111073f, 0.01047868f, 0.07306547f, 0.13207786f, 
    0.03785365f, 0.01880728f, -0.11979461f, -0.08576407f, 0.09774327f, -0.04930709f, 0.20929050f, 0.12715557f, 
    0.04843459f, -0.01357555f, 0.09422307f, -0.00822462f, -0.02090978f, 0.00947587f, -0.15193969f, 0.14976031f, 
    0.01664807f, 0.17965561f, -0.13183354f, 0.05507406f, 0.10763830f, 0.03676742f, -0.04769542f, 0.11078513f, 
    -0.00663380f, 0.04551442f, -0.07580408f, 0.08880477f, 0.10600200f, -0.25330129f, 0.12958825f, 0.07989974f, 
    -0.09708992f, -0.05607947f, -0.02095050f, 0.03060457f, -0.04303086f, -0.04732568f, -0.06204453f, -0.06451426f, 
    0.19161239f, 0.00813630f, 0.00652246f, 0.00136679f, 0.03268592f, -0.00544223f, 0.11811936f, -0.05261843f, 
    -0.20118919f, 0.04532700f, 0.01071429f, -0.01508913f, -0.26170179f, 0.17920999f, 0.45736310f, 0.09103172f, 
    -0.05239304f, -0.00457892f, 0.03548727f, 0.09559259f, 0.03284009f, -0.09710737f, -0.07797731f, 0.05468477f, 
    0.21873072f, 0.30596021f, 0.04051228f, -0.02862329f, 0.01410656f, -0.06258110f, 0.07615732f, 0.02357999f, 
    -0.12408804f, 0.00901377f, -0.01052949f, -0.02857480f, 0.09006299f, 0.01892260f, 0.05095094f, -0.02108437f, 
    -0.02688133f, 0.04181462f, -0.11103038f, 0.15308891f, 0.10482515f, -0.03968482f, 0.01348739f, 0.12268361f, 
    -0.37605220f, 0.20809919f, 0.02203475f, 0.05014960f, -0.04308181f, 0.02369973f, -0.00014328f, 0.04514233f, 
    -0.06522576f, 0.02916226f, -0.04911961f, 0.01439762f, 0.06267600f, -0.14248417f, 0.21677521f, 0.15815161f, 
    -0.12680255f, 0.15869886f, 0.04691844f, -0.06789873f, 0.20773345f, 0.00269039f, -0.02153889f, 0.13098739f, 
    0.13996071f, -0.11208416f, -0.02466135f, -0.07923227f, -0.02696815f, -0.05860212f, 0.03671728f, -0.01685240f, 
    0.06363933f, -0.00108554f, -0.05919507f, -0.06867495f, -0.34888312f, 0.06582022f, 0.10258187f, 0.05244316f, 
    0.05001349f, 0.01105278f, 0.15893763f, -0.07476626f, -0.10194477f, -0.06039141f, -0.01829537f, -0.00705384f, 
    -0.02332959f, 0.11816631f, -0.12638652f, 0.12294313f, 0.04146487f, -0.06627081f, 0.01179247f, 0.02766067f, 
    0.18251395f, -0.01093038f, -0.12688208f, -0.05486871f, 0.02866588f, -0.20139544f, 0.22491799f, -0.06412734f, 
    0.10033143f, 0.02689230f, 0.08011240f, -0.06976820f, -0.10467149f, 0.04256300f, -0.06746487f, 0.19574232f, 
    0.21480554f, 0.29812586f, -0.16899563f, 0.16341653f, 0.01041175f, 0.03675316f, 0.01117237f, 0.12497354f, 
    -0.05574105f, -0.03351811f, 0.02542389f, 0.01112261f, -0.03051792f, -0.22078259f, -0.02911610f, 0.13963041f, 
    -0.05601701f, 0.04106957f, 0.02239726f, -0.09558448f, -0.07997131f, -0.14558475f, -0.18808214f, -0.05210535f, 
    0.41083071f, 0.10043414f, 0.03171238f, 0.06137862f, 0.00989676f, -0.00790192f, -0.08844224f, 0.03384012f, 
    -0.00916110f, 0.05983383f, -0.07449751f, 0.01226850f, 0.05971929f, 0.10912656f, 0.04398855f, 0.08741187f, 
    0.03003319f, 0.11779227f, 0.00472146f, -0.09894691f, 0.06862897f, 0.06942007f, 0.04158712f, 0.21677865f, 
    0.18491024f, -0.19741860f, 0.15222692f, 0.27882221f, -0.10318498f, 0.01182262f, 0.01010657f, -0.07567684f, 
    0.00794797f, 0.07338436f, -0.07491630f, 0.00382999f, 0.07512650f, 0.04265929f, -0.15829258f, 0.37095785f, 
    0.00880748f, -0.01915321f, -0.07586387f, 0.07304148f, -0.00713286f, 0.12229184f, -0.15484525f, -0.00677799f, 
    0.14117241f, 0.01472793f, 0.24208228f, 0.13730989f, 0.02676291f, 0.05893576f, -0.07515779f, -0.13005477f, 
    0.15996870f, 0.00199268f, -0.02309023f, 0.01122190f, -0.03437800f, 0.00368979f, 0.03787579f, 0.07480539f, 
    0.02180675f, 0.02743859f, 0.06374691f, 0.06320177f, 0.07864729f, 0.14040315f, -0.05281098f, 0.15488578f, 
    0.04068173f, 0.05913344f, -0.11299387f, 0.06637187f, 0.01619862f, 0.00462565f, 0.14295468f, -0.08158743f, 
    0.13532445f, 0.09274482f, -0.06735589f, -0.00797570f, 0.21876444f, -0.24944822f, 0.00109675f, 0.08279843f, 
    -0.06802358f, -0.04419458f, 0.14442787f, -0.01899727f, -0.05168084f, 0.00025590f, -0.03074617f, 0.05382314f, 
    0.07455975f, -0.05912883f, 0.05323619f, -0.05366692f, 0.07809483f, -0.02151923f, -0.10679535f, 0.01410353f, 
    0.00473928f, 0.05461008f, 0.00005117f, 0.04885710f, 0.05391826f, 0.23607178f, -0.00747925f, 0.08594544f, 
    -0.09656388f, 0.00633438f, -0.06587708f, -0.09075975f, -0.02472218f, 0.00130422f, -0.00445716f, -0.13065162f, 
    0.04161476f, 0.18474148f, 0.12908800f, -0.15527010f, -0.05380751f, -0.03486856f, 0.12072147f, -0.02798579f, 
    -0.08753137f, 0.03929831f, -0.13092543f, 0.03304829f, 0.20351768f, 0.11060134f, -0.03092787f, -0.11584315f, 
    -0.04706221f, -0.06187969f, -0.05757726f, 0.04080932f, 0.00258408f, 0.18255363f, 0.03958455f, 0.17018609f, 
    -0.02041135f, 0.02914244f, -0.05837782f, 0.14667425f, -0.08022365f, -0.06165249f, 0.06225078f, 0.02804876f, 
    -0.01638631f, -0.03899217f, -0.00867753f, 0.03235904f, 0.18601440f, -0.04537787f, -0.01461361f, -0.04933563f, 
    0.02891520f, 0.06654076f, 0.11867706f, -0.11439540f, -0.16930558f, -0.01362890f, -0.03832530f, 0.01492522f, 
    0.16421093f, 0.05721040f, 0.01557107f, 0.01938187f, 0.02808423f, 0.08332098f, 0.04875915f, 0.01168943f, 
    -0.01117672f, -0.17024329f, 0.04189618f, -0.04079118f, -0.15295964f, 0.07344043f, 0.13654329f, -0.13891724f, 
    -0.00523442f, 0.11003762f, -0.00050171f, -0.02522784f, 0.02219238f, -0.01976903f, 0.11674055f, 0.00479324f, 
    0.05645487f, 0.23285355f, 0.15971322f, -0.06204622f, -0.08648396f, -0.00486339f, 0.04840426f, 0.04094309f, 
    -0.16722973f, 0.00209807f, 0.03038522f, -0.00666436f, 0.14098856f, 0.00219246f, 0.03595144f, 0.11099169f, 
    0.02821282f, 0.04762916f, 0.09973275f, 0.01092299f, 0.00960724f, 0.03655735f, 0.03602394f, 0.03877903f, 
    0.09801778f, 0.08128401f, 0.22363663f, 0.05187253f, 0.13280894f, 0.07069750f, 0.02879895f, -0.04618688f, 
    0.02958717f, -0.08875619f, -0.08881068f, 0.05223590f, 0.07062452f, -0.04813031f, 0.11762045f, 0.11614119f, 
    -0.08817074f, 0.05535859f, -0.06534682f, -0.09550729f, -0.03447561f, 0.00798264f, 0.04478359f, -0.04566267f, 
    -0.03697294f, 0.31068271f, -0.07296874f, 0.15195785f, -0.08790414f, -0.02658029f, -0.00681193f, 0.01841834f, 
    0.01403234f, -0.08434451f, -0.01553482f, 0.02642202f, -0.05453260f, 0.07227035f, 0.13472298f, 0.15669501f, 
    0.07025108f, 0.10894548f, 0.03509715f, -0.09145785f, -0.03975403f, -0.02428175f, 0.01075383f, -0.00436246f, 
    -0.03237520f, 0.03012292f, -0.10767990f, -0.11360155f, 0.00110053f, -0.06264546f, -0.06462868f, 0.00517969f, 
    -0.05391165f, 0.00580807f, -0.04885780f, -0.03669394f, 0.11264668f, -0.01895506f, 0.02629927f, 0.10937253f, 
    0.03925635f, 0.09895755f, 0.00836587f, 0.07564507f, -0.03851683f, 0.02533990f, 0.02690890f, -0.07210407f, 
    0.05898870f, 0.02495301f, 0.00346221f, 0.10337340f, -0.01617836f, 0.01287687f, 0.02556386f, -0.01152017f, 
    0.03834790f, 0.06628065f, 0.03304353f, -0.04245375f, -0.11098103f, 0.27930242f, 0.07883384f, 0.03159015f, 
    -0.01016421f, 0.05519123f, 0.04586235f, 0.06033006f, -0.03704237f, -0.07769121f, 0.04805196f, -0.04168972f, 
    0.23883714f, -0.12730272f, -0.11514487f, 0.22813764f, 0.07216455f, 0.05048069f, -0.02625938f, -0.01325945f, 
    0.02407769f, -0.02209095f, -0.03671878f, -0.04253275f, 0.13567007f, -0.15467042f, 0.24179713f, -0.22130804f, 
    -0.06562583f, 0.13757053f, 0.08380263f, -0.03179725f, -0.04529013f, -0.12397192f, -0.01685038f, -0.12208917f, 
    0.01840223f, 0.06324901f, 0.04162023f, 0.11712494f, 0.04047076f, -0.08507534f, 0.07669740f, 0.00556833f, 
    -0.02283825f, -0.00699037f, -0.01444742f, -0.05318556f, 0.19556041f, -0.17968175f, 0.09011510f, 0.16178133f, 
    -0.00294357f, 0.08891512f, -0.07015679f, 0.02990603f, -0.01630104f, 0.01410641f, 0.12948775f, 0.17472412f, 
    -0.01133931f, -0.02369725f, 0.09832295f, 0.34130585f, 0.03103284f, 0.07536899f, 0.01729807f, -0.04247351f, 
    -0.01274003f, 0.00559375f, 0.01874051f, 0.06256343f, 0.10181718f, 0.26408425f, -0.03651747f, 0.18340674f, 
    -0.04263397f, 0.11781538f, 0.12679352f, 0.04148804f, -0.22095536f, -0.06186136f, -0.07749689f, -0.10055715f, 
    0.19749297f, 0.08403643f, 0.07516117f, 0.08104741f, 0.04480040f, -0.04360472f, 0.03237810f, -0.01827296f, 
    -0.07949316f, -0.01846245f, -0.01860135f, -0.27001837f, 0.07588676f, 0.28091833f, 0.02341701f, 0.13688967f, 
    0.06333145f, -0.01548399f, -0.01231061f, 0.03933515f, -0.07233337f, 0.05092560f, -0.05285602f, -0.03586080f, 
    0.40675429f, 0.13059469f, 0.08257778f, 0.09045208f, -0.08247416f, -0.06899659f, 0.04554524f, 0.03891747f, 
    -0.08421664f, -0.03368620f, -0.11165813f, -0.04929882f, -0.29453883f, 0.10449520f, 0.13180242f, 0.07050315f, 
    -0.04148034f, -0.03419083f, 0.05178528f, 0.08267044f, -0.03967416f, -0.02174450f, -0.01001294f, 0.04430351f, 
    0.12899634f, -0.21551408f, 0.32367647f, 0.09316932f, -0.06424687f, 0.13353059f, 0.01025889f, 0.12639757f, 
    -0.07036658f, -0.06050856f, -0.05577121f, 0.04594313f, -0.39252213f, 0.23748298f, 0.16787408f, -0.16007999f, 
    -0.11919010f, 0.06024735f, 0.13176973f, -0.00138554f, -0.10197264f, -0.08485711f, -0.02680039f, 0.07563881f, 
    0.65390718f, 0.02826627f, 0.22369987f, -0.17332612f, 0.01034457f, 0.02658559f, 0.08566292f, -0.14621121f, 
    -0.09936554f, -0.02525115f, 0.00750073f, 0.17453980f, 0.06823841f, 0.20768234f, -0.14769220f, 0.06991082f, 
    0.06420561f, -0.17764488f, -0.00781334f, 0.14527392f, -0.00665081f, 0.00709628f, -0.10245228f, -0.18197420f, 
    0.19755913f, 0.57799709f, -0.05554723f, -0.05545034f, 0.06882179f, -0.01731486f, -0.12786613f, 0.08515947f, 
    -0.08416755f, -0.00605037f, -0.03231171f, 0.02298550f, -0.08979370f, -0.02257470f, -0.18180867f, 0.01880472f, 
    0.05116433f, 0.00887935f, 0.05116257f, 0.11054941f, -0.10725588f, -0.03050223f, -0.01856958f, 0.09257519f, 
    0.10126503f, 0.32592511f, 0.26052657f, 0.15394501f, -0.07794641f, 0.03465495f, -0.09251937f, 0.10051793f, 
    0.01287184f, -0.01057787f, 0.08595119f, -0.13383809f, -0.07768682f, 0.03874727f, 0.31885678f, 0.16821750f, 
    0.12006571f, -0.03330377f, -0.02054066f, 0.06407914f, 0.11353005f, 0.02498601f, -0.06898467f, 0.00174242f, 
    0.08034477f, 0.05536569f, 0.49273479f, 0.09144838f, -0.03350990f, -0.04045349f, -0.02001306f, 0.25217471f, 
    -0.05379587f, -0.06842235f, -0.01753558f, -0.05005987f, 0.13110381f, 0.49206263f, 0.02447495f, 0.05927493f, 
    -0.18411821f, -0.08397416f, 0.08588420f, 0.08011691f, 0.00910752f, -0.04794136f, -0.07314531f, -0.08088239f, 
    -0.48540023f, -0.06404217f, -0.07697775f, 0.28397006f, -0.00821257f, 0.16398774f, -0.08111743f, -0.05406068f, 
    0.06246665f, -0.12067366f, -0.14481555f, 0.04136478f, -0.13648434f, 0.10862408f, 0.06851123f, 0.05028492f, 
    0.13898128f, 0.19627590f, -0.03125840f, 0.05520224f, -0.04634221f, -0.05595999f, 0.01279134f, -0.02317520f, 
    -0.14879237f, 0.04051540f, -0.08213246f, 0.17549400f, -0.06478809f, 0.14317086f, 0.10944197f, 0.02240531f, 
    -0.03654704f, -0.00223382f, 0.03057487f, 0.24084468f, -0.26594952f, -0.05491968f, -0.29357332f, -0.19503570f, 
    0.07942940f, 0.03563461f, 0.10639607f, 0.04741196f, 0.13673992f, -0.00862766f, 0.02697158f, 0.06170737f, 
    0.14041406f, 0.04366010f, -0.03586349f, -0.01531332f, 0.01278294f, 0.04651211f, -0.17354184f, -0.01027953f, 
    -0.00186730f, 0.09081502f, -0.14502855f, 0.01689065f, 0.09425014f, -0.00040080f, -0.00511748f, 0.01749096f, 
    0.05829231f, 0.05295968f, 0.11799064f, 0.14662871f, -0.06872717f, -0.03825522f, -0.02264376f, -0.05503797f, 
    -0.13854815f, -0.04440864f, -0.03235281f, 0.18842240f, 0.04478585f, -0.05650548f, 0.00193591f, -0.05741412f, 
    0.00988011f, 0.07225291f, 0.02460467f, 0.08858612f, -0.00204570f, -0.30529478f, 0.02294814f, -0.09072684f, 
    0.14847475f, 0.05065940f, 0.10054535f, -0.10623354f, -0.02451539f, 0.02991887f, -0.34182155f, 0.02701315f, 
    -0.06625107f, -0.05576864f, -0.05136093f, -0.01209998f, 0.12914358f, -0.07808865f, -0.06941874f, -0.03955426f, 
    0.17382170f, -0.35962003f, -0.22303388f, -0.07899352f, 0.03210720f, 0.17788522f, -0.03158211f, -0.03058618f, 
    0.16394676f, -0.01502611f, 0.04801244f, -0.07866701f, -0.05779734f, 0.03154816f, 0.04887933f, 0.00884115f, 
    -0.01245870f, 0.14779802f, -0.04331976f, 0.11082785f, 0.04368473f, -0.01228638f, 0.04997289f, 0.08189044f, 
    0.05840759f, 0.03362126f, -0.06807699f, 0.06143197f, -0.10501575f, 0.17432973f, -0.06533875f, -0.10420986f, 
    0.01734418f, 0.09517329f, -0.05757761f, 0.00719928f, -0.00393705f, -0.04155565f, -0.12711780f, 0.34422615f, 
    -0.11126870f, 0.02708625f, 0.42394799f, -0.00892914f, 0.01800385f, -0.00603146f, -0.00916518f, -0.04528149f, 
    0.14732444f, -0.00751285f, -0.04216750f, -0.03082542f, 0.02668644f, -0.03463018f, -0.04435828f, 0.08445569f, 
    0.02180274f, -0.06428814f, -0.03029591f, -0.10746976f, -0.02866928f, 0.20130333f, 0.07549692f, 0.21396784f, 
    -0.11646367f, 0.11897562f, 0.03631335f, 0.29225102f, 0.13065135f, -0.01229840f, -0.00147932f, -0.18374464f, 
    0.04346408f, 0.06708273f, 0.20208338f, 0.09942149f, 0.19321829f, -0.49706432f, 0.53575039f, 0.12735800f, 
    -0.07445911f, -0.03305939f, -0.12460756f, -0.04844343f, -0.00790630f, 0.17400591f, 0.01865837f, -0.05974189f, 
    -0.32669327f, 0.12786707f, -0.14076830f, 0.19558105f, 0.08095536f, -0.05718440f, 0.12019428f, -0.04456558f, 
    0.03775349f, 0.01059453f, -0.04724110f, 0.06909855f, 0.09771781f, 0.10265091f, 0.15626837f, 0.11914248f, 
    -0.10799015f, -0.09671482f, 0.10596593f, -0.14877124f, -0.06714570f, 0.14549035f, 0.11633688f, -0.07294893f, 
    -0.10784740f, 0.02952754f, 0.10294347f, 0.21128914f, 0.03932521f, 0.11685375f, -0.01685740f, -0.35520226f, 
    -0.00577616f, -0.14138047f, -0.19519907f, -0.21420594f, -0.15927519f, 0.18657970f, 0.10027537f, -0.03923479f, 
    -0.11702777f, -0.09378395f, 0.04191492f, -0.13448402f, -0.15583348f, 0.04662982f, 0.10040908f, -0.08203546f, 
    -0.33374035f, 0.12546544f, -0.03752506f, 0.09433828f, 0.05014268f, 0.08405411f, -0.08142513f, -0.10577570f, 
    -0.08156368f, -0.03363029f, -0.04685447f, 0.11174846f, -0.04970285f, 0.13281611f, -0.09153638f, -0.01621246f, 
    -0.02034800f, 0.08316325f, -0.03688492f, 0.02470767f, 0.09804225f, 0.06533301f, -0.01467416f, -0.01248093f, 
    -0.21004900f, 0.15489073f, 0.34011179f, -0.20929709f, -0.10027388f, -0.07920787f, -0.01584643f, 0.04026512f, 
    0.00319176f, -0.02333457f, 0.16020927f, 0.12642436f, -0.13248158f, -0.04769138f, 0.07641815f, -0.02379471f, 
    -0.04080120f, -0.00671343f, 0.00108642f, -0.08466706f, 0.00689472f, -0.08018463f, 0.01555128f, -0.14218640f, 
    0.20709381f, 0.06122782f, 0.30400476f, -0.04942037f, -0.13912357f, -0.02811990f, -0.00077768f, 0.06707396f, 
    -0.10122780f, -0.04398009f, 0.08744096f, -0.14717273f, -0.08440394f, -0.11980376f, 0.28956735f, 0.13777463f, 
    -0.13307451f, 0.13900317f, -0.19227877f, 0.16733874f, -0.00990916f, 0.07121742f, -0.03748769f, -0.03863362f, 
    -0.00775229f, 0.10921554f, 0.10335770f, 0.18126695f, -0.01178058f, 0.08262336f, 0.07271637f, -0.22749008f, 
    -0.03940673f, 0.02352647f, 0.00489634f, 0.11065160f, -0.11734516f, 0.12290341f, 0.08759654f, 0.22283879f, 
    0.13545616f, 0.12287629f, 0.18433723f, 0.13501076f, 0.21838732f, 0.07029798f, -0.01581297f, 0.03701882f, 
    0.12203096f, 0.10070187f, 0.10537381f, 0.05030290f, 0.03548285f, 0.08058007f, 0.11515155f, -0.13782269f, 
    0.20775458f, -0.02320392f, -0.14353894f, -0.08076023f, -0.24621353f, -0.05026000f, -0.15816166f, 0.16376267f, 
    -0.00527220f, 0.05294818f, -0.00538156f, -0.06283863f, 0.21343029f, 0.06396300f, -0.04332244f, 0.18702045f, 
    0.10493656f, 0.13845515f, -0.02556803f, 0.02091218f, 0.17347567f, 0.12249115f, 0.05326924f, 0.15949614f, 
    0.04881284f, 0.00521551f, 0.07369830f, -0.14242513f, -0.14034404f, 0.10903616f, 0.47931686f, 0.10232431f, 
    -0.10459421f, -0.06516366f, -0.05321727f, 0.12461042f, 0.00602680f, 0.01983793f, -0.02032793f, -0.03672567f, 
    -0.10141926f, 0.03504485f, 0.40823907f, 0.10087372f, -0.04515218f, -0.02399084f, -0.13273738f, 0.06320234f, 
    0.10733599f, 0.04455349f, -0.05125673f, -0.02239795f, -0.12165914f, 0.45806679f, -0.12167759f, 0.17150410f, 
    0.13668206f, -0.10615332f, 0.06199837f, -0.02239475f, 0.13682856f, -0.02360834f, -0.09244177f, -0.03100885f, 
    -0.01674587f, -0.13312380f, 0.04104537f, 0.07890906f, 0.02782089f, 0.08313383f, 0.11548100f, 0.02978362f, 
    0.09554567f, -0.06985670f, -0.13574480f, 0.01541899f, 0.01561885f, 0.03131068f, 0.00725059f, 0.02110437f, 
    0.00178666f, 0.03784757f, 0.01568224f, 0.11391801f, -0.03624136f, 0.03484358f, 0.04759600f, 0.11979605f, 
    0.03785513f, 0.04058627f, 0.25889650f, 0.00180264f, -0.05422397f, 0.03140399f, 0.18785095f, 0.01684001f, 
    -0.09222963f, 0.05659603f, 0.10234477f, 0.19324598f, -0.06355089f, 0.15945448f, 0.22264470f, 0.04442232f, 
    -0.02243755f, 0.00932383f, 0.05647863f, 0.05068405f, 0.08425186f, 0.00883156f, 0.07185659f, 0.01716633f, 
    -0.09413354f, 0.25788632f, -0.13445668f, 0.16814996f, 0.02508766f, 0.00826705f, -0.03379327f, 0.04795388f, 
    -0.00457749f, 0.10732890f, 0.00438359f, 0.20793526f, -0.04020313f, 0.01518638f, 0.32405788f, -0.35825527f, 
    -0.00496897f, 0.04004174f, -0.01998689f, 0.03232458f, 0.02669928f, -0.01786087f, 0.09054989f, 0.02722044f, 
    0.07267143f, 0.14015293f, 0.05597736f, 0.14876211f, -0.08683610f, -0.25580195f, -0.13440275f, -0.10530540f, 
    0.11587973f, 0.10903962f, 0.06110372f, 0.06024598f, 0.13436374f, 0.13783921f, -0.04084117f, 0.07841278f, 
    0.04897808f, -0.08735006f, -0.09163151f, 0.06309026f, -0.02139174f, 0.04861659f, 0.05476932f, -0.00026438f, 
    0.01738658f, 0.05259059f, 0.01580259f, -0.06393704f, 0.06391520f, 0.02183469f, -0.00825065f, 0.15296777f, 
    -0.01745857f, 0.01202659f, 0.04320757f, -0.08554173f, 0.07944898f, -0.11312714f, 0.07627522f, 0.15188599f, 
    0.03181983f, 0.08015948f, 0.08195620f, -0.03753812f, -0.09657315f, -0.13845666f, -0.08677193f, 0.09091491f, 
    -0.00067114f, 0.19526717f, -0.03849295f, -0.04225985f, 0.10267898f, -0.12630567f, -0.06479723f, 0.03264576f, 
    -0.08945908f, 0.05925038f, 0.12756875f, 0.08594606f, -0.16807020f, -0.12933619f, 0.31970522f, 0.19927505f, 
    0.03064570f, 0.19832192f, -0.16332226f, 0.13662820f, 0.02202878f, -0.05284239f, -0.05957632f, 0.02787240f, 
    0.01004429f, -0.05060332f, -0.01497601f, -0.03399161f, 0.04805462f, -0.00925380f, -0.03926625f, 0.07632929f, 
    0.00330710f, 0.07115161f, 0.04367995f, -0.01452153f, -0.51659209f, 0.46354121f, -0.37037322f, 0.08906013f, 
    -0.03092439f, 0.02949143f, 0.04671215f, -0.02688887f, 0.04071186f, -0.09265249f, 0.05593105f, -0.14379495f, 
    -0.31102920f, 0.20766413f, -0.20663591f, -0.16480254f, -0.00285242f, -0.05754201f, 0.04763464f, 0.06153684f, 
    0.04767358f, -0.17819037f, 0.16907550f, 0.12902337f, 0.14875683f, 0.06604851f, 0.17031266f, 0.00168270f, 
    0.05154961f, 0.09565176f, 0.04712652f, -0.08201868f, 0.01617911f, -0.06430246f, -0.05238369f, -0.10893207f, 
    0.17471819f, 0.19311786f, 0.12549756f, 0.22390988f, -0.05125441f, 0.07765642f, -0.08587911f, -0.04668669f, 
    -0.08880903f, -0.08573957f, -0.00037543f, 0.15561089f, -0.34522960f, 0.13234197f, 0.02089622f, -0.06838578f, 
    -0.06900306f, 0.12705864f, 0.01781034f, 0.15563883f, 0.08909494f, -0.19846000f, 0.01047627f, -0.05869394f, 
    -0.21689177f, -0.03297341f, -0.19990568f, 0.19608375f, -0.00740553f, 0.09014755f, 0.02086533f, 0.06184919f, 
    -0.02186782f, -0.17870083f, 0.04905616f, -0.08579426f, 0.02956937f, -0.00482761f, -0.01696000f, -0.05133689f, 
    0.06480095f, 0.08761650f, -0.01606771f, 0.19365677f, -0.04549064f, 0.13542874f, -0.16512130f, 0.03494041f, 
    -0.22813869f, 0.15456071f, 0.02208942f, 0.12245541f, 0.01463407f, -0.00833741f, -0.14651336f, 0.04904088f, 
    0.05640991f, -0.05561337f, 0.10574591f, -0.13121417f, -0.04846263f, 0.03437578f, -0.00373824f, -0.09918214f, 
    -0.04825989f, 0.02419705f, 0.00369077f, -0.07893562f, 0.00245566f, 0.00734220f, 0.03240141f, 0.00281315f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.03714615f, 0.00447326f, -0.06844384f, 0.02370373f, 0.24271928f, 0.05724188f, -0.03420969f, -0.05965513f, 
    0.03779470f, 0.23432472f, -0.04463890f, 0.00060563f, 0.00753897f, 0.12063276f, 0.02932086f, -0.06466445f, 
    0.11997408f, 0.01903402f, -0.02132959f, -0.03825718f, 0.07576888f, 0.19702889f, -0.02769023f, 0.04897749f, 
    0.01296614f, -0.07078248f, 0.01969700f, 0.09963547f, 0.07100239f, 0.01462340f, 0.02715857f, -0.07935377f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.14691915f, -0.07105369f, -0.14803794f, 0.10470334f, 0.10019807f, -0.14020805f, -0.07783350f, -0.24512988f, 
    0.00430725f, -0.06983294f, 0.03339067f, -0.15516140f, 0.21559674f, 0.15044491f, -0.10593519f, -0.07795212f, 
    -0.19184354f, 0.05968679f, -0.07587947f, -0.02577475f, 0.08098711f, 0.04897379f, -0.08007415f, 0.24029462f, 
    0.00040419f, 0.25718746f, 0.09574648f, 0.21527185f, -0.18001834f, 0.05593571f, 0.19244310f, -0.21675250f, 
    -0.19282986f, -0.06696245f, -0.02553408f, 0.10457067f, -0.12793891f, -0.04845487f, -0.09012524f, 0.07317001f, 
    -0.08613338f, 0.01477326f, -0.18096898f, 0.08835834f, -0.14935604f, -0.17632769f, -0.02590968f, 0.05661969f, 
    0.00080471f, -0.08216108f, 0.13394104f, 0.04151448f, -0.13512602f, 0.02502449f, 0.11384631f, 0.09837496f, 
    0.03702566f, 0.06982854f, 0.14923638f, -0.02879175f, -0.17275111f, 0.12103894f, -0.12579720f, -0.07046492f, 
    0.20291610f, -0.01162286f, 0.28397319f, -0.07383047f, 0.18277766f, 0.02694977f, 0.12195769f, 0.25926304f, 
    -0.26699221f, 0.10317838f, -0.06813229f, 0.10110800f, -0.17605525f, -0.06812852f, 0.20300515f, -0.07902163f, 
    0.37478119f, -0.39934942f, -0.06683214f, -0.08210231f, -0.06997594f, -0.06329025f, -0.04733817f, 0.16456090f, 
    0.00295016f, -0.17160033f, 0.11521164f, 0.15021077f, 0.18306810f, -0.09539198f, 0.28032070f, 0.18363577f, 
    -0.07856253f, -0.03443522f, -0.20264828f, 0.01680053f, 0.16786018f, 0.01124097f, 0.15934658f, 0.18062139f, 
    0.22238345f, -0.19695555f, -0.02625481f, -0.02360451f, 0.06008015f, -0.15729836f, -0.22324583f, 0.18067312f, 
    0.13227119f, 0.24730437f, -0.12257861f, 0.21139909f, -0.12644155f, -0.03639366f, 0.11086679f, -0.17722657f, 
    0.13641535f, -0.26115674f, -0.04316792f, 0.05331885f, -0.17270431f, 0.01514184f, -0.31445479f, 0.06397557f, 
    0.05011855f, -0.16708733f, -0.09285908f, -0.12450643f, 0.04972994f, 0.18706311f, 0.06644595f, -0.21724564f, 
    -0.02876447f, 0.21499883f, -0.19482113f, 0.04404598f, 0.16412145f, 0.18673371f, -0.32014439f, 0.43663099f, 
    -0.15109502f, -0.03133234f, -0.14884354f, 0.14925352f, 0.02378468f, 0.15480725f, -0.03975848f, 0.31505242f, 
    0.12339674f, 0.59477931f, 0.07266684f, -0.17900674f, -0.05160846f, -0.01233410f, 0.14063351f, -0.23969376f, 
    -0.05565587f, 0.16870540f, 0.08338155f, 0.12638903f, 0.19070713f, -0.15252693f, -0.05021779f, -0.23098490f, 
    0.08226784f, 0.18852377f, -0.08275640f, 0.11862323f, -0.20583388f, 0.14485520f, 0.03021253f, 0.39068413f, 
    0.08831152f, 0.08374742f, -0.11795393f, -0.21051864f, -0.14492583f, -0.08917539f, 0.01553596f, -0.12537153f, 
    0.15251476f, 0.20220599f, 0.12414061f, -0.30545995f, 0.18682994f, -0.07177404f, -0.18186556f, 0.14388730f, 
    -0.00201956f, -0.09094674f, -0.28194690f, -0.11217523f, 0.15717939f, 0.29315647f, -0.16583766f, -0.08967500f, 
    0.04574213f, -0.18986610f, 0.25605872f, 0.00702571f, -0.03531672f, 0.19229461f, -0.09049968f, -0.24501728f, 
    0.34695187f, 0.32508966f, 0.07231452f, 0.28741759f, 0.04867059f, 0.24751213f, 0.08839834f, -0.45961526f, 
    -0.05916134f, -0.44829717f, -0.06222413f, 0.16996129f, -0.22945972f, -0.04677778f, -0.08389241f, -0.11420198f, 
    -0.20308648f, 0.09439825f, -0.05047330f, -0.11212878f, 0.20506606f, -0.32284868f, -0.02494374f, 0.00473203f, 
    0.30269244f, -0.06153234f, 0.35311916f, -0.09150644f, -0.26394740f, 0.00244196f, 0.08709545f, -0.10042993f, 
    0.14031367f, 0.06455270f, 0.03926124f, 0.20396298f, -0.05796832f, 0.02480856f, 0.07622384f, -0.08256500f, 
    -0.16503486f, -0.17054299f, -0.06118844f, -0.00804547f, 0.29667550f, 0.12513709f, -0.06041793f, -0.07027669f, 
    -0.18616386f, -0.08800329f, 0.20676021f, -0.15567900f, 0.15678136f, -0.14327008f, -0.12697814f, -0.08915004f, 
    0.43922201f, -0.04124719f, 0.32956746f, 0.11212388f, 0.31108156f, 0.07919952f, -0.14183167f, -0.00624117f, 
    -0.15871856f, -0.06220190f, 0.00170098f, 0.23479381f, -0.04743356f, -0.07641635f, -0.12181421f, 0.04398655f, 
    0.04144762f, 0.08223511f, 0.09456593f, -0.08040031f, 0.13681065f, 0.09749760f, 0.16781217f, 0.18956640f, 
    -0.07757238f, -0.14428268f, 0.18301822f, -0.06188108f, 0.22563192f, 0.08594441f, 0.16752991f, 0.24597581f, 
    -0.21048942f, 0.02545975f, -0.32043430f, 0.03579648f, 0.05834320f, -0.08117286f, -0.04004403f, -0.15654132f, 
    0.21860069f, -0.13765916f, 0.00592160f, -0.29974732f, -0.19899783f, 0.04373836f, 0.04600243f, 0.10373713f, 
    -0.13172656f, -0.10171906f, -0.09851009f, 0.00242067f, 0.00064471f, 0.03898133f, 0.12162194f, 0.12209532f, 
    -0.10845333f, -0.16476075f, -0.09269559f, 0.10688566f, 0.14896677f, 0.02675357f, 0.09419928f, -0.05487229f, 
    -0.08760366f, -0.07018823f, -0.24080919f, 0.07928398f, -0.17125665f, -0.05078254f, -0.05893430f, -0.14683965f, 
    -0.04148510f, -0.23954138f, 0.05135189f, -0.08114998f, 0.11059890f, 0.06954413f, -0.07749646f, -0.04064032f, 
    0.14735831f, 0.00749364f, -0.04236468f, 0.04689791f, 0.03514713f, 0.09392960f, 0.03584452f, -0.05568277f, 
    -0.16876377f, -0.11970112f, 0.05097922f, 0.02391135f, 0.15295133f, -0.26123738f, -0.05499519f, -0.34867296f, 
    0.52606142f, 0.28026128f, 0.22321315f, 0.04219624f, 0.24544540f, 0.20013085f, -0.08378424f, -0.27376175f, 
    -0.20222124f, -0.00604621f, -0.00027420f, -0.11946820f, 0.06024213f, 0.11992440f, -0.13063866f, 0.35097733f, 
    0.13495021f, -0.23343816f, 0.09647995f, 0.12106911f, -0.15131484f, 0.01219545f, 0.13256736f, 0.32680079f, 
    0.16580385f, 0.05150931f, -0.04498819f, -0.03282694f, 0.02168571f, 0.19685051f, -0.09997676f, 0.47169080f, 
    -0.29252130f, -0.00535304f, 0.16574338f, -0.17131473f, 0.05051559f, -0.12245438f, 0.07886574f, 0.34567088f, 
    0.05130235f, -0.04844905f, 0.06309687f, -0.11405470f, -0.09364280f, -0.25464720f, -0.07874176f, 0.30906510f, 
    0.06509238f, 0.44604915f, 0.10190844f, -0.17580460f, 0.14100794f, 0.11108669f, 0.10792182f, 0.06191417f, 
    0.27205664f, 0.12644520f, 0.04126115f, -0.06773145f, 0.09927096f, 0.01377925f, -0.09471768f, -0.10001950f, 
    0.22304158f, 0.11903642f, -0.19647942f, -0.11190140f, -0.03170646f, 0.23885639f, -0.11665611f, 0.40276358f, 
    -0.33094430f, -0.15664224f, -0.13695025f, 0.09518272f, 0.12143497f, -0.32500991f, -0.17412186f, -0.08533598f, 
    -0.00944570f, 0.17623086f, -0.00336782f, -0.20745827f, 0.12529780f, -0.02605340f, -0.11029601f, 0.16927063f, 
    0.01240994f, 0.13607481f, -0.19587134f, 0.03033402f, -0.10125998f, 0.01408747f, -0.15202616f, 0.16952682f, 
    -0.01581119f, -0.14060082f, 0.08797804f, -0.05399700f, 0.14786643f, -0.01028316f, -0.14978912f, 0.21982087f, 
    -0.09182879f, -0.25679851f, 0.17284624f, 0.04320805f, -0.03816504f, -0.15735085f, 0.02586851f, 0.02795802f, 
    0.01515481f, 0.19210133f, 0.14694178f, -0.23837046f, -0.16159648f, -0.08021151f, -0.04798364f, 0.10522888f, 
    -0.03294529f, 0.10105775f, -0.10718902f, 0.12662503f, -0.04803399f, 0.04592691f, -0.08510879f, -0.32782161f, 
    0.18802020f, 0.36707911f, -0.46219084f, -0.03131763f, 0.25773966f, 0.23360591f, 0.11416334f, -0.00641443f, 
    -0.16847309f, -0.11955624f, -0.13713554f, -0.22649239f, -0.08473999f, 0.23582369f, 0.15774831f, 0.22158079f, 
    0.10683034f, -0.15265939f, -0.10646114f, 0.27642390f, 0.22205532f, 0.12036195f, 0.22765277f, -0.12973928f, 
    0.16151182f, 0.09832772f, 0.17649001f, 0.10606591f, 0.16579981f, -0.05810145f, -0.13682050f, 0.04253959f, 
    -0.22095467f, 0.31393477f, -0.32991219f, 0.12160195f, -0.31196812f, -0.09600100f, 0.13728802f, 0.12898591f, 
    0.59851754f, -0.05445994f, 0.03147979f, 0.06395946f, 0.27305147f, 0.21320328f, -0.12185950f, -0.15770288f, 
    -0.16709770f, -0.08246873f, -0.12715052f, 0.18287314f, 0.26702076f, -0.04172121f, -0.27330601f, -0.25164860f, 
    0.03751329f, -0.15398140f, 0.30262148f, -0.13413569f, 0.08746113f, -0.16811721f, 0.14635336f, -0.50502700f, 
    0.02817157f, 0.02503362f, -0.26877862f, 0.13415694f, -0.08859460f, 0.08528406f, 0.04846924f, 0.02396511f, 
    -0.30727440f, 0.38466340f, -0.17237097f, -0.21996960f, 0.23605852f, 0.10230824f, -0.17489941f, 0.05855479f, 
    0.12431397f, 0.20458740f, -0.07855279f, 0.01615896f, -0.04530301f, -0.13910790f, 0.26494741f, 0.07016182f, 
    -0.04059178f, 0.08846365f, -0.01581749f, 0.01618193f, 0.04984674f, -0.56673938f, 0.14313290f, -0.06418260f, 
    0.34177008f, 0.22274186f, 0.58350438f, 0.03699720f, -0.17449975f, 0.04504021f, -0.02424808f, -0.28219163f, 
    -0.23037328f, 0.22500031f, -0.12590002f, 0.09416145f, 0.17857052f, 0.02524846f, -0.17144893f, 0.03517783f, 
    0.04851814f, -0.08378242f, -0.10169676f, 0.13451028f, 0.16463383f, -0.04235186f, 0.24863385f, -0.04575755f, 
    0.13774909f, 0.11812876f, -0.04374139f, 0.12895578f, -0.01201771f, -0.07925836f, 0.15516923f, -0.02027181f, 
    -0.08495910f, -0.02978575f, -0.02159754f, 0.05178804f, -0.35173729f, 0.28432444f, -0.10045567f, 0.11178420f, 
    -0.01935233f, 0.07052445f, -0.07204458f, 0.10368997f, 0.16524298f, -0.11698680f, 0.05760199f, -0.31453291f, 
    0.05286206f, 0.05690718f, -0.16078441f, 0.18697324f, -0.03028982f, -0.10097105f, 0.21073863f, -0.39921635f, 
    -0.22872338f, 0.03046906f, -0.15108021f, -0.00098266f, 0.19453953f, 0.15019377f, 0.11813848f, 0.11230586f, 
    0.33323312f, 0.25571749f, 0.17930593f, -0.09729929f, 0.10096388f, -0.15968509f, -0.40255752f, 0.00178347f, 
    0.21723674f, -0.20363966f, -0.01688634f, -0.00075988f, 0.05545947f, 0.36584476f, -0.11803269f, 0.16520315f, 
    -0.16559400f, -0.21986654f, 0.04211475f, -0.11996562f, 0.16731559f, 0.04445669f, -0.17219348f, -0.05999326f, 
    0.09642200f, -0.06097384f, 0.11715583f, -0.00125703f, 0.16262980f, 0.27118069f, 0.06575262f, -0.03323695f, 
    -0.05547809f, -0.11611865f, -0.38071662f, 0.12759933f, 0.13031368f, -0.19414203f, -0.09885249f, 0.10285231f, 
    0.16605592f, 0.07591552f, 0.01938666f, 0.09315471f, -0.02340326f, 0.24874835f, -0.16928604f, 0.18337855f, 
    0.04758962f, 0.00100367f, 0.08375479f, -0.37782252f, -0.12266081f, -0.07695486f, 0.01876482f, 0.18992949f, 
    0.19911744f, 0.05666228f, 0.04724915f, -0.06872474f, 0.30228516f, -0.29592365f, 0.10220494f, 0.50079525f, 
    0.22508219f, -0.10643157f, 0.54314542f, 0.11397365f, -0.05361907f, -0.03392479f, -0.16983038f, 0.22745204f, 
    0.37384054f, -0.08849692f, -0.10084886f, 0.28220379f, 0.04339332f, -0.17614430f, 0.03737443f, -0.13220765f, 
    0.13154915f, 0.03507189f, 0.11138408f, -0.16387998f, -0.04173308f, -0.02831155f, -0.33220285f, 0.16620848f, 
    0.04923414f, 0.06639288f, 0.05335379f, -0.01214302f, -0.08668787f, -0.30081859f, -0.12604760f, 0.12912282f, 
    0.29456523f, -0.20491056f, 0.40843695f, 0.01234807f, 0.03211141f, 0.08729034f, -0.15510736f, 0.38274914f, 
    -0.32371899f, 0.22290403f, -0.03328645f, 0.11685841f, 0.21229412f, -0.33183613f, 0.00685980f, 0.07572287f, 
    0.13734044f, 0.06710745f, 0.12494333f, -0.03970659f, 0.02164679f, -0.04628468f, -0.29772082f, 0.14747880f, 
    0.16631101f, -0.09643164f, -0.02947455f, 0.13673057f, 0.14853328f, -0.37314987f, 0.04413816f, -0.01295222f, 
    -0.18201768f, 0.22661965f, 0.02504318f, -0.03912010f, -0.24201094f, 0.05467010f, 0.23072310f, -0.02922590f, 
    -0.06008837f, 0.28286606f, -0.08324194f, -0.13048369f, 0.20101221f, -0.23537004f, -0.07091406f, 0.04668414f, 
    0.01048824f, -0.02093494f, 0.04927493f, 0.28011763f, -0.11888288f, 0.14266413f, 0.11521791f, -0.15607975f, 
    -0.15521374f, 0.16236289f, 0.37398252f, -0.12205774f, -0.08307034f, -0.41519889f, 0.01152734f, 0.05808176f, 
    -0.13374814f, 0.01070614f, 0.44518521f, -0.14194404f, 0.03392838f, -0.36661884f, 0.05892258f, 0.11351480f, 
    -0.07856914f, -0.33462012f, -0.03733536f, 0.02516912f, -0.38726455f, -0.10813718f, 0.01556323f, 0.11077499f, 
    0.13915645f, 0.02966913f, -0.07234123f, 0.02510225f, 0.19804205f, 0.03829158f, 0.19237769f, 0.06155038f, 
    0.18385245f, 0.01202268f, 0.10573906f, -0.11418344f, 0.13435444f, -0.41764334f, 0.01867194f, -0.10893195f, 
    -0.30863556f, -0.01586358f, 0.22657438f, -0.04413643f, -0.12304071f, 0.02748126f, 0.25439343f, -0.15780795f, 
    0.13679120f, -0.07622813f, -0.16123495f, 0.18207736f, 0.16066167f, -0.18166636f, -0.06704859f, 0.17644900f, 
    0.15625612f, -0.08665430f, -0.09182663f, 0.27749971f, 0.12231802f, 0.13919748f, -0.01876245f, 0.06819830f, 
    0.08936305f, 0.17461027f, -0.23738769f, 0.17267184f, -0.04136551f, 0.07351507f, 0.04096336f, 0.41961247f, 
    0.10059233f, -0.21451978f, -0.13600065f, -0.05946073f, 0.23209487f, -0.15134285f, -0.09517179f, 0.24659576f, 
    0.25020343f, 0.12992716f, 0.13282853f, 0.19336644f, -0.18328805f, -0.20090966f, 0.03501002f, 0.15644853f, 
    0.16164124f, 0.00173431f, 0.03603463f, 0.13672389f, 0.02061117f, -0.10556007f, -0.24059367f, -0.29163903f, 
    0.14097971f, 0.12643145f, -0.21052931f, -0.15853184f, 0.26523903f, 0.16224283f, 0.14690416f, -0.34285793f, 
    0.14958784f, 0.23482482f, 0.01809659f, 0.13533001f, 0.07655583f, 0.00754264f, -0.03268838f, 0.08033964f, 
    0.02849982f, -0.09131075f, 0.07341044f, 0.06286303f, 0.30466709f, 0.20705995f, -0.13570371f, -0.08526618f, 
    -0.17060570f, -0.11769487f, -0.12382086f, -0.10700505f, 0.14719424f, -0.07493730f, -0.22926961f, -0.02770219f, 
    0.16962177f, -0.02404147f, 0.13679416f, -0.14766546f, 0.05050233f, 0.06823777f, -0.06458483f, 0.31125635f, 
    -0.20450397f, -0.17196071f, -0.19988668f, 0.15019742f, 0.25303546f, -0.04106149f, 0.22119373f, -0.11648256f, 
    -0.00069869f, -0.14492500f, 0.11807686f, -0.16811582f, -0.10265142f, -0.33026332f, -0.16903219f, 0.11343827f, 
    -0.07798512f, 0.35342997f, -0.12379046f, -0.12288941f, -0.19263898f, 0.09892070f, 0.19893284f, 0.04800866f, 
    -0.22576743f, 0.13720986f, 0.29453418f, 0.12834485f, -0.04619253f, 0.04920832f, 0.11879282f, -0.08258240f, 
    0.20838116f, -0.00874778f, 0.06651346f, 0.09818068f, -0.26615632f, -0.23133476f, -0.11559991f, 0.39143047f, 
    0.20004956f, 0.18829127f, 0.13553560f, -0.00358864f, -0.00341191f, 0.00970908f, 0.08848818f, -0.08255594f, 
    -0.13521543f, 0.07878573f, 0.05836473f, 0.16576436f, 0.20266327f, -0.03933933f, -0.03377720f, -0.04967326f, 
    -0.15888199f, -0.16984184f, -0.05564533f, 0.16070290f, -0.16057919f, -0.10500745f, 0.00184465f, -0.08220258f, 
    -0.08663451f, 0.07289194f, 0.11337221f, -0.02427528f, -0.08520728f, -0.06945999f, -0.18362394f, -0.03510288f, 
    0.02789166f, -0.02962616f, 0.13922194f, -0.16038716f, 0.03977738f, 0.05162495f, 0.07262885f, 0.07492782f, 
    -0.03095465f, -0.00559207f, -0.05792250f, -0.00158158f, -0.01087758f, 0.06349415f, -0.06421544f, -0.11025734f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.05970896f, -0.08167880f, 0.19703904f, 0.22093058f, 0.11768228f, 0.11896393f, 0.05231022f, 0.00909360f, 
    -0.00331570f, 0.10687671f, -0.14390518f, 0.11039931f, 0.14712472f, -0.07871891f, 0.07768598f, 0.34997448f, 
    0.27143589f, 0.15197422f, 0.07730605f, 0.13380243f, 0.15611146f, -0.13502973f, -0.16910471f, -0.13178833f, 
    0.14369017f, -0.05071835f, -0.06567530f, -0.16392253f, 0.30743369f, -0.22645517f, 0.13876194f, -0.05526553f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.22470392f, -0.05432340f, 0.16879044f, -0.08295017f, 0.11919329f, -0.01751808f, -0.20680222f, -0.68641877f, 
    -0.05180437f, 0.18513575f, -0.03316639f, -0.03345688f, 0.10892709f, 0.02271489f, 0.22632813f, -0.20009331f, 
    -0.62910795f, 0.02772060f, -0.36367890f, -0.19965112f, -0.17048791f, 0.24077305f, -0.19083019f, 0.13712320f, 
    -0.48315787f, 0.02601474f, -0.21709707f, 0.21948320f, -0.34690964f, 0.30372307f, -0.17392497f, 0.13018356f, 
    0.19547969f, 0.01642132f, -0.11401777f, -0.08374042f, 0.32734549f, -0.06948256f, 0.18430710f, -0.33086073f, 
    -0.08358082f, 0.14643931f, -0.37717533f, 0.16149941f, 0.08032412f, -0.04797082f, -0.00893008f, 0.20781028f, 
    -0.18245749f, 0.27826047f, -0.11971197f, 0.32061544f, -0.13753583f, -0.01951548f, -0.67939025f, -0.23602089f, 
    0.17236914f, -0.30350059f, -0.01357767f, -0.09658648f, 0.05467567f, 0.15261930f, -0.42095116f, -0.14996402f, 
    -0.02859545f, -0.11712544f, 0.30511352f, -0.16510788f, -0.43891233f, -0.23240498f, 0.00178846f, 0.16967036f, 
    -0.16994198f, 0.15715897f, 0.00686576f, 0.26211363f, -0.16035478f, -0.41992351f, -0.17521717f, 0.05114805f, 
    -0.00534419f, -0.34762645f, 0.26499781f, -0.69376349f, 0.14998993f, -0.08768310f, 0.19522123f, -0.33063492f, 
    0.04723671f, -0.25656566f, 0.29002282f, -0.02318293f, 0.10207967f, -0.10034131f, -0.51972592f, -0.06200997f, 
    0.02597281f, 0.01586546f, -0.08275647f, -0.28586179f, 0.04182859f, 0.10509419f, -0.41321638f, 0.14606625f, 
    0.22450845f, -0.22313814f, -0.19823620f, 0.00545299f, 0.08180151f, 0.01631149f, -0.26132432f, -0.47031903f, 
    -0.33735892f, -0.17598166f, 0.12519182f, -0.14981323f, 0.01146449f, -0.12238643f, 0.13597505f, 0.33685946f, 
    -0.15265273f, 0.25312072f, 0.12311732f, -0.08020177f, -0.07298870f, -0.09425764f, 0.02635968f, 0.10955689f, 
    -0.21912058f, -0.03122050f, 0.23773998f, 0.14369600f, -0.06236046f, 0.15698281f, 0.19319680f, -0.04214070f, 
    -0.09562758f, 0.26461127f, -0.18580909f, -0.14361276f, -0.01476957f, -0.12223025f, -0.11561862f, -0.26881486f, 
    -0.00751424f, 0.18386921f, -0.35567015f, -0.42274204f, -0.51796824f, 0.15699442f, 0.02295923f, -0.01247904f, 
    0.06584801f, 0.24031316f, 0.18555464f, -0.07337964f, -0.20423774f, 0.06221603f, 0.05173447f, -0.15071316f, 
    -0.48007354f, 0.13131435f, 0.04879283f, -0.14342695f, 0.18634197f, 0.31224266f, -0.11855603f, -0.16421276f, 
    -0.15893401f, 0.03062699f, -0.10448565f, -0.01263316f, 0.00201681f, 0.20317161f, 0.11847645f, 0.00983166f, 
    0.23945950f, -0.00951328f, -0.29152671f, 0.03633948f, 0.21279714f, 0.18445529f, -0.20908895f, -0.11340948f, 
    -0.25429684f, 0.01007635f, -0.23110214f, -0.10218360f, 0.32434833f, -0.27840421f, 0.02137761f, 0.06117700f, 
    -0.03986000f, 0.09334604f, 0.05347692f, -0.27414864f, -0.38792461f, -0.37907162f, 0.23007892f, 0.21131019f, 
    -0.34560281f, -0.15188777f, -0.00096017f, -0.18847881f, -0.55921370f, -0.69490284f, 0.03217227f, 0.00239703f, 
    0.20077324f, 0.17618194f, 0.32657191f, 0.03452968f, -0.24356595f, -0.22182943f, -0.29444689f, -0.41131648f, 
    0.13779014f, -0.48359317f, 0.20908767f, -0.24537320f, 0.17429563f, -0.33058196f, 0.14693725f, -0.06598998f, 
    0.00420249f, 0.05435549f, -0.30934459f, 0.26747176f, -0.03343409f, -0.25939596f, 0.27615383f, -0.09404136f, 
    -0.31978008f, -0.34557325f, -0.06002415f, -0.16954535f, 0.12013994f, -0.21683119f, -0.06575733f, -0.32329661f, 
    -0.00206883f, -0.44487229f, -0.11518218f, -0.06967664f, 0.08604055f, 0.03232607f, 0.36918229f, 0.25066882f, 
    0.11170418f, -0.10497421f, -0.19144525f, 0.27557904f, -0.01033562f, -0.12113953f, 0.04634056f, -0.12229836f, 
    0.12944461f, -0.02313159f, -0.63870722f, 0.12890707f, 0.12520000f, 0.01911670f, 0.14066097f, 0.17676227f, 
    0.17716114f, -0.29163632f, -0.16227968f, 0.20137070f, -0.50768483f, -0.06536061f, -0.14528461f, -0.02102415f, 
    -0.11188040f, 0.02076679f, -0.11470057f, -0.28044295f, 0.32668820f, 0.05120639f, 0.06903222f, 0.26878184f, 
    -0.13322408f, -0.48717511f, -0.50850093f, 0.04570717f, 0.18228473f, -0.28491628f, -0.02256050f, -0.09354050f, 
    0.06741533f, -0.11930611f, 0.19148792f, -0.16794865f, -0.08258013f, -0.11749261f, -0.15434435f, 0.04364714f, 
    -0.67260426f, 0.10402135f, -0.08999436f, -0.57240534f, 0.23012370f, -0.08782823f, -0.06393181f, 0.15253398f, 
    0.25581178f, -0.47005013f, -0.10963572f, 0.07430387f, -0.22899041f, -0.29442260f, -0.17179120f, -0.30847964f, 
    0.19107130f, -0.40083316f, 0.19891538f, 0.28243735f, -0.17599423f, -0.11290797f, 0.13594921f, -0.16387388f, 
    0.06259080f, 0.10072155f, 0.06231608f, -0.49421039f, -0.17093191f, -0.18543756f, -0.42916971f, 0.04423615f, 
    0.10196035f, 0.08520330f, -0.22798112f, 0.30527115f, -0.36233971f, -0.36068580f, -0.37352771f, 0.29147103f, 
    -0.27902839f, 0.24327432f, 0.28122243f, -0.38366765f, 0.36637005f, -0.01409169f, -0.57671416f, -0.26237267f, 
    -0.15311018f, 0.27683026f, -0.23998347f, -0.19632439f, -0.28157127f, -0.25974178f, 0.38534904f, -0.02024548f, 
    -0.11778126f, -0.04103614f, -0.11731593f, -0.27783486f, -0.28173828f, 0.28595358f, -0.27406394f, 0.00445299f, 
    -0.05954166f, -0.28037348f, -0.36988983f, 0.23711415f, -0.16311024f, 0.25054052f, -0.17428258f, -0.07348289f, 
    -0.04602458f, 0.42273289f, 0.27882397f, -0.00897755f, -0.32807791f, -0.37621146f, -0.10156955f, 0.34115914f, 
    0.17575294f, -0.43508437f, 0.04293716f, -0.48776421f, -0.00254468f, -0.12754314f, 0.07178308f, -0.13636361f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.15219173f, 0.13000518f, 0.08990910f, -0.20308116f, 0.03244833f, -0.05732150f, -0.00039596f, 0.04314062f, 
    -0.20786066f, 0.11015673f, -0.06648639f, -0.18516028f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
