#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.05267113f, 0.45903116f, 0.16694735f, 0.94961125f, 0.56344718f, -0.08084147f, 0.33726352f, -0.10274260f, 
    0.09311210f, -0.13432392f, -0.12052558f, 0.18293349f, -0.94056886f, 0.30202225f, -1.03324592f, 0.01961144f, 
    0.63464928f, -0.32099020f, 0.93324649f, 0.47824803f, 0.58345109f, -0.16639183f, -0.65559453f, -0.29385412f, 
    0.22281362f, 0.08455769f, -0.10593230f, 0.30453819f, 0.04853197f, 0.02118479f, 0.51713318f, -0.34060872f, 
    -0.55304033f, -0.44844627f, -0.17293130f, -0.51759976f, 0.06703370f, 0.45839685f, 0.78514922f, -0.21386820f, 
    -0.68026221f, -0.13100278f, 0.03226705f, 0.00551950f, 0.37913936f, -0.72506762f, 0.35140762f, 0.21263517f, 
    -0.31857118f, -0.53413308f, -0.43160582f, -0.53420049f, -0.23102354f, -0.80901843f, -0.00881955f, -0.27468303f, 
    0.14416324f, -0.54851127f, -0.24332070f, -0.46452951f, 0.56050390f, 0.02947656f, 0.95843196f, -0.98361480f, 
    -0.34514993f, 0.88088858f, 0.97109097f, 0.14870170f, -0.38150606f, -0.10682064f, -0.19221784f, -0.17431225f, 
    0.57678193f, 1.08119178f, -0.86642963f, -0.45563322f, 0.34596425f, -0.39263985f, 0.15218487f, 0.12890457f, 
    0.58480239f, 0.30539909f, 0.52998936f, 0.21985687f, -0.10047091f, -0.08040999f, 0.97225398f, 0.29857638f, 
    -0.43135127f, 0.05037580f, -0.48390535f, -0.60785252f, -0.19055721f, -0.08256090f, -0.94616693f, -0.63744146f, 
    -0.16141628f, -0.09798163f, 0.47704735f, -0.74252558f, -0.67965335f, -0.34471208f, 0.58250946f, 0.03030563f, 
    -0.44218174f, 0.34328642f, 0.73069280f, -0.30536783f, -0.25373289f, 1.08157086f, -1.39412475f, 0.53035182f, 
    -0.07049932f, 0.07201914f, 0.00131048f, 0.16852257f, 0.06360608f, -0.49372533f, -0.71143246f, -0.58122975f, 
    0.60678548f, 0.31250921f, 0.46058112f, -0.54397190f, -0.37048578f, -0.57696480f, 0.05641472f, 0.00640674f, 
    0.63868403f, -0.59955847f, 0.20361713f, 0.47550416f, 0.51984841f, -0.22523056f, -0.17585188f, -0.13803041f, 
    0.34824318f, 0.45749182f, 0.38626146f, 0.37584198f, 0.26416790f, -0.00841904f, -0.60721260f, -0.51908547f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.17533420f, 0.41456524f, -0.11074961f, 0.33819485f, 0.46088719f, 0.01194990f, 0.14803606f, -0.02985183f, 
    0.26598573f, -0.15989143f, -0.13421097f, -0.13127592f, 0.22608700f, 0.08453375f, 0.77328247f, 0.56863827f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.20142551f, -0.23842959f, -0.23616827f, 0.02962151f, 0.02703967f, -0.14072029f, 0.10700563f, -0.02405885f, 
    -0.06740040f, 0.53139287f, 0.04006777f, -0.31623951f, -0.09200605f, -0.09703476f, 0.06169514f, 0.02815750f, 
    -0.00782269f, 0.10214471f, -0.53834808f, -0.25077572f, -0.37579042f, -0.21163093f, -0.30215868f, -0.01514307f, 
    -0.23573689f, 0.02790733f, -0.16387479f, 0.18434952f, 0.18595722f, 0.34428024f, -0.15897265f, 0.07102948f, 
    0.19255719f, 0.07304558f, 0.27465236f, 0.08988520f, 0.13800898f, 0.12432870f, 0.17866161f, -0.12765054f, 
    -0.09320203f, -0.12543061f, 0.23656909f, 0.05753544f, 0.09762431f, 0.36087063f, 0.39113632f, 0.20614970f, 
    0.07782485f, -0.08031214f, -0.01029857f, -0.16410357f, -0.12986900f, -0.02687292f, 0.20908144f, 0.21183822f, 
    -0.26751953f, -0.17264260f, -0.09142531f, 0.11376261f, 0.26129398f, 0.05698704f, 0.30750659f, -0.18823740f, 
    0.97081292f, -0.28916493f, 0.06943692f, -0.27772635f, 0.23234032f, 0.08744156f, 0.25496984f, 0.11833534f, 
    -0.50588602f, -0.04535454f, -0.19098042f, -0.10840622f, -0.09426727f, -0.23348135f, 0.06061669f, 0.02334580f, 
    0.16311079f, 0.13276568f, -0.20711425f, -0.19860414f, -0.31533954f, -0.05058718f, -0.52154392f, 0.34240785f, 
    0.04394648f, -0.17745495f, 0.27710053f, 0.03154832f, -0.06455835f, 0.11009721f, -0.13447925f, -0.10691046f, 
    -0.09618552f, 0.04051869f, 0.04983782f, -0.09815599f, -0.19081821f, -0.16339284f, 0.07520385f, -0.25075501f, 
    0.18304177f, -0.07741225f, -0.09390336f, 0.18382964f, -0.30251482f, -0.48240849f, -0.51599848f, 0.19113703f, 
    -0.00462267f, -0.03240166f, 0.03823888f, 0.10897734f, 0.11234720f, 0.04073310f, 0.30728278f, -0.11305623f, 
    0.17108977f, 0.13663420f, 0.24450542f, -0.12050215f, 0.15593834f, 0.12076945f, 0.48198482f, -0.10190819f, 
    -0.12735620f, 0.19615845f, 0.26926339f, -0.19729947f, 0.22458571f, 0.19011949f, 0.15266119f, -0.01261019f, 
    -0.23133767f, -0.11555381f, -0.03875546f, 0.16074677f, -0.08764197f, 0.15403400f, 0.04427518f, 0.24468152f, 
    0.00238250f, -0.02055879f, 0.08924743f, -0.06163881f, -0.28476098f, 0.02677492f, 0.02507674f, -0.04825959f, 
    -0.05414018f, -1.01166892f, -0.32273152f, -0.46734226f, 0.04203067f, 0.06093464f, -0.04616661f, -0.02334904f, 
    0.02757497f, -0.08413960f, 0.39114830f, -0.72370297f, -0.14223579f, 0.23043698f, 0.06214842f, -0.17485349f, 
    0.00988075f, -0.00808863f, -0.21014892f, 0.00427334f, -0.08143556f, -0.20056973f, 0.02950544f, -0.01795879f, 
    0.14555019f, 0.20778099f, -0.05566436f, 0.17437951f, 0.30788490f, -0.35731637f, -0.04891270f, -0.01511159f, 
    0.13245505f, -0.21896312f, 0.24397044f, 0.03429551f, 0.07255135f, -0.16270664f, -0.47096702f, -0.36470577f, 
    0.05163452f, 0.06121718f, 0.16486207f, -0.12633267f, -0.08281511f, -0.00262997f, -0.01554063f, 0.05941932f, 
    -0.21398874f, -0.28209662f, 0.06250948f, 0.06117345f, -0.03492408f, -0.19500874f, -0.20808795f, 0.02085037f, 
    -0.00424503f, 0.04234971f, 0.01923057f, -0.10548397f, 0.08579755f, 0.05479992f, 0.11378419f, 0.06090786f, 
    0.34874278f, -0.07568487f, -0.02020058f, 0.05739097f, 0.04474503f, 0.19771872f, 0.21498612f, 0.13504136f, 
    -0.21668938f, -0.08449749f, 0.20153871f, 0.18633322f, -0.01928006f, 0.00126210f, -0.11115031f, 0.19336277f, 
    0.01065245f, 0.20423400f, -0.34908837f, -0.33546561f, 0.07588268f, -0.06654248f, -0.04837785f, -0.37639260f, 
    0.09151156f, -0.03993044f, 0.03793101f, -0.52622366f, -0.27166319f, 0.71640968f, -0.02564799f, -0.05365354f, 
    -0.14855877f, 0.02015630f, 0.04576158f, 0.11533923f, 0.49650449f, -0.13589074f, -0.38651529f, 0.00354215f, 
    0.04760370f, 0.20470941f, 0.00964189f, 0.00942123f, 0.09738227f, -0.18839155f, -0.05669680f, -0.05936234f, 
    0.03278932f, -0.15049778f, 0.09509271f, -0.06777400f, 0.20055829f, 0.27251121f, 0.16148128f, 0.02852452f, 
    -0.18419798f, 0.11221228f, 0.13777220f, 0.07666797f, 0.10655397f, 0.02428331f, 0.27406633f, 0.04929461f, 
    0.29821411f, 0.26030454f, -0.02745410f, -0.00625964f, -0.00749203f, 0.12237270f, 0.10161972f, 0.14895953f, 
    0.03318628f, 0.00132186f, -0.07628943f, -0.01862463f, -0.02827719f, -0.07007861f, 0.01264244f, 0.00232562f, 
    -0.08669072f, -0.02966618f, -0.07613282f, 0.03263057f, 0.00582031f, -0.09043211f, 0.05212107f, -0.08020121f, 
    -0.09409372f, 0.00039054f, -0.06173949f, -0.05669398f, -0.00737464f, -0.07033542f, 0.05434446f, -0.04345283f, 
    -0.09441049f, 0.03467568f, 0.06849673f, 0.01517388f, -0.05383137f, 0.04579379f, -0.03273199f, 0.05116242f, 
    0.04487597f, 0.05423112f, -0.01393277f, -0.07650038f, 0.03465737f, 0.05853376f, 0.01614060f, -0.01183782f, 
    0.06725896f, 0.04077996f, -0.06061009f, 0.05326468f, -0.03584669f, -0.00984255f, -0.07124849f, -0.07327455f, 
    -0.02661263f, -0.07925045f, -0.00631651f, 0.00188471f, -0.02433899f, 0.02604808f, -0.00961192f, -0.03542517f, 
    0.01764421f, -0.03930944f, -0.00555383f, 0.06783717f, -0.02681226f, -0.03647530f, -0.00816911f, 0.05054874f, 
    0.06922267f, -0.04332929f, 0.02538015f, 0.00942413f, -0.05686343f, -0.04636067f, 0.03163692f, -0.08465113f, 
    -0.08599424f, 0.02283271f, 0.00800901f, 0.04133651f, -0.03230880f, 0.00275606f, 0.06623912f, 0.06951651f, 
    -0.04935985f, -0.08466899f, -0.04717320f, -0.06288498f, -0.06657587f, 0.06298138f, 0.02491890f, 0.06027158f, 
    -0.03411583f, 0.05480544f, 0.06114957f, -0.02886963f, -0.05998980f, 0.03260727f, 0.06129244f, -0.03614888f, 
    -0.04107017f, -0.00035180f, -0.04544426f, 0.05719475f, 0.03108755f, 0.05047585f, -0.06358954f, -0.07692850f, 
    0.03589088f, 0.00784296f, 0.06330651f, -0.07051793f, -0.07994022f, -0.09354737f, -0.03176031f, -0.03484554f, 
    -0.00841078f, -0.08651274f, -0.01838835f, -0.03242329f, -0.04801473f, -0.00885324f, -0.00392157f, 0.01810252f, 
    -0.05549873f, -0.01790623f, -0.02439968f, 0.03268724f, 0.00578314f, -0.02462468f, 0.01923290f, -0.02912540f, 
    0.04856293f, -0.02193355f, -0.05911262f, -0.06715944f, -0.01560382f, 0.06835070f, -0.03288212f, -0.04551437f, 
    0.02589029f, -0.09035564f, 0.04678186f, 0.03537485f, -0.05121757f, 0.03245032f, 0.01222653f, -0.06932805f, 
    0.22968082f, 0.07989772f, 0.23953626f, -0.26606494f, -0.00583298f, -0.15701559f, -0.09543753f, -0.31781948f, 
    -0.04094079f, 0.01585324f, 0.09897951f, 0.09519995f, 0.12412873f, -0.24078183f, 0.00230818f, -0.02594984f, 
    -0.04151311f, 0.11693417f, -0.04066018f, 0.00120154f, 0.03319322f, -0.19823730f, -0.31801927f, 0.02751153f, 
    0.04262004f, -0.04757325f, 0.31355357f, 0.11643191f, -0.16333207f, -0.12357196f, 0.05027206f, -0.06305011f, 
    0.07435259f, 0.04811076f, 0.11050737f, 0.11087139f, -0.21426152f, 0.00788192f, 0.11812612f, 0.01773211f, 
    -0.11746201f, 0.11578219f, 0.18735904f, 0.09041669f, 0.13973148f, -0.15934782f, 0.23187743f, -0.22032464f, 
    -0.02908243f, -0.09766822f, -0.07158188f, 0.04051576f, 0.10392773f, -0.00334785f, -0.20114000f, -0.22547472f, 
    -0.23324922f, 0.08703328f, -0.01826183f, 0.11082793f, -0.05511585f, 0.31868154f, 0.39249250f, 0.23264246f, 
    -0.34729710f, 0.18379536f, -0.11637648f, 0.15409012f, -0.08877574f, -0.02270190f, 0.05530369f, -0.16856384f, 
    -0.25029644f, -0.40508386f, -0.02281899f, 0.07218483f, 0.08996020f, -0.07585860f, 0.01259486f, -0.01182871f, 
    0.12178332f, 0.22407313f, 0.46678519f, 0.26481611f, -0.06017526f, -0.06206214f, -0.16474685f, -0.11573827f, 
    -0.01655897f, -0.10617758f, -0.11085836f, 0.18528996f, 0.11988619f, -0.09083652f, 0.11206415f, -0.09208259f, 
    0.08783331f, 0.01903977f, -0.02969418f, -0.03714858f, -0.02262652f, -0.02804559f, -0.19584651f, 0.23151609f, 
    0.06206760f, -0.03601400f, -0.05877614f, 0.13634364f, 0.00239221f, -0.36714312f, -0.41535553f, -0.13142179f, 
    -0.00291628f, -0.02281687f, 0.13055582f, 0.08901166f, -0.06418316f, -0.10490559f, 0.19777171f, -0.20002300f, 
    -0.13670680f, -0.15488821f, -0.12030222f, -0.02698038f, -0.34230366f, -0.32404786f, 0.16606499f, 0.18395011f, 
    0.13550980f, 0.29364690f, 0.08011571f, 0.02483464f, 0.05299110f, 0.13448463f, 0.16729344f, 0.07814834f, 
    0.27314427f, 0.32777599f, -0.06464111f, -0.08718492f, -0.01386254f, -0.01838731f, -0.05061905f, 0.04331842f, 
    -0.01380417f, 0.31766126f, 0.30662376f, -0.12323949f, -0.12160240f, -0.02578551f, 0.08703186f, 0.10472332f, 
    -0.08312543f, 0.17823297f, -0.00706288f, -0.20109671f, -0.06004563f, 0.00505045f, 0.01644275f, 0.01601393f, 
    0.00231108f, -0.07295062f, -0.04235172f, -0.55970210f, 0.22233491f, 0.17050552f, 0.00520727f, 0.11057027f, 
    0.15602627f, -0.04134639f, 0.05768843f, -0.32008868f, 0.01561529f, -0.04615341f, -0.08960940f, 0.00119605f, 
    0.01080136f, -0.03780216f, -0.02597293f, -0.00035600f, 0.04376492f, -0.50718427f, 0.03665170f, 0.07527573f, 
    -0.04848980f, 0.02926124f, 0.14315906f, 0.08105362f, 0.02267700f, -0.07448963f, -0.37388805f, -0.04254116f, 
    -0.09959406f, 0.12881362f, 0.00456437f, 0.16480587f, 0.11761014f, -0.04407335f, 0.09451169f, -0.23668107f, 
    -0.04444108f, -0.15720153f, 0.07010802f, -0.14318295f, 0.14586008f, 0.06490423f, 0.03474031f, -0.37820575f, 
    -0.06247358f, 0.13333669f, 0.20956251f, -0.34050101f, 0.15635771f, 0.06221558f, -0.03054605f, -0.09325209f, 
    0.47352597f, -0.44819486f, -0.54605013f, -0.07172919f, 0.00426339f, -0.00269987f, 0.17002328f, 0.05088559f, 
    -0.05869769f, -0.15327586f, -0.18231283f, 0.08536960f, 0.01724353f, 0.23726824f, -0.11782331f, -0.00978474f, 
    0.15170509f, -0.00162486f, 0.24021029f, 0.61491418f, -0.09227112f, -0.24353835f, 0.00396724f, 0.03938231f, 
    0.05692083f, 0.03283662f, -0.08905168f, -0.19946921f, 0.50180781f, -0.41308123f, 0.02323064f, -0.52529383f, 
    -0.22027895f, 0.06815553f, 0.07979940f, 0.04654134f, -0.07642698f, -0.05924618f, -0.83200687f, -0.00190592f, 
    -0.08475903f, -0.05902794f, 0.09843475f, -0.02748807f, -0.03225117f, 0.34110206f, 0.25613603f, 0.15775645f, 
    -0.41852206f, -0.23134147f, 0.06587428f, -0.15538515f, 0.05061680f, 0.00683260f, -0.29254603f, -0.18819055f, 
    0.30680954f, 0.24899232f, 0.08568726f, -0.06356153f, 0.17042568f, -0.02251443f, -0.07716931f, 0.29380295f, 
    0.19070472f, 0.27516633f, 0.03459685f, 0.05703029f, -0.12867662f, -0.17540362f, 0.10839728f, 0.13267560f, 
    -0.34838438f, -0.33610791f, -0.20702849f, 0.06536544f, -0.21589896f, -0.18258834f, 0.06953561f, 0.03089406f, 
    0.13846925f, 0.05272364f, 0.11013212f, 0.41294944f, -0.22592941f, -0.06896539f, -0.12220275f, -0.07306994f, 
    0.12385192f, -0.07738303f, -0.05308561f, -0.58556342f, -0.24458551f, -0.31076446f, 0.03012707f, -0.17620522f, 
    -0.10505638f, -0.10652487f, 0.16236120f, 0.14761831f, 0.43490157f, 0.11659691f, 0.11859059f, 0.20341922f, 
    0.04161878f, 0.19759849f, -0.24304305f, -0.23078400f, -0.14041919f, -0.40967968f, -0.37478608f, -0.15631656f, 
    -0.07972538f, -0.02374672f, -0.21895380f, 0.11182526f, -0.07623804f, -0.12035573f, 0.06475469f, 0.40071991f, 
    0.08254317f, -0.02894951f, 0.01584617f, 0.15016297f, -0.05239920f, -0.08502889f, 0.08408877f, 0.32216331f, 
    0.20363316f, -0.06536451f, -0.04495466f, -0.09894473f, -0.12046490f, -0.32703996f, 0.11190202f, -0.26695332f, 
    -0.28438643f, 0.15964778f, -0.14986134f, 0.11127621f, -0.10077535f, 0.10690926f, 0.17764281f, 0.08447987f, 
    0.26130649f, 0.02333642f, -0.28667575f, 0.08965454f, 0.07274702f, 0.05677254f, 0.03762835f, -0.03530451f, 
    -0.05782819f, 0.16093256f, -0.65956914f, -0.68920034f, 0.09198792f, -0.10892801f, 0.10331971f, 0.03202836f, 
    0.15879239f, 0.16335155f, 0.28321531f, 0.23272213f, 0.31626642f, -0.03176962f, 0.06998789f, -0.20891784f, 
    -0.03750059f, -0.07057708f, 0.14989181f, 0.11624536f, -0.16321453f, -0.02702154f, 0.30228534f, 0.14098008f, 
    0.04902395f, 0.00878221f, -0.13686191f, 0.32097095f, 0.48904085f, 0.38324568f, -0.51860774f, -0.35696819f, 
    0.20900531f, 0.22559135f, 0.06660476f, 0.08446956f, -0.02914359f, 0.19379744f, 0.37294444f, -0.09634836f, 
    0.30426976f, 0.15253186f, 0.12285186f, 0.15203643f, 0.03310640f, 0.17259254f, -0.02843372f, 0.06549993f, 
    0.05900051f, 0.26347256f, -0.05523980f, 0.01168355f, 0.06615578f, 0.10100991f, -0.05967934f, 0.13536486f, 
    -0.04181077f, 0.07563000f, 0.21000893f, -0.13706216f, -0.16437453f, -0.15972602f, 0.00188701f, 0.11495410f, 
    0.12345772f, 0.21217746f, 0.28169057f, -0.35651153f, -0.07240558f, -0.28302225f, -0.06524795f, -0.08470032f, 
    -0.01211070f, 0.10155569f, 0.08149605f, -0.04225561f, -0.06151336f, -0.23230109f, 0.11148211f, 0.01768239f, 
    -0.02155289f, -0.02704067f, -0.41491225f, -0.20442103f, 0.00459085f, -0.20762172f, 0.08663262f, 0.10873606f, 
    0.25111130f, -0.14809136f, -0.04332045f, -0.09439614f, -0.22540906f, 0.07955012f, -0.12264063f, -0.15234943f, 
    -0.19410121f, -0.04053510f, 0.01917144f, 0.06122128f, -0.13382117f, 0.08015845f, -0.02830310f, -0.31574947f, 
    0.09867883f, -0.25230670f, -0.05437553f, 0.07500216f, 0.04427581f, 0.37323028f, -0.25459379f, -0.06396595f, 
    0.04667119f, 0.05867381f, -0.10028230f, -0.05379821f, -0.01822274f, -0.08377675f, 0.16919282f, 0.38795274f, 
    0.27286568f, 0.10868366f, 0.11968299f, 0.09823142f, 0.10432123f, 0.02862829f, 0.21787620f, 0.76632744f, 
    -0.08680362f, -0.14523551f, -0.28045976f, 0.15591161f, -0.22577961f, -0.09131242f, 0.10497957f, -0.07303108f, 
    -0.34915462f, 0.06981780f, 0.47376642f, -0.02587172f, 0.38083944f, 0.03408213f, -0.26289314f, -0.14477395f, 
    0.12675706f, 0.07304282f, 0.28203794f, 0.19999424f, 0.04545357f, -0.04375824f, -0.15953772f, 0.13442984f, 
    -0.09710985f, 0.10478286f, 0.40763950f, -0.14613706f, -0.23419355f, -0.03926260f, 0.15136096f, 0.07232250f, 
    0.04056165f, 0.08570627f, 0.04356561f, 0.68679059f, 0.13638005f, -0.13339773f, -0.01456250f, 0.00779037f, 
    0.05508193f, 0.05844437f, 0.11351239f, -0.05547127f, -0.32148522f, -0.28151184f, 0.28787580f, -0.02952749f, 
    0.26639983f, 0.24032836f, -0.11392162f, 0.02375103f, 0.04717984f, 0.26771647f, 0.02281966f, -0.22030950f, 
    -0.11199051f, 0.10030612f, -0.14200677f, 0.00467551f, -0.04980685f, 0.08144454f, -0.30204105f, 0.22551119f, 
    0.11177982f, -0.15417528f, 0.06243569f, -0.13781667f, -0.05317217f, -0.10438386f, 0.04014957f, -0.15419883f, 
    0.01263698f, -0.03772760f, 0.12561709f, -0.11926398f, -0.07812945f, -0.23454325f, -0.00071498f, 0.01033824f, 
    -0.01058953f, 0.01447799f, 0.04205613f, -0.03720074f, -0.04738211f, -0.01520473f, 0.05560436f, 0.06065280f, 
    0.07419156f, -0.03236363f, -0.00871154f, -0.00026256f, -0.00713998f, -0.08315312f, 0.03791759f, -0.05555254f, 
    0.06067535f, 0.04902349f, 0.05735214f, 0.03927578f, -0.02444451f, 0.02104961f, -0.04787658f, -0.06301007f, 
    -0.02218085f, 0.02119999f, -0.02247300f, -0.06525974f, -0.03665828f, -0.00493933f, -0.09058098f, 0.04754504f, 
    -0.05567746f, -0.02504497f, 0.04263059f, 0.04024127f, -0.01896341f, -0.09072383f, 0.00160814f, -0.07770980f, 
    0.01846833f, -0.03902606f, -0.09258323f, -0.05189272f, 0.02683662f, 0.02426373f, 0.03739529f, -0.04494829f, 
    -0.07686636f, -0.07094451f, -0.09289762f, -0.07951833f, -0.01787561f, -0.02891781f, -0.08555786f, -0.07244922f, 
    0.05624067f, -0.08032828f, -0.08680166f, -0.08584365f, -0.07433831f, 0.02002716f, -0.00392901f, -0.05386281f, 
    0.07496417f, -0.03859499f, -0.06185811f, -0.00172360f, -0.08011879f, 0.04425944f, -0.08713798f, 0.00965873f, 
    -0.04120522f, 0.04883298f, -0.02119268f, -0.06054757f, -0.03930047f, 0.00355990f, -0.00953409f, 0.05454946f, 
    -0.02774670f, -0.07655778f, 0.04802584f, -0.03374773f, -0.04349218f, -0.02287867f, 0.05445736f, -0.09621405f, 
    0.01536764f, 0.00317906f, -0.07002930f, -0.07069636f, -0.05232051f, 0.00378241f, 0.06440607f, -0.06962781f, 
    0.02730177f, -0.00849587f, 0.02177647f, 0.03972856f, 0.05905563f, 0.06603058f, -0.07065799f, -0.01240310f, 
    0.02264125f, -0.02456891f, 0.03909516f, 0.03722078f, 0.05003838f, -0.08636072f, -0.01579605f, -0.02515509f, 
    -0.07497165f, -0.07729898f, -0.03637791f, -0.08952208f, -0.03586815f, -0.05023814f, -0.02817699f, -0.00608865f, 
    -0.09225810f, 0.01987659f, -0.09535988f, -0.03559621f, -0.03270744f, -0.03979790f, -0.07267694f, -0.02363762f, 
    0.00349951f, -0.06978838f, 0.02769300f, -0.09407587f, 0.06855740f, -0.08403952f, 0.03920736f, -0.07668506f, 
    -0.08612754f, -0.07584570f, -0.04849590f, -0.04922363f, 0.03534769f, -0.03911604f, -0.08230113f, 0.05486162f, 
    0.09158771f, 0.27596888f, -0.05596270f, -0.21283586f, 0.01637820f, -0.18845269f, 0.07730476f, 0.00298652f, 
    -0.18777774f, -0.27326286f, -0.48245734f, -0.02224417f, 0.21922582f, 0.08976328f, 0.20507407f, 0.01989024f, 
    0.15012254f, 0.08098251f, 0.45814672f, 0.13787556f, 0.26563451f, -0.06444968f, -0.35538399f, -0.20069544f, 
    -0.00878641f, 0.06514391f, -0.00722345f, -0.20698561f, 0.31488791f, 0.11809490f, 0.13013892f, 0.05491663f, 
    0.10250239f, -0.08130988f, -0.21021932f, -0.00264658f, 0.48097840f, 0.17767438f, 0.26957753f, 0.15782307f, 
    -0.02161390f, -0.04395650f, 0.05175836f, 0.08909908f, 0.02289763f, 0.29996467f, 0.36137339f, 0.22866945f, 
    -0.06295542f, -0.18545118f, 0.00017355f, 0.05176531f, -0.04835254f, 0.04488787f, -0.09784634f, -0.53095049f, 
    0.16014980f, -0.02761611f, -0.24032474f, -0.22001466f, 0.19842596f, 0.00976696f, -0.03303000f, -0.91070229f, 
    -0.49874067f, -0.83174157f, 0.14922059f, -0.13623725f, 0.29742804f, 0.03922235f, -0.04927789f, -0.14613301f, 
    0.41866556f, 0.14131790f, 0.47604457f, 0.09616796f, 0.15727319f, 0.08345432f, -0.06363665f, 0.28118300f, 
    -0.07777052f, 0.15497293f, -0.04662982f, 0.41670221f, -0.19891742f, 0.01974950f, -0.43599051f, -0.06069731f, 
    -0.33421448f, -0.06991091f, 0.42975819f, 0.05862091f, -0.17507896f, -0.09890577f, -0.23129550f, -0.05851344f, 
    0.03464366f, 0.09300607f, 0.05817377f, 0.18498306f, -0.15087754f, -0.30933920f, -0.15381536f, 0.20568006f, 
    -0.06395878f, 0.01788995f, -0.12171961f, 0.09721408f, -0.61448812f, -0.44973007f, -0.57574666f, -0.08842921f, 
    0.09668736f, 0.17421027f, 0.10639818f, -0.01465804f, -0.26619035f, 0.01511312f, -0.52230406f, -0.41262203f, 
    -0.16627268f, -0.11229099f, 0.09052161f, -0.09979639f, -0.13884693f, 0.20101230f, 0.07110900f, 0.28959021f, 
    0.24200697f, -0.10838382f, -0.05185961f, 0.09461816f, 0.12932341f, 0.34032500f, 0.23410749f, 0.00899407f, 
    0.08512508f, -0.05603680f, -0.08083493f, 0.02289664f, -0.04236228f, 0.04379686f, -0.00969565f, 0.30789524f, 
    0.02586633f, 0.23124331f, -0.56443185f, 0.08335627f, -0.44435534f, 0.15681361f, 0.09954123f, 0.16252644f, 
    0.00571300f, 0.16015045f, 0.00020695f, 0.21462029f, -0.19365913f, 0.17323785f, 0.05599552f, 0.03835738f, 
    0.11206064f, -0.02905414f, 0.10688138f, -0.35520190f, 0.03472085f, -0.01845271f, 0.25439715f, -0.03434427f, 
    -0.26057163f, 0.22139569f, 0.30432597f, -0.20211348f, -0.09916949f, -0.20373218f, -0.05965635f, 0.06675702f, 
    -0.08422410f, 0.07239552f, -0.05446323f, -0.01490566f, -0.08661720f, -0.13168092f, -0.21331643f, -0.09789748f, 
    0.10860024f, -0.14459577f, -0.09389479f, -0.02495461f, -0.08099679f, -0.11494862f, -0.04126257f, 0.14189497f, 
    -0.04865338f, 0.03678792f, -0.09382548f, 0.10822450f, -0.06623327f, 0.08895749f, 0.00088518f, 0.24544187f, 
    0.17968996f, -0.19699177f, 0.16931348f, -0.16953938f, -0.01719210f, 0.33191022f, 0.10742702f, 0.28940371f, 
    -0.22673291f, -0.46169063f, -0.33791673f, -0.02896319f, 0.25013578f, 0.07875694f, 0.09415402f, -0.08588036f, 
    -0.51623601f, -0.51017821f, -0.68186677f, 0.33387208f, -0.05975253f, -0.09284942f, 0.12560056f, 0.18068597f, 
    0.08440336f, -0.24536371f, -0.23294410f, -0.47130978f, 0.08243287f, -0.39730260f, -0.11490350f, 0.09732807f, 
    -0.04149344f, 0.09846823f, 0.37355328f, 0.48091218f, 0.22416888f, -0.30655766f, 0.11984307f, -0.02156374f, 
    0.04047254f, 0.09632400f, 0.13962701f, 0.45199284f, 0.27791542f, 0.26040396f, -0.00332045f, -0.14525156f, 
    -0.16809870f, 0.14497602f, 0.11488266f, 0.06373913f, -0.34613541f, -0.57185858f, -0.73501223f, -0.17187971f, 
    -0.40830082f, 0.18855077f, 0.13547343f, 0.17173202f, -0.05101269f, 0.21772628f, 0.03835021f, 0.13544749f, 
    -0.08722186f, 0.04912086f, -0.01683483f, 0.07478982f, -0.02660148f, -0.00464549f, -0.58275449f, 0.03392776f, 
    0.32876191f, -0.13486847f, -0.08383545f, -0.15482661f, 0.12855881f, 0.01008797f, 0.13653426f, -0.16058461f, 
    -0.05427795f, -0.25637341f, -0.12702830f, -0.37182048f, -0.21030827f, 0.12109707f, -0.07454053f, -0.09837141f, 
    -0.05439937f, 0.03179562f, -0.02013278f, 0.02805627f, -0.07836270f, 0.01578514f, -0.08496419f, 0.15687324f, 
    -0.04784467f, -0.22639936f, -0.15404868f, -0.32733274f, -0.06983027f, 0.31211853f, 0.17672175f, 0.04417764f, 
    0.05715529f, 0.22477712f, -0.46817106f, -0.18457004f, 0.06637870f, 0.00964555f, -0.02017822f, -0.18043627f, 
    -0.22488064f, -0.05362833f, -0.16294712f, -0.05881850f, 0.17942306f, 0.21952505f, -0.01707339f, 0.10160097f, 
    -0.07584976f, 0.13862629f, 0.15550816f, 0.17150547f, -0.04332413f, 0.19272995f, -0.28324643f, 0.14398961f, 
    0.20065925f, 0.01521089f, 0.07230335f, 0.04918642f, 0.16071236f, -0.13070820f, 0.13530014f, -0.11855690f, 
    -0.06631747f, 0.20610113f, 0.13707349f, 0.25860199f, 0.17037602f, 0.15647849f, -0.02053407f, 0.07541522f, 
    0.20985799f, 0.00000049f, -0.15347508f, -0.05831413f, -0.00373464f, -0.04902868f, 0.10039306f, -0.41409042f, 
    0.21405266f, -0.63873887f, -0.09950721f, -0.06477001f, -0.42782295f, -0.04196555f, -0.17759171f, -0.15669502f, 
    0.38819644f, 0.31322780f, 0.00113587f, 0.06360395f, -0.01096173f, 0.03197114f, 0.11800615f, 0.22483762f, 
    0.10224067f, -0.07112275f, -0.13534492f, -0.14321855f, -0.12364873f, -0.00938163f, -0.10845621f, -0.26483929f, 
    0.07147686f, 0.00229630f, 0.05202936f, -0.46623406f, -0.29429439f, 0.13485649f, 0.05288531f, 0.10275044f, 
    -0.04938967f, -0.11940417f, 0.03638700f, -0.32005844f, -0.43264848f, 0.00616975f, 0.11133261f, 0.06505679f, 
    0.03832911f, -0.25803998f, -0.04802744f, 0.04171947f, 0.06930938f, 0.22038355f, 0.06142230f, 0.32829326f, 
    -0.27462319f, 0.13646980f, -0.02439371f, 0.37970105f, 0.09876106f, 0.03625366f, -0.19216661f, 0.27175459f, 
    -0.18234178f, -0.13177109f, 0.07317325f, 0.16866152f, 0.17242700f, -0.15585804f, 0.17888010f, 0.24726304f, 
    -0.08759030f, 0.21393023f, 0.41363677f, 0.10054833f, 0.15683538f, 0.24660687f, 0.29344583f, -0.04478877f, 
    0.34284225f, -0.08603203f, 0.03687999f, 0.20018125f, 0.00007829f, -0.07592943f, -0.01821066f, -0.08398695f, 
    -0.06434549f, 0.04854044f, 0.04903435f, -0.06634609f, 0.03879390f, -0.01116818f, 0.05197358f, -0.05070910f, 
    -0.03254090f, 0.01648971f, -0.07268166f, -0.06965661f, -0.08728292f, -0.05362280f, -0.06571449f, -0.07150073f, 
    0.01365496f, -0.00836300f, -0.01489727f, -0.05670506f, 0.03306934f, 0.01659622f, -0.06994706f, -0.10072253f, 
    -0.00146374f, -0.06828598f, -0.11557698f, 0.00401860f, -0.01059773f, -0.09553804f, -0.02581230f, -0.06880178f, 
    -0.02556272f, -0.03386722f, 0.03171195f, -0.06104510f, -0.01698598f, -0.06038366f, -0.09869035f, -0.00003210f, 
    -0.02805641f, 0.01067252f, -0.05220518f, -0.08371051f, -0.08767264f, -0.07426090f, 0.01258215f, 0.00494917f, 
    -0.00497884f, -0.05063249f, -0.09047388f, -0.08228385f, -0.08801910f, 0.05106597f, -0.00054291f, -0.11952434f, 
    -0.03315570f, -0.11241335f, -0.11263885f, -0.08915503f, 0.02974399f, -0.02334259f, 0.00998499f, 0.01714256f, 
    -0.01216979f, 0.01730902f, -0.00497260f, 0.01208814f, -0.08159655f, -0.03663050f, -0.03641312f, -0.11865629f, 
    -0.08751018f, -0.06291816f, 0.01146436f, -0.09758206f, -0.06237221f, -0.05200261f, 0.02572319f, -0.10201058f, 
    -0.02753387f, 0.05660914f, 0.04137637f, -0.05204378f, 0.04710425f, -0.07697916f, -0.02309535f, -0.02319637f, 
    -0.03348803f, 0.02191515f, -0.04229928f, -0.00530295f, -0.00449943f, -0.06481595f, -0.11562450f, 0.00446214f, 
    -0.10393485f, 0.02869472f, 0.03324660f, -0.01180467f, -0.05317425f, -0.09809057f, -0.10052268f, -0.07028475f, 
    -0.12799405f, 0.02344101f, -0.02774495f, -0.07892103f, -0.10760614f, -0.10292450f, -0.00648206f, -0.06404566f, 
    -0.04090903f, -0.09604140f, -0.05304452f, -0.07475264f, -0.00957436f, -0.10984591f, -0.04637454f, 0.01164580f, 
    -0.02170783f, -0.13272411f, -0.05359680f, -0.00460597f, -0.12821750f, -0.06891013f, -0.09568714f, -0.02110089f, 
    -0.04611760f, -0.07108483f, -0.12135570f, -0.06583913f, -0.08253783f, -0.12505610f, -0.01643535f, 0.01432752f, 
    -0.09917568f, -0.03115888f, -0.03165580f, -0.09281722f, -0.06009728f, 0.02921668f, -0.03863588f, -0.11635600f, 
    -0.21508805f, -0.05920232f, -0.42583466f, 0.30302605f, 0.07287336f, 0.02316614f, -0.12076909f, 0.21048398f, 
    -0.02852316f, 0.15885486f, -0.01291765f, -0.02584913f, 0.09927688f, 0.08405247f, -0.02288557f, 0.07719643f, 
    0.07694363f, 0.01395672f, -0.34452298f, -0.16178267f, 0.11440489f, 0.06089582f, -0.04543861f, 0.10333108f, 
    0.09939314f, 0.11281838f, 0.01188945f, -0.04213529f, -0.05467946f, -0.07160471f, 0.03044781f, -0.04657089f, 
    0.11641260f, -0.08547736f, -0.15602596f, -0.47065392f, -0.11954385f, -0.07068637f, 0.16930039f, 0.06064669f, 
    0.02024173f, 0.05824752f, 0.18646763f, 0.10369708f, 0.17566426f, -0.14239183f, -0.13672677f, 0.07782252f, 
    0.27758735f, 0.04209856f, 0.12789112f, -0.09514038f, -0.10080264f, -0.39933053f, 0.08845499f, 0.07501099f, 
    -0.04262236f, -0.11562834f, 0.11414901f, 0.11222991f, 0.32362053f, 0.39962831f, 0.28986171f, -0.10750395f, 
    -0.03057954f, 0.25083253f, 0.28664067f, 0.06970868f, 0.38158059f, -0.12105764f, -0.18346626f, 0.07229580f, 
    -0.08263502f, -0.13636237f, 0.12096868f, 0.03082174f, -0.13156095f, 0.16436794f, 0.28090975f, 0.18585195f, 
    0.12760784f, -0.15571399f, -0.28903639f, -0.16437899f, -0.07254671f, 0.06331380f, -0.05551440f, -0.15575534f, 
    -0.09908451f, -0.21543725f, -0.01258189f, -0.05790406f, 0.14828904f, -0.02400061f, 0.04572261f, 0.02989630f, 
    0.11411551f, 0.14196064f, -0.09599101f, -0.04960052f, 0.11032549f, -0.09526671f, -0.18555111f, 0.09357852f, 
    -0.08711804f, 0.17577279f, 0.03811902f, 0.06652947f, -0.00260270f, 0.25209808f, 0.26863819f, -0.00836735f, 
    0.07100420f, 0.07158057f, 0.10467825f, 0.04718427f, -0.08150758f, -0.04817061f, 0.05228740f, -0.01780487f, 
    0.00064984f, 0.03867853f, -0.09777256f, -0.29302493f, -0.36876580f, -0.52527446f, 0.14081745f, 0.20745027f, 
    0.20006558f, -0.01211112f, 0.13835987f, 0.19216238f, -0.06642433f, 0.31005278f, 0.12883121f, -0.25817549f, 
    -0.35644424f, -0.14660868f, 0.06171646f, 0.10520416f, 0.13140923f, 0.13187122f, 0.02260799f, -0.24419814f, 
    0.24463338f, 0.25805569f, 0.21308783f, 0.11639417f, -0.16545185f, -0.10303979f, -0.10785446f, 0.11311327f, 
    0.02805721f, 0.34232265f, 0.15775985f, -0.23026960f, -0.00116496f, 0.21330246f, -0.05372910f, 0.02018521f, 
    -0.04709688f, -0.09107472f, 0.27967614f, 0.21136691f, 0.11870396f, 0.18509017f, 0.06898216f, 0.02537441f, 
    -0.07817896f, 0.11708812f, -0.09831712f, -0.14278238f, -0.35636777f, -0.05071311f, 0.11731521f, 0.13384122f, 
    0.17830087f, -0.13618632f, -0.05040590f, -0.11132801f, 0.03838440f, -0.04423429f, 0.20760328f, 0.13000613f, 
    -0.03233634f, 0.00298994f, 0.10788953f, -0.09179568f, -0.06823976f, 0.20097227f, -0.15716033f, -0.14097863f, 
    0.05628218f, -0.14442872f, 0.02136241f, 0.05464563f, -0.02191092f, 0.03184641f, 0.26975057f, 0.07737529f, 
    -0.04150850f, -0.00385950f, -0.03198946f, -0.07770125f, 0.16601007f, 0.31561261f, -0.04941906f, -0.07008019f, 
    -0.06046803f, -0.06232367f, 0.04859966f, -0.00193222f, -0.12166001f, 0.23791267f, -0.08896192f, -0.21657282f, 
    0.00213686f, -0.01306006f, -0.08465669f, -0.25583386f, -0.12928477f, 0.00040168f, 0.14947161f, 0.13706501f, 
    0.01233513f, 0.25682008f, 0.19824517f, -0.04475893f, 0.10177382f, 0.13642024f, 0.11061284f, -0.00973905f, 
    -0.27877343f, 0.09130421f, -0.00058116f, 0.24286824f, 0.11489038f, 0.04444196f, -0.00311726f, 0.19940801f, 
    0.20855570f, -0.11359318f, 0.20945321f, 0.10591017f, 0.43365502f, -0.35539642f, -0.06109616f, -0.47055212f, 
    0.42400855f, 0.15658544f, -0.01512326f, 0.03879398f, 0.01082004f, 0.00056162f, -0.34104457f, -0.03151584f, 
    0.20485090f, -0.25549728f, -0.10325669f, -0.11523154f, -0.12082389f, 0.18864965f, -0.09823906f, -0.44227850f, 
    -0.10576273f, -0.15939458f, 0.01890113f, -0.10952349f, 0.02193370f, -0.20947947f, -0.18562452f, -0.11943793f, 
    -0.14333540f, 0.24823016f, 0.05586527f, -0.19517417f, -0.05537262f, 0.04380714f, 0.09551094f, 0.07360989f, 
    -0.00130567f, 0.21350330f, 0.08915490f, 0.15536495f, 0.12832275f, -0.37859806f, -0.20444936f, -0.12819430f, 
    0.14298315f, 0.16615701f, -0.08564431f, -0.12108880f, 0.00567864f, 0.10235234f, -0.06052913f, 0.04461779f, 
    0.08429942f, -0.21795505f, -0.27680922f, -0.02892807f, 0.06139786f, 0.25051612f, -0.02659118f, -0.04732015f, 
    -0.02616129f, -0.00596066f, 0.12278727f, 0.19357097f, 0.21501069f, 0.17558803f, -0.31173807f, 0.00943578f, 
    -0.08778468f, -0.33360770f, -0.05809535f, 0.12412716f, 0.06718162f, 0.15868111f, -0.04999336f, -0.01116327f, 
    -0.09246388f, 0.04636130f, 0.20955715f, 0.39487326f, 0.21309337f, 0.30705407f, 0.16070040f, 0.07617342f, 
    0.02074557f, -0.16460793f, -0.09652045f, -0.05162143f, -0.20794336f, 0.08831631f, -0.13699654f, -0.03342937f, 
    -0.04916975f, 0.14001381f, 0.01111743f, 0.10685394f, -0.10530847f, 0.20054255f, 0.08588746f, -0.15503399f, 
    -0.17610860f, 0.21223815f, 0.02755581f, 0.00848632f, 0.03325186f, 0.06120693f, -0.45826179f, 0.07002455f, 
    0.11881047f, 0.17007485f, -0.15914527f, -0.15583341f, -0.07369319f, -0.21454367f, 0.17580304f, 0.31340927f, 
    0.14652909f, 0.19653131f, -0.01645291f, 0.10489770f, -0.03483034f, -0.04494481f, -0.09636912f, -0.14532942f, 
    -0.04025235f, -0.00558863f, -0.10817090f, 0.08884414f, 0.20418543f, -0.13958491f, -0.19201335f, 0.11684245f, 
    0.15021399f, 0.05638468f, 0.03366930f, 0.07165472f, 0.47335064f, 0.31952137f, 0.13243738f, -0.29271507f, 
    0.06064169f, 0.06801575f, -0.02840195f, 0.05762385f, -0.01254485f, 0.28279704f, 0.19793881f, 0.10342568f, 
    0.00286012f, 0.10647183f, -0.34700260f, 0.06969146f, 0.02630224f, 0.02985782f, 0.00181440f, -0.04007185f, 
    0.27911296f, 0.18000470f, 0.17299454f, -0.11914214f, -0.07848540f, -0.30402586f, -0.14195547f, -0.12916304f, 
    -0.03238755f, -0.02485931f, 0.01076022f, 0.09021076f, 0.15907820f, 0.27634621f, -0.08678651f, -0.06141581f, 
    0.07253076f, 0.02598721f, 0.11452717f, 0.15899694f, -0.02821880f, 0.00155785f, -0.11672270f, 0.22793922f, 
    0.07316417f, -0.00039284f, -0.25957006f, 0.01675035f, 0.04789815f, 0.23410645f, 0.37670669f, 0.23192799f, 
    -0.04654742f, -0.02254889f, -0.03127930f, 0.04288837f, -0.05779567f, 0.02733543f, -0.01627572f, -0.00157607f, 
    -0.00049842f, 0.06518122f, 0.00427883f, -0.06636924f, -0.03118340f, -0.06442252f, 0.05772729f, -0.00632998f, 
    0.04146923f, -0.07057308f, -0.08774511f, -0.04067397f, -0.01595610f, 0.04008341f, 0.04485610f, -0.04769810f, 
    -0.07976221f, 0.05417416f, -0.04051909f, 0.07042777f, -0.06588536f, -0.01068671f, -0.02784457f, 0.05086068f, 
    0.01978819f, 0.01695541f, -0.02636649f, 0.05117729f, 0.00158795f, -0.07486519f, 0.06649780f, -0.03873984f, 
    -0.06356390f, -0.05778024f, 0.06777004f, 0.04465655f, -0.01833399f, -0.06952929f, -0.03542964f, 0.00687457f, 
    0.01805947f, 0.02668151f, -0.00790181f, -0.02116114f, 0.06307462f, -0.02636963f, 0.01564765f, 0.02450161f, 
    -0.01461457f, -0.03860371f, 0.07058280f, -0.07532772f, -0.03543195f, -0.05702192f, -0.04463981f, -0.01274443f, 
    -0.00319014f, -0.07390157f, 0.02571920f, 0.03243244f, -0.08208288f, 0.00251549f, -0.07809465f, -0.08249120f, 
    0.00602398f, -0.07218380f, -0.00780251f, 0.04161485f, 0.00541889f, 0.03328981f, -0.00309013f, -0.08269367f, 
    -0.02724640f, -0.01618611f, 0.03149306f, -0.07562735f, -0.02382193f, 0.04406890f, 0.02180834f, 0.08000679f, 
    0.04855270f, -0.06222871f, 0.03148812f, -0.07359581f, -0.04957747f, -0.00858634f, 0.05765437f, -0.06620134f, 
    0.01701907f, -0.04302230f, 0.03413404f, 0.00675560f, -0.09290648f, -0.05770366f, 0.04922844f, 0.03355398f, 
    0.02549194f, 0.01089126f, 0.03475301f, -0.07058418f, 0.02094776f, 0.04908253f, -0.04686897f, -0.04304222f, 
    -0.00129152f, -0.04220273f, -0.08819560f, -0.04931422f, 0.04726768f, 0.00268676f, -0.07163998f, 0.00604724f, 
    -0.02197767f, 0.03515176f, -0.02376726f, -0.06480101f, -0.04144351f, -0.02497590f, 0.02770722f, 0.04512900f, 
    -0.08636636f, 0.01276412f, -0.01699517f, 0.04665319f, -0.07687400f, 0.03625597f, 0.02058164f, 0.04278428f, 
    0.04262188f, 0.03446227f, -0.06158410f, -0.06096279f, -0.07082658f, -0.06122903f, -0.00233566f, -0.08136830f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.25532430f, 0.22057937f, -0.00789265f, 0.29665992f, 0.03765578f, 0.12858741f, -0.22640911f, -0.03294675f, 
    0.26057857f, 0.05770048f, 0.29463890f, -0.06992555f, 0.02333288f, -0.10780893f, 0.09723838f, -0.01815835f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.19621815f, -0.22625457f, -0.11413763f, 0.21960963f, -0.42766273f, 0.16390397f, 0.08758821f, 0.03244581f, 
    0.12096317f, 0.03682306f, 0.11344549f, 0.00715756f, 0.31777757f, 0.32188803f, -0.37040803f, -0.05718008f, 
    0.30698627f, 0.01653576f, 0.24017982f, 0.00752578f, -0.24896784f, 0.24474823f, 0.69831955f, 0.07491893f, 
    -0.78902560f, 0.18036310f, 0.19396280f, -0.18756387f, 0.00613708f, -0.63297111f, -0.12929235f, 0.02043889f, 
    0.17883666f, -0.45905176f, -0.14077595f, -0.40177602f, -0.22403909f, 0.19617473f, 0.90616691f, -0.23980215f, 
    0.33965650f, 0.31013495f, -0.21009217f, 0.24197200f, -0.52620614f, -0.10814259f, 0.31880513f, 0.22813857f, 
    0.34463865f, -0.49124783f, -0.05511290f, 0.03469471f, -0.02000469f, 0.56478655f, 0.08301218f, -0.08256458f, 
    0.00848471f, -0.38671353f, 0.20008329f, 0.07124181f, 0.45483196f, -0.22647853f, -0.47991115f, 0.20803446f, 
    0.37113914f, -0.45726067f, -0.17016017f, 0.17328922f, -0.13237932f, 0.44476289f, -0.40944916f, -0.14288756f, 
    -0.92524117f, -0.08804022f, -0.28845957f, -0.03964110f, 0.43882957f, 0.03847070f, -0.44935447f, -0.17131545f, 
    0.00391476f, 0.21198817f, -0.01182520f, -0.25594527f, 0.04391215f, -0.36415544f, 0.05309457f, 0.03025457f, 
    0.29019797f, -0.43075627f, 0.21704780f, -0.10874528f, -0.39704850f, 0.04695868f, 0.20076795f, -0.02913547f, 
    0.25984019f, -0.29257485f, -0.03834358f, -0.19873333f, -0.11021200f, 0.42124856f, -0.19177786f, -0.15083893f, 
    -0.80842674f, -0.28846484f, 0.24321054f, 0.03597178f, 0.36153901f, -0.43662441f, -0.00938228f, -0.15473615f, 
    0.32149142f, -0.65256917f, 0.09439462f, -0.73331124f, -0.01816292f, 0.09114428f, 0.20033655f, 0.00529854f, 
    0.61103278f, 0.35610166f, -0.05259036f, 0.12674868f, -0.36154467f, 0.10819460f, 0.46167210f, 0.01920872f, 
    0.06087092f, -0.02624317f, -0.23244831f, 0.23671201f, 0.47131151f, -0.38130406f, 0.09483566f, -0.06835002f, 
    -0.38923007f, 0.06652940f, 0.01349265f, -0.02957128f, 0.45004261f, 0.27522343f, -0.39362437f, -0.20111962f, 
    -0.15149985f, 0.51465720f, 0.12591851f, 0.17486081f, -0.17806478f, 0.33522102f, 0.06628361f, 0.07343786f, 
    -0.37014201f, 0.34966934f, -0.00342875f, 0.24958931f, -0.07051321f, -0.18456405f, 0.20664860f, -0.01528911f, 
    0.11411277f, -0.01538051f, -0.23382062f, 0.08942883f, 0.02020228f, -0.35491642f, -0.38742933f, -0.19788978f, 
    0.71125817f, -0.34186673f, 0.19067749f, 0.22672887f, -0.14368215f, -0.33447239f, 0.06411823f, -0.10102206f, 
    0.59653622f, -0.53460908f, -0.15738565f, -0.29987243f, 0.47867802f, 0.30758858f, -0.34329835f, 0.20977941f, 
    0.29262620f, -0.12102690f, -0.26858145f, 0.03362042f, -0.07780907f, 0.43430030f, -0.08798278f, 0.21766564f, 
    0.02462754f, -0.08935727f, 0.19416209f, 0.23965347f, -0.59917194f, 0.31859481f, 0.27265224f, 0.20506652f, 
    0.35482985f, 0.00029321f, 0.11495794f, 0.15132849f, 0.10515568f, 0.09189226f, -0.24516787f, -0.20567055f, 
    0.19133428f, 0.31586057f, 0.03465956f, -0.21071297f, -0.79141200f, -0.25297269f, 0.24449880f, 0.00155597f, 
    -0.07865803f, -0.41020876f, 0.53568232f, -0.24702492f, 0.02907042f, -0.50329119f, 0.00815711f, -0.07986787f, 
    0.07219054f, -0.17192701f, -0.19778183f, 0.27786377f, 0.13755617f, 0.23997393f, 0.03519241f, -0.22037092f, 
    -1.12130618f, 0.06110154f, -0.15165581f, -0.11500711f, 0.30212948f, 0.08137332f, -0.42801216f, 0.11885454f, 
    0.32670048f, -0.09603797f, 0.20166188f, -0.19921578f, 0.67839330f, -0.05468773f, 0.38732681f, -0.05926666f, 
    -0.59060049f, -0.20363414f, 0.10118163f, -0.18994541f, 0.00358014f, 0.09103002f, -0.13636784f, 0.25219461f, 
    0.07907879f, 0.36415377f, -0.04067451f, 0.37977999f, -0.86348087f, 0.47879446f, -0.00512085f, 0.04906185f, 
    0.22103843f, -0.05864453f, 0.02059683f, -0.19422506f, 0.39958736f, -0.20520698f, -0.11442243f, 0.19922905f, 
    0.04106972f, 0.05504315f, -0.21722412f, -0.49451864f, 0.54343951f, -0.39296344f, -0.20185627f, -0.00915826f, 
    0.42315260f, -0.35820502f, 0.22669591f, 0.00024887f, -0.03924928f, -0.10449857f, 0.18306272f, -0.05221348f, 
    -0.00319628f, 0.06764870f, 0.08535993f, -0.26241410f, 0.47262624f, 0.29071292f, 0.35535553f, -0.11888476f, 
    -0.36631715f, 0.56534773f, -0.08329371f, -0.15026687f, 0.17625484f, 0.03273539f, -0.12105779f, -0.14074098f, 
    0.33114994f, -0.45259339f, -0.16016194f, -0.25768831f, 0.17889725f, 0.28841296f, 0.18482070f, 0.20706698f, 
    -1.16037011f, 0.50361931f, -0.08291499f, 0.04421907f, 0.12692615f, 0.28241110f, -0.33414605f, 0.20181796f, 
    0.41540861f, -0.21383499f, 0.20211041f, 0.20496243f, -0.37821665f, 0.36153051f, -0.30658603f, 0.22467756f, 
    0.23952475f, -0.39372292f, -0.45727405f, 0.20813148f, 0.15725590f, -0.02754921f, 0.33819306f, 0.21420875f, 
    -0.26357120f, -0.05544615f, -0.08703934f, -0.15996107f, 0.03796843f, 0.51211029f, 0.20694633f, 0.18161969f, 
    -0.48228323f, 0.62263542f, 0.17742911f, -0.10153730f, 0.31250522f, 0.09680888f, -0.15076809f, -0.18005383f, 
    0.05407551f, 0.33749983f, 0.06411858f, 0.21884026f, -0.51142937f, -0.16841805f, 0.41895378f, -0.23342045f, 
    -0.52058464f, -0.41151071f, 0.41276139f, 0.04827540f, 0.33009616f, -0.20584899f, -0.22380418f, 0.03072849f, 
    0.48676500f, -0.13879386f, -0.00858277f, -0.68410128f, -0.01128645f, -0.34157687f, 0.12694936f, 0.10381758f, 
    0.77853310f, 0.19683068f, 0.00340538f, 0.27202305f, -0.37283158f, -0.23857662f, 0.15381935f, 0.14425196f, 
    0.10579421f, -0.12243734f, -0.01479888f, -0.47629344f, -0.54684895f, 0.41222602f, 0.13595384f, -0.14045510f, 
    0.65590113f, 0.82879603f, -0.39828369f, 0.10731283f, -0.49160901f, 0.05954789f, -0.18627997f, 0.16899693f, 
    0.01019114f, 0.02808971f, 0.18204255f, -0.13731217f, 0.56159908f, 0.35664648f, -0.93018013f, -0.08005200f, 
    -0.25988021f, -0.16061239f, 0.28967300f, 0.17024015f, -0.21149564f, -0.39265510f, 0.38821793f, -0.15496652f, 
    -1.00478327f, 0.30131361f, -0.20092246f, 0.21811749f, -0.03362573f, -0.78449285f, 0.11215099f, -0.23043904f, 
    -0.24390811f, -0.18541087f, -0.16500315f, 0.03108758f, 0.03681664f, 0.29131952f, 0.08077892f, -0.12100941f, 
    -0.18600856f, 0.06409883f, 0.10332443f, 0.09643243f, -0.14471497f, -0.03984459f, 0.02904261f, -0.11945018f, 
    -0.13073628f, 0.20679519f, -0.24422711f, -0.02214290f, 0.13805968f, 0.00925665f, -0.13179311f, -0.01443479f, 
    0.42674106f, 0.16984338f, 0.11435515f, -0.07344676f, -0.73867446f, -0.26628092f, -0.31542915f, 0.16901925f, 
    -0.34556952f, -0.24022888f, 0.29365832f, 0.10743703f, 0.00741874f, -0.70011365f, 0.29420149f, -0.17051110f, 
    0.05876134f, 0.07271798f, -0.12707570f, -0.15989791f, 0.12304559f, -0.01118341f, -0.07765745f, 0.02549610f, 
    -0.25994846f, -0.24967521f, -0.07054460f, 0.23793250f, -0.31252474f, -0.12160599f, 0.02558537f, 0.04846716f, 
    0.29953408f, 0.03180109f, -0.17042436f, -0.53136533f, 0.07011130f, -0.08114836f, -0.28871632f, 0.12481884f, 
    -0.77331942f, 0.12004328f, 0.37531644f, 0.19034500f, -0.44508213f, -0.15110113f, 0.58145046f, 0.02723702f, 
    0.57363355f, -0.58220190f, -0.23719880f, 0.28749421f, -0.22023606f, 0.29277250f, -0.02604093f, -0.05414550f, 
    -0.22227481f, -0.33269909f, -0.02576471f, -0.02536997f, 0.30016956f, 0.15667595f, -0.04308745f, -0.24237365f, 
    0.07952433f, 0.05902641f, -0.20583273f, 0.19686745f, -0.08178542f, 0.09027672f, 0.55261964f, -0.22676787f, 
    0.46045700f, 0.15518290f, -0.28468835f, -0.00478606f, -0.28058130f, -0.23561522f, 0.06402776f, -0.02403193f, 
    0.22668093f, 0.07385348f, 0.23842104f, 0.18349169f, -0.54173541f, -0.26982769f, 0.20155652f, 0.25852370f, 
    0.20953940f, -0.04747076f, 0.02122243f, 0.24278371f, 0.11017755f, -0.12198520f, 0.05117072f, -0.01636522f, 
    -0.08326137f, 0.12619622f, -0.18943880f, -0.74138701f, 0.01332174f, 0.24592161f, -0.12979870f, 0.22253525f, 
    0.07759197f, -0.16458477f, 0.45360419f, 0.08101246f, -0.04428590f, -1.02146530f, 0.28604302f, -0.17642508f, 
    0.39709112f, 0.14604865f, 0.23456617f, -0.01550820f, -0.05204127f, -0.20799807f, -0.39789096f, 0.22858450f, 
    -0.06787322f, -0.48747557f, 0.37830916f, 0.03565124f, 0.18350653f, -0.12636764f, -0.15780875f, -0.19598831f, 
    -0.29329950f, 0.37358439f, 0.11662491f, 0.23738326f, 0.25556931f, 0.27386326f, -0.09346978f, -0.17310959f, 
    -0.07910770f, 0.49863309f, -0.02547920f, 0.11575236f, -0.18730949f, -0.06122293f, 0.22524354f, 0.02313469f, 
    -0.06229930f, 0.26287347f, -0.04253173f, -0.16092737f, -0.49173984f, 0.09794033f, -0.52556586f, -0.14247423f, 
    0.04729381f, 0.17429398f, -0.08106881f, -0.11619654f, 0.18019277f, 0.11733197f, 0.07374854f, 0.03058979f, 
    -0.08155879f, -0.65126950f, 0.02133167f, -0.22183225f, 0.06713845f, 0.04105818f, 0.04759697f, -0.17012149f, 
    0.18918486f, -0.34051847f, 0.43180567f, 0.21391018f, 0.44088599f, -0.33488160f, -0.04512222f, 0.04693839f, 
    0.15764582f, 0.04517259f, -0.09183612f, -0.12498256f, 0.18997531f, 0.16333599f, -0.16943648f, -0.26050481f, 
    -0.51169372f, 0.36307818f, 0.34740129f, -0.18072118f, -0.25579083f, -0.22129881f, 0.24508294f, 0.19161661f, 
    -0.15648869f, 0.15632355f, -0.10306095f, -0.16304439f, 0.15788935f, -0.15115085f, -0.24635521f, -0.11144376f, 
    -0.03360642f, -0.08231575f, -0.30583760f, -0.15814403f, -0.09097870f, 0.06521472f, -0.12238043f, 0.14708047f, 
    -0.20677130f, -0.33201095f, -0.19235092f, -0.57643181f, 0.07807127f, 0.26848114f, 0.44775379f, 0.05815324f, 
    0.64359510f, 0.37940335f, 0.02218511f, -0.26508871f, -0.08873039f, -0.43169859f, 0.36152306f, -0.06846136f, 
    -0.27756688f, 0.02536628f, 0.12594405f, -0.20691881f, -0.21281311f, 0.16700217f, 0.02779379f, -0.01663154f, 
    0.09791275f, -0.17585960f, -0.26526269f, 0.12756063f, -0.03905119f, 0.07765101f, 0.02558667f, 0.00659791f, 
    -0.13936394f, 0.12451911f, 0.16865844f, 0.20209394f, -0.30147040f, 0.73063600f, 0.43304527f, -0.26293266f, 
    0.02984187f, 0.60792202f, -0.27561244f, 0.07864887f, 0.03568187f, 0.31404248f, -0.14685230f, -0.05290722f, 
    -0.27254170f, -0.45616853f, 0.18052670f, -0.03370911f, -0.34879476f, 0.14586034f, -0.75599110f, 0.01853090f, 
    0.59458399f, 0.17736675f, 0.16290459f, 0.00498089f, 0.62086868f, -0.23861320f, 0.05887863f, -0.04379386f, 
    -0.28387082f, -0.41898227f, 0.21663383f, 0.17263952f, 0.25223544f, 0.01854637f, 0.19308411f, 0.08412114f, 
    0.21925673f, -0.21837793f, 0.35905766f, -0.05142234f, 0.19805399f, -0.13043146f, 0.28383675f, -0.15400778f, 
    0.09474496f, 0.17708360f, 0.10425357f, 0.30456483f, -0.12017708f, 0.35621661f, -0.51036465f, -0.10160878f, 
    -0.05675523f, 0.23761499f, -0.32432264f, -0.09338109f, 0.11061189f, 0.28355092f, 0.05899997f, -0.04716565f, 
    -0.09671224f, 0.33896500f, 0.17275950f, 0.08694409f, -0.59355801f, -0.14435412f, 0.21354735f, 0.08853798f, 
    0.07933576f, -0.30551070f, 0.18747321f, 0.15180880f, 0.04181818f, -0.21633534f, 0.16400783f, 0.01462818f, 
    0.10785832f, -0.08023636f, -0.04608097f, 0.15830082f, 0.14435241f, -0.30776465f, -0.50877273f, 0.03000117f, 
    -0.07211613f, -0.55135316f, 0.38693717f, 0.05100449f, 0.17577145f, 0.21285963f, -0.04745403f, -0.19417775f, 
    0.46479765f, 0.18458711f, -0.09002534f, 0.31454325f, -0.34259850f, 0.12464730f, 0.16034538f, 0.20027632f, 
    0.01470895f, -0.29992715f, -0.03063933f, -0.11363938f, 0.26020950f, 0.08791675f, -0.30210662f, 0.16696298f, 
    0.32443592f, 0.16325092f, -0.21490218f, 0.14303438f, -0.16031718f, -0.21767023f, 0.64959854f, 0.09289648f, 
    -0.10428030f, 0.38293797f, 0.01381490f, 0.00748710f, -0.11115115f, -0.20220430f, -0.02240423f, 0.07164031f, 
    -0.25778848f, -0.17237024f, 0.14692178f, -0.33481038f, -0.14636636f, -0.07604191f, -0.15250856f, -0.18160698f, 
    0.03164641f, 0.06163017f, 0.34291807f, -0.20916985f, 0.19584209f, -0.14150897f, 0.35660481f, 0.07137241f, 
    0.28340870f, 0.55452198f, 0.22189958f, 0.00847396f, -0.20239726f, -0.27578104f, -0.24621870f, 0.05326001f, 
    0.04840174f, -0.48186773f, -0.10210417f, 0.04202055f, -0.02318785f, -0.23746333f, 0.08676758f, -0.16200337f, 
    0.25410193f, 0.06068048f, -0.05767223f, -0.09904772f, 0.09617095f, 0.13340063f, 0.27033475f, -0.05238700f, 
    0.42720607f, 0.68140173f, -0.11264513f, 0.02679342f, 0.22686182f, 0.08462247f, -0.38065824f, 0.07485947f, 
    -0.01872599f, -0.17612618f, -0.13431762f, 0.19290961f, -0.33731923f, 0.06676023f, -0.22524905f, -0.02299076f, 
    0.45108071f, 0.48790523f, 0.01156838f, -0.01961227f, 0.40937197f, -0.04974581f, -0.26877865f, 0.22537218f, 
    -0.04553461f, 0.31288883f, 0.10259313f, 0.05021902f, 0.05116766f, 0.38683462f, 0.14467221f, 0.00887275f, 
    0.18654539f, 0.46865839f, -0.29290295f, 0.19943947f, -0.13527380f, 0.21331421f, -0.13223869f, 0.11978595f, 
    0.36806476f, -0.07517599f, -0.05720058f, -0.22585285f, 0.38933939f, -0.12604421f, -0.20968980f, 0.08494285f, 
    0.28608853f, -0.63633335f, 0.47750655f, -0.10196847f, 0.17828193f, -0.22214560f, -0.13019723f, -0.21246499f, 
    -0.05329484f, 0.06800836f, 0.11828759f, -0.06540423f, 0.35310784f, 0.05536555f, -0.61379015f, -0.14589061f, 
    -0.18627839f, -0.65438515f, 0.44670343f, -0.04392742f, -0.16429918f, 0.10516116f, 0.08384430f, 0.19894072f, 
    0.25820255f, 0.46787944f, -0.18531577f, -0.34074780f, 0.65117884f, 0.36325425f, -0.36704817f, 0.20829673f, 
    0.05044114f, 0.44034043f, 0.10113037f, -0.11742236f, -0.41400182f, -0.42177299f, 0.05745547f, 0.13960865f, 
    0.22717956f, 0.13798895f, -0.24021411f, -0.67507058f, -0.36926925f, 0.02033953f, -0.21622315f, -0.17383346f, 
    0.41686317f, 0.16221707f, -0.22089094f, 0.07225794f, -0.26481715f, -0.45007661f, 0.50748950f, -0.23827189f, 
    0.46206576f, -0.00704289f, -0.20340751f, -0.06186773f, 0.36542165f, 0.09628934f, -0.81702274f, 0.17244908f, 
    -0.59322786f, -0.61306953f, 0.02797795f, -0.14233804f, 0.05214532f, -0.50933641f, 0.39890409f, 0.18840952f, 
    0.35806850f, 0.20081612f, -0.05537403f, -0.09338292f, 0.04873593f, -0.01417456f, -0.31672806f, -0.00815762f, 
    0.05622215f, -0.65842068f, 0.42657375f, 0.02345110f, -0.14812058f, -0.03536049f, 0.09707667f, -0.08807348f, 
    -0.07649823f, 0.14328015f, -0.18753062f, 0.05741888f, -0.13077927f, 0.09673643f, -0.44026431f, 0.16538899f, 
    0.27231425f, 0.27718112f, 0.06674283f, -0.14572397f, 0.21935511f, -0.14417620f, -0.09736160f, 0.24497190f, 
    -0.14718467f, 0.42617592f, 0.00698975f, 0.22672972f, 0.22662278f, 0.31950489f, -0.04343694f, -0.16659518f, 
    0.06467707f, 0.53170496f, -0.14219655f, -0.22500890f, -0.26644039f, -0.15210883f, 0.28219774f, -0.06181365f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.28919110f, 0.44447958f, -0.06037205f, 0.16896340f, -0.24264626f, -0.21390326f, 0.46538144f, -0.27914000f, 
    -0.07288343f, 0.15118624f, 0.33364049f, 0.20177820f, 0.05897675f, 0.26831681f, -0.07229867f, -0.31256622f, 
    -0.10953785f, -0.02546532f, 0.07343289f, 0.11899386f, 0.13075754f, -0.08521695f, 0.39425442f, -0.14380978f, 
    -0.04748685f, 0.40852606f, -0.44939557f, -0.01516741f, 0.63221037f, -0.18544985f, 0.59310943f, 0.39272821f, 
    -0.10235745f, 0.04197582f, 0.38390794f, 0.21739335f, 0.54276258f, -0.32805637f, -0.02637967f, 0.84267700f, 
    -0.08531041f, -0.19206947f, -0.22716257f, 0.01595061f, 0.20200703f, 0.30888087f, 0.40329513f, -0.36338818f, 
    0.20400324f, 0.06469446f, -0.18644015f, -0.08069914f, -0.04289091f, -0.41140226f, 0.19240433f, -0.03578073f, 
    0.13626465f, 0.36884645f, 0.25572777f, 0.04467832f, 0.41196272f, -0.18925713f, 0.44246012f, 0.41439220f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.10075099f, 0.12057915f, 0.30579472f, -0.01979664f, -0.20569502f, -0.42962867f, -0.16598070f, 0.28190276f, 
    0.04608037f, 0.11505503f, -0.66387892f, 0.21946813f, -0.06291408f, -0.55520898f, -0.13398021f, 0.19557214f, 
    -0.10682407f, -0.22318614f, 0.29026118f, 0.19824764f, -0.10457847f, 0.07993272f, -0.23160833f, 0.43604413f, 
    0.34617671f, -0.76764256f, 0.01273442f, -0.01689479f, -0.59636807f, 0.09518559f, -0.17593877f, -0.04047775f, 
    0.27550346f, 0.07237566f, -0.74639004f, -0.38109156f, -0.01719686f, -0.03114146f, -0.52384537f, 0.03899140f, 
    -0.00033144f, 0.16085632f, -0.03171878f, 0.17692752f, -0.70845467f, -0.34130183f, 0.12770255f, -0.16285370f, 
    0.02179118f, -0.00460379f, 0.20911323f, -0.44656187f, 0.05427277f, 0.24322814f, 0.02506782f, 0.25622723f, 
    -0.55512816f, -0.09409431f, 0.11497177f, -0.10218077f, -0.80994314f, -0.53323829f, -0.28360391f, 0.13248432f, 
    0.05193812f, 0.17957379f, -0.80733168f, 0.08216494f, 0.52843755f, 0.14995338f, 0.09715828f, -0.70252824f, 
    -0.14069283f, 0.09961779f, 0.50025958f, 0.02898993f, 0.10344037f, -0.03189793f, 0.69088811f, -0.08427665f, 
    0.23694672f, -0.05448928f, 0.02299528f, 0.48137754f, 0.17698921f, 0.02659439f, 0.08059531f, -1.04149497f, 
    -1.30872321f, -0.05568519f, 0.03327804f, -0.08767614f, 0.19354139f, -0.05725053f, -0.00269157f, 0.10151669f, 
    0.12589331f, 0.11758976f, -0.71862429f, 0.03296337f, 0.07981517f, -0.75150931f, -0.18736014f, 0.07440178f, 
    -0.02873868f, -0.98810065f, -0.05371634f, 0.06928204f, -0.05015484f, -0.13671184f, 0.19084810f, 0.00086217f, 
    -0.27549192f, 0.21634322f, -0.00611394f, -0.28568253f, 0.07241115f, 0.02655542f, 0.22107932f, 0.12885633f, 
    -0.12331506f, -0.29217687f, -0.09658753f, -0.42730045f, -0.04567083f, -0.13944465f, 0.14262687f, 0.13413823f, 
    -0.14811049f, 0.38457441f, -0.60726738f, -0.11212134f, -0.60462362f, -0.74194819f, 0.24645033f, -0.76008654f, 
    0.12027460f, 0.17832673f, -0.25552458f, -0.68641400f, -0.13337833f, 0.38923305f, -0.59055674f, -0.53678054f, 
    0.03365199f, -0.39607143f, -0.56245852f, -0.66680264f, -0.06899909f, -0.46989712f, 0.20071174f, -0.71389514f, 
    -0.43000990f, 0.18868355f, 0.34836471f, 0.06842396f, 0.64478213f, -0.07936796f, 0.53758991f, 0.06455092f, 
    -0.29793921f, 0.16256584f, 0.32515541f, 0.02463948f, 0.09256539f, -0.84517658f, 0.01531898f, 0.23406658f, 
    -0.00018703f, -0.87117213f, 0.03902890f, -0.13274226f, -0.32783750f, 0.12652613f, 0.11855225f, -0.00134002f, 
    0.12900278f, 0.06577103f, -0.04991368f, -0.04451986f, -0.27692041f, -0.57889968f, -0.33771217f, 0.00737895f, 
    -0.08859099f, 0.00335796f, -0.00893899f, -0.16194700f, 0.62462097f, -0.03824178f, -0.25190327f, 0.08845504f, 
    -0.06525658f, 0.11568316f, 0.27688074f, 0.06641697f, 0.09427345f, -0.34761706f, 0.17355888f, 0.39786291f, 
    0.73699874f, -0.39873210f, -0.41486388f, 0.36511067f, -0.19909963f, 0.21623512f, 0.32158408f, 0.56184942f, 
    -0.45762461f, -0.36925918f, 0.00300997f, 0.06083154f, 0.13200857f, -0.12653638f, 0.00509268f, 0.51548833f, 
    0.00964357f, -0.18145427f, -1.10235584f, 0.01684152f, 0.00208810f, -0.08051555f, 0.17638597f, 0.24168812f, 
    0.13014357f, 0.00626748f, -0.09227727f, 0.02227742f, -0.49760541f, -0.16830049f, -0.07163396f, 0.06221538f, 
    -0.05011562f, -0.12904210f, -0.07650579f, 0.01245488f, -0.62403595f, -0.06755431f, -0.17643203f, -0.05488930f, 
    -0.10981685f, 0.11063780f, 0.01669506f, -0.17323464f, -1.26043200f, -0.07384805f, -0.26364896f, -0.34419698f, 
    0.01304269f, -0.35885984f, -0.10295098f, 0.30624160f, 0.31282529f, 0.08049864f, -0.71478313f, -0.35826468f, 
    -0.04236039f, -0.04593534f, 0.09629017f, -0.10600016f, -0.32831523f, -0.27980831f, -0.00231215f, 0.16740425f, 
    0.01375686f, 0.20996054f, -0.83743584f, -0.11498711f, -0.00889114f, -0.87268776f, -0.37563458f, -0.70826697f, 
    -0.11720765f, -0.02110141f, 0.01556218f, -0.03285787f, -0.20288074f, 0.21650575f, -0.48548654f, -0.12650469f, 
    0.16038439f, 0.02712267f, -0.31363565f, -0.07038937f, 0.00967334f, -0.00708429f, 0.23352763f, -0.10213705f, 
    -0.14093970f, -0.12305805f, 0.25132671f, -0.61380100f, 0.34464124f, -0.34043500f, -0.06176342f, 0.24934143f, 
    -0.04916706f, 0.28124213f, -0.02781792f, 0.28685242f, 0.39434820f, 0.10397431f, 0.18749790f, -0.33255589f, 
    0.08280446f, -0.26970685f, -0.22009438f, 0.21980749f, -0.05810791f, 0.00705765f, 0.22087981f, 0.15040542f, 
    -0.56476426f, -0.11867911f, 0.00668365f, 0.15582345f, -0.34187526f, -0.33824348f, 0.20973101f, 0.25433981f, 
    0.08482110f, -0.07481541f, -0.43048564f, 0.29962158f, 0.14231518f, 0.07810204f, 0.10317880f, -0.09653951f, 
    -0.44051072f, 0.01021321f, -0.66822529f, 0.24436834f, 0.17854723f, -1.07028413f, -0.19483334f, -0.21205649f, 
    0.22675613f, -0.35412720f, 0.02711859f, -0.03045907f, 0.32406315f, 0.15826917f, -0.37360319f, -1.26449800f, 
    0.10813463f, 0.18725227f, 0.04079884f, 0.05902358f, -0.53812855f, 0.01842253f, -0.39241996f, 0.05836665f, 
    -0.36786053f, -0.26570851f, -0.05229273f, -0.10120238f, -0.03261647f, 0.32848525f, 0.07012819f, -0.14443727f, 
    0.04680118f, -0.14505041f, 0.09571799f, 0.14341244f, 0.35613966f, 0.00945247f, 0.29989618f, -0.14451508f, 
    0.03248166f, 0.10390923f, -0.41833499f, -0.06461042f, -0.30508414f, -0.08900058f, 0.11894397f, 0.01421585f, 
    -0.03784448f, 0.05921819f, -0.05122284f, -0.47170800f, 0.01721218f, 0.04339947f, -0.01383951f, 0.04065204f, 
    -0.30164608f, -0.98561990f, -0.14745258f, -1.22242892f, -0.40811437f, 0.19852853f, -1.16881013f, -1.03434622f, 
    -0.21015440f, 0.38233384f, -0.30578452f, -1.00955391f, -0.20071936f, 0.54040277f, -0.62014204f, -0.81219965f, 
    -0.03111818f, 0.08004488f, -1.09912407f, -0.29697251f, -0.34663552f, -0.79284918f, 0.35046259f, 0.11262779f, 
    -0.34457025f, 0.28010911f, -0.01987338f, 0.04138922f, 0.48894837f, -0.07347461f, 0.41224462f, -1.06915522f, 
    -0.61196792f, 0.00775236f, 0.26142505f, 0.25263679f, -0.01756751f, -0.17119817f, -0.71906316f, 0.10002452f, 
    -0.08759785f, -1.17078876f, 0.12425555f, -0.20868400f, -1.19857335f, -0.17456865f, 0.00085815f, 0.17643969f, 
    0.13938154f, 0.04054904f, -0.17530826f, 0.14698379f, 0.48429430f, -0.33540034f, -0.56550831f, -0.16278197f, 
    0.06771847f, 0.24466577f, 0.50809526f, 0.24207872f, 0.40166748f, 0.23949672f, -0.00298927f, 0.04640978f, 
    -0.08655215f, -0.84367371f, 0.66482902f, -1.02190399f, -0.23899214f, -0.12129924f, -0.61019456f, 0.13348329f, 
    0.18003879f, 0.24101478f, -0.43270805f, -0.62898207f, 0.22674608f, -0.62975389f, -0.44757879f, 0.04681117f, 
    0.31009978f, -0.13182232f, -0.24347061f, -0.12683900f, 0.28001416f, -1.20836699f, -0.25400478f, -0.18702008f, 
    0.30582097f, -0.06204753f, -0.09664612f, 0.12168286f, -0.13219914f, -0.12438626f, -0.25890741f, -0.45432317f, 
    0.27393213f, 0.10029342f, 0.07975636f, -0.23802157f, 0.10275428f, -0.06642877f, -0.66835839f, -1.05365229f, 
    0.00488600f, 0.40858486f, -0.02686461f, 0.13018841f, -0.11734586f, 0.14273351f, -0.03448470f, 0.16885637f, 
    -0.37228084f, 0.17019479f, 0.28445223f, -0.06230643f, -0.17627685f, 0.13880453f, -0.07752056f, 0.19021557f, 
    -0.09454220f, -0.31741455f, 0.15160337f, 0.59957302f, 0.02831881f, -0.00539471f, -0.14917928f, 0.22454174f, 
    0.31611037f, -0.83940989f, -0.55425417f, 0.16893086f, -0.79097027f, -0.24063028f, -0.23208041f, -0.47792032f, 
    0.10321563f, -0.77254117f, 0.31413364f, 0.02058446f, 0.25577128f, 0.02136558f, -0.23706414f, 0.28784293f, 
    -0.03399772f, 0.05551615f, -0.50994343f, -0.84574383f, 0.07937113f, -0.26781896f, -0.07830554f, -0.45054060f, 
    0.18463406f, -0.48826933f, -0.12961648f, 0.08231527f, 0.01964360f, 0.06733289f, -0.50462925f, 0.42650250f, 
    -0.23131450f, 0.25840446f, -0.73383039f, 0.09564776f, -0.52910912f, 0.26880637f, 0.33638391f, -1.02386093f, 
    -0.04231478f, -0.24655232f, -0.02486748f, -0.40712228f, 0.56691116f, 0.10183330f, -0.12418107f, 0.00319981f, 
    0.28184855f, 0.15352322f, -0.10195076f, 0.06835658f, 0.13641332f, 0.08108345f, 0.32075268f, -0.29907221f, 
    0.30620304f, -0.01264828f, -0.92164159f, -0.23534815f, -0.22723314f, 0.01997479f, 0.04809139f, -0.48205104f, 
    -0.63189477f, -0.26271525f, -0.59310728f, -0.22589193f, -0.35934979f, 0.34791702f, 0.35730016f, 0.14476992f, 
    -0.27104735f, -0.11492993f, 0.13923915f, 0.18664207f, -0.47466993f, -0.36840394f, -0.27375650f, 0.35123852f, 
    -0.82483310f, 0.45733690f, 0.42284667f, 0.06736184f, -0.36923411f, 0.06333897f, -0.40656438f, 0.28967696f, 
    -0.84160495f, 0.47147349f, -0.51757330f, 0.03157037f, -0.30026504f, 0.02632477f, 0.33982953f, -0.38903725f, 
    -0.07402566f, -0.27052894f, 0.37633821f, 0.02308505f, 0.15934125f, -0.29201981f, 0.08866651f, 0.29634318f, 
    -0.04769788f, 0.18098237f, -0.07802582f, -0.67547566f, -0.12335900f, 0.16086343f, -0.29410940f, -0.22769150f, 
    0.12264934f, -0.50100434f, -0.16409659f, 0.05811338f, -0.21557900f, -0.33751741f, -0.78595811f, -0.32029873f, 
    0.29140654f, 0.38957968f, 0.33682477f, -0.33021683f, 0.25608012f, 0.04670339f, -0.12707222f, 0.13559479f, 
    0.21454780f, 0.39749810f, 0.14200518f, 0.17845112f, -0.25575909f, -0.50190604f, 0.11016070f, -0.58344072f, 
    -0.13637738f, 0.10745232f, -1.46212518f, -0.68150109f, 0.17816859f, 0.69287008f, -0.23660947f, 0.01975730f, 
    0.31734550f, -0.66352683f, -0.00029927f, -0.25928581f, -0.64536351f, 0.37031758f, 0.48978814f, -1.41331601f, 
    -0.49976632f, -0.66043693f, -0.26377386f, 0.05786752f, 0.29586953f, -0.08797876f, -0.21038483f, 0.06513623f, 
    -0.05045749f, 0.02603680f, 0.40855530f, -0.03487072f, -0.12033372f, 0.19018827f, 0.37611490f, 0.07253644f, 
    0.07756004f, -0.06165871f, -0.09860658f, 0.29587394f, 0.06825725f, 0.19694249f, -0.53426808f, 0.09822745f, 
    -0.17507885f, 0.15671977f, 0.06343684f, 0.16472468f, -0.63774502f, 0.01682951f, 0.04422811f, -0.83794057f, 
    0.03470692f, -0.08530688f, -0.64229357f, -0.99787998f, -0.81380039f, -0.11904799f, -0.15504570f, -0.34002766f, 
    -0.29240480f, -1.07125306f, -0.34435451f, 0.09442424f, -0.29721162f, 0.23101149f, -0.50245982f, 0.32181090f, 
    0.04772467f, -0.15107192f, 0.23515822f, 0.37169158f, -0.07449431f, 0.21742319f, -0.54319459f, 0.35782391f, 
    -0.09982506f, 0.23573537f, 0.04627408f, -0.33653337f, -0.20767082f, -0.24879575f, 0.00027468f, 0.64281607f, 
    -0.56508541f, -0.11368895f, 0.20791776f, 0.05323219f, -0.14800429f, -0.08492339f, -0.85585189f, -0.37198403f, 
    0.05335643f, 0.17410263f, 0.35306716f, 0.15517028f, -0.25317615f, 0.23296160f, 0.39517578f, -0.54349017f, 
    -0.03768663f, 0.12373855f, 0.04722682f, -1.01502943f, 0.39148957f, 0.17475270f, -0.65305537f, 0.21931808f, 
    0.14060836f, -0.28325105f, -0.00994684f, 0.20682463f, 0.07384194f, -0.19935915f, 0.10928850f, -0.91789407f, 
    0.04275483f, -0.04492021f, -0.09916474f, 0.27043051f, -0.51383621f, 0.06196545f, 0.07137486f, -0.23700516f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.41095594f, 0.32813579f, 0.37149322f, -0.03978886f, -0.01103541f, 0.03303076f, -0.07628065f, -0.27670452f, 
    0.13803370f, 0.13531119f, -0.09071379f, -0.13753767f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
