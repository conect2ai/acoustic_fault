#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.88403672f, 0.67971724f, -0.57872844f, 0.80015343f, 0.18467276f, -0.69405752f, -0.16120492f, 0.17945927f, 
    -0.07623779f, -0.97329324f, 0.52696866f, -0.60834110f, 0.30581197f, 0.18834122f, 0.23725796f, 0.05756934f, 
    -0.06305859f, -0.58534008f, -1.06054747f, 0.71122307f, -0.37385809f, -0.05354964f, 0.38086218f, -0.77919739f, 
    0.00440843f, 0.02566031f, -0.02142244f, -0.83195204f, -0.90167487f, -0.22920145f, -0.33379626f, 0.11260348f, 
    0.94822508f, -0.30180746f, -0.43584141f, 0.28430328f, 0.15216209f, -0.45228410f, -0.95864564f, -0.71411085f, 
    0.02644703f, -0.01723608f, -0.26975349f, -0.69348949f, 0.46651819f, 0.74630982f, 0.26181608f, 0.83645242f, 
    0.09142628f, -1.10181808f, -0.33603436f, 0.51031131f, -0.09858163f, 0.14236175f, 0.88569266f, 0.84116304f, 
    0.85393196f, -0.15244971f, 0.57599038f, -0.65106821f, -0.37071696f, 0.28999969f, 0.14357780f, -0.26251212f, 
    0.72940326f, 0.60090017f, 0.36860478f, 0.66936660f, 0.51816154f, -0.32942218f, 0.05500031f, -0.18701288f, 
    -0.87370777f, -0.88042945f, -0.19256662f, 0.12942585f, -0.63224727f, -0.20703726f, 0.08329622f, -0.65365446f, 
    -0.11112837f, 0.85699731f, 0.62890273f, 0.64379108f, -0.45534092f, -0.17865288f, 0.45504269f, 0.22656745f, 
    0.07621990f, -0.18608890f, 0.60407054f, -0.98827314f, 0.39394024f, 1.03835559f, 0.15290891f, 0.34366819f, 
    0.17123386f, -0.23210712f, -0.02085712f, -0.56354511f, -0.51701987f, -0.44484255f, -0.48977163f, 0.40836054f, 
    0.57369113f, 0.43490708f, 0.39050153f, 0.63500607f, -0.16011657f, -0.49206236f, -0.30732888f, -0.81302953f, 
    -0.10757660f, -0.80464375f, -0.38879055f, 0.34020910f, -0.60313636f, 0.46818596f, 0.65847087f, -0.78641295f, 
    -0.19087200f, 0.60457706f, -0.56547064f, 0.53216326f, 0.00684354f, -0.02061551f, -0.43850651f, -0.82233226f, 
    -0.34797940f, 0.75821328f, 0.42012829f, 0.67736346f, -0.27201790f, 0.16247267f, -0.23075153f, -0.05375164f, 
    0.45421845f, -0.33538935f, -0.62458217f, -0.89779836f, -0.57986766f, 0.06455705f, 0.22029383f, -0.13566081f, 
    -0.29143661f, 0.06481116f, 0.29223222f, 0.60320991f, 0.74445802f, 0.23453173f, -0.00774650f, -0.64818496f, 
    -0.24175572f, -0.68159753f, 0.62617427f, 0.18352267f, -0.75040752f, 0.52706754f, -0.34546179f, -0.34058219f, 
    -0.58368665f, -0.20711388f, 0.02674079f, 0.55444235f, 0.58587891f, -0.58051163f, -0.64546680f, -1.03850210f, 
    -0.07519118f, -0.05852376f, -0.32630080f, -0.85269785f, -0.84695876f, -0.39248824f, -0.78116435f, -0.22832672f, 
    -0.05078495f, 0.32463342f, 0.30196577f, -0.13794103f, -0.22634441f, -0.60508174f, -0.88252062f, 0.01536119f, 
    -0.23808272f, -0.35742095f, -0.33367404f, 0.33561242f, 0.17715621f, 0.50160670f, 0.40570050f, -0.52943826f, 
    0.10100105f, -0.94266218f, -0.19611090f, 0.81363696f, 0.19591047f, 0.30305386f, -0.58014387f, -0.68497354f, 
    -0.57571465f, 0.54079652f, 0.22392030f, 0.05748709f, 0.37898228f, 0.30616829f, -0.29128078f, 0.74838835f, 
    0.94788623f, -0.71849698f, 0.52487195f, 0.22955690f, 0.41878101f, 0.33086935f, -0.09200371f, -0.02026716f, 
    0.03711695f, 0.76564449f, -0.70107394f, 0.51999801f, -0.80046666f, -0.27573726f, -0.11208280f, 0.24747084f, 
    0.53839344f, 1.20040274f, 0.29483294f, -0.12468742f, 0.94756639f, 0.10140783f, -0.18403287f, -0.10881345f, 
    0.03172842f, -0.30850425f, 0.11485987f, -0.89180648f, -0.76760417f, 0.37972450f, -0.64888871f, 0.71989763f, 
    -0.15813985f, 0.11666524f, -0.09754228f, 0.65070057f, 0.85940373f, 0.47366449f, -0.21515734f, -0.67157978f, 
    0.04637925f, -0.42721751f, 0.15880540f, -0.31090367f, -1.43435347f, 0.21318932f, 0.62233675f, 0.59680551f, 
    0.55620545f, 0.27404669f, 0.00970198f, -0.24795577f, 0.41517675f, -0.44281340f, -0.94051915f, -0.99986386f, 
    -0.22551696f, 0.68800479f, 0.24361864f, -0.04461345f, -0.10257056f, -0.32303733f, 0.71420830f, -0.12948519f, 
    0.98100013f, 1.06446052f, 0.16111253f, -0.42934483f, 0.17935716f, 0.14533554f, 0.17263357f, -0.03281802f, 
    -0.16273177f, -0.42531109f, -0.95016915f, 0.79249638f, 0.75802004f, -0.39667878f, 0.20404127f, -0.26820365f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.03544717f, -0.10662539f, 0.03989071f, 0.16158128f, 0.28831741f, -0.31682289f, 0.11801480f, 0.43276894f, 
    -0.39688200f, 0.41384479f, -0.05547515f, -0.03677205f, -0.20683821f, 0.29737827f, -0.20823237f, 0.21481529f, 
    0.14747672f, 0.14770973f, -0.18821031f, 0.09227351f, 0.31166494f, 0.24228869f, 0.04754331f, -0.42482293f, 
    -0.34412172f, -0.10342826f, -0.20711707f, -0.05597607f, -0.07741849f, 0.11829022f, -0.13269506f, -0.32334006f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.15827176f, 0.05435924f, 0.12892397f, 0.08057798f, 0.16149931f, 0.22099786f, 0.05164491f, 0.11570871f, 
    -0.10611530f, 0.19466770f, -0.21239619f, 0.03431243f, 0.03622121f, 0.02870546f, 0.14417247f, 0.09891956f, 
    -0.01398877f, 0.14335918f, -0.25728905f, 0.09751903f, 0.02851618f, -0.08406752f, 0.15104631f, 0.07953201f, 
    -0.17969067f, 0.09994286f, -0.01346679f, -0.12496934f, -0.02510906f, -0.06393376f, 0.16311827f, 0.15840912f, 
    0.02410954f, 0.04464921f, -0.16539569f, 0.03884695f, 0.07228380f, 0.00857117f, -0.01640444f, 0.14652602f, 
    -0.09065520f, 0.03226131f, 0.18428592f, -0.18252786f, 0.15456189f, 0.26603186f, 0.05558094f, 0.03747944f, 
    -0.23053811f, -0.34397236f, -0.08025641f, 0.09456591f, -0.05586317f, -0.05494948f, 0.46371689f, 0.16785985f, 
    0.19158533f, 0.02733265f, 0.02233306f, 0.11982505f, 0.25853825f, 0.10541965f, -0.25455043f, 0.27938440f, 
    0.02411385f, -0.10203091f, 0.28780633f, 0.19507121f, 0.12558390f, 0.02676668f, 0.04502299f, -0.06377508f, 
    -0.07455995f, 0.07889914f, -0.18070447f, 0.10151462f, 0.00117840f, 0.13671790f, 0.15265337f, -0.09962605f, 
    0.12058734f, 0.08724713f, 0.16428804f, 0.14338344f, 0.02060751f, -0.22805524f, 0.03795792f, 0.21181475f, 
    0.11638542f, -0.12824216f, -0.37133172f, -0.49502566f, -0.22546846f, 0.17914407f, 0.10632721f, 0.14695287f, 
    -0.10413984f, -0.06083270f, -0.03311310f, -0.13065217f, -0.10029309f, 0.09347802f, 0.01844025f, 0.21183234f, 
    0.01131244f, 0.07727373f, 0.02886247f, -0.50517434f, -0.10267109f, 0.25932670f, -0.06007773f, -0.13365036f, 
    0.25641531f, 0.11350725f, -0.17427574f, 0.01133079f, 0.04432168f, -0.01877214f, 0.00960191f, 0.13284476f, 
    -0.00106536f, -0.13069856f, 0.02828111f, 0.18473120f, 0.05208557f, 0.19617723f, -0.24197207f, -0.06744515f, 
    -0.01870373f, 0.20604819f, 0.16215590f, 0.03502436f, -0.08471622f, -0.23916340f, 0.09133930f, 0.12415358f, 
    0.22207350f, 0.07878488f, -0.00164677f, -0.02684595f, 0.01506582f, 0.08212896f, 0.11821610f, 0.25044721f, 
    -0.11087871f, -0.00671293f, -0.07475409f, 0.14271288f, 0.18361953f, 0.22381254f, -0.03438052f, -0.00360309f, 
    0.06323539f, -0.02323996f, 0.03082163f, -0.07144363f, -0.20758040f, 0.04486468f, 0.05041603f, -0.07353985f, 
    0.14608908f, -0.01574667f, 0.33070368f, 0.24273556f, 0.06851842f, -0.07229349f, -0.02577333f, -0.04928342f, 
    0.07659502f, -0.10402729f, 0.15807875f, 0.01199225f, 0.09725314f, 0.04719986f, 0.15227434f, 0.21500424f, 
    -0.08679985f, 0.10213992f, 0.01163280f, -0.25159177f, 0.01472317f, 0.11775681f, 0.23331629f, 0.31292969f, 
    0.01124702f, -0.05388922f, 0.09260068f, -0.12334872f, 0.02721685f, 0.00632577f, -0.00447241f, 0.11324535f, 
    0.11254658f, 0.00622885f, -0.05602972f, 0.05977732f, 0.09075019f, 0.04045387f, 0.07085204f, 0.02661235f, 
    0.20619279f, 0.22103788f, 0.12705246f, 0.00038019f, 0.03532961f, 0.01150561f, -0.08168522f, -0.09277667f, 
    -0.44151896f, 0.08055089f, 0.04984355f, -0.00758650f, -0.07841475f, 0.04042266f, -0.04765736f, -0.16057201f, 
    -0.39998811f, -0.11637451f, 0.00429179f, 0.03796245f, 0.08591732f, -0.04380350f, 0.21367684f, -0.17616698f, 
    -0.12608044f, 0.28450143f, -0.16453002f, -0.12624229f, 0.34967592f, 0.03266697f, 0.08294009f, 0.11085824f, 
    0.15548885f, -0.04490686f, -0.04741127f, -0.15237576f, -0.04581494f, 0.20170116f, 0.02273268f, 0.14682007f, 
    -0.05193057f, -0.23850788f, 0.01428596f, 0.34111694f, 0.31437838f, 0.23717186f, 0.18605205f, -0.10763299f, 
    0.11415103f, 0.20679949f, 0.02215350f, -0.09455238f, -0.08163949f, -0.02390487f, -0.25912648f, 0.09772221f, 
    0.20348878f, 0.21105562f, 0.01952291f, -0.03595433f, -0.30778548f, -0.10456543f, -0.02793271f, 0.17248377f, 
    0.05325883f, 0.14178075f, -0.01108099f, -0.08437278f, -0.10976830f, 0.05677923f, -0.03425986f, -0.33121461f, 
    -0.37410223f, 0.08560713f, 0.06479840f, -0.03803055f, 0.01240586f, 0.14971453f, -0.05887185f, -0.28015113f, 
    0.13662592f, 0.03637381f, -0.27845192f, 0.18688177f, -0.00407433f, -0.10277258f, -0.24305598f, -0.18568212f, 
    -0.79327404f, -0.14975373f, -0.27247319f, -0.01959859f, -0.02972636f, -0.01047602f, 0.08716556f, -0.03033108f, 
    0.10482439f, -0.43341443f, -0.38857961f, -0.35002851f, 0.15561473f, -0.21172251f, -0.12332018f, 0.10342282f, 
    0.00661728f, -0.04136743f, -0.48749310f, -0.41193515f, 0.00668587f, 0.18229376f, 0.14794394f, -0.04137780f, 
    -0.02748469f, -0.00564556f, 0.23460339f, 0.10553589f, -0.12200850f, 0.18668614f, -0.17176144f, -0.05074885f, 
    0.03567994f, -0.02620455f, 0.04232332f, -0.03082481f, -0.62047035f, -0.04610915f, -0.26918259f, 0.08232346f, 
    -0.09991947f, -0.00396183f, 0.15738310f, -0.07200407f, -0.08865545f, 0.20384121f, 0.10504129f, -0.01399741f, 
    0.03629835f, -0.01627719f, 0.25516915f, -0.04635349f, 0.08783534f, 0.22821054f, 0.14000547f, -0.05233428f, 
    0.03596095f, 0.04566273f, 0.17636368f, 0.08418065f, 0.02975051f, 0.05795141f, -0.06638627f, 0.09541848f, 
    0.16173989f, 0.10437315f, 0.07083388f, -0.26052260f, 0.14998509f, 0.13143417f, -0.03873202f, -0.13604580f, 
    0.13525844f, -0.24348377f, 0.33529538f, 0.00713548f, -0.02617174f, 0.15705302f, 0.08167481f, 0.06853481f, 
    -0.05481761f, 0.08820594f, 0.12433092f, 0.12455628f, -0.15700839f, 0.18310927f, 0.09553817f, 0.12566915f, 
    0.14139745f, 0.14497651f, -0.14144093f, 0.15213008f, 0.08019298f, 0.21143471f, -0.12056527f, -0.02604439f, 
    0.03454553f, -0.17554617f, -0.01384458f, -0.05408659f, -0.28587666f, 0.19854411f, 0.06305543f, -0.12096015f, 
    0.05025095f, -0.11680881f, 0.01460557f, 0.14209881f, -0.08872721f, 0.04563151f, 0.10441262f, 0.07217798f, 
    0.09992579f, 0.15581962f, -0.03136890f, -0.24119015f, -0.15184893f, -0.00438203f, 0.01065290f, -0.15518060f, 
    -0.03907581f, 0.00928579f, -0.08804221f, 0.10242749f, 0.01737767f, 0.23484288f, -0.17762177f, -0.44224817f, 
    -0.28253895f, -0.04977615f, -0.14379764f, -0.10418554f, 0.00742322f, -0.02149351f, -0.02724401f, 0.03980787f, 
    -0.12973578f, -0.24321334f, 0.13386379f, 0.25221235f, 0.02844988f, 0.03735296f, -0.05443392f, 0.12531826f, 
    0.24136075f, 0.12830020f, 0.14682676f, -0.07734738f, -0.33117130f, 0.01634331f, 0.16805536f, 0.00401984f, 
    -0.09366088f, 0.13791357f, -0.24850410f, -0.19706410f, 0.05374140f, 0.01881045f, -0.01679490f, 0.12335556f, 
    0.01671856f, 0.15757453f, 0.07172486f, -0.14400466f, 0.20081320f, 0.16508101f, 0.03287509f, -0.08061776f, 
    0.07828765f, 0.20198505f, 0.02724849f, -0.50654167f, -0.05026277f, 0.17946938f, 0.04523831f, 0.13786246f, 
    -0.11605238f, 0.00093416f, -0.12266089f, 0.06491526f, -0.37427801f, 0.28191301f, 0.01668950f, 0.07549496f, 
    -0.07751073f, 0.03773584f, -0.14729835f, 0.02668953f, -0.03823186f, -0.03853055f, 0.34491527f, 0.14561954f, 
    -0.17404376f, 0.11958466f, 0.06158610f, -0.05791872f, 0.14279714f, 0.18849517f, -0.23716332f, -0.29429054f, 
    0.02413829f, 0.02146060f, -0.13903256f, -0.09496886f, -0.06394803f, 0.06034853f, 0.02378380f, -0.22530364f, 
    0.15892111f, -0.10333758f, -0.01876101f, -0.08451192f, -0.20307788f, -0.05420299f, -0.00676240f, -0.08200233f, 
    -0.38689107f, 0.01023788f, -0.38231185f, -0.02467505f, 0.10153562f, 0.05891525f, -0.06744933f, 0.14451058f, 
    0.05589078f, -0.06501620f, 0.01349884f, -0.01075172f, 0.02320163f, -0.01756878f, -0.03474908f, -0.13569854f, 
    -0.09845681f, -0.16565885f, -0.32205954f, 0.07700723f, -0.15022570f, 0.03737132f, -0.05997897f, 0.01413715f, 
    0.04161458f, 0.01528224f, -0.05092429f, 0.10862509f, -0.10793111f, 0.03078800f, -0.05786900f, 0.13396674f, 
    -0.08499637f, 0.01817958f, 0.02308322f, -0.04998918f, 0.06627137f, -0.13552175f, -0.07087033f, 0.01830442f, 
    -0.07545860f, -0.00697060f, -0.15777084f, -0.06878715f, 0.04369957f, -0.71933812f, -0.07454304f, -0.18874925f, 
    0.01610657f, -0.04488206f, -0.04771029f, 0.03980641f, -0.00118567f, 0.07954020f, -0.10653204f, 0.25865674f, 
    0.18713275f, 0.10308730f, 0.09348834f, -0.10067210f, -0.10842340f, -0.08394951f, -0.01989527f, 0.12245210f, 
    -0.16136393f, -0.16034411f, -0.11299001f, -0.07630209f, -0.06158687f, 0.07450464f, 0.06548957f, -0.03070635f, 
    0.03971348f, 0.03794116f, -0.05598615f, -0.02463587f, 0.02374018f, 0.04578393f, 0.01898753f, 0.02791798f, 
    -0.05931619f, -0.05797588f, 0.03337949f, 0.01749037f, -0.04529631f, 0.01930195f, 0.00034921f, -0.06034489f, 
    -0.05244254f, -0.05460283f, -0.02737954f, 0.04767733f, -0.01460150f, -0.05463932f, 0.02419139f, -0.05874674f, 
    0.00826771f, -0.02786185f, 0.00808540f, -0.04609616f, -0.04155198f, 0.03255876f, -0.02420209f, -0.01819466f, 
    -0.04700801f, 0.03647161f, 0.02661211f, -0.05816168f, 0.00592298f, 0.05113340f, 0.03551805f, -0.03640280f, 
    -0.05499256f, -0.02273644f, -0.01610454f, -0.04811577f, -0.06305423f, -0.04293870f, 0.00604564f, -0.01144275f, 
    -0.03317374f, -0.02228660f, -0.05464476f, 0.03121041f, 0.03326741f, 0.01093801f, -0.04281788f, 0.00263485f, 
    -0.01000308f, -0.02414386f, 0.03677512f, 0.01252446f, -0.00466130f, -0.06907971f, -0.02314509f, 0.01663283f, 
    -0.00782248f, -0.04205402f, 0.02200443f, 0.01737257f, 0.03266245f, 0.01369270f, 0.00276713f, 0.02053148f, 
    -0.04453658f, -0.01850934f, 0.01630315f, -0.06382877f, -0.05097467f, 0.00220796f, 0.04289378f, -0.03071090f, 
    -0.04676726f, -0.03180907f, 0.02165944f, 0.01029080f, 0.01446655f, 0.04625127f, 0.00053798f, -0.02189129f, 
    0.01233932f, -0.01791976f, -0.05506759f, 0.00886950f, -0.01004038f, -0.05352843f, 0.03818281f, 0.04157250f, 
    0.03722965f, -0.01525015f, 0.00929013f, 0.00125516f, 0.00570874f, -0.00620352f, -0.01240915f, 0.04015446f, 
    0.01457171f, -0.04552405f, 0.01637959f, -0.05856245f, -0.02291811f, 0.00784409f, 0.04220382f, 0.00658926f, 
    -0.02063176f, 0.02874261f, -0.00591764f, 0.02619904f, -0.06848597f, 0.02769862f, -0.05469681f, -0.00305906f, 
    0.00618144f, -0.00189886f, -0.05219872f, 0.03933833f, -0.03931149f, -0.02563949f, -0.04908344f, 0.03861002f, 
    -0.06290647f, 0.04201136f, -0.02449650f, -0.02608288f, -0.06133104f, -0.02172317f, 0.00326751f, -0.02403986f, 
    -0.04039280f, -0.02726083f, 0.03584843f, -0.01733839f, 0.02187283f, 0.04004664f, 0.01691838f, 0.01897871f, 
    -0.01986404f, -0.01067427f, -0.05652042f, -0.02822951f, -0.02426150f, 0.03721242f, -0.00285411f, -0.06250085f, 
    0.02814654f, -0.03818918f, -0.02514670f, 0.01840503f, 0.03201206f, 0.02838035f, -0.00180201f, -0.02368897f, 
    0.02712215f, 0.04269221f, 0.00817607f, 0.00073357f, 0.03012538f, 0.01811340f, 0.02072225f, -0.01516414f, 
    -0.01006745f, -0.02017386f, -0.01091136f, 0.02954688f, 0.00191289f, -0.00054056f, -0.00249790f, -0.06161003f, 
    -0.01003493f, 0.02250857f, -0.02283800f, -0.05930660f, -0.04787161f, -0.04166950f, 0.01203916f, -0.03793599f, 
    0.02879484f, -0.05254734f, -0.02641949f, -0.04887658f, -0.07166849f, 0.01992054f, 0.04025508f, -0.00875625f, 
    -0.02111441f, -0.03656153f, 0.02861963f, -0.04416717f, -0.00323854f, -0.06263448f, 0.01951319f, 0.01898338f, 
    -0.06348364f, -0.01371879f, -0.02898417f, -0.06240870f, 0.00969522f, -0.04639376f, 0.00511868f, 0.02901318f, 
    0.00685777f, -0.05698590f, 0.02722402f, 0.02603607f, 0.03596854f, -0.04171722f, 0.04276884f, 0.01758623f, 
    -0.03262733f, 0.02711629f, 0.04692778f, -0.03685605f, -0.01520801f, -0.01592523f, -0.03261333f, 0.03025370f, 
    0.00267170f, 0.03373437f, -0.04054501f, 0.00080409f, 0.00337504f, 0.01053799f, -0.02019753f, 0.01276595f, 
    -0.04515283f, -0.02919785f, 0.01248931f, -0.02134116f, 0.00864423f, -0.05946069f, -0.03087115f, 0.02131380f, 
    0.01868934f, -0.05140049f, -0.06635275f, -0.03853820f, -0.00802534f, 0.00283514f, -0.04691907f, 0.04888702f, 
    -0.02805725f, -0.05298332f, -0.02286192f, -0.04761710f, 0.01910704f, -0.03754972f, 0.05959862f, 0.01858499f, 
    0.01460753f, 0.03652283f, 0.02888076f, -0.02408355f, -0.04673159f, -0.02769566f, 0.02213604f, -0.06431410f, 
    -0.00427739f, -0.03955545f, -0.01601716f, 0.00627177f, 0.03568353f, -0.05247003f, -0.03106478f, -0.05354429f, 
    0.03936370f, 0.04208345f, -0.05487167f, -0.04345217f, -0.02594623f, -0.03750773f, -0.04501111f, 0.03168573f, 
    -0.05406672f, 0.01732094f, -0.00891520f, -0.01095638f, 0.01036250f, -0.02300134f, -0.00384153f, 0.02440694f, 
    -0.02586621f, -0.04124081f, 0.01926954f, 0.00478027f, -0.01372235f, -0.01095977f, 0.04586556f, -0.06446650f, 
    -0.00158872f, -0.01076668f, 0.01788905f, -0.00213931f, -0.04304428f, 0.01310305f, -0.05480909f, -0.01709706f, 
    -0.05824668f, -0.02581558f, -0.02731164f, -0.04722511f, -0.01255083f, 0.04551902f, -0.02058448f, -0.05110927f, 
    -0.04363743f, -0.02962074f, 0.01266158f, -0.02025851f, 0.03134379f, 0.00040244f, 0.02313470f, 0.01802965f, 
    -0.03479284f, 0.03700182f, -0.02473494f, -0.00436125f, 0.02454046f, 0.03605265f, 0.03581937f, 0.03540693f, 
    -0.00237671f, -0.01298536f, -0.01713850f, -0.05476536f, -0.01067802f, -0.02668714f, 0.00365869f, 0.04136209f, 
    0.01692881f, 0.01988829f, -0.02653175f, -0.02052793f, 0.04521505f, 0.04613398f, -0.06129429f, -0.03512881f, 
    0.04716410f, -0.00227626f, -0.03543209f, -0.05876172f, -0.02155177f, 0.03829034f, 0.00966478f, -0.05580255f, 
    -0.03515290f, -0.06579957f, 0.00482304f, -0.02764591f, -0.00312611f, 0.01689583f, 0.05329210f, -0.04661507f, 
    -0.01018076f, 0.02320659f, -0.04518377f, 0.02681716f, -0.05780758f, 0.02222927f, -0.05158280f, 0.01976021f, 
    -0.00866614f, -0.01381103f, 0.02865834f, -0.06501073f, -0.05511607f, 0.01674739f, -0.01849523f, 0.03115534f, 
    0.01528401f, 0.03944730f, 0.05760982f, 0.00995292f, -0.01253633f, -0.06456599f, 0.04053682f, 0.03538471f, 
    -0.06990679f, 0.03531411f, 0.03160020f, -0.03065447f, -0.03616290f, -0.05052735f, 0.01922543f, 0.04259244f, 
    -0.05601873f, -0.01296170f, 0.00479285f, -0.03089202f, -0.02763682f, -0.04384815f, -0.03434975f, 0.02590439f, 
    0.00448271f, 0.01174265f, 0.02968890f, 0.00822912f, -0.05759415f, 0.02779240f, -0.03100907f, 0.00096596f, 
    -0.00063219f, -0.00768104f, -0.01719375f, -0.05853787f, -0.03872006f, -0.04380692f, 0.05114830f, 0.01064373f, 
    -0.02004385f, -0.06291776f, -0.02195072f, 0.04113226f, -0.03262563f, 0.00840627f, 0.01176204f, -0.05483805f, 
    -0.00997571f, -0.05626001f, -0.02275323f, 0.02535790f, 0.03640746f, 0.00581499f, 0.04293674f, -0.03174246f, 
    0.01300670f, 0.00126042f, 0.01835301f, 0.03118251f, -0.04532252f, -0.05516535f, -0.05976781f, -0.04876324f, 
    0.01144748f, 0.01682900f, -0.06237967f, 0.03633314f, -0.05937333f, -0.06714007f, -0.05196806f, 0.03268595f, 
    0.03298200f, 0.04137314f, 0.02491401f, -0.01479194f, 0.04320315f, 0.01429224f, -0.02748108f, -0.06895637f, 
    0.04841030f, 0.05196830f, -0.02781451f, -0.01586989f, 0.01929476f, 0.03732580f, 0.02891742f, 0.01759541f, 
    0.01632270f, 0.02530659f, -0.03055960f, 0.01508049f, -0.03091827f, -0.07091548f, -0.04052538f, 0.02633900f, 
    0.03917503f, -0.00450458f, -0.03713344f, -0.02713125f, -0.06154246f, -0.01711294f, 0.03317719f, -0.04130848f, 
    -0.02471354f, 0.01991854f, -0.02808560f, 0.00229767f, -0.04484950f, -0.03720443f, 0.03575679f, 0.02378980f, 
    -0.01601877f, -0.06811611f, 0.02251203f, -0.04383809f, 0.00370553f, -0.05590713f, 0.00756556f, 0.03904096f, 
    -0.02521353f, -0.04970819f, -0.01646282f, 0.03617774f, -0.02241902f, 0.04376667f, -0.06513991f, 0.03466212f, 
    0.03482151f, 0.00105664f, -0.03877452f, 0.03703739f, -0.05647493f, 0.00222478f, -0.03054776f, 0.03153579f, 
    -0.06902928f, 0.01588994f, -0.03824472f, -0.00404252f, 0.02091651f, -0.04609649f, 0.04872705f, 0.04181234f, 
    0.04878961f, -0.02719225f, -0.00843521f, -0.06769727f, -0.01301469f, 0.02596421f, 0.04438423f, -0.05666221f, 
    -0.04046900f, -0.01640792f, -0.03785864f, -0.01218612f, -0.00044384f, -0.01897364f, -0.04829644f, 0.03399635f, 
    0.02387366f, -0.01673709f, -0.06730194f, 0.04006692f, -0.00984408f, -0.00229612f, 0.00868639f, -0.01761896f, 
    -0.04849950f, -0.05228090f, 0.05314454f, -0.00422413f, 0.02659400f, -0.06121092f, -0.01590770f, 0.00202809f, 
    -0.04777667f, 0.01362930f, 0.01930949f, -0.01796574f, -0.00398062f, 0.01512746f, -0.04636899f, -0.01985732f, 
    0.01320119f, 0.02079538f, 0.01344638f, -0.00273162f, -0.03265571f, -0.03218248f, -0.03119534f, 0.03912598f, 
    0.01751283f, 0.01585813f, 0.01987403f, -0.05446924f, 0.03025960f, 0.00826602f, -0.05098379f, 0.01569546f, 
    0.00188569f, -0.18009627f, -0.09852426f, 0.00873722f, 0.03823279f, -0.02592362f, -0.13104342f, -0.07077626f, 
    0.06893098f, -0.05966658f, 0.09681231f, -0.00161163f, 0.04313115f, 0.04592974f, 0.11816294f, 0.01253612f, 
    0.02934651f, -0.19428907f, -0.11428156f, -0.02558779f, -0.02200555f, -0.16078326f, -0.00045660f, -0.12788512f, 
    -0.07177244f, -0.13814735f, -0.00464302f, -0.03361815f, 0.33890900f, 0.02280968f, 0.08815280f, -0.08784246f, 
    -0.21145843f, 0.16371620f, -0.22901365f, 0.23390469f, -0.00971986f, 0.08153448f, -0.11928178f, -0.01480475f, 
    0.15009142f, 0.03857724f, -0.07386018f, -0.00232489f, -0.03528881f, 0.41777092f, -0.18467662f, -0.17113248f, 
    0.10236643f, -0.19504718f, 0.06769792f, -0.11229458f, 0.28649423f, -0.00846693f, 0.44692203f, -0.17668396f, 
    -0.05613638f, 0.07293578f, 0.10955847f, 0.11379621f, 0.13423468f, -0.20785543f, 0.22088005f, -0.31803596f, 
    -0.15044266f, -0.17772178f, 0.07049231f, -0.05834534f, 0.00886766f, -0.14083855f, 0.05761305f, 0.00527078f, 
    -0.13845544f, 0.22418500f, -0.20194690f, -0.27976725f, -0.03375540f, 0.28822088f, -0.08203123f, 0.09902982f, 
    0.22513968f, 0.48823830f, 0.12032364f, -0.05146582f, 0.14842166f, -0.09386314f, 0.07475913f, 0.16174316f, 
    0.04286148f, 0.14008535f, -0.54093748f, -0.34328586f, -0.01665954f, 0.16469187f, 0.18514434f, -0.01694236f, 
    -0.19319393f, 0.02557706f, -0.02664572f, -0.32707202f, 0.11155648f, 0.09379184f, 0.10539353f, 0.07808935f, 
    0.02433723f, 0.07823181f, 0.09321874f, 0.02741097f, -0.36692679f, 0.09008219f, -0.41984168f, 0.06378590f, 
    -0.12911841f, -0.06523008f, -0.10688511f, -0.01620972f, -0.19942434f, 0.29299271f, -0.10882149f, -0.05813797f, 
    0.06860679f, 0.05125471f, 0.09141725f, -0.14667036f, 0.06265310f, 0.06836161f, 0.06141809f, -0.06460831f, 
    0.03195834f, -0.00954470f, 0.14436521f, 0.11109371f, -0.14921454f, -0.08002853f, -0.01248187f, 0.16623090f, 
    -0.00879492f, 0.05905458f, -0.02037821f, 0.05218984f, 0.00808745f, 0.17579873f, 0.05617752f, 0.04451887f, 
    -0.26690018f, 0.04308680f, -0.13255361f, -0.04775565f, 0.16051936f, -0.16670510f, -0.03934107f, 0.04947609f, 
    -0.13329741f, -0.19717921f, -0.11472009f, -0.17316033f, -0.16594444f, 0.08854564f, 0.06903096f, -0.17983823f, 
    -0.14282344f, -0.06452637f, 0.31137130f, -0.36363906f, 0.06469990f, -0.00361132f, 0.12624772f, 0.03710230f, 
    0.00617691f, -0.04101567f, 0.15062484f, -0.31954902f, 0.18353437f, -0.27517143f, -0.06678367f, -0.13934630f, 
    -0.10399624f, -0.01028966f, -0.01373634f, 0.00184255f, 0.23376480f, 0.02881684f, -0.16875678f, 0.12391534f, 
    -0.29055521f, -0.11435053f, 0.13532360f, -0.01482371f, 0.03926340f, 0.12270278f, 0.09313778f, 0.02876105f, 
    0.21892342f, -0.18899688f, 0.04654976f, 0.04148578f, 0.06462470f, -0.07520222f, 0.12769686f, 0.12601602f, 
    0.05838643f, 0.04462228f, 0.05544826f, 0.06174743f, 0.04770913f, 0.01479071f, -0.04292141f, 0.12198891f, 
    -0.12617016f, -0.04161122f, 0.14171958f, -0.02432587f, -0.06751542f, -0.02311707f, 0.09110371f, 0.30593511f, 
    0.06726534f, -0.04111120f, -0.05978603f, 0.18433969f, 0.20650569f, -0.00720237f, 0.19701615f, -0.14716260f, 
    -0.01074551f, -0.18845601f, -0.21516585f, -0.34723240f, 0.03325996f, -0.00218117f, -0.11351327f, -0.12063580f, 
    0.09895137f, 0.33175156f, 0.21003118f, -0.12127954f, 0.03232882f, 0.15153500f, -0.10082141f, -0.04584315f, 
    0.07001630f, 0.28838855f, 0.02630401f, 0.54900199f, 0.11841570f, -0.07447091f, 0.17846593f, -0.11532141f, 
    0.04957923f, 0.10308333f, -0.09462024f, 0.31487864f, -0.50962836f, 0.11586751f, 0.03835972f, 0.07452528f, 
    0.16521615f, -0.08169804f, 0.07613313f, 0.12202045f, 0.04212316f, 0.00639665f, 0.06262260f, 0.06293568f, 
    0.03835867f, -0.07253918f, -0.32857797f, -0.05616682f, 0.20546876f, -0.10656416f, 0.06651693f, -0.23394167f, 
    -0.10105005f, -0.04902287f, 0.21030733f, -0.00659953f, 0.08938703f, -0.10074361f, -0.00348382f, -0.17519411f, 
    -0.00607398f, -0.10241635f, -0.01907857f, -0.09712024f, -0.24896421f, 0.06262487f, 0.00311132f, -0.06117403f, 
    -0.25057793f, 0.03454486f, 0.11415373f, 0.18284658f, -0.00556729f, 0.16389740f, 0.06207125f, -0.08409452f, 
    -0.09208605f, -0.02447379f, 0.17716004f, -0.01201245f, 0.21762870f, -0.05364910f, 0.14552058f, -0.07371173f, 
    0.19824038f, 0.24105336f, -0.09803983f, 0.14079705f, 0.02321994f, 0.16173850f, -0.02129697f, 0.19564722f, 
    -0.12658022f, -0.04696595f, -0.08131728f, 0.01279453f, -0.21248628f, 0.14160845f, 0.05254077f, 0.00356332f, 
    0.06969576f, -0.13246465f, -0.08995438f, -0.08339132f, 0.21933399f, -0.12952033f, 0.21168414f, 0.00924515f, 
    0.14009792f, 0.01417434f, -0.13185382f, -0.08097306f, -0.16717993f, -0.13663422f, 0.03995357f, -0.32022494f, 
    0.11794896f, 0.10021183f, -0.04437732f, -0.12943898f, 0.11028393f, 0.11961447f, -0.25204498f, -0.27490038f, 
    -0.08903595f, -0.13535134f, 0.09672455f, -0.04831992f, 0.01494190f, 0.11261756f, 0.03727999f, 0.09763934f, 
    -0.13226284f, -0.10657483f, -0.07272273f, 0.06336104f, 0.00957583f, 0.07032497f, 0.19263904f, -0.06888336f, 
    0.06740516f, -0.00596598f, 0.12956467f, 0.16650797f, 0.02834860f, 0.12643373f, 0.05091614f, 0.16170403f, 
    0.06572625f, -0.16415872f, -0.15837876f, -0.10159808f, 0.09971232f, -0.07175506f, -0.01135296f, 0.06559978f, 
    0.07975156f, 0.08392204f, -0.15784313f, 0.14910975f, -0.25773656f, -0.05273861f, -0.25055870f, -0.27472669f, 
    -0.19021642f, 0.18655579f, -0.09759877f, 0.16117229f, -0.14267442f, -0.02870524f, -0.10122956f, 0.02890973f, 
    0.11453695f, 0.12469993f, 0.06178426f, -0.06581706f, 0.49913427f, -0.13531169f, 0.30126783f, 0.04189445f, 
    -0.21641967f, 0.20775110f, -0.29219070f, -0.17970538f, -0.08510672f, -0.49073541f, 0.12450235f, -0.03395613f, 
    0.10747426f, -0.00537474f, -0.05117989f, 0.16897216f, -0.05564679f, -0.12679833f, -0.00119450f, -0.04782147f, 
    0.27894130f, 0.14957023f, 0.16683145f, 0.12586233f, -0.03169105f, -0.00187795f, -0.05944494f, 0.02157264f, 
    0.04528698f, -0.16563880f, -0.02484507f, -0.05334079f, -0.23687387f, -0.08227167f, 0.03170775f, 0.01265542f, 
    -0.00047186f, 0.24843186f, 0.01792193f, -0.14612216f, 0.00774714f, -0.15068695f, 0.10181581f, 0.00542104f, 
    0.10870519f, 0.00373520f, -0.06911901f, 0.16548429f, 0.02827894f, 0.14935312f, 0.05898796f, -0.09860202f, 
    0.04409775f, -0.24015211f, 0.08749233f, -0.17198184f, 0.00839779f, -0.08326925f, -0.04872185f, -0.00230864f, 
    0.02500595f, 0.13629685f, 0.07995296f, 0.28737590f, 0.01307806f, 0.10992882f, 0.13468416f, 0.06936643f, 
    0.02741122f, -0.02285153f, 0.03750165f, 0.15784307f, 0.12597401f, -0.01866330f, 0.15276358f, -0.06704587f, 
    0.05893685f, 0.00053542f, 0.00114079f, 0.07249246f, 0.04952941f, -0.30016002f, 0.06135448f, -0.22444393f, 
    -0.05895368f, 0.06633718f, -0.09422199f, -0.10644504f, 0.01575303f, -0.07654995f, -0.09286931f, -0.22186908f, 
    0.09161084f, 0.06510733f, 0.04497672f, 0.05538819f, 0.08943411f, 0.20300658f, 0.15845075f, -0.02176610f, 
    0.13151257f, 0.32320592f, 0.06456885f, -0.14124411f, 0.06154545f, 0.16463868f, 0.05826173f, 0.01170588f, 
    0.21787226f, 0.03095833f, 0.16026720f, 0.11477803f, 0.03060392f, -0.22170731f, -0.08694539f, -0.04910427f, 
    -0.14185014f, 0.32363409f, 0.07057877f, 0.17530318f, -0.08485278f, -0.08748681f, -0.19146989f, -0.11275274f, 
    0.04171768f, -0.06169663f, 0.02686441f, -0.04544106f, 0.26790702f, 0.06763572f, 0.10541070f, 0.12831467f, 
    -0.17583473f, -0.11526930f, -0.14976266f, 0.12255240f, -0.13201560f, 0.18781322f, -0.05123691f, -0.09229627f, 
    -0.04178605f, -0.22184151f, 0.03356247f, 0.05138420f, 0.13613531f, 0.02175333f, -0.33547565f, 0.06797047f, 
    -0.13282406f, 0.07487597f, 0.07663381f, -0.01407972f, 0.04337585f, 0.14545210f, -0.03158503f, 0.33753401f, 
    0.11131728f, 0.14421128f, -0.03850507f, 0.08631529f, 0.00460279f, 0.10826957f, -0.09823348f, 0.18023553f, 
    -0.27130872f, 0.07035365f, -0.25317448f, -0.03943424f, 0.03215691f, 0.01603193f, -0.03754756f, 0.37431702f, 
    -0.09183343f, 0.12666799f, -0.03040342f, 0.25120518f, -0.03472242f, -0.06268962f, 0.06367572f, 0.09193972f, 
    -0.32085785f, -0.21492520f, -0.28572890f, -0.04008942f, -0.19139691f, -0.02556816f, 0.04660731f, -0.14369121f, 
    0.17973572f, -0.25127599f, 0.02266397f, -0.12593421f, 0.15838563f, -0.06076977f, -0.17468336f, 0.03065689f, 
    -0.27007753f, 0.08199763f, -0.25625086f, -0.20920354f, -0.17656890f, 0.21273950f, -0.01461946f, 0.16250329f, 
    -0.01789405f, 0.10985681f, -0.10956521f, 0.13390729f, 0.09034073f, 0.29105675f, -0.14027743f, -0.22222754f, 
    0.00993473f, -0.06290162f, -0.03039335f, 0.03660447f, -0.39284784f, 0.16121528f, -0.03688029f, 0.09944519f, 
    -0.06777931f, 0.16227099f, -0.05562652f, -0.12676503f, 0.10293570f, 0.10673525f, 0.18170607f, -0.03906687f, 
    0.00171472f, 0.01492556f, 0.05965748f, 0.13912281f, 0.02060670f, -0.00817467f, 0.08346585f, -0.08586367f, 
    -0.18583499f, 0.10546238f, 0.01573406f, 0.02203935f, -0.14591943f, -0.12514263f, -0.00744609f, 0.10839752f, 
    -0.02369766f, 0.12377154f, -0.01497831f, -0.14069618f, 0.02729122f, 0.01805339f, 0.13476907f, -0.01610669f, 
    0.47300914f, -0.06437860f, 0.24667078f, 0.02885847f, -0.13594460f, 0.12382080f, 0.12243264f, 0.03151135f, 
    0.02148922f, -0.06341713f, 0.13913475f, -0.01325541f, 0.09233077f, 0.08996768f, -0.08997703f, -0.03965037f, 
    -0.03085024f, 0.16991274f, 0.35377869f, 0.17238522f, 0.04983502f, 0.12482464f, -0.05878099f, -0.08011950f, 
    0.23269022f, -0.06080704f, -0.02877385f, 0.06832621f, -0.09414081f, 0.22334985f, 0.03264658f, 0.04169246f, 
    0.09518069f, -0.03457736f, 0.04798986f, 0.03873551f, -0.13860691f, -0.10249648f, -0.02945808f, 0.04670769f, 
    0.03694981f, 0.17162038f, 0.06827193f, -0.05386387f, -0.09739419f, 0.20953162f, -0.09167580f, -0.48014557f, 
    0.00482816f, 0.05669910f, 0.03127106f, 0.05975460f, -0.05433931f, 0.03834721f, 0.09939855f, -0.01811601f, 
    0.09763443f, -0.01775220f, -0.02714474f, -0.03165527f, 0.11783302f, -0.06010643f, 0.00782495f, -0.21627043f, 
    -0.40079045f, -0.31330726f, 0.11441558f, 0.10889082f, -0.08056974f, 0.16125643f, 0.17416726f, -0.05106145f, 
    0.09572649f, -0.05544282f, 0.14523265f, -0.05933760f, -0.00905605f, -0.00656546f, 0.20672703f, 0.06915756f, 
    -0.18927498f, -0.01941090f, -0.11186062f, -0.19921701f, 0.16827771f, 0.16206628f, 0.15008999f, 0.01164169f, 
    0.18071100f, -0.18614577f, -0.11409494f, -0.32245120f, 0.02944509f, 0.07106917f, -0.02254165f, -0.08075383f, 
    0.10914247f, -0.14078140f, 0.13919434f, -0.51810133f, 0.01391534f, 0.04366457f, 0.09695724f, -0.04767573f, 
    -0.04004297f, -0.04157449f, -0.08499219f, 0.11550088f, -0.18338481f, 0.16519737f, 0.01343079f, -0.09553431f, 
    -0.02314838f, 0.00357635f, 0.06593241f, 0.04333518f, -0.05459296f, -0.05885790f, 0.24496660f, 0.06386571f, 
    -0.05000737f, 0.10364382f, 0.09933247f, 0.02368221f, 0.03176302f, 0.12595989f, 0.18788837f, -0.09733506f, 
    -0.03543729f, -0.14156020f, -0.01024279f, 0.00170548f, -0.08184545f, 0.09285030f, 0.02061298f, -0.00815208f, 
    0.08603681f, 0.03480398f, 0.16577454f, -0.04712458f, -0.06754354f, -0.04892601f, -0.20701841f, 0.01663158f, 
    -0.27199841f, 0.05289062f, -0.46589974f, -0.23308940f, -0.11496322f, 0.04834799f, 0.09289682f, -0.09824116f, 
    0.14829829f, 0.08357318f, 0.06400727f, 0.15719238f, -0.01143314f, -0.15015852f, 0.04428083f, -0.03873932f, 
    0.02045444f, 0.01592486f, -0.22809243f, -0.01823850f, 0.05062536f, -0.09368558f, -0.08973503f, 0.02427821f, 
    0.00984199f, 0.11532661f, -0.12702566f, -0.06304852f, -0.21631417f, -0.01004968f, 0.01453641f, 0.11384577f, 
    -0.00189818f, -0.06244827f, 0.00151082f, -0.14698587f, 0.19929655f, 0.02016878f, 0.08662890f, 0.16745447f, 
    0.06953288f, -0.07306866f, -0.11182513f, -0.11932582f, 0.09315569f, -0.14614233f, 0.22101083f, 0.08744308f, 
    -0.22447993f, 0.07868554f, -0.09019784f, 0.12167890f, -0.03621021f, -0.02734912f, 0.11924393f, 0.16891386f, 
    -0.05053451f, -0.18974274f, -0.03077674f, -0.14044544f, 0.21711977f, -0.07289743f, 0.12355200f, -0.02010352f, 
    0.05064067f, -0.00736597f, -0.06092104f, 0.08327930f, -0.01169454f, 0.13244301f, 0.08301565f, -0.25321028f, 
    0.24207309f, -0.01553456f, 0.08763574f, -0.12185159f, 0.12853695f, -0.03191765f, 0.13564406f, 0.18558298f, 
    -0.11718090f, 0.32745844f, 0.13583073f, 0.28347978f, 0.10075313f, 0.11164182f, -0.00989589f, 0.07913801f, 
    0.08614897f, 0.02732285f, 0.17897528f, 0.06456780f, 0.11068346f, 0.10537324f, 0.03017556f, -0.03682356f, 
    -0.01242401f, 0.02402183f, -0.09122411f, 0.17185938f, 0.07749914f, 0.05764817f, 0.18217342f, 0.03029961f, 
    -0.02693085f, -0.18677227f, 0.07668927f, -0.04119771f, 0.08174821f, 0.04094657f, -0.08709867f, -0.04064986f, 
    -0.05199879f, 0.26932383f, 0.07891613f, -0.16001302f, -0.25764760f, -0.05956082f, -0.20877701f, -0.34495980f, 
    0.05602911f, -0.06116480f, 0.18690391f, 0.03116062f, 0.00932561f, -0.06357732f, -0.63321519f, -0.23405465f, 
    -0.03544728f, 0.07948775f, -0.16232799f, 0.02554568f, -0.03625206f, -0.05145256f, 0.10194150f, -0.40495607f, 
    -0.01882985f, -0.12324853f, -0.09596815f, 0.02402145f, -0.04988191f, -0.05681475f, -0.00732486f, 0.04232244f, 
    0.45782450f, 0.11933739f, 0.31053174f, 0.04643779f, -0.14395900f, -0.02241462f, -0.16448905f, 0.24008465f, 
    -0.07017300f, -0.33796597f, -0.12875216f, 0.10905554f, -0.09788736f, -0.15117486f, -0.06095753f, 0.00161798f, 
    -0.04440301f, 0.03124638f, 0.05499544f, 0.03894991f, -0.20139898f, 0.16719273f, -0.00415655f, -0.15612160f, 
    0.17218584f, 0.19874083f, 0.12106989f, -0.09661431f, 0.02422372f, 0.04572411f, 0.02564072f, -0.13048345f, 
    -0.24463460f, 0.02278939f, -0.12323412f, 0.00840202f, -0.17620829f, 0.23479390f, 0.14047788f, 0.15089072f, 
    -0.00266207f, 0.20443252f, 0.01560381f, -0.18785995f, -0.23578618f, -0.21363479f, -0.11918428f, -0.16832131f, 
    -0.06381956f, -0.03172163f, -0.22535639f, -0.09607026f, 0.02431168f, -0.29061568f, 0.28306350f, 0.14085168f, 
    0.17355172f, 0.05020338f, 0.09065504f, -0.06734714f, -0.03843106f, 0.03437262f, 0.22563079f, -0.06478423f, 
    -0.26461428f, -0.11896468f, -0.12107576f, 0.01700371f, -0.07379800f, -0.17524111f, -0.12337720f, -0.16953276f, 
    0.33374947f, 0.00163911f, -0.00396442f, 0.08235932f, -0.14543408f, -0.15854193f, -0.01974986f, -0.05600189f, 
    0.15425493f, -0.15223795f, 0.10700247f, 0.07166401f, 0.11154161f, 0.04053840f, 0.05198655f, -0.14906451f, 
    -0.05521552f, -0.16851017f, 0.01131156f, -0.17432924f, 0.07084896f, 0.01000679f, -0.04927472f, 0.21486121f, 
    -0.09415281f, -0.15601207f, 0.09912969f, 0.06955116f, 0.19439505f, 0.10395216f, 0.12096880f, -0.19005381f, 
    -0.18136206f, -0.01540362f, -0.02410663f, -0.07531911f, 0.20334494f, 0.19609486f, 0.11274084f, 0.14226827f, 
    -0.06048946f, 0.00548354f, -0.13395439f, 0.12494408f, 0.05146807f, 0.08135275f, -0.02675348f, -0.31784901f, 
    -0.01030073f, -0.02621145f, 0.05966280f, -0.07156885f, -0.06493794f, -0.31420112f, 0.23966798f, 0.24741468f, 
    0.19471779f, 0.02637473f, -0.16016121f, 0.00979626f, 0.11615475f, 0.08322311f, 0.18346031f, 0.04766327f, 
    0.16528802f, 0.09103172f, -0.08135544f, -0.09183031f, -0.24738479f, 0.02904660f, 0.01229045f, 0.06463323f, 
    0.33764926f, 0.08743733f, 0.03338193f, -0.07299431f, -0.09558510f, -0.02859663f, 0.04998473f, 0.14895856f, 
    -0.13871352f, 0.07498442f, -0.04346886f, -0.06857890f, -0.05311960f, 0.02378432f, -0.21836542f, 0.13941883f, 
    -0.06015759f, 0.03382563f, 0.10267109f, 0.21277304f, 0.19951150f, 0.17042783f, 0.00260860f, -0.10440861f, 
    0.00020186f, -0.05941762f, -0.17327006f, -0.03837252f, -0.33382103f, 0.04071550f, -0.08799782f, -0.10721680f, 
    -0.02543415f, -0.09183324f, -0.14316984f, -0.11125535f, -0.08342995f, 0.03410157f, 0.06032225f, 0.09781282f, 
    -0.05188106f, -0.10015581f, 0.05346692f, -0.03147705f, 0.02987283f, 0.22664976f, 0.20930408f, 0.12083258f, 
    0.14140874f, -0.18583766f, -0.12648048f, 0.07140703f, 0.11601011f, 0.03265001f, -0.26229933f, 0.10729703f, 
    -0.13602132f, 0.04880639f, -0.07336073f, -0.04783569f, 0.03501873f, 0.08681104f, 0.01086791f, -0.02299763f, 
    0.03489340f, 0.00651962f, 0.23729727f, 0.07397681f, -0.15663303f, 0.07661359f, -0.01052255f, -0.04088661f, 
    -0.01844082f, -0.18929613f, -0.05537654f, 0.03000937f, -0.14178772f, 0.05073455f, -0.06169025f, 0.09887902f, 
    -0.03323519f, 0.14156078f, -0.23354989f, 0.07422903f, -0.08558942f, -0.01356178f, -0.13797055f, -0.09798659f, 
    -0.00435101f, -0.05348085f, -0.09012713f, -0.02030695f, -0.03028955f, 0.19013330f, 0.14013964f, -0.01214420f, 
    0.15419915f, 0.05231706f, 0.16147208f, -0.01204063f, 0.09063817f, 0.23183706f, -0.02860034f, -0.10660534f, 
    -0.03291246f, 0.05165961f, 0.03586078f, 0.07370152f, -0.09430412f, 0.01763720f, 0.03268632f, 0.07451808f, 
    -0.10670380f, -0.12417174f, 0.04981272f, -0.02087686f, 0.09565088f, 0.22949834f, 0.32818440f, -0.39658207f, 
    0.07299357f, 0.05716076f, 0.02347900f, -0.03405070f, 0.02345239f, -0.17267080f, -0.01102361f, -0.07985732f, 
    -0.25155804f, 0.24953644f, 0.00037847f, 0.07316596f, 0.04828680f, -0.18191870f, 0.02283010f, 0.17827399f, 
    -0.11157435f, -0.02033230f, -0.02435766f, -0.09198014f, 0.07245173f, 0.05227019f, 0.12498011f, 0.07246504f, 
    0.14894678f, 0.10101840f, 0.00129657f, -0.35768443f, 0.02288134f, 0.00258286f, -0.03573006f, 0.03428670f, 
    0.09375890f, 0.02879658f, -0.01330724f, 0.03551313f, 0.19313937f, -0.00444303f, 0.07530977f, 0.00221767f, 
    0.08533381f, -0.14256400f, 0.48600119f, 0.26316127f, 0.35889539f, -0.16092834f, -0.19822951f, 0.04827132f, 
    0.01763204f, -0.02014632f, -0.05358885f, 0.02860559f, -0.11165531f, 0.01658781f, -0.19948044f, 0.11780025f, 
    -0.02144212f, -0.16627297f, -0.03408448f, 0.04379569f, 0.17884007f, -0.06722879f, -0.20142107f, -0.23338386f, 
    0.08811301f, 0.14402358f, 0.10708718f, -0.10944925f, 0.18727659f, -0.00013616f, -0.00451455f, -0.22141355f, 
    0.23006628f, 0.03218277f, -0.19685858f, -0.00640729f, 0.01309650f, -0.09378446f, 0.04924162f, -0.08036625f, 
    0.09835612f, 0.05781056f, -0.06224867f, 0.01107020f, -0.04472555f, -0.12174565f, 0.02174004f, 0.19836314f, 
    0.03083473f, -0.17916602f, 0.10782122f, -0.19045992f, -0.03942288f, 0.05624541f, -0.10605861f, -0.15678693f, 
    0.10215976f, -0.18446077f, -0.01564150f, -0.10383008f, -0.05794168f, 0.11942043f, 0.07207914f, 0.01901124f, 
    -0.03291628f, -0.05362035f, 0.14291364f, -0.23701994f, 0.10786181f, 0.12055194f, 0.04579449f, 0.09997268f, 
    0.07645134f, 0.16472058f, 0.03546732f, 0.19153550f, -0.36599940f, 0.01754089f, 0.13356337f, 0.05952479f, 
    0.01959499f, -0.06712546f, -0.03361156f, -0.14992233f, 0.10282922f, 0.03006042f, 0.05788218f, -0.03384625f, 
    -0.16246614f, -0.03127479f, 0.00104091f, 0.06922491f, 0.09800898f, 0.07293051f, 0.15542127f, -0.12191400f, 
    -0.23376374f, -0.23654369f, -0.03918125f, -0.00136605f, -0.10545602f, 0.09931678f, 0.13317324f, 0.05998964f, 
    0.11786752f, 0.16797161f, -0.01104834f, -0.06669719f, 0.05408726f, -0.03076439f, 0.09707361f, -0.13283253f, 
    0.16322407f, -0.02747611f, -0.08814302f, 0.11646918f, -0.12224382f, 0.06832624f, 0.03440043f, -0.26930624f, 
    -0.19299915f, -0.20262691f, 0.08755925f, 0.11086565f, -0.18914096f, -0.17463471f, -0.01071770f, -0.15872234f, 
    -0.15331914f, -0.09631339f, -0.15657380f, 0.28154054f, 0.02484467f, 0.04568132f, 0.03822777f, -0.11743432f, 
    -0.01288061f, 0.31509042f, -0.00954870f, -0.00040884f, -0.12032776f, 0.08916944f, -0.07142198f, 0.05341267f, 
    -0.09287254f, -0.10398103f, -0.17478552f, 0.20437354f, 0.09465168f, -0.07814657f, 0.01502031f, -0.30811664f, 
    -0.06197019f, 0.11471722f, 0.00857064f, -0.25944188f, -0.02829718f, -0.24709134f, 0.15868899f, 0.17267010f, 
    0.19337253f, 0.01353458f, -0.01224414f, -0.13152705f, 0.29430258f, -0.01750582f, 0.08577862f, -0.06477996f, 
    -0.01609638f, 0.06478394f, 0.01553893f, -0.02209033f, 0.03626249f, -0.06761004f, 0.09178356f, 0.30834499f, 
    -0.25168574f, 0.09692955f, -0.08694046f, -0.00720519f, 0.06362738f, -0.01086598f, 0.16294870f, 0.01417136f, 
    -0.15153545f, 0.06135619f, -0.25380546f, 0.00684279f, 0.19302680f, -0.15870009f, 0.20400885f, -0.24757859f, 
    0.11018666f, 0.06578030f, -0.04128075f, 0.19566460f, 0.07298053f, 0.00467406f, -0.00090087f, -0.06321023f, 
    0.50418788f, -0.12200189f, -0.01349305f, 0.14830418f, -0.17729768f, -0.01391006f, 0.01990220f, -0.00465094f, 
    -0.08919804f, 0.51712334f, 0.03878464f, 0.07638580f, 0.08793757f, 0.10140336f, 0.11660835f, 0.03699479f, 
    -0.02751624f, -0.02272592f, 0.66913396f, -0.09289854f, 0.03655314f, 0.10532480f, -0.02769621f, -0.02663053f, 
    -0.14668772f, 0.11236876f, -0.05191532f, -0.14029996f, 0.21983209f, -0.32037824f, 0.01596539f, 0.00796519f, 
    -0.01966856f, 0.22378859f, 0.01805986f, 0.02097027f, -0.00736064f, -0.05312186f, 0.01084473f, 0.00030239f, 
    0.02504822f, 0.11889876f, -0.21835048f, 0.06759214f, 0.05236894f, -0.29688644f, -0.09126333f, 0.13400574f, 
    -0.20756690f, 0.11017477f, -0.17199366f, -0.15197723f, -0.04249547f, -0.08560151f, -0.07675010f, 0.10014881f, 
    0.14309222f, -0.04408141f, -0.09431186f, -0.24888520f, -0.13335928f, 0.11133768f, -0.16201298f, -0.02842078f, 
    0.12845539f, -0.04719337f, 0.06857947f, 0.02675323f, -0.10055015f, 0.01499826f, -0.07066094f, 0.06751717f, 
    -0.27440473f, -0.18368469f, -0.04983658f, 0.21368915f, 0.15900724f, -0.18100312f, -0.06862862f, -0.21928240f, 
    -0.08996725f, 0.06299399f, 0.18178758f, -0.18303245f, -0.27855933f, -0.17116868f, -0.10747209f, -0.01230230f, 
    -0.09301581f, 0.00435100f, 0.25304657f, 0.09401415f, -0.32584429f, 0.06656250f, 0.07965373f, -0.05206654f, 
    -0.12678932f, -0.02210520f, -0.01012162f, -0.04661046f, 0.34463707f, -0.20631455f, 0.19867414f, -0.00536284f, 
    0.05476720f, 0.01231026f, -0.02379691f, -0.23403032f, -0.16481833f, -0.44149783f, 0.01243522f, 0.07013638f, 
    0.06415218f, -0.13060831f, -0.17748982f, 0.04433072f, 0.09710760f, -0.19757381f, -0.04603139f, 0.06152255f, 
    -0.20492810f, 0.14391485f, 0.01971553f, -0.14275473f, 0.04332934f, -0.02910192f, 0.21744405f, 0.36906579f, 
    0.04487155f, 0.22243744f, 0.08762690f, 0.17271920f, -0.03176251f, -0.08198341f, 0.13925205f, -0.13711989f, 
    -0.20634028f, 0.17361233f, -0.22361019f, -0.16540642f, -0.17110460f, 0.10006683f, 0.24240349f, -0.00481585f, 
    0.06723579f, 0.25809035f, -0.06567403f, 0.04856528f, -0.10925259f, 0.05263080f, 0.19838186f, 0.12322885f, 
    0.12678796f, -0.01488013f, 0.08832777f, -0.02983252f, 0.02591814f, -0.00788554f, -0.00413236f, 0.07269955f, 
    0.01711431f, 0.10500462f, -0.29377463f, 0.10685255f, 0.10496755f, 0.04333518f, -0.00124452f, -0.23355457f, 
    0.02322324f, 0.13341555f, 0.06828756f, -0.50494260f, 0.01046307f, 0.01711365f, -0.03398510f, 0.00278695f, 
    0.02212428f, 0.11125682f, 0.13649723f, -0.01809943f, 0.11772068f, -0.08584645f, 0.12518844f, -0.00331560f, 
    -0.02462217f, -0.17364128f, -0.00009376f, -0.13138823f, 0.11383019f, -0.13351776f, -0.12781855f, 0.10441363f, 
    -0.34214464f, -0.05247846f, 0.08867852f, -0.10065558f, -0.14500535f, -0.10683171f, -0.04823531f, 0.14352666f, 
    0.18975420f, 0.34486175f, 0.13615374f, 0.08282007f, -0.02581257f, -0.12240972f, 0.01743964f, -0.03423202f, 
    -0.17715506f, 0.06487352f, 0.10087105f, 0.09639265f, 0.17466658f, -0.06387380f, -0.02608095f, 0.07859995f, 
    -0.13284965f, -0.01981091f, -0.06352384f, -0.36544919f, 0.01685604f, 0.02228628f, 0.05394482f, -0.00806347f, 
    -0.15750071f, 0.40459988f, -0.19994460f, 0.13085546f, -0.05390935f, -0.08942651f, -0.22379565f, 0.00352634f, 
    0.10269617f, 0.07057110f, 0.54727495f, -0.22700869f, -0.30773976f, -0.00770456f, 0.10605565f, 0.27813151f, 
    -0.06957162f, -0.02225464f, -0.07712740f, 0.06096126f, 0.09442709f, 0.24373318f, -0.22156712f, -0.08502854f, 
    -0.05713115f, 0.04524969f, 0.14637765f, 0.01459343f, 0.53456503f, 0.07710505f, 0.23654887f, -0.10262766f, 
    0.07917678f, -0.25310782f, 0.00797091f, -0.11837000f, 0.06900272f, -0.07512178f, 0.37062967f, 0.07712584f, 
    0.05896062f, 0.09990390f, 0.06033573f, -0.11099376f, 0.09233574f, 0.12734899f, -0.05268298f, -0.14113234f, 
    -0.06730835f, -0.13522583f, -0.02653704f, 0.02781752f, -0.02511712f, 0.11189134f, -0.04615711f, -0.51379055f, 
    -0.00091651f, -0.12655368f, -0.10579913f, 0.18263231f, 0.03722398f, -0.05017870f, 0.12443995f, 0.23367788f, 
    0.24296464f, 0.10278624f, -0.12556796f, -0.07257526f, -0.05764039f, 0.16037504f, -0.04565387f, -0.02991170f, 
    0.03982784f, -0.19055991f, 0.04779990f, 0.04647679f, -0.29632205f, 0.11572179f, 0.04548596f, 0.08648851f, 
    -0.10404769f, 0.02778652f, 0.25868240f, -0.03977281f, -0.12674862f, 0.01421180f, -0.06719532f, 0.05245177f, 
    0.11381236f, -0.00928109f, 0.03267855f, 0.23182447f, -0.04497712f, -0.05250972f, -0.04038504f, 0.03432496f, 
    -0.12669255f, 0.03599163f, 0.26382995f, -0.13108121f, -0.09345080f, -0.11228436f, -0.05066928f, 0.16359337f, 
    0.27533996f, 0.26041272f, 0.14617570f, 0.08949545f, -0.11842400f, -0.17077583f, -0.00365597f, 0.13026656f, 
    -0.05557388f, 0.09888494f, -0.05541729f, -0.14459264f, 0.27367750f, -0.13250592f, -0.97627014f, -0.22344768f, 
    -0.20141844f, 0.07699227f, 0.22069180f, -0.00593768f, 0.07338047f, 0.06796356f, 0.10034378f, -0.30804136f, 
    0.03177183f, -0.13598607f, -0.05736713f, 0.09284395f, 0.06697825f, 0.11310399f, -0.05451835f, -0.14079723f, 
    -0.21132179f, -0.31122589f, -0.16733222f, -0.41551286f, -0.17160483f, -0.17734082f, -0.14675225f, -0.10834303f, 
    0.05559568f, -0.61493671f, -0.21160394f, -0.11658635f, 0.03523915f, 0.11057297f, -0.02974006f, 0.08562880f, 
    0.08717862f, -0.12629601f, 0.14729878f, 0.33911142f, -0.21211909f, 0.10685173f, -0.10242861f, 0.04025824f, 
    0.04297456f, 0.15780929f, -0.01137105f, 0.00434162f, 0.11618810f, -0.04772935f, 0.05041103f, -0.01462428f, 
    -0.12490450f, -0.04487244f, 0.23182280f, -0.04907341f, 0.04077816f, 0.40628311f, 0.35342449f, 0.30918658f, 
    0.17399828f, -0.13251497f, -0.12051690f, 0.18013735f, 0.06484997f, -0.11387651f, 0.03876525f, 0.20033325f, 
    0.12259746f, 0.08956897f, -0.04218344f, 0.02021137f, 0.20068549f, 0.22673060f, 0.33405831f, 0.18497077f, 
    0.09256558f, -0.10020218f, -0.07547326f, 0.02129477f, -0.08819766f, 0.20285662f, -0.13195236f, 0.34849691f, 
    0.27538183f, 0.18880014f, 0.03417480f, -0.00814137f, -0.05837863f, 0.01072975f, -0.03812603f, 0.06874395f, 
    0.07921474f, -0.11502950f, -0.03746257f, 0.02792387f, 0.06795778f, 0.20687576f, 0.11207899f, 0.13357428f, 
    0.02998934f, -0.16632120f, 0.12759881f, 0.04712847f, 0.13950552f, 0.06551836f, -0.03996887f, 0.09593714f, 
    -0.00827627f, -0.08777198f, 0.51988804f, 0.42571044f, 0.27132758f, 0.03807587f, 0.04496441f, -0.13268240f, 
    -0.04631193f, -0.03562806f, 0.18017331f, -0.09186888f, 0.02006129f, -0.03195708f, 0.03137560f, -0.01073696f, 
    0.08637765f, -0.09516681f, 0.04346008f, 0.04668884f, 0.11836480f, -0.02538242f, -0.02327149f, -0.02958355f, 
    -0.04716379f, 0.07207253f, 0.00867279f, 0.04619365f, 0.19864339f, 0.23225816f, 0.03379827f, 0.13339022f, 
    0.04518597f, 0.02443599f, -0.10183735f, 0.12269321f, 0.29609615f, 0.20002951f, 0.14641629f, 0.15908498f, 
    0.07695597f, -0.24470426f, 0.00692228f, 0.08576667f, -0.05661410f, 0.11143291f, 0.12854248f, -0.41417912f, 
    -0.47526708f, -0.19816704f, -0.07617068f, 0.07689787f, -0.07469224f, -0.10348553f, 0.08082704f, -0.23558846f, 
    0.27915248f, -0.26937559f, -0.30185470f, 0.04106371f, 0.10559510f, 0.12070591f, -0.03739403f, 0.12628357f, 
    -0.06381164f, -0.74388319f, -0.22031322f, -0.31310976f, 0.18618040f, 0.01738543f, 0.08782569f, 0.12688304f, 
    -0.10976827f, 0.03478507f, 0.19026834f, -0.15536274f, 0.10622781f, -0.00124895f, 0.05345075f, -0.07461518f, 
    0.01171037f, 0.05370259f, 0.12046776f, -0.64502114f, -0.20011958f, -0.13641843f, 0.27217245f, 0.11247629f, 
    0.02254286f, 0.03931123f, 0.11624434f, -0.16094926f, -0.07767140f, 0.06469484f, -0.31616661f, 0.04276314f, 
    -0.10734914f, 0.11446310f, 0.25424084f, -0.06707643f, -0.04495615f, -0.03812936f, 0.00124885f, -0.05854274f, 
    -0.26081833f, 0.06402869f, 0.11143388f, -0.10610446f, 0.13578074f, -0.02413747f, -0.65585130f, -0.29105955f, 
    -0.41872823f, 0.07543908f, 0.08160299f, 0.09109081f, 0.15447754f, -0.03733950f, 0.22305837f, -0.02568686f, 
    -0.05615200f, -0.08718801f, -0.08167600f, 0.05986822f, 0.08063157f, 0.06849608f, 0.03966816f, -0.20467210f, 
    0.41378170f, -0.14302659f, 0.04588050f, 0.01182731f, -0.24491812f, 0.16883682f, -0.18861589f, 0.04982337f, 
    0.06018563f, -0.06237882f, 0.32500851f, -0.05176048f, 0.24857198f, -0.09072864f, -0.16093665f, -0.00974278f, 
    0.12459526f, -0.01009433f, 0.29253429f, -0.25700656f, 0.12542121f, 0.01637326f, -0.23565608f, -0.02665197f, 
    0.15262982f, 0.08418053f, -0.14559619f, -0.13242474f, 0.32135233f, -0.38869023f, 0.19187023f, 0.00615598f, 
    -0.03005321f, 0.05919259f, 0.23790398f, 0.09252963f, -0.26544264f, 0.08884767f, 0.10434920f, -0.07818183f, 
    0.16628291f, -0.11229078f, -0.00002840f, 0.08623423f, 0.05596901f, 0.17823501f, 0.09799285f, -0.29431733f, 
    0.02042641f, 0.08286966f, 0.09120639f, -0.03657312f, -0.08171263f, -0.00120564f, 0.14788492f, 0.02072118f, 
    0.05181304f, -0.07370459f, 0.10374624f, -0.01918458f, -0.05971316f, 0.19807582f, 0.03630316f, -0.08670432f, 
    0.05979941f, 0.29521835f, 0.08822649f, -0.15300260f, -0.04652673f, 0.04634197f, -0.03788267f, -0.14390391f, 
    -0.36949515f, -0.02932698f, -0.00246462f, 0.15796275f, 0.13961788f, -0.09737372f, -0.15655684f, 0.02755126f, 
    0.27806515f, 0.24356526f, 0.23360957f, -0.07139378f, -0.15348196f, -0.04873344f, 0.02424795f, -0.11445803f, 
    0.02827663f, -0.11933506f, -0.04930048f, 0.01156690f, -0.13052857f, 0.06901996f, 0.14788599f, 0.00910380f, 
    0.18112582f, -0.02395323f, 0.02241611f, -0.41000286f, -0.04597732f, -0.09725747f, 0.10363644f, -0.00811356f, 
    0.13301852f, 0.07284222f, 0.08907357f, -0.01113382f, 0.04906300f, -0.27345872f, 0.07728493f, -0.00049609f, 
    0.01392542f, 0.04116770f, 0.17284758f, 0.04720584f, -0.02044845f, -0.00848358f, -0.10926449f, 0.09007559f, 
    -0.22036006f, 0.07929283f, -0.23093286f, -0.16815709f, 0.06789647f, 0.15397829f, 0.21748222f, 0.30962968f, 
    -0.29645538f, 0.12064850f, 0.11726642f, -0.00930338f, -0.12400679f, -0.02643487f, -0.03852071f, 0.06913000f, 
    0.24461475f, 0.22099470f, 0.02750069f, 0.01804080f, 0.03385288f, -0.06836100f, -0.00278105f, 0.14869067f, 
    0.13875194f, 0.11599774f, 0.31991497f, -0.00271691f, 0.13050339f, -0.08908527f, 0.06989257f, -0.03272734f, 
    -0.06108868f, -0.16019002f, -0.16042380f, 0.01354123f, -0.16272832f, -0.20715477f, -0.19756086f, -0.16984583f, 
    -0.03775810f, 0.14882909f, -0.08868530f, 0.14143260f, -0.14845067f, 0.24775115f, -0.04585993f, 0.02996998f, 
    -0.10583469f, 0.12626180f, 0.04282903f, -0.75366354f, -0.01431488f, -0.34784737f, 0.05916138f, 0.01269441f, 
    0.10986567f, -0.01587597f, 0.10963300f, -0.00371957f, -0.03330892f, -0.26900947f, -0.15670118f, 0.10942902f, 
    0.17385095f, 0.01475866f, 0.04916201f, 0.20035289f, 0.25348079f, 0.02749005f, 0.14059804f, 0.00349955f, 
    0.17157291f, 0.01438296f, -0.07263068f, -0.00374740f, -0.08436203f, 0.10520039f, 0.01524885f, 0.13028806f, 
    -0.46887168f, 0.14271452f, 0.13858426f, 0.08784623f, 0.00229177f, 0.07762792f, 0.11196322f, 0.01980813f, 
    -0.23314269f, -0.14419065f, -0.17547695f, -0.16346680f, 0.09895439f, -0.19434316f, 0.06550289f, 0.08580834f, 
    -0.18428445f, 0.30310091f, 0.14061812f, -0.06152660f, -0.03529500f, -0.13321471f, 0.01414040f, -0.17701630f, 
    0.18723030f, 0.08083747f, -0.53890729f, -0.11008003f, -0.20426629f, 0.02491271f, -0.08305584f, 0.20730713f, 
    0.10412623f, 0.03279630f, 0.49093550f, -0.01671969f, -0.42748454f, -0.08618277f, 0.11683246f, 0.04035836f, 
    -0.03821163f, -0.01131648f, 0.00256808f, 0.10836167f, 0.16905561f, -0.02153123f, 0.08925646f, -0.06036948f, 
    -0.12811717f, -0.02759255f, -0.14495778f, -0.14630802f, -0.08219858f, -0.17482120f, 0.66764653f, 0.08171767f, 
    -0.07802494f, -0.17385951f, -0.13835330f, -0.19024859f, 0.12818687f, -0.09354144f, 0.36870730f, -0.21300216f, 
    0.04305009f, 0.03950484f, 0.12405127f, -0.08530757f, -0.09927251f, -0.11603024f, -0.11501851f, -0.21206924f, 
    0.39168060f, -0.02966379f, 0.12279673f, -0.03381513f, 0.20977362f, 0.01841925f, -0.05078292f, -0.18709885f, 
    0.32335186f, 0.00452759f, -0.09194152f, 0.05456917f, 0.01536819f, 0.02438609f, -0.00430613f, -0.03074420f, 
    -0.01968193f, -0.06488656f, 0.04474364f, -0.05331710f, 0.00101650f, 0.00240179f, 0.02733517f, 0.04836083f, 
    -0.05681649f, 0.01201050f, 0.04895689f, 0.01417505f, 0.03976712f, 0.00493021f, 0.04142085f, -0.00865168f, 
    -0.03469810f, -0.01934920f, -0.05322038f, 0.00829182f, 0.04779662f, 0.03043221f, 0.02404999f, -0.04557297f, 
    0.04256164f, 0.04227432f, -0.00591001f, -0.05287740f, 0.04695965f, 0.00016335f, 0.03784497f, -0.02648409f, 
    -0.06498308f, -0.04017460f, -0.02327842f, -0.02862974f, 0.02290448f, 0.03029413f, -0.03698098f, 0.03888341f, 
    -0.04969278f, 0.03833583f, -0.03465429f, 0.03856171f, -0.03809392f, 0.01779207f, 0.04333931f, -0.06367488f, 
    -0.05294208f, -0.02598929f, -0.01213541f, -0.06559310f, -0.02592087f, -0.00285387f, -0.04983175f, -0.01073984f, 
    -0.05200268f, 0.04830157f, -0.06312844f, 0.04851283f, -0.06235575f, 0.02132037f, 0.01341868f, -0.01236552f, 
    -0.04582642f, 0.03302991f, 0.01606478f, 0.01091257f, -0.05163804f, 0.03060966f, -0.04529194f, 0.04079450f, 
    -0.05324911f, -0.00032189f, -0.06559554f, -0.06238697f, -0.02896963f, -0.02388929f, -0.02409453f, 0.00224541f, 
    -0.04583792f, 0.02544398f, 0.00483978f, 0.02184724f, 0.01451880f, -0.01962148f, -0.04431944f, -0.04141201f, 
    0.02683285f, -0.00036371f, 0.03482984f, -0.04762723f, 0.00043973f, -0.02415552f, 0.01104237f, -0.02330014f, 
    0.01690175f, -0.06559620f, 0.00395109f, -0.03590591f, 0.01117362f, -0.05440472f, -0.04418671f, -0.00255098f, 
    -0.05763988f, 0.03434825f, -0.03692587f, 0.01648861f, 0.02841565f, 0.03638948f, 0.01384707f, 0.04937930f, 
    -0.06479504f, -0.02077399f, -0.01223984f, 0.00362652f, -0.00200465f, 0.02190414f, -0.01417125f, -0.01267815f, 
    -0.03866732f, 0.00631898f, 0.00024547f, 0.01961237f, -0.03594028f, -0.03787244f, -0.00912353f, -0.06315230f, 
    -0.05397414f, 0.00309837f, 0.04822612f, -0.02321083f, -0.04371196f, -0.05407132f, -0.02486767f, 0.04277976f, 
    -0.04603722f, -0.04796553f, -0.03406718f, 0.04549262f, -0.00082852f, 0.00124145f, 0.01568815f, 0.03070839f, 
    0.01158498f, 0.03776922f, -0.05873648f, 0.02581803f, -0.00262148f, -0.03804858f, 0.01641672f, -0.06342075f, 
    0.02098042f, 0.02898427f, -0.05795388f, 0.02767662f, 0.00419479f, 0.03593171f, -0.04300270f, 0.04679252f, 
    0.02392554f, -0.04333699f, 0.02942122f, 0.02121276f, -0.06670947f, -0.04538675f, -0.02378748f, 0.00758767f, 
    -0.02167367f, -0.02201731f, 0.00515832f, 0.01228725f, -0.02838062f, -0.01647657f, -0.00516774f, -0.05574473f, 
    -0.03755396f, 0.00071672f, 0.03644354f, -0.00382157f, -0.00934916f, -0.04743609f, -0.05800559f, -0.06433810f, 
    0.02987322f, -0.05595165f, 0.00984242f, -0.06550606f, -0.05803015f, -0.04986728f, -0.04160445f, 0.00049453f, 
    0.02045384f, 0.00292134f, 0.01042355f, -0.01129511f, 0.03252225f, 0.00434602f, -0.01395731f, -0.06544339f, 
    -0.02827745f, -0.04091893f, -0.03492583f, 0.02851843f, 0.01215210f, -0.00773796f, -0.02656499f, -0.05822320f, 
    -0.02421068f, 0.00045131f, 0.02647456f, -0.00636385f, -0.05475729f, 0.00118326f, 0.02562385f, 0.03685506f, 
    -0.03349943f, -0.04663857f, -0.03882024f, -0.00897970f, -0.03423763f, -0.04879423f, 0.01563043f, 0.00633017f, 
    -0.04818152f, -0.00313703f, -0.05280337f, -0.03810926f, 0.00844055f, -0.05382376f, -0.02179036f, 0.03655238f, 
    0.05103210f, -0.05266952f, 0.01368545f, -0.00618593f, -0.00059538f, 0.00698727f, 0.03454145f, -0.02009805f, 
    -0.00598333f, 0.01402546f, -0.05720909f, -0.00109847f, 0.01575236f, 0.03982351f, 0.02536300f, 0.03065600f, 
    -0.03874649f, 0.03275593f, -0.02959883f, 0.01674781f, -0.02524912f, -0.06339069f, -0.01333550f, -0.03771502f, 
    0.02237242f, 0.00685117f, 0.00016314f, 0.00119523f, 0.04176822f, 0.03627861f, 0.04667569f, 0.05037357f, 
    0.02552866f, -0.04205389f, 0.03551095f, 0.04259333f, 0.02934390f, 0.01900843f, -0.04535457f, -0.00764017f, 
    -0.00603244f, -0.05945872f, 0.01334200f, 0.00134966f, -0.02072953f, -0.06416401f, 0.03868760f, -0.02395042f, 
    0.00931696f, 0.02134416f, 0.03352846f, -0.06227018f, -0.02580383f, -0.00327173f, -0.05097738f, -0.01135917f, 
    -0.08110343f, -0.01293321f, 0.04359613f, 0.04797615f, 0.10362360f, -0.07107843f, -0.05117104f, 0.12804839f, 
    -0.03581287f, 0.17899674f, 0.09851836f, 0.08003705f, 0.11573372f, 0.09152268f, -0.09480467f, -0.18485494f, 
    -0.13388453f, -0.09764624f, -0.14816061f, -0.08581252f, -0.21942121f, 0.01383669f, -0.05451548f, -0.09529304f, 
    0.00308243f, -0.02460741f, 0.05618408f, 0.25702557f, -0.00425288f, -0.18300951f, -0.08140939f, 0.11696249f, 
    0.00162209f, 0.07064461f, -0.12624335f, 0.17493095f, 0.27420333f, -0.06499641f, -0.01739081f, -0.02912601f, 
    -0.03352365f, 0.22182894f, -0.10448024f, 0.13113126f, -0.07511574f, -0.21033451f, 0.15479097f, -0.16063955f, 
    -0.06052311f, -0.01458979f, -0.05100685f, -0.21938230f, -0.04151673f, 0.04208702f, -0.11105411f, 0.17311831f, 
    -0.28074783f, 0.03853195f, 0.11876132f, 0.05226364f, -0.15789373f, 0.20376779f, 0.08629862f, 0.19533369f, 
    -0.10769159f, -0.27299914f, -0.02582176f, 0.02917458f, 0.00080934f, -0.03379325f, 0.13045694f, 0.24959806f, 
    0.02587944f, 0.07626152f, -0.19341439f, -0.06445292f, 0.02657156f, 0.16630617f, -0.09228445f, 0.20138700f, 
    0.10260130f, -0.06982670f, 0.18780957f, -0.08373481f, -0.03947542f, -0.09043861f, 0.17523554f, 0.11572593f, 
    0.08813700f, 0.20655650f, -0.29667163f, 0.05327282f, 0.25685385f, -0.02266361f, -0.00523157f, 0.02611554f, 
    0.01297248f, 0.14184228f, 0.19135869f, 0.33728993f, 0.06426974f, 0.03254027f, 0.05203066f, 0.03575242f, 
    0.17733325f, -0.05604629f, 0.06233280f, -0.07034123f, -0.11630845f, 0.00836504f, -0.18514194f, 0.11613753f, 
    -0.00730552f, 0.34585431f, -0.10881468f, -0.07012757f, -0.06323477f, 0.17337096f, -0.15593347f, 0.05111779f, 
    -0.11536817f, -0.04710338f, 0.03057241f, 0.08966654f, 0.10070287f, 0.02863250f, 0.26714614f, 0.12571515f, 
    0.10171355f, -0.04984256f, -0.04541503f, -0.10303315f, 0.08668999f, -0.11270960f, -0.18028252f, -0.38241908f, 
    -0.01142677f, -0.09931929f, 0.03233011f, 0.11403666f, 0.12820104f, -0.06543653f, 0.13591474f, -0.12866656f, 
    0.21247502f, 0.06796325f, -0.02811712f, 0.10033485f, 0.10158597f, 0.01259309f, 0.10394083f, -0.08177456f, 
    0.03791202f, -0.27371487f, -0.03739734f, -0.31189525f, 0.11291316f, -0.05546058f, -0.02987828f, -0.05319140f, 
    -0.08840985f, -0.09528763f, -0.17269379f, 0.10413250f, -0.29674920f, -0.11991987f, 0.14756143f, 0.12210938f, 
    -0.11402698f, -0.14792107f, -0.00643496f, 0.35156590f, 0.02415765f, -0.03327200f, 0.01407273f, 0.04383138f, 
    -0.08262191f, -0.10828068f, -0.00644395f, 0.01353484f, 0.07426526f, -0.04092311f, 0.06066335f, -0.09515596f, 
    0.03201021f, -0.02026994f, -0.02064169f, 0.03101704f, -0.06028521f, -0.31477025f, -0.22869915f, 0.15466617f, 
    -0.08803421f, -0.06613411f, 0.05285941f, 0.07812894f, 0.07582118f, -0.03549592f, 0.24062322f, 0.13422202f, 
    0.32378328f, 0.04489709f, -0.05430005f, 0.10767218f, 0.13290381f, 0.02368755f, -0.16063835f, 0.25851348f, 
    -0.42748356f, -0.22670558f, -0.24629876f, 0.01170466f, 0.00472078f, 0.17547718f, 0.03732627f, 0.23627141f, 
    -0.37754306f, -0.09898667f, -0.13589558f, 0.13702826f, 0.16133355f, -0.06041292f, -0.14512710f, -0.05852282f, 
    -0.12032172f, -0.00593490f, -0.34707716f, -0.03173095f, 0.16575548f, -0.10600477f, 0.03337352f, -0.08638847f, 
    0.12137873f, 0.15659380f, 0.00222671f, 0.09250820f, -0.09174384f, 0.21567278f, 0.10011396f, 0.01495843f, 
    0.16379224f, -0.00856925f, -0.18188819f, -0.22060883f, 0.03854266f, -0.17754154f, -0.05026352f, 0.05958379f, 
    0.02311606f, -0.00678304f, 0.02114584f, 0.00629268f, 0.41113144f, 0.13865322f, -0.12640755f, -0.02399691f, 
    0.03359129f, 0.15213396f, -0.04267169f, 0.13346818f, 0.14850582f, 0.20168059f, -0.03261237f, 0.10324901f, 
    -0.07210828f, -0.17314413f, -0.12777503f, 0.09306637f, -0.09953522f, 0.08613268f, -0.15029591f, -0.10068283f, 
    0.14493075f, -0.12377732f, 0.13479580f, -0.10264942f, 0.09105009f, 0.05831994f, 0.18273661f, 0.23306404f, 
    -0.06350759f, -0.32800165f, 0.18493143f, -0.14576714f, -0.10512403f, 0.00061596f, 0.04047653f, 0.14758416f, 
    -0.00085571f, 0.03662260f, 0.00229500f, -0.05770731f, 0.01386522f, 0.01312673f, -0.01109605f, 0.04592875f, 
    -0.04370892f, -0.00849449f, -0.04786010f, 0.00544212f, 0.03486665f, 0.03159111f, -0.03954583f, -0.03910756f, 
    -0.05319367f, 0.02211381f, -0.05695772f, 0.01631615f, -0.06597932f, 0.00968656f, 0.00757441f, -0.01207732f, 
    -0.04064767f, 0.02155125f, -0.05902931f, -0.05046170f, 0.03058148f, -0.02396154f, 0.01561724f, -0.03103383f, 
    0.03046909f, 0.01445849f, -0.00253171f, -0.02234644f, -0.04821949f, -0.01161189f, -0.03559315f, 0.04674589f, 
    -0.05995731f, 0.00462693f, 0.00498768f, -0.03988316f, -0.04057432f, 0.00928625f, -0.06664868f, 0.02537910f, 
    -0.06122006f, 0.01966341f, -0.04559820f, 0.04309749f, -0.04540958f, -0.04264584f, 0.03928745f, 0.02730594f, 
    0.02654195f, -0.02807771f, -0.02535191f, 0.00065620f, -0.05352792f, -0.03343108f, -0.06063154f, 0.01445119f, 
    -0.04197150f, -0.01736781f, -0.00322608f, 0.00499148f, 0.00591710f, -0.05211770f, -0.02431854f, -0.01316121f, 
    0.02210209f, 0.00905443f, -0.01344768f, 0.05115040f, -0.00008438f, 0.00081862f, 0.04582916f, -0.02226768f, 
    -0.03269523f, 0.03386852f, 0.04065382f, 0.04812658f, -0.04486530f, 0.03096263f, 0.04047241f, -0.00549852f, 
    0.04026048f, -0.05933654f, 0.02709822f, 0.00974063f, -0.04284799f, 0.04603339f, 0.05185858f, -0.00442669f, 
    0.02919348f, 0.01906664f, 0.02071216f, -0.02070474f, 0.04067030f, -0.02561475f, 0.03468456f, -0.04048399f, 
    -0.06291901f, -0.00954790f, -0.05043202f, -0.03908469f, 0.03256117f, -0.04040011f, 0.02533543f, -0.02080831f, 
    -0.03894680f, 0.00847755f, 0.00811481f, 0.00063688f, -0.02313766f, 0.04414712f, 0.04958469f, -0.02055952f, 
    -0.04694212f, -0.06217515f, -0.00816541f, -0.04314558f, -0.02675692f, -0.05456128f, -0.01797204f, 0.03188998f, 
    0.05172506f, 0.01443618f, -0.04791866f, 0.04739622f, -0.00739807f, -0.05883675f, -0.02020418f, -0.00678167f, 
    0.02899258f, -0.01440744f, 0.02658414f, -0.06379820f, -0.05591951f, 0.02948859f, 0.01528708f, 0.03171367f, 
    -0.02195501f, 0.03792048f, -0.04390364f, -0.04629577f, -0.04286424f, -0.02373872f, -0.02265476f, -0.00227850f, 
    -0.06072520f, 0.02394014f, -0.06698878f, 0.01906167f, -0.00372536f, -0.03195257f, -0.02111451f, -0.00439671f, 
    0.04951331f, 0.03365767f, -0.03965656f, -0.03864860f, -0.00562051f, 0.00829716f, -0.06470775f, 0.03827030f, 
    0.05050722f, 0.05000389f, 0.04621430f, 0.02037896f, 0.03130042f, 0.03270539f, -0.03869802f, 0.00062182f, 
    0.01515699f, -0.05444217f, -0.02491289f, -0.02029138f, -0.02921495f, 0.05039157f, 0.04045382f, 0.02807338f, 
    -0.02380350f, -0.02766784f, -0.05062729f, -0.06467035f, 0.01453621f, -0.01402739f, 0.02683190f, 0.03353081f, 
    0.02188445f, -0.03160079f, -0.03293182f, -0.03771512f, -0.01206586f, -0.05715568f, -0.05746852f, -0.05736348f, 
    -0.03751660f, -0.04346266f, -0.03211459f, -0.02845572f, -0.02321290f, 0.02918339f, -0.04990290f, -0.02815253f, 
    0.03747255f, 0.03959280f, -0.06283845f, -0.03761385f, 0.01168264f, -0.02328452f, 0.04717815f, -0.05078764f, 
    -0.01824808f, 0.01756218f, 0.00493118f, -0.03943767f, -0.01063897f, 0.03054577f, 0.00616694f, 0.04801270f, 
    -0.05242621f, 0.01391918f, -0.00678048f, -0.03638032f, -0.01756288f, -0.00279607f, 0.01716542f, 0.05588116f, 
    0.02318209f, -0.01660414f, 0.03358822f, 0.00506682f, -0.03295489f, -0.02633012f, -0.02040684f, 0.03044978f, 
    0.02432883f, -0.01133043f, 0.02768804f, 0.02322981f, -0.01947502f, 0.01016879f, 0.03212849f, -0.01984489f, 
    -0.05020211f, -0.05189923f, -0.02826666f, 0.04374559f, -0.03144385f, -0.01012157f, 0.02351565f, -0.03313878f, 
    0.04036116f, 0.02056720f, -0.04906867f, 0.01839069f, 0.03711862f, 0.02316969f, -0.05673788f, -0.04998668f, 
    0.00278166f, -0.05852543f, -0.02854577f, -0.02270051f, -0.05870215f, -0.04507081f, -0.03695910f, -0.02776547f, 
    0.00507502f, -0.04584178f, 0.03304911f, 0.03214274f, -0.00012382f, 0.01656783f, 0.02881149f, -0.01879269f, 
    -0.03856608f, -0.06491476f, 0.03050554f, -0.05323913f, 0.03794935f, 0.04954765f, -0.04744666f, -0.02672284f, 
    -0.00256521f, -0.01529467f, 0.01071892f, 0.01477592f, -0.00401857f, -0.03232633f, 0.03397433f, -0.01979169f, 
    -0.04763100f, 0.01947546f, 0.01901236f, -0.06079645f, -0.03949656f, 0.04503402f, 0.01347827f, -0.00035171f, 
    -0.00779471f, -0.02874057f, -0.00773763f, -0.05306695f, -0.05801751f, -0.04961913f, -0.03348949f, 0.03628701f, 
    0.05008264f, 0.01363191f, -0.03691258f, 0.01162242f, -0.04187309f, 0.01092127f, -0.00802362f, -0.01514671f, 
    0.00767980f, 0.00837557f, -0.05733925f, -0.04797388f, 0.05139666f, 0.01941388f, 0.01332362f, 0.02055212f, 
    -0.02319197f, -0.05165248f, 0.02771088f, -0.02839937f, -0.01563765f, 0.03100789f, -0.05629833f, 0.00896907f, 
    0.02146340f, -0.02474989f, 0.00561359f, -0.01383762f, -0.00241474f, -0.00439664f, -0.05359044f, 0.00548055f, 
    -0.01725275f, -0.00275021f, -0.04198742f, 0.05091584f, -0.04338963f, -0.04929562f, -0.03794939f, 0.03440607f, 
    0.02785463f, 0.04204179f, 0.00239231f, -0.03798009f, -0.04337362f, 0.00307189f, 0.04466883f, -0.05366751f, 
    0.00203323f, 0.00045562f, -0.00282263f, -0.03300764f, -0.03876476f, 0.02545790f, -0.00609189f, -0.00492963f, 
    0.01871739f, 0.04218430f, -0.01821364f, -0.01905048f, 0.02465112f, 0.01031522f, -0.05069649f, -0.00415861f, 
    0.03395547f, -0.05416638f, 0.00793676f, 0.00104291f, 0.00758227f, 0.00694874f, 0.04446619f, -0.00036934f, 
    -0.04997587f, -0.06445609f, -0.01863396f, -0.02718831f, 0.02652241f, -0.05182214f, 0.00821745f, -0.04927161f, 
    -0.06042192f, -0.00553790f, 0.03467246f, -0.02851993f, -0.05421989f, 0.02527816f, -0.05260660f, -0.00338301f, 
    0.01960126f, 0.04909705f, 0.02508064f, -0.01797494f, -0.05902729f, -0.06993354f, -0.04714917f, 0.03882428f, 
    -0.02814859f, 0.00257961f, -0.04968379f, -0.01266022f, 0.02991425f, -0.04008633f, -0.02309243f, -0.00644278f, 
    0.05166452f, -0.03788169f, -0.00811456f, 0.01552384f, -0.03606945f, 0.03528435f, 0.00406789f, -0.02312437f, 
    0.03818436f, -0.03842945f, -0.03616706f, 0.00771488f, 0.03007797f, -0.04584348f, 0.02898814f, 0.01813934f, 
    -0.03491317f, -0.00924108f, 0.02436193f, 0.03490150f, 0.01595156f, -0.03898457f, 0.05066487f, 0.01249483f, 
    -0.04752146f, 0.00179249f, 0.03441104f, 0.04032125f, -0.01400771f, 0.00684117f, -0.05567573f, 0.04865554f, 
    -0.05423503f, 0.04224642f, -0.04073765f, -0.00283407f, 0.00758538f, -0.02160558f, 0.04074707f, 0.00549316f, 
    -0.01345404f, 0.04615670f, 0.02672511f, -0.02969025f, -0.04531836f, -0.00198433f, 0.03993843f, -0.04230674f, 
    0.03484234f, -0.01228708f, -0.01503312f, -0.00217014f, 0.02420639f, 0.03584633f, 0.03700790f, -0.00847992f, 
    -0.00006686f, 0.03146017f, 0.00875694f, 0.02856359f, 0.04131728f, -0.05541652f, 0.01244917f, 0.03429819f, 
    -0.05810361f, 0.01371437f, -0.04442177f, -0.00776016f, 0.03720217f, -0.00053721f, -0.01828705f, 0.02090528f, 
    0.05046583f, 0.03842346f, 0.01224315f, 0.02242805f, -0.00467353f, -0.06941272f, -0.02672322f, -0.03023836f, 
    -0.01456768f, 0.01796037f, -0.00613124f, 0.00053677f, 0.00572794f, 0.00767670f, 0.00438703f, 0.05049533f, 
    -0.03301027f, -0.04734255f, 0.04758807f, -0.04749839f, -0.03450506f, 0.03340982f, 0.02115975f, -0.04217004f, 
    0.03217017f, -0.01628472f, 0.04603106f, -0.02369961f, 0.00149518f, -0.01071054f, 0.04576591f, 0.00565290f, 
    -0.01046995f, -0.04583957f, 0.02047715f, 0.02555737f, -0.06236995f, 0.02392277f, -0.02017638f, -0.01199308f, 
    0.02852736f, -0.03744276f, -0.06232241f, -0.00441867f, -0.00138062f, 0.04362190f, -0.00699337f, 0.00968229f, 
    -0.03036090f, 0.00929260f, -0.02942378f, 0.04992901f, -0.01414895f, -0.03988803f, -0.02412012f, -0.06774012f, 
    0.00253628f, 0.01924209f, -0.00067686f, -0.02574842f, -0.02532199f, -0.05096319f, -0.02981292f, 0.04594296f, 
    0.01371861f, 0.02641193f, 0.03214190f, 0.00487527f, -0.05714200f, -0.04357304f, 0.00846412f, -0.01132491f, 
    0.03297866f, 0.00504891f, -0.00133945f, -0.03088799f, 0.03125295f, -0.02040498f, -0.04862882f, -0.02115859f, 
    0.04989661f, -0.02317442f, -0.06586927f, -0.05058075f, 0.00575664f, -0.03474844f, 0.04206454f, 0.04667868f, 
    0.12531552f, -0.04097645f, 0.13935384f, -0.08932222f, -0.07698062f, -0.11051355f, 0.01966109f, 0.04162512f, 
    0.11384711f, 0.14099687f, -0.02358445f, -0.10521704f, -0.07112256f, 0.05399826f, -0.20100105f, 0.02435978f, 
    -0.02418066f, 0.06408824f, 0.00491263f, -0.29583615f, -0.37027550f, 0.08508693f, -0.06707673f, -0.03628768f, 
    -0.01319810f, 0.14309891f, -0.05234490f, 0.27033833f, 0.03074962f, -0.34300560f, -0.07558780f, -0.15941085f, 
    -0.00729345f, -0.09539123f, -0.05840860f, 0.12255821f, 0.16573907f, -0.24782194f, -0.10851383f, -0.00658574f, 
    0.16626193f, 0.04013541f, 0.07816407f, -0.12172686f, 0.03573859f, 0.05368837f, 0.17382586f, 0.10832390f, 
    -0.00576713f, 0.19023420f, 0.04016510f, -0.25387076f, -0.14774524f, 0.05245189f, -0.16989723f, 0.10095766f, 
    -0.16338259f, 0.05775817f, 0.17896217f, 0.11401761f, 0.00272618f, -0.05718167f, 0.00788478f, 0.15876602f, 
    0.02634632f, -0.12324079f, -0.06306413f, -0.03831414f, 0.22661006f, 0.03316103f, 0.03679498f, 0.10373363f, 
    -0.38618258f, -0.41545182f, -0.27274621f, -0.27463236f, 0.08547857f, 0.27807260f, -0.16605477f, 0.16242963f, 
    -0.18854137f, -0.24029864f, 0.32599849f, -0.10375288f, 0.01925960f, -0.05195470f, 0.13989428f, 0.03703552f, 
    -0.19605565f, 0.09383233f, -0.32194516f, 0.06057496f, 0.30639935f, -0.18911289f, 0.00928288f, -0.05110842f, 
    0.05560428f, -0.04045846f, 0.06633065f, 0.36289525f, 0.06747951f, 0.00237099f, -0.33255339f, 0.01778527f, 
    -0.03774996f, -0.12607573f, -0.16671824f, -0.16750592f, 0.06718174f, -0.15763333f, -0.19123162f, 0.06132644f, 
    0.13576739f, 0.10126855f, 0.03780504f, 0.08525090f, 0.12471083f, 0.15836181f, 0.09847855f, 0.06845551f, 
    0.08898409f, 0.08494001f, 0.04625100f, -0.07813250f, -0.17912051f, -0.15188469f, 0.21804772f, 0.07223788f, 
    0.21036525f, 0.02005808f, -0.06193783f, -0.06918380f, 0.24779406f, 0.01011013f, 0.08135550f, -0.00569537f, 
    0.13352963f, -0.06334190f, 0.10423736f, -0.05093094f, 0.00864278f, -0.04194301f, 0.00929374f, -0.11572490f, 
    0.09659571f, 0.12152112f, 0.11050061f, 0.12309646f, -0.00439000f, 0.21030365f, 0.21648917f, 0.03474376f, 
    0.01375991f, -0.01682778f, 0.19633225f, -0.45193672f, 0.08263732f, -0.06127292f, 0.17591049f, -0.02419153f, 
    0.02338082f, -0.31932783f, 0.19406793f, 0.02600440f, -0.14354238f, 0.15612383f, 0.07378820f, -0.00382640f, 
    0.00155955f, -0.01095246f, -0.02315937f, 0.19674143f, -0.29800284f, -0.05516392f, -0.26632959f, -0.01831141f, 
    0.05297749f, -0.01288131f, 0.05750996f, 0.04304961f, -0.18644503f, -0.37390810f, 0.08313781f, -0.31278515f, 
    0.02774267f, -0.02454499f, 0.12994057f, 0.00425919f, 0.06416268f, 0.05120892f, -0.15592285f, 0.10368074f, 
    -0.11282034f, -0.01670192f, 0.13506193f, -0.18520410f, -0.09637481f, -0.04181212f, 0.11203941f, -0.02204387f, 
    0.18597192f, -0.07894883f, -0.05518202f, -0.01901879f, 0.02496679f, 0.08640262f, -0.14027113f, 0.29329985f, 
    -0.21515523f, -0.16717450f, -0.12949499f, 0.05448763f, -0.06147917f, -0.02305397f, -0.16577622f, 0.05321842f, 
    0.05455814f, 0.17454965f, 0.04640791f, -0.04542763f, -0.02334312f, 0.13545606f, -0.15118299f, -0.00847397f, 
    0.03990569f, 0.14683798f, -0.50408113f, 0.08201312f, -0.10970471f, 0.01702002f, 0.13473585f, -0.35746691f, 
    -0.15833600f, -0.15183873f, 0.03132768f, -0.00403512f, 0.01403763f, 0.00713544f, 0.25434947f, 0.06529795f, 
    0.10432649f, 0.00422827f, 0.14525823f, -0.23020592f, 0.10914043f, -0.00299733f, 0.01974393f, 0.08166096f, 
    0.10559124f, -0.25474563f, -0.06268965f, 0.05268918f, 0.44982693f, 0.21121292f, 0.05664819f, -0.18846005f, 
    0.00924878f, 0.04765101f, -0.07482009f, 0.08775778f, -0.07494454f, 0.33001754f, -0.15050706f, 0.10932677f, 
    -0.09359746f, -0.08822992f, -0.00070759f, 0.00927950f, 0.00813821f, 0.16236408f, -0.21786626f, -0.32306966f, 
    0.16062219f, -0.16115040f, 0.22546043f, -0.10793998f, -0.06147094f, -0.01981367f, -0.15584375f, 0.37461361f, 
    0.03399154f, -0.06583586f, -0.09782572f, -0.14661503f, 0.04883410f, -0.00527846f, 0.01314071f, 0.06115627f, 
    -0.00330305f, -0.00418437f, 0.02035680f, -0.04446361f, -0.01637639f, 0.03727584f, -0.00497117f, -0.06150188f, 
    0.00842662f, 0.02359514f, -0.05787181f, -0.02272140f, -0.03322181f, -0.01237015f, 0.03247081f, -0.01097360f, 
    -0.05935970f, 0.01543252f, -0.01923234f, -0.04899101f, -0.04698220f, 0.03975785f, 0.04510604f, 0.01027573f, 
    -0.06601175f, 0.01449527f, -0.01157548f, -0.01674524f, 0.03131622f, 0.03184160f, -0.06254491f, 0.03070003f, 
    -0.03450081f, 0.03279456f, 0.00199942f, 0.02092457f, 0.03794101f, -0.05643682f, -0.02102492f, -0.04078321f, 
    0.03574574f, -0.02163703f, -0.00361530f, 0.04804013f, 0.03244285f, -0.04753159f, 0.02033627f, 0.00714211f, 
    -0.02240942f, -0.05119774f, 0.01353777f, 0.02328244f, 0.01730317f, -0.06035571f, 0.00995657f, 0.03973025f, 
    -0.03719496f, -0.03058206f, 0.03356767f, -0.05035446f, -0.03686512f, 0.03667311f, 0.02137130f, -0.03452927f, 
    0.01040566f, -0.05437526f, 0.00758788f, 0.04340778f, -0.03350000f, -0.02666008f, -0.03369472f, -0.02773516f, 
    0.02764086f, -0.06069310f, -0.01777641f, -0.01169621f, -0.03249426f, -0.01183373f, 0.01265824f, -0.02843307f, 
    -0.03006759f, 0.04322240f, 0.02840605f, -0.01355589f, 0.00476558f, -0.00597374f, 0.03893217f, 0.01497138f, 
    -0.01989971f, -0.03233562f, -0.04780215f, 0.04412837f, -0.02262260f, -0.00582603f, -0.05198294f, -0.04412870f, 
    -0.03566628f, -0.01839188f, 0.01933995f, -0.01847523f, 0.04366232f, 0.05892022f, -0.06036707f, 0.00078772f, 
    -0.01680603f, 0.05074071f, 0.02465371f, -0.02987610f, 0.00991456f, -0.04543823f, -0.06173820f, -0.06484150f, 
    -0.04501449f, -0.04908765f, -0.04616451f, 0.02065573f, -0.06538446f, 0.04906226f, -0.01388977f, 0.03908625f, 
    -0.00291694f, 0.02924692f, 0.02779727f, -0.05695059f, -0.05384709f, 0.03442569f, 0.03364799f, 0.04778032f, 
    -0.05284793f, -0.01964808f, 0.02406382f, -0.01057984f, 0.02580907f, 0.04446050f, -0.01920490f, 0.03952458f, 
    -0.05314264f, -0.06410810f, -0.00976711f, 0.05406901f, -0.04863619f, -0.06212414f, -0.01707973f, -0.00265004f, 
    0.00973331f, -0.02424557f, -0.01908126f, 0.04132626f, 0.03683704f, -0.03028836f, -0.05102240f, 0.04786206f, 
    0.01161142f, 0.01591006f, 0.02354103f, -0.06479131f, -0.01591950f, -0.01394106f, -0.06612851f, -0.04707342f, 
    -0.01977550f, 0.02382110f, 0.02305209f, -0.03413389f, -0.00240299f, 0.04708217f, 0.02821054f, -0.00692997f, 
    -0.02650649f, 0.04130836f, 0.02526757f, -0.06485851f, -0.05726551f, 0.01587705f, 0.01637458f, -0.06353340f, 
    0.04479610f, -0.00150922f, 0.04316385f, -0.00307204f, 0.00106639f, 0.03215489f, -0.03605787f, -0.01430909f, 
    -0.04813070f, 0.03865469f, -0.02892845f, -0.02724822f, 0.01700315f, -0.02019113f, 0.00009175f, 0.00304710f, 
    -0.01953888f, -0.00531171f, -0.03023021f, 0.00016235f, 0.03448598f, 0.04393497f, -0.04402469f, -0.03902391f, 
    -0.00264010f, 0.02814888f, -0.03653111f, -0.02782295f, -0.02411778f, -0.05692781f, 0.05224441f, -0.00149110f, 
    0.01083051f, 0.00429803f, -0.00104856f, -0.00928866f, -0.03648704f, 0.02821697f, -0.00989271f, -0.02178497f, 
    0.04049224f, 0.04158578f, -0.05597020f, -0.02790611f, 0.02693324f, -0.01729742f, -0.02613240f, 0.01382109f, 
    -0.04191168f, -0.04612429f, -0.04833444f, -0.02386343f, -0.03155846f, -0.05044658f, 0.03433225f, 0.00605679f, 
    -0.00502163f, 0.03009984f, -0.02460368f, 0.03789685f, -0.03024562f, 0.02967524f, 0.00026331f, -0.00722017f, 
    -0.01485945f, -0.02356827f, -0.04477623f, -0.01614884f, 0.03337023f, 0.00166483f, 0.04754695f, -0.00003181f, 
    -0.01156536f, -0.05494117f, -0.05428390f, -0.03294169f, -0.00876124f, 0.05643073f, -0.04642224f, -0.02580029f, 
    -0.02060732f, -0.04352218f, 0.01543949f, -0.03739455f, 0.03097056f, -0.04701637f, -0.06637758f, 0.04384309f, 
    -0.01908554f, -0.04011985f, 0.04590857f, -0.03328826f, -0.00415355f, -0.02615160f, 0.02093023f, 0.00451155f, 
    -0.02164564f, -0.02311263f, -0.03424074f, -0.02487965f, 0.00403363f, -0.02850726f, -0.01250747f, 0.02350022f, 
    0.02322105f, -0.06264464f, -0.05131884f, -0.04632796f, -0.01458187f, 0.00703017f, -0.03375385f, 0.03799557f, 
    0.59895033f, 0.10954525f, -0.23351789f, -0.14172651f, -0.06225650f, -0.17095304f, 0.11226474f, -0.00652232f, 
    0.19539563f, 0.34321412f, -0.09917504f, -0.21401627f, 0.06720855f, -0.14460699f, -0.07382287f, -0.20802793f, 
    0.02298633f, 0.17670764f, 0.30860418f, 0.15997517f, -0.14084469f, -0.19435672f, -0.07786247f, -0.05500805f, 
    0.14573599f, -0.01064531f, 0.12041833f, -0.17875321f, -0.26707590f, 0.07700747f, 0.05415060f, 0.01238380f, 
    -0.14316280f, -0.08375862f, 0.16145304f, 0.05198416f, -0.09381301f, -0.16787657f, 0.11300460f, 0.05499351f, 
    -0.01249996f, 0.22345982f, 0.01159497f, -0.02927346f, 0.19706428f, -0.09462415f, 0.33389586f, 0.41775531f, 
    -0.12668042f, 0.03537556f, -0.05975316f, -0.05869774f, 0.22091430f, 0.10678872f, -0.30034983f, 0.39853960f, 
    0.29962221f, 0.10286284f, 0.05365481f, 0.04501455f, 0.05088665f, -0.02878078f, 0.06030007f, 0.18890060f, 
    0.27354965f, 0.18134852f, 0.15225670f, 0.09069143f, 0.12356720f, 0.03034343f, 0.06857944f, 0.09798311f, 
    -0.37783778f, 0.09176542f, 0.18316370f, -0.18127261f, -0.34146264f, -0.16643962f, 0.08715495f, -0.05960894f, 
    0.00957878f, -0.21340403f, 0.36382082f, 0.26601559f, 0.11036017f, 0.03472592f, -0.01486533f, 0.18492337f, 
    -0.02156863f, 0.01106043f, 0.10129673f, -0.33773038f, -0.40365359f, 0.07043157f, 0.10761132f, 0.16172868f, 
    0.00640185f, 0.04593200f, -0.16158585f, -0.00558102f, -0.14440222f, 0.08493672f, 0.06764360f, 0.08032726f, 
    0.07414068f, 0.06560045f, -0.00995438f, -0.29867631f, 0.09150919f, 0.01809090f, -0.14877480f, -0.16103476f, 
    0.15971333f, -0.00871173f, 0.17305797f, -0.02766240f, -0.02473582f, -0.27079448f, 0.05029389f, -0.00007486f, 
    0.15029791f, -0.04130766f, -0.09067855f, 0.03208679f, 0.05321513f, 0.09476249f, -0.26786709f, -0.24346639f, 
    -0.27573201f, 0.06738025f, 0.03607335f, 0.17568684f, -0.00978253f, 0.11334429f, -0.09400463f, -0.04519111f, 
    0.02789777f, 0.17753889f, -0.03111626f, 0.00754751f, -0.18117833f, 0.02356627f, 0.04691994f, 0.11871828f, 
    -0.00713893f, -0.20197979f, -0.04354095f, 0.17174362f, 0.06713232f, 0.11671636f, 0.01452054f, 0.04743836f, 
    0.09799187f, 0.20238794f, 0.15134564f, 0.03889131f, 0.04072833f, -0.02456154f, -0.05199210f, -0.03665736f, 
    0.01390776f, 0.06448279f, 0.33869380f, 0.10190091f, 0.10036843f, 0.01540118f, -0.05859670f, -0.02897125f, 
    0.14553604f, -0.00553621f, 0.01871103f, 0.04824276f, 0.13878909f, -0.01241200f, -0.09976847f, -0.03297665f, 
    -0.08865763f, -0.11405053f, -0.06055718f, 0.03781845f, 0.17129679f, -0.00186673f, 0.01768183f, 0.05282944f, 
    -0.06175898f, 0.00768940f, 0.07451720f, -0.06808229f, 0.08136465f, 0.09764763f, 0.12616560f, -0.09822751f, 
    -0.03207639f, 0.00938451f, -0.19748886f, -0.02958489f, -0.03549624f, -0.12313891f, 0.04126433f, 0.02142497f, 
    -0.26452219f, 0.08147152f, 0.00239992f, -0.06387404f, 0.00518181f, 0.13031998f, 0.01283178f, -0.24271543f, 
    -0.04303980f, 0.22653759f, -0.07535026f, 0.00660418f, 0.11727396f, 0.16282608f, -0.09720525f, -0.01628941f, 
    0.40321714f, -0.17949200f, -0.07819462f, -0.05117616f, -0.11562986f, -0.16475032f, -0.25346687f, -0.00647377f, 
    -0.06428338f, -0.51375979f, 0.14903966f, 0.06922822f, 0.07016373f, 0.12816757f, 0.05081107f, -0.03077175f, 
    -0.02718239f, -0.01802129f, 0.01625078f, -0.33912823f, 0.03540016f, 0.05182515f, 0.10867339f, -0.00268768f, 
    0.03220694f, -0.11623993f, 0.09073199f, -0.30468303f, 0.25944489f, 0.33129212f, 0.01234241f, 0.00020336f, 
    -0.02533995f, 0.10205690f, -0.10358593f, -0.02509965f, 0.55303282f, -0.33467984f, -0.31300065f, 0.15414938f, 
    -0.11017415f, 0.06063687f, -0.06452131f, 0.13389271f, -0.24732928f, 0.17165110f, -0.17949343f, -0.07700071f, 
    0.04622401f, -0.02338250f, 0.15206176f, -0.04083034f, 0.10243071f, 0.34558633f, -0.14117582f, -0.28347641f, 
    -0.04130597f, -0.00795322f, -0.03418732f, 0.24779928f, 0.01867552f, 0.08771196f, 0.14115322f, -0.25292146f, 
    -0.25791866f, -0.08853734f, 0.01076228f, 0.12452958f, 0.10701013f, -0.09264525f, 0.02497776f, 0.15155336f, 
    -0.01751584f, -0.01333081f, -0.02877644f, 0.02273549f, -0.05910916f, -0.03180533f, 0.01625100f, -0.05027683f, 
    0.05158719f, -0.06695156f, 0.03675281f, 0.04185317f, -0.04990993f, -0.05158200f, 0.04297409f, 0.02043695f, 
    -0.05316222f, 0.00937775f, -0.02873220f, 0.00000699f, 0.00177274f, 0.03134843f, -0.05759066f, -0.05665104f, 
    -0.02289473f, -0.02136078f, 0.00394151f, 0.01856453f, -0.01617520f, 0.03556158f, -0.03751782f, -0.05907527f, 
    0.02038308f, 0.01593495f, 0.04503631f, -0.05449488f, 0.00524952f, -0.04848850f, 0.04817050f, -0.04954904f, 
    -0.06177641f, -0.05609186f, 0.03933686f, 0.01826743f, 0.04433673f, -0.06175650f, -0.03483525f, -0.05170753f, 
    0.00055006f, -0.05550263f, 0.00803166f, -0.02664817f, 0.02957717f, 0.01453206f, 0.03969515f, 0.00213502f, 
    -0.03822630f, -0.01388303f, -0.00696731f, -0.02042089f, 0.04457907f, 0.01324762f, 0.03991365f, 0.01106320f, 
    -0.03393019f, -0.03784352f, 0.04499708f, 0.01928466f, 0.01996361f, -0.05752027f, 0.02044747f, 0.04265381f, 
    -0.02721155f, 0.02513205f, -0.01801417f, -0.04788689f, 0.01372160f, -0.00124047f, -0.03097769f, -0.01397287f, 
    -0.04095190f, -0.01634106f, 0.01774643f, 0.01334648f, 0.03848434f, -0.04620983f, -0.00828538f, -0.00350124f, 
    -0.01985452f, -0.03422160f, 0.02820832f, -0.03352229f, 0.01235491f, 0.02782345f, -0.00144288f, -0.00591829f, 
    -0.05742513f, -0.00764918f, -0.00340579f, 0.04085037f, -0.05792589f, 0.04882474f, -0.02639567f, 0.00511987f, 
    -0.05031837f, -0.04854790f, 0.03743418f, -0.04054349f, 0.04753822f, 0.02730609f, -0.06048790f, 0.02259623f, 
    0.02196064f, -0.05727943f, -0.03047623f, 0.01001636f, 0.02271105f, -0.01829595f, -0.02981479f, -0.01108537f, 
    -0.05769416f, 0.01043794f, -0.02543206f, -0.05409080f, -0.05872084f, -0.00248156f, -0.04293508f, 0.03126888f, 
    0.00889021f, -0.03607903f, 0.00181046f, -0.00667900f, 0.01246052f, 0.00978186f, 0.00843773f, -0.03784039f, 
    0.05045688f, 0.03805028f, -0.02651092f, 0.01290675f, -0.01558859f, 0.01248970f, -0.05027746f, -0.03038950f, 
    -0.05381023f, -0.04318033f, 0.04160118f, -0.00391680f, -0.00495417f, -0.00314910f, 0.01760250f, 0.03569649f, 
    0.03798901f, 0.02338502f, 0.00561318f, 0.01161768f, 0.02037502f, 0.01308141f, -0.03169603f, 0.04285324f, 
    -0.06200269f, -0.02260558f, -0.04186675f, 0.03608560f, -0.01467122f, -0.04286268f, 0.02728406f, -0.05206470f, 
    -0.05138600f, -0.01462788f, -0.02080137f, -0.05915409f, 0.00933931f, -0.05538045f, -0.05326205f, -0.04825813f, 
    -0.02188003f, -0.03707254f, 0.02348704f, 0.04745742f, -0.00425382f, 0.01737736f, 0.03629374f, 0.00330669f, 
    0.03958554f, -0.00710908f, -0.00556767f, -0.05786894f, -0.05223127f, 0.02860090f, 0.02391866f, -0.01529791f, 
    -0.02229974f, -0.04619788f, -0.01865550f, 0.01451641f, -0.04210427f, 0.02841330f, -0.06603348f, -0.01413040f, 
    0.01591473f, -0.01145324f, -0.04278758f, 0.04810384f, 0.02885678f, -0.04774426f, 0.02662704f, 0.04248465f, 
    -0.05435871f, -0.00289111f, 0.04527377f, -0.02366782f, -0.02203877f, 0.04379584f, -0.00197437f, 0.02739404f, 
    0.01414876f, -0.02888005f, -0.02067642f, -0.03003987f, -0.06029782f, 0.00965020f, 0.04042812f, -0.00677244f, 
    -0.01110789f, -0.05927369f, -0.05522357f, 0.00064826f, -0.06193037f, 0.04700371f, -0.03922285f, 0.03552957f, 
    -0.04802655f, -0.04816320f, 0.01437271f, -0.00415410f, -0.00315283f, 0.05045284f, -0.02782300f, 0.03215063f, 
    -0.06344549f, 0.02492248f, -0.03849226f, -0.01681384f, -0.06403235f, 0.03202305f, 0.01996625f, 0.00925261f, 
    0.01913285f, 0.03210681f, -0.06050518f, 0.01322407f, 0.03955696f, 0.03716524f, 0.04070489f, 0.02925039f, 
    -0.05148042f, -0.06318168f, -0.02995654f, -0.02572403f, 0.02510681f, -0.05026564f, -0.04295412f, 0.05004248f, 
    -0.00660725f, -0.05780905f, -0.03761393f, 0.02308464f, 0.01694210f, 0.04849962f, 0.04598273f, -0.03436962f, 
    0.03052900f, 0.02936272f, -0.00488765f, 0.04346509f, -0.04964406f, 0.04810024f, -0.01632643f, 0.00050785f, 
    -0.03795736f, 0.01828737f, -0.02855158f, 0.02485815f, -0.06856045f, -0.04316279f, 0.01039992f, -0.02542754f, 
    -0.33492637f, 0.08484344f, -0.00310853f, 0.13535033f, 0.07695809f, -0.00774503f, 0.10759061f, 0.07350059f, 
    -0.01630079f, -0.03569165f, -0.02591689f, -0.26176703f, -0.16936009f, 0.10725732f, -0.04296198f, 0.26534918f, 
    -0.10592124f, 0.20483346f, -0.05856757f, -0.03592134f, -0.03475891f, 0.15137163f, 0.05132106f, -0.01658846f, 
    0.08202693f, -0.01639001f, 0.11877696f, -0.29693410f, -0.06830690f, -0.36155495f, 0.15545663f, -0.00200398f, 
    0.01420540f, -0.08053182f, 0.00225175f, 0.17657763f, -0.05910045f, -0.21724439f, -0.19258270f, -0.08183642f, 
    -0.03852101f, 0.04239697f, 0.12186249f, 0.07747732f, 0.07117780f, -0.03912614f, -0.00641763f, 0.20714052f, 
    0.02911681f, 0.01241236f, 0.05801766f, 0.06766663f, 0.17475128f, 0.07565187f, 0.07539590f, 0.32092980f, 
    0.32474217f, 0.20142211f, 0.12288301f, 0.13991117f, -0.11128267f, -0.03267675f, 0.01413722f, 0.28004265f, 
    0.15132119f, 0.20629624f, 0.07991871f, 0.01760496f, 0.18962859f, -0.04105214f, -0.01100470f, 0.10456305f, 
    -0.28556192f, -0.00728387f, -0.19621387f, 0.17667915f, 0.09396753f, 0.00686555f, 0.22767033f, -0.00346997f, 
    0.07211801f, -0.00140789f, 0.14260811f, 0.32543004f, 0.01001071f, -0.12060755f, 0.12458476f, 0.12060085f, 
    -0.01123832f, -0.05206226f, -0.20288317f, -0.05694476f, -0.19046484f, 0.00409631f, 0.24182020f, -0.03434865f, 
    0.01832845f, -0.11710934f, 0.03517106f, -0.17148165f, -0.08269881f, -0.18224640f, 0.22542541f, 0.02708426f, 
    0.04162293f, 0.06263695f, -0.27426088f, 0.09324453f, 0.11765525f, 0.00761518f, -0.21344770f, -0.16907133f, 
    0.35868242f, 0.05086444f, -0.12124648f, -0.13982284f, -0.18602365f, -0.31849918f, -0.13373467f, 0.11114365f, 
    -0.03642095f, 0.02476642f, 0.07825375f, -0.03245237f, 0.01367649f, -0.04537943f, -0.15925510f, -0.09694324f, 
    -0.15617456f, 0.12769839f, 0.03809160f, 0.01354003f, -0.16552727f, 0.06287736f, -0.19355531f, 0.04222839f, 
    -0.05309820f, -0.01164122f, -0.28889078f, 0.07222752f, 0.13899443f, -0.06784687f, 0.25980568f, 0.29211572f, 
    0.13037434f, 0.08985347f, -0.00051201f, 0.06734503f, 0.10440345f, 0.19016665f, 0.20151895f, -0.06982074f, 
    0.11934409f, 0.08726168f, -0.05855653f, 0.03887459f, -0.21276887f, 0.15018250f, -0.02193379f, 0.09779651f, 
    0.14798063f, 0.10625090f, 0.09315872f, 0.21109833f, 0.01608976f, -0.14595878f, 0.03638968f, -0.02566184f, 
    -0.00715428f, 0.29760867f, 0.33986527f, -0.15842448f, -0.01725109f, -0.23162830f, 0.23478352f, 0.07617541f, 
    -0.03366526f, 0.01910533f, -0.08287259f, -0.05526337f, -0.19538794f, 0.05636443f, -0.12331466f, 0.01716894f, 
    0.10479848f, -0.14443159f, -0.05756630f, -0.04538972f, 0.19453181f, -0.14071083f, -0.23688370f, -0.03014289f, 
    0.06155703f, 0.10246406f, -0.02418087f, -0.08934467f, 0.10775776f, -0.05275999f, -0.03064633f, 0.07438348f, 
    -0.21823627f, 0.08297541f, 0.04758498f, -0.10902000f, 0.08486023f, 0.05857516f, -0.10557001f, -0.19484842f, 
    0.01639535f, 0.05733593f, -0.05384338f, 0.02779119f, 0.03113356f, -0.23763128f, -0.20036225f, -0.12802517f, 
    -0.21098083f, -0.20278460f, -0.04460816f, -0.15968488f, 0.02107328f, 0.08273350f, -0.16367517f, -0.06286571f, 
    0.10778246f, -0.05445815f, 0.02096302f, 0.04378837f, 0.07349627f, 0.16506211f, -0.02247463f, 0.02060943f, 
    -0.08765344f, -0.01428798f, -0.37270179f, 0.05520136f, -0.22109760f, 0.05454737f, 0.20169270f, 0.01530484f, 
    -0.24222022f, -0.08657094f, 0.03208916f, 0.09464259f, 0.22463782f, 0.35340858f, -0.06585287f, -0.12113292f, 
    -0.08612998f, 0.09503391f, 0.19339648f, 0.15168561f, -0.02253446f, -0.15795971f, 0.18606275f, -0.04689214f, 
    0.09672993f, -0.02287981f, -0.01517160f, -0.04920851f, -0.00751629f, 0.08391193f, -0.12220490f, -0.34415856f, 
    0.18071947f, 0.07949899f, 0.05946771f, -0.01334643f, -0.08379053f, -0.01042809f, -0.16975310f, 0.00102511f, 
    0.24624917f, -0.11424714f, 0.07611726f, -0.01848820f, 0.03109057f, -0.12791876f, -0.12329717f, 0.03164233f, 
    -0.28241533f, -0.18136908f, 0.14578500f, 0.24819642f, 0.11052600f, 0.06607023f, -0.27007800f, 0.03868741f, 
    0.01288602f, -0.01670057f, -0.05050745f, -0.06674117f, -0.04524082f, -0.00532265f, -0.05374828f, -0.04618779f, 
    -0.02258475f, -0.04869829f, 0.01264446f, -0.01195475f, -0.05589290f, 0.00596595f, -0.04890183f, 0.02900912f, 
    0.04572042f, -0.06218814f, -0.03837875f, -0.00384348f, -0.01340145f, 0.01738737f, -0.00928443f, 0.03463971f, 
    -0.01228236f, 0.04246739f, -0.02230121f, 0.00072062f, 0.03118700f, -0.06125998f, -0.02026512f, -0.03019400f, 
    0.03288503f, -0.05772498f, -0.06471637f, 0.02836033f, 0.03569292f, -0.02056837f, -0.01814165f, -0.06405175f, 
    0.04433677f, 0.01563405f, 0.00828839f, -0.01768676f, 0.03688846f, -0.03302209f, 0.05096619f, -0.05653273f, 
    0.02565245f, -0.04153907f, -0.06138148f, -0.06263849f, -0.05445198f, 0.02673124f, 0.04279271f, 0.00761513f, 
    -0.05222827f, 0.00662429f, -0.01820476f, -0.03937501f, 0.00325729f, 0.04256672f, -0.01552316f, 0.02747288f, 
    0.01250712f, -0.06367107f, 0.02058207f, -0.00302599f, -0.01721327f, -0.02236623f, -0.03943045f, -0.01182305f, 
    -0.01046393f, 0.01826050f, 0.04997679f, 0.01323371f, 0.04990944f, -0.01515912f, 0.00563099f, -0.05094316f, 
    0.04064631f, 0.04067133f, 0.01023982f, 0.03367655f, 0.01166520f, -0.01711804f, -0.00840939f, 0.00717380f, 
    -0.02304881f, 0.02856615f, -0.06024082f, -0.02297853f, -0.02626996f, -0.01575736f, -0.01162160f, 0.00141391f, 
    -0.05745601f, -0.00365599f, -0.01928476f, -0.03739819f, 0.04877191f, -0.06503210f, 0.02591214f, -0.01940998f, 
    -0.03425369f, -0.05950015f, -0.04415054f, 0.01743014f, 0.04892121f, -0.04129132f, 0.01938494f, -0.04715913f, 
    -0.05548129f, -0.03791662f, -0.03549112f, -0.06509005f, -0.06985322f, 0.01424123f, 0.04465960f, 0.02319955f, 
    0.03866328f, -0.06995406f, 0.03363300f, 0.01102410f, -0.04713430f, -0.05106485f, 0.01348882f, 0.00313083f, 
    -0.03091011f, 0.04779453f, -0.05493037f, 0.02820006f, -0.01175578f, 0.04856467f, 0.02362598f, 0.01863270f, 
    0.03809222f, -0.02722234f, -0.02858473f, -0.02966570f, 0.00560752f, -0.06029774f, -0.00869573f, -0.04330835f, 
    0.03381499f, -0.03418553f, 0.03707320f, -0.00255703f, 0.03379603f, -0.00844515f, 0.03415202f, -0.01529964f, 
    -0.06372152f, -0.04699908f, -0.04131999f, -0.00647236f, -0.02835831f, -0.02782956f, 0.00761677f, -0.06412187f, 
    -0.06756029f, -0.00393043f, -0.05379235f, 0.03150422f, -0.06036646f, -0.03932939f, 0.03724084f, 0.03462841f, 
    0.02625480f, -0.06083877f, -0.04427482f, -0.04937816f, -0.00830793f, 0.02682664f, 0.02673165f, 0.02140314f, 
    0.04517420f, -0.00574182f, -0.05559909f, 0.04590707f, -0.02238345f, -0.02395639f, 0.03337213f, -0.02176237f, 
    -0.02482829f, 0.04341597f, 0.03520561f, -0.01783724f, -0.01284588f, -0.00794982f, -0.05072597f, 0.01849085f, 
    0.02707264f, -0.06494450f, -0.03783492f, 0.03430561f, -0.06040520f, 0.02453810f, 0.02712920f, -0.06076764f, 
    0.00654143f, 0.00922131f, -0.01802215f, -0.06308691f, -0.02727208f, -0.05550199f, 0.00953953f, -0.05890183f, 
    -0.06079944f, -0.06070003f, -0.00797943f, -0.06978026f, -0.02211805f, 0.02520396f, -0.06669748f, 0.01066675f, 
    -0.00002214f, -0.03830565f, -0.00857452f, 0.00908127f, -0.06515104f, 0.00751944f, -0.01777096f, 0.04629543f, 
    0.03661678f, -0.04168240f, 0.04069005f, 0.03825331f, 0.02701009f, 0.02282171f, -0.02183179f, 0.04480901f, 
    -0.03063578f, -0.02404971f, -0.03348003f, 0.03564269f, 0.01580718f, 0.02959768f, -0.02327120f, 0.02180415f, 
    -0.03743123f, 0.00713168f, -0.00970440f, 0.04676818f, 0.04158501f, 0.02460426f, 0.05263041f, -0.06797580f, 
    0.01444673f, 0.02778892f, -0.03712990f, -0.01305387f, -0.02923426f, -0.04434511f, 0.03824141f, 0.02254655f, 
    -0.05664800f, -0.03879659f, -0.01858637f, 0.03726264f, 0.03422359f, 0.04174722f, 0.04768358f, -0.01663249f, 
    0.02055201f, -0.06776880f, 0.01717153f, 0.03148296f, -0.04910976f, -0.00528776f, 0.01425251f, 0.00777529f, 
    -0.04246921f, 0.02700078f, -0.04619179f, 0.03621565f, -0.02691266f, -0.04604645f, -0.05175870f, 0.00384276f, 
    -0.01895471f, -0.00252746f, 0.04859327f, -0.05403479f, 0.00113363f, 0.04344289f, 0.00368636f, -0.05345180f, 
    -0.00253258f, -0.05793649f, 0.04743770f, 0.04110877f, 0.02949169f, -0.03187049f, 0.02309656f, -0.06174637f, 
    -0.01201631f, -0.01878238f, 0.04623597f, -0.05833681f, 0.02397971f, -0.03706547f, 0.01862659f, -0.03962696f, 
    0.04224065f, -0.01614027f, 0.04786767f, -0.05921353f, -0.00715983f, -0.01531436f, -0.00150427f, -0.00988268f, 
    -0.06173420f, 0.02182766f, -0.04958483f, 0.03656957f, -0.00591631f, -0.02067589f, -0.01938365f, 0.00352066f, 
    0.02620308f, -0.04427011f, 0.04854379f, 0.01754872f, 0.01567878f, -0.05892203f, 0.00196953f, -0.02359063f, 
    0.03541404f, -0.02570715f, -0.02767377f, 0.00350159f, 0.00749187f, -0.02402764f, -0.02480589f, 0.02592951f, 
    0.02044627f, 0.03765515f, -0.05901070f, -0.02053559f, -0.01379666f, 0.03761039f, -0.01173123f, -0.00817655f, 
    -0.01619891f, -0.02781074f, -0.03375875f, -0.01735919f, 0.04140284f, -0.03657457f, 0.06057220f, -0.01798056f, 
    0.00484541f, 0.00220525f, 0.04643817f, -0.04241012f, 0.01199370f, 0.02666014f, -0.05203977f, -0.01579500f, 
    -0.04450355f, 0.02968815f, -0.00104342f, -0.04807236f, -0.02368892f, -0.02494616f, -0.03439616f, 0.04776578f, 
    -0.02808385f, 0.00360721f, -0.03561237f, -0.01704153f, -0.02031660f, 0.00050233f, -0.06216699f, -0.05978148f, 
    -0.03428703f, -0.01059857f, 0.03527735f, -0.02134282f, -0.05649986f, 0.03427744f, 0.05219668f, -0.05064880f, 
    0.01362046f, 0.04005974f, 0.04404242f, -0.03496119f, -0.01429510f, -0.05513266f, -0.00836228f, -0.02362420f, 
    0.02869467f, -0.00831091f, -0.00118894f, -0.06599578f, -0.04300792f, -0.04554150f, 0.02485215f, -0.06033531f, 
    -0.03080264f, 0.02901713f, 0.02192047f, -0.02422926f, -0.04575837f, -0.00212787f, 0.00691508f, -0.04651094f, 
    -0.00994771f, -0.04254719f, 0.04314880f, 0.01644443f, 0.00484375f, 0.04905954f, -0.05215440f, -0.02568024f, 
    0.01616081f, 0.02500837f, -0.01727375f, -0.03850989f, 0.00059881f, 0.02511565f, 0.01552342f, -0.04499000f, 
    0.02208362f, 0.02985041f, 0.04392321f, -0.04768963f, -0.00924505f, -0.06862623f, 0.04621626f, -0.03234011f, 
    0.01336301f, -0.06153042f, 0.02991712f, 0.04365152f, -0.01488286f, -0.02603612f, 0.01315901f, 0.01391480f, 
    -0.00095919f, -0.00787894f, -0.03903491f, -0.05603402f, 0.04594149f, 0.00383500f, -0.04569852f, -0.02431739f, 
    0.03420560f, -0.05612992f, -0.01948161f, 0.01526998f, 0.00154140f, -0.04088590f, -0.05018242f, -0.05880646f, 
    -0.03166341f, -0.00213708f, -0.05656083f, -0.01761902f, 0.04668659f, 0.02692908f, 0.00726734f, -0.00720895f, 
    0.03208745f, -0.04054051f, -0.04907890f, 0.01566496f, -0.04491450f, 0.03477113f, 0.03316231f, 0.01726277f, 
    0.02595150f, -0.01119839f, -0.06749286f, -0.00861950f, 0.02182417f, -0.02526669f, -0.05612217f, 0.01103796f, 
    0.04482455f, -0.01456296f, -0.02109386f, -0.06225155f, 0.00265962f, -0.02347225f, -0.04536944f, -0.05667320f, 
    0.00975939f, 0.01766327f, -0.00620885f, 0.02816071f, -0.03487257f, 0.03292776f, 0.00810043f, -0.02066496f, 
    0.04889156f, 0.01366507f, 0.04417527f, 0.02652864f, 0.02818077f, 0.00817186f, 0.03322896f, -0.02916153f, 
    -0.00124302f, 0.03483207f, -0.02248265f, -0.04291698f, 0.02510114f, -0.06513726f, 0.04258322f, 0.02132182f, 
    0.00898016f, -0.06196935f, 0.03334339f, -0.03598528f, 0.00123360f, -0.02162845f, -0.00763869f, 0.00614830f, 
    0.00176656f, 0.00388000f, 0.04722240f, 0.00626338f, -0.00264443f, -0.02289574f, -0.05037429f, -0.02203458f, 
    -0.00396150f, -0.03685501f, 0.02376470f, -0.01882566f, 0.04872622f, 0.00299242f, 0.03432310f, -0.04574376f, 
    0.02209211f, -0.01000871f, 0.04876051f, -0.03645511f, -0.02115392f, -0.01570498f, -0.04876244f, 0.01869997f, 
    -0.03125862f, -0.01558250f, -0.00617846f, 0.04807884f, 0.00801499f, -0.02712499f, 0.02784275f, -0.04635710f, 
    -0.01975246f, -0.04526081f, 0.05026290f, 0.04660196f, 0.01786284f, -0.03984131f, -0.04884533f, -0.03492187f, 
    0.01108713f, 0.04867833f, -0.03356322f, -0.02441047f, 0.04691141f, 0.02230969f, -0.00753347f, -0.05663269f, 
    0.00918035f, -0.05601504f, -0.04161165f, -0.05409252f, -0.05659798f, 0.01894636f, -0.02344149f, -0.02353361f, 
    -0.12143353f, -0.07025844f, 0.17183930f, -0.04407690f, -0.14099310f, 0.02953806f, -0.06347222f, -0.09191290f, 
    0.04373875f, -0.61889011f, -0.01019640f, 0.28956211f, 0.08682402f, 0.02532514f, -0.04185792f, 0.01724810f, 
    0.04525843f, -0.04132388f, -0.57369304f, -0.20241798f, 0.08130077f, 0.13731480f, -0.02397118f, 0.05484750f, 
    0.00935968f, -0.03104318f, 0.07801131f, 0.01626302f, -0.26229802f, 0.02617366f, 0.06443772f, 0.17289107f, 
    0.12130150f, -0.04752317f, -0.09002588f, 0.02884640f, 0.16748588f, -0.06729907f, 0.05110647f, -0.03949407f, 
    -0.05072521f, 0.04095259f, 0.16320600f, -0.03757390f, 0.19419144f, 0.07448521f, 0.23255087f, -0.30728191f, 
    -0.02599140f, -0.02619355f, -0.09925349f, -0.05294773f, 0.08336675f, 0.05247359f, 0.09434229f, 0.05706845f, 
    -0.28904629f, 0.10470786f, 0.03635205f, 0.01727284f, 0.16234352f, -0.05543798f, 0.07612383f, -0.21957627f, 
    0.08966241f, -0.06496639f, 0.12406271f, -0.17540820f, -0.13010512f, -0.08292657f, -0.08593640f, -0.03653648f, 
    0.32295570f, -0.32238939f, -0.13079953f, -0.06184003f, 0.16193928f, -0.00612675f, -0.19991027f, 0.14109702f, 
    0.21886274f, -0.04540648f, 0.15614571f, 0.11304808f, 0.11120398f, 0.00014931f, -0.11492959f, -0.08649594f, 
    0.09252571f, -0.06165941f, 0.08802859f, -0.32988840f, 0.16217223f, -0.08151425f, 0.12863873f, 0.05388624f, 
    -0.11666210f, 0.07206009f, 0.15952295f, -0.06373186f, -0.06208494f, 0.08449531f, -0.14025773f, -0.07498606f, 
    -0.00198264f, -0.02673969f, -0.22964519f, -0.04437924f, 0.03072237f, -0.00268801f, -0.43089852f, 0.14061390f, 
    0.04729587f, -0.07379613f, 0.02840672f, -0.11846284f, 0.11114077f, 0.01233642f, 0.16628560f, 0.02673743f, 
    0.05739197f, -0.03248113f, -0.01980972f, -0.09125691f, 0.00728323f, 0.00266322f, -0.08658469f, -0.18502592f, 
    0.15059374f, 0.02876508f, -0.00697634f, -0.02574395f, 0.04028336f, -0.09590482f, 0.08090017f, -0.13866486f, 
    0.07223720f, -0.14901200f, 0.08082239f, 0.03246957f, -0.04730779f, 0.05735783f, 0.07492641f, -0.16285172f, 
    0.00926095f, -0.07373823f, -0.01495998f, -0.04543076f, -0.01468819f, 0.04388697f, 0.00814357f, 0.00554322f, 
    0.04334345f, -0.54680961f, 0.22602034f, -0.11468072f, -0.07972182f, 0.04040304f, -0.02891006f, -0.13909438f, 
    0.10873500f, 0.02258517f, -0.17060485f, 0.22206788f, -0.47491902f, 0.05919100f, -0.06229982f, 0.10489226f, 
    -0.02285505f, 0.14068584f, -0.02820687f, -0.31203881f, 0.10043604f, 0.23047358f, 0.18232310f, 0.02230169f, 
    -0.14300545f, -0.08193049f, 0.03846512f, 0.04581189f, -0.15539876f, -0.05983977f, 0.28368098f, 0.16945268f, 
    0.11196397f, -0.06407540f, -0.02557929f, -0.09388221f, -0.16410729f, 0.22460824f, 0.12232373f, -0.07191504f, 
    -0.04906542f, -0.06835384f, 0.12159454f, 0.03286184f, 0.08257559f, -0.11466155f, -0.23755778f, -0.03986483f, 
    0.22308488f, -0.04579445f, 0.06173792f, -0.01774778f, -0.06126175f, 0.07245012f, 0.02244638f, 0.09835296f, 
    0.41747549f, -0.27961174f, -0.04567909f, -0.06907262f, 0.01807644f, 0.00022476f, -0.09942368f, 0.02028783f, 
    0.05525925f, 0.16811019f, -0.29603478f, -0.00685476f, -0.02682721f, 0.09402834f, 0.01207224f, -0.14537965f, 
    0.01868678f, 0.76375538f, 0.06026039f, 0.32806990f, 0.05210780f, 0.18435690f, -0.00660288f, 0.00122890f, 
    -0.02945310f, 0.00000857f, -0.19517463f, -0.06592759f, -0.01289323f, -0.03849933f, -0.10077319f, 0.07386912f, 
    -0.05902823f, 0.02736849f, 0.12011580f, -0.11472417f, 0.04729505f, -0.01277226f, 0.06441333f, 0.04417252f, 
    -0.04622825f, -0.07131332f, 0.12801538f, 0.02201437f, -0.02856241f, 0.03596641f, 0.08909892f, 0.00976376f, 
    -0.06543082f, 0.17417499f, 0.02359853f, 0.08054926f, -0.03554660f, -0.20271167f, -0.12783606f, 0.14841272f, 
    0.08381638f, -0.03744278f, 0.08644629f, -0.10270374f, 0.03153742f, -0.00069292f, 0.13201496f, -0.11890456f, 
    -0.19004403f, -0.09888779f, 0.14907229f, -0.09845565f, -0.09864985f, 0.08467234f, 0.12046263f, -0.08891725f, 
    -0.06963175f, -0.05824747f, 0.08811872f, -0.25016192f, -0.00194665f, 0.06745359f, 0.06891590f, -0.06340954f, 
    -0.03191899f, 0.03168955f, 0.03641338f, -0.03776103f, 0.03084175f, 0.01188853f, 0.04953665f, -0.01500664f, 
    0.02180023f, 0.01371483f, 0.00792194f, -0.05512863f, -0.06236719f, 0.02291781f, 0.02268854f, 0.04540359f, 
    -0.00393381f, 0.01280893f, 0.02231967f, 0.03930464f, -0.02064338f, 0.01011525f, 0.04027309f, 0.02699577f, 
    0.02726849f, -0.04845662f, -0.05614227f, -0.03582517f, -0.03094823f, -0.00496211f, 0.00197179f, 0.03610526f, 
    -0.05511740f, -0.03483054f, 0.05504812f, 0.00496373f, -0.05135120f, 0.04155133f, -0.01727987f, -0.00066498f, 
    -0.02066163f, -0.02593064f, -0.03594189f, -0.01973884f, -0.03125618f, -0.05201403f, 0.00114919f, -0.03497590f, 
    0.02026512f, 0.02563310f, 0.03571399f, 0.00205120f, -0.03124088f, -0.05248826f, -0.07006039f, 0.00542584f, 
    -0.02565477f, 0.03187584f, -0.03715971f, -0.05132827f, 0.02218203f, -0.05465876f, -0.01634240f, -0.05921993f, 
    0.02242788f, 0.04599661f, -0.02498433f, -0.01033713f, -0.01008271f, -0.02722011f, -0.00310488f, -0.05346777f, 
    0.01600729f, 0.03902497f, -0.06902770f, 0.02707849f, 0.01060804f, 0.02730133f, -0.05130435f, -0.05333102f, 
    -0.05560625f, -0.01293515f, 0.02486739f, 0.05499300f, 0.00601376f, 0.05351711f, -0.04978032f, -0.00038078f, 
    -0.01043609f, 0.00838164f, 0.03013000f, 0.00390355f, 0.01349218f, 0.02595350f, -0.02479926f, 0.01372140f, 
    -0.01621135f, 0.02119560f, -0.00866021f, 0.01995007f, 0.00392412f, 0.01298233f, 0.04208854f, -0.01134005f, 
    -0.00956901f, -0.04595352f, -0.00124085f, -0.00565693f, -0.05781700f, 0.02493607f, -0.02674370f, 0.02387813f, 
    -0.05832481f, 0.02115519f, 0.01030318f, -0.06314046f, 0.01399025f, -0.00081990f, -0.04032593f, -0.05052276f, 
    0.04703262f, -0.05899712f, 0.03370117f, 0.03701257f, -0.04306583f, 0.04351419f, -0.05673257f, 0.02729048f, 
    -0.02516541f, -0.03919055f, 0.00445038f, -0.01909387f, -0.05148226f, -0.05186873f, -0.02886080f, 0.02043600f, 
    -0.00429338f, 0.00965300f, -0.03404984f, -0.00025693f, -0.05253872f, -0.00802590f, -0.03653847f, 0.03108193f, 
    -0.00324564f, -0.01512478f, 0.04647908f, -0.03068702f, -0.04311541f, -0.06108108f, -0.01524779f, -0.00864791f, 
    0.02376806f, 0.00674950f, -0.01012583f, 0.02049189f, 0.02584734f, 0.01511863f, -0.05409324f, 0.03293929f, 
    0.03260870f, -0.06422646f, 0.05537786f, -0.00781525f, 0.00900110f, -0.04114973f, 0.01819296f, -0.00039299f, 
    -0.05105592f, 0.01198886f, -0.01842942f, 0.03832060f, -0.05922717f, 0.01774578f, 0.01046311f, -0.03326600f, 
    0.04371611f, 0.04622686f, -0.03362808f, 0.02482970f, -0.06502376f, 0.01519416f, -0.05991936f, 0.04720748f, 
    0.00070009f, 0.05099862f, -0.02388730f, 0.02888358f, -0.04878362f, -0.02425732f, -0.04269401f, -0.03901977f, 
    -0.01102094f, -0.00502775f, -0.03850736f, -0.06437445f, 0.03214498f, -0.03201582f, -0.03203709f, 0.00061180f, 
    -0.05119750f, -0.01136414f, 0.00902399f, -0.00616015f, 0.02694974f, 0.04740834f, 0.00270633f, 0.00026682f, 
    0.01479124f, 0.05958527f, -0.02643168f, -0.04699250f, 0.05338914f, -0.01888924f, -0.04574155f, -0.03779271f, 
    0.02497608f, 0.02637001f, 0.00030282f, 0.03411953f, 0.00577918f, -0.02256219f, -0.01322904f, -0.00725505f, 
    0.04199224f, -0.05178519f, -0.03973562f, -0.02339862f, 0.04924958f, -0.01127041f, 0.02044092f, -0.04675815f, 
    0.04267228f, -0.03554570f, 0.01273458f, 0.00978310f, -0.06657433f, 0.01898417f, -0.03543765f, -0.01115655f, 
    0.00389113f, -0.03863792f, 0.02448568f, -0.05162231f, -0.02280656f, -0.04822798f, 0.03488534f, 0.04676094f, 
    0.02027783f, -0.05450386f, 0.01741932f, 0.02788036f, 0.02672091f, -0.01546937f, -0.03406145f, -0.01064765f, 
    0.03282212f, -0.04571678f, 0.01615793f, -0.04338637f, -0.01208674f, -0.00734869f, 0.04350674f, 0.01255591f, 
    0.01884255f, 0.04829342f, -0.03361491f, 0.02940586f, -0.02244884f, 0.01329320f, 0.02987904f, -0.06382459f, 
    0.02421229f, -0.04738901f, 0.00957648f, -0.01780228f, 0.04523917f, -0.04236028f, -0.00873592f, 0.04634630f, 
    0.01648987f, -0.03403159f, -0.01955277f, -0.01505385f, 0.00811807f, -0.05489434f, -0.01631811f, 0.05500028f, 
    -0.04509497f, -0.03803515f, 0.04126265f, -0.05952165f, 0.05368328f, 0.04622623f, 0.00029966f, -0.03142065f, 
    -0.02343742f, -0.00688916f, 0.01781318f, 0.01355267f, -0.05526492f, 0.02855018f, -0.05323897f, 0.04187702f, 
    0.02009518f, 0.02837922f, 0.03149056f, -0.03922171f, 0.03398062f, -0.01397686f, 0.04366853f, -0.01300215f, 
    0.03073890f, -0.02077725f, -0.02476396f, -0.03262846f, -0.04609131f, 0.03859849f, -0.02129634f, -0.00999303f, 
    -0.05031380f, -0.00164647f, -0.02137817f, -0.05632614f, 0.02665583f, -0.03283886f, -0.05042760f, -0.03874940f, 
    -0.01881603f, -0.04700519f, -0.03279068f, -0.03685664f, -0.01311586f, -0.01137554f, 0.00139897f, -0.01779393f, 
    -0.02055770f, -0.03176634f, 0.03568056f, -0.03455462f, 0.03858349f, -0.00298301f, -0.05101184f, -0.02578644f, 
    -0.01197131f, 0.00301901f, -0.06596874f, 0.02033031f, -0.01895841f, 0.04051760f, -0.01639249f, -0.02888909f, 
    -0.06201114f, -0.01863455f, -0.00869304f, -0.01415084f, 0.03388997f, -0.03847569f, -0.01867886f, 0.00912301f, 
    0.00326290f, -0.04520880f, 0.01051338f, 0.04011358f, 0.04447435f, -0.00004260f, -0.03070587f, -0.04363413f, 
    0.00755596f, -0.03050637f, 0.03575191f, -0.01814558f, -0.01057508f, -0.04405977f, -0.04699235f, -0.03914720f, 
    -0.05741445f, 0.01779858f, -0.00894556f, 0.00393648f, 0.05044311f, -0.04443790f, -0.02435663f, 0.03378163f, 
    0.01038119f, -0.04072988f, -0.03144454f, -0.01808547f, -0.00871670f, 0.01728158f, -0.06164956f, 0.01209940f, 
    -0.04362142f, -0.00365205f, 0.04552587f, -0.04979632f, -0.03255908f, 0.01806815f, 0.01688347f, -0.00529872f, 
    0.04313212f, -0.06458847f, -0.01916739f, 0.02691750f, -0.05916496f, -0.00326390f, 0.01253186f, -0.03737416f, 
    0.04384137f, -0.03293620f, -0.06597140f, -0.02975854f, 0.00384345f, -0.04401135f, 0.04827674f, -0.00657292f, 
    -0.06127302f, 0.00375762f, 0.03021106f, -0.00857856f, 0.02014516f, 0.03029185f, -0.02391675f, -0.01594103f, 
    0.00027285f, 0.02483926f, -0.01307068f, -0.01351633f, 0.00855849f, -0.05587215f, -0.06589363f, 0.05314545f, 
    0.02151866f, -0.04070877f, 0.03085765f, -0.01047156f, 0.00489566f, -0.04437326f, -0.01527025f, 0.01846860f, 
    0.01664666f, 0.00321228f, -0.03919082f, 0.00684604f, 0.03237863f, 0.06005068f, 0.01168053f, -0.02170801f, 
    -0.04145652f, 0.03048438f, 0.01732171f, -0.00397215f, 0.05240081f, 0.01186607f, 0.04890335f, -0.03209096f, 
    -0.02656911f, -0.03019919f, -0.06217031f, -0.00630274f, 0.03822448f, -0.02987960f, -0.02664814f, 0.02504976f, 
    -0.01968791f, 0.03221164f, 0.00383032f, -0.04822244f, -0.02738820f, -0.05350600f, -0.02410833f, 0.04168949f, 
    -0.02453617f, -0.01795343f, 0.03854745f, -0.06051317f, -0.00284360f, 0.04949723f, -0.01024981f, 0.02649837f, 
    0.03688000f, 0.01939404f, -0.02955294f, -0.02770020f, 0.01720481f, -0.00733517f, 0.05039633f, 0.03940580f, 
    -0.02808983f, -0.02411284f, -0.00281687f, -0.03604678f, 0.03910089f, -0.03495672f, -0.04617434f, -0.03509264f, 
    0.00905338f, -0.01749592f, 0.00304807f, 0.00452096f, 0.04747808f, -0.03161064f, -0.05035808f, 0.01004572f, 
    -0.02603143f, 0.03005948f, -0.01783406f, 0.04143295f, 0.03672601f, 0.00841724f, 0.00692314f, -0.04759070f, 
    -0.03358197f, 0.00997042f, 0.04015382f, -0.02318578f, 0.03190387f, -0.03109211f, -0.02028983f, -0.00594972f, 
    -0.00232468f, 0.03421560f, -0.06553815f, 0.05011063f, -0.02980386f, -0.01892200f, 0.00166540f, -0.04881191f, 
    0.01906765f, 0.01866228f, -0.00235874f, 0.02249094f, 0.00977530f, -0.04497634f, 0.03111968f, -0.02650087f, 
    -0.01503031f, -0.06391295f, 0.01269414f, -0.01970995f, -0.03928236f, -0.01528474f, 0.03364641f, 0.04629930f, 
    0.00751910f, 0.02581380f, 0.01676547f, -0.05753725f, 0.03883500f, 0.02984944f, 0.02889154f, -0.05111675f, 
    -0.02924672f, -0.02636630f, -0.00762957f, 0.02616231f, 0.00704903f, 0.04954234f, -0.03787902f, 0.01802479f, 
    0.00736403f, 0.00625677f, -0.03527914f, 0.03199320f, 0.02272213f, -0.01438865f, 0.00126332f, 0.04119084f, 
    0.04656688f, -0.01497053f, -0.03944401f, -0.06192119f, -0.05841949f, -0.02250182f, -0.05743734f, -0.05146424f, 
    -0.24149983f, -0.31203496f, 0.08878928f, 0.08743928f, 0.05144526f, 0.04081479f, -0.05016805f, -0.01821114f, 
    -0.06204240f, -0.14479829f, -0.22596473f, -0.14899746f, -0.08403902f, 0.09896869f, -0.25052270f, 0.04935932f, 
    -0.07532501f, 0.03415279f, 0.25078019f, -0.52320737f, -0.07163624f, 0.04072840f, -0.00724441f, 0.05097458f, 
    0.07618622f, 0.01648785f, -0.18809517f, 0.17185432f, 0.06194039f, -0.17853624f, 0.08335429f, 0.15075570f, 
    0.08963128f, -0.00909545f, 0.12913102f, -0.05536693f, -0.21634631f, -0.05196805f, 0.06372079f, -0.02755432f, 
    -0.06301998f, -0.02375827f, -0.04386631f, 0.10981303f, 0.05062075f, 0.11588679f, 0.13426329f, -0.01499538f, 
    -0.17630254f, -0.20994385f, 0.00857711f, 0.06330771f, 0.04617067f, 0.00638028f, -0.14944544f, 0.12060922f, 
    0.11095197f, 0.16306451f, -0.14241700f, 0.17882815f, -0.20666175f, 0.21560158f, 0.01409765f, 0.18496808f, 
    -0.08419984f, 0.02773835f, -0.01534777f, -0.11528028f, -0.03071911f, 0.03067726f, 0.07798565f, 0.08253454f, 
    0.09419563f, 0.12963495f, 0.02216767f, -0.02696126f, 0.10537876f, 0.15111998f, 0.01387157f, 0.27914298f, 
    -0.00461318f, -0.07732940f, 0.18163906f, 0.18925488f, 0.00475582f, -0.12968454f, 0.20864904f, -0.11345606f, 
    0.07808837f, 0.07129259f, 0.44989160f, -0.17612551f, -0.41061178f, -0.10019863f, 0.14278090f, 0.13263719f, 
    0.18603498f, 0.10145524f, 0.13173930f, -0.23946910f, -0.07321218f, 0.16671808f, -0.24069856f, 0.05909816f, 
    0.03778004f, -0.01844679f, -0.04975514f, -0.10374707f, -0.07549688f, 0.26512223f, -0.17709880f, -0.08782414f, 
    0.17246631f, 0.20882234f, -0.11783464f, 0.05935499f, -0.24534909f, -0.12712349f, 0.10712494f, 0.24313779f, 
    -0.14272860f, -0.16997391f, -0.08257252f, 0.15560475f, -0.04577526f, 0.06251234f, 0.05826014f, -0.02169801f, 
    -0.33450314f, 0.17645174f, -0.04397433f, -0.00265876f, -0.07559381f, -0.06918071f, -0.13007803f, 0.04500504f, 
    0.01200783f, -0.05810864f, 0.09022513f, 0.13025245f, 0.18222933f, -0.07394124f, -0.00203700f, 0.05878242f, 
    0.23602208f, -0.06459329f, 0.10585973f, 0.02040834f, -0.10072915f, -0.20709953f, 0.27141064f, 0.00354954f, 
    -0.01388122f, 0.44403723f, -0.14774695f, 0.14320530f, -0.15566401f, -0.00792395f, -0.17095205f, 0.07553677f, 
    0.01135045f, -0.18431200f, 0.06924719f, 0.04919498f, -0.07843457f, 0.05474265f, 0.13284284f, 0.19580986f, 
    -0.22341295f, 0.16921100f, -0.08827524f, -0.19904460f, -0.07679339f, -0.01085531f, -0.11800025f, 0.18984713f, 
    0.10909321f, 0.09379874f, -0.09361055f, 0.01165676f, -0.40300366f, 0.10846017f, -0.21260266f, 0.05222299f, 
    0.17271918f, 0.05416641f, -0.08863087f, 0.13612610f, 0.08230923f, -0.03168789f, 0.07280470f, 0.18103977f, 
    0.11288087f, 0.09266322f, -0.00514588f, -0.14233440f, 0.03347659f, -0.04084332f, -0.06089062f, 0.06723286f, 
    -0.17193769f, 0.12350801f, 0.13653146f, 0.05592193f, 0.14155366f, 0.10672175f, -0.08598591f, -0.31731185f, 
    -0.02269853f, 0.02100776f, 0.02226136f, -0.12903298f, -0.20061426f, -0.15169220f, -0.03540980f, 0.13086204f, 
    -0.10278917f, -0.13714579f, 0.10777203f, 0.15892042f, -0.00995363f, -0.05190231f, 0.04282672f, -0.19070651f, 
    -0.00413445f, -0.43046567f, 0.21507883f, 0.02765233f, -0.01125846f, 0.04780257f, -0.04630841f, -0.11939431f, 
    0.22882243f, 0.02336432f, -0.12821986f, 0.20683061f, -0.05637418f, -0.02233493f, 0.04181294f, 0.00761659f, 
    -0.07740977f, -0.05007034f, -0.05067024f, 0.10262811f, 0.03632387f, 0.02078118f, -0.02324949f, -0.11622155f, 
    0.00538642f, -0.15619573f, 0.11467931f, 0.05302315f, 0.14534216f, -0.35376230f, 0.14163877f, -0.00502521f, 
    -0.06628752f, 0.04854817f, -0.13003163f, -0.11589681f, 0.06219873f, 0.05860578f, -0.09237216f, -0.28111735f, 
    0.01942370f, 0.03115076f, -0.14499295f, -0.12498663f, 0.06967703f, -0.32369554f, 0.01368360f, -0.09378498f, 
    0.08683178f, -0.11812337f, 0.21330562f, 0.07970020f, 0.02136052f, 0.02661476f, -0.05252654f, -0.04802174f, 
    0.02714438f, -0.26338053f, 0.08735553f, -0.07571025f, 0.02563599f, 0.06865247f, 0.13729392f, 0.03961957f, 
    -0.01960524f, -0.02626261f, -0.05223243f, -0.02949939f, -0.00297673f, -0.04899172f, -0.03575005f, -0.02799112f, 
    -0.03625672f, -0.04805379f, 0.04032586f, 0.02744299f, 0.00340676f, -0.03338356f, 0.03446501f, 0.02953061f, 
    0.01967241f, -0.04432805f, -0.04651587f, 0.04193377f, 0.03902889f, -0.04587570f, 0.02302999f, -0.02765897f, 
    0.00758852f, 0.04749136f, 0.02614581f, 0.00303024f, -0.03283750f, -0.00268142f, 0.04246153f, 0.02038256f, 
    -0.06416187f, 0.03476352f, -0.00702878f, -0.03295336f, 0.04437241f, 0.04684464f, 0.00982177f, -0.04170978f, 
    0.02585007f, -0.01434117f, -0.02805188f, -0.03733297f, 0.02465924f, 0.00127898f, -0.02538069f, -0.01010452f, 
    -0.00714733f, -0.05985881f, -0.01112046f, 0.04981105f, 0.00905114f, -0.03605185f, 0.00410745f, 0.02626132f, 
    0.01351290f, -0.04639638f, -0.06321817f, 0.00148103f, -0.00132797f, 0.04660527f, -0.03698737f, -0.04292562f, 
    -0.00271042f, 0.00276938f, 0.04171680f, -0.04656599f, 0.02150048f, 0.02182982f, -0.03166335f, 0.03410939f, 
    0.04409468f, 0.04311726f, -0.00513974f, 0.03281843f, -0.05986426f, 0.03108783f, -0.03059967f, -0.04789228f, 
    0.01080623f, -0.04988122f, -0.00396895f, 0.01184234f, -0.03670136f, -0.04850222f, 0.03184414f, -0.01652940f, 
    -0.02248753f, 0.02329459f, -0.05030194f, -0.03577892f, -0.01335471f, 0.03569544f, 0.01110414f, -0.06379756f, 
    0.04719493f, -0.02873134f, -0.05929060f, -0.03461255f, 0.00382757f, 0.03393831f, -0.01405205f, 0.01757769f, 
    -0.04830724f, 0.04727374f, 0.01068673f, 0.00988430f, 0.02985194f, 0.01061828f, 0.01606781f, -0.01917550f, 
    -0.05267887f, 0.03848444f, 0.01903484f, 0.05374906f, 0.03112772f, -0.01951358f, -0.04877022f, -0.00641605f, 
    0.01838204f, 0.00124163f, -0.00069824f, 0.04204150f, 0.01516261f, 0.02323291f, -0.05272172f, -0.03653929f, 
    0.04364955f, -0.04229279f, -0.04197147f, -0.01347261f, 0.00869284f, 0.00432435f, -0.05932941f, -0.05198358f, 
    -0.06279288f, -0.06039946f, -0.06112285f, -0.00717067f, 0.04976140f, -0.05416545f, -0.02557065f, -0.01723047f, 
    -0.06442713f, 0.02306225f, -0.04030385f, 0.04054438f, 0.02887151f, 0.02387956f, -0.04481499f, -0.01613782f, 
    -0.01577907f, -0.06071756f, -0.05194961f, 0.02370855f, 0.00297254f, 0.02084166f, -0.05297059f, 0.00734542f, 
    -0.03489850f, -0.05421623f, 0.04823674f, -0.03045605f, 0.05306664f, -0.06019261f, -0.04521890f, 0.02010283f, 
    0.00948837f, -0.04884787f, -0.06200160f, -0.00233541f, -0.02445429f, -0.00150406f, 0.02964347f, -0.03309471f, 
    0.00828131f, 0.03383163f, -0.04607076f, -0.01921457f, 0.01952951f, 0.05426590f, -0.01112205f, -0.05640493f, 
    0.03625321f, -0.06267814f, 0.05015716f, -0.01031771f, -0.02501847f, -0.03515713f, -0.01147008f, -0.00116325f, 
    0.02449630f, 0.01689920f, -0.02668423f, 0.02222198f, -0.05223634f, -0.03111242f, -0.02867564f, 0.03772493f, 
    0.01837505f, 0.04923169f, -0.05742045f, 0.02236200f, 0.01429769f, -0.02194270f, -0.02358409f, -0.05082220f, 
    0.02751391f, 0.00169297f, 0.01726501f, -0.04875777f, 0.05235889f, 0.03566881f, -0.01993737f, -0.02158996f, 
    -0.00799780f, -0.05346595f, -0.04849483f, 0.04389911f, -0.04951936f, 0.03125940f, -0.06526067f, -0.06060617f, 
    -0.04709380f, -0.04156347f, 0.00655799f, 0.04761617f, -0.00374373f, 0.02951247f, -0.00060254f, -0.04514181f, 
    0.03820303f, 0.03062753f, -0.05237011f, 0.02344134f, -0.04678860f, 0.00328265f, 0.02806037f, -0.00450393f, 
    0.04872462f, 0.04920497f, -0.01054218f, 0.06538462f, 0.02686744f, 0.05379581f, 0.04369357f, -0.00289210f, 
    0.03319493f, -0.01456593f, -0.01133216f, -0.05247785f, -0.03532647f, 0.04566621f, 0.05064795f, -0.03729289f, 
    -0.01946953f, -0.03001565f, 0.02419635f, 0.02054290f, -0.03552929f, 0.02236548f, -0.04400596f, -0.01723549f, 
    0.02937062f, -0.02951521f, -0.05390786f, -0.05212422f, -0.06209291f, 0.03564304f, 0.03371173f, 0.00739538f, 
    0.04458965f, -0.05617631f, -0.04562663f, -0.06423820f, -0.05301142f, 0.01177488f, -0.02328091f, 0.02603611f, 
    -0.01276048f, -0.01937762f, 0.00518679f, -0.00790824f, 0.00674170f, -0.06646847f, -0.05085070f, -0.02680584f, 
    -0.05936477f, -0.03595842f, 0.02745558f, -0.05332653f, -0.01838597f, -0.02184368f, -0.05150222f, -0.05765226f, 
    0.02470723f, -0.06769590f, -0.03433434f, -0.04733765f, -0.05720437f, 0.02675117f, -0.00679027f, 0.01541581f, 
    0.00413108f, -0.01071919f, -0.04172769f, -0.04006362f, -0.00895093f, -0.00217518f, -0.03602985f, -0.06138755f, 
    0.00816777f, 0.01430157f, -0.02441209f, -0.00686799f, -0.06309632f, -0.07505436f, 0.03764274f, -0.07150731f, 
    0.04615073f, -0.02745622f, -0.02592104f, 0.04521783f, 0.04337979f, 0.02502985f, -0.04206304f, 0.05029660f, 
    -0.05494587f, -0.06461132f, 0.04183712f, 0.00330851f, 0.02751102f, 0.01966987f, -0.04379797f, -0.00024879f, 
    -0.01544347f, -0.02203591f, 0.00932425f, 0.05203569f, -0.04641812f, 0.00854168f, -0.05562501f, -0.02387495f, 
    -0.02325817f, 0.00404871f, 0.01408627f, -0.02919930f, 0.02670458f, -0.02817819f, -0.02579185f, -0.03162618f, 
    -0.04179474f, -0.00861002f, -0.03058820f, 0.00487524f, -0.06144779f, -0.01086540f, -0.01812175f, 0.04055696f, 
    0.00256268f, 0.02281723f, -0.00117935f, -0.03290585f, 0.03774675f, -0.05660777f, 0.02798377f, 0.01865204f, 
    0.04102373f, -0.02320045f, 0.00158720f, 0.00071779f, 0.04927809f, -0.05027210f, -0.03839437f, 0.01331175f, 
    0.03551371f, -0.00658314f, 0.03188324f, 0.03332654f, -0.03647356f, -0.04083296f, -0.01383403f, -0.04637780f, 
    0.03882089f, -0.01050553f, -0.05754679f, -0.04706145f, 0.02722979f, 0.00329189f, -0.02782432f, -0.01135177f, 
    -0.05242762f, 0.02635539f, -0.00393322f, 0.02001280f, -0.00589704f, 0.02553743f, -0.01548771f, 0.01494627f, 
    -0.01598678f, 0.03306723f, -0.02233830f, -0.01888866f, 0.04936234f, -0.00552558f, -0.03279084f, -0.02866725f, 
    -0.01051253f, 0.04061945f, 0.02182985f, -0.02015492f, -0.05662688f, -0.00609301f, -0.05499115f, -0.00518976f, 
    0.03942618f, 0.01437464f, -0.01581982f, -0.03986520f, 0.02698840f, -0.04154265f, -0.02083690f, -0.03500075f, 
    -0.03500949f, -0.01584505f, -0.04859630f, -0.04374676f, 0.00721336f, -0.06079706f, -0.04054194f, -0.01404486f, 
    -0.02792523f, 0.02097808f, 0.04141678f, -0.04589082f, -0.04171309f, 0.00596946f, 0.03045195f, -0.01618123f, 
    -0.01962452f, 0.01384764f, -0.00058117f, -0.02940339f, -0.05096547f, -0.01205552f, -0.06157209f, 0.03464201f, 
    -0.01235044f, 0.04445558f, -0.00422647f, -0.06473026f, -0.06078497f, 0.02990752f, 0.03976440f, -0.00875718f, 
    -0.05584853f, -0.00629399f, 0.03757670f, 0.01985934f, -0.01618202f, -0.00375249f, -0.07191839f, -0.01005821f, 
    0.05689322f, -0.00872865f, -0.01691309f, 0.01389404f, -0.05776639f, -0.07109175f, 0.03643762f, 0.00455156f, 
    -0.00222389f, 0.04515168f, -0.03982930f, 0.05050951f, 0.03013352f, 0.02841347f, -0.03666636f, -0.05324265f, 
    -0.02252843f, -0.01744651f, -0.00672242f, 0.02990422f, -0.05164296f, 0.01921790f, -0.04752829f, -0.04869340f, 
    0.00376288f, -0.04634022f, 0.00046871f, -0.04153544f, 0.02509945f, -0.00843014f, -0.05333221f, -0.03463495f, 
    0.02520001f, 0.04660184f, -0.05212801f, 0.03345182f, 0.05479086f, -0.02205861f, -0.02703804f, 0.01649158f, 
    -0.03467140f, 0.01373550f, -0.03170962f, -0.05231937f, 0.01959520f, 0.04020814f, -0.07308254f, -0.00042193f, 
    -0.00494281f, -0.00369083f, 0.00487834f, -0.05723012f, -0.01495435f, 0.01590776f, 0.05488352f, 0.03786253f, 
    0.02695800f, -0.06864881f, -0.03005069f, 0.03453795f, -0.01373827f, -0.01374294f, -0.00431692f, 0.01226572f, 
    0.03804994f, 0.02767133f, 0.00499488f, 0.00246857f, 0.02799121f, -0.02882818f, 0.00185135f, 0.02758338f, 
    -0.00902151f, 0.04113911f, 0.00934200f, 0.01297553f, -0.01097847f, 0.00890708f, -0.04491926f, -0.03769273f, 
    -0.02533266f, -0.03385365f, 0.05614705f, 0.03906864f, 0.00532848f, 0.01271583f, -0.04908585f, 0.01155792f, 
    -0.02602488f, -0.01306558f, -0.03424828f, 0.01781807f, 0.04062771f, -0.00015264f, -0.04139394f, -0.01871814f, 
    -0.03885067f, 0.04672270f, -0.03930733f, -0.00755840f, 0.02774056f, -0.03866025f, -0.03312476f, -0.00987905f, 
    -0.00997764f, 0.00760878f, 0.02182959f, -0.03222319f, 0.03109626f, 0.04251327f, 0.01732140f, -0.00481976f, 
    0.20967303f, -0.05395605f, -0.08683470f, -0.08489311f, -0.13180725f, -0.10894938f, 0.06965999f, -0.05614257f, 
    -0.07447807f, -0.01222201f, 0.15783425f, -0.02223163f, -0.08294248f, -0.07452319f, 0.23225792f, 0.08408765f, 
    -0.08340923f, 0.09938661f, 0.30697930f, -0.01095956f, 0.02712929f, -0.00844563f, -0.06189203f, -0.05526427f, 
    -0.11218168f, -0.04364748f, 0.10886323f, -0.00689174f, 0.25512192f, -0.05798536f, 0.02218756f, -0.13669942f, 
    0.05624495f, 0.01244626f, 0.05816358f, 0.19062302f, 0.06253248f, 0.10815462f, -0.33155239f, 0.08921003f, 
    0.08306411f, 0.19395934f, -0.09825246f, 0.06675702f, -0.07691833f, 0.18482549f, -0.55425006f, 0.16006863f, 
    0.11339105f, 0.03633021f, 0.19088121f, 0.04375341f, 0.06867027f, -0.00221894f, -0.04003145f, -0.46922833f, 
    0.03476497f, 0.00179434f, 0.00672876f, 0.15652530f, 0.01752844f, 0.01629543f, -0.08409352f, -0.19356658f, 
    0.14426896f, 0.05330672f, 0.03032473f, 0.02255630f, 0.06153981f, -0.07642923f, -0.01811045f, 0.14486419f, 
    -0.35581836f, 0.22324485f, -0.05742186f, -0.02924428f, -0.07759433f, 0.03139229f, -0.14842770f, -0.13691232f, 
    0.17865472f, -0.07494779f, -0.42566577f, -0.15125033f, -0.07484633f, 0.06995837f, -0.03900563f, 0.10362685f, 
    -0.09211565f, -0.05941819f, -0.14250591f, -0.01298226f, -0.24346231f, -0.08628900f, -0.06121631f, -0.03126467f, 
    0.03576177f, 0.16569409f, 0.04752328f, -0.04125397f, 0.15124528f, 0.07799213f, -0.14784251f, -0.12245090f, 
    -0.01404667f, 0.14198387f, 0.03941573f, 0.09240200f, -0.10311938f, 0.34632948f, 0.34322575f, 0.05817061f, 
    -0.09570631f, -0.12878121f, 0.10351702f, -0.12131919f, -0.23156750f, 0.21915482f, -0.12271070f, 0.03433895f, 
    -0.09305119f, 0.03295912f, 0.03380099f, 0.00189382f, 0.06376769f, 0.00211344f, -0.02105217f, 0.29898876f, 
    0.07337451f, -0.03286510f, 0.16090056f, 0.06867541f, 0.00268266f, 0.06574488f, 0.08844364f, 0.12977313f, 
    -0.15737231f, 0.07142708f, -0.12088779f, 0.09019570f, -0.05154739f, 0.04684451f, 0.02592166f, -0.07105085f, 
    -0.23019226f, 0.01068415f, -0.01817437f, 0.10725392f, -0.07950029f, -0.11884061f, 0.15201919f, 0.10610782f, 
    0.13680921f, -0.06720372f, -0.05936844f, 0.28616336f, 0.00250735f, 0.02868565f, 0.03124670f, -0.15318426f, 
    -0.03335588f, 0.31968474f, 0.13944250f, -0.08767176f, 0.18015586f, -0.05559075f, 0.09796908f, -0.00916726f, 
    -0.02228727f, 0.05237293f, 0.01275107f, -0.36076012f, 0.23998453f, 0.00870565f, -0.07244284f, -0.27355430f, 
    -0.08022382f, -0.02472345f, 0.03326270f, 0.07147378f, 0.22809844f, 0.03256555f, -0.24535114f, 0.11879617f, 
    -0.08720974f, -0.11418001f, 0.17691401f, 0.13843945f, -0.07758258f, 0.39440933f, -0.00087250f, -0.04284460f, 
    -0.07226491f, -0.03180817f, 0.06874888f, 0.09550501f, -0.05668805f, -0.14396118f, 0.03668474f, 0.26639178f, 
    -0.00500145f, -0.08138078f, -0.01244286f, -0.10928381f, 0.06119974f, 0.04586609f, 0.05177301f, 0.18219876f, 
    0.19696170f, 0.12039249f, 0.09250838f, -0.03045675f, 0.14788373f, 0.02892483f, 0.14725728f, 0.08289368f, 
    0.54343253f, -0.27146330f, 0.03363877f, -0.11779042f, 0.03572151f, -0.15317880f, 0.16801862f, 0.16353218f, 
    -0.02271995f, -0.24124007f, -0.25777772f, -0.09070599f, 0.00708517f, 0.02897604f, 0.00542504f, -0.12342996f, 
    -0.07002473f, 0.05447151f, 0.17132819f, 0.04983681f, -0.10872553f, -0.03232982f, 0.08632728f, 0.07500117f, 
    -0.09030690f, 0.14842150f, 0.03533771f, -0.03182291f, -0.65031976f, -0.08815608f, -0.06888840f, -0.01740041f, 
    0.00334197f, 0.02151832f, -0.18613429f, 0.01954786f, -0.21110764f, 0.02475769f, 0.14550979f, -0.08886471f, 
    -0.00180104f, -0.09835374f, -0.06601945f, -0.09963033f, -0.06435097f, 0.13216701f, 0.18535522f, -0.22053833f, 
    0.01310669f, -0.11894842f, -0.09245546f, 0.09814298f, 0.10747169f, 0.04266236f, -0.40819192f, -0.12964571f, 
    -0.01153593f, -0.03787709f, -0.15448932f, 0.23537849f, -0.07563458f, 0.09057697f, 0.05708696f, -0.05384128f, 
    0.06121020f, 0.02677080f, -0.00380328f, -0.17338744f, -0.02895795f, 0.10444748f, -0.02770135f, 0.05995236f, 
    -0.41961020f, -0.14301868f, 0.13548297f, -0.12462507f, -0.06300110f, 0.01655075f, -0.02136768f, -0.04347309f, 
    0.03457402f, -0.11932477f, 0.01141561f, -0.05114550f, 0.16088288f, 0.18020494f, -0.01435512f, 0.09181957f, 
    -0.09119136f, 0.09948572f, -0.52184141f, -0.14432411f, 0.16001588f, 0.11875142f, -0.00538707f, 0.08719803f, 
    -0.16687015f, 0.06294542f, -0.08758110f, 0.10019675f, -0.11545986f, -0.10455007f, 0.04365115f, 0.06245131f, 
    -0.04101568f, 0.14806773f, 0.06807835f, -0.01128331f, 0.04478391f, -0.11689977f, 0.22674213f, -0.14098446f, 
    -0.12261166f, 0.03462241f, -0.01608780f, 0.09118129f, -0.08912686f, -0.02923313f, 0.28168353f, -0.23607077f, 
    0.07319845f, 0.11707688f, -0.08879663f, -0.17678209f, 0.14642806f, -0.03235678f, -0.20367716f, 0.02658529f, 
    -0.22172137f, 0.20480369f, -0.02901638f, 0.10874863f, -0.01616943f, -0.02776294f, 0.22863860f, -0.16547303f, 
    0.14775313f, -0.16047186f, -0.11653425f, -0.04466279f, -0.19623046f, 0.13679962f, 0.04070753f, 0.21108408f, 
    0.05454682f, 0.15026382f, 0.14749819f, 0.07323281f, -0.23498636f, -0.11700692f, 0.12749916f, 0.03644870f, 
    0.25888169f, -0.08936766f, 0.19553088f, 0.04359383f, -0.11123780f, 0.00264106f, 0.02089116f, -0.11641209f, 
    0.07156742f, -0.05722372f, 0.25541106f, -0.34067211f, -0.18302251f, 0.06277826f, 0.02857080f, 0.00755972f, 
    0.31145504f, -0.00094505f, 0.12337305f, -0.15130721f, -0.29057655f, 0.08829373f, -0.16060854f, -0.02801816f, 
    0.09191794f, -0.13283841f, -0.12251451f, -0.00447086f, -0.19216031f, 0.05342249f, 0.08513916f, 0.06536656f, 
    -0.06152335f, -0.15537894f, -0.07621242f, 0.05119509f, -0.21756002f, -0.16227296f, 0.17521083f, -0.01525247f, 
    -0.02467940f, 0.03175881f, -0.10701949f, -0.10145635f, 0.00710083f, 0.04781140f, 0.21506700f, -0.05451675f, 
    -0.16917856f, 0.13503897f, 0.10015757f, 0.00098539f, 0.07156935f, -0.03780512f, 0.08029459f, -0.12137799f, 
    0.17162427f, -0.11431539f, -0.07422671f, -0.07442559f, 0.09445649f, -0.06701073f, 0.02905859f, -0.01866438f, 
    0.03013984f, 0.05821288f, -0.18650937f, 0.12365925f, 0.02518697f, -0.12864442f, 0.24503568f, -0.00318785f, 
    0.04684353f, -0.22248285f, -0.08423595f, 0.10544264f, 0.01390742f, -0.07337821f, 0.14294514f, -0.09326053f, 
    0.06376093f, -0.17584975f, -0.04889679f, 0.07436269f, -0.19105867f, 0.03325495f, -0.11378308f, 0.00364247f, 
    -0.01509529f, 0.02300031f, 0.02810492f, -0.33089039f, -0.01589668f, 0.31382617f, 0.11744078f, 0.04987802f, 
    -0.03914690f, 0.03450217f, -0.04450465f, 0.06827096f, -0.09842023f, 0.01032497f, 0.36270958f, -0.04514596f, 
    -0.05835709f, -0.00147269f, -0.04011630f, 0.01669122f, 0.05785875f, -0.10779274f, 0.41820747f, -0.04200460f, 
    -0.18520784f, 0.03030605f, 0.04792316f, -0.09670071f, 0.05692139f, 0.09708648f, -0.01880052f, -0.19323747f, 
    0.08775526f, 0.15444142f, 0.07225044f, 0.16950633f, 0.00827831f, -0.04207614f, 0.13023524f, -0.09286252f, 
    0.52458090f, -0.20285308f, -0.00853743f, -0.11412178f, -0.21818116f, -0.07437634f, 0.00144281f, 0.11541978f, 
    0.02448847f, 0.35205171f, -0.20638873f, -0.04745441f, 0.09985683f, -0.00589258f, -0.20337804f, -0.06745260f, 
    0.18276915f, 0.27351117f, -0.06418260f, 0.15659355f, -0.11919541f, -0.03601359f, 0.07620008f, 0.34078753f, 
    0.13483763f, 0.23538397f, 0.15659976f, -0.22777671f, 0.15964694f, 0.02241497f, 0.02065929f, -0.07770656f, 
    0.00207017f, -0.02176135f, 0.00721987f, -0.10714966f, -0.07963808f, 0.14806025f, -0.03354988f, -0.11412334f, 
    -0.05412313f, 0.07455750f, 0.02127908f, 0.06914902f, -0.19749653f, 0.24747230f, -0.28077078f, 0.08504192f, 
    -0.04074628f, -0.06848396f, -0.03396361f, 0.00597176f, 0.18465137f, 0.03588100f, -0.16989817f, 0.08417349f, 
    -0.00688611f, 0.03845047f, -0.15409949f, -0.10925177f, -0.10446542f, 0.14632073f, 0.00251417f, -0.01056573f, 
    -0.27401221f, -0.07600464f, 0.06621858f, 0.10368989f, 0.12448552f, -0.03559966f, -0.02601915f, 0.09735995f, 
    -0.44773051f, -0.01582073f, 0.13445996f, 0.06355122f, -0.14418562f, 0.19418781f, 0.01458148f, -0.00362463f, 
    -0.27310154f, -0.13635167f, -0.20481323f, -0.07554946f, -0.05278752f, 0.04558284f, 0.03656142f, 0.03363172f, 
    0.02336507f, 0.10613330f, 0.04301801f, -0.01707539f, 0.06292482f, -0.04197694f, 0.23770651f, 0.13879187f, 
    -0.07525048f, 0.01991514f, -0.29833972f, -0.05934251f, -0.26487014f, 0.02746264f, 0.14098932f, 0.14572746f, 
    -0.02223468f, 0.04669609f, -0.07082194f, -0.08203484f, 0.26446658f, -0.06239962f, -0.07225235f, -0.06757222f, 
    -0.06003334f, 0.02320240f, -0.00401226f, 0.06105213f, 0.12474941f, -0.12623610f, -0.21195677f, -0.09246409f, 
    0.00124607f, 0.05900187f, 0.11017208f, 0.02753710f, -0.04553079f, -0.23567227f, -0.08145478f, 0.23122060f, 
    0.01491480f, 0.09213276f, -0.20596322f, -0.01779176f, -0.04933834f, 0.03432944f, -0.26700515f, -0.18171027f, 
    0.17006984f, 0.01117236f, 0.04048248f, -0.06011470f, 0.00418134f, 0.01398875f, -0.07608770f, 0.16025601f, 
    0.09521981f, 0.19439951f, -0.11346217f, -0.00523703f, -0.02769980f, 0.18974660f, 0.11166306f, 0.15209982f, 
    -0.22029279f, 0.28639212f, -0.35559401f, -0.12305000f, 0.02535031f, 0.12014155f, -0.05380513f, -0.09327251f, 
    -0.07254834f, -0.03148007f, -0.06391767f, -0.11148219f, 0.14776273f, -0.07511742f, 0.05083107f, 0.03686939f, 
    -0.06043270f, -0.04090819f, 0.26581675f, 0.06249209f, 0.15025070f, -0.01882526f, 0.06074541f, -0.07196024f, 
    0.02115752f, 0.11980201f, 0.03293912f, -0.11561638f, 0.11547461f, 0.06936925f, -0.11040548f, -0.06887367f, 
    0.08200376f, 0.00350487f, 0.28288811f, 0.17622901f, -0.17634071f, -0.40513307f, -0.21050975f, 0.16024300f, 
    -0.02422085f, 0.05285005f, -0.13223159f, -0.14084661f, 0.05722587f, 0.17946593f, -0.39046225f, -0.11321579f, 
    0.00020465f, -0.06473035f, -0.01939303f, 0.00121166f, 0.04282928f, 0.13266525f, 0.25316009f, 0.11619653f, 
    0.11301210f, 0.15490474f, 0.19339593f, -0.11452314f, 0.15681911f, 0.00792230f, -0.05956275f, -0.19019380f, 
    -0.43290928f, -0.10530519f, 0.01564950f, -0.15129018f, 0.03309280f, 0.07208950f, -0.11018475f, 0.10409594f, 
    0.07003006f, 0.05251407f, 0.14844777f, -0.01226819f, 0.09016619f, -0.02660760f, 0.15268962f, 0.01435081f, 
    -0.00074758f, 0.00585328f, -0.10569960f, -0.19989054f, -0.06725862f, 0.14404859f, 0.08843154f, -0.01336797f, 
    0.16764995f, 0.05575343f, -0.48297197f, -0.05904302f, 0.23815818f, -0.06958768f, 0.03333054f, -0.08220699f, 
    0.03657822f, -0.12608497f, 0.09529547f, -0.02310971f, 0.11872973f, 0.07464965f, -0.02843563f, -0.11128899f, 
    -0.21102378f, 0.00982542f, 0.04817467f, 0.37346703f, 0.10497210f, 0.04358514f, 0.09636419f, 0.10338114f, 
    -0.05536007f, 0.05030063f, 0.08532473f, -0.00932580f, 0.00428896f, 0.20271327f, -0.23828481f, 0.03979617f, 
    -0.03111264f, 0.01776638f, 0.06359746f, 0.10612170f, -0.11036457f, 0.18092464f, 0.17395799f, 0.22323409f, 
    0.01913388f, 0.00978798f, 0.08208167f, 0.09791589f, 0.02072069f, 0.10904880f, -0.03706830f, 0.14806825f, 
    -0.56899804f, 0.01996718f, 0.13328825f, -0.08899572f, 0.00345205f, -0.15876420f, 0.03665246f, -0.02147254f, 
    0.03718759f, -0.30317459f, -0.25157702f, -0.23598576f, -0.02140366f, 0.05788982f, 0.04939091f, -0.06304561f, 
    -0.16632602f, -0.12216137f, -0.05294254f, 0.19661267f, -0.05149952f, -0.11665085f, 0.04082236f, -0.06043816f, 
    -0.10652602f, 0.09724442f, 0.01242598f, 0.06309544f, 0.09236410f, 0.02065552f, -0.05160847f, 0.08358461f, 
    -0.00897140f, -0.06102698f, -0.04461424f, -0.20453687f, -0.27971482f, 0.28291717f, 0.09165709f, -0.07065137f, 
    -0.15982735f, -0.08406060f, 0.04392089f, -0.08980350f, -0.05059455f, 0.15530442f, 0.00726395f, -0.14514522f, 
    0.03189760f, 0.04680824f, 0.08911970f, 0.17247021f, -0.11453793f, 0.29512185f, 0.04234842f, 0.11543686f, 
    0.10330982f, 0.07156818f, -0.09820321f, 0.04814993f, 0.10152817f, -0.01699313f, -0.19047195f, -0.17535526f, 
    -0.00373599f, -0.15012185f, -0.06059199f, -0.03288054f, 0.04743457f, 0.15773229f, 0.08519571f, -0.04953897f, 
    -0.15688084f, 0.18086143f, -0.09084222f, 0.14289922f, -0.10410634f, 0.01965577f, -0.07885420f, -0.08248740f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.23936990f, 0.08088458f, 0.02824568f, -0.01756385f, 0.08974690f, -0.08482836f, 0.00455562f, -0.18917716f, 
    0.00536587f, -0.09004471f, 0.26341245f, 0.05694786f, 0.03571087f, 0.12695090f, -0.00078788f, 0.00168434f, 
    0.04960126f, 0.00865456f, 0.13952266f, -0.04671505f, 0.14298786f, 0.00124690f, -0.05200594f, 0.06669538f, 
    0.02466504f, 0.01406856f, 0.18552731f, -0.05602066f, -0.06179637f, 0.01555085f, -0.02467108f, 0.08627728f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.05331828f, 0.37116173f, -0.08120963f, 0.12935574f, -0.55971110f, -0.12361867f, 0.22138368f, 0.57416487f, 
    0.15652038f, 0.23247804f, 0.17614372f, 0.13433006f, 0.11737911f, -0.07394535f, 0.02748028f, 0.12039353f, 
    -0.42994711f, -0.08354884f, 0.07113420f, -0.11091162f, 0.23153196f, -0.16112426f, -0.13513549f, 0.55684060f, 
    0.05014787f, 0.11452262f, 0.47594634f, -0.03113059f, 0.00255160f, 0.06092661f, 0.79903376f, -0.04350451f, 
    -0.11066849f, 0.72011417f, -0.08572207f, -0.13890706f, -0.20472296f, 0.14263245f, 0.42569888f, 0.01442423f, 
    -0.05888471f, 0.38770893f, 0.11773168f, -0.14657485f, 0.16337556f, 0.24522918f, 0.18036595f, 0.07663435f, 
    0.39091936f, -0.02337629f, 0.06599049f, -0.02044389f, 0.05198196f, -0.11593322f, 0.08957588f, -0.76537496f, 
    -0.02494353f, -0.09538502f, 0.02962780f, 0.06611976f, -0.05189015f, -0.01794590f, 0.12516329f, 0.52533889f, 
    0.33865789f, -0.71137565f, 0.03379832f, 0.10681488f, -0.46815291f, -0.34122971f, -0.54837304f, -0.19761033f, 
    0.02602699f, 0.54833502f, -0.03198335f, 0.21773334f, -0.07660272f, 0.19238047f, -0.09263543f, 0.14075524f, 
    -0.03356957f, -0.13919333f, 0.34560210f, -0.06739970f, 0.34238967f, -0.08574580f, 0.17864825f, 0.46781537f, 
    0.07808016f, -0.06629992f, 0.23930390f, -0.10620213f, 0.12780662f, -0.45647612f, 0.21884257f, -0.51895934f, 
    0.33894145f, 0.38515130f, -0.09118418f, 0.15935971f, 0.28486809f, -0.16325821f, -0.29204351f, -0.43694305f, 
    -0.35430196f, 0.35025042f, -0.18367364f, 0.56134039f, 0.10272262f, 0.06785434f, 0.00889685f, -0.16843311f, 
    -0.07897383f, 0.16396633f, 0.02048396f, 0.13323383f, 0.17107633f, 0.00574496f, 0.01937451f, -0.10121080f, 
    0.11924727f, -0.01017823f, 0.41417333f, 0.02131044f, 0.09015484f, -0.26796591f, 0.05093154f, -0.72508329f, 
    0.00183812f, -0.15559609f, -0.03704597f, -0.12404332f, -0.01594538f, -0.01897226f, -0.09532134f, -0.00429210f, 
    0.09342030f, -0.05621283f, -0.09091078f, -0.04928886f, -0.15287766f, -0.17021058f, -0.05751263f, 0.13247187f, 
    -0.16472819f, -0.06966743f, -0.20379746f, 0.11978848f, 0.08170103f, 0.05442491f, -0.10268145f, 0.04143134f, 
    0.07558177f, -0.14827722f, -0.00112201f, 0.12112099f, 0.05887823f, -0.14667107f, -0.08990585f, -0.00006611f, 
    -0.10369649f, -0.13277307f, 0.11963896f, -0.05759982f, -0.14313962f, -0.01766865f, 0.10070654f, 0.11559157f, 
    -0.19949280f, 0.08930645f, -0.08069956f, 0.02924665f, -0.03311419f, 0.04452699f, -0.08485217f, 0.03845343f, 
    -0.24411790f, 0.04205303f, -0.22498177f, -0.00474909f, 0.07294889f, -0.09938880f, 0.13864078f, 0.01095279f, 
    -0.05876436f, 0.17805697f, 0.01666418f, -0.16862023f, -0.05534521f, 0.01684407f, 0.11137824f, -0.12848382f, 
    0.36156514f, -0.23833503f, -0.11199805f, -0.08624119f, 0.68013656f, -0.19639324f, -0.15449482f, -0.33048189f, 
    0.03241550f, -0.37297550f, 0.21774256f, 0.29526123f, -0.07920764f, -0.13731982f, 0.14498611f, 0.11123986f, 
    0.27471119f, 0.12569979f, 0.17996076f, 0.01668545f, 0.17016910f, -0.08105824f, 0.08855824f, -0.15911165f, 
    0.16955824f, -0.16824780f, -0.48846102f, -0.16669454f, -0.12700313f, 0.05345402f, -0.58716190f, -0.30003875f, 
    0.17581220f, -0.81643528f, -0.01507252f, -0.15931390f, -0.23298512f, -0.10159530f, -0.26320401f, -0.31017756f, 
    0.09526328f, 0.37727323f, 0.64037359f, -0.04523403f, -0.15728928f, -0.45383158f, -0.01915347f, -0.13413212f, 
    0.09538750f, 0.05983100f, 0.40682065f, 0.15529619f, -0.03921133f, 0.12997635f, 0.05775290f, 0.53688633f, 
    0.00188236f, -0.13504769f, -0.24096330f, 0.09116787f, -0.07999190f, -0.01786417f, 0.02757885f, -0.27264649f, 
    0.12048338f, 0.47684440f, 0.04580776f, 0.17309096f, 0.38052535f, 0.00183206f, -0.10790393f, -0.23612304f, 
    0.13145450f, -0.21574335f, -0.37934363f, -0.11367513f, 0.13072406f, -0.30967060f, 0.07517079f, 0.09583788f, 
    -0.42790654f, -0.00743165f, 0.34365124f, -0.01972847f, 0.47762963f, -0.07848585f, 0.08739477f, -0.01608261f, 
    0.06307171f, -0.03442060f, 0.27951309f, 0.07468881f, 0.06917149f, 0.44540718f, -0.45122194f, 0.55490363f, 
    0.14330606f, -0.37175998f, 0.13562030f, -0.13045679f, 0.01648550f, 0.05699043f, 0.30507460f, -0.09568320f, 
    0.35076243f, 0.59587461f, -0.21724680f, -0.10442092f, 0.14318521f, -0.39328426f, -0.14891334f, -0.05068352f, 
    -0.11975358f, -0.01402566f, -0.07295250f, 0.05222949f, -0.02783692f, -0.08987255f, -0.06854926f, 0.55945122f, 
    -0.07710125f, 0.07837515f, 0.22850174f, 0.08345657f, 0.03941314f, 0.31943649f, 0.20626774f, 0.02478166f, 
    0.17152156f, -0.26478499f, -0.01716961f, -0.07291750f, -0.09812140f, -0.13524430f, -0.57998210f, -0.09700502f, 
    -0.34517121f, 0.32467365f, 0.11575370f, 0.21954718f, 0.15124379f, 0.17569998f, 0.08954803f, -0.03747303f, 
    -0.27591249f, -0.09123842f, -0.08656374f, -0.09143883f, 0.39428565f, -0.04461531f, -0.02257412f, -0.19387424f, 
    0.04963084f, -0.14557262f, 0.35687092f, -0.01436211f, -0.10996139f, -0.30124915f, -0.14200805f, -0.29137924f, 
    0.13444057f, -0.05127855f, 0.14673942f, 0.05364231f, 0.36142799f, 0.37752074f, 0.35084361f, 0.07598037f, 
    0.25997266f, -0.15845002f, -0.23152609f, -0.19584464f, -0.14535476f, -0.06855729f, -0.03068716f, -0.03503045f, 
    -0.23554355f, 0.10168964f, -0.13953355f, 0.17932743f, 0.34038800f, 0.13783480f, 0.02211359f, -0.14267130f, 
    -0.01830128f, -0.10550702f, -0.04194971f, 0.14346169f, -0.03197246f, -0.18028642f, -0.18353018f, 0.32194930f, 
    0.02942191f, -0.01498381f, 0.14730430f, 0.03094321f, -0.00318900f, 0.32329422f, 0.12310694f, 0.66155010f, 
    -0.21537121f, 0.29095626f, 0.08349810f, 0.28709894f, -0.13558248f, -0.31017807f, 0.12807047f, 0.08744669f, 
    -0.35687298f, 0.15252538f, -0.02151500f, 0.08404276f, 0.08927740f, 0.10130589f, -0.08451555f, -0.14458477f, 
    0.02860470f, 0.17056200f, -0.09786443f, 0.06150238f, -0.15399185f, 0.52987999f, 0.37337014f, 0.03356570f, 
    0.13966087f, 0.62974262f, -0.16671370f, 0.05733751f, 0.03866217f, -0.06906392f, 0.28969970f, 0.25191122f, 
    0.36932102f, -0.25801769f, -0.06439123f, -0.03214443f, 0.07294837f, 0.44334033f, -0.15434121f, -0.13004476f, 
    -0.11337607f, 0.02040284f, -0.22053559f, 0.09840563f, 0.05169526f, 0.02738251f, -0.06301347f, 0.13152738f, 
    0.08346154f, -0.16712703f, 0.56696713f, 0.13782883f, -0.04289140f, -0.43578663f, 0.29430807f, 0.19558869f, 
    -0.01801596f, 0.02059361f, 0.08665346f, -0.00063420f, 0.29169533f, 0.26597923f, 0.43043938f, 0.28072053f, 
    0.23969807f, 0.31182671f, -0.00233486f, -0.08578884f, 0.10394011f, -0.37616813f, -0.00128176f, -0.12315387f, 
    -0.28757563f, -0.09302109f, -0.07302124f, 0.12511121f, -0.29340217f, 0.10983877f, -0.17232487f, 0.37732786f, 
    -0.16996051f, 0.00793357f, 0.06301557f, 0.00853444f, 0.02321821f, 0.24513121f, 0.40157363f, 0.24116583f, 
    -0.00341573f, 0.72818124f, 0.12564334f, -0.11340024f, 0.62186438f, -0.19640368f, 0.66706687f, -0.13354398f, 
    0.38555184f, -0.21031865f, 0.38754842f, 0.26020941f, 0.04350064f, -0.04430160f, -0.02275608f, 0.02120707f, 
    0.46651465f, -0.04400675f, -0.20524286f, -0.06214128f, -0.35122156f, 0.11392856f, 0.16317636f, -0.30764738f, 
    -0.14950907f, 0.15591022f, -0.15043288f, 0.06593116f, -0.02906566f, 0.49548307f, -0.40136361f, 0.39078265f, 
    0.02554459f, 0.17764220f, -0.07603599f, 0.04087444f, -0.08668502f, -0.12981564f, -0.19351184f, -0.00715614f, 
    0.08740440f, -0.08752052f, 0.11435491f, -0.23290758f, 0.07788529f, -0.11867218f, -0.06354442f, 0.10479181f, 
    -0.02785528f, 0.02253980f, -0.18581185f, 0.08619709f, 0.11510704f, 0.03058174f, -0.02820529f, -0.03885662f, 
    -0.02266586f, -0.10910302f, -0.04921851f, 0.14714091f, 0.00950116f, -0.06187416f, 0.13502438f, 0.09871930f, 
    -0.16097251f, -0.02527068f, 0.12631547f, 0.11176398f, -0.10482287f, 0.04245410f, -0.27851313f, -0.12414002f, 
    -0.36212760f, 0.29043183f, 0.27895415f, 0.33661959f, 0.09253344f, -0.15063369f, 0.01402842f, 0.10752217f, 
    0.29088244f, 0.16210184f, 0.37870204f, -0.12913691f, 0.19571881f, 0.01531170f, 0.08877845f, -0.37643659f, 
    -0.04653719f, 0.04335696f, -0.29994357f, 0.17069158f, 0.00671210f, 0.40602985f, -0.02073436f, 0.00602360f, 
    0.03778844f, -0.05449396f, 0.15979630f, 0.09805603f, -0.12486117f, -0.17931661f, 0.13750030f, -0.08191268f, 
    -0.11756035f, -0.02219044f, 0.05585096f, -0.02421191f, 0.09896421f, -0.06627577f, -0.12717389f, -0.05744404f, 
    -0.00346140f, 0.02935550f, -0.08928417f, -0.09665561f, -0.06155910f, -0.03890944f, 0.07226497f, -0.18206388f, 
    0.04557021f, -0.06495270f, 0.08681029f, -0.02171148f, 0.08478644f, -0.02818502f, 0.09103032f, -0.16607238f, 
    0.10500642f, 0.14889714f, 0.06512484f, -0.00168518f, 0.41888940f, -0.24547556f, 0.12041546f, -0.26925394f, 
    0.39955273f, -0.47848433f, 0.50209868f, -0.09251045f, -0.02351924f, -0.14094386f, -0.13556516f, -0.11976461f, 
    0.44984439f, 0.16999552f, 0.30778715f, 0.12909850f, -0.36622137f, -0.06841947f, 0.07164320f, 0.41726032f, 
    0.09320796f, 0.10957943f, 0.23616129f, 0.05534681f, 0.04964273f, 0.08629884f, -0.51042914f, 0.22862440f, 
    0.14457221f, -0.53335160f, 0.08214389f, -0.15848382f, 0.35562411f, -0.06270482f, -0.49494267f, 0.15532739f, 
    -0.02120607f, -0.80541712f, 0.14323772f, 0.07607203f, -0.03551134f, 0.38279670f, -0.09858484f, -0.11171282f, 
    0.37853581f, 0.09409051f, 0.08905357f, -0.05459482f, 0.13678050f, 0.02708558f, -0.05859504f, 0.50321639f, 
    -0.04548769f, -0.12259701f, 0.23371829f, 0.17784882f, -0.05352329f, -0.18408178f, -0.05338145f, -0.37327924f, 
    0.24504188f, 0.25462291f, -0.00563400f, -0.07640264f, -0.52083617f, 0.29021475f, 0.05430763f, -0.06755394f, 
    0.41487709f, 0.19912666f, -0.33779851f, -0.33578506f, 0.14754084f, 0.29419094f, 0.16247466f, 0.13569902f, 
    0.16790093f, -0.09920251f, 0.04916427f, 0.15842342f, 0.48722526f, 0.07838842f, 0.08603425f, 0.13720478f, 
    -0.11726730f, -0.12260913f, -0.01421756f, 0.14154536f, 0.03633671f, -0.49778017f, 0.26819417f, 0.07383718f, 
    0.20355980f, 0.12649345f, -0.14646555f, -0.00999706f, -0.02568467f, -0.33401605f, -0.06757495f, -0.04212084f, 
    0.08969579f, -0.42404968f, 0.10302481f, 0.24118695f, 0.16038930f, 0.59825063f, 0.08838402f, -0.15815435f, 
    -0.16639046f, 0.17115705f, -0.12754586f, -0.02388690f, 0.13633166f, 0.18172461f, 0.06223178f, 0.53262591f, 
    -0.03029886f, -0.17178255f, 0.70008814f, -0.04600241f, 0.10589115f, -0.34773150f, 0.14963397f, 0.04665044f, 
    -0.14913841f, 0.00107217f, -0.04944830f, -0.09479209f, -0.10384812f, -0.12696159f, 0.11705947f, 0.08133386f, 
    -0.01844336f, -0.11784322f, -0.02435457f, -0.18224511f, 0.02805936f, -0.06119055f, -0.09619354f, -0.07359961f, 
    0.01735637f, -0.10145185f, -0.00586097f, 0.06181505f, -0.15749486f, 0.07162394f, -0.02334400f, -0.04703479f, 
    0.14029589f, 0.07957771f, -0.08573487f, 0.09573321f, 0.09177417f, 0.09602222f, 0.14353029f, -0.09562641f, 
    0.17376173f, 0.13521016f, -0.01387152f, -0.08817012f, 0.21355659f, 0.45048666f, -0.21393712f, 0.41791022f, 
    -0.09042216f, -0.22112662f, 0.15776548f, -0.19619007f, 0.14003824f, -0.10370458f, -0.00317934f, 0.15123467f, 
    -0.19597696f, -0.02074478f, 0.04795887f, 0.08190872f, 0.09173653f, 0.09955695f, 0.07916509f, -0.76346147f, 
    -0.09774127f, -0.11304338f, -0.32381624f, -0.05543618f, 0.11482958f, 0.32167181f, -0.24864164f, 0.00655778f, 
    -0.08058427f, 0.07314502f, 0.11167448f, 0.16513634f, 0.09140111f, -0.03494590f, 0.03740949f, -0.11870954f, 
    -0.02872401f, 0.10232964f, -0.06359160f, -0.11157486f, 0.15472789f, -0.16288844f, -0.07651340f, -0.00227590f, 
    -0.14026020f, 0.07232486f, -0.05280423f, 0.09639265f, -0.09508219f, 0.01786228f, 0.16723111f, -0.06954499f, 
    0.14731504f, 0.12334209f, -0.10788866f, 0.01945574f, -0.14024819f, 0.00888353f, 0.14693603f, -0.03695662f, 
    0.29261672f, -0.62123734f, -0.16668528f, 0.08619358f, -0.13478850f, 0.28954992f, -0.37876433f, -0.19140652f, 
    0.22126924f, -0.16609843f, 0.57752895f, -0.54682356f, 0.12662442f, -0.45727032f, -0.14134982f, -0.06995059f, 
    -0.09826361f, -0.03102068f, 0.31621975f, 0.03707594f, -0.00238391f, 0.00053351f, -0.03067164f, 0.11925197f, 
    -0.04605067f, 0.11743651f, -0.28057024f, -0.06097997f, -0.06478985f, 0.05255127f, -0.24865909f, 0.13547975f, 
    -0.17311297f, 0.14139925f, -0.09970854f, 0.00775068f, -0.13468999f, 0.08009522f, -0.08803189f, 0.07432355f, 
    -0.01192687f, -0.21900713f, 0.10713392f, -0.14905719f, -0.06127996f, 0.02057814f, -0.06072038f, 0.14239632f, 
    -0.07560775f, 0.11577916f, -0.05201964f, -0.18020935f, -0.14606978f, -0.15446845f, -0.16113929f, 0.01521542f, 
    -0.00551416f, 0.02073052f, -0.10795934f, 0.04404561f, 0.00482735f, -0.06161513f, 0.05450437f, -0.18913615f, 
    -0.01063806f, 0.64294100f, -0.09144354f, 0.01931910f, 0.47639883f, 0.12570882f, -0.07444085f, 0.47676542f, 
    -0.47521433f, -0.25001702f, -0.42399350f, 0.46855280f, 0.04688632f, -0.20109992f, 0.12432511f, -0.09508447f, 
    -0.30844936f, 0.05851104f, 0.28811166f, -0.10778680f, 0.35208833f, -0.15496175f, 0.05746089f, -0.31351855f, 
    -0.09077361f, -0.04268264f, 0.18070415f, -0.08425871f, -0.12847961f, 0.26564425f, -0.17244771f, -0.29665270f, 
    -0.14234017f, -0.02080693f, -0.08565216f, -0.14036325f, 0.13327728f, 0.09618811f, 0.02466284f, -0.16640437f, 
    -0.10168168f, -0.11365487f, -0.12101484f, -0.02539838f, 0.09384046f, 0.09587637f, 0.14997815f, -0.02434847f, 
    -0.03683957f, -0.02956044f, -0.14971639f, -0.10003052f, 0.13757856f, -0.13732934f, -0.02801048f, 0.07254692f, 
    0.17509985f, -0.06761018f, -0.16768694f, 0.12961143f, 0.03197240f, 0.07163175f, 0.01181390f, 0.00860592f, 
    -0.06873208f, 0.58209425f, -0.17778601f, 0.10817072f, 0.04634912f, 0.39499736f, 0.75883245f, 0.56225735f, 
    0.14974990f, 0.30885175f, 0.23766156f, 0.09047475f, -0.10829184f, 0.39934748f, -0.00690467f, 0.03670565f, 
    0.47529203f, 0.08776938f, -0.17641969f, 0.12938303f, -0.30857468f, -0.06800046f, -0.02006844f, -0.75650042f, 
    -0.11066334f, -0.10945280f, -0.48685542f, 0.11375720f, -0.19012870f, 0.33163199f, 0.10680712f, 0.27104983f, 
    0.19616206f, 0.31580821f, -0.09323908f, 0.12831733f, 0.07239705f, 0.12237820f, 0.55851805f, -0.25898230f, 
    0.29602394f, 0.33563533f, -0.19088174f, 0.34353164f, 0.08444709f, 0.53809243f, 0.02867194f, 0.01657970f, 
    0.32934192f, -0.01318802f, -0.33506966f, -0.12137953f, -0.14786720f, -0.05138243f, -0.02567220f, -0.02282049f, 
    -0.14160189f, 0.01654311f, -0.45571458f, -0.07852174f, 0.05242916f, -0.13748750f, -0.00600451f, -0.06263348f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.09218249f, 0.03814431f, 0.09820382f, 0.14813308f, -0.06602686f, -0.03793347f, 0.35111675f, 0.05635853f, 
    -0.06156790f, -0.24657546f, -0.01240641f, -0.12758861f, -0.02542726f, 0.13042258f, -0.05131017f, -0.10129829f, 
    0.07370824f, 0.09227539f, 0.09778956f, 0.26162949f, 0.33013254f, 0.22104239f, 0.08498421f, 0.08027686f, 
    0.31401014f, 0.07407985f, 0.23368025f, -0.12207767f, 0.13035382f, 0.05729673f, -0.03447526f, 0.01276441f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.19671273f, 0.18099788f, 0.33994377f, 0.29940048f, -0.06880685f, 0.03410225f, -0.23879224f, 0.25915954f, 
    -0.37857157f, 0.11634237f, 0.42473200f, -0.42001724f, 0.14380454f, -0.32379615f, 0.06244326f, -0.08589860f, 
    -0.13159272f, 0.33875090f, -0.05168348f, -0.25152194f, -0.67821699f, -0.32572868f, -0.02203721f, -0.05819162f, 
    -0.30111015f, -0.11746107f, -0.44672135f, 0.08347500f, -0.07113249f, -0.07339998f, 0.08665225f, 0.24937765f, 
    -0.11967305f, 0.38764396f, -0.21998058f, 0.22675848f, -0.00758640f, 0.06689274f, -0.18237595f, -0.54407132f, 
    0.14277275f, -0.26998761f, -0.38662240f, 0.17346498f, -0.09186100f, 0.30606869f, -0.07844885f, 0.00117869f, 
    0.18467736f, -0.12303553f, 0.13804777f, 0.01368476f, -0.30115524f, 0.25435421f, -0.07185996f, -0.09268397f, 
    0.20360734f, -0.11959060f, -0.29594913f, 0.14756833f, 0.23710538f, -0.15271693f, 0.29015705f, 0.03585180f, 
    -0.40261135f, 0.02573148f, 0.21199408f, 0.10522866f, 0.14374647f, -0.14390995f, 0.13331118f, 0.00367455f, 
    -0.80361301f, -0.13218845f, -0.19541244f, -0.23582457f, -0.79307574f, 0.07302663f, -0.73223650f, 0.05005066f, 
    0.14209236f, -0.10063016f, 0.13598400f, 0.26263219f, 0.49688953f, 0.31535542f, 0.20688599f, -0.01506197f, 
    -0.49243292f, 0.01059502f, -0.39574766f, -0.06631688f, -0.80434674f, -0.16490495f, 0.12228926f, 0.45496646f, 
    0.16785377f, -0.03672747f, -0.37852770f, -0.65426099f, -0.13965495f, -0.11404348f, 0.01460000f, 0.33787790f, 
    0.02213404f, -0.02788653f, -1.02774858f, -0.54327130f, 0.35000882f, -0.82906926f, 0.04721961f, 0.15036395f, 
    0.06773802f, 0.50379604f, 0.07377376f, 0.28149888f, -0.19126286f, -0.94133538f, -0.61181235f, -0.06119048f, 
    0.21873741f, -0.11294041f, 0.07187686f, -0.07819545f, 0.25707662f, 0.12225557f, 0.22788106f, -0.43861708f, 
    -0.05721194f, 0.01770465f, 0.16101032f, -0.34668317f, 0.17964387f, -0.13940781f, 0.02496823f, 0.33219171f, 
    0.14113405f, 0.17667973f, 0.03647297f, 0.30087158f, -0.05612290f, -0.16648686f, -0.14180954f, -0.38702747f, 
    0.07101626f, -0.00302275f, -0.09785721f, -0.09471495f, -0.20571089f, 0.47479987f, -0.24486127f, -0.00102708f, 
    0.22127077f, -0.10288995f, 0.61109835f, 0.14832222f, -0.51413900f, 0.05097897f, -0.15963079f, -0.02259556f, 
    0.16291729f, -0.32737511f, 0.09853720f, 0.27050281f, 0.08284280f, -0.03526512f, 0.07697751f, -0.39516088f, 
    0.14970393f, -0.56087399f, 0.40417430f, 0.10963298f, 0.21472344f, 0.14771028f, -0.40129200f, -0.36334702f, 
    0.04054361f, -0.04596678f, -0.15054402f, -0.38561386f, 0.38315281f, -0.07689737f, 0.30854535f, 0.13581949f, 
    0.02836209f, 0.01863433f, -0.88034093f, 0.14900522f, 0.59611040f, -0.03306576f, -0.26096964f, 0.05765494f, 
    -0.16749893f, -0.33295450f, 0.32862684f, 0.17493737f, 0.07662007f, -0.09590349f, 0.12159272f, 0.26830000f, 
    0.57846648f, -0.12643911f, 0.42341948f, -0.04470079f, -0.21289019f, -0.28596851f, -0.45718527f, -0.45151660f, 
    -0.09675707f, 0.23730896f, -0.08642593f, 0.26375243f, 0.26303026f, -0.06392035f, 0.07228513f, -0.08054865f, 
    -0.07612257f, -0.01806670f, 0.17359099f, -0.13885182f, 0.24723943f, -0.09189726f, -1.15983820f, -0.57846391f, 
    -0.11230514f, 0.22641830f, -0.54787701f, -0.67196566f, 0.03552683f, -0.05296214f, -0.90583146f, -0.22321264f, 
    -0.08133115f, 0.27333230f, -0.59855014f, 0.38894084f, 0.44383132f, -0.32935661f, 0.44995987f, -0.34460634f, 
    -0.14996716f, 0.08109283f, -0.01447706f, -0.56533951f, -0.16059141f, -0.09321965f, -0.60241818f, 0.12212151f, 
    0.28852892f, 0.12862122f, 0.05765380f, -0.00682661f, 0.11413816f, -0.03774631f, 0.48557776f, -0.06278676f, 
    0.25440681f, -0.03711566f, -0.65404207f, -0.65375978f, -0.01874123f, 0.12286757f, -0.36506069f, -0.74564844f, 
    0.52844137f, 0.35572499f, -0.82209742f, 0.38456726f, -0.04513678f, 0.27801013f, 0.42526954f, 0.24941164f, 
    -0.06131731f, -0.61224991f, 0.11286099f, 0.19943465f, -0.58965129f, -0.08538795f, 0.18716347f, 0.14344513f, 
    -0.35484543f, 0.02321662f, -0.58549690f, 0.02837651f, -0.18843110f, -0.13044800f, 0.01449311f, 0.08319686f, 
    0.47215852f, -0.80226839f, 0.31007746f, 0.22025988f, 0.02538786f, -0.00164547f, -0.41929045f, 0.31525671f, 
    -0.36856267f, 0.46573028f, -0.13454467f, -0.06235358f, 0.06735995f, 0.28806555f, 0.35387805f, -0.68771094f, 
    0.06558894f, -0.55291009f, -0.15621909f, 0.00202399f, 0.13465498f, 0.19678502f, 0.22844575f, -0.05911662f, 
    -0.29023057f, -0.12946193f, -0.05283326f, 0.14491542f, -0.32137567f, -0.15583964f, -0.67177176f, -0.15711354f, 
    -0.02468098f, 0.19400816f, -0.16085663f, -0.90733975f, -0.15928037f, 0.16541763f, 0.01017833f, 0.26721042f, 
    -0.51403940f, -0.91333568f, -0.35684648f, -0.20139019f, -0.18031186f, 0.22814542f, -0.01890409f, 0.20504108f, 
    -0.05248063f, 0.03707828f, 0.03097617f, 0.53037792f, 0.38964060f, -0.59568352f, 0.37090611f, -0.18282695f, 
    0.04868856f, -0.14565024f, 0.23684959f, -0.03020327f, -0.74893975f, -0.08809970f, 0.24832064f, -0.16562395f, 
    -0.91887474f, -0.69300449f, -0.27683303f, 0.17615926f, 0.14976712f, -0.06612755f, 0.65096939f, 0.08560062f, 
    0.18177252f, 0.20970263f, -0.09198997f, 0.34693104f, -0.08073413f, -0.22935197f, 0.10405352f, 0.29326707f, 
    0.13798223f, -0.15262531f, -0.11815773f, 0.30568951f, 0.25665405f, -0.73863965f, -0.10522423f, -0.03809043f, 
    0.14698103f, 0.11690552f, -0.10854323f, 0.02874872f, 0.18219052f, -0.15834998f, -0.02916300f, 0.18745559f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.17187616f, 0.18074811f, -0.13816486f, -0.04916318f, 0.09417044f, -0.09986696f, -0.06521761f, -0.11168544f, 
    -0.25311115f, -0.08823130f, 0.08372238f, -0.05059826f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
