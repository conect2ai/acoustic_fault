#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.92281651f, -0.88526404f, -0.25875127f, 0.76622564f, 0.60719299f, 1.12752759f, 0.29650769f, -0.31742531f, 
    -0.49930376f, -0.24734898f, -0.43211147f, 0.04353498f, -0.34647539f, 0.31561139f, -0.61293900f, 0.14511319f, 
    0.00500428f, -0.07447276f, 0.03272216f, -0.06788340f, -0.12782387f, 0.02142453f, -0.21453758f, 0.02695302f, 
    -0.10493214f, -0.97803116f, -0.64029336f, -0.20208256f, 0.39235765f, 0.83933187f, 0.19959079f, -0.22728136f, 
    0.03373981f, 0.47184241f, 0.08743611f, -0.11823280f, -0.29784381f, 0.17227179f, 0.22239394f, -0.24213533f, 
    0.10877780f, 0.01366947f, 0.27804270f, 0.37204832f, -0.00125259f, 0.01313127f, -0.20394263f, -0.08922601f, 
    -0.10388304f, -0.41735929f, 0.00433853f, -0.10329162f, -0.43857795f, -0.43176639f, -0.15028515f, 0.29529288f, 
    -0.44262370f, -0.60862172f, -0.53906107f, -0.59000403f, -0.17344216f, 0.37579724f, 0.29646268f, 0.17518565f, 
    -0.24397671f, -0.30132189f, -0.51982695f, 0.32673296f, -0.06101301f, -0.07249122f, -0.23970763f, -0.12827964f, 
    -0.19380555f, 0.45598614f, 0.33468783f, -0.51068950f, -0.29094136f, -0.52236706f, -0.53972518f, -0.68596315f, 
    0.74169171f, 0.23704974f, 0.15918523f, 0.21709967f, 0.66049081f, 0.16542417f, 0.05502041f, -0.29657760f, 
    -0.21729946f, 0.06862954f, -0.36492559f, -0.08036862f, 0.13932180f, 0.17053145f, -0.03763518f, 0.14917612f, 
    -0.15859653f, 0.24878196f, 0.27659252f, -0.13805501f, 0.58657396f, -0.17436084f, -0.32206130f, 0.19115329f, 
    0.42123812f, 0.28597835f, 0.36395535f, 0.10886039f, -0.19864675f, -0.00278857f, -0.24837576f, -0.25182950f, 
    -0.27920386f, -0.14998209f, 0.42768991f, 0.18021020f, -0.07300925f, -0.15294389f, -0.13553059f, -0.20883535f, 
    -0.33568460f, -0.10265313f, -0.38802433f, -0.41649947f, -0.37719268f, 0.73991978f, -0.35401413f, -0.12133525f, 
    -0.03573090f, 0.42941871f, -0.16583051f, -0.60184956f, -0.58719462f, 0.01221402f, 0.49182066f, -0.30243304f, 
    0.18417910f, -0.12219702f, 0.01511111f, 0.20500240f, 0.18079109f, -0.44777033f, 0.29359335f, 0.34047708f, 
    -0.38186044f, 0.03050626f, -0.30775806f, 0.12066268f, -0.31772879f, 0.10559878f, 0.78663576f, 0.70430553f, 
    0.48753029f, 0.24589546f, -0.00177893f, -0.00568711f, -0.21550497f, -0.12434731f, 0.19150271f, -0.19266203f, 
    -0.09083433f, 0.03467356f, -0.15396416f, -0.21755184f, -0.13630348f, -0.19391300f, 0.28504258f, -0.24179892f, 
    0.03136043f, -0.17894360f, 0.03291289f, 0.19097458f, 0.07185874f, -0.07830378f, -0.10761289f, 0.25247854f, 
    -0.40821642f, -0.29518497f, 0.16317396f, 0.46348685f, 0.31153753f, 0.06036748f, -0.32501152f, 0.01597107f, 
    0.24707220f, 0.13139431f, 0.48992705f, 0.11785151f, -0.41657677f, 0.12677537f, -0.29404518f, -0.25415835f, 
    0.04982515f, -0.29993632f, 0.08100832f, -0.30093297f, 0.26012298f, 0.05843706f, 0.18448301f, 0.25285345f, 
    -1.14666319f, 0.63943839f, 0.22872888f, -0.00082712f, -0.11499447f, -0.40609601f, -0.27944311f, 0.23071371f, 
    0.72961342f, 0.21839733f, -0.31377327f, -0.14950821f, -0.05326647f, 0.21874413f, -0.17059730f, 0.16080159f, 
    -0.00486272f, -0.23594208f, -0.23514378f, 0.41142473f, 0.03065514f, -0.00681352f, 0.16759281f, -0.23684207f, 
    0.10372657f, -0.65350652f, -0.50670558f, -0.35783631f, -0.64374751f, -0.08646280f, 0.14830434f, -0.63619095f, 
    -0.29519483f, -0.45322871f, -0.25361341f, -0.02486371f, 0.39055711f, 0.28359413f, 0.36114600f, 0.02489572f, 
    0.25660548f, -0.18211539f, 0.00451381f, 0.10526073f, 0.10792202f, -0.10299221f, 0.46019733f, -0.12287262f, 
    -0.11726338f, -0.08501101f, 0.39307424f, 0.77169377f, 0.50902903f, -0.48534799f, -0.81707400f, -0.81569743f, 
    0.02137170f, -0.11902607f, 0.09242772f, 0.13027826f, 0.05981826f, -0.17802581f, 0.56551600f, -0.11124099f, 
    0.29376468f, 0.13592449f, 0.20395267f, 0.02127679f, -0.32748115f, -0.39656812f, -0.25863320f, 0.17204274f, 
    0.16117604f, 0.16649987f, -0.09710529f, -0.30680618f, -0.37555397f, 0.03615524f, 0.53079301f, 0.39360735f, 
    0.44111189f, 0.03912660f, -0.25640136f, 0.17729235f, -0.24376372f, 0.14408751f, 0.23866326f, -0.02729138f, 
    0.20111659f, -0.21900317f, -0.48317662f, 0.19467294f, -0.01871267f, -0.30128369f, -0.01043928f, 0.32352093f, 
    -0.16933824f, -0.15309313f, -0.18361790f, 0.11682734f, -0.40101197f, 0.28410074f, 0.10194547f, 0.42546973f, 
    0.34879765f, -0.06018647f, 0.02945141f, 0.16898273f, 0.30155888f, 0.28958341f, 0.16375163f, -0.07410067f, 
    0.07398687f, 0.18733372f, -0.02061355f, -0.03261368f, 0.08281465f, -0.01239980f, -0.06476177f, -0.02565496f, 
    -0.04985267f, -0.17366740f, -0.19893166f, -0.05902694f, 0.00804055f, 0.24434397f, -0.01559965f, -0.04189075f, 
    0.35476807f, -0.03341668f, -0.24547668f, 0.08080811f, -0.33865792f, -0.54805493f, 0.28681082f, -0.11186700f, 
    0.14830038f, 0.21452899f, 0.07668976f, -0.34067878f, 0.34489140f, 0.44154939f, 0.25796625f, 0.10065611f, 
    -0.21578465f, -0.15628003f, 0.28914595f, -0.15698011f, 0.00532189f, -0.04173292f, -0.08461653f, 0.34764698f, 
    0.12530680f, 0.02618548f, 0.38288543f, -0.29131296f, 0.13179314f, 0.37868372f, 0.04490934f, -0.38568255f, 
    0.17877801f, -0.31312931f, 0.06533181f, -0.29307476f, -0.20621663f, 0.25491917f, -0.23482907f, 0.01992132f, 
    0.32154742f, 0.06010724f, 0.35832390f, -0.10629616f, -0.27736163f, -0.33110371f, -0.46351188f, -0.22707163f, 
    0.51676291f, -0.52682489f, -0.48567536f, -0.50487471f, -0.46199837f, -0.32840851f, -0.01641230f, 0.09884103f, 
    0.14864177f, 0.15440500f, -0.24501722f, -0.13179272f, -0.20770656f, -0.27260992f, 0.02460321f, -0.07929210f, 
    0.17186838f, 0.34619546f, 0.00776833f, -0.22675870f, -0.16178477f, -0.44115993f, -0.32305124f, -0.13034762f, 
    1.12726986f, -1.15160644f, -0.85596287f, -0.49738103f, -0.55894756f, 0.54515702f, 0.54747748f, 0.51524448f, 
    0.01896958f, -0.17011842f, 0.24577516f, 0.06408612f, 0.08673300f, -0.17563508f, 0.23636577f, 0.09156940f, 
    -0.32981360f, -0.02794775f, 0.03172183f, -0.03083473f, -0.09199404f, 0.10943521f, 0.08204222f, 0.31080651f, 
    -0.20113318f, 0.73008454f, -0.30531478f, -0.81766194f, -0.84645945f, -0.62567276f, 0.64984745f, 0.11598148f, 
    0.18871659f, -0.27151445f, 0.35245726f, 0.17292732f, 0.09473690f, 0.21145371f, -0.33694500f, -0.07763876f, 
    0.19845520f, 0.32605401f, 0.16901694f, -0.15092224f, 0.06235537f, 0.16596441f, -0.29133299f, -0.23948577f, 
    -0.22756585f, -0.02983317f, 0.33514452f, 0.39679927f, 0.47161013f, -0.08621614f, 0.25418887f, -0.36697856f, 
    -0.38954520f, -0.19526908f, 0.21761094f, 0.17610075f, 0.10928987f, -0.31107911f, 0.18190548f, -0.13507186f, 
    0.04813371f, 0.32190466f, -0.13171768f, -0.12075157f, 0.08895102f, -0.03590854f, -0.07386559f, 0.08219577f, 
    -0.06295746f, 0.21032891f, 0.18602122f, -0.66841811f, 0.31524059f, -0.30310169f, -0.35979521f, 0.47719929f, 
    -0.43854108f, -0.19706100f, 0.33609626f, 0.55924213f, -0.35226843f, -0.63656253f, -0.20002104f, 0.18626040f, 
    0.14184286f, -0.38572121f, -0.01461861f, 0.18051699f, -0.18208572f, 0.08047856f, 0.27394679f, -0.17138340f, 
    0.29308528f, 0.15292692f, -0.23880482f, -0.20024927f, 0.30315614f, -0.16919337f, -0.35328954f, -0.55479056f, 
    -0.31391877f, -0.14694025f, -0.38289222f, -0.40376079f, -0.46320558f, 0.09220441f, 0.37751007f, 0.68085051f, 
    0.00309601f, -0.04393176f, 0.66334671f, -0.34996861f, 0.02874198f, -0.24565202f, -0.42787632f, -0.59231049f, 
    0.23087540f, 0.02092856f, 0.25027895f, -0.27163193f, -0.20949700f, -0.73375624f, -0.29923463f, 0.21677102f, 
    0.13826998f, 0.28217244f, 0.31984752f, 0.32565308f, -0.12485471f, 0.34951448f, 0.14514202f, 0.14932367f, 
    0.16766860f, -0.08748984f, 0.13514458f, -0.20571239f, -0.35028446f, -0.04222272f, -0.25028670f, -0.18241034f, 
    0.19238153f, 0.27276742f, 0.28135034f, -0.01651980f, 0.01114104f, -0.08444693f, -0.69526279f, -0.39037305f, 
    -0.10605816f, -0.04433079f, -0.11974504f, -0.20946653f, -0.36682895f, -0.93037218f, -0.39407736f, 0.33803341f, 
    0.17679408f, -0.21406700f, -0.07960394f, 0.07067104f, -0.45372874f, -0.28505147f, 0.02954749f, -0.18054350f, 
    -0.30658567f, -0.19039224f, -0.32259369f, 0.11164489f, -0.27398935f, -0.17832334f, -0.27976444f, -0.14492019f, 
    -1.17470860f, 0.27043408f, 0.50369471f, 0.85596287f, -0.35166401f, -0.51995832f, -0.43336463f, 0.12689261f, 
    0.44439220f, 0.00534178f, 0.14828421f, -0.33275393f, -0.23655792f, 0.12311258f, 0.00764011f, 0.06633251f, 
    -0.10438212f, 0.05342796f, -0.10468139f, -0.26131195f, 0.03523371f, -0.31484395f, -0.09838890f, -0.11680427f, 
    -0.17175826f, -0.45235172f, 0.32605031f, 0.40064538f, 0.39190811f, -0.22921051f, -0.02158006f, 0.36160389f, 
    -0.35831350f, -0.21054196f, -0.07405477f, -0.44374231f, 0.12570614f, 0.17347586f, 0.17428595f, -0.23133191f, 
    0.08193324f, 0.09469228f, 0.08346307f, -0.13671869f, -0.10674243f, -0.00316539f, -0.31145442f, 0.29544172f, 
    0.32081544f, -0.40439984f, -0.58114952f, 0.21176140f, 0.34861714f, -0.42843735f, -0.41878664f, -0.37355545f, 
    -0.42388386f, -0.60490632f, -0.54644418f, 0.10047657f, -0.22986600f, -0.02253126f, -0.44979969f, -0.33575195f, 
    -0.00622778f, -0.06177941f, 0.18902250f, -0.03194671f, -0.12747689f, -0.08434415f, -0.16381571f, 0.14846157f, 
    -0.11253087f, 0.29905492f, -0.51757187f, 0.50967330f, 0.93893945f, -0.95409459f, -0.64623183f, -0.16040795f, 
    0.25438690f, -0.28950879f, 0.04698304f, 0.33402550f, -0.16924901f, 0.44258159f, -0.05354656f, -0.09559820f, 
    0.12243461f, -0.08827296f, 0.02070460f, -0.27141732f, 0.03699521f, 0.02107651f, 0.03620266f, 0.32492808f, 
    0.19947653f, -0.16857266f, 0.14831670f, -0.42380604f, -0.15768893f, -0.54390353f, -0.30164331f, -0.54700869f, 
    0.48427069f, 0.17902572f, 0.06759840f, 0.13619207f, -0.04086604f, -0.11945786f, -0.01869698f, 0.18208428f, 
    -0.08955102f, -0.28621948f, -0.15129195f, -0.29725969f, 0.00933154f, -0.23544173f, -0.10642089f, -0.13882521f, 
    -0.06522024f, -0.20921606f, -0.31951424f, -0.46037042f, -0.99702394f, -0.15457524f, -0.50998908f, -0.47445938f, 
    0.24719965f, -0.03096848f, 0.48345572f, -0.53451270f, -0.53372908f, 0.03217218f, -0.22381733f, -0.32772142f, 
    -0.43863335f, -0.41361481f, -0.22469686f, 0.12243237f, -0.26360962f, -0.23037124f, 0.00500350f, -0.19103177f, 
    0.12934212f, -0.01332473f, -0.10059472f, 0.06427909f, 0.01624909f, -0.15602310f, -0.04367924f, 0.65301728f, 
    0.02385448f, -0.56171983f, 0.62211925f, -0.13274111f, -0.29891640f, -0.25452855f, 0.47611678f, 0.32463458f, 
    -0.36214435f, 0.09020380f, 0.05671375f, 0.26530877f, -0.08594452f, 0.10448306f, -0.12377930f, -0.11525521f, 
    -0.20091340f, 0.09785663f, 0.34893993f, 0.07157426f, -0.11713707f, -0.17826761f, -0.12844335f, 0.37907106f, 
    -0.03941438f, -0.34272581f, 0.20332429f, -0.20973721f, 0.26830208f, 0.07358462f, -0.32383662f, -0.08051674f, 
    -0.29223096f, 0.14760709f, -0.13676813f, 0.06009605f, 0.09244318f, 0.37455392f, -0.48860484f, -0.04324509f, 
    0.22653179f, -0.38949114f, -0.09248456f, 0.03137474f, -0.07738501f, 0.36613423f, 0.45532221f, -0.66337919f, 
    -0.07276468f, -0.94500518f, -0.81461030f, 0.29238683f, -0.24652641f, 0.15376002f, 0.61232603f, 0.48352250f, 
    0.30518529f, 0.30032942f, 0.14620589f, 0.29257584f, -0.02854456f, -0.12581357f, 0.23042181f, 0.06489351f, 
    -0.09976175f, -0.23388016f, -0.20232190f, -0.29219696f, 0.12978779f, 0.02401834f, -0.18152049f, 0.04408356f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.22250137f, 0.00872340f, 0.10021483f, 0.13129394f, 0.11426428f, 0.21182682f, 0.09355129f, 0.26542413f, 
    0.34692344f, -0.12695716f, 0.19725606f, 0.07038819f, -0.19612442f, -0.00188901f, -0.02624308f, 0.03845306f, 
    0.18330319f, 0.23623526f, 0.14222474f, 0.27247119f, 0.04831523f, 0.16719314f, -0.00025745f, 0.14369258f, 
    0.23105009f, -0.02104707f, 0.07684094f, -0.03100208f, -0.33892968f, 0.29197946f, 0.24380501f, 0.15418732f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.01705576f, -0.03860665f, 0.00839486f, -0.02159654f, -0.00100107f, -0.01536908f, 0.03191318f, -0.00886129f, 
    0.03704716f, -0.03468139f, -0.01409912f, -0.00352570f, -0.04251290f, -0.03296115f, 0.00803749f, 0.00486149f, 
    0.03266909f, 0.03352102f, -0.02229488f, -0.02057723f, -0.02866873f, -0.05770206f, 0.01860054f, 0.00045403f, 
    -0.03721539f, -0.02421474f, 0.03229526f, 0.03487785f, -0.04857977f, -0.03900329f, -0.02329211f, -0.02212795f, 
    -0.03146288f, 0.02114933f, 0.03085089f, -0.03061614f, 0.02724082f, 0.04221314f, 0.02284500f, -0.00242844f, 
    -0.00950064f, -0.03956205f, 0.03179070f, -0.02576331f, -0.04319273f, 0.00602047f, -0.03291998f, -0.02462175f, 
    0.00245069f, 0.01886028f, -0.04476855f, -0.02881167f, 0.04058233f, -0.00883074f, 0.03517076f, -0.05793068f, 
    0.01721146f, -0.04701997f, -0.00941749f, -0.02157079f, -0.03256689f, -0.04789392f, 0.03079955f, -0.03163792f, 
    -0.00621902f, -0.03795546f, 0.00822645f, 0.03911719f, 0.03721739f, -0.04364367f, 0.00781856f, -0.00114649f, 
    0.02663334f, 0.02093914f, 0.01349501f, -0.01967061f, -0.00384816f, -0.03230317f, -0.04160513f, 0.01265629f, 
    0.02345989f, -0.00645030f, 0.01206965f, -0.01253583f, 0.00290413f, -0.01020839f, 0.02228000f, 0.03646235f, 
    -0.03704546f, 0.03867156f, -0.04985656f, 0.00685701f, -0.00666348f, 0.02863337f, 0.03646544f, 0.00836389f, 
    0.01369364f, -0.00100510f, -0.01890464f, -0.03117470f, -0.04156797f, -0.05165924f, 0.03070451f, -0.02345793f, 
    -0.05299567f, -0.00722043f, 0.01249348f, 0.00017644f, 0.01305190f, -0.04237370f, -0.01094530f, -0.01671903f, 
    0.03100926f, -0.02953673f, 0.04490556f, -0.01399632f, 0.01393815f, 0.03142176f, 0.02229430f, 0.03109165f, 
    -0.03944486f, -0.00135887f, -0.01072624f, -0.01861832f, 0.02696289f, 0.01720347f, -0.04000164f, 0.02140928f, 
    0.01501152f, 0.01410581f, 0.00552792f, -0.01982353f, 0.01122908f, -0.02769794f, 0.04687694f, -0.04667260f, 
    -0.05067607f, -0.05013485f, 0.03467178f, -0.03673365f, 0.02267560f, -0.00082481f, 0.04056385f, -0.00866442f, 
    -0.01575526f, -0.03567623f, -0.02751642f, -0.02726916f, 0.03774404f, 0.04115835f, 0.01534084f, -0.03841841f, 
    -0.02176421f, -0.02506109f, -0.04619891f, 0.00046933f, 0.01052402f, -0.05835063f, -0.01757531f, 0.03485073f, 
    0.00004738f, -0.01843499f, 0.04118799f, 0.03905025f, -0.02480095f, 0.03159280f, -0.02621789f, 0.01024542f, 
    0.00938855f, -0.00199612f, -0.03328394f, -0.03201426f, -0.01798522f, -0.01209661f, 0.04588310f, -0.03686074f, 
    -0.01186155f, 0.03974094f, 0.02190037f, -0.00036831f, -0.01335758f, 0.03623876f, -0.01635334f, 0.02725801f, 
    0.03325163f, -0.01742213f, 0.02477799f, -0.04596224f, -0.02761354f, 0.01269209f, 0.03380893f, 0.01701023f, 
    -0.00618876f, 0.04012566f, 0.01150629f, 0.02567539f, 0.03716803f, -0.05155193f, -0.02503549f, 0.04580867f, 
    0.03975912f, 0.01602746f, -0.02203476f, 0.02168170f, -0.04376684f, 0.00473212f, 0.03404849f, -0.03113204f, 
    -0.03107513f, 0.00175174f, 0.02779747f, 0.02183329f, -0.05243327f, -0.00458873f, 0.03447657f, 0.00979948f, 
    -0.00459638f, 0.03529963f, -0.03963644f, -0.00536594f, -0.01429131f, -0.00314865f, 0.01376954f, 0.01040327f, 
    -0.05292195f, 0.03340608f, 0.03411804f, -0.04037746f, -0.02651870f, 0.03305707f, -0.02465859f, -0.03630765f, 
    0.03135341f, -0.05726570f, 0.01821423f, 0.01209649f, -0.01035738f, -0.01777485f, 0.00808933f, -0.03501595f, 
    0.00281007f, -0.02473920f, -0.04110236f, 0.00533357f, 0.03607597f, -0.00725090f, 0.00926500f, 0.01803843f, 
    -0.00974448f, 0.02146961f, 0.01258835f, -0.04198350f, -0.04454596f, -0.04324091f, -0.02655046f, 0.01799159f, 
    -0.06072775f, -0.02356004f, 0.02092120f, -0.03664632f, 0.01388835f, -0.04775213f, -0.00705320f, 0.01603966f, 
    0.04530559f, -0.01552522f, 0.00036963f, -0.04001511f, 0.03106498f, -0.00954993f, 0.01652313f, 0.02252121f, 
    -0.03478675f, -0.04276161f, 0.02933574f, 0.03849504f, -0.04106937f, -0.04989919f, -0.02780426f, -0.02216229f, 
    0.00442389f, 0.00017999f, -0.01751941f, -0.03225519f, 0.00500969f, 0.01220507f, -0.00973836f, -0.00198006f, 
    0.03759414f, -0.04917939f, -0.03227523f, 0.01496542f, -0.04891870f, 0.01710680f, 0.02350149f, -0.00496519f, 
    -0.03456030f, -0.00565722f, -0.04971932f, 0.04482140f, -0.03369410f, 0.01567637f, -0.05013680f, 0.02621720f, 
    -0.00754215f, -0.03220612f, -0.04472670f, 0.03963704f, -0.00429144f, -0.05803138f, 0.02964762f, -0.04838796f, 
    0.00678847f, 0.01375673f, -0.05629061f, 0.01308259f, -0.03617887f, -0.03819824f, 0.01292660f, -0.04108911f, 
    -0.05320571f, 0.00328211f, -0.04264887f, -0.03358974f, 0.00663370f, -0.04032907f, 0.04837683f, -0.03708316f, 
    -0.03480209f, -0.02175868f, 0.02228154f, -0.00674732f, -0.04614184f, 0.02851631f, 0.04628887f, -0.02625938f, 
    -0.00669091f, -0.04899790f, 0.04009320f, 0.01293788f, 0.02677966f, -0.03892792f, -0.03127609f, -0.02191903f, 
    -0.02217006f, 0.00591518f, -0.01021100f, -0.00679778f, -0.04409821f, -0.03604704f, -0.04292239f, -0.03087478f, 
    -0.00216821f, 0.01634433f, -0.00454780f, -0.00247644f, 0.04443456f, -0.05042508f, -0.01320556f, -0.02373880f, 
    0.04143679f, 0.01027474f, -0.01437796f, -0.03075676f, -0.05375866f, 0.01677411f, 0.00760748f, -0.00722124f, 
    0.02834147f, -0.00572106f, -0.05767614f, 0.02954705f, 0.04375910f, -0.05283185f, -0.01330893f, 0.00329305f, 
    0.03496931f, -0.03663249f, 0.01142036f, 0.01449250f, 0.04416759f, -0.03048394f, -0.03835333f, -0.03811700f, 
    0.10043499f, -0.34104395f, 0.16212897f, 0.21472882f, 0.09351644f, -0.02692875f, 0.10158096f, 0.04023628f, 
    0.12191753f, 0.16285811f, 0.08141036f, 0.02416539f, 0.04565149f, -0.14650021f, -0.24725601f, -0.00575827f, 
    0.00708581f, -0.01266673f, -0.05731389f, 0.07467062f, -0.01206264f, -0.08898444f, 0.02441897f, 0.01020107f, 
    -0.61876744f, -0.42411500f, -0.12623134f, -0.31960687f, -0.07160099f, -0.26283574f, -0.11479938f, -0.06063079f, 
    -0.14559925f, -0.01934351f, -0.05174510f, -0.00310013f, -0.03454145f, 0.27387032f, 0.27532956f, 0.31715518f, 
    -0.05256658f, -0.11391645f, -0.02580117f, 0.10300305f, -0.03939687f, -0.00574928f, 0.09551852f, 0.00324210f, 
    0.00970614f, -0.05073788f, 0.05533345f, 0.01078522f, -0.00305402f, 0.03200804f, 0.04730546f, -0.02760652f, 
    0.32037979f, 0.09961110f, 0.41943687f, 0.20683369f, 0.07932062f, -0.21985944f, -0.01170866f, 0.13436474f, 
    -0.02262171f, 0.21274011f, 0.03825163f, 0.02420334f, -0.01124011f, -0.05911504f, 0.01781254f, 0.13575400f, 
    0.10889105f, 0.34322664f, 0.30934930f, -0.23529577f, -0.11119510f, -0.06011027f, -0.03096968f, -0.09985735f, 
    0.02001536f, -0.06633016f, -0.10851941f, 0.04824850f, 0.03678613f, -0.06605748f, -0.03504289f, 0.26327106f, 
    0.02745596f, -0.08517358f, -0.01828491f, 0.10872691f, -0.04645845f, -0.07498784f, -0.12078427f, -0.19634710f, 
    0.31923169f, 0.01910601f, 0.01303649f, 0.24438268f, 0.00695129f, 0.05951622f, -0.00231421f, -0.15708348f, 
    0.10362910f, 0.07247214f, 0.30548835f, 0.26055422f, -0.32322085f, -0.24006821f, -0.09941781f, -0.12387974f, 
    -0.05167611f, -0.04247005f, -0.17781781f, -0.00378044f, -0.09115752f, -0.03266991f, -0.02683233f, 0.00178624f, 
    0.26466328f, -0.28390828f, -0.09577858f, -0.09856620f, 0.00800557f, 0.00093483f, -0.08661634f, -0.07552355f, 
    0.05387168f, 0.03818951f, 0.06104395f, 0.04434752f, -0.16206071f, 0.03378110f, 0.02065102f, -0.08038744f, 
    0.03736195f, 0.10667732f, 0.04938032f, 0.04172033f, 0.19549319f, -0.03795537f, -0.18422690f, -0.11537261f, 
    0.03679994f, 0.05857954f, -0.10881764f, -0.13824588f, -0.08454601f, -0.03561402f, -0.00804916f, -0.05628322f, 
    -0.06143947f, -0.18291292f, -0.21714883f, -0.01720586f, -0.14532483f, -0.14566004f, -0.08317597f, -0.09340646f, 
    0.03336189f, -0.05423320f, -0.08289874f, 0.05976557f, 0.12578715f, -0.14408126f, -0.14350958f, -0.08274170f, 
    0.15701918f, -0.00498115f, -0.04972585f, -0.06413496f, -0.05835199f, 0.05269194f, -0.07937901f, -0.12953271f, 
    -0.07690276f, 0.16967785f, 0.15935926f, -0.10741150f, -0.17791383f, -0.09605029f, -0.05444885f, -0.01571173f, 
    0.04911235f, 0.25395614f, 0.20851652f, 0.15127195f, 0.01956913f, 0.18889597f, 0.13028920f, -0.00130810f, 
    -0.17513052f, 0.51244330f, 0.43165070f, -0.14597528f, -0.19040032f, -0.04282791f, 0.04334712f, 0.05568628f, 
    0.00113187f, -0.10406096f, 0.07695338f, 0.08536865f, 0.11744010f, 0.32363486f, 0.24396153f, 0.21871136f, 
    0.16425210f, -0.06978186f, 0.34260404f, 0.16892146f, 0.11501154f, 0.18374716f, -0.06332528f, -0.01376350f, 
    0.20366398f, -0.01432383f, -0.00663211f, -0.02314678f, -0.14696339f, -0.15570015f, -0.04740151f, -0.03029122f, 
    -0.09097231f, -0.12799369f, -0.10905507f, -0.08615239f, -0.00195829f, 0.09683852f, 0.01563022f, 0.06416608f, 
    0.17653821f, 0.10979931f, 0.19470407f, 0.09272392f, -0.00895418f, 0.05474064f, 0.05617025f, 0.20049444f, 
    -0.34938648f, -0.25708368f, -0.28275278f, -0.33394688f, -0.09548982f, -0.01859462f, -0.13820273f, -0.11882287f, 
    -0.05912584f, -0.03899982f, 0.02297586f, -0.02158604f, 0.10906540f, -0.02342651f, -0.09738557f, 0.00272513f, 
    -0.00125167f, -0.06179354f, -0.01012539f, -0.09789906f, 0.17797911f, -0.01195814f, 0.02934378f, 0.07014344f, 
    -0.10825133f, -0.46200088f, -0.20347498f, 0.10865527f, -0.02938297f, -0.06237837f, -0.09479751f, 0.06623241f, 
    0.07301144f, 0.02852994f, 0.10728011f, -0.02512179f, 0.21837762f, -0.08190597f, -0.14144301f, 0.21299420f, 
    -0.06292488f, 0.17397672f, -0.02139847f, 0.20395343f, 0.05777491f, 0.03816545f, 0.16152538f, 0.09463783f, 
    0.11880735f, 0.40699065f, -0.10778762f, 0.05481810f, -0.08825555f, -0.03906635f, 0.07769181f, 0.01942045f, 
    -0.01143274f, -0.04220085f, 0.01578805f, -0.01466272f, -0.36534101f, -0.28860208f, -0.38864669f, -0.26795751f, 
    -0.08580668f, -0.07420085f, -0.06548151f, -0.08338399f, 0.04086535f, 0.11601511f, 0.02690826f, -0.06509036f, 
    0.30272979f, -0.16624315f, 0.02127646f, 0.16533670f, 0.18034495f, -0.01890652f, -0.07273024f, -0.10716839f, 
    0.03356648f, 0.02285416f, -0.01183664f, 0.06576914f, -0.19807762f, 0.15378857f, 0.24783523f, 0.18273078f, 
    -0.13598973f, 0.04485106f, 0.09920199f, -0.06338822f, 0.08351287f, 0.18620650f, 0.02247036f, 0.15344194f, 
    -0.08086607f, -0.36901045f, 0.00530737f, 0.01749835f, -0.08392535f, -0.13147929f, -0.05760629f, 0.06049893f, 
    -0.11708415f, -0.04313825f, 0.06808842f, -0.13598029f, 0.22893180f, 0.09929287f, 0.09882113f, 0.16558591f, 
    0.00300253f, 0.04286651f, 0.00775006f, 0.04820613f, 0.14577048f, 0.06339287f, 0.20120142f, 0.22583035f, 
    0.08062927f, -0.11931676f, 0.15167920f, 0.03479940f, -0.02480340f, -0.18373977f, -0.07684806f, 0.06398796f, 
    -0.03654428f, 0.05224074f, 0.08174037f, -0.14121898f, -0.30049264f, 0.53040510f, 0.25597259f, 0.07614978f, 
    -0.09716300f, -0.02578836f, 0.03696629f, 0.26342875f, -0.07326343f, 0.17270090f, 0.07713482f, -0.02813163f, 
    -0.12633577f, 0.54215682f, -0.28441387f, 0.04232589f, 0.14064369f, 0.14236076f, -0.07491624f, -0.12674791f, 
    -0.22077188f, 0.08764827f, 0.18518095f, 0.17340834f, -0.15562972f, 0.22908588f, -0.16939703f, -0.19247024f, 
    0.13180536f, 0.06806709f, -0.00229220f, -0.03782852f, -0.03217619f, 0.05773831f, 0.04508867f, 0.11505266f, 
    -0.17715487f, -0.16969484f, -0.00928563f, 0.11195238f, 0.01997174f, -0.17355412f, 0.00284103f, 0.09556714f, 
    -0.00067961f, 0.06170258f, -0.01778449f, -0.14624344f, -0.06228116f, 0.08397681f, 0.09855777f, 0.37588054f, 
    0.21964645f, 0.03327091f, 0.12531845f, -0.02165545f, -0.14112261f, -0.04392112f, 0.04689451f, 0.14855707f, 
    -0.21760069f, 0.31601319f, -0.28115115f, -0.09107875f, -0.09876797f, -0.01976307f, -0.02812069f, 0.07995900f, 
    0.17441733f, 0.17113455f, 0.18402372f, 0.16621913f, -0.15905388f, 0.04374035f, -0.40210393f, 0.29663897f, 
    0.30590433f, 0.07532839f, 0.16999230f, -0.00242598f, -0.06414355f, -0.10147921f, -0.04857791f, 0.12402248f, 
    -0.34701890f, -0.00986301f, 0.04717487f, -0.22872563f, -0.08385503f, 0.00612132f, 0.02750675f, -0.09959234f, 
    -0.11667939f, -0.03620375f, -0.09613730f, 0.00183165f, -0.02256716f, 0.26072377f, 0.00721383f, 0.01826526f, 
    -0.05498181f, 0.06225330f, -0.02433503f, -0.02235453f, -0.17356795f, 0.07226116f, 0.15451077f, 0.01139402f, 
    0.64865088f, 0.08115082f, -0.07132728f, -0.24093124f, 0.01866866f, 0.05487761f, 0.07438174f, 0.16119324f, 
    0.02844555f, 0.02531312f, 0.17031613f, 0.13516784f, -0.01752049f, -0.14649351f, -0.12403475f, -0.03894994f, 
    0.01608503f, 0.01001757f, 0.03691033f, 0.04614722f, 0.01916292f, -0.04075977f, -0.09290234f, -0.06986669f, 
    0.37089765f, -0.03971889f, 0.27599365f, 0.05597543f, 0.00293244f, -0.02706914f, 0.06836486f, -0.10608111f, 
    -0.14760375f, 0.02697345f, -0.08336996f, 0.11454486f, -0.33976558f, 0.13384028f, -0.04076712f, -0.02583010f, 
    0.01583076f, 0.07752879f, -0.08561910f, -0.04307055f, -0.10047456f, 0.07617693f, 0.07144690f, 0.10052297f, 
    -0.09343304f, -0.01073064f, -0.13224675f, -0.18035838f, -0.03415949f, -0.01358977f, 0.05868134f, -0.04402371f, 
    0.10541289f, 0.13765667f, -0.05783840f, -0.05288370f, 0.07554986f, 0.02416395f, -0.02187044f, 0.23521210f, 
    -0.04608262f, 0.04761893f, 0.10885582f, -0.19856472f, -0.08040524f, 0.08805604f, -0.13698876f, -0.17184953f, 
    0.07476043f, 0.06758873f, 0.18479548f, -0.13049559f, -0.08039123f, 0.16764197f, 0.04261967f, 0.11431225f, 
    0.04484292f, 0.05570518f, -0.02403551f, 0.00193148f, 0.18652867f, -0.17482533f, -0.03040268f, 0.10701802f, 
    0.05621975f, 0.00261409f, 0.10969482f, 0.19229110f, -0.02689965f, 0.09858872f, 0.12635405f, -0.07251930f, 
    -0.56389141f, 0.40516680f, 0.14299814f, 0.41411290f, -0.04276915f, 0.07383682f, -0.07968331f, 0.14743607f, 
    -0.04324480f, 0.01835471f, 0.04988569f, 0.12376496f, -0.31706417f, 0.16615935f, 0.13115923f, 0.43410692f, 
    0.09515767f, 0.04546014f, 0.04643718f, 0.06867591f, -0.18936592f, 0.07465287f, -0.00149595f, -0.07860739f, 
    0.11104996f, -0.00850861f, -0.06945542f, -0.02569253f, 0.01535900f, 0.05627250f, 0.04871816f, -0.10118960f, 
    -0.08069678f, -0.04786803f, 0.02291558f, -0.07307874f, 0.65016931f, -0.05399653f, 0.03678032f, -0.19075292f, 
    -0.05814673f, 0.14297548f, -0.10903885f, 0.19903930f, 0.05256611f, 0.03298815f, -0.03617945f, -0.02001262f, 
    -0.01078066f, -0.00933536f, -0.10277166f, 0.20184574f, -0.11318237f, -0.01150969f, 0.05147047f, 0.06698544f, 
    0.09296428f, 0.05827481f, -0.04161157f, 0.09279858f, -0.22004689f, 0.14631368f, 0.01262350f, -0.10562494f, 
    0.07441916f, 0.05693701f, 0.00653371f, -0.04708784f, 0.03838935f, -0.00099384f, 0.02159176f, -0.00839998f, 
    -0.05366911f, -0.05424637f, -0.24116427f, -0.02281055f, 0.06296132f, 0.06819685f, 0.09159960f, -0.01175559f, 
    -0.05915082f, 0.05803069f, -0.02155489f, 0.04531852f, -0.16733490f, 0.32245579f, -0.39156514f, 0.13345039f, 
    -0.02019611f, -0.00685109f, 0.01346818f, 0.05423241f, 0.05723130f, 0.21269111f, 0.13718271f, 0.00257657f, 
    -0.01018346f, 0.20962955f, -0.05344854f, 0.07468625f, 0.09088338f, -0.12213948f, -0.10564148f, 0.10440843f, 
    0.04389109f, -0.12972081f, 0.04045210f, 0.14314586f, -0.09213378f, -0.12000697f, -0.12016985f, 0.23730223f, 
    -0.03031259f, 0.03125782f, -0.10389168f, 0.02251025f, -0.13302803f, -0.00816751f, -0.10208496f, -0.02418863f, 
    0.39218071f, 0.02217164f, 0.14791249f, 0.16223513f, -0.10526673f, 0.01847452f, 0.09662995f, -0.24746954f, 
    -0.12462185f, -0.11217074f, -0.11825740f, 0.05527917f, -0.01497055f, -0.04608380f, 0.13534959f, 0.21012785f, 
    0.06598490f, 0.03394630f, 0.00227524f, 0.01465479f, 0.12119236f, 0.23938538f, -0.03282953f, 0.17395614f, 
    0.17538674f, -0.14525115f, -0.34133652f, 0.09762206f, 0.00574062f, 0.12386250f, 0.00499123f, -0.06130932f, 
    -0.10935268f, -0.03395114f, 0.11803715f, 0.01271211f, -0.23875453f, 0.06021366f, 0.12603979f, 0.20819828f, 
    -0.01020942f, -0.06511202f, 0.20883241f, -0.17638186f, 0.04049714f, -0.03734612f, 0.04305252f, 0.03887788f, 
    0.10760798f, -0.08692916f, 0.11244673f, -0.01902763f, 0.00577358f, -0.02904518f, -0.17562382f, 0.05144114f, 
    -0.15468569f, 0.00778572f, 0.18197978f, -0.00131449f, 0.35795516f, 0.21218966f, 0.05035555f, 0.11698000f, 
    0.05018235f, 0.07692870f, -0.07069971f, 0.08477990f, -0.09420480f, 0.20920797f, 0.05223113f, -0.05320666f, 
    -0.09821958f, -0.58312815f, 0.41136557f, 0.32378313f, 0.19722065f, -0.10454283f, 0.08547617f, 0.11639003f, 
    0.30488369f, 0.00691898f, 0.02956790f, -0.07171861f, -0.17866395f, -0.29316479f, 0.12681155f, 0.18369718f, 
    -0.00586359f, -0.01422225f, 0.04591870f, 0.10523817f, 0.12582049f, -0.00100917f, 0.08761744f, -0.12049917f, 
    0.01122115f, 0.13158335f, 0.10609557f, -0.04107556f, -0.07195295f, 0.10748709f, 0.00658803f, -0.03541892f, 
    0.03047522f, -0.00969035f, -0.12041988f, 0.10596673f, 0.03378282f, 0.47811532f, 0.05011570f, -0.17947447f, 
    -0.19829990f, -0.12141968f, -0.12265321f, 0.04368820f, -0.04478611f, 0.10270283f, -0.07900187f, -0.22521214f, 
    0.34539261f, -0.14114259f, 0.04433551f, 0.05929432f, 0.11141841f, -0.03597473f, -0.04920572f, -0.06006115f, 
    0.05920146f, -0.09217673f, 0.14107068f, 0.06773958f, 0.18375161f, -0.00792425f, 0.21202926f, -0.06758391f, 
    -0.07597315f, 0.17998193f, -0.12483073f, 0.18956202f, -0.01467576f, 0.09008908f, 0.11893927f, 0.02879446f, 
    0.49553144f, 0.00525177f, -0.15380542f, -0.10218552f, 0.01689113f, -0.02054130f, -0.04034652f, -0.03492051f, 
    0.02295077f, 0.01933821f, 0.06541970f, -0.05774941f, 0.11419938f, 0.03911360f, -0.02131287f, 0.28304517f, 
    0.03740145f, 0.01591842f, 0.01213162f, 0.11486546f, 0.15382516f, 0.01251079f, -0.16540402f, 0.02541139f, 
    -0.53238034f, -0.03315601f, 0.13911320f, 0.39027616f, -0.01319040f, 0.21344267f, 0.05476064f, -0.14251286f, 
    0.12399747f, 0.07811841f, 0.16511101f, -0.09822070f, -0.28197592f, 0.06456706f, 0.24975595f, 0.04414578f, 
    -0.01535835f, 0.04095227f, -0.05416285f, -0.05760844f, 0.05272479f, -0.02339583f, -0.01335873f, 0.05629707f, 
    0.01255252f, -0.09540069f, -0.08175609f, -0.24568099f, 0.02304697f, 0.34062517f, 0.11135998f, 0.14301595f, 
    0.01212341f, -0.04681091f, -0.01423597f, -0.01451368f, -0.06580846f, -0.12833317f, 0.14560610f, 0.15776898f, 
    -0.03724494f, 0.00151482f, 0.03395184f, 0.00484550f, 0.25991473f, 0.15921794f, -0.10888659f, 0.07066076f, 
    0.07483785f, -0.00119544f, 0.06576160f, -0.00647570f, -0.04166081f, -0.00595491f, -0.05411274f, -0.01889921f, 
    0.02565505f, 0.02123563f, 0.02822376f, 0.00067401f, -0.00678747f, -0.00718503f, -0.08446357f, -0.21727851f, 
    0.05937334f, 0.09772085f, -0.05934665f, 0.10758200f, 0.06855578f, -0.20880032f, 0.09741082f, 0.08390055f, 
    0.05874690f, 0.04600344f, -0.25805962f, 0.11647813f, 0.01483402f, -0.07559448f, -0.16879080f, 0.09717800f, 
    0.14610030f, -0.07092300f, 0.09975524f, 0.14872007f, -0.12558532f, 0.20358202f, 0.05646380f, -0.13983507f, 
    0.05793461f, 0.03073106f, 0.05104848f, -0.07678755f, 0.06079371f, 0.09842459f, -0.07122084f, 0.15670907f, 
    0.66811520f, 0.20184918f, 0.01651276f, -0.30696097f, -0.13800305f, -0.09429068f, 0.01325062f, 0.01213199f, 
    0.00187244f, -0.04300597f, 0.01386647f, -0.02456201f, 0.31156021f, 0.18649122f, 0.15716794f, -0.34454444f, 
    -0.14141442f, -0.08950119f, 0.04439098f, -0.01336600f, 0.26136225f, 0.09810144f, -0.12479090f, 0.06348575f, 
    0.09155409f, -0.02314917f, 0.02254773f, -0.04002088f, -0.05093017f, 0.05347944f, -0.03170954f, -0.01330486f, 
    -0.06582194f, 0.01972570f, -0.02677705f, -0.07491063f, -0.55939507f, 0.14784041f, 0.06714130f, 0.27812800f, 
    0.04898188f, 0.06701172f, 0.14485531f, -0.14227548f, 0.01605412f, 0.03495523f, 0.02422385f, -0.00025401f, 
    -0.11849594f, 0.05136639f, 0.03211069f, -0.05330830f, 0.06223271f, -0.07045904f, -0.09132348f, -0.08331129f, 
    -0.04240237f, -0.08279466f, -0.03231506f, 0.07537062f, 0.09035025f, -0.02449639f, 0.04408132f, 0.29213214f, 
    0.04380379f, -0.10881864f, -0.04063590f, 0.03287236f, 0.03736332f, -0.01788438f, -0.06359966f, -0.04673742f, 
    0.03278587f, 0.04298626f, 0.10525516f, 0.14735404f, -0.12078699f, -0.08300357f, -0.06201930f, 0.01736283f, 
    0.10814826f, 0.04837877f, -0.00436376f, -0.13971309f, -0.18085854f, -0.32494304f, 0.11343681f, 0.20592703f, 
    0.06708342f, 0.21550368f, 0.04729576f, 0.06308419f, 0.04132815f, -0.07962809f, -0.04250560f, 0.01838059f, 
    -0.02299013f, -0.08225416f, 0.02237177f, -0.02918194f, 0.03716171f, 0.12353908f, 0.16968286f, -0.10199818f, 
    0.02410595f, 0.14484130f, -0.06113391f, -0.03259978f, -0.02849827f, -0.05828152f, 0.11061115f, -0.19298652f, 
    0.04489871f, -0.02543943f, 0.05270781f, -0.07056810f, 0.01192229f, 0.02873420f, -0.02514211f, -0.05004110f, 
    -0.14954250f, -0.11808720f, 0.04459666f, -0.21659161f, 0.09756482f, 0.01676071f, 0.05468643f, 0.24509934f, 
    -0.00387531f, 0.21932869f, 0.00321948f, 0.15177190f, -0.03648616f, 0.17452407f, 0.09754858f, -0.08116685f, 
    -0.16118766f, -0.09795963f, -0.03413150f, -0.02653734f, 0.06457186f, -0.02203621f, -0.01754187f, -0.04249261f, 
    -0.26381972f, -0.06226284f, 0.33525410f, 0.14594188f, -0.00953514f, -0.09894591f, -0.02682732f, 0.07794234f, 
    0.09351125f, -0.05689389f, -0.10674457f, -0.15452474f, 0.08536109f, 0.31168324f, 0.04864818f, 0.04935659f, 
    -0.00163534f, 0.03105534f, -0.01581503f, 0.06624160f, 0.03526600f, 0.18462235f, 0.16144599f, 0.06456472f, 
    0.07534515f, -0.02943027f, 0.05105389f, 0.04489858f, -0.04229429f, 0.16933800f, 0.25868350f, 0.04897105f, 
    -0.05844224f, 0.03491693f, -0.18921416f, 0.03243797f, -0.42188400f, 0.00876849f, 0.20814432f, -0.01169604f, 
    -0.15696830f, -0.10245610f, -0.12953195f, -0.04134581f, 0.10811997f, 0.17797828f, 0.23837292f, 0.04293811f, 
    0.01349530f, 0.22272083f, 0.11869588f, -0.06008135f, 0.12858011f, 0.02420384f, 0.03803006f, 0.06197648f, 
    0.05308199f, 0.12079789f, 0.11923188f, 0.04876784f, -0.11813749f, 0.04851001f, 0.09085302f, 0.10219153f, 
    0.18327002f, -0.21006297f, 0.10984550f, -0.03354062f, 0.09578019f, 0.09896342f, 0.24040775f, 0.08416606f, 
    0.19425510f, 0.10568476f, -0.12605360f, -0.18717147f, 0.20093365f, 0.11569481f, 0.05889293f, -0.07150023f, 
    -0.04931839f, -0.09598864f, -0.07448936f, -0.10955263f, 0.13681665f, -0.18793575f, 0.32231793f, -0.06685312f, 
    -0.07700463f, -0.05356627f, -0.04232403f, -0.16173251f, -0.02213779f, -0.12399976f, -0.01852683f, 0.00213867f, 
    0.14468232f, -0.09546511f, -0.05169198f, 0.09755110f, 0.01391275f, -0.10198215f, 0.00478298f, -0.03298862f, 
    0.09614217f, 0.23985237f, -0.02281226f, 0.14865327f, -0.34211597f, 0.05198326f, -0.12387906f, -0.02643215f, 
    -0.06751338f, 0.12427562f, -0.00806389f, -0.09095430f, 0.13769275f, -0.06492174f, 0.17192300f, -0.11083876f, 
    -0.21571532f, -0.25607342f, 0.10221396f, 0.20017110f, -0.12588198f, -0.01278565f, -0.11964589f, 0.08207072f, 
    -0.03459193f, -0.16130111f, -0.17056398f, -0.03021479f, 0.01670419f, -0.17298736f, -0.04274426f, 0.12625165f, 
    -0.00112277f, 0.03789780f, -0.17259444f, -0.02015183f, 0.06069218f, 0.05791353f, -0.21097650f, -0.02356179f, 
    -0.34558499f, -0.03179725f, 0.05800282f, 0.34052616f, 0.17086117f, -0.04892510f, -0.02964823f, -0.29434529f, 
    -0.06733069f, -0.00805021f, -0.04738047f, 0.07147197f, -0.03523978f, -0.00155014f, -0.20279251f, -0.08859003f, 
    0.19926350f, 0.00548330f, 0.05866640f, -0.03962661f, 0.09572889f, 0.03289495f, 0.02234598f, 0.05569489f, 
    0.30592179f, -0.04434706f, -0.06676289f, -0.37562016f, -0.06739861f, -0.14329395f, 0.01513498f, -0.02542136f, 
    0.06428617f, -0.00901984f, 0.03467705f, 0.00825075f, 0.23633270f, -0.06163545f, 0.08067817f, 0.28306255f, 
    0.08750431f, -0.17275710f, -0.06815507f, 0.23664391f, -0.01626747f, 0.12570858f, 0.01586433f, 0.06085833f, 
    -0.30418137f, -0.10418038f, 0.05559971f, 0.34784487f, -0.06009993f, 0.00846499f, -0.22681636f, -0.06525169f, 
    0.19512984f, 0.12729648f, 0.11872797f, 0.20830870f, -0.05100306f, -0.41276836f, -0.32740352f, -0.03734357f, 
    0.13866253f, -0.05560138f, 0.02830379f, 0.32459098f, 0.10340353f, 0.15830271f, -0.00590038f, 0.06279028f, 
    -0.18133415f, -0.05311486f, -0.15951854f, 0.08630110f, -0.03438531f, -0.04543258f, 0.14034425f, 0.10889366f, 
    0.11326019f, 0.12051166f, 0.24736412f, -0.04001091f, 0.02805383f, 0.18180458f, 0.12437250f, -0.12757114f, 
    -0.00293531f, -0.05408775f, -0.17762201f, -0.11983770f, -0.00015055f, 0.12259095f, 0.14504842f, 0.07357942f, 
    0.22069062f, 0.29132763f, 0.24492638f, -0.11170001f, 0.08515325f, -0.06111011f, -0.06879584f, -0.04257105f, 
    -0.02229557f, -0.05142574f, 0.11094237f, -0.08894139f, 0.24057581f, 0.06040471f, 0.07046841f, -0.24464644f, 
    0.07624000f, 0.14974812f, -0.09621919f, -0.03574427f, -0.02143100f, 0.12592413f, 0.04759575f, 0.27865663f, 
    -0.24756667f, -0.13276286f, 0.03701820f, 0.14170656f, 0.06902871f, -0.05484340f, -0.15470996f, 0.10923436f, 
    -0.03846637f, -0.18988249f, -0.05741766f, -0.23956168f, -0.02429927f, -0.11309485f, -0.01508680f, 0.12664793f, 
    0.06136290f, -0.15730944f, 0.05580970f, -0.08115240f, 0.04293137f, 0.04884917f, 0.09642445f, 0.06592278f, 
    0.11410247f, -0.00011459f, -0.14024694f, -0.18517891f, -0.03704035f, -0.04008663f, -0.12160773f, -0.07945941f, 
    0.08780468f, 0.03898480f, -0.12024295f, 0.13060811f, -0.07043481f, -0.06576376f, 0.00263781f, 0.43144864f, 
    0.03925654f, 0.03546411f, -0.17221434f, 0.16516410f, 0.00553793f, -0.09157585f, 0.00706700f, -0.02786364f, 
    0.14815167f, 0.06349934f, 0.24128716f, 0.00439976f, 0.14626892f, 0.17219707f, -0.06975817f, 0.08537317f, 
    0.07979664f, -0.08091074f, 0.02976035f, 0.02849321f, -0.09903261f, 0.02183795f, 0.05977707f, 0.15377602f, 
    0.03518512f, -0.08760194f, -0.04985796f, 0.00927209f, 0.03565480f, -0.03042200f, 0.04726188f, 0.13163005f, 
    -0.09157620f, -0.01431444f, -0.13310584f, 0.25810519f, 0.02651509f, -0.11033778f, 0.09482127f, 0.02765542f, 
    -0.13637009f, -0.13082282f, -0.03548658f, -0.18837625f, 0.00769379f, 0.23998916f, 0.07056829f, -0.05765370f, 
    0.06683825f, -0.01068334f, 0.07659955f, 0.01708434f, 0.05311347f, -0.04183358f, 0.06093363f, -0.00163900f, 
    0.22032392f, 0.16062841f, -0.17202264f, -0.00434092f, 0.03321392f, -0.06072640f, -0.26883087f, 0.18528976f, 
    0.00323668f, 0.02378215f, -0.34684888f, 0.07022466f, 0.03571700f, 0.16098072f, 0.12961945f, 0.07371688f, 
    0.09628728f, 0.02236248f, 0.00051960f, -0.08529512f, 0.13108809f, 0.18628506f, 0.16298334f, 0.18669532f, 
    0.11805387f, 0.34049028f, -0.09191663f, -0.21751031f, 0.16739410f, 0.05326580f, 0.00359147f, -0.03613276f, 
    -0.00962573f, -0.14019419f, -0.21258879f, -0.03650412f, 0.27790239f, -0.00068556f, 0.08752753f, -0.06985183f, 
    0.04744152f, -0.14156938f, -0.12756157f, 0.18959330f, 0.15873648f, 0.01632872f, 0.06569351f, 0.19904445f, 
    -0.01694271f, -0.12290393f, -0.04721939f, -0.07270341f, 0.12683718f, 0.03958649f, 0.04442132f, -0.08778108f, 
    -0.12457567f, -0.23469767f, -0.26864594f, -0.23937839f, 0.00913493f, 0.46432272f, 0.19412307f, 0.30684698f, 
    0.12065018f, -0.12737460f, 0.09489682f, -0.12746035f, -0.06956182f, 0.12068094f, -0.04358242f, 0.23554437f, 
    -0.02852250f, -0.57743001f, 0.00365656f, -0.21283923f, -0.06693735f, 0.19127488f, 0.00311739f, -0.12887430f, 
    0.07485635f, 0.09901208f, -0.08546523f, 0.06186315f, -0.21239468f, 0.05736258f, 0.09329907f, 0.00366929f, 
    -0.04411767f, 0.01825097f, 0.03130868f, 0.06636368f, -0.05721139f, -0.00058307f, 0.04618541f, -0.00083518f, 
    -0.22995465f, 0.05906013f, -0.14575626f, 0.15797450f, 0.01786779f, -0.05590178f, -0.12895647f, -0.21618009f, 
    0.01241299f, 0.03131355f, -0.09989109f, 0.01826342f, -0.24891441f, 0.08181106f, -0.23206423f, -0.22976401f, 
    -0.09861780f, -0.03780204f, -0.13408653f, -0.00867800f, -0.15287493f, -0.04079166f, 0.01876963f, -0.12479787f, 
    0.13267256f, 0.19580220f, -0.06925616f, 0.14647827f, 0.00799793f, 0.05137277f, 0.06004586f, 0.03230565f, 
    -0.20258015f, -0.06090103f, 0.06020511f, 0.12726626f, -0.04631932f, 0.20396954f, -0.06516448f, 0.13308080f, 
    0.05981601f, 0.18331245f, -0.02163342f, 0.20283313f, -0.05171737f, 0.06056727f, 0.07928101f, 0.08951612f, 
    0.56572330f, 0.26050913f, 0.14689918f, 0.23717253f, -0.01362794f, 0.03889856f, -0.01850560f, -0.03007966f, 
    -0.04281744f, -0.04069265f, -0.06940323f, 0.03402015f, 0.21095730f, 0.21729438f, 0.07501605f, 0.29213282f, 
    0.00209620f, -0.02333466f, 0.00061890f, 0.07158850f, -0.07215542f, 0.04018325f, -0.06247013f, 0.01184958f, 
    -0.37431371f, -0.09591898f, 0.37813061f, 0.11805825f, -0.01606384f, 0.03442762f, 0.12789410f, -0.06973079f, 
    0.18510494f, 0.03574030f, 0.06227542f, 0.03145979f, -0.28638437f, 0.05985391f, 0.07331939f, -0.43115118f, 
    0.12164692f, -0.00151270f, -0.19240953f, -0.17318366f, -0.03685117f, -0.00461365f, -0.06923087f, 0.05359900f, 
    0.69551051f, -0.08144991f, 0.02603440f, -0.25986677f, -0.04128552f, 0.20866945f, 0.20967619f, 0.00080205f, 
    -0.05033087f, 0.00046415f, -0.02977027f, -0.18561751f, 0.01654744f, 0.03300221f, 0.26317519f, 0.17839862f, 
    -0.02975334f, -0.08247924f, 0.06861632f, 0.01354361f, 0.22789125f, 0.11210921f, 0.13344200f, 0.25518689f, 
    0.04712917f, 0.05192801f, 0.09863114f, 0.05184074f, -0.05857991f, -0.06839202f, 0.00557271f, 0.02842133f, 
    0.20144525f, 0.10569490f, 0.05439928f, 0.16883475f, 0.00790477f, 0.08377484f, -0.10672175f, -0.03023143f, 
    0.05991208f, -0.01341941f, 0.04838999f, 0.04190927f, -0.04012746f, -0.06845526f, -0.07532317f, -0.05068502f, 
    0.09905463f, 0.08756479f, 0.11235254f, 0.08545464f, 0.04086957f, -0.07211955f, 0.06960806f, 0.09179820f, 
    0.39034733f, -0.06676652f, 0.20385209f, 0.08323469f, -0.25433037f, -0.18794017f, -0.11783929f, -0.11494916f, 
    0.05703185f, 0.08052538f, -0.02165800f, 0.01314852f, 0.02171846f, 0.01555501f, -0.00629763f, 0.08148745f, 
    0.53938490f, 0.08094530f, -0.54624903f, -0.17640249f, -0.06685454f, -0.02962169f, -0.02478000f, -0.13841978f, 
    0.08338494f, 0.08294878f, 0.00331143f, -0.03124577f, 0.13169329f, -0.09586231f, -0.21803911f, -0.09372742f, 
    0.12651102f, -0.05620547f, -0.10084153f, -0.03902361f, 0.02652712f, -0.10003003f, -0.04745440f, -0.04677457f, 
    0.18178627f, 0.10430159f, 0.07466899f, 0.08627653f, -0.00357812f, 0.04901935f, -0.02725155f, -0.05205122f, 
    -0.08410173f, -0.09080447f, -0.00774028f, -0.06105937f, -0.43115735f, -0.11841431f, 0.22437857f, -0.19232187f, 
    -0.08188535f, 0.02963376f, -0.07738604f, -0.04495208f, 0.00151182f, 0.05647254f, 0.01524889f, -0.08189899f, 
    0.15380408f, 0.18560100f, 0.07054769f, -0.04518908f, 0.08327521f, -0.01418666f, -0.16704048f, 0.03649065f, 
    -0.05807473f, 0.09942680f, 0.03105820f, 0.02237624f, 0.04101143f, 0.16537495f, 0.11268985f, 0.09793980f, 
    -0.04212524f, 0.02040457f, -0.00482201f, -0.03212355f, 0.04719803f, 0.00770377f, 0.07330203f, -0.04687325f, 
    -0.37452936f, -0.02717763f, -0.09421757f, -0.27892661f, 0.16104266f, 0.09596521f, 0.06746829f, -0.06255778f, 
    0.00218506f, 0.06042832f, 0.15697272f, 0.04816881f, -0.41125011f, 0.11196457f, -0.09063154f, 0.05828466f, 
    0.09252729f, 0.10714389f, 0.07044675f, 0.14174674f, 0.00739580f, 0.02936471f, -0.00402958f, 0.17767024f, 
    0.03101043f, 0.00210749f, 0.19658384f, 0.15276252f, 0.06123031f, -0.02590949f, -0.03086394f, -0.05915432f, 
    -0.08544516f, -0.05683774f, -0.01422981f, 0.04117575f, -0.26964596f, -0.28594747f, 0.09562282f, -0.11730432f, 
    -0.10103608f, -0.17669123f, -0.07560182f, -0.29270938f, -0.03067876f, 0.00620337f, 0.02971559f, -0.00998396f, 
    0.00463240f, -0.07859144f, -0.03626382f, 0.03727483f, -0.04957712f, 0.01544173f, -0.09497714f, -0.06750432f, 
    -0.02633520f, 0.05164331f, -0.05634448f, -0.01379148f, -0.22554071f, -0.12769543f, -0.00586345f, -0.41441908f, 
    -0.11007289f, 0.00855775f, 0.05758436f, -0.01511436f, 0.04784013f, -0.07317572f, -0.01577192f, 0.01620797f, 
    -0.41241789f, -0.21102685f, -0.33701134f, 0.12589455f, 0.10654671f, -0.07680886f, 0.05284934f, 0.01061582f, 
    -0.05941516f, 0.02277597f, -0.04543442f, 0.00187017f, 0.25726593f, 0.18788053f, 0.08647418f, 0.11420561f, 
    0.03358524f, 0.06273092f, -0.01782348f, 0.06994936f, 0.19746126f, -0.05679243f, 0.18430260f, -0.06505134f, 
    0.07949335f, -0.01500020f, 0.06467179f, 0.09537543f, 0.11774185f, -0.10631414f, 0.11574806f, -0.07459442f, 
    -0.01073706f, 0.02547932f, -0.07270227f, -0.08507656f, -0.50860453f, -0.38910848f, -0.08211610f, -0.06563456f, 
    -0.11071349f, 0.11587335f, -0.00498609f, 0.21647908f, 0.08727144f, 0.03567432f, 0.07688077f, -0.11316981f, 
    0.07700245f, 0.62672246f, -0.28319159f, -0.15178642f, 0.10943753f, -0.06452349f, -0.05780214f, 0.02567502f, 
    -0.10977578f, 0.04425759f, -0.00478403f, -0.02417803f, 0.19641811f, 0.33721709f, -0.07681606f, -0.27510044f, 
    0.00405749f, -0.04428303f, -0.14336006f, -0.09333033f, 0.01385175f, -0.10589466f, -0.02761693f, -0.15562896f, 
    -0.07504899f, -0.06007257f, 0.07187907f, -0.09648973f, 0.05872419f, 0.10553937f, -0.03490916f, -0.09296098f, 
    0.09709179f, 0.00706392f, 0.10301647f, 0.02558611f, 0.28859720f, -0.41361123f, -0.01016486f, 0.04803510f, 
    -0.05792330f, -0.06191020f, 0.07551197f, 0.13067760f, 0.24101278f, 0.08268245f, 0.11277381f, -0.02599431f, 
    -0.00322989f, 0.00237328f, 0.08604623f, -0.04084231f, -0.07793204f, -0.04955232f, -0.00226178f, -0.10019273f, 
    0.03209290f, 0.00706943f, -0.23741378f, -0.34433880f, -0.44679901f, 0.04449329f, -0.07259573f, -0.08730415f, 
    0.08169865f, 0.03850098f, 0.15287460f, 0.16013804f, 0.10543553f, 0.01489866f, 0.01154976f, 0.02364199f, 
    -0.26215428f, -0.11995190f, 0.07124102f, -0.04422070f, -0.10290495f, -0.05576910f, -0.01821253f, 0.00536702f, 
    0.04506350f, 0.04292636f, 0.05839896f, 0.01816534f, 0.04499243f, 0.07099535f, 0.34778044f, -0.07504825f, 
    -0.07495978f, 0.00753446f, -0.04905820f, -0.10436344f, 0.10626666f, -0.01216738f, 0.17496477f, 0.13048255f, 
    0.36254564f, 0.24939883f, -0.11021989f, 0.04959903f, -0.02683686f, 0.10822731f, -0.02017828f, -0.02384006f, 
    -0.18070279f, 0.04396718f, -0.13559546f, 0.03659121f, -0.07173607f, 0.02120865f, -0.23393986f, -0.15078804f, 
    0.26468757f, 0.22470026f, 0.09746555f, 0.09363972f, -0.03205008f, 0.07120010f, -0.01445859f, -0.07928394f, 
    0.10620246f, -0.03556125f, -0.05242191f, 0.23943634f, -0.11995427f, 0.04877215f, -0.00517402f, 0.19394931f, 
    -0.03927664f, -0.15753457f, -0.06943679f, 0.09978364f, 0.14968976f, 0.26908553f, 0.08507923f, -0.22843114f, 
    -0.01942522f, 0.08389632f, -0.11202858f, -0.02748107f, -0.04398688f, 0.00582805f, 0.03600679f, 0.02152950f, 
    0.12899649f, 0.05204997f, 0.00718593f, -0.10206944f, -0.03270054f, -0.01505963f, -0.04140633f, -0.04679102f, 
    -0.11385032f, -0.05213905f, 0.04277140f, -0.10402969f, -0.12260523f, -0.09166821f, 0.04913450f, -0.07370275f, 
    0.10355613f, -0.02525869f, 0.05126799f, 0.03788793f, -0.18399255f, 0.04190740f, 0.04937027f, 0.16790122f, 
    0.02618711f, 0.16887382f, -0.07056473f, 0.06117687f, -0.08606430f, -0.03125958f, -0.00970202f, -0.11895000f, 
    -0.11412276f, 0.25152403f, -0.08197447f, 0.02192092f, 0.01766250f, -0.08071504f, -0.12135543f, 0.19230694f, 
    -0.04700596f, -0.01344131f, 0.26228788f, 0.00869079f, -0.03194313f, -0.07765997f, -0.00951560f, 0.03138994f, 
    -0.02719442f, 0.12603904f, -0.13717142f, -0.09271641f, -0.05695364f, -0.08128686f, 0.11282258f, 0.25053632f, 
    0.03732938f, 0.10221656f, 0.13800776f, -0.05791769f, -0.10688636f, -0.07864296f, -0.18746127f, 0.04799580f, 
    -0.00398794f, -0.04219504f, 0.25421166f, 0.16610084f, -0.03084967f, -0.10512245f, -0.06500109f, -0.03041016f, 
    -0.25453722f, -0.02866800f, -0.15142344f, 0.02997447f, -0.10590123f, -0.08331173f, -0.09272930f, -0.05726659f, 
    0.01687450f, 0.06223123f, 0.04910876f, 0.04389537f, 0.17537956f, 0.29001254f, -0.20049238f, 0.17391463f, 
    -0.09118165f, -0.08901840f, 0.21485198f, 0.00847286f, -0.07983461f, -0.01029519f, 0.03510924f, -0.02256700f, 
    0.03506626f, 0.12343248f, 0.04250415f, 0.05454055f, 0.04963836f, 0.07320517f, 0.12790126f, 0.21588582f, 
    -0.05020341f, 0.10731478f, 0.12937789f, -0.05885028f, 0.25354546f, 0.16918631f, 0.15547539f, -0.13432148f, 
    -0.06159624f, -0.01612517f, -0.07021349f, -0.01293970f, -0.01143869f, 0.08747808f, 0.12309070f, 0.05655733f, 
    -0.11955474f, 0.06546758f, 0.10083474f, -0.08551357f, 0.03301764f, 0.06579765f, 0.03670281f, 0.20235242f, 
    -0.02738875f, -0.02175541f, -0.10756651f, -0.03626116f, -0.08628279f, -0.05337268f, 0.07209817f, -0.07317796f, 
    0.14039828f, -0.07994829f, -0.04329657f, -0.00106141f, 0.02926936f, 0.05971827f, 0.06410802f, -0.08398829f, 
    0.05010233f, 0.01853472f, -0.04523905f, 0.05846375f, -0.13665120f, 0.01707095f, 0.01681596f, -0.15529895f, 
    -0.02036699f, 0.03973883f, -0.00488734f, 0.06083991f, -0.02778128f, 0.02631305f, -0.04357357f, 0.11626542f, 
    0.23074381f, 0.08456517f, 0.09076210f, 0.15260796f, 0.03695154f, -0.04070596f, 0.01759756f, 0.05193020f, 
    0.22451460f, -0.04948255f, 0.14658211f, 0.13886626f, -0.20699601f, 0.08487868f, 0.12617643f, 0.15736505f, 
    0.18361194f, -0.00906604f, 0.17715576f, 0.07076260f, 0.10451403f, 0.07745454f, -0.00273611f, -0.03538254f, 
    0.12997343f, 0.04901290f, -0.04637494f, 0.05981725f, -0.08721255f, 0.02994991f, -0.05705718f, 0.01338981f, 
    0.14319572f, 0.19683993f, -0.04782551f, -0.10350040f, 0.04123247f, 0.04485546f, 0.09094951f, 0.19303928f, 
    -0.06885715f, -0.07007438f, -0.11665892f, 0.12274633f, 0.44727620f, -0.21774213f, 0.38829324f, -0.09485848f, 
    -0.14588557f, -0.07276757f, -0.09363452f, 0.07760298f, -0.03694616f, -0.05753084f, -0.03284965f, 0.07314535f, 
    -0.04689483f, 0.13082770f, 0.02543190f, -0.11866562f, 0.02772865f, 0.00915975f, -0.00285327f, -0.09272078f, 
    0.05509583f, 0.11652281f, 0.05296913f, 0.11778002f, 0.24478149f, -0.01578404f, -0.29030779f, -0.06066564f, 
    -0.00782002f, -0.20072144f, 0.14406915f, -0.00998048f, 0.07516055f, -0.09204225f, -0.12709896f, 0.12945342f, 
    0.15829743f, -0.24649373f, 0.23539883f, -0.08184938f, -0.20160171f, 0.15985930f, -0.02479395f, 0.17331269f, 
    0.04816000f, 0.09168117f, 0.18422860f, 0.10920702f, 0.44478029f, -0.28582180f, 0.09334321f, 0.16555189f, 
    -0.24121028f, 0.23859811f, -0.09387967f, 0.11257587f, 0.00017840f, 0.11056498f, 0.23043692f, 0.13578694f, 
    0.20402183f, 0.14474997f, 0.09498397f, 0.04928169f, 0.05269885f, -0.01596430f, 0.11710884f, 0.18989876f, 
    -0.00975537f, 0.06572717f, -0.06455535f, -0.17114840f, 0.13218509f, 0.09248426f, 0.13438426f, 0.11242283f, 
    -0.21245418f, 0.04308851f, -0.03930642f, -0.03264815f, -0.02383322f, -0.00178296f, -0.08173329f, 0.12610011f, 
    -0.09354155f, -0.18490599f, 0.05361526f, 0.01618876f, -0.08643256f, -0.02065709f, -0.04943343f, -0.02419862f, 
    0.29773182f, 0.38527212f, 0.11853746f, 0.35728601f, -0.16079423f, -0.25914332f, 0.59678853f, -0.28552800f, 
    -0.13480507f, -0.02154613f, -0.12055444f, 0.02995903f, 0.09221435f, 0.01054585f, -0.04601384f, -0.01900735f, 
    0.17591955f, 0.06444756f, 0.24167040f, -0.02165295f, 0.04891145f, -0.26207569f, -0.19411899f, 0.09532868f, 
    0.00841452f, -0.26074019f, -0.09944430f, -0.11499697f, 0.06680504f, 0.06503095f, -0.08880673f, -0.40450719f, 
    0.06488930f, -0.04413678f, -0.18342814f, -0.25362557f, -0.05884491f, -0.19275996f, 0.05901697f, -0.29342458f, 
    0.44065019f, -0.13070688f, -0.08176769f, 0.00591421f, -0.12415855f, 0.10488974f, -0.07450864f, 0.00955787f, 
    -0.06363028f, -0.00321315f, 0.04134321f, 0.02617790f, 0.20852491f, 0.06667475f, 0.20919839f, 0.07152940f, 
    0.06176798f, -0.07877025f, 0.01778757f, 0.18799622f, 0.20225166f, -0.07427785f, -0.03301697f, 0.02073413f, 
    -0.54773551f, 0.24687976f, 0.04204967f, 0.60153770f, 0.01127059f, 0.26074281f, -0.04327868f, -0.12086245f, 
    -0.03079814f, -0.12522604f, 0.12229907f, -0.06479304f, 0.27471343f, 0.09277586f, -0.05039191f, -0.50118846f, 
    -0.02729179f, -0.09069830f, -0.00253173f, 0.16977772f, 0.12411081f, 0.21271579f, 0.06652231f, 0.03861252f, 
    0.16628499f, -0.11787196f, -0.14564183f, -0.12305662f, 0.02523362f, 0.00230188f, -0.02003698f, -0.03406738f, 
    -0.00239436f, 0.09443559f, 0.08580955f, 0.16713141f, -0.08117628f, -0.26481760f, 0.29780501f, 0.08928566f, 
    0.05830121f, 0.04455005f, -0.11997779f, 0.02072361f, -0.01625886f, -0.04254682f, 0.10010958f, -0.07988830f, 
    0.08215862f, 0.16911899f, -0.06294155f, 0.03390304f, 0.11132579f, -0.25084734f, 0.10918289f, -0.05521987f, 
    0.44488180f, 0.00418634f, -0.07268786f, 0.17692402f, 0.02944569f, 0.04888083f, 0.00943733f, 0.11256617f, 
    0.11542191f, 0.06767935f, 0.16142008f, 0.04672183f, 0.21267137f, 0.16866410f, 0.20007031f, 0.15926769f, 
    -0.06721625f, -0.07591353f, 0.15357524f, -0.09139222f, 0.04613814f, -0.20744683f, 0.14646111f, -0.11793169f, 
    0.04678787f, 0.08664002f, -0.14887033f, 0.12365147f, -0.46435618f, -0.01223740f, 0.00805321f, 0.12708108f, 
    0.02806829f, 0.15480837f, 0.01495782f, 0.06531539f, 0.06475238f, 0.04570218f, 0.08335821f, 0.23011290f, 
    -0.38986725f, -0.12115144f, 0.41826370f, 0.10625296f, 0.08517279f, -0.12972504f, -0.28277081f, 0.06720925f, 
    -0.07560001f, -0.20424201f, -0.19950017f, -0.17674650f, -0.02554909f, -0.17404173f, 0.05376010f, 0.12763222f, 
    0.08019715f, 0.16325152f, 0.02285603f, -0.09583094f, -0.08369440f, -0.07386672f, 0.05223420f, -0.01292409f, 
    0.08253388f, 0.07099799f, 0.12973315f, 0.16383016f, 0.12031596f, 0.00957770f, 0.02162700f, -0.28843927f, 
    0.09657751f, -0.00740451f, 0.05080780f, 0.07129405f, 0.48786858f, 0.11919639f, -0.15143314f, -0.25957650f, 
    -0.03976716f, -0.07293007f, -0.01089231f, -0.07530338f, 0.03769426f, 0.01765447f, -0.10230948f, -0.20509829f, 
    0.12275607f, 0.09963994f, 0.12629004f, 0.14284049f, 0.09931444f, 0.12929460f, -0.05660923f, -0.07816528f, 
    0.11640985f, 0.04276657f, 0.03276594f, 0.18957742f, 0.36324358f, -0.25939623f, 0.39950478f, -0.10194845f, 
    -0.08044782f, 0.16038741f, -0.08237982f, -0.20476809f, 0.16121221f, 0.13263445f, 0.06096587f, 0.24085043f, 
    0.14217113f, -0.01368069f, -0.01212579f, -0.04404078f, 0.04265119f, -0.13061081f, -0.15550932f, 0.06399683f, 
    -0.38315225f, -0.07899361f, -0.31080917f, -0.40765762f, 0.14680775f, 0.10753720f, 0.09961736f, 0.17537180f, 
    -0.05992183f, 0.13960297f, 0.11826897f, 0.21269891f, -0.20555431f, -0.10977332f, -0.05342466f, -0.07909641f, 
    -0.08093007f, 0.05595566f, -0.39636385f, 0.04558634f, -0.02119715f, 0.18369699f, -0.07375892f, -0.26540479f, 
    -0.05587417f, -0.23776425f, -0.17229840f, -0.22810759f, 0.13693663f, -0.21814245f, -0.00093211f, 0.11420744f, 
    -0.05208643f, -0.07516586f, 0.12457707f, 0.03192391f, 0.14367610f, 0.04719331f, 0.20002654f, 0.13166802f, 
    -0.11202475f, -0.05276080f, 0.02066973f, 0.00932017f, 0.09805729f, 0.01996197f, 0.00230574f, 0.15971477f, 
    -0.07239649f, -0.08074727f, 0.08515453f, 0.04612657f, 0.15924527f, 0.06274439f, -0.02905536f, -0.03109284f, 
    0.17910692f, 0.02540564f, -0.31332806f, -0.13253136f, 0.12853687f, -0.01302205f, -0.11787302f, -0.02224162f, 
    -0.17294131f, 0.16112779f, -0.38895321f, 0.19968565f, 0.16192040f, -0.22350793f, -0.17422675f, -0.10489979f, 
    -0.36080071f, -0.16625935f, -0.43298313f, -0.36092916f, 0.44532746f, 0.09230994f, 0.03014363f, 0.00978093f, 
    -0.12051564f, 0.02512662f, 0.16344921f, 0.03640547f, 0.05732614f, -0.05653691f, 0.10012844f, -0.03373366f, 
    -0.54536879f, 0.31365120f, 0.10329259f, -0.01494851f, 0.25206763f, 0.03876015f, -0.03529938f, 0.15978676f, 
    -0.04804758f, 0.12890735f, 0.05901504f, 0.03876372f, -0.11909094f, -0.17837754f, -0.07122066f, -0.01549239f, 
    0.03859914f, -0.07344067f, 0.02468647f, -0.01265263f, -0.12416508f, 0.08478945f, 0.14199641f, 0.23030986f, 
    -0.20385970f, 0.06517024f, 0.14724796f, -0.04026690f, 0.00022006f, 0.03624029f, 0.02973749f, 0.01585934f, 
    0.03186752f, 0.16361843f, -0.10839336f, -0.08430234f, -0.21812506f, -0.03450422f, -0.05783458f, 0.10221388f, 
    0.09665864f, 0.03959801f, 0.03179241f, -0.04265758f, 0.04342957f, -0.02600401f, 0.12058493f, 0.07931280f, 
    0.01028521f, 0.20711420f, -0.09008395f, -0.09309041f, 0.01935581f, -0.02421604f, -0.02524831f, 0.08267886f, 
    0.14779808f, 0.08798409f, 0.03803943f, 0.11718556f, 0.26374519f, -0.25942516f, -0.02879974f, 0.33130640f, 
    0.17812526f, 0.03503346f, 0.04854688f, 0.24757463f, 0.07940485f, 0.10306744f, -0.04701738f, 0.10191374f, 
    -0.00277453f, -0.15081131f, -0.00248991f, -0.18090694f, -0.04724241f, 0.00468999f, -0.02570970f, -0.03336253f, 
    0.01543921f, -0.06484819f, -0.07962925f, -0.13761896f, 0.01208923f, 0.01881838f, -0.09312177f, -0.24177311f, 
    -0.09939568f, -0.02024548f, -0.08590057f, 0.06502869f, 0.01204020f, -0.04089255f, 0.05862374f, -0.07301696f, 
    0.41744614f, -0.20558633f, -0.17559391f, 0.28668252f, 0.14684081f, 0.13053724f, 0.12267313f, -0.02835031f, 
    -0.06426935f, 0.09163624f, 0.13849364f, 0.12386901f, -0.17887513f, -0.08471398f, 0.20037472f, -0.00208754f, 
    0.26702276f, -0.01175187f, 0.04619776f, 0.06276792f, 0.14082524f, -0.04750287f, -0.04322045f, -0.03479157f, 
    0.15510516f, 0.42238632f, -0.19622979f, 0.18406244f, 0.17922682f, -0.01347512f, 0.06180111f, 0.01488784f, 
    0.00645033f, -0.06239932f, -0.07818577f, -0.11944700f, 0.01929454f, -0.06264310f, -0.05514116f, -0.01456400f, 
    0.04760854f, -0.04558314f, -0.07806726f, -0.03055130f, -0.04766589f, 0.01201909f, 0.15602495f, 0.19435424f, 
    -0.08568961f, -0.13546558f, -0.05582077f, -0.02727957f, -0.03035029f, -0.06727888f, -0.03543772f, -0.00481772f, 
    0.17962137f, 0.13932669f, 0.15467794f, 0.09124790f, 0.06664742f, -0.03557672f, -0.01502735f, 0.09689781f, 
    -0.00683682f, -0.02203866f, 0.09452574f, 0.18208954f, -0.03409072f, 0.06733231f, -0.02446534f, -0.02419310f, 
    0.00823985f, 0.02342108f, -0.06897117f, -0.22696303f, 0.03106036f, -0.05055208f, 0.06487899f, 0.13542064f, 
    0.09987205f, 0.05018972f, 0.01215676f, -0.06189753f, 0.11012535f, -0.09901243f, -0.03537922f, 0.01760286f, 
    -0.09975752f, -0.21765891f, 0.15087882f, 0.16736257f, 0.02020777f, 0.08678868f, 0.18758981f, 0.02068652f, 
    -0.37051046f, 0.08832113f, 0.24598689f, 0.03421924f, 0.01850410f, 0.01201450f, 0.09292945f, 0.03765162f, 
    0.01048135f, -0.02351795f, 0.19288826f, -0.01666403f, -0.31428912f, 0.26121542f, 0.28834578f, -0.07177690f, 
    -0.00015816f, 0.00248431f, 0.08618852f, 0.16861014f, -0.04387159f, 0.05725423f, 0.01683908f, 0.14579946f, 
    0.00580569f, -0.19521816f, 0.05909851f, -0.04832323f, 0.04325488f, 0.00350136f, -0.00486556f, 0.05222793f, 
    0.05112496f, -0.03919574f, 0.01276840f, -0.12223949f, 0.47338688f, -0.08886451f, 0.00009708f, -0.04965341f, 
    0.16189465f, 0.07049942f, 0.03450798f, 0.02525798f, 0.09549110f, -0.00930959f, 0.04723507f, 0.10956391f, 
    -0.14164473f, -0.00099612f, 0.01433211f, 0.14484186f, -0.01830067f, -0.07733940f, 0.11762454f, -0.02065560f, 
    0.01784137f, 0.08800541f, 0.03252118f, -0.00554837f, -0.19577958f, -0.23389705f, -0.01764583f, 0.11309255f, 
    0.10476191f, 0.01800933f, -0.14603163f, -0.00212705f, 0.19951457f, -0.11242829f, 0.04597700f, 0.06172640f, 
    -0.35689458f, -0.23841229f, 0.14213939f, 0.12873977f, -0.07788583f, -0.01932629f, 0.04458726f, -0.00733344f, 
    0.12977599f, 0.11797373f, 0.03116003f, 0.02587874f, -0.05863146f, -0.16745956f, 0.12799774f, 0.29813609f, 
    0.04653247f, 0.03898591f, -0.07144038f, 0.20903064f, 0.10586172f, 0.19095440f, 0.11915027f, 0.06801623f, 
    0.10649385f, 0.10419739f, -0.11832044f, 0.02091057f, 0.08910601f, -0.01979308f, 0.03817847f, 0.06457249f, 
    -0.08905528f, -0.01147202f, -0.04970468f, -0.04590750f, -0.26356643f, -0.09972803f, 0.19112602f, 0.36943996f, 
    -0.04990340f, 0.00785159f, 0.07088996f, 0.01773945f, 0.03907027f, 0.02264028f, -0.03155003f, -0.02906029f, 
    -0.28442815f, 0.32042897f, -0.19164599f, 0.18036880f, 0.14296548f, -0.01136333f, 0.07431446f, -0.13773514f, 
    0.13868272f, 0.01291886f, -0.08960076f, 0.08388996f, -0.13036139f, -0.01473716f, 0.12192090f, 0.04575942f, 
    -0.04302425f, -0.02683408f, 0.04820818f, 0.04522235f, 0.23014911f, 0.12975127f, 0.13705680f, 0.05659326f, 
    -0.37986788f, -0.15116379f, 0.00449410f, 0.09516568f, -0.08357651f, -0.14903355f, 0.00364709f, -0.01471709f, 
    -0.00918087f, 0.08520382f, 0.13232565f, 0.08999749f, -0.20630708f, 0.29837570f, 0.07166042f, 0.06145969f, 
    0.07310660f, -0.05816003f, 0.00971638f, -0.11971458f, 0.21706407f, 0.12462306f, -0.01838218f, 0.11616244f, 
    0.03793660f, -0.00288637f, -0.19652387f, -0.08163031f, 0.24272271f, -0.02203895f, -0.05626413f, 0.11803211f, 
    0.03617322f, 0.01059603f, 0.04043335f, 0.11313055f, 0.23562746f, 0.07493687f, 0.14384907f, 0.17934181f, 
    0.01672503f, -0.13036275f, -0.07259128f, -0.09169485f, -0.03156902f, 0.03428559f, 0.04035087f, -0.00740168f, 
    0.01188385f, 0.42486188f, -0.12204985f, -0.17192642f, 0.11268111f, 0.03839508f, 0.03940840f, 0.15094040f, 
    0.04942071f, -0.04416915f, -0.05599835f, 0.07787436f, 0.15894425f, 0.12137412f, -0.16131632f, -0.29186255f, 
    0.11364327f, -0.17771424f, 0.00399883f, -0.11590937f, -0.03570030f, -0.09601189f, -0.10069828f, -0.01357058f, 
    -0.07246356f, -0.09526515f, 0.11173093f, 0.11097138f, 0.10716873f, 0.23538126f, 0.05408104f, 0.01265213f, 
    0.01061162f, 0.03691423f, 0.02870418f, 0.08391643f, 0.22302528f, -0.32197613f, -0.03441554f, -0.16664921f, 
    0.02701545f, -0.01226353f, 0.02161534f, 0.06529359f, 0.12520498f, -0.11116549f, 0.17124148f, -0.01036145f, 
    0.18454342f, -0.05171563f, 0.07760396f, 0.10965293f, -0.03152825f, -0.06222808f, -0.00936820f, -0.06238066f, 
    -0.09891155f, -0.05917059f, -0.20600678f, -0.28391153f, 0.07493515f, -0.13513175f, 0.17292604f, -0.05506000f, 
    0.09634664f, 0.08315523f, -0.16314033f, -0.09486710f, 0.14539769f, -0.01825826f, 0.04813641f, -0.01782464f, 
    -0.05479789f, 0.26029864f, 0.28925970f, 0.08407273f, -0.05512235f, -0.11180102f, -0.13968749f, 0.00714209f, 
    -0.06472098f, -0.06060924f, -0.10799585f, 0.07128548f, 0.20802140f, -0.13350150f, 0.11577386f, -0.07647042f, 
    -0.06623208f, -0.06767421f, 0.05064664f, -0.04954696f, 0.14522476f, 0.19241093f, -0.18404213f, 0.09940059f, 
    0.26272908f, 0.11743189f, -0.04919654f, 0.10007783f, 0.16110814f, -0.02032740f, -0.03352225f, -0.22810724f, 
    0.04793312f, 0.04754788f, -0.03186837f, 0.26065937f, -0.17110057f, -0.17831098f, -0.11854622f, 0.13189338f, 
    0.13892788f, 0.16673023f, 0.07778583f, 0.13031422f, -0.11180341f, -0.00338543f, 0.06770737f, -0.01089283f, 
    -0.04467789f, 0.22608103f, -0.09218951f, 0.13246381f, 0.10563451f, -0.00605865f, 0.00514099f, 0.16091804f, 
    0.06440014f, -0.03421166f, 0.08956314f, 0.04793889f, 0.34629798f, 0.05111894f, -0.04918997f, -0.28997460f, 
    -0.14426447f, -0.14068109f, 0.06095815f, -0.03018603f, -0.02303188f, 0.08194660f, -0.01939374f, 0.07494603f, 
    0.12643892f, 0.05795345f, 0.01156678f, -0.03609852f, -0.08136134f, -0.10366405f, -0.07795428f, -0.14814144f, 
    0.08188814f, 0.08682818f, 0.14528471f, 0.05273844f, -0.08757699f, 0.00738784f, 0.09368119f, -0.07232312f, 
    0.12865202f, -0.04272434f, -0.06381170f, 0.08037300f, -0.13260505f, 0.05062975f, -0.00126365f, 0.07142913f, 
    0.04830691f, 0.16517138f, -0.00553085f, 0.00150016f, -0.10853380f, -0.09962904f, -0.03183422f, 0.09605538f, 
    -0.11567760f, 0.09032726f, 0.08196810f, -0.12600967f, 0.03756768f, -0.03278071f, 0.13038400f, 0.07720301f, 
    -0.05240630f, -0.04697660f, -0.15271911f, 0.00205026f, -0.16259362f, -0.12105115f, -0.02080034f, 0.03452889f, 
    0.05001372f, -0.32622948f, 0.00382205f, -0.11169888f, -0.04118663f, 0.05057690f, 0.18859853f, 0.00946066f, 
    0.04956690f, 0.04134224f, 0.23251556f, -0.13631777f, -0.09094308f, -0.21288686f, -0.12308679f, -0.09791312f, 
    -0.02406449f, 0.11129607f, 0.23125076f, -0.08328831f, -0.01962337f, -0.09162547f, -0.06247379f, 0.07335649f, 
    0.03624360f, 0.13403307f, 0.09510767f, -0.07732692f, 0.04235747f, -0.15368362f, -0.12561513f, -0.07479095f, 
    0.05965464f, 0.00707063f, 0.03349607f, -0.02619911f, 0.22683421f, -0.04979172f, -0.20574951f, 0.16201590f, 
    0.15523456f, -0.11406297f, 0.03093383f, -0.07467434f, 0.03915736f, 0.00573675f, 0.09593636f, 0.14817069f, 
    -0.15436308f, -0.23822421f, -0.07342741f, 0.11950887f, 0.06222441f, 0.19471717f, 0.04946143f, 0.29955405f, 
    0.14808483f, 0.09529128f, 0.04172170f, -0.01891694f, 0.12295286f, 0.02918363f, -0.10147504f, -0.14527291f, 
    -0.00225826f, 0.00347411f, -0.08839781f, 0.04955294f, 0.07959626f, 0.06178322f, 0.10609182f, 0.19737396f, 
    -0.01505835f, -0.06998152f, 0.08286234f, 0.09354865f, 0.04876510f, -0.02234457f, 0.08511887f, 0.13736551f, 
    0.02696906f, 0.02178626f, 0.06480791f, 0.02183227f, 0.15152992f, -0.14348599f, -0.01815275f, -0.02057311f, 
    0.09458203f, -0.14306371f, -0.01388570f, -0.00239792f, 0.10012420f, 0.14174999f, -0.03040709f, 0.14359827f, 
    0.07413935f, 0.31137836f, -0.16405097f, -0.00671864f, -0.14149377f, -0.09082412f, -0.01769169f, -0.16273625f, 
    0.04826108f, 0.03454306f, 0.06393775f, 0.01250532f, -0.09822335f, 0.13362329f, 0.16669634f, 0.15694135f, 
    0.08870309f, -0.04943769f, 0.09995592f, 0.02653849f, 0.03342186f, -0.00069376f, -0.00564547f, 0.03711398f, 
    -0.13005568f, 0.18041007f, -0.03389547f, 0.22659634f, 0.00022845f, 0.14783113f, -0.24589530f, 0.28933567f, 
    0.14522167f, 0.16535360f, 0.02375882f, 0.03988204f, 0.02601451f, 0.06067133f, -0.08126681f, 0.05467238f, 
    0.02090753f, 0.08824676f, -0.02483166f, 0.10545173f, -0.02537397f, -0.02230862f, -0.00248528f, -0.13595694f, 
    0.11656222f, 0.17452443f, 0.08920801f, -0.04164194f, 0.03998012f, -0.05384076f, 0.02248836f, 0.00840517f, 
    0.05540301f, -0.05614152f, 0.00419638f, 0.14034496f, 0.09786728f, -0.05526657f, 0.23777312f, -0.15825765f, 
    -0.13933124f, 0.05606319f, -0.01392511f, 0.13406065f, -0.01034732f, 0.12597431f, 0.18534021f, 0.06121840f, 
    -0.02334521f, 0.10619716f, -0.04440652f, 0.07658649f, -0.02872522f, 0.05049294f, 0.00637627f, -0.11341732f, 
    0.16441011f, 0.04312349f, 0.11777709f, 0.14245720f, 0.15066816f, -0.29747999f, -0.36567876f, -0.10929022f, 
    0.06520944f, -0.14816388f, 0.08853462f, -0.20139425f, -0.04922385f, 0.02827780f, -0.02521272f, 0.10014054f, 
    0.07627456f, 0.40252087f, -0.04798577f, -0.07455712f, -0.02598898f, 0.01996875f, 0.00048537f, -0.09812646f, 
    -0.09187362f, 0.04554612f, 0.03615296f, 0.06497747f, -0.23180915f, 0.23014207f, 0.03017572f, -0.30797014f, 
    -0.12926009f, 0.11720480f, -0.13254379f, 0.03095845f, -0.15646787f, -0.08901917f, 0.00095632f, -0.05335455f, 
    0.14435445f, 0.07261226f, -0.05985114f, 0.08585007f, 0.06543933f, 0.09888114f, -0.04686080f, -0.17039029f, 
    0.10103414f, -0.01690150f, 0.12931250f, -0.04993005f, -0.20267139f, 0.03657007f, -0.08096221f, 0.12758957f, 
    0.05062787f, 0.04337204f, -0.02613234f, -0.02239317f, 0.05046322f, 0.10501251f, 0.07677064f, -0.02573747f, 
    -0.08168510f, 0.27044499f, -0.03899070f, -0.07482585f, -0.12045423f, -0.10440660f, -0.09740807f, -0.08725766f, 
    0.08109365f, 0.06747771f, -0.30611399f, -0.08879514f, -0.91139501f, 0.40176395f, -0.09949116f, -0.06645792f, 
    -0.15419438f, 0.06569978f, 0.02636825f, 0.31110844f, 0.04355196f, -0.00138537f, 0.15762466f, 0.05072854f, 
    -0.13102463f, -0.07237560f, 0.02706362f, 0.04315332f, -0.23501065f, -0.13151464f, -0.08391803f, 0.01018130f, 
    0.08598329f, 0.05511934f, 0.06610273f, -0.06447257f, -0.13542527f, 0.29871070f, 0.03305275f, 0.01276444f, 
    -0.18993552f, 0.00161774f, -0.03075519f, -0.16094482f, -0.01324983f, -0.04156971f, 0.11270758f, 0.09885001f, 
    0.33063659f, 0.05744652f, 0.10025334f, 0.00433200f, -0.10172009f, 0.12759650f, 0.07310580f, 0.11420372f, 
    -0.12488817f, 0.10848927f, -0.11679827f, -0.08158095f, 0.08732150f, 0.07842291f, -0.18008360f, -0.11660046f, 
    0.28397357f, 0.05000430f, 0.07663194f, 0.09752800f, 0.07679657f, 0.14436245f, -0.02662409f, 0.01168493f, 
    -0.09242091f, -0.29787648f, 0.27160960f, 0.25788903f, 0.01386750f, 0.01403050f, 0.05288518f, -0.03031922f, 
    -0.17085844f, -0.04285618f, -0.07657921f, 0.02263387f, 0.26421174f, 0.47681546f, 0.06241629f, -0.00152139f, 
    -0.12957181f, -0.01693420f, -0.12693913f, -0.04754775f, -0.07442997f, 0.04358990f, -0.01522097f, 0.04427668f, 
    -0.08469589f, -0.13491003f, -0.01475336f, -0.09311836f, -0.13061732f, -0.11397961f, -0.09310101f, -0.05974338f, 
    -0.02774622f, 0.00428927f, -0.03594045f, -0.04155403f, -0.10968743f, -0.03981719f, -0.20562726f, -0.05406541f, 
    -0.10170027f, -0.03455725f, -0.02403572f, 0.00688438f, -0.07165250f, -0.00513924f, 0.16226102f, 0.10519148f, 
    0.02210392f, 0.01459692f, -0.08575344f, 0.05166172f, -0.03244360f, -0.09962989f, -0.05188186f, 0.02266463f, 
    0.06018350f, 0.08513798f, -0.10018499f, 0.04941258f, 0.14975049f, 0.05147143f, -0.08301008f, 0.16594093f, 
    -0.02970767f, 0.00163588f, 0.07402151f, -0.00399566f, 0.13012411f, 0.04013905f, 0.04943217f, 0.02404164f, 
    -0.06373021f, 0.36402494f, -0.05088053f, 0.04927719f, 0.02298436f, 0.03138985f, 0.02572011f, -0.04021063f, 
    0.09104957f, 0.17907302f, -0.04607371f, 0.05948959f, -0.10099863f, -0.00067821f, -0.21086994f, 0.31878477f, 
    0.16728909f, 0.01213633f, -0.08092423f, 0.06065698f, -0.01473826f, -0.04198616f, 0.04740943f, 0.05721946f, 
    -0.44518155f, -0.12797987f, -0.01746801f, 0.06947108f, -0.17221579f, -0.08768668f, -0.05614210f, -0.08319881f, 
    -0.01077116f, 0.07193340f, -0.05665774f, 0.15523380f, 0.18637215f, 0.07888687f, 0.01685609f, -0.00089462f, 
    -0.18566743f, 0.02490188f, 0.16282316f, 0.03348447f, 0.01456642f, 0.11555000f, 0.02078820f, -0.17317176f, 
    0.05368574f, 0.31352383f, 0.10402654f, 0.14116533f, 0.07769026f, -0.00370137f, 0.01740611f, -0.06045500f, 
    -0.05615149f, 0.02437251f, 0.03617491f, 0.03147786f, 0.16715409f, 0.20705864f, 0.06378675f, -0.23416832f, 
    0.05345937f, -0.06482659f, 0.02062116f, 0.01265866f, 0.04972058f, 0.13203231f, 0.09039153f, 0.08007123f, 
    -0.06842310f, 0.16748464f, 0.08745012f, 0.01645488f, 0.08647318f, 0.11384918f, -0.01291905f, 0.08983743f, 
    0.02826850f, -0.04941601f, -0.07611118f, 0.05794511f, -0.22855981f, 0.21344429f, 0.12193091f, 0.01349675f, 
    -0.03270372f, -0.04593187f, -0.05967141f, -0.04461131f, -0.07077827f, -0.02460822f, -0.15278989f, 0.11536890f, 
    -0.02148304f, -0.14251232f, 0.09246563f, 0.15024874f, -0.12015910f, 0.02716754f, -0.09000634f, 0.00505240f, 
    0.03550825f, -0.01174751f, 0.06586123f, 0.06867959f, 0.09110359f, 0.06104845f, 0.00698317f, 0.18172187f, 
    0.23865362f, 0.23432288f, 0.09554348f, 0.13988723f, 0.00052467f, -0.09595889f, 0.04923904f, 0.04193386f, 
    0.56179261f, -0.42623082f, 0.11987659f, 0.03152975f, -0.04869295f, -0.14713699f, 0.12691592f, 0.04970597f, 
    0.05186032f, 0.08759311f, 0.12125451f, 0.03210158f, 0.08878652f, -0.01903540f, -0.01059313f, 0.02376905f, 
    0.11243441f, -0.02332748f, 0.03829090f, 0.06555797f, -0.04948097f, -0.10014428f, 0.07546890f, 0.04629283f, 
    0.04562628f, 0.07111849f, -0.03774721f, 0.00995959f, 0.08453056f, 0.14787664f, -0.01513033f, 0.12838258f, 
    -0.06633587f, -0.11996675f, -0.10468650f, 0.05877483f, 0.27788275f, 0.06308018f, 0.31492949f, 0.05788703f, 
    0.08976898f, -0.15207373f, -0.02322823f, 0.11250298f, -0.02191546f, 0.02815649f, -0.06678724f, 0.07251712f, 
    0.05931485f, 0.06921360f, 0.06351954f, -0.00272797f, 0.02943079f, 0.06325033f, -0.02533177f, -0.12205828f, 
    0.02800881f, 0.02347098f, 0.05190180f, 0.16608693f, 0.08374906f, 0.08073172f, -0.19523446f, 0.11722501f, 
    0.00816633f, 0.13564648f, 0.18632704f, 0.03617088f, 0.11740583f, -0.25427493f, -0.00274451f, 0.08888192f, 
    0.05228613f, -0.33708945f, 0.18563704f, -0.11657934f, -0.15316832f, 0.11193395f, -0.23488545f, 0.00208544f, 
    0.12598211f, 0.22290929f, 0.06056621f, -0.02899107f, 0.15308931f, -0.09976471f, 0.33824319f, 0.21040572f, 
    -0.23944360f, 0.07751262f, -0.10007535f, -0.17784001f, 0.13381846f, 0.23442915f, 0.05107691f, 0.23171917f, 
    0.18871796f, 0.16801114f, 0.10156772f, -0.20019522f, -0.06574458f, -0.02839798f, 0.15098682f, 0.18075567f, 
    -0.02587439f, -0.07305174f, -0.06731344f, -0.04222458f, 0.22974914f, 0.00122846f, 0.12183070f, 0.12479035f, 
    -0.21276325f, -0.11206012f, -0.10597109f, -0.12715909f, 0.04228925f, -0.00007837f, 0.02846962f, 0.14298826f, 
    -0.02598665f, -0.11342692f, 0.08013842f, -0.07007216f, -0.03469135f, -0.00167398f, 0.04958950f, 0.01441433f, 
    -0.04182563f, 0.19284563f, 0.21159369f, 0.23627335f, 0.16039532f, -0.35167494f, -0.11755607f, -0.40938494f, 
    0.15264951f, -0.04852724f, 0.20822264f, -0.12375845f, -0.07034464f, -0.04299024f, -0.24126041f, 0.02095344f, 
    -0.04189842f, -0.32273090f, -0.27021542f, 0.25435811f, 0.12893872f, 0.18642980f, 0.20914592f, -0.06360133f, 
    0.02506009f, -0.09858867f, 0.01050427f, -0.05116070f, 0.08948885f, -0.22054783f, 0.33264548f, -0.08229245f, 
    0.06839885f, 0.02108122f, -0.10822459f, -0.23566066f, -0.03049036f, -0.09577404f, 0.23858926f, 0.04866913f, 
    -0.20704938f, 0.10346597f, -0.12319615f, 0.03175374f, -0.14587450f, 0.01560857f, -0.05087432f, 0.03891856f, 
    0.08388642f, -0.20862050f, -0.05285304f, 0.00674729f, 0.00507548f, 0.06647845f, 0.11717533f, -0.23955767f, 
    -0.04009817f, 0.04016478f, 0.12245247f, -0.01454448f, 0.15258680f, -0.05524614f, 0.01056289f, 0.01963238f, 
    0.09152585f, 0.36018807f, -0.39599153f, 0.18691655f, -0.10947041f, 0.00071590f, 0.19207311f, 0.11036095f, 
    -0.04976183f, -0.21890302f, -0.04886806f, -0.03826008f, 0.09809752f, -0.15984677f, 0.40712073f, 0.15879187f, 
    0.05244332f, 0.02233725f, -0.28611287f, -0.11535137f, 0.06005821f, 0.13023674f, 0.13478597f, 0.10056611f, 
    0.00066030f, 0.03219470f, -0.04669321f, 0.12777939f, 0.06003166f, 0.13288832f, 0.10288215f, 0.00195666f, 
    0.16557002f, 0.10181627f, 0.20668489f, 0.19578558f, 0.05563982f, -0.34857500f, -0.11932789f, -0.04804363f, 
    0.23614922f, 0.11344494f, 0.06124520f, -0.08449830f, 0.07639443f, 0.12676476f, -0.18760151f, -0.05999253f, 
    -0.37443158f, -0.02920781f, -0.04337640f, 0.15378381f, 0.09133986f, -0.01319247f, 0.26469934f, -0.01851990f, 
    0.28711745f, 0.00239156f, -0.06598959f, 0.12833244f, -0.04938353f, -0.04055968f, -0.11380041f, 0.00229487f, 
    -0.02535347f, 0.00356094f, 0.21580216f, 0.03857252f, 0.11943659f, 0.09469830f, 0.07319284f, 0.15950200f, 
    0.27368873f, -0.03256009f, 0.00778385f, -0.00813614f, 0.00302705f, -0.16324607f, -0.25749335f, 0.02944838f, 
    0.00334166f, -0.01246605f, 0.00336851f, 0.07994741f, -0.05040480f, -0.05133984f, 0.21363969f, -0.22073068f, 
    0.00688975f, -0.07149217f, -0.08191162f, 0.20040575f, 0.06369376f, 0.13466716f, 0.09883492f, 0.11760274f, 
    -0.32582441f, -0.22426048f, -0.36479560f, 0.19298360f, 0.16160229f, 0.19006428f, 0.27017921f, -0.17625928f, 
    0.00607144f, -0.09224975f, -0.10220632f, -0.10981146f, -0.39025795f, 0.02807278f, 0.03036303f, -0.03279223f, 
    0.13796790f, -0.09856240f, -0.08715109f, -0.01679154f, -0.05448407f, -0.05406021f, 0.00885097f, 0.06527290f, 
    0.39591339f, 0.22574531f, 0.20933105f, -0.16207445f, 0.10366646f, -0.02711248f, 0.08986884f, 0.01286046f, 
    0.12827453f, -0.09277559f, -0.01082724f, 0.06681093f, 0.06357492f, 0.20585772f, 0.40879178f, 0.13166393f, 
    -0.12447134f, 0.06247474f, -0.19557618f, -0.21642700f, 0.04992021f, 0.04126205f, -0.03376138f, -0.05576923f, 
    0.08746161f, 0.02988712f, 0.13263251f, -0.01291800f, -0.02908659f, 0.11261065f, 0.15914291f, 0.01639814f, 
    0.07564031f, 0.09357192f, 0.01564853f, 0.15969966f, 0.15315455f, -0.31546772f, 0.37706533f, 0.02368932f, 
    0.01195579f, 0.11254789f, 0.00660114f, -0.18308258f, 0.08771094f, 0.10702842f, 0.23647153f, 0.10989285f, 
    -0.19795825f, -0.38191569f, 0.16207471f, -0.04720528f, 0.21376707f, 0.10763124f, -0.06172293f, 0.02329254f, 
    -0.33377936f, -0.11744417f, -0.14549610f, -0.08269326f, 0.19247454f, 0.00242722f, 0.07167544f, 0.09217235f, 
    -0.01266044f, 0.06308597f, -0.01444234f, 0.16351916f, -0.06830048f, -0.02684414f, 0.05270024f, 0.00414622f, 
    -0.24065275f, 0.29879352f, -0.37595558f, -0.34920305f, -0.13480628f, 0.06533213f, 0.10511582f, -0.10541017f, 
    0.07072850f, -0.28092715f, -0.05967830f, -0.20583072f, 0.07873814f, -0.11147954f, -0.00088696f, 0.01373400f, 
    -0.03788609f, -0.02916964f, 0.03445356f, 0.06057673f, 0.10377306f, 0.01310538f, -0.01693445f, 0.25493655f, 
    -0.12131911f, -0.00181661f, -0.08526252f, -0.07923120f, 0.00138351f, 0.03207757f, 0.01298678f, 0.09401591f, 
    0.01543746f, 0.05740244f, 0.09295034f, 0.13344009f, 0.31704655f, -0.05271002f, -0.24844506f, -0.09598505f, 
    -0.10773147f, -0.06317978f, -0.19174257f, -0.23395678f, 0.08425819f, 0.06578547f, -0.22901674f, 0.02138959f, 
    -0.36376995f, 0.14857571f, -0.16043746f, -0.01726192f, 0.23870647f, -0.17440712f, -0.00554848f, -0.11591407f, 
    -0.20600581f, -0.11451646f, -0.25167757f, -0.21443225f, 0.32116485f, 0.14075322f, 0.33394521f, 0.14924504f, 
    -0.07531721f, -0.22105415f, -0.02793214f, -0.01564043f, 0.05053977f, 0.08313971f, 0.04235426f, -0.01160766f, 
    -0.42198744f, -0.19823076f, 0.27509233f, 0.12406352f, 0.02763429f, 0.06910764f, -0.12982942f, 0.06337291f, 
    -0.14576173f, 0.21804303f, -0.00965117f, -0.03448889f, -0.17757116f, -0.32150701f, 0.25633037f, 0.17513826f, 
    -0.08127212f, -0.13225994f, -0.05424525f, -0.00983178f, 0.06958470f, 0.12275764f, 0.06838974f, 0.24112581f, 
    -0.04000904f, 0.23559567f, 0.11272810f, -0.17573358f, -0.08347912f, -0.04009306f, -0.09611876f, -0.04051999f, 
    -0.04589262f, 0.02023485f, -0.04072101f, -0.07436289f, -0.36750898f, -0.01173040f, -0.11810891f, -0.05640272f, 
    -0.00337632f, -0.05067160f, -0.01627468f, -0.03882579f, 0.12621863f, 0.04403334f, 0.09792209f, 0.06823276f, 
    0.02671491f, 0.16029106f, 0.07304307f, -0.01077982f, 0.06866035f, 0.04480412f, 0.05219414f, 0.07583466f, 
    0.15061426f, -0.08662698f, 0.07916071f, 0.15346107f, 0.32492658f, -0.22532630f, -0.01603672f, 0.24548006f, 
    0.01623435f, -0.21653712f, 0.20467439f, 0.21270671f, 0.02953721f, 0.11275082f, -0.16133727f, 0.07678758f, 
    0.45624247f, -0.04502420f, -0.07295941f, 0.22207330f, 0.08307485f, 0.11383624f, 0.12416321f, -0.00794829f, 
    0.09480359f, 0.00296006f, -0.01083062f, -0.06308145f, 0.09233970f, 0.09966512f, 0.07421906f, 0.05985991f, 
    0.08948250f, 0.02361413f, -0.06048512f, 0.01350162f, -0.02036524f, -0.18236326f, 0.15280220f, 0.00606834f, 
    -0.39399016f, -0.22704233f, -0.08705255f, 0.18830922f, 0.01510398f, -0.07830008f, 0.19602738f, 0.06124515f, 
    0.01718055f, 0.03470087f, -0.08887547f, 0.00585586f, -0.09681872f, 0.04108743f, 0.34093818f, -0.20181517f, 
    0.10703069f, -0.04009321f, -0.00022957f, -0.06250573f, 0.18936716f, 0.06955571f, -0.06072323f, 0.00932236f, 
    0.03150216f, 0.31079257f, -0.09477680f, 0.12406733f, 0.18290080f, 0.04719650f, 0.06797536f, 0.01847600f, 
    0.14461626f, 0.09314188f, -0.05985294f, -0.02200209f, -0.03656780f, -0.08668187f, -0.03103974f, 0.17634898f, 
    0.16378821f, 0.01280435f, -0.07969627f, 0.04233813f, 0.02964196f, -0.10196363f, 0.24836719f, -0.03869509f, 
    -0.04464108f, -0.06679610f, -0.08301571f, 0.05306976f, 0.02333177f, -0.02649094f, 0.04332348f, 0.02146137f, 
    -0.02377139f, -0.03481265f, 0.03872648f, 0.01444337f, 0.22665161f, -0.02102351f, 0.04930204f, 0.07053400f, 
    0.01815271f, 0.05162947f, 0.00806133f, 0.18784024f, -0.01742038f, 0.02966057f, 0.04805040f, -0.14892164f, 
    -0.09957108f, -0.03360802f, 0.10139105f, -0.07699051f, 0.04318967f, -0.05123020f, -0.02903013f, 0.06036020f, 
    0.14379549f, 0.02270015f, -0.04604835f, 0.06078714f, 0.08054268f, 0.05396355f, -0.03430079f, -0.07101853f, 
    -0.01952931f, -0.12349661f, 0.14968584f, 0.05626506f, -0.03862159f, -0.00155587f, 0.12562115f, 0.12041854f, 
    -0.14763895f, -0.04923980f, 0.11968858f, -0.10350768f, 0.09326278f, -0.02996891f, -0.15906999f, 0.11568291f, 
    -0.07037915f, 0.03330167f, 0.00053627f, 0.05379219f, -0.06638731f, 0.21136804f, 0.12059208f, -0.22740678f, 
    -0.06808512f, -0.10366711f, -0.11554348f, 0.22352216f, 0.01847302f, -0.00149609f, 0.07545845f, 0.06255393f, 
    0.13732930f, -0.09434916f, 0.05974896f, 0.03732398f, 0.12583071f, 0.05892316f, 0.07750000f, 0.04277923f, 
    0.06215915f, 0.00153846f, -0.04973886f, 0.02004715f, -0.12044755f, 0.14944859f, 0.24080397f, -0.01681331f, 
    0.11752975f, 0.15468904f, -0.01851814f, 0.08653057f, 0.11601243f, 0.01758210f, -0.04970720f, 0.09001775f, 
    0.16193451f, 0.28876153f, 0.21701975f, 0.03817866f, 0.08721775f, -0.17200828f, 0.14491251f, -0.17872529f, 
    -0.06944273f, -0.07948426f, 0.19046168f, -0.11985449f, -0.08208016f, -0.09518550f, 0.16985391f, 0.27553734f, 
    0.04619531f, -0.05249225f, -0.10094497f, -0.13533923f, 0.14765063f, -0.13489714f, -0.01572866f, -0.07422738f, 
    -0.18754807f, -0.01235197f, 0.17732874f, 0.02723046f, -0.11981437f, 0.03659530f, 0.00962540f, -0.17468470f, 
    0.01777766f, 0.01573093f, 0.02766880f, 0.04362595f, -0.07139024f, -0.33925247f, 0.27580607f, 0.21318142f, 
    -0.04196263f, -0.03014964f, -0.02343339f, 0.12489506f, -0.01708144f, 0.03247607f, 0.09642196f, 0.00645827f, 
    0.10580678f, -0.29139960f, 0.10021919f, 0.12023324f, 0.07355958f, 0.10217482f, -0.01676155f, 0.14527078f, 
    -0.09168123f, -0.03477618f, -0.05158698f, -0.04473078f, -0.04272179f, -0.04065199f, 0.22512811f, 0.11441323f, 
    -0.07131008f, 0.06044418f, 0.02452511f, -0.03986010f, 0.00784101f, 0.01764981f, 0.11907164f, 0.02731482f, 
    -0.39553398f, 0.15732019f, -0.19061331f, -0.16209501f, 0.10134190f, -0.05878782f, 0.32578722f, -0.14749038f, 
    0.21331580f, -0.02160508f, 0.07893165f, -0.09116922f, -0.09901024f, -0.02628854f, 0.05642706f, -0.13638319f, 
    -0.05163582f, -0.10883854f, 0.05076077f, -0.02033426f, 0.15455081f, -0.00408754f, 0.07472146f, -0.01641026f, 
    -0.53949064f, -0.10966756f, 0.04960201f, 0.05296981f, -0.16893230f, -0.06996766f, -0.00179126f, -0.01849148f, 
    -0.02179820f, 0.06946614f, 0.17052829f, 0.17906234f, -0.03026855f, 0.28223091f, -0.19423313f, 0.21221493f, 
    0.14118506f, 0.01517393f, 0.02099791f, -0.19209377f, 0.11300429f, 0.03831658f, -0.09316544f, -0.03022997f, 
    -0.04241073f, -0.06125009f, -0.05329832f, -0.07875397f, 0.20008078f, 0.07756968f, -0.04910029f, 0.17938572f, 
    -0.01750852f, -0.04968425f, -0.13395685f, 0.12203936f, -0.25145906f, 0.10190035f, 0.15466292f, -0.04377027f, 
    -0.07149655f, -0.07317843f, -0.15605816f, 0.13249873f, 0.00072317f, -0.09618229f, 0.08669166f, -0.07908995f, 
    0.02637490f, 0.02486548f, 0.02587810f, 0.03002678f, -0.00347261f, -0.00188705f, 0.00261468f, -0.02759797f, 
    -0.02734939f, -0.04911630f, 0.02109084f, 0.01097468f, -0.01099099f, 0.02775520f, -0.06133849f, -0.02390577f, 
    0.00079298f, 0.03642896f, -0.04036035f, 0.00961352f, -0.04314246f, -0.06172378f, -0.05231185f, -0.04089537f, 
    0.03102921f, -0.01727166f, 0.01274722f, -0.01416363f, -0.05052739f, -0.00815053f, 0.04717755f, -0.06016282f, 
    -0.03989873f, -0.03461156f, 0.01887064f, 0.00128502f, 0.03166520f, -0.03767187f, -0.04318718f, -0.06025092f, 
    -0.02040689f, -0.05994520f, -0.03326374f, 0.02529431f, 0.01216219f, -0.02215493f, -0.01673106f, -0.05196664f, 
    -0.03238546f, -0.05326738f, -0.05078873f, -0.06342559f, -0.00494225f, -0.06293130f, 0.01184326f, -0.05075846f, 
    0.05064732f, 0.03580524f, -0.04322742f, -0.03369132f, -0.02165123f, -0.04984299f, -0.04388209f, -0.02619708f, 
    -0.00948025f, 0.01083309f, 0.01681941f, 0.01177943f, 0.02386668f, -0.01830910f, -0.01360879f, 0.03141505f, 
    0.04606437f, -0.03754265f, -0.00761726f, 0.01656647f, 0.01150529f, 0.03154930f, -0.04434574f, 0.00676571f, 
    0.00999397f, -0.00310493f, -0.04793214f, 0.01032980f, -0.00905812f, 0.03259797f, -0.05220851f, -0.05560166f, 
    0.00305984f, 0.03384642f, 0.00616766f, 0.02676553f, -0.04768925f, -0.05239897f, -0.02498628f, 0.01979585f, 
    -0.05628208f, 0.00864053f, -0.04896272f, -0.04465469f, -0.05115292f, -0.01681877f, 0.02433521f, -0.01936271f, 
    0.02608353f, -0.02563776f, -0.00513921f, -0.03035716f, -0.03496421f, -0.02250254f, -0.01091168f, -0.01491667f, 
    -0.02531041f, -0.00076221f, -0.00300811f, -0.05645178f, 0.01381184f, -0.04148755f, -0.00101638f, -0.06153317f, 
    0.02534487f, -0.05317206f, -0.00499872f, -0.02386255f, -0.05266832f, -0.03971137f, -0.05121877f, 0.03400419f, 
    0.03291393f, 0.03228885f, -0.03109480f, -0.01795953f, 0.02949383f, 0.01299250f, 0.01153105f, -0.04488927f, 
    0.03625518f, 0.00303588f, -0.05384226f, -0.00523191f, -0.03986540f, -0.00175223f, -0.04011828f, -0.00552880f, 
    -0.04054468f, -0.04610792f, 0.01001050f, -0.04552124f, -0.03057655f, -0.02849105f, -0.03304496f, -0.06334890f, 
    -0.00711066f, 0.00803999f, 0.01333268f, -0.04393929f, -0.05564738f, -0.05074156f, 0.03586196f, -0.04318471f, 
    -0.05826634f, 0.01289153f, 0.00987821f, 0.03463404f, 0.00447633f, 0.02957554f, 0.00959798f, -0.01238254f, 
    0.01370655f, -0.00095892f, -0.01611409f, 0.01686152f, 0.02443628f, 0.03358224f, -0.06422769f, -0.04648174f, 
    -0.02722528f, -0.01157745f, 0.01125920f, 0.01293084f, -0.02799781f, -0.03892503f, -0.02428693f, -0.01553296f, 
    -0.04220509f, -0.03692303f, -0.06258302f, -0.00358406f, -0.04141322f, 0.01009986f, -0.01538744f, -0.01350717f, 
    -0.03154653f, -0.02941825f, -0.05497872f, 0.00036016f, -0.02887099f, 0.00204938f, 0.00771886f, -0.00789167f, 
    -0.02658736f, -0.06055450f, -0.02681337f, -0.02694438f, -0.00855398f, 0.02714785f, -0.03544924f, -0.01276074f, 
    -0.03844526f, -0.05616527f, 0.02317584f, -0.00553105f, -0.00252125f, -0.02848904f, -0.03308270f, 0.02968568f, 
    -0.00255923f, 0.01184358f, 0.01816463f, -0.03728076f, -0.02987719f, -0.02737377f, 0.03482660f, -0.03285203f, 
    -0.05327459f, -0.05442913f, -0.05120128f, -0.00399565f, -0.04343029f, 0.00380399f, 0.03417251f, 0.02370047f, 
    0.03625220f, 0.03046960f, -0.03851667f, -0.06490096f, 0.03416324f, -0.06432470f, -0.03762463f, -0.03172927f, 
    -0.03457274f, 0.03523109f, 0.02195786f, 0.00482789f, -0.04753042f, 0.01208003f, -0.04366149f, -0.04792010f, 
    0.01495751f, 0.02117948f, -0.01767374f, -0.03420196f, 0.02187000f, -0.03324644f, -0.02569220f, 0.01732360f, 
    -0.03658951f, -0.03209682f, -0.06233392f, 0.01677897f, -0.02868853f, -0.04478486f, 0.03047417f, -0.06194421f, 
    -0.01843512f, -0.05108011f, 0.00013596f, -0.01175946f, -0.05024606f, 0.00240867f, -0.04812063f, -0.02160782f, 
    -0.02989801f, -0.05904229f, 0.01460486f, -0.04107675f, 0.00399807f, 0.01707249f, 0.00467828f, 0.01750661f, 
    -0.06113397f, -0.00859690f, -0.04720132f, 0.01253243f, -0.03606643f, -0.03333768f, -0.02064045f, 0.03331808f, 
    -0.03057991f, 0.01145087f, -0.02581078f, -0.00315102f, 0.00500957f, 0.02826440f, 0.01975020f, -0.03173664f, 
    0.03303074f, -0.05955886f, -0.03799002f, -0.06303853f, 0.00968778f, -0.05796051f, 0.03591486f, -0.05766274f, 
    -0.00400259f, -0.00589688f, -0.01256299f, 0.00875055f, -0.03164809f, 0.02702539f, -0.03339805f, 0.00637741f, 
    -0.02453485f, -0.04773666f, -0.01560105f, -0.03028533f, -0.05988777f, -0.05456626f, -0.04819455f, 0.00446266f, 
    0.02811212f, 0.02355672f, -0.05123898f, 0.00385309f, -0.02499359f, -0.05137859f, -0.03865341f, -0.01575332f, 
    -0.01135107f, -0.03916974f, -0.05269371f, -0.05237217f, -0.03365605f, -0.03764287f, -0.03661369f, -0.02822800f, 
    -0.04173748f, -0.01537836f, -0.00812930f, -0.00116080f, -0.00480275f, 0.02580721f, -0.01880204f, -0.01034270f, 
    -0.02785758f, -0.03309923f, 0.03439270f, 0.03182779f, -0.01384027f, -0.06028670f, -0.05368210f, -0.01082619f, 
    0.00140482f, 0.03537040f, -0.05062473f, -0.05215071f, -0.04518574f, 0.03243673f, -0.05221582f, -0.01424304f, 
    -0.01390432f, -0.06162361f, 0.01939349f, 0.00386375f, -0.02272038f, -0.00649260f, -0.03818876f, -0.06173293f, 
    -0.05290505f, -0.04362085f, 0.03324996f, -0.01356263f, 0.00084679f, -0.06002367f, 0.00455992f, -0.00919593f, 
    0.02661913f, -0.06152267f, 0.03377331f, 0.01614198f, -0.03390242f, 0.00231870f, -0.04502814f, -0.04308951f, 
    -0.14042869f, 0.20122300f, 0.09222756f, 0.07835252f, 0.05632823f, 0.07972009f, 0.12477096f, 0.26275027f, 
    0.18162031f, -0.03613274f, -0.00559984f, 0.07822166f, -0.25464338f, 0.01448886f, -0.27330559f, -0.13737731f, 
    0.01814801f, -0.08517987f, 0.07466222f, -0.00095438f, -0.07844342f, -0.05489343f, -0.07934895f, -0.05585515f, 
    -0.09780614f, -0.04624128f, 0.21590139f, 0.26462054f, 0.12367686f, 0.19235650f, 0.14896658f, 0.02183569f, 
    0.04133021f, 0.06367367f, 0.01011166f, -0.01913920f, 0.06782892f, 0.13258511f, 0.03403859f, -0.11179558f, 
    0.07149261f, -0.02585366f, 0.01696064f, -0.01262035f, -0.09642869f, -0.09400726f, 0.02916703f, 0.05758411f, 
    0.23712949f, 0.17964864f, 0.04517905f, 0.11260181f, -0.04779785f, 0.01645691f, -0.10847597f, -0.08377127f, 
    0.02480907f, -0.08992756f, -0.31772774f, -0.07836615f, 0.15397079f, 0.09854200f, 0.19453803f, 0.06297527f, 
    -0.04718626f, 0.10738867f, -0.20212001f, -0.03727180f, 0.05253079f, 0.12889476f, 0.15114903f, -0.06603421f, 
    0.25258586f, 0.37769926f, 0.33552563f, 0.17456993f, -0.07127199f, -0.11887180f, -0.09588167f, -0.05350559f, 
    -0.09633003f, -0.00486297f, -0.04847018f, -0.01372812f, 0.22717236f, 0.00489213f, -0.12105374f, 0.08653293f, 
    -0.00868137f, -0.11712058f, 0.01076998f, 0.00053645f, 0.02312225f, 0.14906169f, -0.24210760f, 0.13585854f, 
    0.17151561f, 0.15558527f, -0.04926353f, 0.09707348f, 0.05336778f, -0.04388313f, 0.07762013f, -0.11830803f, 
    -0.00719063f, 0.05175459f, -0.06398385f, 0.15303789f, -0.18010539f, -0.18806294f, 0.03424275f, 0.26970306f, 
    -0.01915695f, -0.03325832f, -0.02842255f, 0.20324980f, -0.13884318f, -0.06851053f, -0.02846975f, -0.00476754f, 
    -0.06039425f, 0.07404769f, 0.10805928f, -0.09584584f, 0.22426537f, -0.00625826f, -0.11272815f, -0.12224898f, 
    0.08634602f, 0.04340184f, 0.10956270f, 0.03897209f, 0.14502411f, 0.00354160f, -0.08561375f, -0.02682251f, 
    -0.10673394f, -0.17239745f, 0.01775203f, 0.07545316f, 0.03630748f, 0.10194196f, 0.00804541f, 0.10241368f, 
    -0.00523233f, -0.06030760f, 0.02695475f, -0.01236093f, -0.10274310f, -0.11224192f, -0.15616214f, -0.13642733f, 
    0.21411523f, 0.14340377f, 0.07722776f, 0.11387336f, -0.02117557f, 0.01952989f, 0.10216487f, 0.02462075f, 
    0.16579714f, 0.12534931f, 0.00272840f, -0.01115114f, -0.00804330f, -0.02927277f, -0.04354622f, 0.02078594f, 
    0.12765913f, 0.02416821f, -0.01229306f, 0.02512419f, -0.03920085f, -0.03990415f, -0.08035189f, 0.09630259f, 
    0.05657358f, -0.11661957f, 0.13024811f, -0.07189932f, 0.01427233f, 0.06133424f, 0.17023979f, 0.03575417f, 
    -0.04798780f, -0.06532252f, -0.36654940f, -0.18332539f, -0.01899762f, -0.11517156f, -0.07932281f, 0.00509504f, 
    0.04395445f, -0.14901458f, 0.28957471f, 0.04804274f, -0.04127273f, 0.10350303f, 0.12849605f, -0.09841488f, 
    0.16246137f, 0.07952949f, 0.09197061f, 0.00097346f, 0.15006648f, -0.28924856f, 0.04708375f, -0.09516123f, 
    0.01469765f, 0.11040927f, 0.07450278f, -0.27375922f, 0.06248581f, -0.07242498f, -0.10333816f, 0.10788252f, 
    0.18617384f, 0.23081776f, 0.22961022f, 0.06882075f, 0.09013225f, -0.17015433f, -0.12027346f, -0.05467162f, 
    -0.05245513f, -0.01125703f, 0.06955072f, -0.03566524f, 0.17063524f, -0.12411636f, -0.22046845f, 0.02934160f, 
    0.05408360f, -0.12796719f, -0.02399745f, -0.15495604f, -0.03114271f, 0.08704749f, -0.09077287f, 0.15144184f, 
    -0.23343691f, -0.26244926f, -0.05197776f, 0.09313708f, -0.06868066f, 0.10045998f, 0.08773343f, 0.27213958f, 
    0.22427589f, 0.12749581f, -0.09588093f, 0.10267565f, -0.02810442f, -0.07631308f, -0.05396223f, 0.10725334f, 
    -0.01597712f, -0.03165996f, 0.03102995f, 0.00848748f, 0.08821583f, 0.02969608f, 0.06021718f, 0.20715718f, 
    -0.05819024f, -0.07455549f, -0.04594828f, 0.28141186f, 0.12270641f, 0.04284547f, -0.00414728f, 0.07268904f, 
    0.00820270f, 0.07559673f, 0.10710128f, 0.08917867f, -0.16158046f, 0.08808672f, -0.35380369f, 0.13463952f, 
    -0.08215346f, -0.04271056f, -0.09286930f, 0.10826652f, -0.12957336f, 0.06644358f, -0.17400217f, 0.14128773f, 
    0.06518371f, 0.26817274f, -0.03179602f, 0.07805165f, -0.09523832f, -0.09832505f, -0.03876664f, -0.04266471f, 
    0.03406219f, 0.01469508f, 0.03269874f, -0.07242098f, -0.22637981f, 0.00864660f, 0.16714881f, 0.13471745f, 
    -0.00159792f, 0.02548540f, -0.04198054f, -0.04908924f, 0.03623420f, 0.03639213f, 0.00980385f, 0.06035606f, 
    0.10987735f, 0.19922045f, -0.06627664f, 0.14336659f, 0.10532091f, 0.02638619f, -0.29216275f, 0.27511653f, 
    -0.00117311f, 0.17853209f, -0.03080165f, 0.02243535f, 0.08001482f, 0.03957114f, 0.09794523f, 0.12063837f, 
    -0.03833972f, 0.01344605f, -0.04413051f, 0.01623617f, -0.03918906f, -0.17288190f, 0.00496144f, -0.26917490f, 
    0.10487473f, -0.03644121f, 0.18362471f, 0.12497663f, 0.08092164f, -0.10043361f, -0.06984713f, -0.11806922f, 
    0.13804166f, 0.02848255f, -0.03947744f, 0.09962837f, 0.06335380f, 0.30870375f, 0.11493897f, 0.17841054f, 
    -0.07063675f, 0.08192548f, -0.09642145f, 0.09356523f, 0.00222059f, 0.15548962f, 0.24815008f, 0.00305277f, 
    0.12705731f, -0.03613319f, 0.03087000f, 0.06053490f, -0.04031165f, 0.04691657f, 0.04752469f, -0.04208140f, 
    0.09816148f, 0.01652491f, 0.15895315f, -0.00006556f, -0.06084689f, -0.34747902f, -0.17246380f, 0.01369140f, 
    0.04258356f, -0.00993800f, 0.01076382f, -0.19743197f, 0.00213896f, -0.01789477f, 0.03260950f, 0.06051922f, 
    0.48302341f, -0.04827357f, -0.11748321f, -0.07000542f, -0.21549657f, -0.26758024f, 0.30522940f, -0.04583700f, 
    0.12467100f, -0.10328029f, -0.03817746f, -0.04520557f, 0.17473695f, -0.05034581f, 0.07277072f, -0.03867026f, 
    0.04769192f, -0.01474236f, 0.19308278f, 0.07049507f, 0.19137461f, 0.04230903f, 0.10032774f, 0.04578118f, 
    0.24937324f, 0.19366623f, -0.20424727f, -0.03948129f, 0.16303006f, 0.07965663f, 0.05294076f, -0.03389633f, 
    0.09766711f, -0.05631105f, 0.01468075f, 0.05847348f, -0.11397873f, -0.28788510f, -0.20303988f, 0.03080747f, 
    0.01731521f, 0.16246760f, 0.02646166f, 0.07599331f, 0.08609738f, -0.13733062f, 0.13616961f, -0.02966463f, 
    -0.35272771f, -0.47116461f, 0.00074423f, 0.07080829f, -0.01557142f, 0.05291930f, -0.00835881f, -0.04209838f, 
    -0.04694133f, -0.00868763f, -0.20288357f, -0.18117915f, -0.02549639f, 0.06315926f, 0.15051298f, -0.20531844f, 
    0.06069910f, 0.09797812f, -0.05044530f, 0.13807264f, 0.06336135f, -0.01374285f, -0.02676583f, 0.01622914f, 
    -0.12751535f, 0.10728051f, 0.16402499f, 0.18871531f, 0.10202985f, -0.01557748f, -0.10031223f, 0.06408364f, 
    0.01912694f, 0.00612750f, 0.00116638f, -0.00044683f, -0.15486005f, -0.11646325f, -0.16063614f, 0.03524771f, 
    -0.07401709f, 0.07601751f, 0.06598546f, -0.02896672f, 0.06048759f, 0.04697573f, -0.11580320f, -0.02589887f, 
    -0.30074716f, -0.08568138f, 0.47929388f, 0.04605027f, 0.10862503f, -0.02238061f, -0.12345772f, -0.01895065f, 
    -0.06274788f, 0.14718299f, 0.05068171f, 0.05959888f, 0.46810204f, 0.28196099f, -0.14406282f, -0.01489761f, 
    0.03810781f, 0.19002683f, 0.05262569f, -0.01211874f, -0.08846182f, -0.03893962f, 0.03622853f, -0.01483065f, 
    -0.15291542f, -0.11510833f, 0.06273825f, -0.00537570f, 0.12962225f, 0.11494564f, -0.20050666f, 0.10361777f, 
    -0.07199627f, 0.02176666f, 0.13729894f, 0.05253167f, 0.22203518f, -0.10454396f, -0.02804657f, -0.08060644f, 
    -0.04567176f, 0.02403932f, 0.14470652f, -0.07178696f, 0.12987299f, 0.00674845f, 0.00821871f, -0.01533748f, 
    0.06836963f, -0.05565719f, 0.03301854f, -0.01060673f, 0.07245514f, 0.02086012f, -0.00678094f, 0.00957404f, 
    -0.17569983f, -0.07605529f, 0.05990638f, 0.02219265f, 0.00161100f, 0.11264382f, 0.01479213f, -0.03414011f, 
    0.12731010f, -0.02197234f, 0.02199979f, 0.15285094f, -0.03733815f, 0.12912986f, 0.01111657f, 0.00839807f, 
    -0.08415973f, -0.04096769f, -0.07907262f, 0.00709916f, -0.03510916f, -0.01510657f, 0.04851421f, -0.09380572f, 
    -0.18383852f, 0.07471638f, 0.01241283f, 0.00735227f, -0.07065125f, 0.07285762f, 0.05368727f, -0.00894577f, 
    0.05719386f, 0.09346680f, -0.19782785f, 0.04371769f, -0.03925471f, -0.17523456f, -0.07943202f, 0.03184563f, 
    0.51958579f, -0.34721601f, -0.38808241f, 0.02162992f, 0.19701067f, 0.14445943f, 0.08910345f, 0.00753819f, 
    0.09209518f, 0.04845534f, -0.07190921f, -0.08528236f, 0.13612904f, -0.15311983f, -0.30323422f, -0.06983072f, 
    0.05384846f, 0.30827481f, 0.14042029f, 0.11435203f, -0.00290830f, -0.15404090f, 0.09935290f, 0.03871722f, 
    -0.01069332f, 0.05810065f, 0.08594835f, -0.01556347f, 0.15054625f, -0.13218257f, -0.14870742f, 0.03919326f, 
    -0.03444234f, -0.04396292f, 0.07047852f, 0.05319573f, -0.24280158f, 0.13631785f, 0.19854064f, 0.09508763f, 
    0.12177420f, 0.17220962f, 0.11677882f, 0.03700797f, -0.02065000f, 0.01428598f, 0.13604869f, 0.02350784f, 
    0.16003332f, 0.03395813f, -0.23739059f, -0.11206266f, -0.00927665f, 0.22180998f, -0.05221688f, 0.04414275f, 
    -0.09207489f, 0.08807575f, -0.03967458f, -0.12454526f, -0.05331782f, -0.16575263f, -0.12464289f, -0.04028409f, 
    -0.02822976f, -0.00081221f, 0.04977363f, 0.05973201f, -0.02364183f, 0.15502217f, 0.00786620f, -0.04921839f, 
    0.19739954f, 0.19176123f, 0.21064945f, -0.26350716f, 0.01516033f, -0.06859312f, -0.01072016f, 0.06311540f, 
    -0.06450343f, -0.17553301f, -0.01840962f, -0.07607092f, 0.34508550f, 0.18850681f, 0.31251583f, -0.34367895f, 
    -0.00792885f, -0.04779691f, 0.13693045f, 0.00933992f, 0.22655289f, -0.06516274f, 0.03782727f, 0.03372389f, 
    0.14829376f, -0.02043979f, 0.05301436f, -0.06176654f, -0.02703163f, -0.13280964f, 0.06153985f, -0.02063694f, 
    0.07833233f, 0.00066772f, 0.01081969f, 0.05987893f, 0.37547261f, 0.27832419f, 0.04483476f, -0.24782223f, 
    0.14559761f, -0.03002511f, 0.09007201f, -0.03048762f, 0.04730148f, 0.01975037f, 0.09625670f, 0.03684742f, 
    -0.34523344f, -0.11538181f, 0.08754701f, 0.01994621f, 0.00579574f, 0.17940195f, -0.18456964f, -0.01979419f, 
    -0.05253955f, 0.03829355f, 0.05080866f, -0.01346730f, 0.00143606f, 0.08697324f, -0.23768508f, -0.17916059f, 
    0.06236394f, 0.18497518f, 0.03562957f, -0.06145382f, -0.12789413f, 0.03980600f, 0.07607134f, 0.02716652f, 
    0.29620093f, 0.41220054f, -0.05466058f, -0.18820743f, 0.12527120f, 0.08024716f, 0.15920886f, 0.09369045f, 
    0.01242160f, -0.03628553f, -0.03297176f, 0.01419208f, -0.24716590f, -0.31212080f, -0.04066375f, -0.29449487f, 
    0.03648717f, 0.02346892f, 0.00237151f, 0.09605084f, 0.02454204f, -0.01437582f, 0.02320516f, 0.14680693f, 
    -0.11303209f, 0.10126723f, -0.03439832f, 0.13871670f, 0.00912266f, -0.04654972f, -0.09045935f, -0.09336205f, 
    0.04570382f, 0.05051300f, -0.04011802f, 0.07194255f, -0.22156295f, -0.19159085f, -0.10166256f, -0.07513977f, 
    0.15087274f, 0.15857577f, 0.12309197f, 0.10532673f, 0.14610352f, 0.04547160f, 0.03254434f, -0.00483984f, 
    0.17530155f, -0.29663953f, 0.04847216f, 0.32714936f, 0.14327474f, 0.21926123f, 0.00277947f, 0.04334899f, 
    0.16424625f, -0.02153675f, 0.16069980f, 0.14855969f, -0.09777091f, 0.04419189f, -0.21083125f, 0.30144426f, 
    0.06989087f, 0.12880115f, -0.02437303f, 0.02118287f, 0.10716210f, 0.09567334f, 0.02956961f, -0.02099527f, 
    0.07501474f, -0.14371380f, 0.05651354f, 0.18358786f, -0.05620054f, -0.07031065f, 0.21118639f, 0.24168195f, 
    -0.10714363f, -0.01966605f, 0.01085791f, -0.01579458f, 0.46827689f, 0.57494318f, 0.24926867f, 0.00024766f, 
    0.06862254f, 0.01803993f, 0.10836100f, 0.01374184f, -0.17976114f, 0.06140733f, -0.22478604f, 0.04948187f, 
    0.09376152f, 0.10989634f, 0.05071890f, 0.03947863f, 0.02965483f, 0.00929830f, -0.04366438f, -0.08121779f, 
    0.02583746f, 0.07990626f, 0.27429593f, 0.35215753f, 0.17917110f, 0.11024278f, 0.05241384f, -0.02178470f, 
    -0.08459248f, 0.04470399f, -0.05817027f, -0.29616070f, -0.06436566f, -0.03104269f, 0.14003918f, -0.20704697f, 
    -0.06423915f, -0.09547524f, -0.19639775f, -0.14882384f, 0.00811213f, -0.04689754f, 0.09327932f, -0.03197793f, 
    -0.11290971f, -0.04132283f, -0.12812142f, 0.03490559f, 0.12922518f, 0.02651520f, -0.12766048f, 0.03280650f, 
    0.13724066f, -0.07191743f, -0.00437899f, 0.06110250f, -0.08707681f, 0.09632247f, -0.08963943f, -0.06138860f, 
    0.03203986f, 0.06423383f, -0.11071773f, -0.16247919f, -0.00550530f, 0.02396112f, 0.05888394f, 0.05558481f, 
    0.14950332f, -0.05496379f, 0.06407525f, 0.05142219f, -0.03346604f, -0.09224407f, 0.06667893f, 0.25797763f, 
    -0.40555227f, -0.13318326f, -0.03103002f, 0.08396029f, -0.01949402f, 0.01495762f, 0.08725493f, 0.00803378f, 
    -0.01459452f, -0.07508384f, 0.32025400f, -0.33281642f, 0.02553197f, 0.06151246f, -0.02323267f, -0.23520644f, 
    -0.00309824f, 0.11449911f, -0.03604919f, 0.11093961f, -0.26589787f, -0.08278964f, -0.11459296f, 0.15653343f, 
    0.01135468f, -0.02403372f, 0.06017533f, 0.05367094f, -0.03653381f, 0.00633890f, -0.13102411f, -0.06074350f, 
    -0.11054520f, 0.02400493f, -0.05462218f, 0.02925977f, -0.04390084f, 0.09065282f, -0.02449743f, 0.02657402f, 
    0.22060299f, 0.14616467f, -0.01334245f, 0.11447072f, -0.04852577f, 0.09795855f, 0.05179371f, 0.04924924f, 
    0.05040312f, 0.16146189f, 0.10507023f, -0.10358007f, 0.13775858f, -0.11134589f, -0.00332631f, -0.11131100f, 
    0.01635262f, -0.11913479f, 0.13779822f, 0.06311738f, -0.06634965f, 0.11272124f, 0.01558884f, 0.05509856f, 
    0.07695238f, -0.13082288f, 0.13159311f, 0.10415363f, -0.14163877f, 0.08028478f, 0.15197590f, -0.15755321f, 
    0.04365316f, 0.10175871f, -0.15786479f, 0.01074507f, 0.04528940f, 0.17607237f, 0.03795908f, 0.05036657f, 
    0.01037252f, 0.08573169f, 0.45582086f, 0.19695118f, -0.08562935f, -0.07874230f, 0.01684392f, 0.01218580f, 
    -0.13122195f, -0.01799048f, 0.00676275f, 0.09213772f, 0.17029929f, 0.01984131f, 0.20740841f, 0.07802065f, 
    -0.07939063f, -0.10912141f, 0.01426595f, -0.20783709f, 0.13707516f, 0.24321958f, 0.06696748f, -0.00313548f, 
    0.13860434f, 0.02382976f, 0.07427604f, -0.07961638f, -0.07492198f, 0.13071690f, 0.08678361f, 0.04559544f, 
    -0.11804649f, -0.02727102f, 0.01980624f, -0.03460021f, 0.00812107f, -0.19107255f, -0.01946234f, 0.07897114f, 
    0.08662870f, -0.07899641f, -0.15585737f, 0.03036672f, -0.03865338f, -0.03084648f, -0.10055783f, 0.00832597f, 
    -0.05333269f, -0.11790629f, 0.04396184f, -0.00020996f, -0.06376258f, 0.01368896f, 0.00106412f, 0.08013392f, 
    0.18154030f, 0.01522855f, -0.16376199f, 0.13073882f, -0.11112845f, 0.04201080f, -0.16790318f, 0.09461027f, 
    0.00343992f, -0.02785251f, 0.07393847f, 0.01806074f, -0.03462521f, -0.07776392f, -0.08285468f, -0.01164234f, 
    0.20622012f, -0.00671709f, -0.36091411f, 0.15425776f, 0.14645739f, 0.01887279f, -0.02037390f, -0.02855516f, 
    0.01668741f, 0.06514730f, 0.15414760f, 0.05027956f, -0.14408998f, 0.28223717f, -0.34398767f, 0.06473755f, 
    -0.04793079f, 0.08541181f, -0.10299461f, -0.13351639f, -0.22241533f, -0.04202556f, -0.04261716f, -0.06710286f, 
    -0.21302988f, 0.12219351f, -0.15151985f, -0.02016884f, 0.03855683f, 0.09608772f, 0.05944826f, 0.11626831f, 
    0.11375929f, 0.01695206f, -0.00054903f, -0.08101941f, -0.16408263f, -0.14135888f, -0.13100398f, -0.19499016f, 
    -0.23230447f, -0.01772957f, -0.06810762f, 0.03846614f, -0.04679989f, -0.04249530f, -0.06452306f, -0.02585112f, 
    0.40888754f, 0.15007959f, 0.23547284f, -0.12267907f, 0.02141370f, 0.06599908f, 0.00118931f, 0.05900337f, 
    -0.11833592f, 0.04915170f, -0.15678392f, -0.00420862f, 0.18456365f, 0.10416620f, 0.16550760f, 0.29009807f, 
    -0.04915781f, -0.09609868f, -0.03130262f, 0.07059627f, -0.01779866f, 0.02803502f, -0.06023812f, 0.11895283f, 
    0.23184766f, -0.26972649f, 0.08514661f, 0.15075517f, 0.00546012f, 0.12429170f, -0.02821161f, -0.13667186f, 
    0.00617552f, -0.00626704f, 0.05077960f, -0.15095387f, -0.15179686f, 0.13163187f, -0.21013193f, 0.21141161f, 
    0.00060908f, 0.00603585f, 0.12090597f, -0.17503309f, -0.08744299f, 0.00233270f, 0.11771362f, 0.02436834f, 
    0.14471708f, -0.13702278f, 0.19681707f, 0.09088138f, -0.16401270f, 0.03841726f, 0.05119711f, 0.02541876f, 
    -0.08339895f, -0.02916644f, 0.02082603f, -0.15687111f, 0.25501573f, 0.17852078f, 0.24142809f, 0.06659798f, 
    0.02414342f, -0.01808153f, -0.09586267f, -0.03219315f, -0.03531059f, 0.24870047f, 0.18824412f, -0.00110983f, 
    0.15126488f, 0.04862122f, 0.46732339f, 0.15657622f, -0.14445673f, 0.01796109f, -0.10925189f, 0.01559193f, 
    0.06956962f, -0.10235666f, -0.00428259f, -0.02411706f, -0.23267563f, 0.02395908f, 0.14130497f, 0.04037673f, 
    0.10743361f, 0.17939840f, -0.00300691f, 0.01538284f, -0.04462330f, -0.00363628f, -0.11802893f, 0.00728300f, 
    0.52372682f, 0.26517901f, 0.17362536f, 0.16247539f, 0.04202013f, 0.10179951f, 0.05721367f, 0.26485705f, 
    0.01942791f, -0.04188806f, -0.02914706f, -0.03945396f, 0.23644254f, 0.29771608f, 0.06694547f, -0.18346335f, 
    -0.08438963f, 0.04215081f, 0.06004674f, -0.02072240f, -0.01928804f, 0.05416496f, -0.00232983f, -0.08014534f, 
    -0.07320835f, -0.12225433f, -0.12026361f, -0.03305529f, -0.04245572f, 0.02391588f, -0.07504521f, -0.08097225f, 
    -0.06336456f, -0.19837184f, -0.14545356f, 0.13095619f, -0.39237592f, 0.30303770f, 0.19151665f, -0.34932616f, 
    -0.19807079f, -0.01811394f, -0.16084641f, 0.02284936f, -0.02108617f, 0.08168007f, 0.05197371f, -0.03519430f, 
    -0.34521851f, -0.49394840f, -0.41036600f, 0.16689658f, -0.04350327f, -0.03727012f, 0.00650259f, 0.05119045f, 
    0.00175934f, 0.08418280f, 0.10821997f, -0.01356526f, -0.03685820f, -0.03577771f, 0.01748352f, -0.06865209f, 
    -0.02008159f, -0.04688274f, 0.03022177f, 0.00791361f, -0.09457211f, -0.00686936f, 0.06346301f, 0.10653391f, 
    -0.36019051f, 0.18671742f, 0.21772607f, 0.07991302f, 0.03555595f, -0.03562060f, 0.14460459f, 0.12996513f, 
    0.02340672f, 0.06907915f, -0.30527413f, -0.10161664f, 0.09251070f, 0.26401332f, 0.05286368f, 0.24387795f, 
    -0.10770507f, -0.09145035f, 0.08065378f, 0.20469496f, -0.09699980f, -0.01186892f, 0.02170337f, 0.01809717f, 
    -0.20642056f, -0.09179638f, 0.35608554f, 0.02866677f, 0.07803273f, 0.19047748f, -0.03936801f, -0.17296298f, 
    0.04479538f, -0.00188370f, -0.04032028f, -0.00958924f, -0.18389085f, 0.04542679f, 0.01238461f, -0.23693472f, 
    -0.02518963f, 0.03126269f, 0.03080528f, 0.01850422f, -0.10336131f, 0.05905330f, 0.04941259f, -0.00777487f, 
    -0.17520289f, -0.02938070f, -0.01270188f, -0.02381461f, -0.05365472f, 0.05585915f, -0.05901567f, 0.01803070f, 
    0.04722570f, 0.06823981f, -0.00656722f, 0.07978803f, -0.01098944f, 0.08433954f, -0.02587931f, -0.04720153f, 
    -0.07669618f, 0.04399170f, -0.03978134f, -0.01123354f, 0.01262843f, -0.06528781f, 0.14079557f, 0.06068122f, 
    -0.16614109f, -0.11294810f, -0.11117119f, 0.11314897f, -0.00043351f, -0.08314235f, -0.03212295f, 0.06222163f, 
    0.04813007f, 0.03486877f, 0.05899504f, 0.15831007f, 0.04272811f, 0.35597166f, 0.15063141f, 0.01265790f, 
    0.01657257f, 0.03772493f, -0.02207031f, -0.12964216f, 0.01312916f, -0.05698530f, -0.20382266f, 0.09863357f, 
    0.47354564f, 0.08621640f, -0.01855928f, 0.14011426f, 0.02982953f, 0.00082042f, -0.02603292f, 0.02074725f, 
    -0.04003557f, 0.05814268f, -0.03112047f, 0.01018392f, 0.31865650f, -0.00645707f, -0.04113171f, 0.02955753f, 
    0.02808212f, 0.02082593f, -0.09170101f, -0.04705173f, 0.05521485f, -0.13311186f, 0.07203481f, -0.03335097f, 
    -0.29016763f, -0.17307749f, -0.10475213f, 0.01645300f, -0.00753179f, 0.05829788f, 0.01905276f, 0.01593548f, 
    0.04409457f, 0.04688393f, 0.06027888f, 0.06850087f, -0.38701749f, 0.19592258f, 0.15214626f, 0.30893555f, 
    -0.16019028f, 0.00261929f, 0.05463520f, 0.04932126f, -0.06309100f, 0.04467668f, -0.09851207f, -0.12135628f, 
    0.28937849f, 0.22554107f, 0.47668424f, 0.16610701f, 0.04259551f, -0.00915081f, 0.05330663f, -0.00647246f, 
    0.10132416f, 0.05405290f, 0.05682674f, -0.05854637f, -0.06938554f, 0.11778972f, 0.02542022f, -0.07195490f, 
    -0.07048681f, -0.02757102f, 0.01818568f, 0.03472657f, -0.14719208f, 0.07953805f, -0.08147463f, 0.01691363f, 
    0.35943267f, 0.41799664f, 0.03005691f, 0.15499127f, 0.09146175f, 0.15708354f, 0.02102083f, 0.20134500f, 
    0.02143636f, 0.02477714f, 0.00101460f, -0.06547824f, -0.39442366f, 0.04294430f, 0.11783303f, -0.17599551f, 
    -0.05976578f, -0.02712333f, -0.00194743f, -0.10345688f, -0.22301154f, -0.14119244f, -0.16012782f, -0.07591578f, 
    -0.26743495f, -0.26393607f, 0.04237777f, -0.02022357f, -0.03701765f, 0.04157569f, -0.01618730f, 0.05694044f, 
    0.10049075f, 0.10701055f, -0.02902879f, 0.01109414f, 0.09645140f, 0.12036030f, 0.09644458f, -0.09993303f, 
    0.10275451f, 0.12182757f, 0.12554829f, 0.24144545f, -0.05351887f, -0.02017108f, 0.00607898f, -0.01476553f, 
    0.36222243f, 0.04147841f, 0.25082731f, -0.05331637f, 0.03514856f, -0.05641791f, 0.17043209f, 0.02083834f, 
    -0.02610957f, 0.03498165f, 0.02806692f, -0.02842195f, 0.30703068f, 0.10904332f, -0.00121121f, 0.00918263f, 
    -0.01953013f, 0.01804437f, -0.11403815f, -0.02251314f, -0.06193322f, -0.09671773f, 0.02315033f, 0.05852088f, 
    0.16496556f, 0.04114369f, 0.38725692f, 0.09581054f, 0.17197590f, 0.21575589f, 0.00249882f, 0.08516317f, 
    0.05090458f, -0.11634584f, -0.18221183f, -0.07448300f, 0.20727319f, -0.12944740f, -0.05169259f, 0.05596201f, 
    -0.11640700f, 0.00287125f, -0.13056570f, 0.07009438f, -0.11916839f, 0.03369099f, 0.02815816f, -0.08892721f, 
    0.00518955f, 0.08216445f, 0.09198003f, -0.01410073f, -0.04959986f, 0.03185207f, 0.06417580f, -0.03277591f, 
    -0.00111620f, 0.02941170f, -0.06754721f, -0.01370603f, 0.14007658f, 0.04609497f, 0.09439597f, 0.13979056f, 
    0.04973506f, 0.04899256f, 0.14244698f, 0.09134211f, 0.15835378f, 0.11449298f, 0.08867279f, 0.11300139f, 
    -0.06766187f, -0.11946605f, 0.15823133f, -0.15869777f, 0.02189757f, 0.05262149f, -0.03919738f, -0.04417913f, 
    -0.00334355f, 0.15499461f, 0.03777076f, 0.06573265f, 0.05778598f, -0.18614900f, 0.36869836f, 0.12804072f, 
    0.02827816f, 0.07998580f, 0.03641002f, 0.11539067f, 0.14865009f, 0.19815619f, 0.11852451f, 0.19703351f, 
    0.09368019f, 0.20634036f, -0.15070200f, -0.28973177f, 0.05506256f, -0.12634957f, -0.09320150f, -0.00299816f, 
    -0.07981828f, -0.03548473f, -0.14679056f, -0.08737183f, -0.15293290f, -0.15810604f, 0.04335290f, 0.12867217f, 
    -0.02519808f, 0.04203784f, 0.01747949f, -0.00630853f, -0.07084268f, -0.03882620f, 0.04674041f, 0.09995087f, 
    -0.15602736f, -0.23263130f, -0.12109705f, -0.07883249f, 0.00059483f, -0.04545458f, 0.10136943f, 0.06557685f, 
    0.09929240f, 0.26559648f, 0.20884848f, 0.24826682f, -0.10549499f, -0.25314853f, -0.14082709f, 0.06631690f, 
    0.11533164f, 0.00908842f, 0.10480145f, 0.05874088f, 0.11682094f, -0.23046045f, -0.00513440f, 0.05149390f, 
    -0.03097594f, -0.29193115f, -0.00373231f, 0.05493633f, 0.00248569f, 0.19065671f, 0.03698909f, 0.07996829f, 
    0.04751389f, -0.14776169f, -0.01393726f, -0.09912399f, -0.07867002f, -0.06850230f, 0.08745740f, -0.11205386f, 
    0.06608278f, 0.10118730f, -0.15359561f, -0.07203896f, -0.03648570f, -0.04971809f, 0.03165124f, -0.01891154f, 
    -0.07751697f, -0.23756313f, -0.02745683f, 0.24343890f, -0.00596421f, 0.06436928f, -0.03246773f, -0.03816974f, 
    0.07618671f, -0.04553905f, 0.06076502f, 0.03303446f, 0.19435975f, 0.16661064f, 0.13781621f, -0.22566959f, 
    0.22159795f, 0.09440760f, 0.00639255f, -0.14816201f, 0.17461061f, -0.14691219f, -0.07597442f, 0.02904097f, 
    0.19656661f, 0.38671723f, -0.31557682f, 0.03767522f, -0.08013283f, -0.05722779f, 0.12637518f, 0.06941377f, 
    0.02843045f, -0.01362127f, 0.02176306f, -0.16953126f, 0.03572844f, -0.22578444f, 0.18780433f, 0.01892973f, 
    0.17812240f, 0.02055127f, -0.06374124f, -0.02127593f, 0.00490012f, 0.09367204f, 0.11094182f, 0.05789004f, 
    -0.13559353f, -0.15303518f, -0.19607827f, 0.01759123f, 0.09974534f, -0.00080285f, -0.03371898f, 0.13461457f, 
    0.08672274f, 0.08936907f, 0.11245743f, 0.14275396f, 0.15649761f, -0.17743558f, -0.08374179f, 0.12839679f, 
    -0.05213119f, -0.11887153f, -0.04428699f, 0.18424270f, 0.10860318f, 0.22197025f, -0.10267394f, -0.02733951f, 
    -0.21413729f, 0.04689484f, -0.04398537f, 0.03795735f, 0.13798188f, -0.03298426f, 0.12235890f, -0.01066254f, 
    0.31009674f, 0.10930031f, 0.21338288f, -0.01327275f, 0.10130961f, 0.08354273f, -0.05750974f, 0.06345171f, 
    -0.00411346f, 0.09442718f, 0.16001727f, 0.11682153f, -0.00710904f, 0.15169421f, 0.22077172f, 0.14569375f, 
    -0.06801615f, 0.21302953f, -0.01876435f, -0.14444946f, 0.17016175f, -0.06472488f, -0.01875412f, 0.04379462f, 
    -0.09687570f, -0.09780967f, 0.04764821f, 0.05519811f, -0.17826369f, 0.22483258f, 0.12330852f, -0.11077023f, 
    0.12759495f, 0.19021155f, 0.11192492f, 0.22412308f, -0.10985618f, 0.13759893f, 0.01907627f, 0.18245324f, 
    -0.15445675f, -0.33089033f, -0.10605586f, 0.14965554f, 0.12403439f, 0.10716722f, -0.02687091f, 0.01705997f, 
    -0.00530456f, -0.11606982f, -0.09191697f, -0.14642793f, 0.10398831f, -0.01062292f, 0.25357229f, -0.06907393f, 
    0.05305274f, 0.06699221f, -0.08759747f, 0.06630432f, 0.09233246f, -0.06053127f, 0.09350799f, 0.00250316f, 
    0.27298525f, 0.23319700f, 0.08137383f, -0.04465364f, 0.07436974f, -0.07860438f, -0.00355753f, -0.12724130f, 
    -0.09075484f, -0.10060108f, 0.00009595f, -0.02461404f, 0.00861025f, -0.07781515f, 0.11520118f, 0.14622407f, 
    0.09705251f, 0.08783515f, -0.14374189f, -0.05481785f, 0.05033529f, 0.00512226f, 0.02913065f, -0.11091999f, 
    -0.03498606f, -0.02012295f, 0.32824951f, -0.16493845f, -0.06715403f, 0.09342594f, 0.01065328f, -0.06686357f, 
    0.05356274f, -0.02472241f, -0.05830759f, 0.09405392f, 0.20379315f, -0.21611813f, 0.39372072f, 0.18295281f, 
    0.05832895f, -0.04933277f, -0.01225488f, 0.02545816f, 0.18122151f, -0.03822232f, 0.20352928f, 0.16850457f, 
    0.06538452f, -0.15723875f, -0.06807365f, 0.03970670f, 0.33254623f, -0.07442916f, 0.02001018f, 0.09169963f, 
    -0.21147521f, -0.10344989f, -0.17718007f, -0.09092892f, 0.29382741f, 0.18846542f, 0.12378775f, 0.00392766f, 
    -0.01789268f, 0.00705730f, 0.01954033f, 0.04123028f, -0.05936708f, -0.06110946f, -0.01859359f, -0.00377976f, 
    -0.19306614f, 0.07399165f, -0.38991472f, -0.03178923f, -0.00259987f, 0.01197519f, -0.07872908f, -0.03060471f, 
    0.09579380f, -0.14035015f, -0.22404990f, -0.13642132f, -0.17578390f, 0.04704563f, -0.01079024f, -0.02620790f, 
    -0.00085314f, 0.02730251f, 0.12919161f, 0.01265411f, 0.14198385f, 0.21463133f, 0.16268115f, 0.30870590f, 
    -0.18642554f, 0.22696918f, -0.21673819f, -0.24570431f, -0.07169772f, -0.07909866f, 0.05524325f, 0.04587883f, 
    -0.08886552f, -0.05152743f, 0.05909045f, 0.11525168f, 0.17126232f, -0.09959278f, 0.04065913f, -0.13503940f, 
    0.14045632f, -0.10075311f, 0.00898607f, 0.00511049f, 0.22311044f, -0.04143625f, -0.15997532f, 0.00908962f, 
    -0.20893331f, 0.03087704f, -0.25367513f, -0.00795116f, 0.32855228f, -0.18658890f, -0.22058009f, -0.05893106f, 
    -0.12599622f, -0.12027636f, -0.24579060f, -0.18524930f, 0.00780620f, 0.40392980f, 0.23610649f, 0.13560849f, 
    0.04210715f, 0.08296317f, 0.05484973f, 0.21491812f, -0.04409523f, -0.00694913f, -0.04865266f, -0.00295076f, 
    0.19045173f, 0.37411666f, -0.44379020f, -0.00738070f, 0.20627178f, -0.05078956f, 0.32626837f, -0.13949542f, 
    -0.04610997f, -0.02522913f, 0.09713097f, 0.11191059f, 0.19385964f, 0.13293895f, -0.27858120f, -0.34700638f, 
    0.14107189f, -0.09654598f, 0.02345617f, -0.21068195f, 0.08684190f, 0.03628939f, 0.12164697f, -0.01770650f, 
    -0.03180342f, -0.09557062f, -0.07224368f, 0.21531796f, 0.03285223f, -0.05408256f, -0.10352094f, -0.01851073f, 
    0.06272256f, -0.06647217f, 0.00800386f, 0.08311957f, -0.09886181f, -0.15738930f, -0.24086179f, 0.11503629f, 
    0.12253912f, 0.07445557f, 0.02733782f, 0.17001849f, 0.09998152f, 0.04164196f, 0.01606567f, -0.01857296f, 
    -0.06606294f, 0.11616046f, -0.07733416f, 0.11787377f, -0.06146592f, -0.05438265f, -0.04766424f, -0.06758742f, 
    0.16434509f, -0.00451800f, -0.04059182f, -0.23677012f, -0.07742220f, 0.05252150f, -0.16827755f, 0.07600107f, 
    0.13511939f, 0.09487250f, 0.07942495f, 0.01570968f, 0.03610480f, -0.02146034f, -0.05718480f, 0.03283828f, 
    0.06294785f, 0.23387396f, 0.20651981f, -0.08789718f, -0.03643729f, -0.00667130f, -0.04447044f, -0.04307592f, 
    -0.15099809f, -0.00889112f, 0.02740997f, 0.00584434f, -0.01411472f, 0.21673016f, 0.04506488f, 0.05977783f, 
    -0.09467521f, 0.14073439f, 0.09055119f, 0.00470686f, 0.00631565f, 0.05267600f, 0.09702445f, -0.07346302f, 
    0.41339388f, -0.11604431f, 0.31645024f, -0.33603418f, 0.09829336f, 0.00504697f, -0.06255241f, -0.05992087f, 
    0.01508839f, 0.09913626f, 0.24680471f, 0.02912299f, 0.25444883f, 0.06293957f, -0.08990296f, -0.08007753f, 
    0.02481785f, 0.13135809f, 0.05960633f, -0.05599960f, -0.00384917f, 0.00255655f, -0.00046816f, -0.02849430f, 
    0.09150567f, -0.23521815f, 0.38747668f, 0.07395883f, 0.13921854f, 0.13676687f, 0.05600509f, 0.14082037f, 
    -0.09986394f, 0.04644392f, 0.09798995f, 0.15357780f, -0.11667375f, 0.18651788f, -0.03853617f, -0.11925510f, 
    -0.05480997f, 0.10888529f, 0.03039623f, -0.10153504f, 0.18298127f, -0.06429426f, -0.00391072f, -0.02761542f, 
    0.11951593f, 0.08476727f, 0.01731008f, -0.23014350f, -0.00896985f, 0.00294691f, 0.06002545f, -0.06930619f, 
    -0.04625383f, 0.04977242f, -0.00092338f, -0.02284062f, -0.13262263f, 0.15114275f, 0.02803710f, -0.01677989f, 
    0.01718060f, 0.04394070f, 0.15643974f, 0.00483584f, -0.05113740f, 0.04600151f, 0.12655625f, -0.03147917f, 
    0.08959652f, 0.04515261f, 0.08162060f, -0.13381729f, -0.19789965f, 0.09493072f, 0.02939939f, -0.08481561f, 
    -0.33586374f, 0.03855470f, -0.13303761f, 0.01698839f, 0.06898411f, -0.21929716f, 0.00049347f, 0.06017521f, 
    0.13300586f, 0.02062417f, 0.09229754f, 0.26156285f, 0.02042896f, -0.08377777f, -0.00624386f, 0.05028494f, 
    -0.22212231f, -0.06518910f, -0.31326291f, 0.20579754f, -0.07941304f, 0.07341430f, 0.07707321f, 0.27047747f, 
    -0.00963243f, 0.00857641f, -0.10650375f, -0.03005703f, -0.24888907f, -0.02078855f, -0.37523186f, 0.20817989f, 
    -0.04578427f, 0.00211102f, 0.14732331f, 0.16505946f, -0.13077790f, -0.01424911f, 0.05498146f, -0.06183026f, 
    0.16210397f, 0.05953098f, 0.06560763f, -0.11849618f, 0.02434568f, -0.03067739f, -0.00057688f, 0.00240391f, 
    -0.02874340f, 0.00067112f, 0.00253420f, 0.04560234f, 0.42064324f, 0.07585748f, 0.17530675f, -0.06088797f, 
    0.02204443f, 0.37456307f, 0.02990136f, 0.11623905f, 0.05388584f, 0.05795863f, 0.10046908f, 0.00066141f, 
    -0.07890372f, -0.00792739f, -0.33729583f, 0.13821164f, -0.14564811f, 0.02151335f, 0.02776399f, 0.14053860f, 
    -0.06788681f, 0.17240030f, 0.10716368f, 0.05106010f, -0.04382157f, 0.03927635f, -0.14432123f, -0.22552751f, 
    0.03198997f, 0.05721393f, 0.07631803f, -0.06815034f, 0.07798519f, 0.06018902f, 0.10571046f, 0.06919307f, 
    0.12619367f, 0.10632546f, -0.21608114f, -0.07661238f, 0.12677850f, -0.06143193f, 0.03235821f, -0.02376548f, 
    -0.03664205f, -0.00888034f, -0.01759558f, 0.02653974f, 0.29247093f, 0.29792699f, -0.06947668f, -0.10450429f, 
    0.19570802f, 0.06467018f, 0.10643427f, -0.05147706f, 0.15881638f, 0.02340950f, 0.03190583f, -0.05714622f, 
    0.15199859f, 0.22897922f, -0.01198342f, -0.14837253f, 0.03569525f, 0.00611048f, -0.02602629f, -0.11728667f, 
    0.09685013f, -0.00821219f, 0.04810385f, 0.08858827f, 0.25580868f, 0.08301476f, -0.11626944f, 0.03875869f, 
    -0.02111565f, -0.02529390f, 0.05044659f, -0.00937932f, 0.05049797f, -0.01809521f, -0.07328371f, -0.03402206f, 
    -0.09768195f, -0.27437112f, 0.19360094f, 0.12919606f, -0.02820873f, 0.25501415f, 0.25462645f, -0.01364739f, 
    -0.06941062f, 0.06830926f, 0.07638759f, 0.01469134f, -0.03692531f, -0.05884191f, -0.10769527f, 0.01451996f, 
    0.07962268f, 0.08997811f, 0.00519990f, 0.06695621f, -0.00239164f, 0.14917433f, -0.03924212f, -0.01173724f, 
    0.43317381f, 0.13976194f, -0.11177950f, 0.11163607f, 0.02602414f, 0.10207117f, 0.01786890f, 0.00243842f, 
    -0.02955832f, -0.01478443f, 0.05281598f, 0.01937120f, -0.44406834f, -0.05714265f, 0.11653867f, 0.05049287f, 
    -0.02332798f, 0.01026214f, 0.15486871f, -0.00420374f, 0.02916727f, -0.08782533f, 0.14229907f, 0.20268644f, 
    0.08404621f, 0.04210348f, -0.02757900f, 0.10697277f, 0.04708429f, 0.06751139f, -0.03614950f, 0.09487252f, 
    0.04430864f, 0.17431642f, 0.12483870f, 0.10853811f, 0.08659435f, -0.24500912f, -0.20924777f, -0.29003513f, 
    -0.05312936f, 0.11513528f, -0.03372256f, 0.02551994f, 0.11123674f, 0.11878347f, 0.06703915f, 0.03998598f, 
    0.04057456f, -0.22596924f, 0.43697596f, 0.11939919f, 0.02985200f, 0.10828090f, 0.07025667f, 0.12593053f, 
    -0.05131495f, -0.04856110f, -0.08957125f, -0.03914145f, -0.03885076f, -0.17690141f, 0.13144805f, 0.06432575f, 
    -0.01002476f, 0.06047071f, -0.02665709f, -0.05227473f, -0.08858930f, -0.02914688f, -0.05255381f, 0.02451670f, 
    0.25402966f, 0.37792990f, 0.22643453f, 0.33752915f, 0.03269793f, -0.01822659f, -0.06076499f, 0.09597672f, 
    0.02538809f, 0.02254021f, -0.03673455f, 0.01443970f, 0.15559568f, 0.10402944f, -0.13486865f, -0.11612420f, 
    0.02905365f, 0.00718267f, 0.07669595f, 0.11512838f, -0.01509721f, 0.04382170f, -0.03962459f, 0.07734052f, 
    -0.10661210f, -0.23282802f, -0.17238691f, -0.08878506f, 0.05622476f, 0.03450013f, 0.01705878f, -0.07629569f, 
    -0.16023806f, -0.21977779f, -0.06974222f, -0.03565117f, 0.09187454f, -0.18679924f, -0.01795519f, -0.12892753f, 
    -0.16519551f, -0.16558416f, -0.08661212f, 0.05624428f, 0.04677225f, 0.10915587f, 0.00684547f, -0.00292822f, 
    -0.23164259f, -0.67157555f, -0.60577661f, 0.00967424f, -0.06488570f, -0.12411416f, -0.08951051f, 0.00408546f, 
    0.11265103f, 0.09305107f, 0.03088378f, -0.08830435f, -0.10181591f, -0.31719083f, -0.04171062f, -0.24452670f, 
    0.01640657f, -0.07542609f, 0.01815430f, 0.05601128f, 0.02222081f, -0.06510573f, 0.03757359f, 0.07271619f, 
    -0.28042474f, -0.03167510f, 0.09886929f, -0.00124803f, -0.05736661f, -0.01343795f, 0.04294483f, 0.02959220f, 
    0.04014597f, 0.10826796f, -0.19848736f, 0.06661653f, 0.18987319f, 0.24619204f, 0.34738880f, 0.37802085f, 
    0.08836499f, 0.02403088f, 0.05601865f, -0.03488263f, -0.06633975f, -0.06115908f, -0.06656188f, -0.00962363f, 
    0.01468004f, 0.28418308f, -0.04709714f, 0.35721040f, -0.07567329f, 0.05437902f, -0.04488358f, 0.10514513f, 
    0.08809679f, 0.04097895f, 0.05296968f, 0.04183701f, -0.08862836f, -0.42804146f, -0.01488038f, -0.14077570f, 
    -0.01050951f, -0.04503003f, 0.08153494f, -0.04830891f, -0.02773813f, 0.02445020f, 0.01857465f, 0.01545883f, 
    -0.09174586f, -0.16231559f, -0.07730392f, -0.02945604f, -0.00617631f, -0.05172369f, -0.03249184f, 0.00457472f, 
    0.00969863f, -0.06153110f, 0.05737612f, 0.05468785f, 0.12741923f, 0.00770332f, -0.00114289f, -0.08041470f, 
    -0.10706560f, -0.08682437f, -0.07090789f, 0.16652267f, 0.11526808f, 0.01188377f, -0.05385293f, 0.07669213f, 
    -0.25000501f, -0.12388160f, -0.19798447f, -0.03358527f, -0.00024202f, -0.12473731f, 0.00162032f, -0.09104634f, 
    -0.13662435f, -0.14395015f, -0.03257848f, 0.02976504f, 0.01811726f, 0.20292041f, 0.15172476f, 0.19316232f, 
    -0.01402561f, -0.00667012f, -0.11046611f, -0.06334194f, -0.10374537f, -0.11584341f, -0.09266599f, 0.04630795f, 
    0.46829590f, -0.06962867f, -0.05615185f, 0.11769013f, 0.11818844f, 0.10126612f, -0.00781967f, 0.15996310f, 
    -0.00040672f, -0.01094403f, -0.03587293f, -0.05971564f, 0.27627525f, -0.14701617f, -0.02391749f, -0.09408845f, 
    0.11103327f, 0.09964468f, -0.01272593f, 0.11501513f, 0.03105566f, -0.01401610f, 0.06478190f, 0.10650543f, 
    -0.31239316f, -0.23026896f, -0.16271056f, -0.13280708f, -0.11365923f, -0.04630164f, -0.06842262f, 0.04844228f, 
    0.13110043f, 0.06495523f, 0.00888381f, 0.06599957f, -0.11416141f, 0.18441357f, 0.19188070f, 0.09303983f, 
    -0.00508727f, -0.03891527f, -0.12786195f, 0.12317259f, 0.01684774f, -0.02074577f, -0.08465812f, 0.03037699f, 
    0.28186461f, 0.18058525f, 0.33721507f, 0.28435385f, 0.21412681f, -0.00499390f, 0.09560066f, 0.30525425f, 
    -0.10517001f, -0.03569964f, -0.01198914f, -0.15953028f, -0.01916459f, -0.17095856f, -0.08880069f, -0.03456894f, 
    0.02872583f, -0.09605870f, -0.01232586f, 0.00378365f, -0.00789757f, 0.05716968f, -0.05660487f, -0.00613042f, 
    0.17204204f, 0.14760952f, 0.26200765f, 0.19408698f, 0.00889457f, 0.12642685f, 0.02630042f, 0.05723842f, 
    -0.03469724f, -0.05716788f, 0.02868243f, -0.03334527f, 0.04234860f, -0.17953426f, 0.11558989f, -0.11250337f, 
    -0.04247730f, -0.00082987f, 0.02398504f, -0.06451328f, -0.21366355f, -0.13977833f, 0.08110464f, -0.05096488f, 
    -0.25218201f, -0.37247208f, -0.09281319f, -0.15574530f, 0.00628240f, -0.02643624f, 0.03479968f, 0.02132946f, 
    0.01981197f, 0.00280865f, -0.03377828f, 0.07496604f, 0.27385733f, 0.23845179f, 0.31962961f, 0.09734803f, 
    -0.02020895f, -0.01508480f, -0.00116347f, -0.01748277f, 0.02705649f, 0.03527418f, 0.00680185f, -0.04980148f, 
    -0.20510288f, 0.17684755f, 0.01161158f, 0.09893069f, 0.21376736f, -0.00106632f, 0.14751701f, 0.08582246f, 
    0.21167259f, -0.05135376f, -0.01275842f, 0.01044125f, 0.07956134f, 0.11686049f, -0.08182871f, -0.01615637f, 
    0.03764953f, 0.06429688f, -0.00784173f, 0.08401284f, -0.09932049f, -0.07684191f, -0.11008767f, -0.07302710f, 
    0.00976252f, 0.30631983f, 0.23175021f, 0.16130640f, -0.04507193f, -0.04035719f, -0.00213160f, 0.01676835f, 
    -0.03290898f, 0.01715236f, -0.00781029f, 0.07895450f, -0.12278140f, -0.06428729f, -0.15381014f, -0.12593953f, 
    -0.02687627f, 0.02904420f, 0.02178484f, 0.01034757f, -0.07841909f, 0.11587696f, -0.00071148f, -0.06124501f, 
    -0.11645234f, 0.07348926f, -0.23329887f, -0.00940772f, 0.04232319f, -0.03916477f, -0.07601354f, -0.02695266f, 
    0.10999317f, 0.11168595f, -0.12631856f, 0.08415569f, -0.03188928f, -0.22002913f, -0.04623055f, 0.06770527f, 
    0.07007849f, 0.07302785f, -0.04223913f, 0.11354628f, 0.04253228f, -0.08017690f, -0.03973142f, 0.01788955f, 
    -0.08610227f, -0.13484931f, -0.23175861f, 0.19574516f, 0.14242886f, 0.27307349f, -0.01734586f, 0.14699459f, 
    -0.09305889f, 0.10495335f, 0.21771029f, -0.01885507f, 0.12221321f, 0.06899058f, 0.05465014f, 0.03626224f, 
    0.11520465f, 0.06129835f, 0.00147770f, -0.03572106f, 0.05187649f, 0.04652720f, 0.00250227f, 0.04464614f, 
    -0.17995699f, -0.02560365f, 0.14892775f, -0.05465510f, -0.07969895f, -0.08523008f, 0.03053321f, 0.18564765f, 
    -0.00865690f, 0.00688251f, -0.17436412f, -0.03095042f, 0.12881349f, -0.19467911f, -0.21737243f, -0.31891638f, 
    -0.07813273f, -0.13555203f, -0.01200873f, 0.01343760f, -0.05174482f, -0.03350909f, -0.04694813f, -0.01312186f, 
    0.23182181f, 0.16610822f, 0.02099224f, 0.22508882f, 0.00348473f, 0.04529700f, -0.00630295f, 0.01453111f, 
    0.02296764f, -0.04225855f, 0.34400707f, 0.14951982f, 0.47535753f, 0.18964502f, -0.12829316f, 0.25276983f, 
    0.09062438f, 0.01550564f, 0.14695108f, -0.20437358f, -0.03821563f, 0.07307959f, -0.10957708f, 0.01032996f, 
    0.69637555f, 0.18025140f, -0.03993217f, 0.16399737f, 0.00593104f, 0.11749022f, 0.10133822f, -0.07918823f, 
    -0.05271540f, -0.01005950f, 0.00915571f, -0.06849847f, 0.13356107f, 0.09712350f, 0.35549837f, 0.08825053f, 
    -0.02704626f, 0.03839869f, -0.06131131f, 0.09615193f, 0.05177352f, -0.04112499f, -0.17176364f, -0.17433518f, 
    -0.24875621f, -0.07483815f, 0.19565910f, -0.06994920f, 0.03539770f, 0.08165986f, -0.02099227f, -0.05194141f, 
    0.04505809f, 0.01534532f, 0.18744348f, -0.05443068f, -0.05291952f, 0.13802473f, 0.08665141f, -0.40517843f, 
    0.05063912f, 0.03758204f, -0.17716204f, -0.10625789f, 0.02035639f, 0.02482348f, -0.02638154f, -0.06492505f, 
    0.58485216f, 0.38147983f, -0.01504591f, 0.03485108f, -0.09330410f, 0.15651041f, 0.24916923f, 0.19843329f, 
    -0.04274903f, -0.03089429f, 0.02124280f, -0.06815490f, -0.04954708f, 0.03016780f, 0.31447017f, 0.06318927f, 
    -0.01347866f, 0.09417190f, -0.12118711f, -0.14410891f, 0.07721487f, 0.02010769f, 0.13011289f, -0.08018135f, 
    0.14903383f, 0.17749260f, 0.07742781f, -0.02067807f, -0.01706195f, -0.01751019f, -0.05234183f, -0.06189071f, 
    0.05240579f, -0.02325527f, 0.03768143f, -0.01041010f, 0.12449481f, 0.19057147f, -0.07849687f, -0.05168774f, 
    0.16926216f, -0.02653604f, 0.12410490f, 0.01956057f, -0.05954685f, -0.06219257f, -0.24842979f, -0.20124796f, 
    0.01361970f, 0.15443029f, 0.15773793f, 0.02507230f, 0.08208117f, 0.16475205f, 0.04825613f, -0.04021000f, 
    0.15184313f, 0.11842176f, 0.24686570f, 0.23561126f, -0.07713212f, -0.21063574f, -0.02259643f, -0.21243703f, 
    0.00249268f, -0.12369774f, 0.13075098f, 0.02393927f, -0.09293088f, 0.07806385f, -0.02738386f, 0.23807678f, 
    0.21542349f, -0.48787126f, -0.40123725f, -0.02709987f, -0.07037399f, -0.08427713f, 0.06459090f, 0.14472511f, 
    -0.02920811f, 0.07439241f, 0.02270353f, -0.03338569f, -0.10232228f, -0.02927252f, -0.06481536f, -0.41700295f, 
    -0.09789305f, -0.02316284f, 0.01533636f, 0.06506334f, 0.14161526f, 0.15625846f, 0.08802924f, -0.09598244f, 
    0.40145054f, 0.15674384f, 0.01723797f, -0.01994168f, -0.00406992f, 0.10021564f, -0.02109239f, -0.14924189f, 
    -0.13754173f, -0.00573598f, -0.10183918f, -0.16380206f, -0.03802826f, -0.04968731f, 0.12504925f, -0.10515803f, 
    0.05542244f, 0.08441694f, 0.01718080f, 0.07263698f, -0.06183790f, 0.03588940f, -0.03473542f, 0.10836317f, 
    -0.00677413f, 0.08820644f, -0.02737155f, 0.05319047f, -0.02640676f, -0.30563298f, 0.07497157f, 0.29763439f, 
    -0.00729314f, 0.10038347f, 0.11109752f, 0.01106841f, 0.06321382f, 0.12884432f, 0.11323556f, 0.06914821f, 
    -0.00487924f, 0.01323512f, -0.21228677f, -0.12707274f, -0.05766812f, -0.09177204f, -0.08522896f, -0.06103168f, 
    0.00894770f, -0.19853349f, -0.18130231f, 0.07440128f, 0.01022192f, 0.10080586f, 0.09598456f, 0.04156107f, 
    -0.02212586f, 0.11114107f, 0.09592165f, 0.01068447f, -0.16518266f, 0.00393018f, 0.02295010f, 0.08288474f, 
    0.13904965f, 0.08554126f, 0.04442272f, 0.04027766f, -0.04457241f, 0.10353775f, 0.10517778f, -0.11902890f, 
    0.02389429f, -0.02770473f, 0.05268234f, -0.15156665f, 0.15032762f, 0.01058302f, -0.00045573f, -0.11005587f, 
    -0.04421579f, -0.12279537f, -0.00870239f, -0.03104222f, -0.09014340f, -0.39987141f, -0.08290326f, 0.10428005f, 
    0.09058531f, -0.11668633f, 0.00290783f, 0.14255165f, -0.06970046f, 0.02579818f, -0.07035942f, -0.03218760f, 
    -0.31381491f, 0.22467831f, 0.04383698f, -0.30013978f, -0.23005220f, 0.17308988f, 0.25809580f, -0.05581976f, 
    0.04099394f, -0.08137649f, -0.14351751f, -0.06003488f, 0.00897345f, -0.11385874f, -0.05393618f, -0.25754556f, 
    -0.08728862f, -0.06255325f, -0.02702344f, 0.06789911f, 0.02621383f, 0.11697050f, 0.00230770f, 0.12630616f, 
    0.16242720f, -0.12932314f, -0.13116628f, -0.00588374f, 0.08944646f, -0.06062370f, -0.02500259f, -0.00817295f, 
    -0.06278527f, 0.01961379f, 0.10764223f, 0.07284010f, -0.07959765f, 0.12898798f, 0.03659916f, 0.10440831f, 
    -0.06715869f, -0.03266708f, 0.07759127f, -0.17939144f, 0.03713239f, -0.02667877f, 0.02813116f, -0.10528067f, 
    0.03046445f, 0.12293953f, -0.02302723f, -0.00250075f, 0.10961062f, -0.12026072f, 0.08963536f, -0.09592528f, 
    -0.13935602f, -0.00630136f, -0.09535932f, -0.04099162f, 0.09378532f, -0.34957072f, 0.11404502f, -0.31546086f, 
    -0.00610713f, -0.12650076f, -0.20073555f, -0.00395862f, 0.01771131f, 0.22959875f, 0.07334414f, -0.00167373f, 
    0.03213253f, -0.05034406f, -0.04464766f, -0.04722091f, -0.00498044f, -0.03905965f, -0.03641982f, -0.02321360f, 
    -0.03607826f, 0.00666547f, -0.02281426f, -0.00400669f, 0.02700674f, 0.03577946f, 0.03388767f, -0.01513316f, 
    -0.04568460f, 0.01426609f, -0.04138642f, -0.03070583f, 0.01616781f, -0.03685511f, 0.03761588f, -0.05890810f, 
    0.03644044f, -0.00223990f, 0.02352300f, 0.00539556f, -0.03532534f, 0.03864451f, 0.03585128f, -0.03747525f, 
    0.01133968f, 0.03473220f, -0.03945594f, 0.03442641f, -0.02064468f, -0.00471043f, -0.03327044f, -0.03012051f, 
    -0.05819154f, -0.00842849f, -0.00818563f, -0.04910257f, -0.05220119f, 0.01216186f, 0.01285613f, -0.01419782f, 
    0.01577653f, -0.00729203f, 0.00090400f, -0.05588822f, -0.03579855f, 0.04017477f, 0.01119385f, -0.05222901f, 
    -0.03917086f, -0.03995055f, -0.03167250f, -0.05855509f, 0.01657484f, -0.03757977f, -0.05355413f, 0.02539990f, 
    -0.03946634f, -0.00805646f, 0.02092011f, -0.03621929f, 0.01402858f, -0.04376466f, -0.00674726f, -0.02868366f, 
    -0.01334464f, 0.04515349f, -0.05403962f, 0.03805380f, -0.04178853f, -0.01099989f, -0.05497998f, 0.04227233f, 
    -0.02237137f, -0.05047794f, -0.03403340f, 0.03150753f, -0.03127895f, 0.00255167f, 0.00730813f, -0.00620304f, 
    -0.01845104f, 0.04099107f, -0.01380888f, -0.03440254f, -0.03419643f, -0.00519406f, 0.04157455f, 0.00011023f, 
    0.03534374f, -0.04661897f, -0.01262372f, -0.04516679f, 0.04063044f, -0.02244897f, -0.03800532f, -0.04946977f, 
    -0.02262616f, -0.02481610f, 0.00099773f, 0.00110526f, 0.02873489f, 0.01398720f, -0.01217206f, 0.01375536f, 
    -0.02881351f, -0.03527877f, -0.04969048f, -0.04025158f, 0.02300557f, 0.00815097f, -0.03704642f, 0.01887279f, 
    0.02002307f, -0.04392507f, -0.05511569f, -0.05119707f, 0.02008699f, -0.00838910f, 0.01359046f, -0.02542989f, 
    -0.02701361f, -0.03062478f, -0.03268242f, -0.04380231f, -0.04215545f, -0.03918436f, -0.00832304f, -0.00364006f, 
    0.04204497f, -0.00264439f, 0.04420715f, -0.01083079f, -0.04834259f, 0.02204470f, -0.03141906f, 0.02662175f, 
    0.05147558f, 0.02793161f, -0.03776474f, -0.04159557f, 0.02637736f, -0.02445598f, -0.02743418f, 0.03877208f, 
    0.01510304f, -0.05931390f, 0.03092138f, 0.03423295f, -0.00687464f, 0.01193384f, -0.02007491f, -0.01174889f, 
    -0.03877402f, 0.00610684f, -0.03909349f, 0.00560419f, -0.01486834f, -0.01818035f, -0.04090012f, 0.04396199f, 
    -0.00228409f, 0.04105314f, -0.01964104f, -0.02165755f, 0.02349192f, -0.00388539f, 0.00550187f, 0.02000489f, 
    -0.04580398f, -0.00765925f, -0.01213062f, -0.05699728f, 0.04086055f, 0.00653036f, -0.01184375f, -0.02746448f, 
    -0.02950546f, -0.05610374f, -0.00182658f, -0.04108543f, -0.01833488f, 0.02508677f, 0.00506592f, 0.01669170f, 
    0.01737370f, 0.03664042f, -0.04289666f, 0.01793649f, 0.03561310f, -0.03852505f, -0.00675926f, 0.00976703f, 
    -0.01510695f, 0.00309702f, 0.01162614f, 0.00570739f, -0.05477379f, -0.03152822f, 0.05667538f, 0.02526415f, 
    0.03219098f, 0.02358757f, 0.00980061f, 0.03077959f, -0.04553367f, -0.04715103f, 0.05210432f, -0.04517563f, 
    -0.01175399f, -0.04128106f, -0.04891429f, -0.03425410f, 0.02310606f, 0.00976071f, -0.02674715f, -0.05385466f, 
    -0.00563604f, -0.02029864f, -0.03413830f, -0.01664173f, -0.05659776f, -0.02034098f, 0.00740449f, 0.02587488f, 
    0.00756167f, -0.01939812f, -0.02748341f, -0.03225087f, 0.04516414f, -0.03547181f, -0.01201299f, 0.01464057f, 
    -0.04487575f, -0.00159719f, 0.02691448f, 0.02646462f, -0.01258153f, -0.05182510f, -0.03375858f, 0.04321693f, 
    0.00196117f, -0.03639478f, 0.04555244f, -0.03601298f, 0.04641936f, -0.01275237f, 0.03312542f, -0.05566494f, 
    0.03204250f, 0.01330371f, -0.02014267f, 0.04361641f, -0.05063106f, 0.02407300f, -0.01335093f, 0.02614684f, 
    -0.00374740f, -0.04656284f, -0.05102486f, 0.00369700f, 0.02142034f, -0.00493984f, -0.03551376f, 0.03353517f, 
    -0.01720565f, 0.02561689f, -0.05089828f, -0.04400705f, -0.03172048f, 0.04093909f, -0.02268491f, -0.00788100f, 
    0.04421856f, -0.01646490f, -0.05318441f, 0.01418714f, 0.01912141f, -0.04243429f, 0.01402398f, -0.00595066f, 
    -0.00546984f, -0.01650055f, -0.04838484f, -0.01904180f, -0.00349444f, -0.04790090f, -0.03364719f, -0.01792290f, 
    -0.00877258f, -0.05968328f, -0.01831692f, -0.02323798f, -0.01363813f, -0.03677077f, -0.04196085f, -0.04553767f, 
    0.02448291f, -0.01088630f, 0.00958245f, -0.05347071f, 0.01330074f, -0.01598858f, -0.05237963f, -0.04242395f, 
    0.01253094f, -0.02091308f, -0.01958644f, 0.03180460f, -0.04875449f, -0.00662292f, -0.04700536f, -0.01416549f, 
    -0.00348139f, 0.02257414f, 0.00474681f, 0.03977918f, -0.02315585f, 0.01003208f, 0.00807221f, -0.01579591f, 
    0.01127804f, 0.01041347f, -0.03158576f, 0.00657011f, 0.01417574f, -0.02660288f, -0.03843388f, -0.02147719f, 
    -0.03884777f, -0.05434987f, 0.01622986f, 0.01650225f, 0.01622456f, 0.01083069f, -0.04201041f, 0.04649396f, 
    0.03531568f, 0.00870881f, -0.02134776f, -0.00171062f, -0.01481104f, 0.01845883f, -0.02624182f, 0.00834132f, 
    0.03451161f, -0.05377539f, -0.04110868f, -0.02131532f, -0.01543505f, -0.01042399f, 0.01367941f, -0.03207031f, 
    -0.05462491f, 0.02909092f, 0.00613090f, 0.04336591f, 0.02740233f, -0.05505566f, -0.03780374f, 0.02043326f, 
    0.03087378f, 0.01246615f, -0.00642811f, -0.01680279f, 0.00871562f, -0.01687762f, -0.03572655f, -0.01196650f, 
    -0.02709725f, -0.01060257f, 0.02022701f, 0.00640023f, 0.02187413f, -0.00340822f, -0.05862350f, 0.03403885f, 
    0.36647573f, -0.15929994f, 0.17456828f, 0.17080228f, -0.09657714f, 0.05932907f, -0.09223814f, 0.01492150f, 
    0.05792138f, -0.15238762f, 0.09324017f, 0.07707909f, -0.02010106f, 0.08109394f, -0.03775339f, 0.05013065f, 
    0.09476365f, 0.20092309f, -0.02610505f, 0.06613676f, -0.03027854f, -0.13773870f, 0.06657063f, -0.13147327f, 
    0.22865924f, 0.02869537f, 0.10776749f, 0.34061483f, 0.11852261f, 0.10450004f, 0.02584164f, 0.16981390f, 
    -0.01585649f, -0.07561826f, 0.02609317f, -0.06397301f, 0.28927645f, 0.47915807f, -0.00318756f, -0.12204045f, 
    0.01721418f, 0.05535263f, 0.07859068f, 0.04218063f, -0.19076392f, 0.04126739f, -0.17799580f, -0.05974281f, 
    0.04615839f, 0.04354577f, -0.02805983f, 0.04463360f, 0.03026820f, 0.02931538f, -0.07341389f, -0.02885241f, 
    0.02022558f, 0.08801296f, 0.00860191f, 0.19445947f, -0.21895182f, 0.36592585f, 0.17899591f, -0.05430081f, 
    -0.21799238f, -0.08880761f, -0.12417544f, -0.08919255f, 0.00960774f, -0.03536225f, 0.27746326f, -0.13904384f, 
    0.32626137f, 0.14075622f, 0.06273844f, 0.10233158f, -0.09251378f, -0.14549148f, 0.02368864f, 0.08593568f, 
    -0.00965142f, 0.00073264f, 0.06281187f, 0.01205739f, 0.10048534f, 0.26216048f, -0.14650227f, 0.09111723f, 
    -0.05202566f, 0.01384543f, 0.01460760f, 0.06945401f, -0.09712283f, 0.05520542f, -0.05684394f, -0.05773022f, 
    0.08219212f, 0.02177742f, 0.08997106f, -0.25813401f, -0.02016182f, 0.00118746f, 0.10481430f, 0.15030843f, 
    0.00125963f, 0.04317687f, -0.05635611f, -0.07769796f, 0.20258576f, 0.13086845f, 0.00803335f, 0.37270802f, 
    -0.24225704f, -0.06439736f, -0.06437032f, 0.16274360f, -0.07589462f, -0.07619424f, 0.05679869f, -0.04238703f, 
    -0.19185612f, -0.23200296f, 0.60569841f, -0.16464546f, -0.09860684f, 0.27453256f, -0.03610697f, -0.33432177f, 
    -0.02765613f, 0.07424057f, -0.13433622f, 0.00198168f, -0.03138717f, 0.08754376f, -0.12018938f, 0.05198152f, 
    -0.03001916f, 0.00721020f, 0.07544296f, 0.09355122f, 0.06377274f, 0.23784928f, -0.13893275f, -0.07862019f, 
    0.00630048f, 0.08676723f, 0.07980022f, -0.01277947f, -0.05384937f, -0.00008907f, -0.04812655f, 0.01249460f, 
    0.02529513f, 0.03760968f, -0.07377818f, -0.00209971f, 0.01281711f, 0.10006142f, 0.05884936f, 0.05581545f, 
    -0.11264782f, -0.02618405f, -0.10073664f, -0.12344734f, 0.00979039f, -0.12872484f, 0.12599577f, 0.07585471f, 
    0.07421008f, -0.01882056f, 0.09389302f, 0.08945583f, 0.02497315f, -0.03235842f, -0.14936477f, 0.08996860f, 
    0.33435607f, 0.00251454f, 0.09077890f, 0.15186580f, -0.04678471f, 0.19445890f, 0.15305029f, 0.05655724f, 
    0.08002292f, 0.14458890f, -0.12602317f, -0.03139647f, 0.00786805f, -0.02030165f, -0.04542942f, 0.17501061f, 
    0.17722254f, 0.05249344f, 0.08487390f, 0.12261306f, -0.01560937f, -0.09824355f, 0.09788883f, -0.05240323f, 
    -0.02913772f, 0.00377740f, -0.13185789f, 0.07273035f, 0.16833080f, -0.06567705f, -0.09608404f, 0.20431662f, 
    -0.03077072f, -0.00581941f, -0.10392953f, -0.27983975f, -0.00681479f, -0.00859717f, -0.04559951f, 0.05612228f, 
    0.06984711f, 0.06202755f, 0.15235107f, 0.00100782f, -0.13084260f, -0.02729637f, -0.06820952f, 0.08985479f, 
    0.02234797f, 0.05992451f, -0.02853771f, 0.03113819f, -0.19103537f, -0.17845787f, -0.03337588f, 0.09532226f, 
    -0.18862323f, 0.00758479f, -0.05305021f, -0.05740491f, -0.03545189f, -0.05341456f, -0.03713161f, -0.21746029f, 
    -0.13950321f, -0.05495865f, 0.11270981f, 0.21256898f, -0.00673060f, 0.08370060f, 0.00382557f, 0.02693284f, 
    0.06407809f, 0.13666320f, -0.09576705f, 0.05540756f, 0.21309483f, 0.17600127f, -0.09974710f, -0.08304704f, 
    0.04057676f, -0.04343981f, 0.13239783f, 0.04269297f, -0.01664256f, 0.12231769f, -0.19552319f, -0.10070100f, 
    0.36310729f, 0.21036319f, -0.21517916f, 0.23316668f, 0.12585717f, 0.07018030f, -0.06915660f, 0.07413931f, 
    0.05962126f, -0.03295951f, 0.10354562f, 0.08687431f, -0.43859258f, 0.18908043f, -0.34185115f, 0.02680442f, 
    -0.11684251f, 0.10086709f, -0.05185557f, -0.12569201f, -0.25700846f, -0.07932346f, -0.19731577f, 0.12189715f, 
    -0.05835303f, 0.08332453f, 0.02730247f, 0.07987951f, -0.14780529f, -0.01748031f, -0.02245588f, 0.02733717f, 
    0.08630309f, 0.03068605f, 0.05233332f, -0.07510494f, 0.01030838f, 0.06053095f, -0.00033579f, -0.03209142f, 
    -0.01105689f, 0.10666752f, 0.04455349f, 0.10193890f, -0.01835439f, -0.09542458f, -0.07112640f, -0.05250344f, 
    0.41748652f, -0.07533292f, 0.22972178f, -0.11774175f, -0.01054120f, 0.06518672f, -0.00997374f, 0.02592591f, 
    -0.11728797f, 0.12076607f, -0.01907013f, 0.01662382f, 0.16691621f, -0.01622578f, -0.00540313f, 0.17969847f, 
    -0.05035196f, -0.13334502f, -0.04586505f, 0.09077340f, 0.00032712f, -0.06077327f, -0.00795179f, -0.00001444f, 
    0.34497297f, -0.05633003f, 0.16962290f, 0.24739538f, 0.13393506f, 0.10093164f, -0.09831610f, 0.09641451f, 
    0.00092417f, -0.15167017f, -0.11306920f, -0.06551073f, 0.03613554f, 0.12510128f, -0.02912632f, 0.11309196f, 
    0.02935904f, -0.05460158f, -0.06396496f, 0.04641151f, -0.07384352f, -0.00614968f, 0.05728115f, -0.08411307f, 
    0.16613171f, -0.02831745f, 0.14256725f, 0.11337851f, -0.12106207f, 0.09568279f, 0.10057049f, -0.07603621f, 
    -0.14644301f, -0.08494857f, -0.07994775f, -0.06555997f, 0.16513692f, -0.13402593f, 0.01573878f, 0.01369118f, 
    -0.00982593f, 0.14694583f, 0.04710043f, 0.03369171f, 0.07549915f, -0.03681359f, 0.00620026f, 0.02754564f, 
    -0.30463246f, 0.36536932f, -0.07297940f, 0.08130608f, 0.01428772f, -0.03200709f, -0.05534106f, -0.06630140f, 
    0.02121770f, -0.14358421f, 0.12935473f, -0.06944522f, -0.14333960f, -0.29465276f, -0.03627095f, -0.04554927f, 
    -0.03101722f, -0.02201737f, -0.00960702f, -0.09417717f, 0.06139811f, 0.04216984f, 0.06196601f, 0.09709635f, 
    0.04923737f, 0.16698301f, 0.11640669f, -0.13440014f, -0.04349574f, 0.14085619f, 0.02462349f, -0.06192159f, 
    0.03998971f, 0.08309666f, 0.01707586f, 0.07202914f, -0.51629192f, 0.02292852f, -0.02614008f, 0.12792750f, 
    -0.05964164f, -0.05981451f, -0.09900633f, 0.09239426f, 0.15100539f, 0.08923162f, 0.06642672f, -0.06877995f, 
    -0.27732471f, 0.00376347f, 0.02134349f, -0.28408429f, -0.04885473f, 0.04916111f, -0.06822454f, 0.07473690f, 
    0.08008640f, -0.09651320f, -0.38309118f, -0.22256549f, 0.00825742f, 0.08374691f, 0.09552090f, 0.04235896f, 
    0.24784765f, 0.14672621f, 0.02640115f, 0.51773715f, 0.01092837f, 0.06838439f, -0.21521901f, -0.02457040f, 
    0.10336608f, 0.06731502f, 0.00747943f, 0.06237476f, -0.05892326f, -0.00509635f, -0.06109998f, 0.09647628f, 
    0.01344928f, -0.07126892f, -0.00922322f, -0.06029195f, 0.02545791f, 0.06281165f, -0.03349755f, 0.00366629f, 
    -0.21197441f, 0.12786111f, 0.04966171f, -0.11368363f, 0.10073125f, -0.01370049f, 0.23738545f, 0.17439383f, 
    0.09226420f, -0.08766501f, 0.04965311f, 0.30063185f, 0.09155301f, 0.06076838f, 0.07107297f, 0.09401111f, 
    0.06756260f, 0.02820274f, 0.16479452f, 0.00233804f, 0.07255636f, 0.09756790f, 0.18375368f, -0.19526966f, 
    0.13814500f, 0.00334747f, 0.08695464f, 0.06052672f, -0.04244321f, -0.06375308f, -0.11547758f, -0.04037296f, 
    -0.32954708f, 0.25958952f, 0.06270225f, 0.24729651f, 0.31017813f, 0.01413342f, 0.12336987f, 0.24024393f, 
    -0.04258923f, -0.08634621f, 0.10633878f, 0.03829192f, 0.20382729f, -0.00842535f, -0.05015362f, 0.25300232f, 
    0.00090029f, -0.05686803f, -0.19321199f, -0.16124593f, 0.08142114f, 0.03325866f, 0.25512421f, 0.09334130f, 
    -0.16019267f, -0.07950727f, -0.13896155f, -0.09802969f, -0.03488800f, -0.00702693f, 0.02607027f, 0.01689826f, 
    -0.06256742f, 0.05069130f, 0.11603236f, -0.02301199f, -0.07379889f, -0.06851146f, 0.00651890f, -0.02337867f, 
    0.08691609f, 0.12051981f, 0.08961193f, 0.17612772f, -0.05060063f, 0.12408116f, 0.13204053f, 0.02199132f, 
    -0.20100877f, -0.08198297f, -0.17939626f, -0.26804337f, -0.19299436f, -0.01884818f, -0.00602942f, 0.04650453f, 
    -0.21194361f, -0.13861807f, -0.33327547f, -0.04846507f, 0.16369832f, -0.01242375f, -0.04406115f, 0.07485052f, 
    0.04161644f, -0.11398073f, 0.18485674f, 0.06321355f, -0.07783740f, -0.01941610f, -0.02982529f, -0.06852120f, 
    -0.04444157f, -0.19610758f, 0.15075883f, -0.13677382f, -0.03285776f, 0.02928040f, -0.05281690f, 0.18896830f, 
    0.05711317f, 0.12489665f, -0.14000811f, -0.15090364f, -0.37376279f, 0.04353565f, -0.00466552f, -0.08980968f, 
    0.02584059f, 0.00796647f, -0.02293408f, 0.26981431f, -0.08762346f, -0.18909423f, 0.03251301f, -0.06370466f, 
    -0.17248647f, -0.02375359f, -0.07202028f, 0.03287040f, 0.20179427f, -0.05013820f, 0.09335215f, 0.08523276f, 
    0.04113810f, 0.03711941f, 0.04605749f, 0.17046064f, 0.12506998f, 0.26386023f, 0.11672366f, 0.05140182f, 
    0.16407137f, 0.25559196f, 0.27812731f, 0.09173853f, 0.11563173f, 0.12957248f, 0.12018728f, 0.00678390f, 
    -0.09754979f, 0.24380283f, 0.10794415f, -0.00602336f, -0.01954901f, -0.15783605f, -0.05608795f, -0.14535581f, 
    -0.19580178f, 0.10665435f, -0.09373414f, -0.07554064f, -0.20022760f, -0.12102241f, 0.05294257f, 0.15941361f, 
    -0.12113045f, -0.02627639f, 0.03626821f, -0.11313993f, 0.18752827f, 0.05065035f, 0.24882692f, 0.10119496f, 
    -0.25469720f, 0.01098680f, 0.11903936f, -0.09448516f, -0.00640832f, -0.08688639f, 0.07197841f, -0.02632704f, 
    0.07873990f, -0.12786151f, -0.10324721f, -0.05999751f, 0.34393099f, -0.12856346f, 0.28030640f, 0.02482350f, 
    0.18220535f, 0.10308544f, 0.15096685f, 0.01152064f, 0.01782517f, 0.00254278f, -0.02807507f, -0.01930350f, 
    0.23099940f, -0.11932117f, 0.19550435f, -0.06016652f, 0.06204182f, 0.13582514f, 0.06192270f, 0.08429580f, 
    -0.02258605f, 0.12583996f, 0.06204903f, 0.07365724f, 0.03245537f, -0.01532625f, 0.10228542f, 0.15230578f, 
    0.08146508f, 0.18571068f, 0.06446808f, 0.04353219f, 0.09519890f, -0.03509671f, 0.03245733f, 0.06727490f, 
    -0.45540470f, -0.02055469f, -0.07448857f, -0.07661036f, 0.02846424f, 0.01980080f, 0.37497592f, 0.11481467f, 
    0.05725944f, 0.08690870f, 0.11624010f, 0.09510008f, -0.00600007f, -0.13925415f, 0.02686860f, -0.01673841f, 
    0.05470738f, -0.07138516f, -0.08434339f, 0.04089901f, -0.07850853f, -0.21018390f, -0.07109689f, -0.34455666f, 
    -0.47542572f, -0.03476172f, 0.13609570f, -0.04093734f, -0.13210240f, 0.08969104f, 0.01397944f, 0.13047676f, 
    0.07313180f, 0.01054733f, -0.02666884f, 0.14613144f, -0.08963738f, 0.26479268f, 0.01614732f, 0.22250445f, 
    0.06478917f, -0.01900027f, -0.00600631f, 0.04167741f, 0.20591775f, 0.15531915f, -0.06587747f, 0.19116531f, 
    -0.11245649f, 0.04578611f, -0.03439530f, -0.25184390f, 0.13979162f, 0.15929891f, -0.07403622f, 0.25957116f, 
    0.31839296f, 0.19229601f, 0.10018048f, 0.37569585f, -0.04821410f, -0.10014935f, 0.05278873f, -0.09641916f, 
    -0.16974349f, -0.06465463f, -0.11797275f, 0.09347101f, 0.04937030f, -0.22711568f, -0.04552892f, -0.08097348f, 
    0.03460192f, 0.15652235f, 0.00738575f, 0.13824357f, 0.09180368f, 0.05704297f, 0.23270041f, -0.20652102f, 
    -0.03028885f, 0.04163023f, -0.02163105f, 0.17363410f, -0.31124890f, -0.01681737f, -0.10926004f, -0.19181086f, 
    0.00163429f, -0.02982582f, 0.02868837f, -0.01890822f, -0.09555233f, 0.03075253f, 0.01075417f, -0.04274059f, 
    0.02321588f, 0.08423749f, 0.02792776f, 0.41503093f, 0.09649745f, 0.03879556f, -0.08529872f, -0.19164491f, 
    0.09461550f, 0.08404871f, -0.08507409f, 0.06197925f, -0.18853042f, 0.25302258f, -0.12423442f, 0.09994871f, 
    0.11048424f, 0.08842395f, 0.00298116f, 0.11791322f, -0.09206572f, -0.09983756f, 0.03541392f, 0.01110835f, 
    0.06346343f, 0.23437011f, -0.17088977f, -0.01741961f, -0.00183206f, 0.03700408f, -0.02780323f, 0.07508705f, 
    -0.04327255f, -0.01722943f, -0.04615131f, -0.05546695f, 0.00652594f, 0.18012533f, -0.12168381f, 0.26568115f, 
    -0.02615375f, 0.10694079f, -0.02793672f, 0.14444017f, 0.02598399f, 0.01049156f, 0.04964621f, 0.08780583f, 
    0.23069830f, 0.19057353f, 0.21588090f, 0.08872826f, -0.02702762f, -0.00733410f, -0.02665729f, -0.03105153f, 
    -0.08323357f, -0.03977756f, -0.01418847f, 0.05426238f, 0.03982724f, 0.19005448f, -0.09262717f, 0.17430465f, 
    -0.09849171f, -0.05774204f, 0.03795918f, 0.00822924f, -0.11839332f, 0.09070056f, -0.01701499f, 0.11974669f, 
    0.18992317f, -0.16797562f, 0.35557467f, -0.19759083f, 0.02704500f, -0.01747383f, 0.10189060f, 0.04464791f, 
    0.13095367f, 0.02547122f, 0.03590277f, 0.07257529f, 0.08581967f, 0.02655622f, 0.21398385f, 0.33444756f, 
    -0.04789708f, -0.06555570f, -0.00513760f, -0.02777611f, -0.03712786f, -0.00041766f, -0.01170285f, 0.02125999f, 
    0.51124322f, -0.36691579f, 0.34081569f, -0.11404110f, 0.14419155f, -0.00541795f, -0.04109573f, 0.01596408f, 
    -0.13021837f, 0.14620699f, -0.01165698f, -0.01841702f, 0.02104422f, 0.01571837f, 0.03724508f, 0.04255702f, 
    -0.07177380f, -0.09701130f, 0.08070042f, -0.06524375f, 0.13908954f, 0.02007451f, 0.04116463f, 0.22237729f, 
    -0.03998486f, -0.01056288f, 0.01666551f, -0.06615902f, -0.06942017f, -0.11699119f, -0.03461433f, -0.00129716f, 
    0.12326922f, 0.07571035f, 0.05862152f, 0.14701687f, 0.01568227f, 0.09258982f, -0.04552827f, -0.00342282f, 
    -0.18051532f, 0.14678697f, 0.07099676f, -0.07021093f, -0.02443528f, -0.01758116f, -0.11428969f, -0.02452123f, 
    0.13739705f, -0.00565544f, 0.09868284f, -0.04675559f, -0.07809346f, -0.04799895f, 0.02353129f, 0.05878461f, 
    0.05226253f, -0.17111193f, 0.05926174f, -0.07837089f, 0.21655366f, -0.11611526f, 0.08436112f, 0.19337225f, 
    0.03245091f, 0.09143554f, -0.27593368f, 0.16203129f, 0.02525059f, -0.02194335f, 0.08635016f, -0.02400946f, 
    0.01383148f, 0.25582239f, -0.11008471f, 0.22220491f, -0.06876545f, 0.15673956f, -0.01936764f, 0.05038293f, 
    0.20409964f, -0.06373336f, -0.00975604f, -0.02814787f, 0.06686235f, -0.20811976f, -0.28092355f, 0.16855294f, 
    0.18039109f, 0.13510725f, 0.01645061f, 0.04064571f, -0.08940426f, -0.16554001f, 0.05792818f, -0.02781516f, 
    0.12741402f, 0.07579841f, 0.11396770f, 0.02296492f, -0.03832570f, -0.05749083f, -0.04499638f, -0.07241994f, 
    -0.00737587f, -0.00324816f, 0.05097442f, -0.03006361f, 0.37682402f, -0.05738285f, 0.34426937f, -0.32631528f, 
    -0.14813213f, 0.14993230f, -0.12020145f, 0.10992148f, 0.04819010f, 0.13354650f, 0.00059336f, -0.11540119f, 
    0.04181073f, 0.05101383f, -0.10358096f, 0.27072880f, 0.00840172f, 0.15534252f, 0.06506280f, 0.26077601f, 
    -0.05610441f, 0.08418660f, 0.09449787f, 0.08519055f, -0.04881328f, -0.02157942f, -0.05126581f, -0.04479726f, 
    -0.05265669f, -0.06241801f, -0.01438208f, -0.04558342f, 0.07900216f, 0.06034934f, 0.03897131f, 0.16365352f, 
    -0.03987904f, 0.02208204f, -0.15855937f, 0.06031344f, 0.16666219f, 0.00648457f, 0.03268469f, -0.06006255f, 
    0.08492029f, 0.14550103f, 0.19251558f, 0.13912219f, -0.13941453f, 0.40589824f, -0.30451605f, -0.02352669f, 
    0.00357226f, 0.01959597f, 0.05797709f, 0.06308453f, -0.02139306f, 0.12560621f, -0.03009376f, 0.16783339f, 
    -0.07554132f, 0.14641957f, 0.10366448f, 0.08642922f, 0.06391020f, -0.06996840f, -0.02999102f, -0.06744603f, 
    0.11081289f, -0.02853582f, 0.03950541f, 0.04326969f, 0.04712257f, 0.09246482f, 0.15070657f, 0.14744559f, 
    -0.09068145f, -0.02766421f, -0.00067958f, -0.25334260f, -0.06875278f, 0.04190296f, 0.00836299f, 0.03207010f, 
    0.11254879f, -0.20657079f, 0.05856125f, 0.16958134f, 0.23058477f, -0.03164090f, -0.04531199f, -0.10463711f, 
    -0.13872077f, 0.05418552f, 0.00085412f, -0.07836110f, -0.11099184f, 0.05227740f, 0.06084675f, 0.09844986f, 
    0.02469108f, 0.07838740f, 0.09101561f, 0.02600122f, 0.02658568f, -0.10673408f, -0.09840272f, -0.02710094f, 
    0.23412575f, 0.08307538f, -0.05092872f, 0.34549791f, 0.04403774f, 0.10272563f, -0.03707243f, -0.09256974f, 
    -0.04157825f, 0.09751152f, 0.05971964f, 0.12216389f, -0.24207929f, 0.14230451f, -0.01931811f, 0.17765765f, 
    0.06941745f, 0.02607227f, -0.00172062f, 0.00644339f, 0.01126049f, -0.00809246f, 0.23387142f, -0.06445128f, 
    0.04960752f, -0.07845746f, -0.04151073f, 0.10282442f, 0.05694390f, -0.07588058f, -0.07226215f, -0.00819860f, 
    0.01670677f, 0.09151597f, 0.17161873f, -0.02144622f, -0.34569618f, -0.28020087f, -0.29377434f, -0.05834456f, 
    0.00452809f, 0.25852513f, -0.09947961f, 0.24825266f, 0.08786470f, 0.05604408f, -0.01334384f, -0.15312208f, 
    0.13160568f, -0.25761312f, 0.28455532f, -0.22073245f, 0.09181295f, 0.07711952f, -0.03673889f, 0.17709319f, 
    0.08997666f, 0.21929443f, 0.00392638f, 0.01983217f, 0.14787479f, 0.04706706f, -0.09926440f, 0.01210006f, 
    -0.00470394f, -0.05052824f, -0.05627043f, 0.05564189f, 0.08819638f, 0.05328590f, 0.00511218f, -0.03387886f, 
    -0.43443292f, -0.38703886f, 0.15520045f, -0.07957088f, 0.00706452f, -0.06990799f, 0.07940745f, -0.04548284f, 
    0.02201866f, 0.00549767f, -0.05780955f, 0.04864151f, 0.33229709f, 0.16483903f, 0.40730864f, 0.25494766f, 
    -0.07522880f, -0.07118908f, 0.01822681f, 0.16930869f, 0.15003832f, 0.10378283f, 0.10586988f, 0.15751405f, 
    0.24251021f, -0.09718338f, 0.09790473f, 0.00861760f, 0.05188913f, -0.06410871f, -0.00445645f, -0.02284162f, 
    0.11038260f, 0.07710318f, 0.35749283f, 0.05600579f, 0.09753212f, -0.30727994f, -0.09196344f, -0.09635304f, 
    0.01849478f, 0.11271083f, 0.05491108f, -0.06887414f, 0.09555976f, -0.04653142f, 0.05040142f, 0.00362735f, 
    -0.41628021f, 0.01073025f, -0.00991741f, -0.16969848f, -0.01233382f, 0.05050523f, -0.00159129f, -0.02430132f, 
    0.04179132f, -0.02745763f, -0.02816745f, -0.00486498f, 0.09468915f, -0.27499232f, 0.10780525f, -0.06411689f, 
    0.12544584f, -0.09972551f, -0.03712794f, -0.03493546f, 0.11365722f, 0.09533376f, -0.06379677f, 0.22522011f, 
    0.49086893f, 0.27546525f, -0.35241669f, 0.27560788f, -0.06722389f, 0.21559072f, -0.08799087f, -0.10546369f, 
    0.08721170f, -0.06179585f, 0.22400881f, 0.18973754f, -0.45834950f, -0.31138849f, -0.12942322f, 0.10656813f, 
    -0.03750360f, 0.04541878f, -0.02030594f, 0.09596383f, 0.02946853f, -0.03745175f, -0.00478551f, -0.00487079f, 
    0.13069077f, 0.07641830f, -0.43346289f, 0.16253936f, -0.09453292f, -0.13098621f, 0.10827647f, 0.18180901f, 
    0.05004707f, 0.08210415f, 0.01511178f, 0.00230193f, 0.08630178f, 0.00149913f, 0.07033757f, -0.16308631f, 
    0.04548787f, -0.03156217f, 0.05357627f, 0.10240488f, -0.04998117f, 0.01785198f, -0.07596221f, 0.05872428f, 
    0.10030259f, 0.06729479f, -0.07626129f, -0.00512421f, -0.01113694f, -0.01520176f, 0.01796439f, 0.00641880f, 
    -0.03465296f, -0.04868676f, 0.08209250f, 0.12853974f, -0.09211571f, -0.28640246f, 0.01939124f, 0.01850813f, 
    -0.02697406f, 0.10998695f, 0.00580780f, 0.06217138f, 0.09081470f, 0.01289056f, -0.07643015f, 0.08420606f, 
    0.03742140f, -0.00088952f, -0.08066529f, 0.03705245f, 0.07965090f, -0.00490517f, 0.00607927f, 0.03069345f, 
    -0.12718356f, 0.06628415f, 0.08353041f, -0.03949391f, -0.04365816f, -0.05128343f, -0.00260791f, 0.19914874f, 
    -0.03541358f, 0.24783504f, 0.16815557f, -0.09154888f, -0.03665043f, 0.03892120f, 0.06313688f, -0.07261554f, 
    -0.20485607f, 0.55652529f, 0.52509892f, -0.07644603f, -0.17152470f, 0.01804162f, 0.12559892f, 0.05383278f, 
    0.26942164f, 0.00331824f, 0.27562043f, 0.13283703f, 0.07700011f, -0.03426109f, 0.31499740f, 0.10015565f, 
    0.00713615f, -0.04466743f, 0.26133516f, 0.02434113f, 0.20422994f, 0.15085900f, -0.02192499f, 0.08926839f, 
    -0.11020303f, -0.01974689f, -0.08185209f, 0.07085992f, -0.00026803f, 0.10899247f, 0.13177322f, 0.04503476f, 
    0.02907830f, 0.04849345f, -0.02026478f, -0.04971468f, 0.12963004f, 0.04659407f, -0.14922008f, 0.03974511f, 
    0.17692719f, -0.19639120f, 0.08876962f, -0.04597966f, 0.04890943f, 0.02840236f, 0.02686380f, 0.13811921f, 
    -0.13856308f, -0.31284469f, 0.16283469f, -0.16486880f, 0.05718896f, 0.08021594f, -0.13659465f, 0.08259027f, 
    0.22189181f, -0.10196475f, 0.05673477f, 0.04055709f, 0.29377007f, -0.02722475f, 0.01161567f, -0.02793336f, 
    0.11767428f, -0.00639681f, -0.05156685f, 0.08107084f, 0.10206115f, 0.00919700f, 0.16415302f, 0.21229701f, 
    -0.15609698f, -0.35509884f, -0.06659686f, 0.13451540f, 0.01335224f, 0.06585198f, 0.01621925f, 0.12009826f, 
    -0.01793592f, 0.00625028f, 0.04223182f, -0.05758682f, 0.33762720f, -0.30986789f, -0.17028660f, 0.18212555f, 
    -0.02142984f, 0.01395525f, -0.09738424f, 0.04287375f, 0.13759993f, 0.03990858f, 0.25148064f, 0.12230265f, 
    -0.08792815f, 0.13104269f, -0.19848232f, 0.07927431f, 0.09562701f, 0.00300604f, 0.01792892f, -0.00787911f, 
    -0.03332405f, -0.02932866f, 0.03108181f, 0.02503127f, -0.35154560f, -0.08439697f, -0.12425419f, -0.11080573f, 
    -0.08944646f, -0.07158396f, -0.07919895f, -0.15146835f, 0.01053406f, 0.01023363f, -0.08281354f, -0.00824414f, 
    0.30790585f, -0.06772251f, -0.09836063f, 0.20601141f, 0.13372150f, -0.07513380f, -0.23908199f, 0.37699932f, 
    0.19835623f, 0.04918195f, 0.00406322f, 0.03831897f, -0.01937756f, 0.26831096f, 0.23110601f, 0.30899972f, 
    -0.03175152f, -0.11174355f, 0.11226412f, 0.07279734f, 0.01986019f, 0.00488225f, -0.00596327f, 0.09860046f, 
    -0.13509198f, -0.35915595f, -0.03356459f, -0.10998382f, -0.09219025f, -0.18382508f, 0.00589260f, -0.03172434f, 
    -0.05024485f, -0.04146706f, -0.03602607f, -0.08464107f, 0.26451290f, -0.02775823f, 0.19681410f, 0.02905071f, 
    0.08466983f, 0.02493878f, 0.01421040f, 0.12908781f, 0.09635822f, 0.07666954f, 0.12673035f, 0.06646798f, 
    -0.08038340f, -0.04772082f, 0.01348577f, 0.05384840f, -0.01657052f, -0.02310317f, 0.16399641f, 0.08513960f, 
    0.05795849f, -0.02605912f, 0.06180147f, 0.00851461f, -0.02649559f, 0.48195925f, 0.15958321f, 0.19451880f, 
    -0.12643889f, -0.18619691f, 0.05111399f, -0.05225217f, -0.05289439f, 0.08472753f, -0.04688815f, 0.19757909f, 
    0.37841704f, -0.14205281f, -0.00146203f, 0.02973589f, -0.10264955f, 0.02712545f, 0.01883201f, 0.05871671f, 
    0.24772039f, -0.12657054f, -0.06579614f, -0.07539104f, 0.04980394f, -0.20614903f, 0.13464889f, 0.07672217f, 
    -0.00741324f, -0.08851982f, 0.00050819f, -0.04529175f, 0.28113776f, -0.00309694f, -0.11669561f, 0.13347265f, 
    0.25918490f, 0.09532419f, -0.14233190f, -0.14951420f, -0.06966702f, 0.06079954f, 0.04806658f, 0.05854793f, 
    0.03020948f, 0.04806764f, 0.13098648f, 0.11278517f, -0.00685030f, -0.24094242f, 0.06514720f, -0.15407108f, 
    -0.18174322f, -0.06582900f, -0.09798220f, -0.01459723f, 0.08060701f, 0.03553851f, 0.09731650f, 0.00997823f, 
    -0.04266033f, -0.21870153f, 0.31476969f, -0.00481070f, -0.00520682f, 0.02539584f, 0.02169321f, -0.01405134f, 
    -0.16242029f, -0.09723292f, -0.19248301f, -0.17466716f, 0.30238834f, 0.02155877f, 0.22394940f, -0.21838979f, 
    0.17628115f, 0.15385747f, 0.01726011f, 0.04713520f, -0.01380205f, -0.03166980f, -0.15181753f, -0.10786217f, 
    -0.02019273f, 0.15305051f, 0.06525040f, 0.38522592f, 0.10909437f, -0.01808057f, 0.02769976f, 0.02922367f, 
    -0.01830051f, -0.01066960f, -0.05668260f, 0.01812771f, 0.16881679f, -0.21185236f, 0.11986995f, 0.01987936f, 
    -0.05109167f, 0.01341560f, 0.03044850f, -0.14634471f, 0.11612967f, 0.03742823f, 0.01159235f, 0.27221128f, 
    -0.44478324f, 0.17297876f, 0.04780384f, 0.04186928f, 0.08719413f, -0.19541669f, -0.01262328f, 0.02724411f, 
    0.11545840f, -0.01196220f, 0.06540421f, 0.05759774f, 0.17792150f, 0.12443352f, 0.00631046f, -0.13472973f, 
    -0.09695540f, 0.01624431f, 0.10359781f, 0.07178626f, -0.16716710f, -0.00766299f, 0.02714267f, -0.07894437f, 
    -0.36037105f, 0.23164572f, -0.17586210f, 0.04253445f, 0.15332873f, -0.06279444f, 0.04611031f, 0.22974329f, 
    0.13875842f, -0.09676553f, 0.17946337f, 0.14507893f, 0.28193849f, -0.17819425f, 0.09835478f, 0.09239221f, 
    -0.07089028f, -0.13820137f, -0.03292422f, -0.08327723f, 0.01265364f, -0.00643204f, 0.17289595f, 0.01241974f, 
    -0.00650372f, -0.02787966f, 0.02246970f, 0.05281705f, -0.02956476f, -0.01672096f, -0.13309120f, -0.14221105f, 
    -0.04987320f, 0.02416543f, 0.11753549f, 0.06879190f, -0.15904362f, -0.01886029f, 0.02759076f, -0.17496961f, 
    0.36457327f, 0.18401039f, -0.02812551f, 0.25480291f, 0.05237202f, 0.09127760f, 0.06589961f, 0.00110367f, 
    -0.19112147f, -0.04261499f, 0.00248616f, 0.05701328f, 0.02866591f, -0.00650350f, 0.01265297f, -0.05715754f, 
    -0.13852383f, -0.12604019f, -0.12183042f, 0.01444594f, -0.14875926f, 0.22300057f, 0.08452807f, -0.04442969f, 
    0.15244752f, -0.05409124f, -0.07123278f, -0.06043515f, -0.04143464f, -0.04769010f, -0.00707662f, 0.04594917f, 
    0.64620024f, -0.65623653f, 0.04132414f, -0.25651371f, 0.07608958f, -0.06265225f, -0.02645970f, 0.03105358f, 
    0.02605564f, -0.01001017f, -0.02535879f, -0.05346004f, 0.08936419f, -0.24631694f, -0.06945102f, -0.37679082f, 
    0.04398611f, 0.08376168f, -0.03835449f, 0.07345970f, 0.04432227f, -0.05023086f, 0.08315970f, -0.05433537f, 
    -0.13420939f, 0.13174346f, -0.01664196f, 0.16487272f, 0.17096448f, -0.03479489f, 0.07162549f, -0.00846852f, 
    0.00122737f, -0.05421206f, -0.01934466f, 0.12029230f, -0.37435177f, 0.25170305f, -0.01011088f, 0.27405450f, 
    0.20398495f, -0.02646072f, 0.21121532f, -0.01579262f, 0.01610409f, 0.01752221f, 0.10521924f, 0.19238192f, 
    0.17547175f, 0.10108120f, 0.07246377f, -0.27377546f, 0.05192243f, -0.03699096f, -0.04952866f, 0.02463216f, 
    -0.01689304f, 0.06403624f, -0.04504816f, -0.09141466f, 0.01964957f, -0.05722887f, 0.14348644f, 0.24009660f, 
    -0.18294761f, 0.00030996f, 0.00610439f, -0.05195116f, -0.01487083f, 0.05996434f, 0.19016419f, 0.14420663f, 
    0.24500729f, 0.17104462f, 0.17060480f, -0.20991474f, 0.02921015f, 0.00433008f, 0.10792573f, 0.06741019f, 
    -0.01149270f, -0.04454171f, 0.05109936f, -0.01735524f, 0.50000769f, -0.09165592f, 0.34262210f, -0.23354545f, 
    0.18292694f, 0.01276528f, 0.06401124f, -0.15965670f, 0.00553765f, -0.10887092f, 0.02800427f, 0.01161022f, 
    0.06442845f, -0.18499893f, 0.08653648f, -0.08688112f, 0.07784427f, 0.06129318f, 0.10241694f, 0.03607845f, 
    0.05409879f, 0.01937691f, -0.05223458f, -0.06241441f, 0.35807550f, 0.15904468f, 0.02533080f, -0.30649900f, 
    0.07925360f, -0.07531103f, 0.02434858f, 0.05163429f, 0.03524741f, 0.06501052f, 0.12878238f, 0.16516574f, 
    -0.50185233f, 0.09416353f, -0.08981377f, -0.21585844f, -0.05344704f, 0.05107681f, -0.03706561f, 0.33176717f, 
    0.07570928f, 0.00571940f, 0.08406004f, -0.05092649f, 0.10892171f, -0.00206584f, -0.02773230f, -0.05273730f, 
    0.02437384f, 0.05629633f, -0.04462689f, 0.07475305f, -0.10039109f, -0.07825160f, 0.00536890f, -0.14100535f, 
    0.06469845f, 0.22820306f, 0.10031541f, -0.29655492f, -0.10306340f, 0.04670180f, 0.06964356f, 0.04255746f, 
    0.12534960f, 0.01127782f, 0.00329022f, 0.07697551f, 0.16847084f, -0.10084381f, -0.07136920f, 0.08128422f, 
    -0.13594356f, 0.07183836f, -0.03812554f, 0.06972136f, 0.00105067f, 0.14084084f, -0.04119162f, 0.12737148f, 
    -0.29673272f, -0.02109295f, 0.03964368f, -0.10990375f, 0.05141552f, 0.03407201f, -0.07121098f, 0.03834165f, 
    0.17909682f, 0.12498179f, 0.04053583f, 0.07015511f, -0.18054014f, -0.26365417f, 0.00226172f, -0.24323340f, 
    0.06945545f, -0.02159201f, 0.00525565f, -0.08291656f, -0.03712790f, -0.03598399f, 0.00147773f, 0.09779922f, 
    0.02793567f, -0.00590562f, -0.05276019f, -0.00040684f, -0.03768301f, 0.03893789f, -0.01219784f, -0.04618027f, 
    -0.04630717f, 0.01998631f, 0.00741641f, -0.04740194f, 0.02695117f, 0.02801150f, -0.01553230f, 0.03306826f, 
    0.00333017f, 0.04933928f, -0.00699834f, 0.01920787f, 0.04434467f, 0.00172412f, -0.03326072f, -0.03774600f, 
    -0.00406660f, -0.00855356f, -0.02756491f, -0.03354141f, -0.04075966f, 0.02727844f, -0.01635481f, 0.01903688f, 
    0.03320751f, 0.03991207f, 0.01617950f, -0.01796918f, -0.03042505f, -0.02066077f, -0.02446464f, 0.01236776f, 
    -0.03134641f, -0.01077521f, -0.05410593f, 0.02653310f, -0.01991001f, 0.02530790f, -0.02596235f, 0.03406252f, 
    -0.03225152f, 0.00830387f, -0.05535649f, 0.00032580f, -0.04876677f, -0.01882327f, 0.02555872f, -0.02856351f, 
    0.02431347f, -0.02387768f, -0.03260803f, -0.03611539f, 0.02928189f, -0.03819079f, 0.03066565f, -0.02292749f, 
    0.02507567f, -0.03958515f, 0.00090450f, 0.03060034f, 0.01415915f, 0.00272348f, -0.02506013f, 0.02522817f, 
    -0.00912109f, -0.01530206f, -0.02804331f, -0.03171163f, 0.01193161f, -0.04559975f, 0.03223968f, -0.04040316f, 
    -0.02843903f, 0.00176063f, 0.03565682f, -0.02777051f, 0.00363671f, -0.03895725f, -0.01171572f, -0.02064439f, 
    -0.04930887f, -0.02390083f, 0.03487051f, -0.01695441f, 0.00952923f, 0.02372167f, 0.01581574f, -0.04583782f, 
    -0.00187917f, -0.03617369f, 0.04152711f, 0.02375389f, -0.04256300f, -0.01488782f, 0.03014950f, 0.01552648f, 
    0.02589714f, -0.00221067f, 0.04379958f, -0.02231368f, 0.02305276f, 0.00292297f, 0.02655235f, -0.03114153f, 
    -0.01233107f, -0.01400762f, 0.00552433f, 0.01264588f, 0.04031381f, 0.03062604f, 0.03889436f, -0.01071898f, 
    -0.00505768f, -0.04291596f, 0.03650672f, -0.00545807f, -0.01368278f, -0.02467994f, -0.01710102f, 0.02010488f, 
    -0.03855238f, -0.04416860f, -0.03509450f, -0.05532853f, -0.04979856f, -0.03978277f, -0.01738288f, -0.02630490f, 
    -0.04218997f, 0.03595330f, -0.05605363f, 0.02268296f, -0.02863472f, 0.03554908f, 0.01060854f, -0.02914100f, 
    -0.03229032f, -0.03422819f, -0.01640920f, 0.02763354f, 0.05097330f, -0.00902726f, 0.01066884f, -0.05075333f, 
    0.00246156f, -0.04125137f, -0.00540031f, 0.01747912f, -0.04093173f, 0.02682394f, 0.02166868f, -0.00542314f, 
    -0.03955870f, 0.01097608f, 0.03575192f, -0.01146393f, -0.03355936f, 0.03548092f, 0.01190841f, -0.02820466f, 
    -0.01435045f, -0.01931781f, 0.00658542f, -0.05005583f, 0.04644109f, -0.03008920f, 0.04445657f, -0.01497926f, 
    0.03142833f, -0.00166277f, -0.02846753f, -0.04015724f, -0.01058067f, -0.04034080f, -0.04655898f, -0.01162543f, 
    -0.04007293f, 0.00969390f, -0.02657297f, -0.03514558f, -0.02453198f, -0.03213991f, 0.01051895f, -0.04043275f, 
    -0.03815696f, -0.04260015f, -0.03645496f, -0.02725266f, -0.01100610f, -0.02485439f, 0.03348706f, -0.02534228f, 
    -0.05523805f, -0.02729739f, 0.01551924f, 0.04372559f, -0.02317152f, -0.02197144f, -0.04234428f, -0.00222621f, 
    0.04260652f, -0.03013225f, -0.01383652f, -0.03622949f, 0.00173556f, -0.03124570f, 0.01383795f, 0.01917246f, 
    -0.01013694f, -0.01947254f, -0.04500257f, 0.03721469f, 0.01472812f, 0.01797069f, 0.01800604f, -0.03034510f, 
    -0.02365855f, 0.04143286f, -0.03444741f, -0.03303340f, 0.00816763f, 0.04368211f, 0.03774689f, -0.04309315f, 
    -0.03754874f, -0.01923794f, -0.03308815f, 0.01618025f, -0.01079383f, -0.03181065f, -0.01878941f, 0.00634572f, 
    -0.03613429f, -0.02678635f, -0.05022349f, 0.03922691f, 0.04353499f, 0.03911235f, -0.03434582f, -0.01147487f, 
    -0.02423368f, 0.02572520f, 0.03595817f, 0.02889045f, 0.03729919f, 0.01667698f, -0.02644791f, 0.00927841f, 
    -0.03422022f, -0.00126929f, -0.05342129f, -0.01245671f, -0.01774819f, -0.03170321f, -0.05275230f, -0.04603644f, 
    -0.05527519f, -0.00146666f, 0.00884288f, 0.00674646f, -0.02544209f, -0.00650326f, 0.03681432f, 0.03240153f, 
    -0.04916818f, 0.03619924f, 0.01219856f, 0.00135339f, -0.02287729f, -0.04786232f, 0.00114742f, -0.02570692f, 
    0.01047370f, -0.03151299f, -0.05308903f, -0.03336709f, -0.03538480f, -0.03948732f, 0.03096214f, -0.00612457f, 
    -0.04278079f, 0.03113298f, -0.01661179f, 0.01069766f, -0.01087267f, -0.01101072f, 0.00449769f, -0.04732999f, 
    0.01189056f, -0.04955769f, 0.04299597f, 0.00846570f, -0.04381370f, 0.02126107f, -0.05252992f, 0.03793244f, 
    -0.03578430f, 0.03761637f, 0.04007053f, -0.04016862f, -0.01129297f, -0.03393437f, -0.03519111f, 0.02593363f, 
    0.01905656f, 0.01860245f, -0.04604898f, -0.05086153f, 0.02888571f, -0.01754971f, -0.03392569f, -0.03353371f, 
    -0.02082332f, -0.02903540f, -0.04354009f, -0.00094469f, 0.02859082f, 0.01047073f, -0.05441773f, -0.02646408f, 
    0.03930495f, -0.02443894f, 0.03380404f, -0.04323355f, 0.00830260f, 0.03942213f, 0.01937142f, 0.00030667f, 
    -0.01110893f, -0.04656101f, 0.03932355f, -0.01776684f, -0.04144500f, 0.03688619f, 0.00413106f, -0.04383922f, 
    0.02296124f, -0.02803120f, -0.03600119f, 0.04438648f, -0.00188092f, 0.01842804f, -0.01192409f, -0.01243384f, 
    -0.01075819f, -0.01298926f, -0.03479442f, -0.01087205f, 0.03095217f, -0.03221358f, 0.03886063f, 0.02946278f, 
    -0.03752775f, -0.05023754f, -0.03496891f, -0.00466162f, 0.01460882f, -0.05258582f, -0.05371653f, 0.02947760f, 
    0.01112674f, -0.01169752f, 0.02671897f, 0.03185837f, 0.02157831f, -0.04333750f, -0.01696898f, -0.03582391f, 
    0.02767570f, -0.05125235f, -0.05382238f, 0.04774546f, 0.02916470f, -0.02947579f, -0.02387443f, 0.02488800f, 
    0.26405177f, -0.03023236f, 0.02642445f, 0.29824188f, -0.00385900f, -0.14654744f, 0.16639465f, 0.00122071f, 
    0.37116179f, -0.00759214f, -0.03508299f, 0.02176166f, -0.33478695f, -0.10113160f, -0.09814822f, 0.01449978f, 
    0.00071303f, -0.18519779f, -0.01367529f, 0.00869809f, 0.24560583f, -0.03502484f, -0.01845181f, -0.13700281f, 
    0.08504157f, -0.06594992f, -0.15079169f, -0.07973376f, 0.03451286f, 0.08052412f, -0.06089893f, -0.21095841f, 
    0.10942417f, -0.09755501f, 0.08407719f, 0.20083180f, -0.22912692f, 0.06415766f, 0.14052816f, -0.06310765f, 
    -0.08446853f, -0.07816409f, -0.07587852f, 0.06762234f, 0.12308758f, 0.18358400f, 0.09072062f, -0.11794861f, 
    0.06633643f, 0.02063629f, 0.21460307f, -0.02762811f, -0.01497062f, -0.03337808f, -0.03604226f, -0.03511403f, 
    0.03570128f, -0.21688721f, -0.15887472f, -0.26603925f, -0.02007421f, 0.22975989f, -0.14640376f, 0.07018568f, 
    -0.03118129f, 0.15855813f, 0.13101037f, 0.22471841f, -0.05290113f, -0.03877819f, -0.02761461f, -0.03193982f, 
    0.07443455f, 0.16890380f, 0.00862044f, 0.13103589f, -0.05576960f, -0.11180577f, -0.06765421f, -0.14985487f, 
    -0.08366667f, -0.05219240f, 0.03634832f, -0.03640034f, 0.07054941f, -0.08731064f, 0.01842909f, 0.32126939f, 
    -0.07436227f, 0.02057609f, 0.04389049f, 0.01406623f, 0.09804099f, 0.00798261f, 0.02358325f, 0.37997541f, 
    -0.54147202f, 0.38000786f, 0.12469508f, 0.32581216f, 0.01419025f, 0.01912858f, 0.04103608f, 0.03418678f, 
    0.18783320f, 0.02206234f, 0.05240534f, 0.04884388f, -0.12245053f, 0.05851507f, -0.06263764f, -0.01350833f, 
    -0.07541641f, -0.00549080f, 0.00174736f, -0.06275304f, -0.16978732f, 0.01773116f, 0.01248133f, -0.01570492f, 
    0.16758581f, -0.39940682f, 0.11195675f, -0.45768124f, 0.23584957f, 0.00144794f, 0.15765169f, 0.19175072f, 
    -0.02468588f, 0.15922695f, -0.04215395f, 0.19495697f, 0.00272980f, 0.10909771f, -0.01295770f, 0.23048256f, 
    -0.10544182f, -0.02411355f, -0.03089600f, -0.05039435f, 0.22796123f, -0.08347560f, 0.14355280f, 0.09510843f, 
    -0.10075619f, -0.04938004f, -0.05204257f, -0.03371561f, -0.14528567f, -0.13244829f, -0.17017898f, -0.08334370f, 
    0.03500536f, -0.14111207f, 0.00160603f, -0.05990924f, -0.20529202f, -0.09933928f, -0.18368728f, -0.27450433f, 
    0.16253988f, 0.26314193f, 0.07248286f, 0.19741705f, -0.04543105f, -0.02227724f, 0.00674366f, -0.03024903f, 
    -0.02072775f, -0.14558049f, -0.17191698f, -0.03643823f, -0.09266408f, -0.00177444f, -0.02422118f, -0.00654079f, 
    -0.32713506f, -0.03423853f, -0.13042991f, -0.13061862f, -0.10091142f, 0.21470125f, 0.01450809f, -0.07820370f, 
    0.09312977f, 0.14265656f, -0.04268318f, -0.11238687f, -0.01880895f, -0.05746571f, -0.15186785f, -0.08590261f, 
    0.51806480f, 0.27632359f, 0.08298602f, -0.15778594f, -0.01629084f, 0.10299473f, -0.10736930f, 0.09764195f, 
    0.13856086f, 0.15695858f, -0.06942306f, -0.09048220f, 0.38747677f, -0.03266509f, -0.04881928f, -0.19035812f, 
    0.14472860f, -0.03460557f, -0.00954241f, 0.08436370f, 0.10755573f, -0.04258484f, -0.03123501f, -0.15911134f, 
    -0.00411640f, 0.14459355f, -0.13904239f, 0.03609845f, -0.05362207f, 0.00637943f, 0.08951033f, -0.05439153f, 
    -0.09501345f, -0.00732926f, -0.01441233f, 0.10011604f, -0.39299810f, 0.34490255f, 0.09553745f, 0.26005921f, 
    -0.03751948f, 0.03740742f, 0.36562043f, 0.06514325f, 0.01360858f, 0.20824754f, 0.06059006f, 0.07173739f, 
    -0.01941399f, 0.04098659f, 0.03890553f, -0.35043091f, -0.08249352f, -0.04781927f, -0.11009517f, -0.03845144f, 
    0.01269441f, 0.18165202f, 0.00676174f, -0.04972679f, -0.17368516f, -0.04104300f, 0.05603838f, 0.18728155f, 
    -0.14397095f, -0.10576833f, -0.01733910f, 0.04208095f, 0.10525735f, 0.09425896f, 0.25833243f, 0.14734119f, 
    0.12104069f, 0.14702398f, -0.07682119f, -0.15172799f, 0.03203007f, -0.05069006f, 0.03453579f, 0.08498401f, 
    0.06401133f, -0.00850553f, 0.05067325f, -0.01564972f, -0.10256161f, 0.16011414f, -0.11125232f, 0.06273573f, 
    0.09636742f, 0.00527197f, 0.08146804f, 0.25741386f, 0.03356779f, -0.14101958f, -0.08667233f, -0.08161750f, 
    -0.06391006f, -0.00365771f, 0.10794267f, 0.09906259f, -0.05276912f, 0.04275268f, -0.02912780f, -0.12151241f, 
    0.07868514f, 0.10021593f, 0.04352375f, 0.08095563f, 0.09034898f, -0.01973607f, -0.13384606f, -0.38308427f, 
    0.12453577f, -0.03979509f, -0.08779643f, -0.20531014f, 0.07261181f, 0.05236347f, 0.11208401f, 0.15262690f, 
    0.06385734f, -0.34330228f, 0.20144229f, -0.27693582f, 0.19340172f, -0.14946331f, 0.08321466f, 0.30119044f, 
    0.05366318f, 0.15837236f, 0.05161253f, 0.04242283f, 0.04894058f, 0.25007471f, 0.14318120f, -0.11991499f, 
    0.01373563f, 0.01821583f, 0.04218043f, -0.02396530f, -0.12762445f, -0.06900895f, -0.01636057f, -0.13479783f, 
    0.05448202f, 0.05882683f, 0.22308239f, -0.13694134f, -0.12379520f, 0.08811658f, -0.00674423f, 0.01152214f, 
    0.06256265f, 0.02370072f, -0.11264952f, 0.00303373f, 0.25007069f, 0.11556716f, 0.09185490f, 0.21219097f, 
    -0.00343854f, -0.01599791f, -0.00229714f, 0.06715148f, -0.01609487f, 0.11724298f, 0.18264487f, 0.24195957f, 
    0.03917267f, -0.20351335f, 0.28626782f, -0.19268604f, -0.07205220f, 0.11913645f, 0.04454284f, 0.06834498f, 
    0.19596130f, 0.15772989f, 0.13057193f, 0.14321716f, -0.66907167f, 0.16362913f, 0.09738548f, -0.08642077f, 
    -0.04915893f, 0.05428843f, 0.02789550f, 0.05952337f, 0.11160317f, 0.08611673f, 0.09806365f, 0.15410553f, 
    -0.23429100f, 0.41388097f, -0.12538725f, 0.12289169f, 0.09189564f, 0.16204336f, -0.08231911f, 0.08586941f, 
    0.06330610f, -0.09220929f, 0.02870085f, 0.03008559f, -0.16313928f, 0.00579303f, 0.05842590f, 0.07876790f, 
    0.11922276f, 0.02736481f, 0.04501184f, -0.20391953f, 0.09491885f, -0.01721608f, 0.00518346f, 0.14438468f, 
    0.21171419f, 0.08782379f, 0.19256227f, 0.05575758f, -0.02658714f, 0.23308112f, 0.23909535f, 0.19745868f, 
    -0.06854934f, 0.06375743f, 0.02494095f, -0.10289221f, 0.02821156f, 0.01759837f, -0.04445384f, -0.25412834f, 
    0.09684683f, 0.01991902f, 0.07840423f, -0.22262760f, -0.04115170f, -0.02532940f, 0.07785853f, -0.02094031f, 
    0.01295460f, -0.02462633f, -0.04757129f, -0.00982344f, 0.00544257f, -0.01665324f, -0.06975117f, -0.06383139f, 
    -0.12482598f, 0.09566429f, -0.13661076f, 0.10710083f, 0.14824207f, 0.16182138f, 0.15442848f, 0.02619093f, 
    0.12792778f, -0.02597226f, -0.12869932f, -0.25959551f, 0.01047797f, 0.01317201f, 0.08993425f, -0.02257352f, 
    -0.02174268f, -0.22319014f, -0.06515719f, 0.29834771f, -0.05317806f, -0.01886186f, -0.00589862f, -0.03325005f, 
    0.01424123f, -0.01374327f, 0.00109086f, -0.00555906f, 0.16514193f, -0.10694393f, -0.06908638f, -0.05372515f, 
    -0.00929364f, -0.06932661f, -0.05599400f, -0.01967331f, 0.04380494f, 0.06049231f, -0.08196586f, 0.10700358f, 
    -0.24956016f, -0.03789992f, 0.10975952f, -0.09025073f, 0.15968616f, -0.11474633f, 0.03681848f, -0.06090654f, 
    0.04888483f, -0.06008307f, -0.07249808f, 0.05831413f, 0.02918717f, -0.00901200f, 0.09158442f, 0.05282347f, 
    -0.00628430f, -0.00311587f, 0.04937888f, 0.06061059f, -0.05323161f, -0.06861378f, -0.04395407f, -0.04550760f, 
    0.06454648f, 0.44472229f, 0.20256467f, -0.24350584f, 0.08875985f, -0.08564558f, 0.03000638f, -0.03918098f, 
    0.02703288f, -0.03357683f, -0.05975303f, 0.00615461f, -0.09467532f, -0.29994652f, -0.06783541f, 0.14104460f, 
    -0.06482632f, -0.01343004f, -0.01835668f, -0.00564672f, -0.05264706f, 0.04688919f, 0.00995182f, 0.01851414f, 
    -0.28222620f, -0.12684382f, -0.08109989f, 0.05458295f, 0.05043261f, 0.01907361f, -0.08695187f, -0.10175692f, 
    0.34201524f, 0.32823163f, 0.18441981f, 0.12437805f, 0.14316095f, 0.19221756f, 0.07747407f, 0.01933245f, 
    0.22623047f, 0.13812526f, 0.07679672f, -0.01652854f, -0.01268504f, 0.14087835f, 0.00098034f, -0.01789226f, 
    -0.23889981f, -0.09717488f, 0.09416558f, -0.01439252f, 0.00759557f, -0.02628093f, -0.06719249f, 0.04654798f, 
    0.23088162f, 0.02809513f, 0.09230643f, 0.05987632f, 0.14017993f, 0.09285519f, 0.29189470f, -0.20694771f, 
    -0.02945466f, -0.23379850f, -0.15488081f, -0.00739244f, -0.03177124f, 0.01120041f, 0.05664402f, 0.17598984f, 
    0.21957590f, -0.45794046f, 0.21587837f, 0.12874754f, 0.09154905f, -0.06109869f, -0.07230966f, 0.10087502f, 
    -0.00242650f, 0.03385584f, 0.06566887f, -0.04256303f, -0.00161564f, 0.02505311f, -0.00823214f, -0.18684696f, 
    -0.10556146f, 0.08174416f, -0.07193776f, -0.15007116f, 0.01265862f, -0.04223363f, 0.05221280f, 0.07688410f, 
    -0.01987830f, 0.00547576f, 0.06298141f, 0.00610403f, 0.11918002f, -0.07040317f, -0.03946263f, 0.00241444f, 
    0.13870043f, -0.05791618f, 0.10828160f, -0.06799141f, 0.09570932f, -0.13434061f, 0.02732328f, 0.04474318f, 
    0.08288520f, -0.13037065f, -0.16783665f, 0.00218054f, -0.01020084f, -0.04625905f, -0.02475802f, 0.12887610f, 
    0.02159120f, -0.02195039f, 0.12133738f, 0.22148499f, -0.04052405f, 0.04443447f, 0.07133646f, 0.04628072f, 
    0.06488036f, 0.11421663f, -0.12421437f, 0.03529303f, -0.20565264f, -0.12391993f, -0.02147765f, 0.12649484f, 
    -0.01572726f, 0.02533142f, -0.02597256f, 0.01533167f, 0.05290397f, 0.03334962f, -0.09448807f, 0.02960327f, 
    0.03771596f, 0.10418956f, -0.04986591f, 0.13231450f, 0.05637265f, 0.13771683f, 0.09416345f, 0.05618705f, 
    0.10816193f, 0.08846080f, 0.07516336f, 0.13031922f, -0.23095173f, 0.14525439f, 0.03724460f, 0.00521552f, 
    0.05453973f, 0.01374429f, -0.03172108f, -0.14348784f, -0.10472827f, 0.11216488f, -0.09599084f, 0.01130505f, 
    -0.11284720f, -0.10237724f, -0.03953028f, -0.07706917f, -0.06291226f, -0.00246846f, 0.10223497f, 0.01291190f, 
    0.05216051f, -0.01705885f, -0.04012722f, -0.17179823f, -0.10345232f, 0.04033995f, 0.17447729f, 0.20602590f, 
    -0.03322156f, 0.01184003f, -0.01198854f, 0.16925785f, 0.04620192f, 0.03194827f, 0.05885595f, -0.04176568f, 
    -0.16969399f, 0.51630414f, -0.01489361f, -0.13019823f, -0.07338510f, -0.02936025f, 0.05901950f, 0.13069461f, 
    -0.01720042f, -0.01733512f, -0.09072420f, 0.02009924f, 0.18936786f, -0.03548143f, 0.02311669f, 0.03754371f, 
    -0.04273331f, 0.06248507f, -0.09594531f, -0.00615449f, 0.01798563f, 0.01074496f, 0.11726075f, 0.00809786f, 
    0.06618176f, 0.15675646f, 0.08374339f, 0.03968928f, 0.05454307f, -0.00701688f, -0.06427851f, -0.11926373f, 
    0.04104362f, 0.00952676f, 0.01842969f, 0.09404832f, -0.19707425f, -0.01211508f, -0.11825278f, 0.04501327f, 
    -0.14595708f, 0.10184175f, -0.07780369f, -0.08972598f, 0.04586999f, 0.06501205f, 0.03871818f, 0.01820537f, 
    0.01494424f, 0.07293280f, -0.03644158f, -0.05356602f, 0.09676842f, -0.01932933f, 0.05544351f, -0.08400478f, 
    0.00114188f, -0.04535180f, -0.02638648f, -0.07536262f, 0.31414646f, -0.18622585f, 0.15407902f, 0.05891254f, 
    0.10923307f, -0.02256935f, -0.09823060f, -0.32356438f, -0.04393394f, 0.02067359f, 0.09784547f, 0.09303989f, 
    -0.02454892f, -0.00972608f, -0.02476127f, -0.03677524f, -0.01018925f, 0.02416572f, -0.01762559f, -0.05679509f, 
    -0.05296866f, -0.02698903f, -0.01752077f, -0.03512186f, -0.05111589f, -0.01107565f, -0.02601599f, 0.04072557f, 
    0.02828222f, -0.04661006f, 0.02462532f, -0.05509809f, 0.00753593f, -0.04117671f, 0.03307300f, -0.01865380f, 
    0.00249854f, 0.04692568f, -0.03138645f, -0.03871321f, -0.01295896f, -0.05532128f, -0.02304264f, 0.00502563f, 
    -0.01628477f, -0.03577798f, -0.02164964f, 0.02898882f, 0.04203659f, 0.02952114f, 0.01688315f, -0.01208496f, 
    -0.02808967f, -0.04299714f, 0.00072305f, -0.02900940f, 0.04285571f, -0.02207454f, -0.01685256f, 0.01367195f, 
    -0.04867934f, -0.00070883f, -0.02862763f, 0.01621367f, -0.03975186f, -0.04979001f, -0.01784989f, 0.01628013f, 
    0.02476744f, -0.05354415f, -0.00772887f, 0.00530099f, -0.04636557f, -0.00315947f, -0.04261414f, 0.03805449f, 
    0.04135397f, -0.05312219f, 0.02940176f, -0.00629173f, 0.00548396f, 0.02318860f, 0.01709154f, 0.01740375f, 
    -0.03854000f, -0.01995355f, -0.04937875f, 0.00583936f, 0.00020117f, -0.04632784f, -0.03743881f, -0.00909001f, 
    -0.04353490f, 0.00162131f, 0.00177015f, -0.02441866f, 0.03404612f, -0.01354666f, 0.00844415f, 0.03423542f, 
    -0.00767838f, -0.03028363f, 0.03952318f, 0.03145175f, -0.00729495f, 0.03607247f, -0.03570413f, 0.00616535f, 
    0.00220268f, -0.02480747f, 0.01803724f, 0.03499621f, -0.00644295f, 0.01935753f, -0.02840090f, -0.01918722f, 
    -0.00685266f, -0.03038151f, -0.01278673f, -0.03246699f, -0.00860309f, -0.02269604f, -0.04091137f, -0.04432467f, 
    0.02383801f, 0.02332706f, -0.04838893f, -0.01637056f, -0.00722686f, 0.03799731f, 0.02051506f, -0.04254010f, 
    0.00402924f, 0.03580918f, 0.03691057f, -0.04721761f, -0.01641363f, 0.04402748f, -0.00938679f, 0.02548044f, 
    0.01403920f, 0.02641209f, 0.03456368f, 0.04177423f, 0.04150908f, 0.00178101f, -0.01716873f, -0.02986002f, 
    0.00259956f, 0.02750474f, -0.01076904f, 0.00608604f, 0.04177068f, -0.05783969f, 0.00978380f, -0.01276242f, 
    0.04195745f, 0.00549559f, -0.00122840f, -0.01305009f, 0.00737583f, 0.02395641f, -0.02700906f, -0.02818064f, 
    -0.02034793f, -0.04331414f, 0.04811529f, 0.01292055f, -0.04955738f, -0.04283477f, 0.00668141f, 0.01465624f, 
    0.01590336f, -0.00488324f, 0.03177438f, -0.04056630f, -0.02667769f, 0.03928565f, 0.01198084f, 0.02229517f, 
    0.02378923f, -0.02413373f, -0.04061120f, 0.04084545f, 0.02139346f, -0.00328175f, -0.03858367f, -0.02661858f, 
    0.02152332f, -0.04244677f, 0.01141032f, -0.03395806f, 0.00835901f, -0.05468627f, -0.02384666f, -0.04269389f, 
    -0.01818191f, -0.04715030f, 0.02135010f, 0.03960522f, -0.00797462f, -0.05430996f, -0.01055843f, 0.00515160f, 
    0.03795808f, -0.02399579f, -0.02161350f, -0.00246389f, -0.05652485f, -0.02855078f, -0.02863233f, 0.01832946f, 
    0.01154858f, -0.00858019f, -0.03624300f, -0.00093336f, -0.04239784f, -0.00552676f, -0.00650664f, 0.04233822f, 
    0.04198203f, -0.02905575f, -0.00829421f, 0.04523905f, -0.03650022f, 0.02746988f, -0.01920915f, -0.00323559f, 
    -0.00445073f, 0.02990351f, -0.01069796f, -0.02863294f, -0.02875895f, -0.04399079f, 0.00428935f, -0.02107464f, 
    0.01787920f, -0.00359765f, -0.02249655f, -0.03929257f, -0.04046940f, -0.03460058f, -0.00619338f, 0.02252954f, 
    0.02360070f, -0.05603347f, 0.00004293f, 0.03133031f, 0.01578938f, 0.00771095f, 0.00944337f, 0.04029152f, 
    0.03005637f, -0.02455650f, -0.03093826f, -0.04262072f, -0.03444031f, -0.05475585f, 0.01407681f, -0.04421843f, 
    -0.01153133f, 0.02388455f, -0.01002141f, 0.01917368f, -0.00083522f, 0.04340690f, 0.02619844f, 0.01114053f, 
    0.02252566f, 0.00993389f, -0.00844031f, -0.05251764f, 0.03810244f, -0.03083823f, -0.04334582f, 0.02076184f, 
    0.03653820f, -0.05546749f, 0.04887407f, 0.02025277f, -0.02964818f, 0.02621640f, 0.03818615f, 0.00050338f, 
    -0.01428956f, -0.03932982f, -0.01983517f, -0.04220213f, -0.01521639f, 0.01939174f, 0.02834077f, -0.03910255f, 
    0.01107985f, -0.04676543f, 0.00614670f, -0.01183331f, -0.03428337f, -0.03367878f, -0.00785073f, 0.02845238f, 
    0.02239152f, 0.00097067f, -0.02684936f, 0.02699185f, -0.05117416f, 0.01629184f, 0.03747560f, -0.02626912f, 
    -0.01880273f, -0.02544714f, 0.02903911f, -0.04837678f, 0.02128599f, -0.03103040f, -0.01565676f, 0.03206382f, 
    -0.00978932f, 0.02310553f, 0.02638713f, -0.05934613f, -0.02551134f, 0.01639267f, 0.03154641f, -0.03563525f, 
    0.04326247f, 0.03836737f, -0.02682250f, 0.01450810f, -0.00569953f, 0.03916319f, -0.01868859f, -0.00374644f, 
    0.02464000f, -0.00282120f, 0.03145273f, -0.03433365f, -0.05127782f, 0.02813766f, -0.01904353f, 0.01379364f, 
    0.04037828f, 0.03181923f, -0.04290037f, 0.02522099f, 0.02872278f, -0.04297782f, 0.03473466f, 0.00447121f, 
    -0.01331106f, -0.05223763f, 0.01749142f, -0.04479850f, 0.00358298f, 0.02159240f, 0.01049981f, 0.04155880f, 
    0.00024387f, 0.01903004f, -0.00102397f, -0.00470185f, -0.04768517f, 0.02112313f, -0.02642573f, -0.03106534f, 
    0.01116705f, -0.01717804f, -0.01452630f, -0.00874348f, -0.03166038f, 0.04206938f, -0.02270137f, 0.01854275f, 
    -0.01809460f, 0.00009990f, -0.01810756f, -0.04741071f, -0.05092185f, -0.03552248f, -0.00827790f, -0.04408136f, 
    0.01074246f, -0.03499813f, -0.01847450f, 0.00949258f, -0.01796528f, 0.02973010f, -0.01249985f, -0.00214388f, 
    0.03225905f, 0.00459674f, 0.01272745f, 0.01377458f, 0.03961698f, 0.00153246f, -0.01699640f, -0.04017851f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.00109942f, 0.21262299f, -0.01677842f, 0.17499751f, 0.09532917f, 0.12979481f, -0.02766932f, -0.05360368f, 
    0.08530006f, 0.05748728f, -0.01871428f, -0.06670527f, 0.08093958f, -0.02508466f, 0.13662839f, 0.03248437f, 
    0.01236920f, 0.01789228f, -0.06010474f, 0.00320116f, -0.03552859f, -0.00224738f, 0.03462012f, -0.00689772f, 
    0.14298385f, 0.05958386f, 0.06412554f, 0.15092948f, -0.01640926f, 0.23753522f, 0.02842639f, -0.00932344f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.02858793f, 0.07035676f, -0.08089427f, -0.23720644f, 0.19327760f, -0.23932520f, 0.06286307f, 0.07566446f, 
    -0.59110117f, -0.33217463f, 0.15444040f, 0.15167941f, -0.36372629f, -0.03236174f, -0.58155859f, 0.43322256f, 
    0.04177230f, 0.16954385f, 0.21390206f, 0.19847415f, 0.08269644f, -0.36450541f, 0.08941020f, 0.23573279f, 
    -0.41884390f, -0.00797253f, -0.21042679f, 0.21044914f, 0.02141557f, 0.03036921f, -0.09439012f, -0.09467646f, 
    -0.01612015f, 0.00431876f, -0.38560274f, 0.22353734f, 0.05109607f, 0.30998814f, -0.19444068f, -0.60223174f, 
    -0.19280443f, 0.17286623f, -0.14718029f, -0.52601689f, -0.30383450f, -0.08434843f, 0.32544324f, 0.06149020f, 
    0.17735210f, 0.19301596f, -0.54187542f, -0.11712436f, 0.31425819f, 0.28013650f, 0.04222028f, 0.23032691f, 
    -0.32528502f, 0.17129755f, -0.04711523f, 0.15457466f, 0.03866279f, 0.34984630f, 0.10189301f, 0.10781237f, 
    0.12042480f, 0.36980379f, -0.04144419f, 0.13890047f, 0.35304633f, -0.48380342f, -0.19672549f, 0.31663194f, 
    0.05289938f, -0.10302940f, 0.04004410f, -0.40961003f, -0.13823411f, -0.11444201f, 0.11591510f, -0.20282800f, 
    0.30917761f, 0.00439646f, 0.01070772f, -0.37681481f, -0.65239853f, -0.70142478f, 0.02622113f, 0.17068370f, 
    -0.05978163f, -0.12268714f, 0.23588607f, -0.25234452f, 0.06160852f, 0.17920290f, -0.09638383f, 0.06842170f, 
    0.03401971f, -0.38940325f, 0.36763698f, -0.56290376f, 0.20227557f, -0.30790508f, 0.26238787f, -0.03750893f, 
    0.21604690f, 0.27523264f, 0.19465357f, -0.12400369f, -0.45313826f, 0.03858689f, 0.20728862f, -0.29087466f, 
    -0.02811821f, -0.03167669f, -0.01963118f, 0.01986558f, 0.05563892f, -0.05928474f, 0.09804183f, 0.08615707f, 
    -0.36658442f, 0.26233450f, 0.01158898f, -0.64416927f, 0.13940595f, -0.55860007f, 0.20604870f, 0.14561871f, 
    -0.07121999f, -0.49165806f, -0.08479747f, 0.04063180f, -0.01368786f, 0.24293144f, -0.42314032f, 0.44282138f, 
    0.09617238f, -0.32006934f, -0.03109127f, 0.40995499f, 0.30984235f, -0.10687572f, -0.14836918f, -0.19351748f, 
    0.02680361f, 0.06417120f, 0.20100981f, -0.27818993f, 0.22835910f, -0.41829076f, 0.09029887f, 0.19153038f, 
    -0.02269646f, 0.14311996f, -0.06089583f, -0.16109514f, 0.02904087f, -0.42762053f, 0.03803213f, 0.15085079f, 
    0.00578088f, -0.49878258f, -0.33790350f, 0.06094614f, 0.09941562f, -0.01253710f, 0.16820633f, -0.18484735f, 
    0.16596161f, 0.10086041f, 0.06999259f, -0.02002504f, 0.26529244f, -0.00813576f, -0.10977271f, 0.18362150f, 
    -0.69153893f, 0.00434733f, 0.11757454f, -0.16586275f, 0.25954053f, -0.30582988f, -0.11841892f, -0.34154853f, 
    0.50454432f, 0.02923320f, -0.10438564f, 0.23733953f, 0.00871273f, 0.11502536f, 0.05078600f, -0.09517739f, 
    -0.05437526f, 0.39515656f, 0.20168114f, 0.19593273f, 0.05316895f, 0.14374162f, -0.06115353f, -0.54617757f, 
    0.12164377f, -0.28594655f, -0.19032754f, 0.09700304f, 0.10641146f, -0.10196465f, -0.41763321f, -0.33293518f, 
    0.01505974f, -0.74780118f, 0.32849723f, -0.08099616f, -0.44311371f, 0.04637525f, 0.08674568f, -0.41514075f, 
    -0.29430345f, 0.08624874f, 0.32720676f, -0.57733071f, -0.10756848f, 0.25336656f, -0.73024917f, 0.02472371f, 
    0.02823341f, -0.03825880f, -0.31397080f, 0.26715150f, -0.39491892f, -0.09933687f, 0.39749178f, 0.61316013f, 
    -0.00525936f, 0.29005316f, -0.07683284f, 0.02398703f, -0.14303707f, 0.16365264f, -0.10672104f, 0.03374247f, 
    -0.16152982f, -0.44278362f, -0.16253947f, 0.18117900f, -0.23017362f, 0.22549288f, 0.02685640f, 0.16741981f, 
    -0.20526472f, -0.29596034f, 0.14713497f, -0.13458572f, 0.14203279f, -0.52329409f, -0.33592173f, -0.07140705f, 
    -0.03361758f, 0.19373013f, 0.11395133f, -0.24898776f, -0.64532870f, -0.34102565f, 0.10109819f, -0.20930713f, 
    -0.06895804f, 0.28745848f, -0.33479241f, -0.47414982f, -0.51733589f, 0.03863657f, 0.11971970f, 0.24575247f, 
    -0.07018270f, -0.67233354f, -0.42690653f, 0.33279425f, -0.27155414f, -0.26415673f, -0.03559332f, -0.42711553f, 
    0.31597334f, 0.17446643f, 0.16318397f, 0.41917306f, -0.09247912f, 0.19365238f, -0.19701000f, -0.16764703f, 
    0.15282911f, -0.11980637f, -0.10001224f, 0.12301278f, 0.17121053f, -0.18025121f, -0.19145389f, -0.10453556f, 
    0.09185401f, -0.07550473f, -0.58273357f, 0.49817434f, 0.21391743f, 0.03844959f, -0.08891912f, -0.42671281f, 
    0.32469168f, 0.03463110f, 0.13388735f, -0.57823950f, -0.05208017f, 0.25376064f, -0.11865915f, -0.27141127f, 
    -0.17480658f, -0.48272341f, 0.12430871f, 0.36326608f, 0.00142088f, -0.02461735f, 0.39804322f, -0.09457310f, 
    -0.04534290f, -0.04823578f, 0.25298896f, -0.01808994f, -0.43699524f, -0.30341780f, 0.39708868f, -0.60814768f, 
    -0.05652256f, -0.27556294f, 0.42149937f, -0.31341428f, -0.10218515f, -0.07194887f, -0.04742570f, -0.57636648f, 
    0.09527501f, 0.18795677f, -0.69514269f, 0.11352455f, -0.23580824f, -0.18976374f, -0.11065172f, 0.27661663f, 
    0.34349051f, 0.14835437f, -0.14580739f, -0.32499149f, 0.04756401f, 0.34486449f, -0.08783037f, 0.02414819f, 
    0.14887673f, 0.07353242f, 0.25284281f, 0.15506281f, -0.26578307f, 0.02532475f, -0.58509290f, -0.19222435f, 
    0.30791953f, -0.09166154f, -0.43981937f, -0.77395058f, 0.21373148f, 0.10568223f, 0.02270177f, -0.20827712f, 
    0.31993470f, -0.41951168f, -0.11777616f, 0.40761286f, -0.33909801f, 0.40057087f, -0.14558475f, -0.01839676f, 
    0.20873158f, 0.23640832f, -0.32203838f, -0.38949484f, 0.00268602f, -0.09754591f, 0.27901056f, -0.07099032f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.25589696f, 0.01313174f, 0.19392474f, 0.03642297f, -0.11471859f, 0.08226643f, 0.00757133f, 0.14564599f, 
    0.03922701f, -0.05469254f, 0.13612969f, -0.10677482f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
