#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.73284411f, 0.85862172f, 1.18033850f, -0.21209882f, 0.05773018f, 0.67082119f, -0.92763162f, 0.03494640f, 
    0.50584221f, 0.27292415f, 0.73702866f, 0.41431639f, 0.40617290f, 0.24420685f, 0.34220946f, -0.34194776f, 
    -0.70823145f, -0.94092083f, 1.21700644f, -1.44704783f, -0.80104560f, -0.56475633f, -0.27251971f, 0.21569277f, 
    -0.04780204f, 0.16964416f, 0.05713492f, 0.35822254f, 0.72944212f, -0.97614706f, 0.42552516f, 0.99232328f, 
    0.48816884f, 0.98234278f, -0.34284571f, 0.21729375f, 0.72624165f, -0.90342176f, -0.67619240f, -0.34203023f, 
    -1.15742481f, -1.01980627f, -0.65580505f, 0.55930144f, 0.60447699f, 0.69794774f, 0.99372888f, 0.79683322f, 
    0.55145669f, 0.55212802f, -0.81181091f, -0.32891324f, -0.15066606f, -0.31868172f, -0.33960995f, -0.76091546f, 
    0.14197613f, -0.66744965f, 1.33065760f, -0.63064247f, 0.55555093f, -0.19853017f, -0.08536739f, 1.10316074f, 
    0.91191554f, -1.20896327f, 0.07800709f, 0.30936551f, 0.81985092f, 0.19807319f, 0.09567268f, -0.43785772f, 
    0.59066546f, 1.10967410f, -1.32224441f, 0.56285107f, 0.19991350f, -0.82996422f, 0.11242369f, -0.34511790f, 
    0.30213100f, -1.20887542f, -0.46387577f, 0.11412613f, -1.05870986f, -1.02007759f, 0.01976652f, -0.08739126f, 
    0.69037771f, 0.01848116f, 0.90245384f, 0.88284498f, 0.72608036f, -0.08602475f, -0.75205415f, -0.02068795f, 
    -0.28553507f, 0.16338255f, -0.42194974f, 1.31541479f, 0.72468209f, 0.88161844f, 0.69247335f, 0.03252603f, 
    0.49370137f, 0.13536906f, 0.80870289f, 0.11661937f, 0.51175094f, -0.90545273f, 0.22773388f, 0.70255530f, 
    0.88386959f, 0.71461809f, 0.00282529f, 0.61162639f, 0.68110150f, -1.33325410f, 1.57127190f, -0.67175633f, 
    -0.11396994f, 0.16928743f, -0.77537519f, -0.55455685f, 0.27935162f, 0.37710831f, 0.81078500f, 0.69851863f, 
    0.63921458f, -1.80932689f, -0.20422342f, -1.07523644f, -0.03504431f, -0.14295289f, 0.02610082f, 0.83018452f, 
    -1.18973601f, 1.26504946f, 1.17961919f, -0.77820307f, 0.38048807f, -0.14146674f, -0.17884015f, -0.01563507f, 
    0.96712577f, -0.43807879f, 0.96261406f, 0.93238008f, 0.38590881f, -0.60426319f, -0.04174097f, -0.02448810f, 
    0.78482455f, -0.09203711f, 0.42762712f, 1.43951511f, 0.92148066f, 0.65976661f, -0.01570231f, 0.33975342f, 
    0.55001122f, 0.24615772f, -0.14906862f, 0.73130769f, 0.51476306f, 0.68592834f, -0.11692517f, 0.98732179f, 
    0.87045234f, -0.68667799f, 0.93241906f, 0.50983697f, 0.99428242f, 1.07939661f, -0.50104696f, 0.50455171f, 
    0.48276216f, 0.64023530f, -0.10201094f, -0.58037704f, -1.19841051f, -0.57500827f, -0.63586271f, 0.39070690f, 
    1.12240362f, 0.92617708f, 0.24068412f, -0.45967707f, 0.17462489f, 0.93312222f, 0.09004211f, 1.31397748f, 
    0.32279602f, -0.62028623f, -0.25299254f, 0.78658950f, -0.19412492f, 0.22074412f, -0.86048985f, -0.88679749f, 
    -0.69618005f, 0.90331864f, -0.32651073f, -0.25892007f, -0.38678360f, 0.28258544f, 0.65876001f, -0.83648747f, 
    -0.96177971f, -1.14322186f, -0.94279438f, 0.26300389f, 0.88391870f, -0.23493044f, -0.11038262f, 0.33440116f, 
    -0.74565303f, -1.12128544f, -0.61146832f, -0.02518320f, 1.31017852f, 0.07738569f, -0.57452136f, -0.06568451f, 
    -0.54067492f, -1.03373170f, -0.27698505f, 0.86794555f, -0.67869663f, -0.07067597f, -0.82329142f, -0.17465809f, 
    0.30266166f, -0.53802651f, 1.00692034f, 1.02255630f, -0.04441087f, -0.81024116f, -0.81245077f, -0.36295709f, 
    0.35831484f, 0.93608654f, 0.43562976f, -0.67480057f, -1.58874679f, -0.68682444f, -0.14255637f, -0.13692319f, 
    -0.69203550f, 0.42268488f, 0.37696952f, -0.42298442f, -0.83154708f, -0.60662514f, -0.59878713f, 0.45771220f, 
    0.82822776f, 0.27846965f, -0.11930570f, -0.53761655f, -0.92502528f, 1.02543044f, 0.45031691f, -0.19333144f, 
    0.57762837f, -0.66088432f, -0.76250768f, 1.18337154f, 0.57040495f, -0.36704442f, 0.05827120f, -0.54593390f, 
    0.57814717f, 1.59175956f, 0.93018615f, -0.69128406f, -0.42796504f, 0.28939354f, -0.35390615f, -1.00812984f, 
    -0.18685611f, -1.15306008f, -0.65830964f, 0.47851506f, 1.03997552f, 0.75859594f, 0.66696328f, 0.00294946f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.49406937f, 0.43698317f, 0.23373711f, 0.17238380f, 0.18173029f, 0.34432220f, -0.28781307f, 0.20230941f, 
    0.01443748f, 0.18187965f, 0.11049944f, 0.38855717f, 0.19225357f, -0.00517483f, 0.30499706f, -0.22965401f, 
    0.22984247f, 0.06732822f, -0.25885949f, 0.03471598f, -0.06659056f, -0.25738698f, 0.08653627f, 0.02391739f, 
    -0.13630320f, 0.48515996f, -0.04323534f, 0.61746049f, -0.01997860f, -0.21188821f, 0.18196684f, 0.16310947f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.14104266f, 0.06901977f, -0.12598482f, 0.21690543f, 0.32048449f, 0.10502019f, 0.06439634f, -0.04970365f, 
    -0.34875861f, 0.08271121f, 0.14525323f, -0.13734744f, 0.00131281f, 0.13176157f, 0.30041414f, -0.05396993f, 
    -0.17606010f, -0.43895301f, 0.32533899f, -0.01173300f, 0.01620928f, -0.15401401f, 0.12770335f, -0.04483543f, 
    -0.03800316f, 0.23476546f, -0.07671373f, -0.40548608f, 0.06051163f, 0.36413488f, -0.00202777f, -0.00719708f, 
    -0.08139144f, -0.06728784f, -0.09568593f, 0.09538880f, 0.30547860f, -0.10121521f, 0.18784799f, 0.11860997f, 
    -0.16340359f, -0.09050389f, 0.43013510f, -0.10462809f, -0.01334049f, 0.14232515f, 0.10121408f, -0.08429013f, 
    0.34480003f, -0.12430391f, 0.27067709f, 0.20283674f, -0.07216145f, -0.54221046f, -0.28682616f, 0.18974623f, 
    0.14807263f, 0.02020187f, -0.03576996f, 0.35711342f, 0.24092396f, -0.07621830f, 0.08426293f, -0.32778451f, 
    0.18978149f, 0.08773751f, -0.01975363f, 0.26375157f, 0.14797734f, 0.05398390f, -0.29653803f, -0.37061191f, 
    0.33140805f, -0.04448870f, 0.30758598f, 0.17109115f, 0.14973404f, -0.12815933f, -0.00469128f, -0.17034189f, 
    0.24313107f, 0.22605361f, 0.29801917f, -0.09521300f, -0.08304184f, 0.15581273f, -0.03875126f, 0.23587267f, 
    0.02694901f, 0.01560793f, -0.18364391f, -0.02977240f, -0.00374418f, 0.24334615f, 0.16854906f, 0.03660438f, 
    -0.02634678f, 0.01698614f, -0.30271083f, -0.30789626f, -0.19041033f, 0.10826171f, 0.10611086f, 0.05011922f, 
    0.16837490f, -0.14330517f, -0.06143149f, -0.28671697f, -0.14130518f, -0.03449273f, -0.02421628f, 0.05885334f, 
    0.11309321f, -0.13702871f, 0.12795267f, 0.08224910f, -0.16097662f, 0.35944477f, 0.22388746f, 0.25751993f, 
    -0.13663806f, 0.06983090f, -0.11922929f, 0.02752412f, 0.02375998f, 0.22532104f, 0.11903990f, 0.18935575f, 
    0.00267785f, -0.02694064f, 0.06392675f, -0.05494790f, -0.11536878f, 0.18218571f, -0.12762697f, 0.12583470f, 
    -0.01903708f, -0.44470587f, -0.20506597f, 0.07300504f, 0.06806973f, 0.04655582f, -0.04135929f, -0.39472306f, 
    -0.20965481f, -0.01487491f, -0.33633310f, -0.05418934f, 0.09756567f, 0.26192084f, 0.15167522f, 0.15664144f, 
    -0.39880714f, 0.12321171f, -0.27648026f, -0.25134197f, 0.26857990f, 0.21324848f, 0.34351003f, 0.16654223f, 
    -0.06427104f, -0.27992636f, -0.02565178f, -0.00841543f, -0.18244824f, 0.05770997f, -0.18722570f, 0.11014128f, 
    -0.12489431f, -0.05415089f, -0.07298595f, -0.08503734f, 0.11300544f, 0.18548845f, -0.04162307f, -0.04035119f, 
    0.22249983f, 0.05982107f, -0.00735734f, -0.35739273f, -0.17733349f, 0.04210771f, 0.07807649f, -0.03219877f, 
    0.01759655f, 0.10834457f, -0.03660611f, -0.10153480f, 0.05000623f, 0.05935008f, -0.00639098f, 0.09980807f, 
    -0.32316628f, 0.24545811f, -0.04390482f, -0.04299947f, 0.07622309f, -0.12735102f, -0.09328252f, -0.04458979f, 
    0.17358173f, 0.03828762f, 0.00724834f, -0.01457688f, 0.01744008f, 0.05775750f, -0.13251711f, -0.20271985f, 
    -0.07462937f, 0.11702252f, 0.02561793f, -0.07711210f, 0.09180877f, -0.21268271f, -0.22033641f, -0.05233949f, 
    -0.50276732f, 0.01559778f, 0.39330125f, -0.16853468f, -0.29168084f, 0.36875832f, -0.05914482f, 0.05244026f, 
    0.07947834f, 0.36186713f, 0.24995130f, 0.08482946f, -0.11440372f, -0.00072699f, -0.19481088f, 0.02437364f, 
    0.08255850f, 0.14766939f, -0.25668356f, -0.02415710f, 0.10230699f, 0.02900141f, 0.05807219f, -0.18178883f, 
    -0.05348442f, 0.20194398f, 0.07045044f, 0.12306319f, -0.16509300f, 0.21030501f, 0.07122616f, 0.14910132f, 
    -0.30724117f, -0.12159760f, -0.20356597f, 0.14189215f, -0.19894899f, 0.01204711f, 0.18598615f, -0.27230477f, 
    -0.09144745f, 0.19575225f, -0.26654390f, 0.08005988f, 0.20610034f, -0.04966686f, 0.33230621f, 0.22163300f, 
    -0.23012440f, -0.04236344f, -0.21158294f, 0.04980240f, 0.16801733f, 0.04476644f, -0.09624977f, -0.25235960f, 
    0.07631780f, 0.29665166f, -0.10870780f, 0.02219350f, 0.20007232f, 0.08033790f, -0.28731185f, -0.00129306f, 
    0.08416330f, -0.11232467f, 0.07626060f, 0.14743353f, -0.03967552f, 0.10355920f, -0.21122214f, 0.00381889f, 
    0.03157225f, 0.01965769f, 0.00891655f, 0.00669302f, -0.01037392f, -0.04280150f, 0.04002436f, -0.00608292f, 
    -0.00525290f, 0.02008206f, -0.03644333f, 0.04672030f, -0.04231264f, -0.00522450f, -0.00400797f, 0.01842079f, 
    -0.05006350f, 0.01771888f, -0.03777363f, -0.02834294f, -0.02518010f, 0.01101354f, -0.05953417f, -0.04515229f, 
    0.04275838f, 0.00702809f, -0.04128781f, -0.05089070f, 0.02573022f, -0.02760123f, -0.02943957f, -0.01600102f, 
    0.01285930f, 0.02354193f, 0.00022153f, -0.03260687f, -0.05438548f, -0.06780026f, 0.00392070f, 0.03822652f, 
    0.00722553f, 0.02637292f, -0.02664552f, 0.04168480f, -0.05686064f, 0.03089089f, 0.01141916f, -0.05425536f, 
    -0.03008543f, -0.04210110f, -0.03887350f, -0.02694444f, 0.02071876f, -0.05819014f, 0.00628354f, 0.02956950f, 
    -0.05540398f, 0.02102952f, -0.01446532f, -0.05642002f, -0.04080054f, -0.03798618f, -0.02666418f, 0.04103824f, 
    0.04234967f, -0.02139643f, -0.01000881f, 0.02598936f, -0.01470549f, 0.04824050f, -0.04406926f, 0.03238608f, 
    -0.01905498f, -0.00308542f, 0.04688958f, 0.00413651f, 0.04668981f, -0.04422259f, -0.03323156f, 0.02840361f, 
    0.04911217f, 0.03279940f, -0.02953929f, 0.03054494f, -0.00034172f, -0.04947592f, -0.05340630f, -0.05253000f, 
    -0.01585499f, 0.02057910f, 0.02952184f, 0.01038283f, -0.03942679f, 0.04076815f, 0.03775908f, 0.01167588f, 
    -0.05818684f, -0.02614767f, 0.01948875f, 0.01481597f, 0.00589829f, 0.02000722f, -0.01801042f, 0.03230994f, 
    -0.06024477f, -0.01625077f, -0.03238889f, -0.00120088f, -0.02332520f, -0.04515399f, -0.01331925f, -0.00462357f, 
    -0.00384509f, -0.06098596f, 0.00279739f, 0.03057077f, -0.02093541f, -0.01184475f, 0.00927822f, -0.06783909f, 
    -0.01524608f, -0.03710756f, 0.00006156f, -0.03174041f, -0.04618219f, -0.04692446f, -0.06054400f, -0.04627319f, 
    0.03395238f, 0.00171809f, -0.03393039f, -0.02671378f, 0.03890056f, -0.04143596f, -0.01455064f, 0.02024752f, 
    0.01871679f, -0.04344419f, -0.03721406f, 0.03462848f, 0.03230166f, -0.04582836f, -0.00237589f, 0.01731260f, 
    0.03997935f, 0.00486496f, -0.05969156f, -0.05798918f, -0.00257206f, 0.01717476f, 0.02545741f, -0.01946484f, 
    0.04378701f, 0.00210767f, 0.02349722f, -0.05881745f, -0.03834480f, -0.06819470f, 0.03213957f, 0.01858474f, 
    -0.06748147f, 0.03802837f, -0.01969719f, -0.00190994f, -0.03753617f, 0.01085493f, -0.02110253f, 0.05003504f, 
    -0.03118012f, 0.01531704f, -0.03395304f, -0.06097186f, -0.01642792f, 0.04599089f, 0.03388520f, 0.03695112f, 
    0.03596058f, 0.02902021f, 0.01335712f, -0.02935448f, -0.04038456f, 0.00481752f, 0.00033660f, 0.05091348f, 
    -0.00200526f, -0.01598220f, -0.03812553f, 0.03326104f, -0.05678396f, -0.05701419f, -0.00545596f, -0.01070167f, 
    -0.03150060f, 0.01847079f, 0.01588851f, 0.03193344f, 0.04739596f, 0.04967211f, -0.01581918f, 0.04363960f, 
    0.01879770f, -0.01158581f, -0.00825991f, -0.03308108f, 0.04421521f, 0.03684691f, -0.01010598f, -0.02060111f, 
    0.02389784f, 0.05066724f, -0.01827863f, -0.04154296f, 0.02516212f, -0.04313032f, 0.02597934f, -0.01113861f, 
    -0.03476903f, 0.00243281f, 0.01772144f, 0.03386675f, -0.00046869f, -0.01087496f, -0.00476457f, -0.04126147f, 
    -0.04516619f, 0.05265687f, -0.01472586f, 0.01053707f, -0.04694539f, -0.00549768f, 0.02096054f, 0.04698507f, 
    0.03400532f, -0.01618498f, -0.05882594f, 0.02713336f, 0.02784657f, -0.05693312f, -0.05995407f, -0.06579625f, 
    -0.04648728f, -0.00650725f, -0.05068338f, 0.05065829f, -0.01851123f, 0.02249077f, -0.01577667f, -0.01587466f, 
    -0.06095864f, 0.00039154f, 0.05391015f, -0.02334581f, -0.05925567f, -0.03574510f, 0.04030526f, 0.01487458f, 
    -0.02683470f, -0.04447732f, -0.04731259f, -0.01776034f, -0.00672217f, -0.02402573f, -0.03698586f, -0.05544111f, 
    -0.03506107f, -0.05256068f, -0.05955220f, -0.05080045f, 0.03813932f, -0.04845921f, 0.00171104f, -0.04462843f, 
    -0.06088276f, 0.00712353f, -0.01979625f, 0.01395004f, 0.00914828f, -0.05785320f, 0.00518948f, 0.00310060f, 
    0.00007426f, 0.04013977f, -0.03816189f, 0.04800747f, -0.01622997f, 0.01753674f, -0.00202937f, 0.01762006f, 
    0.10356978f, -0.23543075f, 0.29966104f, 0.07454453f, -0.01643430f, -0.02338925f, 0.30143017f, -0.11637142f, 
    0.14733125f, -0.15525420f, 0.27478498f, 0.05152461f, 0.12457415f, 0.26323637f, 0.03093488f, 0.12977695f, 
    0.07037850f, 0.07900606f, -0.39253148f, 0.05191084f, 0.09621361f, 0.23658811f, 0.19686471f, -0.13003527f, 
    -0.20540099f, 0.07919034f, -0.31865922f, -0.11344843f, 0.03478907f, -0.08255675f, 0.03583989f, 0.12055144f, 
    -0.06489230f, 0.27753654f, 0.03273872f, 0.12083273f, 0.32988098f, 0.29956651f, 0.09751876f, -0.04711991f, 
    -0.08317479f, 0.16353826f, 0.08611078f, -0.05714773f, -0.17522107f, -0.32793802f, 0.13529809f, 0.00939234f, 
    -0.23419103f, 0.01554800f, 0.28250715f, 0.13883357f, 0.10901274f, 0.00345886f, -0.56727141f, 0.25134498f, 
    0.10749761f, 0.13679291f, -0.15756591f, 0.07711962f, 0.11217957f, -0.30762470f, -0.14834049f, -0.40647036f, 
    0.19772205f, -0.14978220f, -0.06967740f, -0.00633281f, -0.12249631f, -0.04265442f, -0.01013305f, 0.06318625f, 
    -0.30360329f, -0.03325635f, 0.08270694f, -0.12352918f, 0.03050690f, 0.17704427f, 0.09322803f, -0.03483969f, 
    -0.25221124f, 0.29915321f, 0.08387133f, -0.05959559f, -0.18829735f, -0.10894044f, -0.11707537f, 0.01809094f, 
    0.07380328f, 0.06138233f, -0.28615439f, -0.18486238f, 0.09030557f, -0.09207502f, -0.06421334f, 0.06310596f, 
    -0.08817122f, -0.18649930f, 0.14070649f, -0.07781398f, -0.31183243f, -0.09497006f, 0.08269679f, -0.13855132f, 
    0.03959606f, 0.02477333f, 0.06049911f, 0.06090822f, 0.10801339f, 0.12025567f, 0.25581518f, 0.05897406f, 
    0.05763195f, 0.18694246f, 0.12718149f, 0.17169461f, 0.13390860f, -0.05878030f, 0.24492055f, 0.02451701f, 
    0.24964458f, 0.15840612f, -0.10093317f, -0.31497055f, 0.16443203f, -0.11651801f, -0.57372868f, 0.20605032f, 
    0.50195479f, -0.07511573f, -0.02893515f, 0.04891163f, -0.14191635f, -0.11477140f, 0.04320299f, -0.03489072f, 
    -0.11387575f, 0.17012559f, 0.22296774f, 0.15500562f, -0.20627613f, -0.14132351f, 0.03679918f, -0.11875655f, 
    -0.21136862f, 0.07847113f, -0.04792483f, 0.16343197f, -0.22139464f, -0.00154716f, 0.03916799f, 0.18796575f, 
    0.03523018f, -0.24168420f, -0.04132520f, -0.11731900f, 0.11645390f, -0.24650933f, -0.23599485f, 0.26526910f, 
    0.05469681f, -0.12363347f, 0.02842520f, -0.42434993f, 0.08000562f, -0.19176997f, -0.05859687f, 0.08960904f, 
    0.09888651f, -0.06088571f, 0.10098647f, -0.19291146f, 0.20622632f, 0.06780449f, 0.06834354f, 0.12216919f, 
    -0.20762469f, 0.14708108f, -0.00072163f, 0.30823612f, 0.19336477f, -0.03594706f, -0.05909815f, -0.01366761f, 
    0.10982607f, 0.13792154f, -0.05373501f, -0.10408741f, 0.20744346f, -0.53787988f, -0.09312972f, -0.07027277f, 
    0.14939778f, 0.01004520f, -0.10792617f, -0.12274997f, -0.08814277f, 0.01239977f, 0.21802200f, 0.07698407f, 
    0.16431877f, -0.10228334f, 0.08373956f, 0.15430331f, 0.22621186f, 0.18502590f, -0.01969360f, 0.34196156f, 
    -0.19156106f, 0.31146482f, -0.05625635f, -0.01745033f, -0.00264615f, 0.25790051f, 0.14367557f, 0.02103058f, 
    0.37863278f, -0.09354499f, 0.18986216f, 0.09069137f, -0.12742504f, 0.01936161f, -0.01620629f, 0.00525528f, 
    0.17737775f, 0.18362345f, 0.27795923f, -0.03557990f, -0.03880679f, -0.04833163f, -0.14949156f, -0.08459280f, 
    0.12519105f, 0.01002501f, -0.73860061f, -0.45470297f, 0.03780708f, -0.09823091f, -0.14826675f, -0.06412859f, 
    -0.14181782f, -0.17188287f, -0.11736591f, 0.31996024f, -0.24604645f, 0.23069325f, 0.00461525f, -0.07901305f, 
    0.31452850f, 0.21958043f, -0.04079954f, 0.00829904f, 0.05789507f, -0.11262899f, 0.00914240f, 0.36214021f, 
    0.05804482f, -0.12496013f, -0.14026344f, 0.03877424f, 0.10181262f, -0.45285064f, -0.24365376f, -0.20987618f, 
    0.04110284f, 0.00694489f, 0.00753015f, 0.26952586f, 0.12947157f, -0.09016160f, 0.04161885f, -0.06139567f, 
    0.05388981f, -0.11653603f, -0.06509503f, 0.14130814f, 0.08978186f, 0.28991142f, -0.09770579f, 0.18186168f, 
    0.06281763f, 0.20777240f, 0.05971391f, -0.09947467f, -0.06915958f, 0.45516577f, -0.00106203f, -0.09658354f, 
    -0.02593544f, -0.02880855f, -0.01744219f, -0.02283608f, -0.01163382f, 0.01013900f, -0.06136675f, -0.01991398f, 
    0.01254981f, -0.05439804f, 0.00198715f, 0.03022137f, 0.01889297f, -0.02333032f, -0.00747732f, -0.01669227f, 
    0.04014425f, 0.04449012f, 0.01118286f, 0.02218885f, 0.05064820f, 0.02584054f, 0.01438087f, -0.01938805f, 
    -0.01383072f, -0.05475315f, -0.05030504f, -0.02282036f, 0.02331610f, 0.03757292f, -0.03819332f, 0.04204237f, 
    -0.00596058f, -0.05643920f, 0.03391089f, -0.01179075f, 0.03905715f, 0.04767866f, -0.05076335f, 0.00098736f, 
    -0.03199860f, -0.02063675f, 0.03584646f, 0.04733555f, -0.04833728f, 0.01586549f, -0.05250151f, 0.00601226f, 
    -0.05852621f, -0.02860307f, 0.01364239f, -0.05256740f, -0.01279797f, -0.02416150f, 0.01795793f, -0.04534440f, 
    -0.02291753f, 0.01974399f, -0.03155955f, -0.00850438f, 0.00944501f, 0.04925451f, 0.01181400f, -0.01768367f, 
    0.04659626f, 0.01345097f, -0.03798546f, 0.04167472f, -0.05880975f, -0.00736971f, -0.00580287f, -0.03279766f, 
    0.00460690f, 0.01409042f, -0.04290199f, -0.04906279f, -0.05549055f, 0.02634006f, 0.04921248f, -0.03663171f, 
    -0.05747042f, -0.02375798f, -0.01864573f, -0.04591232f, -0.03708724f, -0.04880871f, -0.03799483f, -0.04158263f, 
    -0.02201330f, -0.06379175f, 0.01251291f, 0.05291117f, 0.01618920f, 0.00398849f, -0.04099894f, 0.01311450f, 
    -0.02585862f, 0.00318614f, -0.00913147f, -0.05148881f, -0.04866112f, -0.03949615f, -0.01495837f, -0.04814344f, 
    0.02379275f, 0.03503681f, -0.04617167f, -0.02871287f, -0.05070116f, 0.04440304f, -0.02550546f, -0.01683686f, 
    0.05244774f, -0.02482756f, 0.04854275f, 0.01586075f, -0.01570150f, -0.05956761f, 0.04844807f, -0.05760975f, 
    0.01952318f, -0.01049413f, -0.02251092f, -0.03881689f, 0.01539003f, 0.04146066f, -0.03651205f, 0.03946190f, 
    0.00359775f, -0.04086308f, -0.05362901f, 0.02382788f, -0.03519110f, -0.06338191f, -0.02167148f, 0.00507032f, 
    -0.00973754f, 0.02248710f, -0.02534089f, -0.01650334f, -0.05318532f, -0.06334570f, 0.04256276f, -0.04306710f, 
    -0.03391508f, -0.01947412f, -0.03155152f, -0.04827093f, -0.04577941f, -0.01134907f, -0.01813351f, 0.01517410f, 
    0.04528088f, 0.01376490f, 0.01364880f, -0.00389250f, -0.02620375f, 0.05243260f, 0.04209955f, -0.02605851f, 
    0.04065730f, -0.03486483f, -0.05743535f, -0.03796307f, 0.02184991f, -0.02528935f, -0.02984714f, 0.00984588f, 
    -0.00710285f, -0.01549609f, -0.01241269f, -0.02706635f, 0.01452515f, 0.00494083f, -0.04978881f, 0.04224066f, 
    -0.04667902f, -0.03722933f, 0.05053389f, -0.01703526f, -0.01488049f, -0.02526772f, 0.03379664f, 0.03877574f, 
    0.01550535f, -0.06333689f, -0.00088333f, 0.01059013f, 0.01686619f, 0.03224245f, -0.06164227f, 0.04031146f, 
    0.00819291f, -0.04971882f, -0.04066535f, -0.03581235f, -0.04881600f, 0.02454905f, -0.04619096f, 0.01032727f, 
    0.00070859f, -0.05660192f, -0.04907241f, 0.05120527f, -0.00304347f, -0.00598974f, -0.05805187f, -0.04093420f, 
    -0.03829817f, 0.01080524f, -0.04635189f, -0.04739603f, 0.02627709f, -0.03975361f, 0.04190077f, 0.02613108f, 
    -0.02599996f, -0.03690228f, 0.05079710f, 0.00591823f, -0.04351625f, -0.03242853f, -0.05443249f, -0.05729055f, 
    0.02538743f, 0.00000955f, -0.00846923f, 0.02138939f, -0.05377112f, -0.02503614f, -0.00897729f, 0.03814220f, 
    0.01411208f, 0.01814521f, -0.02586913f, -0.05251880f, -0.05557899f, -0.03687736f, 0.01632640f, -0.02947080f, 
    -0.04464032f, 0.04865795f, -0.05325247f, 0.00056369f, -0.03102248f, -0.00844710f, -0.01835771f, 0.03546745f, 
    0.04802349f, -0.00161126f, -0.05919793f, -0.03140564f, -0.04880583f, -0.02848285f, 0.02257019f, -0.03091768f, 
    0.01690637f, -0.02677792f, -0.04358646f, -0.00050141f, -0.03660228f, 0.05171504f, -0.05494135f, -0.05097846f, 
    -0.05120501f, 0.01102349f, 0.04137903f, 0.04581281f, 0.04919248f, -0.04268281f, -0.00422644f, 0.01681479f, 
    -0.00940856f, 0.04955670f, 0.00880014f, -0.01229003f, -0.06429682f, -0.04101514f, -0.03608705f, 0.02030235f, 
    -0.00763479f, 0.01256639f, -0.02496130f, -0.00545915f, 0.02766058f, -0.03104427f, 0.04930350f, -0.00357749f, 
    -0.02843129f, -0.02792025f, -0.21376492f, -0.08067549f, 0.07005996f, 0.29827732f, -0.13917141f, -0.12717718f, 
    0.21170753f, -0.34371758f, -0.21118997f, -0.22779347f, 0.28852439f, 0.07293545f, -0.05243075f, 0.04252882f, 
    0.10260295f, 0.01004633f, 0.05181121f, -0.42122972f, 0.11365499f, -0.31233510f, -0.26810467f, 0.15329316f, 
    0.27415621f, 0.02341500f, -0.13182719f, -0.37248844f, 0.01738002f, 0.09142068f, 0.10259572f, 0.15366712f, 
    -0.17934333f, 0.03247206f, 0.23323607f, -0.05658533f, 0.13226439f, -0.33089465f, 0.12523496f, -0.03878112f, 
    -0.14476438f, 0.32186404f, 0.26423118f, -0.01232980f, 0.00013986f, 0.00463811f, -0.08688386f, -0.29853955f, 
    0.14743948f, 0.03493518f, -0.06883032f, -0.02156703f, 0.04829073f, 0.11814344f, 0.23904972f, -0.52274913f, 
    -0.18368036f, -0.16907386f, -0.23353431f, 0.12387774f, -0.02452269f, 0.04483110f, -0.22852118f, 0.21600088f, 
    0.01613615f, -0.19154732f, 0.03955185f, 0.28268546f, -0.19317424f, -0.20607980f, 0.08029824f, 0.11116365f, 
    -0.02620082f, -0.09230077f, 0.41108841f, 0.05814885f, -0.13034888f, -0.07644163f, -0.00019196f, -0.04069087f, 
    0.11047839f, 0.47052601f, -0.12007663f, -0.28326994f, 0.05110765f, -0.02974105f, -0.28701439f, 0.15013391f, 
    0.00257548f, 0.27764434f, 0.05628423f, -0.17918061f, -0.19213657f, 0.00252394f, -0.09465777f, -0.07773514f, 
    -0.02501579f, -0.06183959f, 0.23422915f, -0.18639155f, -0.19597870f, -0.27049729f, 0.16981645f, 0.14120431f, 
    -0.11259132f, 0.12869419f, -0.13025472f, 0.20597956f, -0.02789243f, -0.09852975f, 0.08977381f, 0.01460907f, 
    -0.14862029f, 0.21380277f, 0.03190251f, 0.12828675f, 0.30710256f, -0.02521704f, -0.41274965f, 0.42766422f, 
    0.01887295f, -0.24363895f, -0.03864387f, -0.07025800f, -0.06176120f, -0.04705064f, 0.41954818f, 0.08205057f, 
    0.06295522f, -0.02836378f, 0.00068116f, 0.12224608f, -0.17360498f, 0.11094935f, 0.09315983f, -0.71787024f, 
    -0.25510854f, -0.20717730f, 0.20128337f, 0.03821769f, 0.24169789f, -0.19636783f, -0.14456196f, 0.06332451f, 
    -0.47078758f, 0.01438902f, 0.05950246f, 0.18389131f, 0.02425512f, 0.25303465f, 0.15979268f, -0.19873089f, 
    0.28315622f, -0.33322054f, 0.01733717f, -0.13577217f, 0.27763715f, -0.04481855f, 0.00759002f, 0.13088647f, 
    -0.10883383f, 0.02747541f, -0.36129707f, -0.08542202f, -0.09973462f, 0.33947146f, 0.17959791f, 0.13776585f, 
    0.27087057f, -0.17847063f, -0.20022337f, -0.11946026f, -0.45078191f, -0.49257165f, 0.05262933f, -0.00037160f, 
    -0.06391070f, 0.16234118f, 0.10596159f, -0.20148998f, 0.08230108f, 0.13778257f, 0.19484507f, 0.05621338f, 
    0.07710013f, -0.03933575f, -0.02779748f, 0.20753761f, 0.00381089f, -0.47379684f, 0.09315762f, -0.44921637f, 
    0.14563383f, 0.06777941f, 0.14947206f, 0.23684850f, -0.08714602f, 0.11520692f, -0.08389946f, 0.01520369f, 
    -0.03184474f, 0.50583166f, -0.15752731f, 0.04045181f, 0.01963199f, -0.01527739f, 0.08580415f, 0.22736916f, 
    0.12579563f, -0.08173081f, 0.13406080f, -0.21917213f, -0.05737534f, 0.05262538f, 0.23954880f, 0.08299185f, 
    0.17405690f, 0.08658262f, -0.00979054f, -0.22212242f, -0.00981889f, -0.12230077f, 0.07617527f, 0.05517869f, 
    -0.07244739f, 0.39365464f, 0.13230895f, 0.00588183f, -0.06836765f, 0.08868533f, 0.01058908f, 0.01184815f, 
    0.03739822f, 0.14554071f, 0.24296209f, -0.17758287f, 0.16169158f, 0.01818767f, -0.02009848f, 0.00192016f, 
    0.17838790f, 0.00379347f, 0.09689451f, 0.26141733f, -0.23170388f, -0.08798648f, -0.08703773f, -0.23034145f, 
    -0.02277781f, 0.20854907f, 0.04151031f, -0.22151944f, 0.00853653f, 0.14412841f, 0.18059047f, -0.19642998f, 
    -0.04453890f, -0.28542903f, -0.06443301f, 0.00767979f, -0.25593117f, -0.47762251f, 0.17719153f, 0.25179872f, 
    -0.11321617f, -0.18260810f, -0.06863140f, 0.30597952f, 0.17565916f, -0.23718384f, -0.18886006f, 0.04015573f, 
    0.08844839f, 0.26741078f, 0.13562390f, 0.09797738f, -0.11095308f, 0.21506545f, 0.21906143f, -0.00905478f, 
    0.04557763f, 0.09018550f, 0.08081564f, -0.09002101f, -0.24821863f, 0.14716959f, 0.25485334f, -0.20023178f, 
    -0.07818951f, 0.10779779f, -0.00923651f, 0.02579943f, 0.00458243f, 0.04157172f, 0.11076978f, 0.08965051f, 
    -0.00883493f, 0.27025530f, -0.21182795f, 0.11487861f, 0.04778719f, 0.13981991f, 0.12852371f, 0.07710207f, 
    0.07884140f, 0.33671123f, 0.35872975f, 0.19186722f, -0.07480168f, -0.13131803f, -0.16785380f, -0.10694980f, 
    -0.15493123f, 0.00824588f, 0.02357821f, 0.21584846f, -0.14774515f, 0.12739977f, 0.08238237f, -0.21417004f, 
    0.01770239f, -0.15560360f, -0.10618584f, -0.06551775f, 0.29439682f, -0.19795464f, -0.09585380f, -0.06167987f, 
    -0.07618407f, -0.12386438f, 0.08105495f, -0.11478256f, -0.07136422f, 0.56011772f, -0.24813913f, 0.17667393f, 
    -0.17829561f, -0.30003333f, -0.00209510f, 0.15284970f, -0.06151521f, 0.21330853f, -0.22600910f, 0.14463350f, 
    0.22208826f, 0.04536317f, 0.04148464f, 0.00797568f, -0.16237088f, 0.15302326f, 0.06758669f, 0.00420934f, 
    -0.15820169f, 0.06808669f, 0.07662734f, -0.17112751f, -0.15397629f, 0.00165440f, 0.00685517f, -0.00711370f, 
    0.47038585f, -0.46676448f, -0.02488322f, -0.18252724f, -0.01660455f, -0.39370406f, -0.11754911f, 0.07056706f, 
    -0.03747113f, -0.72245586f, 0.11723612f, 0.08681719f, -0.15939860f, -0.24217851f, -0.04246252f, -0.21320787f, 
    -0.22985435f, 0.04720113f, 0.14449801f, -0.58748841f, -0.04704246f, 0.04698943f, 0.19856973f, -0.13088089f, 
    0.06128415f, -0.09930759f, -0.00320505f, 0.14112650f, -0.05392535f, 0.01444063f, -0.08337871f, -0.19250199f, 
    0.08698518f, 0.08625222f, -0.05921858f, 0.00274454f, 0.18890628f, 0.10883947f, -0.14108157f, 0.22063719f, 
    0.08928621f, 0.01497833f, 0.10784718f, 0.15569893f, -0.13128930f, 0.21949081f, -0.18735340f, -0.17341992f, 
    -0.27788159f, -0.10639956f, -0.14483264f, -0.07873019f, -0.08527011f, -0.04575041f, 0.16505899f, -0.34069642f, 
    -0.29106480f, 0.08728176f, 0.10808179f, 0.22041135f, 0.09173100f, -0.23256193f, 0.07797857f, 0.08250131f, 
    -0.44648930f, -0.42825836f, -0.15276410f, 0.03919303f, -0.00437080f, 0.03035059f, -0.04674006f, 0.11932734f, 
    -0.18198785f, 0.13388750f, 0.09860517f, 0.01356822f, -0.16385944f, 0.01284723f, -0.00439903f, 0.11184226f, 
    0.04981315f, -0.05789262f, 0.21272792f, 0.02115697f, -0.10238545f, -0.24183601f, 0.28168678f, -0.13293192f, 
    0.11214834f, 0.01080878f, -0.10423106f, 0.21254568f, -0.02098763f, 0.05838991f, 0.11982723f, 0.14605476f, 
    -0.24490033f, -0.44420746f, -0.10606659f, -0.05464482f, -0.06729489f, 0.10029470f, -0.06562137f, -0.22486693f, 
    -0.11430437f, 0.06365366f, 0.19595030f, -0.02975414f, 0.10182815f, 0.45601147f, 0.17014965f, 0.06767762f, 
    0.16389711f, -0.17755701f, 0.01464525f, 0.04213765f, 0.06923951f, 0.16571358f, -0.03751453f, -0.08004133f, 
    -0.10600721f, -0.04214586f, -0.07097310f, 0.07474584f, 0.20262335f, 0.16489194f, 0.22703934f, 0.10041336f, 
    0.01644249f, -0.11720526f, 0.23579122f, 0.32776991f, 0.08827438f, -0.01613272f, 0.05208236f, -0.11159947f, 
    0.55285597f, 0.03227597f, 0.11612679f, -0.21604450f, 0.01677880f, 0.30898017f, 0.15942018f, 0.14007330f, 
    0.03398683f, 0.50173545f, 0.25639373f, 0.12908931f, -0.01853965f, 0.14799318f, 0.03745132f, 0.25381678f, 
    -0.07366827f, -0.28168631f, 0.06303626f, -0.16091996f, -0.05404508f, -0.09296276f, 0.07652521f, -0.11959547f, 
    -0.18293561f, -0.04538979f, 0.27509403f, -0.53868008f, -0.17336409f, -0.12574288f, 0.09115220f, 0.14686616f, 
    0.12911774f, -0.10117866f, -0.19680320f, 0.20306735f, 0.17781650f, -0.17891206f, 0.05296202f, 0.03132010f, 
    -0.19432852f, -0.17839845f, -0.02912942f, -0.01489099f, -0.10144278f, 0.52720737f, 0.14610323f, 0.11887215f, 
    0.12776521f, 0.02216315f, 0.00750591f, 0.05518835f, 0.16196316f, 0.37539312f, -0.53653955f, 0.01863571f, 
    0.10321191f, -0.22789551f, 0.08361995f, 0.05215741f, -0.03799587f, -0.09855580f, -0.44011372f, -0.24020475f, 
    -0.37810278f, -0.26363602f, 0.15929304f, 0.09963349f, -0.12383102f, -0.04503663f, -0.01227044f, -0.12633182f, 
    0.45701140f, -0.00118820f, -0.21634242f, -0.23269406f, -0.05546687f, 0.28696910f, 0.15156594f, 0.06183768f, 
    -0.27055210f, 0.30648771f, -0.20215529f, 0.18268591f, 0.06774415f, 0.13665706f, -0.04251906f, -0.03660247f, 
    0.09641971f, 0.22929934f, 0.06702762f, -0.07712720f, 0.05663505f, -0.03529220f, 0.00199895f, -0.21042882f, 
    0.11285173f, -0.17844315f, -0.18609886f, -0.78188211f, -0.19914638f, -0.07361279f, 0.37613454f, 0.25070840f, 
    0.03858570f, -0.10695157f, -0.05827613f, 0.53034663f, -0.07049640f, 0.15746400f, 0.02884459f, 0.10382044f, 
    -0.08267424f, 0.34014827f, 0.08981026f, 0.01375800f, -0.54978240f, -0.10824548f, -0.00123997f, 0.29737321f, 
    0.13881540f, 0.30382153f, -0.19540296f, -0.01661608f, 0.00776667f, -0.15804179f, -0.20446081f, 0.01772549f, 
    0.05912030f, 0.10812794f, 0.01772001f, -0.16121505f, 0.05199194f, -0.10183597f, 0.03225532f, -0.30952558f, 
    0.04569968f, -0.06830835f, 0.03225214f, 0.18736027f, 0.04940867f, -0.02816398f, -0.20266776f, 0.07909194f, 
    -0.15113768f, -0.00953404f, -0.13224162f, 0.01518428f, 0.06444572f, 0.16143028f, -0.08782233f, 0.07759234f, 
    0.12738661f, -0.86660171f, -0.11657048f, -0.07105766f, -0.15360214f, -0.29267520f, -0.33237484f, 0.06084320f, 
    0.01602994f, -0.04074813f, -0.32624054f, 0.09856180f, -0.12602028f, -0.15081078f, 0.20882712f, -0.03292707f, 
    0.07871792f, 0.02366652f, -0.34463990f, 0.02846218f, -0.05003738f, 0.20831756f, 0.05755108f, 0.18176782f, 
    -0.03053728f, -0.09815318f, -0.04912855f, -0.50852728f, 0.01375175f, 0.01088120f, 0.14453639f, -0.01718450f, 
    0.09277158f, -0.24499920f, 0.00069374f, 0.12512924f, 0.10866680f, 0.06000697f, 0.23073296f, -0.26215547f, 
    -0.17980570f, -0.14559950f, 0.10750444f, -0.11789270f, 0.20016484f, -0.12930176f, -0.13732132f, -0.52489895f, 
    0.06737999f, 0.05923205f, 0.43674421f, -0.08889226f, 0.09962008f, 0.03560747f, 0.40167451f, 0.56728816f, 
    -0.35817617f, 0.19858897f, 0.18386857f, 0.00716440f, 0.00487669f, -0.00648773f, -0.05634931f, -0.71352613f, 
    0.25995809f, 0.01524769f, -0.03690444f, 0.19195378f, 0.04239685f, -0.01244600f, -0.09194194f, 0.18484896f, 
    -0.35642835f, -0.38250095f, -0.03259841f, 0.01175177f, -0.13431941f, -0.01894075f, 0.07690667f, -0.03298147f, 
    0.16970988f, 0.05120983f, -0.10088691f, -0.05386748f, -0.21808930f, 0.08961695f, 0.01512589f, -0.03698504f, 
    -0.12569320f, -0.14523210f, 0.10614472f, 0.45009950f, -0.08798423f, 0.05449075f, 0.07035058f, 0.06591588f, 
    -0.09396201f, -0.23491080f, -0.01636894f, -0.41890994f, 0.26681075f, -0.21059370f, -0.07110932f, -0.14009859f, 
    0.02946403f, 0.19754228f, 0.17029418f, -0.08548641f, 0.63858473f, 0.32971752f, -0.26899689f, 0.03282789f, 
    0.05717763f, 0.03371673f, 0.03256766f, -0.02111269f, 0.16820690f, -0.46609139f, 0.22297889f, 0.03021598f, 
    -0.08925376f, 0.01769350f, 0.14279006f, -0.18055025f, -0.01678263f, -0.09140899f, 0.07945355f, 0.09503330f, 
    0.21185502f, -0.11788763f, -0.14015791f, -0.18956062f, 0.13717400f, 0.15800476f, 0.06672250f, 0.58904439f, 
    -0.03016556f, -0.15567321f, 0.09108490f, -0.13757807f, -0.16204569f, 0.03202290f, -0.09909629f, 0.13791709f, 
    0.18550733f, -0.35015053f, -0.14724547f, -0.01793229f, 0.17212407f, 0.07020562f, 0.11469980f, 0.19398053f, 
    -0.00091782f, -0.17451560f, -0.04324251f, -0.30307922f, 0.05746105f, -0.12282558f, 0.10342593f, -0.07161557f, 
    -0.00914516f, 0.07850138f, -0.01555297f, 0.18862964f, 0.28135750f, -0.06324483f, -0.09262063f, 0.19904023f, 
    -0.09666524f, -0.16567366f, 0.03671291f, 0.02980905f, -0.69158518f, 0.08679173f, -0.08569331f, 0.06234812f, 
    0.04537167f, -0.12094983f, -0.12313487f, -0.09433924f, 0.23501317f, -0.07002745f, -0.26535940f, -0.04157034f, 
    0.04123515f, 0.07304920f, 0.15219536f, 0.07488618f, -0.03216437f, -0.08265091f, -0.26370606f, 0.13230121f, 
    -0.11849008f, -0.03464704f, -0.06508135f, 0.10555274f, 0.06231186f, -0.09590317f, 0.40114841f, -0.50583553f, 
    -0.00465295f, 0.08171413f, 0.38577858f, 0.02380204f, -0.04361221f, 0.04149820f, -0.02005608f, 0.62574965f, 
    0.10561417f, -0.07427786f, 0.05845047f, -0.05907598f, 0.07394533f, -0.03237822f, 0.00123760f, 0.05974918f, 
    -0.20966604f, 0.12745841f, 0.14137372f, 0.12686831f, 0.12240811f, -0.02319799f, 0.06115766f, -0.05750809f, 
    0.03271103f, -0.13369393f, -0.08427193f, 0.06772074f, -0.00369812f, 0.05886345f, 0.11974782f, -0.09238108f, 
    0.11733244f, -0.13732366f, -0.03126188f, -0.16208874f, -0.38740709f, -0.07070692f, -0.12662299f, -0.14469360f, 
    0.10155290f, 0.01846199f, -0.03162010f, -0.01541625f, 0.00696548f, 0.46493992f, -0.13067009f, 0.03650265f, 
    -0.03704541f, 0.03502898f, -0.00043401f, 0.01406614f, -0.03988881f, 0.15117562f, -0.55044490f, 0.06794682f, 
    -0.09800975f, 0.15053493f, -0.25217757f, 0.00404490f, -0.01598582f, 0.03849082f, -0.00102155f, -0.07518307f, 
    0.01764321f, 0.09023920f, 0.07321493f, -0.06076669f, 0.06584593f, 0.18254259f, 0.36631832f, 0.15905923f, 
    -0.04814417f, -0.07937731f, 0.12825912f, -0.04239032f, -0.12661940f, 0.13760158f, -0.12412707f, -0.18254964f, 
    0.46658558f, 0.29192111f, -0.05810222f, 0.16895092f, 0.03126017f, 0.20423223f, -0.02482304f, 0.05044796f, 
    0.09558710f, 0.10968795f, 0.41613126f, 0.15152241f, -0.02327417f, -0.06083879f, 0.06673595f, -0.02049896f, 
    0.07019628f, -0.14994481f, -0.05466342f, -0.30219218f, 0.13465287f, 0.01237579f, 0.11437070f, 0.00274259f, 
    0.11565701f, 0.14481333f, 0.29212242f, 0.09325611f, 0.11057786f, 0.10396055f, 0.08109855f, -0.01127163f, 
    -0.00801764f, -0.18574351f, 0.18559569f, 0.10539740f, 0.23234855f, 0.31347319f, 0.06010585f, 0.25939760f, 
    -0.05851597f, 0.03237376f, 0.27362090f, -0.02047238f, -0.06124298f, -0.30648428f, 0.01091314f, 0.00649141f, 
    0.01340345f, -0.08641036f, -0.03818320f, -0.19497657f, -0.14891437f, -0.30451030f, -0.45044982f, 0.28320315f, 
    -0.41279048f, -0.11699087f, 0.19260050f, -0.06662545f, 0.00688213f, -0.19140680f, 0.59663719f, 0.38460624f, 
    -0.08799271f, 0.11336578f, -0.00152938f, 0.15741448f, -0.34233272f, -0.04550872f, 0.04632000f, 0.33102649f, 
    -0.11956238f, -0.29851881f, 0.00607162f, 0.16642617f, 0.11202937f, 0.19802438f, 0.10641237f, -0.00554893f, 
    -0.16346462f, -0.06747078f, 0.06570102f, 0.10411462f, 0.10512957f, 0.10109545f, 0.05011864f, 0.02733336f, 
    -0.07577560f, 0.26163805f, -0.47619238f, -0.05492587f, -0.13405956f, 0.08339079f, 0.06900211f, 0.11011630f, 
    -0.10848475f, -0.30775937f, -0.50033206f, -0.41599804f, 0.22700574f, 0.08434722f, -0.09962870f, 0.15630078f, 
    -0.03013352f, -0.29124138f, -0.12585807f, 0.16733302f, -0.09198347f, 0.06134858f, 0.06209892f, -0.03034941f, 
    -0.06886049f, 0.09341864f, 0.15811154f, -0.01720298f, -0.46693906f, -0.04863512f, -0.22576848f, 0.08569995f, 
    -0.12598279f, -0.00240147f, -0.25054479f, -0.03346591f, -0.17284212f, 0.43449983f, 0.16910137f, -0.05403885f, 
    0.07170436f, 0.20672165f, 0.08850669f, 0.18763331f, 0.04333254f, -0.08178578f, -0.06173853f, 0.13179886f, 
    -0.16954762f, -0.03349290f, 0.28131753f, 0.12709039f, -0.03568667f, -0.07074510f, 0.08124519f, -0.45738301f, 
    -0.09682001f, -0.18266805f, 0.02983295f, 0.17228344f, 0.01293501f, 0.04912902f, -0.09519909f, -0.04358555f, 
    0.30787161f, -0.54309136f, -0.28999671f, -0.02039508f, -0.06857771f, 0.14655213f, -0.14739072f, -0.11650500f, 
    -0.04253902f, 0.13633765f, -0.03633603f, -0.10711718f, -0.07167679f, 0.09063106f, 0.18680564f, 0.07704867f, 
    0.10102377f, 0.00336900f, 0.40663874f, 0.37572581f, -0.06516736f, 0.09877335f, -0.00388077f, 0.18598963f, 
    0.16104534f, -0.03274559f, -0.02846725f, 0.11124744f, 0.17303561f, -0.47303474f, 0.10561976f, 0.16078955f, 
    0.00746431f, 0.05466942f, 0.11324827f, 0.00719125f, -0.26072815f, 0.00524833f, -0.20428930f, -0.05702076f, 
    -0.12303828f, 0.05558045f, -0.21260075f, 0.01520855f, -0.23410822f, 0.26741219f, 0.08003999f, -0.31407598f, 
    0.13676552f, -0.03848313f, -0.07414573f, 0.15848053f, 0.15523070f, -0.09759074f, -0.21095100f, -0.24569996f, 
    -0.13112110f, 0.08552872f, 0.02376125f, -0.05110788f, 0.05299412f, -0.12567775f, 0.01206690f, -0.42004991f, 
    -0.14175622f, -0.10264584f, 0.05674807f, -0.06522793f, 0.01648093f, -0.03325267f, 0.07527704f, -0.24182299f, 
    -0.33083254f, 0.21844575f, 0.09291041f, 0.24734628f, -0.04909272f, 0.07428429f, 0.15051551f, 0.01851494f, 
    0.09982088f, 0.01889072f, -0.05265290f, 0.08938035f, -0.04657013f, -0.11782491f, -0.00204446f, -0.06728259f, 
    -0.01350254f, 0.08144649f, 0.10979056f, -0.28906167f, 0.28627163f, 0.10212541f, 0.17780623f, -0.05407355f, 
    -0.09011971f, 0.20593329f, 0.10531325f, -0.08609121f, 0.20114721f, 0.03881706f, -0.12419899f, -0.07282005f, 
    0.18948585f, 0.01692566f, 0.15875204f, -0.24971585f, 0.17390585f, -0.01209953f, 0.03724364f, -0.14930411f, 
    -0.06123896f, 0.00518112f, 0.11945237f, -0.02059396f, 0.01034961f, 0.01190359f, 0.11069582f, -0.28152817f, 
    0.20920172f, -0.11939073f, 0.00872689f, 0.02527892f, 0.13718461f, 0.15049078f, -0.71196085f, -0.25404820f, 
    -0.22565874f, -0.02289583f, -0.12214569f, -0.19837716f, 0.03286238f, -0.06051952f, -0.20696001f, -0.06177299f, 
    0.24018139f, 0.32208115f, 0.04090466f, -0.02562603f, 0.08674561f, -0.03768762f, 0.02695077f, 0.17237657f, 
    -0.08281829f, 0.53035617f, -0.04585211f, -0.09435111f, -0.06442713f, 0.02142450f, -0.09930103f, 0.07320906f, 
    0.06026064f, -0.10015494f, -0.04565702f, -0.13824794f, 0.34188926f, -0.09782293f, 0.11519220f, 0.00342955f, 
    0.01979474f, -0.02900657f, -0.11524107f, 0.19216454f, 0.09659207f, -0.11211447f, -0.01844468f, 0.01597591f, 
    -0.08569144f, 0.10135689f, -0.07748979f, 0.06027083f, 0.07484453f, 0.09744836f, 0.04549934f, 0.10500825f, 
    0.07166458f, -0.15513797f, -0.03509795f, 0.04869071f, 0.03233679f, -0.20565428f, 0.19929287f, -0.09516609f, 
    0.07983699f, 0.02494711f, 0.01801395f, -0.11039592f, -0.03293582f, -0.55435008f, -0.24306974f, 0.15294227f, 
    -0.04148464f, 0.12175068f, 0.04421770f, 0.00754766f, -0.07179283f, -0.01895174f, -0.39796051f, 0.17240128f, 
    -0.18254605f, 0.16398861f, 0.14435841f, 0.18499927f, 0.03983502f, 0.14328523f, -0.18063915f, 0.51156503f, 
    -0.04236217f, -0.51918352f, -0.03045509f, 0.20985812f, 0.04349148f, -0.02016168f, -0.12722851f, 0.16505887f, 
    0.02447351f, -0.34864908f, -0.23419625f, 0.04763315f, -0.14108407f, -0.00869104f, -0.08006215f, -0.04127291f, 
    0.29662409f, -0.13989344f, 0.13849208f, -0.43924373f, -0.03223417f, -0.05360172f, 0.03498739f, 0.05481927f, 
    0.01713086f, 0.21228030f, 0.30189595f, 0.25005686f, 0.11245184f, -0.08351660f, 0.28096431f, 0.08934298f, 
    0.17621988f, -0.19395849f, 0.08517661f, -0.25470498f, 0.42645395f, 0.00376589f, 0.11577305f, -0.08768367f, 
    -0.07687410f, -0.14839901f, 0.24062218f, -0.12627195f, -0.06083847f, -0.18945999f, 0.24668913f, 0.08455346f, 
    -0.09739254f, 0.03438858f, 0.01781464f, 0.03586050f, 0.19737031f, 0.14677730f, 0.14476161f, -0.42221317f, 
    0.03331029f, 0.07143118f, -0.22994050f, -0.24108203f, -0.07092446f, -0.00510414f, -0.33827490f, 0.05353958f, 
    0.18511334f, -0.01525160f, -0.04419529f, 0.17747974f, -0.01351044f, -0.01546931f, 0.14936544f, 0.03744319f, 
    -0.40322113f, 0.32852519f, -0.12245700f, 0.18578190f, 0.02050042f, -0.07704125f, -0.11009727f, 0.07405794f, 
    -0.41345111f, -0.16999708f, 0.22647578f, -0.01217476f, -0.02241306f, -0.12435507f, -0.02885869f, 0.03950660f, 
    0.05891389f, -0.27839082f, 0.34895521f, -0.19538732f, 0.08819555f, 0.13248917f, -0.07682218f, -0.12858121f, 
    -0.13541567f, -0.10851626f, -0.15422833f, 0.03935463f, -0.12461471f, -0.02185426f, -0.21884452f, -0.08152219f, 
    0.10903224f, 0.01624486f, -0.22399479f, -0.04431140f, -0.22015917f, 0.19312373f, 0.15211935f, 0.10338881f, 
    0.12491240f, -0.00749642f, 0.02483510f, 0.20664044f, -0.13735630f, -0.24117395f, 0.11645503f, 0.14348969f, 
    -0.15602781f, -0.09520172f, 0.08315814f, 0.10608602f, 0.14178152f, 0.31153411f, 0.23723677f, -0.29028040f, 
    -0.11455665f, -0.16650514f, -0.12301597f, -0.12666188f, 0.34248143f, -0.13452409f, 0.23843145f, -0.22911693f, 
    -0.33270803f, 0.10475981f, -0.29227117f, 0.05611684f, 0.15939109f, 0.03128735f, 0.11577710f, -0.37581381f, 
    -0.19655080f, 0.14411722f, -0.03878543f, -0.11681333f, 0.15968408f, -0.13074420f, 0.26265225f, -0.00415537f, 
    -0.03089575f, -0.05581621f, 0.01427990f, 0.04605829f, 0.02907817f, -0.05240301f, -0.05632222f, 0.04062073f, 
    -0.03614354f, 0.04319761f, 0.04077217f, -0.00836205f, -0.05293224f, -0.01210126f, 0.04604402f, 0.02189095f, 
    0.01360252f, 0.04226259f, 0.03719605f, -0.05260249f, -0.02657232f, 0.01565745f, 0.01023650f, -0.05487013f, 
    -0.06067328f, -0.02218364f, -0.02126018f, -0.00946728f, 0.04377986f, -0.01195625f, 0.04112594f, 0.04310049f, 
    0.03501100f, -0.05251096f, -0.01323875f, -0.01931186f, 0.03836203f, -0.06436590f, -0.02614886f, 0.04554230f, 
    0.03579406f, -0.02474563f, 0.04447656f, -0.04328942f, 0.02882175f, -0.01408960f, 0.04674018f, -0.05244311f, 
    -0.04350156f, -0.03537291f, 0.00130181f, -0.05695300f, 0.04002844f, 0.01037566f, 0.04836725f, -0.05304698f, 
    0.00936030f, -0.00638546f, -0.04138400f, 0.04674936f, 0.05016868f, -0.03732715f, -0.00065200f, -0.03137103f, 
    -0.04961796f, -0.06122646f, -0.03356934f, -0.04838097f, 0.01015259f, 0.00919479f, 0.02058283f, -0.03983665f, 
    0.00716777f, -0.01652675f, -0.02817429f, -0.01404320f, 0.04942668f, 0.02132891f, -0.00400578f, -0.03322743f, 
    0.04320043f, -0.05960714f, -0.02669641f, 0.03727050f, -0.02048399f, 0.00496235f, -0.02359961f, 0.02637241f, 
    0.03161493f, -0.02661908f, -0.04301232f, -0.03908872f, -0.00789923f, -0.02360735f, -0.01068018f, -0.04697766f, 
    0.04630573f, 0.01648863f, 0.01575520f, 0.00344978f, -0.05962318f, -0.05670935f, -0.04636148f, -0.03079106f, 
    -0.03600729f, -0.04542692f, -0.01855536f, -0.01017193f, 0.00494062f, -0.01350408f, -0.02274011f, -0.00104196f, 
    0.00784588f, -0.06324717f, -0.02133228f, -0.00600071f, -0.06475584f, 0.01928135f, -0.04526252f, -0.03226354f, 
    -0.00692365f, 0.03369043f, -0.04713311f, -0.03914513f, -0.00412137f, -0.05396101f, -0.04209478f, -0.02093855f, 
    0.05543526f, -0.05955579f, -0.01682627f, 0.01799961f, 0.02407380f, -0.06464557f, -0.03747329f, -0.04583344f, 
    0.03041742f, 0.04601371f, -0.01327812f, 0.01998624f, -0.05080866f, 0.02348306f, -0.01638304f, 0.05167438f, 
    0.03933797f, 0.02938509f, -0.01516033f, -0.01989952f, 0.02764132f, 0.02895871f, -0.02456880f, -0.00246829f, 
    -0.04720308f, -0.01146979f, 0.00137995f, -0.01339448f, -0.00443662f, 0.00672322f, -0.00887283f, -0.01353516f, 
    -0.02732948f, 0.00470647f, 0.00743578f, -0.00427827f, -0.04218642f, -0.04063821f, -0.03550383f, 0.05237193f, 
    -0.00260144f, 0.00630168f, -0.05877146f, 0.05186586f, 0.02809578f, -0.02561072f, 0.01993025f, 0.04568594f, 
    -0.03594930f, -0.03577092f, 0.01308093f, -0.01268970f, 0.04301684f, -0.04205819f, -0.02213329f, 0.03935445f, 
    0.02566767f, 0.01958745f, -0.05884815f, -0.00698996f, -0.06126226f, 0.01309758f, -0.05779460f, 0.00728715f, 
    -0.04676021f, 0.03845046f, -0.00493711f, -0.04678962f, -0.03528477f, -0.02098531f, -0.06023888f, 0.02049229f, 
    -0.00751622f, -0.00099776f, 0.01927484f, 0.01880092f, 0.03551434f, 0.04021389f, 0.01504706f, -0.02594359f, 
    0.04491300f, 0.00283254f, 0.00731601f, -0.04512790f, -0.01563413f, -0.00628398f, -0.00580308f, -0.01863544f, 
    0.03917210f, -0.04625956f, 0.03033975f, -0.03144690f, -0.01412887f, -0.02123361f, -0.00104638f, -0.02984974f, 
    -0.05882182f, 0.02317330f, -0.02888299f, -0.02426584f, 0.03216202f, 0.02396346f, -0.04688738f, 0.03570536f, 
    -0.03364563f, -0.03411766f, -0.06684924f, -0.01324096f, -0.02782393f, -0.01619846f, -0.00358342f, -0.02482952f, 
    -0.05494827f, -0.02483778f, -0.00150139f, -0.02214210f, -0.02888751f, 0.03766998f, -0.01978827f, -0.03184735f, 
    0.02642415f, 0.03023897f, 0.03264152f, 0.03652112f, 0.03688091f, 0.03862231f, 0.01811479f, 0.03813875f, 
    0.00994632f, -0.00505588f, -0.00961765f, -0.00502106f, -0.05998466f, 0.00592485f, -0.04503884f, -0.05431898f, 
    0.00430409f, 0.03236171f, 0.00810866f, -0.00220248f, -0.04927497f, 0.03346933f, 0.03777258f, -0.04365394f, 
    -0.03733481f, 0.02702511f, -0.01268511f, -0.05803817f, -0.03946739f, -0.03831847f, -0.03517380f, 0.01734549f, 
    -0.01545158f, 0.00260481f, -0.03230148f, 0.00281440f, -0.02064940f, -0.04678203f, 0.03892108f, 0.00087464f, 
    0.27890205f, -0.01357748f, 0.41471538f, -0.03088631f, 0.22897154f, 0.01806076f, 0.16415757f, -0.01841072f, 
    -0.05629373f, 0.08916842f, 0.07661788f, -0.01909887f, 0.07529007f, 0.09504502f, 0.29960835f, 0.02400492f, 
    -0.06223632f, 0.07871376f, -0.13324729f, 0.12552771f, -0.01687177f, 0.05286552f, -0.01544192f, -0.24327135f, 
    0.01904754f, 0.08356555f, 0.33171713f, -0.38133863f, 0.04713820f, 0.23306735f, -0.15939541f, 0.16379794f, 
    0.27159026f, 0.00699306f, -0.12500036f, -0.04326481f, -0.12043743f, -0.04833728f, -0.01629523f, 0.35458189f, 
    -0.25214225f, -0.07934115f, 0.05871743f, -0.02689372f, 0.27319923f, 0.40189749f, 0.17269768f, 0.08643748f, 
    -0.03549957f, -0.04754419f, 0.04753332f, 0.13969561f, 0.02497903f, 0.03285348f, -0.33241785f, -0.13754560f, 
    -0.06470878f, 0.21907265f, 0.20540747f, 0.31298566f, -0.32359773f, -0.10528058f, 0.16387929f, 0.12500539f, 
    -0.47811839f, 0.09042541f, 0.00685964f, 0.18251982f, -0.04920885f, -0.04252352f, -0.07014419f, -0.20435138f, 
    0.05998529f, -0.24040106f, 0.34405795f, -0.06821557f, -0.00899676f, -0.04862057f, 0.05496133f, 0.02218987f, 
    0.24129254f, -0.21625172f, -0.23170771f, -0.26450199f, 0.35089213f, 0.19626343f, -0.03183022f, 0.00032274f, 
    -0.01148440f, -0.07804587f, 0.54261476f, -0.06964186f, 0.27042907f, 0.17765038f, 0.08319017f, -0.01099851f, 
    0.16507173f, 0.02713282f, -0.05274277f, 0.39193523f, -0.14407536f, 0.15106302f, -0.03586087f, -0.09580928f, 
    0.09126391f, -0.02968809f, -0.02696912f, -0.02956468f, -0.23490600f, 0.11809655f, -0.14879386f, 0.17001110f, 
    0.27647385f, 0.04052311f, -0.03769161f, 0.19016527f, 0.07421102f, 0.22042148f, 0.24861044f, 0.08087379f, 
    -0.03441137f, -0.18528600f, -0.10631235f, -0.00992546f, -0.14685529f, 0.01144827f, 0.06895471f, 0.20042285f, 
    0.08232293f, -0.02468440f, 0.20893753f, -0.43639055f, 0.35360155f, 0.12637278f, -0.20680840f, -0.29373819f, 
    -0.16480225f, -0.11548152f, -0.12524050f, 0.12037000f, -0.29793623f, 0.08552235f, 0.17980550f, -0.03972487f, 
    -0.01467744f, 0.07538385f, -0.01994657f, -0.24524173f, -0.19987175f, -0.06855725f, -0.16808097f, 0.05994635f, 
    0.03748567f, 0.11893233f, -0.26911283f, 0.32779491f, 0.00894737f, 0.05176064f, 0.15271838f, 0.08141124f, 
    0.10547042f, -0.19864613f, -0.46868160f, -0.66305190f, -0.45639157f, 0.02722311f, 0.26910013f, 0.00666983f, 
    0.02375556f, -0.16965073f, -0.10448492f, 0.25947246f, 0.13050690f, 0.14527287f, -0.08349425f, 0.01971443f, 
    -0.03011256f, -0.05828810f, 0.17677897f, 0.11364131f, -0.24590334f, 0.13347611f, 0.05882809f, 0.29594201f, 
    0.06762312f, 0.23892820f, -0.11718105f, 0.03426539f, 0.05877014f, 0.31054121f, 0.04109288f, 0.20692068f, 
    -0.21968694f, -0.19155163f, -0.07812644f, -0.00105248f, 0.13681704f, 0.08296410f, -0.12272242f, -0.11795758f, 
    -0.33325145f, 0.06144835f, 0.22543836f, -0.04903122f, -0.03497256f, 0.07077032f, -0.18958689f, -0.32469717f, 
    0.13769208f, -0.20945878f, 0.03988404f, 0.24305314f, 0.00706202f, 0.00081178f, 0.10425255f, -0.04156682f, 
    -0.49076888f, 0.19945523f, 0.21362196f, 0.08460955f, 0.15089260f, 0.12300615f, -0.16024078f, 0.14128295f, 
    0.49573126f, -0.14691949f, -0.11146568f, -0.26389828f, 0.45835969f, 0.05067553f, -0.01987443f, 0.11678942f, 
    0.16165200f, -0.09005265f, 0.23950490f, -0.00173894f, 0.01244658f, 0.27143636f, -0.22212724f, -0.21511853f, 
    0.08690833f, 0.00896896f, -0.17976351f, -0.45114151f, 0.01112802f, -0.01577426f, 0.09263706f, 0.10222339f, 
    -0.04244981f, 0.10405034f, 0.28188413f, -0.17919135f, -0.18054867f, 0.25356960f, 0.00509550f, -0.02334272f, 
    0.07880726f, 0.22400014f, -0.13610384f, 0.03674449f, 0.42517963f, 0.15948842f, -0.10071656f, 0.03667171f, 
    0.09370793f, -0.08577792f, -0.15734842f, 0.19844212f, 0.04864962f, -0.20743105f, -0.37990582f, -0.10212770f, 
    0.06567313f, -0.07651552f, 0.17093998f, -0.10380746f, 0.14640611f, -0.03557008f, -0.14709184f, -0.20268978f, 
    0.11510307f, 0.09534650f, 0.18933569f, 0.27972788f, 0.15091947f, -0.15966155f, -0.05713824f, -0.14198305f, 
    0.03586920f, -0.03087712f, -0.00864020f, -0.00774391f, -0.01165607f, -0.00308556f, 0.00723962f, -0.01143968f, 
    0.05297264f, 0.03817005f, 0.01798240f, 0.03795242f, 0.03919506f, 0.04832372f, -0.04005757f, -0.02783391f, 
    0.02489868f, -0.03704062f, -0.00874097f, -0.03740384f, 0.02743602f, 0.02334080f, -0.05800502f, 0.04104186f, 
    0.01142319f, -0.01442934f, -0.00498464f, 0.00616176f, -0.05375632f, 0.04757743f, -0.01240824f, -0.04966962f, 
    0.03754913f, 0.04219222f, 0.01725828f, -0.00442908f, 0.03979612f, -0.02748834f, 0.02817967f, 0.03973613f, 
    -0.01574071f, 0.00248793f, -0.01556072f, -0.04729856f, 0.01240662f, -0.05879315f, 0.02696839f, -0.05970368f, 
    -0.02817704f, -0.05229817f, 0.02897991f, 0.04709747f, 0.04745030f, -0.01037500f, -0.03710720f, 0.00914709f, 
    -0.05439297f, -0.03109656f, 0.00688344f, -0.01256153f, -0.04511063f, 0.01437435f, -0.03996533f, -0.03062770f, 
    -0.03711195f, 0.02353763f, -0.01238171f, -0.04119667f, -0.00803281f, -0.02727003f, 0.04142494f, 0.02002113f, 
    -0.02326980f, -0.02804975f, -0.03170704f, -0.02648324f, -0.03323423f, 0.04211376f, 0.00990103f, -0.05522094f, 
    0.04155976f, 0.03646505f, -0.03890122f, -0.00509414f, 0.00534301f, 0.02770783f, 0.02336253f, -0.05575396f, 
    0.02330768f, -0.01696914f, 0.04459664f, 0.02806308f, -0.03745850f, 0.05050555f, 0.04095354f, 0.04563927f, 
    -0.03782131f, -0.05762092f, -0.00506916f, -0.02264933f, 0.05483372f, -0.04990464f, -0.03101452f, 0.03793254f, 
    -0.02125797f, 0.02449114f, 0.04103110f, -0.05263727f, 0.02687846f, 0.02076392f, -0.01967524f, 0.03455127f, 
    0.05528836f, 0.04490423f, -0.02518345f, -0.01957826f, 0.05640525f, 0.01431693f, 0.02897273f, -0.04403671f, 
    0.01379638f, -0.05850368f, 0.03584547f, 0.00077169f, 0.00748621f, -0.00087065f, -0.01837431f, 0.00241574f, 
    0.03937470f, -0.06006475f, 0.05135488f, 0.03235104f, -0.03467034f, 0.03424480f, -0.04183016f, 0.05319560f, 
    -0.02348679f, -0.02300137f, -0.04671268f, -0.01186316f, 0.00106328f, 0.03415193f, 0.01755044f, -0.03179114f, 
    0.02117717f, -0.04558296f, -0.00255940f, -0.04542734f, 0.05147136f, 0.03150180f, -0.03575050f, -0.03346636f, 
    0.04772609f, 0.03013400f, 0.01462680f, 0.01540509f, 0.01614627f, 0.03085985f, 0.04437568f, 0.02033217f, 
    -0.06285420f, -0.02354219f, 0.01471658f, -0.01463302f, 0.02553608f, 0.04853241f, -0.05287660f, 0.00586317f, 
    0.03200980f, 0.05483116f, 0.00952408f, -0.04305408f, -0.03311170f, -0.01362591f, -0.02921023f, -0.05826290f, 
    -0.04560093f, -0.01093365f, -0.01858211f, 0.04002578f, 0.00162284f, 0.00791082f, -0.04959537f, 0.04083012f, 
    -0.02993009f, -0.01365438f, -0.05551286f, 0.01015695f, 0.00306227f, -0.00090743f, -0.03967307f, -0.03134679f, 
    0.00035797f, -0.05271684f, -0.02367633f, -0.06010211f, 0.02345368f, -0.04477381f, 0.00962185f, -0.02153612f, 
    -0.00452567f, -0.02472671f, -0.05590025f, -0.04074546f, 0.00699132f, -0.03529133f, -0.02807339f, -0.03695942f, 
    -0.01531204f, -0.03091758f, -0.00539321f, 0.03864982f, 0.02539773f, 0.03339777f, -0.04022607f, 0.03291021f, 
    -0.01889767f, -0.03450625f, -0.02419560f, 0.01896795f, -0.04491898f, 0.02948841f, -0.01392354f, -0.03440036f, 
    -0.03622533f, -0.02288265f, 0.04039017f, 0.00224572f, -0.01781365f, -0.04318462f, 0.00249329f, 0.03203043f, 
    -0.02023053f, 0.02881543f, -0.05392649f, 0.00300686f, 0.01969741f, 0.04639002f, -0.02679371f, -0.02579658f, 
    -0.02827314f, -0.05659959f, -0.05526235f, -0.01784018f, -0.04599442f, -0.02570812f, 0.05361758f, 0.05537334f, 
    -0.04140833f, -0.05306011f, 0.01826457f, -0.02234384f, 0.03586055f, -0.01811237f, 0.00967469f, 0.01768645f, 
    -0.03020388f, -0.03918396f, 0.03665468f, 0.04584215f, -0.06317451f, -0.03306097f, -0.04191046f, -0.05071567f, 
    -0.04090070f, -0.00601089f, -0.01356039f, -0.03891433f, -0.05750281f, 0.02529392f, -0.04920795f, -0.04250212f, 
    0.01645536f, -0.02658782f, -0.02614088f, 0.04251662f, -0.04853762f, 0.01293904f, -0.05403129f, 0.01789062f, 
    -0.01781006f, 0.02765627f, -0.04727124f, -0.01199204f, 0.01373436f, -0.04496262f, -0.05408435f, -0.03124656f, 
    0.05176056f, -0.03799244f, 0.01218141f, 0.02179147f, 0.04666977f, 0.05339987f, 0.02769219f, -0.03479626f, 
    -0.05059992f, -0.04467608f, -0.00391380f, 0.04823590f, -0.00755271f, -0.01517972f, 0.03890363f, 0.02874269f, 
    0.00957073f, -0.03556614f, 0.01064800f, -0.06060398f, 0.05757286f, -0.03297092f, -0.00662144f, 0.04065744f, 
    -0.05370347f, -0.03847884f, -0.00289135f, -0.01023546f, 0.01874705f, 0.01111349f, -0.05415401f, 0.03952689f, 
    0.00097483f, 0.01814048f, -0.00201149f, -0.06941677f, 0.03901773f, 0.02148578f, -0.00463125f, 0.04318430f, 
    -0.04902127f, 0.03080152f, 0.02594272f, 0.00410921f, -0.03084199f, -0.04702974f, -0.02768506f, 0.03117023f, 
    -0.00813329f, -0.02927256f, -0.03273176f, 0.05032391f, -0.06797884f, -0.06683166f, -0.01225688f, -0.03860141f, 
    -0.05723127f, 0.02563296f, -0.03500395f, 0.00624652f, 0.00276130f, 0.02368279f, -0.06639376f, -0.06079172f, 
    0.02160658f, -0.02099093f, 0.00480187f, 0.02117091f, 0.01412211f, 0.02644545f, -0.03776481f, 0.03372063f, 
    -0.02359620f, 0.00237191f, 0.02064964f, -0.04900208f, -0.05327519f, 0.01297859f, 0.05527427f, -0.04637555f, 
    0.00699368f, 0.03258344f, -0.05502183f, -0.03571971f, -0.00567775f, -0.04836079f, 0.02704051f, 0.04590440f, 
    -0.02496181f, -0.03119060f, 0.05017191f, -0.05379928f, 0.04468814f, -0.06731280f, -0.03031643f, -0.02514969f, 
    0.01885727f, -0.01913013f, 0.00537510f, -0.03401740f, -0.00149907f, 0.00046386f, -0.06531870f, -0.03081196f, 
    -0.01733468f, -0.05958877f, 0.03933804f, -0.00532698f, 0.00685555f, -0.02598614f, -0.01436609f, 0.01695347f, 
    -0.05182308f, -0.04745783f, 0.00776396f, 0.01038146f, 0.01344502f, -0.04867415f, 0.05269502f, -0.00644465f, 
    -0.01113125f, -0.03440098f, -0.01192275f, 0.04043102f, 0.01057972f, -0.04291830f, -0.02430291f, -0.04463519f, 
    -0.07089902f, 0.00862499f, -0.06877518f, 0.01541762f, -0.04847216f, 0.02146148f, 0.03470152f, -0.04731683f, 
    -0.01330502f, -0.01570711f, -0.00870448f, -0.02808960f, 0.00071301f, -0.01670004f, 0.04264328f, -0.05335140f, 
    -0.02597289f, -0.03793860f, -0.00434570f, -0.03269506f, -0.01772206f, -0.03015044f, -0.01204838f, -0.00222039f, 
    0.02361397f, -0.02395438f, 0.02538305f, 0.03362464f, -0.00852917f, -0.07127105f, -0.04351988f, 0.05037781f, 
    0.01168309f, 0.03340252f, 0.03068186f, 0.04820135f, -0.04947428f, 0.03607607f, -0.04473894f, 0.00703971f, 
    0.00768545f, 0.04230602f, 0.00495538f, -0.02858928f, 0.02869152f, 0.01317829f, 0.02778700f, 0.03304904f, 
    0.03312426f, -0.03443900f, 0.04117803f, -0.06032240f, 0.02820324f, 0.03826081f, -0.03574576f, -0.05789981f, 
    0.05244445f, -0.05423789f, 0.00584801f, -0.03302399f, 0.00120470f, 0.04861825f, -0.05363281f, -0.00848742f, 
    0.00998737f, -0.00461016f, -0.06610731f, 0.05200223f, -0.02192174f, 0.00549959f, 0.02068556f, 0.00908415f, 
    0.05225008f, 0.00352499f, 0.04746029f, -0.00543655f, -0.00827717f, -0.06486100f, 0.04212378f, -0.05101565f, 
    -0.00598438f, 0.01710937f, -0.05672651f, -0.04500513f, 0.00812204f, 0.04944633f, 0.02138337f, 0.03083938f, 
    -0.00622311f, -0.06240886f, -0.06469398f, 0.05018168f, 0.01348223f, 0.04316329f, 0.02006856f, 0.03053050f, 
    -0.04939419f, -0.05458402f, 0.03474229f, -0.01294230f, 0.05155379f, -0.04021484f, -0.05285120f, -0.05815412f, 
    0.01081082f, -0.02928145f, -0.06168789f, -0.01331181f, 0.01994256f, -0.01372867f, -0.05850322f, 0.04580672f, 
    0.01163300f, -0.02734203f, -0.03000494f, 0.04211212f, -0.02069578f, -0.00538930f, 0.02164939f, -0.01324813f, 
    -0.02410297f, 0.01867043f, -0.04011487f, -0.01897254f, -0.03938389f, -0.00763513f, 0.01450338f, -0.03495942f, 
    0.00189456f, 0.01272149f, 0.00810528f, 0.00694529f, 0.04798587f, -0.04989964f, -0.02735284f, 0.02063175f, 
    -0.04053754f, 0.03017443f, 0.04712977f, 0.00994528f, 0.02508952f, 0.02715193f, -0.03389393f, -0.03056699f, 
    0.00474811f, 0.01934017f, 0.00011807f, -0.03595032f, -0.02947422f, -0.00684020f, 0.03825667f, 0.02962354f, 
    -0.02409172f, 0.01288217f, 0.04262176f, -0.03450246f, -0.03021000f, -0.03873650f, 0.04370987f, -0.03211256f, 
    0.35216701f, -0.00207230f, 0.29193118f, -0.14835872f, -0.02789500f, -0.07158017f, 0.03127763f, -0.04201303f, 
    -0.08391520f, 0.00978144f, 0.11292359f, -0.08378824f, 0.10003506f, 0.01517150f, -0.18956149f, -0.15474959f, 
    -0.21424399f, 0.01910584f, 0.32690471f, 0.07500599f, -0.09806835f, -0.19513863f, 0.01015337f, 0.04595684f, 
    -0.01417949f, 0.13230145f, -0.13868476f, -0.16333412f, -0.11791008f, 0.37131667f, 0.01153254f, 0.03776849f, 
    0.07361176f, -0.13019942f, 0.15727563f, -0.07593668f, -0.19766504f, -0.12514654f, -0.19161737f, 0.03539229f, 
    0.31446528f, 0.16504401f, -0.16713664f, -0.04196792f, -0.11733852f, 0.42530009f, 0.47167596f, -0.15273538f, 
    0.09267921f, -0.12368862f, 0.20092171f, 0.00644826f, 0.08668289f, 0.02652606f, -0.07100390f, -0.18732448f, 
    -0.39263746f, 0.12523134f, 0.10457171f, -0.04563238f, -0.29295129f, 0.14690694f, 0.18255325f, 0.12765655f, 
    -0.06374505f, 0.53028673f, -0.23250270f, -0.03854061f, 0.04639310f, 0.08724935f, 0.03055774f, 0.06657367f, 
    0.23240070f, 0.18867567f, 0.43281317f, -0.09863990f, -0.02203600f, 0.07487979f, -0.00305641f, 0.12502648f, 
    0.25767976f, -0.39477503f, -0.28907990f, 0.00541514f, 0.12924081f, 0.30158940f, -0.15045133f, -0.01912613f, 
    0.02104528f, 0.12221324f, 0.46892998f, 0.15791337f, 0.17309406f, 0.02430879f, -0.23906331f, 0.07942770f, 
    0.31272087f, -0.04472188f, -0.00132527f, 0.54394943f, 0.11647745f, 0.13308437f, -0.01862700f, -0.11929611f, 
    -0.08995388f, 0.11029468f, 0.03567465f, -0.08755530f, -0.17720813f, -0.34077051f, -0.17241566f, 0.02129116f, 
    -0.01203963f, 0.03605985f, -0.21892099f, -0.05841389f, 0.18021660f, -0.06299894f, 0.04998563f, 0.13422507f, 
    -0.02201390f, -0.18063562f, -0.08578072f, 0.15045887f, 0.20292799f, -0.06253483f, 0.21910539f, 0.23687659f, 
    -0.00145712f, 0.09084158f, 0.00276461f, -0.05652206f, 0.02367841f, -0.12423033f, -0.10622313f, 0.10040125f, 
    -0.00106520f, -0.08531308f, 0.17776111f, 0.08871550f, 0.22915925f, -0.13892503f, 0.08081197f, -0.00158014f, 
    -0.34831080f, 0.01529850f, -0.15375811f, -0.05757477f, -0.08161251f, -0.02742340f, 0.07696538f, 0.22091712f, 
    -0.03401450f, -0.17550428f, 0.07600962f, -0.04385637f, -0.27144301f, 0.10875999f, 0.22726862f, -0.06732318f, 
    0.08049579f, -0.37911135f, -0.37580028f, -0.03530331f, -0.15858208f, -0.19274391f, 0.30960810f, 0.19903876f, 
    -0.01559089f, 0.11670980f, -0.15736452f, 0.25398538f, 0.24067372f, 0.03292947f, 0.12102648f, -0.22134212f, 
    -0.15497361f, -0.03845568f, 0.06060856f, -0.06952643f, -0.12920740f, -0.12859261f, -0.17210925f, 0.23967743f, 
    -0.10601668f, 0.24235857f, -0.00831662f, -0.08856614f, -0.05236340f, 0.18943436f, 0.32146299f, -0.18642269f, 
    -0.15087411f, -0.00913032f, 0.13796307f, 0.16223338f, 0.15475893f, -0.03991076f, -0.01915427f, 0.04417958f, 
    0.05202608f, -0.13611022f, -0.16750140f, -0.10266814f, 0.18984210f, -0.25061238f, -0.02151952f, 0.07970622f, 
    0.48983723f, -0.30194697f, -0.06500119f, 0.04199955f, -0.07587172f, -0.01257254f, 0.07612426f, 0.07573312f, 
    -0.40907660f, 0.20259589f, -0.36151916f, -0.06429970f, 0.10545032f, -0.19643782f, 0.05279277f, 0.09853419f, 
    0.17653458f, -0.40149328f, -0.21573415f, -0.36078519f, 0.12754546f, 0.12568484f, -0.05608546f, 0.16498037f, 
    -0.03095632f, -0.10397711f, 0.39702252f, 0.01032033f, -0.06561208f, 0.04152219f, -0.13961254f, 0.04554064f, 
    0.05130494f, 0.21321842f, -0.03156504f, 0.10844371f, -0.27866682f, -0.24811159f, -0.08618695f, 0.00056770f, 
    -0.05621456f, -0.08064174f, -0.15749751f, -0.16966967f, -0.42285097f, -0.11879480f, -0.12061221f, 0.06343933f, 
    0.05865604f, -0.07275836f, -0.00296827f, -0.00961384f, 0.05168777f, 0.23408468f, 0.12684612f, -0.29817477f, 
    -0.11200172f, 0.02409010f, 0.06070415f, 0.28335455f, 0.07845434f, 0.00819960f, -0.33586141f, -0.02213797f, 
    -0.20889753f, 0.13489424f, -0.02433511f, 0.08615418f, 0.07894363f, 0.02503075f, 0.23415987f, -0.04246549f, 
    0.19470681f, 0.00152950f, 0.06990124f, 0.13146982f, 0.02963173f, -0.22659738f, 0.05250800f, -0.27054411f, 
    -0.07628082f, -0.25272557f, -0.12016839f, 0.22052737f, 0.22110301f, 0.02251089f, 0.10463957f, -0.24451710f, 
    -0.13754497f, 0.29618415f, -0.17503624f, 0.07387713f, 0.17024875f, 0.11743452f, -0.15963487f, -0.06715256f, 
    0.07840558f, -0.09019081f, 0.12883790f, 0.09055772f, 0.10685370f, 0.14754266f, -0.08098133f, 0.05095450f, 
    0.17153968f, 0.24585515f, -0.13133234f, 0.18192871f, 0.11696243f, -0.08108065f, 0.01127282f, 0.02816942f, 
    0.08560801f, -0.22278599f, -0.01252804f, -0.15798174f, 0.34309137f, -0.09846884f, -0.02688435f, -0.07768151f, 
    -0.17322709f, -0.18345825f, 0.21570630f, 0.01402268f, 0.00437351f, 0.06184880f, -0.04410397f, -0.15465118f, 
    0.11681780f, 0.06471825f, -0.09685129f, -0.00158401f, 0.02635560f, 0.21438597f, -0.09755318f, -0.25285453f, 
    -0.11182217f, 0.10684535f, -0.09703214f, -0.17730682f, -0.15292113f, 0.00737224f, 0.28692627f, 0.12894915f, 
    0.21661153f, 0.05995961f, 0.02601014f, 0.05354528f, 0.19574551f, -0.01650260f, -0.07336240f, -0.22793771f, 
    0.01595437f, -0.13750480f, -0.47981167f, -0.02606932f, -0.01522296f, -0.12537606f, 0.05737699f, 0.22774501f, 
    0.19608705f, 0.04574332f, 0.07543939f, -0.26287049f, 0.21990810f, 0.21190508f, -0.05320757f, 0.17482626f, 
    -0.24358325f, -0.07580543f, 0.04867270f, 0.10290781f, -0.28179497f, 0.16993614f, 0.03549655f, -0.03027645f, 
    0.11681364f, -0.10928740f, 0.03239554f, 0.13322443f, -0.17658243f, -0.27620161f, 0.16762176f, 0.09114812f, 
    0.10106046f, 0.04078402f, -0.09885804f, -0.00643518f, 0.30454880f, 0.11171988f, 0.23343009f, 0.11187156f, 
    -0.14164732f, -0.05814058f, -0.08192342f, 0.06636500f, 0.04474924f, -0.16018647f, -0.08746288f, -0.34702280f, 
    0.12600286f, -0.33317298f, 0.03650255f, -0.03447332f, 0.13166006f, -0.03046099f, 0.22481829f, -0.18819055f, 
    -0.32452139f, 0.27021733f, 0.13037962f, -0.14507653f, 0.04893932f, -0.01115107f, 0.14088370f, 0.31159747f, 
    0.14120883f, -0.16886847f, -0.16558814f, -0.11438099f, -0.10197486f, 0.12680881f, -0.02152979f, -0.10370349f, 
    0.31241193f, -0.29433095f, -0.34166992f, 0.23486060f, 0.05293627f, 0.33583513f, 0.08524345f, -0.20354131f, 
    0.06397522f, 0.06974739f, 0.27202696f, -0.16115294f, 0.15558031f, -0.08589312f, 0.03314587f, 0.09023537f, 
    -0.12037728f, -0.03307875f, 0.33632526f, -0.03587229f, 0.14194514f, -0.12547138f, -0.06250071f, -0.16595252f, 
    0.27358872f, 0.04902475f, -0.08697148f, -0.15660779f, -0.00508655f, -0.08537778f, 0.22966352f, -0.05270815f, 
    -0.10881686f, -0.08013663f, -0.21584681f, -0.07292178f, 0.12317307f, -0.02898069f, 0.21545069f, -0.22602375f, 
    -0.08280710f, 0.04543912f, 0.05558428f, 0.01775511f, 0.33792582f, 0.14124243f, -0.15874013f, -0.08899865f, 
    0.47165418f, -0.20216113f, 0.07709438f, -0.12156779f, -0.13682419f, -0.41792220f, 0.15318079f, 0.06695741f, 
    0.24829619f, 0.06631998f, -0.10096553f, 0.10418897f, -0.05508619f, -0.14899521f, 0.27598092f, 0.06270970f, 
    0.08013972f, 0.29148528f, -0.03216767f, -0.04368009f, -0.17786613f, -0.13752793f, 0.07176182f, 0.02659933f, 
    -0.14602287f, 0.01946906f, 0.37765732f, -0.25932553f, -0.19427620f, -0.08454420f, 0.05639740f, -0.03939644f, 
    0.19681472f, -0.36020723f, -0.09958938f, -0.21025355f, 0.02568663f, -0.04457462f, -0.03802111f, 0.25289780f, 
    0.05436171f, 0.14479594f, 0.12049442f, 0.07103989f, -0.17494810f, 0.25193238f, -0.12696412f, -0.04755969f, 
    0.14516957f, -0.08082392f, -0.11793908f, 0.20374553f, 0.09624223f, 0.14093232f, 0.15238252f, -0.07420954f, 
    0.15259384f, 0.00789222f, -0.17256926f, 0.15885499f, -0.16832291f, -0.08767231f, 0.07209247f, -0.14669277f, 
    -0.01674979f, 0.07742070f, -0.09268806f, -0.05110515f, -0.00421503f, 0.16133563f, -0.01534196f, -0.00987145f, 
    0.22414665f, 0.01937825f, 0.05274843f, -0.18538445f, -0.03096496f, 0.09242357f, 0.11555406f, -0.05894085f, 
    0.15212902f, -0.15463109f, -0.14474413f, -0.03316646f, -0.04799358f, 0.14456317f, 0.22699024f, 0.04445426f, 
    0.09465357f, 0.19959331f, -0.17215990f, 0.33978412f, -0.30415013f, -0.33467031f, 0.18208389f, -0.18263367f, 
    -0.00865980f, 0.04064487f, 0.02208682f, -0.00889588f, -0.00626067f, 0.00050332f, 0.03236021f, 0.03054875f, 
    -0.02906444f, -0.00850630f, 0.01554613f, -0.02875677f, 0.02831634f, -0.03906767f, 0.00477436f, -0.02860885f, 
    0.01784736f, 0.01547467f, -0.02367104f, 0.02012985f, -0.03317251f, -0.03611898f, 0.00015613f, -0.06357823f, 
    -0.01844571f, 0.00166738f, 0.02189839f, -0.04664559f, 0.04573701f, 0.04594399f, 0.00543527f, -0.03964774f, 
    -0.05460378f, -0.03108656f, -0.06175634f, 0.03417572f, -0.03716853f, 0.03417409f, 0.00453909f, 0.02896846f, 
    -0.03570972f, 0.04105911f, -0.05393864f, -0.03546309f, 0.02138679f, 0.01697976f, -0.03723193f, 0.00734791f, 
    -0.01674099f, 0.02583241f, -0.05241721f, -0.01432914f, -0.04989133f, -0.02721926f, 0.05374194f, 0.02127189f, 
    0.03373869f, -0.01709233f, -0.04316103f, -0.06772231f, 0.04168392f, 0.00588237f, -0.03474912f, -0.06284916f, 
    0.01660826f, 0.02828386f, -0.03933714f, -0.03964001f, 0.05279802f, 0.02936141f, 0.02959200f, -0.05228837f, 
    0.04877396f, -0.05670309f, 0.03234245f, -0.04556125f, 0.01018216f, 0.04234714f, 0.02801713f, -0.04514825f, 
    0.00081800f, -0.01395185f, -0.03991821f, 0.04687500f, 0.03904616f, -0.05545630f, -0.00671529f, 0.01105861f, 
    -0.06670833f, 0.03669858f, 0.02460142f, 0.04675528f, 0.04306005f, 0.01752885f, 0.03840563f, -0.02833931f, 
    -0.04521919f, 0.01237098f, -0.06020895f, -0.00324742f, 0.03795982f, -0.03587726f, -0.05274908f, 0.03504464f, 
    0.00398063f, -0.00663337f, 0.02719790f, -0.00587881f, 0.02098381f, -0.01183966f, -0.05722925f, 0.03367610f, 
    0.04832306f, -0.04062583f, 0.04183275f, 0.04042404f, 0.00137186f, 0.00563232f, 0.04611345f, -0.02601442f, 
    0.00284212f, -0.02104975f, -0.05701388f, -0.05513354f, -0.01362840f, -0.06305354f, 0.01387551f, -0.01148590f, 
    0.05082142f, -0.03739052f, -0.01573155f, -0.05424471f, 0.02444701f, -0.05013776f, -0.02618865f, 0.01764198f, 
    -0.05927470f, 0.02138640f, -0.05286023f, -0.01075760f, -0.01844931f, 0.00015982f, -0.04893070f, 0.04525474f, 
    -0.00560859f, 0.04043980f, -0.04951781f, -0.03737713f, -0.06513187f, -0.02984132f, 0.04275094f, -0.02764024f, 
    -0.02101609f, -0.02910758f, 0.04070853f, 0.04065012f, -0.03656938f, 0.03027258f, 0.01114053f, 0.02042728f, 
    0.04855983f, -0.06236991f, 0.02020934f, -0.03727081f, 0.01036500f, -0.02445531f, 0.00813609f, -0.02395878f, 
    0.00131118f, -0.02028599f, -0.03616551f, -0.00425309f, -0.05628027f, -0.05307553f, 0.05283179f, 0.01048189f, 
    -0.01453547f, 0.00079672f, 0.03649700f, -0.01365253f, 0.00962665f, 0.03604220f, 0.01989865f, -0.03739620f, 
    0.01483835f, 0.01848910f, -0.05206867f, 0.02514931f, -0.05454433f, -0.04586406f, -0.03621349f, -0.00166034f, 
    -0.04015227f, 0.05021762f, -0.03004291f, 0.02624548f, -0.04305142f, -0.04461963f, -0.03486862f, 0.01169424f, 
    -0.04101864f, 0.02265666f, -0.04858531f, -0.02337996f, -0.01281243f, -0.06091165f, -0.05443942f, -0.04790843f, 
    -0.04392215f, -0.03064518f, 0.02233664f, 0.01900370f, 0.02505052f, -0.01065021f, 0.00309936f, 0.04662341f, 
    0.03078374f, -0.04102049f, -0.04678813f, 0.04745157f, -0.04765812f, -0.03692541f, -0.04223653f, 0.01696888f, 
    0.02369822f, -0.02612238f, -0.03237880f, -0.03835209f, -0.05945729f, 0.00636541f, 0.01393687f, -0.05479687f, 
    0.01988403f, 0.01869091f, 0.04006578f, 0.04146325f, 0.01032162f, -0.01213839f, 0.02535543f, -0.02519978f, 
    -0.05181979f, -0.02597792f, 0.00813641f, 0.04145756f, -0.04332719f, 0.04988382f, 0.02402598f, 0.04480327f, 
    -0.02613907f, -0.01631834f, -0.00424519f, 0.04769788f, 0.03300484f, -0.05376530f, -0.05219530f, 0.02238503f, 
    -0.05641684f, 0.00300051f, -0.00225823f, -0.05706870f, 0.00700806f, 0.04316749f, -0.03948543f, -0.04728994f, 
    -0.04956333f, 0.04324496f, -0.02270305f, 0.01154128f, 0.04661753f, -0.05771817f, -0.04959946f, 0.01074010f, 
    -0.02824513f, 0.02776412f, 0.03060444f, -0.01547234f, 0.04384326f, 0.02848743f, 0.01687441f, -0.05775180f, 
    -0.03679048f, -0.05253581f, 0.03803734f, -0.05934626f, 0.02165515f, -0.04884996f, 0.01220897f, -0.04976562f, 
    -0.08483975f, 0.02660131f, 0.02369422f, -0.02863961f, 0.02258321f, 0.01350733f, -0.00075702f, -0.05444826f, 
    0.02528163f, -0.03375535f, 0.01199424f, -0.06110663f, -0.00050321f, -0.09424881f, -0.01337160f, -0.04163831f, 
    -0.07114216f, -0.00033598f, 0.05853045f, 0.08214897f, -0.06933308f, 0.01350586f, 0.05330384f, -0.05203892f, 
    -0.07124804f, -0.07185233f, -0.02300022f, -0.01793404f, 0.01552667f, 0.02974435f, 0.03002152f, -0.07008213f, 
    -0.01312221f, -0.05055136f, -0.06090788f, -0.05898749f, 0.00803814f, -0.05392033f, -0.03390408f, -0.05125879f, 
    -0.02218220f, -0.10782287f, 0.01959185f, 0.01085626f, 0.00307130f, -0.06558913f, -0.07936571f, -0.01990437f, 
    0.02881722f, 0.02260980f, -0.06183825f, -0.00741814f, 0.00089017f, 0.03566564f, -0.00570978f, -0.00463682f, 
    -0.04231903f, -0.02185275f, -0.02644778f, -0.04314280f, -0.00905924f, 0.05337145f, 0.01723885f, 0.02658178f, 
    -0.04907340f, -0.04102932f, 0.01729137f, -0.06036345f, 0.02745389f, -0.02036166f, 0.00114662f, -0.08402826f, 
    -0.01786870f, -0.00010321f, -0.04737910f, 0.00105020f, -0.01496601f, 0.01578188f, -0.02177364f, 0.01484331f, 
    0.05201617f, -0.03394495f, -0.02611694f, -0.07014213f, 0.00188965f, 0.03265530f, -0.02788176f, -0.04246999f, 
    -0.01554556f, 0.04193895f, 0.01171152f, -0.03913600f, 0.04374337f, 0.02929441f, 0.02347810f, -0.02300600f, 
    -0.06413753f, -0.04008962f, -0.03811963f, 0.00844005f, 0.01134310f, -0.02711251f, -0.00491497f, 0.01312290f, 
    -0.01620657f, -0.01195045f, -0.01469584f, 0.00057316f, -0.04532596f, -0.03872066f, -0.00267260f, -0.02695432f, 
    -0.05038779f, 0.01839765f, 0.00000823f, -0.07143658f, -0.09370852f, -0.07523777f, -0.08937454f, 0.01322222f, 
    0.03266921f, -0.03125124f, -0.09239279f, 0.02620538f, -0.00505218f, -0.08956332f, -0.05754877f, -0.09527905f, 
    0.01193866f, 0.11275894f, 0.01693872f, -0.05267513f, 0.00794161f, 0.02797879f, -0.02598988f, 0.00323375f, 
    0.05959931f, 0.02380038f, -0.01008481f, 0.02301275f, -0.01766525f, 0.03615500f, -0.06716978f, 0.03564927f, 
    -0.02953753f, -0.00884786f, 0.03999035f, -0.04519356f, -0.05728143f, -0.05083810f, -0.01830403f, -0.02392113f, 
    -0.02315326f, -0.03703839f, 0.02552450f, -0.00068774f, 0.02174371f, -0.07828972f, -0.04704326f, 0.01794869f, 
    -0.08398680f, -0.09581344f, 0.08125810f, 0.01608835f, -0.01409625f, -0.03428927f, -0.01995588f, -0.02223784f, 
    -0.00790993f, -0.04910800f, -0.05325605f, -0.05533420f, -0.00468085f, 0.07921530f, 0.01192358f, 0.00018477f, 
    0.01132944f, -0.02108603f, -0.07549325f, -0.07119564f, -0.08100986f, 0.01741776f, 0.00742650f, -0.06667766f, 
    0.06232852f, 0.03538847f, -0.03819377f, -0.02072886f, 0.00310973f, -0.03305946f, -0.06597516f, -0.03421963f, 
    0.01845997f, 0.04182777f, -0.04841248f, -0.00284178f, -0.01661601f, -0.05276842f, 0.02129848f, 0.04084028f, 
    -0.00109224f, -0.03285298f, 0.06578788f, -0.02777679f, -0.10713220f, 0.00561898f, -0.01589414f, -0.04360190f, 
    -0.02154033f, 0.05212604f, -0.03488975f, 0.00813222f, 0.00342908f, -0.09673435f, -0.04848047f, -0.01705080f, 
    -0.03154292f, -0.03072785f, 0.05555701f, 0.01803839f, -0.02237346f, -0.05810868f, -0.08744936f, -0.08428656f, 
    -0.08496740f, 0.04377896f, -0.05070033f, -0.05994248f, -0.05510746f, 0.02461908f, 0.01716182f, -0.03777987f, 
    -0.06898718f, -0.02172178f, -0.05033314f, -0.06895405f, -0.00572426f, 0.00592643f, 0.06723149f, -0.02416882f, 
    -0.00074834f, -0.05113675f, -0.00619768f, 0.02727892f, 0.04366404f, -0.10502131f, 0.03207632f, 0.05431331f, 
    -0.05287993f, -0.06538763f, 0.01362399f, -0.04447721f, 0.05560316f, 0.06210409f, -0.01277474f, 0.00681060f, 
    0.02031169f, 0.03676740f, 0.00421039f, 0.03077736f, 0.06704865f, 0.06752043f, -0.00949091f, -0.07482360f, 
    0.01822990f, 0.03709243f, -0.10400599f, 0.00040715f, 0.00812779f, 0.02647787f, 0.00734489f, 0.00857900f, 
    -0.03905364f, 0.02974741f, -0.02884713f, 0.00068980f, -0.01114874f, -0.06742358f, -0.04980190f, 0.01564551f, 
    -0.02949401f, -0.04751881f, 0.04352311f, -0.04462561f, 0.00766307f, -0.07195696f, -0.05863993f, -0.04741415f, 
    -0.02983483f, -0.01980766f, -0.05755077f, -0.05742244f, -0.06578369f, -0.03408735f, 0.03791481f, -0.03600223f, 
    -0.05691230f, -0.01635537f, 0.04339831f, -0.03000660f, -0.00524839f, -0.04423678f, 0.03457137f, -0.01805905f, 
    0.00653508f, -0.00673308f, 0.03919569f, 0.02007001f, -0.02654419f, -0.01602834f, 0.01137442f, 0.04891961f, 
    -0.02711916f, -0.05626347f, 0.03825561f, 0.01593116f, -0.06520019f, -0.01876892f, 0.03371641f, 0.01428073f, 
    -0.04052932f, 0.04735677f, 0.00646738f, -0.04666625f, -0.00955919f, -0.03059922f, -0.06523951f, -0.02496741f, 
    -0.00691762f, -0.03059033f, 0.02189982f, 0.01618259f, 0.02448175f, 0.00860798f, -0.00766226f, -0.02139507f, 
    -0.04104805f, -0.04773431f, -0.03984229f, 0.03615045f, 0.04179860f, 0.03409071f, -0.05641121f, 0.03966208f, 
    0.03960304f, 0.05442535f, 0.03948523f, -0.04911606f, 0.04015756f, 0.03100811f, -0.05813653f, 0.01005497f, 
    -0.00071985f, -0.06690835f, 0.00529677f, -0.03928113f, -0.04045026f, 0.02176559f, -0.01894627f, 0.03085157f, 
    -0.01281286f, -0.02599245f, -0.05625701f, 0.04607647f, 0.02283576f, 0.04565500f, 0.05049403f, -0.02923170f, 
    -0.04161386f, 0.02535662f, -0.03046847f, 0.00949713f, 0.00074072f, 0.03161589f, -0.05653327f, -0.03600460f, 
    -0.02500196f, -0.04427371f, -0.02470760f, -0.01954832f, 0.00680620f, -0.04689194f, 0.03202043f, 0.03470948f, 
    -0.01070561f, -0.01103078f, -0.01851544f, -0.02692479f, -0.05414051f, -0.07135621f, -0.05970313f, -0.00474175f, 
    0.03300013f, 0.00020023f, -0.02317473f, -0.03596259f, -0.01886934f, 0.00787438f, -0.03946411f, -0.01727885f, 
    -0.02576923f, -0.00131910f, -0.06300223f, -0.04494971f, 0.03119487f, 0.01242119f, -0.05559824f, 0.03043461f, 
    0.01558702f, -0.06031664f, -0.05791461f, 0.02367633f, 0.00693155f, 0.02195967f, -0.03679449f, 0.04626726f, 
    0.03486418f, -0.00376612f, 0.02946645f, 0.00716779f, 0.02499834f, -0.04250092f, 0.02827356f, -0.04461483f, 
    -0.05081207f, 0.04320532f, -0.00193885f, 0.02258046f, 0.04567279f, -0.01877535f, 0.03572100f, 0.04715629f, 
    -0.01224331f, 0.01862028f, 0.02046022f, -0.06841420f, 0.03372964f, 0.01049084f, 0.04211302f, -0.00763555f, 
    0.01060544f, 0.02556280f, 0.02820996f, -0.06873281f, -0.05832823f, -0.01393214f, -0.03599330f, -0.06099131f, 
    -0.01573814f, 0.04846201f, 0.01562126f, -0.04170728f, 0.01271289f, 0.01354644f, 0.02309937f, -0.05002769f, 
    -0.07079374f, -0.05209935f, -0.03187074f, 0.02723680f, 0.02364126f, 0.02302175f, -0.00338083f, -0.05225182f, 
    -0.00988282f, -0.05979330f, -0.06449763f, 0.00672936f, -0.05882851f, 0.03386401f, 0.00291397f, -0.01169877f, 
    -0.01237804f, -0.01800710f, -0.04281539f, -0.02219029f, -0.01135490f, 0.00104382f, 0.02250692f, 0.02645021f, 
    0.04146601f, -0.01752059f, -0.00204304f, 0.00873928f, -0.02889493f, 0.03841796f, -0.05923296f, 0.00971699f, 
    0.03211883f, -0.00258900f, 0.03782059f, 0.01854789f, -0.00087439f, 0.00946242f, -0.03990801f, 0.03423630f, 
    -0.02690294f, 0.04098739f, 0.00289640f, 0.01909271f, -0.00780417f, -0.02965507f, 0.00812133f, -0.05914490f, 
    0.00664202f, 0.00541678f, 0.06018248f, 0.05269678f, 0.04729025f, -0.00667750f, -0.03451339f, -0.03307262f, 
    -0.02071953f, 0.03181340f, 0.03953264f, 0.02922461f, -0.02050101f, -0.06010749f, -0.03610137f, -0.03750052f, 
    -0.06154207f, -0.04865430f, 0.03350750f, 0.03941868f, 0.01930499f, 0.04628706f, -0.01043310f, -0.02592215f, 
    -0.06646828f, -0.03649363f, 0.02540763f, 0.01265596f, -0.05797889f, -0.04254087f, 0.00775651f, -0.00840329f, 
    0.02972533f, -0.03884142f, -0.06256144f, 0.00464559f, -0.02491040f, 0.05713006f, -0.04724614f, -0.02819354f, 
    0.00877185f, 0.02356580f, -0.01716512f, -0.03177326f, 0.03223326f, 0.01560736f, -0.05433835f, -0.02417373f, 
    -0.01216524f, -0.05416645f, -0.04764064f, 0.03255103f, -0.04066023f, 0.01415766f, -0.00194643f, -0.02450754f, 
    -0.01216086f, 0.02996519f, 0.00124620f, 0.01091735f, 0.02458593f, 0.03506562f, 0.04074105f, -0.03260009f, 
    -0.06261759f, 0.02525485f, 0.02114891f, -0.02912046f, 0.01175603f, 0.02486926f, 0.00797848f, -0.01425078f, 
    -0.00218822f, 0.01284685f, -0.01492100f, 0.00931014f, -0.06075282f, -0.01861722f, -0.03050495f, -0.01050517f, 
    -0.05124752f, -0.04132678f, -0.00774972f, 0.04315010f, 0.02938667f, 0.03523326f, 0.01745301f, 0.03253443f, 
    -0.04289420f, 0.02716968f, 0.00082640f, -0.05251576f, -0.02685548f, -0.06008909f, -0.01265579f, 0.03183943f, 
    -0.04777495f, -0.01282290f, 0.05068585f, -0.02627422f, 0.03346666f, -0.03325157f, -0.03494083f, -0.01434569f, 
    0.01065324f, -0.04713627f, -0.05551889f, 0.02704845f, 0.04432605f, -0.03979816f, 0.02452247f, 0.00136048f, 
    0.02157396f, 0.03958707f, 0.02104573f, -0.02205421f, -0.03405674f, 0.03776937f, -0.05127349f, 0.02913629f, 
    0.02795954f, -0.05380701f, 0.01133226f, -0.00559584f, 0.04429807f, 0.02591502f, 0.02920781f, 0.04748055f, 
    0.01205355f, 0.05583774f, 0.00257370f, -0.03230850f, 0.01474561f, -0.05352281f, -0.03686904f, -0.00823411f, 
    -0.03671345f, -0.02445189f, 0.03607265f, -0.03740683f, -0.01600114f, -0.01927968f, -0.05935897f, -0.00800036f, 
    -0.06516633f, -0.05683840f, -0.00355074f, 0.05216682f, 0.00370425f, 0.03600132f, -0.05408938f, 0.04901487f, 
    0.03970742f, 0.02942591f, -0.05003343f, -0.04015830f, 0.02101662f, 0.04704025f, -0.04401103f, 0.05473373f, 
    -0.01412691f, -0.01007197f, -0.02968943f, 0.00646819f, 0.04865457f, 0.04617883f, 0.01751748f, 0.01764474f, 
    -0.05706659f, -0.00290571f, 0.00726094f, 0.02621801f, -0.03783311f, 0.03728051f, -0.04511598f, -0.04773458f, 
    0.03083683f, 0.03927045f, -0.03560191f, -0.06646664f, 0.03383555f, 0.04470183f, 0.04506480f, 0.02304504f, 
    -0.05153616f, 0.04814350f, -0.04383041f, -0.00818188f, -0.04524907f, -0.00597888f, -0.06241174f, 0.04641439f, 
    -0.01139085f, -0.06233276f, -0.03424104f, 0.01587714f, -0.04739088f, -0.01885363f, -0.02602558f, -0.04053814f, 
    0.03907546f, -0.01458902f, -0.02367701f, 0.03479454f, -0.01647313f, -0.02423969f, 0.02249979f, 0.04668315f, 
    -0.05393619f, 0.00340057f, -0.06091547f, 0.03741603f, -0.00936218f, -0.00147400f, -0.02560891f, 0.04260089f, 
    0.02350567f, 0.03243741f, -0.02965464f, 0.05145581f, -0.00678767f, -0.03172975f, 0.05033787f, -0.04775721f, 
    0.01086120f, 0.02381668f, -0.03186862f, -0.02701846f, -0.00906918f, -0.01234549f, -0.03614844f, 0.04839948f, 
    0.02017258f, 0.00622974f, 0.00075384f, 0.04797789f, -0.02292769f, -0.00043841f, 0.00747076f, 0.02719137f, 
    0.03719573f, -0.05288706f, 0.04760033f, 0.00700417f, -0.05068358f, -0.03748630f, 0.01104167f, -0.05859173f, 
    -0.03279650f, -0.01833881f, -0.00989371f, -0.04204054f, -0.01173436f, -0.01562885f, 0.00620011f, 0.04502778f, 
    0.00334722f, -0.02858337f, -0.00700833f, -0.00276803f, -0.04496624f, -0.03129070f, -0.04828428f, -0.01394858f, 
    -0.01804809f, -0.03188625f, -0.03556399f, 0.01975246f, 0.00153916f, -0.05982188f, 0.04736780f, -0.05894745f, 
    -0.04427725f, -0.02566625f, -0.03433912f, 0.04259480f, 0.05217563f, -0.01915779f, -0.02458221f, -0.03682362f, 
    -0.05359580f, -0.05523955f, 0.01538607f, 0.00009592f, -0.02808313f, -0.04847651f, -0.04957573f, -0.05017944f, 
    -0.02527209f, 0.04223089f, -0.00782545f, 0.05433836f, 0.04266148f, -0.05464888f, 0.01494056f, -0.05682432f, 
    -0.01369439f, -0.02742101f, -0.00035777f, 0.02548050f, -0.00228624f, -0.02855213f, -0.04662381f, -0.03328986f, 
    0.01846885f, -0.01430362f, -0.03557609f, 0.04488480f, -0.03697243f, -0.05480078f, 0.03919770f, -0.00292613f, 
    -0.00740517f, 0.01697680f, 0.04138387f, 0.04329918f, 0.00334335f, -0.03957655f, -0.04268479f, 0.01393930f, 
    -0.00499997f, -0.00764707f, 0.01384260f, -0.04010502f, 0.01408073f, -0.05653225f, -0.06001008f, 0.04452436f, 
    -0.02583138f, 0.05416684f, -0.00471290f, 0.00453677f, 0.05343614f, -0.05005473f, 0.05807079f, -0.01273181f, 
    -0.03062199f, -0.00367495f, 0.03124556f, -0.02210781f, -0.05812055f, 0.04112498f, -0.03589559f, 0.04131900f, 
    0.03122082f, 0.02908378f, 0.02079302f, -0.01757129f, 0.05499523f, -0.01928917f, -0.04809874f, -0.02805411f, 
    0.04872674f, 0.00430859f, 0.03275733f, 0.04183491f, 0.00493302f, 0.01629817f, 0.04884607f, -0.03647771f, 
    0.38299099f, 0.06850106f, 0.26135153f, 0.17874011f, -0.01265976f, 0.15743244f, 0.26787725f, -0.00140831f, 
    0.17169057f, 0.32107067f, 0.19279467f, 0.03043351f, 0.06257173f, 0.13610995f, 0.13548557f, 0.15226229f, 
    0.05954506f, 0.16109478f, -0.35984311f, -0.21941677f, -0.51704335f, 0.07040084f, -0.12028284f, -0.03372554f, 
    0.10750213f, 0.01620333f, 0.18785390f, -0.03036954f, 0.04731069f, 0.17210096f, -0.04698262f, -0.05626165f, 
    -0.15692323f, 0.31009528f, 0.03799088f, -0.05337720f, 0.07840488f, -0.05129483f, -0.07586574f, -0.00434405f, 
    -0.16072446f, 0.10671240f, -0.05526530f, 0.05680958f, 0.20581609f, 0.13291405f, 0.13324653f, 0.26778236f, 
    0.08645028f, 0.21939090f, 0.01692509f, 0.03295440f, -0.04329073f, 0.25725710f, -0.45176971f, 0.00064033f, 
    -0.20932469f, -0.03677635f, 0.22339405f, -0.05181834f, -0.02050701f, -0.06177139f, -0.15078367f, 0.16144957f, 
    -0.12868103f, -0.16103971f, -0.07085947f, -0.17700654f, -0.25176561f, -0.21327756f, -0.05429887f, 0.15221825f, 
    -0.13386630f, -0.23265272f, 0.07620718f, 0.17983174f, -0.13329342f, 0.04132327f, -0.03497270f, -0.02664565f, 
    -0.11818042f, 0.26853418f, -0.35967672f, -0.11817409f, 0.13610256f, 0.06831456f, -0.07907076f, -0.11403815f, 
    -0.01937318f, -0.15820193f, -0.07000809f, -0.09955403f, 0.24949844f, -0.02930551f, 0.13303784f, 0.26224315f, 
    0.10372778f, 0.11253437f, 0.20630404f, -0.12660226f, 0.06982967f, 0.40029997f, 0.13131933f, 0.17312436f, 
    0.08307458f, 0.19176705f, 0.23118475f, 0.02435230f, -0.05365606f, 0.16314615f, 0.35732704f, 0.08512291f, 
    -0.08977657f, -0.05437581f, -0.05520434f, 0.05609449f, -0.03187247f, -0.59130478f, 0.17086394f, 0.22271465f, 
    0.02853356f, 0.20770608f, 0.02256973f, -0.05423577f, 0.03510131f, -0.01363375f, -0.04328091f, 0.39781305f, 
    0.26184651f, 0.13815498f, 0.18705730f, 0.12419407f, -0.05238295f, 0.10215222f, 0.11251363f, -0.64779550f, 
    -0.02838892f, -0.29182133f, -0.11263850f, 0.05665628f, -0.04234500f, -0.06807097f, -0.04634402f, 0.03915505f, 
    -0.05525183f, 0.15467234f, -0.06756927f, -0.07971323f, 0.21959113f, -0.05339976f, 0.04124951f, -0.24519157f, 
    0.21079750f, 0.14779443f, -0.26088172f, 0.03072994f, 0.18159172f, -0.02776834f, -0.11991137f, -0.10062066f, 
    0.03711397f, 0.03884101f, 0.29117191f, 0.00663005f, -0.11697640f, -0.17279488f, 0.10162426f, -0.22694068f, 
    -0.00404274f, 0.05435599f, -0.31525797f, -0.06865725f, -0.02318216f, 0.29769418f, 0.05694690f, 0.00489802f, 
    -0.12204607f, 0.15256378f, 0.00054761f, 0.19086152f, -0.75038850f, -0.00236142f, -0.29525906f, 0.11893730f, 
    0.12069425f, 0.07644779f, -0.07382352f, -0.01363848f, 0.02305949f, 0.14440279f, -0.00488627f, 0.27431864f, 
    -0.11306805f, 0.10972334f, -0.20659371f, 0.09780659f, -0.13713986f, 0.02155641f, -0.62625134f, -0.20315561f, 
    -0.17713338f, 0.05145633f, 0.01373714f, -0.16855632f, 0.17469405f, 0.11625160f, 0.07794216f, -0.53596288f, 
    -0.35806075f, -0.01670497f, 0.37354493f, 0.23354369f, -0.10033461f, -0.12703076f, -0.10309632f, -0.04804773f, 
    -0.32209817f, -0.02570859f, -0.12417452f, 0.04256056f, -0.03752314f, -0.01299011f, -0.08898955f, -0.14200816f, 
    -0.26033035f, 0.16709940f, -0.04621443f, -0.00096923f, -0.09136458f, -0.01044993f, -0.13004416f, 0.01147902f, 
    0.21891993f, -0.11283402f, -0.08476409f, -0.09967121f, -0.00256609f, -0.30217120f, -0.34027237f, 0.23661518f, 
    0.08278278f, 0.08660633f, 0.03056906f, -0.04257747f, 0.08817019f, -0.13219959f, 0.24511833f, -0.08804395f, 
    0.21947493f, 0.22525559f, -0.03230649f, -0.07203352f, -0.00182670f, 0.08203752f, -0.24926125f, 0.01125475f, 
    0.02478521f, 0.20452176f, 0.22020607f, 0.14897631f, 0.10911538f, 0.15241358f, -0.31598458f, -0.12347855f, 
    0.01308197f, -0.06691497f, -0.21888687f, -0.07508737f, -0.03633061f, 0.04981529f, -0.19346441f, -0.16183661f, 
    -0.00792850f, -0.04196880f, 0.10822032f, -0.06798467f, -0.01740245f, 0.08007021f, -0.07763928f, -0.39150789f, 
    -0.04475265f, -0.27884740f, 0.09969279f, 0.17022519f, 0.06092325f, 0.03684330f, -0.01520389f, -0.07485380f, 
    -0.66425002f, -0.84305733f, -0.14760205f, 0.06564102f, 0.07036702f, -0.01030085f, -0.03755988f, -0.00606081f, 
    0.00792435f, -0.15713587f, -0.04874994f, -0.09286124f, -0.01520902f, 0.11843127f, -0.09829903f, -0.25489527f, 
    -0.14818732f, 0.04973102f, 0.05535200f, 0.16471654f, -0.22129220f, 0.22884065f, -0.11941461f, -0.17361723f, 
    0.11233886f, 0.05833231f, -0.02377537f, 0.43938130f, -0.06520559f, -0.17006011f, 0.08416637f, -0.06047195f, 
    0.11361116f, 0.06936610f, -0.01110140f, 0.14183041f, 0.59305382f, 0.25170258f, 0.10966643f, 0.23201415f, 
    0.00161963f, 0.03384320f, 0.05157873f, -0.06949899f, -0.00289781f, -0.32284287f, -0.38015914f, -0.53720629f, 
    -0.05313687f, 0.08538580f, 0.12342347f, -0.09672958f, -0.21062964f, 0.16776669f, -0.30315328f, 0.10939221f, 
    0.10973398f, 0.09955548f, -0.03720403f, 0.15931804f, 0.00293941f, 0.04662650f, -0.31027249f, -0.13649997f, 
    -0.15525222f, -0.07612649f, -0.20453510f, -0.09326498f, 0.02201803f, -0.06640869f, -0.05910314f, 0.35860291f, 
    0.17798591f, -0.18963198f, -0.05006204f, -0.09198996f, 0.15163629f, -0.01215363f, -0.03848698f, -0.10316893f, 
    -0.26786557f, -0.03948230f, 0.32407209f, 0.17506160f, 0.14118969f, -0.15121682f, -0.22954197f, 0.01990565f, 
    -0.21891224f, 0.21582203f, -0.57500476f, -0.52703357f, -0.13922390f, 0.19152768f, 0.02097452f, 0.02951829f, 
    -0.14626442f, -0.08116119f, -0.22001389f, -1.03950834f, -0.78165072f, -0.30873054f, -0.01649911f, 0.09437062f, 
    0.17293765f, 0.02229286f, 0.15091485f, -0.14245102f, 0.44471970f, 0.13021915f, 0.07319921f, 0.08988076f, 
    -0.25959697f, -0.24378964f, -0.11127363f, 0.32465607f, 0.16194303f, 0.80303115f, -0.34947118f, -0.18549801f, 
    0.06450900f, 0.09343040f, 0.09355770f, -0.04077767f, -0.00854719f, -0.21000068f, 0.03846202f, 0.37071663f, 
    0.44927883f, 0.42374006f, 0.29815626f, 0.26100633f, -0.08474082f, -0.26601058f, -0.23290817f, -0.40811670f, 
    -0.27558908f, -0.00156984f, 0.00912913f, 0.16843627f, -0.18433717f, -0.13134979f, -0.07827874f, -0.18483013f, 
    -0.47687021f, -0.27005297f, -0.04104554f, -0.14607765f, 0.06254330f, 0.03279940f, 0.10714033f, 0.03064004f, 
    0.14341263f, -0.55019826f, 0.03659626f, -0.19452734f, 0.22706349f, -0.21187812f, -0.12591910f, 0.09905262f, 
    0.17937197f, 0.14416112f, -0.27574977f, 0.09789122f, -0.01734278f, -0.03102891f, -0.09553018f, 0.33471453f, 
    -0.06194639f, -0.18846299f, -0.02354780f, -0.52240855f, -0.03887988f, 0.17541678f, 0.10399804f, 0.01459311f, 
    -0.02510591f, -0.10843725f, -0.05980480f, -0.05386765f, 0.53548515f, 0.28937680f, 0.05065625f, -0.04003412f, 
    0.03367530f, -0.07055625f, 0.10412889f, 0.19032767f, -0.01153276f, -1.02642119f, -0.25721142f, 0.23152132f, 
    0.27111214f, 0.20432755f, 0.31922871f, -0.24574228f, 0.22504978f, -0.07102538f, 0.17834458f, 0.22794627f, 
    -0.13267080f, -0.18867248f, -0.09044386f, 0.23136136f, -0.16107051f, 0.33548686f, 0.15228567f, 0.00164541f, 
    0.06384341f, 0.06023167f, -0.12489446f, -0.00308369f, -0.16763961f, 0.08251869f, 0.30925417f, 0.07064243f, 
    0.33775848f, 0.17214754f, 0.13736498f, 0.02770924f, -0.13182315f, -0.07103702f, 0.05665685f, 0.09832297f, 
    -0.21267650f, 0.25808588f, 0.27855775f, 0.24593830f, 0.24762484f, -0.21269591f, 0.14020099f, -0.06718122f, 
    -0.11145163f, -0.07010394f, 0.16450964f, -0.23866054f, -0.01824630f, 0.09073127f, 0.08994113f, -0.01352002f, 
    -0.11134882f, 0.06845975f, 0.12295674f, -0.05941238f, 0.08987345f, -0.18651608f, 0.12335599f, -0.05173292f, 
    -0.05593725f, -0.22153276f, -0.17588380f, 0.00265046f, 0.27168381f, 0.16954720f, 0.04755856f, 0.05051878f, 
    0.16446210f, 0.06578639f, 0.12688135f, 0.06363455f, -0.06081315f, 0.22442195f, -0.17018250f, -0.39602426f, 
    0.11824244f, -0.11871754f, 0.22323836f, -0.09368925f, 0.20260963f, -0.17343266f, 0.13856195f, -0.24351835f, 
    -0.31879339f, -0.07248300f, 0.24228747f, -0.16278693f, 0.13547555f, -0.07582677f, 0.26910445f, -0.00099819f, 
    -0.08689796f, -0.00861178f, 0.04629925f, -0.04102806f, -0.03602505f, 0.22908092f, 0.10223572f, 0.17907737f, 
    -0.03111304f, 0.04600539f, -0.04831794f, 0.04382996f, -0.01109563f, 0.04035033f, -0.04064680f, -0.03685466f, 
    0.05272438f, -0.06129915f, -0.05598017f, -0.06173574f, -0.01464833f, -0.00363505f, 0.04419747f, 0.04644932f, 
    0.01160871f, 0.03539631f, -0.04263580f, 0.02848776f, 0.02426947f, 0.02277938f, -0.03176735f, 0.04327756f, 
    -0.03911299f, 0.00855199f, 0.00729249f, 0.04044535f, 0.03659197f, -0.02844349f, 0.01223282f, 0.02670652f, 
    0.00699984f, -0.05128252f, 0.00409493f, 0.00339304f, -0.00084218f, -0.03206927f, 0.01055380f, 0.01166742f, 
    -0.04990491f, -0.00227956f, 0.04287270f, 0.04435391f, 0.02216025f, 0.01458261f, -0.01768957f, 0.00554317f, 
    -0.02962335f, 0.01028003f, -0.06178866f, -0.04788124f, 0.02679425f, 0.04742355f, 0.04330214f, -0.02360982f, 
    0.01001275f, 0.03763184f, -0.04697167f, -0.03136488f, -0.03485246f, -0.02209213f, -0.00293641f, 0.02400452f, 
    -0.02428854f, -0.02769950f, -0.00060850f, 0.04031559f, -0.03831373f, -0.00612227f, -0.00881632f, -0.02048538f, 
    -0.00742643f, 0.02086369f, 0.03215832f, -0.05795509f, -0.01412357f, 0.02535868f, 0.02608691f, 0.02360587f, 
    -0.03160851f, -0.04068261f, 0.00614929f, -0.04834316f, -0.03142135f, 0.00915687f, 0.02977609f, 0.03324470f, 
    -0.01220534f, 0.01640636f, -0.02081627f, 0.02596922f, 0.03874952f, -0.00409196f, -0.02492718f, -0.01559322f, 
    0.01058589f, -0.05959941f, -0.06019122f, 0.01269510f, 0.05222331f, 0.02676617f, 0.05222877f, -0.03373545f, 
    0.01701414f, -0.04745475f, 0.02225873f, -0.05985723f, -0.03869151f, -0.01103078f, 0.02815942f, -0.05610080f, 
    -0.05496285f, 0.01037270f, -0.04836360f, -0.03330531f, -0.00714645f, -0.02577615f, -0.02529130f, -0.03021923f, 
    -0.04002549f, -0.01978542f, -0.05615533f, 0.03128827f, -0.02309773f, -0.03660690f, -0.01533320f, -0.02799959f, 
    0.03463269f, 0.05034874f, -0.00756431f, -0.04262727f, -0.01583094f, -0.06072630f, 0.04103733f, 0.02796337f, 
    -0.04554353f, 0.01320748f, -0.01053930f, -0.04617905f, 0.03753725f, -0.01415297f, -0.01195359f, 0.02866207f, 
    -0.05521889f, -0.05512593f, 0.01398280f, -0.00762075f, -0.02738335f, -0.03563241f, -0.01873966f, 0.02819701f, 
    -0.00093127f, -0.06170949f, 0.00822587f, -0.03092167f, 0.05305241f, 0.03775095f, -0.05015448f, 0.00161660f, 
    0.04758585f, -0.06403834f, -0.00837422f, 0.01247778f, -0.03929622f, -0.02705698f, 0.04619794f, -0.03472630f, 
    -0.04426963f, 0.02833376f, -0.02088955f, 0.01498563f, 0.02888110f, -0.05793201f, 0.03371951f, 0.02348664f, 
    -0.03908109f, -0.05296592f, -0.00010161f, 0.00094215f, -0.01149537f, -0.03853975f, -0.06060748f, -0.02019169f, 
    -0.01539793f, 0.03938933f, 0.02712481f, 0.02568839f, 0.03102248f, -0.02758879f, 0.05024987f, 0.02677539f, 
    0.05331877f, -0.01350027f, 0.00468595f, -0.00573090f, -0.04102063f, 0.04190877f, 0.05289261f, -0.00704632f, 
    0.00152758f, -0.06244552f, -0.05435046f, -0.02276023f, 0.01905762f, 0.02410508f, -0.04333981f, -0.04886447f, 
    -0.04252464f, -0.02430521f, -0.04835348f, 0.01681660f, 0.02976453f, -0.00376919f, 0.00546228f, 0.01755512f, 
    -0.02279687f, -0.04550995f, -0.06011015f, -0.05613659f, -0.01189380f, 0.04123619f, -0.04763543f, -0.00466139f, 
    -0.05998483f, -0.03173035f, -0.02481417f, -0.02488315f, -0.05714908f, -0.03044163f, 0.04480569f, -0.05248691f, 
    -0.00693822f, -0.04983397f, -0.02881985f, -0.02026812f, -0.02582660f, 0.03443537f, -0.05735580f, -0.03376257f, 
    0.04048530f, 0.02168735f, -0.01626738f, -0.01978509f, -0.03900964f, -0.02920488f, 0.04393616f, 0.03822276f, 
    -0.04438092f, 0.03087737f, 0.00762058f, -0.01131538f, 0.03368440f, -0.03516331f, -0.02986456f, 0.01364524f, 
    -0.03071743f, 0.02648266f, 0.04738643f, -0.05031020f, -0.01155920f, -0.05525713f, -0.05431597f, -0.06038311f, 
    0.01374242f, -0.05081531f, -0.00623390f, 0.01452532f, -0.03281017f, -0.03185403f, 0.01724336f, -0.06040493f, 
    -0.05045693f, 0.04862035f, 0.02571932f, 0.04039859f, -0.04837782f, -0.03819465f, -0.04066002f, -0.05884121f, 
    -0.03708319f, 0.04817831f, -0.06406032f, -0.04039365f, -0.00827955f, 0.02756919f, 0.04532197f, -0.06343026f, 
    0.13344355f, -0.24568315f, 0.11439306f, 0.01007082f, 0.10117923f, -0.00437700f, 0.00630370f, 0.01663272f, 
    -0.00397654f, 0.08767520f, 0.01740451f, 0.04324188f, -0.11199523f, 0.02479408f, -0.29008830f, 0.16576551f, 
    0.05783734f, -0.01520442f, -0.62056518f, -0.12438796f, 0.03856020f, 0.05091722f, 0.18116936f, 0.00335068f, 
    0.00005317f, -0.01887899f, -0.06795064f, 0.03528975f, -0.02441482f, -0.47311684f, 0.08244784f, 0.03757246f, 
    0.13838123f, -0.10436895f, 0.00098710f, 0.18205170f, -0.45683533f, 0.07005110f, -0.00013822f, -0.25454253f, 
    0.24437687f, 0.07316657f, -0.06201690f, 0.11639355f, 0.08443676f, 0.05543416f, 0.09232894f, 0.04401023f, 
    -0.16236421f, -0.01781650f, 0.09127975f, 0.08812644f, 0.23679945f, 0.18661059f, -0.50786853f, -0.42880401f, 
    0.18679866f, 0.12482053f, 0.04055375f, -0.06934229f, 0.04034655f, -0.24662851f, -0.25811782f, 0.02428345f, 
    0.21394585f, -0.50069416f, -0.04418170f, -0.21027628f, -0.44913074f, 0.00462974f, 0.01927415f, 0.14384632f, 
    -0.68787944f, 0.08703014f, -0.27416188f, -0.17147696f, 0.04999669f, 0.28369462f, -0.18098938f, -0.30405596f, 
    0.01581957f, -0.60372531f, 0.05747174f, 0.14275849f, 0.04052334f, 0.11497025f, 0.06330549f, 0.10796104f, 
    0.02964332f, -0.05525380f, 0.12869336f, 0.18014841f, 0.11026555f, -0.35757041f, -0.19373849f, -0.12483853f, 
    0.01902156f, 0.14684755f, 0.13336064f, 0.18944883f, -0.08161270f, 0.04366226f, -0.23285687f, -0.20108084f, 
    -0.03533393f, 0.20055069f, -0.06508660f, 0.16964556f, 0.27438286f, -0.25021082f, -0.25119376f, 0.23535055f, 
    0.17106427f, 0.03049705f, 0.05126566f, 0.10824572f, -0.12843278f, -0.10827199f, -0.44147062f, -0.30580041f, 
    0.30344743f, -0.11428057f, 0.02640020f, -0.15071371f, -0.03241480f, 0.10989075f, 0.07232239f, -0.29301545f, 
    0.10690463f, 0.20380595f, 0.07938121f, 0.42168331f, 0.03225413f, 0.18833265f, 0.19872934f, -0.04210163f, 
    0.09923157f, 0.43177372f, 0.23428653f, 0.05224972f, -0.22225727f, 0.33828327f, 0.02661471f, 0.03303650f, 
    0.11081088f, 0.01740400f, 0.17262541f, -0.02510245f, -0.02060238f, 0.03590740f, 0.28981683f, -0.04089116f, 
    0.10740644f, -0.15930837f, 0.53372175f, 0.38339400f, -0.10452333f, -0.06341513f, 0.01977033f, 0.01109351f, 
    0.13535134f, 0.05778686f, -0.30384371f, 0.01546849f, -0.17041816f, -0.09926353f, 0.18371621f, 0.07504477f, 
    -0.32461044f, -0.13329184f, -0.06548634f, 0.31301200f, -0.07280067f, -0.06917755f, -0.22425261f, -0.06377245f, 
    -0.11762232f, 0.03489378f, 0.11802966f, 0.00898979f, 0.31098011f, 0.21785729f, -0.42692524f, 0.08213387f, 
    -0.23120359f, 0.05321553f, -0.07626844f, -0.06889234f, 0.11071926f, -0.05981487f, -0.07975553f, 0.00235156f, 
    -0.13143496f, -0.02646396f, 0.08926284f, -0.00888223f, 0.14796576f, 0.12587464f, -0.05778857f, -0.32087779f, 
    -0.07664664f, 0.20063150f, 0.09887433f, -0.02444558f, 0.22859821f, 0.01792460f, -0.10795105f, 0.30219021f, 
    -0.22487870f, -0.20171483f, 0.03639403f, 0.01349356f, 0.12532048f, -0.03895362f, 0.11732969f, 0.20655918f, 
    0.17642677f, -0.17020562f, -0.26426110f, 0.13893418f, 0.08934820f, -0.06784216f, -0.14300506f, 0.04834487f, 
    -0.09675767f, -0.61807239f, -0.05928518f, 0.09829408f, 0.30252650f, 0.16591755f, 0.20604908f, 0.00264983f, 
    -0.06865401f, -0.06595883f, -0.09940168f, -0.00186543f, -0.19154158f, -0.24616604f, -0.02929685f, 0.03619004f, 
    -0.23280150f, -0.32608861f, 0.12381136f, -0.17429547f, -0.17907672f, 0.25357240f, 0.01089618f, 0.15939243f, 
    0.20474450f, 0.05783334f, 0.08399040f, 0.12676311f, 0.26274008f, 0.12890629f, -0.21646158f, 0.16725959f, 
    0.08555367f, -0.13327233f, 0.15112920f, -0.13455038f, -0.09022313f, -0.13879836f, 0.23244247f, -0.10542477f, 
    -0.10396057f, -0.16035785f, 0.09386194f, -0.01175783f, 0.07795994f, 0.11727019f, 0.06308798f, 0.06105007f, 
    0.12960088f, 0.05432772f, -0.03446111f, -0.04910863f, 0.01182455f, 0.21419376f, 0.07921644f, 0.18770674f, 
    -0.38295430f, -0.21805906f, 0.08435937f, -0.09595837f, -0.01650646f, 0.19247800f, -0.15860493f, 0.05399963f, 
    0.00133805f, -0.00023881f, -0.03419599f, -0.03372394f, -0.02747585f, 0.02728881f, -0.01019850f, 0.03946488f, 
    -0.01922279f, -0.02470357f, 0.02036186f, -0.06345532f, 0.00080255f, -0.01199744f, 0.03405750f, 0.03779111f, 
    0.00697231f, -0.00491541f, 0.04146564f, 0.01787784f, 0.01392804f, -0.06427088f, -0.03860439f, 0.01935316f, 
    -0.05076163f, 0.01723315f, 0.04972852f, -0.03126096f, -0.03592315f, 0.00903372f, -0.01351689f, 0.02523698f, 
    0.00462539f, 0.01923312f, -0.04047263f, 0.03842290f, -0.01612199f, -0.02689227f, -0.01969789f, -0.01338453f, 
    -0.06928771f, -0.05399686f, -0.04622982f, -0.00141498f, 0.03849038f, 0.00204578f, 0.02863588f, -0.01992123f, 
    0.04153858f, 0.00185824f, -0.00598093f, -0.05739643f, 0.04657548f, -0.05888524f, -0.00238243f, 0.02343860f, 
    0.00639907f, -0.02585717f, -0.04563460f, 0.02215096f, -0.06210244f, -0.01654771f, -0.01092264f, 0.04019251f, 
    0.00075093f, 0.00059581f, -0.01274888f, -0.05980994f, -0.06292255f, -0.04953320f, 0.02975266f, -0.03526152f, 
    -0.00036954f, 0.04416092f, 0.02552803f, 0.00466650f, -0.04051157f, 0.02210853f, -0.04929290f, -0.01211701f, 
    0.00229890f, 0.03838993f, -0.00452392f, -0.03488676f, -0.00934130f, 0.01898030f, -0.02518028f, -0.00605964f, 
    0.02795515f, 0.05068958f, 0.03501892f, 0.02865963f, -0.01432204f, -0.04404017f, 0.02977425f, -0.04422327f, 
    -0.02836874f, -0.05732989f, -0.03249800f, -0.04886264f, -0.05265469f, 0.00941416f, 0.04682253f, 0.04773502f, 
    0.00711598f, 0.04542666f, -0.02875185f, -0.02290800f, -0.05920075f, -0.00146190f, -0.05440453f, -0.04234664f, 
    0.04180093f, -0.03230444f, -0.00829053f, -0.06141553f, -0.01282845f, 0.03310438f, -0.01457742f, 0.00974622f, 
    -0.01487166f, -0.03466495f, -0.01768979f, -0.00877762f, 0.01592999f, -0.04647775f, 0.01099909f, -0.04865953f, 
    0.03593609f, -0.01870209f, 0.01739739f, 0.04219153f, -0.03671973f, -0.02258436f, -0.03814736f, 0.04265704f, 
    -0.00190931f, 0.01583276f, 0.04063065f, -0.02971640f, -0.03396317f, -0.01988713f, 0.04491264f, -0.04221238f, 
    0.03390201f, -0.05652677f, -0.01434769f, -0.00117413f, -0.00700783f, -0.05865880f, 0.02420525f, 0.00843092f, 
    -0.01960318f, 0.02650182f, 0.00903486f, -0.01298052f, -0.03318328f, 0.05152912f, -0.05240756f, -0.00140493f, 
    0.02970161f, -0.02166341f, 0.02098139f, -0.01261374f, -0.03752188f, -0.05371600f, -0.02397397f, -0.01597686f, 
    0.03897551f, 0.00961111f, 0.01136545f, 0.04577298f, 0.02233482f, 0.03756980f, -0.00809185f, 0.00824254f, 
    0.01713458f, 0.04424559f, -0.04938678f, 0.00237223f, -0.05204799f, -0.01057084f, -0.04435121f, 0.04556706f, 
    0.03404552f, -0.04392943f, 0.00798779f, -0.05997325f, 0.03475791f, 0.00403663f, 0.04792576f, -0.05124111f, 
    -0.04685583f, -0.01531757f, -0.05522566f, -0.00352825f, 0.03259443f, 0.03062635f, -0.02266190f, -0.04558634f, 
    -0.06676253f, -0.03863867f, -0.00137185f, 0.05408353f, -0.00433310f, -0.04296668f, 0.02009745f, 0.02474103f, 
    0.03662528f, 0.00511752f, 0.03023716f, 0.03201676f, -0.01266631f, 0.00583757f, 0.03080019f, -0.00299504f, 
    -0.03648959f, 0.02085389f, 0.02874654f, 0.05547377f, -0.06030912f, -0.02469684f, 0.02588346f, 0.05018731f, 
    0.04508111f, 0.00259990f, 0.04480677f, -0.02874361f, -0.05660979f, 0.04384856f, -0.03662238f, 0.03919261f, 
    -0.05007680f, 0.04320677f, 0.03371146f, -0.01619422f, -0.00112925f, 0.03409655f, -0.00979851f, 0.02558367f, 
    -0.03754106f, 0.02995577f, 0.00793365f, -0.05232294f, 0.01004086f, -0.00564116f, -0.00002556f, -0.04727399f, 
    -0.01209905f, -0.02606915f, 0.00282574f, -0.03067885f, 0.01135964f, -0.00761261f, -0.00710103f, -0.00085122f, 
    -0.00957671f, -0.01959130f, -0.00733638f, 0.05044862f, -0.05741646f, -0.01447866f, -0.03873171f, -0.04152215f, 
    0.04321336f, -0.00763408f, -0.00983465f, 0.00555721f, 0.02034014f, 0.01307925f, -0.03029843f, -0.03450115f, 
    -0.00821382f, -0.01361376f, -0.05622707f, 0.00380933f, -0.00209976f, 0.03694919f, -0.04331107f, 0.04531536f, 
    -0.01645582f, 0.02758261f, 0.00809515f, 0.03418875f, -0.05779565f, 0.00571812f, -0.03530139f, -0.03994146f, 
    -0.05556189f, -0.00735087f, -0.06896036f, 0.02618546f, 0.03613625f, -0.05690316f, 0.05325510f, -0.00714633f, 
    0.02403979f, -0.04508461f, -0.07653896f, -0.06843591f, -0.02512786f, 0.03298192f, -0.05081215f, -0.02215724f, 
    -0.05006299f, -0.05537380f, -0.05040939f, -0.04380951f, 0.01819983f, -0.07450826f, 0.03942162f, -0.02998514f, 
    0.00484272f, 0.02724810f, -0.00221525f, 0.03718018f, 0.00029895f, -0.03873724f, 0.01356968f, -0.03095232f, 
    0.04052066f, 0.03851316f, 0.01319492f, 0.02983945f, -0.03447394f, 0.02519547f, -0.03375767f, -0.01419423f, 
    -0.00510869f, 0.03306578f, -0.01531082f, -0.00214173f, 0.02339470f, -0.05306303f, 0.01006239f, 0.00200619f, 
    -0.03473045f, 0.00029505f, -0.00767614f, -0.03374949f, -0.01101943f, -0.04499803f, 0.05339817f, -0.06182619f, 
    -0.01276702f, -0.00532886f, 0.01687077f, 0.01569109f, 0.05082881f, -0.03503530f, -0.02155139f, -0.00035653f, 
    -0.02444865f, -0.05133132f, -0.06186066f, -0.07396700f, -0.03855631f, 0.04702990f, -0.01597755f, -0.00401117f, 
    -0.02156921f, -0.01276615f, -0.05397457f, -0.04672738f, 0.03297501f, -0.02188220f, 0.02465293f, -0.02336006f, 
    0.04326917f, 0.00465513f, -0.02812696f, -0.04651389f, -0.00981097f, -0.01885155f, 0.00320682f, 0.01629709f, 
    -0.04997238f, 0.03617042f, -0.00381173f, -0.04828198f, -0.04655566f, -0.01622977f, 0.01172382f, -0.02589023f, 
    0.05815373f, 0.02114851f, -0.05632466f, -0.07477923f, 0.01482850f, 0.03594429f, 0.03413434f, -0.02399732f, 
    0.02045512f, -0.00049664f, -0.00894866f, 0.03261881f, -0.04067586f, -0.03927187f, -0.02474405f, -0.01519203f, 
    -0.03589351f, 0.02909708f, -0.06390711f, 0.01246589f, 0.00499274f, -0.04860474f, -0.06106917f, -0.07620152f, 
    -0.05630997f, -0.07336635f, -0.02257015f, -0.01594636f, -0.05690592f, 0.04182257f, 0.01787697f, 0.03495187f, 
    0.00918764f, -0.02374100f, 0.04186194f, 0.00293212f, 0.01581225f, -0.04698636f, 0.03192088f, -0.00129668f, 
    0.02975675f, -0.07208856f, -0.03399184f, -0.00706871f, -0.05915640f, -0.00004443f, 0.04617826f, -0.00743659f, 
    0.01287936f, -0.07047979f, 0.01270361f, 0.01304174f, -0.01976877f, -0.01710787f, 0.03166692f, 0.04155816f, 
    -0.01633935f, -0.00984108f, -0.07269065f, -0.05380301f, -0.00103971f, -0.04990229f, 0.02212314f, -0.03033816f, 
    -0.05927663f, 0.01272914f, -0.04528737f, -0.01972685f, -0.05724293f, -0.05719979f, 0.03748839f, 0.04098069f, 
    -0.02928727f, -0.00800476f, -0.00792708f, -0.07602133f, -0.09009152f, 0.02334798f, -0.07023983f, -0.01740430f, 
    0.00950774f, 0.00807110f, -0.00885365f, -0.05309151f, -0.05215025f, -0.02821695f, -0.02472959f, 0.01449522f, 
    -0.02837643f, -0.00751563f, 0.02998016f, 0.00260189f, -0.05893868f, 0.00187875f, -0.09034044f, -0.06430193f, 
    -0.05500782f, -0.01487434f, 0.00550903f, -0.07516141f, 0.01589224f, -0.03098952f, -0.04780328f, 0.04038272f, 
    -0.02667951f, 0.03791558f, -0.00175487f, -0.07330073f, 0.02159450f, -0.03264685f, -0.01498593f, 0.02732988f, 
    0.03482001f, -0.01773620f, -0.00960634f, -0.07088278f, -0.01279795f, -0.04287742f, -0.02813738f, -0.04190866f, 
    -0.05401776f, -0.01544145f, -0.01752659f, 0.01798322f, 0.00346780f, -0.04656523f, -0.01384213f, -0.00008432f, 
    -0.00262047f, 0.03271483f, 0.01989257f, -0.02629138f, 0.02941242f, -0.01306172f, -0.06225742f, -0.06235837f, 
    -0.06255119f, -0.03034353f, 0.03515010f, 0.03386720f, -0.07988907f, -0.01724069f, 0.01344243f, -0.00078773f, 
    -0.07091530f, 0.00916691f, 0.04672313f, 0.02004786f, 0.02272441f, -0.01266836f, 0.02642833f, 0.01503710f, 
    -0.02145444f, -0.06590012f, -0.07245464f, 0.05163020f, -0.03531358f, 0.05964902f, -0.02687900f, -0.03328252f, 
    -0.07599596f, -0.07319786f, 0.02264893f, 0.01520333f, -0.06642279f, -0.05849607f, -0.02996588f, -0.03843487f, 
    -0.06989533f, 0.04401508f, -0.05334483f, -0.02463123f, 0.01081243f, -0.04705362f, -0.05120515f, -0.03895030f, 
    -0.05665402f, -0.03538039f, -0.06660794f, -0.05585916f, 0.03984396f, 0.00596645f, -0.06073811f, 0.01214588f, 
    0.01480850f, -0.01940231f, -0.02083163f, -0.07026456f, -0.00601453f, -0.00198319f, -0.03887623f, -0.04232370f, 
    -0.02834817f, -0.04598838f, -0.04239991f, 0.00249149f, 0.04580734f, -0.06036386f, -0.01546525f, -0.02025716f, 
    0.01009795f, -0.02359469f, -0.04473738f, 0.00368911f, -0.03305914f, -0.03554367f, -0.05222225f, 0.02227244f, 
    0.02227454f, -0.00835039f, 0.00490668f, -0.03245699f, -0.05533178f, -0.03237279f, -0.00496970f, -0.02204727f, 
    0.03375762f, -0.05789309f, -0.02614287f, 0.04621506f, 0.05181936f, -0.05289339f, -0.03122110f, -0.06167214f, 
    0.02553294f, -0.04809528f, 0.02228503f, 0.02893652f, -0.01034900f, 0.05183513f, -0.01940091f, 0.02193661f, 
    -0.00161196f, -0.00424437f, -0.00364313f, -0.03389818f, -0.03982293f, 0.02721588f, 0.02493882f, -0.00958970f, 
    -0.01067088f, -0.02445812f, 0.00286189f, -0.06074214f, -0.05235977f, -0.06071617f, -0.04130529f, 0.01621918f, 
    0.02255388f, -0.03130817f, 0.03740502f, 0.00125023f, 0.00257777f, 0.02594310f, 0.04777407f, -0.02824947f, 
    -0.05835052f, -0.02377154f, 0.01079658f, -0.01035409f, 0.00580215f, -0.05382630f, -0.00055053f, -0.04100861f, 
    -0.01088656f, 0.03130668f, 0.02947434f, -0.05839141f, 0.03012417f, -0.02329274f, -0.07345309f, -0.01325356f, 
    -0.01521276f, 0.04402818f, 0.04772934f, 0.03744469f, 0.00365569f, 0.02644520f, 0.01185126f, -0.05602029f, 
    -0.05749182f, -0.05233030f, -0.04374837f, -0.04171660f, 0.03450464f, -0.04350534f, -0.00873081f, -0.03534114f, 
    -0.05306146f, -0.00655698f, 0.03783069f, 0.04235225f, 0.05007020f, -0.05670993f, 0.03469758f, 0.04600400f, 
    0.03080679f, -0.02423603f, 0.03122062f, -0.06742017f, 0.01569020f, 0.03562223f, 0.03795283f, 0.01704575f, 
    0.01877839f, -0.04544704f, -0.02390763f, 0.01771858f, -0.03655666f, 0.01008257f, 0.04673816f, -0.05701079f, 
    0.00026374f, 0.03942890f, 0.05240645f, 0.04723898f, 0.04495952f, -0.04671070f, 0.01512447f, -0.03579993f, 
    0.01430904f, 0.00432754f, -0.00191512f, -0.05537285f, -0.02146191f, -0.01075410f, 0.00036519f, -0.05516310f, 
    -0.06067345f, 0.03258191f, -0.03743495f, -0.02510218f, 0.01366164f, -0.06601902f, -0.00570638f, -0.01739205f, 
    -0.05238616f, 0.01419813f, 0.03329784f, -0.04008667f, 0.00300011f, -0.05774980f, -0.00801622f, -0.05774307f, 
    -0.03320349f, 0.04516289f, -0.04718864f, -0.05056484f, 0.02753096f, -0.02358024f, -0.01504941f, 0.01068930f, 
    -0.06670449f, -0.02113447f, -0.00723335f, -0.05128929f, -0.00850542f, 0.03656988f, 0.02124195f, -0.01758210f, 
    -0.07276610f, 0.03417871f, -0.04849595f, 0.00153428f, 0.03751028f, -0.04763805f, -0.04887048f, -0.03995774f, 
    -0.01116473f, 0.02569520f, -0.02569696f, -0.05256204f, -0.02757922f, -0.06857501f, 0.00776014f, -0.07003481f, 
    -0.04045633f, -0.01827859f, -0.00792896f, -0.05063543f, 0.00713121f, -0.02150880f, 0.01943443f, -0.01098700f, 
    -0.04692727f, 0.02391052f, -0.02085904f, -0.06199012f, 0.01841180f, 0.01066580f, 0.01661565f, 0.01265346f, 
    -0.04086328f, 0.02876047f, -0.05069386f, 0.01584342f, -0.02960746f, -0.02355027f, -0.01951282f, 0.01249807f, 
    0.02922925f, -0.05921064f, -0.04130452f, 0.04135000f, 0.00823541f, 0.02454330f, 0.03545798f, 0.01635200f, 
    -0.03364177f, 0.02593403f, 0.00909252f, -0.04018332f, -0.01386251f, -0.05410576f, 0.04555411f, -0.00812019f, 
    -0.02146550f, -0.01821957f, -0.06097917f, -0.05911971f, -0.00995165f, 0.04249434f, -0.04953502f, -0.06007161f, 
    -0.03514680f, -0.03308418f, -0.04902770f, -0.00449617f, -0.03430057f, 0.00122735f, 0.03469094f, -0.05869117f, 
    -0.03258286f, -0.06824404f, -0.01360293f, 0.00714015f, 0.04666590f, -0.02995966f, -0.02401289f, -0.02922216f, 
    -0.05260260f, 0.00693741f, -0.01248535f, -0.04277637f, 0.01122664f, -0.04512702f, -0.01073350f, -0.07068932f, 
    0.03884396f, 0.01172689f, 0.02996312f, -0.02622873f, -0.05044037f, -0.00953098f, -0.03613410f, -0.01729839f, 
    0.01686951f, -0.05287920f, 0.01795922f, -0.02825264f, -0.07036100f, -0.02947908f, -0.03822067f, -0.05951122f, 
    -0.02161406f, -0.03855698f, -0.00624721f, -0.07116637f, -0.03827808f, -0.04225682f, -0.02141591f, -0.04928022f, 
    -0.02726833f, -0.03129742f, -0.02623516f, 0.02521857f, -0.06904472f, -0.06262412f, 0.03978963f, 0.00750234f, 
    -0.04199347f, 0.04337750f, 0.03357297f, 0.02782035f, 0.01243809f, -0.05431420f, -0.05055759f, 0.05024375f, 
    -0.01946020f, -0.04523084f, 0.03703427f, -0.05598035f, -0.05737397f, -0.05279369f, -0.03262332f, -0.02815451f, 
    0.03769254f, 0.02939991f, 0.02145838f, 0.00507457f, -0.05942142f, -0.02911526f, -0.00845116f, -0.04030735f, 
    -0.03657036f, -0.04266839f, -0.04163302f, -0.00740814f, 0.00014427f, 0.02603054f, 0.02025880f, 0.01116236f, 
    0.01358741f, 0.00061832f, 0.02018226f, -0.05156197f, 0.01010686f, -0.05986487f, -0.01641374f, -0.03719935f, 
    0.01728362f, -0.02073924f, 0.04060416f, 0.01784340f, 0.02822207f, -0.02054183f, 0.03842395f, -0.04589093f, 
    -0.04074409f, 0.04941967f, 0.02089705f, 0.02213580f, 0.02312566f, -0.03000043f, -0.04176136f, -0.05663729f, 
    0.05121921f, 0.05616582f, -0.02301309f, 0.01597619f, 0.00477694f, -0.03759660f, 0.02509610f, -0.02308135f, 
    0.03081233f, 0.00739284f, -0.02339530f, -0.05377844f, 0.00892047f, -0.01915684f, 0.02844528f, -0.01785173f, 
    0.00927867f, -0.04465095f, -0.03419712f, 0.00115868f, 0.00048420f, 0.04880279f, -0.03522951f, -0.00247625f, 
    0.02430789f, 0.03268378f, -0.03948351f, -0.01729675f, 0.01065041f, -0.03912875f, 0.01090405f, -0.05438682f, 
    0.04792991f, -0.06265768f, 0.00377772f, -0.03784209f, 0.04216842f, 0.03016037f, -0.03488773f, -0.04933826f, 
    0.04499291f, -0.02460220f, 0.01682921f, -0.01876025f, -0.01047861f, -0.02157781f, -0.02756009f, 0.00599486f, 
    -0.03488626f, 0.03267691f, -0.04728984f, 0.01487926f, -0.02336812f, 0.02038683f, 0.00055206f, 0.03274597f, 
    -0.06266034f, -0.04102330f, 0.01647574f, -0.00078967f, -0.02135449f, -0.01291236f, 0.01205777f, 0.01822102f, 
    -0.03132695f, -0.04646937f, -0.03158428f, -0.04672316f, 0.02205859f, 0.03614054f, 0.05162996f, -0.00499713f, 
    0.00925763f, -0.00776189f, -0.03066697f, -0.00942042f, -0.04228382f, -0.04879674f, -0.00040993f, 0.01137798f, 
    -0.05515750f, -0.06029966f, 0.02110000f, -0.05104810f, 0.02187807f, -0.01379850f, -0.05771558f, 0.02294523f, 
    0.05063919f, 0.02608777f, -0.02235808f, -0.02731017f, 0.00140735f, -0.04612344f, -0.02152638f, -0.05724367f, 
    -0.06124120f, -0.03105827f, -0.05327491f, -0.03271688f, -0.00644002f, 0.01883705f, 0.02676459f, -0.01610111f, 
    0.01736533f, -0.00706580f, -0.05114641f, -0.00299160f, 0.04831958f, 0.02988139f, 0.00187443f, 0.03622587f, 
    -0.01997922f, -0.05070683f, 0.02077955f, 0.02598560f, 0.03288532f, 0.04205894f, 0.04043559f, 0.01342583f, 
    0.03224691f, -0.00790202f, 0.01544113f, 0.03178795f, 0.00926928f, -0.04744380f, 0.01379806f, 0.00523632f, 
    -0.01687333f, 0.00707881f, 0.04107856f, 0.03604630f, -0.05499246f, 0.04014459f, -0.04059975f, 0.04890700f, 
    -0.04245641f, -0.05307851f, 0.04985920f, 0.03602425f, -0.06047038f, -0.05854701f, 0.02615552f, -0.01881172f, 
    -0.02842797f, -0.03785696f, -0.05534378f, -0.02736439f, 0.03904053f, 0.01590864f, 0.03471399f, -0.00005164f, 
    0.03045531f, 0.03187245f, -0.04648427f, -0.01906425f, 0.00940877f, -0.05441659f, 0.00522757f, -0.05373479f, 
    0.00917136f, -0.03249421f, 0.01067538f, 0.01053420f, 0.00027734f, -0.02031043f, -0.02809619f, 0.04629619f, 
    -0.05679236f, -0.04850305f, 0.02628047f, -0.02645444f, -0.01619244f, -0.00455955f, 0.03657801f, -0.03798177f, 
    -0.01886024f, 0.01994159f, -0.04742444f, -0.03871859f, -0.05205699f, 0.00878967f, 0.02113388f, -0.05559137f, 
    -0.03609999f, 0.00058485f, -0.02900026f, -0.04526060f, 0.03388099f, -0.05844351f, -0.03663389f, -0.01324319f, 
    -0.03038031f, 0.00134533f, -0.05915247f, -0.01568623f, -0.00357961f, 0.02692214f, -0.04732460f, -0.05471138f, 
    -0.02731813f, 0.03778384f, 0.02487611f, -0.00908904f, 0.04864337f, -0.00132168f, 0.00785320f, 0.03294086f, 
    -0.03697390f, 0.01472650f, -0.03525801f, -0.05163344f, 0.04619218f, -0.01603704f, -0.05605761f, -0.04206540f, 
    -0.00610240f, 0.00517626f, 0.04038316f, -0.04526933f, -0.03525570f, -0.06247050f, -0.03533565f, 0.00514700f, 
    0.01058399f, -0.01377695f, -0.05711166f, 0.05151462f, -0.00503589f, -0.02809170f, -0.01501131f, 0.01821806f, 
    0.00272277f, 0.27157310f, 0.00188983f, 0.09999076f, 0.27204692f, 0.06451900f, 0.11041423f, 0.05208969f, 
    -0.01621832f, -0.03647957f, 0.11716816f, 0.01452022f, -0.13541074f, -0.03597957f, -0.00003767f, 0.32436153f, 
    0.33068419f, -0.17242679f, -0.11594230f, -0.53697413f, 0.00749659f, -0.19865359f, 0.12301844f, -0.22955860f, 
    -0.05794993f, 0.18776457f, 0.03267859f, 0.08715567f, -0.06423042f, 0.02749230f, 0.19226608f, 0.18257365f, 
    0.00006230f, -0.13349006f, -0.09249596f, -0.06083725f, -0.09738192f, -0.14363210f, 0.03774267f, -0.19670305f, 
    0.03132206f, -0.20305035f, 0.08146148f, 0.13471927f, 0.30451977f, -0.27370474f, 0.17509426f, 0.34492183f, 
    -0.01794483f, 0.06127613f, -0.07373258f, 0.16935067f, 0.08802021f, -0.04363758f, -0.46980071f, -0.30000618f, 
    0.05576079f, -0.00508299f, 0.01196633f, -0.00078794f, 0.14011204f, -0.20910127f, -0.20964925f, -0.22084768f, 
    -0.05636584f, 0.06925304f, -0.05568958f, 0.16410722f, 0.00491241f, -0.06295124f, 0.05339196f, 0.02225791f, 
    0.09796919f, -0.26475659f, 0.12658961f, -0.06736455f, -0.11689144f, -0.27938291f, -0.04906566f, -0.01429923f, 
    -0.04391711f, -0.40158263f, -0.40950513f, 0.09228115f, 0.03109146f, 0.00083543f, -0.08193464f, -0.13107491f, 
    0.15999739f, -0.00234237f, 0.06292401f, 0.23331800f, 0.38798794f, -0.17484845f, -0.09466196f, -0.07138333f, 
    -0.16011940f, 0.11366464f, 0.01867928f, 0.17663386f, 0.21744975f, 0.21762012f, 0.16657950f, 0.14505275f, 
    0.10339938f, 0.03274573f, -0.19740568f, -0.13891393f, 0.00863086f, 0.22262385f, -0.26507610f, 0.10958255f, 
    0.04482445f, -0.00181359f, 0.25761947f, -0.10104456f, 0.06959844f, 0.31447166f, -0.00543968f, -0.03999634f, 
    -0.04060300f, 0.15612945f, 0.00761560f, 0.05400153f, 0.00664471f, 0.15879768f, 0.15893044f, 0.19567478f, 
    -0.00644151f, -0.45619872f, -0.04311122f, -0.09650687f, -0.06850497f, 0.06951871f, 0.24569675f, 0.54668814f, 
    0.00886012f, -0.14971718f, -0.07609807f, 0.22257721f, -0.08087883f, -0.02726812f, -0.03871329f, -0.17693295f, 
    0.00668935f, 0.24891242f, 0.19727132f, -0.25358406f, 0.07172857f, -0.10552010f, 0.30530947f, -0.16578320f, 
    0.09694482f, -0.50475746f, 0.03847001f, 0.59496123f, 0.04655525f, 0.24757960f, 0.04458883f, 0.12215751f, 
    -0.08379945f, -0.20049556f, -0.21226542f, 0.06537932f, -0.19860289f, -0.02011592f, 0.02150243f, -0.08773719f, 
    0.11783987f, -0.05003112f, -0.28351045f, -0.17476664f, 0.16785374f, 0.01157110f, 0.08999509f, 0.03576755f, 
    0.03807104f, 0.07291816f, 0.09712104f, -0.01910860f, 0.43710428f, 0.27507314f, -0.36807051f, 0.14188287f, 
    0.23831674f, 0.11524140f, 0.21199530f, -0.18383673f, -0.03647335f, 0.01805183f, -0.09838513f, 0.03161184f, 
    -0.08472402f, 0.17996521f, -0.05592506f, 0.00339387f, -0.11352851f, -0.10435049f, -0.27041331f, -0.22583935f, 
    -0.21618025f, 0.37162963f, -0.06346599f, -0.21479124f, 0.19156215f, -0.07588552f, 0.11904614f, -0.48372242f, 
    -0.14536858f, -0.32812938f, 0.18428992f, 0.11651964f, -0.13762257f, 0.13665642f, 0.03265996f, 0.03063444f, 
    0.07328011f, 0.07514729f, -0.50630456f, 0.28727412f, 0.04450288f, 0.09194326f, -0.15972203f, 0.07951450f, 
    -0.13618253f, -0.05216048f, -0.07154737f, -0.23167095f, 0.04675735f, 0.01889975f, -0.07942607f, 0.04878340f, 
    0.06975280f, -0.09194633f, 0.15853460f, 0.20308562f, 0.35130370f, -0.39002496f, -0.20902044f, 0.04281507f, 
    -0.53672111f, 0.02622133f, 0.21273696f, -0.54966348f, -0.18507174f, 0.19528221f, 0.13292277f, 0.17447406f, 
    -0.08204202f, 0.15730208f, 0.13344969f, 0.11262210f, 0.30132779f, 0.39019495f, -0.45628089f, 0.16136910f, 
    0.06029623f, 0.00642651f, 0.22175172f, -0.09001117f, -0.00545258f, 0.05743052f, 0.00433575f, 0.10699715f, 
    -0.07841851f, -0.13887726f, -0.09143603f, 0.10650082f, 0.15634219f, 0.00432820f, 0.14649178f, 0.02330628f, 
    0.29394618f, 0.39338017f, -0.16839179f, -0.03142949f, 0.12954889f, 0.19127099f, 0.06240950f, -0.13784778f, 
    -0.09920993f, -0.19510984f, 0.10662494f, 0.27387059f, -0.14722647f, 0.26240611f, -0.16268417f, -0.07984524f, 
    0.07702434f, -0.33727163f, 0.04006988f, 0.02617230f, 0.09878607f, -0.04216460f, -0.04780663f, 0.01984296f, 
    0.05065097f, -0.03901709f, -0.05477653f, 0.02421125f, -0.02189093f, 0.04884130f, 0.08771767f, 0.09923571f, 
    -0.03354055f, -0.09561257f, 0.02386770f, 0.10311273f, 0.11783959f, -0.01603380f, -0.15209049f, -0.07916945f, 
    -0.10805402f, -0.06974151f, -0.02581057f, -0.11561812f, 0.00027554f, 0.01430550f, -0.07992899f, -0.01893485f, 
    0.11417141f, 0.11415461f, -0.09546425f, -0.04294364f, -0.17227605f, 0.06452245f, -0.41997764f, 0.06807067f, 
    0.00012413f, -0.06754486f, -0.08966844f, 0.13448122f, -0.22919017f, -0.33217630f, 0.10468380f, -0.25162047f, 
    0.10007170f, -0.00075249f, -0.12532966f, -0.06033918f, 0.19957693f, -0.04344781f, 0.06913321f, 0.01994589f, 
    0.15910266f, 0.05921286f, 0.09925905f, 0.21416834f, 0.10778592f, -0.22202873f, 0.15109222f, -0.29460075f, 
    -0.35276163f, -0.11368870f, -0.00951032f, 0.08617780f, -0.13742648f, 0.12995325f, -0.06183757f, 0.13924575f, 
    -0.46994635f, -0.08938786f, -0.23817314f, -0.06603306f, 0.01145035f, 0.05122145f, -0.03666725f, 0.24792807f, 
    -0.06471424f, -0.00361849f, -0.19070365f, 0.00533976f, 0.10677154f, 0.18562983f, -0.05585859f, 0.05304673f, 
    0.00531605f, -0.05709463f, -0.12625571f, 0.00719449f, 0.01911510f, 0.17579947f, -0.03187402f, 0.01702191f, 
    0.11799081f, 0.05872430f, -0.08337021f, 0.35327920f, 0.04541359f, 0.28886610f, 0.15178590f, -0.01881423f, 
    -0.12542237f, 0.01092692f, 0.08144223f, 0.02905341f, -0.16428174f, 0.13867624f, -0.07589916f, -0.27223402f, 
    -0.07837722f, -0.04786767f, -0.08043804f, -0.10728190f, 0.22230491f, -0.36600927f, -0.38659099f, -0.41733423f, 
    0.12176193f, -0.10316104f, -0.04733911f, -0.04448241f, 0.00069024f, -0.15153696f, -0.26919568f, -0.46386957f, 
    -0.44989708f, 0.16658537f, 0.08803888f, 0.05263136f, -0.24090841f, -0.04334682f, -0.05875044f, -0.07241473f, 
    0.16760135f, 0.05386565f, -0.04861424f, -0.13261376f, -0.08053834f, 0.01779493f, -0.10209606f, -0.00028610f, 
    -0.03655552f, 0.10311975f, -0.14275448f, 0.10567991f, -0.12204669f, -0.10908234f, 0.11878182f, 0.00473779f, 
    0.05489241f, 0.16591769f, 0.30284810f, 0.14248218f, 0.07844974f, 0.02540960f, -0.15162070f, 0.19370824f, 
    0.08953560f, 0.19381168f, 0.41023159f, 0.21943894f, 0.05373937f, -0.07157615f, 0.06323263f, 0.03420468f, 
    -0.31046852f, 0.01263325f, 0.00865663f, 0.26520011f, 0.02123874f, -0.12784342f, -0.07141347f, 0.10596662f, 
    -0.14680606f, 0.12241712f, -0.07059868f, 0.02077735f, 0.27640998f, 0.03426682f, 0.47931930f, 0.03586461f, 
    0.00260667f, 0.08862872f, -0.05580235f, -0.12778623f, -0.00430960f, 0.24278636f, 0.26690018f, -0.09599274f, 
    -0.08424030f, -0.12506033f, -0.01739351f, -0.10614977f, -0.17254326f, 0.01300343f, 0.22404507f, 0.20233870f, 
    -0.08328958f, -0.08239418f, 0.21484402f, 0.23551244f, 0.26714340f, -0.07653236f, 0.01640647f, 0.33698583f, 
    0.06875082f, 0.32759315f, 0.04166048f, 0.01946621f, -0.04712606f, -0.13122185f, 0.14138028f, 0.03348475f, 
    0.29610452f, 0.15055965f, 0.51275820f, 0.08071328f, -0.11754394f, 0.04061454f, -0.15942605f, -0.03309159f, 
    -0.05906930f, -0.14272164f, -0.07722562f, -0.12331034f, -0.13240872f, 0.17257118f, -0.00682503f, -0.14613916f, 
    -0.00423469f, -0.11953634f, -0.12069894f, 0.17299584f, -0.33215314f, -0.12011367f, -0.04446445f, -0.08798598f, 
    -0.07323506f, 0.08052918f, -0.13990799f, 0.31968290f, 0.34372255f, 0.47996998f, 0.00273418f, -0.05692141f, 
    0.19010302f, 0.07097248f, -0.02449083f, 0.03154105f, 0.42511290f, 0.14686179f, 0.51078743f, 0.15869187f, 
    -0.04022284f, -0.16574758f, 0.07296095f, 0.07003704f, 0.08890892f, -0.48884231f, 0.16323261f, 0.19138055f, 
    0.16120027f, 0.10070758f, 0.04549094f, 0.23522641f, 0.05292308f, 0.07715849f, -0.23376405f, 0.03169041f, 
    -0.11673807f, -0.20995453f, -0.18676126f, 0.07061192f, 0.04678931f, 0.06397187f, 0.21282485f, 0.27336374f, 
    -0.13183868f, 0.19444343f, 0.01296880f, 0.17194857f, -0.00349706f, 0.07321839f, -0.08601158f, -0.10022383f, 
    -0.02983482f, 0.04158912f, 0.01335258f, 0.01970136f, -0.05099462f, 0.02357162f, 0.00303966f, 0.01479856f, 
    0.02838517f, -0.02476783f, -0.06418752f, -0.00821206f, -0.01384628f, -0.00003746f, -0.04480499f, -0.06360186f, 
    -0.05647399f, -0.05466028f, -0.02871933f, -0.03383478f, 0.02588272f, 0.00233989f, 0.02975190f, 0.01875945f, 
    0.00238400f, -0.03540169f, 0.03816598f, 0.01020962f, -0.00754830f, -0.01969800f, -0.04754054f, -0.03019120f, 
    0.02270908f, -0.00934056f, 0.01748083f, 0.00320785f, 0.00042416f, -0.01427861f, 0.03413324f, -0.04369088f, 
    -0.01074627f, 0.04897010f, -0.05325710f, 0.04087104f, -0.06411234f, -0.01501832f, -0.06465039f, -0.01899139f, 
    -0.02277265f, 0.03759778f, 0.03655819f, -0.01830860f, -0.01064148f, 0.02797092f, -0.01219890f, -0.05355006f, 
    -0.03618693f, 0.01579451f, -0.02730206f, 0.04738792f, 0.03791824f, -0.02387280f, 0.01310806f, 0.03163712f, 
    -0.03831972f, -0.06549253f, -0.05870087f, -0.00845000f, -0.05338180f, -0.02395311f, 0.02652714f, -0.01201958f, 
    0.00746133f, 0.00849630f, -0.03459667f, -0.05306747f, 0.00100719f, -0.01845411f, -0.03884145f, -0.06266815f, 
    -0.03548256f, 0.02331994f, -0.03004446f, -0.04991227f, 0.03283824f, -0.02482483f, 0.03574499f, -0.01458803f, 
    0.01658275f, 0.03760786f, -0.06634042f, -0.05927269f, 0.04629581f, 0.05067965f, -0.07073986f, -0.04194322f, 
    -0.02974686f, -0.03952255f, -0.02310944f, -0.01452682f, -0.04864781f, -0.03297555f, -0.06619367f, -0.05224567f, 
    -0.06597660f, 0.01883636f, -0.04184291f, -0.03246834f, -0.00711809f, 0.02289734f, -0.00919105f, 0.02947570f, 
    0.04412087f, -0.00310510f, -0.02007797f, -0.01631870f, -0.01264530f, 0.00815489f, -0.03852171f, 0.00091722f, 
    -0.05848670f, -0.04157910f, 0.04037157f, -0.06796873f, -0.02638815f, 0.04778131f, -0.05047775f, 0.02995207f, 
    0.05327296f, 0.01299775f, -0.04395001f, 0.05331207f, 0.00403442f, -0.00232153f, 0.04804233f, 0.04259521f, 
    -0.02054682f, -0.06275130f, 0.02429152f, -0.01677469f, -0.05871096f, -0.01343623f, -0.06561894f, 0.00369299f, 
    0.03239731f, 0.04902264f, 0.00290862f, 0.01786451f, -0.06450183f, 0.04479084f, -0.03460598f, 0.01501738f, 
    -0.04269037f, -0.03207646f, 0.01807013f, 0.04775077f, -0.03237078f, -0.02416857f, 0.03176259f, -0.00319985f, 
    -0.01914673f, -0.04715779f, -0.00301652f, -0.04915012f, -0.05759371f, -0.02254890f, -0.01993960f, 0.00291651f, 
    -0.01274792f, -0.01368371f, -0.03734411f, 0.03221827f, -0.02607622f, -0.00568523f, -0.01862173f, -0.03474272f, 
    -0.02154568f, 0.00538198f, -0.02108381f, 0.00238302f, -0.05024726f, -0.01182931f, -0.05596507f, -0.00058827f, 
    -0.04122709f, 0.05103011f, -0.02310396f, -0.04229888f, 0.00810863f, -0.00244833f, 0.02402482f, -0.04909871f, 
    0.00154710f, 0.03670937f, 0.03575884f, 0.01305924f, 0.03174078f, -0.00544692f, 0.00182337f, 0.00429669f, 
    0.02109081f, -0.00202716f, -0.05013566f, -0.04935053f, -0.05852689f, 0.01654980f, -0.02000327f, 0.07414679f, 
    0.05961079f, -0.00561406f, -0.00188479f, 0.00058176f, -0.01644159f, 0.03206309f, 0.05767223f, 0.00036079f, 
    -0.00030939f, 0.00346706f, -0.04150190f, -0.02657058f, 0.05048728f, 0.01617096f, -0.02630772f, -0.03809123f, 
    -0.04211868f, 0.01170364f, -0.04010551f, -0.00847268f, 0.03749250f, -0.04070215f, 0.00580060f, 0.04683864f, 
    -0.03600930f, 0.03202453f, -0.06241195f, -0.06305531f, -0.01167875f, 0.05298857f, -0.00499539f, 0.01915051f, 
    0.00906066f, -0.01563863f, -0.02630117f, 0.00873576f, -0.02787148f, 0.01811380f, -0.00209192f, 0.02952890f, 
    -0.03716781f, -0.02143455f, -0.02897216f, -0.04356989f, 0.06430437f, 0.06899630f, -0.03604123f, 0.03192579f, 
    0.00252655f, -0.03394380f, 0.02259879f, 0.00644033f, -0.02205124f, 0.02899113f, -0.05500307f, -0.00413929f, 
    0.04044323f, -0.00878050f, 0.04660639f, 0.00637977f, -0.06598365f, -0.02780667f, -0.03131222f, 0.01447097f, 
    0.02969128f, -0.04030508f, 0.01277480f, -0.05589865f, -0.05235484f, 0.00820942f, -0.02885411f, -0.02475930f, 
    0.04482521f, -0.01712755f, -0.03716277f, -0.02459591f, 0.04470195f, -0.01550588f, 0.01263263f, -0.04854868f, 
    0.04460552f, -0.03383489f, 0.16954173f, 0.28681028f, -0.10002474f, -0.09444878f, -0.05192534f, -0.00137150f, 
    0.15178294f, 0.26504701f, 0.06148506f, -0.02697751f, 0.03265216f, -0.07820392f, -0.19973299f, -0.03343077f, 
    0.12328401f, 0.08415851f, -0.62185657f, 0.40311825f, -0.21656471f, 0.34300235f, -0.16888624f, 0.12080149f, 
    -0.05553477f, 0.17000939f, -0.24260738f, 0.47345415f, -0.00001643f, -0.01938989f, -0.21236819f, -0.19934888f, 
    -0.20805377f, 0.18054108f, -0.18233211f, 0.04980220f, -0.04969662f, 0.34721512f, -0.33935249f, 0.05243338f, 
    0.21002550f, -0.00470846f, -0.10184153f, -0.04582996f, -0.18511270f, -0.05730290f, -0.10088250f, 0.05001702f, 
    0.09077052f, 0.07265703f, -0.10418870f, -0.04206947f, 0.03556756f, 0.07791772f, -0.01399027f, -0.08030575f, 
    -0.33465269f, -0.01664780f, 0.19439088f, 0.16106823f, 0.30613309f, -0.11415080f, -0.06582756f, 0.15108095f, 
    -0.08637346f, 0.00441825f, 0.06247932f, -0.02564204f, -0.43917513f, -0.17509863f, 0.07996970f, 0.09867664f, 
    0.12843958f, -0.01929794f, -0.82695508f, 0.02292997f, -0.07545101f, -0.02847831f, 0.18526725f, -0.02447038f, 
    -0.17365576f, -0.44449747f, 0.10234927f, -0.11480729f, -0.03108009f, -0.12906361f, 0.25189379f, 0.15067387f, 
    -0.14510371f, -0.04772085f, -0.07059225f, -0.06175039f, -0.10091013f, 0.29863158f, 0.19316924f, -0.06862547f, 
    -0.13739336f, -0.02307972f, -0.02032459f, 0.15214108f, 0.14279425f, 0.19076458f, 0.26151204f, 0.12828372f, 
    -0.10193465f, -0.25241116f, 0.18083778f, 0.09763216f, -0.17124709f, 0.10834545f, 0.29564711f, -0.37933707f, 
    -0.15244517f, -0.10099405f, -0.05444637f, 0.02864427f, 0.08966818f, -0.40259093f, -0.22410271f, -0.82228136f, 
    0.09054565f, -0.06378854f, -0.03800080f, 0.26181155f, 0.05932726f, 0.20700122f, 0.14231135f, -0.29859531f, 
    -0.23131315f, 0.36750522f, 0.19132988f, 0.08921663f, -0.03779725f, -0.26753280f, -0.09699973f, -0.30316415f, 
    0.50988901f, 0.36575061f, -0.17855024f, -0.02077118f, -0.23358001f, 0.22005874f, 0.19065088f, 0.01563743f, 
    -0.05161135f, 0.34395757f, 0.28276324f, -0.03443223f, -0.06796420f, -0.24535592f, 0.28299031f, 0.12469698f, 
    0.19448394f, 0.37525901f, 0.00326227f, 0.31610030f, 0.04561123f, -0.05680754f, -0.02527030f, -0.15792111f, 
    0.03864966f, 0.10610539f, 0.41310629f, 0.44063333f, 0.44839838f, -0.02640809f, -0.10377088f, 0.05168723f, 
    0.19992720f, 0.43676883f, 0.30175295f, 0.24523805f, -0.19188258f, 0.17398968f, 0.27772078f, -0.00936889f, 
    -0.19358714f, -0.12633178f, -0.13986391f, 0.18551551f, -0.16730867f, -0.03754460f, 0.20092028f, -0.16568804f, 
    -0.01774548f, -0.32709599f, -0.09931431f, 0.10627997f, -0.19166058f, 0.08464359f, 0.06937556f, 0.15638615f, 
    0.20049876f, 0.01795297f, -0.13351515f, -0.06820331f, 0.07270625f, 0.25412264f, -0.34794626f, -0.03281683f, 
    0.14177096f, -0.17672038f, 0.36015478f, -0.03275967f, -0.09550809f, 0.16934904f, 0.17421342f, -0.66471595f, 
    0.07226562f, 0.27446827f, 0.02174197f, 0.21315910f, 0.05621738f, -0.07447642f, 0.05394189f, 0.12322675f, 
    -0.23452424f, -0.18737039f, -0.10505741f, -0.03151367f, 0.04329113f, -0.24649578f, 0.06993608f, -0.24452098f, 
    -0.28428379f, -0.26735154f, -0.10630807f, 0.04452097f, 0.09772611f, -0.12727354f, 0.23360944f, 0.00902082f, 
    -0.08528370f, -0.07619671f, 0.39956442f, 0.02809669f, -0.19843695f, 0.27191123f, -0.13181160f, 0.02411920f, 
    0.17851889f, 0.02264434f, 0.23010327f, 0.14517139f, 0.40665430f, -0.07037506f, -0.13189083f, -0.01399440f, 
    0.01879934f, 0.05852566f, 0.07794617f, -0.01740910f, -0.17664117f, 0.01302564f, -0.13925089f, 0.00166328f, 
    -0.04181221f, -0.53848255f, 0.13903449f, 0.15878995f, -0.34112051f, 0.20482822f, 0.12122444f, -0.11001189f, 
    0.15701118f, 0.04709853f, -0.08577950f, -0.15961923f, -0.07882545f, 0.32924882f, 0.09251868f, -0.01124826f, 
    0.09889281f, -0.27944559f, 0.09704724f, 0.00257902f, 0.09096710f, 0.01182159f, -0.14107727f, -0.10703438f, 
    0.06476466f, 0.15089723f, -0.06686465f, 0.05100350f, -0.01357529f, 0.10115413f, 0.08755251f, -0.05021042f, 
    -0.20938109f, 0.03103773f, -0.04437782f, 0.02467283f, -0.13044192f, -0.01636896f, -0.13495822f, -0.07396433f, 
    -0.05031367f, 0.14609741f, 0.01892983f, 0.02504251f, -0.00524333f, -0.07473079f, -0.02699010f, 0.08051483f, 
    -0.13048209f, -0.12728807f, 0.43611720f, 0.13467582f, 0.16129871f, -0.49947092f, 0.00837690f, 0.08174010f, 
    -0.29384127f, 0.06591572f, -0.33647978f, -0.40915263f, 0.03136023f, 0.13538340f, -0.24229473f, 0.14648795f, 
    0.06508813f, -0.09017216f, 0.14420280f, 0.09176002f, 0.28435758f, 0.09293075f, -0.05632743f, -0.21720214f, 
    0.02368186f, -0.09939082f, 0.01326375f, -0.03101908f, -0.09826893f, -0.00048386f, 0.01542050f, -0.05301891f, 
    0.01016466f, -0.10171318f, 0.14542980f, 0.00715551f, -0.09060316f, -0.04405546f, 0.18147694f, 0.12612000f, 
    0.41765410f, 0.00343944f, 0.26369074f, 0.13836737f, -0.07093926f, 0.19577377f, -0.19706589f, -0.29147306f, 
    0.23398519f, 0.04323032f, 0.26162192f, -0.03441131f, 0.04138095f, -0.00782382f, -0.00793654f, -0.02769334f, 
    0.13260974f, 0.61363077f, 0.18643267f, 0.07747281f, -0.34062326f, 0.10427842f, -0.04084132f, -0.19741189f, 
    0.04214065f, -0.07267652f, -0.41005656f, 0.17196868f, -0.00795848f, -0.01141157f, -0.09408034f, 0.26612878f, 
    0.21639773f, 0.02022686f, 0.00790227f, 0.12344245f, -0.00306124f, -0.10810022f, -0.25561231f, -0.02709216f, 
    -0.06466982f, 0.05334632f, -0.11469949f, -0.17695518f, 0.06890936f, -0.00607008f, 0.07079090f, 0.16062321f, 
    0.14771742f, 0.03780273f, -0.06314342f, -0.13984105f, -0.12675971f, -0.44685623f, -0.28253028f, -0.16198829f, 
    0.04378045f, 0.01682126f, -0.31271800f, 0.17415296f, -0.10254990f, -0.34560943f, -0.03838721f, 0.30683121f, 
    0.02906043f, 0.06335014f, -0.09117395f, -0.02915118f, 0.17064428f, -0.01322916f, 0.11338248f, -0.21356724f, 
    -0.08417244f, -0.50576794f, -0.29786760f, -0.01462069f, -0.04157855f, 0.05191368f, 0.06862165f, 0.13723065f, 
    -0.07055826f, -0.38931412f, 0.03635451f, 0.11477870f, 0.03941140f, -0.22142853f, 0.15151180f, -0.02670114f, 
    -0.08171827f, -0.03725311f, -0.10897338f, -0.17784752f, 0.07694188f, 0.13362585f, -0.14568634f, 0.08070012f, 
    -0.00114142f, 0.29458973f, -0.22492081f, 0.24805151f, 0.15695332f, 0.02520194f, 0.16560706f, -0.10508743f, 
    0.07843018f, -0.01122393f, -0.29103288f, -0.19679596f, -0.00046279f, 0.25461909f, 0.08682708f, 0.12064116f, 
    0.12582821f, 0.07370385f, -0.14466687f, -0.04687057f, -0.44390187f, 0.25754666f, -0.28561911f, -0.12462354f, 
    -0.00375020f, 0.24380971f, 0.02144681f, 0.09018621f, 0.11923234f, 0.13660830f, -0.02610776f, 0.12548475f, 
    0.21618462f, 0.11405284f, 0.02659688f, 0.12445375f, 0.26938912f, 0.05496537f, 0.10573892f, -0.42883497f, 
    -0.32282293f, -0.10829361f, 0.00005032f, -0.01480026f, -0.04884901f, -0.09426722f, -0.24139674f, 0.09728532f, 
    0.07175434f, 0.08440258f, 0.22858004f, 0.15080653f, 0.16710837f, 0.01270347f, -0.08785509f, 0.25299206f, 
    -0.15114364f, 0.23767950f, 0.31541014f, 0.18612121f, 0.02435217f, 0.20870981f, 0.09237400f, -0.18910514f, 
    0.17874120f, 0.28331408f, 0.22755601f, 0.15011275f, 0.15979370f, 0.05574071f, -0.08860166f, 0.06505596f, 
    0.17917138f, 0.04923579f, -0.31297621f, 0.24156974f, 0.18361153f, -0.22052668f, 0.11569060f, 0.08583672f, 
    -0.03535194f, -0.15728876f, -0.40697610f, 0.33627674f, -0.14002681f, -0.18642733f, -0.13941288f, -0.41444725f, 
    -0.09663887f, 0.11655568f, 0.05751903f, -0.17553453f, 0.02078423f, 0.37974826f, -0.00835202f, -0.04070369f, 
    -0.21007966f, 0.06290645f, 0.01482916f, -0.11006224f, 0.24335964f, 0.39475268f, 0.08219563f, 0.43877214f, 
    0.21179463f, -0.02955464f, 0.00790218f, -0.05701002f, 0.19202818f, -0.27733174f, 0.32370853f, -0.11655623f, 
    -0.19023600f, -0.19280994f, -0.20895562f, 0.00017195f, -0.02043751f, -0.16624315f, 0.15666193f, 0.40208113f, 
    -0.00050564f, 0.20144175f, -0.05743282f, -0.02848868f, 0.09148636f, 0.08458275f, -0.15628612f, -0.01158445f, 
    -0.16911377f, 0.21544164f, 0.10046884f, -0.10896736f, -0.07547467f, 0.03457143f, 0.25194037f, -0.08112027f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    -0.04660072f, 0.05258222f, 0.20884801f, -0.01629741f, 0.27677432f, -0.11784546f, 0.12531063f, 0.10655605f, 
    0.11839180f, 0.00954094f, -0.06872921f, 0.03666494f, -0.03809307f, -0.13748030f, 0.12671246f, 0.02049815f, 
    -0.04488483f, 0.01055577f, 0.00866553f, 0.27383387f, 0.09955663f, -0.03427853f, 0.05721924f, -0.02068590f, 
    -0.04745888f, 0.01942247f, 0.01848285f, 0.05173490f, -0.14182253f, 0.01817326f, 0.12005474f, -0.08639056f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.01967323f, 0.14473049f, 0.01959701f, -0.02819042f, -0.03838363f, 0.18420947f, -0.36427748f, -0.68115431f, 
    -0.29022714f, 0.05952615f, 0.25384259f, 0.16989990f, 0.06611152f, 0.15201667f, -0.20252983f, -0.07361706f, 
    -0.15553248f, 0.11841860f, 0.13187322f, -0.66033661f, -0.50791138f, 0.14763962f, 0.74181050f, 0.05125038f, 
    0.09253907f, -0.13869768f, -0.05611118f, 0.54833007f, 0.20977055f, 0.04203527f, -0.49934706f, 0.02930007f, 
    -0.55482692f, 0.16098565f, 0.51083463f, -0.03560684f, -0.41670391f, 0.30729717f, 0.73033619f, -0.32920754f, 
    -0.04963836f, -0.08122756f, -0.37685105f, -0.17054778f, 0.02290054f, -0.05283765f, -0.12648655f, -0.09940536f, 
    -0.07490201f, -0.12332889f, 0.03487725f, -0.13554391f, -0.09484705f, 0.05813560f, 0.38736609f, -0.07132684f, 
    -0.12335198f, -0.05169855f, 0.12304434f, 0.35311067f, 0.21796623f, 0.03201564f, 0.15932748f, -0.49604684f, 
    0.15247782f, -0.11538031f, -0.74543816f, -0.10669114f, -0.02963435f, -0.62848896f, 0.87435842f, -0.21922103f, 
    0.04969353f, 0.16084635f, 0.27899450f, -0.13363200f, 0.03395009f, 0.25762075f, 0.07944033f, 0.03068306f, 
    -0.04052209f, -0.14490600f, -0.12076581f, -0.39075607f, -0.29334927f, 0.08247291f, -0.48074970f, -0.05828920f, 
    0.15654013f, 0.05530847f, 0.14023067f, -0.11012512f, 0.62138975f, 0.10046636f, -0.04555115f, -0.33172211f, 
    0.39930844f, 0.13223463f, 0.20668104f, -0.01314901f, -0.01820829f, 0.44923863f, 0.05585227f, -0.27760777f, 
    0.27444485f, 0.07314923f, -0.02294843f, 0.15501985f, 0.02524484f, -0.44456699f, -0.14485812f, -0.11202341f, 
    -0.12226971f, -0.11184707f, -0.13590175f, -0.54250866f, 0.64022511f, 0.02201278f, -0.38710561f, -0.02356550f, 
    0.04443966f, 0.04518525f, 0.05773239f, -0.05812794f, -0.78272700f, 0.12333347f, 0.08130359f, -0.32560754f, 
    0.37951130f, 0.01718864f, 0.15923139f, -0.03811816f, -0.13910030f, -0.25632489f, -0.15120241f, -0.79651797f, 
    0.28563610f, 0.11922234f, 0.21043636f, 0.10429171f, 0.02774238f, -0.36243093f, 0.35696393f, 0.10166386f, 
    0.11369455f, 0.07736602f, 0.02422995f, 0.69759887f, -0.33659706f, 0.13201350f, -0.35524520f, -0.13556416f, 
    -0.10852312f, 0.16796094f, 0.11764777f, -0.14826377f, -0.02509659f, 0.09397047f, -0.34386155f, 0.01995645f, 
    -0.43515077f, -0.14807878f, 0.17443492f, 0.01050653f, 0.04252838f, -0.17671645f, -0.45286581f, 0.31956324f, 
    -0.36810499f, 0.03028914f, -0.05226349f, 0.05422777f, 0.13865057f, -0.58459806f, -0.48239294f, -0.15677027f, 
    -0.06259892f, 0.01907140f, 0.05343936f, 0.51085722f, -0.08792135f, 0.00781214f, 0.22611971f, 0.01748932f, 
    -0.16777268f, -0.11693919f, -0.16040386f, 0.43718311f, 0.06809800f, 0.08106627f, 0.12161930f, 0.25009745f, 
    -0.03094434f, 0.05843220f, -0.09933408f, 0.09060096f, -0.29491588f, -0.35635486f, -0.40457550f, 0.62498724f, 
    -0.27357680f, -0.11027995f, 0.33306834f, 0.12599663f, 0.06003492f, 0.84120160f, -0.27918383f, 0.06674182f, 
    0.07958980f, 0.06355594f, 0.13697004f, 0.22375411f, -0.16319554f, 0.13463290f, -0.27296484f, -0.09198304f, 
    -0.11234803f, 0.08589265f, -0.00955069f, -0.06397513f, -0.75518429f, -0.06406180f, -0.31962904f, 0.14485359f, 
    0.26052910f, 0.05027337f, -0.21227992f, -0.04291764f, 0.00649006f, 0.30467156f, -0.30441311f, -0.16352510f, 
    -0.19048356f, -0.13096087f, -0.57253879f, -0.03921463f, 0.01456488f, 0.00177289f, -0.35554957f, 0.10926025f, 
    -0.06949310f, 0.16362152f, -0.08812247f, -0.09570977f, 0.15606262f, 0.09639617f, -0.25824481f, -0.09188440f, 
    -0.03181501f, -0.15966636f, -0.16725568f, -0.11494929f, 0.61520380f, 0.09341715f, -0.31216723f, 0.80149215f, 
    -0.55814451f, 0.03144670f, -0.50859576f, -0.13933007f, -0.32867771f, 0.54538280f, -0.54647851f, -0.19229767f, 
    0.01686577f, -0.07191662f, 0.25934613f, -0.17252937f, -0.05641239f, -0.09023976f, 0.12582883f, -0.06035732f, 
    0.12397843f, 0.01737314f, -0.01085077f, 0.19064873f, -0.01424133f, 0.06527669f, 0.21821709f, -0.12553437f, 
    -0.13985129f, 0.04304255f, 0.11166207f, -0.50494033f, 0.40845409f, 0.02188959f, 0.65454626f, -0.46168420f, 
    0.02196334f, 0.15700990f, -0.45417890f, -0.02350413f, -0.00853858f, -0.44628260f, -0.76959211f, 0.45083773f, 
    1.11363971f, -0.13918647f, -0.08765694f, 0.00449787f, 0.13338280f, 0.10635207f, 0.20784456f, 0.14939010f, 
    0.06232018f, -0.02662737f, 0.13671835f, -0.30511877f, -0.07206271f, -0.01245990f, -0.07409693f, -0.02657019f, 
    0.05208965f, 0.15015060f, 0.15944369f, 0.35121116f, -0.25190046f, -0.11795644f, -0.52717602f, 0.45363617f, 
    -0.31611365f, -0.01916050f, 0.34900230f, 0.05841966f, 0.53921133f, -0.84063959f, 0.57772684f, -0.20089364f, 
    0.18102841f, 0.03731680f, -0.42874810f, -0.17054826f, -0.04506175f, 0.04348102f, 0.09549835f, -0.15075386f, 
    -0.02568916f, -0.07317652f, 0.02005161f, -0.04538280f, 0.60422271f, 0.12862504f, -0.45908180f, -0.12151845f, 
    -0.05153070f, 0.00107018f, 0.12155327f, -0.72754961f, 0.14612572f, -0.06726732f, 0.31606618f, -0.25792959f, 
    0.16305991f, -0.02961024f, -0.24985510f, -0.10471178f, 0.87609023f, 0.45173240f, 0.04730903f, 0.53278869f, 
    -0.86473089f, 0.08105842f, 0.17815743f, 0.09363297f, 0.00330353f, 0.03749268f, 0.36614871f, 0.00897619f, 
    0.10984015f, -0.02531994f, 0.06823103f, -0.33586735f, -0.45309776f, -0.05562466f, -0.55981368f, 0.07134707f, 
    -0.09237225f, -0.02125232f, -0.17833506f, -0.53091490f, -0.62267107f, 0.04282807f, 0.06648286f, 0.07145087f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.16128457f, 0.09816493f, -0.13070756f, -0.00056288f, -0.03510894f, 0.05825647f, -0.02222792f, -0.39625564f, 
    -0.37691608f, 0.11151242f, 0.07603049f, -0.07861835f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
