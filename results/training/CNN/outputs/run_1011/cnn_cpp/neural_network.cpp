#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.13308603f, -0.87432599f, -0.77616507f, -0.91465700f, -0.00101840f, 1.08321929f, 0.21859951f, -0.11421939f, 
    -0.02376265f, 0.24672894f, 0.31195706f, -0.28352463f, 0.30942565f, 0.44629094f, 0.65125895f, 0.04918644f, 
    0.19439197f, -0.44003534f, -0.86316502f, -0.69632256f, -0.84608912f, 0.67601997f, -0.02201625f, 0.20267318f, 
    0.11146718f, 0.35160708f, 0.30209813f, -0.84742177f, -0.05614434f, -0.48979044f, -0.45033211f, -0.56627452f, 
    -0.72926396f, 0.42054117f, 0.52816153f, -0.04775437f, 0.98471850f, -0.26896873f, -0.06745448f, 0.46583048f, 
    -0.13287801f, 0.26125914f, 0.23820284f, -0.53806406f, -0.64807045f, 0.67858839f, 0.48208877f, -0.73147005f, 
    0.56265783f, 0.16921712f, 0.10275993f, -0.20461935f, -0.08655906f, -0.33908138f, 0.16632201f, -0.06285302f, 
    -0.26244739f, 0.05350994f, 0.33191651f, -0.33587185f, -0.10174400f, 0.81749290f, -0.44353470f, 0.87330949f, 
    -1.10538268f, 0.37909991f, -0.05978980f, -0.00238114f, -0.17032303f, -0.12007339f, -0.22632964f, 0.56302685f, 
    0.83870411f, -0.25577751f, -0.66664118f, 0.37475595f, 0.17537470f, -0.02628429f, 0.17656104f, 0.34009311f, 
    -0.42127231f, -0.39684555f, 1.08326089f, 0.75002557f, -0.12991032f, -0.56824213f, -0.12418880f, -0.25863269f, 
    -0.48064145f, 0.19091721f, 0.57302052f, 0.11038807f, 0.40127951f, -0.20588388f, -0.53523654f, 0.13484921f, 
    0.22357704f, 0.23198161f, 0.12339116f, -0.99040163f, -0.95510012f, -0.87509787f, 0.46304578f, 0.20829305f, 
    -0.52896571f, -0.12572160f, -0.62312460f, -0.12347338f, -0.83190936f, -0.59701127f, 0.94987780f, 0.65296173f, 
    -0.18726072f, 0.00904330f, -0.18868905f, -0.19201393f, -0.14905721f, -0.97685337f, -0.87151945f, 0.97497803f, 
    -0.28767946f, -0.25643602f, 0.92264450f, -0.03426855f, 0.07714197f, -0.00936167f, 1.14563942f, -1.24889255f, 
    -1.23714185f, 0.73644173f, 0.49767601f, 0.36023584f, -0.25813887f, 0.28113648f, -0.22365405f, 0.55917650f, 
    -0.79105538f, 0.29106614f, 0.51269513f, -0.20840482f, -0.49939516f, -0.03845632f, 0.48392692f, -0.21707717f, 
    -0.36831146f, -0.03830744f, 0.33114436f, -0.44920057f, 0.34830537f, 0.16252778f, -0.75436497f, 0.09038842f, 
    0.65923148f, -0.14823528f, -0.51228589f, -0.49455708f, -0.82100499f, -0.73803627f, -0.09950448f, 0.83253944f, 
    0.02818135f, -0.03524512f, -0.92549872f, -0.77143335f, 0.26543251f, -0.62123442f, -0.92392480f, -0.28385174f, 
    0.18492906f, -0.36933756f, -0.45794711f, 0.46379849f, -0.71768248f, -0.32548496f, 0.38235599f, -0.48205817f, 
    0.00611285f, 0.53882909f, 0.12057959f, 0.14358726f, 1.02979505f, -1.06751025f, 0.37014130f, -0.71935338f, 
    -0.81289244f, -0.86685610f, -0.22578804f, -0.63206834f, -0.19906257f, -0.47583878f, -0.26421216f, -0.61118114f, 
    -0.40980309f, -0.28554586f, -0.59488541f, -0.06352881f, -0.56748533f, -0.46712506f, 0.67537260f, 0.59237313f, 
    -0.73419094f, -0.23136748f, 0.09078290f, -0.02265880f, -0.13634063f, 0.01849903f, -0.00198011f, -0.68646175f, 
    -0.55018395f, 0.56762397f, 0.53534567f, 0.08268771f, -0.65364796f, -0.20017049f, 0.27908549f, 0.15157597f, 
    0.14514041f, 0.63677186f, -0.28693131f, -0.44431457f, 0.11721529f, -0.47341600f, 0.05617584f, 0.40677133f, 
    0.37508622f, 1.25226521f, -1.22651875f, -0.21177469f, 0.09490949f, -0.17792417f, -0.47341141f, -0.56260443f, 
    0.77884459f, -0.63788444f, -0.03107427f, -1.16419864f, -0.20907389f, 0.26093668f, 0.73251796f, 0.42997763f, 
    -0.27714297f, -0.22325057f, 0.04558215f, 0.35645664f, 0.37915930f, 0.65175325f, -0.49816287f, -0.41088444f, 
    -0.35181588f, 0.35035768f, 0.34297734f, 0.07558706f, -0.94413376f, 0.41005045f, 0.64010465f, -0.46227792f, 
    0.87182194f, -0.58820480f, -0.20839435f, -0.32853138f, -0.68248433f, 0.47551635f, 0.07415252f, -1.05263793f, 
    -0.17009406f, -0.06843066f, -0.90154004f, -0.69500834f, -0.45383918f, -0.54794317f, 0.16559038f, -0.30170575f, 
    0.08420040f, -0.89357233f, 0.24464850f, 0.71127683f, -0.20710436f, 0.33233854f, 0.14156274f, -1.40578866f, 
    0.77689469f, -1.00109994f, 0.45358691f, 0.50713038f, 0.33252642f, -0.06807458f, 0.04082699f, -0.56430048f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.24385773f, -0.13704827f, 0.22225684f, 0.04599698f, 0.26395351f, 0.09532401f, 0.10374381f, 0.12817834f, 
    -0.06042287f, 0.00401969f, -0.14622419f, -0.33935392f, 0.01221283f, 0.01087485f, 0.12638526f, -0.02058794f, 
    0.23153022f, -0.04428777f, -0.27519128f, 0.20959555f, 0.03201678f, -0.13670354f, 0.41177210f, 0.24918103f, 
    -0.21935712f, 0.17190216f, 0.08601536f, 0.07192197f, -0.18522824f, -0.03614237f, 0.16404428f, 0.07159586f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.29655674f, 0.22328173f, 0.02259377f, -0.19226474f, -0.18150571f, 0.13916214f, -0.09301322f, 0.04572929f, 
    -0.00909039f, -0.15833229f, -0.07189534f, -0.03647514f, -0.14238420f, 0.04267615f, 0.06467540f, 0.12281340f, 
    -0.01452661f, -0.02575147f, -0.01034399f, -0.09107421f, -0.13235338f, -0.16312647f, -0.16553146f, 0.02880248f, 
    -0.03165193f, 0.00620568f, 0.08033144f, 0.07075015f, 0.04369294f, 0.08929833f, -0.00770970f, -0.18022075f, 
    -0.02612013f, 0.10158873f, -0.18905903f, -0.00487650f, 0.07398108f, 0.08083552f, 0.03231167f, 0.02436771f, 
    0.31404710f, 0.27386692f, -0.02786300f, -0.00804845f, 0.06711602f, 0.16371134f, 0.17896120f, 0.13891914f, 
    -0.19888315f, -0.21930838f, -0.17581715f, -0.03733930f, 0.00527570f, 0.00800334f, 0.09375458f, 0.00149599f, 
    0.05467837f, 0.00428403f, 0.00270142f, 0.01588251f, 0.40533522f, 0.34853715f, -0.03359310f, -0.35490462f, 
    -0.14662819f, 0.04163656f, 0.10702823f, -0.07991606f, 0.15400356f, -0.04430942f, 0.07598671f, -0.01392265f, 
    0.01442865f, 0.04120333f, 0.05101010f, -0.01454831f, -0.00719128f, -0.00086834f, -0.12439266f, 0.10272753f, 
    -0.05780610f, -0.41922575f, -0.28651780f, 0.21495485f, -0.17625114f, -0.03777028f, -0.02896697f, 0.01779528f, 
    0.06698505f, 0.07705919f, -0.01441143f, 0.02164925f, 0.00915231f, 0.04195261f, 0.05032708f, -0.11091009f, 
    -0.09057166f, 0.13880289f, -0.11025184f, 0.07836621f, -0.48510513f, -0.14663674f, -0.25010991f, 0.06627512f, 
    -0.12365197f, 0.01061500f, 0.00333596f, 0.03855853f, 0.05616633f, 0.08336815f, 0.02289100f, 0.00107729f, 
    -0.04639390f, 0.02127979f, 0.02987290f, -0.08212525f, 0.00295351f, -0.05359803f, 0.07331470f, -0.01178259f, 
    0.09387327f, 0.03326640f, -0.15676892f, -0.03924063f, 0.06321917f, -0.02567441f, 0.03259352f, -0.07683077f, 
    0.03177878f, 0.03925059f, -0.21754496f, -0.01264904f, -0.02719974f, -0.09388625f, -0.16710320f, -0.11515272f, 
    -0.10934234f, -0.05956646f, -0.09176629f, 0.02929895f, -0.18422756f, 0.00967237f, 0.08184028f, -0.18036896f, 
    -0.00942173f, -0.07783747f, -0.11052224f, -0.03567395f, -0.14905620f, -0.15880330f, 0.04382110f, 0.05803457f, 
    -0.06431346f, 0.03846822f, -0.16301094f, -0.23196390f, 0.13095349f, -0.20437424f, -0.20723243f, -0.22653185f, 
    -0.07176567f, -0.00675429f, -0.05254719f, 0.09926917f, -0.01096702f, 0.04088213f, -0.00983961f, -0.05224032f, 
    0.07526072f, 0.05132981f, -0.17962712f, -0.08850372f, -0.27675894f, -0.24597043f, -0.16817029f, -0.03862092f, 
    0.01629771f, -0.03147037f, -0.01955893f, 0.00909575f, -1.14205432f, 0.08887696f, -0.04757752f, -0.11891611f, 
    0.08313964f, 0.09306961f, -0.05986539f, -0.01197778f, 0.10640146f, 0.05456492f, 0.03649808f, 0.03176269f, 
    0.01638317f, 0.12784965f, 0.06320170f, -0.00203281f, 0.02848317f, -0.04901947f, -0.07120390f, -0.13016367f, 
    -0.01513685f, -0.00067516f, 0.03411273f, 0.01614269f, 0.02273856f, -0.05825900f, -0.00450843f, -0.03931848f, 
    0.06806564f, 0.05172618f, -0.03087313f, 0.10789503f, 0.08490571f, 0.03701424f, 0.00391062f, -0.00713511f, 
    -0.08921154f, -0.13534863f, -0.04988850f, -0.01118993f, 0.41692811f, 0.21917073f, -0.00984279f, -0.19141179f, 
    -0.05120503f, 0.19716823f, 0.25220132f, 0.24642777f, 0.05860063f, 0.03115784f, 0.04140812f, 0.06101827f, 
    -0.03823926f, 0.06415959f, 0.04586877f, 0.00305645f, -0.03296144f, -0.13874871f, -0.03812174f, -0.03185099f, 
    0.32667303f, 0.01589990f, 0.14652494f, -0.64107805f, -0.03184626f, -0.18391865f, -0.16513631f, 0.07767213f, 
    0.03428269f, 0.05362409f, -0.01794906f, 0.03186976f, -0.08108030f, -0.07480302f, -0.01970044f, -0.11931323f, 
    0.03834961f, 0.07873750f, -0.15048680f, 0.07205492f, 0.10941023f, 0.00042381f, 0.38005516f, -0.33554116f, 
    0.02226889f, 0.03052371f, 0.05645613f, 0.19089431f, 0.00161710f, -0.03892794f, -0.01512643f, -0.09856129f, 
    -0.11159019f, 0.00396561f, -0.07173770f, 0.03264811f, -0.02223663f, 0.06086581f, -0.02688717f, -0.01063486f, 
    0.23213339f, -0.54348868f, -1.49965918f, 0.11471695f, 0.07824259f, 0.18717171f, 0.01661654f, 0.05035216f, 
    -0.17615041f, 0.03642893f, -0.03580887f, 0.05125421f, -0.23360918f, -0.26074982f, -0.10178883f, 0.05361221f, 
    0.11686996f, -0.00267511f, -0.05388216f, 0.01956563f, 0.00385865f, 0.02033289f, -0.13418445f, 0.00300328f, 
    0.18978217f, -0.20542964f, 0.04465782f, -0.04443084f, -0.03728291f, 0.00332994f, -0.06154608f, 0.04421091f, 
    0.03608805f, -0.10043221f, -0.09983929f, -0.11043322f, 0.03552247f, -0.08112513f, -0.27552345f, 0.00514404f, 
    -0.77463794f, -0.29049680f, 0.30158669f, 0.03508920f, -0.07394464f, 0.01895514f, -0.12774462f, -0.00710167f, 
    -0.03089068f, -0.08701632f, -0.10968563f, -0.07434501f, 0.01615649f, -0.22254090f, -0.08632218f, -0.23700525f, 
    -0.05835441f, -0.10096879f, -0.16243204f, -0.26004601f, 0.36785457f, 0.33253664f, 0.09823486f, -0.39709955f, 
    -0.14665668f, 0.17748182f, 0.12207845f, -0.08143660f, 0.05665718f, 0.00083718f, 0.07654144f, -0.02394982f, 
    -0.07076468f, -0.00617282f, 0.09264694f, -0.04235220f, 0.01703868f, 0.00067943f, 0.00895543f, 0.18286477f, 
    0.47420585f, 0.38942578f, 0.28742731f, -0.47531775f, 0.08502618f, 0.21213020f, 0.29515770f, 0.18894522f, 
    0.06227822f, 0.02778186f, 0.05813237f, -0.00607094f, -0.02277978f, -0.10285144f, -0.08287730f, -0.00953734f, 
    -0.06459369f, -0.03157231f, -0.04508135f, -0.04422859f, 0.13584934f, 0.07988171f, -0.14090808f, -0.08013715f, 
    0.00119278f, -0.01020897f, 0.06706253f, 0.03503697f, -0.00232417f, -0.05858246f, -0.02802920f, 0.04883947f, 
    0.00280690f, 0.00306138f, 0.05005728f, -0.05123112f, -0.08094490f, -0.08896602f, -0.02430386f, 0.05957790f, 
    0.08359937f, 0.18058588f, 0.18191019f, -0.58058214f, -0.07224044f, -0.04090906f, -0.15982302f, -0.09963495f, 
    -0.19028297f, -0.06561301f, -0.01009041f, -0.02129709f, 0.02617981f, 0.02031479f, -0.03667067f, -0.03877076f, 
    -0.05618212f, 0.04772276f, -0.03093300f, 0.12210155f, 0.32490438f, 0.25783005f, 0.16274945f, -0.21308920f, 
    -0.08481321f, 0.13251758f, 0.21723638f, 0.16422646f, -0.02119896f, 0.00045641f, -0.01038447f, -0.04708358f, 
    0.00005942f, -0.00303435f, -0.04299283f, -0.10992908f, -0.08263186f, -0.13147782f, -0.01765051f, -0.00473842f, 
    -0.70116067f, -0.33175066f, -0.51464224f, -0.08446783f, -0.83299726f, -0.01220460f, -0.03094933f, -0.05628956f, 
    0.02055482f, 0.00998650f, 0.02529705f, 0.00013975f, -0.07685181f, -0.00660504f, 0.00842719f, -0.12044577f, 
    0.02018036f, -0.14242692f, -0.07942721f, -0.10029987f, 0.45333433f, 0.24760179f, -0.11612239f, -0.24702594f, 
    -0.03661346f, -0.18921457f, -0.01440107f, 0.09252904f, -0.14842689f, 0.04849055f, -0.15934977f, -0.18346918f, 
    -0.04961355f, -0.04324050f, -0.04454002f, -0.07397927f, 0.06219194f, -0.00658930f, -0.04145106f, -0.04479491f, 
    0.05948953f, -0.02479215f, -0.00606516f, 0.06897082f, -0.02414701f, 0.03509091f, -0.01383475f, 0.03023363f, 
    0.05077798f, 0.04908459f, -0.04110363f, 0.06021072f, -0.06607807f, -0.08138126f, -0.02657536f, -0.06322006f, 
    -0.02428094f, 0.00360184f, -0.03343040f, -0.03829860f, -0.08988302f, 0.11769837f, -0.02576060f, -0.26095632f, 
    0.08348244f, -0.04020361f, -0.16306525f, 0.15143733f, -0.13045400f, 0.08213370f, -0.11041870f, -0.02023562f, 
    0.00653993f, -0.12224363f, -0.08342925f, -0.11694857f, -0.03101701f, -0.04337978f, -0.00131991f, 0.13882090f, 
    0.13667688f, -0.39403355f, -0.45124561f, 0.01827867f, -0.01888535f, 0.11803871f, 0.00726279f, 0.12083270f, 
    -0.11336736f, 0.01735264f, 0.00650646f, 0.02780672f, -0.11675975f, -0.00657260f, -0.04854570f, 0.03554734f, 
    0.15098082f, 0.09870663f, -0.00243297f, 0.01537490f, -0.06675681f, -0.08381882f, -0.03278106f, -0.05192224f, 
    -0.11470360f, -0.20737976f, -0.07078719f, -0.07911903f, 0.03612170f, -0.00792627f, 0.01297848f, 0.05397313f, 
    0.01236701f, 0.07011866f, 0.03490820f, -0.01676098f, 0.02337692f, -0.04483032f, -0.05488965f, -0.03784882f, 
    0.24907815f, 0.14959966f, 0.07402736f, -0.07800478f, 0.03890269f, -0.12716591f, -0.10309970f, 0.04624144f, 
    0.14688973f, 0.09908645f, 0.05716935f, -0.02312645f, 0.03140809f, 0.05795469f, 0.00241313f, 0.11398003f, 
    -0.18779577f, -0.11233715f, -0.00511197f, 0.08922219f, 0.06239932f, 0.17394872f, 0.12823345f, -0.05998277f, 
    -0.27098811f, 0.04199125f, -0.06526127f, -0.10151961f, -0.11673581f, 0.07569985f, -0.04319009f, -0.05137954f, 
    0.00562894f, -0.01045284f, 0.00402769f, 0.07517940f, -0.12186357f, 0.09568996f, 0.05151147f, 0.12315702f, 
    -0.09159548f, 0.00451792f, 0.07726417f, 0.06719964f, 0.00214354f, -0.08094033f, -0.01828817f, 0.01958769f, 
    0.02527774f, -0.01420299f, -0.23998012f, 0.02353846f, -0.08873209f, -0.03838620f, 0.03044733f, 0.07572401f, 
    -0.10634509f, 0.02670143f, -0.07621802f, -0.12463228f, -0.01784116f, 0.04881535f, -0.24119712f, -0.23137538f, 
    -0.02562517f, -0.12667176f, 0.18754563f, -0.01083116f, -0.03453598f, -0.04823426f, -0.07712793f, -0.01097053f, 
    0.08708455f, 0.06790609f, -0.04062388f, -0.01423997f, 0.11196466f, -0.01618273f, -0.14207307f, -0.00496128f, 
    -0.70530450f, 0.24174386f, -0.14750428f, 0.17712207f, -0.17936294f, 0.02483233f, 0.03258318f, 0.08798688f, 
    -0.33523628f, 0.01067034f, -0.08771306f, 0.00303811f, -0.05526835f, -0.02894278f, -0.03517535f, 0.00341008f, 
    0.05281073f, 0.00740475f, -0.00307890f, 0.03288639f, 0.25856152f, 0.03188398f, 0.17963961f, 0.14336242f, 
    0.03740603f, -0.03026864f, -0.03335476f, 0.00951245f, 0.00636697f, 0.00804109f, 0.10312425f, 0.09139385f, 
    -0.14123507f, -0.04853208f, -0.15616636f, -0.03535891f, -0.11221933f, -0.10245208f, -0.02145888f, -0.06122323f, 
    -0.11624075f, -0.14586298f, -0.22831163f, -0.08641926f, -0.09531892f, -0.05293701f, 0.12948072f, 0.13632122f, 
    0.05912753f, -0.18723398f, -0.05910654f, -0.00372571f, 0.00000654f, 0.00899852f, -0.09110974f, 0.00346178f, 
    0.04662089f, 0.00373776f, -0.01053435f, 0.07863874f, -0.26144871f, -0.09536804f, -0.12623698f, 0.32671440f, 
    0.13759188f, -0.07216867f, 0.16648766f, -0.15065373f, 0.08583726f, -0.02745388f, -0.09185958f, -0.01117436f, 
    0.00523872f, 0.03764889f, 0.00799008f, -0.03038684f, -0.00066526f, 0.02701153f, -0.03114345f, -0.00914129f, 
    0.73983729f, 0.39058667f, 0.06130249f, 0.35009459f, 0.00693548f, -0.04368427f, -0.05666527f, -0.03373828f, 
    -0.00836707f, -0.01884667f, 0.02039917f, -0.00704181f, -0.03706083f, -0.03556728f, 0.08270946f, 0.03259360f, 
    -0.08487508f, -0.04946183f, 0.11228615f, -0.19136903f, 0.41378650f, 0.16359594f, 0.04001309f, 0.18002018f, 
    -0.02150555f, -0.05561186f, -0.03144395f, 0.02917081f, -0.05556326f, -0.02256474f, -0.14300762f, 0.03911038f, 
    -0.01420001f, -0.02681146f, 0.07888372f, 0.08787858f, -0.17771512f, 0.20091601f, 0.07010888f, -0.07462016f, 
    0.09186783f, -0.10803895f, -0.13626988f, -0.07936827f, -0.08369159f, -0.15986308f, 0.02765771f, -0.06869344f, 
    0.13301657f, -0.03521892f, 0.12154496f, 0.17973243f, -0.26383635f, 0.04447908f, 0.06995985f, -0.13466203f, 
    0.09300484f, -0.01858497f, 0.16587315f, 0.09797182f, -0.11149678f, 0.21908948f, -0.14735541f, 0.04416896f, 
    -0.11303174f, -0.20303591f, 0.23912153f, 0.13835333f, -0.25848076f, 0.14196181f, -0.23194630f, -0.03721381f, 
    0.32789737f, 0.09306301f, -0.06112238f, 0.01779758f, 0.12302135f, 0.24892123f, -0.06779496f, -0.01526519f, 
    0.47650969f, 0.05619990f, -0.00558638f, 0.04589418f, -0.12360287f, -0.08275731f, -0.01758359f, -0.04022479f, 
    0.02436133f, -0.04802834f, 0.07441357f, 0.16723663f, 0.00245737f, -0.03849855f, 0.00354026f, -0.05314111f, 
    -0.10509119f, -0.01660944f, -0.00277520f, 0.04991537f, 0.28891939f, -0.04577757f, -0.15316300f, -0.09059443f, 
    0.15377805f, -0.00027073f, -0.11903526f, -0.09330422f, -0.15551595f, -0.04618768f, 0.00589727f, -0.01828159f, 
    0.04901647f, -0.03750900f, 0.01655367f, -0.02482628f, 0.05097016f, -0.04239823f, 0.10347106f, 0.28104582f, 
    0.04616069f, 0.01626748f, 0.09905695f, -0.02232145f, 0.04430538f, 0.01441266f, -0.07054636f, -0.09154677f, 
    0.01379426f, 0.01469608f, 0.00629602f, -0.03967739f, 0.02122941f, 0.10957354f, -0.03152150f, -0.03706368f, 
    0.00061238f, -0.02437256f, 0.05038031f, -0.04635818f, 0.40291807f, 0.22201832f, 0.39693490f, 0.17786197f, 
    -0.05411425f, 0.17948784f, -0.12610914f, 0.12458173f, 0.08736268f, -0.25553811f, 0.05453895f, -0.06561640f, 
    -0.01638720f, -0.17892182f, 0.00668683f, 0.08849339f, 0.01498956f, -0.08661926f, -0.03413445f, 0.00688320f, 
    -0.06210653f, -0.09629578f, -0.01499551f, -0.04014464f, 0.07407024f, -0.07732426f, 0.02010357f, 0.01804407f, 
    0.06355901f, -0.00629589f, 0.24938701f, 0.02324759f, 0.13243894f, 0.00489700f, 0.04803646f, 0.23355627f, 
    -0.01149500f, -0.09815823f, -0.14407752f, -0.17769168f, -0.83257329f, -0.11777582f, -0.19705547f, -0.03438664f, 
    -0.03044465f, -0.13185865f, -0.04745958f, 0.15769978f, 0.00100184f, 0.15387119f, -0.01505293f, 0.18046883f, 
    -0.08527482f, 0.00045443f, -0.24240108f, 0.00204666f, 0.05339469f, 0.00727978f, -0.03341030f, 0.01231507f, 
    1.42781138f, -0.19093449f, -0.32993928f, 0.01369857f, -0.26303875f, -0.13246885f, 0.00861418f, -0.00825027f, 
    -0.13217686f, 0.00672914f, 0.22735339f, -0.14094594f, -0.00939629f, -0.16240853f, -0.05314716f, 0.03055121f, 
    -0.01483399f, -0.18540950f, -0.02086698f, 0.07317411f, 0.12407403f, 0.06628855f, -0.10334681f, -0.11104759f, 
    -0.04063519f, 0.11930822f, -0.11712340f, 0.07637152f, -0.10804226f, -0.03816951f, -0.14885148f, 0.19388695f, 
    -0.14212462f, 0.01170627f, 0.08996811f, 0.00057041f, -0.06860564f, 0.08049902f, 0.01051791f, -0.11680807f, 
    -0.19100916f, -0.02903248f, 0.16414492f, 0.03919069f, 0.13190265f, -0.14321917f, 0.07278748f, 0.22761792f, 
    -0.11440260f, 0.15600798f, 0.13946997f, -0.05990225f, 0.10541293f, 0.13777575f, -0.12416489f, 0.04868525f, 
    0.37934655f, -0.06027520f, 0.04218073f, -0.02241152f, -0.43178505f, 0.20197125f, -0.00422104f, 0.17917296f, 
    0.20658609f, 0.11427803f, 0.02702279f, 0.16056491f, -0.12353428f, -0.07590545f, 0.00200085f, -0.05933441f, 
    0.04540586f, 0.09182420f, 0.05625196f, 0.06777394f, -0.01363734f, 0.02602491f, -0.23766530f, -0.05127187f, 
    -0.27977991f, 0.30728284f, -0.06736282f, 0.16709508f, 0.33966362f, -0.01581058f, -0.18827045f, -0.08597153f, 
    0.15330282f, -0.10526863f, -0.01361256f, 0.06562285f, 0.04233098f, -0.07956342f, 0.01719508f, 0.01903530f, 
    0.05462391f, 0.11041540f, -0.20497228f, 0.08238129f, -0.07118553f, -0.04226412f, -0.25763810f, -0.12977602f, 
    -0.09572428f, 0.02608752f, 0.06670725f, 0.11150555f, 0.09430802f, -0.05504961f, 0.21204148f, 0.08413590f, 
    -0.00301951f, 0.08541190f, 0.01701476f, -0.02894754f, 0.03284236f, 0.05300503f, -0.03587680f, 0.02226532f, 
    -0.32352307f, 0.09141450f, -0.60452104f, -0.48866722f, -0.46380445f, -0.13686365f, -0.04114259f, -0.16580056f, 
    -0.13047026f, -0.00535244f, -0.02717856f, 0.03540493f, 0.02759314f, -0.00135258f, 0.03609069f, 0.01183761f, 
    -0.05717136f, -0.13913864f, -0.25044000f, -0.39708915f, 0.12700675f, 0.23762108f, 0.14802313f, 0.12289906f, 
    0.02270268f, 0.03915939f, -0.17374671f, 0.11215903f, 0.00035856f, 0.15793537f, 0.02216746f, 0.03434538f, 
    0.01326472f, -0.07727589f, 0.07427329f, -0.13830201f, 0.06785479f, 0.16506626f, -0.09973954f, 0.14544135f, 
    0.26869631f, -0.03136890f, 0.22750463f, 0.09611332f, -0.22911374f, 0.04243213f, -0.04913661f, -0.03342316f, 
    -0.07342079f, -0.03685221f, -0.02633145f, 0.03243733f, 0.04892605f, 0.08061853f, -0.06381119f, 0.11969966f, 
    0.02311425f, 0.02365787f, 0.09005734f, 0.02385137f, -0.00768187f, 0.06660417f, 0.10034199f, 0.09152008f, 
    0.22695999f, 0.19256656f, -0.06396417f, 0.26488891f, 0.24771212f, -0.07590821f, 0.19732906f, -0.07524384f, 
    0.01751790f, 0.08363149f, -0.07964718f, -0.00004494f, 0.01683404f, 0.09343235f, 0.02110289f, -0.13949718f, 
    -0.05359205f, -0.06450225f, -0.09495626f, -0.05652603f, -0.05973101f, 0.04570091f, 0.00817755f, -0.01454344f, 
    0.02244932f, 0.01701524f, 0.00013187f, -0.01085499f, 0.04708792f, 0.14962162f, 0.07332820f, -0.04960456f, 
    0.01965841f, -0.15637811f, -0.00317479f, 0.04105831f, 0.50624746f, 0.35982576f, -0.67746025f, -0.09055185f, 
    -0.11409101f, -0.06183241f, 0.08498405f, -0.31568837f, -0.00745875f, 0.17815940f, 0.02931980f, 0.06835963f, 
    -0.09280334f, 0.09875423f, -0.05608565f, -0.09102394f, -0.05349497f, 0.12048392f, 0.12707412f, 0.17185645f, 
    0.16032518f, -0.38210198f, 0.17370997f, 0.10281209f, -0.10738022f, -0.05620814f, 0.03373907f, -0.00603165f, 
    -0.02275709f, -0.01593957f, 0.14128020f, -0.33976197f, 0.06231333f, -0.07788967f, 0.05703387f, 0.07056947f, 
    0.01638362f, -0.03940855f, -0.00619090f, -0.03146049f, 0.09101541f, 0.03302897f, 0.07399830f, -0.11432366f, 
    0.05084640f, 0.01862094f, -0.08801512f, -0.20349188f, 0.03949678f, -0.00891918f, -0.02975766f, -0.04908770f, 
    0.04776868f, 0.03799981f, 0.04174903f, -0.00181683f, -0.07025811f, -0.08814599f, 0.07112967f, -0.04253494f, 
    0.19273964f, -1.09893584f, -0.10733613f, -0.63270640f, 0.40495214f, -0.08612033f, -0.04590650f, -0.11129531f, 
    -0.10337318f, 0.01656987f, 0.03118750f, 0.10544369f, -0.02716062f, -0.02191910f, -0.02286845f, -0.15026772f, 
    -0.42864782f, -0.12198084f, -0.00433989f, -0.44429135f, 0.14190796f, 0.04951876f, -0.10554259f, 0.04436795f, 
    -0.52874947f, 0.14358591f, 0.01402340f, 0.00464879f, -0.05703017f, -0.03766489f, 0.05400582f, 0.01910031f, 
    0.07640213f, 0.01746241f, 0.02236494f, -0.43241671f, -0.29202443f, -0.31596053f, -0.19572002f, -0.00136131f, 
    0.07359102f, -0.02923517f, 0.05431066f, 0.00885754f, 0.04632426f, -0.10521827f, 0.02950194f, 0.01884085f, 
    -0.09113237f, 0.07896707f, 0.21054624f, 0.06025670f, 0.00348233f, 0.05350376f, -0.07449906f, -0.13520700f, 
    -0.04526968f, 0.06036610f, 0.09771630f, 0.15403664f, -0.83933115f, -0.21433994f, 0.02433438f, -0.18418190f, 
    -0.29065254f, 0.04787678f, 0.01302695f, -0.01760039f, -0.07561284f, -0.13297981f, 0.05577638f, -0.03058079f, 
    -0.16050202f, 0.04261754f, 0.09060206f, 0.08697870f, -0.06179069f, -0.24370913f, 0.05718010f, -0.01055740f, 
    -0.00533308f, 0.50752544f, 0.17848477f, 0.11229160f, 0.37136242f, -0.15754406f, 0.06028862f, 0.20647694f, 
    -0.08517767f, 0.23030804f, 0.05695416f, 0.09647243f, 0.11379831f, 0.01082033f, 0.11087842f, -0.01095144f, 
    0.00252600f, 0.05594020f, -0.03665608f, -0.00578278f, -0.09889112f, -0.37002924f, 0.13170850f, -0.04436613f, 
    0.04505101f, -0.00077161f, -0.00326128f, 0.03318576f, 0.00484284f, 0.06287307f, -0.12262677f, -0.05319891f, 
    -0.14015745f, -0.00682565f, 0.08262352f, 0.08499767f, 0.03348309f, -0.01243842f, 0.09972211f, -0.07973875f, 
    -0.01763136f, -0.00795849f, 0.35666049f, 0.31265238f, 0.12874582f, 0.03190762f, -0.13442640f, 0.13129784f, 
    0.19252352f, -0.22512437f, 0.05319406f, 0.10838339f, 0.05313129f, 0.02613461f, 0.02237443f, -0.00038486f, 
    -0.06448980f, 0.02213751f, 0.03719050f, 0.00991051f, 0.08873428f, -0.29495031f, -0.56812149f, -0.15245676f, 
    -0.38923016f, 0.07602715f, -0.03811904f, -0.15334776f, 0.08907029f, -0.20726123f, 0.00747615f, 0.01978619f, 
    -0.01903627f, 0.00950286f, -0.04764862f, 0.05389245f, 0.02393583f, -0.03582170f, 0.04805483f, 0.00436338f, 
    -0.34551400f, 0.03225155f, -0.16014433f, -0.26311365f, -0.33265775f, 0.01016287f, 0.06668269f, 0.01841745f, 
    -0.01788343f, 0.11729351f, -0.01738874f, 0.12995711f, -0.07669474f, 0.03494706f, -0.07647292f, 0.07397214f, 
    0.06819022f, 0.17802291f, 0.06729420f, -0.03601671f, -0.10572820f, -0.09856261f, -0.01065477f, -0.32953784f, 
    -0.09448320f, 0.05650127f, -0.02339950f, -0.01375874f, -0.02192496f, 0.05709751f, -0.01568794f, 0.06955086f, 
    -0.14400402f, 0.04085475f, 0.06078495f, 0.04173392f, -0.09433447f, -0.02407917f, 0.13083746f, 0.02495786f, 
    0.03707493f, -0.07180948f, -0.09141774f, -0.03824646f, 0.08748248f, 0.04137175f, -0.10893668f, -0.03658547f, 
    0.07755145f, 0.04146095f, 0.07759307f, -0.15592499f, -0.18305948f, 0.05067863f, 0.07542693f, 0.08481476f, 
    -0.09994430f, -0.13135800f, 0.04721588f, -0.07489705f, -0.10301024f, 0.30445796f, -0.15327942f, -0.00067504f, 
    0.07372475f, -0.23223558f, -0.07919927f, -0.19076747f, -0.21310572f, -0.11647584f, 0.09842903f, -0.07046085f, 
    0.09174573f, -0.09704472f, -0.10195911f, -0.11804430f, 0.08891215f, 0.03499249f, 0.08877362f, 0.00509985f, 
    -0.13485792f, 0.14390187f, 0.15034474f, -0.08270070f, 0.03882255f, -0.02260643f, -0.03654807f, -0.03253108f, 
    0.05554151f, -0.00936753f, -0.05328744f, -0.18456410f, -0.18635173f, 0.02857339f, 0.15207408f, 0.03992663f, 
    0.00473570f, -0.05418038f, 0.01668906f, -0.06245234f, -0.54904348f, -0.01570892f, -0.19274940f, -0.76139969f, 
    0.27020639f, 0.03680855f, 0.00127318f, -0.06408177f, 0.02406422f, 0.05750310f, -0.03490073f, 0.06283813f, 
    0.03260658f, -0.04057802f, -0.01002906f, -0.16580959f, 0.06355879f, -0.06425717f, 0.01747902f, -0.03546133f, 
    -0.30834165f, -0.02789791f, 0.05878229f, -0.03703716f, 0.01133987f, -0.08177520f, -0.05733293f, -0.07530481f, 
    -0.00369867f, 0.10233687f, 0.01263717f, 0.02418354f, 0.04389323f, 0.02169546f, -0.07880012f, -0.10984460f, 
    -0.17269264f, 0.02140978f, -0.08699495f, -0.03352705f, -0.32581347f, -0.52391082f, 0.68790323f, 0.52461243f, 
    0.23928200f, -0.08366378f, -0.01911996f, -0.10239834f, 0.13275424f, -0.01011815f, 0.00694099f, -0.01158677f, 
    0.05150054f, -0.02030830f, 0.00714065f, -0.04256136f, 0.01540857f, -0.03970443f, -0.09015413f, -0.06235212f, 
    0.40323600f, 0.10363685f, -0.00162648f, 0.25826335f, 0.28308403f, 0.06000685f, 0.03578800f, -0.05613530f, 
    0.10320763f, -0.21287304f, -0.07681911f, 0.01667656f, -0.08109625f, -0.11846532f, -0.02489091f, -0.04450173f, 
    0.05927740f, 0.04958871f, -0.06991012f, -0.00042711f, 0.66858107f, 0.11258681f, -0.28044996f, 0.14528772f, 
    0.26811352f, -0.15765245f, 0.12005714f, -0.20659855f, -0.01677982f, 0.03683148f, -0.00038372f, -0.04318525f, 
    -0.02764115f, 0.07269848f, -0.04928374f, 0.05402405f, 0.00000626f, 0.08285403f, -0.15399931f, 0.13125852f, 
    -0.39604563f, 0.43728843f, 0.92155886f, -0.15050226f, 0.10928836f, -0.06395400f, -0.05841079f, 0.01677701f, 
    -0.13766566f, 0.12019542f, 0.10888261f, 0.04782098f, -0.09682880f, -0.07851925f, 0.03768931f, 0.00821047f, 
    0.01462192f, 0.07802159f, 0.08947306f, -0.07609669f, -0.08019728f, 0.14441946f, -0.20681727f, -0.18141599f, 
    -0.02756522f, 0.04060368f, -0.26269150f, -0.15987982f, 0.08944912f, 0.04710252f, -0.03604648f, -0.22990671f, 
    -0.16105574f, 0.00575303f, -0.01228943f, 0.03006100f, -0.04230379f, 0.00172724f, 0.14541949f, -0.06703674f, 
    0.43307412f, 0.22329736f, -0.26578787f, -0.00472891f, 0.11771108f, -0.25772491f, 0.12526797f, -0.00175124f, 
    -0.05628039f, -0.04674159f, -0.09848695f, -0.09190840f, 0.03242289f, -0.00124706f, 0.05484413f, 0.13377863f, 
    -0.05639224f, -0.05530667f, 0.07192764f, -0.02093421f, -0.62770414f, -0.20094010f, -0.90699428f, -0.12248480f, 
    -0.29827392f, 0.08566071f, 0.03486518f, 0.04147760f, -0.06324077f, -0.08740109f, -0.05512893f, 0.01521287f, 
    0.04498639f, 0.06691563f, -0.02650408f, 0.00912279f, 0.00869146f, 0.00517183f, -0.10262088f, 0.01652758f, 
    -0.20190887f, -0.56208670f, -0.61181134f, 0.08437847f, -0.48462513f, -0.12720317f, 0.12832926f, 0.01841830f, 
    0.28467086f, 0.02785884f, -0.09417228f, -0.00680630f, 0.01598535f, 0.07883190f, -0.09555041f, -0.08054640f, 
    -0.04904955f, 0.06196089f, -0.44630772f, 0.04885712f, -0.07127189f, 0.20822874f, -0.07614004f, 0.04031195f, 
    0.07404988f, -0.00019870f, -0.05980021f, -0.10276406f, 0.04523259f, -0.36342484f, -0.01931825f, 0.04699494f, 
    0.03762655f, 0.03982577f, 0.01881538f, 0.02581024f, -0.01174865f, 0.03494715f, -0.02116719f, -0.08771208f, 
    -0.91999966f, 0.33576646f, 0.07673766f, 0.28064364f, -0.71205711f, -0.06544401f, -0.13090302f, -0.11213007f, 
    -0.21005124f, 0.00146905f, -0.01756620f, -0.02606671f, -0.03230984f, 0.01486248f, -0.06659670f, -0.17271069f, 
    0.06368117f, 0.05762407f, 0.02182077f, 0.13091677f, -0.25864974f, -0.60231739f, 0.03135562f, 0.24288480f, 
    -0.32979113f, -0.02168737f, 0.01041411f, 0.09212299f, 0.03280555f, -0.05115313f, -0.06155480f, 0.00825588f, 
    -0.00009141f, -0.00457127f, -0.06082113f, -0.05095851f, -0.02000227f, -0.03236068f, -0.09614033f, 0.06661455f, 
    -0.29554033f, -0.02708877f, 0.25551435f, -0.13035125f, -0.04968375f, 0.03983194f, -0.04672095f, -0.04865790f, 
    0.02154553f, 0.12703250f, -0.03332711f, 0.01650497f, 0.02319218f, 0.04681630f, 0.03348567f, 0.02966619f, 
    -0.15643950f, -0.10155594f, 0.11490326f, -0.02035892f, 0.44343033f, 0.06862810f, 0.01476395f, 0.22599426f, 
    0.14817631f, 0.13349149f, -0.15274554f, -0.03979477f, 0.07971654f, 0.01114333f, -0.05567822f, 0.02877804f, 
    0.06297898f, -0.02811366f, -0.02810064f, -0.02066892f, -0.00899379f, -0.06987388f, 0.07494207f, -0.08564760f, 
    -0.04538922f, -0.09287978f, 0.10085315f, -0.01606798f, 0.11139328f, 0.02249289f, -0.14082044f, -0.29031715f, 
    -0.01971000f, 0.10050684f, 0.02205509f, -0.18037346f, -0.02735983f, -0.00369203f, -0.06366153f, 0.08819482f, 
    -0.09910961f, -0.15222576f, -0.04022128f, -0.07201650f, -0.22959118f, 0.30668703f, -0.11623672f, 0.12879118f, 
    -0.60122591f, -0.21387587f, -0.03782131f, -0.26414454f, -0.10092637f, 0.00734159f, 0.05318158f, 0.02251915f, 
    -0.12489461f, 0.02676121f, 0.00371515f, 0.04614032f, 0.01863182f, -0.05121519f, 0.05365016f, -0.06951968f, 
    -0.02463846f, -0.05927986f, 0.49758133f, 0.07113895f, 0.20815539f, -0.05004342f, 0.10844962f, 0.11614642f, 
    -0.05203798f, -0.05429153f, 0.03893906f, 0.06056565f, 0.14943658f, -0.20316376f, 0.14088832f, -0.00498485f, 
    0.03252719f, 0.03675281f, 0.05115022f, -0.04267763f, -0.24588069f, -0.08354598f, 0.12142400f, -0.15702043f, 
    0.05492072f, -0.13193130f, -0.04132354f, -0.32857573f, 0.02608890f, 0.16387834f, 0.06965376f, -0.01662203f, 
    0.05382716f, 0.06009750f, -0.08933888f, 0.05848167f, -0.05524838f, -0.05058944f, -0.09670495f, -0.01133869f, 
    0.11850842f, 0.05805132f, -0.07753130f, 0.02088017f, 0.23303983f, 0.11718348f, -0.01313316f, -0.04188202f, 
    0.03741309f, -0.01709298f, -0.10656517f, 0.05683564f, 0.04102908f, -0.00498826f, -0.08154248f, 0.16589350f, 
    0.03537158f, -0.15313691f, 0.28627032f, 0.14431308f, -0.09485616f, -0.25982201f, 0.14609674f, 0.13372676f, 
    -0.33466595f, -0.09803026f, -0.19132292f, 0.02719499f, -0.05718942f, 0.09035438f, 0.00409840f, 0.00259221f, 
    0.00853660f, -0.08189781f, -0.04258556f, 0.12654836f, 0.13446084f, 0.13317201f, 0.15802388f, 0.13851848f, 
    0.05918902f, 0.12146507f, -0.04287894f, 0.01826409f, 0.14177753f, -0.07974507f, 0.08424043f, 0.04291740f, 
    0.04277287f, -0.00012303f, -0.00666504f, 0.08077761f, -0.20962763f, 0.11776237f, 0.05639218f, 0.04840837f, 
    -0.09613393f, 0.05849421f, 0.00583196f, 0.00474978f, 0.08285419f, -0.45612752f, 0.72170430f, 0.08615711f, 
    0.36805597f, -0.05287586f, -0.14571510f, 0.01549969f, -0.14509863f, -0.08965911f, 0.03066249f, 0.02587491f, 
    -0.12695813f, -0.05835540f, -0.00634629f, 0.15162666f, -0.01020226f, -0.08586154f, 0.04426783f, 0.05263999f, 
    0.12230375f, -0.08845534f, -0.18776312f, -0.06786381f, 0.26225275f, 0.07154643f, -0.03341961f, -0.07993685f, 
    -0.16288611f, -0.11673558f, -0.07018690f, 0.09158284f, -0.05248133f, -0.01586361f, 0.11449998f, -0.09027335f, 
    -0.02292181f, -0.01254126f, -0.04963664f, 0.00980802f, -0.11284564f, -0.21676546f, 0.00888004f, -0.03176391f, 
    -0.39543712f, 0.31668183f, 0.13455945f, 0.15601861f, 0.07284831f, 0.02011319f, -0.22398259f, -0.16814494f, 
    0.02916495f, -0.12115087f, -0.05546737f, -0.07248711f, -0.04102413f, -0.20070536f, -0.04660751f, 0.07465512f, 
    -0.19231687f, -0.20886464f, -0.24845402f, -0.02117560f, 0.40371549f, 0.25034204f, 0.06537646f, 0.01992012f, 
    0.04853702f, -0.09717754f, -0.07222144f, 0.04117463f, 0.07675828f, 0.13661283f, 0.03313268f, 0.02070105f, 
    -0.08149004f, 0.12150484f, 0.09379523f, 0.03009046f, 0.16288325f, -0.14382589f, -0.31264612f, -0.02426779f, 
    0.26684251f, 0.13294578f, 0.06326179f, 0.17206743f, 0.09338096f, 0.10964910f, 0.09645159f, -0.06025995f, 
    0.01516256f, -0.05575837f, -0.07200828f, -0.02044526f, -0.07521039f, 0.05031007f, 0.06315225f, 0.10723900f, 
    -0.93850332f, 0.15795994f, 0.02009721f, -0.06258772f, -0.12857020f, 0.15111047f, -0.14064035f, -0.04140147f, 
    -0.01746760f, -0.05592840f, -0.01538942f, 0.11552849f, -0.07024091f, 0.10449082f, -0.05335552f, -0.10984495f, 
    0.01165119f, -0.02600246f, -0.13395612f, 0.05206473f, -0.33101383f, -0.50586069f, -0.05194584f, 0.39770600f, 
    -0.30224669f, 0.27042884f, 0.16222851f, -0.08541705f, 0.14020258f, -0.08441332f, 0.08389105f, -0.04830532f, 
    0.04464330f, -0.06471260f, -0.08341186f, -0.03825868f, -0.03762927f, -0.07233258f, -0.02384012f, -0.11382214f, 
    -0.18339108f, -0.00515557f, -0.32793123f, 0.09111914f, -0.12445286f, -0.01934922f, -0.12529993f, 0.06647795f, 
    -0.16941038f, 0.05041816f, -0.09665506f, -0.09815924f, 0.08513665f, -0.00696571f, 0.02703386f, 0.10140587f, 
    0.05800033f, -0.05707691f, 0.04905112f, -0.05235330f, -1.00903106f, 0.19830227f, -0.42024523f, 0.43999654f, 
    -0.19143786f, 0.25101763f, -0.19846667f, 0.05220733f, -0.18142934f, -0.06799804f, 0.05210297f, -0.09657011f, 
    -0.13515067f, -0.29307386f, 0.07047630f, 0.19198954f, -0.00840792f, 0.15663466f, -0.15523210f, -0.37380201f, 
    -0.16910268f, -0.00268756f, -0.23063423f, 0.25215819f, 0.14972423f, 0.03904870f, -0.13111262f, -0.05299567f, 
    -0.16410913f, 0.02659233f, -0.02834597f, 0.00587618f, 0.13991620f, 0.05365662f, -0.15485330f, 0.16109851f, 
    0.05637047f, -0.03881107f, 0.04566270f, 0.02124653f, 0.43834743f, 0.07753351f, 0.86493635f, -0.55464274f, 
    0.27218068f, -0.28320146f, 0.04212340f, -0.11612234f, -0.14847368f, -0.06150226f, 0.27216226f, 0.05093383f, 
    0.18069080f, -0.05126620f, 0.05398052f, 0.02193725f, -0.13578430f, 0.04150977f, 0.03943999f, -0.18584244f, 
    -0.35903034f, -0.39443809f, -0.33476862f, -0.40772852f, -0.30591694f, -0.13917615f, -0.00007392f, 0.05116144f, 
    -0.06092821f, -0.06449465f, 0.11713185f, 0.18382232f, -0.11367817f, -0.04407340f, 0.13596638f, 0.08932932f, 
    0.07904749f, 0.16946450f, -0.18107007f, -0.20690362f, -0.08487577f, 0.05554126f, -0.22936709f, 0.01076391f, 
    0.37614712f, 0.13368231f, 0.04861132f, -0.11405506f, -0.07580490f, 0.03020762f, 0.06630028f, 0.17868455f, 
    0.01668484f, 0.10092381f, 0.18599184f, -0.05418499f, -0.03854274f, 0.10813707f, 0.00870779f, 0.16094802f, 
    -0.33432049f, 0.86583996f, 0.09474365f, -0.31880763f, -0.07155056f, 0.15269582f, 0.07282385f, -0.05759647f, 
    0.07045516f, -0.13287395f, -0.22281158f, -0.00091942f, -0.06594156f, -0.14005719f, -0.00044295f, -0.01137637f, 
    0.05075142f, -0.09557209f, 0.01470674f, -0.17380999f, -0.01970851f, 0.44430783f, -0.11747998f, -0.41237703f, 
    0.12742473f, 0.15940537f, 0.16318674f, -0.24423078f, -0.05369011f, -0.31550571f, -0.10607088f, 0.03061212f, 
    -0.08206058f, 0.02429990f, 0.03821628f, 0.19827504f, 0.03530966f, -0.11418056f, -0.09579747f, -0.12533839f, 
    -0.29947743f, 0.83772671f, 0.23089525f, 0.09563962f, 0.53018796f, 0.20447581f, 0.10787326f, 0.06899487f, 
    -0.24192913f, 0.04987530f, -0.08029889f, 0.01293963f, 0.17264536f, 0.08787268f, 0.15846434f, 0.01553599f, 
    -0.04865670f, 0.00757640f, 0.07689109f, 0.00651428f, -0.81866753f, -0.26618332f, -0.29462358f, 0.29404971f, 
    -0.26750335f, 0.06066949f, -0.01479937f, 0.13492982f, -0.19681002f, 0.01077813f, -0.26731965f, 0.16295359f, 
    -0.12464558f, 0.14070515f, -0.26103511f, 0.04060541f, -0.22276962f, 0.17563465f, -0.12668110f, -0.18185893f, 
    0.27555037f, 0.15968232f, -0.19071601f, -0.41971123f, -0.27304119f, -0.04895123f, -0.29319599f, 0.01240146f, 
    -0.13046029f, -0.07191671f, -0.03719926f, -0.01951885f, -0.04307665f, 0.11693228f, -0.02096719f, -0.01659750f, 
    -0.07828845f, -0.26015273f, -0.24390499f, -0.13090983f, 0.15277156f, -0.08845544f, -0.06986257f, 0.02246459f, 
    0.23556453f, 0.07448059f, 0.15373676f, -0.00848729f, 0.08160252f, 0.04297862f, 0.04809601f, -0.04796201f, 
    0.02540207f, -0.13782531f, -0.05073583f, -0.13957998f, -0.05461464f, 0.01371071f, -0.04521928f, 0.07469410f, 
    0.01652659f, -0.00671070f, -0.14035393f, -0.10865203f, 0.22043492f, -0.00026680f, 0.06665620f, -0.10134855f, 
    0.15507843f, -0.02912124f, -0.10644495f, 0.04625217f, 0.03886559f, -0.05862166f, -0.01280707f, -0.12667571f, 
    0.00280734f, 0.16696055f, -0.19890881f, -0.02974389f, -0.48993436f, -0.18197237f, 0.13725413f, -0.09086531f, 
    0.38459045f, 0.08525769f, 0.05158865f, 0.04400948f, 0.01270043f, 0.12633339f, -0.21411125f, -0.01563902f, 
    -0.03359351f, 0.13630065f, -0.19727211f, 0.11103692f, 0.05421901f, 0.25584823f, -0.10241547f, 0.01468637f, 
    -0.49877498f, -0.08655147f, -0.08402455f, 0.34505528f, 0.29684034f, -0.06811433f, 0.06608902f, 0.10660646f, 
    -0.05344847f, 0.02584897f, 0.05030176f, 0.08525649f, -0.04121277f, -0.12806588f, 0.09400351f, -0.06918129f, 
    -0.01288743f, 0.00782490f, -0.04371933f, -0.15073727f, 0.09214819f, -0.13604730f, -0.21862605f, 0.03936129f, 
    0.23658061f, -0.04836343f, 0.06655455f, -0.00215883f, 0.00405162f, 0.09355787f, -0.00814987f, -0.00251439f, 
    0.01383165f, -0.10578674f, -0.02633781f, -0.03226003f, -0.06077302f, 0.04607445f, -0.03512961f, -0.04465745f, 
    -0.29733112f, -0.07121169f, 0.52860695f, 0.41046134f, 0.46104017f, -0.08571099f, -0.04337666f, -0.24761617f, 
    -0.01149261f, -0.26422781f, -0.02689855f, -0.10143440f, -0.03388994f, -0.06482185f, -0.00986707f, -0.14298329f, 
    -0.01202031f, -0.00237174f, -0.05119423f, 0.01574589f, -0.52841407f, 0.48513889f, -0.32215452f, -0.09571784f, 
    0.16365817f, 0.12620093f, 0.02188070f, -0.13563277f, 0.03016838f, -0.11864734f, -0.36775666f, 0.02953379f, 
    -0.23287916f, -0.10030859f, 0.01846562f, -0.18457285f, -0.21919969f, 0.04087219f, 0.01074315f, -0.10562836f, 
    -0.21537961f, 0.18816295f, 0.32870597f, -0.00758330f, 0.28220272f, 0.06998096f, 0.06379288f, 0.04426433f, 
    0.08049297f, 0.06814356f, -0.07840847f, 0.04847069f, -0.15116702f, -0.16685800f, 0.09593604f, 0.00584044f, 
    -0.03014232f, 0.01743390f, 0.10257404f, -0.12125657f, -0.52855229f, -0.06267433f, -0.16833507f, 0.22530201f, 
    0.03097407f, -0.14637053f, 0.03253334f, 0.24270928f, -0.24761665f, -0.02638772f, -0.03957034f, 0.00723239f, 
    0.12648001f, 0.00497816f, -0.22173359f, 0.02367430f, -0.09967302f, 0.19142020f, -0.05146357f, -0.10204309f, 
    -0.49113503f, 0.99306411f, -0.01823441f, -0.13685542f, 0.11409906f, 0.28434741f, 0.06601115f, 0.10783812f, 
    -0.12029892f, 0.00887684f, -0.16790482f, -0.11724835f, -0.00151253f, -0.14838323f, 0.04499595f, -0.14436103f, 
    0.09127533f, -0.16012022f, 0.02719715f, -0.01303334f, -0.15028739f, -0.11828028f, 0.37264401f, -0.09950151f, 
    0.16996334f, -0.11429320f, 0.02739831f, 0.07157464f, 0.09815346f, -0.02440323f, 0.14918663f, 0.06125568f, 
    -0.16340435f, -0.03945923f, 0.10562099f, 0.00300874f, -0.01076198f, -0.07325222f, -0.16499658f, -0.07187983f, 
    0.59913307f, 0.50399011f, -0.05949925f, -0.45870221f, -0.00661646f, 0.06008828f, 0.21230765f, 0.04913989f, 
    -0.18972972f, 0.33303931f, 0.00088927f, -0.02830333f, 0.34820327f, 0.04531458f, 0.04875185f, -0.08377012f, 
    0.11483422f, 0.08494322f, 0.19893239f, 0.05102976f, 0.05560835f, -0.10474239f, -0.22882472f, 0.29142907f, 
    0.32224169f, -0.10676660f, 0.06812216f, 0.00948480f, 0.13122752f, 0.09932107f, -0.07700247f, -0.01650134f, 
    0.04871582f, -0.09797730f, -0.03671478f, -0.02114247f, 0.02007029f, -0.13268076f, 0.13541149f, 0.02953603f, 
    -0.04914149f, -0.14011061f, -0.18157439f, -0.29217914f, -0.09260040f, -0.07872474f, -0.20729190f, 0.01029420f, 
    -0.03180943f, -0.13980356f, -0.03982790f, -0.00392930f, -0.18920785f, -0.14682215f, -0.07615928f, 0.00112428f, 
    -0.07211303f, 0.01040341f, 0.12455817f, 0.08307315f, 0.75066972f, -0.21905951f, -0.47876531f, 0.17030291f, 
    0.09938321f, 0.30718884f, 0.03910731f, 0.12588003f, -0.07030775f, -0.07107854f, -0.24659437f, -0.14931780f, 
    0.10606259f, -0.05691491f, 0.11340480f, -0.15783878f, 0.15120579f, -0.06780379f, 0.15171997f, 0.12999398f, 
    -0.10520772f, -0.02794613f, 0.18519494f, -0.18834774f, 0.11210183f, -0.18136027f, 0.10091707f, 0.03231359f, 
    0.08668005f, -0.08184655f, 0.12627167f, -0.08124918f, -0.05530689f, -0.00882707f, -0.04681697f, 0.00001080f, 
    -0.02872847f, -0.07326928f, -0.04007066f, -0.04175412f, 0.17975371f, 0.24519955f, -0.07964136f, -0.05984844f, 
    -0.07716396f, 0.11086843f, 0.04261102f, 0.01894559f, 0.08152726f, 0.12456160f, 0.01331278f, 0.00549604f, 
    0.02925649f, -0.14905761f, 0.04676680f, 0.05985717f, 0.03432877f, 0.04574860f, -0.12793720f, 0.15061730f, 
    0.22211418f, 0.02341451f, 0.17474118f, 0.17590629f, 0.06760454f, -0.12314913f, -0.12748903f, -0.18226840f, 
    -0.05352356f, 0.07475025f, 0.10372726f, -0.04532037f, 0.04737392f, 0.05034274f, 0.02490232f, 0.07235231f, 
    0.05233730f, 0.00795649f, -0.07390012f, -0.04515928f, 0.09937140f, 0.25624070f, 0.35827422f, 0.32044074f, 
    0.21993497f, -0.09427512f, -0.11044073f, -0.01487698f, -0.15563895f, 0.25445339f, -0.02384425f, 0.03742468f, 
    0.07145458f, 0.01431736f, 0.02006316f, 0.00291530f, -0.06187161f, -0.01297353f, -0.09329133f, -0.16879599f, 
    0.01284949f, -0.00901758f, -0.12772571f, -0.66736245f, -0.55380732f, 0.04784219f, 0.04143192f, -0.01566617f, 
    0.14748618f, 0.08460241f, 0.06988411f, 0.07956284f, 0.00322292f, -0.02150613f, -0.06908333f, -0.00858504f, 
    0.00780416f, -0.16219874f, 0.08352467f, 0.15808953f, -0.13877545f, 0.16961138f, -0.02084857f, -0.28893149f, 
    -0.09793440f, 0.04166217f, 0.05922711f, 0.04235353f, 0.01608739f, 0.09603684f, 0.04868634f, 0.04789048f, 
    0.08980553f, 0.00259850f, -0.12994617f, -0.16117300f, 0.05285352f, -0.00607915f, -0.12780879f, 0.13988636f, 
    0.07023719f, 0.02193398f, 0.10707646f, 0.00328506f, -0.08360125f, -0.01531903f, -0.02935714f, 0.11760360f, 
    -0.03424795f, 0.01136131f, 0.02655045f, -0.27335560f, 0.13714437f, -0.07012447f, -0.11796979f, 0.09356228f, 
    -0.03451855f, -0.01122707f, -0.13452643f, -0.13838242f, 0.25372583f, -0.24639419f, 0.06198566f, -0.24899620f, 
    0.27672291f, 0.14766558f, 0.14395404f, 0.05450313f, 0.03429384f, -0.14258759f, -0.13112359f, 0.05728507f, 
    -0.11244159f, 0.04351231f, 0.09733476f, -0.15769221f, -0.23560210f, -0.16226262f, -0.20064561f, -0.27053240f, 
    0.01642914f, 0.00280787f, -0.03643097f, -0.06004377f, 0.01932572f, 0.03188546f, -0.02665878f, 0.12676346f, 
    -0.01802430f, -0.00002998f, 0.07022535f, -0.18762799f, -0.01760199f, 0.08885538f, -0.01039809f, 0.05849909f, 
    0.09487931f, -0.13336658f, -0.11228414f, -0.01834343f, 0.89842111f, -0.17254300f, -0.38132688f, 0.56928718f, 
    0.03238694f, -0.01823103f, 0.06749250f, 0.07930723f, 0.09501818f, 0.12428068f, 0.12407704f, -0.01817428f, 
    -0.05064758f, 0.04668523f, 0.07766923f, 0.12256590f, 0.14576671f, 0.19123435f, -0.04341426f, -0.10835969f, 
    0.01013785f, -0.00724080f, 0.01427840f, 0.06738850f, 0.16466707f, 0.04725467f, 0.09681904f, 0.09488742f, 
    -0.00573624f, 0.05062726f, 0.09208693f, 0.05900317f, -0.02220421f, -0.08076878f, 0.05363636f, -0.05626303f, 
    -0.01670214f, -0.02844480f, 0.00410649f, 0.05555434f, -0.00362800f, -0.03888144f, 0.10902725f, 0.24323517f, 
    0.10257255f, -0.23854199f, -0.02729456f, -0.05660959f, -0.26765156f, -0.16257346f, -0.08283538f, -0.00412826f, 
    0.03242004f, 0.02305958f, -0.00151858f, -0.00954657f, 0.05053136f, -0.01435203f, 0.01579335f, 0.02176617f, 
    -0.02537335f, -0.76875025f, -0.37927914f, 0.11579285f, -0.16135202f, -0.03797791f, 0.03796836f, 0.09996828f, 
    -0.22373667f, 0.09338715f, -0.19139798f, 0.03933572f, -0.01043138f, -0.04793681f, -0.24276327f, -0.13092110f, 
    -0.17984158f, 0.01305968f, 0.09193134f, 0.08882581f, -0.13514505f, -0.23065683f, -0.06651898f, -0.03222174f, 
    0.07362950f, -0.38776228f, -0.21776590f, 0.02042235f, -0.05631661f, -0.02206099f, -0.06504752f, -0.07811665f, 
    0.02645721f, -0.00576731f, -0.01306594f, -0.11172798f, -0.14524451f, 0.00710620f, -0.00084080f, 0.01555866f, 
    -0.44462454f, -0.49499315f, 0.15506960f, 0.00907143f, -0.03517261f, -0.20666067f, -0.03142884f, -0.16845530f, 
    0.02249187f, -0.11814450f, -0.05128164f, -0.17270127f, -0.20065619f, 0.23777384f, -0.03481253f, 0.03431084f, 
    0.07973006f, 0.00134076f, 0.01656174f, -0.11145647f, 0.18735451f, -0.03248861f, 0.17749843f, -0.10656684f, 
    -0.07148036f, 0.19631301f, 0.01040395f, 0.03038605f, -0.04118272f, -0.13141145f, 0.03055468f, -0.00905352f, 
    -0.01862356f, -0.00255954f, -0.05226602f, 0.14734447f, -0.10114536f, 0.01923039f, -0.22172485f, -0.13248132f, 
    -0.17927755f, -0.04324415f, -0.10442088f, -0.27229482f, -0.17368263f, 0.05868520f, -0.12023063f, -0.14662893f, 
    0.13435961f, -0.17916919f, -0.10153543f, -0.19038554f, -0.04015969f, -0.24878812f, 0.17269336f, -0.12534063f, 
    -0.42070317f, 0.08130014f, -0.18474600f, -0.25988239f, 0.15547675f, 0.18348843f, 0.36870807f, 0.22438040f, 
    0.23967572f, -0.19150011f, -0.14121193f, -0.05813402f, 0.07591358f, 0.09185301f, 0.07679460f, -0.01224686f, 
    -0.00567859f, 0.04403694f, -0.03422706f, -0.00220165f, 0.01327450f, -0.11133420f, -0.02312501f, -0.16079773f, 
    -0.13178369f, -0.10270919f, 0.01727339f, 0.28563368f, 0.05447121f, -0.19339095f, -0.09506214f, -0.03945811f, 
    -0.23025848f, 0.09933141f, 0.03104823f, 0.00087996f, -0.00349989f, 0.10743734f, 0.08207624f, 0.01849057f, 
    0.03286725f, -0.07840132f, 0.20513469f, 0.08611456f, 0.25090587f, -0.02882018f, 0.18242098f, -0.01347317f, 
    -0.03084738f, 0.04659116f, -0.07450239f, -0.07773204f, -0.11382264f, -0.08514655f, 0.09263093f, -0.05589302f, 
    0.02581478f, -0.02045114f, -0.00555043f, 0.06352988f, -0.07168987f, -0.10917635f, -0.03953771f, -0.07742415f, 
    0.31203327f, 0.10078232f, 0.38195097f, 0.03683154f, 0.27772605f, 0.01293530f, 0.30047256f, 0.12006120f, 
    0.21941406f, 0.08736318f, -0.04942159f, -0.06251958f, -0.00879177f, -0.00293922f, -0.05240368f, 0.08198293f, 
    0.12726577f, -0.21983241f, 0.07242125f, 0.26238754f, -0.09449010f, 0.05545510f, 0.17602165f, 0.10628308f, 
    0.10139797f, -0.15871215f, 0.09085302f, -0.07569139f, -0.07890189f, 0.08405200f, -0.03667879f, 0.01753606f, 
    0.00805925f, 0.06499638f, -0.02870253f, 0.06359073f, 0.09866491f, -0.11389264f, 0.00059356f, 0.05917837f, 
    -0.34319362f, -0.07787847f, -0.38995636f, -0.18158694f, 0.20979512f, 0.05681951f, -0.00140632f, 0.01264087f, 
    -0.02300841f, 0.06185853f, 0.04602948f, -0.03051225f, 0.11592628f, -0.00833417f, -0.03426697f, -0.09824067f, 
    -0.09756992f, 0.06314006f, -0.11588628f, 0.02339867f, 0.18789791f, -0.22921887f, -0.01583995f, -0.06934930f, 
    -0.15549769f, -0.08498590f, -0.28699651f, -0.03569677f, -0.21984434f, -0.04340830f, -0.21710260f, -0.01804785f, 
    0.03682993f, 0.01884871f, -0.03597127f, 0.02521987f, -0.13213444f, 0.09383004f, -0.17974971f, -0.06961816f, 
    0.06643910f, 0.10050636f, -0.00303938f, -0.01645294f, 0.05800924f, 0.17148325f, 0.15012436f, 0.10265330f, 
    -0.04675959f, 0.10118152f, 0.09039761f, 0.03001868f, 0.20734935f, -0.05741853f, 0.07329091f, 0.01769827f, 
    -0.04312760f, -0.08642114f, -0.10024557f, -0.08811031f, 0.24246748f, -0.11127219f, 0.33682612f, -0.16767359f, 
    0.04489643f, 0.02844628f, 0.06393286f, 0.15614899f, -0.01766532f, -0.19477114f, -0.01981325f, 0.03401793f, 
    -0.07747776f, -0.12406779f, -0.09303661f, 0.05972695f, 0.01091370f, -0.34923351f, -0.20841222f, -0.02660215f, 
    -0.20050061f, -0.38650355f, 0.11570697f, -0.18825932f, -0.00487972f, -0.25201318f, -0.11809498f, -0.06558266f, 
    0.07567297f, 0.06805486f, -0.05980554f, -0.07689416f, -0.14299114f, -0.03005445f, -0.02896956f, -0.02295240f, 
    0.03942946f, 0.04227969f, -0.04932085f, -0.04145293f, -0.06515300f, 0.02561302f, -0.06428217f, 0.14954610f, 
    0.15702672f, 0.08051343f, 0.18500161f, -0.00554698f, -0.05940665f, 0.12273263f, 0.04482434f, 0.05764886f, 
    -0.02007231f, -0.01955684f, 0.00262761f, 0.00495915f, -0.00497895f, -0.18024617f, -0.01779654f, -0.01361091f, 
    -0.06984165f, -0.33848774f, -0.07233559f, 0.29445246f, -0.39602423f, 0.11175793f, -0.00587315f, 0.10637401f, 
    -0.15214255f, -0.01157217f, 0.04770748f, -0.10319464f, -0.07886589f, 0.03060490f, -0.04053632f, 0.07388736f, 
    0.30043480f, 0.06202958f, -0.21164274f, 0.41621912f, -0.16241403f, 0.11229948f, 0.26282778f, -0.13059294f, 
    0.07047769f, -0.07352481f, 0.12711929f, -0.07324131f, 0.00283419f, 0.06278262f, -0.05054458f, -0.02111321f, 
    -0.03838710f, 0.10963015f, -0.09598368f, -0.06013642f, 0.08898526f, 0.02779107f, -0.01885662f, 0.21495987f, 
    0.03347693f, -0.06148023f, 0.02716547f, -0.13911147f, 0.00985935f, 0.07725322f, -0.00554386f, -0.01562551f, 
    0.06377141f, 0.03796137f, 0.04517868f, -0.22936668f, -0.00658524f, -0.07767474f, 0.07142235f, 0.01064261f, 
    -0.09643973f, 0.01743105f, -0.18737125f, -0.09408319f, 0.19191512f, -0.40063715f, 0.17593352f, 0.16530858f, 
    -0.00914779f, -0.13169643f, -0.19375820f, -0.14693977f, 0.19307671f, 0.24201545f, 0.00759589f, 0.04467402f, 
    -0.12324789f, -0.04145458f, -0.03159215f, 0.03344390f, -0.04915202f, 0.13282171f, -0.11817387f, 0.04292565f, 
    0.35266393f, -0.37115854f, -0.19477834f, 0.03376946f, -0.22170961f, 0.03032285f, 0.04226896f, -0.07272774f, 
    0.11722659f, 0.31720617f, -0.02041147f, -0.04754940f, -0.01010633f, 0.01541850f, -0.12616558f, -0.15317748f, 
    0.05732055f, -0.01207393f, 0.03554966f, 0.12595259f, -0.04508463f, -0.13966486f, -0.30382782f, -0.00307567f, 
    0.21279895f, -0.00463991f, 0.03251934f, -0.14728580f, -0.04802769f, 0.00260106f, 0.13860589f, -0.09931188f, 
    0.00545634f, 0.12938063f, 0.16367294f, -0.19621615f, 0.04187254f, 0.20063393f, 0.12318783f, -0.12585776f, 
    -0.54138768f, -0.03160498f, -0.16046028f, -0.29036126f, -0.17660119f, 0.11131322f, 0.00918750f, 0.02219932f, 
    -0.09938398f, 0.07025243f, 0.11547247f, 0.07913262f, -0.03907720f, -0.09861984f, -0.05851731f, -0.00474274f, 
    0.00830637f, 0.03020572f, 0.00405111f, 0.09825017f, 0.01356997f, 0.03573674f, 0.39463854f, -0.12397434f, 
    -0.16857502f, 0.22723171f, 0.06577051f, 0.13402566f, -0.12542759f, -0.20055650f, 0.03284087f, -0.04542754f, 
    -0.09445439f, -0.04875078f, 0.09567809f, 0.01564848f, 0.03547427f, 0.02699498f, 0.03516253f, 0.21710400f, 
    0.08839333f, -0.17693830f, -0.07182653f, -0.43507227f, 0.39455947f, 0.05455196f, 0.06580222f, -0.07253151f, 
    -0.03461892f, -0.07552189f, 0.03946066f, -0.03867747f, 0.11679637f, 0.05585076f, 0.12274952f, -0.03809647f, 
    -0.02845076f, 0.01649018f, 0.16756143f, -0.08617017f, 0.28599924f, -0.02428467f, -0.21779692f, -0.18781412f, 
    0.16301081f, -0.01643459f, 0.07237702f, -0.08513588f, -0.00684724f, -0.04989466f, 0.22631122f, -0.19763915f, 
    -0.10644875f, -0.00283061f, 0.04976187f, -0.12534247f, 0.02315038f, -0.11181892f, 0.03028754f, -0.00446041f, 
    0.09711570f, 0.08725441f, -0.04609334f, -0.15504023f, 0.10629261f, 0.14408703f, 0.03846844f, 0.09523354f, 
    -0.03462647f, -0.14611921f, 0.12345655f, 0.01372611f, 0.17706926f, 0.08746008f, 0.00262933f, 0.12411354f, 
    -0.03260145f, 0.11939158f, -0.05494413f, -0.14297892f, 0.39175251f, -0.38380075f, 0.15520044f, -0.08707677f, 
    -0.03348349f, -0.04134440f, -0.16561291f, -0.11818657f, 0.01396852f, 0.18403934f, 0.11820111f, 0.14315340f, 
    -0.20458871f, -0.12366369f, -0.06769914f, 0.13366127f, -0.09703962f, -0.13379538f, 0.13341221f, 0.43476966f, 
    -0.24652955f, -0.04213842f, -0.30201235f, -0.22230099f, 0.07566779f, 0.16515268f, 0.10590903f, 0.04144287f, 
    -0.13094693f, 0.01657913f, 0.08195295f, -0.03460498f, -0.05580225f, -0.05498042f, 0.07658041f, -0.02442622f, 
    0.02863005f, 0.11746804f, 0.04414401f, -0.05577567f, -1.19446898f, -0.11926673f, 0.13696647f, 0.28811699f, 
    -0.24575755f, 0.18892394f, 0.06821909f, -0.04915755f, 0.09151100f, 0.09957119f, -0.06694536f, 0.04606549f, 
    0.02169000f, 0.02785032f, -0.08276504f, 0.02175873f, -0.08928809f, 0.15787959f, -0.15508407f, -0.10680269f, 
    -0.11785664f, -0.08113365f, 0.00529142f, 0.11258958f, 0.00482683f, 0.06113545f, -0.08024372f, -0.01581953f, 
    -0.04213706f, -0.00787577f, -0.05910375f, -0.10940120f, -0.00022788f, -0.13551205f, 0.03971094f, 0.03961248f, 
    0.03144877f, -0.07114901f, -0.06682996f, -0.01357633f, -0.47689638f, 0.02210242f, -0.04808756f, -0.23748899f, 
    -0.25931981f, 0.04042824f, -0.09953235f, 0.03156444f, -0.09020744f, 0.21608815f, 0.03736017f, -0.00567366f, 
    -0.07323478f, 0.10273682f, 0.00738948f, -0.06379798f, -0.07897002f, 0.10269854f, 0.01084527f, 0.05275951f, 
    -0.21491548f, -0.14585519f, 0.18294871f, 0.11602096f, -0.11797510f, 0.07746308f, 0.03757656f, -0.03335616f, 
    0.09897088f, 0.02614645f, -0.03703921f, -0.14656211f, -0.21309613f, 0.03403969f, 0.16841300f, -0.08381864f, 
    -0.05002213f, 0.03970285f, 0.08877165f, -0.00056269f, -0.12889722f, -0.28286880f, -0.13629340f, 0.16356884f, 
    -0.27098185f, 0.29764590f, -0.02358560f, -0.07446232f, 0.05216589f, 0.13785191f, 0.02574128f, -0.15256667f, 
    -0.00882796f, -0.11579531f, 0.24005947f, 0.00830168f, 0.02528567f, 0.07837873f, -0.06381629f, 0.03696100f, 
    -0.65927893f, -0.18229385f, -0.28515339f, -0.53228736f, -0.02080208f, 0.08954836f, 0.07500836f, 0.01073034f, 
    -0.06574464f, -0.12387002f, -0.06116281f, 0.08733308f, 0.01105541f, -0.20695134f, 0.08053841f, -0.08022567f, 
    -0.10793313f, 0.08325134f, -0.02496224f, 0.01918557f, 0.12334912f, 0.02900683f, 0.03283777f, -0.12834221f, 
    0.05909682f, -0.24285342f, 0.24173349f, -0.06392380f, -0.04136596f, 0.01995730f, 0.33659294f, -0.20327057f, 
    0.21735480f, -0.03325954f, -0.03246448f, 0.07425212f, 0.05916818f, -0.03902639f, 0.27913973f, 0.15280247f, 
    0.07905388f, -0.52395236f, -0.22872688f, 0.39247653f, -0.03051583f, 0.26445332f, -0.16736226f, -0.28640378f, 
    0.14363326f, -0.06611519f, 0.06968734f, 0.14047512f, -0.03335573f, 0.09346443f, 0.09228496f, 0.21038631f, 
    -0.26973891f, 0.09046049f, 0.08423981f, 0.53716230f, 0.23616043f, -0.04553223f, 0.17652641f, 0.14485012f, 
    -0.25071853f, -0.04331630f, 0.12499332f, -0.04482239f, -0.11799132f, 0.04018738f, -0.00448789f, 0.01334556f, 
    -0.08844684f, -0.05010821f, -0.00074614f, -0.02243439f, 0.06049498f, 0.04512939f, 0.11706772f, 0.02045835f, 
    0.05646275f, -0.20526491f, 0.29115963f, 0.10582439f, -0.40315676f, 0.13321869f, 0.11947510f, 0.13641235f, 
    -0.13554877f, -0.10265639f, 0.08101940f, 0.04987859f, 0.01363819f, 0.00559687f, 0.09294098f, -0.00290399f, 
    -0.02884077f, -0.05297000f, -0.06467864f, -0.22162248f, 0.12000915f, 0.01865726f, 0.13795123f, -0.14770095f, 
    -0.07907061f, 0.00168640f, 0.01301278f, -0.02794845f, -0.22279520f, 0.09747244f, -0.11204704f, -0.04635943f, 
    0.01440688f, -0.10010853f, -0.08726241f, 0.08100566f, 0.09234318f, -0.01507361f, 0.09285580f, 0.13192761f, 
    0.44990420f, 0.03783963f, 0.42606914f, 0.15547945f, -0.28087211f, 0.08884247f, 0.07235376f, -0.01885873f, 
    0.07973230f, 0.20253935f, 0.04974968f, 0.03801872f, -0.08161018f, -0.03389708f, -0.02126404f, -0.17742084f, 
    -0.02086502f, -0.00450786f, -0.12536968f, 0.05477615f, -0.14390415f, 0.08172895f, 0.19691791f, 0.06748027f, 
    -0.09143502f, 0.19677551f, 0.06963006f, 0.05424337f, 0.06724305f, -0.25215408f, 0.07314350f, -0.00000367f, 
    -0.00319372f, 0.10451379f, 0.06674030f, 0.05063335f, -0.03855964f, -0.14858067f, -0.11574814f, -0.17702353f, 
    0.65559489f, 0.00251687f, -0.47848210f, -0.07711709f, 0.20728764f, 0.00838865f, 0.19836874f, 0.08658792f, 
    -0.06915711f, 0.02824752f, 0.11432093f, -0.02775979f, -0.04320486f, -0.07340479f, 0.01245318f, -0.00346608f, 
    0.09446210f, -0.04814336f, -0.10131249f, -0.07287861f, -0.46213335f, -0.26109654f, 0.26492527f, -0.10316946f, 
    -0.23052576f, -0.04523867f, 0.15072666f, -0.17306492f, 0.03141356f, 0.05544295f, 0.17190449f, 0.19570608f, 
    -0.02361293f, -0.11920303f, 0.21662399f, 0.10536747f, 0.06047425f, -0.07664742f, 0.09963425f, 0.25101560f, 
    0.10477842f, 0.08775752f, -0.02244353f, 0.02275887f, 0.16487873f, -0.08527297f, -0.14354394f, 0.09921348f, 
    -0.00092980f, -0.15308774f, -0.17707543f, -0.12945724f, -0.10977721f, -0.03860313f, -0.06784067f, 0.09610090f, 
    0.05459810f, 0.24300458f, -0.10377937f, 0.00444820f, 0.02243733f, 0.07014918f, 0.26423687f, -0.00623392f, 
    0.08380636f, -0.01463527f, 0.04485865f, -0.17037144f, 0.06726859f, -0.04598809f, 0.09353431f, -0.09538233f, 
    0.11648275f, 0.01058006f, 0.10092585f, 0.10632069f, -0.06217018f, -0.16253988f, 0.07758560f, -0.06592486f, 
    0.18280385f, -0.16066796f, -0.47306460f, -0.13015690f, 0.03241728f, 0.15864518f, -0.09314442f, -0.00971319f, 
    -0.12441438f, -0.03658439f, -0.14355347f, 0.34042126f, -0.10387239f, 0.12636892f, -0.00458519f, -0.10503135f, 
    -0.07422391f, 0.10771345f, -0.02205321f, 0.08693058f, -0.17965870f, 0.00211433f, -0.14632817f, 0.08327304f, 
    0.00079561f, 0.12898342f, -0.13051645f, 0.05339165f, 0.00919013f, -0.03264317f, -0.05774312f, -0.00361873f, 
    -0.01455645f, -0.07024426f, 0.02424064f, -0.00766182f, 0.02244557f, 0.14792880f, -0.09676862f, 0.09296138f, 
    -0.86741096f, 0.51886499f, 0.07861646f, 0.28723311f, -0.15749161f, 0.08236182f, -0.14421296f, -0.02633169f, 
    0.17304374f, -0.18091206f, 0.02989420f, -0.01110746f, 0.01811887f, 0.02682242f, 0.07990289f, -0.16412421f, 
    -0.03841360f, 0.03249857f, -0.26232138f, -0.26254129f, 0.23317805f, 0.24944668f, 0.07387291f, -0.10716511f, 
    0.23055185f, -0.02476302f, -0.19334453f, -0.04417697f, -0.05204419f, -0.16311185f, 0.02086580f, 0.05294077f, 
    0.05111128f, -0.03503606f, -0.00120283f, 0.13144554f, -0.01358127f, -0.38587081f, -0.07869536f, -0.46774960f, 
    0.03261310f, -0.28202039f, -0.13753125f, 0.19368216f, -0.02490969f, 0.13789725f, -0.11586335f, -0.03844756f, 
    0.07725920f, 0.04793838f, -0.02799738f, -0.00826938f, 0.11763828f, -0.00779322f, -0.06902668f, 0.04360428f, 
    0.18437088f, -0.08269294f, -0.08275389f, 0.03915285f, -0.58797181f, 0.81854087f, -0.28712270f, -0.34305754f, 
    -0.00468043f, -0.18588534f, -0.14134902f, 0.15282425f, -0.13041823f, -0.04790093f, 0.12624761f, -0.03516824f, 
    -0.00811063f, -0.00076845f, 0.03809305f, -0.22470874f, -0.11219811f, 0.22279073f, -0.04982457f, -0.23328206f, 
    -0.21236485f, 0.89544642f, -0.27320355f, 0.05219514f, 0.18432564f, -0.44877440f, 0.07191412f, -0.24371943f, 
    0.22251999f, 0.20845182f, 0.11761126f, 0.03648505f, 0.07502195f, -0.04802076f, -0.06108459f, 0.04068585f, 
    0.02935775f, -0.02767394f, 0.12577961f, -0.04265676f, -0.02344108f, 0.06191028f, -0.09626803f, -0.03761283f, 
    0.04328299f, -0.00494926f, -0.06813146f, -0.11703400f, 0.03483639f, -0.09165426f, 0.10063876f, 0.03204220f, 
    0.08639523f, 0.03142394f, -0.00620867f, 0.04144204f, 0.02723051f, -0.08371651f, -0.07458980f, 0.02215949f, 
    -0.86332148f, 0.69230884f, 0.56617999f, -0.09216470f, -0.01987852f, -0.10798573f, -0.08856347f, -0.13178141f, 
    -0.22367416f, 0.27777091f, -0.16712575f, 0.09768828f, -0.00777085f, 0.17832223f, 0.06403004f, -0.03604649f, 
    -0.03659229f, 0.02241054f, -0.08757310f, 0.00084194f, -1.06361723f, -0.73900896f, -0.11447449f, -0.01482049f, 
    -0.18736382f, -0.32654831f, -0.16083565f, -0.14201006f, -0.16423030f, -0.24936126f, -0.01027488f, -0.00542233f, 
    0.04465576f, -0.06457285f, 0.06845117f, 0.01266634f, 0.02520482f, 0.10490565f, 0.05532198f, -0.20182310f, 
    -0.08333968f, 0.12703389f, -0.11011016f, -0.17602924f, -0.18415768f, 0.06577180f, 0.02398281f, 0.05998069f, 
    0.03068020f, 0.02856763f, 0.03354035f, -0.06556635f, 0.06817170f, -0.06601162f, -0.05043142f, 0.07475615f, 
    0.21555459f, -0.13002540f, 0.00871668f, 0.22181398f, 0.03407787f, 0.02445362f, 0.12946256f, -0.16135086f, 
    -0.00820674f, 0.05311405f, -0.04550735f, -0.03695349f, 0.00144991f, -0.09264626f, -0.06650443f, -0.00611858f, 
    -0.13734263f, -0.07043381f, 0.00288267f, -0.06573176f, -0.00951484f, -0.03245953f, -0.18909039f, 0.01455883f, 
    -0.07746761f, 0.04760165f, 0.22712575f, 0.24894102f, -0.16020016f, 0.10160867f, -0.06269908f, -0.02349795f, 
    -0.28318241f, -0.06665239f, -0.13112544f, -0.00474752f, -0.01005704f, 0.00776742f, 0.00242304f, 0.09820743f, 
    -0.07686235f, -0.00692907f, -0.10591338f, -0.12447552f, 0.04422706f, 0.31776768f, -0.33418155f, -0.00263607f, 
    0.05896913f, 0.09662006f, -0.09132529f, 0.08947876f, 0.37764990f, 0.11027338f, 0.04770675f, 0.01637227f, 
    -0.28553632f, 0.12943253f, 0.14862102f, 0.00466837f, -0.02286153f, -0.06806217f, -0.21264097f, -0.19785124f, 
    0.09630398f, 0.17553747f, -0.03177180f, -0.03795760f, -0.06688622f, 0.08132239f, 0.00383927f, -0.04129426f, 
    -0.07763012f, -0.00862857f, -0.04060031f, -0.01311128f, 0.06756749f, -0.06378201f, 0.04122480f, 0.07035960f, 
    -0.02216017f, -0.10502364f, -0.09987215f, -0.03751444f, -0.33267787f, -0.30053508f, -0.54893625f, -0.14006452f, 
    0.29482251f, -0.16347691f, 0.12179595f, 0.11249082f, -0.05462371f, -0.01138072f, -0.01977496f, -0.08644356f, 
    -0.07235210f, 0.07234681f, 0.02266098f, 0.05609422f, -0.17673515f, -0.09080464f, 0.22220474f, 0.08132306f, 
    0.19629051f, -0.21196064f, -0.22213824f, -0.09952150f, 0.14240915f, -0.08960281f, 0.04258615f, 0.14185083f, 
    0.00788599f, 0.05237776f, -0.08515245f, -0.06346490f, -0.10560448f, -0.15902521f, 0.01780368f, -0.13262501f, 
    -0.17662333f, -0.18510401f, 0.05996606f, 0.01572547f, -0.60639840f, -0.88534594f, -0.27324855f, -0.32317203f, 
    0.04633290f, -0.03769340f, -0.18556055f, -0.18499455f, -0.26391917f, -0.03051015f, -0.00769889f, 0.00523659f, 
    -0.02688472f, 0.12790748f, -0.00464854f, -0.05824276f, -0.02774289f, 0.00419370f, 0.02433093f, -0.04610736f, 
    -0.09780004f, 0.04109580f, 0.05906314f, 0.07466854f, -0.23553076f, 0.00090001f, 0.08274183f, -0.15493906f, 
    -0.05470465f, 0.17366609f, -0.13988288f, 0.09957185f, 0.10083127f, 0.08487318f, -0.09709219f, 0.10861171f, 
    0.10303090f, -0.03842940f, 0.12598793f, 0.15361854f, -0.43171388f, -0.02075103f, -0.07545985f, 0.06787442f, 
    0.12020828f, -0.31664637f, 0.10153545f, -0.18977055f, -0.05897989f, 0.22576296f, -0.29111376f, -0.00084053f, 
    0.21169858f, 0.09699181f, 0.08245018f, -0.01270703f, 0.13061418f, -0.12425387f, 0.14154488f, -0.04484481f, 
    -0.57986826f, 0.76251310f, 0.17388099f, 0.09150546f, 0.26835591f, -0.05440777f, 0.01359110f, -0.07345547f, 
    0.09408282f, -0.07274172f, 0.08888917f, 0.16093396f, 0.15747358f, 0.09176893f, 0.06196482f, 0.04262993f, 
    -0.02167028f, 0.02293131f, -0.12317840f, 0.01173957f, -0.19006765f, -0.02975094f, -0.05467751f, 0.08042064f, 
    -0.23250979f, 0.09193554f, 0.13405028f, 0.17498334f, -0.06235332f, 0.04362014f, 0.10547855f, -0.06476071f, 
    0.01857352f, 0.13935390f, 0.06611656f, -0.00017467f, -0.08761957f, -0.18679486f, -0.09437703f, -0.14064850f, 
    -0.24360742f, 0.13624884f, -0.11720720f, -0.15776119f, 0.15652977f, 0.14146194f, 0.11501542f, 0.09757149f, 
    0.02154534f, 0.14779943f, 0.00552670f, 0.09860443f, -0.06833079f, 0.11147524f, -0.07401393f, -0.09528107f, 
    0.06613374f, 0.03513706f, 0.05963553f, 0.02966611f, -0.94307572f, -0.92256641f, -0.64014387f, -0.24614613f, 
    -0.26265290f, -0.16902180f, 0.02784919f, -0.23346320f, -0.15180303f, -0.37427643f, 0.03794502f, -0.06742572f, 
    0.01194224f, -0.11149797f, -0.03308705f, -0.02269577f, 0.02870468f, 0.00484570f, 0.23532122f, -0.11806799f, 
    -1.07339597f, -0.79995275f, -0.73955566f, -0.16667739f, 0.25857934f, -0.28588149f, 0.05081260f, -0.20307696f, 
    -0.36722931f, -0.25767481f, -0.05535170f, -0.00345217f, 0.00655789f, -0.10177576f, -0.04909943f, 0.02873380f, 
    0.00615395f, -0.03544024f, 0.28289270f, -0.03914664f, -0.16752838f, 0.37453660f, 0.12927307f, 0.01100441f, 
    -0.06056933f, -0.03905180f, 0.00995098f, -0.18478377f, -0.11032842f, -0.04995641f, -0.01565757f, -0.15824240f, 
    0.04979235f, 0.01231696f, 0.12869436f, -0.03721387f, -0.01159952f, -0.02414218f, -0.09060430f, -0.07391989f, 
    -0.43185467f, -1.26357114f, -1.08459604f, -0.30321279f, 0.16869223f, -0.11153734f, 0.08451589f, 0.11513231f, 
    -0.12017207f, -0.37780952f, 0.00722924f, -0.01082771f, 0.00274741f, 0.10811445f, 0.12924081f, 0.01339835f, 
    0.05833546f, 0.28208125f, 0.18751831f, 0.17576683f, -0.54792196f, -0.58725816f, -0.87093842f, -0.12201490f, 
    0.06009640f, -0.19245565f, -0.05627421f, -0.24544103f, -0.18366317f, -0.30284002f, -0.00628371f, -0.03292567f, 
    -0.02886656f, -0.02343971f, 0.01829966f, -0.00133545f, 0.00617631f, 0.00495077f, 0.13368267f, 0.01553123f, 
    0.32261109f, 0.06256546f, -0.12797585f, -0.18581574f, -0.09673259f, 0.02633114f, 0.00418264f, 0.13180941f, 
    0.14032182f, -0.22976544f, 0.08520130f, -0.02403078f, 0.01685495f, -0.10691451f, 0.01182123f, 0.09453378f, 
    0.02895908f, 0.01210283f, -0.13697994f, 0.06842601f, -0.29822105f, -0.40191358f, 0.14684527f, 0.24794658f, 
    -0.25255036f, 0.00251515f, -0.01304268f, -0.04412011f, -0.02224857f, -0.02821709f, -0.01246539f, 0.11356338f, 
    0.00653914f, 0.09471721f, -0.03128867f, 0.01543210f, 0.08323383f, 0.00697962f, -0.03847166f, 0.10026269f, 
    0.07362600f, -0.07629611f, -0.09313335f, 0.01710608f, 0.04534224f, -0.04324742f, -0.10465307f, 0.00126397f, 
    0.01884194f, -0.14842768f, 0.00289660f, -0.00106397f, -0.29204977f, -0.01884550f, 0.03251466f, -0.08573969f, 
    -0.03010551f, 0.08434935f, -0.07544780f, -0.07989109f, -0.38171756f, -0.32381782f, -0.56847483f, 0.11444309f, 
    -0.47563037f, 0.14329223f, 0.28956059f, 0.24035709f, -0.08744923f, -0.24907489f, 0.05873585f, -0.07613302f, 
    0.01314486f, 0.09514979f, 0.10285382f, -0.05542590f, -0.03890900f, 0.21729738f, 0.00457691f, -0.07050533f, 
    -0.31787819f, 0.38695809f, 0.25323990f, 0.01433847f, 0.31781915f, -0.12091461f, -0.00716163f, -0.05804248f, 
    0.07728762f, 0.20103413f, 0.11144476f, 0.13915053f, 0.14253823f, 0.11307117f, -0.02776994f, 0.08773421f, 
    0.02006494f, 0.05989870f, 0.07619774f, 0.01790116f, 0.20327304f, -0.37022316f, -0.36449966f, -0.14005405f, 
    0.18915829f, -0.01002040f, 0.13702837f, 0.20027509f, -0.01831776f, -0.06719189f, -0.02719572f, -0.05512855f, 
    -0.05653347f, -0.05018064f, 0.00086939f, -0.04103015f, 0.04730989f, -0.06956916f, 0.11477461f, 0.02527851f, 
    -0.14528975f, -0.16257000f, 0.05517435f, -0.02074019f, 0.20427440f, 0.04370730f, 0.06494344f, 0.02611068f, 
    0.03040898f, 0.04550174f, -0.06798590f, -0.00879685f, 0.07433559f, 0.03889516f, -0.02207355f, 0.01965655f, 
    0.12589306f, 0.02229937f, 0.12836188f, -0.07578036f, -0.24888101f, -0.45800063f, -0.36489123f, 0.34082264f, 
    -0.50585777f, -0.11775094f, 0.10444180f, -0.05801599f, -0.00222053f, -0.31514871f, 0.04815632f, 0.01220470f, 
    -0.03588287f, 0.14150992f, 0.06233349f, 0.05825469f, 0.09164844f, 0.28858167f, 0.08043393f, 0.06074205f, 
    -0.03746049f, 0.24223819f, 0.04151436f, -0.15287033f, 0.05089931f, -0.12359022f, -0.05738287f, -0.04968646f, 
    0.07057931f, 0.18696360f, 0.20248818f, 0.04105971f, -0.07859260f, 0.00575219f, 0.02188161f, -0.07579988f, 
    0.03622912f, -0.15759309f, 0.07246570f, -0.10299809f, -0.66337138f, -0.15296750f, 0.35376686f, 0.28528887f, 
    0.48095369f, 0.02304225f, -0.11583288f, -0.02018623f, 0.15435247f, 0.29436192f, 0.04637999f, 0.13788784f, 
    0.19240765f, -0.01445386f, 0.05372905f, 0.02807418f, 0.12472314f, 0.06603566f, 0.00126793f, 0.02512937f, 
    0.10572594f, -0.34446368f, -0.53632408f, -0.19260471f, -0.19522522f, -0.06306694f, -0.09103396f, 0.25493917f, 
    -0.06499507f, -0.12446834f, -0.07631727f, 0.08767514f, 0.05595633f, 0.05923639f, -0.05846529f, 0.01042303f, 
    -0.08443555f, 0.06521516f, -0.04807095f, -0.02906859f, 0.00104206f, 0.08520252f, -0.01761696f, 0.01305838f, 
    -0.11606693f, 0.01861116f, 0.03287521f, 0.13823994f, -0.03976338f, -0.02332149f, 0.03961341f, -0.21772727f, 
    -0.24001728f, -0.27801669f, -0.08314233f, 0.02940910f, -0.09581394f, -0.03963299f, 0.02067752f, 0.04835235f, 
    0.62723494f, -0.77742642f, -0.33547917f, -0.16201866f, -0.29129764f, -0.15882134f, 0.00015372f, -0.00895467f, 
    0.17025846f, -0.21681412f, 0.06302179f, -0.04805664f, 0.10150772f, 0.05387586f, 0.03194679f, 0.00646341f, 
    -0.02628350f, -0.01326115f, 0.07437304f, -0.03211660f, 0.20841178f, -0.55794293f, -0.12757730f, 0.26439697f, 
    -0.09324989f, 0.00016602f, 0.20434104f, -0.07524964f, 0.01247330f, 0.15609343f, 0.02187293f, 0.05886374f, 
    0.02656321f, 0.01139894f, 0.01506717f, -0.00354078f, 0.06421477f, -0.07285881f, 0.02346228f, -0.11938414f, 
    -0.00591880f, -0.12794769f, 0.21057300f, 0.05147285f, 0.12826955f, 0.00097072f, 0.09508773f, 0.05966709f, 
    -0.06391763f, -0.01830351f, 0.10725788f, -0.02475628f, 0.07089361f, -0.03394071f, -0.05932893f, 0.01779005f, 
    -0.15992357f, -0.25821951f, 0.06192724f, -0.04562314f, -0.01634097f, 0.05616605f, 0.09272575f, 0.15623395f, 
    0.00918410f, 0.01596349f, 0.02260631f, 0.06146063f, -0.06760482f, -0.03736848f, 0.14960909f, -0.00679866f, 
    0.10342427f, -0.01881903f, 0.00809276f, 0.05694989f, -0.04039361f, -0.21845642f, -0.02486377f, 0.00021124f, 
    -0.25044605f, -0.12424141f, 0.00874235f, -0.03406061f, -0.02135062f, 0.05823847f, 0.03008937f, 0.03540505f, 
    -0.05821694f, 0.02620870f, -0.13882048f, -0.10392457f, 0.09066913f, -0.03499677f, -0.02615314f, 0.01293960f, 
    0.02949140f, -0.02103626f, -0.04622906f, -0.00525112f, -0.07432538f, -0.16657755f, 0.34676567f, -0.05128520f, 
    0.22071517f, 0.02022926f, 0.11003636f, -0.01552005f, 0.00643814f, -0.16015448f, 0.08900019f, -0.02180415f, 
    -0.09709504f, -0.04938052f, -0.08571574f, 0.08413807f, -0.09607568f, -0.02132400f, 0.03276477f, -0.04044499f, 
    -0.11433551f, 0.06910379f, 0.09351677f, -0.06818965f, -0.01490017f, 0.02058225f, -0.03749133f, 0.05684776f, 
    -0.01914244f, -0.00577304f, -0.15311928f, -0.03744795f, -0.06414659f, 0.07368399f, -0.02942035f, 0.02829069f, 
    -0.01100487f, 0.02889355f, 0.07944789f, -0.06261580f, 0.02206785f, 0.24352750f, -0.07169336f, 0.04249219f, 
    -0.45987138f, 0.00221710f, 0.12704159f, -0.08082715f, 0.02632566f, -0.03967339f, -0.00776405f, 0.01421410f, 
    0.08034887f, 0.05380662f, -0.08354641f, -0.15764910f, 0.00281238f, 0.07263959f, -0.03425703f, 0.02711919f, 
    0.01299994f, -0.00233721f, 0.01873916f, 0.00688894f, -0.06489611f, 0.02406312f, 0.01114395f, 0.02176839f, 
    -0.00906269f, -0.05139788f, 0.07227910f, -0.00898310f, 0.03628712f, 0.02341335f, -0.02051216f, -0.03289921f, 
    -0.08621916f, -0.00113124f, 0.05739868f, 0.04633382f, 0.45422629f, -0.57581311f, -0.41482407f, -0.49763569f, 
    -0.37284625f, -0.10245553f, -0.01048369f, -0.15027876f, 0.34437203f, 0.00028591f, 0.02962640f, 0.06653901f, 
    -0.02015019f, -0.05866287f, 0.02865731f, -0.04631843f, -0.03127527f, -0.05477603f, 0.09024956f, 0.08560433f, 
    0.34562340f, -0.10416231f, 0.03783679f, -0.34390900f, 0.05532007f, 0.01536022f, 0.02507552f, -0.02733180f, 
    0.11899475f, 0.07720681f, -0.07244474f, 0.07736543f, -0.01153379f, -0.00012340f, -0.12581697f, -0.09427639f, 
    0.02919481f, 0.03828187f, 0.04805620f, 0.02584548f, 0.56557524f, 0.23451169f, -0.11461096f, 0.03925402f, 
    -0.20101179f, 0.07535907f, -0.15306380f, -0.19245972f, -0.02921438f, -0.11857318f, 0.22383288f, 0.05990002f, 
    0.10136478f, -0.10986849f, 0.02983776f, -0.01855399f, -0.09135249f, -0.01146043f, 0.01885196f, -0.16459113f, 
    -0.23330502f, -0.40891540f, 0.00281389f, -0.13854253f, 0.01686792f, 0.05897682f, -0.06516817f, 0.23754828f, 
    0.09225269f, 0.06842547f, -0.23295674f, 0.05918949f, 0.17290010f, 0.13802870f, -0.05971585f, -0.08110897f, 
    0.03142639f, -0.03442300f, 0.10790017f, 0.05725627f, -0.20690787f, -0.08876951f, 0.20934816f, -0.23635586f, 
    0.12578838f, -0.01969847f, 0.10903922f, -0.01826584f, 0.02271284f, -0.01408600f, -0.06840935f, -0.09226131f, 
    0.11303627f, -0.02082330f, 0.10405029f, -0.09825303f, -0.00119515f, -0.00749592f, 0.03203559f, -0.01558391f, 
    0.27293164f, 0.12208871f, -0.25145018f, 0.06001820f, -0.22376288f, -0.15293816f, 0.24562983f, 0.08664557f, 
    -0.34699589f, 0.08308840f, -0.07527363f, 0.00085068f, 0.09719532f, -0.08506401f, -0.28448305f, -0.09918500f, 
    -0.17384966f, 0.11222698f, -0.29384762f, -0.06869794f, -0.12551965f, -0.78051841f, -0.64820266f, 0.39399219f, 
    -0.11057972f, -0.04917736f, 0.09154091f, -0.03462635f, 0.08689418f, 0.16694865f, 0.03014877f, 0.03706315f, 
    0.01498507f, 0.02344414f, 0.02848491f, -0.06423815f, 0.07665794f, 0.03907102f, -0.08023000f, -0.10827408f, 
    0.35662395f, -0.64563924f, -0.19494441f, 0.63712192f, -0.11804791f, 0.09033152f, 0.02745179f, -0.20717165f, 
    0.21127582f, 0.13774732f, 0.02126729f, -0.01008134f, -0.07305729f, -0.10403918f, 0.04440082f, -0.04979853f, 
    0.01739930f, -0.05874019f, 0.23589453f, -0.06919238f, -0.13970739f, -0.22591877f, 0.05639773f, -0.09813951f, 
    0.10336896f, 0.01759526f, 0.06277153f, 0.10995221f, -0.04282263f, 0.15928015f, -0.13650210f, 0.06124541f, 
    -0.01795293f, 0.09686428f, 0.05029067f, -0.02503624f, 0.01910532f, -0.04611574f, -0.02558217f, -0.07746516f, 
    -1.03279686f, -0.75650573f, 0.58945739f, 0.31917888f, 0.30074370f, 0.13760819f, 0.04577091f, 0.14041126f, 
    -0.21018814f, 0.07857118f, 0.10781455f, -0.02284348f, -0.02932317f, 0.05624582f, -0.03380939f, 0.12871677f, 
    0.09229396f, 0.00696895f, -0.03123927f, -0.12404305f, -0.14331813f, -0.43415898f, -0.21626852f, -0.14616711f, 
    -0.25294310f, -0.03045925f, 0.01011972f, -0.18741588f, 0.06130314f, 0.12021979f, 0.02785839f, -0.02757039f, 
    -0.07545915f, -0.11033833f, 0.01514734f, -0.02399478f, 0.04885399f, -0.12022268f, 0.08384352f, -0.11224514f, 
    -0.13579497f, 0.17333789f, 0.06932041f, 0.05947331f, -0.01756830f, -0.05037091f, -0.03592408f, 0.03373099f, 
    -0.08289351f, -0.04200839f, 0.11117116f, 0.01846176f, 0.02826929f, 0.02018472f, -0.01718395f, 0.03381998f, 
    -0.24196663f, -0.15175189f, -0.08276361f, 0.02970113f, 0.42997560f, -0.28383300f, 0.04762539f, -0.62252170f, 
    0.23685661f, -0.13018279f, 0.25448939f, -0.13319400f, 0.03668219f, -0.15973854f, 0.00156320f, 0.06617283f, 
    0.04093079f, -0.07453734f, 0.09393308f, -0.09237338f, -0.00688429f, 0.02558457f, -0.07164560f, 0.02147319f, 
    -0.00196009f, 0.07492574f, 0.01330925f, 0.01336022f, -0.08844378f, 0.02008755f, 0.04525142f, 0.03153901f, 
    -0.00247400f, 0.01226872f, 0.04822044f, -0.11298316f, 0.09235515f, 0.02579581f, -0.06139383f, -0.00857181f, 
    -0.03513224f, 0.03234457f, -0.00185744f, 0.01493953f, -0.72258329f, -1.24565160f, 0.54249203f, -0.71748155f, 
    0.49661654f, 0.01397895f, -0.17967606f, 0.25796416f, -0.18957624f, -0.13600434f, -0.01957670f, -0.03075335f, 
    0.09077295f, -0.02106601f, -0.18010063f, 0.07397842f, -0.03250886f, -0.03823010f, -0.13479204f, -0.25155804f, 
    0.17467865f, -0.08876974f, -0.43403888f, 0.01960822f, -0.26656297f, 0.07088131f, 0.00543253f, 0.04764182f, 
    0.03175837f, 0.01223328f, 0.03570913f, -0.02232681f, 0.04070282f, -0.01459073f, 0.04919548f, -0.03102469f, 
    -0.07510578f, -0.00349202f, 0.04817561f, 0.03374767f, -0.10460444f, 0.02089097f, 0.01863622f, 0.07976146f, 
    -0.09658489f, 0.06503578f, 0.01681568f, 0.09848250f, 0.00903803f, -0.04259218f, 0.06394851f, 0.03118930f, 
    0.02453564f, -0.03591686f, -0.05945970f, -0.03266390f, -0.05731446f, 0.00839145f, 0.08157061f, 0.02274565f, 
    0.16174260f, 0.00819613f, -0.31694031f, 0.20905365f, -0.42303899f, -0.04401655f, 0.06784599f, -0.10570946f, 
    0.09003084f, 0.07182993f, -0.14033274f, 0.05304846f, 0.01332441f, -0.05092418f, 0.01044794f, 0.01476662f, 
    0.02214348f, -0.20173422f, 0.01546158f, 0.21075016f, -0.33673710f, -0.41281572f, 0.44739139f, -0.28413621f, 
    0.20836891f, 0.08526887f, -0.12276442f, 0.01679668f, 0.12243007f, -0.02833155f, 0.01077695f, 0.00478166f, 
    -0.05900093f, 0.01973087f, -0.05805644f, 0.12113684f, 0.05774216f, 0.17835191f, -0.00372283f, 0.03936135f, 
    0.08390569f, 0.13596076f, -0.23314878f, 0.06672424f, -0.17303310f, 0.05455106f, 0.01623074f, 0.10280694f, 
    -0.11713906f, -0.03719338f, -0.37526992f, -0.09075369f, 0.06764337f, -0.03114325f, -0.21397519f, 0.00632703f, 
    -0.12126366f, 0.03742909f, -0.06203867f, 0.02827689f, 0.93910348f, -0.71163338f, -0.72898513f, -0.45438865f, 
    -0.58529752f, 0.08153530f, 0.00667758f, 0.07587781f, 0.09943358f, -0.01425969f, -0.01777713f, -0.07778443f, 
    -0.01104745f, -0.00361140f, -0.03184882f, -0.05631284f, -0.04840650f, -0.08225960f, 0.05951478f, 0.06646864f, 
    0.07499507f, -0.86868972f, -0.49288294f, -0.07097659f, 0.43933308f, 0.08833932f, 0.22673714f, 0.21670026f, 
    0.18751581f, 0.15372865f, 0.01518934f, -0.07018328f, 0.07816495f, 0.07772062f, -0.05885896f, 0.06134115f, 
    -0.01140314f, -0.00599668f, 0.02354112f, -0.02885946f, -0.37104449f, -0.06388456f, 0.12860620f, -0.10391668f, 
    -0.13296469f, -0.10689744f, 0.03520685f, -0.09205911f, -0.02357110f, -0.07718778f, 0.04032606f, 0.06405854f, 
    0.12923735f, 0.12692487f, 0.15640615f, 0.01996609f, 0.05708216f, -0.10659011f, -0.02125668f, -0.03602466f, 
    -0.04424982f, -0.49861708f, -0.63485229f, -0.13939518f, 0.09797323f, -0.04750063f, 0.06186279f, 0.18706140f, 
    0.08358064f, 0.28816003f, 0.12269627f, -0.23332572f, -0.10818043f, -0.08426975f, -0.11209269f, -0.01420998f, 
    0.02812844f, 0.01062504f, -0.02198439f, 0.00016785f, 0.08649838f, -0.30890653f, -0.50998336f, -0.27321559f, 
    0.03833719f, -0.11513252f, -0.20355001f, 0.04287492f, 0.01411258f, 0.00969687f, -0.05759845f, 0.03183643f, 
    -0.00772757f, 0.02751011f, 0.02122150f, 0.00208920f, 0.05498144f, 0.12465321f, 0.13518676f, 0.09885180f, 
    -0.53326488f, 0.02250199f, 0.30611086f, 0.08466697f, 0.00657563f, -0.01497204f, -0.03567515f, -0.00408244f, 
    -0.06078072f, -0.07754922f, -0.03976992f, -0.06788875f, -0.05953743f, -0.06055059f, -0.08067766f, -0.25156459f, 
    -0.14652593f, -0.12793340f, -0.50398469f, -0.10533717f, -0.62742513f, -0.10267409f, 0.26176754f, 0.11284074f, 
    -0.00852839f, -0.11170645f, -0.05322877f, -0.06310928f, -0.08151892f, -0.03361840f, -0.08302721f, -0.06115573f, 
    0.08580116f, 0.04668053f, 0.00711768f, -0.08428498f, 0.03069393f, -0.01837637f, -0.03303882f, 0.03811219f, 
    -0.17011039f, -0.00355289f, -0.05502315f, 0.19969374f, -0.11148205f, -0.06543553f, 0.04345113f, 0.15200825f, 
    -0.01328607f, 0.13840063f, -0.03507677f, 0.00231247f, -0.14895572f, 0.06788541f, -0.00291709f, -0.12751836f, 
    0.12593432f, 0.06690016f, 0.10253624f, 0.08781753f, 0.55296868f, -0.27371734f, -0.05808037f, 0.23465608f, 
    -0.05596478f, 0.12860693f, 0.02645640f, -0.11057282f, -0.08709025f, 0.08627465f, 0.03407545f, 0.10790004f, 
    -0.03388281f, 0.18500368f, -0.02792784f, 0.05145130f, 0.06934000f, 0.11719545f, -0.03424873f, 0.05589132f, 
    -0.39882791f, -0.18570472f, 0.06630707f, 0.05073506f, -0.00831943f, -0.08632129f, 0.03022005f, 0.01071576f, 
    0.02605988f, 0.06194062f, 0.09634684f, 0.05978451f, 0.03919180f, 0.07344349f, 0.10272720f, 0.04464566f, 
    0.08055926f, 0.04413152f, 0.10182735f, 0.06723494f, 0.19101721f, 0.27559251f, 0.15872988f, 0.06925330f, 
    -0.25669470f, 0.00621931f, -0.15326872f, -0.04793011f, 0.02562832f, -0.19298054f, -0.05690389f, -0.05832369f, 
    -0.05824134f, -0.07243013f, -0.01588833f, -0.13455965f, -0.09103664f, -0.36394784f, -0.13536289f, -0.12878525f, 
    -0.06241171f, 0.14526264f, 0.04501940f, 0.04155955f, -0.13464358f, -0.03441654f, -0.04576419f, -0.09969357f, 
    -0.02143747f, -0.12619376f, -0.05702224f, 0.00873443f, -0.00490272f, 0.02119102f, 0.02964758f, -0.03241505f, 
    0.09979194f, 0.12948780f, 0.09670938f, 0.07889937f, -0.13394164f, -0.34993228f, -0.84407753f, -0.57867813f, 
    -0.05085653f, -0.07931352f, -0.00909682f, 0.18636239f, 0.05988319f, -0.19486846f, -0.01584571f, -0.07436953f, 
    -0.08662826f, 0.02729462f, 0.06600441f, 0.06822231f, -0.01164972f, 0.04818544f, -0.02339192f, -0.03024903f, 
    0.07390913f, 0.09436350f, -0.29936278f, -0.09876222f, -0.02203254f, 0.02192152f, -0.13857703f, -0.06046533f, 
    0.03049627f, -0.10005288f, 0.13666205f, 0.15318625f, 0.07909223f, 0.09907500f, -0.09011485f, -0.15589836f, 
    -0.06744969f, -0.04137954f, 0.01457568f, -0.00510764f, 0.28183851f, -0.17555191f, -0.41563648f, -0.24496095f, 
    -0.12852353f, 0.06753233f, 0.07007159f, 0.13126855f, 0.10514414f, -0.08910621f, 0.17044088f, 0.02618614f, 
    0.10399925f, 0.00960848f, 0.00116831f, -0.02011451f, -0.08390543f, -0.08481868f, 0.15769713f, -0.03924184f, 
    -0.51334083f, -0.77414620f, 0.05792287f, -0.01859355f, 0.14271970f, -0.05077240f, 0.10032861f, 0.13145295f, 
    -0.06851291f, 0.10275723f, 0.17423214f, -0.06255896f, -0.00323985f, 0.06691991f, -0.01581863f, -0.10589317f, 
    0.02364482f, 0.01482998f, -0.03926509f, -0.06511705f, 0.17116755f, -0.13760309f, -0.06899337f, 0.07995541f, 
    -0.08442145f, -0.11169428f, -0.09751975f, -0.16311155f, 0.08359753f, 0.10210314f, 0.09262799f, 0.04748209f, 
    -0.00850056f, -0.02588867f, 0.15748414f, -0.10544689f, 0.23955026f, -0.05635527f, 0.02139304f, 0.15172505f, 
    0.23725700f, 0.20655988f, 0.00551672f, 0.05039183f, -0.39531064f, -0.01053038f, 0.30134365f, 0.19623783f, 
    0.20436777f, 0.05693639f, 0.12858623f, -0.02488611f, -0.05296461f, 0.03931371f, 0.01559043f, 0.05623290f, 
    0.25819722f, 0.10761300f, 0.27827996f, -0.17774291f, -0.03425045f, -0.41072589f, -0.60376525f, -0.51572490f, 
    0.11915594f, -0.05013033f, -0.13505900f, -0.01114025f, 0.07478546f, 0.09671067f, -0.02736627f, -0.01536611f, 
    -0.01965204f, 0.01139129f, 0.00671334f, 0.02483959f, 0.00939410f, 0.10028239f, 0.08133384f, 0.16153391f, 
    -0.12963553f, -0.19866972f, -0.64261061f, -0.57437766f, -0.25138333f, -0.04629430f, -0.22802050f, -0.06888073f, 
    -0.01715847f, -0.28992534f, 0.00501477f, 0.04531083f, -0.07394759f, 0.07549030f, 0.07314823f, 0.04278095f, 
    0.03344658f, 0.06256094f, -0.08009380f, -0.18103936f, 0.06220518f, -0.19162962f, -0.21110581f, 0.00496830f, 
    0.03609977f, -0.02371522f, -0.05981896f, -0.04005603f, 0.04937050f, 0.15098669f, -0.00706864f, 0.00682163f, 
    -0.09998674f, -0.04957627f, 0.02528092f, -0.08154274f, 0.11318454f, 0.15487169f, 0.00712406f, 0.08883095f, 
    1.02229106f, -0.31403109f, 0.11990952f, -0.05978189f, -0.00564872f, 0.10328802f, -0.24646211f, -0.12967889f, 
    -0.21299785f, -0.20318654f, 0.04595006f, -0.04167226f, 0.04828157f, -0.03079404f, 0.01963045f, 0.13981198f, 
    -0.02417308f, 0.10699833f, -0.29302177f, -0.44499546f, 0.17507085f, -0.26615208f, -0.57895362f, -0.41653088f, 
    -0.06418677f, -0.16107377f, -0.16087404f, -0.01401045f, -0.15079680f, -0.33589378f, -0.02241902f, -0.02787821f, 
    -0.05241434f, 0.09213743f, 0.08403493f, 0.04446655f, -0.00569019f, 0.13482293f, -0.05254939f, -0.15788648f, 
    -0.64886677f, 0.04726941f, 0.19265375f, 0.17934088f, 0.12768744f, -0.02791631f, 0.05333007f, -0.04987408f, 
    0.04217172f, 0.01173797f, -0.07764931f, -0.05052450f, 0.01835981f, -0.00104341f, 0.00741477f, -0.01599076f, 
    -0.05339222f, 0.01249369f, 0.06959083f, 0.03219234f, 0.19790395f, 0.21801662f, -0.25900677f, -0.02149377f, 
    -0.09078970f, 0.01492585f, 0.02996533f, 0.07632154f, 0.18053146f, 0.13310634f, 0.25510719f, 0.03865287f, 
    -0.08835522f, 0.00449548f, -0.02484507f, 0.02254871f, 0.09909356f, 0.04119229f, 0.09306929f, -0.00032762f, 
    -0.09266604f, 0.00728081f, -0.03043505f, 0.04770401f, -0.17889291f, -0.13793768f, -0.10384227f, -0.12961265f, 
    -0.05512408f, -0.08304465f, -0.01927024f, 0.08541968f, 0.08492710f, 0.00158660f, -0.03153592f, 0.00086874f, 
    0.18330841f, 0.18952443f, 0.16942413f, 0.15306973f, 0.62288672f, -0.43017590f, -0.16600941f, 0.22581609f, 
    0.15438385f, 0.26494378f, 0.15627511f, -0.00929371f, 0.12530865f, 0.30832300f, -0.00660059f, 0.09939282f, 
    0.03147866f, 0.05315427f, 0.20952289f, -0.00485011f, 0.09770398f, -0.19739905f, -0.05793735f, -0.06916881f, 
    0.01665075f, -0.25284106f, -0.04842799f, -0.05305590f, 0.10994336f, -0.10659887f, 0.13902365f, 0.17547885f, 
    0.02644764f, 0.09503556f, 0.14139315f, -0.04831795f, -0.01829214f, -0.04070203f, -0.09130823f, -0.02040828f, 
    0.04322428f, 0.00700703f, 0.05195422f, -0.09386346f, 0.02569835f, 0.21043833f, 0.09554984f, 0.03142684f, 
    -0.17019911f, -0.11545772f, -0.11465608f, -0.12349109f, -0.05159767f, -0.16081253f, -0.03979490f, 0.00763668f, 
    0.03039696f, -0.06945807f, 0.03292974f, -0.08531071f, 0.15562296f, 0.13802403f, 0.13181362f, 0.09187827f, 
    0.21184301f, 0.40368491f, 0.23459421f, 0.09722804f, -0.38840449f, -0.06574308f, -0.07380629f, -0.21188121f, 
    0.07170302f, -0.14634813f, 0.02933789f, 0.11150490f, 0.00111107f, -0.00071340f, 0.05032590f, -0.36885875f, 
    -0.14038281f, 0.03045502f, -0.24660619f, -0.31872505f, -0.03451015f, -0.40385124f, -0.02538963f, 0.06150169f, 
    0.21049404f, 0.16508518f, 0.19018143f, 0.04309332f, 0.05562664f, 0.04644627f, 0.06985188f, 0.01646470f, 
    0.02627978f, 0.03778027f, 0.02712470f, 0.09458324f, -0.26152027f, 0.05668201f, -0.11394933f, -0.42196295f, 
    0.07102553f, 0.15414505f, -0.03946748f, -0.07398556f, -0.11804640f, -0.10638736f, 0.08947015f, -0.02592884f, 
    -0.02564215f, -0.06233423f, 0.11719269f, -0.01695149f, 0.01205237f, 0.05947597f, 0.09240960f, 0.00926546f, 
    0.09725209f, 0.05643615f, 0.20554163f, 0.01543006f, 0.23681170f, -0.45795217f, -0.29666659f, -0.00175768f, 
    0.23039904f, -0.08838621f, 0.26292130f, 0.14240703f, 0.02457831f, -0.04676770f, -0.02102308f, 0.07742862f, 
    -0.06029704f, -0.07573402f, 0.11559882f, 0.01144443f, 0.00803606f, -0.17594086f, -0.16805930f, -0.11667989f, 
    -0.32263514f, -0.40973410f, 0.37860754f, 0.29015461f, -0.81249452f, 0.30063483f, -0.45243677f, -0.04540856f, 
    -0.04663253f, -0.22632399f, -0.14864706f, 0.04556428f, 0.03842486f, -0.04054277f, 0.08768862f, 0.01999737f, 
    -0.07028405f, -0.09453620f, 0.00052582f, 0.10582475f, -0.04426419f, 0.09037025f, -0.05374839f, -0.12326026f, 
    0.28088373f, -0.11021453f, -0.01280301f, -0.00758939f, 0.07980337f, -0.21505731f, 0.01745075f, 0.16508985f, 
    0.10382060f, -0.17981973f, 0.00844891f, 0.10157304f, 0.14895260f, -0.05182251f, -0.06156082f, 0.24692143f, 
    0.33253106f, 0.11348990f, 0.30321786f, 0.05419790f, -0.32617825f, -0.04446283f, -0.16587535f, -0.49475795f, 
    -0.06926771f, -0.14409922f, 0.12332530f, 0.01299969f, 0.09985817f, 0.10415429f, 0.03273799f, 0.03597155f, 
    -0.06721257f, 0.03204014f, -0.00840993f, -0.04010785f, -0.31685403f, -0.19147456f, 0.16657324f, -0.02788921f, 
    -0.28966936f, 0.08520100f, -0.11223303f, 0.16595468f, 0.06741548f, 0.22288035f, 0.04065520f, -0.00517773f, 
    0.04215157f, 0.01888767f, -0.14603961f, 0.06916808f, -0.01121448f, -0.06404626f, -0.04222920f, -0.20483412f, 
    -0.01303864f, -0.38997844f, -0.28849027f, -0.28816459f, 0.21286248f, -0.16380107f, 0.10849061f, 0.05541414f, 
    0.08066680f, -0.10720108f, -0.04274025f, 0.01504910f, 0.04304016f, -0.08895555f, -0.07127996f, 0.18847446f, 
    0.17576754f, 0.22992381f, -0.05810181f, 0.02478542f, -0.06058186f, -0.27362823f, -0.19063246f, -0.35202849f, 
    0.15703358f, -0.08726712f, 0.01005566f, 0.22912526f, 0.09345556f, 0.01055305f, -0.14725304f, 0.03271501f, 
    0.07059693f, -0.14200675f, -0.08151321f, 0.11336802f, 0.06865790f, 0.05265580f, -0.01567208f, 0.18005332f, 
    0.15793863f, 0.01399462f, 0.21889523f, -0.55070341f, 0.05858423f, -0.05667275f, -0.01512544f, -0.19321205f, 
    0.16045420f, 0.04807773f, -0.13509274f, 0.22744505f, -0.06319679f, 0.00928975f, 0.09601555f, -0.01857671f, 
    0.06920861f, -0.03122025f, -0.03807831f, 0.10407620f, -0.32685152f, -0.30658704f, -0.11988398f, -0.27465591f, 
    -0.32522589f, 0.15819034f, 0.08315461f, 0.05599340f, -0.32476816f, -0.07831655f, 0.20219384f, -0.16577123f, 
    -0.08819644f, 0.00182007f, -0.05265131f, -0.16433078f, 0.02615259f, -0.23023650f, -0.24287637f, 0.10393299f, 
    0.02829802f, -0.08010025f, 0.41293734f, -0.27219930f, 0.02318266f, -0.02225126f, -0.11383454f, -0.12456840f, 
    0.23365493f, 0.02063059f, -0.01185129f, 0.11444528f, 0.10554129f, -0.09485019f, -0.00965515f, 0.03329902f, 
    0.09204627f, -0.00361466f, -0.10647929f, 0.02144589f, -0.37471840f, -0.05009866f, -0.72695541f, 0.16369510f, 
    -0.23025073f, 0.09776717f, 0.12976380f, 0.28620827f, -0.16657668f, 0.21016204f, 0.05608959f, -0.05561455f, 
    -0.09582489f, -0.02099824f, -0.08988751f, -0.12946472f, 0.05508345f, 0.06058415f, 0.02469891f, 0.09508115f, 
    -0.00699381f, 0.07054278f, -0.45041069f, 0.11885515f, -0.14564735f, 0.15244518f, 0.24113168f, 0.36488700f, 
    0.09032536f, 0.02744698f, 0.03502848f, -0.13410036f, -0.01755506f, -0.01592529f, -0.14088118f, 0.23841074f, 
    0.08848583f, -0.20233005f, 0.03174426f, -0.06074944f, -0.15900868f, -0.13931060f, -0.02321010f, 0.31694666f, 
    -0.95328671f, -0.21479338f, 0.07486000f, -0.06443872f, 0.17542602f, 0.08379840f, 0.09626991f, -0.04563415f, 
    0.07684533f, 0.04629389f, -0.05246763f, 0.02332840f, 0.05392103f, 0.05462630f, 0.11990166f, -0.03335591f, 
    -0.42302606f, 0.02103753f, -0.14507271f, 0.14205702f, 0.13432017f, -0.26119745f, 0.22049944f, -0.25949866f, 
    0.07451085f, 0.06729646f, 0.06677029f, -0.06914125f, 0.11988938f, 0.01443593f, -0.05628898f, 0.06791488f, 
    0.14049897f, -0.06500227f, -0.03424996f, 0.20431033f, -0.41002321f, 0.39343148f, -0.07576111f, 0.67057467f, 
    -0.31934887f, 0.02368753f, -0.20529687f, -0.11467724f, -0.12029550f, -0.24086154f, 0.10531782f, 0.01398415f, 
    0.04237138f, -0.05836805f, 0.01226291f, 0.04641664f, 0.03903700f, -0.14284776f, -0.00475301f, 0.08902515f, 
    0.08466560f, -0.23632060f, 0.46896178f, -0.18861707f, -0.45218801f, 0.04588042f, -0.35453370f, -0.37395361f, 
    0.19621471f, -0.24764930f, -0.07946432f, 0.01194823f, -0.00742140f, 0.18865359f, -0.06342477f, 0.04475437f, 
    -0.01798453f, 0.00588277f, -0.09150912f, 0.10943616f, 0.02192811f, -0.45970973f, 0.16626900f, -0.11389834f, 
    0.04902229f, 0.01575789f, 0.14987369f, -0.33372018f, -0.06977812f, -0.10840973f, 0.04015546f, 0.10685203f, 
    -0.08810687f, 0.00137529f, 0.04472554f, 0.01907951f, 0.08820170f, -0.12769258f, -0.30740294f, 0.03203166f, 
    -0.56713593f, 0.20648690f, -0.25818455f, 0.10666489f, 0.16429919f, 0.06797484f, -0.11108620f, -0.12117203f, 
    -0.00984753f, -0.07330711f, 0.19861816f, -0.11566316f, -0.06453032f, 0.00530115f, 0.03241284f, -0.05768400f, 
    -0.09677004f, 0.01272240f, -0.16782284f, -0.05748766f, -0.41552275f, -0.19702652f, 0.55044419f, -0.17186415f, 
    -0.40751508f, 0.17888086f, -0.38870120f, 0.17690994f, 0.23607834f, 0.25670987f, 0.00198378f, 0.08755811f, 
    -0.02248051f, -0.01123047f, -0.02609594f, 0.04470437f, -0.01601803f, -0.01227782f, -0.05464626f, -0.10809053f, 
    -0.50369263f, -0.27760211f, 0.17870912f, 0.43706906f, -0.63513225f, 0.06887901f, -0.50807965f, 0.19463058f, 
    -0.02858884f, 0.23223236f, 0.13944133f, 0.01757512f, 0.11650010f, 0.04174655f, 0.00515308f, 0.00185878f, 
    0.04684874f, 0.02831268f, 0.18183079f, 0.17864560f, 0.16736752f, 0.04289139f, 0.58680755f, -0.09483213f, 
    -0.24710530f, 0.07163909f, -0.07279044f, -0.13201818f, -0.03147379f, -0.01897388f, 0.04187202f, 0.02806645f, 
    0.10430136f, 0.01010994f, -0.00398548f, 0.08162509f, -0.17901145f, -0.16848023f, -0.13414904f, -0.05913396f, 
    0.65986836f, -0.64398837f, -0.71146560f, 0.04441463f, -0.04037844f, 0.05171461f, -0.11984289f, 0.02848667f, 
    0.03063135f, 0.10954812f, 0.03061393f, 0.01161282f, 0.01184868f, -0.10058835f, -0.02484147f, -0.01799212f, 
    0.01393201f, -0.02902722f, 0.08977304f, 0.11952509f, -0.17343049f, -0.18229777f, 0.34475869f, 0.22441675f, 
    -0.39509600f, -0.03831894f, -0.14452076f, -0.05508706f, 0.13833655f, 0.23826256f, 0.01242168f, 0.05226238f, 
    0.02617297f, -0.01784021f, -0.06930451f, -0.00320810f, 0.08739050f, 0.09267320f, 0.13588521f, 0.13131361f, 
    -0.18652456f, 0.20813406f, -0.22584893f, -0.44005790f, -0.05280409f, 0.06275199f, 0.02243662f, 0.21344094f, 
    0.01207580f, 0.15620133f, -0.00966615f, 0.03314672f, -0.12972152f, 0.08503766f, 0.00630602f, -0.01573892f, 
    0.18698417f, -0.01813236f, 0.01266182f, 0.00547286f, -0.42370701f, -0.27496392f, -0.15966934f, -0.03683085f, 
    0.08176235f, -0.34252086f, 0.33183682f, -0.34639946f, -0.16442806f, -0.06011784f, 0.04077542f, -0.03135268f, 
    -0.07357905f, -0.00380621f, -0.00166658f, 0.07037768f, 0.04662419f, -0.03399365f, 0.03880252f, -0.02575005f, 
    -0.00314871f, 0.35685283f, 0.02502191f, -0.16967013f, -0.03808790f, -0.01999221f, 0.13607223f, 0.15550150f, 
    0.06157293f, 0.10628164f, 0.19303070f, 0.05460071f, -0.01003682f, 0.00725404f, -0.01953629f, 0.01540191f, 
    -0.01622635f, -0.31584391f, 0.08610515f, -0.01166485f, -0.06913310f, -0.84776276f, 0.09678313f, -0.64571834f, 
    -0.22931960f, -0.07679790f, -0.36483669f, -0.18775488f, -0.00666769f, -0.00293286f, -0.15802431f, -0.02482593f, 
    -0.06226133f, -0.07601727f, 0.02259723f, 0.04154502f, 0.04317869f, 0.01410720f, -0.01570987f, 0.00733012f, 
    0.04210208f, 0.15928873f, 0.15924180f, 0.47055218f, -0.06495705f, -0.02966785f, -0.15528779f, -0.30953223f, 
    0.09981208f, -0.34550482f, 0.02176257f, -0.07084619f, 0.09763923f, 0.18027224f, -0.03261555f, 0.15930571f, 
    0.07939879f, -0.10609207f, 0.00146460f, 0.13376465f, 0.12598580f, 0.21696246f, -0.48844156f, 0.14469682f, 
    -0.04161607f, 0.07142689f, 0.24485724f, 0.33863610f, 0.04201110f, 0.07928357f, 0.04377009f, -0.11064443f, 
    -0.15113528f, -0.08033118f, -0.16112560f, 0.10489326f, -0.04549383f, -0.13761809f, -0.00110245f, -0.02517279f, 
    -0.94183606f, -0.34501293f, -0.33187792f, 0.04161434f, 0.08160439f, 0.02078065f, 0.20059976f, 0.01164396f, 
    0.06507205f, 0.03004387f, 0.05608362f, -0.17556396f, 0.08280184f, -0.03876898f, 0.04625095f, 0.16358633f, 
    0.15630654f, -0.04183051f, 0.11082266f, 0.13457648f, 0.39594367f, -0.62802917f, -0.22081274f, -0.16765903f, 
    0.15915048f, -0.08758345f, 0.02495234f, 0.08807840f, 0.15864311f, 0.15875387f, -0.03009657f, 0.07835587f, 
    0.03671246f, -0.00923608f, 0.02008437f, -0.11581095f, 0.20812289f, 0.21575919f, 0.02266391f, 0.18293509f, 
    -0.35152841f, 0.16299535f, 0.19437572f, 0.04687025f, 0.06734579f, 0.22107692f, -0.09858550f, 0.04672660f, 
    -0.14642310f, -0.28040534f, -0.04816041f, -0.01159348f, 0.10405914f, -0.05571266f, 0.11532069f, 0.03903871f, 
    -0.24190547f, -0.19950427f, 0.01544298f, -0.10272024f, -0.08189102f, 0.31024653f, 0.32253653f, 0.45799571f, 
    -0.32837290f, 0.07297800f, -0.05971438f, -0.33341339f, -0.25387222f, -0.03530143f, 0.09281500f, -0.09974977f, 
    0.08239509f, 0.03916251f, -0.01040620f, 0.18992162f, 0.11754240f, -0.03401967f, 0.07214729f, 0.18187113f, 
    -0.36123422f, -0.09792944f, 0.16136497f, 0.01041492f, 0.06861740f, -0.03530668f, 0.04841762f, -0.35337704f, 
    0.07037529f, -0.15483259f, 0.13666193f, -0.14008400f, -0.18473341f, -0.02060102f, 0.06869853f, -0.01087060f, 
    -0.00534351f, 0.13069117f, -0.11531163f, 0.05746816f, 0.03507764f, -0.33091530f, 0.06265088f, 0.00163131f, 
    -0.38400093f, 0.08498483f, -0.10049411f, -0.04603023f, -0.09706723f, -0.09920787f, -0.00388585f, 0.06330387f, 
    -0.07566424f, -0.01441738f, -0.01051715f, -0.00111694f, -0.07750037f, 0.07360339f, -0.13692170f, -0.23937242f, 
    0.13598208f, 0.14545181f, -0.14037226f, 0.13012612f, 0.08060473f, 0.04507520f, 0.01266646f, -0.16977401f, 
    -0.03683164f, 0.06285600f, -0.18299168f, 0.18663314f, -0.02114549f, -0.17951480f, -0.16629244f, 0.10959971f, 
    0.12681630f, -0.12124567f, 0.15629992f, 0.09489382f, -0.30919167f, 0.02037446f, -0.05058892f, -0.16919746f, 
    0.11907841f, -0.15077987f, -0.04853936f, 0.13082650f, 0.07247694f, -0.04532766f, -0.11089740f, 0.08312332f, 
    0.04991290f, 0.07748888f, 0.04071571f, 0.14664197f, 0.01626911f, -0.00055075f, 0.05165755f, 0.13879111f, 
    -0.01652593f, 0.02972067f, -0.11626305f, 0.27716550f, 0.02649966f, 0.01465071f, -0.08835191f, -0.23390965f, 
    -0.01215829f, 0.10201589f, -0.05787674f, 0.07327224f, -0.11885165f, -0.05887360f, 0.11923278f, 0.07892933f, 
    -0.18048260f, -0.16261898f, -0.16295670f, 0.02620289f, 0.10586058f, -0.18351892f, -0.23300184f, 0.26531669f, 
    -0.35544232f, -0.01001190f, -0.07485992f, 0.05305541f, -0.09918705f, -0.03779769f, 0.02110266f, 0.10723624f, 
    -0.14580885f, 0.08750925f, 0.02211524f, -0.02996959f, 0.00705763f, 0.09427688f, -0.04210307f, -0.11202074f, 
    -0.08928941f, 0.07633691f, 0.33292526f, -0.00341645f, -0.01251652f, 0.03322678f, 0.02886136f, -0.13276763f, 
    0.02794622f, 0.05211543f, 0.00184941f, -0.08227762f, 0.23333710f, -0.05722991f, -0.09378930f, -0.04023814f, 
    -0.00434655f, 0.14260714f, 0.06330296f, 0.19666152f, -0.70205247f, 0.21260363f, 0.08270709f, 0.31359887f, 
    -0.09068806f, -0.01766353f, -0.15611361f, -0.02166952f, 0.51202768f, 0.07508568f, -0.14995213f, -0.02269935f, 
    0.17465301f, -0.01522137f, 0.10534712f, -0.04792803f, 0.08844001f, -0.13282543f, 0.41412842f, 0.21222033f, 
    0.14770192f, -0.18587765f, -0.04561636f, 0.10063525f, -0.12082201f, -0.04424238f, 0.04738351f, -0.19544996f, 
    -0.01557392f, 0.10008965f, -0.04219052f, -0.07817658f, 0.05822588f, 0.03578896f, 0.03562357f, -0.11539932f, 
    -0.05234765f, 0.09303675f, 0.11288029f, 0.12029919f, 0.03107562f, -0.59546292f, 0.15243722f, 0.27815038f, 
    0.02972538f, -0.26826295f, -0.01383014f, 0.05094771f, -0.34275410f, -0.10791978f, -0.08391692f, -0.04503364f, 
    -0.13433804f, 0.04550244f, 0.11292209f, 0.05486340f, -0.33635658f, -0.13841936f, -0.06720931f, -0.03497206f, 
    -0.28274238f, -0.59174007f, -0.38148585f, -0.17675798f, -0.16174151f, -0.08579706f, -0.16321227f, 0.15417917f, 
    0.10097646f, 0.00584625f, -0.20186533f, 0.09300077f, 0.02517643f, -0.03640806f, 0.00515950f, 0.11686991f, 
    -0.09510478f, 0.19588323f, 0.17677467f, 0.12468428f, -0.26578340f, 0.09807850f, -0.37462178f, -0.01059690f, 
    0.19036564f, -0.03297546f, -0.13868362f, -0.10156668f, -0.07538722f, 0.05933430f, -0.04463286f, 0.14243674f, 
    0.09711649f, -0.05371102f, -0.09716827f, 0.06019144f, -0.00582142f, -0.02487592f, -0.04322295f, -0.09781828f, 
    0.26117453f, 0.16224077f, 0.11717513f, 0.24757785f, 0.08887091f, -0.00918734f, -0.08214724f, 0.10796597f, 
    -0.11757929f, -0.10229365f, -0.12768424f, -0.03973202f, 0.00330948f, -0.07103375f, 0.11099491f, 0.00199357f, 
    -0.15512669f, -0.00901274f, 0.05157725f, -0.09800790f, 0.10791769f, 0.19728121f, 0.35923472f, 0.01258974f, 
    0.00554524f, -0.16159837f, -0.11137930f, 0.01408795f, 0.06493691f, -0.08231382f, -0.06350847f, 0.04358798f, 
    -0.05085444f, 0.06608561f, -0.11888804f, 0.08880780f, -0.06217025f, 0.07997365f, 0.02350183f, 0.02919914f, 
    -0.37100315f, 0.54964423f, -0.22323103f, 0.23517843f, 0.04645753f, 0.11956398f, -0.10673392f, -0.09387328f, 
    0.10180686f, 0.06369580f, -0.05044840f, -0.09111086f, -0.01064783f, 0.02998990f, -0.08900140f, -0.06655272f, 
    -0.08873452f, -0.17948398f, 0.08245268f, -0.08087102f, -0.49460834f, 0.14138556f, 0.07163387f, 0.31064633f, 
    0.16512530f, -0.00478327f, 0.00037985f, 0.19146188f, 0.21622090f, 0.17722020f, -0.20177504f, -0.01553887f, 
    0.13645972f, -0.07713907f, -0.09508329f, -0.19461049f, 0.10239778f, 0.06384435f, 0.02037965f, 0.35555875f, 
    0.04409759f, -0.36017475f, 0.32268727f, -0.07780911f, 0.06364877f, -0.23307703f, 0.02554010f, -0.05093918f, 
    0.07583909f, 0.10077671f, -0.12907550f, 0.11942124f, -0.02418625f, -0.05367696f, -0.01084226f, 0.00276909f, 
    0.27555221f, 0.03336372f, 0.26557395f, -0.09548854f, -0.37606758f, -0.08734944f, -0.50963897f, 0.05451730f, 
    0.08523665f, -0.11506622f, -0.07366144f, 0.00792798f, -0.01403600f, -0.10418789f, -0.06960712f, 0.03019678f, 
    -0.01472894f, 0.07178886f, 0.07549407f, 0.07092090f, -0.02949974f, -0.04214562f, -0.02040362f, 0.08880778f, 
    -0.40811631f, 0.18684518f, -0.37447512f, -0.20313995f, 0.07144197f, -0.07251143f, -0.07817812f, -0.04497944f, 
    -0.14794981f, 0.03080208f, -0.11776675f, 0.10289285f, -0.07469430f, 0.07716858f, -0.03542534f, 0.04011998f, 
    -0.17119947f, -0.04361757f, -0.04946735f, -0.06779109f, -0.27365580f, 0.20956275f, -0.49640542f, 0.22759596f, 
    0.16136689f, -0.10500342f, -0.00398471f, -0.02843322f, 0.12866560f, 0.15421519f, -0.05059278f, -0.13951495f, 
    0.00385194f, 0.02665734f, -0.03397813f, 0.13296400f, 0.03805632f, -0.13479985f, 0.16260767f, 0.29916036f, 
    -0.50137389f, 0.15708493f, -0.57774758f, 0.11349556f, 0.01778968f, 0.03831942f, 0.01183506f, -0.10248215f, 
    0.35109511f, 0.08518892f, -0.06177453f, 0.13416842f, 0.01799850f, 0.02020598f, -0.01027442f, 0.03920418f, 
    -0.21820219f, -0.32026577f, -0.07137559f, -0.18461929f, -0.24477169f, 0.06957273f, -0.45106861f, 0.03007976f, 
    0.11586666f, -0.01511582f, -0.07626046f, -0.02601092f, -0.07037108f, 0.04176192f, 0.01680689f, 0.09876520f, 
    -0.03933327f, -0.01421911f, -0.00582310f, 0.03297174f, -0.06569308f, -0.10866702f, -0.07410327f, -0.13780627f, 
    0.04291280f, -0.07657550f, -0.02685804f, 0.07824551f, -0.08485279f, 0.02472309f, 0.02380301f, 0.11921116f, 
    -0.02842604f, -0.06194925f, -0.02945987f, 0.00889451f, 0.06236374f, 0.04128107f, 0.02617151f, 0.04951930f, 
    -0.05354509f, 0.06784481f, -0.03170462f, -0.07889053f, 0.15206669f, 0.17344902f, 0.00542297f, 0.11064842f, 
    0.20051757f, 0.07755716f, -0.01823543f, 0.08563884f, -0.14486609f, 0.06427391f, -0.10935376f, 0.12298458f, 
    0.09579009f, 0.08727895f, 0.05136746f, -0.04601172f, 0.18648984f, -0.13296992f, -0.06367055f, 0.04516203f, 
    -0.32179630f, -0.42271376f, 0.09680270f, -0.05355228f, -0.19768144f, 0.00626650f, 0.07336308f, 0.09392527f, 
    -0.03724369f, -0.13902181f, 0.02841701f, -0.21250077f, 0.03770524f, 0.01345360f, -0.00378521f, 0.02089119f, 
    0.16953635f, 0.26825860f, 0.18563965f, 0.28078461f, -0.56612808f, 0.33813179f, 0.19990163f, 0.28821185f, 
    0.17146833f, 0.06777373f, -0.11420655f, -0.06754550f, 0.21015468f, -0.00558299f, -0.09205820f, -0.01924363f, 
    0.15061589f, -0.05689352f, 0.05201614f, -0.10596542f, 0.07964861f, -0.45913714f, -0.09421327f, 0.11354511f, 
    -0.16731557f, 0.16340798f, 0.12172342f, -0.03917590f, -0.08286060f, 0.08674198f, -0.05237287f, -0.12284186f, 
    0.15664601f, -0.10154103f, -0.04361778f, 0.08514667f, -0.05164618f, 0.00581028f, -0.09603718f, -0.03998010f, 
    -0.08417682f, -0.04631254f, -0.06661020f, -0.17643310f, -0.23619987f, -0.51805025f, -0.05871569f, -0.21803491f, 
    0.00452099f, 0.04305009f, -0.16453229f, 0.23546258f, 0.00751563f, -0.04558034f, -0.10893384f, 0.13301638f, 
    0.04822749f, 0.02694703f, 0.03531274f, 0.08209527f, -0.09460967f, 0.23166230f, 0.13803686f, 0.14635946f, 
    0.28893381f, -0.30205181f, 0.49843797f, 0.09476302f, 0.05654468f, 0.11303393f, -0.02073062f, 0.04489472f, 
    0.10481524f, -0.14100973f, -0.01299354f, -0.13199550f, 0.03658002f, 0.01085288f, -0.00034294f, -0.02532562f, 
    -0.28735483f, 0.03189138f, -0.24454379f, -0.39876923f, -0.07687204f, 0.08561553f, -0.18122409f, 0.01907174f, 
    -0.06933793f, -0.02966482f, 0.12570672f, 0.09354398f, -0.17696632f, -0.07106692f, 0.08145946f, 0.01820097f, 
    -0.08057129f, 0.03667707f, -0.08439429f, -0.00014466f, -0.02728895f, -0.15790254f, -0.35836387f, -0.27067024f, 
    -0.42607263f, -0.40965417f, 0.13155358f, -0.23733097f, -0.06688277f, 0.00948421f, 0.03318173f, -0.12712644f, 
    0.11050729f, -0.11304513f, -0.10674751f, -0.02998299f, 0.03507763f, -0.03735486f, 0.13811694f, 0.08489232f, 
    0.14114630f, 0.04990644f, 0.10475768f, -0.12181450f, 0.55998814f, -0.20415640f, 0.21572874f, -0.01911078f, 
    -0.11147133f, 0.08076993f, 0.14012733f, 0.09439227f, 0.14493573f, -0.00778054f, -0.06455577f, 0.12405947f, 
    -0.08179862f, -0.27812761f, -0.43110222f, -0.10964470f, -0.05204161f, 0.10080702f, 0.00366847f, -0.23125957f, 
    0.28363764f, -0.51702023f, 0.39532736f, -0.15178928f, -0.05999021f, -0.02729993f, 0.02819483f, -0.04546001f, 
    0.05215931f, -0.38260859f, 0.01708631f, -0.09276436f, -0.05214155f, -0.02061742f, 0.06670580f, 0.03634036f, 
    0.00719820f, 0.03926152f, 0.14205413f, 0.01609447f, -0.33039790f, -0.28471956f, -0.23907289f, 0.05551103f, 
    0.08044583f, -0.01862397f, 0.13848013f, -0.05769772f, 0.05599996f, -0.01609234f, -0.37504727f, -0.04026721f, 
    0.18064383f, 0.14208367f, -0.09233191f, 0.03419670f, -0.00402398f, 0.05085946f, -0.07616367f, 0.05683560f, 
    -0.32567492f, -0.15484323f, -0.20068321f, 0.20372848f, -0.32275066f, -0.04016009f, -0.23670985f, -0.07307763f, 
    -0.11657085f, 0.04772910f, -0.15417670f, -0.16203786f, -0.16472699f, -0.20380838f, -0.12302574f, -0.05422745f, 
    -0.08851495f, -0.09293790f, -0.01906857f, -0.11085771f, -0.16574880f, -0.28850210f, -0.31082025f, -0.05477054f, 
    0.03990326f, -0.07652280f, -0.28227991f, -0.08653787f, -0.28262633f, -0.13612571f, 0.05662211f, 0.11798755f, 
    -0.14182316f, -0.09642041f, -0.13362779f, 0.04257512f, -0.07059849f, 0.02438894f, -0.08842923f, -0.15639545f, 
    -0.08642189f, -0.15637876f, -0.04638268f, 0.34158820f, -0.18669578f, 0.00976855f, -0.12468304f, -0.07806832f, 
    -0.15800235f, -0.06130865f, -0.10517690f, -0.10745146f, 0.03920328f, 0.06694943f, 0.01992727f, 0.07992729f, 
    0.10954872f, 0.08569969f, -0.09086169f, -0.22717401f, 0.02825073f, -0.14852677f, -0.18580629f, 0.21597716f, 
    0.20542005f, -0.05165533f, 0.16472065f, -0.08925696f, 0.12738283f, -0.02844598f, -0.19145602f, -0.01821813f, 
    0.04893627f, 0.04469715f, -0.04428199f, 0.07961325f, 0.06056581f, -0.05106635f, -0.02262984f, -0.24753952f, 
    0.03058081f, 0.11265916f, -0.41881174f, 0.37967470f, 0.27013162f, -0.10710569f, 0.16898161f, -0.05213607f, 
    0.08919696f, 0.02397398f, -0.00218584f, 0.04291280f, -0.00846365f, -0.02413400f, 0.09813699f, -0.00479977f, 
    -0.15149137f, 0.09575924f, -0.06376407f, -0.11110587f, -0.16471317f, 0.19691868f, 0.29144681f, 0.28548241f, 
    -0.27508491f, -0.12932330f, -0.07112409f, 0.15981159f, 0.20346794f, -0.13272046f, -0.08482266f, -0.02287260f, 
    -0.05419917f, 0.01988935f, 0.17745768f, 0.21337058f, -0.10551059f, 0.00074716f, 0.04453350f, -0.26400933f, 
    -0.26216710f, -0.07757460f, -0.26535961f, 0.40796041f, -0.02575641f, -0.07921156f, 0.12964161f, 0.11139503f, 
    0.19241501f, 0.15611440f, -0.14259776f, 0.02149216f, 0.06027593f, 0.13817956f, -0.03760993f, -0.12233735f, 
    0.03723206f, 0.10909579f, -0.13899513f, -0.09630523f, 0.64246148f, -0.08278539f, 0.63614237f, -0.46618018f, 
    -0.11487581f, 0.03717586f, -0.05800111f, -0.01669394f, 0.19957022f, 0.02663088f, -0.10208121f, 0.11044773f, 
    -0.07870699f, -0.05278404f, -0.13156219f, -0.00754144f, 0.32426539f, -0.09240302f, 0.15604536f, 0.04352903f, 
    0.39305112f, 0.26765633f, 0.30452433f, 0.05120295f, -0.29415029f, -0.02928839f, 0.04511121f, -0.03640729f, 
    0.01823168f, -0.11877965f, -0.09360225f, 0.03468283f, -0.01584794f, 0.01590488f, -0.04585548f, 0.04335335f, 
    -0.01798548f, 0.05145236f, -0.21126528f, -0.02152243f, -0.13961504f, -0.09109308f, -0.26571229f, -0.02202138f, 
    -0.42851931f, -0.12106186f, -0.16353533f, 0.06483183f, -0.14846176f, -0.02144815f, -0.07362823f, 0.08860672f, 
    0.13910656f, 0.03103815f, -0.05474069f, 0.06886754f, 0.09739506f, 0.04821200f, 0.04802151f, 0.06692012f, 
    -0.49376619f, -0.32904312f, -0.01247444f, 0.19488868f, 0.01306092f, 0.18123843f, -0.01595363f, 0.29021102f, 
    -0.16876616f, 0.08322028f, 0.02630348f, -0.10705777f, 0.12757735f, 0.27501991f, 0.18435127f, 0.11227644f, 
    -0.05534569f, -0.04532851f, 0.08835182f, 0.08785494f, -0.02840199f, -0.58966517f, 0.54254520f, -0.10257804f, 
    0.22628951f, 0.28094134f, 0.34735087f, 0.04495458f, -0.02206727f, 0.00194100f, -0.06374256f, -0.00151693f, 
    0.01045401f, 0.12621668f, 0.12437621f, -0.01226539f, 0.05348199f, 0.12543516f, -0.10854004f, 0.01529010f, 
    -1.04303920f, -0.06858516f, -0.85665685f, 0.53798312f, -0.39001065f, 0.02215594f, 0.19917084f, -0.04473709f, 
    0.27493474f, 0.07854418f, -0.10446057f, -0.08280793f, -0.06519417f, 0.05051535f, -0.06644648f, 0.05913888f, 
    0.00456008f, 0.21369211f, -0.03817771f, 0.12049393f, -0.33003482f, 0.23719892f, -0.28940123f, 0.45802659f, 
    -0.09481175f, -0.13855009f, -0.20977758f, 0.29442754f, 0.08371454f, -0.05145403f, -0.12820640f, 0.01985627f, 
    -0.28511876f, 0.01364470f, -0.06534357f, 0.14487149f, -0.00756920f, 0.07261681f, -0.15938336f, -0.08728239f, 
    0.21129231f, 0.12562838f, 0.12864149f, -0.00405443f, 0.31504878f, 0.04145499f, 0.18473357f, 0.03412079f, 
    0.08031680f, -0.00513699f, 0.03481529f, 0.09134936f, 0.05567116f, 0.11464202f, 0.16038468f, -0.06804017f, 
    -0.05195766f, -0.04623364f, -0.05665233f, -0.05629510f, 0.19917433f, -0.43573156f, -0.21953411f, 0.09899229f, 
    0.01997008f, -0.29248258f, -0.39274234f, 0.07619986f, -0.15337214f, -0.29283926f, 0.02447410f, 0.02676395f, 
    0.05458033f, -0.05165883f, -0.04923625f, 0.01271045f, -0.12968175f, 0.05666233f, 0.20120008f, -0.14416662f, 
    0.24118856f, -0.47512650f, 0.02310870f, -0.23609748f, 0.20738924f, -0.11148984f, -0.22411518f, 0.02088690f, 
    -0.08800906f, -0.10597880f, -0.04470142f, -0.01634749f, 0.13001059f, -0.02410762f, -0.05315480f, 0.04894751f, 
    -0.11490653f, 0.02934958f, 0.01086670f, -0.04726020f, -0.14742334f, -0.25544426f, -0.19702670f, 0.36751616f, 
    -0.08144623f, -0.14768028f, -0.12819770f, 0.09671119f, 0.09204796f, -0.09843422f, 0.09888850f, 0.03401499f, 
    -0.10726089f, -0.04844199f, -0.18871792f, -0.06694037f, -0.16504435f, 0.08322787f, -0.14965950f, -0.47977033f, 
    0.04182563f, -0.16306283f, 0.25897461f, 0.13298196f, -0.02060366f, -0.09322485f, -0.51457608f, 0.04585357f, 
    -0.01347878f, -0.44591951f, -0.14984655f, -0.02555696f, 0.03227334f, -0.03855476f, 0.05987439f, 0.13401550f, 
    -0.08428472f, 0.03054998f, 0.24560834f, -0.13161249f, 0.15547313f, -0.21082473f, -0.20954016f, -0.20425358f, 
    0.02796108f, -0.12670672f, -0.19939514f, 0.14322726f, -0.05602385f, -0.00719982f, 0.00364510f, 0.10523514f, 
    0.10053017f, -0.10684970f, -0.05656316f, 0.07336816f, -0.05583898f, -0.05731145f, 0.05801145f, 0.14453773f, 
    0.45872253f, -0.11744510f, 0.34346199f, 0.26446101f, 0.15837790f, -0.08825028f, 0.16879016f, -0.19944745f, 
    0.17871124f, -0.05129864f, -0.15271880f, 0.10393384f, -0.04075183f, 0.00094188f, 0.01246510f, 0.02427777f, 
    0.16719662f, 0.02255645f, 0.13631840f, -0.02276326f, -0.49925095f, 0.12389365f, -0.17298560f, 0.37637129f, 
    -0.19715430f, 0.17168088f, -0.13957566f, 0.21383971f, -0.27323109f, 0.10812093f, -0.08026730f, -0.11793414f, 
    -0.09965031f, 0.01802237f, -0.07938107f, 0.12039666f, -0.18827084f, -0.01956156f, 0.08584467f, -0.04000296f, 
    0.23850247f, -0.01450622f, 0.13176228f, 0.13990782f, 0.04541636f, -0.07594384f, 0.07688241f, -0.08382467f, 
    -0.10110287f, 0.00347756f, -0.05098291f, 0.14497946f, -0.01370616f, 0.13929355f, 0.10954025f, -0.16403157f, 
    -0.11304690f, -0.13715534f, -0.29535121f, -0.11910395f, -0.57422519f, -0.11356001f, -0.36953649f, 0.70226139f, 
    -0.06635931f, 0.03725943f, -0.09765028f, 0.00751661f, 0.09292147f, -0.17370340f, -0.02711753f, 0.01848637f, 
    -0.10436825f, 0.00051558f, 0.19292133f, 0.03794078f, 0.08161740f, 0.31732443f, 0.08399004f, 0.10794363f, 
    -0.35768455f, 0.17972544f, -0.20369874f, 0.10817970f, -0.33191371f, 0.15397140f, 0.06161430f, 0.06791410f, 
    0.06540076f, 0.03687996f, -0.12511517f, -0.10631663f, -0.06537004f, 0.12010752f, -0.02636694f, 0.05195138f, 
    -0.04792699f, 0.02551364f, -0.19598599f, 0.07762532f, 0.41776732f, 0.28969181f, 0.46681917f, 0.11988506f, 
    -0.19020760f, -0.00965029f, 0.00501954f, -0.00213418f, -0.13397662f, -0.09113834f, -0.15503217f, 0.03894526f, 
    -0.08372081f, 0.04243267f, -0.02588485f, -0.03498644f, -0.04061035f, 0.04953354f, -0.16472588f, 0.08020794f, 
    -0.51060426f, -0.36894149f, -0.49298474f, 0.27979279f, 0.23981422f, 0.01706030f, 0.13559437f, 0.20242682f, 
    -0.15976608f, 0.13939546f, 0.09983957f, 0.15306658f, -0.05163389f, -0.04636591f, 0.04009655f, 0.05843974f, 
    0.17820875f, 0.25318524f, 0.22233145f, -0.02716511f, -0.46447408f, -0.31991875f, -0.20070486f, 0.00291370f, 
    0.21849664f, -0.02297427f, 0.01978547f, 0.08763540f, -0.04421448f, -0.00331235f, -0.02874942f, 0.06293302f, 
    0.05274475f, -0.01662813f, 0.11939050f, 0.23899534f, -0.06963339f, 0.10628215f, 0.10314485f, 0.07536022f, 
    0.17937995f, -0.03880192f, 0.06295040f, 0.08410580f, 0.21210803f, 0.03724506f, 0.18943012f, -0.00358521f, 
    0.16252719f, -0.21591656f, -0.11681867f, -0.00732128f, 0.14048921f, -0.00664883f, 0.10330210f, 0.10382675f, 
    -0.04814072f, 0.07859635f, -0.10469308f, -0.02233751f, -0.75076109f, 0.06777915f, -0.57111108f, -0.21754320f, 
    -0.13657606f, 0.21365382f, 0.23761098f, -0.13314617f, 0.07326975f, 0.09899635f, -0.11051762f, -0.00312894f, 
    0.16359088f, 0.09472785f, 0.04882640f, 0.04994898f, -0.02627796f, 0.08068333f, 0.16082738f, 0.18231769f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.18442684f, 0.16605294f, 0.04365497f, -0.08123396f, -0.06315833f, 0.00445761f, 0.06027535f, -0.07121444f, 
    0.07754914f, 0.05298960f, -0.01481100f, 0.03284847f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
