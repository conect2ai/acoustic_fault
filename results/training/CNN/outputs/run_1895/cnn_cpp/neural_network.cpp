#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.47130227f, 0.41037562f, -0.37229455f, 0.01029677f, -0.04636624f, -0.22045763f, -0.34472767f, -0.25628963f, 
    0.02040735f, -0.00052402f, 0.03872886f, 0.14726192f, 0.24078010f, 0.19695464f, 0.12141876f, -0.16651316f, 
    0.27384239f, -0.10868436f, 0.34467325f, -0.09453566f, 0.11897156f, -0.15973616f, -0.13456683f, -0.14712848f, 
    -0.44411936f, 0.87731773f, 0.86583412f, -0.31318706f, -0.42589095f, -0.10458029f, -0.38471079f, -0.29880708f, 
    -0.22154909f, 0.12107521f, 0.20401928f, 0.06926307f, -0.22318923f, -0.03357831f, 0.09685995f, -0.22692239f, 
    -0.01259961f, 0.04613976f, 0.19128342f, -0.20048982f, -0.18810083f, 0.16040018f, 0.14697687f, -0.07155321f, 
    0.29972333f, -0.10178979f, 0.67486709f, -0.31685695f, -1.00241172f, -0.91091132f, -0.41617483f, 0.01730625f, 
    0.19798426f, 0.34151635f, 0.06828487f, -0.39093602f, 0.41965914f, -0.65218115f, -0.29966971f, -0.25459066f, 
    -0.19597413f, -0.40945283f, -0.64506024f, 0.06188997f, -0.17764969f, -0.46051642f, -0.23277059f, 0.12194089f, 
    0.30079296f, 0.30023754f, 0.09398882f, 0.74570078f, -0.32841238f, -0.47908324f, -0.62844485f, -0.87019885f, 
    -0.37359872f, -0.64743638f, -0.48507640f, 0.40524414f, -0.22598526f, 0.36152524f, 0.39257672f, 0.32135484f, 
    0.38703805f, 0.23418118f, -0.05359466f, -0.19806562f, -0.04372021f, -0.15860572f, -0.36421081f, -0.14553171f, 
    -0.13299344f, 0.25468269f, -0.19340570f, -0.15364614f, 0.81043828f, 0.72873372f, -0.39567086f, -0.90562022f, 
    -0.73980498f, 0.51385599f, -0.15130621f, -0.15071684f, -0.13068086f, -0.26795718f, 0.37053308f, -0.11740012f, 
    0.70368314f, -0.27190149f, -0.04887340f, 0.14138246f, 0.29190114f, -0.01469616f, -0.21412222f, -0.27614716f, 
    0.01039715f, -0.06160520f, -0.17227197f, -0.06039305f, 0.15652458f, -1.14696479f, -1.06846201f, -0.39328295f, 
    0.52642548f, 0.81594223f, 0.46985060f, -0.43709326f, -0.41865465f, 0.40297276f, 0.58844590f, 0.12941985f, 
    -0.34539565f, -0.53731441f, 0.08685703f, -0.06952723f, -0.00812497f, -0.03168628f, -0.09696835f, 0.22229527f, 
    -0.34883747f, -0.39574027f, -0.22052540f, -0.46448109f, -0.32490811f, -0.64817369f, -0.97760302f, -0.64821333f, 
    -0.26778105f, 0.56642789f, 0.14734833f, 0.35851961f, -0.45277646f, -0.36587119f, -0.20161012f, -0.38578048f, 
    -0.22141361f, -0.46052957f, -0.29103076f, 0.37223268f, -0.63073820f, 0.36192140f, -0.11267663f, 0.36297774f, 
    -0.06392126f, 0.15757377f, 0.01670884f, 0.08874371f, 0.08026497f, 0.12477908f, 0.34117061f, 1.13295221f, 
    0.39236376f, -0.77161461f, -0.54338920f, 0.42432937f, 0.43779123f, 0.01985385f, -0.16069745f, -0.68219638f, 
    -0.86157435f, 0.19503289f, 0.18905631f, 0.05121875f, -0.12957036f, -0.10346320f, 0.10012735f, 0.12379155f, 
    -0.03678005f, -0.26376593f, 0.16194876f, -0.07043285f, -0.14598805f, -0.06219317f, 0.07415929f, -0.12526500f, 
    -0.18412068f, -0.06891687f, -0.00319724f, -0.19185480f, -0.01177418f, 0.68045986f, -0.56781322f, 0.46913365f, 
    0.52973497f, -0.22043338f, 0.01578016f, 0.01018528f, 0.10425433f, 0.25755578f, -0.55664653f, 0.03296360f, 
    0.49513909f, 0.17272021f, -0.50841916f, -0.33183661f, 0.29976347f, -0.25986230f, -0.05435369f, 0.00675350f, 
    -0.09019902f, -0.08421029f, 0.14497165f, -0.33242935f, -0.22035009f, -0.21434331f, 0.39175025f, -0.15763249f, 
    -0.14830804f, -0.04168146f, 0.18866174f, 0.00252810f, 0.51173240f, -0.21961479f, 0.40064695f, -0.50179327f, 
    -0.18031096f, 0.06508062f, -0.05909957f, 0.18488577f, -0.14810395f, 0.38304511f, 0.47531885f, 0.29329890f, 
    0.33306620f, 0.04020816f, -1.32815778f, 0.21593978f, -0.43578532f, -1.30611873f, -0.92497474f, 0.46887836f, 
    0.27364600f, 0.25236705f, 0.32103315f, 0.38851550f, -0.03019162f, -0.03664032f, 0.00919311f, 0.23592132f, 
    0.08276054f, 0.17196068f, 0.02510538f, 0.01012699f, 0.14291348f, -0.05822196f, -0.15827371f, 0.02620907f, 
    -0.08173542f, -0.26254061f, -0.40022293f, -0.66962206f, -0.83098513f, -0.11581235f, -0.15858653f, 0.24545409f, 
    -0.43360838f, -0.52577299f, -0.06700486f, -0.60704678f, -0.63233924f, 0.28242868f, 0.09076461f, -0.24598457f, 
    -0.00222112f, -0.37887570f, -0.39117655f, -0.66892445f, -0.45817658f, 0.03170178f, -0.26938370f, -0.07413623f, 
    -0.25510454f, 0.19127735f, -0.35101485f, -0.12221967f, -0.24389964f, 0.54582900f, 0.40638769f, -0.61694777f, 
    -0.68154389f, -0.10507635f, 0.30464122f, -0.68827522f, -0.61150551f, 0.93126774f, -0.19513400f, 0.06115826f, 
    -0.01469439f, 0.17266072f, 0.21942905f, 0.33109441f, -0.31359860f, -0.09164969f, 0.06691831f, -0.31976464f, 
    -0.08429574f, -0.13234770f, 0.28373855f, 0.14038768f, 0.14287342f, -1.56084287f, 0.58943808f, 0.32733458f, 
    -0.52572769f, -0.15006794f, -0.10541383f, 0.01789597f, 0.05600801f, 0.88358957f, 0.77504253f, -0.24410978f, 
    -0.25682619f, -0.02852954f, -0.38943109f, 0.28969479f, 0.00924644f, -0.13263847f, 0.00997167f, -0.25729090f, 
    0.20016876f, -0.10991767f, -0.28202894f, 0.46050939f, 0.18379979f, -0.16853490f, 0.06259901f, -0.43762428f, 
    -0.18879645f, 0.23000541f, 0.13586047f, -0.35044527f, -0.45442051f, 0.19119480f, 0.22530942f, 0.36303857f, 
    0.00921254f, -0.03073867f, -0.01893530f, -0.20087564f, 0.31587005f, -0.48159534f, 0.12493359f, 0.20884705f, 
    -0.00234105f, -0.46482041f, 0.25245985f, -0.08842027f, -0.35980746f, 0.32225072f, 0.45097971f, -0.19180000f, 
    -0.57827568f, -0.53999668f, 0.01512359f, -0.93629777f, -0.77533889f, -0.88329786f, -0.77948868f, -0.68450201f, 
    -0.94441891f, 0.26105294f, -0.20189364f, -0.02760562f, -0.12217402f, 0.46003675f, -0.20748572f, -0.02632617f, 
    -0.05912554f, -0.38513646f, -0.31631675f, -0.16376056f, -0.26384869f, 0.01101902f, 0.26116118f, -0.10910152f, 
    -0.60893941f, -0.55649430f, 0.04126143f, 0.30841142f, 0.76355034f, -0.79215866f, -0.72063982f, -0.15456337f, 
    -0.47743806f, -0.35376009f, 0.42431018f, -0.37017146f, 0.08114958f, -0.29544926f, -0.08968691f, 0.11727451f, 
    0.39836642f, 0.04297205f, 0.17472270f, 0.49198556f, 0.02745219f, -0.30015150f, 0.04332444f, -0.01015725f, 
    -0.16603458f, -1.63973594f, -0.62637609f, -0.58297670f, -0.52994037f, -0.44809523f, 0.41984266f, 0.81617486f, 
    -0.42897335f, -0.60984075f, 0.52184677f, -0.17996906f, -0.55437136f, -0.44419160f, -0.22267745f, -0.17752066f, 
    0.05384207f, 0.32724562f, -0.24306521f, -0.39928147f, -0.25737995f, -0.05410222f, -0.24132285f, 0.10669734f, 
    0.09038839f, -0.03401238f, 0.65786141f, -0.61221862f, -1.22065628f, -0.87042046f, -0.72791088f, 1.09968925f, 
    0.18261211f, 0.19310480f, 0.09156224f, 0.43093631f, -0.21685986f, 0.61389464f, -0.28450608f, -0.20982461f, 
    -0.47368103f, 0.00347726f, -0.41341215f, 0.08179514f, 0.09043607f, -0.11021192f, 0.04090536f, -0.09899621f, 
    0.13127139f, 0.28884795f, 0.36633644f, -0.36680323f, -0.65713042f, -0.93683136f, -0.80888528f, -0.10630693f, 
    -0.61676949f, -0.87738895f, -0.22003233f, -0.20620812f, -0.21041095f, 0.03584243f, 0.34346542f, 0.77945060f, 
    -0.21278657f, -0.19687420f, 0.12298951f, 0.06041257f, 0.00626510f, 0.24102679f, 0.36757275f, 0.48188129f, 
    -0.13675311f, -0.37378067f, -0.05042495f, 0.08608147f, 0.27519077f, 0.37277600f, 0.03115415f, -0.44996822f, 
    -0.41776502f, 0.06930680f, 0.21467380f, 0.40075663f, -0.50469530f, -0.52821928f, -0.30371860f, -0.05414943f, 
    0.13710026f, 0.34455177f, -0.49751881f, -0.16030179f, 0.20444927f, -0.09226581f, 0.33194134f, -0.26683849f, 
    -0.01019220f, -0.12214997f, -0.36048639f, 0.11682391f, 0.47217008f, -0.53726035f, -0.73149765f, 0.28130227f, 
    0.36998153f, 0.07469181f, -0.57428133f, -0.37756169f, 0.50204951f, 0.36647147f, -0.01888034f, 0.24681307f, 
    -0.07860427f, -0.44004261f, 0.33787063f, 0.02450589f, -0.10012516f, 0.25432017f, -0.00172986f, -0.53176230f, 
    -0.00627782f, -0.33069104f, 0.30619255f, 0.25758827f, -0.33774137f, -0.31633595f, -1.67006874f, 0.87752295f, 
    0.29030961f, -0.19072744f, 0.54270637f, 0.18330643f, -0.04356262f, -0.17729521f, -0.35265994f, -0.39556727f, 
    -0.01842260f, -0.02932687f, -0.13057390f, 0.38266391f, -0.46822244f, 0.33553272f, -0.03348389f, -0.54032654f, 
    -0.36641398f, -0.54392761f, -0.38177127f, -0.11838096f, -0.32474372f, -0.27470204f, -0.59914017f, 0.59999788f, 
    0.87933940f, 0.20266230f, -0.12931511f, -0.16649956f, -0.81057328f, -0.58366734f, -0.09669909f, -0.28876996f, 
    -0.57764673f, 0.10560480f, -0.18813346f, -0.22229211f, 0.20652646f, 0.48861030f, 0.00903920f, 0.02136525f, 
    -0.06087458f, 0.39887890f, -0.30507383f, -0.06837112f, 0.06919762f, -0.14385371f, 0.26764566f, 0.14566799f, 
    0.09597973f, -0.46549746f, -0.18613131f, 0.35400468f, 0.29389626f, -0.71786779f, -0.18951046f, 0.22596465f, 
    0.41785133f, 0.03706571f, 0.66657728f, -0.44892284f, -0.34045598f, -0.11640132f, 0.03486580f, 0.00541766f, 
    0.06110342f, 0.19232096f, -0.08844715f, -0.35246119f, 0.05215470f, -0.53607953f, -0.02470689f, 0.30914268f, 
    0.42243308f, -1.31953955f, -0.56715888f, -0.37369299f, -0.64358956f, -0.49650240f, -0.18781845f, 0.36883801f, 
    0.73407781f, 0.74743694f, 0.30305147f, -0.00210102f, 0.46051577f, 0.23133279f, -0.33790901f, -0.00855049f, 
    -0.20671983f, -0.32911506f, -0.12089364f, -0.41381902f, -0.49445090f, 0.17170481f, 0.44520131f, 0.16332893f, 
    -0.04782822f, 0.52813005f, 0.69655925f, 0.42562711f, 0.53715247f, 0.41854110f, 0.25724661f, -0.13311511f, 
    0.29859751f, 0.12875603f, -0.10432639f, -0.11521617f, -0.11362316f, 0.10551926f, 0.15426688f, -0.17776711f, 
    -0.07658816f, 0.11189516f, 0.09864146f, -0.13487679f, 0.08055954f, -0.27170160f, 0.09561039f, -0.11107788f, 
    -0.12548880f, 0.22393925f, -0.12506899f, 0.74899435f, 0.07248893f, 0.43889913f, 0.52701414f, -0.74245036f, 
    -0.62031239f, -0.04676620f, -0.28158349f, 0.23161429f, -0.29857618f, -0.04573153f, -0.07316347f, -0.05314613f, 
    0.31101424f, -0.46257603f, -0.12426604f, -0.02397126f, 0.11054140f, 0.14004129f, 0.11200250f, 0.12284413f, 
    -0.27486676f, -0.19252238f, -0.08879017f, -0.03145276f, 0.88544834f, 0.00565053f, -0.79463720f, -0.52877992f, 
    0.01374992f, 0.46718624f, 0.60579956f, 0.22558765f, -0.31157005f, -0.14460029f, -0.07589799f, -0.19847637f, 
    -0.39604566f, -0.08546279f, 0.16548964f, 0.03308723f, -0.15455273f, 0.15851726f, -0.14794873f, -0.42828175f, 
    -0.30746409f, -0.41623256f, -0.47695917f, -0.29229763f, -0.35179192f, 0.33352396f, -0.05720806f, 0.15301825f, 
    -0.26855561f, 0.18612294f, -0.15255910f, 0.09450837f, 0.39125475f, -0.13020153f, 0.51144159f, 0.03860467f, 
    0.34951976f, -0.24783717f, -0.31643102f, 0.44705421f, 0.09661492f, -0.07766479f, -0.16895948f, -0.21561679f, 
    -0.12687899f, 0.29464152f, 0.06625237f, -0.09166657f, -0.01037390f, -0.15063852f, 0.52534741f, -0.45893365f, 
    -0.31020847f, 0.14693025f, -0.36397797f, 0.43913966f, 0.17441103f, -0.17250100f, -0.52571458f, -0.59042144f, 
    0.22041626f, 0.43074748f, -0.27767581f, -0.49792469f, 0.41693366f, 0.10208560f, 0.30641031f, 0.02211459f, 
    0.14668445f, -0.02628158f, -0.58085287f, -0.28389254f, 0.07640900f, 0.24182716f, -0.40086553f, 0.67292345f, 
    0.33362201f, -0.12442220f, -0.89382815f, -0.85490090f, -0.03609898f, -0.22008714f, 0.06003770f, 0.37824431f, 
    0.57265526f, 0.15140690f, -0.09394471f, -0.14479257f, -0.02851306f, -0.27325511f, 0.00194828f, 0.04246369f, 
    0.31122890f, 0.20556365f, -0.27026102f, 0.11910062f, 0.13425437f, -0.34368122f, -0.02947092f, 0.36742720f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.06565477f, 0.34767345f, -0.15204714f, 0.32919714f, 0.37188801f, 0.03409519f, 0.26337966f, 0.22415616f, 
    0.56451923f, -0.02052804f, 0.04687037f, 0.33014017f, 0.49466947f, 0.39435253f, 0.48198590f, -0.41580793f, 
    0.41972610f, -0.36397901f, 0.40558508f, 0.13844213f, 0.53971380f, 0.27272466f, -0.06027713f, 0.15328546f, 
    0.45812199f, 0.28796765f, 0.00499691f, 0.37296817f, 0.14061019f, 0.02231325f, 0.22727022f, 0.21798559f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.02833189f, 0.01867318f, 0.08685368f, 0.14861238f, -0.00615539f, -0.00357841f, 0.08773327f, 0.00496053f, 
    -0.05732466f, -0.03223055f, -0.13766886f, 0.09458359f, -0.26363647f, -0.03422079f, -0.28149018f, 0.18481852f, 
    0.02851798f, 0.06528524f, -0.07668830f, -0.02746518f, -0.00817750f, -0.03856226f, 0.00692265f, 0.01741394f, 
    0.26555243f, -0.07150155f, -0.33193135f, 0.00791979f, 0.02136423f, -0.00129312f, -0.41930124f, -0.19963196f, 
    -0.01751873f, -0.23831704f, -0.29025728f, 0.07877801f, 0.45816419f, -0.07805750f, -0.13891406f, -0.27753875f, 
    -0.10629843f, -0.04850613f, -0.05581379f, -0.00559280f, -0.05456892f, -0.06152588f, -0.03366799f, 0.05994410f, 
    0.28370562f, -0.26067367f, -0.67111933f, 0.08058478f, -0.03430289f, 0.00204989f, -0.00310475f, -0.05651971f, 
    -0.15851700f, 0.02585672f, -0.07424155f, 0.13648400f, 0.53409636f, 0.19515589f, 0.17295936f, -0.11437279f, 
    0.01944139f, 0.13411717f, 0.13407066f, -0.05759706f, 0.02107329f, 0.02047955f, 0.19203427f, 0.10182077f, 
    0.56874239f, 0.21087843f, -0.04914479f, -0.41827679f, -0.02503532f, -0.01832504f, 0.05765774f, 0.08021259f, 
    0.02952041f, -0.00317593f, -0.02459987f, -0.11905443f, 0.01094501f, -0.16697958f, -1.24132335f, 0.38279065f, 
    -0.06069477f, -0.32621008f, 0.22007333f, -0.02037928f, -0.14926605f, 0.15614177f, 0.06728370f, -0.17286254f, 
    -0.19168474f, -0.24583833f, 0.06514924f, -0.02698373f, -0.10435104f, 0.06513403f, -0.11553597f, 0.07095886f, 
    -0.12560132f, -0.04076230f, -0.10173805f, -0.21153802f, 0.05879227f, 0.01479589f, -0.02800100f, 0.03688376f, 
    -0.10386103f, -0.09215825f, -0.31738538f, -0.13564576f, -0.03606844f, -0.09882195f, 0.00711543f, -0.04704038f, 
    -0.02336034f, -0.05199180f, 0.06014588f, 0.04744922f, 0.12562837f, 0.28781396f, -0.02896700f, 0.08153296f, 
    -0.11368641f, 0.11584288f, 0.05592474f, 0.08206304f, 0.49741513f, 0.21826957f, -0.05392916f, -0.22778887f, 
    0.06041760f, 0.07773720f, 0.00472903f, 0.10236707f, -0.14061937f, -0.25413978f, -0.21983433f, -0.15645434f, 
    0.11796259f, -0.03748918f, -0.19794805f, 0.01840951f, -0.21555829f, -0.04987801f, -0.21366674f, -0.17441368f, 
    -0.26138964f, 0.00832391f, 0.02664594f, 0.03238742f, -0.65603381f, -0.13212118f, 0.37002194f, -0.17422369f, 
    -0.15154259f, 0.01986070f, 0.04657880f, 0.18836765f, -0.05715522f, -0.08594614f, 0.02656973f, -0.20399936f, 
    -0.20685363f, 0.03588993f, 0.10847462f, -0.22553138f, -0.11181768f, 0.09134152f, -0.06904385f, -0.09354152f, 
    -0.18292578f, -0.21320972f, -0.12661867f, -0.14772077f, 0.49540347f, 0.16964626f, -0.03799717f, -0.27100161f, 
    0.15606630f, 0.07670143f, -0.05073762f, -0.00043729f, 0.00308141f, -0.02696978f, -0.01498676f, 0.06272209f, 
    0.46994317f, 0.17186929f, 0.17998734f, -0.30251646f, 0.03935724f, 0.05631560f, 0.00702548f, 0.13695405f, 
    -0.00736433f, 0.09888504f, 0.00231879f, -0.05391338f, 0.50692677f, 0.23836611f, -0.02808259f, -0.10284191f, 
    0.14107227f, 0.12959027f, 0.10499953f, 0.16856286f, -0.12771387f, 0.00927596f, 0.01928006f, -0.07929600f, 
    0.04254786f, -0.20054251f, -0.39942649f, -0.00249680f, 0.13834000f, 0.10473654f, -0.01311207f, -0.29751340f, 
    0.09664286f, 0.07037147f, 0.02518646f, 0.06755229f, 0.38638312f, 0.32356998f, -0.16476540f, -0.17693362f, 
    0.14874163f, -0.06050878f, 0.05943374f, -0.02999868f, 0.02706292f, -0.04164204f, 0.11128546f, 0.03524043f, 
    -0.11845962f, -0.50313717f, -0.07199024f, 0.02943109f, -0.07247846f, -0.15356612f, -0.32214552f, -0.04921680f, 
    -0.09457037f, 0.04106972f, -0.10659257f, -0.03367610f, -0.03372438f, -0.06940490f, 0.24508560f, -0.42373654f, 
    -0.03937499f, -0.02417823f, 0.06753860f, 0.01891761f, -0.22349156f, -0.24299169f, -0.32872468f, -0.04659664f, 
    0.11367952f, 0.11780040f, -0.28088292f, 0.14858022f, -0.16053744f, -0.03693783f, 0.03729010f, 0.10631414f, 
    -0.09154142f, 0.17225263f, 0.02577138f, 0.07434480f, -0.12141119f, 0.03385136f, 0.02505345f, -0.33095145f, 
    0.06382421f, 0.08116265f, -0.01993530f, -0.20347014f, 0.05936945f, 0.09354612f, 0.01678089f, -0.02491798f, 
    -0.13658412f, -0.01599708f, 0.04877814f, -0.37820572f, -0.13333373f, 0.10786424f, -0.04825047f, 0.01690952f, 
    -0.08527044f, -0.06034442f, -0.00908358f, 0.06817133f, -0.17739944f, 0.00175295f, 0.16618125f, -0.02127422f, 
    0.14602129f, 0.20641330f, 0.04543365f, -0.19877297f, -0.22162129f, -0.20826995f, -0.01600580f, -0.08196856f, 
    -0.21130677f, -0.13635606f, -0.15960732f, 0.18179841f, 0.07455088f, 0.07191855f, 0.05060694f, 0.01875931f, 
    0.02632755f, 0.05241549f, 0.08930859f, 0.07210374f, -0.29568294f, -0.14370783f, 0.06420124f, -0.32846236f, 
    0.00380939f, -0.01243984f, -0.07746180f, -0.05674068f, 0.01548013f, 0.01482899f, -0.02489517f, 0.08505732f, 
    -0.24126340f, -0.56342757f, -0.34448355f, 0.21183497f, -0.02184814f, 0.09145547f, -0.09532103f, -0.08187191f, 
    0.04522131f, -0.10260813f, -0.17648570f, 0.16444124f, -0.09552277f, 0.06292303f, 0.01934890f, 0.02684064f, 
    0.03592212f, 0.08676627f, 0.01172754f, 0.01684863f, -0.03361783f, -0.07219565f, -0.13509697f, -0.29215676f, 
    0.28699172f, -0.04577031f, -0.21403909f, 0.10278019f, 0.21395245f, -0.10035674f, -0.00508367f, -0.13293004f, 
    -0.18259786f, 0.00735135f, 0.13297631f, 0.06658141f, -0.00404319f, -0.28756139f, -0.13431582f, -0.02136439f, 
    -0.01169616f, 0.21229288f, 0.04166424f, -0.16779119f, 0.07996322f, -0.11397502f, 0.12679359f, -0.05406728f, 
    -0.11185138f, -0.03100723f, 0.05319735f, 0.00065112f, 0.06021535f, -0.00351320f, -0.02460870f, 0.10920888f, 
    -0.06731877f, -0.00349129f, 0.14141463f, 0.17975733f, 0.12367540f, 0.13050781f, 0.32342795f, -0.14001624f, 
    0.05381278f, -0.19524570f, 0.02120314f, -0.01883940f, -0.03311089f, -0.04233496f, 0.02670965f, 0.08855464f, 
    0.10614114f, 0.25255987f, 0.18853223f, -0.37346330f, -0.16492936f, -0.08898960f, 0.25648835f, -0.00247995f, 
    0.07541589f, -0.00562550f, -0.18332870f, 0.00195098f, -0.23346068f, -0.22588243f, -0.05953604f, -0.26710182f, 
    0.16525678f, 0.22381374f, -0.11690126f, 0.09092570f, 0.24290545f, 0.08597807f, 0.01742477f, 0.09346014f, 
    0.08819945f, -0.32375214f, -0.06134335f, -0.34009817f, 0.18301979f, 0.10478108f, 0.10755672f, -0.13093854f, 
    -0.08224127f, 0.31460676f, 0.01360663f, 0.06543182f, -0.01233182f, 0.20249271f, -0.26456347f, -0.04718718f, 
    0.04824710f, -0.00479140f, 0.03109615f, 0.01414421f, -0.14261754f, -0.29925045f, -0.29819891f, -0.30358177f, 
    -0.04358230f, 0.09779639f, 0.12517370f, 0.02464122f, -0.06120513f, 0.05699782f, 0.26423100f, -0.12217896f, 
    0.01698088f, -0.02539624f, -0.04279528f, -0.07828610f, 0.31422624f, -0.07452137f, -0.29017869f, 0.17039965f, 
    -0.18567337f, -0.21781713f, 0.23746932f, 0.06808930f, -0.07711007f, 0.18409148f, -0.18151286f, 0.22739221f, 
    -0.00788954f, 0.10056888f, 0.13901378f, -0.09825716f, -0.06782904f, -0.02502781f, 0.07991812f, 0.11561519f, 
    0.00350643f, 0.06373046f, 0.18984011f, 0.00983179f, -0.01864856f, -0.01549405f, -0.05613621f, 0.03255945f, 
    0.06323505f, -0.01649627f, -0.02909152f, 0.07090700f, -0.19445677f, -0.15578185f, 0.00237538f, 0.01479601f, 
    -0.27520815f, 0.02859886f, -0.04171980f, -0.11163070f, 0.06127423f, 0.09283724f, -0.22929528f, -0.16587786f, 
    -0.16127379f, 0.07865449f, 0.03479065f, -0.17655264f, -0.27402949f, -0.08058066f, -0.11249692f, -0.01142881f, 
    0.02989081f, 0.10842457f, 0.16797595f, 0.11669220f, 0.03534026f, 0.11696135f, -0.10330144f, 0.02823871f, 
    0.16773406f, -0.34374362f, 0.13721219f, 0.01888098f, 0.24846725f, 0.28277132f, -0.00220478f, 0.15361077f, 
    0.27477413f, -0.00767639f, 0.02043293f, -0.14639311f, -0.61198246f, 0.59713751f, 0.17325485f, -0.20808733f, 
    0.04151229f, -0.08755969f, -0.00482581f, -0.08907357f, 0.03909824f, 0.09744729f, -0.15602081f, 0.04396535f, 
    -0.27568570f, 0.33572313f, 0.07180023f, -0.03155880f, -0.05162692f, 0.09760410f, 0.05812106f, 0.01227364f, 
    0.10076154f, 0.07445373f, 0.04711786f, 0.05211917f, -0.01686685f, 0.15355027f, 0.30057350f, -0.12072783f, 
    -0.06126723f, -0.08121376f, -0.02409025f, -0.01818803f, 0.03770434f, 0.00696867f, 0.04551364f, -0.02042555f, 
    -0.31655368f, 0.10625416f, -0.38660336f, -0.17603643f, 0.05766106f, 0.09269951f, 0.08123885f, -0.31740651f, 
    -0.06671713f, -0.06816479f, -0.00267083f, 0.02181386f, 0.72387105f, 0.13248351f, 0.34070894f, -0.08443750f, 
    0.11725653f, -0.05544591f, -0.01417905f, -0.17427690f, 0.08445297f, 0.03387138f, -0.14781688f, -0.17771481f, 
    0.68394685f, 0.15327793f, -0.19694510f, -0.31680036f, -0.08240192f, -0.04210501f, 0.09054575f, -0.01861071f, 
    0.04967095f, 0.06789549f, -0.19397697f, -0.17821328f, -0.12746276f, 0.07526314f, -0.09385762f, 0.35149136f, 
    -0.14706299f, 0.07442309f, -0.17167510f, -0.16433805f, -0.08220635f, -0.08297169f, 0.04820987f, 0.00854558f, 
    0.49505410f, -0.21028955f, 0.15120448f, 0.04777506f, -0.04919690f, 0.07006695f, 0.20160800f, -0.12617540f, 
    0.11933437f, -0.07077637f, 0.07058980f, 0.06779565f, -0.40502062f, 0.22278410f, -0.00528230f, -0.03323802f, 
    -0.14199126f, -0.01546910f, 0.04286347f, 0.12004870f, -0.04071930f, 0.07360961f, -0.18210138f, 0.15879150f, 
    -0.20173608f, -0.60142761f, -0.22571595f, 0.15177190f, 0.16192891f, -0.07868119f, -0.04139685f, 0.02204058f, 
    -0.17238896f, -0.20684311f, -0.48511973f, -0.10861368f, 0.31132495f, -0.02788741f, 0.00322820f, -0.21672441f, 
    -0.17226398f, -0.04641352f, 0.02167563f, 0.13688132f, -0.03817480f, -0.06844797f, -0.04629839f, 0.05800003f, 
    -0.33905014f, 0.30542865f, 0.10921279f, 0.11595946f, 0.09374061f, 0.06057478f, 0.04110371f, -0.24309357f, 
    0.13181423f, 0.00768807f, -0.02782059f, 0.11112179f, -0.79766995f, -0.03218673f, -0.39690748f, -0.26534584f, 
    -0.07690951f, 0.11798030f, -0.07423067f, 0.16767834f, -0.07944725f, 0.22472383f, -0.05432446f, 0.02061625f, 
    0.29482689f, 0.22250956f, 0.19084725f, 0.16054428f, -0.03321456f, -0.06714081f, 0.01769466f, -0.16299735f, 
    -0.00623161f, -0.01836461f, 0.08819547f, 0.08319033f, 0.14510752f, 0.06468622f, 0.07760351f, -0.32616377f, 
    0.04636548f, -0.04209555f, -0.09238682f, -0.11847402f, -0.04803211f, -0.06841543f, 0.13131253f, 0.00226690f, 
    0.53247356f, 0.04126606f, 0.20318875f, 0.00144605f, -0.02510244f, -0.02839246f, -0.09946541f, -0.05624427f, 
    -0.19296527f, -0.18259957f, -0.39706713f, -0.28462481f, 0.15712225f, 0.15703662f, 0.13496487f, 0.09992132f, 
    -0.04841159f, -0.01562038f, -0.09992345f, -0.03902656f, 0.09109769f, -0.00545759f, -0.08673477f, 0.06860463f, 
    0.08559989f, -0.07645953f, -0.18335965f, -0.12829125f, -0.28277507f, 0.07879774f, 0.21666683f, 0.05593202f, 
    0.32507968f, 0.05935393f, -0.10136491f, 0.03656027f, -0.02126682f, -0.12005976f, 0.34841517f, -0.39101815f, 
    0.04359777f, 0.07745430f, -0.15464926f, -0.04213923f, -0.12841107f, -0.06788511f, 0.02085210f, -0.08710115f, 
    -0.17525132f, -0.03229418f, 0.06562735f, 0.06828137f, -0.03133811f, -0.05333174f, -0.15398732f, -0.13949719f, 
    0.14332569f, -0.13060033f, -0.01653592f, 0.13944168f, -0.20789251f, -0.26002064f, 0.36137298f, -0.12916680f, 
    0.09850244f, -0.04638880f, -0.02887836f, 0.10141879f, 0.03137307f, -0.01825578f, -0.00886227f, -0.01543108f, 
    -0.39748189f, 0.52498060f, 0.42982891f, -0.44004565f, -0.00505855f, -0.03188191f, 0.08866867f, -0.10278164f, 
    -0.03797925f, 0.01498129f, -0.00545391f, -0.26217693f, -0.45170429f, 0.30082232f, -0.04750391f, 0.11210001f, 
    -0.09406293f, -0.07693223f, 0.09182637f, -0.40187645f, 0.11627943f, 0.03431095f, -0.00668510f, 0.06887872f, 
    -0.03029669f, 0.07230017f, 0.10458319f, -0.13548882f, -0.06874201f, -0.08692903f, -0.04453175f, -0.24691531f, 
    0.02530516f, 0.12839462f, 0.11277241f, 0.03734746f, -0.17148735f, -0.02577584f, 0.02566884f, 0.19026047f, 
    -0.04337014f, 0.02461232f, -0.11373252f, 0.07960675f, 0.07788282f, -0.09197703f, 0.04181454f, 0.02799867f, 
    -0.16203131f, -0.02762140f, 0.09973377f, 0.05435125f, -0.14513209f, 0.01990203f, 0.12177517f, 0.19055019f, 
    -0.01186992f, -0.00926983f, 0.00539696f, -0.04827595f, -0.21905206f, -0.08288634f, -0.07348669f, -0.25048295f, 
    -0.23116846f, -0.12348945f, -0.15168905f, -0.00772308f, -0.01096171f, 0.05644619f, -0.13151202f, 0.03721922f, 
    -0.02100252f, -0.01601207f, -0.18496238f, 0.06784112f, -0.05250891f, 0.10607348f, 0.10839275f, 0.10971861f, 
    0.05784886f, -0.17407879f, -0.14196602f, 0.12526114f, -0.03465008f, -0.00922487f, 0.04272478f, -0.02433839f, 
    -0.08209810f, -0.33848190f, -0.08745355f, 0.02910778f, 0.04094367f, -0.25112557f, -0.05315412f, -0.00175911f, 
    0.31374493f, 0.43126816f, 0.26427123f, 0.34591112f, 0.02772607f, 0.01108444f, 0.15763956f, 0.00174694f, 
    0.08283364f, -0.02884591f, 0.05733338f, 0.14733161f, -0.02514158f, 0.17836925f, 0.02035226f, 0.02325699f, 
    0.20351607f, 0.01090224f, 0.05974919f, 0.11216719f, -0.08871968f, -0.02072482f, 0.00822273f, -0.09358183f, 
    0.51863593f, -0.43733257f, 0.35198063f, 0.17493449f, 0.21622793f, 0.12129371f, -0.30061781f, -0.06480908f, 
    -0.05212142f, -0.07404004f, 0.02893116f, 0.12975666f, 0.16575664f, 0.12174852f, 0.00487076f, 0.30901730f, 
    0.09751453f, 0.04514113f, 0.01775930f, 0.02272196f, -0.24642786f, 0.16463339f, -0.09109701f, -0.15795650f, 
    -0.23904866f, 0.04566920f, -0.27485991f, 0.21777253f, 0.01134260f, 0.18480055f, -0.03224512f, -0.00736596f, 
    -0.02728430f, 0.03592345f, 0.13807514f, 0.01182229f, -1.31031871f, -0.69408846f, -0.28826970f, -0.50307089f, 
    -0.25187913f, -0.11229018f, 0.14180522f, -0.30022493f, -0.02806188f, 0.03870741f, -0.02500917f, -0.07998089f, 
    -0.41401982f, -0.26124603f, -0.47512206f, -0.01955455f, 0.09930979f, 0.04043707f, 0.09567074f, 0.02185960f, 
    -0.04314647f, 0.03094191f, -0.01218427f, 0.04869600f, -0.32837451f, -0.12847839f, 0.83103031f, 0.42708465f, 
    -0.01827659f, 0.01158824f, -0.04057840f, 0.07511604f, 0.04593969f, -0.06762417f, -0.00814290f, -0.03655909f, 
    -0.25256631f, 0.42126057f, 0.21214864f, 0.15705706f, 0.07747183f, 0.10534553f, -0.25084978f, -0.02649389f, 
    0.09109540f, 0.04701848f, -0.10875434f, -0.00321183f, -0.19646823f, -0.21127746f, -0.26302031f, 0.15752424f, 
    -0.02069362f, -0.22348262f, 0.14908627f, -0.04156553f, 0.01754408f, 0.10330664f, 0.05516184f, -0.02275670f, 
    -0.01862635f, -0.11590950f, 0.07996397f, -0.27259415f, -0.00743182f, 0.01672388f, -0.00459806f, 0.15304680f, 
    0.03802258f, -0.17189583f, 0.05411045f, -0.22686242f, 0.02467737f, -0.00785246f, -0.23907521f, 0.17999622f, 
    -0.00359652f, 0.04513311f, 0.04949331f, 0.00838340f, 0.07329906f, 0.04637869f, -0.09500258f, 0.11773973f, 
    0.29161242f, -0.39867133f, -0.31114563f, -0.12456673f, -0.00775664f, -0.05335632f, -0.02183997f, -0.03435232f, 
    -0.12231025f, 0.13420720f, 0.03053991f, 0.07117352f, -0.67223352f, -0.21277791f, 0.13707672f, 0.14554855f, 
    -0.08334877f, -0.15370484f, -0.29682299f, -0.47085285f, 0.09454489f, -0.01915625f, -0.05267147f, -0.03155685f, 
    -0.15125903f, 0.06450763f, -0.17478642f, 0.13913526f, 0.06130200f, 0.06994321f, 0.10721291f, -0.01049689f, 
    -0.00985000f, 0.07022011f, 0.02615227f, 0.01721084f, 0.15998071f, 0.36642241f, 0.05521971f, 0.23328023f, 
    -0.08864935f, 0.16305454f, 0.06106522f, -0.17331232f, -0.11693466f, -0.13700731f, -0.16269860f, 0.14313789f, 
    -0.27293664f, -0.11545449f, -0.01672863f, -0.06875787f, -0.03098791f, -0.05274528f, 0.05733423f, 0.05216477f, 
    -0.00098251f, -0.12778148f, 0.00815202f, -0.00289890f, -0.43041140f, 0.13084857f, 0.09114907f, -0.18736012f, 
    -0.05556896f, -0.03670525f, 0.03832320f, 0.01284537f, -0.02715356f, -0.05322734f, 0.08853990f, 0.03902478f, 
    0.02092936f, 0.02331536f, 0.43792915f, -0.26294640f, 0.01787630f, -0.06136276f, 0.04431577f, -0.00947080f, 
    0.20382510f, 0.25917184f, 0.13038641f, 0.02319982f, 0.02005819f, -0.26705360f, 0.03413342f, 0.08964030f, 
    0.03591382f, 0.02135253f, -0.03851813f, 0.06831782f, 0.02160177f, 0.09428572f, -0.46328077f, 0.22001354f, 
    -0.13242488f, -0.04123912f, 0.26739132f, -0.37031221f, -0.11615229f, -0.02821488f, 0.11712595f, -0.31326273f, 
    0.07021347f, 0.06069553f, -0.03579037f, 0.01028317f, -0.00566621f, 0.40398613f, 0.01983625f, 0.09971363f, 
    0.12450672f, 0.17485678f, -0.22787759f, 0.18441859f, -0.01248156f, 0.01904312f, -0.00694227f, 0.08836555f, 
    -0.18713605f, 0.18996747f, 0.14302361f, 0.27707595f, -0.15510558f, 0.22453211f, -0.06429881f, -0.04744897f, 
    0.03369369f, 0.14669286f, -0.02932121f, 0.07870746f, -0.48786613f, 0.12890658f, 0.30116227f, 0.18653871f, 
    -0.33895627f, -0.19550735f, -0.17343934f, -0.20847343f, -0.06014181f, 0.02511456f, -0.14959762f, -0.13388298f, 
    -0.08157963f, 0.14322670f, -0.02566309f, 0.28881696f, -0.04901509f, -0.05653189f, 0.07649273f, -0.05618834f, 
    -0.02650845f, 0.10217413f, 0.12076019f, 0.27974901f, -0.13938096f, 0.00030032f, -0.14051016f, 0.22287849f, 
    0.05050169f, 0.20744659f, 0.09520636f, 0.01021936f, -0.10878903f, -0.14039966f, 0.03692632f, 0.09245813f, 
    -0.32653287f, 0.27042067f, 0.02243303f, 0.36061677f, -0.04414670f, 0.00913577f, -0.19648771f, -0.05496414f, 
    0.08339105f, 0.10283348f, -0.06223356f, 0.05256524f, -0.17288335f, 0.26996702f, -0.42125210f, -0.31166846f, 
    0.17007059f, 0.00020293f, -0.00994565f, -0.15584944f, -0.13047238f, 0.01845380f, -0.03450114f, 0.01854706f, 
    -0.13183577f, 0.23146401f, -0.13413310f, 0.06467190f, -0.14798576f, -0.03820147f, -0.10018934f, -0.00029253f, 
    -0.08322293f, 0.10099049f, 0.12372094f, -0.01017064f, -0.15923177f, 0.22750404f, 0.75857627f, 0.69710630f, 
    0.10870177f, -0.10244931f, 0.03245449f, -0.16361387f, 0.03861695f, -0.21640548f, 0.01208531f, -0.03382294f, 
    0.07661563f, -0.90850896f, -0.07828317f, -0.55318266f, 0.15018868f, 0.14400278f, 0.17647524f, 0.02678310f, 
    -0.42996919f, 0.05419178f, -0.39789286f, 0.10816161f, 0.12231997f, -0.10948654f, -0.15147033f, 0.09098358f, 
    0.07665358f, 0.04080077f, -0.17449322f, -0.25542533f, 0.06351353f, 0.14237049f, -0.06676646f, -0.00182898f, 
    0.82536376f, -0.26853138f, 0.09590857f, 0.41803080f, 0.19457331f, 0.03719901f, 0.09092159f, -0.17591649f, 
    -0.10468935f, -0.14004754f, 0.11461926f, 0.10579613f, -0.16023718f, -0.07775844f, -0.17724198f, 0.05735530f, 
    -0.07150846f, 0.04420660f, -0.03234072f, -0.04589438f, -0.11345451f, -0.07875630f, 0.18967208f, -0.02306880f, 
    0.16098277f, -0.06973006f, 0.05227661f, 0.21950760f, -0.10162495f, -0.05307178f, -0.11985035f, -0.33245501f, 
    -0.15591884f, -0.40924516f, 0.03149423f, -0.01203609f, 1.47593212f, -0.21890327f, -0.11377929f, -0.32611457f, 
    0.33168224f, 0.19908074f, -0.13914749f, -0.29469809f, -0.23563717f, 0.02156861f, -0.16199036f, 0.08443898f, 
    -0.06277035f, 0.09946497f, 0.01058372f, -0.36911950f, -0.19483197f, -0.40847576f, 0.01029110f, -0.17370754f, 
    -0.08116666f, 0.13900632f, -0.19915882f, -0.14510533f, -0.01571169f, -0.24100205f, -0.16718312f, 0.24265790f, 
    0.09169048f, 0.09148935f, 0.02725069f, 0.12676086f, -0.02063305f, 0.01567074f, -0.12084352f, -0.12182240f, 
    -0.01044475f, 0.08010219f, -0.08115955f, 0.12792709f, -0.11530849f, 0.02910269f, -0.05982197f, -0.04697683f, 
    0.05245855f, -0.07916649f, -0.11523655f, -0.00731361f, 0.06743775f, -0.13009387f, -0.01656052f, 0.08886486f, 
    0.20056421f, -0.01233711f, -0.03536725f, -0.12528543f, -0.13515376f, 0.04753547f, 0.02660167f, 0.15549946f, 
    -0.24205276f, -0.03192240f, -0.09285599f, 0.20010832f, 0.31458798f, 0.03889387f, 0.01601464f, -0.04788508f, 
    -0.08130148f, -0.00105864f, 0.28737226f, 0.04197918f, -0.03168722f, -0.10341494f, -0.18045193f, 0.09598511f, 
    0.08537482f, -0.00961839f, 0.03252656f, -0.04643486f, -0.06398827f, -0.04877646f, 0.09059955f, 0.00067062f, 
    -0.08273327f, -0.34986401f, 0.06339986f, 0.20433673f, -0.00145513f, -0.01094715f, -0.00956937f, -0.31102207f, 
    0.16147204f, 0.02232595f, 0.02881130f, -0.13505371f, 0.07772107f, 0.14576276f, 0.11587414f, -0.49696121f, 
    -0.01171623f, 0.20926808f, -0.14784941f, 0.13928181f, -0.21394584f, 0.13482665f, 0.09157328f, -0.15733875f, 
    0.22055013f, 0.54409450f, 0.08727481f, -0.28678694f, -0.26463884f, 0.02727363f, -0.02027379f, 0.00263546f, 
    -0.15444955f, -0.10209671f, 0.07354116f, -0.05982291f, -0.12558959f, -0.54398739f, 0.57341367f, 0.30135921f, 
    -0.24167019f, 0.07155915f, -0.03523920f, 0.18504994f, 0.10602421f, -0.15110630f, -0.00288209f, -0.11608905f, 
    0.01164702f, 0.12699558f, -0.16659157f, -0.49210641f, -0.13092992f, -0.39667717f, -0.03924360f, -0.11205869f, 
    -0.23240469f, 0.14642791f, -0.04935505f, -0.25974578f, 0.40538287f, 0.00032956f, 0.02586840f, 0.17504664f, 
    0.23988433f, -0.02790594f, 0.09210261f, 0.12849183f, -0.02297488f, 0.14885318f, -0.07929261f, 0.09005550f, 
    -0.39635202f, -0.22747186f, -0.31170648f, -0.37403515f, -0.12183572f, -0.28973526f, -0.06836452f, -0.14295004f, 
    0.13401529f, 0.19691560f, 0.01618600f, -0.04656246f, -0.27787668f, -0.47521865f, 0.09763197f, 0.28963423f, 
    -0.01470733f, -0.30734304f, 0.02419579f, -0.21186236f, 0.10692117f, 0.16539158f, 0.08234695f, -0.01013060f, 
    0.12215847f, 0.30476394f, -0.31776807f, 0.28458029f, 0.09834384f, 0.09466852f, -0.00711063f, 0.10772131f, 
    -0.17546332f, 0.15288344f, 0.15549377f, 0.11179300f, -0.62878740f, -0.31647152f, -0.52188706f, 0.05539481f, 
    0.16973954f, -0.06851126f, 0.02019290f, -0.24956213f, -0.16156740f, 0.04004803f, -0.28717661f, 0.17252393f, 
    -0.52881831f, 0.02582069f, -0.20367806f, 0.48263165f, 0.05969492f, -0.08551307f, 0.26324302f, -0.19788314f, 
    0.09285609f, 0.00110173f, -0.07751035f, 0.10872603f, -0.10123963f, 0.08847897f, -0.07988437f, 0.42449558f, 
    -0.10397186f, 0.02838329f, -0.30367586f, -0.14146352f, -0.09644136f, -0.12423562f, 0.06489615f, -0.01738057f, 
    0.07708258f, 0.07222860f, 0.08103135f, 0.08854713f, 0.09801241f, 0.07774662f, 0.11998070f, -0.00797330f, 
    0.05605756f, -0.03316556f, 0.01869218f, 0.09181022f, 0.13255177f, -0.10207839f, -0.19854566f, 0.36235753f, 
    -0.01270553f, 0.08402540f, 0.02518154f, 0.06166661f, 0.06023705f, -0.00703689f, -0.07472450f, -0.04785629f, 
    -0.19783647f, -0.06615321f, 0.30149314f, 0.13805427f, 0.11754131f, -0.02391232f, -0.10227160f, -0.01217142f, 
    -0.00904643f, 0.02110860f, -0.11252675f, -0.23733489f, 0.04287475f, 0.13579084f, 0.38996744f, 0.22893664f, 
    0.00850611f, -0.04608671f, -0.08375864f, -0.19043556f, 0.04720190f, 0.10331402f, -0.05717260f, -0.03631350f, 
    0.08124899f, 0.13438264f, 0.01040695f, -0.08134795f, 0.09003223f, -0.04740629f, -0.28626594f, -0.21948254f, 
    -0.04746594f, -0.16267702f, 0.06991336f, -0.12634526f, 0.04189989f, -0.22964580f, 0.00334799f, 0.06574734f, 
    -0.19195265f, 0.00180115f, -0.05042122f, -0.01523109f, -0.03639618f, 0.23712017f, -0.03911753f, 0.13166268f, 
    -0.04029184f, -0.39059889f, 0.20645307f, 0.06815165f, -0.16964953f, 0.14132234f, -0.06084757f, -0.06168904f, 
    -0.03360571f, 0.05328550f, -0.06053155f, -0.10795136f, 0.10398231f, 0.22534288f, -0.07547823f, -0.45149520f, 
    0.09330350f, 0.21249296f, -0.05065681f, 0.07978223f, 0.09961881f, -0.04014693f, 0.18328628f, -0.10347669f, 
    0.14858887f, -0.01573647f, -0.03314699f, 0.05747189f, -0.09223324f, -0.07575230f, 0.01804045f, 0.00372075f, 
    -0.09516267f, -0.10092323f, -0.12572195f, -0.27304435f, 0.19461456f, 0.14689425f, 0.03234945f, 0.03568710f, 
    0.03442224f, 0.00638626f, -0.12771077f, -0.01562802f, 0.20171927f, -0.00088872f, -0.04700434f, 0.02151376f, 
    -0.15594783f, 0.01380183f, 0.10171894f, 0.07707649f, -0.10095329f, -0.22290504f, -0.04407059f, 0.05139317f, 
    0.03800085f, -0.02031771f, -0.01715528f, 0.14396355f, 0.06365963f, 0.09155897f, 0.27194050f, 0.13352633f, 
    -0.04170405f, -0.12278294f, -0.07555611f, -0.00211328f, 0.05703394f, 0.07469178f, -0.00396168f, 0.20904553f, 
    -0.17565067f, 0.16385487f, -0.46980494f, 0.13248765f, 0.01523217f, -0.28876171f, -0.09352873f, -0.08277096f, 
    -0.16353954f, -0.03257564f, 0.02298848f, -0.06045894f, -0.35799822f, -0.00558841f, -0.48624903f, -0.08617642f, 
    0.05945056f, -0.14342721f, 0.15686022f, 0.12200846f, -0.07542300f, -0.42158404f, 0.20175317f, -0.08692341f, 
    -0.21245657f, -0.10012989f, 0.24193777f, 0.09035675f, -0.09290896f, -0.06215900f, -0.16210471f, 0.04834332f, 
    -0.31881443f, -0.11088459f, -0.20140304f, -0.37203485f, 0.08227089f, 0.23522240f, 0.27232406f, 0.24933866f, 
    -0.03892335f, 0.01005937f, 0.08292985f, 0.24607351f, -0.05414079f, -0.00461206f, 0.02555289f, 0.06215779f, 
    -0.03105262f, 0.12778011f, 0.24856167f, 0.40741649f, -0.19175746f, -0.03480165f, -0.21357034f, 0.20412113f, 
    -0.01174528f, -0.05273531f, 0.01500588f, -0.06932706f, -0.19222327f, -0.09759106f, -0.00699231f, 0.18373410f, 
    -0.08256447f, -0.03308351f, 0.04413748f, -0.11425760f, -0.00604920f, -0.09342431f, 0.04371810f, 0.02183353f, 
    -0.09493519f, 0.11384773f, -0.06646033f, 0.17579402f, -0.08467011f, -0.15348883f, -0.06340577f, 0.11247702f, 
    -0.00503334f, -0.24127027f, 0.05923400f, 0.07907733f, 0.06185684f, 0.10105480f, 0.33163831f, 0.07226723f, 
    -0.27767700f, -0.13743430f, -0.05816256f, 0.14372675f, 0.06929725f, 0.10348063f, -0.06569127f, 0.01811644f, 
    -0.05976048f, 0.09138520f, -0.41793191f, -0.14295438f, 0.01733545f, -0.06180537f, -0.28747693f, 0.08868337f, 
    -0.06780408f, -0.02879022f, -0.07918141f, -0.28003162f, -0.27305815f, -0.53446090f, -0.11775955f, -0.21140267f, 
    -0.03199963f, -0.05876516f, 0.07443375f, -0.18797888f, 0.02069797f, -0.21095853f, -0.01210414f, 0.11488060f, 
    0.34503952f, -0.29840690f, 0.07433803f, 0.31960729f, -0.06182776f, -0.06528186f, -0.08577231f, -0.08905037f, 
    0.19695266f, 0.19922830f, 0.15882529f, 0.35669932f, -0.12535024f, 0.45592374f, -0.08943357f, 0.27806568f, 
    0.16000664f, 0.17460383f, 0.04323645f, 0.13955370f, -0.00630147f, 0.02192061f, -0.08137859f, -0.07498465f, 
    -0.00165744f, -0.11342768f, 0.13617532f, -0.42854539f, -0.15179396f, -0.03735259f, 0.02657584f, 0.21843086f, 
    -0.12245203f, -0.04614362f, -0.20007193f, -0.11054873f, 0.39058962f, 0.16993544f, 0.14066246f, 0.08681709f, 
    -0.09244103f, -0.06228975f, -0.00826767f, -0.09590644f, 0.07269596f, -0.30233592f, 0.00472071f, -0.12493254f, 
    0.03813251f, -0.03273407f, 0.05232477f, 0.06510448f, 0.16067135f, 0.11972868f, -0.02146586f, 0.05594312f, 
    0.07103944f, -0.00560307f, 0.03537918f, 0.02043354f, 0.11833829f, -0.15744747f, -0.08177274f, 0.16523460f, 
    -0.10612103f, 0.04765745f, -0.11320630f, 0.11496994f, 0.14006844f, 0.01565811f, -0.04990910f, 0.06208319f, 
    -0.32093623f, 0.01604695f, -0.11518095f, -0.13897370f, 0.03300878f, -0.05107896f, 0.05001208f, 0.02241761f, 
    0.09349889f, 0.04123837f, 0.12009604f, 0.21015456f, 0.02532369f, 0.02583945f, 0.02343182f, 0.02698007f, 
    0.03132825f, 0.12189505f, 0.07741622f, 0.07584051f, -0.01990351f, -0.03328899f, -0.06703173f, 0.01314482f, 
    0.23398571f, 0.13096379f, 0.04868765f, -0.08983795f, -0.01735226f, -0.03356734f, -0.24464512f, 0.03293688f, 
    -0.11567670f, -0.06825031f, -0.06908068f, -0.03965002f, -0.15124585f, -0.03431622f, -0.14712588f, 0.04134622f, 
    0.06482705f, -0.17778791f, 0.06224874f, 0.14379224f, 0.05485136f, 0.04642081f, -0.03470901f, 0.02627231f, 
    0.09529152f, -0.12527706f, 0.02756949f, -0.03894367f, -0.17648001f, -0.04651459f, 0.02777441f, -0.03844234f, 
    0.00675594f, 0.10816758f, -0.06020696f, -0.59992254f, 0.28128663f, 0.05794745f, -0.44799563f, -0.17752917f, 
    0.11051694f, 0.09097937f, -0.13874450f, -0.04570694f, 0.10647666f, 0.04026888f, 0.06544232f, -0.01833774f, 
    0.36469427f, -0.04081115f, -0.37586981f, -0.13751443f, -0.06690671f, 0.08166312f, -0.24259174f, 0.01736616f, 
    0.10253885f, -0.04351776f, 0.07779418f, 0.02426793f, 0.16330087f, 0.10261305f, -0.09763359f, -0.06743649f, 
    -0.08521876f, -0.01794603f, -0.01206371f, 0.14813995f, -0.12462440f, -0.12237483f, 0.04346344f, -0.21988058f, 
    0.04617473f, 0.12436073f, -0.24772267f, -0.02730405f, -0.02108996f, 0.20042160f, 0.00684373f, 0.20785062f, 
    0.15066871f, -0.29119349f, -0.01645052f, 0.04961292f, -0.46454772f, -0.27284250f, 0.38537112f, -0.31885687f, 
    0.03304416f, -0.02314663f, 0.05597992f, 0.09755092f, -0.08370487f, -0.24173428f, -0.24845017f, -0.16729897f, 
    -0.08445688f, 0.15999539f, 0.11211327f, 0.07579429f, 0.29630759f, 0.04707942f, 0.01578365f, -0.01329563f, 
    0.07308877f, -0.01827887f, 0.06372429f, 0.26367158f, -0.10852197f, 0.10321616f, -0.31941026f, -0.64703470f, 
    0.14353484f, 0.31017420f, -0.01592418f, -0.14626214f, 0.04709005f, -0.19749911f, -0.03386339f, -0.00139527f, 
    -0.08451403f, 0.16406423f, -0.25278774f, 0.10439491f, 0.12363812f, 0.08678994f, -0.06384202f, -0.28062439f, 
    0.19251019f, -0.25360680f, 0.29565763f, 0.17462124f, -0.06258074f, -0.04094522f, -0.00933213f, -0.19558667f, 
    0.03347252f, 0.16214126f, -0.03566225f, -0.17805620f, 0.16754813f, 0.20714372f, 0.08128573f, -0.08951442f, 
    -0.60896766f, -0.07045425f, -0.47266546f, -0.41196090f, -0.02566941f, -0.12957639f, 0.09783271f, 0.18063502f, 
    0.12505215f, -0.03793117f, -0.06390996f, -0.13715972f, 0.26181710f, 0.30559406f, 0.23218468f, 0.00539202f, 
    0.08272912f, -0.01085450f, 0.08060992f, -0.02682103f, 0.11073011f, -0.01942062f, -0.05300329f, -0.04214742f, 
    -0.34421173f, 0.29587826f, -0.01079591f, -0.25989139f, 0.00454499f, -0.13332613f, 0.24788530f, 0.31963149f, 
    0.06027740f, 0.04149452f, -0.00601204f, 0.11962485f, -0.63433540f, -0.22176620f, 0.00476394f, 0.36488697f, 
    -0.17860171f, 0.02257911f, -0.09354822f, 0.13886818f, -0.02302142f, 0.00448195f, -0.02405696f, -0.02525072f, 
    0.22298734f, -0.43061244f, -0.00702782f, 0.11319888f, -0.09548775f, 0.04366888f, -0.01898145f, 0.04275372f, 
    0.08389106f, 0.05301627f, 0.05651876f, 0.37429091f, 0.19918540f, 0.10771267f, 0.08064580f, 0.16074814f, 
    0.24422950f, 0.22078143f, -0.04961897f, -0.20806396f, 0.04605907f, 0.02213394f, 0.03786027f, 0.02757614f, 
    0.15913510f, 0.06852816f, 0.30538085f, -0.11051950f, 0.15475747f, -0.03239170f, 0.13226342f, 0.11337572f, 
    0.06678214f, 0.03999440f, 0.05705187f, 0.08459591f, -0.45933560f, 0.21174648f, -0.15810508f, -0.19721380f, 
    -0.03521902f, -0.03208061f, -0.07931425f, 0.07833360f, 0.05722614f, -0.11428610f, -0.03414169f, 0.02290932f, 
    -0.20191225f, -0.27804303f, 0.07705475f, -0.32911411f, -0.06329133f, 0.21040332f, -0.05306985f, 0.01276260f, 
    0.07486869f, 0.05109714f, 0.04742337f, 0.08995477f, 0.11735959f, -0.08055743f, 0.12992799f, -0.16113101f, 
    0.29912984f, 0.21465324f, 0.04494372f, 0.14917777f, 0.00324047f, 0.08160865f, 0.02581084f, 0.04964375f, 
    -0.13950604f, 0.19137646f, -0.38986176f, 0.15221465f, 0.02243898f, -0.03148100f, -0.21197487f, -0.01688740f, 
    -0.08180005f, 0.25298369f, 0.10393717f, 0.31760097f, 0.33918533f, -0.35129091f, 0.07661536f, 0.34330440f, 
    0.11681372f, -0.04912316f, -0.02154854f, -0.03972089f, 0.11379779f, 0.11847609f, 0.08605861f, -0.13447787f, 
    -0.75520110f, 0.37281504f, 0.44714153f, 0.07818459f, 0.01169927f, 0.12228255f, -0.02709086f, -0.08327361f, 
    0.11667155f, -0.44973290f, -0.09575345f, -0.37118927f, -0.18486798f, -0.30273545f, -0.18078080f, 0.04852288f, 
    0.17555800f, 0.16996132f, 0.03259631f, -0.15994287f, -0.04383196f, 0.04961565f, 0.05450933f, 0.08730440f, 
    0.33860773f, -0.39077094f, -0.01875359f, 0.28275064f, 0.09626041f, -0.04748698f, -0.02628889f, 0.05254751f, 
    -0.02905088f, -0.16530050f, 0.18406323f, 0.05479918f, -0.38460121f, -0.36894992f, -0.10049015f, 0.10629546f, 
    0.03899055f, -0.11644225f, -0.02165220f, -0.02682762f, 0.31644678f, -0.03427134f, 0.01432561f, 0.06550235f, 
    -0.19789663f, -0.24379104f, -0.14650440f, 0.19243152f, -0.03699169f, 0.02486210f, -0.10317123f, 0.00970752f, 
    -0.01357857f, -0.08353379f, -0.03585692f, -0.07287621f, 0.04516273f, -0.17409039f, -0.21289384f, 0.49236670f, 
    0.04004925f, 0.10704562f, 0.17739366f, -0.03362861f, -0.00009461f, 0.04253336f, -0.07156619f, -0.03755860f, 
    -0.15026070f, 0.04313660f, -0.29044196f, -0.24679874f, -0.11945400f, 0.02175282f, 0.15142873f, 0.10533854f, 
    0.10472295f, -0.39686337f, -0.26541743f, -0.43733147f, -0.08570580f, -0.07793186f, -0.13794377f, 0.11005741f, 
    0.02257766f, -0.14484076f, -0.08462946f, 0.02988434f, 0.01495240f, -0.00173099f, 0.29861057f, -0.01574506f, 
    0.06690912f, 0.11595479f, 0.02712278f, -0.34800825f, 0.24552631f, -0.03339413f, -0.03360556f, 0.08414969f, 
    -0.19074963f, 0.04937513f, 0.15318827f, 0.04742800f, 0.17411341f, 0.01610791f, -0.34974280f, 0.03645837f, 
    -0.00084946f, -0.12820862f, -0.12838084f, -0.00072807f, -0.00488854f, -0.08710462f, -0.00904818f, 0.22171031f, 
    0.18483713f, 0.09200468f, -0.13524188f, -0.09733727f, -0.11160483f, 0.13749646f, 0.05764063f, 0.04725485f, 
    -0.01403629f, -0.12908182f, -0.02609935f, 0.10738754f, 0.27246240f, -0.16614948f, -0.48095211f, -0.48392236f, 
    -0.06971441f, -0.09260252f, 0.15192480f, 0.04541015f, 0.07659681f, 0.06340079f, -0.05237155f, -0.23160709f, 
    -0.92404503f, 0.04848604f, -0.08840329f, 0.25261781f, 0.09997024f, -0.11416119f, 0.01517334f, 0.13104513f, 
    0.07054559f, 0.04122795f, 0.17816311f, -0.11960293f, 0.42759272f, 0.42928866f, -0.39092958f, -0.29260552f, 
    -0.03343818f, -0.08187606f, -0.11811415f, -0.00269287f, 0.11276038f, -0.09439449f, -0.06729219f, -0.02543363f, 
    0.56253290f, 0.16177699f, -0.17829546f, -0.54276741f, 0.21498589f, -0.38075545f, -0.01661225f, 0.04713567f, 
    0.07107835f, -0.00546716f, -0.01916045f, -0.09766158f, -0.23300155f, -0.10344660f, 0.09325205f, 0.02771808f, 
    -0.01500162f, 0.00494265f, 0.02918763f, 0.24290673f, 0.13828272f, 0.16932884f, 0.13167965f, 0.07525145f, 
    -0.33299786f, -0.59143382f, -0.33083522f, 0.25917354f, -0.09887805f, -0.32948825f, -0.11403984f, -0.24537523f, 
    -0.01184096f, 0.08386870f, -0.09921727f, 0.00812644f, -0.02757332f, 0.08950096f, 0.46097508f, -0.15051436f, 
    0.22902477f, -0.00057330f, -0.04360194f, -0.09919930f, 0.06991004f, -0.03700391f, 0.00931934f, -0.00399285f, 
    0.03910904f, 0.06933114f, 0.27034914f, -0.22017939f, 0.07147422f, -0.03032403f, -0.02662691f, 0.10407984f, 
    0.01786240f, 0.33194101f, -0.06248808f, -0.05465326f, -0.11226495f, 0.05975015f, 0.14223784f, 0.00258526f, 
    -0.04469597f, -0.19703388f, -0.14029087f, 0.01248023f, -0.06484639f, -0.08688509f, -0.16150700f, -0.15332247f, 
    -0.14450216f, 0.39597908f, 0.40166694f, 0.08279978f, 0.03791870f, 0.07529344f, -0.00009029f, 0.05693563f, 
    0.09471586f, 0.01185770f, 0.12427295f, 0.13409345f, -0.99856353f, -0.94198102f, 0.02091975f, -0.17659132f, 
    -0.12734336f, 0.01568879f, -0.07626162f, -0.28927359f, -0.10526436f, -0.03356973f, 0.03101194f, -0.04408881f, 
    0.57655394f, -0.44890010f, -0.43462732f, 0.16095915f, -0.07671300f, -0.22967885f, 0.11926764f, 0.11426405f, 
    -0.07039052f, 0.02882470f, 0.02225630f, -0.01767630f, 0.02671135f, -0.26380935f, 0.07064983f, 0.60181326f, 
    -0.19219804f, 0.01596059f, -0.10444172f, 0.15949175f, 0.08692542f, -0.00411415f, 0.36816043f, 0.19547248f, 
    0.01130044f, 0.05389955f, -0.22031966f, 0.05233353f, -0.11845230f, -0.05478615f, 0.11324572f, 0.20062059f, 
    0.08619764f, 0.07371949f, -0.19244611f, 0.10308884f, -0.76693249f, -0.93838805f, -0.67493665f, -0.02666475f, 
    -0.24565922f, -0.08577116f, -0.27680776f, -0.35725021f, -0.01112239f, -0.04835238f, 0.00749666f, -0.00541913f, 
    -0.66361171f, -0.77810395f, -0.74302441f, 0.14971171f, -0.04835843f, -0.10773063f, -0.02802824f, -0.06868328f, 
    0.06336604f, -0.00040362f, 0.10776500f, 0.10889816f, -0.68809122f, -0.80427325f, -0.17004846f, -0.38526416f, 
    -0.24307239f, -0.01762600f, 0.00539049f, -0.02924510f, -0.08521964f, -0.01353519f, 0.11416869f, 0.04712905f, 
    -0.22811377f, 0.14591239f, 0.21128085f, 0.61840725f, 0.05251456f, -0.24155119f, 0.15098526f, 0.09110050f, 
    -0.03904763f, 0.12363183f, -0.13812481f, 0.01581974f, -0.99827331f, -0.39876974f, -0.27030480f, -0.51651019f, 
    -0.13309549f, 0.12526108f, -0.07027728f, -0.22003125f, 0.06250156f, -0.00077798f, -0.13357545f, 0.07933749f, 
    0.07674885f, -0.02293113f, 0.27374151f, -0.61237323f, 0.08476937f, -0.01881530f, 0.14074169f, -0.22230743f, 
    -0.03272048f, -0.05563344f, -0.19849291f, 0.12755255f, -0.06226816f, 0.13688569f, -0.12996930f, -0.03623967f, 
    -0.01726635f, 0.15615483f, -0.06105782f, 0.08860880f, 0.08631346f, 0.03901552f, 0.13193609f, -0.15435009f, 
    -0.22135444f, -0.28110802f, 0.18182367f, -0.40482402f, -0.05702008f, 0.04615284f, 0.10079797f, 0.06066336f, 
    0.16343449f, 0.39814210f, -0.01797416f, 0.06132817f, 0.50273681f, -0.62044811f, -0.46422482f, -0.37912652f, 
    -0.06767812f, -0.13547225f, 0.32951880f, 0.01262757f, -0.04105598f, -0.01567952f, 0.00579422f, -0.13328461f, 
    -0.00055963f, 0.04712060f, -0.34127280f, 0.17831913f, 0.13460638f, -0.00294308f, 0.06227068f, 0.17159954f, 
    -0.01268912f, 0.06589833f, -0.05500278f, -0.01893845f, -0.39243215f, 0.28378767f, 0.51022452f, 0.15584846f, 
    -0.07133929f, -0.14398748f, -0.00382920f, 0.04413400f, -0.01398054f, 0.12820907f, -0.00515401f, 0.03097842f, 
    0.01038037f, -0.04810741f, -0.14136559f, -0.04893248f, 0.00138392f, 0.09694416f, 0.10057530f, 0.02723174f, 
    -0.08467852f, -0.02154537f, -0.24184883f, -0.15474676f, 0.15285672f, -0.03550171f, -0.03346989f, -0.22892153f, 
    -0.01519110f, 0.04119220f, 0.32927397f, -0.24639305f, -0.00965260f, 0.01223597f, -0.09710377f, 0.05732517f, 
    0.02323489f, 0.13295878f, 0.11278355f, 0.00033471f, 0.00892645f, 0.03846055f, 0.05187766f, 0.08631880f, 
    0.06569174f, 0.03084007f, 0.38582867f, 0.22099513f, 0.26768234f, 0.06586614f, -0.15836807f, -0.09892021f, 
    0.02059208f, -0.06365504f, 0.11492640f, 0.08278189f, -0.09257387f, -0.08082847f, 0.17527428f, 0.05534842f, 
    -0.30857319f, 0.01231108f, -0.02345714f, -0.02633752f, -0.06781599f, -0.06290236f, -0.01786208f, -0.23222663f, 
    -0.09185946f, -0.11314475f, 0.26191270f, -0.06786818f, 0.47810587f, 0.24596809f, -0.40701616f, 0.41131580f, 
    0.20145126f, -0.09795503f, 0.40864253f, 0.02326260f, 0.12218499f, 0.22134584f, -0.15206769f, -0.29567567f, 
    0.04517894f, 0.05720060f, 0.03839881f, -0.05871514f, 0.07769694f, 0.07730652f, -0.05303066f, 0.09140133f, 
    0.03510927f, 0.13147794f, 0.26397297f, -0.08080475f, -0.30251649f, -0.09535716f, 0.06224643f, 0.10287138f, 
    0.02302035f, -0.01003039f, 0.01448127f, -0.04378821f, 0.15016083f, 0.03280058f, 0.02771983f, -0.05400195f, 
    -0.81961280f, 0.35940292f, -0.31928453f, 0.19303623f, 0.18378869f, -0.15762183f, 0.07203835f, -0.12273476f, 
    -0.13486400f, 0.09505964f, 0.17174946f, 0.01240096f, -0.26606977f, -0.45522296f, -0.08621667f, 0.17335731f, 
    -0.02053088f, -0.02004889f, -0.01427930f, 0.06096122f, -0.03036372f, 0.09393840f, 0.06854539f, 0.01918151f, 
    -0.32270950f, 0.15106963f, 0.28343463f, 0.05910310f, -0.01351238f, 0.00565616f, 0.06577542f, 0.16225998f, 
    0.13059244f, 0.08158462f, 0.00892650f, 0.02584850f, 0.62231928f, -0.76719499f, 0.18932240f, -0.75655550f, 
    -0.06630710f, 0.03177805f, -0.08665533f, 0.00621022f, 0.16363244f, 0.00400678f, -0.06533545f, -0.04309321f, 
    -0.00665636f, -0.93229896f, 0.50271422f, -0.50747466f, -0.12659019f, -0.10661457f, -0.32964841f, 0.15861650f, 
    -0.05439080f, 0.06098646f, -0.06075583f, -0.08943586f, -0.11752643f, 0.21580404f, 0.33130068f, -0.02629102f, 
    0.01327973f, -0.17360163f, 0.07005766f, 0.22642043f, 0.00236554f, 0.07051232f, 0.10359252f, 0.01306939f, 
    0.02337329f, 0.08362059f, -0.03081484f, -0.15222348f, 0.00165422f, 0.06347647f, -0.14143527f, -0.00386034f, 
    -0.00747910f, -0.19818082f, -0.41922072f, -0.23888099f, 0.05434672f, -0.05646685f, 0.09208081f, -0.01484052f, 
    -0.27284697f, -0.41417238f, 0.31484523f, 0.16370347f, 0.02939101f, 0.01405863f, 0.09170791f, 0.05565242f, 
    0.45207384f, -0.51519901f, -0.22798982f, -0.23228474f, -0.10788604f, 0.01108912f, 0.10898253f, -0.03693175f, 
    0.15315086f, -0.05636647f, -0.03484549f, 0.15849344f, -0.06364278f, 0.15535343f, 0.06313124f, 0.46037924f, 
    0.04519042f, -0.04506837f, -0.05212531f, 0.12327068f, -0.04264334f, -0.21212143f, 0.01916951f, 0.06318506f, 
    -0.35841489f, -0.10411144f, -0.04785635f, -0.05661915f, -0.09788117f, 0.16122560f, -0.19114649f, -0.09058393f, 
    -0.04790414f, 0.02527594f, -0.04690675f, -0.07319064f, 0.58318180f, -0.34250331f, -0.06491324f, -0.37516731f, 
    -0.03435653f, 0.26037392f, 0.00823936f, 0.02568229f, -0.13264306f, -0.01826501f, 0.14178880f, -0.08221503f, 
    0.22482750f, -0.33077002f, 0.02493538f, -0.09172431f, 0.01804366f, 0.10144486f, -0.11152582f, -0.12211593f, 
    -0.16684571f, 0.00512696f, -0.26187658f, -0.09888693f, -0.53970045f, -0.35881051f, -0.20045075f, 0.36288241f, 
    0.03410165f, 0.12049622f, -0.02729323f, 0.16859876f, 0.00114198f, -0.02158774f, -0.07801419f, -0.04509801f, 
    -0.00631338f, -0.69234771f, -0.08064985f, 0.29648900f, 0.11714049f, -0.14480366f, -0.05032316f, -0.04295942f, 
    0.00580089f, 0.00669244f, -0.08902071f, 0.03752234f, 0.37074739f, -0.69872242f, -0.33881715f, -0.55235827f, 
    -0.00381480f, -0.25664291f, -0.04135304f, 0.30126059f, -0.00683106f, 0.03559100f, -0.03991811f, -0.02603553f, 
    -0.38103068f, -0.58811700f, -0.31902185f, -0.25032192f, -0.07063413f, 0.13701420f, 0.23195967f, 0.07492071f, 
    0.08171163f, 0.05892715f, -0.00320731f, 0.00817339f, -0.41106233f, -0.41463324f, -0.39675283f, -0.14085199f, 
    0.13427687f, 0.05680890f, 0.04086286f, 0.14753608f, 0.05787164f, -0.04744712f, -0.03972305f, 0.01589795f, 
    -0.25013676f, 0.31276399f, -0.08144461f, 0.06853890f, -0.02363911f, 0.01134028f, -0.01832664f, 0.08798116f, 
    -0.07748778f, 0.04142414f, -0.04373540f, -0.01664208f, 0.47411418f, -0.17023659f, 0.11153547f, -0.01371393f, 
    0.01500341f, 0.02782572f, 0.05984423f, -0.02766188f, 0.07267655f, -0.15152450f, -0.08085342f, -0.24755383f, 
    0.49022025f, 0.22768092f, -0.21785229f, 0.13296489f, -0.16450925f, -0.09662541f, -0.01445280f, 0.03702034f, 
    0.03622294f, 0.12485687f, 0.12424196f, -0.06712194f, -0.40994075f, 0.45321727f, -0.17494392f, -0.01111010f, 
    -0.13330328f, -0.12380175f, -0.24139729f, 0.05406785f, 0.02027152f, 0.08628594f, 0.00554615f, 0.02288365f, 
    0.24825703f, -0.09940380f, 0.11151037f, -0.11572362f, -0.03379280f, 0.11467404f, 0.00875426f, -0.07845340f, 
    -0.11850754f, 0.02205224f, -0.07364593f, 0.03757753f, 0.79198295f, -0.66300285f, -0.59493107f, -0.55354917f, 
    0.01907800f, -0.04241897f, -0.02355882f, -0.05708226f, 0.08831146f, 0.00498715f, 0.24129319f, 0.06679930f, 
    0.03567644f, 0.04973672f, -0.00803661f, -0.04693957f, -0.00357889f, -0.00664734f, 0.01074644f, -0.02274773f, 
    0.07682838f, 0.08419908f, -0.00070256f, 0.00350228f, 0.06231046f, 0.05087589f, -0.08170974f, -0.13476753f, 
    -0.07017649f, -0.08075991f, -0.11258648f, -0.02284261f, 0.02847770f, 0.09166227f, 0.01164767f, 0.07173619f, 
    -0.08377760f, 0.01739576f, 0.02422382f, 0.23307188f, -0.02308214f, -0.10902205f, 0.00290241f, 0.03391532f, 
    0.03566418f, 0.08669368f, 0.07316253f, 0.05707860f, 0.01678735f, -0.09549145f, 0.04387672f, -0.05463964f, 
    0.09264634f, -0.02082660f, 0.03440247f, -0.00458916f, 0.00923770f, -0.00461943f, -0.28844008f, -0.35792181f, 
    0.00395498f, 0.18127127f, 0.19342487f, -0.13911293f, 0.03873117f, 0.05241192f, -0.03965761f, 0.14160438f, 
    -0.11871754f, 0.06553353f, -0.02435015f, -0.08971549f, -0.31486279f, -0.31925097f, 0.02192289f, -0.05123091f, 
    -0.26591840f, 0.20961118f, 0.03397499f, 0.01385867f, 0.10809008f, 0.08098494f, -0.13840567f, 0.01792269f, 
    -0.20536588f, -0.12308569f, -0.08272293f, -0.00768382f, -0.03019140f, -0.06572932f, -0.19427527f, -0.24827203f, 
    -0.27711803f, -0.21571617f, -0.19097371f, -0.25815052f, -0.62366921f, 0.14486887f, 0.06897075f, 0.15299872f, 
    0.12589121f, -0.06944186f, -0.07389808f, 0.02625081f, 0.02922946f, 0.09445355f, 0.23838186f, 0.10152962f, 
    -0.45648646f, -0.45894507f, 0.07515043f, 0.14793491f, 0.09853914f, 0.16141938f, 0.13025494f, -0.01555800f, 
    0.01134363f, -0.00299654f, 0.13861683f, 0.12564775f, -0.06900509f, -0.27374786f, -0.10973876f, -0.05912980f, 
    0.14306064f, 0.02052197f, -0.17418237f, 0.11156701f, -0.15183355f, 0.00291243f, -0.06055195f, -0.05701503f, 
    -0.50622618f, -0.17729972f, -0.06918524f, 0.34017694f, -0.18972230f, 0.16871080f, 0.03078069f, 0.13948508f, 
    0.00595347f, -0.06332912f, 0.01289493f, -0.05982821f, 0.21384118f, 0.12802699f, -0.23091045f, -0.22076666f, 
    0.11302932f, -0.02960712f, 0.11847843f, -0.03812601f, -0.02343375f, -0.01125166f, -0.22480728f, -0.39087802f, 
    0.22723354f, 0.13244338f, -0.23170519f, -0.18093836f, 0.15651797f, -0.11074306f, -0.01787017f, 0.07633462f, 
    0.09927126f, 0.01810361f, -0.04491184f, 0.13714845f, -0.54861730f, -0.03659149f, -0.07726747f, -0.04807580f, 
    -0.00564901f, 0.07215709f, -0.22517323f, -0.04202932f, 0.01572923f, -0.09391841f, 0.07769825f, -0.02451218f, 
    -0.13008426f, -0.03541044f, -0.16288227f, -0.02418723f, 0.03041006f, -0.05348363f, -0.00888330f, -0.00583880f, 
    0.15878287f, 0.13800837f, -0.06174371f, 0.14623958f, -0.20556334f, -0.18762165f, -0.10685788f, 0.03378502f, 
    0.09177134f, 0.03952127f, 0.05722523f, 0.06928694f, -0.07320071f, 0.12923077f, 0.11431935f, 0.11822273f, 
    -0.36981854f, -0.54081190f, -0.23133865f, 0.08122225f, -0.01857157f, 0.16834421f, 0.04739085f, 0.15712427f, 
    -0.35463884f, 0.06209136f, -0.09202171f, -0.17326801f, 0.38903943f, -0.57807988f, -0.89660406f, -0.37856209f, 
    -0.10094038f, -0.30360788f, 0.07319762f, -0.08050276f, 0.04550153f, 0.07997902f, 0.07322389f, -0.08945933f, 
    -0.21382472f, -0.54374850f, 0.39920506f, 0.11044484f, -0.06924307f, 0.24689002f, 0.11731298f, 0.19141477f, 
    -0.00990833f, 0.24710692f, 0.03244329f, -0.12651356f, 0.47213006f, -0.11880752f, -0.44589511f, -0.06773494f, 
    0.09192758f, 0.05807352f, -0.13444352f, -0.00894321f, 0.26866657f, -0.07501828f, 0.09855167f, 0.04519192f, 
    0.24112356f, -0.09505523f, -0.10807269f, -0.13162057f, 0.27220196f, -0.05824468f, 0.13954857f, 0.08021898f, 
    0.21327642f, 0.04282660f, 0.31620625f, 0.20311914f, -0.30796239f, -0.59338158f, -0.29537952f, -0.40183857f, 
    0.15272588f, -0.20177852f, 0.11273736f, -0.16347271f, 0.10646608f, -0.04512655f, 0.01763286f, 0.13233629f, 
    0.22547919f, 0.27251503f, -0.05167032f, 0.01705698f, 0.03519541f, -0.01972195f, 0.02883534f, -0.30418175f, 
    0.07507719f, 0.04858425f, 0.00443388f, -0.03784114f, -0.32561156f, -0.28143156f, -0.26916271f, -0.10128650f, 
    -0.28791746f, 0.28221014f, 0.16270769f, 0.02244595f, 0.04511128f, -0.00569999f, -0.06100396f, 0.16813630f, 
    -0.22897254f, -0.39021736f, 0.24415393f, 0.51914775f, -0.13946742f, 0.05490752f, 0.24166101f, -0.15286702f, 
    0.01412357f, 0.04175875f, 0.07824530f, 0.00493282f, 0.16501394f, -0.43830121f, -0.43995523f, 0.15836658f, 
    -0.09050120f, -0.05696771f, 0.18168715f, 0.02685134f, -0.10983085f, -0.08355573f, 0.02782090f, -0.08006559f, 
    -0.45468187f, 0.10541007f, 0.27406698f, 0.28250346f, 0.14701365f, 0.04024101f, -0.01880925f, 0.15657641f, 
    0.14423290f, 0.00032517f, 0.15338257f, 0.16466743f, 0.05555084f, 0.40319350f, -0.32841325f, -0.36403424f, 
    0.13699353f, 0.03662083f, 0.01923131f, 0.02427427f, 0.25029847f, 0.04376332f, 0.08789994f, 0.10285726f, 
    0.30344909f, 0.04721148f, -0.48935661f, -0.39111146f, 0.02022935f, -0.03647770f, 0.10219817f, 0.08816776f, 
    -0.03680080f, 0.07094692f, -0.26489124f, -0.21911713f, -0.31190267f, 0.22480176f, 0.26161981f, 0.09145527f, 
    0.01388951f, -0.14742978f, -0.22181234f, -0.12912606f, 0.12541227f, -0.13664058f, 0.18273990f, -0.01189182f, 
    0.34236154f, 0.12830842f, -0.02673345f, -0.23867257f, -0.08483824f, -0.13595623f, -0.03551646f, 0.00964937f, 
    0.24825369f, 0.08701652f, 0.11473097f, 0.03817390f, -0.53631401f, -0.28641292f, -0.66427493f, 0.26222602f, 
    0.05278083f, 0.22751167f, 0.13745731f, 0.18624492f, 0.09133564f, 0.00481175f, -0.16763239f, 0.01290678f, 
    -0.11578695f, 0.04531051f, 0.09973815f, 0.01579492f, -0.09136387f, -0.04244945f, -0.07398694f, -0.03184523f, 
    -0.08380321f, 0.01070189f, -0.08066811f, -0.03289476f, -0.05538483f, 0.16490690f, 0.04607865f, 0.09978383f, 
    0.05582291f, 0.11814123f, -0.11759054f, -0.04664208f, -0.07689799f, -0.10593186f, -0.00043309f, -0.06638242f, 
    -0.19747928f, -0.29427379f, 0.13456962f, -0.09056431f, -0.06906801f, 0.05238508f, -0.05847459f, 0.02608473f, 
    -0.16098572f, 0.05520521f, -0.17964844f, -0.44699064f, -0.23000795f, -0.13396072f, 0.11222642f, -0.13623700f, 
    -0.03848305f, 0.02226269f, -0.03647456f, -0.05687384f, -0.03477737f, -0.02341977f, 0.06526136f, 0.00626206f, 
    -0.22151159f, -0.11971360f, -0.06203204f, 0.25863892f, -0.07060421f, 0.09721994f, 0.04941431f, 0.16802263f, 
    0.20633796f, -0.11583864f, -0.10395791f, -0.03504609f, -0.45353100f, -0.03591391f, -0.05534689f, 0.27676818f, 
    0.11125242f, 0.12323681f, -0.04467237f, 0.03340035f, 0.03647738f, -0.08984289f, 0.13023922f, 0.12532626f, 
    0.08652838f, 0.21514131f, 0.17767832f, 0.05619142f, 0.14152117f, 0.05998427f, -0.01176538f, 0.02947798f, 
    0.17282610f, -0.00485020f, 0.01002121f, -0.05756731f, -0.12388740f, 0.29617110f, -0.52083600f, -0.07916017f, 
    0.03228325f, -0.05621617f, 0.25204796f, -0.28649408f, 0.08058980f, -0.04972363f, -0.22058944f, -0.15919025f, 
    0.26627606f, -0.44795978f, 0.01728856f, -0.79647487f, 0.11760232f, -0.13351445f, 0.11733501f, 0.09090656f, 
    -0.17264904f, 0.04078323f, 0.02047187f, -0.10698925f, 0.38354009f, 0.33973366f, 0.43172467f, -0.32185227f, 
    -0.15081511f, -0.17263314f, 0.05963556f, -0.11149673f, -0.17197143f, 0.13162176f, -0.00191282f, 0.04988588f, 
    -0.23780532f, 0.55477345f, -0.07783163f, -0.42476088f, -0.07998094f, -0.16774206f, 0.16785066f, 0.25631434f, 
    -0.08278502f, 0.12159882f, -0.05433773f, -0.15992004f, 0.21033497f, -0.09803237f, 0.46392429f, 0.57803011f, 
    -0.00666758f, 0.10561112f, -0.12792709f, -0.14430417f, 0.20713158f, 0.07497617f, 0.16323419f, 0.12919533f, 
    -0.14331810f, -0.32031125f, -0.22006649f, 0.08264967f, -0.16708988f, 0.07772665f, -0.29124972f, 0.05584643f, 
    0.11253271f, -0.06633992f, 0.04811084f, -0.02512900f, 0.22182588f, -0.12007257f, 0.06787347f, -0.32804611f, 
    0.08867131f, 0.01692270f, 0.11481870f, 0.14103231f, 0.14824022f, -0.01306675f, 0.02907020f, -0.08876644f, 
    0.22779508f, 0.12878840f, -0.21752194f, 0.20203938f, 0.05818534f, -0.20110884f, 0.02283051f, -0.16595381f, 
    0.11615989f, 0.12988050f, -0.14229162f, 0.00820008f, 0.23081580f, 0.08608990f, 0.06131942f, -0.09983988f, 
    0.12198211f, 0.09575442f, 0.20372649f, 0.14706250f, 0.17229709f, -0.05473893f, -0.05933253f, 0.05909079f, 
    -0.10334643f, 0.14412227f, -0.04638102f, -0.14563826f, -0.18622312f, -0.25873315f, -0.10644415f, -0.30612528f, 
    0.13788132f, 0.02361745f, 0.19554842f, 0.01762174f, -0.51585376f, -0.09149821f, -0.11840636f, 0.03484157f, 
    -0.10601211f, -0.08643590f, -0.05474648f, 0.00121086f, 0.10574102f, 0.09900744f, 0.20572959f, 0.11042096f, 
    -0.42098981f, 0.16387568f, 0.18667436f, -0.62352377f, -0.32790533f, -0.12511270f, 0.16185321f, -0.15457231f, 
    0.14456223f, -0.01861637f, 0.01630652f, -0.06414215f, -0.45859542f, 0.35210863f, 0.02710205f, 0.10811212f, 
    -0.18470715f, -0.16272108f, -0.03593453f, -0.16174681f, 0.10952304f, -0.10730646f, 0.02387237f, -0.06633653f, 
    0.41407138f, -0.07624233f, 0.10052559f, 0.09669532f, 0.09566051f, -0.09849852f, 0.06428063f, -0.19872689f, 
    -0.00611330f, 0.03886596f, -0.17700210f, -0.13632430f, -0.10721863f, -0.22931017f, 0.16233496f, -0.21480319f, 
    0.07496379f, -0.18476373f, 0.08733999f, 0.31026942f, -0.00152534f, 0.02440396f, 0.07092065f, -0.05200681f, 
    0.06063490f, -0.28789964f, 0.05535864f, -0.28229514f, -0.00264646f, -0.08255330f, -0.04249851f, 0.01610978f, 
    0.03981176f, 0.09695878f, -0.01662060f, 0.06902399f, -0.22919154f, -0.01882866f, -0.35306513f, 0.18963869f, 
    -0.11016925f, 0.11532842f, -0.13422686f, -0.03890529f, 0.14405562f, -0.03849121f, 0.11818814f, -0.04421816f, 
    0.27922705f, -0.04879769f, 0.62997532f, -1.02028930f, -0.00793181f, -0.15812394f, 0.02927345f, -0.00115703f, 
    -0.20142306f, 0.12241451f, 0.09219192f, 0.01470172f, -0.53909844f, 0.28487945f, 0.38398704f, -0.21718986f, 
    -0.31843969f, -0.26897639f, 0.20159462f, 0.09687132f, -0.08880750f, -0.02982074f, 0.04450221f, -0.06961942f, 
    -0.49183458f, 0.12941732f, -0.23107280f, -0.10431120f, -0.04805601f, -0.10522395f, 0.23228590f, 0.16291246f, 
    -0.03310801f, -0.03234181f, -0.21206534f, -0.11181283f, 0.06171970f, 0.20845969f, 0.04300464f, 0.39733469f, 
    0.18862358f, -0.08122663f, -0.04560149f, -0.03583058f, 0.02120038f, 0.02311088f, 0.11924516f, 0.07823894f, 
    -0.51644957f, -0.07054758f, -0.22365630f, 0.24283044f, 0.05322686f, 0.20490319f, -0.12616228f, -0.08525034f, 
    -0.01449521f, 0.01186993f, 0.15585126f, -0.00385141f, -0.31593505f, 0.21824503f, -0.49567351f, -0.24189520f, 
    0.03215897f, 0.05283211f, 0.18429744f, 0.08879117f, -0.03194927f, -0.08099583f, -0.14056660f, -0.04230965f, 
    0.08715585f, -0.10511281f, 0.01896482f, 0.00591711f, -0.03032147f, 0.08350120f, 0.05573190f, 0.08830927f, 
    -0.05426358f, 0.10381317f, -0.03737176f, -0.17305499f, 0.15894306f, 0.38958502f, 0.20303760f, 0.08364576f, 
    0.07929044f, -0.47338739f, -0.19043830f, -0.10930485f, -0.14152873f, -0.08481703f, -0.07221706f, 0.01354205f, 
    -0.17035808f, -0.29598504f, -0.13236187f, -0.13971376f, 0.18078183f, 0.10273350f, 0.21641809f, 0.13256785f, 
    0.09020946f, 0.01777067f, 0.08946891f, 0.03614215f, -0.13057280f, 0.01883849f, -0.70703954f, -0.00265190f, 
    0.18328340f, 0.18727064f, 0.04732808f, 0.16927350f, -0.08413766f, -0.03547822f, -0.03530909f, 0.03812234f, 
    0.19828355f, -0.19215493f, 0.11947683f, -0.07284363f, 0.06445628f, -0.01272050f, 0.00295774f, 0.08684592f, 
    -0.02913545f, 0.18956341f, 0.14769189f, 0.12719516f, -0.25197807f, -0.00882328f, 0.01415536f, -0.05013159f, 
    0.10107453f, 0.19479334f, 0.02611728f, -0.17497934f, 0.35421705f, 0.05334347f, -0.02148765f, -0.23335212f, 
    0.33364999f, -0.52903527f, 0.01338201f, -0.36311257f, -0.01288679f, 0.14603539f, -0.20001286f, 0.28804672f, 
    0.03357870f, -0.01840301f, -0.16926070f, 0.09359528f, -0.06515271f, 0.15806212f, 0.45364049f, -0.66217607f, 
    -0.06618263f, -0.24423137f, 0.12019723f, -0.20478363f, -0.03085768f, 0.11702806f, -0.05895120f, -0.13553673f, 
    -0.17297582f, -0.09190094f, -0.43323442f, -0.10485849f, -0.05943904f, -0.25958255f, 0.06036972f, 0.04209669f, 
    -0.20897089f, -0.20123610f, -0.13424125f, -0.25772992f, 0.12270711f, 0.02277864f, -0.60283619f, -0.00265183f, 
    -0.15561533f, 0.22187896f, 0.31579176f, -0.03159343f, -0.09771933f, 0.07663034f, 0.04951332f, 0.23551023f, 
    0.04300179f, -0.29709738f, -0.28585297f, 0.48896852f, -0.02857536f, 0.09057337f, -0.02199660f, 0.10362568f, 
    0.12190641f, -0.09257176f, -0.28104979f, 0.13470590f, -0.36609742f, 0.12633359f, 0.00087747f, 0.10988445f, 
    0.21427017f, -0.21630944f, 0.11620355f, 0.01791118f, -0.14424741f, 0.04247843f, -0.07541135f, -0.01005065f, 
    0.07517050f, -0.56896281f, 0.19689518f, 0.43815020f, 0.02023884f, -0.22142304f, 0.01258763f, -0.04471900f, 
    -0.16412567f, -0.23500429f, -0.01085584f, 0.12639962f, -0.61906403f, 0.24507949f, -0.38141713f, -0.16252284f, 
    0.02198062f, 0.05427153f, 0.04316210f, 0.02999085f, -0.19890706f, -0.27105999f, -0.33914420f, -0.64799470f, 
    -0.30919972f, 0.43886632f, -0.39224672f, 0.24959576f, 0.04472566f, 0.29775339f, 0.13790371f, 0.01748701f, 
    -0.10043632f, 0.14538780f, 0.01318538f, 0.04169748f, 0.08369558f, -0.26277515f, 0.04665025f, 0.28781825f, 
    0.02921328f, -0.24393560f, -0.25137034f, 0.10074268f, -0.02294450f, -0.26136118f, -0.07007363f, -0.17540087f, 
    -0.03172539f, 0.39253893f, -0.24622400f, 0.38860449f, 0.09631445f, -0.05804698f, -0.06282061f, -0.04272926f, 
    -0.12389616f, 0.07427709f, 0.02107741f, -0.08080693f, -0.08795392f, 0.21916255f, 0.24168201f, 0.13154395f, 
    -0.08189116f, 0.01531371f, 0.12475378f, 0.06115212f, -0.10609301f, 0.29831758f, 0.30148506f, 0.24839850f, 
    0.44910124f, -0.22497393f, 0.00922127f, -0.05272581f, 0.14419262f, -0.34409732f, 0.03634040f, 0.20137498f, 
    -0.10110776f, 0.13205542f, -0.18734823f, -0.36774048f, -0.12799606f, -0.14929539f, -0.17590193f, 0.03659999f, 
    0.05094356f, 0.18172604f, -0.03398541f, 0.08595390f, 0.06375992f, 0.08898661f, -0.04611273f, -0.15683886f, 
    0.14349748f, 0.29417163f, 0.21661723f, -0.04986079f, -0.07445338f, 0.06726656f, 0.11037083f, -0.06515463f, 
    0.03913997f, 0.03700372f, 0.02714940f, 0.20940995f, 0.20748447f, 0.09043036f, 0.32278284f, -0.09952401f, 
    -0.15234317f, 0.00242961f, -0.01064790f, -0.04458233f, -0.04816519f, 0.07917158f, 0.06456465f, -0.08056311f, 
    -0.39306781f, 0.09298474f, 0.00458146f, -0.04972792f, -0.05384254f, 0.17925158f, -0.07102454f, 0.04497728f, 
    0.15408361f, -0.13485789f, 0.20816207f, 0.14660537f, -0.31813672f, 0.09962662f, -0.50056702f, 0.15157469f, 
    0.02715167f, -0.00934902f, -0.08335473f, -0.15722266f, 0.02618657f, 0.16770269f, 0.08477407f, 0.04229963f, 
    -0.32053903f, -0.23748855f, -0.21893963f, 0.03826624f, 0.14076219f, 0.28355664f, -0.26716086f, -0.04833693f, 
    -0.23114339f, 0.00021153f, -0.00512880f, 0.04964677f, -0.14406034f, -0.13500158f, -0.11692084f, 0.00987880f, 
    -0.07310650f, -0.05876933f, 0.10152994f, 0.21539919f, -0.09581175f, 0.11524319f, -0.02987703f, -0.25316498f, 
    0.10369024f, 0.17532142f, 0.21636513f, 0.27946633f, -0.06075360f, -0.09407113f, 0.06150120f, -0.01856628f, 
    0.08116998f, -0.01921905f, 0.00750384f, -0.01863544f, -0.37836203f, -0.35084060f, 0.16381758f, 0.09732346f, 
    -0.04226129f, 0.12115183f, -0.21586022f, 0.09238063f, -0.04042076f, 0.07563536f, 0.01007836f, -0.04977944f, 
    0.22466885f, -0.15751737f, 0.25761557f, 0.21653347f, 0.08575558f, 0.16878587f, 0.23595384f, 0.02211277f, 
    0.08181079f, 0.16105399f, 0.26694384f, 0.09992632f, -0.31262827f, 0.39691994f, 0.16539396f, -0.23197347f, 
    -0.05531827f, -0.10376532f, 0.18298051f, 0.08263131f, -0.34858143f, -0.05372385f, -0.22205697f, -0.03120982f, 
    0.48793387f, 0.52702010f, 0.05315503f, -0.07899404f, -0.08632233f, 0.00870047f, 0.13049993f, 0.10060584f, 
    0.04490480f, -0.08282081f, -0.31559035f, -0.38390487f, -0.04036466f, -0.23054382f, -0.19815882f, -0.10034072f, 
    -0.10218593f, -0.20200372f, 0.27387753f, -0.09747004f, -0.13017949f, 0.16601321f, -0.11480433f, -0.00459667f, 
    -0.20827875f, 0.11585497f, -0.20970441f, 0.22424637f, -0.05984855f, 0.10582308f, -0.16665161f, 0.10067509f, 
    0.05971735f, -0.11079197f, 0.14610732f, 0.12408987f, 0.42933875f, -0.01470495f, 0.35971197f, -0.35337126f, 
    -0.24314871f, -0.01451503f, 0.08911052f, 0.06320462f, -0.01589319f, -0.19995484f, 0.10544764f, -0.17349988f, 
    -0.15575312f, -0.35182601f, -0.09103820f, -0.46968165f, -0.20707735f, -0.06776560f, -0.22237152f, -0.01677573f, 
    -0.06132462f, -0.12182171f, 0.06243964f, -0.11426260f, -0.11112117f, 0.36112568f, 0.23656878f, -0.04295599f, 
    -0.05738422f, -0.03710745f, -0.06022197f, 0.05116438f, -0.06831007f, 0.04133894f, 0.08752815f, -0.09259860f, 
    0.00307212f, 0.19055313f, 0.02216851f, 0.12626132f, 0.01803955f, -0.07159040f, -0.11427590f, 0.05684175f, 
    -0.17633168f, -0.22054403f, -0.22133635f, -0.28257036f, -0.32774940f, 0.13903596f, 0.10875527f, -0.42773208f, 
    -0.21157001f, -0.09206316f, 0.19894956f, 0.00438335f, -0.21556397f, -0.05480789f, 0.25951537f, -0.02657902f, 
    -0.21244104f, 0.37344328f, 0.18030593f, 0.08090124f, 0.05106088f, 0.36524981f, -0.40593019f, 0.10738559f, 
    -0.21513009f, 0.07479529f, 0.04919404f, -0.06558359f, 0.07105510f, 0.16175097f, -0.36687404f, 0.22051969f, 
    -0.12778610f, 0.00674161f, 0.11765679f, -0.09316693f, 0.13019204f, -0.02345024f, -0.03613738f, 0.00019698f, 
    0.32073706f, -0.10464414f, 0.03696281f, 0.00130214f, -0.01489727f, -0.07684489f, -0.07365774f, 0.03285276f, 
    0.07492606f, 0.16610466f, 0.20424400f, 0.27333623f, 0.60643947f, -0.38249540f, 0.51453799f, 0.03582570f, 
    0.14651938f, 0.25117344f, -0.22525299f, 0.20229249f, -0.43118176f, -0.14084035f, -0.05027723f, -0.26970854f, 
    -0.09297570f, -0.33992785f, 0.08324618f, -0.30546170f, -0.03041820f, 0.21179013f, -0.03076445f, 0.09925724f, 
    -0.18476740f, 0.06881119f, 0.14595445f, 0.15661682f, -0.17990264f, -0.80437934f, 0.19994748f, 0.21592508f, 
    0.13589154f, 0.04683852f, 0.18734552f, 0.09566114f, -0.05471502f, 0.06799214f, -0.00331477f, 0.07411528f, 
    -0.25087258f, -0.26572117f, 0.75813037f, 0.11143674f, -0.22153607f, 0.16283442f, -0.01432155f, -0.05413754f, 
    0.01791701f, 0.01411633f, 0.00225413f, -0.02359743f, -0.18519826f, 0.00084354f, -0.43332011f, 0.33784723f, 
    0.23645163f, -0.12346128f, 0.07417087f, -0.12339086f, -0.00132888f, 0.08029149f, 0.37410277f, 0.25406286f, 
    -0.05030771f, -0.20387734f, 0.20372608f, 0.41348529f, 0.14424649f, -0.07456122f, 0.02930257f, -0.01082659f, 
    -0.04279683f, -0.09843384f, 0.09787662f, -0.01045885f, -0.04929942f, -0.17008406f, 0.09086091f, 0.05590058f, 
    -0.14838959f, 0.24278939f, -0.08229792f, -0.03743637f, -0.10725050f, 0.14002106f, -0.02691387f, -0.02636293f, 
    -0.07011872f, -0.48443800f, 0.21876605f, 0.31082866f, -0.15599254f, -0.09446090f, 0.03906754f, -0.15552671f, 
    0.05877686f, 0.07445303f, 0.24614604f, 0.07712589f, -0.09756308f, 0.03507514f, 0.00659489f, 0.08303680f, 
    0.00626220f, 0.08553515f, 0.06559242f, 0.16578184f, -0.12124971f, -0.22713020f, -0.27110976f, -0.33827722f, 
    0.00664609f, 0.04316162f, -0.10104135f, -0.42681053f, -0.07028449f, -0.00084940f, 0.08660483f, -0.13159485f, 
    -0.05349571f, 0.11283500f, -0.05392510f, -0.18492295f, -0.23182046f, -1.23367667f, 0.38949817f, 0.04421538f, 
    -0.12583777f, -0.07750449f, -0.22654442f, -0.26471585f, 0.09491220f, 0.01071291f, 0.11846836f, 0.07801272f, 
    -0.16378760f, 0.75189453f, -0.14847125f, 0.23450573f, 0.05901709f, 0.02742201f, 0.02661463f, -0.01361889f, 
    0.00787532f, 0.21934003f, -0.09295548f, 0.29004762f, -0.45789200f, -0.46971962f, 0.21625978f, -0.35501388f, 
    0.26311010f, 0.03746630f, 0.19978867f, -0.02452299f, -0.06870538f, 0.07129624f, -0.10509077f, -0.05367809f, 
    0.11474287f, 0.04572979f, -0.06813708f, 0.04441315f, 0.27293107f, -0.18759950f, 0.02369539f, 0.11561242f, 
    0.00864241f, -0.03825794f, -0.01741785f, -0.08516118f, -0.12499539f, -0.40289730f, -0.31281859f, -0.03529490f, 
    -0.18292968f, -0.19958028f, -0.11855486f, -0.26436931f, 0.00213380f, 0.06168194f, -0.08466586f, -0.04851086f, 
    0.26379478f, -0.09714488f, 0.29955840f, -0.20490204f, -0.34207305f, 0.04175970f, -0.07828961f, -0.08350892f, 
    0.05619063f, -0.04984756f, -0.01396082f, -0.04391372f, -0.58515584f, 0.38847223f, -0.33999851f, 0.25926581f, 
    -0.26043451f, 0.11663097f, 0.09422683f, -0.20519383f, -0.01052631f, 0.04355202f, 0.09617539f, 0.00241408f, 
    -0.63706428f, 0.35626945f, -0.48925683f, 0.06230080f, 0.21974650f, 0.04596247f, -0.15131117f, 0.16555573f, 
    -0.25536147f, -0.08217357f, -0.07925667f, -0.13859372f, 0.17389920f, -0.11420849f, 0.27196160f, -0.32725400f, 
    0.09047737f, -0.19610438f, -0.05785871f, -0.13512155f, 0.04811966f, 0.15671340f, -0.11190644f, -0.19564103f, 
    0.07263261f, 0.04285960f, 0.32619938f, -0.19335437f, -0.07699293f, 0.02963224f, -0.19061734f, 0.04092760f, 
    -0.12769195f, -0.16374306f, 0.00178353f, 0.06447467f, -0.10262603f, -0.34215486f, 0.12751813f, 0.38343793f, 
    -0.03272491f, 0.07568914f, -0.14961825f, 0.04514160f, -0.00385045f, -0.09799568f, 0.04378455f, 0.07901603f, 
    -0.33086482f, -0.11730254f, 0.14325725f, -0.31730673f, 0.07161956f, 0.14655232f, -0.02277078f, 0.03639660f, 
    0.02250776f, -0.03506950f, 0.22048718f, 0.22643280f, 0.85279053f, 0.17464446f, 0.28223771f, 0.09890290f, 
    0.17531672f, -0.00920473f, -0.53858280f, 0.08393893f, -0.14537112f, -0.01618025f, 0.02169752f, 0.11267658f, 
    0.03385225f, 0.00247695f, -0.23488419f, 0.26760289f, 0.03425490f, -0.13383602f, -0.06454574f, 0.15413028f, 
    0.06382719f, -0.00114640f, -0.00690628f, -0.13230841f, -0.19660665f, -0.44160366f, -0.07410280f, -0.33232445f, 
    0.01155049f, 0.05060617f, -0.00856169f, -0.06518985f, -0.26893166f, 0.05201152f, 0.16410792f, -0.28626156f, 
    0.37363333f, 0.17727250f, -0.08746291f, -0.23755886f, -0.02529930f, -0.04680337f, -0.06877668f, 0.19252463f, 
    -0.10655797f, 0.07895156f, 0.07715011f, -0.12878843f, 0.15457152f, -0.07509547f, 0.58402401f, 0.23873419f, 
    0.08103201f, -0.20019659f, 0.09060818f, 0.23364733f, 0.06557722f, 0.00666977f, -0.19783267f, 0.11610501f, 
    -0.40439412f, 0.17097792f, -0.27139744f, 0.18698496f, -0.01668596f, 0.16444896f, -0.03737995f, 0.06299991f, 
    -0.12922844f, 0.05581459f, 0.18109609f, 0.13114007f, -0.12534444f, 0.19527034f, -0.20909263f, 0.12045804f, 
    0.00831691f, 0.18933032f, 0.19050677f, -0.02404753f, 0.01492485f, 0.04226959f, -0.06301047f, 0.08572213f, 
    -0.34349996f, 0.24360090f, 0.02360086f, 0.31699410f, -0.20069391f, -0.08945835f, 0.18458764f, 0.09406634f, 
    -0.17269480f, 0.01867707f, -0.04466043f, -0.00464755f, 0.19077064f, -0.06658480f, 0.43649676f, 0.04822282f, 
    0.10505019f, -0.10486216f, 0.08846954f, 0.05193430f, -0.10830429f, -0.14461023f, 0.05215602f, -0.22031905f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.18837698f, 0.15560132f, 0.08587763f, -0.11668906f, -0.08486837f, 0.14648698f, 0.08889831f, -0.12432687f, 
    0.02298608f, 0.00469615f, 0.00821513f, -0.07065220f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
