#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    1.03611481f, 0.78642672f, 0.96072626f, 0.57818919f, -0.04694960f, -0.37478250f, 0.37169299f, -0.62364578f, 
    0.21154368f, 0.53422815f, -0.37600252f, -0.41671225f, -0.14717443f, -0.01966436f, 0.19605486f, 0.47325277f, 
    0.21953842f, 0.10431516f, 0.54757208f, 0.07587557f, 0.33404630f, -0.01499670f, 0.09589198f, -0.00877528f, 
    0.40919134f, -0.87474108f, -0.71455193f, -0.26052469f, -0.51665634f, -0.48415133f, -0.26076928f, -0.56704998f, 
    0.25475693f, 0.25868514f, -0.22869375f, 0.52891421f, 0.04647309f, -0.21833308f, 0.16792484f, -0.43140873f, 
    -0.20046122f, 0.21298467f, -0.45519197f, 0.12160528f, 0.23646443f, 0.17780071f, 0.14150941f, -0.16482404f, 
    -0.04719272f, -0.50600100f, -0.43650442f, -1.12561977f, -0.68570805f, -0.41416684f, -0.59564316f, -0.32875821f, 
    0.94953173f, 0.71866149f, -0.21293356f, 0.47053334f, -0.27779263f, -0.34788898f, -0.34238917f, -0.33902812f, 
    -0.39352852f, -0.03602102f, 0.34761450f, -0.13155861f, -0.13045126f, -0.09956251f, -0.19899760f, 0.17184024f, 
    -0.11159532f, -0.25945967f, 0.16240419f, 0.32110158f, -0.18358789f, -0.53700978f, -0.63355911f, -0.36774191f, 
    0.62240869f, 1.04469717f, 0.61154014f, 0.75317097f, 0.68391043f, -0.04006165f, 0.25455886f, -0.33033976f, 
    -0.33954602f, -0.25590178f, -0.05042178f, -0.05968486f, -0.23184733f, 0.22129464f, 0.29102632f, 0.01221643f, 
    -0.36091924f, -0.18572165f, -0.32046461f, -0.39155370f, -0.20076609f, 0.05794802f, -1.09162247f, -0.61262375f, 
    -0.12848832f, 0.53845531f, -0.57835120f, -0.02683435f, -0.29938617f, 0.39320499f, -0.21326512f, -0.35698649f, 
    0.32284033f, 0.05341357f, -0.07878228f, 0.13798809f, -0.45517948f, 0.22167857f, 0.17482516f, 0.21262328f, 
    0.20620327f, -0.15635855f, -0.11162183f, -0.26817027f, 0.37976992f, -0.51599497f, -0.78361976f, -0.44669220f, 
    -0.29771259f, 0.21654513f, -1.02790511f, -0.55427092f, -0.36701244f, -0.51618415f, 0.18626921f, -0.06571324f, 
    0.27208361f, 0.22426938f, -0.12648940f, 0.04144621f, 0.15259323f, 0.15765086f, 0.42470542f, -0.11409757f, 
    -0.45318294f, 0.28323418f, -0.43506643f, 0.23109254f, 0.27429461f, 0.04488565f, -0.14768870f, -0.41220009f, 
    -1.15993571f, -0.74212432f, -0.16161942f, 0.37566087f, -0.07322625f, 0.21392980f, 0.47757658f, 0.03308994f, 
    -0.50576824f, 0.02104308f, -0.04325396f, -0.01101568f, -0.71889055f, 0.44176710f, 0.09401052f, 0.20713606f, 
    -0.15336816f, 0.35150468f, 0.32927927f, 0.07208597f, -0.35528171f, 0.18557255f, 0.17370827f, 0.31072426f, 
    0.23336397f, 0.35365206f, -0.06548656f, 0.90243542f, 0.73882157f, -0.61618841f, -1.14874029f, -0.59104764f, 
    0.10472614f, -0.01441630f, 0.57247931f, 0.00755103f, -0.00020363f, 0.27382737f, 0.23267710f, 0.13800508f, 
    -0.12722285f, 0.05876077f, 0.46023950f, 0.36239466f, 0.05302789f, 0.02942105f, -0.06683224f, -0.08782435f, 
    -1.02105117f, -0.66159260f, -0.18359549f, -0.34442317f, 0.18224414f, 0.41594553f, 0.09707052f, -0.02994044f, 
    -0.50201821f, -0.52446985f, -0.24586342f, 0.39633998f, 0.24790846f, 0.55949658f, 0.33955055f, -0.14179656f, 
    0.17796774f, -0.46032351f, 0.00093089f, 0.48404121f, -0.11782467f, -0.11940923f, 0.05440508f, -0.48215237f, 
    -0.27754903f, 0.35258803f, -0.96051854f, -0.69061029f, -0.47114241f, -0.62924546f, -0.19179720f, 0.35688719f, 
    -0.13833115f, -0.13332745f, 0.20462780f, 0.80832940f, 0.46685186f, -0.19401006f, 0.04243362f, 0.35350287f, 
    0.17980260f, -0.12800978f, 0.05683817f, 0.01377800f, 0.26213175f, 0.11356813f, 0.26169187f, -0.12533979f, 
    0.18647446f, 0.07350624f, 0.62292808f, -0.52354431f, 0.56443685f, -0.35556230f, -0.10385377f, 0.32609534f, 
    0.32576847f, -0.39227071f, -0.17519055f, 0.14573760f, -0.44803897f, 0.58221644f, 0.35120639f, 0.37788227f, 
    -0.01224656f, -0.48920542f, 0.27556276f, 0.51989770f, -0.30328527f, 0.03372922f, -0.00341699f, 0.33426774f, 
    -0.34572151f, -0.34037575f, 0.45074281f, -1.46545255f, 0.86010939f, -0.51811689f, -0.33419117f, 0.16747075f, 
    -0.01157842f, 1.20035970f, 0.15859480f, -0.03706030f, 0.41979107f, -0.23197632f, -0.31414628f, 0.28475982f, 
    -0.29633573f, 0.57063085f, 0.40674445f, 0.03154676f, -0.15475275f, 0.13157505f, -0.05882078f, 0.43822852f, 
    0.38158947f, -0.07779721f, 0.13693532f, 0.16737598f, -0.61663175f, -1.23911905f, 0.04725982f, -0.13921745f, 
    -0.58537853f, 0.23513000f, -0.41437647f, -0.16320723f, -0.64067638f, 0.23938176f, 0.07903196f, -0.06409477f, 
    -0.04251117f, 0.19685808f, 0.25620428f, 0.36046290f, 0.29151639f, 0.27579132f, 0.37113535f, -0.22022896f, 
    -0.12655406f, -0.53934264f, 0.08736683f, -0.01945775f, -0.09471116f, 0.83626395f, -0.79378110f, 0.30730191f, 
    0.63645947f, -0.06234613f, 0.68985718f, -0.90059263f, 0.38777658f, 0.79494363f, -0.03284024f, -0.72394383f, 
    -0.17629799f, -0.49249792f, 0.49181074f, 0.25092259f, 0.07767440f, 0.13928106f, 0.07358722f, 0.06247100f, 
    0.29069552f, -0.39803004f, -0.22933021f, -0.14666680f, -0.08961780f, -0.00583505f, -1.08367264f, -0.76672417f, 
    0.42132437f, 0.04910631f, 0.11792751f, -0.39821854f, 0.73259050f, 0.74759763f, -0.58292782f, 0.01043400f, 
    0.05611493f, -0.05452788f, 0.48354155f, -0.13323033f, 0.09346415f, -0.14294712f, -0.07961511f, 0.13792795f, 
    -0.38788077f, -0.20873672f, 0.29445750f, -0.00512130f, -0.12577130f, 0.23749371f, -0.34843403f, -0.48829243f, 
    0.52732939f, 0.12583403f, -0.32288796f, -0.37712419f, -0.20842724f, 0.57805943f, -0.92261493f, -0.69805348f, 
    -0.06599490f, 0.12153863f, 0.34771138f, 0.12611729f, -0.14429812f, 0.01900313f, -0.03376783f, -0.63034743f, 
    -0.47719035f, 0.06986091f, 0.02361412f, 0.37178859f, 0.31293750f, 0.35291860f, 0.22375707f, -0.04737104f, 
    1.43802440f, 0.38636476f, 0.30051714f, 0.87479258f, 0.61907589f, -0.49538866f, 0.29235080f, -0.48095635f, 
    0.41862017f, 0.10315754f, -0.26202661f, 0.08850731f, 0.12450330f, -0.00180629f, -0.11031501f, -0.09776665f, 
    -0.02175512f, 0.02220176f, -0.21566088f, 0.04841444f, -0.22297271f, 0.19083491f, -0.05524793f, 0.20492527f, 
    0.25869811f, 1.37920356f, 0.51305890f, -1.03441751f, -0.93536156f, -0.67758071f, -0.06403854f, -0.55508095f, 
    -0.24433711f, 0.10659596f, 0.08850211f, -0.41780370f, -0.13423185f, 0.07775118f, -0.13629153f, -0.33222985f, 
    0.00545749f, -0.14181724f, -0.30489883f, 0.17170645f, 0.60133332f, -0.22844733f, 0.36370248f, -0.00707116f, 
    -0.25965819f, -0.20082413f, -1.36427927f, 1.12521124f, -0.45096335f, -0.90977961f, -0.76240546f, 1.07440913f, 
    -0.21200792f, -0.43607903f, 0.42840719f, -0.33733830f, -0.01921326f, -0.06803526f, 0.06745749f, 0.31925619f, 
    -0.09899358f, -0.07311311f, 0.18772981f, 0.06838176f, -0.05074876f, -0.10735589f, 0.04523657f, 0.06106472f, 
    0.36571074f, 0.28396630f, 0.23693927f, 0.86665100f, 0.59619832f, 1.05196047f, 0.65038371f, 0.01839153f, 
    0.22617991f, -0.58583844f, 0.18954784f, 0.25961566f, 0.67910022f, 0.35222873f, 0.10560893f, -0.49277768f, 
    0.28021684f, -0.48229212f, -0.19290689f, 0.09504347f, 0.10207055f, -0.32985058f, -0.32100546f, -0.14652310f, 
    -0.09968817f, 0.29978147f, -0.07820742f, -0.00957640f, 0.23796867f, 0.05051228f, -0.25902081f, 0.75935197f, 
    -0.32839844f, -0.79593748f, 0.35318321f, -0.90983474f, -1.02385998f, -0.06576514f, 0.02330291f, 0.45008546f, 
    0.06586323f, 0.36895627f, -0.30932915f, -0.20257342f, -0.17463368f, -0.10177462f, 0.00429837f, -0.39647180f, 
    0.33844012f, -0.18609399f, 0.20007230f, 0.15515371f, 0.17735954f, 0.19064066f, -1.47279394f, -0.81384319f, 
    0.71927607f, 0.09507669f, -0.51549745f, 1.01765811f, 0.16943578f, -0.20809756f, 0.49411273f, 0.37270245f, 
    0.20850354f, -0.24400657f, 0.11567876f, 0.35557297f, -0.36438334f, -0.11609474f, 0.01349700f, 0.04494223f, 
    -0.23237213f, -0.08075196f, -0.14292431f, -0.12218339f, -0.14129746f, -0.14481603f, -0.73134673f, 0.55069435f, 
    0.81685364f, 0.27914375f, 1.13454926f, 1.04729199f, -0.12776572f, 0.15179957f, 0.01137464f, -0.51211923f, 
    0.40646040f, -0.09216778f, -0.36249036f, -0.28315127f, -0.45985606f, -0.26252228f, -0.13746887f, -0.17813721f, 
    -0.13382301f, -0.04931628f, 0.16605057f, 0.14446598f, 0.04271332f, -0.12798236f, 0.12555666f, 1.24262643f, 
    -0.97104084f, 0.43228719f, -1.03772938f, -0.26560840f, 0.07498197f, 0.39837241f, 0.68819672f, 0.35076734f, 
    0.16206640f, 0.30445170f, -0.09045786f, -0.35821354f, 0.20707886f, -0.38381991f, -0.11295653f, -0.21805690f, 
    0.15169746f, 0.06234022f, -0.30303180f, -0.17269491f, 0.34425724f, 0.20970170f, 0.32016468f, 0.15220207f, 
    -0.25538868f, -0.34400129f, -0.40637460f, -0.43709663f, 0.64865690f, 0.47249597f, -0.09819451f, 0.77827960f, 
    0.46215230f, 0.53173059f, 0.50413835f, -0.41237324f, -0.06622481f, -0.09094999f, 0.30846581f, 0.16423476f, 
    -0.02888988f, -0.08974970f, 0.27731618f, -0.13167080f, -0.41449064f, 0.15247858f, -0.10012943f, 0.63011450f, 
    0.31698781f, 0.32136825f, -0.58296609f, -0.74140072f, 0.06121903f, -0.58940279f, -0.31020552f, 0.34501508f, 
    0.46157017f, 0.68150282f, 0.02680069f, -0.58682376f, -0.50384229f, 0.16347654f, -0.19744894f, 0.09190389f, 
    -0.51693815f, -0.44655594f, -0.04592220f, -0.02668692f, -0.26552165f, -0.02342884f, -0.02868414f, -0.09389413f, 
    -0.13416921f, 0.01655154f, 1.07211256f, 0.84450895f, 0.19782995f, -0.21549486f, -0.77917218f, 0.64994866f, 
    -0.13916047f, 0.42682412f, 0.49604073f, 0.26336077f, 0.61437362f, 0.33260643f, 0.27568752f, 0.43090045f, 
    0.27793387f, 0.20315191f, -0.42118648f, -0.15192214f, -0.03864575f, 0.32660633f, 0.09554816f, 0.20783924f, 
    0.04890561f, -0.33369416f, 0.00126033f, 0.31900075f, -1.01433313f, 0.36487815f, 0.53377193f, 1.08239567f, 
    -1.15080774f, 0.39426523f, 0.16271015f, -0.43033114f, 0.35398409f, 0.34198248f, 0.45836884f, -0.07673862f, 
    -0.06226904f, 0.15985084f, -0.28265703f, 0.00907897f, -0.22559714f, 0.18184727f, -0.20689280f, -0.12980676f, 
    0.08964910f, 0.07787824f, 0.04654229f, -0.23177637f, 0.77975494f, 0.03713287f, -0.18445374f, 0.81717616f, 
    1.05362892f, -0.28105420f, 0.33073217f, 0.52846944f, 0.74833572f, -0.37746575f, -0.36898339f, -0.23254047f, 
    -0.24506734f, -0.13816121f, -0.10153320f, 0.21322812f, -0.14150816f, 0.40797353f, 0.08558061f, -0.16263635f, 
    0.16567001f, -0.38892996f, -0.36621448f, -0.12183990f, -0.10395183f, 0.99929637f, 0.31563336f, 0.73449087f, 
    1.09874821f, 1.10667086f, 0.44628003f, 0.37886232f, -0.07887425f, -0.48882362f, -0.27529162f, 0.24838181f, 
    0.27485758f, 0.04568185f, 0.41786346f, 0.14500225f, 0.04382249f, 0.11117132f, 0.37291932f, 0.07777017f, 
    0.08183838f, 0.11102229f, 0.05011295f, 0.17153098f, -0.12119854f, 0.09838594f, 0.21474163f, -1.34079826f, 
    0.77940834f, 1.10981274f, -0.51320237f, -0.47758856f, 0.49337125f, 0.64138514f, 0.11095713f, -0.52207130f, 
    0.01744165f, -0.02770999f, -0.06759377f, -0.09907307f, 0.08062390f, -0.11405529f, 0.14333761f, -0.18294692f, 
    -0.03104062f, -0.14133048f, -0.06786519f, 0.01753205f, 0.11964867f, 0.22987795f, 0.20901895f, -0.11845197f, 
    0.09417666f, 0.79613853f, 0.03643337f, 0.73839629f, -1.32993031f, -0.47167593f, -0.54113716f, -0.55491108f, 
    -0.88043094f, 0.29559827f, 0.38396022f, 0.15366164f, 0.15321076f, 0.21079925f, 0.11525675f, 0.31867880f, 
    0.19938654f, -0.12376878f, 0.35747474f, 0.24852002f, 0.03712722f, 0.10243830f, 0.04824872f, -0.09643956f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.14006521f, 0.29116112f, -0.04234380f, 0.11011963f, 0.39725870f, 0.31336135f, 0.04737508f, 0.29645905f, 
    0.42372200f, 0.04540253f, 0.14314638f, 0.13696188f, 0.12205178f, 0.01276285f, 0.20639728f, 0.18342628f, 
    0.12393687f, 0.12704174f, 0.22637519f, 0.39733270f, 0.19509543f, 0.02995123f, 0.20444900f, 0.23525536f, 
    0.22586368f, 0.01640692f, 0.10652392f, 0.19959193f, 0.13139348f, 0.21912019f, 0.00609701f, 0.50075817f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.14381389f, 0.08220294f, -0.14449459f, 0.14559190f, -0.04098501f, -0.03449764f, 0.00519534f, 0.03743856f, 
    0.06498824f, -0.07490974f, -0.08661652f, 0.06615110f, -0.22883663f, -0.49806613f, -0.25538194f, 0.10026740f, 
    -0.04691978f, 0.03658406f, 0.07376873f, 0.06339312f, 0.01244719f, -0.05862780f, 0.09472732f, -0.21390390f, 
    -0.07098334f, 0.35238427f, 0.07707648f, -0.43946135f, 0.00274937f, 0.16512851f, 0.06416569f, 0.10675751f, 
    0.05357315f, -0.04160371f, 0.01758490f, 0.06621198f, 0.19982919f, 0.23986360f, -0.05340280f, -0.31559363f, 
    0.06165378f, 0.04227340f, 0.08364072f, -0.02786397f, -0.08683009f, -0.00553094f, 0.01627586f, 0.02747713f, 
    0.30953088f, -0.23685677f, -0.12493423f, -0.19077945f, -0.02497255f, -0.20967464f, 0.02728871f, -0.05983853f, 
    0.03128990f, -0.02681276f, -0.05611297f, 0.00137848f, -0.43596679f, -0.41345081f, -0.05932511f, 0.13658594f, 
    0.04787757f, -0.03451568f, 0.01478064f, 0.11692337f, 0.01838662f, 0.04337697f, -0.19444627f, -0.09994958f, 
    0.24186131f, 0.12454237f, -0.04774720f, -0.37374365f, 0.09896784f, -0.02343080f, 0.11127814f, 0.02983700f, 
    0.00916199f, 0.00421826f, 0.01730120f, 0.16728392f, -0.01528204f, -0.19867747f, 0.23629777f, -0.29983133f, 
    -0.13146260f, 0.02888889f, 0.08192580f, -0.14266752f, 0.08176909f, 0.01774329f, 0.06345943f, 0.08568192f, 
    -0.63457978f, -0.10100274f, 0.15819561f, -0.05002321f, 0.18854055f, 0.18204041f, -0.07507426f, -0.05695890f, 
    0.14493166f, -0.14363837f, 0.05600252f, -0.16680977f, -0.27740476f, -0.35371527f, 0.04118783f, 0.09106315f, 
    -0.04545942f, -0.03874370f, 0.10186820f, -0.05456366f, 0.00999755f, -0.00891576f, 0.06390043f, 0.09825264f, 
    0.04028622f, -0.11582769f, 0.16194937f, -0.27875480f, 0.02298419f, -0.05672262f, 0.17723012f, -0.08652247f, 
    -0.02200188f, 0.06536360f, -0.11957630f, 0.15038100f, 0.54548717f, 0.20832556f, 0.25886494f, -0.17285566f, 
    0.00076040f, -0.02973907f, 0.02948600f, 0.08113363f, 0.11322184f, -0.01994166f, -0.11285242f, 0.09812220f, 
    -0.18476932f, -0.05555624f, 0.04378362f, 0.14244971f, 0.15435132f, -0.00828864f, -0.09015193f, 0.01980864f, 
    0.13535154f, 0.08677069f, -0.17480920f, -0.08216238f, 0.49150947f, -0.30968794f, -0.18006857f, 0.42767355f, 
    0.00472113f, -0.01409128f, -0.08939450f, 0.07540906f, -0.05101763f, -0.07798924f, 0.06579203f, 0.14811833f, 
    -0.45013541f, 0.10012820f, 0.07721476f, 0.08425876f, -0.07818109f, -0.19327998f, -0.04992562f, 0.00173179f, 
    0.06654606f, -0.01381841f, 0.07332543f, -0.07507053f, -0.15673934f, -0.05480354f, 0.32244548f, -0.29795980f, 
    0.07487739f, 0.16731137f, 0.11490725f, 0.03595762f, 0.02381306f, -0.03678135f, -0.04180156f, 0.00137057f, 
    0.31232333f, -0.01186125f, -0.19186696f, 0.25829312f, -0.09376084f, -0.21137525f, -0.04277597f, 0.22561012f, 
    -0.09455585f, -0.00820780f, 0.00270989f, -0.08639096f, -0.06171019f, -0.17754793f, 0.17009716f, -0.51878965f, 
    -0.03456865f, -0.00395442f, 0.01780119f, 0.06441072f, -0.18602461f, -0.16109553f, -0.01669912f, 0.15826367f, 
    0.54782683f, -0.11223899f, -0.04249890f, -0.23827945f, -0.09669531f, -0.05705804f, 0.04752196f, 0.02908797f, 
    0.02482315f, -0.08976436f, -0.00795919f, -0.07064886f, 0.16367108f, -0.08541941f, -0.03739055f, 0.20355737f, 
    -0.35992253f, -0.06832796f, 0.06734738f, 0.09479584f, -0.04304286f, 0.13723369f, -0.03015494f, -0.23956421f, 
    -0.06955225f, 0.09621191f, 0.11759227f, 0.25334668f, -0.21765850f, -0.01703493f, 0.01939003f, -0.03220426f, 
    -0.09009378f, 0.12101954f, -0.13760895f, -0.04758538f, -0.23740141f, -0.02714160f, 0.01055987f, 0.26475483f, 
    0.03076371f, -0.04980872f, -0.04160928f, -0.12270976f, 0.01394902f, 0.05638924f, -0.13587444f, 0.05272008f, 
    -0.27675915f, -0.16016112f, 0.31630239f, -0.05244323f, -0.11880886f, -0.01648371f, -0.00489262f, -0.13958173f, 
    -0.11071769f, -0.17952479f, 0.03084237f, -0.07466354f, 0.19384253f, 0.03990633f, -0.00346020f, -0.27860168f, 
    0.01379633f, -0.09493739f, -0.13499536f, -0.15456043f, -0.05370750f, 0.16695161f, -0.30580986f, -0.07492003f, 
    0.32430664f, 0.09786743f, 0.18180360f, -0.19221286f, 0.02755933f, -0.03876054f, 0.04126994f, -0.24268442f, 
    -0.00877218f, 0.12174337f, -0.06177805f, 0.03027422f, -0.04306658f, 0.30892381f, -0.26452765f, -0.02643416f, 
    -0.00984333f, -0.01393418f, 0.18387319f, 0.00995780f, 0.09663207f, -0.16909213f, 0.21062022f, 0.16522950f, 
    -0.12617581f, -0.25174487f, -0.24942675f, -0.11421487f, -0.10076436f, 0.02761613f, 0.06162391f, 0.00392150f, 
    0.02927970f, -0.06686138f, -0.10263252f, 0.22046760f, 0.35600999f, -0.15018518f, -0.23392297f, 0.28285167f, 
    -0.23382466f, -0.00654601f, -0.09069765f, -0.11252815f, -0.11727921f, -0.01246853f, 0.01483064f, -0.05085212f, 
    0.07748494f, 0.17851304f, -0.09418633f, 0.23986100f, -0.28811830f, 0.12269362f, 0.06463421f, 0.07546526f, 
    0.07125533f, -0.04566668f, 0.04843244f, -0.00334173f, 0.08575840f, -0.07136181f, -0.28631312f, 0.14363903f, 
    -0.38478053f, 0.04707444f, 0.02837107f, 0.06378620f, -0.08588444f, 0.02112327f, -0.10000904f, -0.07938514f, 
    0.08360591f, -0.11298059f, -0.15180869f, 0.52202427f, -0.07533287f, 0.03358632f, 0.14322384f, -0.21900922f, 
    0.18591087f, 0.02949370f, -0.00989143f, -0.06885422f, 0.04592754f, 0.08689385f, -0.10941253f, 0.02034619f, 
    0.02253184f, -0.07016251f, -0.04035050f, -0.11833515f, -0.00415881f, -0.16303279f, -0.07327960f, -0.13122909f, 
    0.46210331f, 0.01286017f, -0.02043891f, 0.13248184f, -0.11233339f, -0.12560318f, 0.00968642f, 0.08780306f, 
    0.07395051f, -0.00759217f, -0.04138098f, -0.06784727f, -0.09179088f, 0.08619093f, 0.01189720f, 0.03000285f, 
    -0.02245893f, -0.13708907f, -0.07785829f, 0.13570243f, 0.01341271f, -0.04338766f, -0.08721670f, -0.01698536f, 
    0.17465636f, -0.15741055f, -0.06208342f, -0.06609106f, -0.05593782f, -0.13245818f, 0.06697283f, -0.06989750f, 
    0.11533735f, -0.07069149f, -0.29963970f, -0.22016819f, 0.19937721f, -0.18858992f, 0.15846074f, -0.14104186f, 
    0.20821494f, -0.10387503f, -0.04038624f, 0.03373641f, -0.07046913f, 0.09844255f, -0.06362029f, -0.01947822f, 
    -0.17389281f, -0.04587930f, 0.12835881f, -0.34491885f, -0.08941811f, -0.03404652f, 0.07244210f, -0.04499194f, 
    -0.00870432f, 0.08550001f, 0.00138526f, -0.05430610f, 0.18974011f, 0.08258490f, 0.16193715f, -0.09064632f, 
    -0.06161223f, -0.00271327f, 0.05366881f, 0.11817209f, -0.04645298f, -0.08257326f, 0.13161264f, 0.14051984f, 
    -0.08634770f, -0.33495513f, 0.06895200f, -0.36837330f, -0.00266613f, -0.04114123f, -0.08689547f, 0.03966761f, 
    0.14075139f, -0.04374898f, -0.02204538f, -0.00944113f, 0.02501684f, -0.18454021f, 0.09705205f, -0.11961438f, 
    -0.02816940f, 0.05030347f, -0.03363087f, -0.01456027f, -0.09067889f, -0.00660315f, 0.03159354f, -0.03522241f, 
    0.13781451f, 0.12985879f, -0.07633866f, -0.05547805f, -0.11560044f, -0.14030513f, 0.14220971f, -0.05812446f, 
    -0.17657782f, 0.17235284f, -0.05998847f, -0.02202329f, 0.26005498f, -0.14431904f, -0.24055448f, -0.03384094f, 
    -0.05468461f, 0.20864832f, -0.05977152f, 0.21592864f, -0.14192840f, -0.05381860f, -0.01882864f, 0.16172031f, 
    0.28465426f, -0.01535519f, 0.10211049f, -0.10513914f, -0.14536376f, -0.06637095f, -0.11338000f, -0.02728547f, 
    -0.00575800f, -0.08719948f, 0.15729192f, -0.25896442f, -0.11816850f, 0.03350737f, -0.23847151f, -0.28365663f, 
    -0.02903391f, 0.11006757f, -0.10330255f, -0.00075083f, 0.16883047f, 0.05726990f, 0.01678214f, -0.04710921f, 
    -0.08654313f, 0.14353405f, -0.06886211f, 0.19698447f, -0.12386265f, 0.23156179f, 0.21594872f, -0.11175175f, 
    -0.06399135f, -0.07856268f, 0.09190165f, 0.08679768f, 0.40286028f, 0.12334098f, -0.03806984f, 0.01715428f, 
    -0.07495876f, 0.00667253f, -0.16706850f, -0.07622550f, 0.07762992f, 0.01076728f, 0.20672010f, -0.02332390f, 
    0.01857209f, 0.17819005f, -0.20654222f, 0.14839828f, 0.00869937f, 0.01805148f, -0.11795653f, 0.08366685f, 
    0.02589478f, -0.16754054f, 0.04849929f, -0.08101021f, -0.21547340f, 0.06324586f, -0.21801020f, -0.13767549f, 
    -0.08607386f, -0.01817192f, -0.04375876f, -0.11184680f, -0.03699667f, -0.00090702f, 0.01131261f, -0.00903762f, 
    0.51386976f, -0.06468717f, 0.19493277f, 0.21618541f, -0.06149293f, 0.08526788f, 0.00235794f, -0.04523604f, 
    -0.02302455f, -0.07533352f, 0.05943507f, -0.05033285f, 0.34694761f, -0.33210456f, 0.12771702f, -0.35955763f, 
    0.10505379f, -0.23532847f, 0.15956141f, -0.02859347f, -0.11373482f, -0.04746852f, 0.09036542f, 0.00505788f, 
    -0.85896975f, -0.37820226f, 0.06006988f, -0.25097600f, 0.17150103f, 0.02545977f, 0.13202204f, 0.02521963f, 
    0.14974914f, 0.05491860f, -0.09187470f, -0.08865999f, 0.15776238f, 0.22185051f, 0.17060968f, 0.20263049f, 
    -0.08327929f, -0.13478491f, 0.06832664f, 0.07011324f, -0.07408163f, -0.12394120f, 0.13005187f, 0.02125386f, 
    -0.24520428f, -0.30770412f, -0.46033120f, -0.03435752f, -0.00865157f, 0.06158245f, -0.07918378f, 0.07893047f, 
    0.23459987f, -0.07293338f, -0.03048111f, -0.09445924f, 0.35207078f, -0.34016207f, -0.04612311f, 0.14544207f, 
    -0.06304107f, 0.03372462f, -0.08099539f, -0.01867102f, -0.01680044f, -0.11452809f, 0.01354790f, 0.06543911f, 
    0.15172938f, 0.16462666f, -0.14649753f, 0.18201032f, -0.09104709f, 0.11629611f, 0.01941461f, 0.01212592f, 
    -0.04625987f, 0.01985115f, -0.02197953f, -0.03510062f, 0.15056255f, -0.37342247f, -0.01767514f, -0.14887372f, 
    0.06459815f, -0.03360266f, 0.00966957f, -0.13287210f, 0.00790238f, -0.13101839f, 0.01619089f, 0.08604515f, 
    -0.10890724f, 0.04071021f, 0.02121893f, -0.07227708f, -0.02430396f, 0.08751696f, -0.15978856f, 0.17323817f, 
    0.09801381f, 0.06505030f, 0.05895326f, 0.27504450f, 0.08078696f, -0.25412747f, 0.02018045f, -0.12947407f, 
    0.18481076f, -0.11926325f, -0.11076252f, -0.08909224f, -0.12700763f, -0.08003599f, -0.21215723f, -0.28881955f, 
    0.04967814f, -0.14067675f, 0.27475590f, 0.00273202f, -0.03494408f, -0.03292384f, 0.04807313f, -0.03673725f, 
    0.00796182f, 0.00535204f, -0.08020871f, 0.02502599f, -0.20697865f, -0.25200164f, 0.16901161f, 0.18192995f, 
    -0.07933258f, -0.01687900f, -0.01410838f, 0.12980828f, 0.00484097f, 0.12202329f, 0.04042698f, -0.02831165f, 
    0.11604618f, -0.08177266f, 0.06806727f, 0.30500570f, 0.13347381f, 0.04601221f, -0.19407055f, 0.09959594f, 
    -0.05946557f, -0.01019679f, -0.15565813f, 0.06628933f, 0.19904724f, 0.07174968f, 0.28720745f, 0.18241426f, 
    -0.11351478f, -0.01630789f, -0.01616688f, 0.03598371f, 0.12520622f, 0.02331735f, 0.06749529f, 0.02269295f, 
    -0.40715340f, -0.05657600f, -0.16900422f, 0.04787810f, -0.22545867f, -0.02150165f, -0.00276150f, -0.07472570f, 
    0.02585079f, -0.02139772f, -0.00252929f, 0.06167036f, -0.54245216f, -0.02150470f, -0.08246898f, -0.10534862f, 
    0.11196122f, 0.00587788f, -0.13318247f, 0.04171523f, 0.07285498f, 0.14258561f, 0.11622316f, 0.13656619f, 
    -0.05000308f, 0.03892523f, -0.02603541f, -0.06902009f, -0.00305613f, 0.04864691f, -0.01614869f, 0.09535308f, 
    -0.07738835f, -0.06935542f, 0.00765059f, -0.15507181f, -0.24633597f, -0.27393204f, 0.04747659f, -0.08440214f, 
    -0.11042318f, 0.09608340f, -0.12303016f, -0.13182122f, -0.01505303f, -0.10555133f, -0.03467342f, -0.06571811f, 
    0.25379726f, 0.07256906f, -0.02835370f, 0.34205619f, -0.20082541f, -0.05418561f, 0.14911073f, 0.10823958f, 
    0.00394001f, 0.17040890f, 0.03553663f, 0.09668235f, 0.25445455f, 0.17786491f, 0.11151176f, 0.13768768f, 
    -0.10832593f, -0.02464877f, 0.06364672f, 0.19358411f, -0.11174091f, 0.03629802f, 0.05535627f, -0.18390022f, 
    -0.35377982f, 0.06846441f, 0.05931073f, 0.00359233f, 0.00647216f, -0.16323802f, -0.14056018f, -0.15990067f, 
    -0.06395331f, -0.04020178f, -0.20494901f, 0.07041880f, 0.44303292f, -0.47022447f, -0.05958547f, -0.29752505f, 
    -0.20066604f, 0.10329974f, -0.19557138f, -0.01280803f, 0.01291898f, 0.07322779f, -0.04283677f, -0.14917132f, 
    -0.11231983f, 0.15356991f, 0.07790402f, 0.23790284f, -0.17429970f, -0.18379545f, 0.01408712f, 0.01192490f, 
    0.00758959f, 0.05069092f, -0.11244823f, 0.03781449f, -0.04520717f, -0.37659878f, 0.12207568f, -0.12718353f, 
    0.02176126f, 0.01911435f, -0.09491841f, 0.01279395f, 0.11403198f, -0.07749176f, 0.06024455f, -0.11572976f, 
    0.27012971f, -0.05619330f, -0.05490860f, -0.25031537f, -0.08486829f, -0.08306277f, 0.07451047f, 0.02317313f, 
    0.02633039f, -0.07206715f, -0.14391126f, -0.05776194f, 0.22574709f, -0.23269682f, 0.31530514f, -0.05493509f, 
    -0.08088542f, -0.09621995f, 0.08889164f, -0.14643036f, 0.05710498f, -0.12703951f, 0.05447347f, -0.09680115f, 
    -0.06097628f, 0.11439416f, 0.07149827f, -0.23062654f, -0.16494584f, 0.00644245f, 0.06031216f, -0.05290538f, 
    0.00729409f, 0.15265943f, -0.19057466f, 0.01167021f, 0.28423050f, 0.08236907f, -0.14387386f, 0.01613904f, 
    0.11151152f, -0.04431695f, 0.02029134f, -0.01808731f, 0.05494961f, -0.02369449f, -0.04161308f, -0.00405432f, 
    0.02783628f, -0.13202399f, 0.07648787f, -0.26082987f, -0.23852882f, -0.15774308f, -0.30917430f, 0.12303086f, 
    -0.00377868f, -0.07348745f, -0.08616963f, -0.08451071f, -0.89644104f, 0.15194443f, -0.12334519f, -0.05745510f, 
    0.32747585f, 0.01111904f, -0.16767381f, 0.14623398f, 0.04107171f, -0.20869659f, 0.00280049f, -0.16147988f, 
    0.41440025f, -0.13639118f, -0.24631988f, 0.02128378f, -0.13010694f, 0.01323109f, 0.16084507f, 0.03277342f, 
    0.10078582f, -0.00640020f, 0.02605789f, -0.10573423f, 0.05101174f, -0.04073797f, -0.08553119f, -0.48048514f, 
    0.00350502f, -0.03131251f, -0.03054565f, -0.03976117f, 0.10900370f, -0.04980329f, 0.06936824f, -0.03132831f, 
    0.15141182f, 0.12236100f, -0.09556313f, -0.11784203f, 0.11938216f, 0.00321043f, -0.01082001f, 0.06661533f, 
    -0.13657549f, 0.08326674f, -0.02251111f, -0.08468741f, -0.24071124f, -0.28499916f, 0.11326262f, -0.16980599f, 
    -0.00370706f, -0.06947397f, 0.09856502f, 0.00475577f, -0.12267117f, -0.00764305f, -0.00997867f, -0.02453652f, 
    0.05660874f, 0.24542636f, -0.06179565f, -0.16437979f, -0.01901219f, -0.05651672f, -0.20996121f, -0.10251417f, 
    -0.25253588f, 0.04983077f, 0.01554962f, -0.02114801f, 0.01019022f, 0.08817937f, -0.15235820f, -0.08191089f, 
    0.02229959f, 0.03963639f, 0.00113656f, 0.08917432f, -0.09649462f, 0.11290567f, 0.01142042f, -0.01331988f, 
    0.05890237f, 0.12582150f, -0.46285132f, -0.45841745f, 0.01567274f, 0.14529096f, 0.05602130f, 0.00788651f, 
    -0.11138336f, 0.06500527f, -0.09699947f, -0.24084634f, 0.65456712f, -0.32339445f, 0.08947098f, 0.04885797f, 
    0.07755367f, -0.01725497f, 0.02408011f, 0.02660955f, -0.05531257f, 0.07237465f, 0.07528778f, -0.01361822f, 
    0.24182385f, -0.14652660f, -0.14467452f, 0.20609595f, 0.00507575f, -0.03070793f, -0.00867958f, -0.13774893f, 
    0.04447608f, 0.14845183f, -0.05534459f, 0.05572705f, -0.30224019f, 0.16391489f, -0.01379516f, 0.03452493f, 
    -0.00199455f, -0.05925183f, 0.10316729f, 0.07284494f, -0.21972294f, 0.07699117f, 0.00406835f, 0.07981695f, 
    -0.07457364f, 0.18084754f, 0.07666294f, 0.21583723f, -0.16514674f, -0.01730065f, -0.16407533f, -0.04475645f, 
    -0.06107709f, -0.07393108f, -0.03557936f, 0.08085018f, 0.32541808f, 0.20210287f, -0.23537445f, 0.34774697f, 
    -0.07494052f, -0.08631462f, 0.16474150f, 0.08349103f, 0.01985029f, 0.09724905f, -0.12800778f, 0.02781896f, 
    0.05470845f, 0.14490636f, 0.08911249f, -0.15031336f, -0.11461663f, -0.06658535f, 0.11788706f, 0.01894999f, 
    -0.16321959f, -0.14121924f, 0.03796323f, 0.00946971f, 0.57806575f, -0.14883544f, -0.02915463f, -0.02918954f, 
    0.04694689f, 0.16041292f, -0.06811669f, -0.09290673f, -0.07135110f, -0.02835908f, 0.03123628f, 0.02757063f, 
    -0.14435528f, -0.04582442f, -0.06415750f, -0.07440481f, 0.05332942f, 0.02441110f, 0.02638791f, 0.07290573f, 
    0.08815859f, -0.11161456f, -0.00202337f, -0.03337285f, 0.24152797f, -0.10788786f, -0.01184291f, 0.05664463f, 
    0.16762263f, 0.05307464f, -0.01503441f, -0.01593808f, 0.00632893f, -0.04067972f, -0.12844993f, 0.09750272f, 
    0.21120600f, 0.00832447f, -0.27685457f, -0.13609736f, -0.15484121f, 0.07547101f, -0.02532256f, 0.03439225f, 
    0.04694158f, 0.11197262f, 0.04327021f, -0.16763166f, 0.33841893f, -0.11529775f, -0.26337156f, 0.03830133f, 
    0.03538609f, 0.12210690f, 0.01646320f, -0.02617360f, -0.04224187f, -0.05820215f, 0.00796970f, -0.16781634f, 
    -0.49834117f, -0.29150182f, -0.50735939f, -0.06637390f, -0.06169794f, -0.14122583f, -0.04516509f, -0.09491733f, 
    -0.13339344f, -0.17297921f, 0.08686623f, 0.07351822f, 0.02348195f, 0.11324565f, -0.02604846f, -0.02326500f, 
    -0.29424509f, 0.07285690f, -0.01871935f, 0.10111196f, -0.05140101f, 0.17219065f, 0.04099492f, 0.03247200f, 
    -0.01925914f, -0.19325972f, 0.06026423f, -0.12102974f, -0.05776844f, -0.01244383f, 0.04784744f, 0.05270029f, 
    -0.06333950f, 0.13933268f, 0.01353625f, -0.03214255f, -0.38145697f, -0.24691592f, -0.15264101f, -0.14931904f, 
    -0.01316650f, -0.03541403f, -0.06733652f, 0.03180015f, -0.10480472f, -0.05596724f, 0.03919814f, 0.00899522f, 
    0.13274466f, 0.21198007f, -0.14390303f, 0.04536752f, -0.09448500f, 0.10409395f, 0.08043180f, -0.02444238f, 
    -0.07611476f, 0.02930456f, 0.09282167f, 0.05013179f, 0.06193691f, 0.12972084f, 0.11394121f, 0.20563586f, 
    0.09412099f, -0.26130581f, -0.06661072f, -0.09958632f, 0.18110746f, 0.10112474f, -0.13099800f, -0.04063220f, 
    -0.01252473f, -0.09412060f, -0.07257915f, -0.10921770f, -0.29237229f, -0.08340419f, 0.03269495f, -0.11918076f, 
    -0.15979795f, 0.09611257f, -0.06305733f, -0.08163206f, 0.25326395f, -0.09141137f, 0.08577121f, 0.40742749f, 
    0.13332710f, 0.06200028f, -0.06672132f, 0.03064780f, -0.00694540f, -0.14432447f, -0.01512299f, -0.08185055f, 
    0.12947913f, 0.03394264f, 0.02727997f, 0.17343880f, -0.00640749f, 0.02630388f, -0.03006717f, 0.11078466f, 
    0.00947506f, -0.03492900f, -0.02120540f, -0.02403568f, 0.12537830f, -0.17985553f, -0.27750018f, 0.01035041f, 
    -0.28007540f, -0.13093977f, -0.00923019f, 0.05005666f, 0.09122477f, -0.07383910f, 0.02452386f, 0.02923256f, 
    -0.19737533f, -0.14907035f, 0.01670740f, -0.06578624f, 0.02957855f, 0.02787291f, -0.02165711f, 0.13209501f, 
    0.08758443f, 0.03655419f, -0.21815230f, 0.22621040f, -0.57454610f, 0.52385223f, 0.10990998f, -0.15623406f, 
    0.06758535f, -0.07567640f, 0.00080597f, 0.09231173f, 0.03815578f, 0.02990928f, -0.18639977f, -0.02373199f, 
    0.15682030f, -0.22909747f, 0.00669446f, -0.17777717f, 0.02529707f, -0.03997336f, -0.06624620f, 0.05187587f, 
    -0.11757705f, 0.11410010f, -0.03978844f, 0.00021668f, -0.01459175f, -0.26532951f, 0.09826411f, 0.25799179f, 
    0.10008550f, 0.12896894f, 0.11956169f, 0.05022996f, 0.06969205f, -0.01935572f, 0.01149440f, 0.03691903f, 
    0.19583845f, 0.18892159f, 0.17576680f, -0.02588538f, 0.07002737f, 0.06750343f, -0.15838404f, 0.07507014f, 
    -0.01672281f, 0.04003626f, -0.22798483f, 0.18056400f, 0.12464824f, 0.37557286f, 0.32981098f, 0.03972963f, 
    -0.06494745f, -0.00219540f, -0.14564078f, 0.06799129f, -0.02509608f, -0.02837773f, 0.09999516f, 0.00513431f, 
    -0.30432492f, -0.58483332f, -0.39734811f, -0.09803795f, -0.12796226f, 0.04514128f, -0.06798344f, 0.03217752f, 
    -0.04751946f, -0.09399310f, 0.05980099f, 0.17589229f, 0.12303268f, -0.00194542f, 0.10624126f, 0.01053157f, 
    -0.16136855f, 0.12745900f, 0.02800567f, 0.11387753f, 0.19751123f, 0.12625156f, -0.06970730f, 0.13492805f, 
    0.53396618f, 0.25765640f, 0.00745152f, -0.08936208f, 0.06521080f, 0.01457774f, 0.06009937f, 0.13201298f, 
    -0.09289853f, -0.09655543f, -0.14915197f, -0.10184582f, -0.38546059f, -0.53073913f, -0.53907698f, 0.18047532f, 
    -0.15360320f, 0.05700820f, 0.04137037f, -0.06394286f, 0.07328150f, 0.10071449f, -0.01105925f, -0.01236000f, 
    -0.03267359f, 0.14840946f, 0.30030400f, 0.01566308f, 0.20758328f, 0.02864911f, -0.03820991f, -0.09686951f, 
    -0.03083457f, 0.15834425f, 0.04237098f, 0.03221497f, -0.04922745f, -0.06327450f, -0.14809617f, 0.03482258f, 
    -0.01949604f, -0.06636555f, 0.14302285f, -0.10749055f, -0.00538619f, 0.07410096f, -0.01177889f, -0.06614015f, 
    0.18953831f, -0.18179545f, -0.12327507f, 0.23227422f, 0.08923768f, -0.09371819f, 0.00829256f, -0.02929508f, 
    -0.09285889f, 0.00421958f, -0.06971414f, -0.18059713f, 0.03435946f, -0.33529714f, -0.20700711f, 0.05077260f, 
    0.07278803f, 0.09566176f, -0.02378666f, 0.22490919f, -0.12404770f, 0.10651622f, -0.11689788f, 0.00499556f, 
    0.08174004f, 0.20871486f, -0.08192972f, -0.23894380f, -0.20895927f, -0.08522376f, 0.05833209f, -0.32068682f, 
    -0.03369578f, 0.01853867f, 0.01027917f, 0.00576013f, 0.22240353f, -0.15693311f, 0.09823499f, 0.12451140f, 
    -0.09678916f, -0.01200667f, 0.13819531f, 0.00025667f, -0.08886959f, -0.08241522f, 0.06135804f, 0.07758618f, 
    -0.02723135f, -0.25149885f, -0.22063377f, -0.12487490f, -0.16032566f, -0.01481686f, -0.14927261f, 0.11744779f, 
    -0.01342010f, 0.06235706f, -0.02424414f, -0.11438832f, -0.48939204f, 0.36708066f, 0.25340533f, 0.22482868f, 
    0.01940967f, 0.22389232f, -0.02396458f, -0.09035598f, -0.07978161f, 0.18162781f, -0.05098066f, -0.01502066f, 
    -0.18523762f, -0.18021198f, 0.07894135f, -0.25125957f, 0.02738962f, -0.06756616f, 0.10846025f, -0.05500865f, 
    0.04766671f, 0.02074788f, 0.05462546f, -0.07410496f, -0.77707559f, -0.54666090f, 0.36730760f, 0.11011022f, 
    0.03008285f, 0.08738635f, -0.07490043f, -0.08241925f, 0.04566097f, -0.21438779f, -0.07857845f, -0.03333136f, 
    -0.08781070f, 0.03837933f, 0.15550043f, -0.08347090f, -0.00737435f, 0.09400370f, -0.09007603f, 0.07113295f, 
    -0.20297842f, -0.02559203f, -0.00926137f, -0.12577644f, -0.24270208f, 0.23340924f, 0.20326813f, 0.25481883f, 
    0.12275071f, 0.14474130f, 0.04230983f, -0.04945479f, -0.07285097f, -0.03068688f, -0.05027977f, -0.20356125f, 
    -0.24931936f, 0.18046123f, 0.10550450f, 0.02090549f, -0.15387543f, -0.03740799f, 0.00475642f, 0.02267823f, 
    0.06738642f, -0.03438494f, 0.11393856f, -0.04918808f, 0.34393778f, 0.08150847f, 0.03473844f, 0.04613594f, 
    0.08686838f, 0.03671476f, 0.09271047f, 0.06013991f, 0.06654458f, 0.04130903f, 0.11136674f, -0.01657556f, 
    -0.65871847f, -0.05383565f, 0.12101500f, 0.21882929f, -0.01411935f, -0.05308409f, -0.02252785f, 0.00515026f, 
    -0.17267536f, 0.04192335f, 0.21338253f, 0.10153194f, -0.44150433f, 0.02422084f, 0.18624662f, 0.27180558f, 
    0.02786584f, 0.18758760f, 0.05313782f, 0.02261755f, 0.11014170f, 0.12661420f, 0.14313498f, 0.01174182f, 
    0.15092117f, -0.29924315f, -0.05800274f, 0.40725046f, 0.09511515f, -0.11201864f, 0.06005183f, -0.06439772f, 
    -0.15750456f, -0.09204332f, 0.08757917f, -0.12631559f, -0.01885775f, -0.03440282f, 0.06158882f, 0.19506040f, 
    0.05570503f, -0.08756962f, 0.07183479f, 0.20135626f, -0.00185210f, 0.04992973f, -0.06954112f, -0.00231587f, 
    -0.25772965f, 0.01350245f, -0.11729213f, 0.35656387f, 0.14857620f, -0.06592966f, -0.08650576f, 0.07290854f, 
    -0.00270256f, 0.02037979f, 0.07495225f, 0.00359554f, -0.41563043f, -0.06047931f, 0.04239757f, -0.01102056f, 
    0.00662432f, -0.01284808f, -0.04856367f, 0.01911421f, 0.08993913f, -0.27601814f, -0.06976728f, 0.10845710f, 
    -0.18578897f, 0.15555565f, 0.02003856f, -0.14009817f, -0.00234999f, -0.16360834f, 0.00139824f, 0.05142048f, 
    0.04395248f, -0.13322239f, 0.00824545f, -0.00040327f, -0.14853361f, 0.19692777f, 0.30554709f, 0.00498156f, 
    -0.06885377f, 0.12413362f, 0.02542215f, 0.08216945f, -0.00643345f, 0.10259715f, 0.03747835f, -0.06653045f, 
    -0.30573449f, 0.04372929f, 0.16662334f, -0.01336252f, 0.01430544f, 0.07979850f, -0.21449323f, -0.11609746f, 
    0.08088759f, 0.01874862f, -0.15407906f, 0.11742343f, -0.10889804f, -0.10616332f, -0.03055119f, -0.00766369f, 
    -0.01877092f, -0.20659195f, 0.15422654f, -0.16233291f, -0.09175485f, -0.22720863f, -0.14415930f, -0.03970585f, 
    0.00992126f, -0.07539232f, 0.29621264f, 0.02788803f, 0.18894495f, 0.02433220f, -0.06961804f, 0.11864693f, 
    0.12392847f, 0.04043679f, -0.12877132f, 0.02236360f, -0.22962195f, 0.18767385f, -0.05993356f, -0.02018056f, 
    -0.04942293f, 0.10316358f, 0.14156124f, -0.14869308f, 0.08484513f, -0.08198040f, 0.04699558f, 0.05560499f, 
    -0.26372567f, 0.16364296f, -0.08386585f, -0.22868633f, -0.02969768f, 0.04044224f, 0.08064333f, 0.08036936f, 
    -0.07185084f, -0.04162870f, -0.05960983f, 0.04952355f, -0.40326548f, 0.01902520f, -0.00028610f, -0.20975965f, 
    0.14949384f, -0.17433164f, -0.10982180f, -0.01227657f, 0.02571359f, -0.04985179f, -0.10058483f, 0.04072149f, 
    0.18313156f, 0.12979878f, 0.07207390f, 0.16545627f, -0.15624979f, -0.01066595f, -0.02813861f, 0.04184021f, 
    0.10095965f, -0.02878983f, -0.09372304f, 0.03712386f, 0.00229908f, -0.13906471f, -0.19752088f, 0.18650910f, 
    -0.26038834f, 0.01443457f, 0.17144194f, -0.04042979f, 0.00087039f, 0.17910974f, 0.04878997f, 0.00187357f, 
    0.60848689f, 0.01157821f, -0.14716266f, -0.20637940f, 0.17711221f, 0.03426690f, 0.16583034f, 0.09016448f, 
    -0.03092919f, -0.02065128f, -0.01592994f, 0.08608229f, -0.34652409f, -0.05523069f, 0.04368408f, -0.03242966f, 
    -0.03320876f, 0.08067517f, -0.07703755f, 0.12044422f, 0.03000808f, 0.10283708f, -0.05998916f, 0.10621044f, 
    -0.28293276f, -0.10719322f, 0.34504017f, -0.07771974f, 0.13432199f, -0.05752659f, -0.05370009f, -0.15765975f, 
    0.01038744f, 0.02512124f, -0.06008216f, 0.10731345f, -0.58230972f, 0.39910042f, -0.21791133f, 0.01575645f, 
    0.08932752f, -0.04405269f, 0.08512615f, -0.03536765f, -0.02368469f, 0.06094545f, -0.03945929f, -0.00273878f, 
    0.34073091f, 0.39748001f, -0.15849678f, -0.06003677f, -0.05452681f, -0.03536203f, 0.00046962f, 0.05274448f, 
    -0.11205737f, -0.02154911f, 0.25296044f, -0.01686934f, -0.51924801f, -0.08278283f, 0.18071164f, -0.17743640f, 
    -0.10837274f, 0.07070109f, 0.00800641f, 0.04456692f, 0.17272337f, 0.03714123f, 0.01664018f, -0.02374384f, 
    0.02060624f, -0.23899932f, -0.30209047f, 0.17925699f, 0.12993555f, -0.06567750f, -0.10203265f, -0.04069414f, 
    -0.18138115f, -0.19521733f, -0.01018252f, -0.10402171f, -0.23249601f, 0.07879461f, -0.04878571f, 0.06074623f, 
    -0.07237364f, -0.03789200f, -0.01469757f, 0.04494273f, -0.05871098f, -0.06525781f, 0.08445483f, 0.02011941f, 
    -0.01507840f, -0.06128261f, -0.07509112f, -0.06780637f, 0.04158454f, 0.02747577f, -0.06735639f, -0.00439568f, 
    -0.11310416f, -0.02483643f, 0.08077337f, 0.00272927f, -0.71224922f, 0.01028095f, 0.01387490f, -0.07836117f, 
    0.12322053f, -0.11959586f, 0.00331638f, 0.00320722f, 0.15495768f, 0.00526475f, -0.06900562f, 0.09325462f, 
    0.38963357f, -0.06676631f, -0.19065911f, 0.01517086f, -0.10196423f, -0.15791902f, 0.21610965f, 0.03356598f, 
    -0.01703942f, 0.04563474f, 0.05597768f, 0.13575268f, -0.11329588f, 0.06713130f, -0.05357927f, -0.04008403f, 
    0.04200178f, -0.12472156f, 0.07370640f, 0.09562740f, -0.03465261f, -0.03047297f, -0.04068667f, -0.12135091f, 
    -0.46155769f, 0.20745236f, 0.01179917f, -0.22645488f, -0.07924066f, 0.03130010f, -0.06243548f, 0.17167076f, 
    -0.21354519f, -0.02300720f, 0.06786305f, -0.02080432f, -0.31759772f, -0.06464957f, 0.30808648f, 0.02536186f, 
    -0.05729639f, -0.06212391f, -0.04726935f, -0.13790554f, 0.14928843f, -0.08927339f, -0.10255919f, -0.03147024f, 
    0.05503164f, -0.02416819f, 0.10960723f, 0.01737911f, -0.08433583f, 0.08864319f, -0.04693790f, 0.04488458f, 
    -0.06890943f, 0.20821261f, 0.05771057f, 0.23011188f, -0.09414288f, -0.48152173f, -0.20330447f, 0.12681501f, 
    0.18094073f, -0.06757948f, 0.07582054f, -0.01733083f, 0.00769228f, 0.30354974f, -0.23306999f, 0.12097058f, 
    -0.17784855f, 0.12012874f, -0.57606095f, -0.12371577f, 0.12258989f, 0.16887066f, -0.11907510f, 0.13234404f, 
    -0.01024615f, -0.14848940f, -0.17930201f, -0.00101886f, 0.13623396f, -0.05802310f, -0.23813851f, -0.12614650f, 
    -0.05873379f, -0.12974535f, -0.29266930f, -0.24721029f, -0.05361030f, -0.04546920f, -0.00745608f, 0.02731762f, 
    -0.14974697f, 0.06000064f, -0.07357458f, 0.04839595f, 0.06171481f, 0.23769347f, -0.17254542f, 0.12719761f, 
    0.02931438f, 0.09264500f, 0.30143991f, -0.17902838f, -0.02218954f, -0.04911066f, 0.00261745f, 0.01737406f, 
    0.02863995f, 0.00887653f, -0.00670072f, -0.06523386f, 0.02507477f, -0.07937253f, 0.08866468f, 0.04266444f, 
    0.26359645f, 0.00777019f, -0.21995352f, -0.04800846f, 0.11959036f, 0.21579933f, -0.07967684f, -0.10669392f, 
    0.16880992f, 0.02938383f, -0.05926714f, -0.02733728f, -0.01320842f, 0.13552691f, 0.12558603f, 0.06344292f, 
    -0.07323458f, -0.04579587f, 0.00151789f, 0.02157327f, -0.07416617f, 0.20610477f, -0.01072441f, 0.11621930f, 
    -0.56982046f, -0.38603944f, -0.18461232f, 0.06636343f, 0.09623215f, 0.18787682f, -0.00397765f, -0.02450422f, 
    -0.05345300f, 0.18203688f, 0.28799567f, 0.09767877f, -0.37463760f, -0.27643734f, -0.11099939f, 0.27162138f, 
    0.09471135f, -0.18110447f, 0.03840483f, 0.04409958f, 0.06081210f, 0.07444569f, -0.07016606f, 0.15762658f, 
    -0.27645656f, 0.01704771f, 0.06199385f, 0.24648058f, 0.15950936f, 0.00966816f, -0.05091998f, 0.06530020f, 
    -0.09110355f, -0.14227153f, 0.13530509f, -0.02970668f, -0.71096420f, -0.02850694f, 0.03882981f, -0.03430467f, 
    0.05795596f, 0.10684396f, -0.02238743f, -0.13634175f, 0.14370024f, 0.11780540f, 0.13599223f, -0.04848103f, 
    -0.33907282f, 0.00014720f, -0.17889351f, -0.04302157f, 0.05640043f, -0.16700296f, -0.10890611f, 0.06345109f, 
    0.11799587f, 0.00373122f, 0.23517032f, 0.06246959f, -0.34371927f, 0.03069801f, 0.10812984f, 0.01129526f, 
    -0.04772364f, -0.21419126f, -0.07849065f, -0.09207513f, -0.13129553f, 0.12762074f, -0.03648382f, 0.00980932f, 
    -0.34881732f, -0.28838998f, -0.17655955f, -0.14584580f, 0.14217614f, -0.05278838f, 0.09101476f, 0.07030012f, 
    -0.03795184f, -0.03565648f, -0.08576436f, -0.09646972f, -0.22563300f, -0.27835175f, 0.04191980f, 0.35318464f, 
    -0.00317927f, -0.04845417f, 0.16752934f, 0.17776643f, -0.06074788f, 0.27255794f, 0.08223236f, -0.03125745f, 
    -0.11785294f, -0.08099612f, 0.08882564f, -0.21230693f, -0.10122240f, -0.03221812f, 0.22308987f, -0.15708011f, 
    0.04410128f, -0.03196756f, -0.07745405f, 0.04230644f, 0.11694758f, 0.16054758f, -0.02710855f, -0.09846666f, 
    0.05633308f, -0.11428773f, -0.08995774f, 0.03203611f, 0.10718714f, -0.03488988f, -0.00815658f, -0.11376631f, 
    -0.30019787f, -0.29370871f, 0.12253975f, 0.34523714f, -0.03812327f, 0.03522271f, -0.00704707f, -0.05015418f, 
    0.06605629f, -0.08641216f, 0.06465127f, 0.09673749f, 0.13867046f, 0.07822372f, 0.02652219f, 0.11181165f, 
    0.12177110f, 0.03664349f, -0.01427541f, -0.06268951f, 0.03492744f, -0.24121042f, 0.03433211f, -0.02862604f, 
    0.18322688f, 0.05544527f, 0.31411588f, 0.33954310f, -0.22014730f, -0.08458580f, -0.01570566f, 0.14010820f, 
    -0.15370816f, -0.36019939f, 0.17657614f, 0.07252391f, -0.86232603f, -0.00305833f, 0.05593935f, -0.27064207f, 
    0.04983360f, -0.08133495f, -0.02472138f, -0.04502371f, 0.01589081f, -0.08072268f, 0.10409141f, -0.16849220f, 
    -0.23123585f, -0.17050195f, 0.46911716f, 0.11492584f, -0.00155018f, -0.04022481f, 0.00642091f, 0.08661667f, 
    0.08023910f, 0.02305279f, -0.18139164f, 0.06532750f, -0.01941539f, 0.06465757f, 0.06224144f, 0.02131752f, 
    -0.10704547f, 0.12744351f, 0.06260662f, -0.01832674f, 0.03135047f, -0.14392161f, 0.08697384f, 0.07647041f, 
    -0.11621064f, 0.01219052f, -0.08867133f, -0.17195877f, 0.11595181f, 0.05036282f, 0.08709276f, -0.01810844f, 
    0.04225564f, -0.07537454f, -0.13585110f, 0.02002029f, 0.28988278f, 0.01398732f, -0.23865038f, -0.00417536f, 
    0.01072560f, 0.15658803f, -0.17278260f, 0.00723864f, -0.12742075f, 0.05459593f, -0.10275611f, -0.26506171f, 
    0.32728270f, 0.34060484f, -0.10038441f, 0.00275742f, 0.00059545f, -0.03912539f, 0.05138564f, -0.12345982f, 
    -0.05361754f, 0.06499367f, 0.06125078f, 0.04622728f, 0.01194496f, 0.09352236f, 0.10157486f, -0.54078472f, 
    0.05314230f, -0.03253825f, 0.10710201f, -0.11090200f, -0.03844213f, -0.22034520f, -0.04276169f, -0.09994210f, 
    0.02866076f, 0.13367981f, 0.21136320f, -0.34761289f, 0.06480365f, -0.09226696f, -0.05447950f, -0.26130682f, 
    0.09905940f, -0.04037252f, -0.01194749f, -0.00364800f, -0.08887443f, 0.00141749f, 0.24336453f, 0.05926038f, 
    0.08824790f, 0.12834781f, 0.04907957f, 0.04301459f, -0.00248783f, 0.05839923f, 0.09888416f, 0.14641818f, 
    -0.39659131f, 0.26924747f, -0.11612009f, 0.16527896f, 0.01843025f, 0.05724457f, -0.05456180f, 0.12049539f, 
    -0.03030766f, -0.09528463f, -0.17246494f, -0.03232996f, 0.19400302f, 0.00440555f, -0.00166785f, 0.02259933f, 
    -0.04835943f, -0.07831308f, 0.06190801f, 0.05244418f, -0.08881444f, -0.03608533f, 0.09002028f, 0.27497774f, 
    -0.17949332f, 0.27748439f, 0.28357375f, -0.06476031f, 0.05021396f, 0.12094081f, -0.03401342f, -0.01474066f, 
    0.08461235f, -0.11872583f, -0.06998533f, -0.28320262f, -0.26484028f, 0.17709558f, -0.25183451f, -0.19679917f, 
    -0.03332071f, 0.00103050f, -0.04822444f, -0.12350971f, -0.15184446f, -0.02375660f, 0.15772541f, 0.09210756f, 
    -0.11202510f, -0.54035056f, -0.07007845f, -0.25696051f, 0.06322093f, 0.02537532f, -0.03124016f, -0.06194246f, 
    -0.02598708f, -0.11299681f, 0.20934895f, 0.25575122f, -0.46574134f, -0.27868229f, -0.16980141f, 0.11985644f, 
    -0.04768195f, -0.12547466f, 0.01625523f, 0.00956768f, 0.10546936f, -0.06109838f, 0.12318797f, 0.01338931f, 
    0.16160855f, 0.09521236f, -0.02197337f, -0.08709393f, -0.02228262f, -0.00081372f, 0.03651241f, -0.06664611f, 
    -0.05776110f, -0.12027539f, 0.01180808f, 0.20577355f, -0.26445553f, 0.04010018f, -0.29620823f, -0.32958895f, 
    0.00516163f, -0.01589092f, -0.07151867f, -0.03890443f, -0.00197481f, -0.00729634f, -0.07887594f, 0.05669440f, 
    -0.30949226f, -0.03106395f, 0.01462868f, -0.10305189f, -0.11976758f, -0.05312495f, 0.09454836f, -0.12733559f, 
    0.00443354f, 0.03552156f, -0.01169365f, -0.06713806f, 0.11979176f, 0.08373383f, 0.01110009f, -0.13556807f, 
    -0.02697170f, 0.13334295f, 0.03310480f, 0.03592653f, -0.05317787f, -0.20485631f, 0.02354241f, -0.12329788f, 
    0.08631183f, -0.05715918f, -0.01061219f, -0.00787608f, -0.12644154f, 0.01703657f, -0.04444833f, 0.06434533f, 
    0.03738351f, -0.10724618f, -0.08758861f, 0.14287522f, -0.21936774f, 0.11029080f, -0.28814757f, -0.06007985f, 
    0.08059718f, -0.15784308f, -0.02873377f, -0.10646919f, -0.06254259f, -0.04021386f, 0.07347963f, -0.39625916f, 
    -0.04829122f, -0.22106314f, -0.08395090f, 0.15220264f, -0.06529323f, -0.18860286f, 0.06441602f, -0.19906211f, 
    -0.00727293f, 0.07426029f, 0.04475502f, -0.16874726f, -0.15516290f, -0.21759312f, 0.02168095f, 0.30209929f, 
    -0.06261458f, 0.05260924f, 0.07684116f, 0.08615057f, -0.24750042f, -0.07145949f, -0.10578842f, -0.11290415f, 
    -0.23741327f, 0.05313845f, -0.22459136f, -0.32188100f, -0.08550271f, 0.07170609f, -0.07305408f, 0.06395968f, 
    -0.07486764f, 0.17459492f, -0.09228108f, -0.04320925f, -0.30087727f, 0.00011086f, 0.05274669f, -0.27562520f, 
    0.02818850f, 0.01344807f, 0.23292586f, 0.11873169f, -0.09539717f, -0.20588945f, -0.24872740f, -0.07541467f, 
    0.00624913f, -0.53978765f, -0.00824936f, 0.08452164f, -0.04710663f, 0.06130581f, -0.00432429f, -0.08021654f, 
    0.02325090f, 0.14529152f, 0.03457367f, 0.13332835f, 0.11165468f, -0.16643283f, -0.10265295f, 0.11203279f, 
    0.13008890f, 0.20566800f, -0.08023962f, 0.01772332f, -0.03589502f, -0.11345708f, -0.04665318f, 0.00684023f, 
    -0.21049750f, 0.37045279f, 0.17004123f, -0.26584312f, 0.02983338f, 0.08448403f, -0.02018091f, -0.00721954f, 
    -0.05815661f, 0.04632667f, 0.21313491f, 0.03337402f, -0.22638191f, -0.14332756f, -0.19967031f, 0.32216257f, 
    -0.04169187f, 0.22526272f, -0.04505090f, 0.15129752f, 0.10666078f, -0.03383090f, -0.01172728f, 0.06209174f, 
    0.20561998f, 0.01623693f, -0.03115513f, 0.34907261f, -0.22079678f, -0.06668253f, -0.11131127f, -0.03093874f, 
    -0.14397101f, 0.08400212f, -0.12737742f, -0.05424490f, -0.05397079f, 0.26094419f, 0.05025309f, -0.08216946f, 
    -0.04470425f, -0.03048083f, 0.10636298f, 0.13066034f, 0.05280542f, 0.13879173f, 0.01796779f, 0.12387228f, 
    -0.05935047f, -0.02253355f, -0.12747747f, -0.00296553f, 0.17648400f, 0.00517122f, 0.03226442f, -0.05863811f, 
    0.10487647f, 0.07029826f, -0.04050734f, -0.12786980f, 0.42357355f, -0.15119205f, 0.05813174f, -0.13509533f, 
    -0.12685271f, 0.01266203f, 0.18532091f, 0.08184247f, 0.09544754f, -0.02332359f, 0.00427161f, 0.04888976f, 
    0.22407858f, -0.13264516f, -0.14617509f, -0.07365389f, -0.07420970f, -0.07920330f, 0.03876418f, 0.15903381f, 
    0.16205974f, 0.04543826f, -0.00921107f, 0.14867561f, 0.17565373f, 0.13290937f, -0.11632021f, 0.26463866f, 
    0.07817630f, -0.15573131f, -0.01474932f, -0.06743960f, -0.07625185f, -0.06782328f, 0.18153335f, 0.09808251f, 
    -0.14248583f, -0.33123097f, 0.09343430f, -0.16231002f, 0.06325603f, -0.08877541f, -0.02098379f, 0.01394546f, 
    0.00755721f, 0.04808612f, 0.07370380f, -0.06440527f, -0.21812369f, -0.06853998f, 0.13483238f, -0.27780545f, 
    0.06386215f, -0.00940023f, 0.19301251f, -0.26388684f, 0.05401541f, -0.03759924f, 0.20186830f, 0.32962573f, 
    -0.45480102f, -0.05426094f, -0.19299656f, 0.41785535f, -0.06747668f, 0.14357425f, -0.00673489f, 0.11651080f, 
    0.07151259f, -0.06866050f, 0.03689405f, -0.14946420f, 0.47860330f, 0.08660802f, 0.07893453f, 0.12966646f, 
    -0.09822971f, 0.13757159f, 0.01173357f, 0.04533511f, 0.11169308f, -0.01868681f, -0.02169349f, 0.12331277f, 
    0.07570454f, 0.06806342f, 0.15608646f, -0.27181748f, 0.00189530f, 0.10662441f, 0.20578849f, 0.18861869f, 
    -0.08641406f, -0.05405475f, -0.00040413f, -0.05761645f, 0.23551232f, 0.04514667f, 0.12295290f, -0.42367262f, 
    -0.07138557f, 0.00258237f, -0.02640361f, 0.03702039f, -0.02347662f, 0.01245904f, -0.03500578f, -0.16214910f, 
    0.60678971f, -0.43685439f, 0.37564951f, -0.22251526f, 0.19783226f, -0.09170599f, 0.11105483f, -0.13150036f, 
    0.04551879f, 0.06446637f, 0.14210179f, -0.13220122f, 0.27237418f, 0.17499463f, -0.02538187f, -0.14933388f, 
    0.00378190f, 0.15501437f, -0.01034642f, 0.00000082f, -0.07124358f, -0.00772118f, -0.12915538f, -0.15272151f, 
    -0.09342808f, -0.02972478f, -0.26418230f, -0.13202207f, -0.01002055f, -0.17685764f, 0.00853282f, -0.01673931f, 
    0.05520446f, -0.00834405f, 0.05092633f, 0.14046496f, 0.04128546f, 0.08251787f, 0.09231914f, 0.14352340f, 
    0.12705429f, 0.00647388f, -0.07291874f, -0.12575735f, 0.03129276f, -0.03383467f, -0.02278275f, -0.13855866f, 
    0.18761717f, 0.16531523f, 0.31331557f, 0.09666201f, 0.11440025f, 0.11781951f, 0.06407930f, 0.05380378f, 
    -0.09423319f, 0.15572862f, -0.03392445f, 0.01735450f, -0.06682887f, 0.21602209f, -0.06436996f, 0.01923107f, 
    -0.05613619f, -0.00677862f, 0.04578546f, -0.06279752f, 0.11727158f, 0.10986370f, -0.02959815f, -0.03185542f, 
    0.00073010f, 0.10498629f, 0.02752220f, 0.02358038f, 0.00061393f, -0.09197251f, -0.05864365f, -0.02349781f, 
    0.03271128f, -0.11460727f, -0.03958578f, -0.11467505f, 0.08349727f, 0.06305374f, 0.15498047f, -0.04037970f, 
    0.00713494f, -0.12378378f, -0.11370736f, -0.10363264f, 0.10400254f, -0.07582103f, -0.02626876f, -0.13247924f, 
    0.17753601f, 0.31519660f, 0.07306921f, 0.19521165f, 0.21912262f, 0.09301477f, 0.01558283f, 0.07251439f, 
    -0.07286109f, 0.06760776f, -0.04330187f, -0.00535738f, -0.23932949f, 0.03950160f, -0.32499886f, 0.13697849f, 
    -0.15264125f, -0.06897261f, -0.06951638f, -0.14488733f, 0.03198488f, -0.01565184f, 0.01457018f, -0.09694234f, 
    0.12788555f, -0.04002124f, 0.04682477f, 0.10328249f, 0.04297636f, -0.00574701f, 0.05942630f, -0.05598379f, 
    -0.01508720f, -0.08098669f, -0.15964770f, -0.03197086f, 0.11131476f, 0.34631562f, 0.18730001f, 0.08806080f, 
    -0.10008215f, 0.04155633f, -0.02199802f, -0.05005779f, 0.01590296f, 0.02164411f, -0.02804388f, -0.00014090f, 
    -0.02735429f, -0.08405048f, -0.22357866f, -0.04898335f, 0.05855352f, -0.06994369f, -0.03705130f, -0.17383200f, 
    -0.03398490f, 0.07520472f, -0.02127378f, -0.04999200f, -0.04054283f, -0.24332316f, 0.07925677f, 0.14621562f, 
    0.03818827f, 0.04497701f, -0.06899022f, 0.01630585f, -0.17310935f, -0.10493180f, 0.05903161f, 0.08720051f, 
    0.08750695f, 0.12507799f, 0.02291943f, 0.12502380f, 0.04300037f, 0.07729225f, 0.04919910f, -0.05552651f, 
    -0.06585110f, 0.03404636f, -0.04005582f, -0.07775679f, 0.11729869f, 0.28367436f, -0.12159839f, 0.15995222f, 
    -0.12792419f, -0.03559167f, 0.01970967f, -0.01454857f, -0.07576295f, 0.02464366f, -0.17473872f, -0.13846268f, 
    0.10505623f, -0.19070083f, 0.17964964f, 0.06068853f, 0.16599184f, 0.06791635f, -0.07993180f, -0.06133446f, 
    0.03811842f, 0.08692177f, -0.07675143f, -0.05050001f, 0.23399968f, 0.02056115f, 0.04390722f, 0.22445838f, 
    -0.10517231f, 0.01236616f, 0.01163500f, -0.05382965f, -0.05731599f, -0.01934092f, -0.03981847f, -0.01977106f, 
    -0.39991966f, 0.06043867f, -0.27348197f, -0.09282075f, 0.03846103f, -0.00301450f, -0.06885945f, -0.00713524f, 
    -0.11097022f, -0.00874298f, -0.11016351f, -0.14590026f, 0.06609426f, 0.14688931f, -0.20308936f, 0.18477990f, 
    -0.05332642f, 0.00482596f, -0.14779530f, 0.02687192f, -0.03496998f, -0.01062214f, 0.04942199f, -0.11919007f, 
    -0.11347699f, 0.26890200f, -0.01067766f, 0.37130710f, 0.15574402f, -0.21377309f, 0.09994324f, 0.05629479f, 
    -0.03423018f, 0.06513073f, 0.05114785f, -0.06629197f, -0.16367131f, 0.00540580f, -0.12569797f, -0.38029006f, 
    -0.02537988f, 0.03887003f, -0.10545162f, -0.14378488f, -0.08298274f, 0.07004739f, -0.02551183f, -0.10324186f, 
    0.16305380f, -0.10233404f, -0.02041917f, 0.08277405f, -0.18497308f, -0.09187047f, -0.01853943f, -0.07546145f, 
    -0.01925953f, 0.00916620f, -0.08163489f, -0.09990332f, 0.20301306f, 0.04608355f, 0.15784588f, -0.20977385f, 
    -0.13390823f, 0.01775881f, -0.11284892f, -0.04405165f, -0.04891929f, 0.07823671f, -0.17155787f, -0.00992617f, 
    -0.49375546f, 0.09369857f, -0.05427102f, -0.15229355f, -0.03263110f, 0.01769606f, -0.04992398f, -0.22093554f, 
    -0.05877481f, -0.04565800f, -0.00490252f, -0.15809599f, -0.21486039f, 0.21498030f, -0.06459682f, 0.03776092f, 
    -0.11514103f, -0.04160281f, 0.00712750f, 0.02939880f, -0.04735103f, 0.14541899f, -0.03308605f, -0.02605799f, 
    -0.25721726f, 0.05239290f, -0.12816559f, -0.05256562f, 0.03517763f, -0.12067489f, 0.03950133f, -0.05665866f, 
    0.00972120f, 0.01202969f, 0.12538932f, -0.15029834f, 0.07899071f, 0.11630254f, 0.07339855f, -0.02153659f, 
    -0.11224934f, 0.14180486f, 0.10607467f, -0.09129883f, 0.01884173f, 0.07709186f, -0.04124045f, -0.11046039f, 
    -0.44538063f, 0.02509826f, -0.11470101f, -0.18002883f, -0.17996448f, 0.07375527f, 0.02945446f, 0.00572843f, 
    0.05801269f, 0.02405502f, 0.04782210f, -0.07012360f, 0.16404830f, -0.17040482f, -0.09100806f, -0.12696433f, 
    -0.08750062f, -0.00261353f, -0.06095278f, -0.10625814f, -0.08957122f, -0.02894952f, -0.07347504f, 0.00171881f, 
    0.06642970f, 0.03818721f, -0.00106336f, -0.01235783f, -0.11239944f, -0.00040770f, 0.02843683f, -0.21643557f, 
    -0.10096093f, -0.14333974f, -0.02929077f, -0.08106317f, -0.24584033f, 0.08957151f, -0.10293313f, 0.03554755f, 
    -0.09530786f, 0.01620999f, 0.02474308f, -0.13330621f, -0.07193585f, 0.05250721f, -0.00622566f, -0.12388568f, 
    0.54740840f, 0.31684446f, -0.08130299f, -0.10758894f, 0.00001042f, 0.01863165f, -0.01189376f, 0.08760038f, 
    0.06505185f, 0.04589184f, 0.01096871f, 0.03878637f, 0.08096553f, -0.49568954f, 0.06824845f, 0.14038706f, 
    -0.04340884f, -0.17200655f, -0.05049785f, -0.09693015f, -0.05304654f, -0.01059357f, 0.02902668f, -0.12951103f, 
    0.15607424f, -0.10566457f, -0.15128879f, 0.19357641f, 0.07567600f, 0.06320850f, 0.06220722f, -0.11782752f, 
    -0.07856844f, 0.07362644f, 0.12943079f, 0.10931477f, -0.26907647f, 0.04215282f, 0.32315171f, -0.28630322f, 
    -0.03368450f, -0.09654848f, 0.07144435f, -0.01733497f, -0.03823194f, -0.21780221f, -0.09814164f, 0.09727529f, 
    -0.28519496f, -0.13473159f, 0.17920078f, -0.07320479f, -0.01364997f, 0.04792536f, -0.09292398f, -0.00973190f, 
    0.10581840f, -0.18329825f, -0.20424476f, -0.11997624f, 0.25786904f, 0.17105439f, 0.05922072f, 0.20762865f, 
    -0.30747432f, 0.04749306f, -0.18071042f, -0.09804613f, -0.00904828f, -0.06980375f, -0.10923099f, 0.08432841f, 
    -0.42609930f, 0.12098586f, 0.03978593f, -0.18684231f, 0.13677874f, 0.07162594f, -0.34605756f, -0.11047743f, 
    0.12529017f, -0.08277299f, 0.17698905f, -0.32729709f, -0.34347841f, 0.12134807f, -0.10582799f, -0.22488017f, 
    -0.07658046f, -0.07167354f, -0.06321244f, 0.03387439f, -0.02485123f, 0.01191183f, 0.11677063f, -0.04481340f, 
    -0.43994087f, 0.10220849f, 0.22736864f, -0.00333203f, -0.04279787f, -0.04850547f, -0.12047785f, 0.01987085f, 
    0.09322537f, -0.13643496f, 0.00221763f, 0.02723555f, 0.10942215f, -0.02217366f, -0.19861285f, -0.06080047f, 
    -0.18463492f, -0.21728799f, 0.04796388f, -0.10850251f, 0.06273177f, 0.11540440f, -0.10269278f, -0.13635558f, 
    -0.29514238f, -0.17597158f, 0.07199655f, -0.37798986f, 0.07668872f, -0.05012730f, 0.00031437f, -0.11373656f, 
    -0.10988668f, 0.06955383f, 0.04570388f, -0.05755251f, 0.07926250f, 0.29264328f, 0.13571861f, -0.13628137f, 
    0.08290611f, 0.18753976f, -0.07906725f, 0.03257840f, 0.14406246f, 0.01764307f, 0.04138869f, 0.10559034f, 
    0.29087114f, 0.07650061f, -0.17944388f, -0.07868729f, -0.09406234f, 0.09417560f, -0.09848945f, -0.02726530f, 
    0.04760272f, -0.06561926f, 0.06993299f, -0.00906722f, 0.07662509f, 0.08629824f, -0.01076482f, 0.15370075f, 
    -0.07721833f, -0.03417212f, -0.11432430f, -0.08281291f, -0.01657869f, 0.07432690f, -0.04061906f, -0.08906676f, 
    -0.39183721f, -0.11636680f, 0.17226601f, -0.43667573f, -0.11132358f, -0.03899899f, 0.12501289f, -0.26900929f, 
    0.02499478f, -0.00389376f, 0.07066184f, 0.08102528f, -0.23551339f, 0.00239250f, 0.29859868f, -0.13524289f, 
    -0.07121410f, 0.01495333f, -0.16730358f, -0.04927864f, -0.06412283f, 0.22942086f, 0.05634199f, -0.11821368f, 
    0.17244837f, -0.27659068f, 0.16992290f, -0.03145730f, -0.07764795f, 0.02575011f, 0.06356508f, -0.13060006f, 
    0.01507482f, -0.00473591f, 0.06013810f, -0.09417691f, 0.15079269f, 0.19338980f, -0.26565862f, -0.12912636f, 
    0.02451900f, -0.08566196f, 0.18562156f, -0.00772153f, -0.02807165f, -0.12575482f, 0.04642797f, -0.09449036f, 
    0.03564976f, -0.21544793f, -0.00592191f, 0.20338662f, 0.24441381f, 0.04239114f, -0.03001251f, -0.11602881f, 
    -0.01186558f, 0.00265131f, 0.12437639f, 0.01308466f, -0.27584893f, 0.18378650f, -0.24910417f, -0.27261916f, 
    -0.05047206f, 0.01093670f, -0.22325557f, -0.00178333f, 0.15113381f, 0.05419196f, 0.01374235f, -0.14611053f, 
    -0.02016846f, 0.33714262f, -0.08195323f, -0.33749810f, -0.07362779f, -0.07206493f, -0.03016915f, -0.16041118f, 
    0.12171462f, 0.00102283f, 0.14131768f, 0.18217839f, 0.03634301f, 0.00311056f, 0.04200250f, 0.11227243f, 
    0.20185663f, -0.02344587f, -0.13116124f, -0.04379284f, -0.03372687f, -0.08488331f, 0.12715629f, -0.12857971f, 
    0.17837466f, -0.07639787f, -0.49531904f, -0.21380650f, -0.06697594f, -0.06040172f, 0.06145567f, -0.11633641f, 
    0.03787451f, -0.08022971f, 0.21712178f, 0.07313652f, -0.06406777f, 0.17891389f, 0.12621933f, -0.04667621f, 
    0.01127671f, -0.02862579f, -0.08278681f, 0.18288033f, -0.06895001f, -0.01258486f, 0.06918151f, -0.07081819f, 
    -0.02015758f, 0.11749836f, 0.04266017f, 0.19963887f, 0.10943131f, -0.07561409f, -0.12084226f, 0.04058252f, 
    0.15803081f, -0.02973885f, -0.11891363f, 0.06958495f, 0.22115988f, 0.17722976f, -0.15042023f, 0.08928719f, 
    0.05561645f, 0.10256045f, -0.04702250f, -0.11209772f, 0.15045817f, -0.08316257f, 0.06274448f, -0.09615883f, 
    0.00002493f, 0.07192207f, 0.14427526f, 0.22468415f, -0.13789441f, -0.04710118f, 0.11588822f, -0.12831260f, 
    -0.03899968f, -0.04836817f, -0.01386303f, -0.03197280f, -0.09312109f, 0.08676497f, 0.14939795f, -0.00590632f, 
    -0.02599627f, 0.07532968f, -0.08450864f, 0.16097645f, -0.00327091f, 0.04164746f, -0.04272720f, -0.25411713f, 
    0.21029669f, 0.24854924f, -0.17229769f, 0.04390528f, 0.15615651f, 0.02678735f, -0.05727205f, -0.08606990f, 
    0.04056836f, 0.13373341f, 0.04815960f, 0.02236703f, -0.26893851f, 0.03672623f, -0.07636125f, 0.05118652f, 
    -0.05579320f, -0.07927446f, -0.07184450f, -0.04073826f, 0.05044967f, 0.08530831f, 0.05607045f, 0.01272114f, 
    -0.03248753f, -0.24430026f, 0.06198341f, 0.15432583f, -0.01395973f, -0.09570310f, -0.02918379f, -0.04607740f, 
    -0.11796995f, 0.00299895f, 0.11950726f, -0.00301962f, 0.10636632f, -0.08020207f, -0.09375073f, 0.23222703f, 
    0.12469860f, -0.02597531f, 0.02432315f, 0.02661785f, 0.01521140f, -0.09338314f, 0.15077928f, 0.10532958f, 
    0.07868139f, -0.22174153f, 0.11105050f, -0.06967617f, 0.15717874f, -0.10138381f, -0.00554548f, -0.08049751f, 
    -0.02424329f, -0.06100883f, -0.04383786f, 0.24359646f, -0.24075392f, -0.42856473f, -0.23091839f, -0.24929772f, 
    -0.14473405f, -0.02834440f, -0.09231302f, 0.00403198f, 0.12025579f, 0.15072286f, -0.04735857f, 0.08469263f, 
    -0.17728622f, -0.13769180f, 0.07405405f, -0.07346591f, 0.11678579f, 0.08653090f, -0.07726745f, 0.10181227f, 
    -0.13760975f, 0.05853226f, -0.17558359f, -0.13361047f, -0.06756701f, -0.31337172f, -0.03975401f, 0.10333064f, 
    -0.02771165f, -0.00902733f, -0.06527999f, 0.01636358f, 0.11481369f, -0.01495477f, 0.03592065f, -0.03196603f, 
    0.13619027f, -0.05800231f, -0.11401913f, 0.00261472f, 0.10394825f, -0.11051904f, 0.09618472f, 0.08495340f, 
    -0.12687403f, 0.04507691f, 0.13912667f, 0.02163604f, -0.12423583f, -0.13963850f, 0.03718346f, 0.07713835f, 
    0.08838270f, 0.16556720f, 0.01003960f, 0.11151043f, 0.09453953f, -0.07439277f, -0.01379632f, -0.05670435f, 
    -0.29383475f, 0.01016779f, 0.36925238f, -0.23160833f, -0.07679533f, -0.00136416f, 0.02741509f, 0.11523755f, 
    0.11571994f, -0.04134959f, -0.16410956f, 0.14436549f, -0.14507742f, -0.11528535f, -0.05599053f, 0.13093477f, 
    0.01745567f, 0.18259583f, 0.07194848f, -0.14344168f, -0.03897966f, -0.08065883f, 0.00212952f, -0.10739897f, 
    -0.15930118f, -0.09401964f, 0.19663043f, 0.12857996f, 0.10927726f, 0.11039952f, -0.13108619f, 0.16967501f, 
    -0.19958612f, 0.00662720f, -0.04766406f, 0.05424972f, -0.28153685f, 0.55311769f, -0.18286079f, -0.30078027f, 
    0.12885018f, 0.03841852f, -0.04020924f, 0.07129423f, -0.09624974f, -0.02929953f, 0.04818850f, -0.19026889f, 
    0.20505340f, -0.03901443f, -0.28804299f, 0.34259239f, 0.06294910f, 0.01104866f, -0.07388760f, 0.08819129f, 
    0.06871232f, -0.03590474f, -0.07880563f, -0.04244847f, 0.00005749f, -0.17805125f, -0.19431172f, 0.04223348f, 
    -0.03062978f, 0.08395062f, -0.08896942f, -0.15024364f, -0.03809805f, -0.06154560f, 0.03194453f, -0.04580730f, 
    0.21698380f, 0.12866300f, -0.07148341f, -0.09937948f, 0.04812565f, 0.07091668f, 0.20131156f, 0.07777393f, 
    -0.16604289f, 0.13083902f, -0.13027595f, 0.31754759f, 0.58076763f, -0.79564416f, 0.09495713f, -0.10373452f, 
    0.03014384f, -0.16964491f, 0.01898319f, 0.04538887f, -0.17550227f, -0.17867054f, 0.06920218f, 0.07953748f, 
    0.28944504f, -0.12821071f, -0.23051524f, -0.15735795f, 0.03734574f, -0.01070246f, 0.09155646f, -0.01255986f, 
    -0.04907718f, -0.05705125f, -0.00288164f, -0.14716114f, 0.45333591f, 0.07334697f, -0.11576024f, -0.34649375f, 
    0.00507593f, -0.06978684f, 0.08737835f, 0.12585385f, 0.04767094f, 0.10036042f, 0.03426253f, 0.01696278f, 
    0.42354193f, -0.25581160f, 0.11530969f, 0.06500758f, 0.09312963f, 0.07367017f, -0.05146624f, -0.05194610f, 
    0.02293407f, 0.09364597f, -0.08939996f, 0.02990824f, 0.15757985f, -0.17717698f, 0.05055040f, -0.11595576f, 
    -0.08863676f, 0.14644544f, 0.02801649f, -0.05416524f, 0.06168544f, -0.04292419f, -0.05401015f, 0.06233206f, 
    -0.54078329f, 0.17110051f, -0.02828578f, -0.36288476f, 0.04506987f, -0.04567053f, -0.19101776f, -0.06424469f, 
    -0.15330499f, -0.14314464f, -0.09240238f, 0.06668859f, -0.20765837f, 0.29198083f, 0.23184678f, 0.01272165f, 
    0.01245004f, 0.05816608f, -0.12479930f, 0.00243192f, -0.04479131f, -0.08146105f, -0.06677201f, 0.06582547f, 
    -0.63247252f, -0.41806284f, 0.35568234f, -0.06811024f, 0.08122665f, -0.06882094f, -0.03122120f, -0.03963488f, 
    -0.08870989f, -0.06619787f, 0.08986366f, -0.03839976f, 0.09021668f, 0.08741777f, 0.22318098f, -0.28780785f, 
    0.02111336f, 0.10636292f, 0.12774639f, -0.21769699f, 0.11240033f, 0.17238234f, 0.11018330f, -0.04094782f, 
    -0.45895788f, 0.04368971f, -0.01229557f, -0.13987648f, -0.05023967f, -0.14146619f, 0.13435018f, 0.09347995f, 
    -0.02693993f, 0.09824503f, 0.06201638f, 0.12822425f, -0.43578729f, -0.17386678f, -0.07077453f, 0.00186961f, 
    -0.08342045f, 0.08839326f, -0.08495922f, -0.01669257f, 0.04829279f, 0.15388942f, 0.11279727f, 0.02448445f, 
    -0.27930456f, 0.06629168f, -0.35419634f, -0.22569975f, 0.14949664f, -0.03804039f, -0.01636893f, 0.03806613f, 
    -0.22535384f, -0.03139553f, 0.05649227f, -0.00082696f, 0.49167818f, 0.02855385f, -0.10742029f, 0.28589875f, 
    0.00003090f, -0.02980226f, -0.13151246f, 0.19018799f, -0.01131607f, 0.13902913f, -0.15856209f, 0.08937684f, 
    0.09168940f, -0.03672469f, -0.10337734f, 0.07156198f, -0.08520441f, -0.11056460f, -0.04139153f, 0.22266862f, 
    0.12339129f, -0.10223037f, 0.23217233f, -0.07167265f, -0.42030445f, 0.11377341f, 0.12269989f, 0.05262753f, 
    0.05658732f, -0.08082469f, -0.06849519f, 0.04251547f, 0.03127959f, 0.14270131f, -0.07295354f, 0.19341351f, 
    0.35085917f, 0.15988271f, 0.39198160f, -0.14150603f, 0.10353224f, 0.04446410f, 0.09547867f, -0.08685482f, 
    0.13817842f, -0.04155427f, -0.10878931f, -0.17101192f, -0.31381607f, -0.11341889f, -0.03288960f, -0.03142655f, 
    0.04767682f, -0.01535120f, 0.01741274f, -0.06224187f, -0.06480463f, 0.09236808f, 0.13414215f, -0.01440273f, 
    -0.23898913f, 0.10175791f, -0.28641659f, 0.35449851f, -0.04363432f, -0.14082029f, 0.06586508f, -0.11077312f, 
    0.00951696f, 0.04148101f, 0.03325222f, 0.01247357f, -0.32880202f, 0.46901739f, -0.54122263f, -0.48836282f, 
    0.21038447f, -0.07656275f, 0.09355374f, 0.00176328f, 0.00009754f, -0.02864322f, -0.07995677f, -0.18237875f, 
    0.37504801f, -0.00313822f, 0.00910612f, 0.14813310f, 0.15856922f, 0.00212432f, -0.09723245f, 0.04609333f, 
    0.03678591f, -0.07302584f, -0.04814855f, 0.12946281f, 0.03779739f, -0.10280630f, -0.10045911f, -0.33282071f, 
    -0.01643270f, -0.01699041f, 0.11796482f, -0.06243417f, 0.03290683f, 0.04308512f, 0.04118572f, -0.19653320f, 
    -0.74195117f, -0.43681067f, 0.22370215f, -0.00349366f, 0.15493517f, 0.02013165f, -0.09543928f, -0.08651076f, 
    0.10546122f, 0.14108856f, -0.01005696f, 0.11623857f, 0.34498122f, 0.06777827f, 0.17030311f, -0.33019111f, 
    0.16127992f, -0.11029872f, 0.14164108f, 0.01908738f, -0.02178555f, -0.12242900f, -0.07524028f, 0.00372873f, 
    0.25238711f, 0.05670521f, -0.11649726f, -0.15862545f, -0.12270276f, -0.05812955f, -0.08126855f, -0.14346193f, 
    -0.00803428f, -0.18892431f, -0.11801261f, -0.15626439f, 0.24291618f, 0.06492079f, -0.11302095f, -0.15802327f, 
    -0.08811953f, -0.07296047f, 0.09731507f, -0.10314085f, -0.03995632f, -0.21584284f, -0.11143995f, 0.01873154f, 
    0.12278779f, -0.11123650f, -0.06739642f, 0.12416841f, -0.05781763f, 0.10154339f, -0.02281229f, 0.03834206f, 
    -0.07012848f, 0.05697830f, -0.10736708f, -0.05829768f, 0.32809067f, 0.04813856f, 0.00413539f, -0.13375497f, 
    0.09753352f, 0.29029986f, 0.08752202f, 0.01590238f, -0.21612766f, 0.04907278f, 0.14207846f, 0.03002691f, 
    0.06566761f, 0.01488278f, 0.12767848f, 0.07460233f, -0.19272269f, -0.03878760f, -0.13958642f, -0.01576496f, 
    0.00397490f, -0.15784945f, 0.18006320f, -0.00086254f, 0.16987993f, 0.01456500f, 0.08492544f, -0.23241758f, 
    0.09630619f, 0.01083003f, 0.08912680f, -0.00469315f, 0.04264100f, 0.05583575f, 0.11442477f, 0.15758200f, 
    0.27321815f, 0.06863449f, -0.00695326f, 0.00932585f, -0.06715853f, 0.01313778f, 0.16135851f, 0.00271302f, 
    0.27967557f, 0.07092381f, -0.01518281f, -0.04398599f, -0.10137264f, 0.04297729f, 0.08961191f, -0.19746196f, 
    0.10178578f, -0.04005454f, 0.02766035f, 0.08488332f, 0.12017793f, 0.00668159f, -0.02301262f, 0.08500908f, 
    -0.23709114f, 0.11884707f, -0.09283895f, 0.16211252f, -0.03347766f, 0.09057210f, -0.02813093f, 0.02118640f, 
    0.10297813f, 0.03821133f, 0.20249946f, -0.11489266f, 0.17179503f, -0.04410841f, -0.10953730f, 0.05428774f, 
    -0.06840696f, 0.07804821f, -0.09802362f, -0.00498666f, 0.01177047f, 0.29852980f, 0.08145843f, 0.19464308f, 
    0.15449910f, 0.14800866f, -0.03577027f, 0.30886933f, -0.16813299f, -0.07209218f, 0.00552192f, -0.21734239f, 
    -0.16310701f, -0.01460626f, 0.08316111f, 0.08327745f, -0.60999542f, -0.54056883f, -0.00827140f, -0.05355621f, 
    0.07932269f, -0.01137188f, 0.07754959f, -0.19549724f, -0.01783048f, 0.21806064f, -0.05953812f, 0.07115704f, 
    -0.01842245f, 0.19909121f, -0.10010472f, 0.03233993f, -0.06881046f, 0.03923893f, 0.03979406f, -0.02994149f, 
    -0.00963030f, -0.03600428f, 0.09976521f, -0.08851590f, -0.01258003f, 0.07492457f, -0.17203283f, 0.14730714f, 
    -0.01366393f, -0.11665007f, 0.06591716f, -0.11204261f, 0.09861185f, 0.10360619f, -0.05304280f, -0.01683589f, 
    -0.97097009f, -0.68659711f, -0.03558787f, -0.12838167f, 0.05837914f, 0.04693925f, 0.04830660f, -0.03206458f, 
    0.23680741f, 0.20572178f, -0.00524793f, -0.02930858f, -0.59388649f, -0.34231812f, 0.23459582f, 0.06714869f, 
    0.11114106f, 0.07442967f, 0.01813434f, -0.23407008f, 0.09200256f, -0.14704849f, -0.06181635f, -0.16966555f, 
    -0.31204847f, -0.07460291f, -0.22407119f, -0.01073969f, -0.04725483f, 0.09115770f, 0.03810703f, -0.04250425f, 
    0.09998301f, 0.12553956f, 0.11038382f, 0.03573697f, -0.62363791f, -0.29297420f, -0.10351715f, -0.15770504f, 
    0.21718396f, -0.09693408f, 0.01973935f, -0.05561887f, -0.13044919f, -0.21581863f, -0.03600960f, 0.06279659f, 
    0.20445985f, -0.01664144f, 0.15124771f, 0.05819066f, 0.08920649f, 0.12891714f, 0.07254720f, 0.23068957f, 
    0.06241379f, -0.03732253f, -0.03180654f, -0.01911635f, 0.25732934f, -0.09814207f, -0.01996941f, 0.12227842f, 
    -0.02338776f, -0.04184809f, -0.15171701f, 0.17393205f, -0.14408645f, -0.17707483f, -0.16421446f, 0.01173280f, 
    -0.27992958f, 0.15505837f, -0.25137821f, -0.59185493f, 0.14298931f, 0.03996578f, -0.09399810f, 0.05702514f, 
    0.03148059f, -0.03255947f, -0.00691128f, 0.08293975f, 0.02519556f, -0.13886213f, 0.26443124f, 0.08133763f, 
    -0.04424714f, 0.09800965f, 0.10595243f, -0.12841167f, 0.09449868f, -0.00471960f, -0.00401573f, -0.10370930f, 
    0.22484273f, -0.01819376f, 0.03669800f, 0.01974145f, 0.05596507f, 0.10574108f, 0.02302922f, 0.06488033f, 
    0.13302556f, 0.12970595f, -0.06867025f, 0.11570361f, 0.23067814f, -0.18626560f, 0.03409110f, -0.10279357f, 
    -0.04181409f, 0.09061822f, 0.00532935f, 0.01484862f, 0.01954264f, -0.01838276f, -0.21141988f, -0.28734496f, 
    -0.31481162f, -0.39876577f, 0.11773627f, -0.08679722f, 0.02146334f, -0.07332007f, 0.10517012f, 0.06691761f, 
    -0.06277146f, 0.07154134f, -0.02239769f, 0.16605189f, 0.20500702f, 0.01303739f, -0.18106367f, 0.01357739f, 
    0.05019106f, 0.06703482f, -0.07339625f, 0.07334710f, -0.00474336f, -0.12816088f, -0.13441913f, -0.03995106f, 
    -0.32670301f, -0.37990326f, -0.27979788f, -0.02692481f, -0.03679166f, 0.10010651f, -0.22885925f, 0.11584388f, 
    -0.08533406f, -0.02826858f, -0.09102037f, -0.03748504f, -0.59725302f, -0.23729418f, -0.46154702f, -0.22161137f, 
    -0.15831265f, -0.20087634f, -0.07295819f, 0.05604627f, -0.07086620f, 0.16332775f, 0.12314768f, 0.07270194f, 
    -0.28231585f, -0.19464670f, -0.01836839f, 0.05540350f, 0.06935149f, 0.09741185f, 0.09222689f, -0.06788148f, 
    0.06200756f, 0.13995674f, 0.02793155f, 0.11143305f, 0.20447962f, 0.36678281f, -0.11206000f, -0.24111637f, 
    0.08447013f, 0.03310048f, 0.02409938f, 0.28829461f, -0.00274398f, 0.09955677f, 0.16051292f, 0.19190653f, 
    0.55773866f, 0.05877031f, -0.28829908f, -0.21519171f, 0.06835274f, -0.07176430f, 0.11053117f, 0.01102640f, 
    -0.14801735f, -0.04701981f, -0.11872729f, -0.03928977f, 0.01337258f, 0.20459197f, -0.07383201f, -0.22588141f, 
    -0.19268961f, 0.07799537f, -0.08207878f, -0.15833773f, -0.02315084f, -0.00843454f, -0.03007326f, -0.18401170f, 
    -0.04648926f, 0.25901243f, -0.18204480f, 0.11779698f, -0.02830643f, -0.19956268f, -0.07909351f, -0.18922731f, 
    -0.02682279f, 0.02921890f, 0.12375797f, -0.21859203f, -0.27739486f, -0.21400085f, -0.04596087f, -0.10144019f, 
    -0.04411014f, 0.07725740f, 0.14423780f, 0.16430594f, -0.08041691f, -0.06431054f, -0.06093524f, -0.08061329f, 
    0.16766153f, 0.05112410f, -0.18342668f, 0.13256742f, -0.07791508f, -0.03286735f, -0.01277450f, -0.10578819f, 
    0.22151756f, -0.02066898f, -0.18151759f, 0.02213505f, -0.23354621f, 0.23246235f, -0.22846860f, -0.14963645f, 
    -0.29594165f, -0.00729562f, -0.00403435f, -0.07803505f, 0.00362485f, -0.03609565f, -0.00557349f, -0.05663624f, 
    0.35102871f, 0.06659418f, -0.19023220f, 0.03569788f, -0.12203851f, -0.03623935f, 0.21694562f, -0.34718898f, 
    -0.11773688f, -0.03884575f, -0.10128982f, -0.06617582f, 0.27198374f, -0.23568931f, -0.29724315f, 0.50539130f, 
    0.04896130f, -0.15832375f, 0.03972666f, 0.02091451f, 0.09510959f, -0.04166907f, -0.01201330f, -0.07184790f, 
    -0.00506878f, 0.06513640f, 0.15885310f, 0.07251365f, -0.15380177f, -0.08698461f, -0.13549247f, 0.08081198f, 
    0.00747138f, 0.02511441f, 0.12770583f, 0.18938604f, -0.02869413f, 0.07718471f, 0.10612056f, -0.09916576f, 
    0.25050923f, 0.05193254f, -0.04062173f, -0.15067616f, -0.02498124f, -0.02251152f, -0.03015848f, -0.17306776f, 
    -0.06878250f, -0.17306058f, -0.13175236f, 0.14957435f, 0.05102034f, -0.06843687f, 0.06973321f, 0.08670949f, 
    0.04915729f, -0.08189677f, -0.19683765f, -0.13195436f, -0.14758933f, 0.09958141f, 0.00265256f, 0.16732702f, 
    -0.04888784f, 0.12794274f, -0.03639327f, 0.19330741f, -0.18841113f, -0.03298131f, 0.02737709f, -0.06048540f, 
    0.12023686f, 0.03870129f, -0.03626767f, 0.15911849f, -0.31634602f, 0.08128925f, 0.07744378f, 0.01557557f, 
    0.07868469f, -0.19165340f, 0.12243691f, -0.01584576f, 0.20186093f, -0.48603883f, -0.03951279f, -0.29838839f, 
    0.05613906f, -0.00486482f, -0.02243257f, 0.19192877f, -0.09981752f, -0.10988021f, 0.05534136f, -0.08828843f, 
    -0.54352331f, 0.27887505f, -0.03193462f, -0.04121727f, -0.10630424f, 0.05262167f, 0.07038688f, 0.01307660f, 
    0.04744453f, 0.02527568f, 0.16585234f, 0.05957011f, 0.34983078f, -0.16806419f, -0.17413703f, 0.21084365f, 
    -0.01052372f, -0.00500275f, -0.09112094f, 0.06231850f, 0.01168428f, -0.03949767f, 0.17907010f, -0.05292200f, 
    0.16539437f, 0.05857878f, -0.15133533f, -0.16842505f, 0.18138570f, -0.05176593f, -0.07265641f, 0.10011480f, 
    0.03887948f, 0.10897118f, -0.13564883f, -0.10731375f, 0.21742472f, 0.44814205f, -0.20936109f, 0.19486152f, 
    0.07577313f, -0.07534558f, -0.18292572f, -0.18836534f, 0.00712186f, 0.17727619f, 0.01694572f, 0.11452229f, 
    -0.03892583f, -0.24224240f, -0.14541240f, 0.14023638f, -0.19934104f, 0.20706378f, -0.20337760f, -0.03965437f, 
    0.04158529f, 0.00471973f, -0.06445523f, 0.00753642f, 0.55944240f, -0.27727860f, -0.16037636f, -0.48346403f, 
    0.01382904f, -0.04631633f, 0.02790246f, 0.02964316f, 0.10164978f, 0.11549194f, 0.03621577f, 0.04618393f, 
    0.33442175f, 0.03134156f, -0.23852046f, 0.02770146f, 0.18272629f, 0.03471307f, -0.02753121f, -0.01670256f, 
    -0.09805024f, -0.01416504f, 0.05545406f, 0.19062565f, -0.17110913f, 0.28160661f, -0.06261277f, -0.01671855f, 
    0.31193984f, 0.03563549f, 0.05914514f, -0.01129422f, 0.04798926f, -0.03189290f, 0.06007275f, 0.06780109f, 
    0.10326479f, -0.31046918f, 0.09473275f, -0.05309530f, -0.05760631f, 0.14565067f, -0.07270136f, -0.04596452f, 
    0.02454760f, 0.12965751f, 0.03301487f, 0.01417154f, -0.55151153f, 0.28270081f, -0.05716533f, -0.06954949f, 
    0.08109196f, -0.03751597f, -0.04034198f, 0.13928959f, -0.10063415f, 0.05005437f, -0.01356828f, -0.08862430f, 
    -0.17702846f, -0.07059518f, 0.01733115f, 0.17917649f, -0.06822126f, 0.11563983f, 0.04155646f, 0.06957237f, 
    -0.13819472f, 0.05543406f, -0.08892372f, -0.16121699f, -0.39219677f, 0.17451987f, -0.01136927f, 0.02208310f, 
    0.05048562f, -0.16527461f, -0.11700380f, 0.21263181f, 0.18148701f, 0.04327724f, 0.14838931f, 0.02824330f, 
    0.04238728f, -0.47100431f, 0.04598309f, 0.01912574f, 0.22336330f, -0.17495596f, -0.11466762f, 0.10374787f, 
    0.07565089f, -0.07275003f, -0.02576433f, -0.02169836f, -0.28480878f, 0.19657375f, -0.39914230f, -0.11010666f, 
    0.17852277f, -0.08877376f, 0.11135557f, 0.12272574f, -0.12330120f, 0.02622345f, 0.10451493f, 0.03270114f, 
    -0.51143426f, 0.06882377f, -0.02285495f, -0.18129328f, 0.11939237f, 0.10041767f, 0.00497309f, 0.07404988f, 
    0.08775520f, 0.11375766f, -0.06582432f, -0.00877115f, 0.30880311f, -0.24675792f, 0.01562710f, -0.14473043f, 
    0.03930125f, 0.01669109f, -0.03954424f, -0.15077671f, 0.00532282f, -0.09529006f, 0.00870979f, -0.02050414f, 
    -0.55993855f, 0.08036376f, 0.26054445f, -0.06438213f, 0.18479149f, -0.05674674f, -0.12115373f, 0.10889220f, 
    0.06224223f, 0.07614839f, 0.03126268f, 0.00082992f, 0.07031707f, -0.15675583f, -0.12395112f, 0.32033384f, 
    -0.07386600f, -0.03170052f, 0.00432553f, 0.15675528f, 0.04684311f, -0.02835041f, -0.12694673f, -0.15458214f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.10395233f, 0.03572014f, -0.03074430f, 0.00841946f, 0.03404332f, -0.01825388f, -0.03575142f, -0.08973591f, 
    -0.09789008f, 0.06822987f, 0.12906691f, 0.02025417f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
