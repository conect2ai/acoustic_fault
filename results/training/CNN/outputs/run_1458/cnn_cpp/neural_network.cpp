#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -1.41228032f, 0.63577241f, 0.62501842f, -1.16098607f, -0.61323321f, 0.23250672f, 0.44278061f, 0.12928252f, 
    0.33753121f, 0.24219298f, -0.01361578f, -0.14492632f, -0.13628286f, -0.02344551f, -0.23573695f, 0.19885120f, 
    0.06289009f, 0.08968904f, 0.17311375f, -0.01030744f, 0.12630327f, 0.13212910f, 0.06119070f, -0.19708493f, 
    -0.35027635f, -0.35061261f, -0.13008495f, -0.47713789f, -0.05715656f, 0.09849988f, -0.35009536f, -0.07906326f, 
    -0.05675979f, -0.20813130f, -0.00159944f, 0.17888846f, -0.22402520f, -0.20201972f, 0.01761403f, 0.05523892f, 
    0.11848206f, 0.22906817f, 0.33798683f, 0.34487310f, 0.28858787f, -0.08536076f, 0.22531383f, -0.16311832f, 
    -0.22458181f, -0.26545566f, -0.94520098f, -0.01905395f, -0.23913296f, -0.47362465f, -0.70649523f, -0.38979259f, 
    -0.27595136f, -0.13988866f, 0.37093994f, 0.27703094f, -0.05396187f, -0.21832490f, -0.13284485f, -0.60956472f, 
    0.30376148f, -0.12521784f, 0.05278662f, -0.04557717f, -0.21831167f, 0.34506088f, -0.26969367f, 0.07896374f, 
    -0.19787659f, -0.11992712f, -0.21345793f, 0.74396676f, -0.00875761f, -0.30973914f, -0.54979229f, -0.42087343f, 
    -0.28252393f, -0.04245212f, -0.67353141f, -0.56350541f, -0.92356610f, -0.00932525f, 0.63301855f, -0.51603580f, 
    -0.12314770f, -0.02745653f, -0.01423267f, 0.18750519f, 0.14832510f, -0.25697413f, -0.43130013f, -0.34840858f, 
    -0.09043830f, 0.14433354f, -0.28545699f, -0.21350995f, 1.25964355f, -0.05255340f, -0.57451355f, -0.19235000f, 
    -1.02225196f, 0.16052254f, 0.04812704f, 0.14233226f, 0.39830065f, 0.35831121f, 0.33119503f, -0.33664981f, 
    -0.25842458f, 0.10617402f, 0.01275397f, -0.10294712f, -0.00094980f, -0.03569726f, 0.03162774f, -0.07976345f, 
    0.07799145f, -0.10830196f, 0.28614590f, -0.19196902f, 0.12213913f, -0.40998897f, -0.55796117f, -0.66320837f, 
    -0.32529566f, -0.64595729f, -0.61068082f, -0.23181021f, -0.36004141f, -0.40089658f, -0.71592635f, 0.37057200f, 
    -0.01432481f, 0.15701148f, -0.05951490f, 0.19286802f, -0.04811457f, -0.06363978f, 0.09959614f, 0.07216329f, 
    -0.13334909f, 0.31012455f, 0.29903811f, 0.03234243f, 0.33870298f, 0.22279486f, -1.22400641f, -0.66045672f, 
    -0.98991519f, -0.32679754f, 0.53451645f, -0.23746081f, 0.22917518f, 0.69175547f, 0.34802243f, 0.14945970f, 
    0.50624871f, 0.31083056f, 0.15483922f, 0.00412280f, -0.00545035f, 0.10516764f, -0.03334040f, -0.29624397f, 
    -0.22141470f, -0.10513571f, 0.00615371f, -0.16512580f, -0.03788601f, 0.11243256f, -0.02241198f, -0.20210311f, 
    0.44506857f, -0.81494784f, -0.50308758f, -0.24340124f, 0.02947293f, 0.20770180f, 0.29165971f, -0.18152075f, 
    0.04439629f, -0.23985557f, 0.00521749f, -0.52733135f, -0.32407427f, 0.41431409f, 0.14293794f, -0.13209449f, 
    0.30567354f, 0.28309026f, -0.09499077f, -0.23451374f, -0.08847605f, 0.19079044f, 0.10512517f, 0.21747456f, 
    -0.19713107f, 0.69355935f, 0.51554257f, 0.65160906f, 0.66723561f, -0.43997231f, -0.64349639f, -0.68585658f, 
    -0.49121058f, -0.12841472f, -0.02984424f, 0.38917992f, -0.20553271f, 0.01451453f, 0.14561382f, -0.13387479f, 
    0.23708285f, -0.18520221f, 0.20479243f, 0.19352253f, -0.04799033f, -0.18741134f, -0.03937976f, -0.10937794f, 
    -0.18251766f, -1.25721371f, -0.45759767f, -0.76926243f, -0.90515959f, -0.83859807f, 0.69045347f, 0.32322562f, 
    0.04975785f, 0.32235616f, 0.63543791f, 0.00381681f, 0.34708318f, -0.08918814f, 0.15859137f, -0.51562595f, 
    -0.45477951f, -0.01741019f, -0.23343036f, -0.20657647f, -0.13384017f, -0.11908585f, 0.08702193f, 0.14264482f, 
    0.19080374f, -0.06962603f, -1.28962934f, -0.20781083f, -0.21344939f, -0.75060284f, -0.35425067f, 0.36320969f, 
    0.02625666f, -0.63897228f, -0.25361183f, 0.32204071f, -0.20801166f, -0.42139927f, -0.35812476f, -0.52693069f, 
    -0.28847679f, 0.04369039f, 0.40437910f, -0.21074657f, -0.09707225f, -0.31069458f, -0.06196268f, -0.06948774f, 
    -0.11680555f, -0.12952222f, 0.01934659f, 0.17921348f, -0.02320310f, 0.12440217f, 0.05316455f, -0.08557386f, 
    -0.22797921f, 0.37586647f, -0.47538987f, 0.18659338f, -0.12626337f, 0.34739468f, 0.19163485f, -0.32843009f, 
    -0.57401180f, 0.54322833f, 0.28474906f, -0.11475922f, -0.25913417f, -0.26408124f, 0.30310714f, -0.18841995f, 
    0.11174639f, -0.09254886f, 0.11240903f, 0.14230046f, 0.27787685f, 0.73628324f, -0.22482687f, -0.80450720f, 
    -0.70465481f, -0.04061997f, 0.41791546f, 0.04733445f, -0.21915014f, 0.36963519f, -0.34991413f, 0.85417050f, 
    -0.47915551f, -0.29961798f, -0.17239134f, 0.33619916f, 0.18825954f, -0.10369503f, -0.06675032f, -0.02676217f, 
    0.12060340f, -0.02030124f, -0.01292998f, -0.28455088f, 0.37630928f, -0.74111605f, -0.72669387f, -0.35829297f, 
    -0.38279477f, -0.20700189f, -0.60589778f, -0.34004062f, -0.38748837f, -0.92620510f, -0.73871553f, -0.26998821f, 
    -0.27917010f, -0.24557540f, 0.67276078f, -0.56742626f, -0.15201557f, -0.56583983f, -0.25049871f, -0.01011076f, 
    -0.57870674f, -0.09665956f, -0.28937620f, -0.35809347f, 0.22506569f, 0.03422936f, 0.64495164f, 0.11979649f, 
    -0.56829280f, -0.69315577f, -0.45196709f, 0.25336772f, 0.36346230f, 0.51979816f, -0.42415306f, -0.63384300f, 
    -0.04821102f, 0.04669092f, -0.17337608f, -0.03414572f, -0.30425373f, -0.28483638f, 0.08518454f, -0.37515938f, 
    -0.35922810f, -0.03355099f, -0.05716735f, -0.14353770f, -0.06191726f, 0.27981898f, 0.39107692f, -0.42062369f, 
    -0.74893183f, 0.34175131f, 0.11203071f, 0.20214409f, -0.73200732f, -1.01639783f, -0.84874082f, -0.48805237f, 
    -0.47353366f, 0.38978595f, 0.23570964f, -0.18044627f, -0.08743010f, -0.00263419f, 0.19260889f, 0.04056704f, 
    0.03646569f, 0.02928689f, 0.20576832f, -0.06780446f, -0.16275258f, -0.24868698f, -0.21412712f, -0.08653662f, 
    -1.06510127f, -0.08289342f, -0.10159256f, 0.50966823f, 0.58011913f, -0.17410919f, -0.17103924f, 0.13686734f, 
    0.61507183f, 0.45193681f, 0.18313837f, -0.27879259f, 0.08478950f, 0.37609661f, -0.39536861f, -0.13991898f, 
    0.03680934f, -0.03274930f, 0.04165611f, -0.08531170f, -0.06679755f, -0.03412437f, -0.14176174f, -0.19398770f, 
    -0.34832305f, 0.19487181f, 0.63911897f, 0.47336286f, 0.50848687f, -0.46569011f, 0.27983728f, 0.33982190f, 
    -0.36361685f, -0.44769737f, -0.27195036f, -0.26007786f, -0.09832416f, 0.07800838f, -0.00376138f, -0.02225978f, 
    0.03791649f, 0.18480502f, -0.12477266f, -0.02599208f, 0.34471378f, 0.09614136f, -0.04083153f, -0.01280386f, 
    -0.36363080f, -0.21603997f, -0.45870540f, 1.03242457f, 0.91830498f, -0.58069271f, -0.02712617f, -0.48157147f, 
    -0.22337152f, 0.17662092f, 0.19558245f, -0.39056796f, -0.33054432f, -0.30654767f, 0.01117172f, -0.19747089f, 
    -0.17355740f, 0.20562328f, 0.03485287f, 0.02670990f, 0.00124449f, 0.19154146f, -0.11743649f, 0.03622962f, 
    -0.08280873f, 0.19984287f, 0.12103575f, 0.47941518f, 0.19853352f, 0.30682409f, 0.35244226f, 0.27566376f, 
    -0.12222669f, 0.31647530f, 0.36303380f, -0.11940446f, -0.54898602f, 0.14150611f, -0.00760432f, 0.14308006f, 
    0.04924513f, -0.31969076f, -0.24702206f, -0.08632839f, -0.16786149f, -0.07393412f, -0.15485209f, -0.02905050f, 
    0.27387223f, 0.11939159f, 0.09342074f, -0.45849293f, 0.75917494f, 0.50177008f, -0.03756545f, -0.34555689f, 
    -0.12686493f, 0.03724561f, -0.00047774f, 0.43977576f, -0.09270726f, -0.03008517f, -0.04067380f, -0.08031546f, 
    -0.14749886f, -0.47165683f, -0.31976098f, 0.32886314f, 0.36227050f, -0.17881863f, -0.16253899f, -0.34353447f, 
    -0.27918044f, 0.38868716f, 0.05718381f, 0.15282097f, -0.36448348f, -1.02949536f, -0.46695507f, -0.18205519f, 
    0.31240058f, 0.80152977f, 0.29325861f, 0.75876260f, -0.43487182f, 0.08388282f, -0.32731450f, -0.26463330f, 
    0.00458588f, -0.30912024f, 0.29746595f, -0.55869067f, -0.23322575f, -0.02981541f, 0.41863504f, 0.17715850f, 
    -0.14051579f, -0.08802500f, -0.18743843f, -0.08036368f, 0.12974587f, 0.24643421f, -0.74786079f, -0.26687187f, 
    -0.77546245f, -0.92318308f, -0.25745419f, 0.39519551f, 0.14671944f, 0.11622541f, 0.01311925f, 0.34547076f, 
    -0.50230676f, -0.40800241f, -0.30870965f, -0.05286119f, -0.14672671f, 0.44542205f, -0.04318709f, -0.26752776f, 
    0.01331926f, -0.16450503f, -0.36246735f, -0.36790752f, -0.34904972f, -0.52652079f, -0.52950579f, 1.29232836f, 
    -0.56498218f, -0.39478934f, -0.76570207f, -0.89906394f, 0.75495952f, 0.06553061f, 0.06037033f, 0.05553480f, 
    0.37384084f, -0.06810370f, 0.20357315f, 0.16231814f, -0.19098721f, 0.11241244f, -0.36847159f, -0.05094328f, 
    0.44433913f, -0.18771949f, -0.15106167f, -0.09395529f, 0.00506823f, 0.12755989f, 0.32395798f, -0.01391074f, 
    0.11371744f, 0.12598126f, 0.15311085f, -0.23412202f, -0.13684446f, -0.09361444f, -0.30347171f, 0.29882091f, 
    -0.09320269f, 0.40396014f, -0.32205182f, 0.34056944f, -0.18411681f, 0.50154787f, -0.54172546f, -0.19352151f, 
    0.23312274f, -0.19582544f, -0.26222941f, 0.26419747f, -0.20215757f, -0.33469391f, 0.01862086f, 0.33136186f, 
    0.21307559f, 0.24982545f, 0.38714936f, 0.58343124f, -0.22160204f, -0.37580836f, -0.57098359f, -0.54896462f, 
    -0.08695935f, 0.25692752f, 0.27735052f, 0.19621477f, -0.04720962f, -0.15916203f, 0.64202654f, -0.26771095f, 
    -0.00896018f, 0.14071205f, 0.11872567f, -0.02760260f, -0.09551562f, 0.15230249f, 0.55470014f, 0.36508882f, 
    -0.39633816f, -0.26765728f, -0.98691547f, -0.51206571f, 0.24340190f, 0.72032273f, 0.05904831f, 0.48242000f, 
    0.71444643f, -0.98972303f, -0.56663233f, 0.60721302f, 0.13979855f, -0.05271766f, -0.34768969f, -0.15876956f, 
    -0.29251140f, -0.02813328f, -0.05178807f, -0.12701805f, 0.20610715f, 0.35511476f, -0.11065473f, -0.24658412f, 
    -0.27373213f, 0.06186386f, -0.09182357f, -0.73892373f, -0.33848551f, -0.05460526f, 0.17084588f, 0.20763077f, 
    -0.10692904f, 0.34240013f, -0.01673074f, 0.31076479f, 0.24287297f, 0.39894271f, -0.21437261f, 0.18350565f, 
    -0.14566499f, -0.11284166f, -0.22498101f, 0.03969773f, -0.25808552f, -0.30921340f, -0.64713389f, 0.16367549f, 
    0.30577338f, 0.30381611f, 0.50229836f, 0.57634258f, 1.38002396f, -0.37777579f, -0.20992272f, 0.05139561f, 
    -0.71554083f, 0.87796420f, 0.08868819f, 0.11107916f, -0.69252408f, -0.44916376f, 0.21914822f, 0.23893782f, 
    -0.40792122f, -0.28194118f, -0.21973929f, -0.14020693f, 0.39320669f, 0.44821820f, -0.03420365f, 0.12063775f, 
    0.00228837f, -0.30020839f, -0.14987810f, -0.09261231f, -0.12329053f, 0.01474682f, 0.28789857f, 0.18756929f, 
    0.07597374f, -0.12503687f, -0.60169631f, -0.59817320f, -0.14237939f, -0.66855019f, -0.95146388f, -0.15511419f, 
    -0.36021727f, 0.66199636f, -0.57978779f, -0.16450885f, 0.43613818f, -0.17607674f, 0.03383884f, -0.05740752f, 
    0.06217462f, 0.10124775f, -0.13047464f, -0.05470150f, 0.20681618f, 0.28369510f, 0.57877451f, -0.62234282f, 
    -0.45607123f, -0.29613245f, -0.22893292f, -0.57786864f, -0.36322460f, 0.21463867f, 0.00759881f, 0.11374147f, 
    -0.08751965f, 0.30346140f, 0.67847294f, -0.15786241f, 0.27371517f, -0.11064144f, 0.13899356f, -0.06162459f, 
    0.06645735f, -0.14064057f, -0.01715706f, -0.38331044f, -0.28323337f, 0.27303588f, 0.08029393f, 0.13160107f, 
    0.19247416f, 0.24058218f, 0.09049270f, 0.24584214f, 0.00439870f, 0.03206114f, -0.07006955f, 0.11343534f, 
    0.36167085f, -0.08145592f, 0.19614112f, -0.12392836f, -0.17646867f, 0.35680476f, -0.24677061f, -0.17118558f, 
    0.06832994f, 0.01585551f, -0.14416544f, 0.00721534f, -0.32113552f, 0.27555442f, 0.03163555f, -0.17529513f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.06787591f, -0.20369154f, 0.31165171f, 0.15635329f, 0.32019326f, -0.21815531f, 0.40201014f, 0.09384236f, 
    0.20876317f, -0.11618859f, -0.25546393f, 0.42475817f, 0.27166000f, -0.33512098f, 0.28172654f, -0.07327707f, 
    0.25184724f, 0.22462665f, 0.28086880f, -0.01469506f, 0.51522958f, 0.14458473f, -0.27708748f, 0.48333171f, 
    0.25369403f, 0.30506453f, 0.30767441f, 0.08731244f, 0.13874289f, 0.32068452f, 0.51404232f, 0.09126344f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.37806910f, -0.04448406f, 0.08425348f, -0.07643391f, -0.22193281f, 0.44751972f, 0.03337820f, 0.22518742f, 
    0.10004240f, 0.16248690f, 0.01979879f, -0.06046265f, 0.35016233f, 0.20074271f, 0.16512439f, -0.03839045f, 
    0.03728104f, 0.15371239f, -0.05617480f, 0.14516436f, 0.01933735f, 0.03893461f, 0.05416378f, 0.08646993f, 
    0.12485348f, 0.21519335f, 0.19639601f, -0.17702222f, 0.09469233f, 0.20654777f, 0.04096835f, 0.02640062f, 
    0.02107427f, -0.00082205f, -0.02989613f, -0.02602314f, 0.28787437f, -0.08794162f, -0.23167381f, -0.06624186f, 
    0.13652150f, -0.12789972f, -0.02781769f, 0.16394280f, -0.10144085f, 0.03193043f, -0.14399095f, -0.00848047f, 
    -0.54125941f, -0.49601266f, -0.40729353f, 0.07014736f, -0.09784102f, 0.00191930f, -0.11011351f, 0.09718862f, 
    -0.09715702f, -0.04342596f, -0.23011161f, -0.14269644f, 0.36344036f, 0.14568923f, -0.18261796f, -0.25525323f, 
    0.13682625f, 0.10259387f, -0.03046682f, -0.16541579f, -0.01080152f, -0.02974092f, -0.01913404f, 0.07097371f, 
    0.23491873f, 0.24024937f, 0.11458644f, -0.07428969f, 0.13365749f, 0.08832805f, 0.06669217f, 0.00050934f, 
    -0.15382218f, -0.08071227f, -0.12064388f, 0.07145213f, 0.03572395f, 0.19825301f, -0.02567075f, 0.13451952f, 
    -0.06791158f, -0.12315273f, -0.00009125f, 0.00750438f, 0.03924858f, 0.01637686f, -0.00295379f, 0.01792807f, 
    -0.24566305f, 0.29947591f, -0.06941045f, -0.05624192f, -0.02375991f, -0.19742826f, -0.29336309f, -0.08400792f, 
    0.04736096f, -0.01729232f, 0.07116694f, 0.05419978f, 0.16081662f, -0.10542573f, 0.00087091f, -0.00900226f, 
    0.08562042f, 0.25172016f, -0.07118412f, 0.07925927f, -0.17007588f, 0.03508279f, 0.01269798f, 0.01358857f, 
    0.33354962f, 0.39282662f, -0.03089745f, -0.10849690f, 0.16192979f, 0.30371433f, 0.02316307f, 0.24601510f, 
    -0.09125397f, -0.00628930f, -0.12914062f, -0.04846239f, -0.11217394f, -0.10110018f, 0.04212610f, -0.19586758f, 
    -0.41536349f, -0.10038050f, -0.15155478f, -0.07320594f, -0.23127045f, -0.09656783f, -0.05231554f, -0.07234160f, 
    0.02945405f, -0.10649364f, -0.30860320f, -0.10694703f, -0.04293105f, 0.10525115f, -0.32011220f, -0.13638528f, 
    -0.07957826f, 0.04069810f, 0.21204132f, -0.18699646f, 0.44001120f, 0.12900950f, -0.08117612f, -0.28593171f, 
    0.17274278f, 0.11769931f, 0.08373996f, 0.06735852f, -0.22405457f, -0.18098922f, -0.12673368f, -0.25457570f, 
    0.09468223f, -0.27350861f, -0.44844937f, 0.09005354f, 0.04331814f, -0.01794402f, -0.13460922f, -0.10526958f, 
    -0.13702549f, -0.17352766f, -0.17496639f, -0.22538513f, 0.47950804f, 0.31764677f, -0.13234927f, -0.25598526f, 
    0.07223270f, 0.02542774f, -0.11873421f, 0.24682769f, 0.04673310f, -0.04854950f, -0.06423900f, 0.02881692f, 
    -0.08501207f, 0.15408427f, 0.20929769f, -0.00190621f, 0.01286409f, 0.02811050f, 0.05847236f, 0.06384104f, 
    -0.03412986f, 0.06563097f, 0.01424409f, -0.10065169f, -0.19397579f, -0.57728457f, -0.16338462f, 0.10756809f, 
    0.13734972f, -0.00382847f, -0.04330016f, -0.07862897f, -0.00516416f, 0.03191240f, 0.01998142f, 0.10375170f, 
    -0.30155867f, 0.15180284f, 0.10457417f, 0.16049381f, -0.15104182f, -0.00730365f, -0.02680301f, 0.10877332f, 
    0.03634420f, -0.00270591f, -0.07585523f, -0.03923876f, -0.03851918f, 0.06338347f, 0.09138430f, 0.39612550f, 
    0.05793472f, -0.00931409f, 0.02808608f, 0.00829379f, 0.03124072f, 0.03073141f, 0.05248073f, 0.01669124f, 
    -0.40747058f, -0.09174565f, -0.78181714f, 0.20650885f, 0.00149040f, -0.05430871f, 0.05241388f, 0.04315447f, 
    -0.05191296f, -0.05611129f, -0.03078261f, 0.02551930f, 0.54030931f, -0.11495757f, -0.27505928f, -0.10542857f, 
    -0.26399755f, 0.02480617f, 0.16541733f, -0.06454659f, -0.02469279f, -0.19204894f, -0.19167188f, -0.06574865f, 
    0.11284012f, 0.22315888f, -0.06557291f, -0.07452214f, -0.04454641f, 0.20344292f, -0.03816869f, 0.09227566f, 
    -0.20504415f, 0.03471559f, 0.00398769f, 0.14191100f, 0.15355833f, -0.36863455f, -0.59036368f, 0.19757028f, 
    0.03753415f, -0.01854390f, -0.35313889f, -0.27946660f, 0.01066892f, -0.11606012f, -0.07944271f, 0.07181256f, 
    -0.35081971f, 0.00126621f, -0.26119354f, -0.10204536f, -0.01253277f, -0.02860591f, 0.06545513f, 0.01382708f, 
    -0.16608329f, -0.13426976f, -0.16807482f, -0.10665037f, -0.02243766f, 0.00269998f, 0.13471322f, -0.04570344f, 
    -0.30951199f, -0.09601189f, -0.18777028f, -0.26052353f, -0.01443954f, -0.14722650f, 0.00464197f, -0.05438766f, 
    0.77232069f, 0.05189758f, -0.15418909f, -0.51156640f, -0.18777417f, -0.20559511f, 0.11708075f, -0.28719628f, 
    -0.07582336f, -0.21817879f, 0.00030717f, -0.06377995f, -0.06624021f, 0.13975616f, 0.16114558f, -0.09523772f, 
    0.11326475f, 0.06189173f, 0.01022944f, -0.07063533f, -0.11907481f, -0.20893678f, -0.31838828f, -0.22796680f, 
    0.20055860f, -0.27341640f, -0.49042597f, 0.02898378f, -0.01308778f, -0.09308331f, -0.04316695f, -0.01115371f, 
    -0.08933658f, 0.25253206f, 0.04392866f, 0.03676711f, 0.09990827f, 0.10872912f, -0.12748614f, -0.21124771f, 
    -0.00558052f, -0.07677756f, -0.08240243f, 0.05117847f, 0.01369372f, 0.06535398f, -0.00502354f, 0.02768479f, 
    0.16385329f, 0.14579067f, -0.06086611f, -0.09891409f, -0.03416035f, 0.01288238f, -0.20551300f, -0.16041456f, 
    -0.13035814f, -0.07256307f, -0.09849862f, 0.09849293f, -0.32119104f, -0.10412154f, -0.07286631f, 0.07150088f, 
    0.00657529f, 0.05418514f, 0.02734430f, -0.00012601f, -0.07118207f, 0.00403567f, 0.00432547f, -0.13290782f, 
    -0.11108572f, -0.05556856f, 0.04699713f, -0.12246603f, -0.07403318f, 0.03664005f, -0.19927971f, -0.05435717f, 
    -0.12409489f, -0.06932382f, -0.04322466f, 0.13824956f, -0.14934297f, 0.01604348f, 0.06088325f, 0.07650045f, 
    -0.07139708f, -0.02816101f, -0.04717122f, -0.05789808f, -0.09310339f, -0.08482506f, -0.08014541f, -0.02611878f, 
    -0.15856951f, 0.12091847f, -0.01305923f, -0.18480626f, 0.04452595f, 0.10347422f, -0.48361826f, -0.27621511f, 
    0.02194176f, 0.00959896f, -0.13810751f, -0.09537483f, 0.14166091f, -0.26357719f, -0.19653644f, -0.21602240f, 
    -0.26136848f, 0.01169256f, -0.13162474f, 0.03657500f, -0.04354455f, -0.02357128f, -0.22625269f, 0.13740900f, 
    0.56733119f, -0.08193111f, 0.10557152f, -0.11518291f, 0.03235318f, -0.02258296f, 0.01589243f, 0.01899238f, 
    0.15458710f, -0.00864678f, 0.02930815f, -0.20183593f, -0.00941050f, 0.28116748f, 0.28238153f, 0.10526672f, 
    -0.08053240f, 0.03325357f, -0.11151087f, -0.20951442f, -0.09820227f, -0.03479928f, -0.00716863f, -0.05578360f, 
    -0.39475214f, -0.54874736f, -0.26354736f, -0.01459766f, -0.01854350f, 0.10270809f, 0.06989168f, -0.04133524f, 
    -0.03774907f, 0.02614501f, -0.00227917f, 0.02738686f, -0.08345921f, 0.10311700f, 0.20088837f, -0.09285533f, 
    -0.09243219f, 0.23063983f, 0.04719698f, -0.30370072f, -0.05137490f, 0.03149482f, -0.03964135f, -0.17743127f, 
    -0.08165936f, 0.10355070f, -0.13975950f, -0.06039409f, 0.01852331f, -0.27430752f, -0.16480210f, 0.03448996f, 
    -0.03936737f, -0.02252671f, -0.02779750f, 0.04559623f, 0.26989096f, 0.17455138f, -0.33515668f, -0.29305965f, 
    -0.14241429f, 0.12378204f, 0.06739777f, 0.02220311f, -0.00912094f, -0.06943911f, -0.11787385f, -0.03763937f, 
    0.44489399f, 0.14543043f, 0.07970379f, 0.02259962f, 0.26572356f, 0.01282154f, -0.25368980f, -0.10846341f, 
    0.02068684f, 0.04262959f, -0.03346149f, -0.02104557f, 0.20184278f, -0.01056513f, -0.07372968f, 0.08563433f, 
    0.03026325f, 0.04555125f, -0.05326644f, -0.05253369f, -0.02146308f, 0.06304902f, 0.01188165f, 0.16709216f, 
    0.18727370f, -0.12945017f, 0.11970365f, -0.45823944f, -0.03438847f, 0.16613881f, -0.06255250f, -0.15257971f, 
    -0.02800890f, 0.02608826f, -0.29898664f, 0.04760701f, 0.01915213f, -0.16475104f, 0.35802704f, 0.15185788f, 
    0.02378670f, 0.14653584f, 0.17233118f, -0.04081307f, 0.03671638f, -0.01188325f, 0.03061047f, -0.06125719f, 
    0.55979711f, -0.46621135f, 0.05446937f, 0.22798207f, -0.09057997f, 0.02205474f, 0.26708952f, 0.11032819f, 
    -0.04642873f, -0.04886126f, -0.05667638f, -0.03147663f, -0.22366208f, 0.18703742f, -0.28753591f, -0.21416700f, 
    -0.02124513f, -0.20992015f, -0.05292591f, 0.20354989f, 0.00672240f, -0.03817639f, 0.08299333f, 0.08249272f, 
    -0.03748166f, 0.15518455f, 0.06558632f, 0.08070095f, -0.07257459f, -0.08414269f, 0.03909415f, 0.00647517f, 
    -0.29285085f, -0.15362507f, -0.34165984f, 0.02011679f, 0.14487974f, 0.18826382f, 0.03975461f, -0.03680521f, 
    -0.07790577f, -0.10131878f, -0.10640196f, 0.02910086f, -0.14039908f, -0.03046628f, 0.09667423f, -0.00663448f, 
    0.04113935f, -0.08827463f, 0.13122599f, -0.19944036f, -0.04292627f, -0.03901480f, 0.11115474f, -0.10065068f, 
    -0.03714428f, 0.04431086f, -0.03205139f, -0.03185968f, 0.57470334f, 0.29995385f, 0.55686766f, 0.02693325f, 
    0.00517140f, -0.04558922f, -0.04548572f, -0.02569024f, -0.09743422f, -0.00486165f, 0.06856243f, 0.13975784f, 
    0.34146044f, -0.08944463f, 0.55683482f, 0.23582487f, -0.00596399f, -0.14059938f, 0.03758245f, -0.00131248f, 
    -0.16724622f, 0.10879602f, -0.11119253f, 0.28066707f, -0.18737096f, -0.37113753f, -0.11501367f, -0.09519258f, 
    -0.25431305f, -0.02649953f, -0.03010858f, -0.03970123f, 0.26469037f, -0.10095129f, 0.07062111f, -0.02052177f, 
    0.07306807f, 0.09406312f, 0.03189836f, 0.31938064f, 0.06817334f, -0.09487969f, -0.30035117f, -0.13470437f, 
    -0.01742291f, 0.03934339f, -0.14824058f, -0.39970812f, 0.79773378f, -0.16374959f, -0.16799678f, -0.49776149f, 
    0.03630426f, 0.03560724f, 0.04736539f, 0.17413883f, -0.04834502f, 0.29090333f, 0.16719706f, -0.10753428f, 
    0.16875438f, 0.19261745f, 0.15174624f, -0.23464791f, 0.17770499f, 0.05860978f, 0.03416929f, -0.08187868f, 
    0.33563319f, -0.14170825f, 0.07852450f, 0.01333104f, 0.01187585f, -0.02737642f, 0.11820303f, -0.21017458f, 
    0.15868753f, 0.09244794f, -0.26960763f, 0.23673701f, -0.05343260f, -0.09599645f, -0.03219062f, 0.02882680f, 
    0.67028612f, 0.07767576f, -0.26817992f, 0.06307124f, -0.03818965f, 0.05113941f, -0.05298259f, 0.03077820f, 
    0.17101759f, -0.11179487f, 0.17595226f, 0.00188345f, -0.25441223f, 0.05134363f, 0.03920321f, -0.10031132f, 
    0.17199941f, 0.06311105f, 0.16547853f, 0.02591248f, -0.01447642f, 0.07401273f, 0.08344366f, -0.04984676f, 
    0.68926519f, -0.22253224f, -0.30545953f, -0.17428742f, -0.17130721f, -0.32316008f, -0.11967461f, -0.28994441f, 
    0.11859897f, -0.22652358f, 0.07499287f, 0.09631244f, 0.01938086f, -0.06414755f, -0.37278625f, -0.23787396f, 
    -0.33644474f, 0.00907404f, 0.07429332f, -0.27500314f, -0.03298841f, 0.02499664f, 0.02497786f, 0.03088101f, 
    -0.09989591f, -0.18500604f, -0.09151242f, 0.05313496f, 0.11106198f, 0.16038732f, 0.10327452f, -0.22304517f, 
    0.24389045f, 0.00545881f, 0.07987700f, 0.09107549f, 0.14251728f, 0.15143645f, 0.16197452f, 0.17773159f, 
    -0.04229397f, 0.08021518f, -0.01085530f, -0.05231879f, 0.05278034f, 0.04189663f, 0.08800788f, -0.21099734f, 
    0.40938693f, 0.19090120f, -0.00602694f, 0.17029282f, 0.08677610f, -0.11507539f, -0.07317937f, 0.13883345f, 
    0.02534036f, 0.08796030f, 0.10662142f, 0.11055924f, -0.12797607f, -0.14971872f, -0.02264019f, -0.05758353f, 
    0.21322365f, 0.00288491f, -0.04339101f, 0.24438582f, 0.02314603f, 0.06131893f, 0.09371664f, 0.03129286f, 
    0.27639204f, 0.41879728f, -0.00865252f, 0.42070973f, -0.03998313f, 0.08562636f, -0.03780141f, 0.04034073f, 
    0.00278957f, 0.04741337f, -0.07580993f, 0.11598402f, -0.62315345f, -0.10655921f, 0.09094854f, -0.35378897f, 
    -0.04068724f, 0.01537726f, -0.04783026f, -0.31566706f, 0.04217475f, 0.04898949f, -0.00202232f, 0.09505381f, 
    -0.89753610f, 0.66305459f, 0.09317331f, -0.07196292f, -0.04617838f, 0.08945441f, -0.08290623f, -0.04371926f, 
    0.08681539f, -0.00221183f, -0.00255103f, 0.28785613f, -0.71129888f, -0.30540308f, -0.05726812f, -0.23687790f, 
    -0.21588393f, -0.04629460f, 0.13481762f, 0.01747870f, 0.04430686f, -0.00016656f, -0.04155830f, -0.02995178f, 
    0.10464224f, 0.26546857f, 0.28043163f, 0.22384119f, -0.07956550f, -0.08778430f, 0.08844836f, 0.06656804f, 
    -0.00001167f, -0.05434808f, -0.18637159f, 0.15061806f, 0.04224207f, 0.01665260f, 0.33575869f, 0.08137967f, 
    0.18003012f, 0.03604459f, -0.12407656f, 0.07194677f, -0.01481281f, -0.03213934f, 0.03063133f, 0.00055133f, 
    -0.37057188f, 0.09544793f, 0.16020049f, -0.35407048f, 0.02115165f, -0.06273790f, -0.26097152f, 0.04884102f, 
    0.08589961f, -0.04439238f, 0.02331802f, 0.02285480f, 0.17066810f, 0.66377503f, 0.38371968f, 0.48167694f, 
    -0.02804099f, -0.03664755f, 0.19239637f, 0.05767777f, 0.07524884f, -0.07820733f, -0.02687751f, 0.03586026f, 
    -0.16390088f, -0.14756674f, 0.38661975f, 0.44316980f, -0.03832615f, -0.01897729f, -0.10986113f, 0.00833183f, 
    -0.02578246f, 0.02900011f, -0.01103545f, 0.04983690f, 0.02082451f, -0.21095687f, -0.07722579f, -0.17393839f, 
    0.08257148f, -0.04973860f, -0.07175764f, -0.04972560f, 0.08101843f, 0.03681441f, -0.26441595f, 0.19549580f, 
    0.28385034f, 0.03692098f, 0.04337030f, -0.32574931f, -0.04009267f, -0.12581056f, -0.08110880f, 0.16145231f, 
    -0.02218048f, 0.02159078f, -0.32754266f, 0.03902729f, -0.68580520f, -0.57257605f, -0.05604281f, -0.39039239f, 
    0.02956145f, -0.04073931f, -0.11378240f, -0.01890995f, -0.00484278f, -0.09008325f, 0.09306394f, -0.11210133f, 
    -0.05847923f, 0.48186848f, 0.31498528f, -0.51749420f, -0.09788566f, -0.18040366f, -0.05303951f, -0.12442783f, 
    -0.05428306f, 0.06977165f, -0.23646511f, -0.13053164f, -0.38705674f, -0.44684988f, -0.37344489f, -0.10936246f, 
    -0.12989561f, 0.08238448f, -0.17459871f, 0.19498010f, -0.00138103f, 0.04241828f, -0.03957427f, 0.03287879f, 
    0.02790199f, -0.04096894f, -0.15288235f, 0.12404386f, -0.03907713f, -0.00619060f, 0.01774946f, 0.09597230f, 
    0.12064099f, 0.03990858f, 0.04597444f, 0.12160776f, -0.20665547f, 0.37069920f, 0.02293509f, -0.62101388f, 
    0.08792241f, -0.12489783f, -0.09979049f, 0.08631784f, 0.00085678f, 0.05778930f, -0.03365111f, -0.04259898f, 
    -0.00032895f, 0.01300603f, 0.11840633f, -0.36124873f, 0.04081769f, 0.00463417f, -0.00706723f, 0.12670851f, 
    -0.06981958f, 0.03475826f, -0.04813809f, -0.09141444f, -0.26371142f, 0.07474526f, -0.34007448f, -0.00417362f, 
    -0.04366940f, -0.09082682f, 0.06639794f, -0.00312635f, -0.06106616f, -0.05397473f, 0.02539841f, -0.03741217f, 
    -0.04100503f, -0.54923046f, 0.28317848f, -0.19295749f, 0.09687988f, -0.09744947f, 0.06305499f, 0.03711633f, 
    0.02812752f, -0.03356559f, -0.13815987f, 0.16575639f, -0.23930827f, -0.09091047f, -0.01121073f, -0.08643582f, 
    0.10171618f, 0.02319398f, -0.08428808f, -0.00997121f, -0.01377750f, -0.00672034f, 0.09516678f, -0.27760130f, 
    -0.31011033f, 0.02382025f, 0.29646069f, 0.37713981f, 0.03772356f, -0.08166837f, 0.16482911f, -0.08868656f, 
    0.01780409f, -0.07233238f, -0.02280141f, 0.18367770f, -0.48416555f, 0.53709131f, 0.16750300f, -0.07331676f, 
    -0.07529759f, 0.09780319f, -0.19877513f, -0.07720058f, 0.04325908f, -0.02063562f, -0.07778336f, -0.06776506f, 
    -0.09497142f, 0.04939908f, -0.14809474f, 0.11270715f, -0.12581927f, 0.03824877f, 0.06700271f, 0.01438648f, 
    0.05153154f, -0.11235876f, -0.05601320f, 0.20844746f, -0.22325136f, -0.09985826f, -0.03119346f, 0.00849095f, 
    -0.13785708f, -0.24747550f, -0.09239188f, 0.08166375f, 0.06036145f, -0.14224558f, 0.07994657f, 0.12926479f, 
    0.14530180f, -0.05817718f, 0.02825734f, -0.13730980f, 0.07166969f, 0.03885981f, -0.13053739f, 0.20905942f, 
    0.07943450f, 0.12635246f, -0.05418108f, -0.03002482f, -0.00142106f, -0.19284606f, -0.22847383f, -0.01861743f, 
    0.09922680f, 0.04770997f, 0.00594168f, -0.05297356f, -0.09338798f, -0.03191501f, -0.21369690f, 0.10108688f, 
    -0.26950359f, 0.09610286f, 0.02729028f, -0.55600870f, -0.04301446f, -0.15766358f, -0.09447895f, -0.28269896f, 
    0.15218711f, 0.00667950f, -0.15151642f, 0.04945015f, -0.36504552f, -0.09004951f, -0.17492142f, -0.32621801f, 
    0.10269200f, -0.17308646f, 0.10833751f, 0.04674469f, -0.06677061f, -0.06066338f, 0.04178284f, -0.04346620f, 
    0.06134488f, 0.12034062f, 0.02516339f, -0.01321602f, -0.28097469f, 0.17261103f, -0.05453836f, -0.13004126f, 
    0.04353197f, 0.18606046f, 0.07658795f, 0.00519009f, -0.03609253f, -0.11875502f, 0.17725396f, -0.05138087f, 
    -0.05619511f, -0.05385976f, 0.01934758f, 0.00002088f, -0.04954382f, 0.06500571f, -0.01378225f, 0.06406552f, 
    1.35075474f, 0.05091505f, 0.27402815f, 0.37379989f, 0.18982217f, 0.04831581f, -0.03007738f, -0.18846434f, 
    -0.24280491f, -0.04429701f, 0.03011938f, 0.02045248f, 0.17774425f, 0.03057194f, -0.15248804f, 0.20181201f, 
    -0.04034756f, 0.05063349f, 0.01656689f, -0.20776539f, 0.15612707f, -0.09277085f, -0.03735328f, 0.13832752f, 
    0.27921295f, -0.21499765f, 0.08492162f, -0.00095060f, 0.06671187f, -0.16052105f, 0.08136638f, 0.01427582f, 
    0.00760674f, 0.08599078f, -0.11623980f, 0.15949951f, -0.17834289f, -0.27788773f, -0.00588647f, 0.18846460f, 
    -0.01835837f, 0.21034902f, 0.05697510f, -0.01359802f, 0.03325787f, -0.04821873f, 0.05913396f, -0.04510016f, 
    -0.68558234f, 0.11822693f, 0.13428201f, 0.20442121f, -0.09637240f, 0.07529493f, -0.19083099f, -0.23930492f, 
    -0.15125227f, 0.11252501f, -0.01968429f, 0.06648736f, -0.00183854f, -0.14920191f, -0.06005107f, 0.15567957f, 
    0.01685968f, 0.06240828f, -0.04701661f, 0.17577419f, 0.10026477f, 0.00893321f, 0.08507884f, -0.10140023f, 
    -0.01453731f, -0.10099749f, -0.25469822f, -0.05772158f, 0.18841718f, -0.06317488f, 0.11450501f, -0.15848312f, 
    -0.29680550f, 0.05818997f, -0.12225588f, 0.03688566f, 0.47563413f, -0.56967753f, -0.16411482f, 0.28079841f, 
    0.02116611f, -0.14117672f, 0.01640812f, -0.12144388f, 0.01465741f, -0.19521701f, 0.21915722f, 0.07562994f, 
    -0.05263095f, 0.30042553f, 0.28192264f, 0.11172457f, -0.24679756f, 0.07196273f, -0.16117577f, -0.07203902f, 
    0.05735958f, -0.02024913f, 0.02103711f, 0.26858178f, 0.24008968f, -0.19225116f, 0.06802753f, 0.20317987f, 
    0.15549847f, 0.15163597f, 0.05912448f, 0.09173591f, -0.01673374f, 0.07062698f, -0.07064927f, 0.17238314f, 
    0.23015703f, -0.23429289f, 0.01305273f, 0.11263510f, 0.11267238f, -0.09090845f, -0.06773754f, -0.07346434f, 
    0.02122767f, 0.09497252f, -0.02971183f, 0.08635731f, -0.00898011f, -0.30263525f, -0.26136142f, -0.39601535f, 
    -0.05351105f, -0.12151206f, 0.00693971f, 0.01232363f, -0.13348158f, 0.01020667f, -0.08378823f, -0.37257946f, 
    0.12659386f, 0.14108606f, -0.18402079f, 0.47744980f, -0.03665262f, -0.00703739f, -0.21891901f, -0.01231417f, 
    -0.02734826f, -0.13915572f, 0.02814924f, 0.14595523f, -0.14080554f, -0.15174635f, -0.09497701f, 0.14136808f, 
    -0.07601623f, 0.16158617f, 0.01302785f, 0.09479332f, -0.13786560f, -0.07146373f, -0.02572952f, -0.12506531f, 
    -0.09402680f, 0.00373800f, 0.06167042f, 0.43586969f, 0.07120124f, -0.01766995f, -0.01299278f, -0.07949899f, 
    -0.08726732f, -0.13691044f, -0.11488116f, 0.09433780f, -0.16309753f, 0.02044254f, -0.13647375f, 0.12390497f, 
    0.19917999f, 0.17051308f, 0.03918093f, 0.00502241f, -0.02062999f, 0.01301176f, -0.01406573f, 0.03796494f, 
    -0.00049266f, -0.07294130f, -0.20716956f, -0.60163116f, -0.11130003f, 0.18717578f, 0.00184248f, -0.00654331f, 
    -0.11869151f, 0.02051312f, 0.00591806f, -0.25107703f, -0.37401855f, 0.33846515f, 0.33023158f, 0.17321081f, 
    0.01668750f, -0.10853807f, 0.01291269f, -0.13420647f, 0.07706658f, -0.14915420f, 0.03339569f, -0.00521559f, 
    0.59739470f, -0.12120487f, 0.45715672f, -0.39437944f, -0.38685900f, 0.00355579f, -0.15732500f, -0.10298021f, 
    0.02328668f, 0.08001982f, 0.06416843f, -0.05234195f, 0.00270415f, -0.18356273f, 0.10671511f, -0.01356918f, 
    -0.12700063f, -0.19726697f, -0.23908775f, 0.04925970f, 0.02841872f, -0.07320058f, -0.06451645f, 0.08208320f, 
    -0.17678472f, 0.02413350f, -0.15286313f, -0.12032532f, -0.02264882f, 0.13111256f, -0.12893452f, -0.13344394f, 
    -0.30607611f, 0.09862750f, -0.14662573f, -0.02611733f, -0.20435655f, 0.54115450f, -0.86335236f, -0.43750888f, 
    0.33027384f, 0.12101115f, -0.10159857f, -0.05507588f, -0.54899651f, -0.04778547f, 0.05293557f, 0.01883242f, 
    0.30880824f, -0.19435024f, -0.15343820f, 0.18675041f, 0.14611711f, -0.01635117f, 0.13403548f, -0.08430157f, 
    0.03704382f, 0.10917170f, 0.21694063f, 0.16788970f, -0.78131819f, -0.07560103f, 0.11449383f, 0.25638342f, 
    0.03709674f, -0.20998877f, 0.12886976f, -0.18543853f, 0.01466756f, 0.00041468f, 0.10976125f, 0.18338990f, 
    0.03532498f, -0.29082644f, -0.07533062f, -0.28632212f, -0.17762405f, -0.16699144f, 0.03193379f, -0.19055718f, 
    -0.06910952f, 0.05895168f, -0.13287424f, 0.07669607f, 0.02503355f, -0.16329917f, 0.20717856f, -0.17514461f, 
    -0.11135304f, 0.14810865f, -0.23996821f, -0.19842367f, -0.01141445f, 0.08530420f, -0.14148900f, -0.18044521f, 
    -0.73360348f, 0.68357575f, -0.27288669f, -0.23828074f, -0.00211277f, 0.05687796f, 0.04238166f, -0.03771327f, 
    -0.21713075f, -0.14175592f, -0.07347935f, -0.00921025f, 0.20175120f, 0.09426411f, 0.00535162f, -0.04047498f, 
    0.07079060f, -0.00388386f, -0.07225822f, -0.11039991f, 0.00882343f, 0.14772590f, 0.19534937f, 0.14990143f, 
    -0.50240493f, 0.22465147f, 0.19301319f, 0.47402138f, -0.15263191f, 0.00347122f, 0.22709873f, -0.11893502f, 
    -0.00387044f, 0.15260527f, -0.01212476f, 0.01760358f, -0.03355509f, -0.13615955f, 0.01806534f, 0.26358715f, 
    0.00865636f, 0.20254470f, -0.12465011f, -0.02619740f, -0.10809918f, 0.11142277f, -0.13535379f, -0.04666548f, 
    -0.47043291f, 0.03041510f, -0.19937089f, 0.11905546f, -0.09949713f, -0.10442322f, 0.12036226f, -0.00702052f, 
    -0.05628478f, 0.06198897f, -0.08398324f, -0.02994087f, -0.61820763f, -0.03821428f, -0.23474659f, -0.32581571f, 
    0.05034225f, -0.18345042f, -0.08265379f, -0.21063612f, 0.12850316f, 0.12823983f, -0.29415354f, 0.22472546f, 
    0.00471332f, -0.29759797f, -0.09976207f, 0.00363679f, -0.12772569f, -0.39945593f, -0.03621177f, -0.15017562f, 
    0.07389447f, -0.10719549f, 0.14376584f, 0.03197471f, -0.04697381f, 0.07739577f, 0.02070740f, 0.21993215f, 
    -0.05960965f, -0.12143192f, -0.26050502f, 0.01914151f, 0.07400973f, 0.03596694f, -0.00834048f, 0.02383521f, 
    -0.14978318f, -0.09301548f, -0.08640670f, 0.17506692f, -0.03690603f, -0.00713677f, -0.02484398f, -0.16264494f, 
    -0.11125592f, -0.07365287f, 0.09175813f, 0.13264641f, 0.07911941f, 0.38930652f, 0.15582672f, 0.04224100f, 
    0.07985641f, -0.16496417f, 0.03264908f, 0.00984949f, 0.06210250f, -0.02452024f, 0.15093748f, -0.10953802f, 
    -0.40374020f, -0.16615972f, -0.10159467f, -0.04147841f, 0.08495302f, -0.04944286f, -0.09395253f, 0.04518158f, 
    -0.08316560f, -0.08619177f, -0.20923221f, 0.26658621f, 0.12134348f, 0.08182441f, 0.26659206f, 0.17588453f, 
    -0.15569606f, -0.12454993f, 0.08479376f, 0.18373585f, 0.09164915f, 0.10543613f, -0.01037447f, 0.04567280f, 
    0.18380809f, -0.13729356f, 0.03372608f, -0.01221780f, -0.14989750f, -0.00170977f, -0.08740232f, 0.00478321f, 
    0.11057536f, 0.10815685f, 0.00614304f, -0.15369600f, -0.37483239f, 0.01593285f, -0.30771637f, -0.02167265f, 
    -0.15829964f, -0.01346326f, -0.03416521f, -0.10368364f, -0.10388498f, 0.02696722f, -0.09375115f, -0.07187734f, 
    0.29443669f, -0.14394167f, 0.10973638f, 0.58339208f, 0.05362239f, -0.04393527f, 0.29276037f, -0.00782146f, 
    0.07493775f, 0.02141025f, 0.02354362f, -0.01505874f, 0.20778097f, 0.31236905f, 0.17852378f, 0.29359576f, 
    -0.14049883f, -0.24358687f, -0.06177742f, -0.07277370f, 0.03970698f, -0.27519646f, -0.06553837f, -0.01039043f, 
    -0.25380251f, -0.20843914f, -0.12759081f, 0.07567045f, -0.09630256f, 0.00238133f, 0.09475654f, -0.01532585f, 
    -0.01307513f, -0.04616645f, 0.09700525f, 0.03021576f, -0.11268255f, 0.07347863f, 0.02209741f, 0.00497192f, 
    -0.03512720f, 0.16983925f, -0.10594235f, 0.00641499f, -0.10953684f, -0.02597054f, -0.14013447f, 0.02049659f, 
    -0.07254440f, -0.15662330f, -0.26209375f, -0.10412152f, 0.15752730f, -0.16597433f, 0.00001582f, 0.15162966f, 
    0.05324541f, -0.04560747f, 0.10818242f, -0.33068681f, -0.02391050f, 0.11845933f, 0.11552297f, 0.27025241f, 
    -0.11975337f, -0.05734633f, -0.00122980f, 0.07575741f, -0.05492513f, 0.09034569f, -0.04234880f, 0.16835403f, 
    -0.13330257f, 0.04399693f, 0.09547793f, 0.00325738f, 0.04403311f, -0.02205646f, -0.26198107f, -0.00841447f, 
    -0.09477492f, -0.08552030f, 0.13392070f, -0.15450105f, 0.16509716f, 0.17694384f, 0.40659878f, 0.26086423f, 
    0.00139749f, 0.04485282f, -0.06646623f, 0.03136305f, 0.00231368f, -0.03549798f, -0.03979693f, -0.04907703f, 
    -0.06352241f, -0.13961662f, 0.01435000f, 0.02281475f, 0.04093853f, -0.04464407f, 0.10725310f, -0.00662625f, 
    0.01696832f, 0.13733830f, 0.10681114f, 0.39420816f, 0.36234346f, -0.17722461f, 0.00392833f, 0.24286179f, 
    0.16101889f, 0.10250950f, 0.05291183f, 0.02546536f, 0.08706530f, 0.08224415f, 0.01589403f, 0.02394746f, 
    0.08934809f, -0.04184126f, -0.24157630f, 0.33813271f, 0.12320376f, 0.04118674f, 0.02960512f, 0.02677891f, 
    0.10139851f, -0.06353719f, -0.02432369f, -0.06440330f, -0.45937079f, -0.37322554f, -0.13107300f, -0.02075035f, 
    0.07283266f, 0.09080724f, 0.03129565f, -0.01412921f, 0.08609947f, -0.04647858f, -0.01092274f, -0.01637047f, 
    -0.06877477f, -0.02699115f, -0.51780611f, -0.33552349f, 0.11189799f, 0.04028654f, 0.04358783f, 0.07244223f, 
    0.16378753f, 0.01347118f, -0.04042683f, -0.09826061f, -0.20283101f, -0.66753465f, 0.47206625f, 0.08301128f, 
    -0.02211777f, 0.05610770f, -0.12163041f, -0.05351009f, -0.16745304f, 0.09722605f, -0.18350203f, -0.34587231f, 
    -0.28024510f, -0.02432786f, 0.11966046f, 0.17029834f, -0.18250801f, 0.07290419f, 0.02114584f, 0.13650027f, 
    0.08804020f, 0.06969210f, -0.01822106f, 0.25657365f, -0.22464339f, 0.00574898f, 0.02142266f, -0.00939879f, 
    0.08219074f, -0.14938985f, -0.00900388f, -0.16079569f, -0.26443419f, -0.21155407f, -0.15660992f, -0.01033458f, 
    -0.33673424f, -0.16918071f, -0.28665805f, -0.03267433f, -0.05618202f, 0.00131893f, -0.16656099f, 0.07479165f, 
    -0.06480817f, -0.08254571f, -0.12256330f, -0.32953799f, -0.06500601f, 0.11633971f, -0.10023447f, 0.14779626f, 
    -0.13359815f, 0.03628878f, -0.06511422f, -0.26090789f, 0.10000475f, -0.09966289f, -0.03281249f, -0.08639621f, 
    0.21215004f, -0.62913817f, 0.21663834f, 0.14933300f, -0.18820831f, -0.04340583f, 0.00575932f, -0.20403515f, 
    -0.41871029f, 0.12429195f, -0.04152290f, 0.12056201f, 0.23763333f, 0.00901748f, 0.03359346f, 0.12234062f, 
    0.02450243f, 0.01466766f, 0.07205541f, -0.04731881f, -0.10733207f, -0.21964160f, -0.17431122f, -0.13988134f, 
    0.12175389f, 0.14684732f, -0.05647571f, -0.12267250f, 0.24773358f, -0.10634804f, 0.01982820f, 0.04423291f, 
    0.07533640f, -0.02951704f, -0.06240736f, -0.20854913f, 0.10794188f, 0.31332639f, 0.20765880f, 0.03982081f, 
    0.08002961f, 0.05913603f, 0.05268035f, 0.16254757f, -0.00056769f, -0.13035321f, -0.14597714f, -0.07480633f, 
    0.16297431f, -0.06433310f, 0.10626142f, -0.00229413f, 0.04014050f, -0.15845796f, -0.18125530f, -0.16471854f, 
    -0.08046901f, -0.10153583f, -0.07034972f, -0.12663496f, 0.01483488f, -0.13600315f, -0.07435123f, -0.02395293f, 
    0.04951370f, 0.03803919f, 0.08648601f, 0.00468141f, -0.07822850f, -0.14056486f, 0.01016453f, 0.14257930f, 
    -0.97589767f, 0.18089615f, -0.35931671f, -0.11693606f, 0.21065997f, -0.16360873f, 0.09047920f, 0.15451664f, 
    0.02205896f, 0.06391731f, -0.11427856f, -0.17070067f, 0.03409338f, 0.05602228f, -0.03666809f, -0.18002127f, 
    -0.00025789f, -0.17300247f, 0.06683243f, -0.00027672f, -0.01354938f, 0.10081508f, 0.12888570f, 0.12471550f, 
    0.04604329f, 0.08855534f, 0.15893950f, 0.12101097f, -0.16555724f, -0.17855288f, 0.17188628f, 0.19933544f, 
    -0.06230700f, -0.01585242f, 0.11600222f, -0.09272043f, 0.08722831f, 0.34011477f, 0.00836259f, -0.00378565f, 
    0.04620470f, -0.08906963f, 0.06392766f, -0.06546069f, -0.07654346f, -0.22304113f, 0.16674243f, 0.01734226f, 
    0.37204492f, -0.36335221f, -0.25251490f, -0.29336262f, -0.11770819f, -0.00737489f, -0.07104440f, 0.03572652f, 
    0.12096047f, 0.06958816f, 0.03727742f, -0.10052828f, 0.04419732f, 0.11283529f, -0.08714484f, -0.11495532f, 
    0.27145618f, 0.30018902f, 0.15326232f, -0.06005028f, 0.05162406f, -0.04582383f, 0.06475544f, 0.08658297f, 
    -0.23463058f, 0.16975804f, -0.12893811f, -0.07496323f, 0.03705027f, -0.12907189f, -0.10980713f, 0.12928368f, 
    0.10899788f, -0.27433893f, -0.01135778f, -0.10933278f, 0.09979268f, 0.15306704f, -0.17541853f, -0.26393938f, 
    0.04125164f, -0.10485774f, 0.11382964f, 0.17481415f, 0.12096174f, -0.03115898f, 0.07509099f, 0.26261884f, 
    -0.23581167f, -0.33848229f, 0.30155677f, -0.13646919f, 0.19846106f, -0.03226595f, -0.11506546f, 0.13648196f, 
    -0.02470038f, -0.09274843f, 0.00684332f, -0.08536634f, -0.74105078f, -0.36137256f, -0.15795915f, -0.33397421f, 
    0.04221664f, -0.01318404f, -0.01898534f, -0.15355000f, 0.10358144f, 0.02333801f, 0.19054154f, -0.10208734f, 
    -0.35333306f, 0.23654911f, 0.21868420f, -0.21122234f, -0.03807780f, -0.14864391f, -0.03062004f, 0.04717528f, 
    0.02156063f, -0.13401289f, 0.09088781f, 0.08853262f, -0.09233740f, 0.08846550f, 0.04261147f, 0.06311786f, 
    0.22903818f, -0.06552684f, 0.03567857f, -0.01232028f, 0.20874791f, -0.09409337f, 0.04440325f, 0.12028911f, 
    -0.07673769f, 0.33173645f, -0.32975104f, -0.12918672f, 0.04654742f, -0.04723574f, 0.01628823f, -0.04529835f, 
    0.08902723f, -0.15769313f, 0.08548375f, 0.30937368f, 0.14415973f, 0.30304375f, -0.00551671f, -0.00676568f, 
    0.30608377f, -0.01991892f, -0.06294462f, -0.14776289f, 0.12914507f, 0.06805815f, -0.06414410f, 0.13361348f, 
    -0.09376272f, 0.23180412f, -0.30930969f, -0.18751778f, -0.11331646f, 0.06182713f, -0.08748470f, -0.13186404f, 
    0.22056593f, -0.07809184f, -0.10572627f, 0.12781487f, 0.17470768f, -0.10696605f, 0.45347545f, -0.02719717f, 
    0.06653976f, -0.08648519f, -0.08475083f, -0.29940635f, 0.02490168f, -0.05734031f, 0.03244654f, 0.06560067f, 
    -0.21479525f, -0.25055179f, 0.06705739f, 0.11523562f, 0.09855749f, -0.08326905f, -0.09289452f, 0.05920886f, 
    0.07955541f, -0.14921464f, 0.20805015f, -0.22368172f, -0.04098595f, -0.18567200f, -0.39070252f, 0.28654847f, 
    -0.06900251f, -0.11842790f, 0.07423657f, 0.15038154f, 0.07160030f, -0.04121007f, -0.07257956f, -0.10777722f, 
    -0.42237297f, 0.06492870f, -0.14273778f, 0.30294827f, 0.30686811f, -0.06110258f, -0.12376556f, 0.07867916f, 
    0.03226300f, 0.06390102f, -0.00308546f, 0.10928780f, -0.46129268f, -0.57887816f, -0.48518935f, 0.26072431f, 
    0.03509246f, 0.06903256f, -0.05174038f, -0.04967058f, -0.02861159f, 0.11592421f, -0.00997713f, -0.14804901f, 
    0.24503970f, 0.22579296f, -0.51943254f, 0.00517027f, 0.01045963f, 0.11580395f, -0.13089709f, -0.03348585f, 
    0.14050521f, -0.34718120f, 0.21912234f, -0.27171624f, 0.01175054f, 0.32859969f, -0.06029917f, -0.09184113f, 
    -0.17788272f, -0.18771288f, 0.19459598f, -0.01123381f, 0.00243886f, -0.05043782f, -0.00850694f, 0.16183203f, 
    -0.12949519f, 0.13765308f, -0.02522756f, -0.57873476f, 0.05355049f, -0.19506636f, -0.12960403f, 0.04097446f, 
    -0.03627292f, -0.37634173f, -0.37187904f, -0.16642034f, -0.00937975f, -0.11728468f, -0.22711113f, -0.25524920f, 
    0.02268979f, 0.07606181f, -0.13327566f, -0.01237002f, 0.24725664f, -0.03943939f, 0.06638834f, -0.12549409f, 
    -0.00456652f, -0.08389045f, -0.29625550f, 0.41792729f, -0.06290941f, -0.03929562f, -0.03592482f, -0.04668429f, 
    -0.14913641f, 0.19079445f, -0.05287209f, 0.18467590f, -0.03830228f, -0.05087414f, -0.08033250f, 0.05594298f, 
    0.04051245f, -0.11273072f, 0.32528427f, 0.08341313f, 0.01452868f, 0.28261316f, -0.00613248f, -0.06230571f, 
    -0.56585455f, 0.03073424f, 0.28641242f, -0.01737523f, 0.04094123f, -0.19812514f, 0.00818965f, 0.25248805f, 
    0.13105966f, 0.08687748f, -0.22441180f, -0.07332159f, -0.14953166f, -0.21824391f, -0.00624322f, 0.08053786f, 
    -0.34693140f, -0.10330082f, -0.10997629f, -0.00349875f, 0.17374416f, -0.04828512f, 0.09488466f, 0.14340110f, 
    -0.29211357f, 0.07450942f, -0.20879281f, -0.32897884f, 0.08905275f, 0.32420859f, -0.11445010f, 0.16414128f, 
    -0.16833644f, 0.04197779f, -0.03676455f, -0.24669145f, 0.18208329f, 0.18095000f, -0.00722063f, 0.11339793f, 
    0.31116250f, 0.07629905f, 0.10209514f, 0.25812015f, 0.13389242f, 0.00279089f, 0.10084932f, 0.04999236f, 
    0.35499477f, -0.11421507f, 0.04560794f, -0.02243115f, 0.07041693f, 0.03310388f, -0.09100404f, 0.27903190f, 
    0.03773932f, -0.05576508f, 0.01873110f, -0.05021460f, -0.15280816f, -0.08897084f, -0.03151969f, 0.14246669f, 
    0.05880662f, -0.03733483f, -0.00317952f, 0.05134065f, -0.00274999f, 0.05530991f, 0.13490514f, 0.02610953f, 
    -0.04798647f, -0.18227680f, 0.14618403f, 0.11681909f, 0.09666996f, -0.02872388f, -0.00178060f, 0.03432892f, 
    0.11766210f, 0.08885191f, -0.03573927f, -0.01340733f, -0.05929029f, -0.21509460f, -0.22862473f, -0.08901189f, 
    -0.17616877f, 0.13611855f, 0.14212555f, 0.12433211f, 0.06191561f, -0.05690965f, -0.00829092f, -0.07434157f, 
    -0.77694350f, -0.46045551f, 0.02227894f, 0.44017494f, -0.09869169f, 0.15565136f, 0.14489733f, 0.02027538f, 
    0.07609999f, 0.02212070f, 0.11108218f, -0.05935673f, -0.16554368f, -0.60712492f, 0.06044846f, -0.12544735f, 
    -0.08378198f, 0.26880574f, 0.09055845f, -0.30863395f, 0.07821576f, -0.08297276f, 0.08899189f, 0.02732210f, 
    0.55541706f, 0.50169009f, -0.37113219f, 0.50249410f, 0.11649580f, -0.01071721f, 0.14010254f, 0.08160269f, 
    0.28819224f, -0.03334080f, 0.19996704f, -0.04458466f, -0.75527126f, -0.72052276f, -0.56695133f, -0.41424656f, 
    -0.33658785f, -0.35921231f, -0.22523151f, -0.51775569f, 0.00741605f, -0.00316472f, -0.07154141f, 0.03847149f, 
    -0.68266964f, 0.52808398f, 0.38995206f, 0.04661771f, -0.09463977f, -0.02763003f, -0.07639674f, 0.10352483f, 
    0.01461340f, 0.18921885f, 0.21501240f, -0.04055017f, -0.25369984f, -0.22117771f, 0.00350653f, -0.06738189f, 
    -0.19617909f, 0.03042730f, -0.13322784f, 0.19775420f, -0.02552577f, -0.06175154f, 0.06893533f, -0.10451363f, 
    -0.27028984f, -0.54115635f, -0.51788294f, 0.12671953f, -0.02782954f, 0.31233504f, 0.25743097f, 0.09191892f, 
    0.07957033f, -0.02003187f, 0.04415938f, 0.06260896f, -0.64750403f, 0.10281343f, 0.63833684f, 0.40329036f, 
    0.04534224f, -0.03563597f, -0.26384586f, -0.11725449f, -0.11370295f, 0.14743610f, -0.10665920f, 0.05845151f, 
    -0.59135556f, -0.85240597f, -0.24718840f, -0.02228954f, -0.06149386f, -0.01482663f, 0.04716397f, 0.01197625f, 
    -0.00129342f, 0.03916481f, 0.07296512f, -0.04901889f, 0.08309867f, -0.09555037f, 0.02187305f, 0.14763178f, 
    -0.02270290f, -0.09804684f, 0.02336528f, 0.03378185f, -0.05818074f, -0.06267925f, 0.16872960f, -0.28592366f, 
    0.15326497f, -0.26952708f, -0.01105625f, 0.27538538f, -0.01989278f, -0.12207972f, 0.08475890f, 0.06022354f, 
    0.02759860f, 0.04014854f, -0.03703704f, -0.06601349f, -0.74779457f, -0.67703581f, -0.59777021f, -0.28429714f, 
    -0.26685479f, -0.29272696f, -0.09594049f, -0.43308821f, -0.02970305f, 0.08933115f, -0.03688423f, 0.07663257f, 
    -0.50891960f, 0.10218871f, 0.36235091f, -0.62548923f, -0.01532930f, -0.11870156f, 0.02466440f, -0.03583030f, 
    0.05185241f, 0.07493252f, 0.12865427f, -0.06718493f, -0.56412530f, -0.37378517f, -1.09142292f, 0.23176707f, 
    -0.22396368f, 0.23504370f, 0.04798130f, -0.34569374f, 0.02387763f, -0.00518219f, 0.09331008f, 0.00830483f, 
    0.04686987f, -0.01721400f, 0.04454107f, -0.03171926f, -0.00097215f, 0.04555430f, -0.03347203f, 0.09051207f, 
    0.16132574f, 0.12616563f, 0.24613059f, 0.12645398f, 0.03290480f, -0.33153826f, -0.14824893f, 0.10508714f, 
    -0.01331341f, 0.17816998f, 0.14281315f, -0.18787444f, 0.07145543f, -0.07622593f, 0.03274436f, 0.03366180f, 
    -0.14419764f, -0.10209452f, -0.14712414f, -0.43564609f, -0.12813519f, 0.15079571f, 0.12745470f, -0.09082649f, 
    -0.10313435f, 0.04564889f, 0.04080563f, 0.06315903f, -0.11111460f, -0.03835737f, -0.25014803f, -0.30829006f, 
    0.04221711f, 0.03248083f, -0.12120870f, -0.02761808f, 0.01751948f, 0.01667948f, -0.03547585f, -0.11643236f, 
    -0.02694083f, 0.11611032f, -0.01111040f, -0.43268117f, 0.02145728f, 0.05844280f, -0.04624444f, -0.03650108f, 
    -0.01456267f, 0.11672164f, 0.02316055f, -0.06632817f, -0.10541322f, -0.15512198f, 0.24714535f, 0.15796526f, 
    0.08005054f, -0.27366135f, -0.02666870f, 0.01588291f, -0.23416439f, 0.13977346f, -0.10208673f, 0.19779597f, 
    -0.00323762f, -0.41017696f, 0.05356386f, -0.09688623f, -0.24484889f, -0.02254493f, 0.10236713f, -0.03639755f, 
    0.03897475f, 0.14773829f, 0.11484288f, 0.07283317f, 0.44968209f, 0.46284688f, -0.30805710f, 0.22295322f, 
    0.09980531f, -0.15462899f, 0.17567658f, 0.24357726f, -0.01506433f, 0.04084067f, 0.01551693f, 0.11413155f, 
    0.08074734f, 0.06709078f, 0.19207335f, 0.22208355f, -0.31785932f, 0.02072070f, 0.01543801f, 0.15786654f, 
    -0.03463089f, 0.07822961f, -0.27699545f, -0.12447134f, 0.37313718f, 0.00300391f, -0.39695647f, -0.14243516f, 
    -0.23314096f, 0.08461966f, -0.09403278f, -0.01770496f, 0.00644560f, 0.00943452f, -0.02864072f, -0.25365484f, 
    -0.03513746f, -0.33527395f, 0.09240761f, 0.17293161f, 0.23881774f, 0.03125449f, 0.10170684f, 0.17302942f, 
    -0.00672435f, 0.18804233f, 0.09084716f, 0.03995231f, -0.20981140f, -0.22345845f, 0.07095162f, -0.17279772f, 
    -0.26523316f, -0.48545757f, -0.08794130f, 0.06906691f, -0.06116412f, 0.06254013f, -0.04177489f, -0.28251761f, 
    -0.11758945f, -0.17171775f, 0.17117527f, -0.15671510f, 0.12481686f, 0.03640586f, 0.16128236f, -0.10843082f, 
    0.04079770f, 0.07206438f, 0.05379082f, 0.17720388f, -0.83618200f, -0.72593880f, -0.44238228f, -0.14738384f, 
    0.09196877f, -0.01865245f, -0.01992682f, -0.49393874f, 0.03170687f, -0.04086077f, -0.02194123f, 0.07024467f, 
    0.25977188f, 0.35019279f, -0.36713377f, -0.24584657f, -0.30760959f, -0.07993863f, 0.04838721f, 0.26236814f, 
    -0.05288296f, 0.05997442f, -0.15017703f, -0.04389110f, 0.13911353f, -0.06280139f, -0.11124083f, 0.03543736f, 
    -0.03506338f, 0.01291144f, 0.03644646f, 0.07175975f, -0.11499767f, -0.09288778f, -0.03264915f, 0.09476877f, 
    0.23264246f, 0.17614534f, 0.05399803f, -0.03939543f, -0.03965236f, 0.21458057f, -0.34986871f, -0.07947627f, 
    0.08419588f, -0.03948734f, -0.04477002f, -0.01594887f, 0.02877892f, -0.02362558f, -0.01265132f, -0.03306860f, 
    0.20457251f, 0.06873411f, 0.00133243f, -0.06571147f, 0.00194684f, -0.03646920f, -0.02353779f, 0.00918226f, 
    0.03412576f, -0.27323759f, -0.45868626f, -0.02163831f, 0.11459499f, 0.04818517f, 0.15194216f, 0.10722898f, 
    -0.05315832f, -0.02517617f, -0.07996317f, 0.01402096f, -0.91833013f, 0.22989096f, 0.06503963f, 0.22517547f, 
    0.10974074f, -0.18347399f, -0.05991222f, 0.08921686f, -0.09630134f, -0.06040279f, 0.02499823f, -0.12305094f, 
    -0.23031208f, -0.23878866f, 0.23754513f, -0.12768196f, -0.01531366f, 0.08957485f, 0.07701217f, -0.07601131f, 
    -0.23475292f, 0.01206040f, 0.04937367f, -0.06241814f, -0.46512145f, -0.47645456f, -0.47414625f, -0.11284620f, 
    0.16310434f, -0.18381956f, -0.11724012f, 0.04935453f, -0.01481553f, 0.04275430f, -0.04862091f, 0.04661214f, 
    0.67626017f, -0.11861138f, -0.19878203f, -0.27419958f, 0.02495633f, -0.08380251f, 0.07144985f, -0.13267545f, 
    0.10741514f, 0.08228081f, -0.05514089f, 0.09273502f, -0.35202333f, 0.03520690f, -0.40438318f, 0.03247453f, 
    0.25581670f, -0.37146947f, 0.18182649f, -0.19517803f, 0.03605267f, 0.00265130f, -0.02599736f, -0.11031725f, 
    0.16760688f, -0.10262012f, -0.13138555f, -0.03209300f, -0.11267763f, -0.04512628f, 0.04816222f, -0.04972295f, 
    0.03879536f, 0.06616603f, 0.08215234f, -0.01079711f, 0.64552259f, -1.04864216f, -0.79370630f, -0.93727344f, 
    0.02319855f, -0.20082626f, -0.19208187f, 0.12910438f, 0.07842696f, 0.04155558f, 0.12987560f, 0.08613282f, 
    -0.16243663f, -0.34354407f, -0.15349802f, -0.43432394f, -0.01911156f, 0.03893859f, -0.03346028f, 0.18988661f, 
    0.04324639f, 0.01205553f, -0.08582938f, -0.13242762f, -0.03830482f, -0.02776925f, 0.01747625f, 0.02265272f, 
    -0.01849556f, -0.00308112f, -0.02358103f, -0.05220752f, -0.06546737f, -0.02335797f, -0.11500482f, -0.07958747f, 
    -0.63117760f, 0.13609472f, -0.03027537f, 0.33586961f, 0.02070905f, 0.07209112f, 0.23868410f, -0.01103271f, 
    0.12594743f, -0.02421973f, 0.03930670f, -0.04471501f, -0.49336472f, 0.00792582f, -0.00732073f, 0.28503972f, 
    0.10015451f, -0.06109233f, -0.05563607f, 0.13560335f, -0.08080763f, 0.01467713f, -0.18458350f, 0.00112767f, 
    -0.42872888f, 0.91967988f, -0.06341504f, 0.29831952f, 0.06756889f, -0.03297458f, 0.20980267f, -0.08882049f, 
    -0.19437832f, 0.11869404f, -0.05480640f, -0.13257934f, -0.14565741f, -0.76455200f, 0.23276864f, 0.41621742f, 
    0.02270355f, 0.15015885f, 0.23599046f, 0.07964788f, 0.04493308f, -0.03013082f, -0.13867137f, -0.00040169f, 
    0.39032578f, 0.12231358f, 0.03619297f, -0.22709399f, 0.00724518f, 0.08375017f, -0.06098948f, -0.05704912f, 
    -0.15376617f, -0.18089108f, -0.18825851f, -0.23698358f, 0.15009585f, 0.20353526f, -0.13582133f, 0.00421293f, 
    -0.01782111f, -0.10592860f, -0.06287389f, 0.04879187f, 0.07800008f, 0.12926215f, 0.03055615f, 0.07985384f, 
    -0.29020843f, 0.32341698f, -0.49709970f, 0.23952749f, -0.00687589f, 0.24974549f, -0.05957342f, -0.05355925f, 
    -0.00747156f, 0.09787162f, 0.02781574f, 0.00353012f, 0.00235160f, 0.16549020f, -0.22389105f, -0.02950662f, 
    -0.06186161f, -0.06986745f, 0.00164190f, -0.01771627f, 0.13386729f, 0.01124139f, -0.08125956f, -0.12343904f, 
    -0.17646413f, 0.09592331f, -0.04704172f, 0.10816657f, 0.03332082f, 0.06570879f, 0.09557442f, -0.02512614f, 
    0.09570610f, -0.04857993f, 0.10292210f, -0.09400576f, 0.51235360f, -0.05633279f, 0.08883789f, -0.76320338f, 
    0.04894030f, 0.05539331f, -0.03650660f, 0.16083573f, -0.05819288f, -0.07858311f, -0.09910288f, -0.22251835f, 
    -0.18525685f, -0.49187586f, -0.32992303f, -0.21472965f, 0.01746541f, 0.04923861f, 0.16697474f, 0.19068557f, 
    0.16633749f, -0.02451796f, -0.00180627f, 0.13929874f, -0.25355390f, -0.40783781f, 0.12568627f, -0.13120739f, 
    -0.32566160f, 0.08624507f, 0.14134344f, 0.05541559f, 0.00676703f, -0.17333062f, -0.00480841f, -0.07613368f, 
    -0.03971871f, 0.03547073f, -0.08391361f, -0.12846762f, -0.16250767f, 0.08889701f, 0.02645345f, -0.12308408f, 
    -0.02008260f, -0.06849391f, -0.05430780f, -0.19130543f, -0.17346430f, -0.27804360f, 0.07773581f, 0.07388287f, 
    -0.22476940f, 0.08002841f, -0.08818015f, -0.05900785f, 0.07125948f, -0.06838740f, 0.02571296f, 0.07177759f, 
    0.28713661f, -0.08736040f, 0.08761034f, -0.26011500f, -0.00966122f, -0.03899229f, -0.22365907f, 0.05051898f, 
    -0.18212821f, -0.05023016f, 0.08375362f, -0.09125837f, 0.31740630f, -0.08944912f, -0.12484253f, 0.01131160f, 
    -0.10341607f, 0.22586805f, 0.04920411f, 0.02765944f, -0.03719449f, -0.03347609f, 0.08959749f, 0.03844766f, 
    -0.01795697f, 0.30040830f, 0.35720485f, -0.08461295f, -0.12852040f, -0.00177903f, 0.11352785f, -0.01410849f, 
    -0.08860149f, -0.15325019f, 0.08710270f, 0.10174142f, -0.92789257f, 0.41398945f, 0.04124774f, 0.30241540f, 
    0.17084458f, -0.21939152f, -0.07808124f, 0.03848222f, -0.06975007f, -0.05152984f, -0.10990414f, 0.00172272f, 
    -0.51434976f, -0.27908376f, -0.15650044f, -0.06468102f, -0.13042839f, 0.06850271f, -0.06394807f, 0.08386208f, 
    -0.13507336f, 0.07363048f, 0.01871595f, 0.00600613f, 0.08014431f, -0.01570788f, 0.03749115f, -0.18302087f, 
    0.02398820f, -0.08455140f, 0.01104109f, -0.06078679f, 0.05482881f, -0.03750817f, 0.05682280f, -0.06713089f, 
    -0.21651037f, -0.07687329f, -0.15001352f, 0.10446909f, -0.00341223f, 0.12951563f, -0.16579619f, 0.09663117f, 
    0.08336163f, 0.12300227f, -0.03133794f, -0.14960392f, -0.04116758f, -0.22623818f, -0.24828796f, -0.23821704f, 
    0.06506162f, 0.34567195f, 0.00917508f, 0.22755608f, -0.06000312f, -0.05907824f, -0.01625222f, -0.09407911f, 
    0.07723398f, -0.22317302f, -0.46330419f, -0.01414051f, 0.22808065f, 0.01708372f, 0.14140373f, 0.07595331f, 
    0.00959198f, -0.10958134f, -0.06063308f, -0.10972398f, -0.43046165f, -0.32135096f, -0.10060969f, 0.07280578f, 
    0.20798159f, 0.27089110f, 0.00858286f, -0.07537808f, -0.06265958f, 0.01889836f, -0.10834145f, -0.05115422f, 
    -0.63253218f, 0.12344977f, 0.10495482f, 0.06653874f, 0.07702084f, 0.12795965f, -0.06138704f, -0.03023649f, 
    -0.03063161f, 0.10943780f, -0.02866598f, 0.09271602f, -0.34080920f, -0.76408046f, -0.67731506f, -0.12167497f, 
    -0.03749568f, 0.01367360f, -0.02504892f, -0.03684715f, -0.07864778f, -0.00811700f, 0.04907666f, 0.07776752f, 
    0.09556495f, -0.49137124f, -0.39851886f, -0.44493735f, -0.02453327f, 0.12366630f, 0.18327582f, 0.04181061f, 
    0.13958110f, -0.28444213f, -0.02223993f, -0.12139279f, -0.05989048f, -0.28102788f, 0.06792741f, 0.11526068f, 
    -0.09214801f, 0.29213977f, 0.03169545f, 0.03365889f, 0.04823158f, -0.07380920f, 0.12730505f, 0.00686866f, 
    0.13480964f, 0.19069594f, 0.15970811f, -0.26698598f, -0.15444691f, -0.04965779f, -0.07059246f, -0.32275766f, 
    -0.05069675f, 0.04379493f, -0.06548017f, -0.04222723f, -0.72074908f, -0.73431695f, -0.50561279f, 0.43484566f, 
    0.02529731f, 0.27603537f, 0.07370105f, 0.11565488f, -0.07861961f, 0.09829886f, 0.07966135f, 0.13291408f, 
    0.03812890f, -0.18321392f, -0.48267865f, -0.20422648f, 0.04913788f, 0.00188869f, 0.04349633f, -0.12899749f, 
    0.01111299f, -0.02532900f, -0.07186759f, -0.07131445f, -0.10618174f, -0.06777988f, 0.01815702f, 0.08221296f, 
    0.11262444f, 0.00746360f, 0.03792403f, -0.00451014f, 0.12108742f, -0.00129873f, 0.21103200f, 0.00047839f, 
    -0.54067171f, -0.23397996f, 0.21676064f, 0.48770356f, -0.12641674f, 0.09289050f, -0.11783604f, -0.11943625f, 
    -0.21279992f, -0.04326227f, 0.06504440f, 0.05344595f, -0.27003360f, -0.29616043f, -0.68541175f, -0.56632698f, 
    -0.26599988f, -0.23253104f, -0.13488874f, -0.04427555f, 0.15491834f, 0.06247964f, 0.11279015f, 0.06682502f, 
    -0.65961218f, -0.15493599f, -0.03918131f, 0.21988307f, -0.01525354f, 0.19940771f, 0.05710351f, 0.02760553f, 
    0.19460629f, 0.10436497f, 0.14031878f, 0.34599781f, 0.35461584f, 0.15117630f, -0.19015680f, -0.09622470f, 
    -0.03915164f, -0.15007667f, -0.08493097f, -0.20866069f, -0.00491740f, 0.03681530f, -0.05442652f, -0.06946618f, 
    0.18061499f, -0.06950188f, -0.32203355f, -0.38330913f, -0.02660910f, 0.03452329f, -0.04253810f, -0.13800754f, 
    0.14498867f, 0.13164376f, 0.04482686f, -0.05826592f, -0.62663770f, 0.00928140f, 0.16187188f, -0.00412102f, 
    -0.08890210f, -0.00008467f, -0.18496589f, -0.19697756f, -0.32121527f, -0.08542828f, -0.09254398f, -0.19222163f, 
    0.06253579f, 0.34872288f, 0.17308566f, 0.23799071f, 0.09226575f, -0.26704562f, -0.14691852f, 0.06917232f, 
    0.17636773f, -0.08737473f, 0.10541587f, 0.07855240f, -0.36944988f, 0.12556005f, -0.21390751f, -0.08035915f, 
    -0.13306719f, -0.05772216f, -0.02988854f, -0.09292810f, 0.00298304f, 0.11884978f, 0.02053077f, 0.05092912f, 
    -0.82696939f, 0.11595275f, 0.04216162f, 0.23882847f, -0.10659821f, -0.05378814f, -0.12414550f, 0.02236114f, 
    -0.04123588f, 0.00550821f, -0.06967843f, 0.12166763f, 0.34287569f, 0.40137351f, -0.35236031f, -0.05691389f, 
    -0.31836292f, -0.20343816f, -0.03724940f, 0.02805295f, 0.16226222f, 0.01472158f, 0.20957814f, 0.29593968f, 
    0.22997336f, -0.24377719f, -0.12498273f, 0.15021524f, -0.03250765f, 0.08130077f, -0.00638836f, -0.13349584f, 
    -0.06116867f, -0.03089404f, -0.11595111f, -0.80746704f, -0.63141084f, -0.53427917f, 0.18716995f, 0.55526966f, 
    0.17530897f, 0.17092539f, 0.10000871f, 0.05571223f, 0.07758804f, 0.04297509f, 0.06745661f, 0.24445619f, 
    -0.10279860f, 0.13964292f, -0.11575124f, 0.14193478f, 0.03403252f, -0.00812193f, -0.03700230f, 0.00542529f, 
    0.13423002f, -0.01095262f, 0.10942069f, -0.02729154f, -0.25172529f, 0.16077684f, -0.17354153f, 0.06352668f, 
    0.29898053f, 0.00183068f, -0.12278882f, 0.08882669f, -0.14659104f, 0.12628426f, 0.17576611f, 0.22530091f, 
    0.16649263f, 0.04410392f, -0.09395099f, -0.16677544f, 0.03815874f, -0.01664847f, 0.02419177f, 0.01758978f, 
    -0.07626565f, -0.00627445f, 0.08537627f, -0.03649291f, -0.05738095f, -0.15439324f, -0.33168909f, -0.23048785f, 
    0.10556296f, 0.12503020f, -0.00379473f, 0.08885549f, 0.21382603f, 0.16724129f, 0.16097073f, 0.32152453f, 
    -0.56888741f, -0.20085815f, -0.03054141f, 0.20869371f, 0.12165260f, 0.11876772f, -0.27624583f, -0.17043528f, 
    0.00829517f, -0.18963252f, -0.09680555f, 0.04629521f, 0.14201194f, 0.06321260f, 0.16441144f, 0.25694895f, 
    -0.03783248f, -0.10851038f, -0.04765431f, -0.30313393f, -0.01647924f, 0.11382889f, 0.06442302f, 0.09538203f, 
    0.32139111f, -0.22100669f, -0.27600110f, 0.11361746f, 0.08023102f, 0.03563166f, 0.14324684f, 0.14478719f, 
    0.09058997f, -0.08256063f, -0.00788653f, 0.05912481f, 0.09920013f, 0.04341590f, 0.08410297f, -0.22175820f, 
    0.06376494f, -0.01006404f, -0.00470873f, 0.01435535f, -0.00577549f, -0.09241696f, -0.03099028f, 0.05556408f, 
    -0.46033391f, 0.25676233f, -0.34529993f, -0.01027393f, -0.27317178f, 0.04677381f, -0.01846061f, -0.36624348f, 
    0.15587580f, -0.14554934f, 0.07256717f, -0.05930497f, 0.07729813f, -0.09082320f, 0.14106043f, 0.06901284f, 
    -0.01342688f, 0.03187743f, -0.09418414f, -0.09680900f, 0.07698690f, -0.03793941f, -0.09072278f, 0.01469707f, 
    -0.26313898f, -0.02450769f, 0.16381356f, -0.27720329f, 0.02335079f, -0.20664380f, -0.02959494f, -0.03832591f, 
    0.10085254f, 0.03568505f, 0.10515029f, 0.08425124f, 0.34372425f, 0.12352312f, -0.04912366f, -0.34778112f, 
    0.05443872f, -0.10934013f, 0.07174615f, 0.35811836f, 0.05907911f, 0.08230786f, -0.19239566f, -0.01955470f, 
    0.15157031f, -0.14548509f, 0.24274151f, -0.83084959f, -0.12390073f, -0.26707900f, 0.02895756f, -0.05760260f, 
    -0.19850296f, 0.13146929f, 0.16080216f, -0.17382351f, -0.16400801f, 0.07533852f, -0.01132358f, -0.22738731f, 
    0.09734465f, -0.29745281f, 0.03600316f, 0.29224417f, -0.02950002f, 0.05382467f, 0.05863620f, 0.02544694f, 
    0.24370067f, 0.12512130f, 0.57137060f, 0.52043265f, 0.16159081f, -0.26126871f, -0.23673131f, -0.26202336f, 
    -0.10349830f, 0.05994843f, 0.14410174f, 0.09072325f, 0.03698543f, -0.32061216f, -0.04371380f, -0.39462200f, 
    0.20466065f, -0.14820705f, -0.01166882f, 0.09751517f, -0.13642599f, -0.05947831f, -0.12545741f, 0.14364515f, 
    0.28950241f, -0.56398028f, -0.28822881f, 0.04618782f, 0.19275977f, 0.37291726f, 0.26274616f, -0.03356015f, 
    -0.04453074f, -0.09967617f, -0.02988213f, -0.07222832f, 0.22029229f, 0.09128249f, 0.08211545f, -0.44751212f, 
    -0.17809619f, -0.15641363f, -0.26599625f, 0.00778201f, -0.00828866f, -0.11316448f, 0.11090464f, 0.16807795f, 
    -0.03278673f, 0.08797856f, -0.03745139f, 0.02176295f, -0.11864707f, -0.01665594f, 0.03933778f, -0.02710532f, 
    0.09129038f, 0.11219615f, 0.03083011f, -0.05470771f, 0.17222215f, -0.28881714f, -0.13958822f, -0.14407919f, 
    0.03438324f, 0.11464197f, 0.02146496f, 0.09531647f, 0.03158893f, -0.20806198f, -0.03184237f, -0.06760950f, 
    -0.38853639f, 0.30644011f, 0.37568343f, -1.03018486f, -0.03437950f, 0.02351173f, 0.22381040f, 0.04016230f, 
    -0.01685412f, 0.14694333f, -0.12546517f, -0.22907254f, -0.53876829f, 0.04212946f, -0.07824766f, 0.25279123f, 
    -0.14205225f, 0.03598192f, 0.10028036f, 0.13396928f, -0.07219495f, 0.07910998f, 0.06627429f, -0.10513445f, 
    -0.20137733f, -0.14280747f, -0.08331853f, -0.61955327f, 0.19268650f, 0.01889616f, 0.00938516f, 0.15919846f, 
    -0.09312662f, 0.12189182f, 0.03963195f, -0.07609794f, -0.16782108f, -0.28336102f, 0.02849549f, -0.04857549f, 
    -0.06116020f, -0.18205999f, 0.12102121f, 0.08890674f, 0.00439929f, 0.00461984f, -0.03956253f, -0.08540244f, 
    -0.08302972f, -0.00410976f, 0.10806301f, 0.46153441f, 0.04668529f, 0.03250045f, -0.02472749f, -0.21332066f, 
    0.15018171f, -0.02080599f, -0.03143348f, -0.00189638f, -0.06909961f, -0.33517525f, 0.03418180f, -0.11439606f, 
    0.11376595f, 0.16588098f, -0.03039649f, 0.17138824f, 0.07869893f, 0.00975933f, -0.12608026f, 0.26248413f, 
    -0.83009130f, 0.00495684f, -0.85390532f, 0.28384900f, 0.03334930f, -0.04396001f, 0.12872981f, -0.04552580f, 
    -0.01679568f, -0.14135146f, 0.00438120f, -0.01606417f, -0.19091572f, -0.35024205f, 0.21667333f, 0.05997156f, 
    0.15771644f, 0.09082591f, 0.03084530f, -0.05470512f, 0.14153609f, -0.06451274f, -0.06426972f, -0.11736418f, 
    -0.20719154f, 0.01010592f, -0.28278884f, -0.08289697f, 0.09372986f, -0.01579788f, 0.14141315f, 0.03150681f, 
    0.13554195f, 0.02897650f, 0.08457776f, -0.10469731f, -0.15089835f, -0.30034551f, 0.35397673f, 0.29347339f, 
    0.23049150f, 0.06792074f, -0.08996821f, 0.28241497f, 0.03094445f, 0.00757770f, 0.00804115f, -0.02725375f, 
    0.13098834f, 0.07157716f, 0.04782914f, 0.05666266f, 0.02456998f, 0.03408465f, -0.08721806f, 0.00535339f, 
    0.19950132f, 0.05513971f, 0.18378425f, 0.13748567f, 0.16199331f, 0.00604752f, 0.59325033f, -0.85580391f, 
    -0.05015360f, -0.17644420f, 0.03259393f, -0.24153219f, -0.20725001f, -0.08947596f, 0.00437789f, 0.19777857f, 
    0.11833379f, -0.15564930f, -0.15275642f, -0.14897621f, 0.26302344f, -0.02499106f, 0.16035056f, -0.12619294f, 
    -0.14901519f, 0.00896452f, -0.03164601f, -0.04759955f, 0.19404340f, 0.50105476f, -0.61536819f, 0.17711027f, 
    0.06174552f, 0.07793918f, 0.27072242f, -0.03095902f, 0.16752376f, -0.21653295f, -0.16078933f, 0.11563662f, 
    -0.64590877f, -0.85202503f, -0.01840971f, 0.15041855f, -0.08792963f, 0.20661624f, -0.29157531f, -0.08795854f, 
    0.13581945f, -0.05462143f, 0.09327918f, -0.03349657f, 0.21314159f, 0.17007139f, 0.20800537f, 0.17870599f, 
    0.11518110f, -0.15267013f, -0.15811600f, -0.05656233f, -0.07307258f, 0.06182858f, -0.15024859f, -0.09724439f, 
    0.06636900f, -0.18045866f, 0.15723668f, -0.29824832f, -0.02130838f, 0.10845807f, -0.03729942f, 0.17015159f, 
    0.10329249f, -0.07732012f, -0.04425299f, 0.05882380f, -0.24845643f, -0.28704408f, -0.48034695f, -0.03464500f, 
    -0.04926830f, -0.10243159f, 0.20694341f, 0.14248113f, -0.06781536f, -0.07475074f, -0.00983473f, -0.10085038f, 
    -0.09487983f, 0.25355741f, 0.43209958f, -0.07480937f, 0.05561265f, -0.44670999f, 0.13166912f, -0.24103166f, 
    -0.10344941f, 0.00980813f, 0.01732312f, 0.09478717f, -0.04370628f, -0.19867350f, -0.03058393f, -0.04865734f, 
    -0.02529168f, 0.11050671f, -0.04243566f, -0.06649121f, -0.04525288f, -0.15240374f, 0.12486045f, 0.01822211f, 
    0.67595756f, -0.13319381f, 0.28725001f, -0.13042235f, 0.15010621f, -0.30412331f, -0.02285721f, 0.03568769f, 
    -0.23472045f, 0.14652309f, -0.10695381f, 0.01426301f, -0.20914708f, -0.22000284f, -0.20868327f, -0.12036097f, 
    0.10279974f, -0.09499387f, -0.05935791f, -0.04174231f, -0.21260555f, 0.00340014f, -0.09741753f, -0.09985364f, 
    -0.21094857f, -0.09584148f, 0.06910829f, -0.03262710f, -0.05223745f, 0.09473335f, -0.02338586f, 0.08267518f, 
    -0.02615167f, 0.16974704f, -0.05987035f, -0.09396067f, -0.17114735f, 0.20190312f, 0.44906473f, 0.20656851f, 
    0.07347357f, -0.36680493f, -0.12947056f, 0.03065443f, -0.17766960f, -0.08216257f, -0.02354716f, -0.25107583f, 
    -0.02452992f, 0.19824073f, -0.20094946f, 0.23829712f, -0.09924059f, -0.02793670f, 0.12437142f, -0.05220256f, 
    -0.03066359f, -0.07262633f, -0.14421862f, -0.16568790f, -0.35702237f, -0.07672562f, -0.06784672f, 0.31198859f, 
    -0.18769108f, -0.04946781f, -0.03435488f, -0.16196215f, 0.15075213f, 0.10224523f, 0.12466101f, 0.10035143f, 
    -0.11730277f, 0.03254352f, 0.04096539f, 0.01742692f, -0.02515714f, 0.15628551f, -0.23368068f, 0.04984701f, 
    -0.04128527f, -0.07228379f, -0.04250264f, -0.21326701f, 0.02189423f, 0.05984774f, 0.36598104f, 0.12384910f, 
    0.03898720f, 0.09167140f, 0.21492247f, 0.09929218f, 0.25093129f, 0.12914421f, 0.02150976f, 0.15210371f, 
    -0.50419587f, -0.52460521f, 0.05440309f, -0.18532677f, -0.35400960f, -0.04518454f, 0.19655913f, -0.08405739f, 
    -0.12947947f, 0.02789668f, 0.03106033f, -0.25081354f, 0.09467275f, 0.10753752f, -0.02237405f, -0.20173338f, 
    0.04304041f, -0.13289809f, 0.07241051f, 0.05164425f, -0.12942025f, 0.19414140f, -0.06998424f, -0.26365745f, 
    -0.08912046f, -0.35804009f, -0.42727071f, -0.08140741f, -0.05994526f, 0.03173580f, 0.06543396f, 0.10731427f, 
    -0.07869193f, -0.03293236f, 0.08674990f, -0.13526611f, -0.12409820f, 0.29351217f, 0.42233822f, 0.08245909f, 
    0.08583854f, -0.05768080f, 0.14875317f, 0.08183009f, -0.17351507f, -0.04839928f, 0.27464092f, 0.20082024f, 
    0.15974376f, -0.25807592f, 0.56631851f, 0.13367519f, -0.15243281f, 0.09981995f, 0.29491434f, 0.15043430f, 
    -0.13327013f, -0.06330404f, 0.18596573f, 0.13080002f, -0.14188756f, 0.21219237f, -0.32797432f, -0.06899410f, 
    -0.19067614f, 0.03072671f, -0.21138310f, 0.04187748f, 0.13669889f, 0.15836228f, -0.06563212f, -0.04944420f, 
    0.25864762f, -0.27077588f, 0.19453579f, 0.01832098f, 0.11293339f, 0.02339862f, -0.24247824f, 0.04667965f, 
    0.22030628f, -0.19861737f, 0.08491377f, 0.08416614f, -0.24323766f, -0.18915971f, -0.50973678f, -0.20874265f, 
    0.03478691f, -0.15452193f, 0.04285032f, -0.08924364f, -0.09902280f, 0.15620558f, -0.06866521f, -0.00077382f, 
    -0.43330893f, 0.42722279f, -0.05020025f, -0.37920776f, -0.33333138f, -0.00348427f, 0.10844110f, 0.00219223f, 
    -0.07985869f, -0.24220189f, -0.47803828f, -0.27688575f, 0.29726931f, -0.64216149f, 0.26316205f, -0.14946666f, 
    -0.29411674f, 0.18572235f, 0.01460896f, -0.22506663f, 0.01003732f, -0.04264915f, -0.04965656f, -0.08207919f, 
    0.32491839f, -0.35073793f, -0.05090466f, -0.00344683f, -0.26677200f, 0.12580787f, 0.25877261f, -0.11740319f, 
    0.05370280f, 0.03803626f, 0.04568708f, 0.06329620f, -0.28207555f, -0.23221721f, -0.18894497f, 0.01968759f, 
    -0.35393402f, 0.01298834f, -0.05504608f, 0.05955328f, 0.07719122f, 0.03605099f, -0.06991888f, 0.01301406f, 
    0.16801187f, -0.19407985f, -0.08041854f, 0.01643323f, -0.13069682f, -0.01259514f, -0.11242475f, -0.12204352f, 
    -0.19633500f, -0.07149281f, -0.05151077f, 0.06801701f, -0.24796450f, 0.36055273f, 0.40862992f, 0.25398356f, 
    0.03979032f, 0.16016370f, 0.10945612f, -0.19243622f, 0.02268370f, 0.00414857f, 0.09769239f, 0.07104850f, 
    -0.02600207f, -0.03194063f, -0.09573492f, 0.01822683f, -0.06363805f, -0.05643542f, -0.13435237f, -0.15808725f, 
    -0.10793785f, 0.09871250f, -0.21763982f, -0.74850929f, -0.14377855f, 0.29281887f, -0.06303713f, 0.34440315f, 
    -0.08745130f, 0.03429559f, -0.10122082f, 0.11858453f, 0.01150428f, 0.16015050f, -0.04873667f, 0.00607869f, 
    0.01933843f, 0.39863840f, 0.37792826f, 0.00451016f, 0.12853433f, -0.09300391f, -0.07969289f, -0.03556064f, 
    -0.03923216f, 0.18074489f, 0.26354793f, 0.07236052f, -0.04716614f, 0.17419700f, -0.38229665f, -0.19701487f, 
    -0.20736499f, -0.36414120f, 0.14906400f, 0.01415987f, -0.14864086f, 0.16930746f, -0.03617328f, 0.20541686f, 
    -0.47861904f, -0.07621969f, 0.31598085f, -0.07103143f, 0.08755185f, 0.16935842f, -0.03353329f, -0.08270801f, 
    -0.02494275f, 0.07610211f, 0.01444034f, -0.08230795f, -0.04389580f, 0.21374501f, 0.11738429f, -0.00652433f, 
    -0.15279971f, 0.02156571f, 0.05002460f, -0.05813752f, 0.18633223f, 0.10477436f, 0.22138599f, 0.36971933f, 
    -0.07607233f, -0.08279407f, 0.10501076f, 0.36999345f, 0.15610252f, -0.07924937f, -0.42639706f, 0.25371280f, 
    -0.33082601f, -0.13481191f, -0.04981407f, -0.18684775f, -0.07495114f, -0.64346397f, 0.28194088f, 0.14752534f, 
    -0.15510345f, 0.21814679f, -0.03661361f, -0.04335871f, 0.07792585f, 0.01462390f, 0.24198887f, 0.20689397f, 
    -0.66001493f, 0.11468928f, 0.09010530f, 0.36677456f, 0.00090934f, -0.00855604f, -0.29221454f, 0.09504092f, 
    -0.00658897f, -0.04664812f, 0.06250910f, 0.06050237f, -0.42973959f, 0.10747112f, -0.15382627f, -0.25937471f, 
    -0.34747079f, -0.08813362f, -0.07124310f, -0.08623409f, -0.08254869f, 0.05411734f, -0.08209383f, -0.08411199f, 
    -0.06919772f, -0.19447002f, 0.16599999f, -0.14938413f, 0.06097412f, 0.19095142f, 0.28764713f, -0.09136079f, 
    -0.07876728f, -0.03759817f, 0.08972856f, 0.06268066f, 0.24351686f, 0.03907640f, -0.23262762f, 0.13170755f, 
    -0.05263925f, 0.07601213f, 0.27382401f, -0.23702003f, 0.14893414f, -0.01911446f, 0.03033611f, -0.25197035f, 
    0.26658213f, -0.22278318f, 0.09712282f, -0.70482975f, -0.07222898f, -0.27228248f, 0.12822163f, 0.00475255f, 
    0.06545686f, 0.08488186f, 0.09302480f, -0.13680500f, -0.33377755f, -0.17290585f, -0.26060364f, 0.13786843f, 
    -0.22687468f, 0.12512204f, -0.07080913f, -0.03213397f, 0.02825504f, 0.10479157f, 0.08006088f, 0.09000608f, 
    0.01956664f, -0.45605496f, 0.26160499f, 0.38705051f, 0.00903272f, 0.09057382f, 0.19174768f, 0.09760185f, 
    -0.19688706f, -0.12305644f, 0.03975818f, 0.21178757f, 0.14376922f, -0.07691968f, -0.08153049f, -0.04845878f, 
    -0.03492536f, -0.23300636f, -0.20413975f, -0.05545649f, -0.00394378f, -0.01052018f, -0.13511153f, -0.23710880f, 
    -0.55753607f, -0.40183675f, 0.01551270f, -0.11750296f, 0.08574057f, 0.00293698f, 0.07147652f, -0.00652823f, 
    0.01193247f, 0.18622361f, 0.20771863f, 0.06387035f, -0.02579325f, 0.24816348f, -0.05702475f, 0.09368328f, 
    0.29182023f, 0.08197552f, -0.24290514f, 0.10490813f, -0.21828149f, 0.08007541f, -0.09846343f, 0.05788748f, 
    0.60085148f, 0.54906869f, 0.13541135f, -0.14930528f, 0.05601522f, -0.00493721f, -0.07012314f, 0.04745041f, 
    -0.11063997f, 0.01033627f, -0.15362507f, -0.02775392f, -0.29271773f, 0.27893168f, -0.25247371f, -0.49081799f, 
    0.07156239f, -0.26271358f, -0.06118888f, -0.04080252f, -0.13311169f, -0.03610953f, -0.03086793f, -0.03461453f, 
    -0.27381089f, 0.16844617f, -0.01256942f, 0.10037138f, -0.17211345f, 0.11673628f, 0.17180027f, -0.13964078f, 
    0.04062603f, 0.08683402f, 0.04926979f, -0.10218967f, -0.02100546f, 0.28366128f, -0.01582004f, 0.24605550f, 
    0.02490236f, 0.00577636f, 0.09255398f, 0.03466355f, -0.02793843f, -0.02838453f, 0.10806125f, -0.01133505f, 
    -0.24908049f, 0.21780670f, -0.05404256f, 0.14696774f, 0.01690115f, 0.11732529f, -0.18288770f, 0.02328817f, 
    -0.03423536f, 0.08526353f, 0.11770947f, -0.06545699f, 0.00777887f, -0.72041470f, 0.24313915f, -0.21840841f, 
    -0.08488370f, -0.17683955f, -0.03040237f, -0.10344242f, 0.04963177f, 0.00110718f, 0.03364469f, -0.07955318f, 
    -0.32870638f, -0.06414749f, 0.04120827f, -0.40382624f, 0.08271980f, 0.16190562f, -0.14643504f, 0.30625153f, 
    -0.31130567f, 0.09403419f, 0.02135242f, 0.09044009f, -0.29549721f, -0.59245867f, 0.03296822f, 0.03347623f, 
    -0.25808185f, -0.32172126f, 0.33044574f, -0.14350349f, 0.00786994f, -0.03587246f, -0.00653882f, -0.06809662f, 
    -0.13133016f, -0.23314656f, -0.19887586f, 0.07673380f, 0.05715415f, 0.07419725f, 0.10711788f, 0.09711114f, 
    0.09705852f, 0.18650271f, 0.23127142f, 0.11444173f, -0.06209810f, 0.23380157f, 0.09488489f, -0.22013508f, 
    0.00007301f, 0.00199457f, 0.09511732f, -0.12200765f, -0.00630521f, 0.07738064f, 0.06200902f, 0.09901094f, 
    0.47127366f, -0.70032430f, 0.36668867f, -0.46896714f, 0.09458674f, -0.17241356f, -0.07899983f, 0.05819967f, 
    -0.16002460f, 0.06417586f, -0.10069461f, 0.07183546f, 0.40086228f, 0.27766830f, 0.09786430f, -0.30694950f, 
    -0.16967092f, 0.08871944f, -0.08106840f, 0.10593046f, -0.00159947f, -0.18658584f, 0.11127325f, -0.06667761f, 
    0.18768492f, -0.05484809f, 0.15254828f, -0.10370925f, -0.12248894f, -0.03187433f, -0.19512886f, -0.01259283f, 
    -0.18079175f, 0.00094449f, 0.19932096f, -0.12929401f, -0.66080511f, -0.05077036f, -0.40840897f, 0.47123906f, 
    0.20565812f, 0.23582163f, -0.08532151f, -0.10726652f, -0.15089600f, 0.14304408f, 0.10043529f, 0.00117293f, 
    -0.13275898f, 0.31616014f, -0.00929502f, -0.29609522f, 0.05362938f, 0.00740181f, 0.03989379f, -0.00323972f, 
    -0.02351842f, 0.06459104f, 0.20669870f, 0.24543080f, -0.58307564f, 0.12416901f, 0.22721522f, 0.11553361f, 
    -0.08235951f, 0.02324339f, 0.08773695f, 0.02617917f, -0.18638158f, -0.00989627f, -0.32390964f, -0.22831737f, 
    0.21631332f, -0.12049009f, 0.44523701f, -0.06848111f, 0.19292894f, 0.02273912f, 0.06110173f, 0.15688832f, 
    -0.26648590f, 0.11859237f, 0.20094205f, 0.00031667f, 0.13006508f, -0.42061600f, 0.73384696f, 0.26063064f, 
    0.23908320f, 0.07749109f, 0.21493992f, -0.07284988f, -0.17377019f, -0.15271088f, 0.14033595f, -0.19644627f, 
    -0.91701227f, 0.43616015f, -0.57923913f, 0.45036000f, 0.16883764f, -0.08213139f, 0.32472047f, -0.18513921f, 
    0.18989533f, -0.08074605f, 0.12430353f, 0.03122781f, -0.46904212f, -0.06189551f, -0.41445440f, -0.07252663f, 
    0.11525191f, -0.26444682f, -0.14209898f, 0.06210432f, -0.17360353f, 0.00343265f, -0.20927040f, -0.37778786f, 
    -0.52647573f, 0.34791166f, -0.01868903f, 0.31830463f, -0.32440877f, -0.06080731f, 0.13116384f, 0.14910764f, 
    -0.09325361f, 0.22924337f, 0.11127929f, 0.05756217f, 0.26677662f, -0.10957626f, 0.58673894f, -0.08169658f, 
    -0.24288727f, -0.20278762f, -0.24304752f, -0.09923716f, -0.00702757f, 0.06918981f, -0.08305539f, -0.03971854f, 
    -0.06727453f, -0.16339339f, 0.31831226f, -0.02902277f, 0.06799305f, -0.02088556f, 0.15580043f, 0.03465072f, 
    -0.11348467f, 0.01608668f, 0.04795792f, -0.06032133f, 0.14720552f, 0.14916295f, -0.27667436f, 0.16529649f, 
    -0.09673112f, 0.04288442f, -0.06840289f, -0.07400342f, -0.17728804f, 0.19217932f, -0.21001816f, -0.05246591f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.21085590f, 0.07577376f, 0.13638003f, -0.12107987f, -0.05544845f, 0.12229630f, 0.04240002f, -0.13164584f, 
    0.13611522f, 0.07305806f, 0.01054803f, -0.01569103f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
