#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.11208958f, -1.24299669f, 0.44032994f, -0.90328103f, -1.34500635f, -1.31580126f, -0.50619024f, 0.26502308f, 
    -0.30210191f, 1.19186759f, -1.36358309f, -1.04453838f, -0.55180180f, -0.54571211f, 0.41964224f, -0.44157478f, 
    0.18400663f, 0.47129178f, 1.40196609f, -0.57043374f, -1.29830241f, -0.25208470f, -0.55332994f, -0.51562893f, 
    -0.79614353f, -0.27664331f, -0.22525735f, 0.00861088f, 1.69539034f, 1.03144169f, -1.87427199f, 0.85427189f, 
    -0.55322641f, -0.01524367f, 0.01670828f, -0.20895196f, -2.11267877f, 0.73595560f, 1.17533457f, 0.13362193f, 
    0.86691833f, -0.57145512f, 0.01636424f, -0.04727348f, -0.17016152f, 0.14927816f, 0.20768064f, 1.10157537f, 
    -0.11699039f, 1.37323678f, -0.84923142f, 0.49592829f, 0.68333441f, -0.42912796f, 1.28418291f, 1.03052771f, 
    -0.79328394f, -0.58364159f, -1.11400020f, -0.04256207f, 0.50006193f, 0.55557805f, 0.28733146f, -1.20308983f, 
    -1.09126282f, -1.21072030f, 1.08119619f, -0.11321934f, 0.10204138f, -0.35255614f, -0.01748746f, -0.53778988f, 
    -1.40835273f, -1.64476824f, -0.63524812f, 0.42029876f, 1.54790401f, 0.64618748f, -0.18810102f, -0.18920773f, 
    0.31051773f, 0.54325539f, 1.53755689f, 0.28525817f, 1.39586782f, 0.05683040f, -0.86775732f, -0.30822945f, 
    0.09579065f, -0.59421778f, 1.25584805f, 0.58133674f, -0.95365810f, 0.96202254f, 0.69117588f, -0.82956541f, 
    0.42647627f, -0.37776721f, -0.30891895f, 0.94414651f, 1.48787713f, 0.72277218f, 0.28300190f, 0.31971347f, 
    0.84638917f, 0.56588483f, -0.80572307f, 0.15012339f, 0.95383286f, -1.40634096f, 1.26601601f, 1.37474239f, 
    -1.02252936f, 0.08392652f, 0.13467349f, -0.34227920f, -0.48021719f, 1.56071806f, 0.96466476f, 0.98093402f, 
    -0.18839791f, -0.54184163f, -0.65498638f, -0.17134285f, -0.08048127f, -0.00502534f, 1.05715430f, 0.00458140f, 
    -1.34554362f, -0.51456904f, 1.39021790f, 0.97480661f, 0.51984882f, -0.52821612f, 0.59551668f, -1.45097947f, 
    -0.86505193f, -0.45676172f, -0.91553533f, -1.00841534f, -0.55366594f, 0.60476953f, 0.68516105f, -0.30859801f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.40648720f, 0.18719557f, 0.09981561f, 0.01175283f, -0.02213238f, -0.03471606f, -0.11964859f, 0.03662312f, 
    0.31229708f, -0.09274170f, 0.33767447f, 0.24195935f, 0.25221878f, 0.01770247f, 0.01915211f, 0.67248034f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.08862323f, -0.61674571f, 0.06610651f, 0.23071043f, -0.34233552f, -0.04388540f, -0.18989781f, 0.00985142f, 
    0.07042801f, 0.03749591f, -0.12885535f, 0.01148550f, -0.13598873f, 0.03267529f, -0.00011239f, -0.05131250f, 
    -0.01291283f, -0.01158431f, 0.01902898f, -0.13148929f, 0.33402473f, -0.73819816f, 0.08802487f, 0.15228106f, 
    -0.32648093f, 0.16043311f, 0.05679411f, 0.04351584f, 0.10182519f, -0.07434233f, 0.02860161f, 0.06549355f, 
    -0.08994684f, 0.09757891f, -0.00464694f, -0.08728534f, -0.21562272f, -0.14359021f, 0.01286979f, -0.02073357f, 
    0.14502896f, -0.64462352f, 0.24430260f, 0.31458256f, 0.25881520f, 0.13014568f, -0.03819766f, -0.01754113f, 
    0.13948044f, 0.05280899f, -0.07372174f, 0.06977672f, 0.03172618f, 0.08235273f, -0.05229919f, 0.00718484f, 
    -0.06782451f, -0.05679335f, -0.00059201f, -0.07227359f, -0.01685125f, 0.03607406f, -0.11307164f, -0.17770958f, 
    0.33644831f, -0.22550879f, -0.04872818f, -0.12522839f, -0.10675067f, -0.01095144f, -0.07602391f, -0.02003093f, 
    0.04433356f, -0.26759598f, 0.14249671f, -0.19418718f, 0.01602951f, 0.06444967f, 0.11515936f, -0.11068511f, 
    0.06406127f, -0.18802923f, 0.59075516f, -0.10047306f, -0.02702790f, -0.09138200f, -0.08854205f, 0.10242099f, 
    -0.00631777f, 0.04952463f, 0.01590070f, 0.18476489f, 0.06378622f, -0.09206604f, -0.14068094f, 0.10247573f, 
    -0.20451733f, 0.05036278f, 0.01379638f, -0.10420309f, -0.16022074f, -0.12854199f, 0.13003920f, -0.01915297f, 
    -0.26404363f, -0.08226302f, -0.06196906f, 0.03261214f, -0.10092466f, 0.01472709f, -0.09844644f, 0.15880363f, 
    0.07291884f, 0.05599550f, 0.03235367f, 0.04347918f, -0.06531438f, 0.01826730f, -0.15588601f, -0.16640469f, 
    0.34630916f, -0.13746278f, 0.27684474f, -0.10832953f, 0.44357166f, -0.17768592f, -0.03778410f, -0.19272470f, 
    0.10430801f, 0.04385015f, 0.02179572f, -0.04453469f, 0.01696425f, -0.04001049f, 0.07251392f, 0.00115737f, 
    0.00677485f, 0.03760586f, 0.11198828f, 0.09671311f, 0.32654959f, -0.11296846f, -0.06022785f, -0.15764514f, 
    -0.69144446f, 0.13205495f, 0.17732146f, 0.11165212f, 0.12394040f, -0.11713868f, 0.05742725f, -0.13390197f, 
    0.09590940f, 0.08009425f, 0.00698019f, 0.11050569f, 0.07824510f, -0.03317441f, 0.13035001f, 0.07275233f, 
    -0.00614944f, 0.55671698f, 0.16265756f, -0.29106793f, -0.78227830f, 0.08798297f, 0.19820644f, -0.02105486f, 
    0.12594271f, -0.19384454f, -0.05842207f, 0.05722826f, -0.02812768f, 0.06878155f, -0.05487001f, 0.01952561f, 
    -0.05871824f, 0.07582082f, 0.02099092f, 0.00675182f, 0.20623320f, 0.06745764f, 0.08708929f, -0.12475847f, 
    0.30375123f, -0.25842732f, -0.26692113f, 0.17174371f, -0.04004536f, -0.03818876f, 0.06010350f, 0.09867650f, 
    -0.33126974f, 0.13610716f, -0.17059737f, -0.00480388f, 0.18133779f, -0.06117438f, -0.09885561f, 0.04861690f, 
    0.11330173f, -0.22088663f, 0.06060240f, 0.03589764f, 0.63593584f, -0.11512271f, 0.16059792f, 0.02343873f, 
    0.14763366f, -0.13005820f, 0.04939983f, 0.15657225f, -0.05389607f, -0.21623451f, 0.05728030f, 0.13666898f, 
    -0.12259536f, 0.17802869f, -0.05069008f, -0.05396664f, 0.19782990f, 0.01067202f, 0.04834528f, -0.43955323f, 
    0.49756476f, -0.24353750f, -0.32365176f, 0.00920395f, 0.02046578f, -0.11211585f, 0.00976870f, 0.00681996f, 
    0.01530646f, -0.04568351f, 0.07997587f, -0.02861843f, 0.07009495f, 0.00806799f, -0.17271197f, 0.14010702f, 
    0.23853786f, -0.66502476f, 0.00018893f, 0.12265950f, -0.65737784f, -0.08309594f, -0.03492679f, -0.00469275f, 
    -0.05977755f, 0.12455331f, -0.30795851f, 0.05086584f, -0.11357444f, 0.09098914f, 0.03403817f, -0.03960054f, 
    0.03873926f, 0.20360918f, 0.07384880f, -0.08924683f, 0.29202017f, 0.24671310f, -0.03054892f, -0.35304910f, 
    0.21646754f, -0.06813525f, -0.41756502f, -0.06446163f, 0.14880885f, 0.08518727f, 0.05760503f, -0.06674158f, 
    -0.15935473f, 0.09990712f, -0.17515737f, 0.23205605f, 0.02221484f, -0.00694974f, 0.14440548f, 0.14663318f, 
    -0.96478307f, 0.45951530f, -0.02661661f, -0.12266077f, 0.35380560f, -0.04200286f, -0.12054542f, -0.00660217f, 
    -0.08057484f, 0.03421713f, -0.12104999f, -0.05930633f, -0.00619250f, 0.10877041f, 0.05859899f, -0.03984052f, 
    0.05791185f, -0.04105553f, -0.10832189f, -0.12874423f, -0.96802795f, -0.65591866f, -0.35873201f, 0.21416916f, 
    -0.14871749f, -0.08425483f, -0.09514402f, 0.09297744f, 0.08881918f, 0.03549195f, -0.02113021f, -0.00832519f, 
    -0.11220443f, -0.22678508f, -0.01011422f, 0.05428132f, 0.18152720f, 0.11264794f, 0.00627469f, -0.13722540f, 
    -0.39225000f, -0.12717009f, -0.02069257f, -0.21696298f, -0.26768026f, -0.07443101f, 0.08898633f, 0.10905097f, 
    0.00393539f, -0.01581226f, -0.12948896f, -0.14136843f, 0.24070232f, 0.06983270f, 0.18694089f, -0.18752675f, 
    0.02162045f, -0.14992802f, -0.28406927f, 0.05506925f, -0.03510580f, -0.59646070f, 0.22846624f, -0.19599304f, 
    0.24513207f, 0.02859661f, 0.06121675f, -0.02688066f, 0.08403645f, 0.09846799f, -0.01656252f, -0.02023522f, 
    0.02391746f, -0.05697187f, -0.09855371f, -0.00300987f, -0.08495707f, 0.07593688f, 0.00992459f, -0.28369221f, 
    0.28538951f, -0.47980192f, 0.02966868f, -0.65421915f, -0.03275068f, -0.17387663f, 0.02786716f, 0.03058821f, 
    -0.02552925f, 0.00688223f, -0.11644488f, -0.01380742f, 0.00515306f, 0.14666209f, -0.21532537f, -0.31808424f, 
    -0.13383920f, -0.39977428f, -0.03166670f, -0.08675759f, 0.23632315f, 0.37435222f, -0.51491576f, -0.19780843f, 
    0.18944308f, 0.13082416f, 0.08357527f, 0.06807043f, 0.02619625f, 0.07713517f, 0.21325584f, -0.10437026f, 
    0.03520105f, 0.11945544f, -0.12072914f, 0.04182113f, 0.15456966f, 0.10429410f, -0.13403660f, 0.00493147f, 
    -0.92143410f, -0.13605469f, -0.61169225f, -0.35724977f, 0.14613472f, -0.20292214f, 0.09035858f, -0.07155224f, 
    0.10724403f, 0.19052786f, 0.01356714f, 0.11676712f, -0.03833990f, -0.12693061f, -0.10821366f, 0.05460066f, 
    -0.04308519f, 0.23268627f, -0.09421311f, -0.01577656f, -0.08408224f, -0.00615719f, 0.22900128f, -0.02288612f, 
    0.40034249f, -0.23246129f, -0.03823716f, -0.10651635f, -0.07421311f, 0.20169599f, 0.15743753f, -0.29704937f, 
    -0.00493742f, -0.17855991f, -0.08417431f, -0.23924923f, 0.17652912f, -0.00946036f, 0.01201786f, 0.10320601f, 
    0.24226305f, -0.48295909f, 0.10111249f, -0.09804031f, -0.11394040f, 0.02639944f, -0.31829423f, -0.01074793f, 
    0.04291173f, -0.22050104f, 0.06708606f, 0.05758233f, -0.04108139f, 0.14729813f, 0.13825034f, 0.00270923f, 
    -0.16667008f, -0.28241646f, -0.03379915f, -0.21475004f, 0.01826200f, 0.00720436f, -0.43273491f, -0.02864325f, 
    -0.44196415f, 0.15534350f, -0.07668408f, -0.13412683f, -0.13451785f, 0.16979049f, 0.24213903f, 0.10743465f, 
    -0.06954774f, 0.02181621f, -0.03842991f, -0.01519605f, 0.13711545f, -0.10487408f, -0.19906941f, 0.00380687f, 
    0.32855499f, 0.06613830f, -0.30579102f, 0.10422228f, -0.36249292f, -0.09398279f, 0.13941328f, 0.00646736f, 
    -0.04521886f, 0.32870951f, -0.11227818f, 0.05435027f, -0.13592434f, -0.01827135f, 0.05628979f, 0.21698330f, 
    0.14598483f, -0.02339659f, -0.02418626f, 0.04608817f, -0.17385858f, -0.13035882f, 0.25690332f, -0.00134857f, 
    0.43226492f, -0.15024535f, -0.02587247f, -0.05195072f, -0.09343693f, -0.01577660f, -0.04534926f, 0.01441342f, 
    0.04066241f, -0.14716361f, 0.00193092f, 0.03332076f, 0.05118485f, -0.08213177f, 0.19360344f, 0.12457652f, 
    0.21234329f, -0.46721140f, -0.10167807f, -0.16574760f, -0.15585306f, -0.12123883f, -0.20213525f, -0.00812807f, 
    -0.05234758f, -0.12578402f, -0.15925668f, -0.00158037f, -0.01220742f, 0.00393274f, -0.02171632f, -0.18888412f, 
    -0.00075231f, -0.12716696f, 0.19582292f, -0.05233356f, 0.23011561f, 0.35074484f, 0.28064153f, 0.21746984f, 
    0.44832960f, -0.00911266f, -0.08638698f, 0.06929305f, 0.03029623f, 0.00284514f, -0.21048263f, 0.01375133f, 
    0.06433013f, 0.00405695f, -0.08360592f, 0.11213434f, -0.02699682f, 0.13885927f, -0.11296675f, -0.04133397f, 
    -0.06118857f, 0.15798596f, 0.30249378f, -0.07051296f, -0.33548644f, -0.11669223f, -0.03232974f, 0.08375023f, 
    -0.03769089f, 0.10983804f, 0.17241463f, 0.13739097f, 0.12317350f, 0.03557264f, 0.14756884f, 0.05232081f, 
    -0.07552160f, -0.18196049f, 0.20321213f, 0.20617931f, 0.41151160f, -0.09282274f, 0.08507268f, 0.28584355f, 
    0.06820683f, -0.24383076f, -0.17724437f, 0.08878791f, 0.04252612f, 0.04909935f, 0.04840937f, -0.04050985f, 
    0.06951521f, 0.03617675f, 0.08664051f, -0.05595687f, 0.12197573f, -0.08986608f, -0.05394094f, -0.06925499f, 
    0.80602419f, -0.43248498f, 0.11232485f, -0.13326690f, -0.07783087f, -0.23350479f, -0.01462965f, -0.20137264f, 
    0.04779106f, -0.08003732f, 0.17588112f, -0.00380629f, 0.00054707f, -0.09944946f, 0.05306068f, 0.04554469f, 
    -0.01823698f, 0.05126529f, -0.00436173f, 0.25407973f, 0.19645202f, -0.00363469f, -0.11420272f, -0.04441211f, 
    -0.22599059f, 0.21428537f, 0.00879499f, 0.08039824f, 0.21771640f, 0.18043873f, -0.13357204f, -0.15205847f, 
    -0.02178373f, 0.19641887f, -0.23616685f, 0.07030081f, 0.11944006f, -0.20215748f, -0.29392850f, -0.10749032f, 
    -0.16503827f, -0.39360431f, -0.06031761f, -0.25730628f, -0.54822260f, 0.04502418f, 0.09909392f, -0.17093149f, 
    0.10602976f, -0.06201402f, 0.00737626f, 0.04531869f, -0.05214369f, -0.05386018f, -0.06257770f, -0.01021660f, 
    0.00542987f, 0.12144782f, 0.02589828f, -0.15223268f, 0.41956201f, -0.18240868f, -0.34700370f, -0.11266805f, 
    -0.59466106f, 0.02530208f, 0.04435129f, 0.11708222f, 0.03322396f, 0.05801276f, 0.01030574f, -0.11249276f, 
    -0.12607737f, 0.04597897f, -0.07117844f, -0.04616253f, 0.23404332f, 0.14934739f, 0.08936580f, 0.02918473f, 
    -0.46123895f, -0.67529076f, -0.25847727f, -0.12741023f, -0.63154906f, -0.00825910f, 0.02779353f, 0.04291790f, 
    0.07422547f, 0.09725426f, 0.02249557f, 0.03217147f, 0.02637104f, -0.08545360f, -0.04204751f, 0.00964742f, 
    0.08135090f, 0.20812427f, 0.02465957f, 0.01166042f, 0.20509022f, 0.29225415f, -0.39103946f, -0.31511360f, 
    -0.08514081f, 0.07106061f, 0.07392141f, -0.03956493f, -0.17509367f, -0.15109992f, -0.13167146f, -0.12628938f, 
    -0.09501158f, -0.15347758f, -0.06941925f, 0.02035632f, -0.00433874f, -0.06728809f, -0.23064424f, -0.03089726f, 
    0.84052634f, -0.11805034f, -0.52618730f, 0.00395341f, -0.30066308f, 0.09637058f, -0.09562305f, 0.07871816f, 
    -0.12135226f, -0.02561615f, -0.07338201f, -0.05258398f, 0.00470083f, -0.06559511f, -0.01573794f, 0.10473648f, 
    -0.10976064f, -0.22517124f, 0.13858239f, -0.17063768f, 0.31154549f, 0.08708904f, 0.02035199f, -0.05640890f, 
    0.10690592f, 0.01367801f, 0.00397363f, 0.04573097f, -0.10404336f, -0.09874753f, -0.03418023f, -0.11301383f, 
    0.07088604f, 0.00500930f, -0.03560774f, 0.02543566f, -0.07944421f, -0.14926836f, 0.05602346f, 0.01888504f, 
    -0.06048508f, 0.18630645f, 0.10271285f, -0.37763727f, -0.12427785f, 0.07596813f, -0.13371019f, 0.38291174f, 
    -0.08342826f, 0.12498491f, -0.15031484f, 0.08823785f, 0.10743856f, -0.20342851f, 0.00792081f, 0.11972744f, 
    -0.07216818f, 0.13036402f, 0.04425150f, -0.01344143f, 0.28921697f, -0.23020585f, 0.12475015f, 0.21905079f, 
    0.36421683f, -0.15517056f, -0.12265089f, -0.19817841f, -0.00980291f, 0.06133879f, 0.02791841f, -0.16733979f, 
    -0.11942605f, -0.01947973f, 0.04734073f, -0.07232019f, 0.02860616f, -0.05553564f, 0.08255392f, 0.04988749f, 
    0.55064577f, -0.14810809f, 0.20603600f, 0.13616499f, 0.51121420f, -0.26183373f, -0.16277312f, -0.23436178f, 
    0.09834427f, 0.07569569f, 0.26001772f, -0.15760903f, -0.06618392f, -0.01527266f, -0.02600149f, -0.10885873f, 
    -0.02560946f, -0.01646334f, -0.01164366f, 0.02908200f, 0.36861283f, -0.54334557f, 0.13283604f, -0.09638990f, 
    0.05835232f, 0.16276611f, 0.09889850f, 0.15005897f, -0.02807610f, 0.16039829f, -0.01658357f, 0.10671562f, 
    -0.01101172f, 0.00012593f, -0.14817342f, -0.02326302f, -0.15562145f, 0.03803683f, -0.12230063f, 0.03283289f, 
    0.42884013f, -0.47075766f, 0.07445909f, -0.28858310f, -0.00689388f, 0.06597831f, -0.22143181f, -0.00746201f, 
    -0.01521864f, 0.15870865f, -0.05669700f, 0.01284960f, 0.10982168f, 0.07220931f, -0.10051624f, 0.05915151f, 
    -0.21477650f, 0.06156872f, 0.05306533f, 0.00313264f, -0.06669905f, 0.08149672f, -0.10715847f, -0.12375526f, 
    0.12647544f, 0.13113946f, 0.03482685f, 0.15855981f, 0.05539052f, -0.09380724f, -0.05811454f, 0.14736611f, 
    -0.02980400f, 0.07625806f, -0.05656252f, -0.05685394f, -0.02449954f, -0.05050443f, -0.19939865f, -0.09713414f, 
    -0.76553112f, 0.13570221f, 0.21914391f, -0.05139066f, 0.09002991f, 0.07095154f, 0.03300419f, -0.20429626f, 
    -0.16160573f, -0.03111747f, 0.01033876f, -0.08150048f, -0.00180203f, -0.02515178f, 0.10046621f, 0.04749360f, 
    0.00688413f, -0.08312943f, -0.16172361f, 0.17973511f, -0.24270694f, 0.22366329f, -0.04055579f, -0.22728652f, 
    0.17426938f, 0.29014850f, 0.11656991f, 0.12200746f, -0.02720865f, -0.11044098f, -0.09664308f, 0.06124309f, 
    -0.10821590f, -0.16138746f, -0.05716693f, -0.08903416f, 0.00948451f, 0.03855840f, -0.19936588f, 0.11698882f, 
    0.24137007f, 0.12119800f, 0.20733185f, 0.12123378f, -0.19907749f, -0.07206978f, -0.09856877f, 0.08449291f, 
    0.13981462f, 0.18321884f, 0.00391958f, -0.02363118f, 0.08045966f, 0.07649819f, -0.03389538f, -0.05226714f, 
    -0.10971247f, -0.02962727f, 0.10246441f, -0.03738041f, 0.33917192f, -0.71367806f, -0.04415798f, -0.14799555f, 
    -0.45753089f, -0.11949820f, -0.04188776f, -0.07496160f, 0.00296494f, 0.00947469f, -0.03432744f, -0.00643141f, 
    -0.00364042f, -0.14273135f, -0.04526648f, -0.08896817f, -0.10530332f, 0.08937591f, 0.19823776f, -0.03926387f, 
    0.10378579f, 0.40059546f, 0.27481046f, 0.37405938f, 0.06304565f, -0.02223452f, 0.00393225f, -0.02423305f, 
    -0.19683188f, 0.05551009f, 0.01768297f, 0.01224451f, -0.13342051f, -0.07513865f, -0.15284172f, 0.01204236f, 
    -0.06274465f, 0.13315316f, 0.15161808f, 0.05258923f, 0.08417457f, 0.31613764f, 0.13174462f, 0.26728013f, 
    -0.08509789f, -0.02196909f, 0.01025528f, -0.15762879f, -0.04408226f, -0.07030857f, 0.06780639f, 0.04907575f, 
    0.09047813f, -0.06567289f, -0.00942637f, -0.03044037f, 0.00353799f, -0.07615305f, -0.06070999f, 0.09727086f, 
    0.10663942f, 0.01355276f, 0.45456499f, 0.09184385f, 0.09091962f, 0.04012580f, 0.13293548f, -0.00056373f, 
    -0.10867025f, 0.08856799f, 0.14175034f, 0.07843550f, -0.01113747f, -0.06210951f, -0.05575164f, 0.00988161f, 
    0.05070119f, -0.14003895f, 0.04985461f, 0.13463104f, -0.65659118f, 0.59609854f, -0.21671446f, 0.09624360f, 
    0.48578843f, -0.01036855f, 0.16133225f, 0.02497297f, 0.03766960f, -0.09286831f, -0.15130360f, -0.06471774f, 
    0.09701824f, -0.15121713f, -0.12216678f, 0.03326862f, 0.07887541f, -0.12589978f, 0.23606238f, 0.11621716f, 
    -0.11576244f, 0.53062314f, 0.07008847f, 0.03573072f, -0.11289143f, 0.08202828f, -0.01604622f, -0.05331877f, 
    0.16764976f, -0.08701728f, 0.07358756f, 0.02011526f, -0.06169060f, 0.07393221f, -0.20617202f, -0.19203259f, 
    -0.01568751f, -0.12716964f, 0.12153151f, 0.00174770f, -0.44875535f, 0.35449994f, -0.12712620f, 0.16610199f, 
    0.03517561f, -0.11839612f, 0.02837609f, 0.01464696f, 0.08702290f, 0.00183352f, -0.05935652f, 0.04011177f, 
    -0.00134587f, -0.12780696f, 0.00218396f, -0.08177322f, -0.04922277f, -0.16901417f, 0.07501425f, 0.00675947f, 
    0.24651964f, -0.35155222f, -0.40722102f, 0.26341274f, 0.20584853f, -0.06207206f, 0.15647277f, 0.08472040f, 
    0.09199777f, 0.07133023f, 0.22902226f, -0.08105018f, -0.05735497f, -0.26879346f, 0.03983547f, -0.08231967f, 
    0.08771332f, 0.02084735f, -0.03975919f, -0.11227373f, 0.00698665f, 0.04145605f, -0.23636506f, -0.10856280f, 
    0.08586054f, -0.16556826f, -0.20515878f, -0.06985827f, 0.13138233f, -0.02445956f, -0.21328446f, -0.12030349f, 
    0.08273701f, -0.17625304f, 0.15153749f, -0.06141927f, -0.11766224f, 0.24189784f, 0.09158739f, 0.11093436f, 
    0.04322391f, -0.08207946f, 0.00838901f, -0.01531481f, -0.26930723f, -0.08592252f, -0.33143932f, -0.00197382f, 
    -0.10161437f, 0.00973155f, -0.21688156f, 0.08700240f, 0.00566017f, -0.16858870f, 0.07297950f, 0.12407155f, 
    0.07748120f, 0.02160057f, 0.12542361f, -0.05490668f, 0.75932348f, -0.12039919f, -0.50951004f, 0.20120198f, 
    -0.06583366f, -0.21507686f, -0.14427470f, -0.15932408f, 0.03243794f, 0.03198822f, -0.15112597f, -0.10046262f, 
    -0.18401623f, 0.07798743f, -0.13148104f, 0.08108980f, 0.03327302f, 0.00122988f, 0.06561723f, -0.06717186f, 
    -0.12797461f, 0.09257240f, -0.19598660f, -0.00466024f, -0.04981265f, -0.04191899f, -0.10331548f, 0.02651033f, 
    -0.05954257f, 0.00366483f, -0.00796314f, -0.11099372f, 0.04563727f, 0.09838451f, 0.04444302f, -0.20254508f, 
    0.11510079f, 0.07603129f, -0.11677261f, -0.04312152f, -0.79435790f, -0.91870284f, -0.22796541f, -0.12883896f, 
    -0.17117284f, -0.08005414f, 0.07389230f, 0.01970664f, 0.05438862f, -0.06462494f, 0.07006940f, 0.05079654f, 
    0.05301936f, -0.03732804f, 0.10418646f, 0.10352770f, -0.01482523f, -0.11030695f, 0.09025260f, -0.09012926f, 
    0.06321866f, 0.14042069f, -0.53126580f, 0.22175157f, -0.01753669f, 0.04393394f, 0.12758443f, -0.07780974f, 
    -0.06934742f, -0.07787042f, 0.05700681f, 0.00564110f, -0.10479455f, -0.01824048f, 0.10537412f, 0.03174726f, 
    0.12216309f, 0.06026818f, 0.04950583f, -0.15843588f, -0.65291226f, -1.13283348f, -0.73383445f, 0.10891717f, 
    0.11427853f, 0.08400078f, 0.01242789f, 0.21957618f, -0.00803583f, -0.09757698f, 0.09941656f, -0.01502120f, 
    -0.10576388f, -0.16922878f, -0.23297001f, -0.01720341f, 0.01341381f, 0.06949136f, -0.02014890f, -0.08142559f, 
    -0.23343661f, -0.45183527f, -0.25617766f, -0.05306862f, -0.30108112f, -0.06684260f, -0.09143733f, -0.00734279f, 
    -0.07157926f, 0.08842152f, -0.13210021f, 0.03208306f, 0.06661648f, 0.14766538f, 0.18105997f, 0.12255497f, 
    -0.08404501f, -0.02919398f, 0.03023330f, 0.04636062f, -0.14047022f, 0.31243500f, 0.08852874f, 0.10017462f, 
    -0.00705214f, -0.14441651f, -0.05395944f, -0.16402678f, -0.04933083f, -0.08828219f, -0.14897491f, -0.06626149f, 
    0.11923624f, -0.00874589f, 0.10717797f, -0.02460875f, 0.10854030f, 0.19702752f, 0.07998580f, -0.08226700f, 
    -0.15050776f, -0.28900889f, 0.10823819f, 0.36270419f, -0.06949817f, -0.02824813f, 0.09393629f, -0.16126730f, 
    -0.05776774f, -0.07719559f, 0.04608577f, 0.02395948f, -0.14320248f, 0.03872671f, 0.00387704f, -0.05157743f, 
    -0.07571017f, 0.04471739f, 0.10017697f, 0.07539263f, -0.01769252f, 0.39682171f, -0.37430313f, 0.01058345f, 
    -0.38881484f, -0.05854244f, -0.09144180f, -0.23114246f, -0.01920738f, 0.02707569f, -0.03971688f, 0.01691789f, 
    -0.04291810f, -0.02157627f, -0.03022572f, -0.05910265f, -0.04353552f, 0.05189017f, 0.07651138f, -0.09429490f, 
    0.20315368f, 0.37139273f, -0.46852800f, 0.27914622f, -0.28970844f, -0.04781717f, -0.11300255f, 0.09076101f, 
    0.04653631f, -0.11950163f, -0.04449047f, 0.05381742f, -0.03415637f, -0.09567408f, 0.05614383f, 0.24945499f, 
    0.12957153f, 0.08625644f, 0.07422268f, 0.09080955f, -0.77122915f, 0.01517579f, 0.33446911f, 0.48883033f, 
    0.06681368f, -0.13865572f, -0.08315466f, 0.14906961f, -0.17101945f, -0.02805007f, 0.12142287f, 0.04677925f, 
    0.03050925f, -0.00989120f, 0.07860328f, 0.04124043f, -0.01617827f, -0.01130523f, -0.07565953f, -0.03261380f, 
    0.10757156f, 0.59664714f, -0.17629746f, -0.33220461f, -0.23287208f, -0.02526782f, -0.01363590f, 0.10350453f, 
    -0.00663074f, -0.07691108f, 0.00171114f, 0.02018524f, -0.00335634f, 0.11571222f, -0.06134026f, -0.12317052f, 
    0.05619336f, -0.20935567f, -0.09949291f, -0.06412144f, -0.57493383f, 0.05560884f, 0.15912655f, -0.13172103f, 
    -0.01716605f, 0.01863363f, 0.06730914f, -0.13582444f, -0.02219385f, 0.00184864f, -0.02984910f, 0.23682266f, 
    -0.07166851f, -0.14658748f, 0.08096087f, 0.17521928f, -0.02730113f, -0.11404172f, -0.04340315f, -0.04101527f, 
    -0.23326379f, -0.59285295f, -0.09154257f, 0.16679680f, -0.29926562f, -0.40645000f, -0.01248041f, -0.01774532f, 
    -0.20869258f, -0.06709065f, -0.05344057f, 0.07012460f, -0.05623995f, -0.10734043f, 0.02167871f, -0.09126852f, 
    0.12778543f, 0.25293970f, -0.08496328f, -0.03739289f, -0.36222991f, -0.28601158f, -0.13200302f, 0.13990541f, 
    0.37951785f, 0.14470172f, -0.02378011f, 0.11173955f, 0.11530638f, 0.13373835f, 0.08696675f, -0.10693058f, 
    0.07658710f, -0.00583921f, 0.08653049f, 0.10505369f, -0.01616532f, 0.06932033f, 0.11531187f, 0.09678464f, 
    -1.37563407f, -0.12511742f, -0.09695908f, 0.12074156f, 0.42906481f, 0.04530409f, -0.06325993f, 0.10440167f, 
    0.15647270f, 0.09582492f, -0.00838172f, -0.03806385f, 0.02558870f, 0.15160149f, 0.02665531f, 0.05534663f, 
    0.09247951f, 0.15679526f, 0.07122177f, -0.18383314f, -0.15864404f, 0.38375273f, -0.12550454f, -0.14705481f, 
    0.04880043f, 0.06357290f, -0.07927898f, 0.04287836f, 0.17862940f, 0.16951220f, -0.03047828f, -0.19149147f, 
    -0.00171036f, 0.04635942f, -0.04774695f, -0.03875174f, 0.10409331f, 0.15436035f, -0.05665984f, 0.04986684f, 
    -0.04623462f, 0.13804862f, -0.00314972f, -0.02896170f, -0.51723820f, -0.06203303f, 0.04566867f, 0.10304213f, 
    0.03155267f, -0.03812686f, -0.02090904f, -0.08917657f, 0.00656022f, 0.02264494f, 0.03230809f, -0.01520752f, 
    0.07025848f, -0.08120025f, -0.06873535f, 0.06070872f, 0.11268681f, -0.07188319f, -0.07034634f, -0.08500928f, 
    0.03292295f, 0.06792530f, 0.06058772f, -0.02224629f, 0.14404155f, 0.25318253f, 0.00013800f, 0.08731559f, 
    -0.05193990f, -0.02331340f, -0.02828490f, -0.02866814f, -0.06716134f, -0.14144737f, 0.17705336f, 0.02933250f, 
    -0.21490911f, 0.23562177f, 0.04850511f, -0.34220466f, 0.01218050f, 0.28458005f, -0.03935844f, -0.05405866f, 
    -0.05960296f, -0.20988938f, 0.02706036f, -0.24124531f, -0.21276091f, 0.00375286f, -0.19437930f, -0.09180703f, 
    -0.14306539f, 0.01586789f, -0.24880889f, -0.02018358f, -0.14637259f, -0.21647926f, 0.33570233f, 0.20045352f, 
    -0.14327726f, -0.18316486f, 0.07312497f, -0.01997807f, 0.08574136f, 0.05716224f, 0.13116392f, 0.03150927f, 
    0.03116775f, -0.10885948f, -0.03264958f, -0.02254580f, 0.09162146f, -0.03243617f, 0.10071684f, 0.12971714f, 
    0.50055653f, -0.04895556f, -0.08754068f, -0.35216728f, -0.09135555f, -0.01544461f, 0.05429773f, 0.00894789f, 
    -0.18942142f, 0.00459604f, 0.12362567f, -0.03264395f, 0.06179360f, 0.17328522f, 0.03614313f, -0.05041650f, 
    -0.10793979f, 0.07965320f, -0.01201529f, -0.22737813f, 0.04770197f, 0.04784480f, 0.12485830f, -0.01140555f, 
    0.09423395f, 0.11363295f, 0.15589468f, -0.01532983f, 0.12030093f, -0.05925605f, 0.11152730f, 0.08541667f, 
    0.05251975f, 0.00013455f, 0.03533184f, -0.14314295f, -0.10654002f, 0.03446352f, -0.02893342f, 0.03629887f, 
    -0.00116315f, 0.18992803f, -0.16244145f, 0.15991476f, 0.26387605f, 0.13880382f, -0.19999646f, -0.00745263f, 
    -0.03558315f, 0.00685867f, -0.04327781f, 0.04924532f, 0.08840258f, 0.01063232f, 0.12375030f, -0.08924900f, 
    0.11302003f, 0.03888441f, -0.17406757f, -0.16271576f, -0.16169098f, -0.49641490f, -0.06464632f, -0.06090957f, 
    0.01664923f, -0.07954016f, -0.08883324f, 0.03108613f, -0.09356173f, 0.14509533f, -0.01564975f, -0.04461569f, 
    0.03872753f, -0.03978576f, -0.19966722f, -0.12872051f, -0.10702913f, -0.15648983f, -0.05750936f, 0.10371218f, 
    -0.04198687f, -0.39680475f, -0.00140893f, -0.19693485f, 0.09923324f, 0.00624035f, 0.02660253f, -0.01722157f, 
    -0.06841870f, 0.18806468f, 0.16493988f, 0.05075235f, 0.00635337f, 0.00670283f, -0.04488784f, -0.20252535f, 
    -0.19090423f, 0.00374241f, -0.16307038f, -0.20099711f, 0.20248654f, -0.02144009f, 0.01166774f, 0.08198979f, 
    -0.29337332f, -0.22605532f, -0.12455801f, -0.07476914f, 0.11941551f, 0.10651337f, -0.02668697f, 0.08976195f, 
    0.06596945f, 0.17865461f, 0.28747818f, -0.14722939f, -0.11620405f, 0.05878727f, 0.05707689f, -0.01359017f, 
    -0.61490017f, -0.30197510f, 0.27519524f, 0.00657904f, -0.66002095f, 0.06256950f, -0.02418366f, 0.09005286f, 
    -0.13152598f, -0.18064253f, 0.05016625f, -0.16562796f, 0.13174492f, 0.05645283f, -0.02412832f, -0.19021468f, 
    0.09556487f, 0.18433408f, 0.06338755f, -0.09283483f, -0.17831443f, -0.04835817f, -0.07422240f, -0.07033341f, 
    0.14949772f, -0.11750815f, -0.06511642f, 0.08203781f, 0.02581129f, -0.09957924f, 0.02698608f, -0.00844864f, 
    -0.14037777f, 0.04445624f, -0.04020260f, -0.04996323f, 0.11567200f, 0.04601418f, 0.02877260f, 0.02910069f, 
    0.00391625f, 0.38803917f, 0.11774536f, 0.18319389f, 0.05505226f, -0.23850617f, -0.03383288f, -0.07710323f, 
    -0.00846929f, 0.16360845f, -0.15475617f, -0.24469849f, -0.09528050f, 0.11924109f, -0.01002533f, 0.10595717f, 
    0.13268904f, -0.14945486f, -0.06729559f, 0.12028126f, -0.38722488f, 0.21734490f, -0.28356564f, -0.19782686f, 
    -0.17964180f, 0.19683442f, 0.28261322f, 0.28265962f, -0.08562619f, 0.07443897f, 0.01403486f, 0.02654517f, 
    -0.06661618f, -0.18323143f, 0.03276536f, 0.03968504f, 0.07314634f, -0.14001441f, -0.00370625f, -0.12898216f, 
    -0.91463464f, -0.02008426f, -0.56762469f, -0.28234050f, -0.12709846f, 0.27628323f, 0.23066780f, 0.02674177f, 
    -0.07054345f, -0.27763286f, 0.19644493f, 0.08253524f, 0.00070862f, -0.11830167f, 0.05022300f, -0.00082979f, 
    -0.06076796f, -0.11839695f, 0.04581033f, 0.06804179f, -0.08448784f, -0.28635821f, 0.20647518f, 0.20723797f, 
    -0.39442939f, 0.21094519f, 0.01862899f, -0.01517391f, -0.01821502f, 0.00854261f, 0.05485431f, 0.11379135f, 
    0.01780992f, -0.08100125f, 0.10237870f, 0.04036982f, -0.15015839f, -0.05741309f, 0.14118281f, -0.03473382f, 
    0.19647920f, 0.33827212f, -0.09701301f, -0.04150333f, 0.23683082f, -0.02125534f, -0.08643413f, 0.01267050f, 
    -0.07727479f, 0.02764599f, 0.11618715f, -0.02228685f, -0.04954646f, -0.05653345f, -0.05446057f, 0.00115097f, 
    0.20283610f, -0.24293099f, 0.21886759f, 0.04432302f, 0.06036511f, 0.09485620f, 0.10719624f, 0.17288828f, 
    -0.40774208f, -0.14207049f, -0.04255211f, 0.01475582f, -0.14636621f, 0.11777345f, -0.05323816f, 0.00650365f, 
    0.07624961f, -0.06133978f, -0.08221997f, 0.07630932f, 0.00699522f, 0.12151907f, 0.19185688f, 0.17471276f, 
    -0.26939595f, -0.03373731f, -0.00769326f, 0.51649690f, 0.02952506f, -0.19406660f, 0.06044254f, 0.00608377f, 
    0.02944372f, 0.01128794f, 0.19865574f, -0.01972661f, -0.01067415f, 0.03788625f, 0.08455169f, 0.08560659f, 
    0.04236544f, -0.12303653f, -0.09259888f, -0.24983935f, 0.20729926f, 0.00728304f, 0.09719642f, 0.22944728f, 
    0.38029063f, -0.18031619f, -0.06432109f, 0.08360383f, -0.03342126f, -0.10232037f, -0.10262228f, -0.21451250f, 
    0.07559248f, 0.23070198f, 0.15355431f, -0.06525987f, -0.01946073f, 0.09987872f, 0.01008310f, -0.04799582f, 
    -0.29068616f, 0.37950307f, -0.05395621f, 0.09123915f, 0.22285298f, -0.04882739f, -0.22368659f, 0.03236642f, 
    -0.10318831f, -0.10915121f, 0.06049482f, 0.08150323f, -0.09710603f, -0.13785979f, 0.01513327f, 0.03508982f, 
    0.05239579f, 0.09372003f, 0.09591179f, -0.04302721f, -0.02233816f, -0.25242054f, -0.30943283f, -0.07433362f, 
    0.30210128f, 0.12532227f, -0.03897301f, 0.11809397f, -0.03475740f, 0.18033615f, 0.08862933f, 0.07632757f, 
    0.09969149f, 0.19964187f, 0.20337258f, 0.07045063f, -0.00767973f, -0.04560042f, -0.44083923f, 0.06685307f, 
    0.06595718f, 0.27896744f, -0.24162124f, -0.55073589f, -0.09004778f, 0.11548727f, 0.07385073f, 0.09471802f, 
    0.04590135f, 0.14326520f, -0.05138903f, -0.00757814f, -0.11869504f, -0.02053116f, -0.06795476f, 0.13473354f, 
    -0.32908297f, 0.02802879f, 0.12564464f, 0.12040367f, 0.24763380f, -0.19856615f, 0.33056945f, -0.20948869f, 
    0.44374782f, 0.11455709f, -0.09989499f, 0.18207058f, -0.17055286f, -0.14566597f, 0.06396766f, -0.10136361f, 
    -0.00128255f, -0.09194136f, -0.01200963f, -0.04074452f, 0.16438542f, 0.10528260f, 0.19059131f, -0.11558999f, 
    0.05974425f, -0.30430526f, -0.24705109f, -0.35244757f, 0.11417885f, -0.06575000f, 0.18001732f, -0.01796926f, 
    -0.08686722f, -0.12428696f, -0.14740247f, -0.23814684f, -0.17867164f, 0.06243290f, -0.22374831f, 0.19660579f, 
    0.10075387f, 0.14682752f, -0.00532242f, 0.16100237f, -0.17493978f, 0.25848863f, 0.43382195f, -0.08087406f, 
    -0.28947628f, 0.27264404f, 0.10473001f, 0.15777272f, 0.05900969f, -0.20031497f, -0.19559260f, -0.00623234f, 
    -0.22505315f, 0.06917388f, -0.21153840f, 0.12127761f, -0.01190204f, 0.00569883f, 0.15492153f, 0.01247337f, 
    0.86985141f, -0.58505803f, -0.04813384f, 0.36162481f, 0.20052217f, -0.07786465f, -0.13908693f, -0.14591560f, 
    0.03672076f, 0.09066620f, -0.07332382f, -0.04006813f, -0.09695291f, -0.12954189f, 0.03750033f, 0.07925815f, 
    -0.00541455f, -0.00865363f, -0.15295771f, 0.18465342f, 0.22541055f, -0.16536382f, 0.01518854f, 0.11256732f, 
    -0.00171994f, 0.09685719f, 0.08834641f, 0.03474365f, -0.01878304f, -0.06194149f, -0.12523645f, 0.09543373f, 
    0.09021304f, 0.02787672f, -0.01046698f, -0.02445131f, -0.26291028f, 0.14005110f, -0.19339877f, -0.05665329f, 
    -0.01529403f, 0.01546428f, -0.15897201f, 0.09738678f, -0.33065313f, 0.04012953f, 0.25824088f, -0.24810904f, 
    -0.03773117f, 0.09946501f, -0.01790859f, -0.04088725f, 0.15464406f, 0.06968489f, -0.01611733f, -0.07197979f, 
    0.00054210f, 0.18309522f, -0.09522974f, 0.08295542f, -0.05827845f, -0.26642656f, -0.02077634f, -0.59553778f, 
    0.24375081f, -0.34429628f, 0.02234715f, -0.18671286f, 0.05388109f, -0.19112566f, -0.06973358f, 0.06130722f, 
    -0.03261836f, 0.13823038f, 0.13387269f, 0.06998160f, -0.07312723f, -0.00724806f, -0.08052810f, 0.09248716f, 
    0.27131090f, -0.92952144f, -0.16436453f, -0.36177236f, -0.02085057f, -0.02450511f, 0.08753446f, 0.11144279f, 
    -0.06653168f, -0.04028555f, 0.03103930f, -0.06654140f, 0.15112904f, 0.19082211f, 0.11660136f, -0.08471037f, 
    -0.04961748f, -0.03383772f, -0.08561470f, 0.07155193f, -0.07797620f, 0.23598798f, -0.35459852f, 0.32994094f, 
    -0.38134792f, -0.24424507f, 0.09573572f, 0.08147953f, 0.14061353f, -0.06867950f, -0.02146238f, 0.05667233f, 
    0.07133474f, 0.04975126f, 0.07925576f, -0.09436561f, -0.03325617f, 0.15900849f, -0.32624546f, 0.04581994f, 
    -0.00216035f, -0.04099097f, -0.20126961f, 0.18319300f, -0.06749504f, 0.02395820f, 0.13720728f, -0.18364052f, 
    0.08047219f, 0.10600533f, -0.12217532f, 0.01766779f, -0.02566781f, -0.00480150f, 0.05273002f, 0.09995957f, 
    -0.06716780f, 0.16271272f, -0.38106367f, -0.05876049f, -0.54325157f, 0.28205141f, -0.12869163f, 0.17047049f, 
    -0.29438511f, -0.09017614f, -0.09708933f, -0.09247253f, 0.07422004f, -0.13263719f, 0.15156674f, 0.03908960f, 
    0.09640682f, 0.02363659f, 0.06355831f, -0.05275140f, -0.03415756f, -0.16611177f, 0.01634999f, -0.31600395f, 
    -0.15185310f, -0.12166506f, -0.09214560f, -0.12466020f, 0.57834381f, -0.06048957f, 0.13710576f, 0.15130100f, 
    0.04723557f, -0.01961487f, -0.22199798f, -0.02022342f, -0.01132839f, -0.01111403f, 0.16516438f, -0.04156946f, 
    -0.06961294f, 0.25536659f, 0.06458931f, 0.23136215f, -0.60280609f, 0.68333554f, 0.24027899f, 0.03855108f, 
    -0.60719794f, 0.04943951f, -0.01504361f, 0.07621200f, 0.04033742f, 0.03186794f, -0.03606662f, 0.16123842f, 
    0.07964983f, -0.12344772f, -0.03842375f, 0.10394387f, -0.22284837f, -0.15872888f, -0.08794295f, 0.06530571f, 
    -0.68305814f, -0.25776890f, -0.14930631f, 0.33015999f, 0.36928752f, 0.25022525f, 0.02454706f, 0.11047378f, 
    0.16755259f, -0.00502255f, 0.11724146f, -0.04636219f, 0.12241598f, -0.05262320f, -0.24276750f, 0.05110991f, 
    0.00533914f, -0.21510473f, 0.01335214f, 0.05774991f, -0.18109769f, -0.01350561f, -0.12201338f, -0.23257999f, 
    0.11474342f, -0.02427656f, 0.04837149f, -0.17699291f, -0.31002325f, -0.16191435f, 0.11158209f, -0.03716296f, 
    -0.06682771f, -0.09857631f, 0.05083083f, -0.09191321f, -0.02317024f, 0.14727716f, 0.14106959f, 0.00423614f, 
    0.24344118f, -0.05904474f, -0.06846807f, 0.03761294f, 0.35482305f, -0.03143515f, -0.11217120f, -0.09914394f, 
    -0.05555322f, -0.13467792f, -0.09866027f, 0.07551077f, -0.03424571f, -0.08904943f, -0.12408678f, 0.00968970f, 
    -0.12360232f, -0.07694012f, -0.03000497f, -0.00223011f, 0.24088727f, 0.44478497f, 0.21436417f, -0.10339092f, 
    0.30258417f, -0.20336875f, 0.22482631f, -0.21278636f, 0.01551457f, 0.03881096f, -0.12291870f, -0.03175214f, 
    -0.15159261f, -0.09257023f, 0.06843624f, -0.01602571f, 0.10020871f, 0.07634158f, -0.15789384f, 0.01907133f, 
    0.16488685f, 0.41368553f, 0.12511978f, 0.14967100f, 0.36513358f, -0.09663492f, 0.17845035f, -0.07103729f, 
    0.02764605f, -0.06169837f, -0.08714761f, -0.02314598f, -0.06753872f, -0.08984929f, -0.01209914f, -0.00597688f, 
    0.10802186f, 0.07403688f, -0.13790257f, -0.04323419f, 0.18581736f, -0.92886472f, 0.20991866f, -0.06732029f, 
    -0.21702884f, 0.05916411f, -0.04172049f, -0.02682126f, 0.05376859f, -0.00130518f, -0.14897867f, -0.01131526f, 
    -0.16554794f, 0.10854738f, -0.18677956f, -0.06007235f, 0.13054328f, -0.11694361f, 0.02105235f, -0.11364665f, 
    0.46059486f, 0.17778622f, 0.08835294f, 0.22667466f, -0.09397160f, 0.24211374f, 0.06913994f, -0.03445850f, 
    0.04807157f, 0.09753805f, -0.08756225f, -0.03516719f, 0.09703157f, 0.04827678f, 0.03442780f, 0.13944738f, 
    0.08429115f, 0.00230778f, 0.05118482f, 0.00850739f, 0.11755671f, -0.11690673f, -0.04462856f, 0.02666672f, 
    -0.17271726f, 0.01495858f, -0.00157620f, 0.15866987f, -0.05127181f, -0.14322820f, -0.00080078f, -0.09481937f, 
    -0.08352185f, 0.11030292f, -0.00479917f, 0.01585734f, 0.07122383f, -0.04055200f, 0.00578261f, -0.12129852f, 
    -0.38709989f, 0.35042322f, -0.29899114f, -0.15368065f, 0.01294020f, 0.05603363f, 0.06172492f, -0.28699845f, 
    0.03970874f, 0.02968759f, -0.26934558f, 0.09898249f, 0.06168310f, -0.08178428f, -0.06479154f, -0.08789119f, 
    -0.03327100f, 0.08764413f, -0.03150496f, 0.15516095f, 0.08385653f, 0.33773088f, 0.28890410f, 0.22513713f, 
    0.38494742f, 0.10904933f, 0.14199120f, 0.02701485f, -0.00018267f, 0.03562768f, -0.10821603f, -0.00798735f, 
    0.07983851f, -0.02597465f, -0.16397007f, 0.02419110f, -0.04560841f, 0.00792860f, -0.03067840f, -0.00137116f, 
    -0.02304550f, 0.16938575f, 0.35938588f, 0.15908536f, 0.25809714f, 0.17084529f, 0.10531134f, 0.10150845f, 
    -0.02379422f, -0.16578186f, -0.09489045f, 0.05208839f, 0.04434558f, -0.04624150f, -0.08770013f, -0.18549776f, 
    0.06828690f, -0.00604566f, -0.03065994f, -0.12285854f, -0.25175285f, 0.32058260f, -0.03184979f, -0.08160853f, 
    -0.20033719f, 0.00892029f, -0.11001444f, 0.04348813f, 0.00190173f, -0.11899896f, -0.19559713f, 0.11883398f, 
    0.08446296f, 0.02057724f, -0.21322842f, 0.09239248f, -0.00283349f, -0.00744072f, 0.04060388f, -0.10581164f, 
    -0.69245458f, 0.21852285f, -0.07522871f, 0.03580175f, -0.08404443f, -0.06104420f, -0.04090699f, -0.11881882f, 
    -0.04045333f, -0.05249608f, -0.06661683f, 0.00189579f, -0.08682274f, -0.05401372f, -0.09409244f, 0.03347814f, 
    -0.08222983f, 0.03138471f, -0.07467898f, -0.04866347f, -0.37131006f, -0.21939410f, 0.12140517f, -0.41362864f, 
    -0.46906888f, 0.01116489f, 0.00216180f, -0.04131246f, -0.04586272f, -0.16771513f, 0.00619114f, -0.10509796f, 
    -0.14775401f, -0.14472136f, -0.17935231f, -0.17243370f, 0.00885991f, 0.03367762f, 0.01507712f, 0.00447674f, 
    -0.09823433f, 0.12993716f, -0.46219084f, 0.00105297f, 0.24003066f, -0.12171312f, -0.13745557f, -0.26373264f, 
    0.00410623f, -0.06698745f, -0.19177428f, 0.11023268f, -0.01466793f, -0.14644708f, -0.08981367f, -0.03050026f, 
    -0.27536985f, -0.11243674f, -0.02907139f, -0.02373133f, -0.65928191f, -0.33702260f, -0.59036952f, -0.27077311f, 
    -0.11612534f, -0.08958583f, -0.20410186f, -0.02154047f, -0.01662684f, -0.07195759f, -0.26667717f, -0.04342695f, 
    0.12179426f, -0.01585033f, -0.23143642f, -0.00636426f, 0.03611003f, -0.01131887f, -0.00248237f, 0.08442625f, 
    -0.02769049f, -0.06804984f, 0.18428856f, -0.18058011f, -0.01980066f, -0.13770075f, 0.21455410f, -0.15928988f, 
    -0.24254647f, 0.06211561f, 0.02060072f, 0.17648828f, -0.08008208f, -0.08550670f, -0.07637876f, -0.01063879f, 
    0.05525574f, -0.01686535f, -0.16697864f, -0.04117141f, 0.17145111f, -0.04227536f, 0.32452592f, 0.10133105f, 
    0.15980527f, 0.11020713f, -0.02585723f, -0.13165806f, -0.16124293f, -0.08035894f, -0.06349185f, 0.10111334f, 
    -0.05545628f, -0.10423393f, -0.00936338f, -0.16461897f, -0.13040489f, -0.01463938f, 0.16974999f, 0.01047452f, 
    -0.34350255f, -0.28526381f, 0.04761203f, -0.83028567f, -0.33000970f, -0.06874821f, -0.19137768f, 0.02258509f, 
    0.00572881f, -0.20482662f, 0.04970916f, 0.08537833f, 0.04260720f, -0.05737919f, 0.04763534f, -0.02433223f, 
    -0.01942543f, 0.05828213f, -0.51573896f, -0.07524915f, -0.36415595f, 0.22860369f, 0.10903550f, -0.28892282f, 
    -0.42586508f, 0.07056580f, -0.08751726f, 0.03668506f, 0.00850460f, -0.22912414f, 0.19608422f, 0.01026167f, 
    0.06556867f, 0.16186222f, 0.10159111f, -0.07246663f, 0.09098394f, -0.18172047f, 0.15776773f, 0.16733432f, 
    -0.18179712f, 0.32420141f, -0.01589159f, -0.13953036f, -0.65907592f, -0.09794211f, -0.03978953f, 0.01739972f, 
    -0.10711832f, -0.13333252f, 0.18962033f, -0.06240867f, 0.10930974f, -0.07237746f, 0.08503880f, -0.24623455f, 
    0.01372761f, -0.16113737f, 0.03236101f, 0.00974475f, -0.08441855f, -0.20506352f, -0.51901448f, 0.08217211f, 
    0.23116121f, 0.02497121f, 0.00693762f, -0.07437064f, -0.06370080f, -0.05388923f, 0.03092881f, 0.14961219f, 
    0.04739741f, 0.09684217f, 0.07713819f, 0.08866759f, -0.01180535f, 0.04197118f, 0.16854507f, 0.08271997f, 
    -0.22804254f, -0.21993856f, -0.26853907f, -0.21808834f, -0.16522111f, 0.01231387f, -0.05705154f, 0.01048248f, 
    -0.07515530f, -0.01239618f, 0.13877654f, -0.07954877f, -0.16959988f, 0.08647413f, 0.18951845f, 0.04709357f, 
    0.10317591f, -0.04335473f, 0.04092769f, 0.06988703f, 0.25914425f, -0.10630332f, -0.46238726f, 0.06562719f, 
    -0.14416243f, 0.01396417f, -0.04727025f, 0.01091158f, -0.07246160f, 0.04155734f, -0.14364013f, -0.12171445f, 
    0.05382938f, 0.15201834f, -0.01002128f, 0.12197442f, -0.04233237f, -0.06923955f, 0.05835800f, -0.03916666f, 
    -0.10031967f, 0.14753561f, -0.36316568f, -0.16274384f, -0.22593039f, 0.14925021f, 0.12249572f, -0.19310319f, 
    0.04751502f, -0.06277093f, 0.17109144f, -0.02496830f, -0.00402384f, 0.10324136f, 0.05085911f, -0.00834073f, 
    -0.03613539f, 0.05128401f, 0.09847006f, -0.05464644f, -0.23678787f, -0.06447168f, 0.50261688f, -0.09982078f, 
    -0.00730109f, -0.12500022f, -0.14832199f, -0.19817805f, -0.06343541f, -0.01001665f, 0.01633363f, 0.09533703f, 
    -0.10880307f, 0.06425168f, 0.08612308f, -0.06884553f, 0.11109956f, -0.18553902f, 0.01560428f, 0.02778124f, 
    -0.20099045f, -0.11350342f, 0.48632982f, 0.02743267f, 0.19615857f, -0.22953258f, -0.09355954f, 0.04670760f, 
    -0.04241049f, 0.05851333f, 0.01429741f, -0.10825635f, 0.03299865f, -0.30972242f, -0.01493243f, -0.04395695f, 
    -0.10020956f, -0.09299732f, 0.06569146f, 0.07707956f, 0.24433447f, 0.22137634f, 0.11766368f, 0.23654376f, 
    0.19555975f, -0.00525280f, -0.03048537f, -0.12323865f, 0.01743116f, -0.01211429f, 0.15549651f, -0.07741082f, 
    0.03746311f, -0.16237734f, 0.16913916f, -0.02230134f, -0.01675191f, 0.03488217f, 0.08677716f, -0.02585041f, 
    0.18646215f, 0.22727828f, -0.02256890f, 0.27600968f, -0.13405073f, 0.02790767f, 0.10211491f, -0.07489824f, 
    -0.20940280f, 0.04487034f, 0.07386687f, -0.04273058f, 0.09261686f, 0.02427513f, 0.09654898f, -0.02039606f, 
    -0.04875827f, 0.01907977f, 0.19039336f, -0.09781679f, 0.18723610f, 0.25524455f, -0.10974093f, 0.15231287f, 
    0.31606585f, 0.22558104f, 0.14040746f, -0.13801301f, -0.01771014f, -0.12316131f, -0.08064779f, -0.09952943f, 
    -0.10090192f, -0.13378766f, -0.20160525f, -0.19276123f, 0.00384864f, 0.10527687f, 0.12762845f, -0.08477303f, 
    -0.17216875f, 0.19431552f, 0.16087446f, -0.04071345f, -0.01786026f, -0.12503147f, -0.09691092f, -0.12341318f, 
    -0.15304014f, -0.27437836f, 0.19718139f, 0.06709994f, -0.11115330f, 0.05107056f, -0.04525783f, -0.08997434f, 
    0.09470073f, -0.07015025f, -0.01840511f, -0.19891676f, -0.07474605f, -0.36467990f, -0.13287358f, 0.10354882f, 
    0.28887495f, 0.13068670f, 0.15258145f, -0.07768938f, -0.05712669f, 0.00919297f, -0.05069343f, -0.04331818f, 
    0.02111856f, -0.07098314f, 0.07792740f, -0.17737447f, 0.21398327f, 0.13342141f, 0.17547387f, -0.03989970f, 
    0.14108907f, 0.19328564f, -0.19025925f, 0.10462927f, 0.12649576f, -0.01778947f, -0.14026961f, -0.07955310f, 
    -0.07866836f, -0.02902316f, 0.07241799f, 0.07468764f, -0.00794596f, -0.10400829f, 0.06171817f, -0.01829426f, 
    -0.12791370f, 0.00869478f, 0.09068626f, -0.01223073f, -0.29521260f, -0.28502315f, 0.27930436f, -0.29852995f, 
    -0.16098273f, 0.09184294f, -0.01131387f, -0.08168395f, -0.09554891f, -0.13143839f, 0.12503229f, 0.05744955f, 
    -0.01109185f, 0.12873617f, -0.05844084f, 0.02296122f, 0.01742724f, -0.19294572f, -0.44917899f, 0.15949441f, 
    -0.00440774f, -0.20700851f, 0.00070450f, -0.31960508f, 0.03077939f, -0.24840939f, 0.13869382f, -0.01086656f, 
    0.03812806f, 0.05678524f, 0.05539401f, -0.06445295f, -0.04774623f, -0.06533617f, -0.11885155f, 0.07613624f, 
    0.21653704f, 0.05713770f, 0.16848618f, 0.01549072f, -0.18405956f, -0.00342316f, -0.39463165f, 0.26514429f, 
    -0.06691092f, -0.02256931f, 0.18953592f, -0.05559027f, 0.01494518f, -0.08950202f, -0.16755602f, -0.15543573f, 
    -0.01113389f, 0.08376232f, 0.17776079f, 0.23927809f, -0.01602713f, 0.02694950f, -0.08943768f, 0.12506576f, 
    -0.56219685f, 0.35022435f, -0.09242778f, 0.06984386f, -0.08091990f, 0.13671446f, -0.11747120f, -0.13583788f, 
    -0.02839905f, 0.02241946f, -0.02343288f, 0.00537772f, 0.16813877f, 0.09124448f, 0.26429921f, 0.03005726f, 
    0.10192827f, 0.18469030f, -0.11054182f, -0.01419057f, 0.37859213f, -0.75425053f, 0.34818086f, -0.43331704f, 
    -0.43728408f, -0.22149375f, -0.04037004f, -0.12643468f, 0.01764947f, -0.01564481f, -0.02143441f, 0.01075240f, 
    0.19070596f, -0.28205842f, -0.22140381f, 0.04911765f, 0.05697737f, -0.01856297f, 0.02165346f, 0.10327294f, 
    -0.06968835f, -0.57650745f, 0.11366427f, 0.10164468f, 0.58253014f, 0.09835666f, 0.08621771f, 0.00593941f, 
    0.03047018f, -0.12563825f, -0.01812525f, -0.23933233f, -0.14229824f, -0.00527047f, 0.10632870f, 0.08415896f, 
    0.09988799f, -0.02042685f, -0.04061373f, 0.12767392f, -0.28317320f, -0.12922174f, 0.06216269f, -0.21054886f, 
    -0.30319068f, 0.21645351f, -0.18768366f, -0.04156632f, 0.06144928f, -0.10753160f, -0.08826886f, 0.02727332f, 
    -0.10261046f, 0.21115787f, 0.02842871f, -0.19278313f, 0.05261466f, 0.09414658f, 0.11726066f, 0.14152639f, 
    -0.24901018f, 0.10831861f, 0.25727195f, -0.27855399f, -0.49093789f, 0.06923997f, 0.03473155f, 0.16332984f, 
    0.08475492f, 0.09849738f, -0.00697472f, -0.13426343f, 0.05198973f, 0.02985712f, -0.06783063f, -0.08576642f, 
    -0.01483574f, -0.16791053f, 0.15268616f, -0.17932209f, -0.51652414f, -0.23501453f, -0.23919569f, 0.25265837f, 
    -0.09502182f, 0.06556415f, 0.03232775f, -0.08338194f, -0.09667045f, 0.07489908f, -0.23569879f, -0.03923540f, 
    0.03636419f, 0.13026249f, 0.09800389f, -0.01312677f, -0.21236068f, 0.04895118f, 0.15101621f, -0.10961989f, 
    0.63792872f, -0.25008178f, -0.10630549f, 0.22553796f, 0.08811425f, 0.09556685f, -0.13212809f, -0.12051068f, 
    0.09127942f, 0.33174336f, -0.10812204f, 0.14171787f, -0.07941416f, 0.09482650f, -0.04361665f, -0.03654045f, 
    -0.14400232f, 0.04332396f, -0.10658613f, -0.06274581f, -0.50190431f, 0.32573274f, 0.23043671f, -0.40469015f, 
    0.28946093f, -0.00805452f, 0.24423879f, -0.11326596f, -0.06052143f, 0.01443440f, -0.09967332f, -0.05198507f, 
    0.06381450f, -0.04075894f, 0.10889579f, 0.18462372f, 0.06054303f, -0.05485888f, -0.07734447f, 0.15359525f, 
    -0.68617260f, 0.49639115f, 0.24569106f, -0.07232784f, 0.28311521f, 0.18909466f, 0.14025007f, -0.03817058f, 
    0.01885739f, -0.06518073f, -0.04999102f, -0.05745188f, 0.10042664f, 0.04168041f, 0.05746395f, 0.17877136f, 
    -0.10627885f, 0.18883805f, -0.32273006f, 0.06209175f, 0.10179899f, -0.20696950f, 0.18369226f, 0.17596450f, 
    -0.18489449f, -0.04598009f, 0.22038852f, 0.01238586f, -0.15353540f, -0.08722217f, 0.22042452f, -0.07061540f, 
    -0.12848455f, 0.00825584f, -0.06417309f, 0.01771344f, 0.00206081f, -0.06160645f, -0.25902683f, -0.08656670f, 
    0.90772635f, 0.18132561f, -0.28451270f, -0.54312295f, -0.16075253f, 0.02632001f, 0.02603175f, 0.11074279f, 
    0.05331290f, 0.10427885f, -0.14531516f, -0.07691814f, 0.17216597f, 0.02951122f, -0.19142637f, 0.01077149f, 
    0.15838932f, -0.08866341f, -0.09960341f, 0.03060472f, -0.05427547f, -0.03855444f, 0.10631336f, -0.42715892f, 
    -0.57980877f, 0.14615580f, 0.21297610f, -0.32004586f, -0.06255289f, -0.06104237f, -0.12058173f, 0.01282436f, 
    -0.13399523f, -0.21009277f, -0.05211951f, -0.16545482f, 0.01502698f, 0.00092317f, -0.02409951f, 0.00641720f, 
    -0.37980163f, -0.10163707f, 0.22886291f, 0.19395538f, -0.29239604f, 0.03730707f, 0.13582925f, -0.14220105f, 
    0.25854620f, -0.07960700f, -0.22987762f, 0.05451851f, 0.12610611f, 0.05258946f, -0.10626343f, 0.09407836f, 
    0.00376367f, 0.01840266f, -0.15673697f, -0.25618428f, -0.21172555f, -0.39942768f, 0.07935431f, 0.39496407f, 
    0.07218584f, -0.11220781f, 0.07199172f, 0.00895701f, -0.07834852f, 0.03160730f, 0.01549082f, 0.08995450f, 
    0.08246435f, -0.24570690f, -0.02872512f, 0.02638154f, -0.10467602f, -0.02372620f, 0.34397817f, 0.08937122f, 
    0.50965101f, 0.42333484f, 0.13271567f, -0.02679097f, -0.14377686f, 0.12249989f, 0.02584315f, 0.06532028f, 
    -0.00161106f, 0.12570357f, -0.11295523f, -0.08153930f, 0.07608053f, -0.05494115f, -0.07242415f, 0.03142895f, 
    0.12325879f, -0.41464040f, -0.28922549f, 0.03427301f, -0.32677829f, -0.23318774f, 0.13053571f, -0.06150078f, 
    0.32299367f, 0.05207725f, -0.06421475f, 0.18553063f, -0.05067309f, 0.02934714f, -0.07326805f, -0.01358010f, 
    -0.00030237f, 0.04351205f, 0.23371628f, 0.06605142f, -0.08786356f, -0.14616056f, -0.15583634f, 0.02058225f, 
    -0.55751979f, -0.40171641f, 0.25252625f, 0.07177534f, 0.04907457f, -0.01181966f, 0.13156891f, 0.08961800f, 
    0.01103070f, 0.02799964f, 0.14642324f, 0.00151034f, -0.07598777f, -0.15978210f, -0.04984617f, -0.09106212f, 
    -0.18600868f, -0.47123200f, -0.10314365f, -0.19420925f, -0.62600631f, -0.03085944f, 0.02908986f, -0.07992905f, 
    -0.05950321f, 0.09041145f, -0.00537131f, -0.10892820f, 0.04750371f, 0.15446337f, 0.00443055f, -0.09859993f, 
    -0.11722281f, -0.05248853f, 0.19486758f, 0.18449984f, -0.02868534f, 0.00371370f, -0.18602385f, -0.03816610f, 
    -0.52448779f, 0.33018643f, -0.34058577f, 0.04456128f, 0.31293997f, -0.03688730f, -0.04781380f, 0.02553239f, 
    -0.02949284f, 0.14426458f, 0.03409288f, 0.05103701f, -0.01917520f, -0.20430902f, 0.12939103f, -0.05108973f, 
    -0.05627408f, 0.07330266f, -0.07157548f, -0.03417920f, -0.30903685f, -0.05427679f, -0.32182509f, -0.01188914f, 
    -0.19786680f, 0.00244157f, 0.08776319f, -0.10012111f, 0.01742297f, 0.23197003f, 0.12482593f, 0.10017100f, 
    0.00600291f, -0.06441974f, 0.02639383f, 0.15533195f, 0.01385572f, 0.18871872f, 0.06358322f, 0.14136119f, 
    -0.40181184f, -0.37876502f, -0.18389411f, 0.06561778f, 0.24880691f, 0.11658090f, -0.06404977f, -0.03861823f, 
    -0.01114193f, -0.26104620f, 0.04728049f, 0.16887282f, 0.09979253f, 0.14106636f, -0.15412234f, 0.18761238f, 
    0.08486430f, 0.03537629f, 0.11008073f, 0.14964624f, 0.44462326f, 0.16219562f, -0.05995118f, -0.01245761f, 
    -0.17954604f, -0.12766282f, -0.19626945f, 0.00759247f, -0.04776032f, 0.10012721f, 0.03771154f, 0.06610502f, 
    -0.21696027f, 0.02031254f, -0.20467676f, 0.00030702f, -0.05513468f, -0.12005353f, -0.15010208f, -0.21477759f, 
    0.49339426f, 0.23846906f, -0.23402077f, 0.17339702f, -0.15584967f, -0.22019811f, -0.24279952f, 0.07559185f, 
    -0.04428336f, -0.04633821f, -0.04991952f, 0.13403283f, -0.11741261f, -0.13169588f, -0.11848717f, -0.10229203f, 
    0.04015008f, 0.12186551f, -0.19606453f, 0.09337825f, -0.94843221f, -0.48565605f, -0.39696547f, -0.33030593f, 
    -0.40707621f, 0.21316163f, 0.03541235f, -0.09258715f, 0.00743617f, -0.02275037f, 0.14871198f, 0.03398278f, 
    0.07565399f, 0.04754022f, 0.05884708f, -0.01292374f, -0.14768478f, 0.01198989f, 0.15240571f, -0.01672670f, 
    -0.29969764f, -0.14396559f, -0.17988621f, -0.02317062f, -0.14964786f, 0.11939976f, 0.09567693f, 0.15722655f, 
    0.02192053f, 0.07637673f, 0.31576318f, 0.06387190f, -0.09391908f, -0.04380735f, 0.11465906f, 0.10680369f, 
    0.00873854f, -0.00416868f, 0.25856370f, 0.11228051f, -0.63793999f, -0.43910596f, -0.33239368f, -0.24003312f, 
    -0.17558324f, 0.15095958f, -0.06713989f, -0.17485535f, -0.13558248f, -0.05680902f, -0.07284620f, -0.00070299f, 
    -0.09009593f, 0.14686175f, 0.06605703f, -0.13090348f, 0.04259063f, 0.22537677f, 0.18521908f, 0.17168240f, 
    -0.45132440f, -0.09077787f, 0.44860560f, 0.11689127f, -0.01127660f, 0.06306831f, 0.02763812f, 0.05641717f, 
    -0.12541337f, 0.22892979f, 0.11280362f, 0.18499745f, 0.09088188f, 0.06986067f, 0.04229764f, -0.08730476f, 
    -0.03000168f, -0.02303868f, 0.08935305f, 0.06258908f, -1.16744375f, -0.51076031f, 0.12484094f, -0.39897200f, 
    -0.59012580f, 0.00872640f, -0.02744245f, -0.15197040f, -0.17157623f, 0.06503388f, 0.07009681f, 0.14092979f, 
    -0.06706751f, 0.25487909f, -0.02342551f, -0.02794007f, -0.16717806f, -0.07555111f, -0.13911134f, -0.12730832f, 
    -0.07902572f, -0.16743983f, -0.11540472f, -0.13713551f, 0.17463134f, -0.15269901f, 0.15485309f, 0.11719532f, 
    -0.02976049f, -0.04880581f, -0.02283274f, 0.04406264f, 0.02806088f, -0.23874098f, 0.16211540f, -0.08242639f, 
    0.19742303f, 0.24269496f, 0.07437495f, 0.10291076f, 0.47729915f, 0.32475096f, 0.06480703f, -0.11066620f, 
    0.07860518f, 0.25915608f, 0.05884193f, 0.29948226f, -0.01662545f, -0.05145289f, -0.10458329f, -0.08682874f, 
    0.04181701f, 0.16682345f, -0.18840595f, 0.09897374f, 0.08638651f, -0.09350722f, -0.06818030f, 0.20340504f, 
    0.05909399f, -0.09777731f, -0.16601703f, -0.03038931f, 0.56764358f, 0.08819379f, -0.08552063f, 0.03438320f, 
    0.03101566f, -0.15114954f, 0.07098865f, -0.10313600f, 0.09038318f, -0.06982908f, -0.04430184f, 0.16823950f, 
    0.02356431f, 0.11043414f, 0.16331884f, 0.07147650f, -0.29963022f, 0.33936816f, -0.21646348f, -0.11081892f, 
    0.12071165f, 0.17029583f, -0.29825747f, 0.13430078f, -0.09911601f, 0.04842395f, 0.09907492f, 0.24187577f, 
    -0.04688194f, 0.02108174f, 0.09763115f, 0.04455910f, 0.17280370f, -0.07269876f, -0.11891636f, 0.02800340f, 
    -0.15450385f, 0.30952892f, -0.18880296f, 0.08959686f, 0.09809575f, 0.04070017f, -0.15416473f, -0.00579054f, 
    -0.13654976f, -0.06787724f, 0.11292941f, 0.12159559f, -0.09619322f, -0.19339760f, 0.05260212f, -0.02275053f, 
    0.13737461f, -0.08223951f, 0.09303536f, 0.05657399f, 0.58798993f, 0.24635258f, -0.41449580f, -0.03761655f, 
    -0.22982173f, -0.21086718f, -0.13432638f, 0.00293816f, 0.09684743f, 0.06834511f, 0.04876820f, 0.08377676f, 
    -0.06663699f, 0.04269017f, -0.01539426f, 0.01507526f, 0.07641249f, 0.04807240f, 0.10318409f, -0.03502580f, 
    -0.51301074f, 0.00477838f, 0.09070431f, 0.07668647f, -0.07929540f, -0.06694185f, 0.07489462f, -0.12978078f, 
    0.02834315f, -0.09720963f, -0.16694064f, 0.06410731f, 0.05860335f, 0.18390460f, 0.09233402f, 0.05803085f, 
    0.02309898f, -0.05658027f, -0.03577458f, 0.01904233f, 0.67273819f, 0.08900137f, -0.26417100f, 0.14929478f, 
    -0.01495359f, 0.03757654f, -0.05563911f, 0.08341106f, 0.05636014f, 0.10788099f, 0.00914658f, -0.17736243f, 
    0.12392741f, 0.03457442f, -0.00542840f, 0.20339689f, -0.04401295f, -0.10586397f, -0.10952552f, -0.08192611f, 
    0.16929898f, 0.32322729f, -0.30049321f, 0.06057955f, 0.46432245f, 0.47641587f, 0.02769048f, 0.00274810f, 
    0.01284202f, -0.04918749f, 0.07240942f, 0.18251638f, -0.00211999f, -0.08250920f, -0.03796916f, 0.03316122f, 
    -0.00603057f, 0.00110950f, -0.26086956f, 0.18645504f, 0.50872368f, -0.28584483f, 0.18205309f, -0.25054279f, 
    0.10280573f, -0.23764482f, 0.05613824f, -0.24987854f, -0.06057293f, -0.49573258f, -0.10146726f, -0.16509388f, 
    0.12882553f, 0.16121426f, -0.33455181f, -0.16721454f, -0.14641263f, 0.12601995f, -0.06353409f, 0.10138707f, 
    -0.18671004f, 0.02895520f, 0.26025292f, -0.05727391f, -0.08939578f, -0.10848064f, 0.00337722f, 0.06911799f, 
    -0.05788362f, -0.22011165f, -0.10332675f, -0.13742137f, 0.07497567f, 0.02121596f, 0.02635753f, -0.17442931f, 
    -0.00859800f, -0.13039382f, -0.20716941f, 0.00240462f, 0.25229385f, -0.54823571f, -0.39524436f, -0.05502902f, 
    -0.45648924f, 0.16054444f, 0.15336613f, 0.11554054f, -0.06014233f, -0.14521325f, 0.11408250f, -0.00306700f, 
    0.00595279f, -0.06347950f, -0.03127708f, -0.06747655f, 0.08084698f, -0.15515244f, -0.04960212f, -0.08228678f, 
    0.16585420f, -0.56635916f, 0.10931396f, 0.10370480f, -0.17810294f, -0.01348344f, 0.10019779f, 0.11136661f, 
    -0.03484938f, 0.15605931f, 0.01279378f, -0.00899675f, -0.04661772f, -0.00146572f, -0.13898240f, -0.09851532f, 
    0.00167635f, 0.01952882f, -0.11787482f, -0.00159240f, 0.30618614f, -0.41355431f, -0.27945599f, -0.10943241f, 
    -0.42193115f, 0.03397018f, 0.02506770f, -0.12386354f, 0.12346515f, 0.03409025f, 0.06002820f, 0.02290927f, 
    -0.04105261f, -0.11762126f, 0.15129174f, -0.03149742f, -0.04059051f, -0.11908136f, -0.03766974f, 0.03317312f, 
    0.02239211f, -0.81284440f, -0.11242457f, -0.04626875f, 0.09719674f, -0.03588725f, -0.06790556f, -0.03582827f, 
    0.14862934f, 0.08588430f, -0.10987391f, -0.17091593f, 0.10793270f, -0.06833684f, -0.19986825f, 0.04438292f, 
    0.13615622f, -0.02888652f, 0.01193072f, -0.25396526f, 0.61866891f, 0.35389712f, -0.55729371f, -0.24909966f, 
    -0.06162019f, -0.17435852f, -0.13840172f, -0.19966951f, -0.01273238f, 0.02354225f, 0.23317340f, 0.13039853f, 
    -0.04645069f, 0.04307147f, 0.15364634f, -0.02498638f, -0.01139451f, 0.07636608f, -0.04569127f, 0.09366477f, 
    -0.67432427f, 0.02689224f, 0.05697049f, 0.14700654f, -0.34044117f, 0.23585077f, 0.22280659f, 0.17391521f, 
    -0.03131397f, 0.28227478f, 0.02035938f, -0.11890741f, -0.11539027f, 0.00975631f, -0.01860539f, -0.04285178f, 
    0.08509358f, 0.00103523f, -0.06256093f, -0.04076529f, 0.09133725f, 0.54035258f, -0.20502971f, -0.24623522f, 
    -0.00566570f, -0.37462065f, -0.11456432f, 0.00769877f, -0.08566555f, -0.16549937f, 0.06543298f, -0.12448386f, 
    -0.26496491f, -0.00755461f, 0.11078633f, 0.16368446f, -0.13847418f, -0.07500597f, 0.17684402f, -0.09581216f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.06082381f, 0.03397367f, -0.02867849f, -0.00024974f, 0.02681431f, 0.01346811f, -0.04755103f, -0.08165998f, 
    -0.00333857f, -0.01340261f, 0.09349379f, 0.06124004f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
