#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.73388404f, 0.40960073f, -0.21302699f, 0.12736452f, -0.87519026f, -0.16295347f, -0.18752311f, 0.16255292f, 
    0.21440764f, -0.19799435f, 0.05127256f, -0.05493519f, 0.15447067f, 0.04948466f, -0.16368650f, -0.22783276f, 
    -0.15215755f, -0.24111961f, -0.22255701f, -0.19114943f, -0.04678185f, 0.16469859f, -0.07154310f, -0.05271580f, 
    -0.31012097f, -0.42971888f, 0.69160980f, -0.16966808f, -0.71035069f, -0.35635069f, 0.03590856f, 0.27110177f, 
    0.02927728f, 0.03399982f, -0.38410333f, -0.09334168f, 0.24907719f, -0.25789443f, 0.12377464f, 0.18404387f, 
    0.19106416f, 0.25314975f, 0.03089740f, 0.06059591f, 0.03935852f, -0.07095263f, -0.05961287f, 0.30237153f, 
    0.04886170f, 0.43724534f, -1.22504067f, 0.18937249f, 0.54189956f, 0.06602743f, -0.40084067f, 0.22423369f, 
    0.40620822f, 0.17479028f, 0.40919411f, -0.21023256f, -0.44515741f, -0.19721596f, -0.13621861f, -0.06851197f, 
    -0.06794493f, -0.23126632f, 0.01618690f, -0.01342402f, -0.21189611f, -0.29419351f, 0.21945125f, 0.06019675f, 
    -0.08189753f, 0.07632380f, 0.14699119f, -0.00578569f, -0.16342261f, -0.26059356f, -0.62560797f, 0.59001499f, 
    -0.48820946f, 0.27327323f, -0.12654191f, -0.54049039f, 0.26644841f, -0.03323370f, 0.24414502f, 0.19824734f, 
    0.22820072f, 0.36917704f, 0.20811781f, 0.11984806f, 0.01370411f, 0.33469245f, 0.36351392f, -0.18760261f, 
    -0.20653009f, -0.20339091f, 0.00660371f, 0.22540404f, -0.19669968f, 0.10837648f, -0.14831050f, -0.47345170f, 
    0.17996781f, -0.58292800f, 0.39203200f, -0.32491532f, -0.47985974f, -0.04602087f, -0.20818940f, -0.13604693f, 
    -0.17974225f, -0.50407028f, -0.40670434f, 0.14259163f, -0.05953934f, 0.25322512f, -0.46297094f, -0.44487679f, 
    -0.22037308f, -0.24394278f, -0.20959403f, 0.14091590f, 0.20760082f, 1.14514220f, 0.11322405f, -0.22186962f, 
    0.83994573f, 0.73196012f, 0.33817989f, 0.09718338f, -0.18056817f, 0.37886816f, 0.15646654f, -0.30025193f, 
    0.15821414f, -0.17697714f, -0.08500618f, -0.17137323f, -0.03759372f, -0.12016081f, 0.01242061f, -0.03846974f, 
    -0.06633703f, 0.24656455f, 0.19359130f, 0.21634948f, -0.00525101f, 0.18946499f, -0.23329277f, 0.04277520f, 
    -0.50898546f, -0.57964587f, -0.62561512f, 0.60298735f, 0.70009553f, -0.03184864f, 0.20292708f, 0.54776382f, 
    -0.09335154f, -0.30394223f, -0.06640861f, -0.07693358f, -0.20372877f, -0.10641247f, -0.17486899f, 0.06877961f, 
    0.04167628f, -0.18847553f, -0.01825677f, -0.07942559f, -0.26239920f, -0.10085147f, 0.10723447f, 0.68217796f, 
    0.62673908f, 0.04481112f, -0.19292197f, -0.04817270f, 0.13321906f, -0.08102570f, 0.58493090f, 0.61783552f, 
    0.43853056f, -0.60347337f, -0.10896350f, 0.12679416f, -0.43027887f, -0.22986032f, 0.19061376f, 0.06112996f, 
    -0.03918476f, 0.10967766f, 0.04117773f, 0.04690661f, -0.16646996f, -0.03239672f, -0.19271889f, -0.11293233f, 
    0.09489160f, -0.52758044f, -0.43348649f, -0.64353848f, -0.41850773f, -0.23084910f, -0.27401292f, -0.19436254f, 
    0.11195052f, -0.09623719f, 0.20587666f, -0.40557188f, 0.04135674f, -0.20852275f, -0.07613778f, -0.06263541f, 
    0.06355248f, -0.28785142f, 0.22651954f, 0.26431906f, 0.35678869f, 0.36333662f, -0.22380579f, 0.01629397f, 
    -0.17988832f, -0.47913578f, 0.34107110f, 0.49327642f, 0.03782465f, -0.19341947f, -0.58934855f, 0.43751892f, 
    0.25345883f, -0.34372678f, -0.32406515f, 0.28098848f, 0.34194896f, 0.06633090f, 0.17819117f, 0.41523063f, 
    0.21365523f, 0.02314466f, -0.18541403f, -0.04827705f, 0.04940654f, 0.11881956f, 0.12976184f, 0.14062613f, 
    0.27212778f, 0.00517928f, -0.13087450f, -0.84782791f, -0.11558785f, 0.27804366f, -0.25178081f, -0.27496374f, 
    0.34482393f, 0.29427683f, -0.58675647f, 0.04277933f, 0.13854636f, 0.28928655f, -0.04517068f, 0.05067293f, 
    0.32209027f, -0.40035030f, -0.18772061f, -0.08448450f, -0.09728923f, -0.38050693f, -0.12074653f, -0.00688387f, 
    -0.11048968f, 0.22713374f, 0.08376563f, 0.77084494f, 0.54708612f, -0.28180096f, -0.00638646f, 0.07680304f, 
    -0.32696909f, -0.78372651f, -0.50852650f, -0.36685753f, 0.17032546f, -0.14141218f, 0.29405579f, -0.15077284f, 
    -0.07843329f, 0.13604288f, -0.11931584f, -0.03484220f, -0.05615969f, -0.19936433f, 0.27056953f, -0.26516676f, 
    0.33577260f, -0.08467548f, -0.25320280f, 0.07708749f, 0.70329314f, 0.54371995f, 0.72792906f, 0.92676222f, 
    0.35166779f, -0.27485469f, 0.17010166f, -0.47403565f, 0.12871817f, -0.09746271f, 0.01337492f, -0.07991392f, 
    0.27563155f, 0.19307303f, -0.10637071f, 0.11801472f, 0.13891399f, 0.22991870f, 0.02579599f, 0.15340517f, 
    -0.21100220f, 0.05481386f, 0.09647895f, 0.12955187f, 0.01325900f, -0.41308948f, -0.92335713f, -0.63700044f, 
    -0.20559044f, -0.07024611f, -0.41185248f, 0.67580599f, 0.73846436f, -0.30680892f, 0.19826443f, -0.04567532f, 
    -0.10729545f, 0.03871645f, -0.17144771f, -0.29826793f, -0.06614611f, 0.27256206f, -0.03669176f, -0.01629924f, 
    -0.12576488f, 0.13935995f, 0.02658834f, 0.05493201f, 0.11330407f, -0.00085358f, -0.00517693f, 0.64391446f, 
    -0.43088236f, -0.31501895f, -0.41162008f, 0.64629358f, -0.65809053f, -0.64810610f, -0.62120736f, -0.20211963f, 
    -0.08220685f, -0.12819104f, 0.39336964f, 0.25972798f, -0.13407493f, -0.08339502f, 0.05250667f, 0.06807870f, 
    0.08014352f, -0.17618006f, 0.05072586f, 0.03049604f, 0.16512069f, 0.00492170f, -0.07061184f, 0.53164232f, 
    0.22192307f, 0.55647039f, 0.52536261f, 0.48342586f, -0.45974642f, 0.59557498f, -0.21492027f, -0.17863318f, 
    0.38348332f, 0.57249868f, 0.36905944f, 0.00167880f, -0.05626333f, -0.08639865f, -0.24781869f, -0.05579901f, 
    -0.15361030f, 0.11719887f, -0.40129963f, 0.03059129f, 0.13269314f, 0.12114318f, -0.12036189f, -0.16672270f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.00269963f, 0.08399367f, 0.15821233f, 0.20315768f, 0.09006058f, 0.18982905f, -0.14571016f, -0.01565378f, 
    0.12768573f, -0.05461311f, -0.11980844f, 0.10591588f, 0.12960514f, -0.05412538f, 0.17365150f, -0.02627385f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.05373880f, 0.00559148f, 0.05026488f, -0.05823423f, -0.00962946f, -0.03272302f, 0.04456288f, -0.01470175f, 
    0.01170623f, -0.05874001f, 0.04861480f, -0.03538740f, 0.02360622f, -0.07388978f, -0.01000057f, -0.03948993f, 
    0.03697131f, -0.00574797f, 0.03428110f, -0.03910013f, -0.02720410f, 0.01218756f, 0.05951306f, -0.04635326f, 
    0.03173710f, 0.01891012f, 0.00029158f, 0.05977407f, 0.02377272f, 0.03689786f, -0.00644222f, -0.02793783f, 
    -0.04734864f, 0.02789373f, -0.03595932f, -0.00212558f, -0.06891663f, 0.01505663f, -0.02020704f, 0.06262954f, 
    -0.02485877f, -0.05067116f, -0.01969628f, -0.03369954f, -0.05723944f, 0.01780387f, 0.03786024f, -0.03036669f, 
    -0.04324770f, -0.02969057f, 0.04070399f, -0.04090285f, -0.06008456f, -0.06292468f, -0.07972731f, -0.06411193f, 
    -0.07022095f, -0.07354494f, -0.03896669f, 0.03838971f, -0.05516106f, -0.02741131f, -0.01343122f, 0.01508066f, 
    0.01970867f, -0.02920027f, -0.00440684f, 0.04354766f, -0.05452478f, -0.02695891f, 0.00103233f, -0.03476886f, 
    -0.06018953f, -0.01848272f, 0.01024986f, -0.03879596f, -0.07469139f, -0.01010694f, -0.04375326f, 0.01607352f, 
    -0.06544847f, 0.06053751f, -0.03270365f, -0.00481559f, 0.01455671f, 0.00523106f, -0.04443234f, -0.04729226f, 
    0.00572267f, -0.02969866f, 0.01090368f, -0.06071339f, -0.03324752f, -0.03020754f, 0.00009492f, -0.01610047f, 
    0.03441367f, 0.05953235f, 0.04308580f, 0.03656583f, 0.02711736f, -0.02378227f, -0.06311976f, 0.00952281f, 
    -0.07999538f, 0.04229810f, -0.06110160f, -0.05720700f, -0.00672977f, 0.01973791f, -0.03512018f, 0.03387593f, 
    -0.04266583f, 0.04308019f, 0.00636667f, 0.04733658f, -0.05068758f, 0.05115464f, -0.05594878f, -0.00917023f, 
    0.03476572f, 0.03173725f, -0.03047011f, 0.05555874f, -0.01189782f, -0.03078928f, -0.08034079f, -0.06594516f, 
    -0.06134160f, -0.05157860f, 0.01694604f, -0.02184322f, 0.05529630f, 0.00475514f, -0.00915057f, -0.05469294f, 
    0.06202823f, -0.00551544f, 0.02466813f, -0.03016069f, 0.03767570f, 0.04999587f, -0.02352063f, -0.02264614f, 
    0.05799352f, 0.00040087f, 0.03694182f, 0.04157501f, -0.02101335f, 0.06406518f, -0.04034389f, -0.02135970f, 
    0.01131550f, -0.06608021f, -0.00196815f, -0.05090323f, 0.05980260f, 0.00005593f, 0.03164544f, 0.02071668f, 
    -0.04232857f, 0.05164844f, 0.06258741f, 0.00270627f, 0.03478238f, -0.05721428f, 0.06454955f, 0.02743013f, 
    -0.05932070f, 0.05889685f, -0.07898837f, -0.04930720f, -0.05168684f, 0.01991380f, 0.03480458f, -0.02291374f, 
    -0.03096214f, -0.07838932f, 0.00521771f, 0.01176448f, 0.00247849f, 0.04759919f, 0.03618304f, 0.03120139f, 
    0.04001819f, -0.03423087f, -0.03907866f, -0.08150595f, 0.01581982f, 0.04746483f, 0.03450746f, 0.06055764f, 
    0.05813709f, -0.05280253f, -0.00020422f, -0.00414968f, -0.04354512f, -0.02221024f, 0.02466816f, -0.01419866f, 
    -0.01608129f, 0.03808022f, -0.07737011f, 0.05144215f, 0.07286476f, 0.06457018f, -0.02713159f, -0.02718375f, 
    0.04597936f, 0.04676016f, 0.01532254f, -0.02028666f, 0.00964335f, 0.00407902f, 0.00328883f, -0.00586820f, 
    -0.00168991f, -0.03532295f, -0.02522783f, 0.04808069f, 0.04792843f, 0.05881555f, 0.05245845f, 0.02982668f, 
    0.02005465f, 0.06250153f, 0.01288138f, 0.05262574f, 0.01445011f, -0.00132703f, -0.01913497f, 0.04175449f, 
    -0.00170970f, 0.04964903f, -0.03821433f, -0.06824255f, -0.05843930f, 0.00014488f, -0.01228548f, 0.00201073f, 
    -0.01000583f, 0.04861191f, -0.04152080f, -0.03554892f, -0.02008981f, -0.02670883f, -0.05706830f, 0.05758910f, 
    0.02563418f, -0.04688962f, 0.06492653f, 0.03827333f, -0.01849474f, 0.01855255f, 0.02069590f, -0.05638992f, 
    0.05010368f, -0.07988629f, 0.02499459f, 0.02179017f, -0.00442899f, -0.01414942f, -0.02647686f, -0.03615030f, 
    -0.04619394f, -0.06720970f, 0.05314808f, -0.00580841f, -0.01031257f, -0.04091395f, -0.05614644f, -0.04152296f, 
    0.04783823f, -0.02977974f, -0.01224383f, 0.04594778f, -0.04442509f, -0.06170892f, -0.03739421f, -0.08002486f, 
    0.04126906f, -0.05073797f, -0.04703142f, -0.06465124f, -0.02636249f, -0.04669298f, 0.05705270f, -0.05470753f, 
    -0.02994009f, 0.05416359f, -0.06488544f, -0.02754539f, 0.05192600f, -0.00026850f, 0.06158679f, 0.02916068f, 
    -0.04984741f, -0.04488932f, -0.03059411f, -0.01541168f, 0.01869817f, -0.00397235f, -0.06821950f, 0.01041386f, 
    -0.05007794f, 0.04400604f, -0.03954325f, 0.00143337f, -0.07388020f, -0.05411801f, -0.01344080f, 0.00401942f, 
    0.01854805f, 0.01060827f, -0.03872561f, -0.06492119f, -0.00016713f, -0.04159697f, -0.03137076f, 0.01857389f, 
    -0.01444690f, -0.02138722f, 0.05672324f, 0.01177778f, -0.05843379f, -0.04854446f, -0.00281156f, -0.02365476f, 
    0.04640875f, -0.06278130f, -0.01562147f, 0.02413565f, 0.00292492f, -0.02813900f, 0.02636611f, 0.00612794f, 
    -0.01165520f, 0.04095985f, -0.00072239f, -0.03398573f, -0.02067410f, -0.04630366f, 0.05641944f, 0.03090274f, 
    0.01601242f, 0.01348075f, 0.00843464f, -0.04533006f, 0.01473452f, -0.05651681f, -0.04394159f, 0.06489592f, 
    0.05746854f, -0.02280044f, 0.05438128f, -0.03513420f, -0.06219681f, -0.01724054f, -0.07239135f, 0.05850198f, 
    0.02159548f, -0.02874148f, -0.05901982f, -0.06664650f, 0.04312308f, 0.00498531f, -0.02791036f, -0.03709221f, 
    0.03561868f, -0.06078009f, -0.00240709f, -0.06923436f, -0.08280737f, -0.01960191f, -0.07555041f, 0.00360821f, 
    0.00698573f, -0.06169447f, -0.07477979f, -0.03263230f, -0.03484996f, -0.00595489f, -0.04560172f, 0.01245363f, 
    -0.18234691f, 0.06616007f, 0.17092308f, -0.07325453f, -0.14711998f, 0.11180548f, 0.06369835f, -0.13755375f, 
    0.01759163f, 0.01806829f, 0.04317973f, -0.12717271f, 0.16758621f, -0.01064734f, 0.08711819f, 0.03220088f, 
    0.09870017f, -0.08338450f, 0.08947340f, -0.01654323f, -0.01215444f, -0.00777712f, -0.03393159f, 0.05504346f, 
    0.35842481f, 0.09897178f, -0.16566297f, -0.07499993f, 0.02231058f, 0.08917393f, 0.02710854f, 0.08603941f, 
    -0.06124036f, 0.01062420f, 0.01333719f, -0.00265766f, 0.24079347f, -0.05035401f, -0.14966622f, 0.04723454f, 
    0.02866068f, -0.15831788f, -0.01290980f, -0.04416258f, 0.07702315f, 0.03291752f, -0.08397686f, 0.06160183f, 
    0.26134634f, -0.04200950f, 0.11843929f, 0.18538237f, 0.04553005f, 0.00464163f, -0.08372005f, -0.02435566f, 
    0.02160716f, 0.03214205f, 0.06124167f, -0.06031734f, -0.30930629f, 0.29581258f, -0.16779858f, -0.16782689f, 
    0.11126184f, -0.04743692f, 0.04980832f, -0.07039871f, 0.05640875f, 0.06468081f, 0.03866456f, -0.02733818f, 
    -0.06779829f, 0.17240015f, 0.16489708f, 0.19053370f, -0.06968032f, -0.04243325f, 0.09329841f, 0.17464985f, 
    0.07867183f, -0.02109344f, 0.06693318f, 0.04220222f, 0.09197090f, -0.16676238f, -0.06001128f, -0.00826092f, 
    -0.05314373f, 0.07871348f, 0.12263453f, -0.08220835f, -0.04962949f, 0.02104852f, -0.00773757f, -0.01365210f, 
    0.11668349f, 0.07006143f, 0.22185491f, 0.14667565f, -0.04183329f, 0.02018419f, 0.08606745f, -0.09891698f, 
    -0.14630550f, 0.04584813f, -0.03301621f, -0.03619990f, 0.23619720f, -0.00039135f, -0.08952590f, -0.01163779f, 
    0.02450306f, 0.06963268f, -0.02266804f, -0.05301184f, -0.09823440f, 0.00763788f, 0.07311219f, 0.13992368f, 
    0.29241118f, -0.01180927f, 0.05187093f, 0.00949423f, 0.13771087f, 0.09060528f, -0.02379158f, 0.06066603f, 
    0.07087861f, 0.04807276f, -0.02182751f, -0.03467628f, -0.31316832f, 0.00988228f, 0.16021919f, -0.09463312f, 
    -0.03641704f, 0.03299046f, 0.05981771f, -0.01641421f, 0.05485757f, 0.00362768f, -0.01464347f, -0.06238536f, 
    -0.41265890f, -0.12947273f, 0.04377834f, -0.14913225f, 0.03695710f, 0.01172313f, -0.02673569f, 0.10717045f, 
    -0.11071952f, 0.03571926f, -0.03360751f, -0.05285209f, 0.37377363f, 0.05652696f, 0.11216009f, 0.28991687f, 
    0.05285206f, -0.06884396f, 0.03670582f, 0.00418065f, -0.07012144f, 0.10405166f, 0.02431530f, -0.11718224f, 
    -0.10385339f, 0.18840791f, -0.07031164f, -0.05016696f, -0.00949940f, -0.04990404f, -0.05606683f, -0.03450486f, 
    -0.06677372f, 0.08933523f, 0.12695991f, 0.08613792f, -0.36376286f, -0.10386316f, -0.19777860f, -0.10173114f, 
    0.09221180f, 0.03345322f, -0.06603705f, -0.06342945f, -0.18462069f, -0.14815697f, -0.04714468f, -0.10343569f, 
    0.27560836f, 0.22155803f, 0.05092189f, -0.01248616f, 0.03102056f, 0.07052288f, 0.13458104f, -0.13981654f, 
    -0.06476022f, 0.15135154f, 0.08121844f, 0.08336280f, -0.01203145f, -0.08216841f, 0.03339007f, 0.20254795f, 
    -0.06405528f, -0.15036210f, -0.06928147f, 0.02037538f, 0.00006838f, -0.02489172f, 0.01155625f, -0.08080436f, 
    -0.21757463f, -0.17592454f, -0.13839887f, 0.02643303f, 0.14720961f, -0.05352322f, -0.02047839f, -0.07516417f, 
    -0.06029517f, 0.11522853f, 0.00582990f, 0.24624102f, 0.16473134f, -0.06716421f, 0.07792221f, 0.08370335f, 
    0.00480724f, -0.08505927f, 0.12646292f, -0.01778083f, 0.02063796f, -0.09479859f, -0.12765132f, -0.12644030f, 
    0.06551037f, 0.10066999f, 0.04829793f, 0.01775392f, -0.03274673f, 0.00489091f, 0.08042492f, 0.02981560f, 
    -0.05549811f, 0.01774668f, 0.05781874f, 0.06625795f, 0.18107918f, 0.34797928f, 0.03700614f, -0.20749311f, 
    0.01222981f, 0.11127092f, 0.05491614f, 0.00673503f, 0.06043223f, -0.03549758f, -0.10170336f, 0.13926926f, 
    -0.25844592f, -0.36685184f, 0.03298584f, 0.03591104f, 0.10451394f, -0.03503533f, 0.06905615f, 0.03918009f, 
    0.03984111f, 0.21360514f, 0.06630682f, -0.02580279f, 0.25297943f, 0.02636689f, 0.24716242f, 0.06868008f, 
    0.08380683f, 0.10809920f, 0.11476291f, 0.03970722f, 0.10074081f, -0.06928037f, 0.10907004f, 0.02733873f, 
    0.25709039f, 0.09669960f, -0.04519039f, 0.10349532f, -0.01248482f, -0.04931345f, -0.08357004f, -0.01778754f, 
    -0.10286433f, 0.00797784f, 0.02944090f, 0.00532225f, 0.10948814f, -0.31145763f, -0.11861037f, 0.09064846f, 
    -0.14858909f, -0.06144400f, -0.06816075f, -0.00067464f, -0.03169977f, -0.03827779f, -0.08164294f, -0.12082277f, 
    -0.35488588f, 0.06183195f, -0.09688037f, -0.09703323f, 0.10564394f, 0.12070815f, -0.00633791f, 0.02950084f, 
    -0.16380899f, -0.01218568f, -0.00137296f, 0.08949943f, -0.08413767f, 0.04549411f, -0.06840715f, 0.01406335f, 
    0.00662803f, -0.08462980f, 0.06515850f, -0.18085617f, -0.06586575f, 0.01625047f, 0.16007397f, 0.18478170f, 
    0.23664977f, 0.13826615f, 0.23382244f, -0.12224769f, 0.04322944f, 0.08739620f, 0.01472445f, 0.07301164f, 
    0.12571110f, 0.05171171f, 0.00900680f, 0.04286623f, -0.05542918f, -0.08101127f, -0.08614221f, 0.13940303f, 
    0.14977801f, 0.05446897f, -0.04023133f, 0.02528591f, -0.00293496f, 0.00896316f, 0.15860657f, -0.04071564f, 
    -0.16262622f, -0.13538216f, 0.09034321f, -0.04731590f, -0.01765463f, 0.04864644f, 0.14985646f, 0.00864312f, 
    -0.08307689f, -0.02303167f, 0.13414000f, 0.05071679f, 0.06649857f, 0.19179067f, 0.14922868f, -0.09041384f, 
    -0.11337032f, 0.02542445f, 0.02458924f, 0.04153571f, 0.10997742f, -0.02893762f, 0.00924621f, -0.06074006f, 
    0.10309754f, -0.11090738f, -0.16317417f, -0.07139987f, -0.20385446f, 0.07482626f, -0.08244935f, -0.01728848f, 
    -0.02130255f, 0.05893143f, 0.06215554f, 0.12095802f, 0.11776968f, 0.25142193f, -0.02601481f, -0.14463232f, 
    -0.00384305f, -0.14759742f, 0.01996583f, -0.02047944f, -0.09658945f, -0.07858747f, -0.03674965f, -0.01747374f, 
    0.19295000f, 0.06656482f, -0.25411499f, -0.19850551f, -0.08312944f, 0.04671719f, 0.02865401f, 0.10200180f, 
    0.03069999f, -0.08600774f, 0.05171100f, 0.09566652f, 0.01668392f, -0.05796510f, -0.05808395f, 0.13451989f, 
    -0.01407958f, -0.02799518f, 0.17746213f, 0.06758333f, 0.03497010f, -0.04366243f, -0.00848730f, -0.00607051f, 
    -0.04010273f, 0.08357734f, 0.06108662f, -0.27516752f, 0.03200284f, -0.06561836f, -0.24622428f, 0.06620102f, 
    -0.01003288f, 0.01986329f, 0.11721580f, 0.01107274f, 0.40014383f, 0.01835947f, 0.05274788f, 0.31967005f, 
    -0.10283189f, -0.00712910f, -0.11556322f, -0.01366486f, -0.07606427f, 0.03213787f, -0.01838913f, 0.02897960f, 
    -0.10937916f, 0.19641851f, 0.23430999f, 0.20087585f, 0.01596373f, -0.08040158f, 0.16060463f, 0.04418565f, 
    0.06192373f, 0.04079799f, 0.03639308f, -0.04191347f, -0.03295688f, 0.07284987f, 0.00693047f, 0.04214934f, 
    -0.09001435f, -0.08203828f, 0.13216397f, 0.10518669f, 0.04916402f, -0.03223408f, 0.08676322f, -0.05004219f, 
    -0.00371036f, 0.04117265f, 0.00259865f, -0.10440029f, 0.05439777f, 0.04005311f, 0.08174960f, -0.04108006f, 
    -0.02228583f, -0.10749598f, 0.07174709f, 0.05471665f, -0.14665656f, -0.14289805f, -0.08094420f, -0.05419381f, 
    0.00817928f, 0.04370394f, -0.01574107f, -0.14201017f, -0.01031344f, -0.03437839f, 0.03641838f, -0.18417782f, 
    0.43145761f, 0.01217023f, 0.11906136f, 0.02580675f, 0.00013959f, 0.07687884f, 0.02961121f, -0.05781842f, 
    0.13953368f, 0.06052735f, -0.01523582f, 0.08272336f, -0.24229501f, -0.09421471f, -0.16802423f, -0.05049201f, 
    -0.07567187f, -0.03629339f, 0.12093716f, -0.07965500f, 0.16113527f, 0.08204494f, 0.06049125f, -0.06476841f, 
    0.14583826f, 0.16194116f, -0.11547367f, 0.13020796f, -0.17309272f, -0.06433243f, 0.02508712f, 0.00732349f, 
    -0.00073852f, -0.12935321f, -0.11303700f, -0.24413574f, 0.21300408f, 0.05336723f, 0.29661828f, 0.22884475f, 
    -0.06113587f, 0.02431683f, -0.05038214f, -0.07902061f, 0.07224634f, -0.09581335f, 0.01447758f, 0.06945073f, 
    -0.03109998f, -0.02058631f, -0.18838225f, -0.18261366f, -0.00088193f, -0.00809094f, -0.02603653f, -0.01486618f, 
    0.08268856f, 0.11142664f, -0.07948232f, -0.04465999f, 0.18674475f, 0.05909438f, 0.01156276f, 0.03054538f, 
    -0.09865677f, 0.04691621f, -0.05256091f, 0.04630367f, -0.00897225f, 0.10558850f, -0.10627334f, 0.05163996f, 
    0.10883190f, 0.13478769f, -0.23435172f, -0.08394980f, -0.08877405f, 0.06138402f, 0.11046121f, 0.04047723f, 
    -0.07980701f, 0.02141447f, 0.13844453f, -0.11521005f, 0.09481334f, 0.07029831f, 0.01566699f, 0.14496781f, 
    0.06464410f, -0.04790521f, 0.02842469f, -0.00913298f, 0.01633641f, -0.02031309f, -0.03060177f, 0.14677224f, 
    0.03870589f, -0.18303385f, 0.03986163f, -0.01996042f, 0.15315384f, -0.01470168f, 0.02150216f, -0.01158914f, 
    0.04570328f, 0.01376728f, -0.08174697f, 0.04733988f, -0.02707886f, -0.13175954f, 0.05680197f, -0.04407658f, 
    -0.11921253f, -0.08588137f, -0.09491676f, -0.10494801f, -0.09896480f, -0.04270021f, 0.06071438f, -0.04850727f, 
    0.11520504f, -0.01238877f, 0.05458429f, 0.22352512f, 0.06781500f, -0.02179490f, 0.09713549f, -0.00308637f, 
    -0.02576982f, -0.11439350f, -0.09256940f, -0.01144588f, 0.28532091f, 0.14311375f, 0.14119400f, -0.09992259f, 
    0.04149212f, 0.03287326f, 0.02441538f, -0.00827530f, 0.05996993f, -0.01352849f, -0.14523913f, 0.00031436f, 
    -0.07868102f, -0.01066534f, 0.03261785f, 0.27377063f, 0.09098525f, -0.00728258f, 0.02985487f, 0.05158634f, 
    0.03808996f, 0.01757301f, 0.10409945f, -0.05217246f, 0.58487165f, 0.03090558f, 0.13821183f, -0.03472810f, 
    0.03665604f, -0.00263545f, 0.00552342f, -0.08233194f, -0.01256333f, 0.04976951f, 0.11316711f, -0.02504890f, 
    0.12670802f, 0.00375059f, 0.03058406f, 0.31883967f, 0.12631391f, -0.07296310f, 0.04326250f, 0.01041335f, 
    -0.02759324f, 0.04530393f, -0.06227988f, -0.04721355f, 0.19132064f, -0.24794281f, 0.02545925f, 0.03397230f, 
    -0.07902772f, -0.07435727f, -0.04341176f, 0.04155929f, -0.02089281f, 0.03088772f, 0.03669338f, 0.06188315f, 
    -0.21655285f, 0.09405456f, -0.07184481f, -0.30950499f, 0.04830727f, 0.00392378f, 0.00543616f, 0.15771508f, 
    -0.03288747f, -0.06928259f, 0.06152966f, -0.08487692f, -0.27015817f, -0.07266133f, 0.05036615f, 0.04410443f, 
    -0.13215505f, -0.12919782f, -0.05387346f, -0.15665415f, -0.08699472f, 0.06700691f, 0.06318569f, 0.07215026f, 
    0.06730876f, 0.22304434f, 0.02108335f, 0.11763678f, -0.05676125f, 0.13163075f, 0.02457769f, -0.02918901f, 
    -0.00670293f, 0.02540355f, 0.00315888f, 0.12095267f, -0.08216723f, 0.12479189f, 0.07512736f, 0.11700385f, 
    0.12710306f, 0.11008551f, -0.03241057f, 0.11789557f, 0.02431284f, -0.00948834f, 0.04636482f, -0.06404394f, 
    -0.36432907f, 0.07716137f, 0.07738971f, 0.05344358f, -0.07841600f, -0.09223016f, 0.04357225f, -0.10541747f, 
    -0.03160562f, 0.00533442f, 0.10269614f, 0.02847619f, 0.08151403f, -0.04467893f, 0.22551066f, -0.14404951f, 
    -0.05486572f, -0.02137843f, 0.14924005f, -0.03897987f, -0.01025519f, -0.18850577f, -0.15886456f, -0.11350153f, 
    -0.07211103f, 0.06145519f, 0.00433340f, -0.02294582f, 0.01508632f, 0.04646629f, -0.02534112f, 0.04164140f, 
    -0.01967263f, -0.02930309f, -0.03134583f, -0.03212961f, 0.05717551f, -0.06480989f, 0.02603103f, 0.02957288f, 
    -0.07020875f, -0.03324687f, 0.00474621f, 0.04769509f, 0.03381756f, 0.00314038f, -0.03051185f, -0.05077333f, 
    -0.05372804f, -0.03377959f, -0.04170528f, -0.05592826f, -0.04696559f, -0.04099229f, 0.07071266f, -0.00217090f, 
    0.02244223f, -0.02645459f, -0.02805265f, -0.02335762f, -0.04115419f, -0.05928949f, -0.00031416f, -0.04756281f, 
    -0.00741125f, 0.06233224f, -0.06785410f, -0.05785998f, 0.00756469f, 0.04468238f, 0.05490180f, -0.00534983f, 
    -0.02549275f, 0.01349787f, -0.05216511f, 0.02237545f, -0.04171320f, -0.02043551f, 0.04862162f, 0.04022981f, 
    -0.03168758f, 0.02459320f, 0.03307450f, -0.05221604f, 0.06239248f, -0.03453602f, -0.00318406f, 0.00990805f, 
    0.02244521f, 0.02890444f, 0.01681472f, -0.04919874f, 0.04982591f, 0.06152115f, -0.06433601f, -0.04416077f, 
    -0.03816302f, -0.05324993f, -0.03047931f, 0.04698851f, 0.04023203f, -0.04671424f, -0.01889860f, -0.03101929f, 
    -0.02612098f, -0.04151993f, -0.03785816f, 0.00546069f, 0.06858756f, 0.07344915f, -0.00012819f, 0.05752245f, 
    -0.02398888f, 0.05699019f, -0.07179329f, 0.04898885f, -0.07313100f, 0.01958758f, 0.00691699f, 0.01745228f, 
    0.02132414f, -0.02213790f, -0.08276039f, -0.05289725f, 0.02631342f, -0.00343325f, 0.02248325f, -0.06147866f, 
    0.01750975f, 0.05511013f, 0.01986791f, 0.03217185f, -0.03711309f, -0.00656323f, -0.05369464f, -0.03047261f, 
    0.05359424f, 0.02765503f, 0.06139257f, 0.03003058f, 0.01924320f, -0.06095216f, -0.00545413f, -0.05742979f, 
    -0.06824907f, 0.04729168f, 0.00018180f, -0.06678966f, 0.01109105f, -0.01062969f, 0.04267291f, 0.00225888f, 
    0.02213232f, -0.03558131f, -0.03535966f, 0.03019511f, 0.05447277f, -0.06574398f, -0.03333433f, 0.03036152f, 
    -0.03923790f, 0.03537780f, -0.05403054f, -0.06572478f, -0.03490122f, -0.03576767f, 0.05010713f, -0.07458935f, 
    -0.03356820f, -0.01598468f, -0.00589480f, 0.01192237f, -0.05985280f, -0.02319057f, 0.04368819f, 0.00528292f, 
    0.02126321f, -0.05100877f, -0.06910370f, 0.00463738f, 0.02098623f, -0.05559655f, 0.01486886f, -0.04307252f, 
    -0.00193568f, 0.00763487f, -0.07288533f, 0.06439407f, 0.04495180f, -0.02275015f, 0.05566182f, -0.00525868f, 
    -0.01473065f, 0.01136305f, -0.07908591f, -0.00338534f, -0.02562174f, -0.01734299f, -0.03890599f, -0.05851056f, 
    0.02256911f, 0.05256116f, 0.06918759f, -0.06630031f, -0.04339633f, 0.03731803f, -0.07199274f, -0.04797916f, 
    0.01450578f, -0.05627339f, 0.03492291f, 0.05441148f, -0.02966733f, 0.03162897f, 0.06226194f, 0.02979320f, 
    0.03067312f, -0.07816514f, 0.02049804f, 0.02725531f, 0.05183925f, 0.02682619f, -0.02043310f, -0.06515314f, 
    0.02220807f, -0.05942640f, -0.00194979f, -0.00813842f, 0.01258363f, -0.02929950f, -0.07948256f, 0.04393657f, 
    -0.04329827f, 0.05644917f, -0.03842747f, 0.03004635f, 0.00097429f, 0.05249889f, 0.04166183f, -0.00604714f, 
    -0.04596398f, 0.05798953f, -0.06200785f, -0.06717790f, -0.00328960f, 0.01504092f, -0.04748388f, 0.00967335f, 
    -0.05119150f, -0.03485879f, 0.01711943f, -0.06254124f, 0.04720360f, -0.02774718f, -0.06466106f, -0.00974113f, 
    0.00355088f, 0.00938636f, -0.04858227f, -0.01248987f, 0.01844508f, 0.01529714f, 0.00138340f, 0.00561173f, 
    -0.00466802f, -0.07106141f, -0.01280135f, -0.07171565f, 0.05350173f, 0.01783220f, -0.03937174f, 0.03453360f, 
    -0.01599392f, -0.06057488f, 0.00571063f, -0.00834612f, -0.07659502f, 0.00520880f, -0.01939646f, -0.03130816f, 
    0.00586138f, -0.04711606f, 0.00744562f, -0.06374624f, -0.06749481f, -0.07998831f, -0.05801290f, 0.04653130f, 
    -0.03533103f, 0.06792748f, -0.00310022f, -0.00826403f, -0.02734501f, -0.00049927f, -0.05504404f, -0.07672332f, 
    -0.03231638f, -0.05911879f, -0.01935676f, 0.01581823f, -0.05486555f, -0.02436364f, -0.00377621f, -0.06359039f, 
    0.02479788f, -0.01850503f, 0.00589687f, -0.00384721f, 0.02208699f, -0.06857415f, 0.03750741f, 0.03244419f, 
    -0.03099995f, -0.01539370f, 0.05958280f, -0.00419883f, -0.07573278f, -0.04093313f, 0.05762878f, 0.01027652f, 
    0.03945146f, -0.04926778f, -0.07079300f, 0.05104742f, -0.06359915f, -0.05515587f, -0.05222651f, 0.01787776f, 
    -0.05731758f, -0.02246004f, 0.02857028f, 0.02939719f, 0.05638807f, -0.03789359f, -0.03912053f, 0.00023946f, 
    -0.01516092f, -0.02222830f, -0.05819373f, 0.05068231f, 0.04116458f, -0.02282104f, 0.02362955f, 0.00977740f, 
    -0.04946406f, -0.00939552f, -0.05682492f, 0.00264194f, 0.01961755f, 0.05040932f, 0.05896483f, 0.04543755f, 
    0.03549137f, -0.05885553f, -0.03495981f, 0.04875518f, -0.04567965f, 0.04260768f, 0.03726684f, 0.00860603f, 
    0.02820930f, -0.03622051f, 0.03413486f, -0.05607944f, -0.03606079f, -0.02081866f, 0.05094375f, 0.06576908f, 
    0.00445338f, -0.01442751f, -0.01672397f, 0.02034805f, 0.03550344f, 0.00954802f, -0.03669377f, 0.05997592f, 
    0.03538728f, 0.06265886f, -0.06630312f, 0.00385706f, -0.04364841f, 0.01741490f, -0.02239307f, 0.00269775f, 
    -0.07159295f, -0.01529909f, 0.01700318f, 0.04152307f, -0.04649218f, -0.06896752f, 0.05545988f, 0.03340292f, 
    -0.00832426f, -0.05192677f, 0.04436371f, -0.00848711f, -0.01925480f, -0.05797829f, 0.03964115f, -0.00320073f, 
    -0.04129263f, -0.05247100f, -0.05643396f, -0.00923207f, 0.06427125f, 0.00180601f, 0.02749550f, 0.05174889f, 
    -0.07221421f, 0.12911029f, 0.29601204f, 0.01628572f, 0.13964248f, -0.12606592f, 0.03871880f, -0.08157206f, 
    0.07555053f, -0.03176747f, 0.02806731f, 0.03315715f, -0.18785921f, -0.15702029f, 0.00965624f, -0.04862449f, 
    0.01299790f, 0.04748546f, 0.00482460f, 0.03855180f, 0.08232170f, 0.14677905f, 0.05494468f, 0.05065444f, 
    -0.08525361f, -0.12773341f, 0.15266830f, 0.09657519f, 0.04190215f, 0.11103940f, -0.04318725f, -0.05042401f, 
    0.03492134f, 0.03939232f, -0.05595169f, -0.00892701f, 0.05195275f, 0.01583503f, -0.03341310f, -0.04820271f, 
    0.02698270f, -0.01201919f, -0.03472517f, 0.08237828f, -0.06024050f, 0.17519647f, 0.05358155f, 0.07301708f, 
    -0.00344588f, -0.05967088f, -0.21321522f, 0.02025875f, -0.16855425f, 0.12008303f, 0.15571024f, 0.00012932f, 
    -0.10814255f, -0.06889772f, 0.03290576f, 0.08294343f, -0.16764429f, 0.02825864f, 0.06596400f, 0.08753045f, 
    0.02631735f, 0.05880309f, 0.01907567f, 0.10369557f, 0.09919158f, -0.03838813f, 0.04714330f, 0.01334007f, 
    0.19378981f, -0.11165517f, -0.17069334f, -0.20116659f, 0.04265893f, 0.05064791f, -0.01883342f, -0.04318473f, 
    0.02705329f, 0.05144629f, -0.04964155f, 0.05080960f, 0.08630685f, 0.13277511f, 0.07188788f, 0.03475757f, 
    0.17049308f, 0.02545323f, -0.12834421f, 0.01067692f, 0.16957110f, -0.11064267f, -0.01239812f, -0.00045150f, 
    0.09716601f, 0.02156743f, 0.04849388f, -0.09771999f, 0.14821111f, -0.03571682f, -0.04125044f, 0.02649006f, 
    0.02109050f, 0.09976463f, -0.00458962f, -0.06532978f, 0.04169875f, -0.10309807f, -0.01856592f, 0.00894679f, 
    -0.02827996f, 0.00455103f, -0.01816980f, 0.07085508f, 0.03065264f, 0.15530518f, 0.05956896f, 0.15771556f, 
    -0.47215715f, -0.07793335f, -0.11026719f, 0.18209426f, -0.02555402f, 0.13026276f, 0.10353668f, -0.09643593f, 
    -0.07889225f, -0.04523479f, 0.09208652f, -0.04915421f, 0.10015959f, 0.11127777f, 0.03172085f, -0.16916625f, 
    0.04573319f, 0.04246350f, -0.03083557f, 0.12134995f, 0.01021752f, 0.04758975f, 0.05924014f, 0.16275570f, 
    0.15309753f, -0.01292081f, 0.01625796f, -0.24850264f, 0.11718876f, 0.01735087f, -0.05602509f, 0.02205369f, 
    0.10513182f, 0.09154537f, -0.01270194f, 0.07454776f, -0.29479510f, 0.08506178f, -0.14119697f, -0.18699758f, 
    0.04341587f, 0.01941450f, 0.05572411f, 0.08612913f, 0.09424835f, -0.09145621f, 0.10258539f, -0.00012941f, 
    -0.07417208f, -0.08384690f, -0.00229921f, -0.10359091f, -0.00778730f, 0.04668304f, 0.18768026f, -0.07968380f, 
    0.09124653f, 0.04830921f, -0.00484356f, -0.03913307f, 0.22095500f, 0.05094879f, -0.17559119f, -0.06629266f, 
    0.02339638f, -0.09772924f, 0.06072797f, 0.11065435f, 0.03045077f, -0.00167278f, -0.03779554f, -0.11932746f, 
    -0.11773407f, 0.20311648f, 0.13876109f, 0.00928571f, -0.01191178f, 0.00339416f, 0.06089101f, -0.04273123f, 
    0.07913953f, 0.12294782f, 0.07691330f, -0.05181184f, 0.27085534f, 0.06482239f, -0.06849068f, 0.34566805f, 
    0.09992465f, -0.09396309f, -0.00447013f, -0.15962726f, -0.08126836f, -0.01925983f, 0.01644595f, 0.01165447f, 
    0.52908629f, -0.25982410f, 0.07947268f, 0.02891590f, 0.17926766f, -0.01360375f, -0.00981655f, -0.00587549f, 
    0.02736402f, -0.04116588f, -0.03098784f, 0.00908120f, 0.00252395f, 0.06956487f, -0.09693690f, 0.09311457f, 
    0.01572225f, -0.00782635f, -0.11586176f, -0.19343422f, -0.00286404f, -0.06318650f, 0.05789306f, 0.02474356f, 
    0.08306810f, 0.01996932f, -0.07968096f, 0.17456289f, 0.00076318f, -0.07908659f, 0.08734123f, -0.08277258f, 
    -0.06815077f, 0.10219352f, 0.01211118f, -0.05348844f, -0.17205372f, 0.20847470f, 0.04777497f, -0.18240732f, 
    0.08541758f, -0.03479380f, 0.05627018f, 0.01417191f, -0.05719791f, 0.08249228f, 0.02961461f, -0.02180062f, 
    0.01099093f, 0.15829206f, 0.07429183f, 0.27793920f, 0.03846486f, 0.04815301f, -0.01652216f, 0.03221859f, 
    0.05473271f, 0.00148187f, 0.05573362f, 0.05546312f, 0.24691774f, 0.08508930f, -0.01595583f, 0.07693215f, 
    -0.03096930f, 0.10028788f, -0.04927399f, 0.02457471f, -0.04906563f, 0.00767576f, 0.06939494f, 0.11684721f, 
    -0.13454042f, 0.03898145f, 0.15849599f, 0.09948514f, 0.06360562f, 0.03446050f, 0.02162826f, -0.04455874f, 
    0.02981895f, -0.00364406f, -0.01618529f, -0.18057673f, 0.43064067f, -0.32414186f, -0.06004707f, -0.00972759f, 
    -0.00082941f, -0.00595006f, -0.00164151f, -0.04344711f, -0.06646639f, 0.09644568f, 0.08480800f, 0.02453861f, 
    0.20133397f, -0.06925120f, 0.00858431f, -0.31479651f, 0.01312730f, 0.10137088f, -0.01731681f, 0.07270011f, 
    0.14028515f, 0.13237174f, -0.01069921f, -0.10236035f, -0.40096739f, 0.12878036f, 0.00732459f, -0.19183256f, 
    -0.08849709f, 0.08283514f, -0.11164322f, -0.03459800f, -0.07160427f, 0.09647849f, -0.10048318f, 0.05608997f, 
    -0.23788761f, 0.18596816f, 0.23138481f, -0.11975533f, 0.10322905f, -0.01018723f, -0.10455748f, 0.00869685f, 
    -0.04757442f, 0.07579720f, 0.04375945f, 0.02217319f, -0.01886023f, -0.04323363f, 0.13464789f, -0.00155001f, 
    0.02206886f, 0.11644085f, 0.04485362f, 0.02142006f, 0.01145226f, 0.07290577f, 0.08310870f, -0.01728091f, 
    -0.21497470f, 0.15576981f, -0.10904796f, 0.04733714f, 0.04581547f, -0.11937194f, -0.10359424f, -0.01048648f, 
    0.04953257f, -0.04975081f, 0.10471775f, 0.12497927f, 0.02002138f, 0.07131817f, -0.07492074f, -0.10738178f, 
    0.15711387f, -0.11280159f, -0.05485776f, -0.10523652f, 0.00512728f, -0.18602583f, 0.11678690f, 0.00010096f, 
    -0.17165987f, 0.22415146f, 0.26593214f, 0.00507114f, 0.13657480f, 0.00057459f, 0.07701843f, -0.18411155f, 
    0.04959700f, 0.07939026f, 0.08011513f, 0.10456994f, 0.04163887f, -0.06787545f, 0.09239118f, 0.11844066f, 
    0.07784305f, -0.14886051f, -0.08557846f, -0.04591138f, -0.16559403f, -0.04931385f, 0.01670785f, -0.08841058f, 
    0.18448429f, 0.06667788f, -0.03569355f, -0.01471430f, 0.08412863f, 0.03843877f, -0.03108891f, -0.01761339f, 
    -0.06721444f, 0.15536122f, -0.08964222f, 0.17511915f, 0.07554532f, 0.05881257f, -0.10518292f, 0.24857943f, 
    0.00214985f, -0.13656570f, 0.06313096f, 0.10994034f, 0.07130814f, -0.06263790f, -0.00645895f, 0.02706167f, 
    -0.02369114f, 0.05781572f, -0.16714877f, -0.07777948f, -0.13608231f, -0.10793941f, 0.11951082f, 0.10345602f, 
    -0.03481455f, 0.19598567f, 0.08203118f, 0.13056257f, -0.03614122f, 0.18536057f, -0.16265304f, -0.20649390f, 
    0.09258369f, 0.05852619f, 0.10333308f, 0.09414827f, -0.01408201f, 0.08033218f, 0.15064766f, 0.09385220f, 
    0.11318229f, -0.36185524f, 0.12512133f, 0.12976955f, 0.03866785f, -0.01492042f, 0.06704320f, 0.04366622f, 
    -0.00621809f, 0.09856969f, -0.06647603f, 0.10879716f, -0.43299228f, 0.12625459f, 0.00275581f, 0.03280863f, 
    0.06398129f, 0.06530847f, 0.21198095f, 0.06218827f, 0.08153249f, -0.04944592f, 0.05126139f, 0.06391894f, 
    0.06817549f, -0.09572347f, 0.04455528f, -0.16775566f, -0.02561788f, 0.05061368f, 0.06346623f, -0.15579148f, 
    -0.08641035f, -0.04998403f, 0.01372439f, 0.00805733f, -0.02650362f, -0.02032317f, -0.03757901f, 0.08570048f, 
    -0.10052104f, 0.07259976f, -0.06551587f, 0.02706124f, -0.06791891f, -0.00586372f, 0.10187026f, -0.13092153f, 
    -0.36492053f, 0.00368170f, -0.04916539f, 0.00635281f, 0.10537013f, -0.00143176f, 0.07380892f, -0.00466791f, 
    0.04051456f, 0.10062893f, 0.07398379f, 0.06857151f, 0.10573552f, 0.21788262f, 0.02231899f, -0.07825701f, 
    0.01684704f, 0.07031544f, 0.06281608f, 0.06212949f, -0.02590607f, -0.06812114f, 0.01348804f, 0.00938928f, 
    0.13835487f, 0.26277977f, 0.04645169f, -0.41348937f, -0.00061234f, 0.04622991f, -0.00817690f, 0.07089589f, 
    0.12413432f, 0.09432296f, -0.12633082f, 0.08453678f, -0.33739513f, 0.18572167f, -0.17348598f, -0.02317632f, 
    0.00535669f, -0.05628575f, -0.00994762f, -0.02436451f, -0.01147926f, 0.03093307f, 0.11308517f, 0.01905892f, 
    0.09885094f, -0.13809392f, 0.18867810f, 0.03747933f, 0.04542284f, 0.12808979f, -0.09221143f, -0.01579205f, 
    -0.01097508f, 0.07140254f, -0.17999898f, 0.17249036f, 0.20093080f, 0.23659453f, -0.16820662f, -0.08293238f, 
    -0.03505444f, -0.11017287f, -0.04648716f, -0.05976760f, 0.11073386f, 0.12606724f, 0.12656638f, 0.03164175f, 
    -0.02128845f, 0.21539423f, 0.11233786f, 0.12207644f, -0.04096306f, 0.06508528f, 0.00139194f, -0.09291490f, 
    0.02607419f, 0.10061965f, 0.16889775f, 0.04594096f, 0.08651119f, -0.14485256f, 0.10534551f, 0.22923216f, 
    0.03583035f, -0.03140069f, 0.03246915f, -0.00304482f, -0.17296480f, -0.16956915f, -0.07219924f, -0.10341256f, 
    0.22044949f, -0.00013264f, 0.15480337f, -0.07566883f, 0.02631936f, -0.05455096f, 0.14470673f, -0.02740034f, 
    0.02477215f, 0.03593317f, 0.00029330f, 0.12668510f, -0.20590512f, -0.02055338f, -0.08291553f, 0.17746593f, 
    -0.07886510f, -0.07482722f, -0.11628925f, -0.11588945f, 0.06378881f, -0.16408511f, -0.07391246f, -0.10133807f, 
    0.00393836f, -0.03135123f, 0.14110462f, 0.19696961f, -0.07030297f, -0.17660984f, -0.03975255f, 0.10790481f, 
    -0.03142926f, 0.17410484f, 0.01720056f, 0.07155088f, -0.26950514f, 0.28021911f, -0.25159693f, -0.28432500f, 
    0.01086342f, 0.04301332f, 0.10030244f, -0.03969457f, -0.01261958f, -0.01859822f, 0.01711637f, 0.08250641f, 
    -0.09870970f, -0.17098236f, 0.13284732f, 0.09417551f, -0.01878393f, 0.10149110f, 0.07588094f, 0.00336689f, 
    0.14092669f, -0.05677593f, -0.03333716f, -0.02157349f, -0.14231686f, 0.09228849f, -0.02612669f, 0.04237431f, 
    -0.06692198f, 0.15014333f, 0.09506971f, 0.07734598f, -0.01379754f, 0.14470692f, 0.05607760f, 0.20859881f, 
    0.08532181f, -0.06775054f, -0.01671159f, 0.05947528f, -0.07593068f, 0.02812040f, 0.08940432f, -0.15823624f, 
    -0.07462161f, -0.08769345f, 0.08232684f, -0.09689314f, 0.12852715f, 0.02088860f, 0.17327516f, 0.09290963f, 
    -0.04631420f, -0.04192175f, -0.05438033f, 0.09278738f, 0.00524547f, -0.03525695f, 0.02216997f, 0.07783128f, 
    0.07251582f, 0.12664823f, -0.07633192f, -0.14041679f, 0.19356555f, -0.03116808f, 0.10564262f, 0.08822906f, 
    0.03763860f, 0.03599762f, 0.17508426f, 0.00113765f, 0.01054974f, 0.25272033f, 0.01211573f, 0.04071113f, 
    -0.17154334f, -0.04156582f, -0.01423177f, 0.07174204f, -0.05441726f, -0.07117844f, 0.03481142f, 0.03203694f, 
    -0.20662273f, 0.14931187f, 0.08962625f, -0.16859084f, -0.05530440f, -0.04424314f, 0.06649720f, -0.01347428f, 
    -0.02010019f, -0.00284641f, 0.00412857f, 0.10769428f, -0.35249704f, 0.12221725f, 0.02559054f, 0.00820844f, 
    0.08509287f, 0.05200990f, 0.01445667f, 0.09567444f, -0.15022674f, 0.16612314f, 0.04262196f, 0.02833752f, 
    0.18170981f, 0.13760322f, 0.17863965f, 0.19364023f, -0.05034363f, -0.07723791f, -0.14402853f, -0.02357623f, 
    -0.09028061f, 0.05670707f, -0.06664248f, 0.18792695f, -0.11467637f, 0.04228961f, 0.01836360f, -0.05997957f, 
    -0.02373283f, -0.01041745f, 0.00749532f, -0.06935763f, -0.01566459f, 0.01157221f, -0.02072323f, 0.07775497f, 
    -0.00303994f, 0.01250700f, -0.04921851f, 0.01242924f, 0.02847589f, 0.04177668f, -0.05748871f, 0.01111891f, 
    -0.06414846f, -0.04200150f, 0.05376782f, -0.05920392f, -0.02535978f, -0.03912554f, 0.02525779f, 0.04438083f, 
    0.02078713f, -0.00086764f, 0.04224107f, 0.00622833f, 0.00211992f, -0.05977491f, -0.06401722f, 0.00480707f, 
    -0.06204269f, -0.04756337f, -0.01126643f, 0.04656793f, 0.03916777f, -0.01583546f, -0.03514773f, -0.05497170f, 
    -0.05806145f, 0.06862976f, -0.05093572f, 0.01351100f, -0.02746784f, -0.07395382f, -0.02772221f, -0.03334752f, 
    -0.00836409f, 0.04634525f, -0.04409874f, -0.04766937f, 0.05778618f, -0.06620147f, 0.06329764f, -0.05139415f, 
    0.00506309f, -0.01619011f, -0.04032214f, -0.00557795f, -0.08256251f, -0.03791152f, 0.05343322f, -0.01672662f, 
    -0.05458947f, 0.03818737f, -0.05302829f, 0.05399731f, -0.00145777f, -0.05777488f, -0.02365189f, 0.04423958f, 
    0.04779587f, -0.02222064f, -0.04012472f, -0.06206717f, -0.05467358f, 0.02675791f, 0.05310368f, 0.02530102f, 
    -0.00298399f, -0.04782488f, -0.03198868f, -0.00095581f, -0.06878655f, -0.06322427f, -0.02180207f, -0.06859966f, 
    -0.01714875f, -0.06370426f, -0.07377379f, 0.02303267f, 0.00804078f, 0.03927661f, 0.04714838f, 0.06448986f, 
    0.02236626f, -0.05092400f, 0.04407312f, -0.01483963f, -0.00806110f, -0.01624258f, 0.02132419f, -0.02108321f, 
    0.03560193f, 0.03630447f, -0.03344810f, -0.05641758f, 0.05690337f, 0.01116485f, 0.04278202f, -0.06661925f, 
    0.03082395f, -0.05320457f, -0.07491689f, -0.08559217f, -0.00453372f, -0.04826473f, -0.05158733f, 0.04950772f, 
    0.04542535f, -0.00922100f, 0.04115970f, -0.00232207f, -0.03722875f, 0.00812586f, 0.03501775f, 0.01143158f, 
    -0.04636082f, -0.01713002f, -0.03080621f, -0.04156997f, -0.03594603f, -0.01144996f, -0.01856579f, -0.04092979f, 
    -0.04054473f, -0.02037109f, -0.06440847f, 0.05366305f, 0.03458010f, 0.02305257f, -0.04930464f, 0.02400435f, 
    0.05917758f, 0.06838962f, -0.00223336f, 0.02597295f, 0.05153143f, -0.02868651f, -0.04316285f, 0.04526463f, 
    -0.06658814f, 0.02928613f, 0.03959101f, 0.03239258f, 0.00798957f, -0.05000388f, -0.02888374f, -0.04226310f, 
    0.06153724f, -0.00545746f, -0.02684549f, 0.05356842f, 0.07283685f, -0.00604789f, -0.02396184f, -0.01117191f, 
    0.04168120f, -0.00271416f, -0.03062443f, -0.03513465f, 0.01073758f, -0.00358272f, -0.06110580f, -0.06075818f, 
    -0.03923712f, -0.04069190f, -0.02003595f, -0.00891398f, -0.01838444f, 0.04289008f, -0.05897725f, 0.00233813f, 
    -0.01873823f, -0.02998369f, -0.02630605f, -0.03495028f, 0.01321202f, -0.02344471f, -0.01097868f, -0.05884388f, 
    -0.03261972f, -0.06869719f, 0.03730299f, -0.04953070f, 0.01053061f, 0.02599393f, -0.04160592f, 0.00485960f, 
    -0.08130897f, 0.02120613f, 0.07065602f, 0.09827974f, -0.02320324f, 0.13565876f, 0.13445710f, -0.13410883f, 
    0.02003069f, 0.11798885f, 0.07717601f, 0.05895854f, 0.18144210f, -0.04643874f, -0.00247247f, 0.14795020f, 
    0.02329770f, -0.14869997f, -0.04599369f, -0.04363879f, 0.03962567f, 0.00118081f, -0.00180789f, -0.05667951f, 
    0.62290901f, -0.15557462f, -0.08803531f, -0.21776806f, 0.04285322f, -0.09636015f, 0.04334354f, 0.16347763f, 
    0.00086915f, 0.03894159f, 0.01138563f, 0.06772204f, -0.13087606f, 0.12072548f, -0.05445715f, 0.20344007f, 
    -0.02498005f, -0.08127779f, 0.04724484f, 0.02472560f, 0.15288766f, -0.15179168f, 0.02545314f, -0.13887386f, 
    -0.07388274f, 0.13672981f, 0.06096561f, -0.11334867f, -0.00623270f, 0.06217087f, 0.00825547f, 0.05484398f, 
    0.04243652f, 0.06087011f, -0.00441845f, 0.12907165f, 0.12967053f, 0.16472962f, 0.01953263f, -0.31926131f, 
    -0.05804045f, 0.07645640f, 0.12864554f, -0.08906478f, 0.07589475f, 0.04475289f, 0.01095033f, 0.02964632f, 
    -0.34444523f, -0.17282464f, 0.15953527f, 0.31093329f, -0.08467060f, 0.02784146f, -0.00877649f, 0.06637273f, 
    0.00117486f, 0.06835797f, 0.01120473f, 0.07061256f, -0.22976607f, -0.06463726f, 0.00967354f, 0.29806235f, 
    -0.07739219f, 0.15056872f, 0.12381696f, 0.00076108f, -0.02017354f, -0.03691055f, 0.12430061f, 0.16678873f, 
    0.00287322f, -0.02544212f, -0.01336696f, 0.03403907f, -0.07779820f, 0.01869220f, 0.09667897f, 0.03765835f, 
    -0.09114024f, 0.04925803f, 0.06344717f, -0.08872382f, 0.00756608f, -0.22552255f, -0.10447545f, 0.01728365f, 
    -0.09530159f, -0.02998708f, 0.10471442f, -0.03856235f, -0.15945686f, -0.10738998f, 0.01715187f, -0.09565765f, 
    0.18207358f, 0.01221942f, 0.05876278f, -0.36041495f, 0.10765893f, -0.01462729f, 0.04343456f, 0.16311066f, 
    0.14715058f, -0.07676267f, 0.09354183f, 0.05766991f, -0.42397845f, -0.04934364f, -0.00514506f, -0.03791722f, 
    -0.01357050f, 0.05951694f, -0.03095066f, -0.04111762f, 0.09286805f, 0.01052404f, -0.01647816f, -0.00574858f, 
    -0.23366471f, 0.25655630f, 0.24973436f, -0.17400378f, 0.06418990f, -0.00952475f, 0.03681406f, 0.02901548f, 
    0.03533022f, 0.07250549f, -0.01446727f, 0.00188134f, -0.19272745f, -0.20988023f, -0.00485598f, 0.09256773f, 
    -0.00487428f, -0.01346344f, 0.04546819f, -0.06816021f, -0.07128987f, 0.01093065f, 0.09069666f, 0.00338273f, 
    -0.03703807f, 0.04915835f, 0.11792840f, 0.10591217f, 0.17146422f, 0.04773506f, -0.07745523f, 0.00893485f, 
    -0.12994650f, -0.02049746f, -0.00201706f, 0.14648548f, -0.23497093f, 0.11919204f, 0.14802989f, -0.12663592f, 
    0.07453802f, 0.04266584f, -0.05434076f, -0.00381704f, 0.09655095f, -0.13224913f, 0.02547436f, 0.14337845f, 
    -0.02055526f, 0.14779329f, 0.03114826f, 0.14526127f, -0.02441078f, 0.07204071f, 0.02712693f, 0.01703757f, 
    -0.01088064f, 0.11104934f, -0.00142321f, -0.00950183f, -0.08227489f, -0.05340396f, 0.07913446f, 0.08140976f, 
    0.07194611f, 0.03043135f, 0.02444082f, -0.08017379f, 0.04723832f, -0.09191786f, -0.04510034f, 0.06225019f, 
    0.67335355f, -0.06545810f, -0.00235997f, 0.17404628f, 0.15534174f, 0.03763960f, 0.10125353f, 0.01900522f, 
    0.12171304f, 0.00558546f, -0.03986254f, 0.08292361f, -0.15557429f, 0.01765622f, 0.04964538f, -0.13480638f, 
    0.10309381f, 0.09734764f, -0.08266778f, 0.03564497f, 0.20715356f, -0.14358585f, 0.15423819f, -0.08663689f, 
    -0.10787705f, -0.25027665f, 0.01089267f, 0.05587207f, -0.10894709f, -0.02446966f, 0.08586749f, -0.00228572f, 
    -0.00175509f, 0.04718189f, -0.12581921f, 0.00158934f, 0.13915080f, 0.15214121f, 0.07271080f, 0.16528027f, 
    -0.16374737f, -0.04492987f, 0.11039837f, 0.09356213f, -0.00096637f, 0.06529912f, 0.04395226f, 0.04274224f, 
    0.02528866f, -0.03869846f, -0.06999414f, -0.15044932f, 0.09833983f, 0.14054932f, -0.00333678f, 0.05564868f, 
    0.01644673f, 0.03735846f, 0.09786804f, 0.01640633f, 0.13648051f, -0.09301735f, 0.17117567f, -0.02706822f, 
    -0.00400787f, -0.01243265f, -0.04605861f, 0.00850033f, 0.03073370f, 0.27638453f, 0.06675089f, 0.11811585f, 
    -0.25521952f, -0.33382201f, -0.00268631f, -0.10945597f, 0.16302390f, 0.15274720f, 0.12334218f, 0.11442652f, 
    -0.01257144f, 0.02985449f, 0.10885391f, -0.12045010f, 0.08664601f, -0.18670464f, -0.03421626f, 0.05166614f, 
    0.04814714f, -0.02015719f, 0.11586842f, -0.05546533f, 0.03997229f, 0.19717045f, -0.05556282f, 0.09118025f, 
    -0.54705846f, -0.20799042f, -0.19384526f, -0.22195821f, 0.00896796f, 0.03534367f, -0.03609976f, 0.13612521f, 
    0.01001234f, -0.06421380f, -0.10427654f, -0.04027517f, -0.20122729f, -0.01173138f, 0.24032597f, -0.14843285f, 
    -0.15914045f, 0.05742980f, -0.03024639f, 0.17211498f, 0.00936981f, -0.09395747f, 0.05071847f, 0.05955005f, 
    0.07933249f, 0.20479529f, 0.18120499f, 0.03159218f, 0.05370987f, 0.01071590f, -0.10714795f, 0.00255966f, 
    0.07893297f, 0.07707400f, 0.02102613f, 0.07316700f, -0.58706051f, -0.18890138f, -0.19562724f, -0.26631737f, 
    0.17841673f, 0.16052656f, 0.08524223f, 0.08538692f, 0.01752847f, 0.03260109f, -0.01812263f, 0.07737467f, 
    -0.16611782f, 0.24553052f, 0.27701780f, -0.05090323f, -0.09847217f, -0.00503823f, 0.09312487f, -0.13135982f, 
    -0.00035299f, -0.03554366f, 0.12000326f, 0.05592001f, -0.14986911f, -0.00971319f, 0.15739411f, 0.00816787f, 
    -0.02096888f, -0.15258728f, -0.02050475f, -0.01917206f, 0.04029923f, 0.07894167f, -0.01591375f, 0.08931579f, 
    -0.08454558f, 0.19013283f, 0.19756529f, -0.07023463f, 0.07728023f, -0.08163766f, 0.01660026f, 0.05561796f, 
    -0.04977998f, -0.08803380f, 0.00901253f, -0.02752496f, -0.20296286f, -0.02224953f, -0.03313147f, 0.00010596f, 
    0.05310167f, 0.09210932f, -0.08456583f, -0.01150441f, -0.03681517f, 0.02095819f, -0.00526506f, -0.03844785f, 
    -0.23385228f, -0.00421561f, 0.10346031f, 0.24448003f, 0.14332652f, 0.07968329f, 0.02026562f, -0.11984398f, 
    -0.01864255f, 0.06156125f, 0.07068914f, 0.03654984f, 0.23134039f, -0.12649092f, -0.17469427f, -0.13403054f, 
    0.06810842f, -0.00496374f, 0.12670176f, -0.05349158f, 0.05764689f, -0.00361024f, -0.13044968f, 0.03326231f, 
    0.23960464f, 0.00476535f, -0.24140155f, -0.05426707f, 0.02675813f, 0.02647383f, -0.11295773f, 0.08527358f, 
    0.02192839f, -0.06161985f, 0.02524361f, 0.00341993f, -0.21201816f, 0.27575728f, -0.09497973f, 0.07727852f, 
    0.10143307f, 0.03770947f, -0.02256178f, 0.08226689f, -0.02523464f, -0.07395244f, -0.02439704f, -0.06039178f, 
    0.17450716f, 0.01818321f, 0.01545240f, -0.15065944f, 0.15820229f, 0.02192123f, 0.07901650f, -0.06579094f, 
    0.05966102f, 0.02809924f, -0.05894526f, 0.05803655f, 0.14824845f, 0.26352531f, 0.05573006f, -0.04660638f, 
    0.15335310f, 0.00935178f, 0.00381080f, -0.00209187f, 0.11136215f, -0.09219973f, 0.01478080f, -0.03108503f, 
    0.10352826f, -0.00206602f, -0.05380650f, -0.07648323f, 0.06935967f, -0.00529462f, -0.10872510f, 0.03199651f, 
    -0.00860565f, 0.05828653f, -0.11344597f, 0.03343155f, 0.20086044f, -0.10503194f, -0.19480903f, 0.02113451f, 
    0.08362319f, 0.07879642f, -0.15732057f, 0.03222707f, 0.02160024f, -0.02465510f, -0.00921762f, 0.00776689f, 
    -0.03221762f, -0.13067657f, -0.07341989f, 0.31924045f, -0.15860996f, 0.05887696f, -0.10177892f, -0.15286596f, 
    -0.06828767f, 0.12986259f, -0.03205654f, 0.00223026f, 0.17020424f, -0.00378078f, 0.03361379f, -0.18933377f, 
    0.13845797f, 0.00972221f, -0.00911893f, -0.03464181f, 0.00559342f, 0.01252734f, -0.00279204f, 0.02040272f, 
    0.15825514f, -0.07587156f, -0.00766883f, -0.32114390f, 0.10534987f, 0.03917443f, -0.10153887f, -0.01899181f, 
    -0.13759688f, -0.04679327f, -0.09002287f, -0.10831338f, 0.40979788f, 0.03683605f, -0.10260219f, 0.09367309f, 
    0.09564474f, -0.00864468f, -0.08879913f, -0.00387088f, 0.02242178f, -0.01378257f, 0.00727542f, -0.10758931f, 
    -0.30566704f, -0.15154353f, 0.11632524f, -0.25147718f, 0.01241969f, 0.02818902f, 0.00479739f, 0.07392882f, 
    0.05467990f, -0.00478948f, -0.13539052f, -0.01796276f, 0.31608513f, 0.16123705f, -0.00352281f, -0.17167547f, 
    -0.07938165f, -0.08174787f, -0.10322179f, -0.00022837f, -0.03864327f, 0.08559171f, -0.01529393f, -0.04037069f, 
    -0.13202338f, -0.08633182f, 0.15967079f, 0.05617844f, -0.00245299f, 0.10595705f, 0.09303681f, 0.00610445f, 
    0.06195075f, 0.07109347f, -0.12569003f, 0.04494546f, -0.01247272f, 0.08046225f, -0.06579569f, -0.04464808f, 
    0.00868298f, 0.04260005f, -0.00536883f, 0.01167599f, 0.02619981f, 0.05796026f, -0.01302123f, -0.03852481f, 
    0.49326161f, -0.10259005f, -0.07315473f, -0.00334160f, 0.12453439f, 0.02827151f, -0.02391542f, 0.11587811f, 
    0.01713667f, -0.00729428f, 0.02850786f, 0.04680688f, 0.16033730f, -0.06701469f, -0.14754723f, -0.07429736f, 
    0.13483450f, 0.02996701f, -0.12775467f, -0.08360612f, 0.12064724f, 0.04258383f, 0.07201540f, 0.07521248f, 
    -0.05437418f, -0.04814615f, -0.14791678f, -0.18876684f, -0.03085681f, 0.11010794f, -0.14204897f, 0.14009878f, 
    0.03119067f, -0.05330269f, 0.13402654f, 0.03062642f, -0.18852551f, 0.07867847f, 0.04174917f, 0.11988181f, 
    0.01462724f, 0.07232800f, 0.01932888f, -0.03919478f, -0.03912183f, -0.08282576f, 0.07384320f, 0.01898099f, 
    -0.09249563f, 0.25909430f, 0.21070676f, 0.04298086f, -0.08074591f, -0.06173541f, 0.05107778f, 0.07713620f, 
    0.09645733f, -0.00547621f, 0.04395049f, 0.14338420f, -0.15338205f, -0.12895012f, 0.06499445f, 0.14786327f, 
    0.08214653f, 0.08150336f, -0.01290950f, 0.10464411f, 0.04331907f, 0.09672947f, 0.05837045f, 0.06881185f, 
    -0.08147420f, -0.01078838f, 0.06585008f, -0.18859896f, -0.03559776f, 0.09860577f, 0.06206055f, 0.13303414f, 
    -0.02500172f, 0.11348505f, 0.00768155f, -0.04923483f, 0.05215511f, -0.07957534f, -0.08965793f, -0.14770892f, 
    0.23019175f, 0.17353360f, -0.02970775f, -0.14783412f, 0.08463437f, -0.01062788f, -0.13930380f, 0.08908012f, 
    0.46468088f, -0.21401447f, 0.03657758f, -0.04048732f, -0.06199214f, 0.04861675f, -0.05925351f, 0.08548734f, 
    0.21519253f, -0.03439876f, -0.08500478f, 0.01113227f, -0.29031223f, -0.10747693f, 0.13651165f, -0.20460619f, 
    0.06252464f, 0.15793413f, 0.04497901f, -0.00809766f, 0.00659975f, -0.01966450f, -0.09645402f, -0.07711827f, 
    -0.30205795f, -0.12840298f, 0.11402340f, -0.07758371f, 0.11716641f, 0.04107656f, -0.04214830f, 0.06539651f, 
    0.00569932f, 0.00253359f, 0.06314290f, -0.10689428f, 0.47447684f, -0.21871161f, 0.00509254f, -0.03704338f, 
    -0.15982543f, 0.06524935f, -0.01180025f, 0.00635189f, -0.04802679f, 0.06358653f, -0.01531936f, 0.02731670f, 
    -0.08454587f, 0.13520649f, -0.09005957f, -0.21334255f, 0.08619455f, -0.03927360f, 0.00765894f, 0.04362179f, 
    -0.12972383f, 0.05603521f, 0.05900719f, -0.04868067f, -0.26311812f, -0.10884255f, 0.03676910f, 0.00817506f, 
    0.09234904f, 0.06541833f, -0.07297346f, -0.10036840f, -0.01377523f, -0.15396175f, 0.13325733f, -0.02395187f, 
    0.28664389f, -0.00836019f, -0.25324762f, 0.10282422f, -0.07093799f, 0.05937061f, 0.05959920f, 0.13577852f, 
    -0.06306544f, 0.08365816f, 0.10920157f, 0.04669256f, 0.08312365f, 0.07207733f, -0.14383397f, 0.20018277f, 
    -0.03229962f, 0.05280688f, -0.06163064f, -0.07733386f, 0.11814589f, 0.12671988f, -0.01774289f, 0.03775175f, 
    -0.22803672f, -0.09554181f, 0.03540705f, -0.20636605f, 0.02997312f, 0.05161388f, -0.07063589f, 0.02237835f, 
    -0.01189045f, -0.05305927f, -0.01473235f, -0.07476877f, -0.26370835f, 0.12455953f, 0.25160104f, 0.01784724f, 
    -0.14031488f, 0.11266312f, -0.11239556f, 0.14215896f, -0.01437594f, -0.05478770f, 0.06453007f, -0.06946895f, 
    0.02707621f, 0.17350693f, 0.02808950f, 0.07277960f, 0.02827831f, 0.06674830f, 0.11172040f, 0.11113636f, 
    0.01112077f, -0.02249386f, -0.03107098f, -0.06695651f, 0.24561453f, -0.16003795f, 0.33270293f, -0.05114794f, 
    -0.13272747f, 0.06354014f, -0.03209416f, 0.00610537f, -0.01456843f, -0.09185234f, -0.06115059f, -0.05397157f, 
    -0.17813031f, -0.00000351f, -0.22326228f, 0.11405238f, -0.01080541f, 0.08056726f, -0.04682775f, -0.05727131f, 
    -0.08043432f, -0.03660948f, -0.05499897f, -0.02979832f, 0.09938439f, 0.03922886f, 0.14835609f, 0.03350473f, 
    0.10868397f, -0.05829351f, -0.10672739f, -0.10213713f, -0.02781251f, -0.00968243f, 0.09261728f, -0.04272551f, 
    0.06611335f, 0.15821138f, -0.10043424f, 0.14753157f, 0.00027995f, -0.13524629f, -0.12141167f, 0.07404094f, 
    0.05968455f, -0.05875656f, -0.02623595f, -0.08605442f, -0.05913268f, -0.11011565f, 0.13065185f, -0.07496847f, 
    -0.09052403f, -0.11955886f, -0.01889613f, 0.09464422f, 0.01464653f, 0.04739872f, -0.09869603f, -0.05048744f, 
    -0.10405692f, 0.08495798f, 0.08328500f, -0.01845774f, 0.07860154f, 0.07102778f, 0.04550860f, 0.01846297f, 
    0.02260861f, -0.06769925f, 0.05917928f, 0.05021155f, 0.01963715f, 0.02509968f, -0.18173902f, 0.25102934f, 
    -0.03054429f, -0.02895673f, -0.06013145f, 0.03576060f, 0.04931246f, 0.04845254f, -0.03040029f, 0.05142976f, 
    0.10878356f, 0.05548346f, 0.05889759f, 0.11739229f, -0.00384136f, 0.10146000f, 0.12835307f, -0.06276041f, 
    -0.00277370f, -0.08419340f, 0.12309568f, 0.04444736f, -0.22594440f, -0.08895692f, 0.20221503f, -0.21037120f, 
    0.06374318f, 0.12463212f, -0.01580032f, 0.07740107f, 0.04050164f, -0.01816717f, 0.04655878f, -0.04172273f, 
    0.13368212f, -0.10479213f, -0.10498221f, 0.38062119f, -0.11518455f, -0.02447307f, 0.01702696f, -0.05132054f, 
    0.00679643f, -0.00398439f, 0.19706039f, 0.01622819f, 0.10233986f, -0.10371716f, 0.26838323f, 0.02817983f, 
    -0.06372120f, 0.01621158f, 0.05055261f, 0.01123199f, 0.03115732f, -0.09860854f, -0.08639288f, 0.08127816f, 
    -0.35499969f, 0.11771012f, 0.18983093f, -0.07158483f, -0.01569806f, 0.01733400f, 0.09765211f, 0.07536978f, 
    0.05361059f, -0.02872461f, -0.00350620f, -0.02669092f, -0.26415876f, -0.18647356f, -0.04229388f, 0.09024422f, 
    -0.09968577f, -0.06764149f, 0.05250710f, -0.00456343f, -0.01509371f, -0.07781073f, 0.04486785f, 0.01687527f, 
    0.19102770f, -0.19528322f, -0.21393141f, 0.00693676f, 0.03141053f, 0.07567119f, -0.04401881f, -0.01701184f, 
    0.07822558f, 0.03029528f, 0.12141207f, 0.11002153f, 0.22710836f, -0.11991922f, -0.11533199f, -0.12689050f, 
    0.10401340f, 0.07583964f, -0.08366615f, -0.02556898f, 0.03465852f, 0.09924669f, -0.07180919f, -0.08151130f, 
    0.22869724f, -0.05284479f, -0.24639830f, 0.12295422f, 0.08005302f, 0.00174796f, 0.01323420f, -0.05822442f, 
    0.03984701f, -0.14607173f, 0.08702427f, -0.01431971f, -0.26683703f, 0.16381451f, 0.10165498f, -0.22413559f, 
    0.00101574f, 0.02134284f, 0.03517189f, -0.05935556f, 0.07835817f, 0.05148035f, -0.03300238f, -0.00389743f, 
    -0.08486070f, 0.02828910f, 0.03586715f, 0.02425214f, -0.02158839f, -0.11722837f, 0.09325866f, 0.04364360f, 
    0.03080565f, -0.11530795f, 0.08618397f, -0.10054542f, 0.18105249f, 0.02252460f, 0.06342509f, 0.08102527f, 
    0.08962137f, -0.06293788f, 0.04760716f, -0.07375700f, -0.00155115f, -0.02618674f, 0.10455584f, 0.13354212f, 
    -0.05005069f, 0.05874240f, 0.08350260f, 0.08575525f, 0.10876384f, 0.03577449f, 0.02360586f, 0.11637864f, 
    0.00813592f, 0.13063402f, 0.00504135f, 0.00924509f, 0.25508934f, -0.16079378f, -0.14444159f, -0.21984634f, 
    0.03505602f, 0.19007678f, 0.03483733f, 0.00035086f, 0.06286686f, -0.06734836f, -0.05083432f, 0.00150243f, 
    0.32572448f, -0.14754865f, -0.10253723f, -0.04440542f, -0.09278627f, 0.21050170f, 0.00918884f, 0.18289028f, 
    -0.18069750f, -0.03718382f, 0.01832669f, -0.07320368f, -0.21225587f, -0.13510886f, 0.01813519f, -0.10163128f, 
    -0.04184789f, -0.04516879f, 0.03102637f, -0.07056876f, -0.08670312f, 0.03241238f, 0.08612616f, 0.05158683f, 
    -0.22220212f, 0.10359802f, 0.22847714f, -0.18755440f, 0.18296769f, 0.10487577f, -0.02682297f, -0.06357626f, 
    -0.01950938f, 0.11735263f, 0.05777204f, 0.02084885f, 0.51433635f, -0.26824504f, -0.13392942f, 0.03403491f, 
    -0.03422078f, 0.10275874f, -0.06246137f, 0.09537953f, -0.08581311f, -0.08859811f, 0.13168739f, -0.02784788f, 
    -0.31482306f, 0.00183076f, -0.07532378f, 0.10101794f, 0.23866335f, -0.08035824f, -0.06993323f, 0.00178022f, 
    -0.05911774f, -0.02786099f, 0.05020658f, -0.10653266f, -0.08291232f, -0.01443408f, 0.24350883f, -0.21647424f, 
    -0.07812209f, 0.04869605f, -0.07975119f, 0.03593870f, -0.01897158f, -0.21572572f, 0.15585203f, -0.08685374f, 
    -0.07477643f, -0.06772847f, -0.04604414f, 0.05676415f, -0.03112996f, -0.03814603f, -0.02291876f, 0.04252453f, 
    0.03589181f, -0.07929283f, -0.08709311f, 0.05515924f, 0.05951727f, 0.00932899f, 0.00439617f, 0.04826553f, 
    0.00330871f, -0.05274800f, 0.03141902f, -0.04779728f, -0.06093512f, 0.00008386f, -0.00636872f, -0.02991789f, 
    -0.00829264f, 0.03136142f, 0.05753332f, -0.10622343f, -0.00059781f, 0.01482461f, 0.01049398f, 0.00955884f, 
    -0.08563012f, -0.07195415f, 0.05068837f, -0.00898552f, -0.06339402f, 0.00263624f, -0.09717081f, 0.06087884f, 
    -0.05220019f, -0.02605339f, 0.01044271f, -0.07923094f, 0.00590394f, 0.02307739f, -0.05041077f, -0.02667591f, 
    -0.05198159f, -0.06437501f, -0.01422754f, -0.04554011f, 0.02623566f, 0.02019073f, 0.05827429f, 0.05865946f, 
    0.02989282f, 0.00454160f, 0.06341038f, 0.04714123f, 0.05777786f, 0.01103542f, -0.01385088f, 0.03314816f, 
    -0.03476570f, -0.07969777f, -0.09356562f, -0.06121075f, 0.02015845f, 0.03110025f, -0.06189973f, 0.00961966f, 
    0.00636423f, 0.04368200f, 0.06633778f, 0.02268293f, 0.03613043f, -0.00987456f, -0.03218408f, -0.07038563f, 
    0.04363218f, -0.00210311f, 0.02183542f, 0.00677960f, -0.00162998f, -0.00862083f, 0.01397469f, -0.06390554f, 
    -0.10597903f, 0.00430392f, -0.09017070f, -0.04388141f, 0.00685327f, -0.00676147f, -0.01886636f, -0.03430743f, 
    0.08786530f, -0.04821676f, -0.05732672f, 0.05801984f, -0.03827616f, 0.00701041f, -0.01709724f, -0.00855811f, 
    -0.09323251f, 0.06004493f, 0.00457688f, 0.05303034f, 0.03146555f, 0.01459697f, -0.00528541f, -0.07913975f, 
    -0.01739850f, 0.03575051f, -0.04831748f, -0.01178044f, -0.00217174f, 0.00855243f, -0.03135435f, -0.02516936f, 
    0.01178024f, -0.03522688f, -0.05006308f, -0.11364657f, 0.01174975f, -0.01139999f, 0.05047955f, -0.05388595f, 
    -0.04686130f, 0.03279253f, 0.07523581f, -0.06431790f, -0.03305518f, 0.04907864f, 0.03792427f, -0.03767977f, 
    -0.07773457f, 0.00377616f, 0.06762251f, -0.02571834f, -0.07953686f, -0.04314217f, 0.04455869f, -0.01274313f, 
    0.05208687f, 0.04093459f, 0.03962686f, -0.09812072f, 0.00376952f, -0.03232465f, -0.07968430f, 0.02858459f, 
    0.00440708f, -0.00673642f, -0.08107381f, -0.09069424f, -0.10459387f, -0.05034921f, 0.04359337f, -0.08155841f, 
    -0.04407063f, -0.02567880f, 0.00058713f, 0.03639303f, -0.07143953f, 0.01783508f, 0.01093564f, -0.04349871f, 
    0.02385448f, 0.05557105f, -0.06609735f, 0.06807368f, -0.07801745f, -0.07404216f, 0.01568323f, -0.11104736f, 
    -0.00883853f, -0.02097179f, 0.00123763f, -0.05646696f, 0.03234288f, 0.04517750f, -0.04733479f, -0.01113242f, 
    -0.06052351f, -0.04803719f, -0.08758568f, -0.04435397f, 0.02817201f, -0.07773651f, -0.07715829f, -0.02525276f, 
    0.11583769f, -0.06995003f, -0.25434133f, -0.07359987f, -0.04899377f, 0.06058697f, 0.06599700f, -0.10421339f, 
    -0.07216662f, 0.09972836f, 0.03305846f, 0.03580992f, 0.24545117f, 0.17078608f, 0.30065188f, 0.13838753f, 
    -0.10871896f, -0.01948476f, 0.07129817f, 0.10258062f, -0.06208488f, -0.16209927f, 0.02364443f, -0.11177395f, 
    -0.16433047f, 0.20973299f, -0.01891077f, -0.11021321f, 0.01124577f, 0.03246105f, 0.02251407f, 0.13933292f, 
    0.02956892f, -0.02443822f, 0.16118154f, 0.13046320f, 0.12928435f, -0.05800727f, 0.02295765f, 0.28056595f, 
    0.00447523f, -0.02872130f, 0.19768240f, 0.07571257f, -0.14126970f, 0.00659186f, -0.12387118f, 0.00565613f, 
    0.15897071f, 0.09603964f, 0.39894944f, 0.29300138f, -0.03803468f, 0.02571160f, -0.07805444f, 0.00037423f, 
    -0.03570573f, 0.05037997f, 0.21797004f, -0.02497983f, 0.06981047f, 0.10423085f, -0.21801150f, 0.18411292f, 
    0.02528816f, -0.17107576f, -0.28498179f, -0.08363524f, 0.07013934f, 0.10819130f, 0.01779219f, 0.08690263f, 
    -0.09658843f, -0.01710274f, 0.07358662f, 0.12138011f, 0.14274396f, 0.00085284f, 0.21675515f, 0.19167690f, 
    0.12190963f, 0.09821822f, -0.03755400f, 0.19129133f, 0.08734440f, -0.15477951f, -0.26843429f, -0.13281870f, 
    -0.20327416f, -0.04520154f, 0.03847663f, -0.21430516f, -0.09803946f, -0.01541929f, 0.05509692f, 0.14584793f, 
    0.42604354f, 0.26301110f, 0.19918251f, 0.38384193f, -0.09261710f, -0.07453835f, -0.10560600f, -0.05483017f, 
    -0.01544857f, -0.12274824f, -0.00927505f, -0.01239294f, 0.06172840f, -0.05394997f, 0.20058189f, -0.01400211f, 
    -0.06015804f, 0.00335899f, -0.05698752f, 0.04573804f, -0.17852326f, -0.25628644f, 0.18140376f, -0.02494958f, 
    -0.11458758f, 0.17413762f, -0.05829902f, 0.04832916f, 0.08631140f, 0.04516856f, -0.09862638f, -0.11298855f, 
    -0.21679904f, -0.10879287f, -0.04505483f, 0.16042696f, 0.08518782f, 0.01860807f, -0.11457104f, 0.31305489f, 
    0.08757565f, -0.14267386f, 0.06893605f, -0.27421546f, 0.05929301f, 0.04341212f, 0.04660986f, 0.04881671f, 
    0.03741621f, -0.16153999f, -0.21700445f, -0.06663247f, -0.06487023f, -0.14249569f, -0.19915415f, 0.01610430f, 
    0.04899900f, -0.12599447f, -0.00678223f, 0.09369878f, 0.21001729f, 0.33026180f, 0.23933825f, 0.37014297f, 
    0.06957911f, 0.07325088f, 0.00852299f, 0.06463841f, -0.01325471f, -0.07190222f, -0.17842598f, -0.04856810f, 
    0.01855997f, 0.13497415f, -0.14598483f, 0.15303305f, -0.17740846f, -0.00059898f, -0.07614768f, -0.10396762f, 
    -0.07006814f, 0.00808800f, -0.08316493f, 0.02620605f, -0.25727710f, -0.16264893f, -0.42967057f, -0.10584529f, 
    0.02002907f, 0.15591510f, -0.15275151f, 0.01292645f, 0.08612815f, 0.09891620f, -0.00069678f, -0.01659378f, 
    -0.24889614f, -0.00744559f, -0.00712856f, -0.07013733f, -0.00615620f, -0.00299064f, -0.02685453f, 0.04899681f, 
    -0.03600485f, -0.03861880f, -0.01914688f, -0.11694725f, -0.14089933f, 0.06200777f, -0.25601479f, -0.11724583f, 
    0.03536639f, 0.17926696f, -0.03568760f, -0.11242434f, -0.00543637f, 0.08051127f, 0.13190757f, 0.06147625f, 
    0.21161360f, -0.06221448f, 0.09177740f, 0.15730035f, -0.03358169f, 0.03571804f, -0.00591117f, -0.02219474f, 
    0.14821088f, 0.00719120f, -0.05115698f, -0.04452374f, 0.01783564f, 0.09050030f, 0.01906755f, -0.25123554f, 
    -0.06423624f, 0.07894933f, -0.06626781f, 0.01949258f, -0.10368808f, 0.14828414f, 0.08037972f, 0.15702365f, 
    -0.00878962f, -0.06709586f, -0.26086652f, -0.12066280f, 0.00028459f, 0.04793838f, 0.05839876f, -0.07521059f, 
    0.16727783f, -0.08270319f, -0.00537964f, 0.04932329f, 0.20352927f, -0.20416801f, 0.30289039f, 0.38309646f, 
    -0.01773116f, -0.00013798f, 0.00214188f, 0.14211987f, -0.07864249f, 0.04995432f, 0.02228853f, -0.08505056f, 
    0.51928943f, 0.26725483f, -0.09514335f, -0.17758092f, -0.09868982f, -0.08440293f, -0.00634779f, 0.06967037f, 
    -0.06859524f, -0.00414245f, 0.03058937f, 0.01336902f, 0.13601080f, 0.12549327f, 0.02312591f, -0.06026181f, 
    0.13798648f, -0.07840712f, -0.06683433f, 0.01522080f, 0.02586189f, -0.07973989f, -0.00457039f, -0.11420710f, 
    -0.31247598f, -0.15539254f, -0.07819126f, -0.14299235f, 0.07702005f, -0.12812559f, 0.09350374f, 0.05527917f, 
    0.19006483f, 0.05684035f, 0.05234377f, -0.01213303f, -0.06484122f, 0.01574014f, -0.10819283f, -0.11674695f, 
    0.07817666f, 0.09429216f, -0.06271665f, -0.06227163f, 0.01410659f, 0.08766703f, 0.01204369f, -0.05693550f, 
    0.04078253f, -0.15075049f, -0.02894571f, 0.12970762f, -0.17604543f, 0.04763189f, -0.13965195f, 0.00380082f, 
    0.05995924f, 0.10902046f, -0.11707556f, -0.11667321f, 0.02015758f, -0.07189458f, 0.01522950f, -0.14768420f, 
    0.02399557f, 0.08037277f, 0.03747301f, 0.14037512f, -0.04306590f, 0.10029347f, -0.03746586f, 0.04114151f, 
    0.26769423f, 0.11238369f, 0.03648511f, 0.13047487f, 0.01522794f, 0.04898717f, 0.00152246f, -0.08004309f, 
    0.02152921f, 0.03135272f, 0.08141133f, -0.01389991f, 0.10543175f, 0.09798773f, -0.07790473f, -0.16644736f, 
    -0.09101292f, -0.06039587f, -0.02062817f, 0.11049302f, 0.20044062f, -0.09493612f, -0.00841880f, 0.08110096f, 
    -0.24373053f, 0.08463369f, -0.10757621f, -0.18841088f, -0.02060604f, 0.01276982f, 0.08124020f, 0.00247216f, 
    0.02462050f, 0.09386154f, -0.00704829f, -0.06621499f, 0.51848042f, 0.13258733f, 0.15708779f, 0.07101835f, 
    0.07737622f, -0.11222747f, 0.08708803f, 0.14430274f, -0.07497777f, -0.06851163f, -0.07279459f, 0.03942938f, 
    0.30394155f, 0.05894763f, 0.17269664f, 0.02061023f, 0.13078682f, -0.07367485f, 0.00448925f, 0.01013821f, 
    0.13136548f, 0.12379815f, 0.03961589f, 0.18107581f, -0.03877324f, -0.11079901f, -0.06977804f, -0.04322078f, 
    -0.07029476f, -0.01462415f, -0.10580778f, 0.11860020f, -0.05306156f, -0.07193823f, 0.01723937f, -0.06636657f, 
    -0.30555889f, -0.02668016f, 0.14668420f, -0.03724976f, -0.07382690f, 0.07928558f, 0.00969789f, -0.02179555f, 
    -0.13887003f, 0.11127035f, 0.10411216f, 0.16910169f, -0.05776507f, 0.02641977f, 0.00043559f, 0.05919992f, 
    0.11765487f, 0.03816746f, 0.16137251f, 0.06007318f, 0.01595644f, -0.04155742f, -0.05693735f, -0.06378710f, 
    -0.14136536f, 0.09300253f, -0.11600602f, -0.24251682f, 0.01787371f, 0.06992102f, 0.06382617f, 0.10147797f, 
    -0.04758494f, 0.11300275f, -0.01597897f, 0.16812594f, -0.04519199f, 0.15223448f, -0.08223287f, 0.02073599f, 
    0.01800244f, 0.02058671f, -0.01085122f, 0.07338883f, 0.01625675f, -0.02607574f, -0.07085668f, 0.10478060f, 
    -0.17466429f, -0.26476443f, -0.04140389f, -0.12588044f, 0.04512814f, 0.02282314f, 0.01007890f, -0.05915060f, 
    -0.06326617f, 0.04629362f, -0.04908960f, 0.01121327f, -0.34456226f, 0.15319900f, 0.00710441f, 0.12599769f, 
    0.08982068f, 0.00626498f, -0.00576807f, 0.15382046f, 0.13317893f, 0.04068716f, 0.01271521f, -0.11297052f, 
    0.10636581f, 0.13082539f, -0.17503464f, -0.17449853f, -0.03592932f, 0.04837259f, -0.07495029f, 0.04520897f, 
    -0.10918799f, 0.04320386f, 0.06609888f, 0.16111556f, -0.02930489f, -0.04399566f, -0.04033600f, 0.11957339f, 
    -0.05285481f, 0.00384962f, -0.03011828f, 0.06033326f, 0.06863365f, -0.08472250f, -0.07317703f, -0.13456766f, 
    -0.17004964f, -0.02126353f, 0.01163251f, 0.14486958f, -0.02867508f, 0.05207536f, 0.05572242f, -0.16277859f, 
    -0.00213364f, 0.01217985f, 0.06149082f, 0.06233997f, 0.29152673f, 0.10747460f, -0.11538958f, 0.03661925f, 
    0.25871119f, 0.05516265f, 0.05023807f, 0.07968399f, 0.08023807f, -0.07758884f, 0.01784530f, 0.02603137f, 
    0.29278648f, 0.02530654f, -0.03303977f, -0.14468442f, 0.09525670f, -0.05142107f, 0.03178047f, 0.08292444f, 
    0.02707141f, -0.06985752f, -0.12211235f, 0.01345725f, -0.09571480f, -0.01928236f, -0.13946034f, -0.00216909f, 
    0.05613191f, -0.01855227f, -0.08278076f, -0.07675481f, -0.09894644f, 0.03484261f, 0.04681203f, -0.07621645f, 
    0.37886959f, -0.25083268f, 0.10515314f, -0.07173970f, -0.01237018f, 0.05323613f, 0.15193769f, 0.01189915f, 
    0.04798681f, 0.00660936f, -0.08879728f, -0.01037928f, 0.03227794f, 0.18657932f, -0.12084448f, 0.03834253f, 
    -0.01778275f, 0.04191733f, -0.03249157f, 0.05551248f, 0.09139504f, 0.24114446f, 0.07164366f, 0.05795211f, 
    0.08725249f, 0.31215078f, 0.18417260f, -0.16234218f, 0.13891445f, -0.10633641f, 0.04380801f, 0.07660355f, 
    0.06913705f, 0.01292599f, 0.07662614f, -0.12080171f, -0.04947422f, 0.01738607f, -0.03953151f, 0.06264412f, 
    -0.01852685f, 0.06018287f, -0.04999033f, -0.08689124f, -0.09518529f, -0.01085946f, 0.12228128f, 0.06827023f, 
    -0.13886079f, -0.40594047f, 0.15315877f, 0.04331453f, 0.02522104f, 0.07976517f, -0.17888758f, -0.00540565f, 
    0.11324301f, 0.01344078f, 0.01403161f, 0.06696201f, 0.12534696f, 0.08908986f, -0.20666280f, -0.01713389f, 
    0.07493911f, -0.00065427f, -0.07242644f, 0.00609545f, -0.05946897f, 0.17596184f, -0.00833828f, 0.06273217f, 
    -0.02163628f, 0.03286070f, -0.23684603f, 0.03568220f, -0.10864790f, -0.03778194f, 0.05676846f, -0.05492096f, 
    -0.02794895f, -0.05925579f, 0.14011367f, 0.11692497f, -0.26246580f, 0.18721102f, 0.28727087f, 0.10536865f, 
    0.17708659f, 0.01738320f, 0.05818060f, 0.03838417f, 0.02600618f, 0.01842582f, 0.10378946f, -0.00787670f, 
    0.24987988f, 0.06079159f, -0.12214854f, -0.12117027f, -0.10978751f, -0.03299054f, 0.11161200f, 0.07316419f, 
    0.00267904f, 0.01724068f, 0.01848801f, -0.05158056f, 0.35795605f, 0.26552200f, -0.01200214f, 0.12153161f, 
    0.18776341f, 0.09178158f, -0.10415222f, -0.07272866f, 0.06444344f, -0.00664692f, 0.05347032f, -0.15419745f, 
    -0.09464449f, 0.21406884f, -0.01780787f, -0.06632321f, 0.06015333f, -0.11597941f, -0.04682003f, 0.10722377f, 
    0.02020171f, 0.11355822f, -0.07307495f, -0.09211131f, 0.37839797f, -0.08425106f, -0.05233212f, -0.07752091f, 
    0.06472255f, 0.10879940f, -0.05886934f, -0.04264471f, -0.00172211f, 0.02887000f, 0.12970445f, 0.08614424f, 
    -0.18700014f, -0.15415134f, -0.06192095f, 0.04380549f, -0.09783211f, 0.06410307f, 0.04021683f, -0.01416639f, 
    0.03800938f, 0.09251992f, -0.05465440f, -0.03493515f, 0.06832945f, 0.04652925f, -0.20113190f, -0.17312285f, 
    0.04848518f, 0.06662593f, -0.00633632f, -0.04100915f, 0.00108778f, 0.17474428f, -0.11344355f, 0.13440724f, 
    0.20712110f, -0.07989335f, 0.02631822f, 0.07229890f, 0.24062920f, -0.00089965f, -0.13968742f, -0.04039378f, 
    -0.02437952f, 0.06962165f, 0.07782072f, 0.01715334f, -0.04889681f, 0.05600914f, 0.06548292f, 0.00416475f, 
    -0.17034498f, 0.01458830f, -0.02776819f, 0.20428008f, 0.06458563f, -0.12203318f, 0.03335424f, -0.07170035f, 
    -0.33974344f, -0.12378049f, -0.27542156f, -0.19258603f, -0.03085136f, -0.05514976f, -0.01284781f, -0.03704383f, 
    0.12016752f, 0.03183971f, 0.07764014f, -0.05951853f, 0.40837526f, 0.18391925f, -0.16147280f, -0.08620223f, 
    0.16289814f, -0.10766750f, 0.03417735f, 0.02948458f, 0.06638392f, -0.04839884f, -0.04145792f, -0.20153697f, 
    0.19218521f, 0.10730344f, 0.04449097f, 0.16153587f, 0.05381901f, 0.01545200f, -0.02209871f, 0.02701244f, 
    0.04529348f, 0.08961571f, 0.04425805f, 0.11892908f, 0.11803402f, 0.16799803f, 0.12827195f, -0.14335939f, 
    0.13558570f, -0.05530401f, -0.02710888f, 0.06323608f, -0.13714863f, -0.05550250f, -0.01326129f, -0.04761225f, 
    0.44213176f, 0.06107058f, 0.22108617f, 0.19985303f, 0.09682893f, -0.06102748f, 0.07931751f, 0.02050301f, 
    -0.08236573f, -0.00663668f, -0.00761438f, 0.18245818f, -0.22254111f, -0.02430420f, -0.16439614f, 0.01653593f, 
    -0.01614797f, -0.01586877f, -0.04455683f, -0.08973935f, 0.14940572f, -0.18282269f, -0.07511149f, -0.07761217f, 
    -0.11614539f, -0.05105883f, 0.06766000f, -0.17095856f, 0.05603722f, -0.05885686f, -0.12046620f, -0.00612044f, 
    0.03474150f, 0.16396648f, -0.11225531f, -0.03829295f, -0.01883250f, 0.37731537f, -0.09412547f, 0.15107837f, 
    -0.11545683f, 0.12874623f, -0.01244471f, 0.03699667f, -0.24110202f, 0.01214297f, 0.03516182f, -0.09055913f, 
    -0.09325799f, 0.17452770f, 0.25606078f, -0.07299308f, 0.11665254f, 0.09958492f, -0.01867160f, 0.02231917f, 
    0.15718828f, 0.05503445f, 0.00321808f, 0.18407658f, -0.10708432f, 0.11025237f, -0.04668422f, 0.02945153f, 
    -0.08129163f, 0.03545133f, 0.01112543f, 0.20062028f, 0.02181396f, 0.07083166f, -0.02913038f, 0.07327767f, 
    -0.32814732f, -0.14505133f, -0.09121282f, -0.23166741f, -0.08117588f, 0.14095055f, 0.17857428f, 0.12580124f, 
    0.07663461f, -0.01866175f, 0.05906229f, 0.02367215f, 0.12370679f, -0.07934619f, 0.00508890f, 0.15434107f, 
    0.03388301f, 0.04285208f, 0.04243184f, -0.12906943f, 0.01261147f, 0.09150992f, 0.04983122f, 0.06911804f, 
    0.11407121f, -0.06286271f, 0.18170920f, -0.06361969f, -0.04234098f, 0.01702996f, -0.04696536f, -0.14232668f, 
    0.21713890f, 0.17797811f, -0.04043900f, 0.05399748f, -0.07086438f, -0.01300324f, 0.01431599f, -0.23451354f, 
    -0.04456182f, 0.04235512f, -0.06246464f, 0.12427784f, 0.00308177f, -0.07998635f, 0.04381880f, -0.13205597f, 
    0.03984402f, 0.06251879f, -0.16389152f, 0.10162959f, -0.12945801f, -0.02450038f, 0.07350364f, -0.02619443f, 
    -0.10174151f, -0.09243000f, -0.00403144f, -0.14296252f, -0.27723604f, 0.01584812f, 0.18598612f, -0.15828159f, 
    0.01362906f, -0.01596259f, 0.08261932f, -0.06936775f, -0.08040741f, 0.10469466f, 0.04022590f, 0.12182964f, 
    0.06769603f, 0.18833353f, 0.09981385f, -0.16432512f, -0.03740193f, -0.01669724f, -0.06529484f, 0.03951195f, 
    -0.10946265f, -0.01236922f, -0.13185209f, 0.09472021f, -0.07204480f, 0.02859268f, -0.03990722f, 0.02176584f, 
    -0.04235552f, -0.11975858f, -0.06492450f, -0.12262310f, 0.00399639f, 0.06541807f, 0.05840403f, 0.08343907f, 
    -0.01680974f, 0.16204704f, 0.06531984f, -0.13469505f, 0.09600008f, 0.05174538f, 0.07103124f, -0.16915134f, 
    0.05712707f, 0.14493178f, 0.00467494f, -0.04837530f, 0.21799415f, 0.05561309f, -0.09998872f, -0.02989207f, 
    -0.02244502f, -0.07375999f, 0.05284340f, -0.06298549f, -0.11417773f, -0.11833420f, 0.11453345f, 0.02934856f, 
    0.19272546f, -0.13874133f, -0.08958237f, -0.22026637f, -0.07911400f, -0.04297628f, -0.00617183f, 0.18815143f, 
    -0.01834780f, 0.03043767f, 0.09269831f, 0.12165702f, 0.25273314f, 0.03696585f, -0.21145433f, 0.26013228f, 
    0.04023925f, -0.23826638f, 0.09693334f, 0.00851289f, 0.08210008f, 0.01675082f, -0.00710472f, -0.01665466f, 
    -0.03054403f, 0.09654880f, -0.11332858f, -0.07117842f, -0.06296761f, -0.03075336f, 0.06399717f, -0.06378816f, 
    -0.08244628f, 0.17142430f, 0.22789675f, 0.10355002f, -0.01839919f, 0.20230263f, -0.11538626f, -0.07421543f, 
    0.19706069f, -0.00992370f, 0.13398191f, 0.01559436f, 0.03212459f, -0.00783664f, 0.06707097f, 0.04001274f, 
    -0.15440749f, -0.17462085f, 0.24275438f, 0.36812657f, -0.10565495f, -0.11500254f, 0.07003946f, 0.10808498f, 
    0.00046446f, 0.02721960f, -0.04172407f, -0.02669742f, -0.05255536f, 0.00203549f, -0.09433108f, 0.21064268f, 
    0.08161703f, 0.09983808f, 0.04488287f, 0.01630824f, -0.09883829f, -0.05362723f, 0.03736714f, 0.02561695f, 
    0.05066479f, 0.22915582f, 0.04992487f, 0.01145823f, -0.02937229f, 0.02500331f, -0.02209202f, -0.11285945f, 
    -0.02557446f, 0.02688972f, -0.01606886f, -0.09636718f, 0.25633588f, -0.09993250f, -0.09764162f, -0.12595114f, 
    -0.06821734f, -0.06172990f, -0.01554278f, -0.05743439f, -0.04824602f, 0.06030842f, 0.05492432f, -0.08682918f, 
    -0.11077820f, 0.02906086f, -0.00826792f, -0.15922548f, 0.16429922f, -0.04817786f, 0.16041395f, 0.03972187f, 
    0.08360693f, -0.00633792f, 0.05398773f, 0.03772882f, -0.17009792f, 0.08048113f, -0.00938602f, -0.13103507f, 
    0.11849934f, 0.08971103f, 0.04591890f, -0.16268012f, 0.16748232f, -0.03894762f, -0.10529650f, 0.00781445f, 
    -0.16380787f, 0.01823125f, 0.05674063f, -0.13471930f, 0.07678570f, 0.00838193f, -0.12852335f, 0.02731190f, 
    0.02719786f, 0.01307492f, -0.03048800f, -0.03433552f, -0.08334660f, 0.02901693f, 0.11157040f, 0.38158923f, 
    -0.16327260f, -0.08299176f, 0.01337826f, -0.01797625f, -0.05024144f, -0.10780346f, 0.04373978f, -0.05778167f, 
    -0.09629137f, -0.01369617f, -0.16525768f, -0.18117806f, 0.08507963f, 0.16446330f, -0.00291721f, 0.03129577f, 
    0.01943713f, -0.00878358f, -0.03081285f, 0.10756000f, -0.15468925f, 0.11266079f, -0.20957948f, -0.06963099f, 
    0.11764318f, 0.00297015f, 0.03713531f, 0.00285612f, 0.01440816f, 0.01262781f, 0.05432098f, -0.02263836f, 
    0.14009212f, -0.22507150f, -0.10914368f, 0.04373148f, 0.10068639f, 0.05921328f, 0.01657629f, 0.04940523f, 
    0.09197448f, 0.01389825f, -0.06868877f, 0.03476759f, -0.03012866f, 0.13965353f, -0.11475755f, -0.23978563f, 
    -0.10593396f, 0.04342848f, 0.04527869f, 0.02809421f, 0.01564559f, 0.08828102f, -0.02282788f, -0.03366334f, 
    -0.23069438f, 0.11876573f, -0.07437562f, -0.18784218f, -0.08865086f, 0.06591579f, -0.01794617f, 0.00717449f, 
    -0.04299114f, 0.10331623f, 0.13489684f, -0.04304213f, 0.01049551f, 0.17696241f, 0.06046453f, -0.00079820f, 
    0.08167215f, 0.18406460f, 0.06856142f, 0.13907924f, -0.05496235f, 0.12179901f, 0.09341484f, 0.02820122f, 
    -0.04793424f, 0.25667965f, 0.03382189f, -0.11704990f, 0.01447893f, 0.16531721f, 0.06918432f, 0.03915517f, 
    0.02321856f, -0.06936364f, -0.01348242f, 0.03227267f, 0.35092491f, -0.27035195f, 0.09282430f, 0.20012251f, 
    -0.07898523f, 0.05121493f, -0.08550275f, 0.00612623f, -0.02624632f, 0.01438570f, 0.02743383f, 0.09248956f, 
    -0.13989770f, -0.01268169f, -0.06764247f, -0.06412613f, -0.07933487f, -0.02897933f, -0.03365434f, -0.08599260f, 
    -0.01643561f, 0.11262313f, -0.04438854f, 0.00287785f, -0.19733024f, -0.08334585f, -0.02001972f, 0.06995225f, 
    0.07398897f, -0.08561158f, -0.08199973f, -0.05040148f, 0.08878014f, -0.05260083f, 0.05525945f, -0.05734101f, 
    -0.07451409f, 0.10298817f, -0.06189440f, -0.20803805f, -0.07562683f, -0.04214509f, 0.07212074f, 0.14534943f, 
    0.08360709f, -0.03175936f, 0.01674046f, 0.09127825f, -0.26270631f, 0.01931765f, -0.09544996f, -0.02689835f, 
    -0.06465460f, -0.06572539f, -0.07604343f, -0.01787105f, 0.08548354f, -0.00886902f, -0.11698611f, -0.04184120f, 
    -0.07593618f, 0.05836885f, 0.01506065f, 0.13856190f, -0.02777493f, -0.00889642f, 0.05153761f, -0.06553926f, 
    0.07006682f, -0.07130200f, 0.05605572f, 0.14106734f, 0.22335580f, -0.16647688f, -0.08624857f, 0.05346148f, 
    0.16309685f, 0.12117387f, -0.01155915f, 0.05141055f, 0.11275719f, 0.01346031f, -0.02741620f, 0.03111106f, 
    0.12028308f, -0.15569094f, -0.04036978f, 0.15371209f, 0.09528194f, -0.01893564f, 0.10760648f, -0.04868848f, 
    0.09668614f, -0.10062709f, 0.10205022f, -0.02501987f, -0.09781381f, -0.14839862f, -0.00623619f, -0.08624140f, 
    -0.10884017f, -0.01468404f, -0.01048694f, -0.05886464f, 0.08860660f, -0.14645109f, 0.05844847f, 0.05257014f, 
    0.35824272f, -0.17737967f, -0.12726557f, 0.05199711f, -0.05172549f, 0.09500317f, 0.15362984f, -0.01336684f, 
    0.05782544f, 0.01386324f, 0.00156217f, -0.10153379f, 0.04288860f, 0.00515133f, 0.08079804f, 0.21497475f, 
    -0.09600891f, 0.12987493f, -0.03314937f, 0.00978565f, 0.11815487f, 0.10223685f, -0.00638478f, 0.00482007f, 
    -0.04582644f, 0.14310715f, -0.12976544f, 0.06148256f, 0.10041505f, 0.16418792f, 0.07931150f, -0.06166004f, 
    -0.01172605f, 0.09590614f, 0.09647155f, 0.13651489f, 0.29775599f, 0.10243915f, 0.19733357f, 0.02857382f, 
    0.12004887f, -0.13915767f, -0.17025706f, 0.02017477f, 0.02349893f, -0.03058419f, -0.11191411f, -0.04438947f, 
    0.36188072f, 0.21024205f, 0.06455489f, 0.03921746f, 0.03470206f, 0.07955745f, 0.02082670f, 0.10230222f, 
    -0.06464557f, -0.05235547f, 0.08314896f, 0.17786904f, -0.01158075f, -0.15191796f, -0.17062636f, 0.17220189f, 
    -0.10989470f, -0.16498354f, 0.00680117f, 0.10449812f, 0.19103071f, -0.20948844f, -0.23002803f, -0.14190021f, 
    -0.16800530f, -0.00027817f, 0.13859631f, 0.08773278f, -0.16125095f, -0.08339044f, 0.01579912f, 0.14923683f, 
    0.03783560f, 0.11515318f, 0.01307914f, 0.17129785f, 0.07312610f, -0.03697885f, -0.11990658f, 0.19213663f, 
    0.20216872f, -0.12472464f, 0.03876682f, -0.11600693f, 0.01904256f, 0.14700978f, 0.16906860f, 0.02558086f, 
    0.17301637f, -0.01736847f, 0.06984551f, -0.06256776f, 0.09225535f, 0.11620000f, 0.15465830f, 0.02946380f, 
    -0.00300816f, 0.02267661f, 0.01891769f, 0.03905423f, -0.29021513f, -0.08053631f, -0.23455711f, -0.12932776f, 
    -0.09204939f, 0.15937752f, -0.06205371f, -0.18141036f, 0.03003205f, 0.16954602f, -0.02495852f, 0.07051759f, 
    0.14769147f, -0.10590560f, 0.08384160f, 0.02875571f, 0.00098891f, 0.02617046f, 0.06054843f, -0.22878417f, 
    -0.20321913f, 0.02123030f, 0.13464607f, 0.07888272f, 0.02374277f, 0.35970116f, -0.04154107f, 0.19952434f, 
    0.01248672f, 0.03549751f, -0.00455699f, -0.05408998f, -0.07860569f, -0.02238520f, 0.03068580f, -0.03503863f, 
    -0.14647426f, -0.01050026f, -0.16784310f, 0.12954356f, 0.05427057f, -0.19220041f, -0.05578625f, -0.10488218f, 
    0.17395844f, 0.03307819f, 0.01375624f, 0.19061032f, 0.20949653f, -0.09064706f, 0.12962136f, 0.16527206f, 
    0.14939544f, 0.08808839f, 0.05508944f, 0.03678848f, 0.08685830f, -0.12238511f, 0.08855711f, 0.14977095f, 
    -0.14782897f, 0.05426707f, -0.29185635f, 0.11314032f, 0.04101001f, -0.08099099f, -0.15939726f, 0.03117488f, 
    -0.04440065f, 0.03565025f, -0.13652906f, -0.04223480f, -0.14674762f, 0.32282794f, -0.05872773f, 0.03751419f, 
    -0.01960409f, -0.03010925f, 0.13714071f, 0.02228020f, -0.17826478f, 0.11340240f, 0.01772836f, 0.03593335f, 
    0.17875271f, 0.16177495f, 0.12003037f, 0.06047476f, -0.09853438f, 0.04760012f, 0.00256384f, 0.02099786f, 
    0.04101886f, 0.07549378f, -0.15103495f, 0.22913460f, 0.03365962f, -0.09756931f, -0.31879222f, -0.04715924f, 
    0.17476417f, -0.09593501f, -0.18158862f, -0.19913888f, 0.04281172f, 0.09627731f, -0.06811488f, -0.05988420f, 
    0.09991402f, -0.04063558f, 0.13447553f, 0.05306343f, 0.05456263f, 0.14834362f, 0.14057855f, -0.15913847f, 
    0.03895934f, 0.09061950f, -0.09354996f, 0.16925085f, -0.04063012f, -0.12645163f, 0.08471601f, -0.01495259f, 
    -0.19116828f, -0.03344308f, -0.00004495f, 0.16689014f, 0.16530772f, 0.01826494f, -0.01341309f, -0.04012745f, 
    0.16877784f, 0.13811682f, -0.27058917f, -0.06585642f, 0.04913814f, 0.00228474f, 0.02753752f, 0.12144839f, 
    -0.11020439f, 0.08047276f, 0.08354270f, 0.08336712f, 0.21438017f, -0.02869132f, 0.08859753f, 0.06297324f, 
    0.17247707f, -0.02493736f, 0.22519065f, 0.10000628f, 0.20135383f, 0.07693776f, -0.06697366f, -0.05581993f, 
    0.02053806f, 0.08264179f, 0.05486112f, -0.17050329f, -0.03348293f, 0.14509979f, -0.00876042f, 0.17599945f, 
    0.08263522f, 0.03994022f, 0.08226201f, 0.15570377f, -0.01306038f, 0.18081853f, -0.14428683f, 0.00049888f, 
    0.03918903f, 0.04979591f, 0.10000055f, 0.04331136f, 0.07957338f, 0.03259854f, 0.09040549f, 0.14161193f, 
    -0.36844978f, -0.15758570f, 0.07820749f, -0.08768715f, -0.06631982f, -0.03124966f, -0.00843484f, 0.02293850f, 
    0.14860243f, 0.08947119f, -0.02828509f, -0.01105586f, -0.26282522f, -0.27750701f, 0.09315263f, 0.07821007f, 
    -0.07222352f, 0.01700911f, 0.20093438f, 0.01669876f, 0.15625013f, 0.06851864f, 0.01716701f, -0.02286732f, 
    0.23295355f, -0.20356634f, 0.00657814f, -0.10727292f, -0.00266312f, 0.09850879f, 0.07599217f, -0.00381210f, 
    -0.03416517f, 0.17016351f, 0.02483106f, 0.10314591f, -0.29270032f, -0.04041579f, -0.09475582f, 0.05709008f, 
    -0.07493163f, -0.03759203f, -0.02213321f, -0.09339909f, -0.04635628f, -0.11207160f, -0.09860452f, -0.09008691f, 
    -0.05479265f, -0.00356245f, -0.00209444f, 0.01636269f, -0.00613783f, 0.09504359f, 0.00983982f, 0.08673852f, 
    -0.00321388f, -0.03690483f, -0.06550758f, 0.03209795f, -0.09492647f, -0.07233513f, 0.20962767f, 0.05977329f, 
    0.07816907f, 0.07067993f, 0.04649113f, -0.00118155f, 0.07715993f, -0.12336999f, 0.05469555f, 0.07118416f, 
    -0.08734492f, -0.00669627f, 0.15313694f, -0.21740134f, 0.06815164f, 0.07460072f, 0.04447271f, 0.17957085f, 
    0.06623689f, -0.08619799f, 0.05272743f, -0.00907262f, 0.21344808f, -0.23495373f, -0.22511736f, 0.05898436f, 
    -0.08661846f, -0.00133706f, -0.04986799f, -0.10288503f, 0.01920896f, -0.04122819f, -0.01582981f, -0.08982386f, 
    0.10999758f, -0.07076721f, 0.14057182f, -0.01895269f, 0.12594710f, 0.12142134f, 0.19108790f, 0.04733827f, 
    -0.10292337f, -0.04077639f, -0.01955540f, 0.06264630f, -0.33485726f, -0.03921650f, 0.04367241f, 0.03087509f, 
    -0.10877570f, 0.13570774f, -0.13201173f, -0.00342259f, 0.04508943f, -0.05655903f, 0.10432841f, 0.07076447f, 
    0.10482064f, -0.04480912f, -0.21949035f, 0.04833500f, -0.06517656f, 0.03392922f, 0.09230495f, 0.16453975f, 
    0.08051533f, 0.05119912f, 0.01803876f, 0.01221244f, 0.13920933f, 0.07383043f, 0.11515813f, -0.08005507f, 
    0.04532734f, 0.10615800f, -0.16616029f, 0.00423527f, 0.05348835f, -0.03303527f, -0.05424015f, 0.04161691f, 
    0.09569098f, 0.26051083f, 0.11686614f, 0.01531879f, -0.01217506f, 0.03149726f, 0.28373721f, 0.10166568f, 
    0.05804950f, -0.12893648f, 0.13162631f, 0.11159052f, -0.12634003f, -0.13290237f, 0.08021393f, -0.22455081f, 
    -0.16041483f, -0.06372041f, 0.05915549f, 0.03039148f, 0.17398891f, -0.18982185f, -0.06220083f, -0.06186261f, 
    -0.01324920f, 0.15541039f, 0.35233429f, 0.25102600f, 0.12271521f, 0.07960699f, 0.11365481f, 0.02064268f, 
    0.03876084f, 0.14265132f, -0.02068950f, -0.08267166f, -0.00069303f, -0.07643901f, -0.01156126f, 0.04139300f, 
    -0.06804152f, -0.06879779f, 0.00952563f, -0.30317938f, -0.04143971f, 0.00617045f, -0.15512869f, -0.11166592f, 
    0.01319890f, 0.10117195f, -0.21811016f, -0.09824210f, 0.04413878f, 0.18419494f, 0.24089627f, -0.01379112f, 
    0.05787266f, 0.12577477f, 0.10951865f, 0.15039067f, 0.27075636f, -0.18815579f, -0.25128549f, -0.09737720f, 
    -0.19693774f, 0.15870205f, -0.03238446f, -0.00693193f, -0.10905799f, 0.24718046f, -0.05014449f, -0.03171315f, 
    -0.11897068f, 0.00834556f, 0.01352988f, 0.28852138f, -0.06871361f, 0.07161780f, 0.06669965f, 0.07605013f, 
    0.01986589f, 0.14087354f, 0.20247075f, 0.20492457f, -0.06391938f, 0.19153765f, 0.18280220f, -0.11237128f, 
    -0.07162177f, -0.05676461f, -0.11210480f, 0.00129799f, 0.12606813f, -0.02581956f, -0.06598277f, -0.22022797f, 
    0.05124374f, -0.00911103f, 0.03533200f, -0.04786433f, 0.14108177f, 0.02380851f, -0.07283442f, 0.01941888f, 
    0.07961750f, -0.10986258f, -0.05266454f, 0.08354667f, 0.20351237f, 0.06270874f, 0.05524119f, 0.18147749f, 
    -0.18983163f, -0.10617982f, 0.03202744f, -0.06645476f, 0.05962353f, 0.02920220f, 0.08499066f, -0.03478352f, 
    -0.15398760f, -0.10516421f, -0.09350718f, 0.45521927f, -0.11708269f, 0.03097415f, -0.05280268f, -0.16821364f, 
    -0.11189070f, -0.13553250f, -0.22630876f, -0.05430519f, -0.11266688f, 0.03314385f, -0.29018900f, -0.16130784f, 
    0.08707178f, 0.12695359f, 0.19196011f, -0.00621960f, -0.14590046f, 0.26985684f, 0.13326873f, -0.01784788f, 
    0.26817662f, 0.19492027f, 0.15682884f, 0.09186900f, -0.03018101f, 0.00822420f, 0.00128319f, -0.11044730f, 
    0.06982201f, 0.01106975f, -0.08573146f, 0.07668514f, -0.32504576f, -0.06176610f, -0.01217585f, 0.13885526f, 
    -0.14636710f, 0.12725145f, -0.16086909f, -0.15733333f, -0.24325353f, -0.04280860f, -0.18320532f, -0.12306539f, 
    0.11803453f, -0.03595652f, -0.07720299f, -0.10318935f, 0.07345132f, -0.01051842f, -0.22165883f, 0.06597149f, 
    0.03405193f, -0.11310309f, -0.01603512f, -0.03344348f, 0.12426541f, 0.03635678f, 0.18749925f, 0.06340088f, 
    0.07698063f, 0.03875037f, 0.08635662f, -0.01309554f, -0.02696386f, 0.04818296f, -0.07763828f, 0.15797330f, 
    -0.21047574f, 0.12831308f, 0.30543691f, 0.01505641f, -0.00553505f, 0.09226976f, -0.04315724f, -0.05416069f, 
    -0.07277451f, 0.00753633f, -0.10883941f, -0.14362606f, -0.18605015f, 0.05745953f, -0.01900685f, 0.09625152f, 
    0.04933871f, 0.00341155f, -0.13122283f, 0.01707083f, -0.06028035f, -0.01798848f, 0.07574044f, 0.15723693f, 
    -0.05235887f, 0.12754692f, 0.09241365f, 0.13927650f, -0.06118188f, -0.06674015f, -0.00824624f, -0.14235407f, 
    0.03885296f, -0.00526924f, 0.05408624f, -0.10370667f, -0.21123587f, -0.09642921f, -0.06374744f, 0.17574312f, 
    0.13360433f, -0.07539336f, 0.01351770f, 0.04094746f, 0.07169770f, -0.06776007f, -0.00114903f, -0.18738583f, 
    0.22111106f, 0.25558126f, -0.12594758f, -0.04881905f, -0.04747215f, 0.07905842f, -0.02046038f, -0.03536684f, 
    -0.02345533f, -0.10581733f, 0.04675086f, -0.00783732f, 0.04321868f, 0.03488911f, -0.22975531f, -0.16267939f, 
    0.00243011f, 0.04896766f, -0.17854644f, -0.06758855f, -0.10966600f, 0.07372968f, -0.04967841f, -0.10291946f, 
    0.06187473f, 0.23557439f, -0.14854543f, 0.01167669f, 0.10123188f, -0.00632427f, -0.05299918f, -0.05804842f, 
    0.03935790f, 0.09756169f, 0.02052426f, 0.02852265f, 0.08430015f, 0.26611713f, 0.17932568f, -0.05207317f, 
    -0.00739547f, 0.04834410f, 0.01563278f, 0.09576783f, 0.08440427f, 0.11675869f, -0.00825748f, 0.19414750f, 
    0.04272830f, 0.04562007f, 0.03132329f, 0.14527118f, 0.18885355f, -0.04273972f, 0.09351482f, -0.07918517f, 
    0.09745520f, 0.00546084f, -0.05879632f, 0.00716576f, 0.30231810f, 0.05708867f, -0.10663323f, 0.24729174f, 
    0.09297294f, -0.06472975f, -0.04386666f, 0.01995725f, 0.06313699f, 0.05506844f, -0.03659270f, -0.08469420f, 
    -0.21133895f, -0.21986476f, -0.27429911f, 0.26530185f, -0.05419365f, -0.05778562f, -0.00914293f, -0.06775777f, 
    0.03782395f, 0.02341031f, -0.01077982f, 0.12327474f, -0.13132453f, 0.25175589f, 0.19254774f, -0.06627352f, 
    0.02464714f, 0.04681339f, 0.03256334f, 0.04805992f, 0.10840686f, 0.08951210f, -0.11259007f, -0.05358848f, 
    0.18421480f, 0.05737044f, -0.24382374f, 0.11183432f, -0.03436947f, -0.05604203f, -0.06449296f, -0.15363033f, 
    0.13128477f, -0.04861535f, 0.00154262f, -0.03070056f, -0.06110325f, -0.19051433f, -0.22300942f, 0.14388491f, 
    0.10502307f, -0.06037338f, -0.02299838f, 0.06632136f, -0.06396380f, 0.04292528f, -0.00978224f, -0.15919958f, 
    0.31530130f, 0.03652148f, -0.23577449f, -0.13842784f, -0.04240008f, 0.03660531f, 0.05404660f, 0.09009928f, 
    -0.11303431f, -0.07548310f, 0.07277412f, -0.07947034f, -0.07432198f, 0.04886283f, 0.01686344f, -0.04592300f, 
    -0.08437967f, -0.02980720f, 0.01781344f, 0.11074681f, -0.02175054f, 0.03697859f, -0.06636144f, 0.09291846f, 
    -0.35927904f, 0.01440413f, 0.01062332f, 0.21163121f, -0.00083563f, 0.01868100f, 0.02290213f, -0.06456184f, 
    0.01371828f, -0.02024826f, 0.01161888f, -0.01872073f, 0.10259932f, -0.06436685f, 0.19575492f, -0.28327936f, 
    0.03757549f, -0.03119549f, 0.07521213f, -0.05764150f, -0.04108074f, 0.00568286f, -0.10479202f, 0.01423776f, 
    0.13042799f, -0.17711966f, 0.15273008f, 0.19272849f, 0.08980319f, 0.04114004f, 0.02337494f, -0.01893689f, 
    -0.02578300f, -0.01728265f, -0.08358296f, -0.04569194f, 0.22497457f, 0.05554704f, -0.06992297f, 0.17260772f, 
    -0.01509760f, -0.02779782f, -0.01273599f, -0.05083917f, 0.03536797f, 0.05685065f, -0.09069718f, 0.04785689f, 
    0.05640669f, -0.14692514f, 0.01364372f, -0.08627766f, 0.13980299f, 0.05393154f, 0.03199221f, 0.12849770f, 
    0.06046553f, 0.00323669f, 0.01285592f, -0.14390014f, 0.48323199f, 0.01441780f, 0.17722307f, -0.16317551f, 
    0.00887807f, -0.11674672f, -0.07916029f, 0.07928538f, -0.03507486f, 0.01872346f, 0.04128768f, 0.02697301f, 
    0.22951089f, -0.16052788f, 0.04469237f, 0.30658069f, 0.09926648f, -0.04961373f, -0.01376119f, -0.04823685f, 
    -0.00033810f, 0.06921054f, -0.03785753f, 0.06434133f, -0.01131191f, 0.08632118f, 0.03981446f, 0.08933042f, 
    -0.10618630f, -0.07978353f, -0.07291105f, 0.08363006f, 0.06838239f, -0.00760802f, -0.12182795f, 0.01720582f, 
    -0.20015137f, 0.01790866f, -0.01759499f, 0.11763673f, -0.00119656f, 0.00408182f, -0.10429437f, 0.05559742f, 
    -0.23234494f, -0.12203947f, -0.08671252f, -0.00297330f, 0.14139210f, -0.06434880f, 0.07864858f, 0.07246727f, 
    -0.00582688f, -0.20207253f, 0.01268561f, -0.11048945f, -0.07101724f, -0.05014228f, 0.23111451f, 0.00979710f, 
    0.34398445f, 0.04953612f, -0.01786225f, 0.22647071f, -0.10457708f, 0.03057217f, 0.06014302f, -0.02578080f, 
    0.05182730f, 0.02735884f, -0.01691511f, -0.01382614f, 0.12283015f, 0.06654237f, -0.14267035f, 0.06489145f, 
    0.08875217f, 0.04769574f, -0.12755132f, 0.11284701f, 0.05766211f, -0.01144507f, -0.06393902f, 0.08009436f, 
    -0.22944114f, -0.07200266f, 0.13097639f, -0.09142119f, -0.02654969f, -0.00359940f, 0.12759092f, 0.03256250f, 
    -0.07549667f, 0.04061970f, -0.02734201f, -0.02316214f, 0.03206823f, 0.03780990f, 0.27551973f, 0.03004342f, 
    -0.17197469f, 0.10936467f, 0.12759462f, 0.06405119f, 0.05614848f, -0.07262835f, -0.15504955f, -0.16301379f, 
    0.19891408f, 0.27156964f, 0.00588703f, -0.01988450f, 0.00593114f, -0.04386147f, 0.11105035f, 0.09268881f, 
    0.12681630f, -0.04669169f, 0.02730543f, -0.09363084f, -0.08613927f, -0.08299963f, 0.13701501f, 0.10508978f, 
    -0.01582015f, 0.05587825f, -0.00624671f, -0.00775000f, 0.06083833f, -0.04663478f, 0.16701813f, 0.06431023f, 
    -0.09676903f, -0.20129202f, 0.07184721f, 0.12888321f, 0.08275316f, -0.06503002f, -0.00572307f, -0.02265249f, 
    0.17074765f, 0.07542749f, -0.10830211f, 0.08909893f, 0.06182753f, -0.01710448f, -0.01807892f, -0.20282614f, 
    0.12343851f, -0.03603473f, -0.02247534f, -0.18591550f, -0.03889793f, 0.06564484f, 0.08610874f, 0.03726052f, 
    0.04114371f, -0.04740456f, -0.22348516f, 0.14286456f, -0.04796300f, 0.08446822f, 0.09362672f, -0.12862480f, 
    -0.08411094f, 0.05438636f, 0.09955788f, 0.02130597f, -0.21453586f, 0.20568854f, -0.02799800f, -0.23916534f, 
    0.15086657f, -0.03122300f, 0.13187289f, 0.07990870f, 0.13036335f, -0.00618999f, 0.00956209f, -0.03390754f, 
    0.13073680f, -0.16250132f, 0.02548434f, 0.02169825f, 0.02630022f, -0.02299107f, -0.01490749f, 0.02816209f, 
    -0.01933054f, 0.03138858f, 0.07643324f, -0.08995956f, 0.41907489f, 0.02411474f, 0.03858966f, -0.04195837f, 
    0.02640622f, 0.06190300f, -0.18633884f, 0.04526998f, 0.05955373f, 0.02267056f, 0.08332381f, 0.07942301f, 
    0.00884432f, 0.08358795f, 0.05047048f, 0.17513174f, 0.12884586f, -0.01574565f, -0.13381571f, 0.05307058f, 
    0.04717434f, 0.13504098f, -0.08893693f, 0.00627989f, 0.33392262f, -0.03459278f, 0.01365935f, -0.02385652f, 
    -0.03396662f, -0.09775918f, -0.01209157f, 0.19764829f, 0.01839766f, 0.12042375f, -0.04077655f, 0.16134037f, 
    -0.31773865f, -0.08006622f, -0.13318256f, -0.11224394f, 0.03474374f, -0.04778003f, -0.00286496f, 0.07292826f, 
    -0.15309191f, 0.06493760f, 0.01367532f, -0.18079183f, 0.04718888f, 0.12959597f, 0.08308532f, -0.06186687f, 
    -0.05867357f, -0.07322292f, -0.01021930f, -0.13552520f, -0.13375458f, -0.00469663f, 0.06537474f, 0.01765459f, 
    -0.01244372f, -0.04432470f, 0.04220646f, 0.10854107f, 0.11800308f, 0.12509458f, -0.07171574f, 0.02910945f, 
    -0.02544721f, 0.12173838f, 0.08828315f, 0.13053004f, -0.12873580f, -0.02623115f, -0.34307128f, 0.14569056f, 
    0.04084423f, 0.02607705f, -0.02805635f, -0.00617648f, -0.07005914f, -0.03587054f, -0.08248731f, 0.02243720f, 
    -0.34836879f, 0.02269761f, 0.06128571f, -0.14585920f, 0.01257640f, -0.02943185f, -0.02282607f, 0.02135726f, 
    0.10823969f, -0.09714641f, 0.05398724f, -0.01849125f, -0.11110748f, 0.12289274f, 0.03510604f, -0.05963007f, 
    0.01459172f, -0.03737121f, 0.05721573f, -0.04035464f, 0.06635907f, -0.08106946f, -0.04683475f, -0.04572540f, 
    0.45934132f, 0.25465286f, 0.07022235f, 0.18074085f, 0.10094091f, 0.03050835f, 0.09682567f, 0.13653499f, 
    0.23485388f, 0.06502653f, 0.08920708f, -0.02125283f, -0.03403126f, -0.17503303f, 0.04584165f, 0.12231992f, 
    0.03406554f, 0.00417127f, -0.17679875f, 0.18100309f, -0.03923531f, -0.08083626f, 0.07202796f, 0.03584291f, 
    -0.21033913f, -0.15563649f, 0.28064549f, -0.00956295f, 0.15776716f, 0.01017772f, -0.00064629f, 0.02570569f, 
    0.02363009f, 0.01262733f, 0.10363624f, 0.04582298f, -0.30992302f, -0.00291677f, -0.15081149f, -0.03208526f, 
    0.07117096f, 0.07311244f, 0.04065272f, -0.09848152f, -0.00543362f, -0.13697979f, -0.05597183f, -0.02897120f, 
    -0.10365772f, 0.10175510f, -0.00355997f, 0.16360204f, 0.04808978f, 0.08743463f, -0.00213113f, 0.10720725f, 
    0.04335268f, 0.12314977f, 0.06167317f, 0.04784577f, -0.39984781f, 0.38937265f, 0.02337225f, -0.22892329f, 
    0.04160774f, -0.00118831f, -0.01143656f, -0.19523603f, 0.02620291f, -0.15851291f, -0.04287384f, 0.04935931f, 
    -0.31615928f, -0.03850506f, -0.05979756f, -0.21948193f, -0.06671476f, 0.15335268f, -0.12279419f, -0.04041997f, 
    -0.01114474f, 0.01579511f, -0.05120361f, 0.06680273f, 0.12733768f, 0.30847788f, -0.07360668f, -0.01563406f, 
    -0.01311173f, 0.07076209f, -0.12581214f, -0.04609896f, 0.02814121f, 0.13474497f, 0.01299697f, 0.05418729f, 
    -0.13322005f, 0.09134182f, 0.00870314f, -0.03339650f, -0.03071019f, 0.05957551f, -0.09455749f, -0.00033355f, 
    -0.03648833f, 0.12167949f, -0.05117598f, 0.06476533f, 0.42856613f, 0.01525665f, 0.17652039f, -0.09299959f, 
    -0.02676806f, -0.02852502f, -0.13280985f, 0.11032178f, 0.14569259f, -0.02548724f, -0.14131038f, 0.06406903f, 
    0.20574629f, -0.08516189f, 0.07674446f, -0.06597079f, -0.00129550f, -0.01539975f, 0.17024797f, -0.04697983f, 
    -0.00996053f, 0.07075010f, 0.10214540f, 0.09016079f, 0.15161893f, 0.26810360f, -0.08573370f, 0.11941095f, 
    0.00672088f, -0.04353780f, -0.06810845f, 0.09024850f, 0.05366861f, -0.09491561f, -0.03046053f, -0.01993794f, 
    -0.00839468f, -0.11121635f, 0.12361272f, 0.03756528f, 0.04443158f, 0.01721028f, 0.00389664f, -0.09982852f, 
    -0.17676039f, -0.04961182f, 0.01106545f, -0.01629509f, -0.04281460f, -0.37032756f, -0.09760438f, -0.17054258f, 
    0.10617401f, 0.06271823f, 0.05520567f, 0.07814738f, -0.05725134f, 0.13560066f, 0.01373523f, 0.02124203f, 
    0.08457279f, 0.04719736f, 0.11372919f, 0.15409648f, 0.04499577f, 0.04170328f, -0.10683230f, 0.07604861f, 
    -0.05487922f, -0.05809242f, 0.04703454f, 0.08136979f, -0.09714430f, 0.03372642f, -0.01028040f, 0.00096748f, 
    0.00090204f, 0.09353766f, -0.01785906f, -0.02615117f, -0.12203177f, 0.02137275f, 0.08369604f, -0.07229964f, 
    -0.07432800f, 0.04104071f, -0.05077732f, -0.04945809f, -0.07858431f, -0.02598814f, 0.02343284f, -0.00532294f, 
    -0.00677608f, 0.01761687f, -0.00626991f, -0.03394044f, -0.05688256f, 0.00160385f, -0.03689439f, -0.03470789f, 
    0.02431339f, 0.02973825f, -0.04247156f, -0.05661517f, -0.06666438f, 0.03886820f, 0.00244946f, -0.01009691f, 
    -0.01428514f, 0.01418067f, 0.02425371f, 0.02863812f, 0.02964124f, 0.05428866f, 0.03918054f, -0.06189385f, 
    -0.04881892f, -0.04567257f, 0.00056369f, -0.08244170f, -0.03868108f, 0.04893736f, 0.01182577f, 0.01013151f, 
    0.03993542f, 0.01150225f, -0.00693255f, -0.03351060f, -0.03514677f, -0.02263118f, -0.08255936f, -0.02148732f, 
    0.00560000f, -0.04053080f, 0.03324344f, -0.01268108f, 0.02787950f, 0.03685169f, 0.03655046f, -0.01307416f, 
    0.06663103f, -0.01926257f, 0.03554552f, 0.01378979f, 0.03615028f, -0.02123542f, -0.00710901f, -0.06308939f, 
    0.01860235f, 0.03516956f, 0.01111009f, -0.05177614f, 0.04049092f, -0.00950766f, 0.05246165f, -0.05961952f, 
    -0.03096432f, -0.05653215f, 0.03002617f, -0.07405078f, -0.03992380f, -0.07239508f, -0.05121690f, -0.03104465f, 
    0.04406340f, 0.00889224f, -0.08584511f, 0.00555085f, 0.04215329f, 0.01022374f, -0.02292940f, -0.05068436f, 
    -0.04371035f, -0.03247559f, -0.04334443f, -0.06714227f, -0.04682314f, 0.03553380f, -0.05133559f, 0.01067557f, 
    0.04485107f, 0.00305057f, 0.03443423f, -0.03266527f, 0.00071710f, 0.03968482f, -0.04697565f, -0.06190182f, 
    -0.03469287f, -0.01948833f, -0.06745479f, -0.04038498f, -0.00173549f, -0.04989822f, 0.04350292f, -0.01618804f, 
    0.01937553f, -0.03519791f, 0.02861750f, -0.06651416f, -0.03521684f, 0.05946669f, 0.00235231f, -0.03655751f, 
    0.03889804f, 0.05797961f, -0.01604079f, 0.04290359f, -0.07380260f, -0.04756884f, 0.00143944f, -0.04905301f, 
    0.01536279f, -0.02791274f, 0.02175122f, -0.02172966f, 0.03744197f, 0.04751972f, 0.05621209f, 0.06689626f, 
    0.04996207f, 0.01076605f, -0.02348142f, 0.02270020f, -0.01643404f, -0.07956812f, 0.00947951f, -0.05325796f, 
    0.00458207f, -0.04925967f, 0.01082155f, -0.07081460f, -0.05522232f, -0.06159030f, 0.04194494f, -0.00510648f, 
    0.02457821f, -0.04971720f, -0.03942321f, 0.04022216f, -0.01510117f, -0.00942213f, -0.07336985f, -0.02029395f, 
    0.00632950f, -0.01527204f, 0.01806540f, 0.03642593f, 0.01305417f, 0.02047675f, -0.00435033f, 0.05504885f, 
    0.01292265f, -0.02387268f, 0.03024132f, 0.00395889f, -0.01715801f, -0.06907036f, -0.07790091f, 0.04010008f, 
    0.03890148f, -0.05423326f, -0.04626999f, 0.01464612f, 0.03992468f, -0.03699654f, 0.00204963f, -0.00445694f, 
    0.04928600f, -0.06756921f, 0.03445200f, 0.01096714f, -0.02103353f, 0.02920305f, -0.04065089f, -0.01481543f, 
    0.20973541f, 0.20099896f, 0.12074693f, -0.17318326f, 0.07638204f, 0.07368068f, 0.08727270f, -0.23754317f, 
    -0.01933094f, 0.00685109f, -0.05154049f, 0.11136986f, 0.13080217f, -0.00213548f, 0.23906171f, -0.15472177f, 
    -0.02577083f, -0.00459628f, -0.04472015f, 0.03082772f, 0.05501213f, 0.06749017f, 0.07725260f, -0.05093093f, 
    -0.10108725f, 0.09991325f, 0.01558227f, 0.03752661f, 0.02851886f, 0.05565578f, -0.04815426f, -0.00703866f, 
    -0.09257676f, -0.08122171f, -0.00415664f, 0.09152120f, 0.25015581f, -0.21510260f, -0.05091795f, 0.12727642f, 
    0.02046208f, -0.12521097f, 0.19979759f, -0.06369068f, 0.04453444f, 0.16814256f, -0.07573543f, 0.06445708f, 
    0.00272631f, -0.05377426f, 0.06595719f, -0.07540316f, -0.08644364f, 0.01527057f, -0.01785116f, -0.02354782f, 
    -0.06072784f, 0.11453568f, 0.16026926f, 0.11235905f, 0.11580954f, 0.26860648f, -0.12907882f, 0.24338257f, 
    0.18553467f, -0.01899578f, 0.02454909f, 0.00834961f, 0.04326024f, -0.07707161f, -0.01777699f, 0.04861106f, 
    -0.23112386f, -0.35313442f, 0.15619701f, -0.01259313f, 0.08609711f, -0.05745545f, 0.19327271f, 0.02489781f, 
    0.14652334f, 0.08377017f, 0.02616536f, 0.06908192f, 0.06312258f, -0.08681391f, 0.08480356f, -0.13372602f, 
    0.03316462f, -0.02786026f, -0.00178131f, -0.00546527f, 0.03755243f, -0.00595392f, -0.07633409f, -0.10398068f, 
    0.21639563f, 0.13062024f, 0.04962607f, 0.04957628f, -0.01370909f, 0.04387490f, -0.09540059f, -0.10382207f, 
    -0.18538359f, 0.02851335f, 0.01413537f, 0.10723576f, -0.00838153f, -0.08358066f, -0.03847622f, 0.05284357f, 
    -0.13211648f, -0.02898882f, -0.07258310f, -0.08132488f, -0.02906370f, -0.01861499f, 0.08904383f, -0.03296777f, 
    -0.65674663f, 0.05145865f, -0.11180016f, 0.03820724f, 0.09505792f, 0.00111215f, -0.01343816f, -0.04407407f, 
    -0.13830818f, -0.05064816f, 0.00913143f, 0.13532650f, -0.06695982f, -0.13150236f, 0.21446063f, 0.08155994f, 
    0.02545847f, -0.05007909f, 0.10786153f, -0.04555925f, 0.03837547f, 0.00454825f, 0.02715944f, 0.06489149f, 
    0.15301956f, -0.05985795f, -0.12267007f, -0.00040500f, 0.05372536f, -0.07329959f, 0.00440692f, 0.16117668f, 
    0.09311152f, -0.08039943f, -0.15521471f, -0.01738804f, -0.24040380f, 0.27115089f, -0.10414041f, 0.25512218f, 
    0.07593920f, -0.10073338f, -0.13891655f, -0.04781320f, -0.12789419f, -0.07217909f, 0.05728000f, -0.16031145f, 
    -0.20144263f, -0.09529825f, -0.02936222f, -0.24273908f, -0.11102981f, 0.05228424f, 0.00902115f, -0.07867667f, 
    0.14637321f, 0.06124759f, -0.00932580f, 0.09606395f, -0.12733562f, 0.06253314f, -0.24513049f, -0.06064953f, 
    -0.00081741f, 0.07700275f, -0.09171792f, -0.04138025f, 0.06720332f, 0.02668933f, -0.02626617f, -0.04463580f, 
    -0.23656932f, -0.02069229f, 0.07540317f, -0.11249118f, 0.01721784f, -0.11614823f, -0.10575743f, 0.14783327f, 
    0.03882759f, -0.13369535f, -0.04538012f, -0.11561547f, -0.04503545f, 0.16138197f, 0.06384391f, 0.05792592f, 
    0.03613434f, -0.15120247f, -0.00226305f, -0.12530680f, 0.01564326f, -0.06239972f, -0.04630287f, 0.20212643f, 
    -0.00955410f, -0.11120182f, -0.04874582f, 0.18624154f, -0.05712799f, 0.03469030f, -0.00890554f, 0.02054984f, 
    0.09806550f, 0.04420179f, -0.05390076f, 0.01948642f, 0.13449030f, 0.02243233f, -0.13888273f, -0.11115251f, 
    -0.15820892f, 0.02238484f, 0.02655226f, -0.05973100f, -0.35801315f, 0.20053197f, 0.11457430f, -0.00167033f, 
    0.05610664f, -0.23813246f, -0.03092995f, 0.05394877f, 0.00163085f, 0.02746024f, -0.11209577f, -0.17655106f, 
    0.20239672f, 0.13896997f, 0.05613815f, -0.17095716f, -0.31129777f, -0.11023467f, -0.21782820f, -0.14398600f, 
    0.23892403f, -0.15081795f, -0.00203494f, 0.08472092f, 0.08810251f, 0.06614874f, 0.07492480f, 0.12279549f, 
    0.29662547f, 0.22669208f, 0.15612081f, 0.01370271f, -0.02353253f, -0.03756541f, 0.06212218f, 0.02997263f, 
    -0.00730028f, -0.12562634f, -0.02572180f, -0.05200254f, 0.01640920f, 0.07545029f, -0.02946188f, -0.13011222f, 
    -0.01038261f, 0.09349816f, -0.01385731f, -0.05620533f, -0.03977527f, 0.12480528f, 0.08983653f, 0.09190080f, 
    -0.17547019f, 0.00745395f, 0.24158125f, 0.22731277f, -0.08238407f, -0.14983137f, -0.02327371f, -0.08222330f, 
    0.00312216f, 0.06992727f, -0.07605996f, -0.06798794f, 0.24306998f, 0.21186452f, -0.03299765f, -0.05851681f, 
    0.08790075f, 0.06805353f, -0.03563902f, 0.02751427f, 0.02198670f, -0.04266416f, 0.08795919f, 0.10055939f, 
    0.32261339f, -0.01053787f, 0.06258336f, 0.02566481f, -0.16787942f, -0.03521928f, 0.06495738f, -0.05205316f, 
    0.02047966f, 0.18642299f, 0.19666070f, -0.05790507f, -0.10411243f, -0.08873580f, 0.03939528f, -0.17045119f, 
    0.00240528f, 0.13545272f, 0.09037017f, -0.05180937f, 0.06385793f, 0.16907491f, 0.06570680f, -0.03297073f, 
    -0.09179073f, -0.08326706f, -0.16805406f, -0.21572682f, 0.03015102f, 0.01428509f, -0.07190429f, -0.02622369f, 
    -0.04143728f, 0.13460054f, 0.05898425f, 0.19494465f, 0.48439002f, 0.04565012f, -0.05128764f, 0.17904821f, 
    -0.27589929f, -0.14803152f, 0.05820328f, 0.09795732f, -0.04893385f, -0.02372461f, -0.04105588f, 0.06338750f, 
    -0.35037535f, 0.08758413f, 0.07726281f, -0.16815187f, 0.13560510f, -0.02947726f, 0.04503796f, -0.01590582f, 
    0.09184211f, -0.03783725f, -0.05676331f, 0.02027045f, 0.28620285f, -0.06971391f, -0.02388471f, -0.20844080f, 
    0.21421811f, -0.03998417f, 0.07603197f, 0.00574256f, 0.05374007f, -0.11275554f, 0.13998695f, -0.00842055f, 
    -0.11058957f, -0.12659909f, 0.05141068f, 0.03818791f, -0.00586588f, -0.05456685f, 0.05440020f, -0.12258483f, 
    -0.06730073f, -0.02910148f, -0.13239835f, 0.13039593f, -0.28803450f, -0.02488552f, -0.12226731f, -0.00593619f, 
    -0.10626789f, -0.01123998f, 0.06610265f, 0.02289478f, 0.07197979f, 0.08917250f, -0.03378712f, -0.02377680f, 
    -0.14355433f, 0.08947912f, -0.21472909f, 0.08496836f, -0.07872359f, 0.05719261f, 0.01741482f, -0.00203800f, 
    -0.08656874f, 0.13079698f, 0.07138221f, 0.03742260f, 0.15859303f, 0.06257904f, 0.03696276f, -0.09466856f, 
    0.13376655f, 0.13880463f, 0.15099479f, 0.17997529f, -0.07465957f, 0.06111103f, -0.02167579f, -0.10272878f, 
    0.01357324f, -0.00859792f, -0.12363837f, -0.15532768f, -0.01084892f, 0.04508764f, 0.04569952f, 0.11402137f, 
    0.11878842f, -0.08793880f, 0.07241920f, 0.11379053f, -0.01789235f, -0.13204294f, 0.02528860f, -0.07189691f, 
    -0.04816080f, 0.03479842f, -0.03855121f, 0.13201912f, 0.07717750f, 0.05202943f, 0.12171001f, 0.18725163f, 
    -0.03972613f, -0.09536408f, -0.14393717f, -0.23467048f, -0.02181842f, -0.06174779f, 0.08315311f, -0.08752795f, 
    -0.00068665f, -0.02346128f, -0.07399031f, 0.06405478f, -0.38253295f, -0.01355573f, 0.02328159f, 0.09725507f, 
    0.03275515f, -0.05777262f, 0.09373738f, 0.10499733f, 0.04598394f, -0.06375510f, -0.00732646f, -0.08022758f, 
    0.07255439f, -0.14480571f, -0.12851807f, -0.20818079f, 0.04138642f, 0.06849832f, 0.02361372f, 0.03259228f, 
    0.03337333f, -0.05413369f, 0.05141727f, 0.04794409f, -0.37481135f, 0.08512332f, -0.05881506f, -0.01137130f, 
    -0.01248386f, 0.00595171f, 0.01693958f, 0.05479121f, -0.05509212f, -0.06144081f, -0.01085962f, -0.19724472f, 
    0.21812092f, 0.05887883f, 0.03432322f, 0.17933752f, -0.14689653f, 0.04067867f, 0.01313539f, 0.03015645f, 
    -0.01699651f, -0.02416003f, 0.02823076f, -0.04006641f, 0.21534790f, -0.00195513f, -0.01523540f, -0.07690667f, 
    0.16909301f, -0.02045306f, 0.13210961f, -0.03227866f, 0.00716640f, -0.06382216f, 0.01515177f, 0.05625647f, 
    0.13273156f, 0.11303549f, 0.11045916f, -0.25010139f, 0.04927373f, 0.03757429f, 0.06013681f, -0.00615951f, 
    0.07173336f, -0.04758109f, 0.02836693f, 0.04786272f, 0.32060900f, -0.21597478f, -0.18722560f, -0.14977108f, 
    0.07174235f, 0.02192681f, -0.01073588f, -0.04808598f, 0.01305067f, -0.06696360f, 0.05213363f, 0.10307856f, 
    0.23958609f, -0.21010946f, 0.03250776f, 0.07385769f, 0.07180208f, 0.14235242f, 0.19824326f, 0.04280896f, 
    0.01577602f, 0.08306444f, -0.12120709f, -0.04288493f, 0.19050735f, -0.03176575f, 0.14073032f, 0.07803708f, 
    -0.19384949f, 0.07253954f, 0.01164994f, -0.04087770f, 0.08552091f, -0.03246428f, 0.12203981f, 0.12180503f, 
    0.01829568f, -0.32887936f, -0.22264756f, 0.11153939f, -0.06079740f, -0.11606151f, -0.01168493f, 0.04631682f, 
    -0.04993257f, -0.09434786f, -0.19482951f, 0.22643833f, -0.01181976f, 0.16135268f, 0.12614650f, -0.21730866f, 
    -0.13939226f, 0.21914062f, 0.19526996f, -0.06055126f, 0.09506620f, 0.15097684f, -0.01063896f, 0.07995032f, 
    -0.07316092f, 0.32153973f, -0.01513244f, 0.10539873f, -0.02252453f, 0.05396766f, -0.00318312f, 0.09357071f, 
    0.02264581f, 0.09488419f, -0.01910503f, -0.05661537f, -0.02675826f, -0.10494025f, 0.10887606f, -0.06637421f, 
    0.09141740f, 0.13244136f, -0.02183748f, -0.01876554f, 0.11678467f, 0.09458727f, 0.21260948f, 0.06739021f, 
    0.01838177f, 0.01509683f, 0.35609239f, 0.06435861f, -0.05973252f, 0.13743895f, -0.03100974f, 0.08558349f, 
    0.11705919f, -0.07155402f, -0.12874091f, -0.11156398f, 0.11310705f, -0.36594626f, -0.07147870f, 0.17961040f, 
    -0.17719263f, -0.20895791f, -0.19431193f, -0.05908222f, 0.05210112f, -0.01107755f, 0.08318537f, 0.10306589f, 
    0.16462590f, 0.36828396f, -0.14495228f, -0.26825699f, 0.03552173f, 0.02237066f, 0.05424851f, -0.10558059f, 
    0.12344734f, 0.04651678f, 0.07895423f, -0.01947463f, 0.15594395f, -0.31885475f, 0.00212254f, -0.20780759f, 
    -0.11126306f, -0.09399974f, 0.04686024f, -0.12278477f, -0.02955327f, 0.07816681f, 0.04065157f, 0.04916611f, 
    0.15634407f, -0.10331416f, 0.05937853f, 0.18369280f, 0.06015372f, 0.01759880f, 0.05701083f, 0.02575896f, 
    0.10474689f, 0.03578309f, 0.03763774f, 0.18228987f, -0.52776659f, 0.16766849f, 0.10464294f, -0.13027619f, 
    -0.04604527f, -0.00257216f, 0.06194791f, -0.14545080f, 0.03211551f, -0.01606079f, -0.02906584f, 0.01993831f, 
    0.04330226f, 0.05595912f, 0.09166107f, 0.06415394f, 0.04590335f, 0.00066253f, -0.02850045f, 0.12347214f, 
    0.14048867f, -0.21631023f, 0.01820718f, 0.08474758f, 0.15500273f, -0.08253725f, 0.15972707f, 0.23863035f, 
    0.02585401f, 0.00751809f, 0.03335292f, -0.10057936f, 0.11095339f, 0.07427300f, -0.01771109f, 0.01038629f, 
    -0.08482586f, -0.14841983f, 0.01383951f, 0.27206114f, -0.16984633f, -0.16309577f, -0.00057585f, -0.11959358f, 
    0.05990504f, -0.07778415f, -0.05360467f, 0.02981117f, 0.27078819f, 0.07436764f, -0.00946144f, -0.07017123f, 
    -0.04001958f, 0.05474002f, -0.01522249f, 0.05208217f, 0.06252316f, 0.16659848f, -0.04864720f, 0.09077780f, 
    0.11335457f, 0.12252426f, 0.12930694f, 0.13227798f, -0.05952061f, -0.08237933f, 0.12081649f, 0.09374011f, 
    -0.04246667f, -0.03404651f, -0.10437977f, -0.04011364f, -0.36133638f, -0.21604162f, 0.06433950f, 0.14042400f, 
    -0.18688181f, 0.06503379f, -0.12941505f, 0.00363656f, 0.03178203f, -0.04317396f, -0.13278997f, -0.10151128f, 
    0.04071484f, 0.03391212f, 0.00462615f, -0.07481335f, 0.05812660f, 0.02695943f, 0.02941001f, 0.04176804f, 
    -0.03983536f, 0.06419575f, -0.06688754f, 0.03578584f, -0.06580147f, -0.07839537f, 0.00981212f, -0.04647459f, 
    -0.05019581f, 0.04577204f, -0.06485097f, 0.03305843f, -0.04180633f, 0.05656132f, 0.04381785f, -0.06880949f, 
    -0.01123534f, -0.02404780f, -0.06567931f, 0.03343296f, -0.02037613f, -0.01186874f, -0.02854728f, -0.04244148f, 
    -0.04094817f, 0.02182739f, -0.07530105f, -0.04646740f, 0.02106585f, -0.06556152f, 0.01822325f, 0.00847731f, 
    0.00772209f, -0.03404335f, -0.04359740f, 0.03401619f, 0.02658106f, -0.02574387f, 0.02555636f, -0.05556575f, 
    -0.02294854f, -0.05878215f, 0.01126559f, -0.04392366f, -0.05997113f, -0.07443820f, 0.02335159f, 0.04231976f, 
    0.00973750f, -0.04166345f, -0.07798259f, -0.03514593f, 0.06293321f, -0.02787594f, 0.05758233f, -0.01077500f, 
    0.01915885f, 0.02219795f, -0.06217558f, -0.02284241f, -0.06554713f, 0.00014721f, 0.00506639f, -0.06286225f, 
    0.02354710f, -0.04296964f, -0.02231093f, 0.00612524f, -0.06033499f, -0.06252235f, -0.01165589f, -0.05445388f, 
    -0.06294101f, -0.02132061f, -0.07279269f, -0.07012933f, -0.06711997f, 0.01275353f, -0.05558614f, 0.04879985f, 
    0.02058622f, -0.04015012f, -0.01256853f, -0.05264276f, -0.00083527f, 0.01687118f, -0.03485863f, -0.06459793f, 
    -0.06717122f, 0.01720448f, -0.02881948f, -0.01844331f, -0.05319796f, -0.03247572f, -0.05024361f, -0.04604262f, 
    -0.00703738f, 0.02462896f, -0.02742004f, 0.06799732f, -0.03333779f, 0.05014256f, 0.00309555f, 0.04784941f, 
    0.02777023f, 0.01607218f, -0.06118467f, 0.01606255f, -0.07749192f, -0.05179376f, 0.03796030f, -0.01602812f, 
    0.04060393f, 0.01096859f, 0.01157660f, 0.01186026f, -0.03039991f, -0.01734671f, -0.00991238f, 0.05050802f, 
    -0.01983486f, 0.05999663f, -0.03178179f, 0.01201822f, 0.04182970f, -0.03569430f, -0.06485175f, 0.00600085f, 
    -0.01585514f, -0.07408696f, 0.00193529f, 0.02647563f, 0.05818431f, 0.01806470f, -0.03170454f, 0.06239872f, 
    0.04341854f, -0.01784721f, 0.05650901f, 0.05360429f, -0.00710280f, -0.04936007f, 0.00600803f, -0.00769964f, 
    -0.06356278f, -0.01946767f, -0.07570515f, 0.01795538f, -0.02622994f, 0.03241073f, 0.00789261f, -0.00203153f, 
    -0.05166887f, -0.00010882f, 0.01331571f, 0.00217247f, -0.07563116f, -0.00119619f, -0.00893956f, 0.02152362f, 
    -0.01639939f, -0.00645364f, 0.04840107f, 0.01925440f, 0.00846024f, -0.02343206f, 0.01948631f, -0.06002631f, 
    0.02272904f, 0.00769129f, -0.05570727f, -0.01789830f, -0.06278404f, -0.05860358f, -0.07073947f, 0.03368470f, 
    0.04350333f, 0.06186943f, 0.04962580f, -0.04908429f, 0.04490513f, -0.04632789f, 0.04036501f, -0.03646529f, 
    -0.06259756f, -0.13246767f, -0.14888285f, -0.15531905f, -0.04759812f, 0.11965808f, 0.01161307f, -0.15068331f, 
    -0.16397460f, 0.07107097f, 0.07748529f, 0.05496931f, 0.08182276f, 0.07847053f, 0.10201857f, 0.12086271f, 
    -0.09401061f, -0.11229208f, 0.13779476f, -0.00064162f, -0.00165013f, 0.01647654f, -0.04512948f, -0.02026770f, 
    0.21291894f, -0.02632097f, -0.18338546f, -0.21975970f, 0.10014680f, -0.01741739f, 0.06934054f, 0.05818374f, 
    0.01669201f, -0.06860658f, -0.04747523f, -0.18213135f, -0.09131677f, 0.03326264f, 0.06815732f, 0.25145367f, 
    -0.06398030f, 0.00747284f, 0.01654555f, 0.06051132f, -0.03818365f, -0.00861937f, -0.00798955f, 0.03445498f, 
    0.13364212f, 0.13826250f, 0.24766621f, 0.22054558f, 0.02380650f, 0.07578853f, -0.03182027f, -0.08615288f, 
    -0.08672098f, -0.09900807f, 0.01813898f, -0.07494809f, 0.12469258f, -0.21218714f, -0.18837576f, -0.00513295f, 
    0.00630393f, -0.09007751f, -0.03250392f, -0.06495550f, 0.00397351f, -0.08193733f, 0.07692917f, -0.02979381f, 
    -0.26483658f, 0.07094535f, 0.01019989f, 0.33212143f, -0.01362362f, -0.00358137f, 0.11433861f, -0.00975858f, 
    0.07312241f, 0.05603994f, 0.08427237f, -0.03708483f, -0.04390576f, -0.41393918f, 0.03765426f, -0.12612024f, 
    -0.28564021f, -0.03288697f, -0.01379541f, -0.02081191f, -0.17825726f, -0.04477275f, -0.02915959f, -0.07194616f, 
    0.35675967f, 0.17590795f, 0.20676436f, 0.15858150f, 0.06447493f, -0.11720958f, 0.09949631f, -0.01597451f, 
    -0.07490226f, -0.03974997f, -0.07673346f, 0.01502412f, -0.31556737f, -0.11037501f, 0.01490647f, -0.08808178f, 
    0.00097102f, -0.00324897f, -0.03653028f, -0.02904888f, -0.11253209f, -0.11869059f, -0.01534781f, -0.07554168f, 
    0.00573303f, 0.27318746f, 0.09942411f, 0.06423483f, 0.08465103f, -0.02617226f, -0.09677181f, 0.12461806f, 
    0.07680345f, -0.05156985f, -0.09728637f, 0.01890615f, -0.11833373f, -0.07345024f, 0.03960799f, 0.23445156f, 
    0.01660041f, 0.03925094f, -0.02456861f, -0.08261114f, -0.01536383f, -0.01037444f, -0.05171777f, -0.04880419f, 
    -0.20156115f, -0.10974456f, -0.07800446f, -0.15507904f, 0.00351916f, -0.08673101f, -0.06336445f, 0.01424716f, 
    -0.00180411f, -0.11068168f, 0.11407503f, 0.06764273f, 0.11196683f, 0.12590937f, 0.25103849f, 0.19140971f, 
    0.06391619f, -0.05338641f, -0.06503409f, 0.05952495f, -0.00539968f, -0.02566864f, -0.01438197f, -0.07527818f, 
    0.09269974f, 0.04089611f, -0.05998856f, 0.13707432f, 0.04111586f, 0.01658866f, 0.01650221f, -0.06382793f, 
    -0.02233518f, 0.04418457f, 0.13099490f, -0.17551418f, -0.55173391f, -0.07477406f, -0.28560403f, -0.10101148f, 
    -0.17155798f, 0.02826932f, -0.01227113f, 0.01567524f, -0.01731740f, -0.13582475f, -0.16689013f, -0.07382380f, 
    -0.00330516f, -0.20214581f, -0.18623282f, -0.14110252f, -0.04616937f, -0.07630647f, -0.00522423f, 0.12419666f, 
    -0.08772376f, -0.04367541f, -0.01240152f, -0.09617890f, -0.17537090f, 0.10610280f, -0.02298416f, -0.23152541f, 
    -0.08113514f, 0.03324096f, 0.06908592f, 0.06591514f, 0.13776883f, 0.21481840f, 0.08115215f, 0.07991745f, 
    -0.27336431f, 0.02065658f, -0.09055729f, 0.06364775f, -0.10093411f, 0.04578456f, 0.01159110f, 0.10031871f, 
    0.05353839f, 0.05563698f, -0.09842972f, -0.10378303f, 0.03259772f, 0.00914054f, 0.08145081f, -0.26866877f, 
    -0.01337402f, 0.09476554f, -0.00095448f, 0.07065330f, -0.09371625f, 0.21602145f, 0.05908694f, 0.19355913f, 
    0.01528436f, 0.08100733f, -0.04123496f, 0.05858711f, 0.04246896f, 0.16391012f, 0.08611590f, -0.10614000f, 
    0.04872429f, -0.13525903f, 0.02166694f, 0.02674034f, 0.34439465f, -0.40244898f, 0.03896336f, 0.15725404f, 
    -0.04713788f, -0.05350463f, -0.08808627f, 0.07074205f, 0.04785254f, 0.02911747f, 0.01319893f, 0.04323684f, 
    0.27735713f, -0.15237053f, -0.16289529f, -0.09654392f, -0.01474152f, -0.07241302f, -0.05523705f, 0.08659893f, 
    -0.08459947f, -0.02908920f, -0.00255388f, -0.10238350f, 0.20473348f, -0.08372010f, 0.02541575f, -0.04508596f, 
    0.08879523f, -0.03010652f, -0.08097165f, -0.15521874f, 0.06772269f, -0.01181869f, 0.01952932f, -0.10528625f, 
    -0.07402369f, -0.11916447f, -0.00119093f, 0.04051092f, 0.06680603f, -0.05253952f, -0.11169913f, 0.11183980f, 
    0.16842011f, 0.10354456f, -0.04390850f, 0.08054551f, -0.12875077f, 0.23742652f, -0.01840611f, -0.03217712f, 
    -0.12227455f, -0.00678174f, -0.01823769f, 0.05537885f, 0.05804107f, 0.04230732f, -0.11941103f, 0.02625204f, 
    -0.25256628f, 0.04814187f, -0.11629684f, 0.08217654f, 0.04705184f, 0.02416093f, -0.00060056f, 0.02362732f, 
    -0.10912024f, -0.09318873f, -0.01178947f, -0.06580426f, 0.22505552f, -0.09122854f, 0.03678377f, 0.03312833f, 
    0.02973553f, -0.01058833f, 0.07923020f, -0.05590060f, 0.00662664f, 0.06782051f, 0.05376769f, 0.01195404f, 
    0.09963567f, -0.14106080f, -0.08751054f, 0.39404953f, 0.06863381f, -0.02520993f, 0.01845144f, -0.06435550f, 
    0.14053522f, 0.02736700f, 0.08480798f, 0.13579874f, -0.21526869f, 0.13843340f, -0.15244778f, 0.01635774f, 
    0.00330872f, -0.06149071f, 0.09928375f, -0.01103289f, 0.16019565f, -0.14522396f, -0.04586242f, -0.05156350f, 
    -0.09313241f, -0.00804973f, -0.10181203f, -0.14841491f, 0.09874336f, 0.02326945f, 0.08961228f, -0.03227672f, 
    0.17198162f, 0.01865969f, -0.00178770f, -0.18807246f, 0.10384199f, -0.03276365f, 0.12980114f, 0.19937289f, 
    -0.11531434f, -0.08359130f, 0.15436985f, 0.00290588f, 0.08251950f, -0.00304512f, -0.09933415f, -0.09484416f, 
    -0.18944725f, -0.13543788f, -0.02050219f, -0.01873573f, -0.00529754f, -0.05016280f, -0.13523136f, -0.00664324f, 
    0.01530707f, -0.07733502f, -0.03933930f, 0.11598714f, 0.03028504f, 0.11758418f, -0.00901120f, -0.09393046f, 
    0.05689241f, 0.04683733f, 0.03466350f, 0.02358788f, 0.02083312f, 0.08880897f, -0.03274588f, -0.01509820f, 
    -0.20429458f, 0.25672835f, 0.16114756f, 0.05804621f, -0.05784030f, 0.04327787f, -0.05268650f, -0.05772112f, 
    -0.01006298f, -0.01442961f, 0.00635002f, -0.03335620f, 0.10706575f, -0.08321643f, 0.09323826f, 0.04818042f, 
    0.00603017f, 0.05861605f, -0.01348733f, 0.07958101f, -0.13305886f, -0.00073774f, 0.01102332f, -0.00806001f, 
    0.02449661f, 0.07050153f, 0.07902279f, 0.10694898f, -0.05950725f, -0.02950502f, -0.01034881f, 0.03922588f, 
    0.02277190f, -0.05863934f, 0.00934454f, -0.01969741f, -0.02416194f, -0.28050816f, 0.06655981f, 0.20167539f, 
    0.07266990f, 0.06947982f, -0.10678884f, 0.04158353f, -0.08486933f, 0.03696870f, 0.06042729f, -0.02722839f, 
    0.38154024f, 0.27757177f, -0.13038345f, -0.18925692f, -0.07573087f, -0.06549101f, 0.14200348f, -0.11039787f, 
    -0.08312511f, -0.13049018f, 0.03008601f, 0.02379468f, -0.28819171f, 0.03216156f, -0.03071688f, -0.22711371f, 
    0.04469610f, -0.05949187f, 0.01921573f, 0.03346601f, -0.04104223f, -0.11842535f, -0.15847936f, -0.02720480f, 
    0.11789221f, 0.04487175f, -0.09483241f, -0.08583049f, -0.07065210f, -0.11326168f, 0.00938621f, -0.12403211f, 
    0.01292684f, -0.11343390f, 0.10798841f, 0.16844396f, -0.20716441f, 0.36450687f, 0.04284914f, 0.14335358f, 
    0.09745332f, 0.07909175f, -0.04752488f, 0.06631915f, 0.02905578f, 0.03757185f, 0.12229487f, 0.02994538f, 
    0.12417107f, 0.15060736f, 0.02474551f, 0.30949390f, -0.04596759f, -0.09034515f, -0.03826744f, -0.21475400f, 
    0.03539955f, 0.06253278f, 0.00130378f, 0.05230850f, 0.32929963f, 0.03002720f, 0.01957221f, 0.06404108f, 
    0.06404484f, -0.02006125f, 0.05973716f, 0.20066190f, 0.01501832f, 0.11609691f, 0.07074515f, 0.03493564f, 
    0.05127238f, -0.04718238f, -0.23350559f, 0.06287955f, -0.07488618f, -0.07774521f, 0.04062999f, -0.02267602f, 
    0.02660252f, -0.03364050f, -0.09237406f, -0.04563188f, 0.17287536f, 0.30298078f, 0.18328597f, -0.10745245f, 
    0.05177084f, -0.07432159f, -0.00252994f, -0.00570598f, 0.04165468f, 0.05555548f, 0.02906233f, 0.02714522f, 
    0.29511747f, -0.10329662f, -0.02450345f, 0.07861166f, -0.12836234f, -0.08801173f, -0.00007868f, 0.04697313f, 
    -0.01379804f, 0.10505512f, -0.22454287f, -0.00584696f, 0.27992249f, -0.08859275f, -0.22372022f, 0.05242990f, 
    0.02661688f, -0.06553148f, -0.00539784f, 0.03218235f, -0.07989986f, 0.08290398f, -0.06002779f, -0.03267790f, 
    0.05746922f, -0.05378278f, 0.05549151f, 0.01460528f, -0.02656391f, -0.06850302f, -0.07147773f, 0.02996792f, 
    0.00864279f, 0.06218532f, -0.01344753f, -0.01748893f, -0.04345962f, -0.04416496f, 0.03981998f, 0.01199252f, 
    -0.00962582f, -0.07265966f, 0.03822738f, -0.07111529f, 0.00869471f, -0.01490162f, 0.04645240f, -0.01397567f, 
    0.00856255f, -0.03353557f, -0.03769447f, -0.00600930f, -0.03598156f, -0.05143538f, 0.01159365f, -0.03045311f, 
    0.03808087f, -0.00553983f, 0.00476666f, 0.02095489f, -0.04718300f, 0.03773413f, -0.00992461f, 0.02391918f, 
    -0.07499263f, 0.01086256f, 0.05355820f, -0.00018586f, 0.05985690f, 0.06026135f, 0.03336056f, -0.08865419f, 
    -0.06571853f, 0.03809250f, 0.05859149f, 0.07165212f, 0.05317065f, 0.00000466f, -0.08242377f, 0.01455490f, 
    -0.02059552f, 0.03158469f, -0.03993677f, -0.00842439f, -0.06805107f, 0.04260510f, 0.03170810f, -0.00638105f, 
    -0.07136720f, -0.03409605f, -0.03749708f, -0.04559316f, -0.03887623f, 0.04367102f, -0.02838900f, -0.04779474f, 
    0.02844076f, -0.03225660f, 0.01337356f, -0.00372746f, 0.05852226f, 0.04153263f, -0.05810686f, -0.04727086f, 
    0.03471594f, 0.04002998f, 0.03644804f, -0.00256541f, 0.00319390f, -0.03307166f, -0.01723537f, -0.01308676f, 
    -0.00116777f, -0.04697513f, -0.07281174f, -0.03547138f, 0.01701075f, -0.00952374f, -0.01369637f, 0.05822659f, 
    -0.00060286f, -0.00783666f, -0.00536935f, -0.02826815f, 0.03009589f, -0.02708665f, -0.05479152f, -0.03337973f, 
    0.03085874f, 0.00798504f, -0.00212442f, 0.03988466f, 0.01450726f, -0.04180685f, 0.00829609f, -0.03192993f, 
    -0.05707568f, -0.03724768f, 0.00319933f, 0.00834579f, -0.02964835f, -0.05565607f, -0.07019365f, -0.07954535f, 
    -0.05227875f, 0.00735410f, 0.04044265f, -0.03127347f, -0.00201845f, 0.03416148f, 0.04838602f, -0.00305451f, 
    -0.00157093f, -0.04706908f, 0.03874373f, -0.06068110f, -0.01246372f, -0.07322989f, -0.01588146f, -0.08315443f, 
    0.05959769f, 0.02527216f, -0.00708688f, -0.03792837f, 0.01453919f, 0.00118535f, 0.02193767f, -0.04408492f, 
    0.06470416f, -0.07613771f, -0.05903978f, -0.08143459f, -0.07527665f, -0.06040462f, -0.07832459f, 0.05002513f, 
    -0.04128774f, -0.01822909f, -0.01532009f, 0.02949305f, -0.03703990f, 0.01820812f, -0.00122585f, 0.05847040f, 
    0.03938010f, -0.01807136f, -0.06781510f, 0.01726954f, 0.03465179f, -0.01014515f, 0.03893428f, -0.06548087f, 
    0.02183288f, -0.04119701f, 0.02139965f, -0.00107326f, 0.03626497f, 0.01972637f, 0.01287694f, 0.05357417f, 
    -0.06185023f, -0.05641463f, -0.06306816f, -0.03436960f, -0.07775932f, -0.00790838f, 0.04888644f, 0.01578835f, 
    -0.01982730f, -0.06224836f, -0.07569498f, 0.05018125f, -0.07239567f, -0.00227930f, 0.01791873f, 0.02244239f, 
    -0.28048071f, -0.12025666f, 0.00594309f, -0.14407584f, 0.02958984f, -0.16801463f, -0.09638706f, 0.04914214f, 
    -0.04225608f, -0.16671087f, -0.08364882f, -0.02808061f, -0.20056720f, -0.03263269f, 0.03514935f, -0.18067037f, 
    0.02711847f, 0.17729010f, 0.09463529f, -0.02689066f, 0.03982016f, 0.13425821f, 0.08271405f, 0.11760885f, 
    -0.32279047f, 0.26511714f, -0.12272681f, 0.05178570f, -0.11685644f, 0.07044230f, -0.10294300f, 0.01055571f, 
    0.01696205f, 0.07453996f, -0.09227167f, -0.10605530f, 0.24892181f, -0.05020975f, 0.08765108f, -0.13544622f, 
    0.08328144f, -0.00582186f, 0.06149578f, 0.12074792f, -0.15609512f, 0.20649186f, 0.03974634f, 0.11758641f, 
    0.00332450f, -0.00608956f, 0.02935148f, 0.01146598f, -0.04971107f, 0.10375597f, 0.11862565f, 0.01948367f, 
    0.09160050f, -0.17533019f, 0.05005787f, -0.06055265f, 0.05340737f, -0.53868002f, -0.06876951f, 0.27687132f, 
    -0.05647044f, -0.03039179f, -0.04649805f, 0.13152413f, 0.10940595f, 0.16273546f, 0.05320948f, 0.14137180f, 
    0.51455349f, 0.00823147f, -0.14670429f, -0.16719687f, -0.04543430f, -0.06905100f, 0.06543298f, -0.03459634f, 
    -0.02769202f, 0.03649756f, -0.01898354f, -0.14442055f, -0.11210120f, -0.06891520f, 0.03114743f, -0.15615712f, 
    0.05408116f, -0.09251249f, 0.00212014f, 0.00220205f, 0.02684107f, -0.13402617f, -0.03136218f, -0.07180148f, 
    0.07834999f, -0.05288161f, 0.01536157f, -0.03490322f, 0.03835968f, -0.08190816f, -0.02059069f, -0.01051176f, 
    0.08710653f, -0.02578058f, -0.08732875f, 0.08651243f, -0.35552779f, 0.33977634f, -0.12356111f, -0.07626063f, 
    0.01358506f, -0.01312260f, 0.01330201f, 0.08054458f, 0.00759421f, 0.11617871f, -0.03844039f, 0.02239980f, 
    -0.11591125f, 0.10441801f, -0.12475232f, 0.18798245f, 0.04541049f, -0.09919783f, -0.06774830f, -0.04810389f, 
    -0.03779620f, -0.06258390f, -0.04705407f, -0.03170279f, 0.41568780f, -0.02093730f, 0.16183709f, 0.01042245f, 
    0.10847958f, -0.11174752f, 0.10602992f, -0.02119598f, -0.04635618f, 0.09466437f, 0.15931924f, -0.05444321f, 
    0.15527587f, -0.07663843f, -0.14698756f, 0.20070945f, 0.07026304f, 0.08226020f, -0.06046338f, 0.03466586f, 
    0.07210633f, -0.00638189f, 0.05409822f, 0.08784164f, 0.07436489f, 0.25887644f, -0.19428319f, -0.00756687f, 
    0.05919835f, 0.00351561f, 0.07282838f, -0.03499709f, 0.06850329f, -0.09002931f, -0.02075563f, 0.05548474f, 
    0.10828269f, -0.14822844f, 0.02431739f, -0.07920370f, 0.02381962f, 0.10983688f, 0.13063422f, -0.04437536f, 
    0.14192358f, 0.02284104f, -0.00242537f, -0.18071795f, 0.31306800f, 0.03439575f, -0.03026979f, 0.15886156f, 
    -0.08086982f, 0.04127834f, 0.05100867f, 0.05535278f, 0.02852093f, 0.02154602f, 0.02122368f, -0.05459844f, 
    -0.06766574f, -0.18315196f, -0.13584085f, -0.07112827f, -0.05204491f, 0.08158936f, 0.03792828f, -0.06496958f, 
    -0.20319843f, 0.16203932f, -0.04017276f, 0.07306983f, 0.21059695f, 0.08595511f, -0.07041977f, -0.09924573f, 
    -0.09679366f, -0.14513338f, 0.12258155f, 0.07451739f, -0.02389345f, 0.04144427f, -0.08076058f, -0.06295159f, 
    0.24524441f, 0.20027542f, -0.26095805f, -0.30728042f, -0.03838592f, -0.06450245f, 0.05222626f, 0.14685577f, 
    0.06039202f, 0.03286420f, 0.02539848f, -0.04980293f, 0.09406583f, 0.03783178f, 0.06551293f, 0.17958243f, 
    0.00584383f, -0.03575176f, 0.02164414f, 0.06134351f, 0.05633348f, -0.06671404f, -0.09547362f, -0.10958935f, 
    -0.07596096f, 0.09910908f, 0.21035510f, -0.15884185f, 0.12191508f, 0.07509962f, -0.00138208f, -0.02138618f, 
    0.06189026f, -0.01468842f, -0.02929350f, 0.08127267f, 0.34470022f, -0.16384083f, 0.09060168f, -0.01325920f, 
    -0.02040350f, -0.05804316f, 0.06558545f, -0.08302116f, -0.02661924f, 0.02382600f, 0.06733640f, 0.11856433f, 
    -0.17564991f, -0.01666966f, 0.19530369f, 0.39224964f, -0.08610083f, -0.01690683f, 0.08528969f, 0.01864214f, 
    0.02538458f, 0.09407874f, 0.03144056f, -0.05212354f, -0.27627242f, -0.22449149f, -0.04379968f, 0.19604835f, 
    -0.12452377f, 0.01169142f, 0.24229863f, 0.05616524f, -0.13228686f, -0.10229610f, -0.03088839f, -0.03995448f, 
    0.02197182f, 0.06423970f, 0.10197777f, 0.02277814f, -0.04925504f, -0.01649744f, 0.16617697f, 0.02458309f, 
    0.06623141f, -0.09078607f, 0.04632049f, 0.02277594f, -0.20943852f, 0.10044858f, -0.05169384f, -0.09111289f, 
    -0.07131899f, 0.00261143f, 0.00330482f, 0.01522556f, -0.05131998f, -0.06642728f, -0.04003250f, -0.25099969f, 
    0.51497513f, 0.04712639f, 0.12736292f, -0.22881900f, 0.00980787f, -0.02765333f, -0.09965770f, 0.13733731f, 
    0.15981047f, 0.00148975f, -0.01452035f, 0.04950923f, -0.23088396f, -0.18197688f, 0.01372915f, 0.17974323f, 
    -0.01585333f, 0.06432172f, 0.08805557f, -0.12967394f, 0.11606915f, -0.00163528f, 0.02321288f, -0.10471602f, 
    -0.12014534f, 0.06180374f, 0.02408509f, 0.11000187f, -0.04053673f, 0.07093280f, 0.04747797f, 0.03549679f, 
    0.06727638f, -0.09592403f, 0.05745031f, -0.11944854f, 0.28409865f, -0.09656560f, 0.26974294f, 0.26872778f, 
    -0.08004718f, -0.05601561f, 0.02983314f, -0.05229855f, 0.03216397f, -0.03619506f, 0.00500800f, 0.11600311f, 
    0.10195563f, 0.04327985f, -0.12065893f, 0.00259296f, 0.14448124f, 0.09078629f, -0.06037368f, -0.08729153f, 
    -0.07146250f, 0.10145080f, -0.02949488f, 0.03498030f, -0.12436849f, -0.04817130f, 0.14927763f, 0.13963589f, 
    0.03509253f, 0.09914772f, -0.00801531f, -0.00810169f, 0.08973371f, 0.03304480f, -0.02868768f, 0.10029534f, 
    0.03823619f, 0.01276723f, 0.00331603f, -0.17162076f, 0.00720827f, -0.10818796f, -0.05951019f, -0.18316545f, 
    0.10767980f, 0.15068211f, -0.01924987f, -0.09720768f, -0.03021984f, 0.21006887f, -0.21678682f, -0.09856974f, 
    -0.07274093f, -0.03106465f, 0.20022549f, -0.03383267f, 0.11359956f, -0.13176346f, 0.05378864f, -0.14437160f, 
    0.21301991f, -0.06076596f, -0.35670710f, -0.13693956f, -0.12320932f, -0.06562119f, 0.00550170f, -0.21248601f, 
    -0.03189552f, 0.14732735f, 0.05683726f, -0.04330009f, 0.10382138f, -0.12092609f, 0.00864328f, -0.11561827f, 
    0.09394001f, -0.05547133f, 0.11954602f, 0.09078649f, -0.17299299f, -0.11582018f, -0.10339968f, -0.09500760f, 
    -0.08533722f, 0.06634689f, -0.04598047f, -0.19456401f, 0.09987718f, -0.02618467f, -0.10624874f, 0.00654856f, 
    -0.02138163f, -0.11077358f, -0.06819326f, 0.02634415f, 0.01190904f, 0.02578332f, -0.09184100f, 0.01566944f, 
    -0.12220900f, -0.13009357f, -0.15163074f, -0.14019527f, 0.13933922f, 0.00823525f, -0.03389073f, 0.05173019f, 
    -0.25436229f, 0.05277425f, -0.08495675f, -0.19640665f, 0.05805539f, -0.14118077f, -0.04702451f, -0.16272466f, 
    0.17541423f, 0.04601077f, -0.04731462f, 0.06286936f, 0.01160862f, 0.02431101f, -0.07233063f, -0.05400345f, 
    0.07015458f, -0.19403604f, -0.04430922f, 0.01223386f, 0.04580707f, 0.06560966f, 0.12564103f, -0.24718870f, 
    -0.10174615f, -0.01207250f, -0.02682558f, -0.06252044f, -0.06836987f, -0.04750871f, 0.02043992f, 0.14474872f, 
    0.17714974f, -0.30946165f, -0.00755428f, -0.08877653f, 0.05268060f, -0.17151490f, 0.01629593f, -0.17053151f, 
    -0.04401246f, 0.11150344f, 0.07774306f, -0.18913123f, 0.06487557f, 0.01991785f, 0.02771923f, -0.14648919f, 
    0.10299531f, -0.23125362f, -0.06369948f, -0.07775896f, -0.15012896f, 0.01102524f, -0.02187140f, -0.15669037f, 
    0.12502670f, 0.10389573f, -0.05354737f, 0.00565514f, -0.05882735f, -0.12075068f, 0.07952587f, -0.19478525f, 
    0.07412434f, -0.23899530f, 0.08638516f, -0.17522693f, 0.25557369f, 0.14512751f, -0.00611205f, -0.11381561f, 
    0.12442908f, 0.05233373f, -0.20700379f, -0.19389607f, -0.24289659f, 0.12485899f, 0.03501020f, -0.13366066f, 
    -0.08810415f, 0.10860982f, 0.04489564f, -0.09774040f, 0.23739985f, -0.37221420f, 0.00020051f, -0.02693154f, 
    -0.11438490f, 0.18015939f, -0.07585549f, -0.20618190f, 0.15567571f, -0.09275981f, -0.09287095f, -0.05989315f, 
    -0.01241335f, 0.26089004f, -0.21897554f, -0.04516904f, 0.16219613f, -0.15485382f, 0.14949325f, 0.00780374f, 
    -0.17444640f, -0.01261313f, -0.01779148f, -0.03739439f, -0.03274104f, 0.07170056f, 0.06803574f, -0.01862574f, 
    -0.19203030f, -0.02388767f, -0.05273788f, -0.10635554f, -0.07697198f, 0.07060554f, 0.02709812f, 0.18557537f, 
    0.23241566f, 0.02363604f, 0.06710797f, -0.04781080f, 0.08786768f, -0.03425720f, 0.11977995f, 0.19954783f, 
    0.01712944f, -0.02405345f, 0.14977078f, -0.10026303f, -0.37249592f, -0.05297963f, 0.08548816f, -0.04702653f, 
    -0.02687915f, -0.10554973f, -0.00290446f, 0.05612743f, 0.03613633f, -0.02771809f, 0.12113449f, 0.08037573f, 
    -0.33206820f, -0.20378193f, -0.11302234f, 0.04325530f, 0.09442038f, -0.13013190f, 0.07504819f, 0.03149768f, 
    0.15038581f, 0.00852155f, -0.04854387f, 0.04484726f, 0.09020502f, -0.29383212f, -0.12105212f, -0.03604749f, 
    0.02360425f, 0.08591530f, 0.08075096f, 0.01855253f, -0.14432418f, 0.08366338f, 0.08925992f, 0.03596665f, 
    -0.11132762f, -0.47169453f, -0.10302356f, 0.16610296f, 0.00086458f, 0.10393029f, -0.06360921f, -0.03023537f, 
    0.20193946f, -0.01641553f, 0.17536919f, -0.08328895f, -0.06622607f, 0.09700108f, -0.21250936f, -0.16989316f, 
    0.27047870f, 0.03354077f, 0.14688262f, 0.04494466f, 0.08480519f, -0.03490683f, 0.03669100f, 0.20397578f, 
    -0.09804944f, -0.05366527f, 0.13713141f, -0.14717202f, -0.11733431f, -0.10106153f, -0.22536246f, 0.11683039f, 
    -0.03412330f, -0.13032909f, 0.09282085f, -0.00078750f, 0.19514960f, 0.10395610f, -0.02648889f, -0.11830278f, 
    0.15822542f, 0.09889026f, -0.01513413f, 0.07751042f, 0.13035302f, 0.04184856f, 0.16826117f, 0.02209013f, 
    -0.39433163f, -0.26546708f, 0.12382946f, 0.08557223f, -0.17666112f, -0.19009544f, 0.04872718f, 0.12755668f, 
    -0.09135418f, 0.00927169f, -0.05786907f, 0.03834480f, 0.31323424f, 0.15347049f, -0.02629212f, -0.09086493f, 
    0.07379170f, -0.09709346f, -0.02570302f, 0.01337062f, -0.00382120f, -0.00278999f, -0.04078729f, 0.17852528f, 
    -0.01877935f, -0.20857732f, -0.07369259f, 0.14817940f, -0.16119872f, -0.05808548f, -0.14854366f, -0.12465473f, 
    -0.07681289f, 0.04789988f, 0.02865400f, 0.04576404f, -0.05069957f, -0.10884082f, 0.04057493f, -0.09481525f, 
    0.17131531f, 0.12979572f, 0.00464200f, -0.04194985f, -0.03148316f, 0.10836645f, -0.02734881f, 0.09264296f, 
    0.08887710f, 0.07428515f, -0.03914670f, -0.39645195f, 0.14354597f, 0.10430821f, 0.16288154f, -0.03844275f, 
    -0.09122340f, 0.03220093f, 0.10069490f, 0.24561319f, 0.08455724f, -0.29508767f, -0.25099668f, 0.12353981f, 
    -0.16083889f, -0.19339646f, -0.10773800f, 0.03945672f, 0.02456089f, -0.09684503f, -0.12671018f, 0.05571166f, 
    -0.54477650f, -0.23683129f, 0.18898067f, -0.13877971f, -0.02492937f, 0.16541961f, 0.01736680f, 0.11806951f, 
    0.08169033f, -0.02310564f, 0.06057786f, -0.00539476f, 0.25073054f, 0.16899386f, 0.09968532f, -0.30243513f, 
    0.10275867f, 0.06126945f, 0.18117219f, 0.01247483f, -0.02503894f, -0.05446189f, -0.06936334f, -0.02824084f, 
    -0.07767020f, -0.01275499f, -0.04608712f, -0.07273772f, -0.07863866f, -0.02676068f, -0.06831609f, 0.02421827f, 
    -0.08223554f, 0.04348255f, -0.07408249f, 0.00263351f, 0.03662688f, -0.04451073f, -0.00970290f, 0.05974475f, 
    -0.07612126f, 0.03450355f, -0.02473055f, 0.03256225f, 0.01074625f, -0.06605886f, 0.05259972f, -0.05147095f, 
    -0.01536753f, 0.00896502f, 0.04515487f, 0.04971567f, -0.03577612f, -0.04412483f, -0.05403622f, 0.04170083f, 
    0.03399823f, -0.01677880f, -0.07582177f, -0.01522037f, -0.07045808f, -0.02111911f, -0.00370211f, -0.01781086f, 
    0.05632402f, -0.07823316f, -0.07411566f, -0.00740216f, -0.03316524f, 0.04045302f, -0.07404006f, 0.01054394f, 
    0.00587107f, 0.02303800f, 0.03364037f, -0.06077987f, -0.02687228f, -0.05149076f, 0.06448602f, 0.02324802f, 
    -0.06594822f, -0.02629013f, 0.05352788f, -0.02906333f, 0.04665833f, -0.02288668f, -0.01489625f, -0.06089950f, 
    0.02058318f, 0.04786056f, -0.03853962f, -0.03207684f, 0.00324472f, -0.06589504f, 0.04926160f, -0.05099011f, 
    -0.03555002f, -0.06933739f, -0.07754095f, 0.00816703f, -0.06164728f, -0.06178478f, 0.03900339f, 0.04379729f, 
    0.05842572f, 0.02299033f, -0.02728365f, -0.02563087f, -0.00032670f, -0.00758644f, 0.04705659f, 0.01359171f, 
    -0.03077665f, -0.03444220f, 0.04631237f, 0.00092967f, 0.05856801f, 0.02737084f, 0.04559699f, -0.07450466f, 
    0.05996672f, 0.05710219f, -0.02915241f, 0.00423959f, -0.00828179f, -0.00611031f, -0.02315489f, 0.01772876f, 
    0.05866655f, -0.06635051f, 0.02543285f, 0.04893491f, -0.04801872f, 0.01188231f, -0.00005316f, 0.03207396f, 
    -0.00404376f, 0.01978318f, -0.07285778f, 0.06073618f, -0.00536644f, -0.03926080f, 0.03827941f, -0.01942381f, 
    0.01602039f, -0.01963559f, -0.05041628f, -0.03201187f, -0.05789132f, -0.03822139f, -0.00725321f, 0.03488919f, 
    -0.07381190f, 0.00770687f, -0.04857722f, -0.04347877f, 0.03285437f, -0.05788109f, -0.04475135f, -0.02677725f, 
    -0.07078587f, 0.04774795f, 0.01234407f, -0.01756767f, 0.02683931f, -0.05847422f, -0.06622559f, -0.06458351f, 
    0.03546938f, -0.03742448f, -0.06078965f, 0.04070196f, -0.00440709f, 0.06556217f, -0.06097169f, 0.06260183f, 
    0.02058346f, 0.02294524f, -0.03147710f, -0.03772108f, -0.00826687f, -0.00399573f, -0.02666185f, -0.02914600f, 
    -0.07269429f, 0.01619179f, 0.04986082f, 0.04887347f, 0.04862460f, 0.04969068f, -0.03825086f, -0.03278552f, 
    0.04149802f, -0.04679788f, -0.05092208f, -0.02624700f, -0.04125436f, -0.03072159f, -0.01242468f, 0.00995790f, 
    0.05380477f, 0.05704381f, -0.02433533f, -0.03367835f, 0.04004378f, -0.05604884f, 0.00181734f, 0.03747554f, 
    0.03502299f, 0.03709714f, -0.04713196f, -0.07326699f, -0.05372363f, 0.00277996f, -0.00802329f, 0.03962833f, 
    -0.08375979f, 0.14930044f, 0.16779040f, -0.08116875f, 0.00422637f, 0.05342161f, -0.01951108f, -0.14768374f, 
    -0.02276476f, 0.00418153f, 0.06122957f, 0.06267568f, 0.22275135f, -0.05669650f, 0.26411107f, 0.03794204f, 
    0.02651156f, 0.02191132f, -0.02950738f, 0.04420480f, 0.00390032f, -0.14743021f, -0.08956760f, -0.05042653f, 
    0.26889542f, 0.07211070f, 0.06616650f, 0.08659083f, 0.07060074f, -0.06201037f, 0.09644685f, -0.01864300f, 
    -0.05871995f, -0.04639111f, 0.04769845f, 0.05393039f, 0.02167024f, -0.13745201f, -0.10646176f, 0.14303349f, 
    -0.03375398f, -0.03261564f, 0.01230324f, -0.15180430f, 0.14074418f, -0.04214780f, -0.09459839f, -0.00616104f, 
    0.13073528f, 0.01343666f, 0.22305232f, 0.08798634f, -0.08159974f, -0.15372159f, -0.11972583f, 0.03298660f, 
    -0.02654062f, 0.13889793f, 0.08310644f, -0.04757549f, -0.17748010f, 0.38791931f, -0.23843753f, 0.06833252f, 
    0.13701880f, -0.04737310f, 0.12196559f, -0.11369166f, -0.02380641f, 0.04414717f, -0.03437724f, 0.09294929f, 
    -0.22360720f, 0.06017365f, 0.25474608f, 0.16740412f, 0.01099001f, -0.06917058f, 0.09582567f, 0.00840514f, 
    0.16220579f, -0.07431300f, 0.02047271f, 0.06507520f, -0.08020658f, -0.04304030f, -0.04911101f, 0.05024519f, 
    -0.10173214f, 0.13222937f, 0.05454092f, 0.01412128f, -0.10030651f, 0.03177604f, -0.02614418f, 0.11033993f, 
    0.06553234f, 0.01006237f, 0.09217931f, 0.03841797f, -0.08220512f, 0.01986304f, 0.13477822f, -0.02960994f, 
    -0.07783891f, -0.05077124f, 0.05310392f, -0.03454311f, 0.07296725f, -0.02356835f, 0.01611717f, 0.13528827f, 
    0.09797693f, 0.08115552f, -0.06473852f, -0.01819785f, -0.07369101f, 0.00356553f, 0.10572322f, 0.11128646f, 
    0.05055954f, 0.03559564f, -0.06538660f, -0.00270175f, 0.15409344f, -0.10495745f, 0.07606528f, -0.06088983f, 
    0.05092376f, 0.11990616f, -0.00688240f, 0.12201241f, -0.26334313f, -0.11063084f, 0.12016112f, 0.01781133f, 
    -0.06660035f, 0.11103031f, 0.08696748f, 0.06261112f, 0.00215663f, -0.02548349f, -0.05306563f, -0.06195527f, 
    -0.24006948f, -0.00734250f, -0.02651694f, -0.10327116f, -0.06753960f, -0.04055262f, -0.13054244f, 0.06308182f, 
    -0.00497817f, -0.05508849f, -0.08850739f, -0.07675738f, 0.02800486f, 0.12605220f, 0.18075082f, 0.10025156f, 
    -0.01406217f, -0.06683559f, -0.04799493f, -0.03616598f, -0.12101820f, 0.10966215f, 0.03569163f, -0.03312350f, 
    -0.06480654f, 0.16318561f, 0.09592268f, -0.00658199f, -0.06692218f, 0.01601535f, -0.06870908f, 0.02044671f, 
    -0.15697522f, 0.11261800f, -0.10038621f, 0.17766427f, -0.23167567f, -0.03220254f, -0.28637737f, -0.14639798f, 
    0.16511919f, 0.05759671f, -0.15425070f, -0.07355051f, -0.02689289f, -0.01044410f, 0.02189507f, -0.03398773f, 
    -0.25901470f, 0.02825780f, 0.20455576f, 0.06915326f, 0.10722744f, 0.04130706f, -0.01021255f, -0.13010725f, 
    -0.00557912f, 0.07302547f, -0.04877666f, 0.05120823f, 0.05613927f, -0.02549208f, 0.00252150f, 0.12102080f, 
    0.12159202f, 0.00730937f, -0.11944599f, -0.05069575f, -0.05851601f, -0.13786298f, -0.00945055f, -0.11095807f, 
    0.26637208f, 0.06875832f, -0.06435357f, -0.06130160f, -0.09721304f, -0.01712070f, 0.01003361f, 0.03722587f, 
    -0.08274973f, 0.02652426f, -0.02261465f, 0.05584314f, 0.14901513f, -0.05226690f, -0.27950844f, 0.23551992f, 
    0.02582562f, -0.04640487f, 0.13425432f, 0.06288549f, 0.09743537f, 0.01794987f, -0.16317901f, -0.10416480f, 
    0.09905763f, -0.00881698f, -0.14584292f, -0.06851310f, 0.01280564f, -0.09053221f, -0.00771623f, 0.10974111f, 
    -0.01928542f, 0.06901218f, 0.00898199f, 0.05838379f, -0.33959371f, 0.17379411f, -0.17259921f, -0.08672920f, 
    0.10961822f, -0.01795787f, 0.04118092f, -0.00289384f, -0.02083797f, 0.03064914f, 0.12991093f, 0.06284669f, 
    0.04240939f, -0.07429565f, 0.07365767f, 0.06987362f, 0.00448509f, -0.01722834f, 0.13746090f, -0.02171775f, 
    -0.01137883f, 0.00459997f, -0.04795661f, 0.08949429f, -0.45509297f, -0.02028854f, -0.15122150f, 0.03844306f, 
    -0.00061989f, 0.01514430f, 0.18160529f, 0.01292045f, 0.03366216f, -0.09581802f, -0.10309188f, 0.01257270f, 
    -0.03737072f, 0.11090062f, -0.02503705f, -0.09728807f, -0.06080608f, 0.04578306f, 0.12821041f, -0.14879265f, 
    -0.15810867f, -0.13072209f, -0.00649576f, 0.01032566f, 0.08169507f, 0.03409771f, -0.04877381f, 0.06216946f, 
    0.03073701f, 0.16128443f, -0.00839362f, -0.03874770f, 0.01702889f, -0.06552051f, 0.03078155f, -0.17903036f, 
    0.42568114f, -0.05526359f, 0.03248299f, 0.11446211f, 0.01342657f, -0.01658574f, 0.04964556f, -0.14987187f, 
    0.06901553f, 0.11743335f, 0.06621885f, 0.01838523f, 0.04606895f, 0.10087567f, 0.06199786f, -0.06164147f, 
    0.12003492f, 0.13360621f, 0.11839857f, 0.06826594f, 0.07774858f, -0.01685743f, 0.00623556f, -0.07568809f, 
    -0.22698240f, 0.01026221f, -0.09352756f, -0.34719068f, 0.03163229f, 0.01878969f, -0.08935401f, 0.03150942f, 
    -0.01948175f, -0.00790279f, -0.07436837f, -0.14401843f, 0.33416116f, 0.02601778f, -0.02043606f, 0.12724534f, 
    -0.12344159f, -0.12237861f, -0.02771616f, -0.07889494f, -0.07132694f, 0.02999197f, 0.06611284f, 0.01999846f, 
    0.23054086f, -0.01624141f, -0.06875867f, -0.05909385f, 0.10058600f, 0.09008052f, -0.01780285f, -0.02105789f, 
    -0.12507081f, 0.16566695f, -0.19029304f, 0.06911777f, 0.17136654f, 0.07248712f, -0.21896215f, -0.08344290f, 
    0.04164447f, 0.04028848f, -0.09909520f, -0.07980151f, -0.02298114f, 0.08673942f, 0.09980611f, 0.10958830f, 
    -0.17477204f, 0.01839085f, -0.07405537f, 0.14086896f, 0.01283014f, 0.03653086f, -0.14794917f, 0.09767520f, 
    0.08070915f, -0.03704858f, 0.05303222f, 0.01019462f, -0.03684536f, -0.09241255f, -0.07055852f, 0.30084139f, 
    0.03274341f, 0.02264505f, -0.06553588f, -0.12146699f, -0.01876712f, 0.01736563f, -0.11049638f, -0.01571616f, 
    -0.21898054f, -0.04949912f, 0.19526587f, -0.05908874f, 0.03658465f, 0.10799571f, -0.06811650f, -0.13153213f, 
    -0.01878554f, 0.01950922f, -0.05525688f, 0.02104571f, -0.10417967f, 0.06045415f, 0.17961289f, 0.03278092f, 
    0.01032667f, 0.02709810f, -0.04056902f, 0.08399609f, -0.07711009f, -0.01305055f, 0.00619246f, 0.06776683f, 
    -0.02698108f, 0.12300744f, -0.14188507f, 0.11061123f, -0.04259740f, 0.04720042f, 0.10445549f, 0.06586103f, 
    -0.03899595f, 0.04252557f, -0.03623530f, -0.00734271f, 0.01753104f, -0.25637570f, 0.15023932f, -0.22380097f, 
    -0.08547632f, -0.03556963f, -0.05455103f, 0.11698533f, 0.12505770f, 0.08667707f, -0.00916098f, 0.04285950f, 
    0.34673691f, -0.18903293f, -0.35965091f, -0.03148513f, -0.04188971f, 0.06905923f, 0.03265110f, -0.11269452f, 
    -0.11793968f, -0.01686884f, -0.02022991f, -0.04236790f, -0.18905841f, 0.19929345f, -0.09909682f, -0.14638852f, 
    0.08001465f, -0.04946309f, -0.05642632f, -0.09546740f, -0.07038499f, -0.06117158f, -0.05865926f, 0.02318710f, 
    -0.01052016f, 0.05879973f, -0.16663246f, -0.00454119f, 0.05622869f, -0.10709847f, -0.00789962f, -0.02021235f, 
    0.03606823f, -0.05503818f, 0.08474663f, -0.09678629f, -0.07377525f, 0.17094195f, 0.17819671f, 0.20218845f, 
    -0.08553217f, 0.00341271f, 0.04054184f, 0.11639803f, 0.00807133f, 0.12508652f, 0.04295918f, -0.00564266f, 
    -0.26105106f, 0.17705990f, -0.02812674f, -0.04936613f, 0.07976411f, 0.01371626f, 0.08614130f, -0.04903113f, 
    0.00630763f, -0.01795151f, 0.09475242f, 0.05155559f, 0.23630431f, 0.22270052f, -0.06672944f, 0.19964948f, 
    -0.03825204f, -0.11797516f, -0.05223646f, 0.17877942f, -0.10644461f, 0.08980437f, -0.01750513f, 0.01667677f, 
    0.12917706f, 0.15578103f, 0.01335514f, -0.12260529f, -0.04486663f, -0.06211308f, 0.01623794f, -0.06904060f, 
    0.05166083f, 0.03988637f, 0.06796252f, 0.08581670f, -0.55854136f, 0.29724160f, -0.03797033f, -0.37380314f, 
    0.19675758f, 0.08688058f, 0.03357327f, 0.00656187f, 0.04932374f, -0.00830543f, 0.00099481f, 0.08087230f, 
    0.14858353f, -0.14157698f, 0.04736116f, 0.41159976f, -0.07514659f, -0.00814835f, 0.01430539f, -0.10810380f, 
    0.11715353f, 0.07900021f, -0.08580649f, 0.01866936f, 0.36047098f, 0.09869932f, 0.08359564f, -0.09374499f, 
    -0.06067716f, -0.06934975f, 0.03534317f, 0.01384169f, 0.02357237f, 0.04338575f, 0.06620839f, -0.05006856f, 
    -0.04018630f, -0.09459697f, -0.02954470f, -0.10186993f, -0.09496559f, 0.00025093f, -0.01154585f, -0.04538686f, 
    -0.07406097f, 0.02274450f, -0.04384407f, -0.04492567f, -0.07107884f, -0.08550784f, -0.04664549f, -0.03942594f, 
    -0.02096657f, -0.07475651f, 0.00463993f, -0.04401911f, -0.03539493f, -0.03836120f, -0.05053981f, 0.01664249f, 
    -0.09172716f, -0.04846651f, -0.02149982f, -0.07909862f, -0.02729921f, -0.07698065f, -0.06435958f, -0.04042905f, 
    0.04647598f, 0.01485834f, -0.07371692f, -0.06260409f, 0.01069434f, -0.03212757f, 0.01294795f, -0.00798254f, 
    0.03026291f, -0.04827582f, -0.03801214f, -0.01004802f, -0.02730570f, 0.00594316f, -0.03340195f, 0.02248366f, 
    -0.06675600f, 0.01097244f, 0.01273935f, -0.09537917f, -0.06943006f, -0.05412616f, -0.00064366f, -0.09576234f, 
    -0.02660756f, 0.04739649f, 0.01154450f, -0.09322002f, 0.01003914f, 0.02363171f, -0.00999149f, -0.06174083f, 
    -0.02758752f, -0.07837992f, 0.02745598f, 0.00881116f, -0.08080589f, 0.02464790f, -0.00364828f, -0.06600893f, 
    -0.01158250f, -0.00200674f, -0.08405784f, -0.06353940f, -0.08435155f, -0.01126998f, -0.05373386f, -0.03128802f, 
    -0.08800761f, -0.03655224f, -0.07192490f, -0.10138801f, -0.08541239f, 0.02006388f, -0.11105724f, 0.03324672f, 
    -0.07677323f, -0.09746714f, -0.01918356f, 0.02134659f, -0.08528697f, 0.04370427f, -0.01091272f, -0.07457748f, 
    -0.10331902f, -0.09354140f, 0.03408154f, -0.06811690f, 0.01892109f, -0.03677499f, -0.08706491f, 0.03292235f, 
    0.04880172f, -0.00989529f, -0.04507523f, -0.00904986f, 0.04039007f, -0.09258707f, -0.07798173f, -0.00888997f, 
    -0.10035725f, -0.00889796f, -0.00488059f, -0.05119720f, 0.04327702f, -0.03733497f, 0.01734461f, -0.00459996f, 
    -0.07899876f, 0.03791299f, -0.00030347f, -0.02869784f, 0.01459688f, -0.08357931f, -0.00144982f, -0.02625934f, 
    -0.07885344f, -0.02835181f, -0.04943695f, -0.05061436f, -0.01534157f, 0.01320343f, -0.09909803f, -0.05639855f, 
    0.01717361f, -0.01680565f, -0.01192810f, 0.00275052f, 0.01324387f, -0.02419535f, -0.09067518f, 0.01111428f, 
    -0.06877710f, -0.00656074f, -0.00795239f, 0.00321826f, -0.04198764f, -0.04082914f, 0.03016340f, 0.00938304f, 
    -0.00747938f, 0.03937874f, -0.08490450f, -0.07187177f, -0.04856111f, -0.04540761f, 0.03009071f, 0.00816835f, 
    -0.10394761f, -0.10713396f, -0.05523369f, 0.00758589f, 0.01526532f, 0.01817415f, -0.10159189f, 0.02086954f, 
    -0.07187578f, -0.02990788f, -0.03728036f, -0.08784337f, -0.04199293f, -0.09403104f, -0.08268900f, -0.03864749f, 
    -0.01633901f, -0.03777991f, -0.05524825f, 0.00642846f, 0.02372791f, -0.08326304f, -0.04263448f, -0.06919279f, 
    -0.06936423f, 0.02354333f, -0.09062131f, -0.00370855f, 0.01607145f, -0.01731776f, -0.03868594f, -0.06242321f, 
    0.15935148f, 0.23167750f, -0.02847379f, 0.04274293f, 0.02516979f, 0.08784885f, 0.11455344f, -0.05557629f, 
    -0.04742393f, 0.20931967f, 0.11819931f, 0.08796635f, 0.31333280f, -0.05209045f, -0.02457543f, 0.34648404f, 
    -0.02715829f, -0.07208464f, -0.12064444f, -0.00452776f, 0.01036527f, -0.07603177f, -0.07448521f, -0.02808647f, 
    0.13858269f, -0.25391480f, 0.06220744f, -0.21531397f, 0.08806536f, 0.02207247f, 0.04121074f, -0.04245217f, 
    -0.09820721f, 0.10865360f, 0.08692852f, 0.00680497f, -0.25432059f, 0.07719754f, -0.06994359f, 0.27714959f, 
    -0.04438034f, -0.06745307f, -0.08904313f, -0.07532305f, 0.04302321f, -0.21731387f, -0.02735962f, -0.08630087f, 
    0.06389820f, 0.12470219f, 0.14344579f, 0.09811393f, 0.03181027f, -0.03492533f, 0.03624751f, 0.05886482f, 
    -0.05731393f, 0.06425443f, -0.01013166f, 0.02087460f, -0.02548936f, 0.21616802f, 0.01683817f, -0.38874063f, 
    0.03633951f, 0.10046413f, 0.04639629f, -0.17387898f, -0.00456806f, -0.09772059f, -0.00080691f, -0.02923310f, 
    -0.44837475f, 0.02812949f, 0.00933974f, 0.31314412f, -0.06535091f, 0.09299387f, 0.03106215f, -0.06756786f, 
    0.04791322f, -0.00436062f, 0.02845004f, 0.03351879f, -0.04024831f, 0.05837522f, -0.02230296f, 0.05936844f, 
    -0.04437863f, 0.00758899f, 0.03616850f, -0.06809371f, -0.05658277f, 0.06000244f, 0.04098542f, 0.07841893f, 
    0.18227434f, 0.24897441f, -0.10798935f, 0.04823805f, -0.01223824f, 0.03794412f, -0.02023081f, -0.07114577f, 
    -0.03653579f, 0.01171428f, 0.00563201f, -0.08404062f, 0.20890626f, -0.31014511f, 0.05653480f, 0.01441011f, 
    -0.09359442f, -0.03180332f, 0.04003894f, -0.03992695f, -0.10782643f, -0.08187944f, 0.06221566f, -0.01734921f, 
    0.09232641f, 0.05303329f, 0.11608467f, -0.27440903f, 0.06795909f, 0.01299539f, 0.10563409f, 0.02946251f, 
    0.13844720f, -0.01357178f, 0.00782192f, 0.09848158f, -0.27791387f, 0.10277351f, -0.16452259f, 0.12333636f, 
    -0.03830661f, -0.05007994f, -0.13300622f, -0.08271825f, 0.05318377f, 0.03515753f, -0.03993616f, -0.03948972f, 
    -0.05931837f, 0.13810922f, 0.26023236f, -0.20078593f, 0.01559864f, 0.03031127f, 0.02857358f, -0.07501525f, 
    -0.04191611f, -0.04928258f, 0.02565891f, -0.07764646f, -0.00562652f, -0.12809044f, 0.30134872f, -0.04049113f, 
    0.10622590f, 0.03391729f, -0.02370441f, -0.01343849f, -0.07141214f, 0.10516687f, 0.15066037f, 0.03337245f, 
    0.22295038f, 0.01350813f, 0.01710301f, 0.36815292f, -0.02159860f, 0.05059365f, -0.15429707f, 0.01278197f, 
    0.01312367f, -0.06583854f, 0.06352998f, 0.10142387f, -0.17795645f, -0.02197488f, -0.04550253f, -0.08765998f, 
    0.10235448f, 0.01545589f, 0.01620368f, -0.04689584f, -0.03929062f, -0.07433778f, -0.00190634f, 0.08352096f, 
    0.06715877f, -0.07020883f, -0.15838915f, 0.03350323f, 0.05548966f, -0.01708287f, -0.03658431f, 0.08529174f, 
    -0.10020672f, -0.04635826f, 0.09944763f, 0.01664438f, -0.16025330f, 0.10473019f, -0.10468310f, -0.26026240f, 
    -0.00096353f, -0.12000010f, -0.03949497f, 0.00041931f, -0.03590844f, 0.04730130f, 0.00711292f, 0.02144753f, 
    0.14240502f, 0.07958557f, 0.03865846f, 0.04098268f, -0.12158110f, 0.01057629f, 0.06588689f, 0.05826951f, 
    0.13450815f, 0.06224088f, -0.11279907f, 0.00605130f, -0.09081544f, 0.05405738f, 0.03518065f, -0.15215676f, 
    0.06041440f, -0.00680641f, 0.05146144f, 0.15049797f, 0.03479918f, -0.06339198f, 0.08152916f, 0.07659271f, 
    -0.04764336f, -0.06401956f, 0.00421717f, -0.30785230f, 0.01622464f, 0.08895746f, 0.04415109f, -0.05360748f, 
    -0.03085522f, 0.15218244f, -0.05827646f, 0.03267245f, 0.44920325f, -0.15497114f, 0.11022707f, 0.21434194f, 
    -0.00607417f, -0.02316310f, -0.02957097f, 0.02101482f, -0.05449558f, 0.07448190f, -0.05996438f, 0.01476616f, 
    0.17569548f, -0.08051073f, -0.00225322f, -0.04090561f, -0.00288684f, 0.01449504f, 0.02737611f, 0.02109968f, 
    -0.08586054f, 0.16967954f, -0.03962687f, 0.08577529f, 0.08470332f, 0.08397636f, 0.06697486f, 0.01547441f, 
    0.03974340f, -0.05249899f, 0.03856821f, 0.01132941f, 0.01244772f, 0.00952447f, 0.13060625f, -0.01153838f, 
    -0.24724311f, -0.19561581f, 0.05222828f, -0.03080957f, 0.11887858f, -0.02809012f, 0.09505700f, 0.08690275f, 
    0.13301882f, -0.02432133f, 0.10020274f, 0.02199180f, -0.02779174f, 0.09022843f, -0.02420052f, -0.00293574f, 
    -0.06459564f, -0.09355457f, -0.03186614f, -0.04043404f, -0.04469670f, 0.15150635f, -0.06353879f, -0.17449859f, 
    -0.16262591f, -0.08406732f, -0.04461971f, -0.10848177f, -0.07608374f, -0.07958633f, -0.11601292f, -0.00449029f, 
    0.04955421f, -0.04165577f, 0.12739499f, -0.07885766f, 0.18169478f, -0.07540870f, 0.15141036f, -0.18623528f, 
    0.03491147f, 0.02711167f, 0.01730332f, 0.03952266f, -0.02865702f, -0.02217946f, 0.09185359f, 0.05885651f, 
    0.36118090f, 0.19028592f, -0.07040866f, 0.27443776f, -0.03070837f, 0.04069507f, 0.13482569f, 0.02803671f, 
    0.11356659f, -0.03230187f, -0.02728425f, -0.07653519f, -0.30263901f, 0.12412282f, -0.07295152f, 0.03189166f, 
    -0.02188737f, 0.09928379f, 0.05062914f, 0.03148794f, 0.08786569f, -0.03248978f, 0.04927678f, 0.04089652f, 
    -0.08522274f, 0.01231644f, 0.12456361f, -0.27727312f, -0.04992929f, 0.05976938f, -0.01550874f, 0.03021783f, 
    0.02072797f, -0.01911549f, -0.00364722f, 0.00296520f, 0.32478544f, 0.19602942f, 0.18682039f, 0.17312099f, 
    -0.18241203f, -0.03565963f, 0.09108917f, 0.01004433f, 0.15144987f, 0.18219438f, 0.00530107f, 0.14558540f, 
    -0.25268418f, -0.04096845f, 0.14269009f, 0.10513301f, -0.03483810f, -0.05738772f, -0.01631285f, -0.07402490f, 
    0.06683508f, -0.12715271f, -0.12048183f, 0.06710291f, -0.21677443f, 0.00130248f, 0.03297353f, -0.07932221f, 
    0.07383583f, -0.03042151f, -0.06122934f, 0.05008621f, -0.04042684f, 0.00364210f, -0.02664033f, -0.03974009f, 
    0.36513087f, 0.23967136f, -0.03115723f, 0.41420344f, 0.08601854f, 0.07861347f, 0.04601510f, -0.09499591f, 
    0.03736009f, 0.02797369f, -0.06600409f, 0.04052629f, 0.14568834f, -0.10451584f, -0.03368790f, -0.24712224f, 
    0.01994784f, 0.08648341f, 0.03075706f, 0.00766536f, 0.13860257f, -0.07431906f, -0.02030229f, -0.05787004f, 
    -0.03450114f, -0.32266212f, -0.02567016f, -0.12512302f, 0.11476384f, 0.04518312f, -0.09714927f, 0.09233008f, 
    0.10295443f, 0.01672513f, -0.02305259f, 0.00441697f, -0.14001730f, 0.10909688f, -0.11625557f, 0.15751722f, 
    0.02067703f, 0.07224973f, -0.05494001f, 0.04634537f, -0.13951157f, 0.08472997f, -0.02573653f, 0.08116048f, 
    0.27781743f, 0.13641682f, 0.00748373f, -0.28733715f, 0.06430531f, -0.01731237f, 0.01240105f, -0.01011622f, 
    0.00609599f, 0.05898119f, 0.03904924f, 0.00025119f, -0.06873093f, -0.03126289f, 0.12736936f, 0.04438294f, 
    0.03128772f, 0.00978754f, 0.10696072f, 0.10361952f, 0.18472695f, -0.00119210f, -0.10999459f, 0.08332026f, 
    -0.06421951f, -0.40418372f, -0.04521313f, -0.12565383f, 0.03748249f, 0.10056283f, 0.09188554f, -0.06391995f, 
    0.02425396f, 0.03916913f, 0.09243638f, 0.02560617f, -0.04055639f, 0.14390858f, -0.12397405f, 0.10607099f, 
    0.10081467f, 0.20016028f, -0.10565720f, -0.07393323f, 0.02646526f, -0.05099426f, -0.02156769f, -0.11082290f, 
    0.07079037f, -0.11535748f, -0.06903541f, 0.19247442f, -0.16005851f, -0.00183377f, -0.17606403f, 0.00641245f, 
    -0.05452388f, -0.00023448f, -0.06864562f, -0.00392084f, 0.03530817f, -0.10739836f, 0.21205154f, -0.15865646f, 
    -0.00891048f, 0.02999166f, -0.01238978f, 0.16920309f, -0.07837643f, -0.06421930f, 0.15268983f, -0.09732287f, 
    0.13456297f, 0.13187958f, 0.00273683f, -0.07461337f, -0.09621649f, 0.01033507f, 0.04092678f, 0.12576769f, 
    -0.05836547f, 0.11800849f, -0.10564079f, -0.03067861f, 0.43233591f, 0.02106861f, -0.27350447f, -0.08918915f, 
    0.07492606f, 0.07313005f, -0.03969464f, -0.01124070f, -0.09391127f, 0.08587139f, -0.00440863f, 0.02861359f, 
    -0.09266268f, 0.05232285f, 0.24264787f, -0.23574351f, 0.05530019f, -0.05341861f, 0.02349995f, 0.06141591f, 
    -0.14471121f, -0.03343593f, -0.13149734f, -0.05122444f, 0.08812912f, 0.02728000f, 0.14139506f, 0.04377184f, 
    -0.13324352f, -0.01689947f, -0.07892986f, -0.05232218f, -0.00491264f, -0.00155066f, 0.01496287f, -0.00217601f, 
    -0.05058138f, 0.01263727f, -0.03141919f, -0.00748508f, 0.03454839f, -0.05077922f, -0.00454858f, -0.00030125f, 
    0.01923900f, 0.02890707f, -0.02436295f, 0.03820402f, 0.03376257f, -0.03138211f, -0.03943058f, -0.06430152f, 
    0.03129214f, -0.03180122f, 0.04297949f, -0.07276431f, -0.07410812f, 0.00716380f, -0.07056912f, 0.03921071f, 
    -0.07310115f, -0.00575939f, -0.05502577f, -0.03306514f, -0.01011722f, 0.04073174f, -0.03274402f, -0.00004504f, 
    0.03651081f, -0.00780591f, 0.02262634f, 0.04493145f, -0.06448255f, -0.06441143f, 0.02649176f, -0.01530080f, 
    -0.04674186f, -0.03654967f, -0.05221697f, 0.01753997f, 0.01693740f, 0.05927429f, 0.01936304f, -0.04265358f, 
    0.02635312f, 0.03018627f, 0.00205632f, 0.00169704f, -0.03363292f, -0.03842840f, 0.01620625f, -0.05624704f, 
    -0.05847380f, -0.04534369f, -0.01191993f, -0.05861308f, -0.05390193f, -0.01180306f, -0.00083729f, 0.03373078f, 
    -0.01775050f, -0.06456495f, -0.03967886f, 0.04466357f, -0.02813369f, -0.03578128f, -0.01945771f, -0.07434985f, 
    0.01717697f, -0.06465703f, -0.06927228f, -0.00578030f, 0.02494492f, -0.01267451f, -0.01087323f, -0.02355282f, 
    -0.03741117f, -0.06033739f, -0.00031442f, -0.01903917f, -0.01602918f, -0.03830843f, -0.02078619f, -0.01982065f, 
    0.00776508f, 0.03698360f, 0.05662346f, -0.02976223f, -0.07234728f, -0.00137506f, 0.01250240f, 0.05791409f, 
    0.01567188f, -0.01108901f, -0.04067820f, 0.01205629f, -0.04706172f, 0.04318189f, 0.05302471f, -0.02098902f, 
    -0.01620800f, -0.01458674f, -0.03992912f, 0.04282779f, -0.00759546f, -0.00181846f, -0.01535846f, -0.04301343f, 
    0.04134300f, -0.04172701f, 0.00923215f, -0.05101813f, 0.05909858f, -0.07578764f, -0.00925582f, 0.03565847f, 
    -0.03201948f, 0.00187193f, 0.01917194f, -0.05892882f, 0.00264388f, 0.00234371f, 0.00946098f, 0.03424862f, 
    0.05230624f, -0.01411029f, 0.01887627f, -0.04140183f, 0.05936803f, -0.02126209f, -0.05834108f, -0.01809573f, 
    0.05006387f, 0.03046431f, -0.02245441f, 0.00562767f, -0.05360278f, -0.02760851f, 0.03205467f, 0.01941085f, 
    -0.02959454f, 0.00846075f, -0.02670906f, 0.02540607f, -0.00866026f, -0.00388484f, -0.03810241f, -0.00137410f, 
    0.01079316f, -0.02622769f, -0.03573338f, -0.01444491f, -0.00126808f, 0.05656418f, -0.07152801f, 0.03664048f, 
    0.06399070f, -0.02605491f, 0.03680252f, -0.00248599f, -0.04821599f, -0.06676909f, 0.00377110f, 0.01681418f, 
    -0.06267151f, -0.00683808f, -0.03209269f, -0.01774375f, 0.00669860f, 0.05361083f, -0.07064362f, 0.03233070f, 
    -0.04557453f, -0.06315911f, 0.02021241f, -0.05595265f, -0.05171263f, 0.03181836f, 0.00653746f, -0.04694694f, 
    0.06551722f, -0.03864001f, 0.02418105f, 0.01391420f, -0.00267922f, 0.01779055f, 0.00522783f, -0.01283325f, 
    0.03644587f, 0.06209062f, -0.06201250f, 0.03046971f, -0.04329963f, -0.03360238f, -0.02242452f, 0.00810046f, 
    -0.07322927f, 0.03745391f, 0.03053037f, 0.04684088f, 0.01843772f, -0.01044452f, -0.02791810f, -0.00024546f, 
    -0.02170714f, -0.00388651f, 0.05949891f, -0.05144665f, -0.04550491f, -0.00601892f, -0.01932590f, 0.00262981f, 
    -0.01099508f, 0.01415332f, -0.03220780f, 0.03857787f, 0.00595634f, -0.00043208f, 0.00441118f, -0.02297807f, 
    0.05816358f, -0.02067348f, 0.02890906f, -0.06628015f, 0.01174801f, -0.00066335f, 0.00706686f, 0.02998823f, 
    -0.05370693f, -0.01093194f, -0.06438142f, 0.04299629f, -0.05215720f, 0.00703211f, -0.04941504f, 0.01688167f, 
    0.02007463f, -0.03309627f, -0.04982413f, 0.06153333f, 0.05511974f, 0.04106505f, -0.00167268f, -0.08055366f, 
    0.00346569f, 0.03568233f, -0.01855591f, 0.00977055f, 0.01790652f, -0.05810813f, 0.02330838f, 0.05666627f, 
    0.03411710f, 0.02033285f, 0.03293777f, -0.02672047f, 0.03167393f, -0.00983719f, -0.07547027f, -0.01296915f, 
    -0.03612838f, 0.06025627f, 0.03963942f, -0.03338976f, 0.03085928f, -0.04906041f, 0.03137789f, -0.04683172f, 
    -0.07848746f, -0.00377112f, -0.03914906f, 0.02771526f, -0.01860812f, 0.04950460f, -0.07834695f, -0.04367783f, 
    -0.00164172f, 0.01850234f, 0.05841622f, -0.03439619f, 0.01712456f, 0.05210679f, -0.02414848f, 0.05547183f, 
    -0.01690311f, -0.06427522f, -0.00889163f, 0.00789382f, 0.03054871f, 0.01255283f, 0.05291028f, -0.03127200f, 
    -0.02891483f, 0.00077614f, 0.05531500f, -0.00850657f, 0.04981412f, 0.05324858f, 0.01380828f, -0.03471627f, 
    0.02351982f, 0.02255799f, -0.02698908f, -0.03900313f, -0.02515282f, 0.04501212f, 0.06115283f, 0.04473945f, 
    -0.04719920f, -0.04660245f, -0.00579447f, -0.07033239f, 0.03352384f, 0.06061300f, -0.05999347f, -0.00356193f, 
    0.04126053f, -0.00860817f, -0.02257304f, -0.03936303f, -0.05194120f, -0.04373154f, -0.01336236f, -0.04355181f, 
    -0.06350749f, -0.03545231f, -0.03552965f, -0.07294081f, 0.04388129f, -0.07667984f, -0.00802763f, 0.05564184f, 
    -0.08076674f, -0.01862529f, 0.00063811f, 0.02854982f, -0.04815493f, -0.03070630f, 0.04462441f, -0.02227009f, 
    -0.07824113f, -0.04064334f, 0.03519799f, -0.01605160f, -0.04309604f, -0.01050178f, -0.01750312f, 0.02872013f, 
    -0.02203245f, 0.05521175f, 0.00642262f, 0.00021469f, -0.05041876f, -0.00048562f, 0.04956007f, -0.01145067f, 
    -0.00655793f, -0.00472257f, -0.05855708f, -0.05671383f, -0.05910236f, -0.03440278f, -0.02101275f, -0.00308929f, 
    0.02769535f, -0.00834231f, -0.07446063f, -0.02320359f, 0.02421273f, -0.02533584f, -0.04374680f, -0.03519105f, 
    0.00785937f, -0.06242009f, -0.06929012f, -0.01116741f, -0.01266242f, -0.01436511f, 0.01050417f, 0.06946941f, 
    0.02097797f, 0.13792586f, 0.15407363f, 0.03470618f, -0.01678173f, -0.03333819f, 0.03033748f, 0.02371956f, 
    0.05878072f, 0.08715332f, -0.00552775f, -0.03617552f, -0.07500000f, -0.11361922f, -0.21404503f, 0.30221531f, 
    0.03306119f, -0.01562749f, -0.03532339f, -0.14397565f, 0.04842280f, 0.09272751f, 0.02130525f, 0.07864006f, 
    -0.29009175f, -0.32464570f, 0.12433939f, -0.03746685f, 0.07110353f, 0.13680798f, -0.07258616f, -0.02676841f, 
    -0.00236936f, 0.09386227f, 0.02262838f, 0.05542274f, 0.05594370f, 0.19234057f, -0.06964016f, -0.04626133f, 
    0.03993570f, 0.11063464f, -0.04540337f, -0.02867252f, -0.13405493f, 0.02048346f, 0.08774474f, 0.09775060f, 
    0.07846490f, 0.15082914f, -0.31162825f, 0.03610049f, 0.03124423f, 0.12094534f, 0.08024357f, -0.04084250f, 
    -0.00288849f, 0.00746737f, -0.00824993f, 0.03217555f, -0.26860845f, -0.03820441f, 0.25996298f, -0.34461561f, 
    0.05800859f, 0.05922634f, 0.04334256f, 0.07736093f, 0.11388197f, -0.03229073f, 0.09073627f, -0.01692938f, 
    0.02258500f, -0.04187178f, -0.35681570f, -0.01499711f, -0.01397226f, 0.02080567f, 0.02239443f, -0.07623608f, 
    -0.10237176f, -0.07211533f, -0.01990762f, -0.07544128f, 0.04534642f, 0.19898027f, -0.03083027f, 0.11287110f, 
    0.22430879f, 0.09740094f, -0.13290922f, 0.00471551f, 0.12397749f, -0.08560471f, 0.06209567f, -0.04412205f, 
    -0.03001458f, 0.12118595f, -0.06953387f, 0.01401570f, 0.15107438f, -0.09156767f, -0.12123124f, -0.03937370f, 
    0.08744271f, 0.04476915f, 0.03638140f, -0.10734341f, 0.23251778f, -0.10037478f, -0.04350496f, -0.12693946f, 
    0.08971664f, 0.06457245f, 0.03302975f, 0.17196600f, 0.07844486f, 0.10264578f, 0.00396452f, 0.01706851f, 
    0.06254528f, 0.00398829f, 0.04424465f, -0.03165647f, -0.08175357f, 0.06886249f, 0.05135043f, 0.00950545f, 
    -0.05529707f, 0.10537824f, -0.02095644f, -0.04004155f, 0.17839934f, 0.29336751f, -0.21396230f, 0.01254502f, 
    0.01710936f, -0.07995579f, -0.01006109f, 0.05565869f, -0.02327564f, 0.04259584f, -0.05990609f, 0.12345486f, 
    0.07117041f, 0.02209182f, 0.20648007f, -0.21650803f, 0.23672928f, 0.00089927f, 0.02823018f, -0.04575609f, 
    -0.01416865f, 0.18027587f, 0.15720125f, 0.11987387f, 0.09404299f, -0.20983151f, -0.00337263f, -0.12544480f, 
    0.01415301f, -0.00526831f, 0.00335894f, -0.03907507f, 0.11807109f, -0.09103296f, -0.02548080f, 0.00817435f, 
    0.03281148f, -0.08168504f, -0.15635248f, 0.20416452f, 0.03129253f, -0.01630186f, 0.07072290f, 0.02451607f, 
    0.04086190f, 0.03868187f, 0.08520966f, -0.02697499f, 0.28593320f, 0.01630596f, 0.07169726f, -0.13439523f, 
    0.06429184f, -0.00558679f, 0.00480665f, 0.00570947f, 0.09752972f, -0.11932867f, 0.05964116f, -0.04517161f, 
    -0.05879414f, -0.00482761f, -0.05143515f, 0.04063373f, -0.01185819f, 0.04270621f, -0.04825959f, 0.04049086f, 
    -0.02768597f, 0.04061909f, -0.04049573f, 0.00721195f, 0.03044422f, -0.06297735f, -0.02870588f, 0.01629133f, 
    -0.02655818f, 0.02993731f, -0.03501742f, -0.04899232f, -0.07641838f, -0.04719860f, 0.02839193f, 0.01978808f, 
    -0.04907899f, 0.00922220f, -0.02476306f, 0.04181679f, -0.04485388f, -0.00973956f, -0.08018202f, -0.07376324f, 
    0.01597441f, 0.00464479f, -0.04477210f, 0.01620068f, 0.02738793f, 0.06369031f, -0.05725758f, -0.02211780f, 
    -0.07702812f, 0.00688850f, 0.05208122f, -0.02291996f, -0.02997158f, 0.03319970f, -0.07490189f, 0.03607649f, 
    -0.04056785f, -0.07597757f, 0.06599541f, -0.03632259f, 0.05102804f, -0.05070871f, 0.00062932f, 0.03534493f, 
    -0.00342368f, 0.02371432f, -0.03393318f, 0.00599005f, -0.02519786f, -0.03733901f, -0.04761829f, -0.07594845f, 
    0.03618541f, -0.04254807f, -0.04857921f, 0.02014362f, 0.05618443f, -0.04671539f, -0.01127991f, -0.00298960f, 
    0.04300182f, 0.05917381f, 0.06023176f, 0.02324805f, -0.04942439f, -0.01169832f, 0.00361704f, -0.07877046f, 
    -0.01000192f, -0.00349367f, -0.00236858f, 0.00033997f, 0.04980467f, 0.02905742f, 0.04854903f, -0.01773483f, 
    -0.04745608f, 0.05409790f, -0.06776263f, -0.06370012f, 0.02584948f, 0.00003570f, -0.01325041f, 0.01095704f, 
    -0.02910252f, 0.01599968f, -0.04162380f, 0.02115281f, 0.06160997f, 0.04950431f, 0.04591997f, -0.02597587f, 
    -0.06006751f, 0.05591105f, 0.02812918f, -0.01576536f, -0.02489560f, -0.06691709f, 0.05273651f, -0.06856214f, 
    -0.01187468f, 0.03202297f, -0.05726703f, 0.04653277f, 0.02623708f, 0.01334533f, 0.04269041f, -0.06835803f, 
    0.05470211f, -0.03098781f, -0.01830956f, 0.02883806f, -0.06774534f, 0.02934843f, -0.06946786f, 0.01883768f, 
    -0.04407484f, -0.04468618f, 0.00068468f, -0.06547505f, 0.05041904f, 0.05857890f, -0.03444200f, -0.02511235f, 
    -0.05474760f, 0.03612990f, 0.04378348f, -0.03206293f, -0.00369551f, -0.02684606f, 0.01704322f, 0.06342912f, 
    -0.00390250f, -0.06798957f, -0.03480295f, -0.01205959f, 0.00212669f, 0.05831396f, -0.07552780f, 0.03466615f, 
    -0.07541879f, 0.00525381f, 0.05855181f, -0.07154435f, 0.02134889f, -0.04828211f, -0.06528902f, 0.02408412f, 
    0.03005444f, -0.02792602f, -0.06446150f, -0.05731872f, 0.03691225f, -0.05551719f, -0.01647185f, -0.05784968f, 
    0.03869266f, -0.06404296f, -0.04490015f, -0.05900153f, 0.01885102f, -0.01641277f, 0.00899303f, 0.01328754f, 
    0.02876122f, -0.06253242f, -0.07071669f, -0.01970840f, 0.06281042f, 0.03614605f, 0.02750123f, -0.08133309f, 
    0.05095467f, -0.07381496f, -0.03840405f, -0.03680883f, 0.05576790f, 0.00364036f, 0.01423415f, -0.04663195f, 
    -0.08595351f, -0.23368086f, -0.03998327f, 0.16365208f, 0.01475388f, 0.02516332f, 0.00215743f, 0.00089699f, 
    0.09918413f, -0.12638739f, -0.00596611f, 0.08269242f, -0.08742101f, -0.07701583f, 0.14742346f, -0.13730551f, 
    0.04644336f, 0.09931605f, 0.11204506f, -0.12111627f, 0.13779467f, 0.10517254f, -0.01168698f, -0.01175115f, 
    0.15907015f, 0.03475352f, 0.08980451f, 0.08338955f, 0.11867673f, -0.07680592f, 0.03609847f, -0.04598243f, 
    0.06063297f, 0.04240292f, -0.07379698f, -0.18598090f, -0.01868090f, 0.05546778f, 0.15058902f, -0.15710175f, 
    0.00433763f, 0.05983533f, -0.07671425f, -0.03179084f, -0.00225863f, -0.01923996f, 0.21451303f, 0.12410537f, 
    -0.14995711f, 0.02657858f, 0.29469991f, 0.07946007f, -0.11374485f, 0.13629635f, 0.00021682f, 0.01754536f, 
    0.12840700f, -0.09875438f, -0.09844410f, -0.09578404f, 0.01628950f, -0.32421896f, -0.06472678f, 0.28416994f, 
    -0.15013418f, -0.11043254f, -0.04421724f, 0.03901843f, -0.00175534f, 0.14192945f, -0.08893420f, -0.01850569f, 
    0.23005117f, 0.18154871f, -0.13098162f, -0.11956743f, 0.05946664f, 0.03357553f, 0.02374165f, -0.06929792f, 
    0.06408957f, -0.12891561f, 0.00681703f, -0.06432994f, 0.11438988f, -0.23091131f, 0.09316015f, -0.25227210f, 
    -0.13052289f, -0.05199977f, -0.21515273f, -0.02838957f, 0.11526372f, 0.17617179f, -0.09307007f, 0.07893912f, 
    0.14533995f, -0.10530585f, 0.03261339f, -0.01350498f, 0.03693472f, 0.08378381f, 0.08390075f, 0.15002891f, 
    0.04350309f, 0.11888248f, 0.10959253f, 0.08153119f, -0.31655905f, 0.13599096f, 0.06225906f, -0.01786866f, 
    0.04141631f, -0.04581733f, 0.08273916f, -0.06188995f, -0.01672682f, 0.00006042f, -0.11203599f, 0.20760863f, 
    -0.25443313f, 0.13260943f, 0.07783759f, 0.04368147f, -0.05267135f, -0.04669910f, -0.08187304f, 0.05510078f, 
    0.12638617f, -0.17456956f, 0.03407399f, 0.02042617f, 0.02805648f, -0.06940269f, 0.19253422f, 0.21714823f, 
    -0.12091427f, -0.01249551f, -0.13116488f, 0.05720507f, -0.10107881f, -0.07117226f, 0.10961881f, -0.03903767f, 
    -0.17470436f, -0.10641291f, -0.00854557f, 0.24890947f, -0.00702175f, -0.03434397f, -0.07785627f, 0.01681354f, 
    -0.00644372f, -0.08307558f, -0.16352831f, -0.01530559f, -0.00578330f, 0.14673960f, 0.00975755f, -0.17311583f, 
    0.03142262f, 0.13053703f, 0.05109820f, 0.07986033f, 0.13606691f, -0.04189040f, 0.02268343f, 0.11414929f, 
    0.09909733f, 0.11494058f, 0.08158255f, 0.02985631f, -0.08301830f, -0.05535213f, 0.00205340f, -0.01474617f, 
    -0.04757423f, 0.00284850f, -0.04803997f, -0.09037231f, -0.16443805f, -0.15060337f, 0.07428204f, 0.05256612f, 
    0.03730353f, -0.09291214f, -0.01972231f, -0.04738560f, 0.04603796f, -0.09616964f, -0.12178949f, -0.18600757f, 
    -0.06181999f, 0.04550339f, 0.08115883f, -0.13894638f, 0.05242046f, -0.04223507f, -0.03568170f, 0.02273014f, 
    0.06247764f, -0.06077377f, 0.06253915f, 0.03226853f, 0.09863438f, 0.15940514f, 0.07119379f, -0.26695424f, 
    0.13579379f, 0.00270608f, 0.08163892f, 0.03070177f, -0.08030091f, -0.11482686f, -0.00356699f, 0.07603923f, 
    -0.07002792f, 0.12556797f, 0.01897059f, -0.03829501f, -0.18116403f, 0.01591288f, -0.00651523f, 0.05464724f, 
    -0.02468190f, -0.01526462f, -0.07195737f, -0.00212614f, 0.13290402f, -0.08663386f, -0.22809884f, -0.03409641f, 
    0.09031024f, -0.09539612f, 0.04656749f, -0.05015184f, -0.00605322f, 0.09895831f, 0.08479804f, 0.17161055f, 
    -0.10886466f, -0.04743473f, 0.04000618f, -0.02113264f, -0.06588861f, -0.03705694f, 0.01169734f, -0.10313892f, 
    -0.09401969f, 0.12093993f, 0.10250288f, 0.03951781f, -0.06261963f, -0.16140436f, -0.13378821f, 0.27657980f, 
    0.25481659f, -0.03374069f, 0.02336829f, 0.01552578f, 0.07616846f, -0.00926784f, 0.09884300f, 0.04658602f, 
    0.35012299f, 0.09614549f, 0.25659454f, -0.07049229f, -0.10587591f, -0.08701221f, 0.11289255f, 0.00249920f, 
    -0.02180554f, -0.00042557f, 0.01280931f, 0.03388387f, -0.13851923f, -0.05779003f, -0.25848547f, -0.05983159f, 
    0.00257356f, 0.02162095f, 0.00961562f, 0.02798835f, 0.00734877f, 0.06385850f, -0.08342672f, 0.03973800f, 
    -0.14431305f, 0.06583761f, 0.02723825f, 0.05312667f, 0.01413971f, -0.00529040f, 0.06731410f, -0.10177581f, 
    -0.04886252f, -0.04368842f, -0.01330941f, 0.10037109f, 0.05090602f, 0.35091445f, -0.04998286f, 0.04223180f, 
    0.03869675f, 0.05267103f, 0.00169650f, 0.03923006f, 0.02965100f, 0.03381677f, 0.12116373f, 0.13190110f, 
    0.02938931f, -0.03828238f, -0.13297997f, 0.08099677f, 0.05498002f, -0.04208079f, 0.08664014f, -0.07128820f, 
    0.12992927f, 0.08693542f, 0.02044773f, 0.00001067f, 0.19084242f, 0.02641803f, 0.06737952f, -0.02037192f, 
    0.05921369f, 0.00196340f, 0.06873191f, 0.05654070f, 0.02446538f, 0.06934544f, 0.00240029f, -0.06822491f, 
    -0.12139005f, -0.28610823f, -0.22872996f, 0.26738840f, 0.09688472f, 0.01070576f, -0.09612136f, 0.12880637f, 
    -0.02599936f, -0.04892148f, 0.00572900f, 0.04411448f, -0.10684101f, 0.25916258f, -0.06988303f, 0.38461784f, 
    -0.04669017f, -0.10474232f, -0.00285402f, 0.02516988f, 0.02852329f, 0.06325327f, -0.02440796f, 0.04553239f, 
    0.02995251f, 0.05824220f, -0.09183251f, -0.20080476f, 0.01430840f, 0.09058787f, -0.05675035f, 0.05972225f, 
    0.03067379f, -0.00792163f, -0.01797088f, -0.02025846f, -0.07927438f, 0.02201697f, -0.31572688f, 0.16031025f, 
    0.16565904f, 0.02421795f, -0.04126256f, 0.03221953f, -0.11055303f, 0.12429257f, -0.05781615f, -0.12310609f, 
    -0.08853333f, -0.12054364f, -0.06704256f, 0.02625202f, -0.09110644f, -0.01777837f, -0.07043709f, -0.08248604f, 
    -0.08535527f, 0.05074083f, -0.11309079f, -0.04029621f, 0.17245738f, -0.17905645f, 0.07283498f, 0.02178275f, 
    -0.11487263f, 0.09463926f, 0.00448496f, -0.04372324f, 0.17330298f, 0.06823986f, 0.01371322f, 0.02889295f, 
    0.22000785f, 0.12432356f, -0.03182110f, -0.11031672f, -0.01318470f, -0.05798169f, -0.02916439f, 0.10476691f, 
    -0.01841799f, 0.06299114f, -0.01011656f, -0.06716200f, 0.11511075f, -0.04267198f, 0.19780482f, 0.03971086f, 
    0.01495558f, 0.02217572f, 0.02407791f, -0.06417703f, 0.10016204f, 0.01676625f, 0.03075347f, 0.12618376f, 
    0.14614567f, 0.11666112f, 0.29201552f, 0.21842787f, 0.01225958f, 0.15239002f, -0.11189004f, -0.02883494f, 
    0.01386015f, -0.12684432f, -0.04386901f, -0.08028309f, -0.08652523f, -0.05480063f, -0.04130052f, -0.03598231f, 
    -0.09118870f, -0.09499725f, -0.03372958f, -0.02388854f, 0.15885322f, 0.05391169f, 0.02354025f, 0.02116351f, 
    -0.17912702f, 0.10029444f, 0.02524380f, 0.20729442f, 0.06076321f, 0.11207604f, 0.00370713f, 0.04472834f, 
    -0.02614587f, -0.00972935f, 0.08312064f, 0.02778156f, 0.06283671f, -0.38831154f, 0.12496471f, 0.04757936f, 
    -0.25344458f, 0.01171718f, -0.20618600f, -0.12103065f, -0.15173231f, 0.07606286f, 0.04718862f, 0.09398094f, 
    0.38410863f, 0.00575696f, 0.18715610f, 0.20068923f, 0.13444944f, 0.03863606f, -0.00586148f, 0.04505977f, 
    0.00539014f, 0.18461226f, -0.16907457f, 0.01782940f, -0.20085330f, -0.00820254f, 0.05150836f, -0.12446912f, 
    -0.03980189f, -0.14877273f, 0.13951309f, 0.08208083f, -0.15851055f, -0.01815497f, -0.03763911f, 0.20182990f, 
    0.04084625f, 0.13709897f, 0.05805976f, -0.00926005f, 0.06608512f, -0.01033655f, -0.02451628f, 0.08618139f, 
    0.08493455f, -0.19975452f, -0.01257407f, 0.02610341f, -0.15869841f, 0.11405967f, 0.17375727f, 0.18084154f, 
    -0.10725141f, 0.05311234f, -0.17563683f, -0.13637270f, -0.00658877f, -0.07179475f, 0.00280940f, -0.03288716f, 
    -0.46533126f, -0.04923602f, 0.17730691f, 0.12224995f, -0.05367227f, -0.10226529f, -0.02870347f, 0.10492847f, 
    0.04750432f, 0.00845809f, 0.06932078f, -0.04529855f, 0.34125230f, -0.01725380f, 0.08986044f, 0.03672367f, 
    0.09722202f, 0.16526811f, 0.12213895f, 0.17381728f, 0.01085179f, 0.04871934f, 0.04146909f, -0.03877982f, 
    0.08239502f, 0.13550358f, 0.12682889f, 0.06538203f, 0.01923051f, 0.02868284f, -0.07152582f, -0.03329396f, 
    0.05162243f, 0.01132603f, 0.08539928f, 0.01500864f, -0.69460839f, -0.16304106f, -0.08086891f, 0.04313516f, 
    -0.20730104f, 0.06201046f, -0.05712986f, 0.02373197f, 0.04110202f, -0.11030416f, -0.16861857f, -0.01304189f, 
    -0.00292153f, 0.04151406f, -0.01483872f, 0.04067973f, -0.03263590f, 0.01114653f, -0.06859890f, -0.00184930f, 
    0.00244673f, 0.05346449f, 0.05951210f, -0.07814237f, 0.03551681f, -0.06942909f, -0.01985422f, -0.02430535f, 
    0.06394932f, -0.02882832f, -0.03925659f, 0.00018505f, -0.02482801f, -0.07342219f, -0.00067962f, 0.02182398f, 
    0.06102896f, -0.05738238f, -0.01559607f, 0.01453617f, 0.01275150f, 0.03745926f, 0.01777449f, -0.07280784f, 
    0.05290955f, -0.06215691f, 0.04577992f, -0.02596161f, 0.05095490f, 0.01093111f, 0.03181677f, 0.03318119f, 
    -0.02014384f, -0.05964219f, 0.03698331f, -0.04884359f, -0.01743970f, 0.02062948f, -0.01268014f, 0.00437853f, 
    0.01793794f, -0.01788724f, -0.05610311f, -0.02487453f, 0.05311069f, -0.04636026f, -0.06035430f, -0.00076079f, 
    -0.04467420f, 0.02575223f, -0.07278109f, 0.03034442f, 0.04617212f, 0.04209541f, 0.04855504f, -0.06974735f, 
    -0.02761005f, -0.04346852f, -0.02790828f, 0.02687220f, -0.06500212f, -0.02071328f, 0.02105748f, 0.04529272f, 
    -0.05376070f, -0.03848072f, -0.04177644f, -0.04786545f, -0.00256865f, 0.02327845f, -0.04412701f, 0.03722798f, 
    -0.07406686f, 0.04573996f, -0.07156198f, -0.03309762f, -0.00428729f, -0.04595929f, 0.03845520f, 0.02659069f, 
    -0.05297010f, -0.00412379f, -0.07690816f, 0.02760323f, 0.02998221f, 0.03833745f, 0.03472518f, -0.02729740f, 
    -0.00676561f, -0.03487064f, -0.03414929f, 0.01597192f, -0.03804801f, -0.01861742f, 0.02482741f, -0.04676495f, 
    0.01733378f, -0.00361858f, 0.02145788f, 0.00245839f, -0.01090066f, -0.05452698f, 0.02885257f, 0.01781067f, 
    -0.04934094f, -0.03131668f, 0.00539035f, 0.06023284f, -0.03643845f, 0.06303379f, 0.01236170f, 0.04703025f, 
    -0.04277084f, 0.01604929f, 0.03196507f, -0.05585204f, -0.07989662f, 0.03175963f, 0.03434608f, 0.05178420f, 
    0.00199811f, -0.01343070f, 0.04084060f, -0.02064002f, 0.04784171f, -0.01195888f, 0.01088134f, -0.06826169f, 
    -0.00797069f, -0.02491483f, 0.03136330f, -0.01422658f, 0.03817519f, -0.02348432f, -0.02860531f, -0.06035670f, 
    0.03336323f, -0.01665571f, 0.01969583f, -0.07121232f, -0.04834699f, -0.02430782f, 0.02597224f, -0.00601505f, 
    -0.02255709f, -0.06857248f, -0.02150366f, 0.05481768f, -0.03665004f, -0.02184004f, 0.01175547f, -0.04439682f, 
    -0.03784664f, -0.03030992f, 0.04941813f, 0.04543261f, -0.01713557f, -0.00867279f, -0.06595068f, 0.01577313f, 
    -0.01348531f, -0.03702203f, 0.00633978f, -0.00082807f, -0.06696300f, -0.02111277f, -0.01509585f, -0.06034867f, 
    0.02781220f, 0.00482107f, -0.07019208f, 0.06329266f, -0.02488772f, 0.02078174f, 0.03308879f, -0.05682635f, 
    -0.05140737f, -0.06116838f, 0.01509939f, -0.07951576f, -0.00150022f, -0.05113049f, 0.05797854f, -0.02928729f, 
    0.01035522f, 0.04923226f, -0.03943038f, 0.01761274f, 0.05150958f, -0.02179181f, -0.05392043f, 0.03716595f, 
    0.04264156f, -0.06152918f, 0.04013681f, -0.07219992f, -0.01795624f, -0.00162491f, -0.08122361f, 0.01382507f, 
    -0.04284280f, -0.06145926f, -0.06456455f, 0.02078292f, 0.06361095f, 0.06419685f, 0.06006372f, 0.04673143f, 
    0.04824920f, -0.05175048f, -0.02720233f, -0.04376812f, -0.03556703f, -0.05979330f, -0.06192856f, 0.05344195f, 
    -0.01452755f, -0.00120524f, 0.06141998f, 0.01832448f, -0.05746518f, -0.01631764f, -0.00952970f, 0.04216402f, 
    0.03954891f, -0.05784218f, -0.04150415f, 0.01804959f, 0.01975329f, -0.06626898f, -0.05112532f, -0.00719437f, 
    0.01666013f, -0.03177815f, 0.05753064f, -0.02576109f, -0.03741458f, 0.04321402f, -0.07664405f, 0.03355111f, 
    -0.01001035f, -0.07681986f, 0.06734911f, -0.04600524f, 0.05389770f, -0.01411996f, -0.03321091f, 0.02544362f, 
    0.04298358f, -0.00383247f, -0.04509464f, 0.05912371f, 0.00566939f, 0.03552090f, 0.02906109f, 0.04866910f, 
    -0.07030180f, -0.05927189f, -0.06182552f, 0.04223274f, 0.01344250f, 0.01136746f, -0.04006948f, 0.04146853f, 
    0.02842056f, 0.01320088f, -0.07045856f, 0.00714898f, 0.01828035f, -0.00158535f, -0.01264751f, -0.01054877f, 
    -0.03097660f, 0.03662405f, -0.03270966f, -0.02858409f, -0.07673193f, -0.05596193f, 0.01451456f, -0.03713344f, 
    -0.06493582f, -0.02876145f, -0.06108392f, -0.06679709f, -0.01030130f, 0.00311062f, -0.01985389f, -0.01361153f, 
    0.01101585f, -0.03063110f, 0.05711327f, 0.04728975f, -0.04456605f, 0.03206604f, 0.00857312f, -0.03785966f, 
    -0.05531259f, 0.00000814f, -0.05336756f, 0.02488470f, -0.01521622f, -0.04405348f, 0.05907826f, -0.00468906f, 
    -0.01180345f, -0.03434604f, -0.00706313f, 0.00979966f, 0.06586304f, 0.03667450f, 0.06640076f, 0.03724729f, 
    -0.03492333f, 0.05570760f, -0.03887136f, 0.01886665f, 0.05230312f, 0.05748809f, -0.01841523f, 0.00983769f, 
    -0.07819428f, -0.07031637f, -0.05338133f, 0.05285300f, -0.04834326f, -0.01347686f, -0.05087242f, 0.03397326f, 
    -0.02997218f, 0.01351815f, 0.03189975f, -0.00830552f, 0.05247217f, -0.01569836f, -0.05855570f, -0.05620502f, 
    0.03040171f, 0.06392624f, -0.05167466f, 0.01891709f, -0.03760717f, 0.02521431f, -0.02778675f, 0.04377425f, 
    -0.05183659f, -0.02027124f, 0.01827771f, 0.04838781f, 0.05202676f, -0.01535588f, 0.03404542f, -0.04221467f, 
    0.03737250f, -0.07141983f, 0.00134401f, -0.00276160f, -0.02518684f, -0.05912089f, -0.07687524f, -0.06050612f, 
    -0.04882129f, 0.01020346f, -0.06962328f, -0.00197086f, 0.04232010f, -0.03704276f, 0.02690635f, -0.07354382f, 
    -0.07075094f, 0.02291319f, 0.03187897f, 0.00566396f, 0.02772090f, -0.01709002f, -0.06732207f, -0.04798013f, 
    -0.01604068f, 0.06041126f, 0.04137477f, 0.00520488f, -0.00205315f, 0.01429222f, -0.02802397f, 0.02703309f, 
    0.02901798f, 0.03197490f, -0.02110477f, -0.04175604f, 0.02062555f, 0.03594973f, -0.00425300f, 0.00561102f, 
    -0.05041480f, -0.06781231f, 0.03103098f, 0.01110634f, 0.05393245f, -0.07240161f, 0.05490458f, 0.03337436f, 
    -0.06744356f, 0.02353513f, -0.05217058f, -0.02124627f, -0.07892410f, 0.03294205f, -0.00437222f, 0.01297888f, 
    -0.05201725f, 0.01771747f, -0.01208281f, -0.05689206f, -0.05354762f, 0.01546978f, 0.03656444f, -0.07070190f, 
    -0.05646725f, -0.02199784f, 0.01043487f, -0.00053783f, -0.07357838f, -0.06734613f, 0.00892829f, 0.01960985f, 
    0.04308705f, -0.04665529f, -0.05583563f, -0.00092952f, 0.02796466f, -0.01267959f, 0.01505261f, -0.07518743f, 
    0.01053837f, -0.04834359f, 0.03361951f, -0.00809981f, 0.05898986f, 0.05576415f, 0.03057415f, 0.05935843f, 
    -0.00716396f, 0.01200489f, -0.06326370f, 0.01231984f, 0.02046086f, 0.03636619f, -0.00111967f, 0.02549918f, 
    -0.05660956f, -0.01503800f, 0.01863604f, -0.00126710f, 0.00856398f, -0.05335254f, 0.01118179f, -0.01483328f, 
    -0.02298298f, -0.04214557f, 0.02320511f, -0.02870933f, -0.00269587f, 0.02603514f, 0.01672136f, 0.01499034f, 
    -0.05438190f, -0.07121481f, -0.05688409f, -0.06702333f, 0.06237653f, -0.01854835f, -0.07995766f, -0.05606643f, 
    0.00152730f, 0.04371725f, 0.04078673f, -0.03973023f, 0.03521414f, 0.04140485f, 0.05417696f, 0.02762312f, 
    -0.07301086f, -0.00909061f, -0.01080452f, -0.00363181f, 0.04299014f, -0.07806477f, 0.03997847f, -0.04795355f, 
    -0.02974910f, -0.04040774f, -0.07094535f, 0.01785962f, 0.02629224f, -0.07555964f, -0.06686360f, -0.04787455f, 
    0.02788697f, -0.02344397f, -0.04142412f, 0.02456876f, -0.07219581f, 0.00406385f, 0.02094864f, 0.01706841f, 
    -0.01560851f, -0.07273231f, -0.06345003f, -0.04354332f, 0.04759442f, -0.03723819f, 0.04197086f, 0.00265373f, 
    0.02242426f, -0.06126960f, 0.05134653f, -0.03063140f, -0.00179042f, -0.06006925f, 0.01123901f, 0.01342579f, 
    -0.07179462f, 0.03487639f, -0.03990851f, -0.03312994f, 0.03730475f, 0.00425055f, -0.05928742f, 0.03505439f, 
    0.06097349f, -0.05025405f, 0.01969968f, 0.01577708f, -0.01079516f, -0.05661990f, -0.06515286f, -0.05056205f, 
    0.05119448f, -0.07188278f, -0.00932154f, 0.00266659f, 0.01056357f, 0.06323728f, -0.06699788f, -0.07085088f, 
    0.00570640f, -0.01138416f, -0.03089470f, -0.05244722f, -0.05186133f, -0.00571098f, 0.03506650f, -0.05393293f, 
    -0.00680440f, 0.02880131f, -0.02814234f, 0.03711544f, -0.04833715f, -0.01840762f, 0.05487387f, -0.03640307f, 
    -0.01721225f, 0.06107010f, -0.01662183f, -0.07421419f, 0.03898936f, 0.00126006f, -0.02249580f, 0.00519289f, 
    -0.02996039f, -0.00903362f, 0.02752710f, -0.01611399f, 0.03579764f, -0.03788647f, 0.01461690f, 0.06722173f, 
    0.00353325f, -0.02171747f, -0.00746067f, -0.07192056f, -0.00455896f, 0.04398509f, 0.00223489f, 0.04615381f, 
    0.03555490f, -0.06635036f, 0.05770040f, -0.06436956f, -0.05616507f, 0.02557320f, 0.00840287f, -0.03517994f, 
    -0.00641117f, 0.02725169f, -0.03558607f, -0.06836636f, -0.06652317f, 0.02138709f, -0.00695926f, 0.03424874f, 
    -0.04437262f, -0.03135229f, -0.00406636f, 0.01206855f, -0.03345849f, -0.02268052f, -0.00245193f, -0.02233597f, 
    -0.05109922f, -0.01696360f, 0.00356423f, -0.03106453f, 0.05883926f, -0.05198386f, 0.03726461f, 0.00248435f, 
    0.02969326f, 0.01869728f, -0.06768344f, -0.03064050f, -0.01367165f, -0.02462982f, -0.06605819f, 0.02064819f, 
    -0.04357105f, -0.00700922f, 0.04739248f, -0.02791705f, 0.02337349f, 0.03892646f, -0.04450026f, -0.03120560f, 
    -0.02096744f, -0.06442926f, 0.04249431f, -0.02845189f, -0.03159359f, 0.05803701f, -0.02470998f, 0.02735928f, 
    0.01576640f, 0.05429869f, -0.04192419f, -0.04976175f, -0.01333910f, -0.02226599f, -0.00864184f, -0.05382562f, 
    0.05434226f, -0.02697692f, -0.00544801f, 0.03413188f, -0.04062175f, -0.01154780f, 0.04847242f, 0.05233964f, 
    0.04184298f, 0.01979647f, -0.01246106f, -0.05248648f, 0.03764959f, 0.02046150f, 0.05280813f, -0.03526459f, 
    -0.06707326f, -0.04962703f, -0.00678946f, -0.01164017f, 0.00958451f, -0.02089161f, 0.01330778f, -0.07018992f, 
    -0.04876833f, 0.02625890f, -0.04346741f, 0.06303996f, -0.04587843f, -0.02558987f, 0.03254005f, -0.06536041f, 
    -0.03896884f, -0.07409612f, 0.00110644f, 0.04763830f, -0.01242510f, 0.04207181f, -0.06977668f, -0.07241549f, 
    -0.05741023f, -0.00206032f, 0.02315262f, 0.04648741f, -0.01294912f, 0.03056629f, -0.02284099f, 0.04883846f, 
    -0.05724641f, -0.03430652f, 0.01560294f, 0.03296701f, -0.02656494f, -0.02342849f, 0.04988960f, -0.00448139f, 
    -0.06552124f, -0.05436094f, -0.00017192f, -0.06726649f, -0.01303761f, 0.01764004f, 0.00683292f, -0.03991888f, 
    -0.01942642f, -0.01746756f, -0.03551133f, -0.07085986f, 0.05803337f, -0.03017000f, 0.04506741f, -0.05446524f, 
    0.03031442f, -0.05973304f, 0.02856451f, -0.04381605f, 0.05457492f, -0.07400591f, 0.06379838f, -0.06090728f, 
    0.02229133f, -0.04273751f, 0.01934333f, 0.02743377f, -0.00510292f, -0.02657326f, -0.00727736f, 0.02980483f, 
    0.03549288f, 0.01868349f, 0.02188413f, 0.04177310f, 0.02695560f, -0.06233779f, 0.05672982f, 0.04412038f, 
    -0.02356026f, -0.01851778f, -0.06181711f, -0.03054465f, -0.05616076f, 0.05131751f, 0.00720501f, 0.05258892f, 
    0.01197145f, 0.00931481f, -0.05277054f, 0.00681285f, -0.02010314f, 0.06196766f, 0.00389877f, -0.06296755f, 
    -0.01399911f, -0.18939705f, -0.25072655f, -0.18785939f, -0.11058158f, 0.00195283f, 0.02807675f, 0.01552423f, 
    -0.03673704f, 0.06545885f, -0.08281741f, 0.06904928f, 0.10537428f, 0.13464014f, 0.02056327f, -0.32028830f, 
    -0.06649145f, -0.07287541f, 0.06148886f, 0.08321591f, -0.07305476f, -0.07004084f, 0.02269362f, -0.00903610f, 
    0.21798189f, 0.32412732f, -0.15616979f, -0.07116617f, -0.23369011f, -0.08921156f, 0.10465218f, 0.12100651f, 
    0.07602227f, -0.00351860f, 0.02384078f, 0.02580487f, -0.03459482f, -0.09963454f, -0.02315516f, -0.07182702f, 
    0.02995339f, -0.06150789f, 0.11613199f, 0.01334030f, 0.07057049f, 0.03568555f, -0.05201200f, 0.07149700f, 
    -0.20437017f, 0.00474761f, 0.06949437f, -0.24564666f, 0.06118375f, -0.04061197f, -0.10906240f, -0.05025209f, 
    -0.03019739f, 0.09033995f, -0.06143778f, 0.00590247f, 0.36786997f, -0.13747893f, -0.04980192f, 0.24342699f, 
    0.00416132f, -0.05130138f, 0.04938177f, 0.05551026f, 0.01127435f, 0.10275536f, -0.02840797f, -0.00107700f, 
    0.17135482f, 0.15493797f, 0.25298041f, 0.20702578f, -0.06440983f, 0.02979933f, -0.00117479f, 0.06443442f, 
    0.02194909f, 0.02677519f, -0.00371687f, 0.04738698f, -0.07710299f, -0.14959753f, -0.06829802f, 0.06146303f, 
    -0.08437044f, -0.06080827f, 0.20089665f, 0.10992657f, -0.07125960f, 0.04918192f, -0.04443763f, -0.09645890f, 
    -0.30860850f, -0.16056044f, 0.04461655f, -0.05164261f, -0.12865181f, 0.01319194f, 0.17582400f, -0.04877155f, 
    0.08555428f, -0.07517751f, 0.10096435f, 0.04238635f, -0.10789536f, 0.31639481f, -0.05154124f, -0.02159098f, 
    -0.06382158f, -0.00970053f, 0.05480438f, -0.08548747f, 0.03183754f, -0.03227535f, 0.04141970f, -0.06219890f, 
    0.35564315f, -0.00327036f, -0.02584523f, -0.14348049f, 0.12940751f, -0.13181923f, 0.03406183f, 0.04726942f, 
    0.05471169f, 0.06591733f, -0.00558254f, 0.02810702f, -0.03459169f, -0.25776497f, 0.11596309f, 0.02918332f, 
    0.05504016f, 0.12323393f, 0.05057331f, 0.05718553f, 0.10125094f, -0.04624628f, 0.02244696f, -0.06179831f, 
    -0.07002224f, -0.09852624f, -0.14152588f, 0.40281913f, -0.05527067f, -0.02065254f, 0.12121881f, 0.12331834f, 
    -0.06895189f, -0.04067323f, -0.07369317f, -0.20217809f, 0.05008997f, 0.15468600f, 0.07519067f, 0.28515580f, 
    -0.11929235f, -0.15661336f, -0.00222139f, -0.04278212f, -0.01785388f, 0.04427258f, 0.02265073f, 0.08627082f, 
    0.12861413f, 0.08283599f, 0.00639087f, -0.21701704f, 0.03578886f, 0.01417299f, -0.12237296f, 0.04784418f, 
    -0.00484993f, 0.00240280f, -0.06180997f, -0.01581187f, -0.08702513f, 0.06831902f, 0.11731811f, 0.26184592f, 
    0.08693195f, 0.12934259f, 0.02068029f, 0.06920821f, -0.13191848f, 0.13764654f, -0.04658327f, 0.07500705f, 
    0.28756097f, 0.07480677f, -0.26751915f, -0.18888043f, -0.11618207f, -0.02745433f, -0.10086758f, 0.11307483f, 
    -0.12259537f, 0.01014475f, 0.06422527f, -0.10338108f, 0.13314830f, 0.15409665f, -0.07351764f, 0.00153542f, 
    -0.01660184f, 0.01133348f, 0.07595100f, -0.12063927f, 0.08859684f, 0.09091891f, 0.00044059f, 0.04068664f, 
    -0.41367757f, -0.12630516f, 0.07300533f, -0.22695328f, -0.08148105f, -0.00579020f, -0.01440480f, 0.06373376f, 
    0.08944952f, -0.05519680f, 0.02761262f, -0.09671686f, -0.12942649f, 0.07299916f, 0.20063728f, 0.01417552f, 
    -0.04822302f, -0.01836429f, -0.09011640f, 0.01420089f, -0.17626186f, 0.13053849f, 0.08772883f, 0.01073137f, 
    -0.05656000f, 0.08518628f, 0.13597615f, 0.18497397f, -0.05062151f, 0.03245510f, 0.14571135f, -0.08922360f, 
    -0.01802653f, -0.09615134f, -0.00889939f, -0.08974474f, 0.37037903f, -0.20438461f, 0.23951562f, 0.21989793f, 
    0.00928536f, 0.01997928f, -0.05469788f, -0.05048420f, 0.10774251f, 0.04636535f, -0.08386199f, -0.11771519f, 
    0.07894367f, -0.09724361f, -0.10580899f, 0.11060443f, 0.03763007f, 0.06840250f, -0.00488965f, 0.05810105f, 
    -0.04260442f, 0.02663087f, 0.08338158f, -0.02430108f, 0.37154752f, 0.04185835f, -0.05880438f, -0.12273045f, 
    0.05464900f, -0.01940448f, -0.20414840f, -0.16205786f, -0.05746808f, -0.03386812f, 0.07003929f, -0.06490280f, 
    0.18727207f, 0.19104342f, 0.02487496f, 0.19559090f, 0.11280478f, -0.09275491f, -0.05938138f, 0.15199085f, 
    0.14995348f, 0.01193412f, -0.00531756f, -0.01893299f, 0.05639240f, 0.06706992f, 0.08599118f, -0.01769896f, 
    -0.08219721f, -0.12126137f, 0.03605213f, 0.09137365f, -0.08786382f, 0.07021796f, 0.01106171f, 0.08881210f, 
    -0.45183435f, 0.13569540f, 0.03585427f, -0.04431316f, 0.18236899f, 0.00832165f, 0.06054176f, 0.09593793f, 
    -0.05161827f, -0.08196680f, 0.06607203f, -0.00537840f, 0.04540292f, 0.04124135f, -0.16782072f, 0.21847576f, 
    -0.10662906f, -0.15572897f, 0.02142300f, -0.05452363f, -0.02638796f, 0.02868632f, 0.09693252f, 0.10773815f, 
    0.26892921f, -0.08366430f, -0.04012034f, 0.36421871f, -0.08380708f, 0.03025350f, 0.11563850f, -0.07855531f, 
    0.06327597f, -0.11906495f, 0.07907318f, 0.07589846f, -0.50197119f, 0.27487871f, 0.18035863f, -0.07326301f, 
    0.00963124f, 0.02316164f, 0.00304473f, 0.19396062f, 0.12683867f, -0.03209628f, 0.04249728f, -0.01448054f, 
    -0.16934939f, -0.09855748f, -0.14830941f, 0.00896795f, -0.08468642f, -0.03168687f, 0.10374913f, -0.08445323f, 
    0.19779599f, -0.04662598f, 0.19645208f, -0.08911729f, 0.05689385f, -0.02815207f, 0.00396015f, 0.02834853f, 
    -0.00295103f, -0.09011324f, 0.03856368f, 0.07248477f, 0.04121372f, 0.04186957f, -0.18010971f, -0.16178107f, 
    0.04765112f, -0.02400124f, -0.04398565f, 0.10138668f, 0.02437668f, 0.01103039f, -0.08027891f, 0.00016480f, 
    0.04543708f, 0.27807671f, 0.03812308f, 0.05180017f, 0.22736776f, 0.06243542f, 0.06943196f, 0.07817964f, 
    -0.03065744f, 0.03603053f, -0.05271456f, -0.05912295f, -0.00887699f, -0.05005383f, -0.08048904f, -0.10523219f, 
    0.07906913f, 0.02596636f, 0.04597195f, -0.23492292f, -0.05808341f, -0.07038292f, 0.01062424f, 0.10579664f, 
    -0.09079426f, 0.02744834f, -0.02076581f, 0.05729473f, -0.33020040f, 0.11826061f, -0.10340215f, 0.32976732f, 
    -0.02735803f, -0.00112124f, -0.07867141f, 0.11619317f, -0.01024524f, -0.19559811f, 0.05499147f, -0.03181255f, 
    -0.23766387f, 0.16516300f, 0.01951127f, -0.11896041f, -0.08976832f, -0.06588485f, 0.02712142f, -0.01680743f, 
    -0.11073267f, 0.05315704f, -0.00898108f, -0.01070342f, -0.02005368f, -0.05924366f, -0.01298941f, -0.03793120f, 
    0.07634902f, 0.07791767f, -0.04398294f, 0.00221300f, 0.03017030f, 0.01287794f, -0.01876141f, -0.05925384f, 
    -0.22683594f, -0.05321465f, 0.08511637f, 0.12026726f, -0.12246158f, -0.05356255f, -0.09238482f, -0.07389940f, 
    -0.05513914f, 0.08238348f, 0.04561329f, 0.05611408f, -0.58030856f, 0.13008243f, -0.22231451f, 0.09041214f, 
    0.00658654f, 0.07572559f, 0.07456500f, 0.04339050f, -0.06282362f, 0.06853531f, -0.05417404f, -0.02640620f, 
    -0.07639387f, 0.17224284f, -0.14693357f, -0.09958982f, -0.07498547f, -0.08255227f, 0.12604392f, -0.01880114f, 
    0.04585366f, -0.11161111f, 0.05238756f, 0.07528997f, -0.10324720f, 0.07122850f, 0.15184131f, 0.11351097f, 
    -0.09429903f, -0.03981922f, 0.04131103f, 0.05507767f, -0.04947260f, 0.08354686f, 0.04903495f, -0.09644837f, 
    0.09993190f, 0.06966540f, 0.13151036f, -0.11561520f, 0.15931095f, -0.07241861f, 0.14272785f, -0.08180325f, 
    0.18024574f, 0.02787149f, 0.03737665f, 0.14513499f, 0.12019406f, 0.11840693f, -0.17591278f, 0.13435048f, 
    0.00434889f, 0.07763924f, 0.03367817f, 0.08231688f, 0.19514316f, 0.03541117f, -0.14051312f, -0.00222643f, 
    -0.11358035f, 0.05927381f, -0.11918817f, 0.12297140f, 0.01544588f, -0.08716200f, 0.09791035f, 0.10641499f, 
    -0.01925776f, -0.09784088f, -0.11267880f, 0.00855756f, -0.37951738f, 0.06160938f, 0.18498436f, -0.06337225f, 
    0.05648346f, -0.11075851f, 0.08321647f, -0.10488417f, -0.04418774f, 0.02029013f, 0.01913057f, -0.05632789f, 
    0.47837302f, -0.08761952f, -0.03880286f, 0.19470218f, -0.09180029f, 0.11860292f, -0.04223816f, -0.08133944f, 
    -0.02933452f, 0.00836166f, 0.03280092f, 0.12056401f, -0.06375271f, -0.00370346f, -0.11754118f, 0.16527067f, 
    0.10687304f, 0.03447362f, -0.00697696f, -0.05810962f, 0.03938005f, 0.17244190f, -0.04043068f, 0.08890224f, 
    -0.21087846f, 0.22430827f, 0.20131627f, -0.14084424f, 0.05786320f, 0.08703211f, 0.09670960f, 0.02153894f, 
    0.15261322f, -0.03767065f, 0.01645338f, 0.04573427f, -0.15053588f, -0.11714673f, 0.11114239f, -0.04138714f, 
    -0.04684183f, 0.09615687f, 0.02816316f, 0.02638476f, 0.15045612f, 0.05311767f, 0.07810229f, 0.16422772f, 
    0.02344293f, -0.18470864f, -0.16157284f, 0.03823702f, 0.04174696f, -0.00780052f, 0.01227317f, 0.07114413f, 
    0.05815779f, 0.02946305f, 0.04710015f, 0.00931897f, 0.37383232f, -0.12442128f, -0.14983618f, -0.11209401f, 
    0.08897089f, 0.01034157f, -0.04861099f, -0.02177204f, 0.09423191f, 0.22839461f, 0.16928442f, 0.03020153f, 
    0.08070980f, -0.12427241f, -0.09540268f, 0.17677872f, 0.00011436f, 0.05630437f, 0.02328117f, -0.07139149f, 
    0.06198658f, -0.05392166f, 0.18817876f, 0.07139057f, -0.40523189f, 0.05155271f, -0.07503477f, -0.16916148f, 
    0.07236718f, -0.08609935f, 0.03189030f, 0.04366084f, 0.11132706f, 0.10262047f, 0.05484429f, 0.17437395f, 
    0.08377572f, 0.07358076f, 0.12838967f, 0.07390766f, -0.06814867f, -0.09744991f, 0.00714687f, 0.13713294f, 
    0.13794681f, -0.02449934f, 0.11907755f, -0.09782816f, 0.04594079f, -0.07141944f, 0.01262960f, 0.12623547f, 
    0.03766897f, 0.08476769f, -0.03586861f, -0.12616248f, 0.00539097f, 0.02208405f, 0.07871000f, 0.05276855f, 
    -0.09170749f, -0.12591386f, 0.22999804f, 0.09062307f, 0.06008781f, 0.01921389f, -0.04459760f, 0.11345702f, 
    0.02643069f, 0.10193487f, -0.05194481f, 0.00493731f, 0.21422288f, 0.03660869f, -0.14481847f, -0.14163008f, 
    0.08458724f, -0.02880595f, 0.10685319f, 0.04143578f, 0.10807964f, 0.02936747f, 0.07327171f, 0.10104353f, 
    -0.13524254f, -0.08376069f, -0.08480737f, 0.04147168f, 0.00158924f, 0.00749295f, -0.02692019f, 0.05758446f, 
    -0.02254659f, -0.04396654f, 0.02967306f, -0.02950227f, -0.16010469f, -0.13088791f, 0.13868102f, -0.12889110f, 
    0.21000022f, 0.09802127f, 0.06512222f, -0.15108360f, 0.03655382f, -0.02597892f, -0.01074049f, 0.05465320f, 
    -0.30834389f, -0.13312036f, 0.08451974f, -0.24676041f, 0.21003264f, 0.04289176f, -0.03929983f, 0.06169626f, 
    -0.02477858f, 0.17764658f, 0.14755571f, 0.08688792f, 0.04566529f, -0.16391174f, -0.17007850f, 0.19612780f, 
    -0.21041952f, -0.01690581f, 0.07623696f, 0.05049910f, 0.05215295f, -0.09759697f, -0.06503902f, -0.08830141f, 
    -0.26495045f, 0.13349839f, -0.02321979f, -0.17249373f, 0.11366182f, 0.15601847f, 0.04467830f, -0.02247527f, 
    0.00849777f, -0.01052617f, 0.09112931f, 0.05832762f, -0.23127091f, -0.02562802f, -0.08576641f, -0.20176376f, 
    0.14759800f, 0.04272989f, -0.05410885f, -0.01592587f, -0.02239428f, -0.05835376f, 0.13186927f, -0.05771885f, 
    -0.22529042f, -0.20987856f, -0.00196696f, 0.04834241f, 0.09626732f, 0.11946224f, -0.00489393f, -0.04137088f, 
    0.11656084f, 0.07246488f, -0.06162992f, 0.11349857f, 0.12731993f, -0.12577176f, -0.10053188f, 0.03548724f, 
    -0.10855208f, -0.01790645f, -0.05007874f, -0.07549358f, 0.08470716f, 0.09452084f, 0.04531050f, -0.02117295f, 
    0.03477948f, -0.01477548f, -0.15427130f, -0.34993279f, -0.08907431f, -0.04882830f, -0.16219844f, 0.08890586f, 
    0.03515067f, 0.10556084f, -0.03287795f, -0.15225132f, -0.07198499f, 0.16973701f, 0.05624774f, 0.15286870f, 
    -0.11335511f, 0.01397750f, -0.10835209f, 0.12041088f, 0.00502290f, 0.00156296f, 0.16572160f, -0.04547866f, 
    -0.26822400f, 0.26026115f, 0.04198037f, -0.11951206f, -0.09166504f, 0.11124519f, 0.18622264f, 0.00744575f, 
    0.08323950f, -0.00887067f, -0.00603503f, 0.02337040f, 0.19679664f, -0.47089052f, 0.10946288f, -0.19788049f, 
    -0.08513089f, -0.09786581f, 0.01169480f, -0.03544769f, 0.04790874f, -0.04127208f, 0.06755837f, 0.04970522f, 
    -0.03660407f, 0.02024404f, -0.20707601f, 0.09833105f, -0.17174165f, 0.03898498f, -0.03664200f, -0.10954267f, 
    -0.00798978f, -0.06844799f, -0.01307605f, 0.00645179f, -0.52220452f, -0.03037698f, -0.04134696f, 0.06049899f, 
    -0.01285589f, -0.03227809f, -0.06880819f, -0.04623141f, -0.05878693f, -0.02218951f, 0.00805182f, -0.04024871f, 
    -0.06412896f, 0.15450282f, -0.10058613f, -0.19515309f, -0.05783672f, 0.05321547f, -0.00523883f, 0.02193992f, 
    0.04575464f, -0.03866306f, 0.07393094f, -0.07466890f, -0.27660596f, 0.09975402f, 0.05292445f, -0.05019206f, 
    -0.00528839f, -0.19625732f, 0.13152860f, 0.09028577f, -0.07190085f, -0.09118979f, -0.00286778f, -0.08821836f, 
    -0.02201396f, 0.08401840f, 0.06126530f, -0.07065401f, 0.04427743f, -0.07777424f, 0.05236537f, -0.02596582f, 
    0.03274961f, 0.00396056f, 0.09612691f, 0.04167491f, -0.04462061f, -0.03029038f, -0.13266818f, 0.10129733f, 
    0.05483470f, 0.10807212f, -0.05032931f, 0.08142977f, 0.12730689f, 0.04487401f, -0.18902624f, 0.05346530f, 
    -0.19679561f, -0.11379738f, 0.11550385f, 0.01663342f, 0.10052928f, -0.07290227f, -0.03900441f, -0.07607116f, 
    0.06833676f, -0.05999881f, 0.16777155f, 0.05402340f, -0.35180283f, -0.06126856f, 0.08568288f, -0.15680386f, 
    -0.00506368f, -0.13464411f, 0.11449417f, -0.00274975f, -0.01202061f, -0.04154337f, 0.04226617f, 0.04823263f, 
    0.40037408f, -0.03609166f, -0.08609100f, 0.27295431f, 0.01425739f, 0.12814096f, 0.00813135f, -0.07661936f, 
    0.07893428f, -0.05289607f, 0.15207279f, -0.00753588f, 0.00738601f, -0.08672512f, -0.05360616f, 0.11116334f, 
    0.06648234f, 0.04069093f, 0.04620293f, 0.07707135f, 0.04872881f, -0.03613307f, 0.09154185f, 0.03279044f, 
    -0.06863105f, -0.03634314f, -0.02403042f, 0.00654335f, -0.06388823f, -0.01228349f, 0.02767581f, 0.00955161f, 
    -0.00079002f, -0.04761166f, 0.00782092f, -0.00491825f, -0.01531099f, -0.02396888f, -0.04006151f, 0.04897809f, 
    0.04366375f, 0.00107947f, -0.00601482f, 0.00064528f, -0.08998859f, -0.01634226f, 0.00707531f, -0.05378681f, 
    0.04577137f, 0.01178037f, -0.04549098f, -0.03316656f, 0.01062825f, -0.03983200f, 0.01351866f, 0.01819596f, 
    -0.04860717f, -0.04915790f, -0.01198944f, 0.05420544f, 0.00851009f, -0.06449667f, -0.02910757f, 0.02357796f, 
    -0.05080879f, -0.01147166f, -0.02315869f, -0.03081270f, -0.07632183f, 0.04192859f, 0.00039337f, -0.03987598f, 
    -0.01827641f, -0.07777962f, -0.01113311f, -0.02894459f, -0.04505884f, -0.06748948f, 0.01182996f, 0.00042044f, 
    -0.07504844f, 0.04150760f, 0.01552486f, 0.05189391f, -0.02748312f, -0.04226562f, -0.01240741f, -0.07749025f, 
    -0.06355882f, -0.02461379f, -0.05672097f, -0.01500839f, 0.05185075f, -0.00427966f, -0.02986067f, 0.04918483f, 
    -0.07495295f, 0.05842450f, 0.03175997f, -0.04731138f, 0.05124636f, 0.03328741f, 0.00221667f, 0.04874319f, 
    0.00179173f, -0.04466767f, -0.02385989f, -0.02929311f, -0.03209018f, -0.04611493f, 0.00085959f, -0.04791420f, 
    0.05294823f, -0.05719100f, -0.08001739f, 0.01143110f, -0.03887163f, 0.01672417f, 0.01614503f, -0.02112246f, 
    -0.06890728f, 0.00509605f, -0.06560768f, -0.04526063f, -0.04561608f, 0.03943423f, 0.04340098f, 0.01087073f, 
    -0.05190900f, -0.03029798f, 0.01186655f, -0.01179459f, 0.01233882f, -0.03099661f, 0.04582325f, 0.04969964f, 
    -0.05154606f, 0.00822516f, -0.05431050f, 0.02271354f, 0.01357084f, -0.04084551f, 0.00584850f, 0.04580434f, 
    -0.02090409f, -0.01904411f, -0.06319161f, 0.00827688f, 0.02552314f, -0.06083816f, 0.01275517f, -0.06513315f, 
    -0.03158863f, -0.06257638f, -0.05114692f, -0.03290632f, -0.01519686f, 0.01847489f, -0.04568256f, 0.05594507f, 
    0.05397738f, 0.05185779f, -0.04693621f, -0.04597439f, -0.07537825f, -0.02459479f, 0.01377897f, -0.06180698f, 
    0.03525270f, -0.00579605f, -0.01800946f, -0.05319969f, 0.02948613f, -0.07734130f, -0.06245118f, -0.02693504f, 
    -0.02059255f, -0.00635123f, -0.07121696f, -0.01953093f, 0.00805806f, -0.08396512f, 0.04534466f, -0.05192772f, 
    -0.08400483f, 0.03081207f, -0.08390045f, -0.00184197f, 0.00814783f, 0.00853773f, 0.01613568f, 0.04610730f, 
    -0.02465903f, -0.01561444f, -0.02103660f, -0.05376471f, 0.02408807f, -0.05668938f, 0.04641700f, -0.01740088f, 
    -0.08706028f, 0.03900454f, -0.05693596f, 0.03551540f, -0.00289864f, 0.04057806f, -0.02656561f, -0.00323538f, 
    -0.00464635f, -0.00723162f, -0.07046998f, -0.04830987f, 0.03442755f, -0.00281162f, -0.07925764f, -0.02527747f, 
    0.25681746f, 0.06256337f, -0.04489860f, -0.17211561f, 0.19246164f, 0.08798017f, -0.05161618f, 0.06819391f, 
    0.07870126f, -0.05193171f, -0.05360625f, 0.09500166f, 0.22803685f, 0.08390067f, -0.02649004f, -0.37170428f, 
    -0.04885218f, 0.05344680f, 0.06374344f, -0.02343281f, 0.06937419f, -0.08737362f, 0.06958092f, 0.03989976f, 
    -0.02261896f, 0.05705757f, 0.01263550f, 0.02927793f, -0.09665816f, 0.00516682f, -0.13242951f, -0.07866987f, 
    0.07206456f, -0.07385379f, 0.05443217f, -0.10804018f, -0.11957653f, -0.06340002f, -0.26806137f, 0.15697141f, 
    -0.01585006f, -0.07388685f, -0.02239946f, -0.09901708f, 0.26531860f, 0.11530361f, 0.00310761f, 0.03865429f, 
    -0.42892885f, -0.06739514f, -0.04136129f, -0.17735928f, -0.17141837f, -0.01783055f, -0.09470677f, -0.05973503f, 
    -0.11247642f, 0.00197048f, 0.08439395f, 0.18161540f, 0.40764484f, 0.20296578f, 0.23787411f, 0.55970383f, 
    -0.00712794f, 0.06126101f, 0.09353082f, -0.14193591f, -0.02201026f, 0.06474081f, -0.03800029f, 0.10602219f, 
    0.11095764f, 0.18438059f, 0.06561176f, 0.02674050f, -0.01213163f, -0.04273072f, 0.00607406f, -0.00195812f, 
    -0.00539097f, -0.02528765f, 0.12572759f, 0.03905011f, 0.20388231f, 0.09142310f, 0.02549685f, -0.05409344f, 
    0.01808074f, 0.03939449f, -0.09348197f, 0.00207670f, -0.02771946f, 0.09861722f, 0.07675193f, -0.10876980f, 
    -0.37648532f, 0.01106068f, -0.06389899f, -0.39373720f, -0.02818723f, 0.06881638f, -0.11908557f, 0.25566730f, 
    0.11911469f, 0.11703895f, 0.00055206f, 0.08833585f, -0.16430786f, 0.04976442f, -0.00166378f, -0.03512061f, 
    0.06017264f, -0.13441749f, 0.08662794f, -0.19749860f, -0.00016096f, 0.13460229f, -0.01266375f, 0.00743173f, 
    -0.50716525f, -0.06331904f, -0.14389729f, -0.10310875f, -0.03263715f, 0.05251832f, 0.03203059f, 0.02638433f, 
    0.10189278f, 0.05744752f, -0.05289424f, 0.14861301f, -0.28779742f, -0.22657901f, -0.04598943f, -0.11563284f, 
    0.20249964f, 0.14579652f, -0.03961091f, 0.09073097f, 0.16802871f, -0.01796810f, 0.02396556f, -0.03626678f, 
    0.27040228f, -0.05664437f, -0.05464594f, 0.34414348f, 0.09816309f, -0.03520464f, 0.03070708f, -0.03802021f, 
    0.07795596f, -0.06659874f, 0.04987777f, -0.09815218f, -0.43992862f, -0.04164635f, 0.09071963f, -0.16055256f, 
    -0.21525100f, -0.20844412f, -0.16296485f, 0.03398742f, 0.07855694f, -0.00722630f, 0.02718581f, -0.03278474f, 
    -0.23717628f, 0.03904784f, -0.16578999f, -0.31895337f, -0.06279980f, 0.03730934f, 0.04644705f, 0.04974216f, 
    0.15173982f, 0.07592689f, 0.04174633f, -0.01459069f, 0.05189459f, -0.01138482f, -0.18379070f, 0.39462411f, 
    0.12688050f, 0.06699687f, -0.08345308f, -0.06827077f, -0.03086445f, 0.09928156f, 0.03066697f, 0.01966957f, 
    -0.04515699f, 0.01779457f, -0.01206076f, 0.02648580f, -0.06993937f, -0.03710901f, -0.01819705f, 0.06152487f, 
    0.03750838f, -0.06236717f, 0.06325293f, 0.03431686f, -0.01316963f, -0.06503550f, -0.05615793f, -0.02496233f, 
    0.01284846f, -0.05262203f, -0.04633064f, 0.01755481f, -0.01240451f, -0.00102497f, -0.03275095f, -0.04573077f, 
    -0.05033384f, -0.03866107f, -0.03431814f, 0.02680130f, -0.04972086f, 0.04116500f, 0.01663693f, -0.02125874f, 
    -0.04165401f, 0.05459725f, -0.01977602f, -0.03936576f, -0.05822719f, 0.03967025f, -0.04764203f, -0.06148436f, 
    -0.06773750f, 0.02337593f, 0.05145336f, -0.04235715f, 0.06476430f, -0.01989051f, 0.02552315f, -0.02139563f, 
    0.03372063f, 0.00957381f, 0.03200721f, -0.02181662f, 0.01839036f, -0.07195675f, 0.05493215f, -0.04324583f, 
    -0.07216295f, -0.04703618f, -0.06262420f, 0.03082690f, 0.02547800f, 0.02290967f, 0.05500604f, 0.03432145f, 
    -0.01098067f, 0.03345511f, -0.02537332f, 0.04783467f, -0.00832635f, 0.00574718f, -0.05717266f, -0.07066656f, 
    -0.03140084f, 0.03536165f, 0.05920302f, -0.03938419f, -0.05195485f, -0.06540168f, -0.01654760f, 0.01276595f, 
    0.00765443f, 0.03442517f, 0.03523925f, 0.01115745f, 0.02408405f, 0.03405913f, 0.01695237f, -0.01828561f, 
    0.01586946f, -0.01650326f, -0.01461857f, -0.00424959f, 0.01203154f, -0.02408223f, -0.03903411f, 0.05723409f, 
    -0.07647035f, -0.04185276f, 0.01833637f, 0.06338077f, -0.07019274f, 0.01039414f, -0.07715456f, -0.06847686f, 
    -0.04149356f, 0.05728640f, 0.06566310f, -0.05804000f, 0.00841152f, 0.05523561f, -0.04252511f, -0.07031316f, 
    0.05383442f, 0.04037350f, 0.03170420f, -0.01322977f, -0.04907483f, 0.02130799f, -0.02094390f, 0.00066249f, 
    -0.05524227f, -0.02719732f, -0.02436683f, 0.02438997f, 0.00986915f, 0.04651576f, 0.04545632f, -0.05449151f, 
    -0.02946855f, 0.05244895f, 0.04384550f, -0.00910895f, 0.03262828f, 0.04241462f, -0.01278918f, 0.00587418f, 
    -0.07668705f, 0.05536690f, -0.00456125f, 0.00139000f, 0.02461138f, 0.04109848f, -0.05135819f, 0.02122289f, 
    0.00327363f, 0.04040119f, -0.03569060f, -0.05234018f, -0.03546805f, -0.03084995f, -0.05429365f, -0.06612530f, 
    0.04503284f, -0.02526619f, 0.00255837f, -0.04888451f, 0.02372116f, 0.04710676f, 0.01459853f, -0.04596117f, 
    0.02651758f, -0.07786857f, 0.03338939f, -0.05760827f, 0.00120281f, -0.01952481f, -0.01913858f, 0.00344304f, 
    -0.06555424f, -0.01722788f, -0.05581522f, 0.02943239f, -0.06917908f, -0.05165233f, 0.00348598f, 0.00004698f, 
    -0.06285048f, 0.05909759f, -0.02252953f, -0.02322006f, -0.03441762f, -0.03363322f, 0.02116285f, 0.00594581f, 
    0.02821518f, -0.07146206f, 0.01838446f, -0.00909875f, -0.03639190f, 0.02378849f, -0.00909044f, -0.00436046f, 
    0.12274661f, 0.08411926f, -0.06613709f, 0.07845648f, -0.02429357f, 0.10700078f, -0.02191783f, -0.08070798f, 
    0.05090232f, 0.15441950f, 0.03928168f, -0.04723398f, 0.15176949f, -0.12341786f, 0.02357632f, 0.19992219f, 
    -0.13221654f, -0.04054805f, 0.07974924f, 0.08623450f, -0.00778189f, -0.07561232f, -0.13926165f, 0.01277469f, 
    -0.41989973f, 0.00871744f, 0.09289905f, -0.13240869f, -0.01464762f, 0.02563493f, -0.00861255f, 0.08242793f, 
    -0.01929593f, 0.06332289f, 0.10910332f, 0.08920369f, -0.12524937f, -0.02254312f, 0.04229582f, 0.24298966f, 
    -0.05896385f, 0.00965895f, 0.10740528f, -0.03120861f, -0.02898824f, -0.05238935f, -0.03867780f, -0.04962833f, 
    0.04918039f, 0.15334168f, 0.13060591f, 0.21979566f, 0.00306651f, -0.10137925f, -0.10551443f, -0.03820905f, 
    -0.01271146f, 0.07983565f, -0.02750605f, 0.04769678f, -0.26082167f, 0.05027581f, -0.13347466f, -0.41947168f, 
    0.10916537f, 0.01217768f, 0.03832181f, -0.05037706f, 0.14197092f, -0.01190332f, -0.03214062f, 0.08228124f, 
    -0.24678296f, -0.10920308f, -0.07531474f, -0.01341690f, -0.12337910f, 0.10909742f, -0.01394035f, -0.02979953f, 
    -0.02785259f, -0.10663140f, -0.03487997f, -0.04732975f, -0.18367843f, -0.09224501f, -0.13724214f, -0.00326847f, 
    -0.09162575f, 0.10219700f, -0.00025126f, -0.00533197f, -0.10007781f, -0.03059570f, 0.03458206f, 0.04532333f, 
    0.12852059f, 0.20582470f, -0.02424994f, 0.11030845f, -0.06768206f, 0.00039228f, -0.12093340f, -0.18093070f, 
    -0.11259371f, 0.07006312f, -0.14705878f, -0.01417682f, 0.11210724f, 0.10697176f, 0.11309317f, 0.03751472f, 
    -0.06621748f, -0.00125288f, 0.02178328f, 0.24502283f, 0.06217564f, -0.09613966f, 0.06341399f, -0.05600952f, 
    0.29837042f, 0.20050055f, 0.04143137f, -0.00732902f, 0.12661989f, -0.04117453f, 0.09350321f, 0.07546428f, 
    -0.03038814f, 0.02946042f, 0.07138801f, -0.02176768f, 0.15816058f, 0.18034543f, -0.23764969f, 0.22459464f, 
    -0.07144780f, -0.02722130f, 0.00971560f, 0.00090226f, -0.01534067f, -0.02353049f, 0.00341402f, 0.00591572f, 
    -0.21785156f, -0.18632118f, 0.00385457f, -0.07888877f, 0.07472467f, 0.01795023f, 0.05392819f, -0.08452737f, 
    0.00027314f, -0.04225610f, -0.00281346f, 0.03165334f, 0.14367396f, 0.02502432f, 0.05059345f, 0.13675691f, 
    0.00032873f, -0.06254047f, 0.06086949f, -0.01474509f, -0.11241496f, 0.05758721f, -0.09238451f, -0.00553896f, 
    0.30917990f, -0.02221964f, 0.05664933f, 0.24359933f, 0.04897527f, 0.01642640f, -0.02229500f, 0.09165634f, 
    -0.00281219f, -0.08481755f, 0.00239799f, 0.11567464f, -0.31500134f, -0.06139957f, -0.02924884f, -0.00287674f, 
    -0.00818011f, 0.11191858f, -0.01359227f, -0.01613961f, -0.04737480f, -0.04095207f, -0.02950355f, 0.09334930f, 
    -0.27167815f, -0.08053377f, 0.08716289f, 0.10717072f, -0.11939464f, 0.17521290f, 0.10359181f, -0.05792129f, 
    -0.08195583f, 0.03242329f, 0.00182177f, 0.05855396f, -0.00496129f, 0.05698418f, -0.26264021f, 0.19429642f, 
    0.02078011f, -0.04988253f, 0.01300106f, -0.12325349f, -0.00277790f, 0.03845166f, 0.01231173f, -0.06387752f, 
    0.14590304f, -0.02105562f, -0.17481209f, -0.22470295f, -0.02147382f, 0.04829151f, -0.09009833f, 0.02259794f, 
    -0.07786801f, 0.05576521f, 0.10420509f, 0.08690819f, 0.17339931f, 0.17229259f, 0.10943919f, 0.13134895f, 
    -0.04876610f, 0.06226278f, 0.10839012f, 0.12457407f, -0.03055038f, -0.11234494f, -0.06523353f, -0.09454077f, 
    0.02092714f, 0.09655450f, -0.10957569f, -0.05423909f, 0.09273832f, 0.08303474f, -0.08261661f, 0.17158352f, 
    -0.00049299f, 0.04777540f, -0.07876166f, 0.03115151f, -0.06191327f, -0.05327603f, 0.02519838f, -0.25608721f, 
    -0.03311103f, 0.04497956f, -0.08118934f, -0.01261110f, -0.05846625f, 0.03889355f, 0.02867118f, -0.04156178f, 
    -0.08922540f, 0.08314756f, -0.07605267f, 0.16524638f, -0.07093059f, -0.02322297f, -0.00535285f, -0.06921373f, 
    -0.07892748f, 0.08132362f, 0.07430727f, 0.02009156f, -0.45345822f, -0.00625501f, -0.06690856f, 0.02448217f, 
    0.05337367f, 0.05695214f, 0.27020165f, -0.00211927f, 0.02306139f, -0.05288252f, 0.08224092f, -0.02987180f, 
    0.10742021f, 0.04124074f, 0.00455715f, -0.02912633f, -0.09403849f, 0.00319038f, -0.02890276f, -0.10002876f, 
    -0.10619943f, -0.16254815f, 0.10060224f, 0.05586086f, -0.12940936f, -0.01973709f, -0.11858103f, -0.02287072f, 
    -0.04870829f, 0.09583739f, 0.03772090f, -0.01667933f, -0.02923387f, -0.10965245f, -0.06265792f, -0.25605935f, 
    0.77517521f, 0.12104025f, 0.20872305f, 0.04052801f, -0.05961752f, 0.09922570f, 0.06457665f, -0.01942509f, 
    0.03316535f, 0.08585837f, -0.06348523f, -0.01987610f, -0.04181179f, 0.01387039f, -0.09950588f, 0.03182571f, 
    0.00773916f, 0.01835812f, 0.08068129f, 0.08887801f, 0.06513916f, 0.04914540f, 0.04932000f, -0.03256642f, 
    -0.01417956f, 0.10741465f, 0.09557497f, -0.24625710f, 0.06101588f, 0.00911370f, 0.09439630f, -0.08220675f, 
    0.00380520f, 0.05986040f, -0.01415779f, -0.14077695f, 0.57245767f, -0.25461781f, 0.22687897f, 0.00842565f, 
    -0.07601795f, -0.03165625f, -0.01515586f, -0.09675903f, 0.05135296f, -0.00175244f, 0.04019702f, 0.13369542f, 
    0.34084922f, -0.12053196f, -0.01271215f, 0.27913770f, 0.13533805f, 0.07868075f, 0.01851314f, 0.02296307f, 
    -0.11677842f, 0.11199015f, 0.02343603f, 0.05450136f, 0.28893942f, -0.00983668f, 0.13594235f, -0.02007519f, 
    0.00071801f, 0.21447283f, -0.04751071f, 0.01771569f, -0.04493029f, -0.14010537f, 0.15007417f, 0.17632827f, 
    0.03654964f, 0.03213010f, -0.01004795f, 0.03996264f, -0.04722847f, 0.02388280f, -0.06561708f, 0.03140665f, 
    -0.01602306f, -0.01814742f, 0.05690266f, -0.00230848f, 0.05462629f, -0.05400750f, -0.02381757f, -0.04890798f, 
    -0.01369129f, -0.03482001f, -0.04749556f, 0.03809029f, -0.03043236f, -0.05121619f, -0.03041705f, -0.05407510f, 
    0.00793556f, -0.07203871f, -0.02010528f, -0.07434205f, -0.02688959f, -0.04842043f, -0.02799212f, -0.04175575f, 
    -0.03816497f, -0.01646824f, -0.01653304f, 0.03159650f, 0.01391650f, 0.00585145f, -0.07136913f, 0.01500041f, 
    -0.07043862f, 0.03620108f, -0.07642078f, -0.06607041f, -0.06868018f, 0.01190101f, -0.03820521f, 0.04002780f, 
    -0.03860325f, 0.04217787f, 0.02521836f, -0.04614933f, 0.01520761f, -0.04208057f, -0.02326828f, -0.03261489f, 
    -0.02767808f, -0.02437915f, -0.07277115f, 0.02277846f, 0.02518876f, 0.02317009f, -0.02383554f, 0.02070658f, 
    -0.04650521f, 0.00913823f, 0.04420421f, 0.02899111f, -0.03611468f, -0.03194270f, 0.03916985f, 0.05052919f, 
    0.02123898f, 0.02507254f, -0.07019521f, -0.06044079f, -0.01756657f, -0.05225760f, -0.05573073f, 0.01644215f, 
    -0.07202379f, -0.02426205f, 0.02552514f, 0.03071656f, -0.04525936f, 0.01444791f, -0.07316714f, 0.02129132f, 
    -0.07144830f, 0.00938908f, 0.05057928f, 0.03487091f, -0.05482487f, -0.04361185f, 0.04403346f, -0.07003399f, 
    0.00353812f, 0.00902493f, 0.05388400f, 0.05727593f, -0.05233509f, 0.03888280f, 0.04894204f, -0.06981590f, 
    -0.00856122f, -0.00046195f, 0.04141396f, 0.01517821f, 0.04834604f, 0.05681906f, 0.04212745f, 0.05456082f, 
    0.00763854f, -0.05535133f, 0.02187044f, 0.06001311f, -0.07706223f, -0.02709724f, -0.03033834f, 0.00566379f, 
    -0.00434069f, -0.02360316f, -0.04129281f, -0.04387730f, -0.06972656f, 0.01397565f, -0.02272661f, 0.02074975f, 
    -0.04504506f, 0.04816791f, -0.01370490f, 0.04484031f, 0.01527529f, -0.01977237f, -0.04678633f, -0.05273515f, 
    0.06265896f, 0.05323267f, 0.01342889f, -0.02632493f, -0.04800292f, -0.02202111f, -0.05076778f, -0.06032513f, 
    -0.00726296f, 0.05725438f, -0.06814854f, -0.05427734f, -0.02634976f, 0.02591969f, -0.01849636f, -0.07369685f, 
    0.01500499f, 0.03808542f, 0.06182213f, -0.03230998f, -0.01511874f, -0.06113672f, -0.02210296f, 0.03619020f, 
    0.03699261f, 0.01717508f, 0.01897949f, -0.01571029f, 0.05609610f, 0.01992458f, -0.01887992f, -0.01132858f, 
    -0.07450096f, 0.04442798f, 0.01576950f, 0.05166443f, -0.07700901f, -0.05993588f, -0.04923254f, 0.03537091f, 
    -0.07128666f, 0.04718859f, 0.04329591f, -0.07377406f, 0.01428545f, -0.06807088f, -0.00130364f, 0.03553228f, 
    0.03977532f, -0.06718681f, -0.06116163f, -0.04189636f, 0.02438511f, -0.02714960f, 0.04760799f, -0.02153744f, 
    0.18525375f, 0.20172130f, -0.05392960f, 0.17328273f, -0.03689536f, 0.12214264f, 0.00124340f, -0.00566916f, 
    0.07914537f, 0.10147756f, 0.07559108f, 0.14362237f, 0.22542444f, -0.07561630f, 0.13161951f, 0.09836238f, 
    0.00253049f, -0.04235571f, 0.01273387f, 0.08614486f, -0.07011153f, -0.09881105f, -0.03193186f, -0.16100812f, 
    0.06035249f, 0.16602138f, 0.23507312f, 0.02484631f, 0.01105783f, -0.07292544f, 0.09189205f, -0.01114382f, 
    -0.03545389f, 0.01514153f, 0.00612744f, 0.10710171f, -0.37365869f, -0.05408760f, 0.00655687f, 0.28214306f, 
    -0.05884123f, 0.04993388f, -0.00640614f, 0.11546666f, 0.05386798f, -0.19126880f, -0.07081892f, -0.02890996f, 
    -0.18625392f, 0.09798706f, 0.16532660f, 0.08758067f, -0.05060887f, -0.16703272f, 0.00865263f, 0.05628881f, 
    -0.03479774f, 0.06963155f, -0.10632277f, 0.04751397f, -0.03200088f, 0.28311512f, -0.16049077f, -0.07158878f, 
    -0.08954651f, 0.03499453f, 0.05991667f, -0.05912347f, -0.05271912f, -0.02839256f, -0.03422813f, 0.01750561f, 
    -0.13959824f, -0.20739396f, 0.03214010f, 0.08715696f, 0.04592016f, 0.01115563f, 0.07062469f, -0.01870583f, 
    0.13640845f, 0.08447585f, 0.03121660f, 0.02718385f, -0.23879738f, 0.11314496f, -0.05592067f, 0.01899652f, 
    -0.14110437f, 0.07550550f, 0.01154725f, 0.03318446f, -0.09234501f, 0.17553425f, -0.07934465f, 0.06491852f, 
    0.12522678f, 0.05369031f, -0.16796462f, -0.01467144f, -0.03259201f, 0.05677823f, 0.09263665f, -0.05533936f, 
    -0.02769178f, 0.00052398f, 0.05706758f, 0.05193698f, -0.08286864f, 0.01407255f, 0.22247386f, 0.19517525f, 
    -0.12404576f, -0.00363084f, 0.02985360f, -0.02951159f, -0.08882927f, 0.01484752f, 0.06859419f, 0.05810189f, 
    -0.28363657f, 0.19684967f, -0.00076935f, -0.07144552f, 0.11470652f, -0.02844839f, 0.07356352f, -0.05629314f, 
    0.08957209f, -0.01586802f, 0.04868759f, 0.09202875f, 0.10808346f, 0.14523084f, -0.08245724f, 0.23617896f, 
    -0.03286333f, -0.05462432f, -0.03981236f, 0.15127940f, -0.04533277f, -0.08614708f, -0.04188490f, 0.04325553f, 
    0.05073684f, 0.10213191f, -0.04408449f, 0.04978379f, -0.06837657f, -0.08346301f, -0.01581560f, -0.00464260f, 
    0.07381909f, -0.06591727f, -0.12600422f, -0.05667641f, -0.52951747f, 0.22949101f, 0.12855902f, -0.13816863f, 
    0.05531972f, 0.08734164f, -0.04528687f, -0.00672863f, -0.08814683f, 0.14728887f, 0.02836077f, -0.01055001f, 
    0.34822989f, -0.03352545f, 0.14067966f, 0.17044495f, -0.15907277f, 0.07883347f, -0.02303313f, -0.07299638f, 
    -0.09639540f, 0.05319958f, -0.02788939f, 0.10695685f, -0.07644045f, 0.05318826f, -0.02072830f, 0.05648171f, 
    0.03696126f, -0.11625468f, -0.06151537f, -0.08049746f, 0.03448476f, 0.09312856f, -0.03462006f, 0.02669058f, 
    -0.03588128f, -0.05770440f, 0.05485760f, 0.01182692f, -0.00244184f, -0.04727076f, 0.06829612f, 0.04273418f, 
    -0.02928314f, -0.04002257f, 0.03007816f, -0.00209906f, -0.03634511f, 0.01094375f, -0.00902642f, 0.05277560f, 
    0.01589882f, -0.01284936f, -0.04118408f, 0.04890473f, 0.05501084f, -0.03140733f, 0.04107554f, -0.00104095f, 
    0.03126768f, -0.06917483f, -0.02461939f, -0.06938794f, 0.05004494f, 0.00285500f, 0.05811160f, -0.02247723f, 
    0.03761724f, -0.02810711f, 0.02712643f, -0.06034947f, 0.03606912f, -0.05434161f, -0.02281695f, -0.01424868f, 
    -0.06272005f, 0.01037211f, -0.02164195f, -0.03165394f, 0.04765756f, 0.05293965f, 0.05158594f, -0.03077916f, 
    -0.02544383f, -0.03897171f, -0.06712986f, -0.02164545f, -0.00954275f, -0.04800749f, -0.01364772f, -0.05322722f, 
    -0.01995080f, -0.03780346f, 0.06694826f, -0.05062630f, 0.02132922f, -0.03298553f, -0.03028989f, -0.04820057f, 
    0.00442285f, 0.01267981f, -0.06710473f, -0.01619096f, -0.06900718f, -0.06422085f, 0.02107219f, -0.07613155f, 
    -0.06092382f, -0.06407917f, 0.06298164f, 0.04924249f, -0.07246486f, -0.07286364f, 0.01688057f, 0.05021986f, 
    0.02273045f, -0.02835830f, 0.04964796f, -0.01595355f, 0.06379731f, -0.00720316f, -0.04856542f, 0.00431570f, 
    -0.03997788f, 0.05186455f, -0.05355424f, -0.03952944f, -0.07366741f, 0.02983847f, 0.01635060f, 0.04047725f, 
    0.05478657f, 0.04632460f, -0.01489953f, -0.06545267f, -0.06964054f, -0.06423956f, -0.00654111f, -0.00384272f, 
    -0.02134344f, -0.06489695f, 0.03855500f, 0.00614329f, 0.05946410f, 0.01012247f, 0.01544425f, 0.04636985f, 
    0.00709657f, -0.03650895f, -0.01795848f, 0.04503191f, 0.04521756f, -0.03986587f, -0.01781893f, 0.06566357f, 
    0.04802000f, -0.06516717f, -0.05155485f, 0.05221100f, -0.04069481f, 0.06083642f, -0.03405986f, 0.01684301f, 
    0.01886976f, -0.01825645f, 0.03450603f, -0.00945566f, 0.01333547f, -0.01077993f, 0.01401289f, -0.05052004f, 
    0.04365196f, 0.01456341f, -0.06283309f, 0.04294873f, -0.04089675f, -0.07058360f, 0.00018972f, -0.00714223f, 
    -0.08198114f, 0.02027512f, 0.01864371f, 0.00256602f, 0.05531596f, 0.02344152f, -0.07737011f, 0.01622393f, 
    -0.03704543f, -0.01795761f, -0.07798129f, 0.00949597f, -0.04014276f, -0.01838515f, -0.04521061f, 0.04530303f, 
    -0.05407589f, 0.01620173f, -0.02263646f, 0.04954144f, -0.01518960f, 0.00976732f, -0.07618887f, -0.04999641f, 
    -0.00219384f, -0.02917682f, -0.02071791f, -0.07727522f, 0.00470784f, -0.07862953f, 0.03704796f, 0.01497438f, 
    0.03608464f, -0.03543703f, -0.07613397f, 0.02378327f, 0.00281551f, -0.02677219f, 0.05949998f, -0.01169753f, 
    -0.05336270f, -0.01728509f, -0.04977506f, 0.03005368f, 0.03103978f, -0.05727242f, -0.05962814f, 0.02219616f, 
    0.03856814f, -0.17136908f, 0.14066179f, -0.06955570f, 0.11155374f, 0.07517964f, -0.04398378f, 0.08364786f, 
    0.10435101f, -0.07617150f, -0.09383786f, 0.00882293f, -0.11157563f, 0.08477467f, 0.05545678f, -0.07926016f, 
    -0.13580047f, 0.11310611f, -0.03299145f, -0.10103866f, 0.21422622f, 0.03464068f, 0.05399285f, 0.08229481f, 
    -0.04131912f, -0.06276834f, -0.11707285f, 0.10392726f, -0.02536374f, 0.07169814f, -0.10760183f, 0.04149095f, 
    -0.11290443f, 0.02873014f, 0.03747506f, -0.02726594f, 0.23870641f, 0.07440069f, 0.04659241f, 0.01140227f, 
    -0.01293836f, 0.04727410f, 0.01259610f, -0.00821734f, 0.10227756f, 0.07106209f, 0.07295825f, 0.14945588f, 
    -0.14575629f, 0.01550660f, 0.04982672f, 0.08357429f, -0.02182970f, 0.17248370f, -0.03263773f, 0.03160127f, 
    0.12935202f, 0.05140349f, 0.07837924f, 0.05952262f, -0.27885595f, -0.28357527f, -0.04349753f, -0.09787510f, 
    0.05178495f, 0.01759044f, 0.02209620f, 0.01825726f, -0.02444692f, -0.03944281f, 0.14991347f, 0.14264701f, 
    0.16976655f, 0.29213384f, -0.12400004f, -0.14200546f, -0.17300744f, 0.00887186f, -0.01927870f, -0.03775585f, 
    -0.13198270f, -0.12213437f, 0.03513708f, -0.01975517f, -0.29452690f, -0.29198164f, -0.17935514f, -0.09050661f, 
    -0.04040523f, 0.12072732f, 0.00125269f, 0.02956019f, 0.08535378f, 0.01803283f, 0.06976991f, 0.03030218f, 
    0.04242520f, 0.04839666f, 0.12376720f, -0.04592064f, -0.13764808f, 0.05817541f, -0.02736928f, 0.01714654f, 
    -0.02515580f, 0.19712512f, 0.00064617f, 0.09187642f, -0.12642249f, 0.17797121f, 0.03703635f, -0.13311490f, 
    0.17820232f, -0.01244361f, -0.05279979f, 0.05673228f, 0.04907059f, 0.00028721f, -0.08549828f, 0.10474364f, 
    0.36019492f, 0.01074459f, 0.13020341f, 0.15953499f, -0.10268877f, 0.03429196f, 0.04703138f, 0.00911463f, 
    -0.05262841f, -0.02444791f, -0.07355090f, -0.01244947f, -0.15267156f, -0.20161070f, 0.15547796f, -0.08246817f, 
    0.24729398f, 0.02723887f, 0.13106503f, -0.01060359f, 0.16584659f, 0.07920495f, -0.08751394f, 0.02296476f, 
    -0.30063471f, -0.31302696f, -0.16017759f, -0.19914462f, 0.21138306f, 0.04066548f, 0.06691696f, 0.03580112f, 
    -0.02580685f, -0.02802943f, 0.05523431f, -0.03779060f, 0.52091551f, -0.16471329f, 0.00368288f, 0.13108504f, 
    -0.20813146f, 0.02004538f, 0.15506883f, -0.01333006f, -0.01299516f, 0.03030676f, -0.10529712f, 0.05688658f, 
    -0.02806251f, 0.10709918f, 0.08076469f, 0.03238720f, 0.09157936f, 0.10604573f, 0.00936004f, 0.16715534f, 
    0.04849454f, 0.09492687f, -0.01705143f, -0.14323255f, -0.27065197f, -0.16579637f, -0.17274240f, -0.09566184f, 
    0.10882042f, 0.11918929f, 0.05198405f, 0.02956308f, -0.10770074f, -0.07090928f, -0.05407768f, -0.14505810f, 
    -0.14251150f, 0.01504308f, -0.13079363f, 0.17749524f, -0.01540528f, 0.12102679f, 0.05429022f, 0.01661442f, 
    -0.08308709f, 0.06684630f, -0.01393854f, 0.09617455f, -0.01447162f, -0.02801598f, -0.10175736f, 0.13365754f, 
    -0.03317655f, -0.12570319f, 0.00492464f, -0.06028958f, 0.12059129f, 0.06949556f, -0.13831231f, 0.02354437f, 
    0.36423352f, 0.06263016f, 0.08990529f, 0.02888575f, 0.12279300f, -0.09159184f, -0.01078806f, -0.00412948f, 
    0.02305008f, 0.00810182f, -0.00166761f, -0.04182044f, -0.28984219f, 0.12642372f, 0.11134936f, -0.01607291f, 
    -0.08800179f, 0.10339683f, -0.05793159f, 0.03821905f, 0.09974331f, -0.18619530f, 0.10641829f, -0.09371079f, 
    -0.26600119f, -0.05422439f, 0.06664743f, -0.03684446f, 0.03116715f, 0.06177586f, 0.14318468f, 0.09446182f, 
    0.06540226f, 0.06055131f, -0.05819906f, 0.08284529f, 0.21737216f, -0.05137316f, 0.16808482f, 0.01210845f, 
    -0.20914844f, -0.00973697f, -0.03008947f, 0.03257105f, 0.08381911f, 0.03227030f, 0.05520812f, 0.09987096f, 
    -0.14767168f, -0.09000459f, -0.19553134f, -0.02471232f, 0.03379624f, 0.16308118f, -0.07189626f, -0.03644542f, 
    0.06459209f, -0.04598775f, -0.06980095f, -0.01174246f, -0.06383947f, 0.00913264f, -0.05667709f, -0.00884258f, 
    0.02589629f, -0.05942767f, 0.00107025f, -0.05855012f, 0.10723162f, 0.16793478f, 0.09608462f, 0.10276747f, 
    -0.15893365f, -0.19164243f, -0.07292005f, -0.11275239f, 0.12889998f, 0.09328257f, 0.09217136f, 0.07905234f, 
    -0.06180593f, -0.04292934f, 0.00484260f, -0.11080424f, -0.11860016f, -0.12489181f, 0.05869331f, -0.09514721f, 
    -0.03172291f, -0.12826572f, 0.00454119f, 0.00511630f, 0.01075046f, 0.07112926f, -0.10906149f, 0.04918147f, 
    -0.19139345f, -0.17210038f, 0.02927455f, -0.25759813f, 0.02726943f, -0.05293458f, 0.00786736f, 0.05714502f, 
    0.07131562f, -0.09570796f, -0.02940856f, 0.00993031f, -0.22353606f, 0.03192084f, 0.10979025f, 0.12274060f, 
    -0.04715401f, 0.04570364f, -0.02522309f, -0.00138534f, -0.04802502f, 0.03489641f, 0.03931261f, 0.10071534f, 
    0.08453547f, 0.26038152f, 0.19863339f, 0.13256094f, 0.02677962f, 0.01900245f, -0.00137825f, -0.04019346f, 
    0.04998400f, 0.11290222f, 0.06506993f, 0.09035096f, -0.57555020f, -0.18208896f, -0.03212619f, -0.37568089f, 
    0.09623849f, 0.14514609f, 0.00677407f, 0.07810003f, -0.00130087f, -0.03813551f, -0.00352219f, -0.01433592f, 
    0.02638335f, 0.11228124f, 0.11834164f, 0.25460410f, -0.07450081f, -0.03151812f, 0.00358826f, -0.00025314f, 
    0.00759936f, -0.01332301f, 0.06501335f, 0.02636079f, -0.08706685f, -0.08224539f, 0.23820259f, 0.05769091f, 
    -0.07143416f, -0.10898089f, -0.05882541f, 0.00364821f, 0.10227113f, 0.06328265f, 0.06805298f, 0.16364707f, 
    -0.03633290f, -0.04665541f, -0.01996751f, -0.07481821f, 0.00581855f, -0.07433512f, -0.03391305f, -0.04259668f, 
    -0.03204696f, -0.03921431f, -0.00036895f, 0.06847680f, 0.02413625f, -0.07679892f, -0.05270468f, -0.05276347f, 
    0.06534003f, -0.03203059f, -0.06353084f, -0.03213886f, 0.00603064f, 0.02433388f, -0.03821935f, -0.07011902f, 
    0.01771013f, -0.03168950f, -0.01482393f, -0.00790951f, 0.02482477f, 0.01754667f, -0.03298005f, 0.05466896f, 
    0.03794050f, -0.00490248f, 0.02536666f, -0.00176201f, 0.02148233f, 0.01723849f, -0.05284181f, 0.05477953f, 
    0.05301782f, -0.04450968f, 0.00633539f, -0.02804381f, -0.05562270f, -0.01866376f, -0.05721700f, -0.07613717f, 
    0.05815859f, -0.06956992f, -0.07760070f, -0.02323256f, 0.00962969f, -0.06675365f, 0.00010387f, 0.06225375f, 
    0.02245861f, -0.00372070f, -0.03336351f, -0.03826161f, -0.03897510f, -0.04072783f, 0.01075464f, 0.03068876f, 
    0.03355666f, 0.02912232f, -0.02626385f, 0.02778737f, 0.04956284f, -0.07380246f, 0.05588698f, 0.02375176f, 
    0.05638305f, -0.01363255f, 0.06595652f, -0.00293676f, 0.01931414f, -0.01894265f, -0.05580895f, 0.06340637f, 
    -0.03410544f, 0.05333487f, 0.01490689f, 0.02529897f, 0.01018701f, 0.00899702f, -0.05530667f, -0.02842323f, 
    0.04945027f, 0.03418674f, -0.07359561f, -0.06785030f, -0.04143734f, -0.00983079f, 0.03412003f, 0.03740959f, 
    -0.02639595f, 0.00695731f, -0.02351982f, 0.02302674f, 0.03498648f, -0.06778204f, 0.00952820f, -0.06511801f, 
    -0.03214783f, 0.01926709f, -0.05395145f, -0.01356544f, -0.00535171f, 0.00180809f, -0.06209674f, -0.07673249f, 
    -0.03197281f, 0.00789480f, -0.06142966f, -0.00175006f, -0.02792424f, -0.06194687f, -0.02833200f, 0.04589820f, 
    0.04192867f, -0.01683601f, 0.00091179f, 0.02343644f, -0.05969072f, -0.03295148f, -0.05679588f, -0.07068235f, 
    -0.04159083f, -0.00395152f, 0.01362654f, -0.02012126f, 0.02905994f, -0.01038921f, 0.02923073f, 0.00088002f, 
    0.03825407f, -0.07592238f, 0.04509624f, 0.03552347f, -0.00246887f, -0.04978294f, -0.01835546f, 0.06242637f, 
    0.00824067f, 0.02425015f, 0.01095728f, -0.03789581f, 0.03265237f, 0.02992729f, 0.04204625f, 0.03737788f, 
    0.00178422f, -0.07099283f, 0.03260538f, -0.03749504f, -0.03911855f, 0.02154336f, 0.04253225f, -0.04805597f, 
    -0.07602949f, -0.06995171f, -0.01358351f, 0.03018718f, 0.05564683f, 0.02393364f, 0.01915074f, 0.02575833f, 
    0.02061413f, 0.04955382f, -0.06554819f, -0.04948905f, -0.03468171f, -0.01991644f, 0.00169907f, -0.04398708f, 
    -0.04706830f, 0.00153850f, -0.07212985f, -0.02591900f, 0.02173869f, -0.04293689f, -0.06598979f, -0.00446726f, 
    0.00075650f, -0.00130710f, -0.03445537f, -0.03226928f, -0.03646960f, -0.04048923f, -0.00703601f, 0.06587481f, 
    0.15643319f, -0.09303470f, 0.00639846f, -0.06835283f, -0.03462066f, 0.16130850f, 0.03639983f, -0.09835124f, 
    -0.17328060f, 0.10069863f, 0.02822972f, 0.11475214f, 0.13028331f, 0.09176538f, 0.11383486f, -0.20510773f, 
    -0.05094404f, -0.12784016f, 0.01476505f, 0.09636886f, 0.09668409f, -0.03510088f, -0.03727729f, -0.00880692f, 
    0.35862947f, 0.15187638f, -0.25124726f, -0.02705453f, -0.00750335f, -0.09995618f, 0.13910620f, 0.08734762f, 
    -0.04637491f, 0.02450247f, 0.05338370f, 0.03832309f, 0.04935196f, -0.03995428f, 0.01695768f, 0.08850740f, 
    0.10500725f, 0.02003732f, 0.14217155f, -0.01389532f, 0.22485189f, 0.11321152f, 0.01237860f, -0.01500999f, 
    0.07899471f, -0.11140978f, 0.15986907f, -0.20984083f, 0.04298488f, -0.05275558f, -0.05003766f, 0.01532296f, 
    -0.02477150f, 0.05001960f, -0.02620853f, -0.01994810f, 0.40779325f, 0.26162753f, -0.05931468f, 0.40792790f, 
    -0.06763922f, 0.07956956f, -0.03919104f, -0.02181046f, -0.02559481f, 0.04506875f, 0.02301734f, 0.04347226f, 
    -0.36190376f, -0.09910321f, 0.27854180f, 0.11486693f, 0.13653661f, -0.03078291f, 0.07387520f, -0.01140084f, 
    0.00807551f, 0.12733367f, 0.08094084f, 0.01122011f, 0.12210488f, -0.24825732f, 0.11128192f, 0.04293363f, 
    -0.12156116f, -0.02916666f, 0.06229676f, 0.11727014f, -0.02831268f, 0.07362165f, -0.03548892f, -0.05575636f, 
    0.12261447f, -0.14300103f, 0.08453988f, 0.00325313f, -0.02402014f, 0.10050674f, 0.04138490f, 0.05804869f, 
    -0.02473607f, 0.09142596f, 0.03224991f, 0.00942542f, -0.22468166f, -0.16591510f, -0.16113250f, 0.09194551f, 
    -0.06759328f, -0.02140514f, 0.01817015f, -0.23269999f, -0.00846312f, -0.07261518f, 0.03829467f, -0.04180294f, 
    -0.16089822f, 0.00606336f, -0.12340967f, 0.00133017f, -0.01042541f, 0.06438499f, -0.08256938f, -0.00567692f, 
    0.11230364f, -0.11360271f, -0.10855274f, 0.08190285f, -0.24382533f, -0.30190778f, 0.23158583f, -0.02371759f, 
    0.02587166f, 0.14755794f, 0.13138516f, -0.12191171f, 0.12187005f, -0.02482115f, 0.01112636f, 0.03207601f, 
    0.15364313f, 0.03584653f, -0.02696273f, 0.10309285f, -0.08183597f, -0.04932252f, -0.00760421f, 0.12533984f, 
    -0.02424865f, -0.03429634f, -0.07767075f, -0.10672168f, 0.13274090f, -0.08222692f, 0.08343002f, 0.15616556f, 
    -0.08614726f, -0.00697595f, -0.07907338f, 0.00729756f, -0.05970634f, -0.02443287f, 0.04401316f, -0.02421249f, 
    -0.12733278f, 0.02307910f, 0.14195557f, -0.22164936f, -0.03229574f, 0.01454656f, 0.00341370f, -0.04570654f, 
    -0.17260338f, 0.02830526f, 0.10057838f, -0.06041203f, -0.25503653f, 0.04397127f, -0.04615897f, 0.10732058f, 
    -0.07118616f, 0.02239139f, -0.05412791f, -0.09937697f, 0.00066401f, 0.07372112f, -0.08624432f, 0.05441570f, 
    -0.05580104f, -0.02152397f, -0.04222310f, -0.06300182f, 0.05190830f, 0.06000343f, 0.07188776f, -0.06389011f, 
    0.05092451f, -0.07097181f, 0.05113316f, 0.04103091f, 0.04715426f, -0.07031808f, -0.02666383f, -0.01494388f, 
    0.02621591f, -0.06078535f, -0.01588300f, -0.01403443f, 0.04622858f, 0.01093334f, -0.06282990f, 0.00456305f, 
    -0.06291027f, 0.06268679f, -0.02557424f, 0.04993498f, 0.03278147f, 0.03759428f, -0.03223462f, 0.03194017f, 
    0.01395899f, -0.01723623f, -0.02157590f, -0.02501145f, 0.02296787f, 0.06929973f, 0.00290937f, 0.04941384f, 
    0.00357801f, 0.00266345f, -0.01485332f, -0.01755692f, -0.03784848f, -0.03696913f, 0.02334919f, 0.01459271f, 
    0.00204798f, 0.01395183f, -0.02258846f, 0.00848908f, -0.02383629f, -0.02277189f, 0.03124328f, -0.06543288f, 
    0.04805712f, 0.05002042f, 0.00993926f, -0.04464395f, -0.07078851f, -0.05641335f, -0.00179723f, 0.05908527f, 
    -0.05820285f, 0.00403291f, -0.01562119f, -0.05173491f, -0.04105033f, -0.02215103f, -0.01846712f, -0.03592388f, 
    -0.04907669f, -0.03084875f, 0.07177879f, -0.06731052f, 0.00064900f, 0.05148544f, 0.04979787f, -0.05289086f, 
    -0.04680206f, 0.04487034f, -0.01792480f, 0.06395037f, 0.05581090f, 0.04682724f, -0.06157670f, -0.04360639f, 
    -0.02929025f, -0.01692732f, 0.04059003f, 0.00111105f, -0.04914463f, -0.03118411f, -0.02917037f, 0.02919037f, 
    -0.01415281f, -0.04873364f, -0.01711341f, 0.00393863f, -0.06176469f, 0.02731816f, 0.00114577f, -0.04636764f, 
    -0.01290634f, -0.05698025f, 0.02548864f, 0.05611146f, -0.01787823f, 0.00899894f, -0.01268690f, -0.03011032f, 
    -0.04626988f, 0.05785636f, -0.07076401f, -0.04203167f, 0.02083810f, -0.02158601f, -0.06813014f, 0.05486767f, 
    -0.02467456f, -0.02655749f, -0.06787163f, -0.01229947f, -0.02407801f, 0.02475299f, -0.00040347f, -0.01944024f, 
    -0.06529011f, -0.02285705f, 0.01158909f, 0.02287598f, -0.03208042f, 0.06665530f, -0.05263479f, -0.02519982f, 
    -0.03879953f, -0.00491350f, -0.04120373f, -0.00706761f, -0.04560445f, -0.06090810f, -0.06492751f, 0.02241127f, 
    0.00262335f, -0.07149833f, -0.04264451f, 0.04865261f, 0.02254086f, 0.03461772f, -0.00529582f, -0.04711918f, 
    -0.01137397f, -0.01528825f, 0.05615548f, 0.04075943f, -0.01219472f, 0.02479544f, -0.05198501f, -0.04162800f, 
    -0.03630287f, -0.02207233f, 0.03603157f, -0.05330267f, -0.04414120f, -0.01985136f, 0.03233257f, -0.03262123f, 
    -0.03110292f, -0.04790069f, 0.04784387f, -0.05896666f, -0.02775387f, 0.03681679f, -0.06852952f, -0.02837294f, 
    -0.04756333f, -0.06186587f, -0.04024852f, 0.01241265f, -0.05901165f, 0.03268374f, 0.02207055f, -0.00067674f, 
    0.05033277f, -0.04817604f, 0.05400717f, -0.06123337f, 0.03013683f, -0.03162382f, 0.01279809f, -0.01491908f, 
    0.17502591f, -0.00992374f, -0.04782496f, 0.01590989f, -0.00416500f, 0.07363728f, -0.10851179f, -0.00592656f, 
    0.10077836f, -0.06979474f, 0.08725024f, -0.03658499f, 0.01596438f, -0.07188088f, 0.06009128f, 0.07250486f, 
    -0.13421117f, 0.09738391f, 0.10551023f, -0.02646657f, 0.17445330f, 0.10915341f, -0.04462428f, 0.09376001f, 
    -0.55282336f, -0.08755430f, 0.03271279f, -0.17213853f, -0.03520717f, -0.03736189f, -0.21511540f, 0.08557541f, 
    0.02784183f, 0.06431196f, -0.03540856f, -0.12674820f, 0.10241397f, -0.02864223f, 0.10278908f, -0.07900813f, 
    0.06037980f, -0.03074212f, -0.04510717f, -0.04874310f, -0.14008886f, 0.18798444f, 0.05273407f, 0.18920866f, 
    0.00403931f, 0.18666646f, 0.09727081f, 0.21031265f, 0.01915394f, 0.14109400f, 0.00687672f, -0.02347418f, 
    0.02419481f, -0.12824315f, 0.02323653f, -0.06888235f, -0.08625145f, -0.24557461f, 0.18639565f, -0.17397745f, 
    0.10914664f, -0.01825575f, 0.06991764f, -0.03158493f, 0.18907771f, -0.03407529f, 0.01962495f, -0.05358282f, 
    -0.02727465f, 0.03656319f, -0.24700476f, -0.19709085f, 0.00190297f, -0.01669193f, -0.09198338f, 0.06353577f, 
    0.00332979f, -0.02241290f, -0.05897830f, -0.18875569f, 0.14225917f, 0.10402682f, 0.04515684f, -0.12254800f, 
    0.01823752f, 0.06112957f, -0.26042569f, -0.17325883f, 0.03370848f, -0.09386824f, 0.01931998f, -0.09226389f, 
    0.24877785f, 0.19490610f, 0.05856468f, 0.18182319f, 0.01906162f, -0.06261326f, -0.18069488f, 0.09343966f, 
    0.21253365f, 0.09972635f, -0.01302679f, -0.05927470f, 0.05939329f, 0.14367856f, 0.12034032f, -0.06722894f, 
    0.03361670f, -0.06016437f, 0.04728885f, 0.22958703f, 0.03739247f, -0.02400373f, -0.02542421f, 0.11440860f, 
    -0.12253846f, 0.05309934f, -0.03692221f, 0.15033454f, 0.10110766f, 0.01611977f, 0.15556324f, -0.04313589f, 
    -0.09479977f, -0.02245074f, -0.06397857f, -0.04555905f, 0.26608771f, 0.10159694f, -0.14518695f, 0.25112772f, 
    0.01524912f, -0.14399678f, -0.05526365f, -0.12416213f, 0.01046006f, 0.14388619f, 0.01034636f, 0.04055735f, 
    -0.06699136f, -0.24818631f, 0.10173404f, 0.13246813f, 0.20040207f, 0.01732431f, 0.02529329f, -0.15820618f, 
    0.11299422f, -0.04290361f, 0.21471068f, 0.24572822f, -0.00557490f, -0.13244149f, 0.07456224f, -0.10137480f, 
    0.06421392f, -0.02191344f, 0.08484858f, 0.00454009f, 0.11674552f, -0.01253278f, -0.01781962f, -0.01640112f, 
    0.01579384f, -0.02430558f, -0.19738354f, 0.16949566f, 0.04392483f, -0.09471389f, 0.14890362f, 0.10140969f, 
    0.18061967f, 0.06940822f, 0.21022743f, -0.08429870f, -0.04997022f, -0.16509354f, -0.08223234f, 0.00908944f, 
    0.03973126f, 0.11069663f, 0.06798328f, 0.07888427f, 0.05121376f, -0.07667892f, 0.07285214f, -0.15188764f, 
    -0.06983950f, -0.30610669f, -0.14420946f, -0.06651296f, -0.02348777f, -0.12573841f, -0.05481088f, 0.04448330f, 
    -0.03889053f, -0.09261945f, -0.10092298f, 0.04802795f, -0.23424785f, 0.13237153f, -0.15844743f, -0.26070336f, 
    -0.09465148f, 0.06726372f, 0.02512491f, 0.07023500f, 0.04820764f, 0.17559828f, 0.07923010f, 0.04592571f, 
    -0.28540146f, 0.15015641f, -0.15300943f, 0.00997923f, -0.17345054f, -0.01464244f, -0.07705528f, 0.05250031f, 
    0.03533770f, 0.03578029f, 0.03723450f, -0.06055855f, 0.10285699f, 0.05217080f, 0.09886468f, -0.24028806f, 
    0.09328773f, 0.11541036f, 0.07605758f, 0.20233634f, -0.14501947f, 0.06332719f, 0.00892638f, 0.07328775f, 
    0.07757952f, 0.00956106f, -0.10572157f, -0.11544670f, 0.06137423f, 0.12313208f, 0.04538661f, -0.00710305f, 
    0.11010854f, -0.14904977f, -0.05323538f, -0.05309470f, 0.22806090f, -0.34271777f, 0.04245905f, 0.20886371f, 
    -0.06834453f, -0.01682425f, -0.16227891f, 0.02680241f, 0.02545982f, 0.03316884f, 0.06245032f, 0.05334992f, 
    0.20972097f, -0.01320068f, -0.03056212f, -0.13639653f, 0.02117540f, -0.05071311f, 0.01250786f, 0.01793977f, 
    -0.16757295f, 0.01716539f, 0.01284353f, -0.02864198f, -0.03906654f, 0.04267931f, 0.04753018f, 0.03931972f, 
    0.10802574f, -0.11736359f, 0.04270435f, 0.01489747f, 0.02323287f, -0.04285987f, -0.00781033f, -0.03195821f, 
    -0.07456685f, 0.00859395f, 0.07401389f, 0.08204249f, 0.05079855f, -0.10044793f, 0.03445759f, 0.01571553f, 
    0.16306874f, -0.03858776f, 0.00136357f, 0.22037266f, -0.17859581f, 0.30291182f, -0.12693462f, -0.17167534f, 
    -0.04649285f, 0.08060150f, -0.02897684f, 0.01613094f, 0.01241836f, 0.04757102f, -0.07633344f, -0.14715292f, 
    0.30861074f, -0.01407842f, 0.05041102f, 0.15870790f, -0.05240975f, -0.01821415f, -0.11872773f, 0.07468902f, 
    -0.03474232f, -0.03192076f, 0.00044248f, 0.04475829f, 0.30414709f, -0.15741330f, 0.02842746f, 0.05908843f, 
    0.17598131f, -0.05231902f, 0.11995338f, -0.00358947f, 0.07814997f, 0.00048065f, 0.01967146f, 0.03405190f, 
    0.23867567f, -0.03694514f, -0.13172679f, 0.28181574f, -0.00581777f, 0.07202809f, 0.11926758f, -0.02346757f, 
    -0.04354849f, -0.03026533f, 0.04620036f, -0.02797043f, 0.40063864f, -0.01761447f, -0.02494917f, 0.09378864f, 
    -0.12056561f, -0.02675824f, 0.02014787f, -0.00088504f, 0.11240932f, -0.06242316f, -0.03680097f, 0.10714708f, 
    0.08652902f, -0.07389505f, -0.09343191f, -0.14292623f, 0.08481768f, 0.03111654f, 0.14293559f, 0.10179679f, 
    0.08598174f, -0.04859597f, -0.05584871f, -0.11445264f, 0.27650082f, -0.03172315f, 0.13572538f, 0.20378602f, 
    -0.04294825f, 0.08010257f, 0.07113162f, 0.04487646f, -0.03429312f, 0.08529421f, -0.04131185f, 0.03238077f, 
    -0.00267494f, 0.03394495f, -0.00197500f, 0.04184828f, 0.03809812f, -0.06250359f, -0.07648055f, -0.06606835f, 
    -0.01764731f, -0.03918328f, -0.03265705f, 0.03464097f, -0.00507968f, -0.00678697f, -0.07621223f, 0.03251525f, 
    0.02678556f, -0.07797953f, 0.01179224f, -0.06994776f, 0.04231957f, -0.08626749f, -0.03078399f, -0.02346988f, 
    -0.03555234f, 0.00454401f, -0.04051361f, -0.01958021f, -0.08961966f, 0.00216506f, -0.05442392f, -0.02226957f, 
    -0.00889818f, 0.05453861f, 0.00146049f, -0.04672820f, -0.02798065f, 0.04099470f, 0.05612599f, -0.05042045f, 
    -0.02073858f, -0.06129257f, 0.04282801f, 0.02491224f, -0.07203878f, -0.04302391f, -0.06700338f, -0.04584668f, 
    0.02632645f, -0.02570775f, 0.01341571f, -0.01195411f, 0.02586268f, -0.02413822f, -0.00771872f, 0.03610931f, 
    -0.06222096f, 0.04478848f, -0.01932191f, -0.05899387f, 0.04508960f, 0.01026059f, 0.02015103f, -0.06660156f, 
    0.02498416f, -0.08370700f, -0.01212243f, -0.05299814f, -0.07544523f, -0.03842583f, -0.00590165f, -0.03944816f, 
    0.04340026f, -0.00139985f, -0.06250551f, 0.05609440f, -0.03129146f, 0.01343994f, -0.08029539f, 0.04393750f, 
    0.01147409f, 0.00479756f, -0.02236426f, -0.04753207f, 0.03830699f, -0.01577278f, 0.01993090f, 0.02664913f, 
    -0.04860036f, 0.00522305f, 0.00078362f, 0.06281312f, -0.06083317f, -0.04771527f, -0.02897623f, -0.08664171f, 
    -0.01971317f, -0.06168225f, -0.06516735f, 0.03182924f, -0.02128462f, -0.04356540f, -0.00779611f, -0.06439160f, 
    -0.04053799f, -0.03751761f, -0.05864616f, 0.00850895f, 0.04807964f, 0.01536123f, -0.03093695f, 0.00080240f, 
    0.05184842f, -0.04502002f, 0.02223275f, -0.02631605f, 0.00770536f, 0.01479695f, -0.09228949f, -0.00295128f, 
    -0.03421453f, -0.08002228f, -0.08851051f, -0.08206684f, -0.00923736f, -0.04670200f, 0.01865447f, -0.08619300f, 
    0.02456027f, -0.06888704f, -0.08079787f, 0.02971209f, 0.01117880f, -0.04009235f, -0.09121636f, -0.00351870f, 
    0.01432921f, -0.07686027f, -0.08698494f, 0.02655273f, -0.06278616f, -0.05871589f, 0.02470532f, -0.04566110f, 
    0.04312571f, 0.04165521f, -0.05738548f, 0.05278123f, 0.01455980f, 0.01539372f, 0.00862563f, 0.01922075f, 
    -0.04420759f, -0.05473767f, 0.02966766f, -0.03443818f, -0.01418413f, -0.06859549f, 0.01352982f, 0.00828297f, 
    0.02139860f, 0.01363785f, -0.10374855f, -0.04576995f, 0.00305994f, -0.03829467f, 0.02230692f, -0.01377350f, 
    0.01282135f, 0.02499927f, -0.04208332f, -0.04173836f, -0.01147036f, 0.04893211f, -0.01401061f, -0.05379477f, 
    -0.06352415f, -0.03425884f, 0.05881142f, 0.00185071f, 0.01625660f, 0.03038261f, -0.05357195f, 0.04042599f, 
    -0.01888716f, 0.06098440f, 0.04920441f, -0.07039308f, 0.01313555f, 0.02606281f, -0.03502732f, -0.03969545f, 
    -0.04079178f, -0.05978858f, 0.01645516f, 0.00436811f, 0.02341873f, -0.07796399f, 0.00109732f, -0.06831320f, 
    0.04132358f, -0.05851273f, -0.04668827f, -0.05706292f, -0.06119664f, -0.03553130f, -0.03062492f, -0.03832373f, 
    -0.08025745f, -0.07645271f, -0.07700195f, -0.07784406f, -0.00799388f, 0.01993268f, 0.06694028f, 0.01257476f, 
    -0.00193896f, 0.03836005f, -0.04959719f, -0.04435977f, -0.08628786f, 0.01990743f, -0.06656359f, 0.01430222f, 
    -0.04135801f, -0.04677203f, -0.02280686f, -0.07158112f, 0.01687972f, -0.04367656f, -0.04528989f, 0.00232563f, 
    0.04906475f, 0.05848822f, -0.07490168f, -0.02162523f, -0.05361639f, -0.03647835f, -0.07532100f, -0.07261656f, 
    0.02222814f, 0.04542062f, 0.05380607f, -0.04317211f, -0.01904738f, -0.00878921f, 0.01878057f, -0.06660824f, 
    0.04075719f, 0.03066149f, 0.01486092f, -0.06934213f, 0.01046182f, 0.00951897f, -0.02201339f, -0.00832517f, 
    -0.08530847f, -0.02334159f, -0.03313870f, -0.08349948f, 0.04889930f, 0.02198422f, -0.05687822f, 0.00437840f, 
    0.04360990f, 0.04555395f, 0.01114953f, -0.01684370f, 0.01221944f, -0.09572415f, 0.03643490f, -0.00127444f, 
    0.04051717f, 0.01538699f, 0.03047005f, -0.07038576f, -0.01751844f, -0.03431015f, 0.05026291f, -0.02603830f, 
    -0.05309207f, 0.00619515f, -0.03032020f, 0.03580982f, -0.02063537f, 0.00275567f, 0.03095861f, 0.01238818f, 
    0.02816298f, 0.02957548f, -0.06280975f, 0.00413132f, -0.06380578f, -0.05455493f, -0.00170052f, 0.01529779f, 
    0.00406823f, 0.05844832f, 0.04500872f, 0.05340808f, -0.06361154f, -0.07603867f, 0.03927697f, -0.05047988f, 
    -0.03241270f, 0.02858503f, -0.08808867f, 0.04787046f, -0.02834647f, 0.00925450f, 0.04074120f, -0.00709798f, 
    0.03163450f, -0.06143861f, -0.06908498f, 0.03560472f, -0.01020407f, 0.03337687f, -0.00717777f, 0.02045844f, 
    0.03893286f, -0.03630011f, 0.04039856f, -0.04134193f, 0.04321975f, -0.02769293f, -0.01655526f, 0.04329717f, 
    0.00719238f, 0.00997807f, 0.01726677f, -0.10908809f, 0.05031405f, -0.02577276f, 0.03287388f, 0.05067240f, 
    -0.04450963f, -0.07986956f, -0.05092527f, 0.04599685f, -0.02509742f, -0.05203494f, 0.02041439f, -0.00759564f, 
    0.01750740f, -0.07015894f, -0.09042852f, -0.08986951f, 0.04225477f, -0.05714321f, -0.00371901f, 0.03268846f, 
    -0.01428045f, -0.01039885f, 0.04628860f, -0.00304067f, -0.05871873f, -0.04273861f, -0.04737391f, -0.06787331f, 
    -0.06157995f, 0.03443708f, 0.03698666f, 0.04761718f, 0.01449786f, 0.06700368f, 0.02474892f, -0.06621498f, 
    -0.06946635f, -0.05852134f, 0.02710265f, -0.05199900f, -0.05061230f, -0.03531263f, -0.03197678f, -0.00487682f, 
    -0.08448759f, -0.06171510f, -0.08508884f, 0.03599881f, 0.03591774f, -0.10425774f, -0.04956331f, 0.03995585f, 
    -0.05697988f, -0.00412662f, -0.06729504f, 0.00112991f, 0.05406654f, -0.08190353f, -0.00646087f, -0.06594203f, 
    -0.03141176f, 0.03083802f, 0.04767235f, -0.05386673f, 0.05385736f, -0.04605241f, 0.01530118f, -0.03651471f, 
    0.00659035f, -0.08007003f, 0.00625474f, -0.01958743f, 0.00365525f, -0.02114140f, 0.03888412f, 0.06196672f, 
    0.04043486f, 0.00936684f, -0.04531326f, -0.07349116f, 0.05276507f, -0.04134273f, -0.00500154f, -0.02561844f, 
    0.05188389f, 0.05030169f, -0.05421388f, -0.02911921f, -0.04416879f, 0.04453624f, -0.02314883f, -0.04667909f, 
    -0.03037810f, -0.01625466f, 0.03058608f, -0.06087967f, -0.07740615f, -0.07327673f, 0.02619599f, -0.05520884f, 
    0.07509310f, 0.03222607f, -0.06513452f, -0.05236034f, -0.06697340f, -0.07253551f, 0.05076335f, 0.01719924f, 
    -0.04590108f, -0.02713347f, -0.05686501f, 0.02579071f, -0.05508484f, 0.04457700f, -0.04467495f, 0.04948515f, 
    -0.07555107f, -0.03403991f, 0.03006556f, -0.07212211f, 0.04275258f, 0.00247601f, -0.04082005f, 0.04706386f, 
    -0.06980283f, -0.06454571f, -0.04938927f, 0.05590006f, 0.01722432f, -0.08207651f, 0.01367347f, -0.06455787f, 
    0.02226006f, 0.04936965f, 0.05641581f, -0.02851538f, 0.00149775f, 0.02251515f, -0.05532010f, 0.04093159f, 
    0.02168008f, -0.01501729f, 0.03125243f, -0.04464116f, 0.00503421f, -0.04286552f, -0.03162440f, -0.03199564f, 
    -0.03329527f, -0.01505837f, 0.03941701f, -0.03031565f, -0.01534527f, 0.00456446f, -0.01861065f, -0.04216106f, 
    -0.01309571f, 0.02419030f, -0.02685681f, 0.02441457f, 0.03858692f, -0.03480325f, 0.03111893f, 0.05738904f, 
    -0.07726852f, 0.03407481f, -0.01521679f, 0.00874351f, -0.00204795f, 0.05156654f, 0.02543779f, -0.08487972f, 
    -0.04915329f, 0.01292953f, 0.01714702f, -0.00042701f, -0.01179688f, 0.01757927f, -0.05270329f, -0.02850409f, 
    -0.06030370f, -0.07600626f, 0.05219515f, 0.00102482f, 0.06784522f, 0.04166852f, -0.05678677f, 0.01030137f, 
    -0.03458099f, -0.00532143f, 0.02394423f, -0.01529424f, -0.07735789f, -0.02120415f, 0.02316576f, -0.05803523f, 
    -0.02931182f, 0.00128002f, -0.02152281f, -0.08364996f, -0.02272464f, 0.05254399f, -0.02090066f, -0.02271442f, 
    0.02593965f, -0.06841796f, 0.01093755f, -0.05879029f, 0.06502035f, -0.00267049f, 0.02005437f, -0.06273632f, 
    -0.03389539f, -0.02587518f, 0.00881926f, 0.05895981f, 0.02137160f, -0.03834035f, -0.00121060f, -0.01728746f, 
    -0.02460927f, 0.01332877f, 0.04772241f, -0.07451216f, -0.07813104f, 0.02520237f, -0.02858614f, -0.03967049f, 
    0.04236949f, -0.03937137f, -0.03988015f, 0.05463298f, -0.01040923f, -0.04414891f, 0.02124458f, 0.05063286f, 
    -0.03128329f, 0.02279403f, 0.00641124f, 0.01574436f, -0.07223544f, 0.04330976f, -0.02288898f, 0.04208863f, 
    -0.02479254f, -0.16783625f, -0.26448405f, 0.05422772f, 0.01637598f, 0.00146631f, -0.07683434f, -0.01672875f, 
    -0.11375295f, 0.05566702f, -0.01382934f, -0.02402358f, 0.03928071f, 0.25719675f, -0.23311955f, -0.12627845f, 
    -0.04476978f, -0.13219033f, -0.00843713f, -0.00943998f, 0.00121742f, -0.01564761f, 0.02572026f, -0.01791073f, 
    0.07664762f, 0.13890195f, -0.14496639f, -0.03968543f, -0.15893468f, -0.01446236f, 0.02759793f, 0.05499637f, 
    0.02312676f, 0.04225990f, -0.00771340f, 0.01166045f, -0.11461638f, 0.05293167f, 0.07985692f, -0.00482349f, 
    -0.05532475f, 0.07548046f, 0.04804742f, 0.12755243f, 0.04635788f, -0.09034500f, -0.07363121f, -0.06303965f, 
    0.01496543f, 0.11737198f, -0.03545900f, -0.31376234f, -0.00620845f, -0.01629744f, -0.15519536f, 0.01232304f, 
    0.07965114f, 0.05079200f, -0.02115750f, -0.05236876f, 0.31181091f, -0.07013883f, 0.17182870f, 0.24607421f, 
    -0.12676150f, 0.00976461f, -0.11538916f, 0.03869561f, -0.20945497f, -0.02836571f, -0.06451233f, 0.06337671f, 
    -0.06095678f, 0.13141297f, 0.09222123f, 0.20847990f, -0.07387979f, -0.15176275f, -0.02509823f, -0.00126073f, 
    -0.03842443f, 0.02677449f, 0.05814909f, 0.06897505f, -0.31063840f, -0.06719290f, -0.00243293f, 0.10874218f, 
    0.00899486f, -0.15742728f, 0.15185730f, 0.00617637f, -0.10453653f, 0.01171106f, -0.00797438f, -0.03891654f, 
    -0.23671499f, -0.03619795f, -0.12191593f, -0.21668930f, -0.12872767f, -0.02202546f, -0.04619045f, 0.03937536f, 
    0.01666068f, -0.07040936f, 0.03481537f, -0.02657577f, -0.17307322f, 0.08227547f, -0.13068317f, -0.22643432f, 
    -0.04000868f, -0.05444920f, 0.08062149f, -0.12901531f, -0.06754077f, -0.12598135f, 0.02597378f, -0.13458489f, 
    0.55993497f, 0.02438937f, 0.05638408f, -0.09472276f, -0.07366982f, 0.01101396f, -0.02880433f, -0.00577219f, 
    0.14633326f, -0.03477716f, -0.07252529f, 0.04918518f, -0.08782685f, -0.19722953f, -0.03363128f, -0.11331154f, 
    0.03274243f, 0.02870477f, 0.03653777f, 0.09347112f, 0.04429863f, -0.00105927f, -0.02676129f, -0.05147764f, 
    0.03006744f, 0.09210560f, -0.04662623f, 0.17776449f, -0.02536545f, 0.08772454f, 0.02798145f, -0.02459995f, 
    -0.05022555f, -0.05441206f, -0.03259022f, -0.20534563f, 0.41597050f, -0.14166433f, 0.30962831f, -0.02198208f, 
    -0.21354999f, -0.05167118f, -0.02026905f, -0.15068394f, 0.03337986f, -0.03346828f, -0.04761872f, 0.08608931f, 
    0.13289258f, 0.01206183f, -0.10812935f, -0.08254605f, -0.00571210f, 0.02258048f, 0.01081860f, 0.05051035f, 
    -0.07802328f, -0.00763132f, 0.00267131f, -0.05025201f, 0.07774343f, 0.05367560f, 0.08961976f, 0.25165451f, 
    -0.12159560f, 0.13512242f, 0.03285987f, 0.06229839f, -0.05433308f, 0.08837632f, -0.03527009f, 0.15865541f, 
    0.19156934f, 0.21396871f, 0.13074774f, -0.11440529f, -0.05041357f, -0.07149411f, 0.04473247f, 0.05974832f, 
    -0.03587861f, -0.12640028f, -0.03867620f, -0.01547447f, 0.00513708f, 0.12843858f, 0.10096698f, -0.09159961f, 
    0.06507825f, -0.08998837f, -0.10412833f, 0.04658120f, -0.02499187f, -0.07446766f, 0.07133911f, -0.03320277f, 
    0.21104386f, 0.04325002f, 0.06216231f, 0.25476310f, 0.12546904f, 0.00472911f, 0.13477960f, -0.06921292f, 
    -0.02065818f, -0.04939478f, -0.06346510f, 0.15608504f, 0.14464878f, -0.07263768f, -0.03672265f, -0.10612600f, 
    -0.05284781f, -0.05825783f, -0.04457060f, -0.12973815f, 0.18290266f, -0.02683753f, -0.03964814f, -0.11955967f, 
    0.11842594f, -0.28314784f, 0.08506879f, 0.03689927f, 0.11424007f, -0.13979685f, -0.06571510f, -0.00322899f, 
    0.03549770f, 0.04178704f, -0.04519188f, -0.09208165f, -0.04224529f, 0.49489307f, -0.11716152f, 0.17092913f, 
    0.08715630f, 0.00878832f, -0.01084759f, -0.10667638f, -0.23991229f, -0.06129402f, -0.04951421f, 0.00377088f, 
    -0.04616404f, 0.13636295f, 0.25707480f, 0.00934258f, 0.07503975f, 0.02259568f, 0.07640278f, 0.07568877f, 
    0.12988113f, -0.05124885f, 0.05199889f, 0.12301383f, 0.46101996f, 0.07802394f, 0.03520203f, -0.11130194f, 
    -0.06418730f, 0.04669458f, -0.02232987f, 0.15287489f, 0.01358885f, 0.00382779f, -0.04766110f, 0.09877657f, 
    -0.03051515f, -0.09944060f, 0.18520068f, 0.06185057f, -0.00002534f, 0.03848652f, 0.04763903f, 0.02402997f, 
    -0.03000300f, 0.10239507f, -0.08410036f, 0.03136254f, 0.29216787f, -0.18133274f, -0.02562176f, 0.12234110f, 
    0.06738574f, 0.04890662f, -0.06126101f, -0.13782425f, 0.09778251f, -0.00270704f, 0.06755516f, 0.04199624f, 
    -0.00984344f, -0.12770826f, 0.03786973f, 0.00323731f, -0.01092170f, -0.00540218f, -0.07754587f, -0.00842904f, 
    0.02851276f, -0.00872108f, -0.03802505f, 0.01014463f, -0.15854479f, -0.09234877f, 0.03775230f, -0.15763421f, 
    -0.08331818f, 0.01299936f, -0.00853031f, -0.04189386f, -0.14647540f, -0.01516221f, 0.14380802f, -0.03020663f, 
    0.12859680f, 0.03271653f, -0.07772803f, -0.06910255f, -0.02483200f, 0.05589694f, -0.06365798f, 0.08663706f, 
    -0.07577854f, 0.04400247f, -0.02595978f, -0.13931555f, 0.26674700f, -0.00334910f, 0.08107331f, 0.11741549f, 
    -0.01875435f, 0.08410276f, -0.01508555f, 0.00708370f, 0.02934659f, 0.06008554f, -0.08364236f, 0.00234685f, 
    -0.36143458f, 0.17315634f, 0.16552339f, -0.30713233f, -0.00702998f, -0.18687347f, -0.13406694f, -0.01234743f, 
    -0.14697477f, 0.01847023f, 0.03425462f, 0.03080480f, 0.07414689f, 0.10318056f, 0.00160507f, 0.02890188f, 
    -0.03765597f, 0.03182404f, -0.09956829f, 0.00706472f, -0.16524836f, -0.02699250f, -0.09316836f, -0.07279208f, 
    0.12389231f, 0.08554189f, 0.04361900f, 0.03619080f, 0.00486389f, -0.01915890f, 0.01588622f, 0.01706525f, 
    -0.02088899f, 0.14306775f, 0.13314049f, -0.04746747f, 0.00832797f, 0.04909039f, -0.23380461f, 0.03176278f, 
    -0.15211076f, -0.08564139f, -0.06269055f, -0.09708419f, -0.07285710f, 0.08966931f, 0.08803502f, -0.01968588f, 
    -0.36162531f, -0.12190630f, -0.12475137f, -0.23560613f, -0.03941000f, 0.02265799f, -0.02948209f, -0.01633558f, 
    0.01494370f, 0.04145161f, 0.05113610f, 0.11239243f, 0.08639961f, 0.16556442f, -0.01797122f, 0.14575285f, 
    0.02976511f, 0.00585466f, 0.10632246f, 0.05666833f, -0.08952577f, -0.08920043f, -0.06817170f, -0.03007529f, 
    0.06467138f, 0.15212630f, -0.27121308f, -0.13675430f, 0.06101477f, 0.15086095f, 0.09491926f, 0.03898360f, 
    -0.03251902f, 0.09618042f, 0.04979566f, 0.16118163f, 0.22855406f, -0.10032689f, 0.13783632f, -0.15203291f, 
    0.11793253f, 0.10191430f, -0.04808845f, 0.06136808f, 0.06255775f, -0.01254082f, 0.03882803f, 0.05256290f, 
    -0.11401779f, -0.24722411f, -0.05756732f, 0.09627606f, -0.06297804f, -0.08671709f, 0.07626675f, -0.01962377f, 
    -0.12838288f, 0.12177367f, 0.05932673f, -0.05046296f, -0.15253425f, 0.23675787f, 0.06236482f, 0.09173974f, 
    0.15043209f, 0.05069266f, 0.05853668f, 0.01929658f, -0.03878523f, -0.14681774f, 0.04678851f, -0.04681104f, 
    0.10916664f, 0.22663301f, 0.01072144f, 0.08279222f, -0.00269045f, -0.00496840f, -0.04274892f, -0.08562444f, 
    0.09775271f, 0.03406112f, 0.01933111f, 0.00711358f, 0.14335702f, -0.03422670f, -0.12782821f, -0.09652918f, 
    -0.13917373f, 0.02652459f, -0.00516108f, 0.05644900f, 0.00905473f, -0.13435860f, -0.10920183f, -0.21829171f, 
    0.26103806f, 0.11320215f, 0.06394041f, -0.06119326f, -0.04448733f, 0.07202426f, 0.07900766f, 0.04606770f, 
    0.00774847f, -0.00487183f, 0.10227641f, -0.01264348f, 0.19471151f, 0.16494419f, -0.20418458f, 0.01453233f, 
    0.05073169f, -0.00234849f, 0.02570700f, -0.03123684f, 0.06571499f, 0.13334070f, 0.01675129f, 0.06150062f, 
    0.26433972f, 0.15066715f, 0.09441801f, -0.07038952f, 0.07404176f, 0.16168755f, -0.01827766f, -0.10336764f, 
    -0.05651190f, -0.01610916f, 0.06317151f, -0.05268930f, 0.18171871f, -0.12664768f, 0.04087232f, 0.18207572f, 
    -0.00602369f, -0.08961057f, -0.08358181f, -0.11608317f, 0.00389755f, -0.00556064f, 0.04010122f, 0.01428878f, 
    0.12937388f, -0.19557883f, -0.17234473f, 0.05244194f, 0.16193710f, 0.06962131f, -0.04498056f, 0.07252214f, 
    0.09087398f, 0.05924690f, 0.02902441f, -0.01358610f, 0.36398181f, 0.10912903f, 0.16706426f, -0.05406119f, 
    -0.04454444f, 0.15479572f, 0.09829344f, 0.03818909f, 0.05362658f, -0.07059051f, 0.03915647f, -0.03075481f, 
    -0.37117073f, -0.03626318f, 0.08883832f, -0.03414870f, 0.03670543f, 0.03879691f, -0.08131016f, 0.02104932f, 
    0.07034086f, -0.02252782f, 0.08210477f, -0.12003899f, -0.14980729f, -0.06990308f, -0.19697724f, 0.17628846f, 
    -0.05780779f, 0.08897697f, -0.05234548f, -0.21766956f, -0.02242047f, 0.13555038f, 0.02212075f, 0.08340541f, 
    -0.06250629f, -0.14283195f, -0.22464330f, -0.04472844f, -0.05151793f, 0.08823168f, -0.06410678f, -0.07720690f, 
    -0.03433598f, -0.01700135f, -0.03060792f, -0.12303564f, 0.17291446f, 0.13395764f, 0.01170367f, -0.11995747f, 
    0.05349846f, -0.01599645f, -0.04859972f, 0.04413157f, -0.13261367f, 0.08054926f, 0.12058844f, 0.05122548f, 
    0.15052389f, 0.10018352f, -0.24351287f, 0.01203479f, 0.02314991f, 0.04503281f, 0.15249106f, 0.02323375f, 
    0.01342580f, -0.16786735f, 0.01585197f, -0.04972380f, -0.13137288f, -0.33240983f, 0.23507011f, -0.18431336f, 
    0.03006842f, -0.06122409f, -0.05987012f, 0.10077289f, 0.07234746f, 0.01470357f, 0.01280728f, -0.05200351f, 
    0.11606744f, 0.00544272f, -0.39061230f, -0.03800781f, -0.06436075f, -0.02648403f, -0.04592872f, -0.04337393f, 
    -0.12307899f, -0.11268144f, -0.09389384f, -0.12641399f, -0.18177031f, 0.11177000f, 0.08551306f, 0.01268695f, 
    0.20281446f, 0.04867066f, -0.01659285f, -0.12588495f, 0.03553969f, -0.10526776f, 0.04112609f, -0.08703445f, 
    -0.05517790f, 0.11003760f, 0.01548355f, -0.08155398f, 0.04990985f, -0.06837603f, -0.05149793f, -0.04628185f, 
    -0.02938985f, -0.07834825f, 0.02179766f, -0.15144117f, -0.04091441f, -0.04193194f, -0.08365330f, -0.10048771f, 
    0.00793130f, 0.08889408f, 0.06702975f, 0.09324067f, 0.01053477f, 0.02770878f, -0.06809817f, -0.04306652f, 
    0.12457578f, -0.15312809f, -0.06667586f, 0.08250342f, -0.11042951f, 0.06949396f, 0.02070659f, 0.00488121f, 
    -0.02280424f, 0.04435511f, -0.11174409f, -0.02410498f, -0.02700340f, 0.15249752f, -0.15186228f, -0.07226209f, 
    -0.00175463f, -0.10116428f, 0.00200853f, -0.01279789f, -0.11945232f, 0.12859456f, 0.00851995f, -0.01429809f, 
    0.02724716f, 0.00073590f, 0.17239903f, -0.25255373f, 0.14354543f, 0.05854947f, -0.01088093f, -0.07380489f, 
    0.06201581f, 0.15820502f, 0.12536064f, 0.08679242f, 0.09943623f, -0.11351078f, -0.06176066f, -0.15926722f, 
    -0.02636887f, 0.01444006f, 0.07366873f, -0.01849844f, 0.07785532f, -0.10772513f, 0.09062790f, -0.06842236f, 
    -0.01862304f, -0.11147787f, -0.12418268f, 0.19147499f, 0.03361727f, -0.06602830f, -0.01940728f, -0.07543733f, 
    0.01303928f, 0.03319668f, 0.09058490f, -0.01713568f, 0.40318912f, -0.00769071f, 0.05217277f, -0.19947386f, 
    -0.00807334f, -0.07020181f, 0.07459698f, 0.03684361f, 0.09964181f, -0.09295840f, 0.01224331f, -0.02424251f, 
    -0.24928111f, 0.07068961f, 0.25526753f, 0.18863353f, 0.07335201f, 0.11482124f, 0.17846504f, -0.12509350f, 
    0.06682425f, 0.06095727f, -0.11226019f, 0.00938965f, -0.07808334f, -0.21976481f, -0.01405856f, 0.24789552f, 
    -0.06594881f, -0.02767660f, 0.02161334f, 0.00285164f, 0.17703839f, -0.01055856f, -0.04146412f, 0.05364428f, 
    0.37575561f, -0.06488322f, -0.12705190f, 0.03698676f, 0.09038063f, 0.01320949f, -0.01064655f, 0.02944104f, 
    0.07198565f, 0.14675327f, -0.03052321f, -0.03969278f, 0.07162017f, 0.09497640f, 0.11022312f, 0.07805348f, 
    0.11395361f, 0.01500279f, -0.10317406f, -0.01670280f, 0.05226688f, -0.10605506f, 0.07875380f, -0.05636914f, 
    -0.06460508f, -0.01586355f, -0.06963684f, 0.06465311f, 0.04702825f, 0.09633017f, 0.04443842f, 0.06693573f, 
    0.13734880f, -0.01016880f, -0.05822589f, 0.00323625f, -0.36123344f, -0.00534946f, -0.06219869f, -0.39589113f, 
    -0.00453993f, 0.02931224f, 0.16079326f, 0.01573833f, 0.14478402f, 0.06699238f, 0.09544806f, 0.07580543f, 
    -0.14670916f, -0.02763595f, -0.22643262f, 0.02819229f, 0.00348008f, 0.09889682f, -0.05116546f, -0.05002894f, 
    0.04320923f, -0.05913587f, 0.05890899f, 0.00328104f, -0.27275687f, -0.10199818f, 0.05810897f, 0.17288509f, 
    -0.09874801f, 0.11212537f, 0.03143745f, -0.00243449f, 0.09447079f, 0.08478937f, 0.07889416f, 0.21723974f, 
    0.01677122f, -0.06992683f, 0.01484475f, -0.04790670f, 0.04544619f, 0.10362948f, -0.00639904f, 0.01991422f, 
    -0.04392336f, 0.06378502f, 0.01715852f, -0.11371654f, 0.00092282f, -0.04469224f, 0.03532739f, -0.01843740f, 
    0.06430733f, -0.02698159f, 0.06892881f, 0.04979999f, -0.00938352f, -0.04320616f, -0.04115814f, 0.11258896f, 
    0.18555078f, -0.04485615f, -0.02977964f, -0.16117086f, -0.00850954f, 0.05913758f, 0.05309159f, 0.10383539f, 
    -0.00432515f, -0.01605760f, 0.02222556f, -0.05443770f, -0.09752764f, 0.11066941f, 0.08772083f, 0.02375642f, 
    -0.09109901f, 0.13253023f, -0.08414696f, -0.07617693f, 0.00512169f, -0.09769138f, -0.07159097f, -0.00434926f, 
    -0.33606949f, 0.09526561f, 0.32156831f, -0.32365543f, 0.07326263f, 0.11104118f, 0.01400634f, 0.05283574f, 
    0.00655829f, 0.07181038f, 0.06447168f, 0.12136241f, 0.08553334f, -0.32325783f, -0.22092703f, -0.18366545f, 
    0.04068845f, 0.12073088f, 0.07468832f, -0.08662255f, 0.02248185f, 0.02100101f, 0.00469654f, 0.03381565f, 
    0.21763673f, 0.14711793f, 0.22080658f, 0.24905413f, 0.14552622f, 0.07828651f, -0.00098564f, 0.04753674f, 
    0.00448387f, -0.00122021f, 0.00326620f, 0.04307777f, -0.29642195f, -0.08547945f, 0.17435938f, -0.11816268f, 
    0.04484573f, -0.03259543f, -0.00818187f, -0.07210518f, 0.04923049f, -0.08902752f, 0.08317022f, 0.13951395f, 
    0.13200417f, -0.15637003f, -0.25894314f, -0.00474195f, 0.05615293f, 0.11222839f, -0.01905223f, 0.04254134f, 
    -0.00110848f, 0.02334042f, -0.12939020f, 0.02733470f, 0.11897885f, 0.12444061f, -0.13561818f, -0.20455772f, 
    -0.07381529f, 0.02996367f, 0.03643677f, 0.03536288f, 0.15413810f, 0.03161516f, 0.05010809f, 0.02719254f, 
    0.11526204f, 0.11131343f, -0.03264793f, -0.15841228f, -0.14438672f, -0.06527071f, -0.03856771f, 0.11561609f, 
    0.09719788f, -0.07432453f, 0.05721143f, -0.09272482f, -0.14883894f, 0.19034584f, 0.11168287f, -0.02957556f, 
    0.05510286f, 0.11558139f, -0.04563523f, 0.07743743f, 0.03405403f, 0.06644303f, 0.07907681f, 0.11543009f, 
    -0.28194538f, 0.09102550f, 0.11450282f, -0.07857408f, 0.03331227f, 0.15128423f, 0.06348220f, -0.04337760f, 
    0.13041189f, 0.01292310f, -0.00541231f, -0.03635494f, 0.36964118f, -0.28032750f, 0.07029392f, 0.20985046f, 
    -0.04860187f, -0.03617050f, 0.09668021f, 0.06959819f, 0.08966367f, -0.02462295f, -0.03363657f, 0.06697676f, 
    -0.10267169f, 0.08791590f, 0.04726605f, 0.09193441f, -0.08784936f, -0.06333181f, -0.17717643f, 0.03620200f, 
    -0.10337083f, 0.00289320f, 0.03006938f, 0.13266981f, 0.04141236f, -0.25677991f, -0.02574893f, 0.05205391f, 
    -0.00462404f, 0.05229212f, -0.14568578f, -0.01930919f, -0.01866350f, 0.15249391f, 0.02248453f, 0.03084492f, 
    -0.16637547f, -0.03716718f, 0.01286614f, -0.03061251f, -0.05699628f, 0.07235711f, -0.04702743f, 0.17232691f, 
    0.18761854f, 0.11891351f, 0.00819879f, 0.11737057f, -0.03520769f, 0.04016371f, -0.00326479f, -0.09899520f, 
    -0.00766880f, -0.15772976f, -0.00425930f, 0.05460856f, -0.02264149f, 0.00520664f, -0.05890485f, 0.04503045f, 
    -0.01605645f, 0.02469559f, 0.02078775f, -0.10371127f, 0.04535460f, -0.04029787f, 0.00431224f, 0.10500005f, 
    0.15940268f, -0.16000448f, -0.00880691f, -0.06471080f, -0.16999251f, -0.09006873f, 0.06440798f, 0.00744108f, 
    0.02853304f, 0.13450298f, 0.00637110f, -0.04015391f, 0.11936014f, -0.05744174f, -0.10458639f, -0.06762729f, 
    -0.17698507f, -0.15500221f, 0.08278549f, 0.39379582f, 0.10159498f, 0.09154273f, 0.13941820f, 0.09469835f, 
    -0.01538999f, -0.02205729f, 0.14332035f, 0.01825505f, -0.21422067f, -0.16799179f, 0.03871077f, -0.02074478f, 
    -0.11318671f, -0.06464551f, 0.10214140f, -0.03169120f, -0.05037248f, -0.07948374f, 0.01130650f, 0.02815743f, 
    0.03187380f, 0.16640781f, -0.12605852f, -0.10078838f, 0.09949241f, 0.14297579f, 0.00633940f, 0.02358890f, 
    0.14556304f, -0.04160662f, 0.16692495f, -0.01945797f, -0.45188043f, -0.13891812f, 0.05577741f, 0.15614195f, 
    0.07944778f, -0.00286398f, 0.00711839f, 0.00016986f, 0.03164181f, -0.03885000f, -0.02917444f, 0.06201139f, 
    0.30862004f, -0.07324066f, -0.13193873f, 0.19079727f, 0.01170018f, -0.00366246f, -0.08069696f, 0.14354067f, 
    0.00076272f, 0.08981757f, -0.04567262f, 0.06432244f, -0.06800620f, 0.01609254f, -0.02862734f, -0.12197845f, 
    -0.08802658f, 0.02235756f, -0.06656498f, 0.08647148f, -0.01868804f, -0.01636147f, 0.02570955f, 0.02648522f, 
    -0.34242293f, -0.03822776f, 0.14721341f, 0.15423220f, -0.12952915f, 0.02807881f, -0.03040935f, -0.06520341f, 
    0.06916621f, -0.01805766f, 0.02562852f, 0.06025116f, -0.30561325f, 0.10032386f, 0.15510364f, -0.09941243f, 
    -0.00411229f, 0.13470186f, 0.04249638f, 0.01468860f, -0.11573039f, -0.08523095f, 0.01956216f, -0.06829783f, 
    -0.12824278f, 0.12961739f, -0.08518713f, -0.05627939f, 0.11042990f, 0.07778392f, -0.07985449f, 0.04833489f, 
    0.10056069f, 0.05902253f, -0.03380841f, 0.11944544f, 0.01934636f, -0.11955691f, 0.06683332f, -0.00192412f, 
    -0.08086985f, 0.10475072f, -0.14369042f, 0.06203715f, 0.06703895f, 0.00058024f, -0.06303359f, 0.00629695f, 
    -0.17841411f, -0.05959984f, -0.17145838f, -0.23002444f, -0.00328865f, 0.05134037f, -0.16234618f, -0.10556029f, 
    -0.11186317f, -0.00026004f, -0.11739265f, -0.00912658f, 0.01145313f, 0.20938317f, 0.02748175f, 0.04417807f, 
    0.04772614f, -0.12117305f, 0.02066550f, 0.11381232f, 0.11543687f, 0.11819340f, 0.09006397f, 0.07807174f, 
    -0.17473669f, -0.06775215f, -0.02897669f, -0.07060874f, -0.00484486f, 0.01450538f, -0.10256661f, 0.14084053f, 
    -0.01731667f, 0.02599355f, 0.03286771f, 0.18871096f, -0.04778151f, 0.19072284f, 0.02769081f, 0.01629656f, 
    -0.04433270f, -0.04647201f, -0.01694156f, 0.10167629f, 0.11625415f, 0.04281237f, -0.20673324f, -0.08792554f, 
    0.16917181f, -0.07770810f, 0.06325115f, 0.02775090f, -0.18316647f, 0.00170967f, -0.08590239f, -0.08906458f, 
    -0.07584698f, -0.02562144f, 0.06485121f, -0.00453325f, 0.37004861f, 0.13616171f, -0.14242697f, 0.07487043f, 
    0.09227268f, -0.02376000f, -0.09855786f, 0.15446246f, 0.04092887f, -0.01869980f, 0.00526789f, -0.03873726f, 
    0.33741191f, -0.04909301f, 0.05810947f, 0.28032261f, -0.09022126f, -0.02335941f, 0.15326849f, -0.05958964f, 
    -0.07962721f, 0.01809855f, -0.02642409f, -0.01314918f, 0.01363990f, -0.12137443f, -0.09323476f, -0.17735362f, 
    0.09799021f, 0.03501375f, -0.05591504f, -0.01469610f, -0.01957733f, -0.02280399f, -0.05864988f, 0.03928702f, 
    0.30547491f, -0.08263016f, 0.15514359f, 0.08123074f, -0.09441290f, -0.01988998f, 0.09989078f, 0.10192122f, 
    0.04933636f, -0.04824863f, 0.01822830f, -0.05250697f, 0.13135596f, 0.05708211f, 0.23403202f, 0.29580811f, 
    -0.19950865f, 0.03380786f, 0.06403819f, 0.02176945f, 0.01223432f, 0.11549620f, 0.01024177f, 0.11821592f, 
    -0.14103007f, 0.06511507f, -0.28410348f, -0.06625430f, 0.00220275f, -0.07104506f, 0.00097855f, -0.05668119f, 
    -0.06004778f, 0.02143577f, 0.01146054f, 0.03036487f, 0.06769479f, 0.14110577f, 0.14946634f, -0.11727035f, 
    0.18333954f, 0.01771254f, -0.02660870f, 0.05052517f, 0.06734664f, 0.03549346f, 0.03484484f, -0.05663763f, 
    0.36170661f, 0.16704807f, 0.05645230f, 0.22387284f, 0.04489858f, 0.13409333f, 0.02171075f, -0.05619920f, 
    0.07245381f, -0.00134062f, 0.00065645f, 0.00962292f, -0.11714561f, -0.26657069f, -0.01822880f, -0.21170215f, 
    0.02159900f, -0.00573884f, -0.03743039f, 0.21743390f, 0.15042832f, -0.03263938f, -0.08424335f, -0.06881087f, 
    -0.09748105f, -0.04574478f, 0.17323253f, 0.08894325f, -0.04406476f, -0.10877648f, 0.04669371f, 0.06815159f, 
    0.02485077f, -0.04373528f, 0.00042605f, 0.01106839f, 0.24705458f, -0.17599626f, 0.08395658f, 0.40698883f, 
    -0.08987387f, -0.27862877f, -0.12466162f, -0.11776443f, -0.07531390f, 0.14264712f, 0.04798909f, 0.01414327f, 
    0.34221601f, 0.11034428f, -0.08828250f, -0.58477020f, 0.03964670f, 0.08953582f, 0.10093123f, 0.06019239f, 
    0.05815050f, -0.08761674f, 0.07229280f, 0.06970687f, -0.05985794f, 0.06160115f, -0.12328041f, -0.21571301f, 
    0.01952198f, -0.16871625f, -0.00938941f, -0.11269290f, 0.03679825f, 0.04733827f, 0.09647987f, -0.05079792f, 
    -0.12001385f, -0.16249745f, 0.00958079f, 0.08474039f, 0.06634180f, 0.07566207f, 0.02584927f, -0.05980711f, 
    0.05020617f, -0.08027576f, 0.07487654f, -0.00767984f, -0.28063273f, 0.15437785f, 0.06102078f, 0.17283168f, 
    -0.03176444f, 0.16294126f, -0.01504116f, -0.15607132f, 0.06632519f, 0.05398874f, 0.01896536f, 0.02084787f, 
    -0.42500079f, -0.06844294f, -0.15930308f, 0.10082233f, 0.08115128f, 0.00025913f, -0.11593535f, -0.11268745f, 
    0.19163692f, 0.03476723f, -0.03277315f, 0.07598446f, 0.10392947f, -0.17390010f, 0.09886498f, 0.06924456f, 
    0.00691919f, 0.03156337f, 0.04932240f, 0.04236430f, -0.09076314f, 0.02750242f, 0.14821123f, 0.00471981f, 
    0.10306616f, 0.08995837f, -0.22195992f, 0.19374003f, -0.19899209f, -0.28723690f, -0.10089421f, -0.03869851f, 
    0.05617098f, 0.02844181f, 0.01322088f, -0.00341112f, -0.36020935f, 0.39934042f, -0.02993997f, -0.08338721f, 
    -0.04406677f, -0.02545454f, 0.05337785f, 0.07237671f, 0.11152059f, 0.10403822f, 0.07494766f, -0.01213448f, 
    -0.00282805f, 0.11632712f, 0.15790395f, -0.12752841f, -0.06482982f, -0.16920406f, -0.08277908f, -0.00005756f, 
    0.10234225f, 0.05026371f, -0.12050339f, 0.07941824f, 0.31702587f, -0.10900179f, -0.28789625f, -0.13107564f, 
    -0.11501698f, -0.25028017f, -0.10426100f, -0.13699874f, 0.00826460f, 0.14493659f, -0.06250134f, -0.01943164f, 
    -0.05588619f, 0.02975064f, 0.00457265f, -0.04144372f, -0.02213833f, -0.04666437f, -0.03785351f, 0.02796777f, 
    0.04452938f, -0.00791074f, 0.03727855f, -0.05627519f, 0.01063027f, -0.06204184f, -0.03731460f, -0.01533769f, 
    -0.07447635f, 0.00212366f, -0.04745357f, 0.05532205f, 0.02197697f, -0.06796186f, 0.05140787f, -0.05576323f, 
    -0.01140175f, 0.00217725f, 0.03865994f, 0.01681644f, 0.05555279f, -0.04288012f, 0.00881775f, -0.06506671f, 
    -0.05226154f, -0.00108664f, 0.00179192f, 0.04902662f, -0.07111271f, 0.05968367f, -0.04049368f, -0.05821439f, 
    0.01536834f, -0.06448142f, 0.00875524f, -0.00096346f, -0.00506612f, -0.01332893f, -0.05138667f, -0.00731782f, 
    -0.06756286f, -0.05006159f, 0.05240893f, 0.03448148f, -0.07728006f, -0.00863667f, -0.05327657f, -0.06738348f, 
    0.05877343f, -0.02774341f, -0.07637911f, -0.01338623f, -0.03965332f, -0.06342505f, 0.03977276f, 0.05942582f, 
    -0.04988573f, -0.03492176f, 0.05217849f, -0.02551237f, -0.00331956f, 0.03549458f, -0.02648502f, -0.00436557f, 
    -0.00484579f, -0.03846377f, -0.03315100f, -0.04487206f, 0.03340895f, -0.07029283f, -0.02034199f, 0.06230717f, 
    -0.02685378f, 0.03895963f, 0.00723630f, 0.03505290f, -0.04874602f, 0.01631269f, -0.06550940f, -0.02336919f, 
    0.00607574f, -0.02518384f, -0.03936615f, 0.04678337f, 0.03897990f, 0.05394423f, -0.00648759f, 0.00073303f, 
    -0.06754820f, 0.04468638f, -0.02601498f, 0.00851991f, -0.01748184f, 0.00986398f, 0.01993997f, -0.05867548f, 
    0.03943305f, 0.01097393f, 0.03476276f, 0.04496523f, -0.00728327f, -0.03454766f, -0.03953126f, 0.03706474f, 
    0.06354279f, -0.03140145f, -0.04518047f, -0.03355375f, 0.04428344f, -0.00830535f, -0.02301805f, 0.00847735f, 
    -0.03244501f, 0.01043244f, -0.08524564f, -0.00132364f, 0.04122021f, 0.05418855f, -0.06492534f, 0.01568253f, 
    -0.06494130f, 0.02653983f, 0.05550922f, -0.05930435f, 0.01923297f, -0.06051030f, 0.03378481f, -0.04664230f, 
    -0.03481331f, 0.03416797f, 0.05128726f, -0.05554914f, 0.02844408f, 0.02843488f, -0.01850853f, 0.04106267f, 
    -0.01944125f, 0.02574465f, -0.06596188f, 0.02573762f, 0.03882892f, -0.07043193f, -0.02632612f, -0.00470577f, 
    0.04170589f, 0.02754703f, 0.03105275f, -0.05817107f, -0.06240051f, -0.05104403f, -0.00651426f, 0.00511116f, 
    -0.05269002f, 0.02064405f, -0.02210488f, -0.01662273f, -0.05264899f, 0.04756189f, 0.05008391f, 0.04780209f, 
    0.04621630f, -0.08882406f, 0.05225845f, -0.03868218f, -0.02836306f, -0.06595200f, 0.04205417f, -0.02657955f, 
    0.01223963f, 0.01734226f, 0.02689740f, 0.00392820f, -0.04050640f, -0.03765619f, 0.02980538f, -0.06515674f, 
    0.01011737f, -0.00267289f, -0.04074931f, -0.04370319f, 0.03219676f, -0.02159471f, 0.04917677f, -0.01089053f, 
    0.35413471f, 0.08227340f, 0.05966346f, 0.13894010f, -0.01412737f, 0.00437030f, 0.01240481f, 0.04657496f, 
    -0.07077800f, 0.06931406f, -0.01489933f, 0.04591210f, -0.01360458f, -0.04024711f, 0.29046351f, 0.05224436f, 
    0.06374720f, 0.02068727f, -0.09831716f, 0.10064840f, -0.02503544f, -0.10218518f, -0.02418642f, -0.06862348f, 
    0.01226615f, 0.05606515f, 0.28819132f, 0.21327083f, 0.13401638f, 0.04189480f, 0.09594813f, -0.08711386f, 
    -0.03883598f, -0.06655563f, -0.03150059f, 0.16221240f, -0.15847328f, -0.18308423f, 0.05844684f, 0.00544250f, 
    -0.06496885f, 0.04418338f, -0.07811497f, -0.13306637f, 0.24881527f, -0.12231924f, -0.12799993f, -0.02587193f, 
    -0.03284496f, -0.10121195f, 0.23313572f, 0.12342101f, -0.00068624f, -0.14773755f, -0.06988288f, 0.10620220f, 
    -0.03822383f, 0.09393871f, -0.00204552f, -0.06764410f, -0.13636838f, 0.48798448f, -0.23747285f, 0.04684713f, 
    -0.06850537f, -0.00948064f, -0.02319600f, -0.11998171f, -0.12674741f, -0.02025507f, -0.05863090f, -0.02527099f, 
    -0.21619642f, 0.05314441f, 0.16264687f, -0.08979455f, 0.06284612f, 0.05364480f, 0.04450452f, 0.01780399f, 
    0.11781269f, -0.02598769f, 0.02326863f, 0.15696749f, 0.22784859f, 0.04568215f, 0.11589826f, 0.00095625f, 
    -0.11443276f, -0.04388862f, -0.10969987f, 0.13791932f, 0.06894629f, 0.05807720f, -0.05257250f, 0.01329626f, 
    0.15164022f, -0.02219137f, -0.07291517f, -0.07079887f, -0.06428672f, 0.07278361f, 0.05752393f, 0.08383268f, 
    -0.07514834f, -0.00229955f, -0.10230631f, 0.11202759f, 0.02513894f, -0.03841343f, 0.11888092f, 0.18092795f, 
    -0.00614524f, 0.02010239f, -0.00201229f, -0.09122170f, 0.05438579f, -0.09236761f, 0.07145414f, 0.11061155f, 
    -0.14708087f, 0.03043636f, 0.07700467f, -0.05778457f, 0.07595915f, 0.01647793f, 0.00075447f, -0.03220956f, 
    -0.03542953f, -0.02866125f, -0.09273779f, 0.09333515f, -0.06069344f, 0.13275076f, -0.02186535f, 0.01493539f, 
    -0.07472344f, -0.01430867f, -0.12882145f, 0.08362897f, -0.05341379f, -0.15367736f, 0.03906336f, 0.04862207f, 
    0.07467572f, 0.06856145f, -0.02269826f, 0.00535728f, -0.14745827f, -0.12435868f, 0.09022804f, -0.01613764f, 
    -0.10651229f, -0.12501615f, -0.04704558f, -0.01679567f, 0.03085089f, -0.05621322f, 0.02941377f, -0.08567358f, 
    0.11183381f, 0.13861568f, -0.11148898f, 0.07859128f, -0.14800945f, 0.22291023f, -0.10997554f, -0.06725384f, 
    -0.00846100f, 0.01827030f, 0.18242294f, 0.01002637f, -0.11399294f, -0.05616376f, 0.05311401f, 0.10878988f, 
    -0.15497094f, -0.07571295f, -0.04956428f, 0.09338400f, -0.23756081f, -0.03025749f, -0.03408661f, -0.01590631f, 
    -0.11120567f, -0.06740547f, -0.01362547f, -0.05166865f, -0.03326384f, 0.03616808f, 0.00859483f, -0.05829573f, 
    0.21511376f, -0.22527172f, -0.07213246f, 0.02886823f, -0.07010821f, 0.00056626f, -0.01016985f, 0.17999993f, 
    -0.00142476f, 0.06642322f, -0.05867193f, 0.00498106f, 0.12807062f, 0.16411845f, -0.18751688f, -0.18865576f, 
    0.04299425f, 0.06580091f, 0.04813490f, -0.05382863f, -0.04428186f, -0.04736654f, 0.05155623f, 0.09972432f, 
    -0.29463664f, -0.11885214f, -0.05429516f, 0.01722463f, -0.13667649f, 0.06566202f, -0.01143170f, 0.13297585f, 
    -0.03499262f, -0.09274875f, 0.13839485f, 0.03355494f, 0.08331334f, 0.05784034f, -0.07123964f, -0.03102252f, 
    0.09312810f, 0.16266106f, 0.14393227f, -0.12964864f, -0.11910503f, 0.03576156f, -0.05139342f, 0.01706475f, 
    -0.02795410f, 0.10697077f, 0.05946176f, 0.06337027f, 0.06235599f, -0.07315541f, -0.08417519f, -0.00235653f, 
    -0.05865644f, -0.05238412f, 0.19422546f, -0.03125456f, -0.01067755f, -0.22101146f, 0.14589971f, -0.01133070f, 
    0.17778809f, -0.08991415f, -0.00018653f, -0.03463918f, -0.01177857f, 0.05990994f, 0.06667727f, -0.02140558f, 
    0.26757753f, 0.36875439f, 0.05074408f, -0.03833589f, -0.00960977f, -0.06661189f, 0.05617668f, 0.12147388f, 
    -0.05538018f, -0.07841361f, 0.09199802f, -0.12115822f, 0.05188213f, 0.08542749f, -0.14273712f, -0.03615670f, 
    -0.00428653f, -0.06591861f, 0.01959547f, 0.04164402f, -0.04053953f, -0.00599914f, 0.01958419f, 0.04190149f, 
    -0.08787082f, 0.05313773f, 0.18343771f, 0.13857383f, -0.10075569f, 0.00867935f, 0.04996489f, 0.09120775f, 
    -0.05035440f, -0.04855279f, -0.02504048f, 0.11293086f, 0.18059248f, 0.19886182f, -0.09907713f, -0.16583297f, 
    0.16069332f, 0.03579358f, 0.03291539f, -0.06584560f, 0.12598988f, 0.04045350f, -0.04414798f, -0.02004180f, 
    0.66995269f, -0.10193831f, 0.18352546f, 0.13549919f, -0.06886176f, -0.00670538f, 0.00243967f, -0.03726638f, 
    0.11550361f, 0.07278226f, -0.06077949f, -0.07887229f, 0.10223391f, -0.02804739f, -0.04363970f, -0.00065263f, 
    0.12413415f, 0.02390215f, 0.05431632f, -0.02438262f, 0.09863371f, -0.01839563f, -0.03296795f, -0.14148904f, 
    0.07650556f, -0.28308657f, -0.25253755f, 0.15814964f, 0.12554576f, 0.07865763f, -0.05293368f, -0.10853988f, 
    -0.20883563f, -0.12073800f, -0.02122659f, -0.01097879f, 0.61345714f, -0.14205961f, 0.12770702f, 0.20802584f, 
    -0.17755000f, -0.02559725f, -0.00815840f, 0.00730686f, -0.01162322f, -0.04843383f, -0.17874345f, 0.10873339f, 
    -0.04747006f, 0.13702817f, -0.16666493f, -0.04694655f, -0.04393123f, -0.08202158f, -0.05365811f, 0.11224264f, 
    0.04772385f, 0.00560135f, -0.01685196f, -0.07840118f, 0.13012514f, -0.10778104f, -0.10532678f, 0.05021887f, 
    0.21430801f, 0.18340690f, 0.04839948f, 0.02280856f, -0.13376188f, -0.02877794f, 0.02015327f, -0.11775277f, 
    -0.14227271f, 0.12298147f, 0.15267609f, -0.05033886f, -0.03565169f, -0.01629517f, 0.11801758f, -0.18466569f, 
    -0.07524816f, 0.01242143f, -0.08373729f, -0.01312772f, -0.16026576f, -0.14389530f, -0.07552868f, -0.00951136f, 
    -0.04716764f, -0.11896238f, 0.03982837f, 0.07738435f, 0.01971735f, 0.05516339f, 0.08453109f, -0.06598984f, 
    0.07196008f, 0.00414882f, -0.25395608f, -0.00277364f, 0.09336120f, -0.09222447f, -0.08039659f, 0.04068336f, 
    -0.08448271f, 0.01737446f, 0.06221792f, 0.12488969f, 0.26521322f, -0.13419561f, -0.06577796f, 0.03887406f, 
    0.12429228f, -0.06129874f, 0.13487773f, -0.01759317f, 0.01466604f, 0.04588599f, 0.03003457f, -0.11070736f, 
    0.03749717f, -0.10929491f, -0.04828817f, -0.03941462f, 0.02433341f, -0.01736066f, 0.09486566f, 0.01950852f, 
    -0.03135357f, 0.05283418f, 0.01029130f, 0.07885595f, 0.15688816f, 0.12225784f, -0.14149608f, -0.12908675f, 
    0.06877727f, 0.05444241f, 0.11218647f, 0.01215668f, -0.00307842f, 0.00887065f, 0.09035102f, 0.16656065f, 
    -0.22348920f, -0.26801515f, 0.01265590f, 0.05079982f, 0.00735337f, -0.01389080f, 0.05998422f, 0.03398990f, 
    0.02992783f, 0.04075221f, 0.06673300f, -0.03378354f, 0.10397817f, -0.15942347f, 0.24074452f, 0.05586442f, 
    -0.00818990f, 0.08224121f, 0.04431618f, -0.06838376f, 0.00324513f, -0.05965037f, 0.11343672f, 0.02658536f, 
    0.01831004f, -0.21614936f, 0.05111724f, 0.05667135f, 0.02149268f, 0.04091667f, 0.04773539f, -0.00506590f, 
    -0.09719838f, 0.00698079f, -0.02762359f, -0.07298381f, -0.05069281f, -0.14667080f, -0.08105036f, -0.01140200f, 
    -0.11911362f, -0.07463833f, -0.00232155f, 0.01174279f, -0.00068814f, 0.00644265f, -0.06725268f, -0.08660173f, 
    -0.29908755f, -0.11400315f, -0.21173109f, 0.02801459f, 0.00591164f, 0.11756591f, -0.06386824f, 0.05536370f, 
    -0.20493536f, -0.04367873f, -0.07945450f, -0.04539106f, -0.13798240f, -0.15488964f, 0.16662163f, -0.05021207f, 
    0.00162568f, -0.07288192f, 0.14170651f, -0.09638285f, -0.03409408f, -0.07703924f, 0.10904545f, -0.00580204f, 
    0.08349046f, 0.06394271f, 0.23634128f, -0.30649981f, 0.02619183f, -0.00086381f, -0.04660318f, 0.04054035f, 
    0.11944924f, -0.00769882f, 0.04991184f, 0.11118934f, -0.01797326f, -0.10944857f, -0.28407609f, 0.02515782f, 
    -0.04941355f, -0.03129736f, -0.04079611f, 0.01575539f, -0.04480840f, -0.17065640f, 0.08065111f, -0.11288269f, 
    -0.32093543f, -0.17472024f, 0.03575664f, -0.08554592f, -0.01244505f, 0.10223006f, 0.06211517f, -0.04950698f, 
    -0.01010115f, 0.05680721f, 0.01972350f, 0.02435577f, -0.05812362f, 0.02812386f, 0.04467276f, -0.21940796f, 
    -0.11567343f, 0.05336583f, -0.07131094f, -0.03407397f, 0.06807759f, 0.02082184f, 0.09858359f, -0.03565547f, 
    -0.06982198f, -0.03470490f, 0.10280270f, -0.19645329f, -0.02274886f, -0.05132534f, 0.01395169f, -0.02920224f, 
    -0.02838169f, -0.18510388f, -0.01700582f, -0.10663080f, -0.14710473f, 0.01472415f, -0.03244115f, -0.19925658f, 
    0.07978131f, 0.17377922f, 0.05921117f, 0.05904132f, 0.04911540f, 0.12580778f, 0.12706052f, 0.02648282f, 
    -0.09393459f, 0.00059740f, -0.01041647f, 0.24682114f, 0.07009639f, 0.03018035f, -0.03614088f, -0.05013275f, 
    0.05889389f, -0.05100212f, -0.07216355f, -0.13640738f, 0.14103737f, 0.02221247f, 0.08624362f, -0.18970188f, 
    0.07924078f, 0.09449941f, -0.09667841f, -0.02570230f, -0.01776993f, 0.17496593f, 0.12487975f, 0.09951352f, 
    -0.02414519f, -0.13806345f, 0.01713430f, -0.04495069f, 0.04081203f, 0.12650311f, 0.03953175f, 0.02455290f, 
    0.03914719f, -0.10717475f, -0.03428556f, -0.04428494f, 0.20526789f, -0.25042078f, 0.09805726f, 0.31444615f, 
    -0.03881636f, -0.05958200f, -0.02830814f, 0.00683437f, -0.03301822f, -0.02407785f, -0.01490265f, 0.06445827f, 
    0.30772209f, 0.00889860f, -0.11264066f, -0.18827453f, -0.02137110f, -0.14029750f, -0.09961759f, 0.02156730f, 
    -0.06812713f, -0.00384119f, 0.07081329f, 0.04058865f, 0.36217275f, -0.14849880f, 0.12824011f, -0.13598356f, 
    0.00901421f, -0.08061323f, -0.11752453f, -0.04195951f, 0.08318970f, -0.04247402f, -0.04111898f, -0.09092049f, 
    -0.07730740f, -0.10542991f, -0.00058853f, 0.01837199f, 0.15205789f, 0.05995162f, -0.00214795f, 0.16457179f, 
    0.07821748f, 0.01806803f, -0.03455057f, 0.01099346f, -0.20789227f, -0.11450619f, -0.16703977f, -0.09835362f, 
    -0.00002798f, 0.02858493f, 0.08897131f, 0.00204959f, 0.02771399f, 0.11004430f, 0.06150178f, 0.13541803f, 
    -0.39906886f, -0.09274171f, -0.16557239f, 0.14311287f, -0.11341075f, 0.03478128f, -0.04944428f, 0.00450203f, 
    -0.03112588f, -0.12890159f, -0.09700906f, -0.11936793f, -0.06270564f, -0.21834135f, 0.29830712f, -0.10208000f, 
    0.00071013f, 0.00216629f, -0.08239213f, -0.07690919f, -0.06902581f, -0.03323470f, 0.11288121f, 0.08400813f, 
    0.24508034f, 0.00001021f, -0.00664101f, 0.12446617f, -0.07738654f, 0.03740055f, 0.01087972f, -0.06000089f, 
    0.06703348f, 0.07638714f, -0.05345448f, -0.02472010f, -0.09145412f, -0.03114115f, -0.13454300f, -0.12367266f, 
    -0.05113892f, 0.04975903f, -0.04627267f, 0.12075624f, 0.04159512f, -0.11224370f, -0.05010168f, 0.04663168f, 
    -0.32391670f, -0.06246502f, -0.00323949f, -0.19412395f, -0.07866832f, -0.00830970f, 0.13743801f, -0.02296221f, 
    0.13992739f, 0.03617286f, 0.10030601f, -0.11912901f, 0.09032345f, 0.00695710f, 0.13140404f, 0.05069188f, 
    -0.08712222f, -0.10738671f, -0.04601569f, 0.07934470f, -0.08299425f, 0.00227219f, -0.06621926f, -0.12817676f, 
    -0.23381476f, -0.15458933f, -0.04645608f, -0.14062534f, -0.10264104f, 0.10757660f, -0.03178006f, 0.02265190f, 
    -0.08181608f, -0.03312686f, 0.08156293f, -0.03926511f, -0.10025571f, 0.04351200f, -0.08061197f, -0.05808980f, 
    -0.01873329f, 0.09350397f, 0.04758494f, -0.12927932f, 0.08661912f, 0.24847576f, 0.01388833f, 0.13014592f, 
    0.18349531f, 0.04257095f, -0.25296992f, -0.02470302f, -0.06519493f, -0.03653364f, -0.11274473f, 0.00895793f, 
    0.11219266f, -0.08151544f, -0.08991611f, -0.16487490f, 0.29224384f, 0.06842878f, 0.16651709f, -0.07622825f, 
    0.00235325f, 0.04627413f, -0.11805820f, 0.07439558f, -0.06272231f, 0.12684673f, 0.15781668f, 0.06671487f, 
    0.12083276f, -0.06233846f, 0.01252897f, -0.11358174f, -0.00509077f, 0.14870991f, 0.14377797f, -0.02327053f, 
    0.09867585f, -0.20104386f, 0.00433625f, -0.07075684f, 0.32816485f, -0.28516245f, 0.27263910f, 0.35364538f, 
    -0.11849985f, 0.02518605f, -0.06222516f, 0.08773656f, -0.07878152f, 0.15339446f, -0.04927777f, 0.01231816f, 
    0.39296848f, 0.29492044f, -0.08366054f, 0.09416807f, -0.06098919f, -0.11133358f, 0.08508321f, 0.05331425f, 
    0.08719631f, 0.08741279f, 0.05381435f, -0.02897056f, 0.13763042f, -0.12412224f, 0.16379619f, 0.01725641f, 
    0.07210952f, 0.02133054f, 0.11062860f, -0.07132478f, 0.06715387f, -0.09048451f, -0.01016279f, -0.06165288f, 
    0.07875646f, -0.01302047f, 0.12700422f, -0.08852378f, 0.03592414f, -0.08352398f, 0.04563307f, 0.12860978f, 
    0.03006578f, 0.08061112f, 0.15853818f, -0.00000434f, -0.30436227f, -0.12030523f, -0.11675405f, -0.05547292f, 
    -0.00766736f, 0.00059769f, 0.01902810f, -0.05316125f, -0.00637821f, 0.08889185f, 0.07985746f, 0.01473222f, 
    -0.07826280f, 0.04020315f, 0.00462518f, 0.06238208f, -0.05130743f, 0.10724925f, -0.07114020f, 0.02361110f, 
    0.01684549f, -0.07325258f, -0.07205024f, 0.00680893f, -0.20674270f, -0.31269243f, 0.10242850f, -0.17335945f, 
    0.06847359f, 0.00018633f, 0.10243061f, -0.10848370f, -0.05199240f, 0.17403218f, 0.07402522f, 0.04763135f, 
    0.20123559f, 0.13935280f, 0.05133717f, 0.04686626f, 0.01524002f, 0.05305194f, 0.02256382f, -0.03887484f, 
    0.02107636f, 0.06203714f, -0.05263451f, -0.03524822f, 0.17557892f, 0.08025589f, 0.17412503f, -0.12324014f, 
    -0.16004820f, -0.03729344f, 0.02653455f, -0.02576396f, 0.09176934f, -0.06778386f, 0.07377712f, 0.02947355f, 
    -0.35269165f, 0.02298754f, -0.10851851f, -0.19256431f, 0.02804093f, 0.12233830f, 0.11520862f, -0.11643360f, 
    0.07946211f, 0.07757311f, 0.16962704f, -0.05200353f, 0.41426808f, -0.03118984f, 0.13031067f, 0.00071322f, 
    -0.00391379f, -0.03978306f, 0.03284877f, 0.16625881f, 0.01904597f, -0.14756650f, -0.09127144f, 0.01194311f, 
    0.14130276f, -0.03167906f, -0.01242446f, -0.04982551f, 0.07054410f, 0.01420148f, 0.03036775f, -0.01522737f, 
    0.05294662f, 0.02214411f, 0.07081826f, 0.11083133f, 0.06435250f, -0.04006594f, 0.07778704f, -0.15495448f, 
    0.03400607f, -0.12572201f, 0.01174648f, 0.16590728f, 0.00715819f, -0.15572223f, -0.02817623f, 0.02823205f, 
    0.11838406f, 0.10905550f, -0.03789791f, 0.01400259f, -0.08509678f, -0.08430325f, 0.11277410f, 0.10694242f, 
    0.08300829f, 0.08714745f, -0.00848336f, 0.14224672f, -0.06052681f, -0.05299573f, -0.06210254f, 0.04298221f, 
    0.03268680f, -0.13554706f, 0.19319731f, -0.08269770f, 0.12646100f, -0.13560833f, -0.04409564f, -0.02934892f, 
    -0.21994048f, 0.05561701f, 0.16791694f, -0.17143372f, 0.00499935f, -0.02511269f, -0.01592894f, 0.03789917f, 
    -0.00660334f, 0.23504752f, -0.01467585f, 0.07706243f, 0.20552786f, 0.18334199f, -0.31695032f, 0.02898335f, 
    0.09607920f, 0.04003279f, 0.05080970f, 0.02420956f, 0.11896378f, -0.03174654f, 0.03690593f, 0.17716223f, 
    -0.16941479f, -0.19850132f, 0.37594220f, 0.14448924f, 0.01269346f, -0.05387488f, 0.02656615f, 0.08138005f, 
    0.08323925f, 0.10513031f, 0.02911098f, 0.10213043f, -0.07371756f, -0.20645830f, -0.02620834f, 0.04905665f, 
    -0.18145876f, 0.15403755f, 0.10028067f, 0.13572878f, -0.11490779f, 0.08673218f, -0.00261010f, 0.08745887f, 
    -0.15099688f, -0.08806553f, -0.03625497f, 0.02330509f, -0.12928787f, 0.06436344f, 0.00169390f, 0.02723381f, 
    -0.09543930f, -0.02465017f, -0.07447503f, 0.17551236f, -0.04775386f, 0.18933645f, 0.08793427f, 0.06927914f, 
    -0.12909804f, -0.04043704f, -0.05852962f, 0.03210467f, -0.05054668f, 0.04134401f, 0.04369290f, -0.00935332f, 
    -0.06624159f, 0.04672822f, -0.01790822f, -0.24832916f, 0.02404018f, -0.20170541f, -0.01795991f, 0.01824402f, 
    0.07337637f, -0.03047091f, 0.07073148f, 0.07726585f, 0.01314081f, -0.02910703f, 0.07590035f, 0.04261379f, 
    0.07315283f, 0.09531190f, 0.08815259f, 0.02768316f, 0.08201799f, -0.09964909f, -0.01310517f, -0.03217617f, 
    -0.08514463f, -0.03055662f, -0.14036091f, 0.20777121f, -0.07594366f, -0.00287962f, 0.00927665f, 0.03970897f, 
    -0.03821126f, -0.06857537f, -0.02768088f, -0.00900672f, -0.29191041f, 0.04998844f, -0.09389684f, 0.22235993f, 
    -0.11728685f, -0.02408576f, -0.03844960f, -0.01916423f, -0.13165823f, 0.05275205f, -0.06758685f, 0.01221387f, 
    0.07501137f, 0.09081240f, 0.19662689f, -0.21801497f, -0.00402057f, 0.08881264f, -0.01176197f, -0.02044336f, 
    -0.09682276f, -0.04988368f, -0.04849730f, 0.13280852f, -0.50477099f, 0.11735012f, -0.02832546f, 0.07344981f, 
    0.02566140f, 0.12539133f, 0.04226932f, 0.00547680f, 0.03901507f, 0.16162963f, 0.01166224f, 0.04259961f, 
    -0.03513228f, -0.06634352f, 0.04083224f, -0.00231356f, 0.03682514f, -0.05766170f, -0.05530134f, -0.03864608f, 
    -0.06703949f, 0.05840462f, 0.01604923f, 0.02834300f, -0.00281264f, 0.04396719f, -0.07542583f, 0.03385647f, 
    0.01700529f, 0.01457651f, 0.01874718f, 0.00875958f, -0.00624877f, -0.00792498f, -0.06857905f, -0.00528962f, 
    0.05702553f, -0.03209858f, 0.06043980f, 0.02854162f, -0.03604724f, 0.03460871f, 0.06078640f, -0.01948324f, 
    -0.01403321f, 0.01846394f, -0.04687425f, -0.03179897f, -0.05890371f, 0.00595891f, -0.03162194f, -0.03985825f, 
    -0.05009136f, -0.00823259f, 0.00721295f, 0.03509881f, -0.03603301f, -0.06985506f, -0.06102348f, 0.02975691f, 
    -0.02615026f, -0.03897236f, -0.00095762f, 0.01624980f, -0.01490394f, 0.02908583f, 0.05567895f, -0.05719845f, 
    0.02580154f, -0.04646393f, -0.04882168f, 0.05986742f, -0.06342300f, 0.01048322f, -0.04351183f, 0.00111651f, 
    0.01352007f, 0.03475476f, -0.07554103f, -0.04305182f, -0.04316558f, -0.03029012f, 0.01136400f, -0.03736831f, 
    -0.02710249f, -0.00326423f, 0.02174675f, -0.05288534f, 0.01937963f, -0.05246687f, 0.02208791f, -0.06716591f, 
    -0.00579743f, -0.02302932f, 0.03615560f, 0.04673418f, -0.07577769f, 0.02657205f, 0.03875704f, -0.03032159f, 
    -0.06766388f, 0.06247043f, 0.05322686f, 0.04159982f, 0.02514916f, 0.00597731f, 0.04064843f, 0.01164950f, 
    0.06696227f, -0.07771713f, -0.04475652f, -0.07503131f, -0.02407596f, -0.00331738f, -0.01889654f, 0.01552900f, 
    -0.00220346f, 0.03478302f, 0.04134720f, -0.02902929f, 0.05700410f, 0.06500750f, 0.04833975f, -0.07283667f, 
    -0.06638375f, 0.00124443f, -0.05904870f, 0.04478565f, 0.02303790f, -0.00558131f, -0.07072088f, 0.00016926f, 
    -0.02460906f, -0.02109893f, -0.05191857f, -0.06516253f, -0.06105727f, 0.03768780f, 0.00400958f, -0.05417313f, 
    -0.07248859f, 0.02872559f, 0.02519667f, 0.05258579f, -0.05763492f, 0.05288184f, 0.00882043f, 0.05705845f, 
    -0.05830304f, 0.06656498f, -0.03044556f, -0.03904750f, 0.00656873f, -0.02544592f, -0.01693454f, 0.02255584f, 
    0.04735279f, -0.03428932f, -0.06691580f, 0.03936720f, 0.03184756f, -0.04164072f, 0.03887420f, -0.00759950f, 
    0.03789456f, 0.02460497f, 0.03943074f, -0.07295579f, -0.03380590f, -0.02810217f, -0.03481093f, -0.03262167f, 
    0.02224507f, -0.05592123f, 0.02229826f, -0.04402724f, -0.00620566f, -0.05482145f, -0.05909040f, -0.00639314f, 
    0.06586809f, -0.04603473f, -0.02683851f, 0.01439350f, -0.06401382f, -0.02028359f, -0.07255953f, 0.00115809f, 
    -0.03563903f, 0.00793318f, 0.00172338f, 0.00474911f, -0.03652385f, 0.03593199f, 0.05536010f, -0.01129527f, 
    -0.00330777f, -0.04840811f, 0.02086732f, -0.06759425f, 0.00104628f, 0.05238906f, -0.02606402f, -0.07373095f, 
    0.00384068f, 0.16683094f, -0.06716903f, -0.11398218f, -0.04056391f, -0.02599318f, -0.02245190f, -0.16733611f, 
    -0.13723506f, 0.13557142f, 0.09338467f, -0.03081560f, 0.03930199f, -0.01402199f, -0.07331001f, 0.14624716f, 
    0.05051289f, -0.25886539f, -0.12049897f, -0.11050598f, -0.13907023f, -0.12965667f, -0.05603951f, -0.14515553f, 
    -0.14816250f, -0.02993013f, -0.04008839f, -0.13680808f, -0.06187633f, -0.08261785f, -0.03277833f, -0.01497665f, 
    -0.13112336f, 0.01933458f, 0.07651024f, 0.09313754f, -0.00310725f, -0.07333650f, -0.06928750f, 0.16001485f, 
    -0.08820103f, -0.02824878f, 0.04997001f, 0.03153271f, -0.09551808f, -0.22725113f, -0.18311766f, -0.18666950f, 
    0.12481054f, -0.00818627f, -0.14031363f, 0.03302481f, -0.01217177f, -0.07088645f, 0.00932771f, -0.02264689f, 
    -0.18650922f, 0.09419572f, 0.14185762f, 0.13770112f, 0.06616051f, 0.27696589f, -0.00685997f, -0.16613476f, 
    0.10154078f, 0.13696747f, 0.02833386f, -0.03537452f, -0.00642973f, -0.02903468f, -0.06814095f, -0.15491144f, 
    -0.21631309f, -0.14981823f, 0.10105236f, 0.18203112f, 0.06134493f, 0.03425355f, 0.15034448f, 0.00357024f, 
    -0.04767225f, 0.07139007f, -0.04851063f, -0.01571663f, 0.01397345f, 0.23581211f, -0.04365316f, -0.06320238f, 
    0.02513334f, -0.01900400f, 0.07758766f, 0.07580370f, -0.01207135f, -0.20553036f, 0.01477562f, -0.15621905f, 
    0.08411252f, 0.16879198f, -0.03900065f, 0.10416065f, -0.02944254f, -0.15616304f, -0.07258625f, -0.21299769f, 
    -0.11659660f, -0.11317531f, -0.00471350f, -0.00657729f, 0.23165372f, -0.28748015f, -0.13614705f, 0.06761040f, 
    -0.05877999f, -0.03152340f, -0.18177594f, -0.14445770f, -0.15839368f, -0.08455675f, -0.03165707f, -0.24920291f, 
    -0.01872185f, 0.02022219f, 0.08700059f, -0.14052583f, -0.01715318f, 0.08993357f, -0.06930730f, -0.13092797f, 
    0.01517527f, -0.01289405f, 0.09532408f, 0.07924674f, -0.04677379f, 0.04999844f, -0.13614781f, -0.08366912f, 
    -0.04095614f, -0.12864511f, 0.16013607f, -0.01444737f, -0.06453056f, -0.08239940f, 0.07912297f, 0.03658075f, 
    0.26134256f, 0.16849132f, 0.02366887f, -0.23843563f, -0.10657052f, -0.05919940f, -0.08465293f, -0.03265917f, 
    -0.00656123f, -0.12267230f, -0.15833871f, -0.19690877f, 0.06223219f, 0.08689934f, 0.11439637f, 0.12851728f, 
    0.04834687f, -0.04179036f, -0.12403079f, 0.01804450f, -0.06242213f, -0.06077192f, 0.15669733f, -0.05761250f, 
    -0.14161201f, -0.14850381f, -0.02509007f, 0.05731739f, 0.00698434f, -0.05680384f, -0.01137638f, -0.11785271f, 
    -0.07934501f, 0.10095908f, -0.05718156f, 0.06846721f, 0.29130808f, 0.18646833f, -0.10483692f, -0.20875248f, 
    -0.03988450f, -0.05972911f, -0.04988651f, -0.03737011f, 0.04912561f, -0.14968298f, 0.03121546f, -0.10206439f, 
    0.14085597f, -0.13776968f, -0.18453662f, -0.23524575f, 0.02006181f, 0.01862290f, -0.07644445f, 0.11276273f, 
    -0.01284530f, -0.04045827f, 0.06013711f, -0.14120783f, 0.04660179f, 0.05942296f, -0.03343147f, -0.19683722f, 
    -0.04214865f, -0.00998322f, 0.08881848f, 0.09982647f, 0.15572679f, 0.14932603f, 0.07376172f, 0.10316343f, 
    -0.07139536f, 0.11055877f, 0.02599558f, -0.06198685f, -0.08878133f, -0.01426043f, -0.02967103f, 0.14944871f, 
    0.07230908f, -0.02242532f, -0.01939753f, -0.17659923f, -0.19712780f, 0.01124110f, -0.00877483f, -0.15733103f, 
    0.02105958f, -0.04686922f, -0.12242041f, 0.03334099f, 0.08763385f, 0.19951905f, 0.11118861f, 0.15241131f, 
    -0.20034648f, 0.10165457f, 0.11391773f, -0.03852892f, -0.00102930f, 0.08285438f, 0.08565167f, -0.26046395f, 
    0.01503464f, -0.14409441f, 0.03836435f, -0.07121176f, 0.28216082f, -0.21292131f, 0.15088463f, 0.14864448f, 
    0.04888877f, -0.10576933f, 0.09516381f, -0.00322034f, 0.11917908f, 0.03141078f, -0.01017456f, -0.04183380f, 
    0.07381266f, 0.01374510f, -0.03857325f, 0.03016986f, -0.04346908f, 0.00718811f, -0.02959222f, 0.04189514f, 
    0.05572878f, -0.04744688f, 0.03709862f, -0.04573723f, 0.29629040f, -0.04483335f, 0.00054643f, -0.08196664f, 
    0.02088268f, -0.02823916f, -0.22476670f, -0.12601647f, -0.08270995f, 0.04076497f, 0.08472460f, -0.00975450f, 
    -0.20987347f, 0.00988244f, 0.01706235f, 0.11163703f, 0.10681146f, 0.02780552f, 0.01926803f, 0.19053969f, 
    0.09842654f, 0.05206371f, -0.10701586f, 0.05860648f, 0.03107965f, 0.14439669f, 0.02913642f, -0.13829929f, 
    0.06004186f, -0.07587332f, 0.08818475f, 0.09655969f, 0.01089108f, 0.06216587f, 0.03914867f, 0.10411169f, 
    -0.39628193f, 0.03605111f, -0.02951439f, -0.17435044f, 0.16246623f, -0.02523388f, 0.08817595f, 0.10746756f, 
    0.02103668f, -0.12742807f, 0.06387867f, 0.07298046f, -0.00908686f, -0.14986682f, 0.04301205f, 0.06377374f, 
    0.09659307f, 0.03646541f, -0.08888160f, -0.03443237f, 0.12955928f, -0.02181725f, -0.08709551f, -0.01188852f, 
    0.02665886f, -0.16433857f, -0.10074780f, 0.40792182f, -0.01545297f, 0.04551876f, 0.05948890f, -0.04321552f, 
    0.06915018f, 0.03971533f, 0.09982718f, 0.08417881f, -0.55162615f, 0.01554623f, 0.10153030f, 0.04128293f, 
    -0.01901391f, 0.02195697f, 0.08261076f, 0.00238881f, 0.11623986f, -0.06716248f, -0.07252942f, 0.04359096f, 
    -0.06942344f, 0.10211190f, -0.12452342f, -0.07334174f, 0.05792397f, 0.09850693f, 0.04130066f, 0.00797353f, 
    0.23221278f, -0.10156766f, 0.23839688f, -0.06880154f, -0.15219127f, -0.05546270f, -0.13147652f, 0.18838236f, 
    0.05253330f, -0.05567797f, 0.05454969f, 0.00060946f, -0.00623452f, 0.07010451f, -0.05654700f, -0.10521039f, 
    0.05427356f, -0.08437032f, -0.01039348f, -0.00597060f, -0.02828883f, 0.06172894f, 0.13547781f, -0.06608694f, 
    -0.06439362f, -0.11665433f, -0.07309082f, -0.01190611f, -0.02550499f, -0.07759158f, 0.04961209f, 0.07393052f, 
    -0.12041532f, 0.10042832f, 0.06452718f, 0.07321852f, 0.17394440f, 0.09234883f, -0.06450906f, 0.10185993f, 
    -0.18244487f, 0.08036823f, -0.15601300f, 0.00336501f, 0.14151925f, 0.00057621f, -0.07279655f, 0.09177098f, 
    0.04198192f, -0.05721484f, 0.08537216f, -0.08464958f, 0.07536096f, -0.06143615f, 0.27638155f, 0.03394033f, 
    0.10922708f, 0.03177000f, -0.01810673f, 0.05627860f, 0.04349537f, 0.09560232f, 0.13100870f, -0.01998012f, 
    0.06064138f, 0.08568124f, 0.20044291f, 0.24614850f, -0.04135394f, 0.18126900f, 0.04406166f, 0.11205917f, 
    0.11011981f, -0.15127279f, -0.06860530f, -0.09323554f, 0.10318284f, -0.05377226f, 0.02710064f, -0.05992823f, 
    -0.13103184f, -0.05884281f, 0.05977370f, -0.10494719f, 0.11975630f, 0.02618851f, -0.09695787f, 0.07613971f, 
    -0.27302498f, -0.02052652f, -0.21588111f, -0.01760327f, -0.01572270f, -0.02100245f, -0.04078062f, -0.00510979f, 
    0.02672245f, 0.00659816f, 0.07128201f, -0.07493626f, 0.15897417f, -0.30681634f, 0.24914065f, -0.00014120f, 
    -0.07310525f, -0.01633160f, -0.06944603f, -0.10707068f, 0.04301288f, 0.01005535f, 0.01516438f, 0.00821276f, 
    0.32237041f, -0.13395540f, -0.05839866f, 0.19827729f, 0.00143326f, 0.03777529f, -0.08295711f, 0.14691049f, 
    0.06648465f, 0.20051062f, -0.09685198f, 0.04710043f, -0.16620615f, 0.01092503f, 0.11115444f, 0.00196388f, 
    -0.07685466f, -0.11488190f, 0.08572306f, 0.07839918f, 0.02596440f, -0.00561486f, -0.11670373f, 0.10926863f, 
    -0.15993257f, 0.17177700f, 0.02568084f, -0.00655053f, -0.03509468f, 0.00583874f, -0.01748909f, 0.13144416f, 
    -0.05372411f, -0.16815734f, -0.11086073f, -0.03917112f, -0.13537845f, -0.08928553f, 0.07948647f, 0.27711934f, 
    0.02022955f, 0.03791190f, -0.06227816f, -0.16215682f, 0.04057967f, -0.04859060f, 0.07988841f, 0.11001946f, 
    -0.22305499f, -0.04724202f, 0.12952641f, 0.05176813f, 0.03591946f, 0.11172359f, 0.05891227f, -0.00933916f, 
    0.12297645f, -0.01859372f, 0.04809048f, 0.19565243f, 0.21414390f, -0.13250948f, 0.02286557f, -0.11656348f, 
    0.07696301f, 0.02602532f, -0.07564762f, 0.13559185f, -0.01189036f, 0.04495785f, -0.01418020f, -0.07839140f, 
    -0.03323523f, -0.12387989f, 0.11053834f, 0.22361226f, 0.11453754f, -0.02888790f, 0.15973276f, -0.05735354f, 
    -0.04086843f, -0.10285429f, 0.22324963f, -0.03373409f, -0.30588466f, -0.12350932f, 0.14827523f, -0.00461193f, 
    -0.07383389f, 0.11131873f, 0.02188106f, -0.05634582f, 0.02630020f, -0.15795645f, -0.06535137f, 0.00079700f, 
    0.42993534f, 0.18288828f, -0.08733884f, -0.17758805f, 0.01789524f, 0.10436717f, 0.04589617f, -0.16626067f, 
    -0.01474152f, 0.04945651f, -0.06624131f, 0.09364747f, 0.11276183f, -0.09966902f, 0.23219983f, -0.00109359f, 
    -0.09652624f, -0.00934891f, -0.05137635f, 0.12140002f, 0.00187719f, 0.02247347f, -0.04504754f, -0.00940556f, 
    -0.12098134f, 0.06976194f, 0.02449047f, -0.08491714f, 0.05088829f, -0.01687719f, -0.02643972f, -0.07664771f, 
    -0.06570853f, -0.01666284f, 0.00376690f, 0.00514488f, -0.13702777f, -0.12989029f, 0.07497142f, 0.19849601f, 
    -0.09190037f, -0.17619650f, 0.06686603f, 0.06630682f, 0.23076330f, -0.00848978f, -0.05361515f, 0.03013297f, 
    -0.13801944f, -0.04117208f, 0.36679801f, 0.16036353f, -0.09467745f, -0.04503680f, -0.04688659f, -0.02114579f, 
    -0.06791710f, -0.03010017f, -0.00454307f, -0.01957956f, 0.15855777f, 0.23172902f, -0.16146913f, 0.25228474f, 
    0.00469335f, 0.10614555f, 0.04393487f, -0.12878095f, 0.03246761f, -0.13340285f, -0.07187947f, 0.06179247f, 
    -0.36690718f, -0.22651172f, 0.03456135f, -0.10769849f, 0.02706779f, -0.04560361f, -0.04337158f, 0.06786185f, 
    0.03555242f, 0.01370424f, -0.05085696f, -0.03810204f, 0.29120749f, -0.12525481f, -0.00975120f, -0.04459253f, 
    -0.04451052f, 0.00622740f, 0.01729695f, -0.05927278f, 0.07652076f, -0.01566171f, 0.00544439f, -0.07714066f, 
    0.32229388f, 0.01453255f, -0.05156416f, -0.04089008f, -0.10556176f, 0.04549808f, -0.09065840f, 0.09147134f, 
    0.03197214f, 0.14612502f, -0.01191020f, 0.01205132f, 0.01553836f, -0.16889228f, 0.13518932f, 0.10340741f, 
    -0.09155797f, -0.13529806f, -0.09131797f, -0.00644646f, -0.15457858f, 0.01931963f, -0.03360959f, 0.05357913f, 
    -0.73128766f, 0.06942923f, -0.11475889f, -0.05829005f, 0.03291412f, -0.03198983f, 0.02351395f, -0.04387434f, 
    -0.07883310f, -0.14100574f, -0.08510157f, 0.16682270f, -0.14320980f, -0.08688157f, -0.03755065f, 0.11337565f, 
    -0.05314866f, -0.04368380f, -0.00553131f, -0.09940679f, 0.07336889f, -0.02828732f, 0.05074235f, 0.05294312f, 
    0.09551077f, -0.04062526f, -0.00391314f, 0.10659271f, -0.05400502f, -0.06906930f, -0.03531985f, 0.02909517f, 
    -0.00591293f, -0.14379169f, -0.13499060f, 0.05821328f, -0.41939041f, 0.11456672f, 0.03841715f, -0.13685042f, 
    -0.02503742f, 0.01089357f, -0.06583367f, 0.12104630f, 0.02478522f, 0.02637818f, 0.07794167f, -0.11321935f, 
    -0.16581814f, -0.01711218f, -0.03282476f, -0.02437022f, -0.17830397f, 0.04959519f, 0.05226709f, 0.05975372f, 
    0.02275000f, -0.06822443f, -0.02150566f, -0.04450696f, -0.31975338f, -0.04833727f, -0.07936410f, -0.01590415f, 
    -0.06838660f, -0.05517067f, -0.12818725f, -0.03866984f, 0.04916402f, 0.03325287f, -0.16461904f, -0.01680799f, 
    -0.03781170f, -0.03360717f, 0.05325459f, -0.02091936f, -0.01706409f, 0.03421501f, -0.03861891f, 0.00429535f, 
    -0.05305731f, -0.06312592f, -0.01564889f, -0.04063127f, -0.07088278f, 0.04487205f, -0.00119144f, 0.01640301f, 
    0.03202644f, -0.04172676f, -0.06942347f, -0.02243281f, 0.06767606f, -0.07283780f, 0.00861420f, -0.07474027f, 
    0.03767679f, -0.07974330f, -0.07084811f, -0.04338796f, 0.04301339f, 0.04228488f, -0.04603101f, -0.01926435f, 
    0.04109959f, 0.02064991f, -0.01024812f, 0.00353903f, -0.00333623f, 0.06647927f, 0.00189825f, -0.01127848f, 
    -0.02782433f, 0.05002294f, -0.02445568f, 0.05112087f, -0.04195632f, 0.03956760f, -0.05134981f, -0.03339812f, 
    0.02680225f, -0.05088872f, 0.05699937f, 0.03204469f, 0.03010479f, 0.04589868f, -0.04414533f, -0.04557286f, 
    -0.05003319f, -0.00824956f, 0.00837906f, -0.07280364f, -0.06467841f, 0.04110052f, 0.02311151f, 0.00593467f, 
    -0.01553754f, -0.04487864f, 0.05151757f, 0.02361525f, -0.05775895f, 0.02042458f, 0.03943782f, 0.03381405f, 
    -0.01998425f, -0.07131632f, -0.03943226f, -0.01594652f, -0.02651598f, 0.07537136f, -0.06552915f, 0.01846956f, 
    0.03314225f, 0.00222152f, 0.04594551f, -0.01288244f, -0.07017100f, -0.08473070f, -0.01220558f, 0.00590838f, 
    0.02441424f, 0.04165906f, -0.00763441f, 0.06501964f, 0.03570113f, 0.04650477f, 0.02847263f, -0.03339405f, 
    -0.01988436f, 0.02415168f, 0.04810536f, -0.02471575f, -0.00239065f, -0.08089937f, 0.01848605f, 0.06546226f, 
    -0.01162304f, -0.05964296f, -0.03717967f, -0.05051716f, -0.03573925f, -0.05867613f, 0.05449374f, -0.06835169f, 
    0.07668732f, -0.07033529f, -0.01721241f, 0.01158902f, 0.02796747f, -0.05587086f, -0.01176051f, -0.06466513f, 
    -0.05659465f, 0.05357841f, 0.05171215f, -0.00172706f, -0.07715446f, 0.03261356f, 0.03760509f, -0.03435292f, 
    -0.00324547f, -0.04098363f, 0.05733018f, -0.05982143f, 0.02826482f, -0.00699239f, 0.01627006f, -0.02169461f, 
    -0.07905949f, -0.00876016f, 0.05215062f, 0.01796572f, 0.03528949f, -0.06806386f, -0.01812647f, -0.04830532f, 
    -0.04554500f, -0.05358581f, -0.03095089f, 0.03545780f, 0.01417236f, -0.03207275f, 0.00043641f, -0.04734240f, 
    -0.04574804f, 0.02255461f, -0.05050625f, -0.02118077f, 0.01869074f, -0.04580431f, -0.02753265f, 0.05977638f, 
    -0.04838494f, 0.01341519f, -0.04651270f, 0.01684349f, -0.01672717f, -0.07781625f, -0.00388211f, 0.01738275f, 
    0.02934816f, -0.02645560f, -0.06822222f, 0.05445869f, 0.04725797f, 0.03751867f, -0.02189040f, 0.00062869f, 
    -0.05633864f, 0.05999962f, -0.00346414f, 0.02250600f, 0.03277469f, -0.05064022f, 0.01631003f, -0.05606584f, 
    0.00399109f, 0.01761515f, 0.03240376f, -0.05740978f, -0.05666349f, -0.02495089f, -0.01439981f, 0.00141566f, 
    0.17866343f, 0.01392895f, -0.18922159f, -0.06464669f, -0.17108044f, -0.09296425f, 0.04823955f, 0.08033399f, 
    -0.12731950f, -0.05150195f, -0.03784595f, -0.08264715f, -0.20659778f, 0.11099553f, -0.01299954f, -0.01459999f, 
    -0.01225843f, 0.04157869f, 0.05221075f, 0.09144942f, -0.00725141f, 0.12382898f, -0.02753234f, 0.09080967f, 
    -0.14444704f, -0.00471029f, -0.03230709f, 0.24493322f, 0.03765628f, 0.01889985f, 0.07894680f, -0.02154434f, 
    0.10384188f, -0.02967897f, -0.07381640f, 0.03103357f, 0.00221480f, 0.03245040f, 0.18827741f, -0.28145957f, 
    -0.10552633f, 0.05309376f, -0.01974081f, 0.04422164f, -0.05567713f, -0.02742784f, -0.02738465f, -0.07046034f, 
    0.07574797f, -0.22770697f, 0.06611428f, -0.07146931f, 0.15231593f, 0.08999047f, -0.02348584f, -0.02142515f, 
    0.02374781f, -0.05404267f, -0.14388949f, -0.02982137f, 0.33106413f, -0.00497413f, 0.05578890f, 0.18355893f, 
    -0.13575278f, 0.01200340f, -0.10354849f, -0.01932373f, -0.03386767f, -0.02652755f, -0.08195703f, 0.02824499f, 
    0.02318729f, -0.01128064f, -0.06510637f, -0.10934251f, 0.06799740f, 0.06838116f, -0.03286060f, -0.00062249f, 
    -0.10389569f, 0.12061920f, 0.02303550f, -0.13930479f, 0.54321212f, 0.05789039f, 0.24194710f, -0.18485437f, 
    0.02175280f, -0.06406859f, 0.05460032f, 0.08120613f, 0.05846136f, 0.03827321f, 0.09059776f, 0.06071392f, 
    0.05168693f, -0.30752203f, 0.07644867f, 0.20470782f, 0.12656280f, -0.04453254f, 0.02146285f, -0.02803107f, 
    0.05498663f, 0.04013496f, -0.08442911f, 0.05966255f, -0.01189508f, -0.07154469f, -0.06121878f, -0.01530698f, 
    -0.14614481f, -0.04650421f, 0.02312624f, -0.07657964f, 0.05248742f, 0.06040072f, -0.03343637f, -0.00785575f, 
    0.00656089f, -0.02451068f, -0.08196155f, 0.11622620f, -0.12980516f, 0.09556393f, -0.20475200f, 0.08403544f, 
    -0.09220462f, -0.09033860f, -0.00067259f, -0.07087675f, 0.04452737f, -0.11272517f, 0.08264835f, -0.06462339f, 
    -0.07852836f, -0.09188033f, 0.03626667f, 0.00279304f, -0.04680378f, 0.06938011f, 0.24375278f, 0.03339545f, 
    0.26989159f, 0.16792096f, 0.03102715f, 0.26622391f, -0.16570191f, 0.03750045f, 0.12201699f, -0.06103000f, 
    -0.08306341f, -0.01574021f, -0.00949445f, 0.00288849f, 0.19850416f, -0.12168888f, -0.23936108f, 0.05398780f, 
    0.01147179f, 0.14689350f, -0.02292831f, 0.12199485f, 0.09686594f, 0.04874066f, -0.01815816f, 0.08246429f, 
    -0.38957036f, -0.10963401f, 0.22256704f, -0.08483627f, -0.02101006f, -0.01586204f, 0.08786555f, 0.10922310f, 
    -0.04246738f, -0.08401407f, 0.02090644f, -0.16000742f, 0.25067806f, 0.05929346f, 0.41124868f, 0.05457289f, 
    -0.20119481f, -0.04013690f, -0.00508824f, 0.08944320f, -0.02582168f, -0.06170636f, 0.01626193f, 0.07323959f, 
    -0.13209412f, 0.03252225f, 0.01402759f, 0.23352078f, 0.05834616f, 0.12030852f, -0.02655041f, -0.09053224f, 
    0.10514951f, 0.15304197f, 0.01025060f, -0.11744492f, 0.05675698f, -0.01448838f, -0.00875395f, 0.26158413f, 
    0.04744622f, 0.08903477f, -0.13239209f, 0.00681781f, 0.04378069f, -0.00809032f, -0.06790216f, -0.10248859f, 
    0.27961442f, -0.01877657f, 0.02793717f, 0.04837301f, 0.05671266f, 0.14696309f, -0.04399566f, 0.08530609f, 
    -0.06248741f, 0.09957208f, 0.13648668f, -0.08324659f, -0.12383306f, 0.10523849f, 0.00976152f, 0.06965808f, 
    -0.04251480f, 0.15812762f, -0.04173785f, 0.06486249f, 0.09417067f, -0.06845270f, 0.16729660f, 0.07547999f, 
    -0.04632645f, 0.11804326f, -0.12124278f, -0.12695371f, 0.17991379f, 0.02488604f, 0.08629885f, 0.11921949f, 
    0.05486040f, 0.09425222f, -0.00231985f, -0.03755541f, -0.31127310f, -0.17063500f, 0.15039359f, -0.23089798f, 
    -0.07394639f, -0.09635437f, -0.07427774f, -0.11113466f, -0.12517318f, 0.04261830f, 0.00344104f, 0.10444255f, 
    -0.05385406f, 0.33053461f, -0.11034711f, -0.06080828f, -0.07466147f, -0.00124196f, -0.06123549f, -0.20960520f, 
    -0.05743816f, 0.01412252f, 0.01360712f, 0.08067531f, -0.39761886f, 0.08524993f, -0.13559316f, 0.02756226f, 
    0.04972402f, 0.00399306f, -0.00617673f, -0.01283813f, 0.05057753f, 0.01865681f, -0.04264624f, 0.21701118f, 
    -0.26837045f, 0.10981508f, 0.07165833f, -0.20578933f, -0.05778510f, 0.06961662f, 0.02689871f, -0.00710199f, 
    0.09388831f, -0.10021452f, 0.21746135f, -0.19448557f, 0.08897230f, -0.09700096f, 0.05967104f, -0.04391494f, 
    0.06157216f, 0.12098664f, 0.01183293f, -0.00493114f, -0.01904815f, 0.05529445f, -0.04977624f, -0.04047197f, 
    0.71464878f, -0.09000936f, 0.17314723f, 0.02541671f, -0.08710225f, 0.02830330f, 0.08296369f, 0.06835201f, 
    0.12956168f, 0.11548790f, -0.01218770f, 0.11715069f, -0.08715151f, 0.09076834f, -0.16611667f, -0.02867555f, 
    -0.08649378f, 0.07160882f, -0.10902116f, 0.10112578f, 0.12363113f, -0.11538107f, -0.08699907f, -0.05087706f, 
    -0.21496560f, 0.03202841f, 0.19194324f, -0.16629203f, 0.08269943f, -0.00316043f, -0.08821394f, -0.10009917f, 
    -0.17279258f, 0.05861165f, 0.03208653f, 0.10695291f, 0.38542318f, -0.25570610f, 0.24404058f, -0.21270505f, 
    -0.02769224f, 0.01476184f, 0.20480774f, -0.01439627f, -0.00987338f, 0.12006598f, -0.08376025f, 0.03043435f, 
    0.32326373f, 0.22131354f, -0.05075756f, 0.21397324f, 0.03519800f, 0.00308589f, 0.03295396f, 0.01981290f, 
    -0.11822285f, 0.07724708f, -0.09916221f, 0.04527345f, 0.11794230f, -0.09086724f, 0.05447550f, -0.13014331f, 
    0.17671975f, -0.08551489f, -0.04723983f, -0.01495435f, -0.05415547f, 0.01454703f, 0.11199833f, 0.08665545f, 
    -0.17611973f, 0.18679696f, 0.31503949f, 0.08136326f, 0.05295408f, 0.03468494f, 0.01012442f, -0.09167471f, 
    0.16975777f, -0.04064376f, -0.02277943f, -0.00398399f, -0.05391295f, -0.27312437f, 0.20125201f, 0.20664135f, 
    0.06469053f, 0.12508637f, -0.04960375f, 0.02175586f, 0.11535588f, 0.03320617f, 0.05767376f, -0.00427199f, 
    -0.17296538f, -0.07530201f, 0.09899637f, 0.04459041f, 0.15297334f, -0.01047803f, -0.06869160f, -0.07004098f, 
    0.00849200f, 0.09999792f, -0.02788248f, 0.01993777f, -0.01522352f, -0.03533776f, 0.08576941f, 0.07831399f, 
    0.02225188f, -0.07462490f, -0.06964768f, 0.05283298f, -0.01167933f, 0.05200554f, 0.08242686f, 0.02499240f, 
    0.07558927f, 0.02584996f, 0.00086823f, 0.12601057f, -0.17787617f, 0.02936574f, 0.20806579f, 0.10128307f, 
    0.03002654f, -0.08152736f, 0.09814927f, -0.06463677f, -0.22478385f, -0.00495252f, 0.06036323f, -0.18701594f, 
    0.00308813f, 0.11133935f, 0.04167229f, 0.02475078f, 0.10969770f, -0.07036883f, 0.07918879f, 0.07596938f, 
    -0.08335930f, -0.21646315f, -0.27170092f, -0.10300265f, 0.08179256f, 0.04817277f, 0.01511169f, -0.07402528f, 
    0.07684188f, -0.10089456f, -0.01469353f, 0.03510372f, -0.03821871f, 0.08099340f, 0.20514408f, 0.05780593f, 
    0.07015015f, 0.06208413f, -0.10042793f, -0.13597712f, 0.17739618f, 0.03404069f, 0.04140687f, 0.02562948f, 
    0.24526048f, -0.02471963f, -0.05548777f, -0.02697385f, 0.14298451f, 0.02643945f, 0.00771266f, 0.03115122f, 
    -0.00725350f, 0.09883088f, 0.01272430f, -0.08254755f, -0.01012355f, -0.12512456f, 0.04334393f, 0.06814641f, 
    -0.04826071f, -0.00791811f, 0.01645143f, 0.12997359f, 0.04103922f, 0.04471033f, 0.05724997f, 0.15688412f, 
    -0.62491018f, 0.04676783f, -0.06586950f, 0.08915917f, 0.11263838f, 0.09889873f, 0.16627623f, 0.04238087f, 
    -0.12248462f, -0.01250677f, 0.08010810f, 0.04231242f, 0.06778695f, 0.14537437f, -0.01495637f, 0.17661966f, 
    -0.01173672f, 0.04339699f, -0.01986248f, 0.08580823f, -0.02400297f, 0.01290053f, 0.04023833f, 0.12823129f, 
    -0.02030848f, 0.02432755f, 0.18595161f, -0.30854028f, 0.11801507f, -0.08225825f, -0.01917310f, 0.02112053f, 
    0.13209103f, -0.01828337f, 0.11343520f, 0.24003385f, -0.35272771f, -0.04956814f, -0.15939569f, -0.35303959f, 
    0.15775423f, 0.16233291f, 0.04396429f, 0.10444143f, 0.05484478f, -0.05412625f, 0.06881721f, -0.08921854f, 
    0.02692536f, -0.11204740f, 0.03696607f, 0.30955529f, 0.04584056f, 0.10742281f, 0.08670025f, -0.01294172f, 
    0.11942656f, -0.04821042f, 0.08296686f, 0.00968971f, -0.11719112f, 0.03889006f, -0.07783831f, -0.21370031f, 
    0.06058160f, -0.13654901f, 0.07330468f, 0.07382415f, 0.11229955f, -0.09633881f, -0.03332685f, -0.12503923f, 
    0.03854697f, -0.21184616f, 0.01564753f, -0.13608350f, 0.02844267f, 0.06029572f, 0.06288041f, -0.04080033f, 
    0.11057682f, -0.04739540f, -0.14054000f, 0.06288705f, -0.03010392f, 0.12177122f, -0.21027656f, -0.16264273f, 
    -0.09462125f, 0.02366330f, 0.04356192f, -0.03556863f, 0.04289435f, 0.17217858f, 0.07161140f, 0.08621110f, 
    -0.42352521f, -0.04776917f, -0.08300059f, -0.13835816f, -0.14450817f, 0.06259716f, -0.10829896f, 0.11792424f, 
    -0.06723822f, -0.03047494f, 0.02287117f, -0.06480461f, 0.22446065f, 0.11033463f, -0.09625468f, 0.08275520f, 
    0.00671089f, -0.03746291f, 0.20244460f, 0.03622992f, 0.03561706f, 0.08714716f, 0.02264823f, 0.04303502f, 
    0.11963671f, 0.17266743f, -0.13093236f, -0.12065879f, 0.03938833f, 0.05653386f, -0.06045143f, 0.03088368f, 
    -0.02423222f, -0.10082336f, 0.20691904f, 0.15110712f, 0.09900084f, -0.09881868f, 0.18271804f, 0.21876480f, 
    -0.00480400f, 0.08514001f, 0.01705411f, 0.01818504f, -0.03670895f, -0.04723025f, -0.00060036f, -0.06973717f, 
    -0.07278682f, 0.15206710f, 0.02848272f, -0.11081886f, -0.03383869f, -0.07632837f, -0.00086201f, 0.04474119f, 
    -0.12248941f, 0.01335272f, 0.02805890f, -0.06673998f, 0.02607162f, -0.00525071f, 0.08081273f, 0.16336541f, 
    0.21872458f, 0.00934665f, -0.06600811f, 0.02422666f, 0.04773019f, -0.19663829f, 0.05548013f, -0.15558918f, 
    0.12835841f, 0.19049054f, -0.02230367f, -0.05429074f, -0.09461689f, -0.09563170f, -0.12404691f, 0.05141589f, 
    0.09727515f, 0.16261974f, -0.06002583f, 0.15450051f, -0.09772178f, -0.07294788f, -0.17102312f, -0.19393924f, 
    0.14006248f, -0.07269304f, -0.14183989f, -0.07867764f, 0.01073375f, -0.01154464f, 0.04753881f, -0.01835503f, 
    0.25260592f, -0.07780369f, 0.11439721f, 0.26094466f, -0.10019125f, 0.03429618f, -0.04588445f, -0.05949197f, 
    0.12192201f, 0.05068609f, -0.06960284f, 0.05059525f, 0.04678196f, -0.14331834f, -0.11573180f, -0.03163750f, 
    0.14506462f, 0.03671440f, 0.05596539f, -0.03660518f, 0.16704847f, 0.09085447f, 0.03930387f, -0.02956130f, 
    0.15643454f, -0.19642225f, 0.01388395f, 0.01083893f, 0.22982010f, -0.02786404f, 0.05275774f, -0.07693156f, 
    0.01549806f, -0.15193994f, 0.07047929f, -0.01680827f, 0.60077012f, -0.21715350f, 0.23301682f, 0.16599475f, 
    -0.07131986f, -0.05425371f, -0.08585174f, -0.07648855f, -0.05199188f, -0.12238173f, 0.01623365f, -0.01786884f, 
    -0.02761565f, -0.18711346f, -0.30723470f, -0.21138774f, 0.06705339f, -0.01138325f, 0.01582205f, 0.03949456f, 
    0.14006844f, 0.11331871f, 0.09070733f, -0.12961122f, 0.04219659f, -0.02842032f, -0.16266733f, 0.00837965f, 
    0.11177465f, 0.27051294f, -0.05961597f, 0.05127327f, 0.01438768f, -0.02828412f, 0.03442122f, -0.09014678f, 
    -0.24913491f, 0.11036759f, 0.06399833f, 0.08576875f, 0.00008842f, -0.04602236f, -0.02892404f, 0.00521120f, 
    -0.10765579f, -0.00238987f, 0.11751828f, -0.07706986f, 0.13610242f, -0.22389500f, 0.14274748f, 0.27859092f, 
    0.04821900f, -0.00115018f, -0.02865023f, -0.16147113f, 0.02176437f, 0.02919011f, 0.00655087f, 0.10809148f, 
    -0.07227097f, 0.03158358f, 0.07325634f, -0.06178629f, -0.01901176f, 0.03444566f, -0.00462631f, -0.01461902f, 
    0.11096917f, -0.03876067f, -0.09274440f, -0.05214787f, 0.07922246f, -0.02497024f, 0.04422790f, 0.11483710f, 
    -0.01346362f, -0.00449344f, -0.12470741f, 0.01622454f, -0.08273790f, -0.07005884f, 0.03979849f, 0.08903282f, 
    0.06525555f, 0.00076519f, 0.08956259f, 0.36543795f, 0.00473986f, -0.11111491f, 0.11306412f, -0.01561323f, 
    0.03117770f, -0.02905231f, -0.09520397f, -0.05877791f, -0.35687703f, -0.15994771f, -0.00527925f, -0.40711230f, 
    0.00744885f, 0.02850011f, 0.13638321f, -0.04098761f, 0.18098840f, 0.10829146f, 0.01737272f, 0.01364967f, 
    0.12023617f, 0.00273830f, -0.24091673f, 0.20059438f, -0.05359496f, -0.00136528f, -0.04522247f, 0.01793050f, 
    0.04777549f, -0.09277984f, 0.04997375f, -0.05905046f, -0.03360059f, -0.12211546f, -0.11148852f, -0.03694037f, 
    -0.02154923f, 0.12942660f, -0.00260983f, -0.11931501f, -0.13335875f, -0.02993082f, 0.00188949f, 0.04169017f, 
    0.18524827f, 0.10172734f, 0.02930507f, 0.19936539f, 0.07907645f, -0.03395149f, 0.05563932f, -0.17407410f, 
    -0.00757108f, -0.03707352f, -0.03768765f, -0.07502528f, 0.09958258f, 0.22883369f, 0.06315654f, 0.08454367f, 
    0.04923033f, 0.03051262f, 0.13766797f, 0.12883200f, 0.02739886f, 0.05672003f, 0.10331459f, 0.10223540f, 
    0.05673934f, 0.10837688f, -0.01563195f, -0.09227875f, 0.10992496f, -0.07237199f, 0.11845513f, 0.12649481f, 
    -0.06147058f, -0.00996076f, 0.05043539f, -0.03667455f, -0.03772566f, 0.08767167f, -0.06218291f, 0.25826666f, 
    -0.07060131f, -0.14740250f, -0.01457987f, -0.09476668f, -0.08280800f, 0.01632764f, 0.02059332f, 0.03745495f, 
    -0.35652706f, 0.04531805f, 0.11269300f, -0.13613369f, 0.02736966f, 0.00964708f, 0.00935505f, 0.05129399f, 
    0.00558128f, 0.13251582f, 0.07638664f, 0.13608092f, -0.10468643f, 0.21598674f, 0.04158793f, 0.01853306f, 
    0.17553462f, 0.02151355f, 0.01543300f, 0.11362629f, -0.06917984f, 0.00891119f, -0.01048153f, 0.00237559f, 
    0.11565174f, 0.00008754f, -0.03065500f, 0.42415819f, 0.01770133f, -0.05758183f, -0.03037804f, -0.07287728f, 
    0.03113589f, 0.06251017f, 0.08605140f, 0.05647919f, 0.02337508f, -0.09492714f, 0.04098499f, -0.08089381f, 
    0.14120428f, -0.09430984f, 0.03919284f, 0.00016427f, -0.04717119f, -0.18149744f, -0.00764569f, 0.00443266f, 
    0.04037373f, 0.01637032f, -0.05205377f, -0.01095406f, -0.00361885f, -0.00319255f, 0.02303546f, -0.02089092f, 
    0.00553061f, 0.01519455f, -0.01898528f, 0.02006534f, 0.00716492f, -0.02149746f, 0.03091791f, -0.03073594f, 
    -0.07228183f, 0.02881073f, -0.08529712f, -0.00922450f, -0.06609511f, -0.04769831f, 0.01758637f, 0.03012818f, 
    0.00827543f, -0.05523518f, 0.00617469f, 0.05872605f, -0.07432637f, -0.06947982f, -0.06010164f, -0.04810664f, 
    0.00298068f, 0.03803886f, 0.05032228f, 0.03862427f, 0.00351951f, -0.07189135f, 0.00603676f, -0.05251503f, 
    0.02132136f, -0.00845124f, -0.07623215f, -0.05628736f, -0.07567076f, -0.07868041f, 0.02647991f, -0.05572939f, 
    0.03368690f, -0.01704666f, -0.06205459f, -0.02902498f, 0.00982111f, -0.07537913f, 0.03508760f, -0.04852626f, 
    0.04190663f, 0.05873882f, 0.02841377f, -0.06263337f, 0.05453173f, -0.01422644f, 0.05969058f, -0.05322344f, 
    0.05525290f, 0.02528979f, 0.03218558f, -0.07199751f, -0.05144159f, -0.04447070f, -0.06427966f, -0.02816811f, 
    -0.07514694f, -0.04810524f, 0.03951505f, 0.00630599f, 0.03955681f, 0.05528133f, 0.01425149f, 0.06686851f, 
    -0.01091887f, 0.01930412f, 0.04433944f, 0.01227462f, -0.03665770f, -0.04239850f, 0.06106816f, 0.04670128f, 
    0.01104814f, 0.01589976f, -0.06955139f, 0.02310828f, -0.07261553f, 0.00470634f, 0.03490253f, -0.05168418f, 
    0.02689300f, 0.04525337f, 0.02976140f, 0.02476519f, -0.00852989f, 0.03437987f, 0.02760523f, 0.03122516f, 
    -0.06624048f, 0.03216554f, 0.06083051f, -0.05298001f, -0.06106460f, -0.00008243f, 0.03423716f, 0.04013359f, 
    0.00932377f, 0.05236425f, -0.02887310f, 0.03640097f, -0.06058350f, -0.01325038f, 0.00290898f, -0.00917206f, 
    0.00887312f, 0.05020193f, -0.00071443f, -0.06284403f, 0.03633547f, -0.06203973f, 0.00076125f, -0.02223137f, 
    -0.06685394f, 0.00504095f, 0.02751581f, 0.04013596f, 0.02563912f, -0.03404948f, 0.01909387f, -0.02504643f, 
    -0.06161886f, -0.01230454f, 0.04900140f, 0.05078668f, -0.07179388f, -0.05573875f, 0.03125395f, 0.00345445f, 
    -0.04526675f, 0.04819269f, -0.01151718f, 0.03012217f, 0.04264085f, -0.04210250f, -0.00581103f, -0.04147493f, 
    -0.05037133f, -0.02502448f, -0.05124139f, 0.02091772f, -0.06025921f, 0.00644162f, -0.00550145f, -0.05883594f, 
    -0.05161181f, -0.02878566f, -0.03272893f, 0.00946996f, -0.04179066f, 0.03179050f, -0.01801870f, -0.05618211f, 
    0.02627888f, -0.05804108f, -0.05029371f, -0.06951172f, 0.00034251f, 0.03186334f, 0.04533090f, -0.05885625f, 
    -0.01741667f, -0.05588952f, 0.02959234f, 0.06275914f, -0.05022576f, -0.00254416f, 0.03223295f, -0.02142090f, 
    -0.04184015f, 0.02127623f, -0.03966038f, 0.04559480f, -0.05014432f, -0.06862549f, 0.02742390f, 0.02054077f, 
    0.07147879f, -0.01859725f, 0.10177603f, -0.07425078f, 0.11613379f, 0.03465256f, 0.12312648f, -0.08374961f, 
    0.07857552f, 0.03181852f, -0.02325642f, 0.17324223f, -0.08599292f, 0.04010628f, -0.00340242f, -0.20213227f, 
    -0.10354213f, -0.01843370f, 0.06692316f, 0.14274842f, -0.07564631f, -0.02797983f, -0.00033849f, -0.14497666f, 
    -0.13415015f, 0.07256147f, -0.20512336f, -0.09054357f, -0.14066315f, 0.00627872f, -0.02853112f, -0.00167383f, 
    -0.00954964f, 0.10894118f, 0.16015482f, 0.11596616f, 0.16173808f, -0.00458700f, -0.05521729f, 0.18498023f, 
    0.16192582f, -0.07764517f, 0.35619923f, 0.14137949f, 0.14195670f, 0.04124648f, -0.08110663f, -0.01112782f, 
    0.00998843f, 0.11513192f, 0.05969197f, -0.26138473f, -0.04733734f, -0.00009853f, -0.10695482f, 0.13371134f, 
    -0.02154804f, 0.15504283f, 0.19586562f, 0.23154031f, 0.13525514f, 0.13140109f, -0.13662659f, 0.06876556f, 
    0.12412082f, 0.05793746f, 0.01984607f, -0.01135605f, 0.07094146f, -0.00204120f, 0.07093050f, 0.15621348f, 
    -0.20677687f, -0.22706808f, 0.19665726f, -0.02521116f, -0.07696546f, -0.05724467f, 0.10190896f, 0.03751626f, 
    0.08065594f, 0.18402813f, -0.08734034f, 0.04682680f, -0.30427301f, 0.00065637f, 0.05547583f, 0.14034995f, 
    0.07532225f, 0.09701870f, 0.17433240f, 0.15464799f, 0.04596603f, -0.00333506f, 0.03246327f, -0.07624014f, 
    0.04944590f, 0.06555081f, 0.04602038f, -0.07551085f, -0.10896569f, -0.00490599f, 0.07889402f, -0.01467343f, 
    -0.00328915f, 0.05819387f, -0.02594445f, 0.13050935f, -0.05890109f, 0.09944656f, -0.14205042f, 0.02324627f, 
    -0.08000538f, -0.01523690f, -0.04431605f, -0.04505498f, 0.04473497f, 0.01098047f, -0.04937141f, -0.20776351f, 
    -0.04062445f, 0.01930655f, -0.03939890f, 0.11431952f, 0.02853383f, 0.09568224f, 0.02341373f, 0.05152900f, 
    0.01394191f, -0.02432526f, 0.00295322f, 0.07258081f, 0.23926896f, -0.02181126f, 0.04386733f, -0.11076977f, 
    0.27795136f, 0.15568875f, 0.17441374f, -0.07998878f, 0.15833437f, -0.02547827f, 0.03568270f, -0.07768604f, 
    0.15688856f, -0.03293223f, -0.04001748f, -0.12917894f, 0.11688349f, 0.10576291f, -0.01015609f, 0.06361348f, 
    0.01317171f, -0.06517407f, -0.06688572f, -0.07901614f, 0.21139121f, -0.15324020f, -0.18082540f, 0.18482022f, 
    -0.08275710f, -0.12144518f, -0.01995933f, -0.10955370f, -0.03954872f, -0.06506685f, 0.02396116f, -0.03384718f, 
    0.26172552f, -0.10309692f, -0.03721907f, -0.25619039f, 0.07305066f, 0.21827006f, 0.08717272f, 0.02975524f, 
    -0.02630321f, 0.03686039f, -0.01451454f, 0.08212718f, -0.19428128f, 0.06125792f, -0.08483751f, 0.04945282f, 
    -0.10808082f, 0.13460355f, -0.06176719f, -0.03107957f, 0.02290378f, 0.16209756f, 0.03134542f, 0.09827635f, 
    -0.04615577f, 0.20356603f, -0.11322739f, -0.00190635f, 0.12120967f, 0.14191692f, 0.06497194f, 0.06994188f, 
    0.05508176f, 0.10818169f, 0.12580211f, 0.07552247f, 0.22839803f, 0.19585504f, 0.00050564f, 0.11649145f, 
    0.16197972f, -0.13214467f, -0.25018689f, -0.01684995f, -0.01417049f, -0.10017306f, -0.11345718f, 0.03703789f, 
    0.65564990f, 0.01639651f, 0.13327545f, 0.00655399f, -0.11360996f, 0.03001218f, 0.07958461f, 0.09407206f, 
    0.00545257f, 0.09473845f, -0.01465211f, 0.08037287f, -0.04248841f, -0.00430063f, -0.04181592f, 0.02405158f, 
    0.00502166f, -0.15979783f, 0.05620844f, 0.03943747f, -0.00213194f, -0.27856466f, -0.10946519f, -0.08330728f, 
    -0.20636463f, 0.01359322f, -0.10529373f, -0.01567492f, -0.01331598f, -0.13527529f, 0.16902821f, 0.12975302f, 
    -0.02872162f, 0.22149137f, -0.08388582f, 0.09123378f, 0.05904849f, -0.12184843f, -0.00935038f, 0.06704643f, 
    0.17216277f, -0.13456835f, 0.05434631f, -0.05582507f, -0.03136555f, 0.06808443f, 0.14725997f, -0.06012445f, 
    0.36774796f, 0.12322505f, -0.03096055f, 0.06906370f, -0.03607347f, 0.14942570f, 0.12179200f, 0.15960075f, 
    0.06828221f, -0.05791490f, 0.07344749f, 0.10477612f, -0.07931931f, 0.04909994f, -0.33887002f, 0.09929118f, 
    -0.04160772f, 0.11857487f, 0.02729738f, -0.07045984f, -0.04959879f, 0.15266590f, -0.06151238f, -0.07208164f, 
    -0.32282755f, -0.18560244f, 0.13342364f, -0.02982264f, 0.05430492f, 0.07389618f, 0.00651479f, -0.13516738f, 
    -0.06733452f, -0.03353797f, 0.09365328f, 0.01914265f, 0.35122964f, 0.16494982f, -0.08892448f, 0.08548940f, 
    -0.09371464f, -0.04341131f, -0.07161037f, 0.05824989f, -0.09353537f, 0.07224244f, -0.07085860f, -0.19029912f, 
    0.12618159f, -0.07000685f, 0.00676810f, -0.18656611f, 0.01191464f, -0.12838772f, -0.10560082f, -0.00507350f, 
    0.15002754f, 0.04502029f, 0.04266314f, -0.02820182f, 0.19723788f, 0.02868799f, 0.03021371f, -0.03902483f, 
    0.00975308f, 0.00408762f, -0.03248702f, 0.08433166f, -0.06754651f, -0.06739268f, -0.04538939f, 0.00086577f, 
    -0.00272447f, 0.06408166f, -0.26218638f, 0.30513400f, 0.02943349f, -0.09571516f, -0.05737692f, -0.02267492f, 
    -0.10065898f, -0.13682105f, -0.16819796f, -0.03804481f, -0.45041287f, 0.19061601f, -0.22424173f, 0.04887782f, 
    -0.07698184f, 0.06566373f, 0.08355165f, 0.12516420f, -0.06804729f, 0.00952383f, 0.03584032f, 0.11043330f, 
    -0.02721703f, 0.27655822f, 0.07534381f, -0.09565997f, -0.04571636f, 0.10348064f, -0.11594213f, -0.10789050f, 
    0.03777037f, -0.02741634f, -0.07700871f, 0.13983260f, 0.29111439f, 0.08517665f, -0.24029419f, 0.03308151f, 
    0.11058747f, -0.13244429f, -0.03567560f, -0.17903334f, -0.04802396f, 0.08779839f, -0.06362483f, -0.03016989f, 
    -0.26095262f, 0.01024065f, 0.20434880f, 0.05341807f, -0.08285508f, -0.01579714f, -0.10307012f, 0.05915345f, 
    -0.06717344f, -0.10649219f, -0.00442695f, -0.01786328f, -0.13267246f, 0.03281752f, 0.02735491f, 0.15081145f, 
    0.04601185f, 0.07500117f, -0.07108638f, -0.16282888f, 0.02178704f, 0.10079650f, 0.01424157f, 0.05022753f, 
    0.42081562f, -0.05699428f, 0.04610896f, 0.26935461f, 0.24472849f, 0.11401840f, 0.14856769f, -0.10218126f, 
    0.00081898f, -0.03856053f, -0.07119888f, 0.06451994f, 0.00084709f, 0.01370990f, 0.11640142f, -0.06174972f, 
    -0.16182281f, 0.10711578f, -0.14203002f, 0.04955480f, 0.05693856f, -0.04281677f, 0.15287550f, 0.02372868f, 
    0.15418538f, -0.11101519f, -0.02163562f, 0.05896858f, -0.03429779f, -0.00064193f, 0.05334491f, 0.12502275f, 
    0.02476702f, -0.04723614f, -0.15931822f, -0.17913815f, -0.01080874f, 0.04584587f, 0.06860767f, 0.06087812f, 
    -0.20997699f, 0.09803095f, -0.10136283f, 0.15332010f, -0.19573607f, 0.06803039f, -0.03036688f, -0.08961460f, 
    0.37407488f, -0.01252270f, -0.23670691f, -0.21664980f, 0.08688551f, 0.00258336f, 0.01919006f, -0.12555006f, 
    0.09525504f, 0.01997615f, -0.04796582f, 0.02426711f, 0.11706363f, 0.00616114f, 0.18508735f, -0.07365823f, 
    0.11621109f, -0.04098034f, 0.10082562f, 0.00957787f, 0.21200129f, 0.01118446f, -0.07394391f, -0.02728314f, 
    -0.01072974f, -0.19295730f, -0.02922153f, -0.04042379f, 0.06821153f, 0.04114670f, 0.09578955f, -0.05496286f, 
    0.03945082f, -0.00200307f, 0.12106494f, -0.05105911f, -0.22295271f, -0.09508364f, -0.02888178f, 0.13328622f, 
    0.11721434f, 0.02343093f, -0.09044250f, -0.24391596f, -0.00344420f, 0.03309499f, 0.07865047f, 0.03016029f, 
    -0.28459004f, -0.10955730f, 0.04694321f, 0.04838348f, -0.04208869f, 0.05774549f, -0.15224347f, -0.11292829f, 
    -0.01229931f, -0.00520559f, -0.01758711f, -0.03510122f, -0.01271937f, 0.05800754f, 0.09269907f, -0.20268005f, 
    -0.08957053f, 0.10897883f, 0.02562343f, 0.16805491f, -0.17207405f, -0.04340927f, 0.16123931f, 0.02818231f, 
    0.20153186f, 0.16304775f, 0.01361340f, -0.18207940f, -0.08217163f, -0.00130563f, -0.02275456f, -0.02547625f, 
    -0.00448847f, 0.06051924f, -0.03893427f, -0.11157842f, -0.00506035f, 0.19268143f, -0.07027847f, -0.36846727f, 
    0.11252150f, 0.12263745f, 0.02051384f, -0.05625274f, 0.10177930f, -0.04022795f, 0.16427502f, -0.01863560f, 
    -0.17438570f, -0.01914098f, 0.14696282f, 0.04279020f, -0.15206382f, -0.11107770f, 0.08222906f, -0.05437128f, 
    0.00319496f, 0.04412690f, 0.00223558f, -0.05630168f, 0.48854661f, 0.14731815f, 0.14524776f, -0.09007106f, 
    -0.07655387f, -0.06532378f, 0.02556678f, -0.04242748f, 0.04673162f, -0.07160436f, -0.11958085f, -0.00635442f, 
    0.25341153f, -0.03120992f, -0.04512354f, -0.06183922f, -0.06449991f, -0.04961930f, 0.03376704f, 0.10577308f, 
    -0.03472314f, -0.10638576f, -0.05334999f, -0.10393134f, -0.20426713f, -0.10940107f, 0.12402597f, -0.16925734f, 
    0.00337241f, 0.10183457f, 0.10177525f, 0.10505120f, 0.06374095f, 0.10953450f, 0.02533278f, 0.06272500f, 
    -0.25075200f, 0.15106109f, 0.00489940f, 0.24177526f, 0.11083558f, -0.08455904f, 0.00247680f, 0.05843103f, 
    0.10125972f, -0.04821684f, -0.08977952f, -0.04742476f, 0.04773363f, -0.16790493f, 0.25868672f, -0.17368084f, 
    0.11403026f, 0.01460334f, -0.00670416f, 0.02111290f, -0.06541300f, 0.14208928f, 0.15076098f, 0.13124111f, 
    0.00389265f, -0.20087902f, 0.11968645f, 0.16086605f, 0.01134183f, 0.14309451f, 0.08865175f, 0.06360727f, 
    0.16044870f, -0.08206803f, -0.09024917f, -0.06897631f, 0.23550636f, 0.00615904f, 0.08655630f, 0.18102428f, 
    -0.16770723f, -0.08933846f, -0.02700509f, 0.03483734f, 0.08642087f, 0.13540204f, -0.10884988f, 0.11320943f, 
    0.04172414f, -0.07346690f, -0.07293580f, -0.16039835f, 0.14016615f, 0.05979498f, -0.01340978f, 0.01623554f, 
    0.10928704f, 0.03604365f, 0.10978662f, -0.09560682f, 0.46260968f, -0.12554997f, 0.17739527f, -0.12808859f, 
    -0.07653143f, -0.00843299f, -0.13556443f, 0.04187907f, 0.02544373f, 0.07725118f, 0.08485416f, -0.04893438f, 
    0.18393014f, -0.34525850f, -0.08150124f, 0.19273876f, 0.06821291f, 0.02104698f, -0.03418889f, 0.05111452f, 
    0.08364993f, 0.11084117f, -0.08213491f, 0.04230766f, -0.24938487f, 0.08530069f, 0.05416643f, 0.06651521f, 
    -0.02561203f, -0.05121117f, -0.04471325f, 0.02131457f, 0.11804756f, -0.03430821f, -0.09372600f, 0.03830234f, 
    -0.57298636f, 0.01091822f, -0.08333566f, 0.10617535f, 0.06034292f, -0.07289948f, -0.05843847f, 0.05208880f, 
    -0.17810453f, -0.12303433f, -0.06785314f, -0.02782250f, 0.13566431f, -0.12462394f, 0.13630697f, 0.18632421f, 
    -0.03165536f, -0.09828212f, 0.04633412f, -0.10270457f, -0.05492415f, 0.00654585f, 0.12576194f, 0.11669603f, 
    0.15598722f, -0.03838031f, 0.08549965f, 0.40655267f, -0.02766816f, 0.02678934f, 0.10435753f, -0.08439676f, 
    0.03671105f, -0.04898988f, -0.06236215f, 0.03125338f, -0.19590865f, 0.09266358f, -0.29728419f, -0.17099722f, 
    0.10018554f, 0.07737695f, 0.04999384f, 0.19346358f, 0.04514011f, -0.00237852f, -0.11559550f, 0.07992782f, 
    -0.20356424f, -0.11395790f, 0.15055643f, -0.07376538f, -0.08777864f, -0.02622913f, 0.12682228f, 0.02538437f, 
    -0.04246856f, -0.09100071f, 0.01913630f, -0.03270061f, -0.12444440f, -0.03399040f, 0.29487753f, 0.11660692f, 
    -0.23946969f, -0.00989938f, 0.07468612f, 0.05436529f, 0.01111644f, -0.03342033f, -0.20798068f, -0.08403368f, 
    0.05907655f, 0.05085978f, -0.00096673f, -0.01459400f, 0.05189918f, 0.02809519f, 0.03084093f, -0.06261905f, 
    0.05202647f, 0.02112580f, -0.04012362f, 0.05386156f, 0.01134648f, -0.06044174f, -0.04491514f, 0.02465104f, 
    0.01842132f, -0.05833938f, -0.04671175f, -0.05119247f, -0.02857966f, 0.00593375f, 0.06065350f, -0.03641159f, 
    -0.06423239f, 0.00845813f, -0.07130623f, -0.02080411f, 0.04537002f, -0.02262042f, -0.01935825f, -0.00767006f, 
    -0.03993992f, -0.02669187f, -0.00744875f, -0.02500360f, -0.04250343f, -0.04747555f, 0.06495383f, 0.02739899f, 
    0.01364039f, 0.01055213f, -0.01598757f, 0.03018679f, 0.02717749f, -0.03076760f, 0.05149160f, -0.01650515f, 
    -0.02470764f, 0.01725454f, -0.03169837f, -0.03529485f, 0.00288631f, -0.00233872f, 0.02011745f, 0.04568967f, 
    0.06119059f, -0.07953439f, 0.03711241f, -0.03455192f, 0.02077292f, 0.03281802f, -0.07065769f, -0.04194394f, 
    0.04954692f, -0.02035406f, -0.00231878f, -0.02886979f, -0.01079750f, -0.06144110f, -0.00114996f, 0.00645644f, 
    -0.03095428f, 0.01419479f, 0.05281805f, -0.06612222f, -0.02735144f, -0.03153344f, -0.00898805f, 0.02578987f, 
    -0.03477906f, -0.04781023f, -0.05139164f, 0.03499562f, -0.00482533f, -0.04719822f, -0.00925977f, -0.06532504f, 
    -0.04800573f, 0.00964316f, -0.07177971f, 0.00523667f, 0.03530877f, 0.00758395f, -0.05125994f, 0.01086189f, 
    -0.06262103f, -0.02551543f, 0.07388259f, -0.04334313f, -0.06453247f, -0.03559655f, -0.05089594f, 0.01175036f, 
    -0.03542937f, 0.01738330f, 0.02472579f, -0.00973522f, 0.00291386f, -0.05044158f, -0.00425905f, -0.05330367f, 
    0.04457690f, -0.02665480f, -0.01409387f, 0.05385566f, 0.02093063f, 0.00518183f, -0.04834743f, 0.03127588f, 
    -0.04479438f, 0.05418960f, 0.00201056f, 0.03604183f, 0.01756536f, 0.03388764f, -0.00798847f, 0.06626721f, 
    0.01805927f, -0.07479900f, -0.02078699f, 0.00971265f, -0.00620065f, -0.03160306f, -0.03352417f, -0.03119673f, 
    0.00211335f, -0.03527184f, -0.01658139f, -0.05590316f, -0.07161894f, -0.06286679f, 0.06094712f, 0.03763796f, 
    -0.00927810f, -0.00273138f, -0.06076482f, 0.01216795f, 0.05512572f, -0.07377297f, 0.05776056f, -0.05428347f, 
    -0.01771816f, 0.05218134f, 0.02667541f, -0.04540614f, 0.05245668f, -0.03852933f, -0.05607062f, 0.05044667f, 
    -0.05795281f, 0.00312322f, -0.04353375f, -0.05370119f, -0.06882454f, -0.07013614f, -0.07349442f, 0.03781113f, 
    0.02860465f, 0.06173862f, -0.06792455f, 0.02178416f, 0.05209612f, -0.06818414f, 0.05963396f, 0.04255290f, 
    0.01386402f, -0.02666012f, -0.07044850f, 0.05635066f, 0.02339150f, -0.07018563f, 0.01846918f, -0.03169183f, 
    -0.00131826f, -0.00524375f, 0.00025400f, -0.05219562f, 0.00792900f, -0.05977449f, 0.01695381f, -0.03382375f, 
    0.03921577f, 0.05336849f, -0.03757213f, -0.05835962f, -0.01087942f, -0.07141571f, 0.05432089f, 0.01938474f, 
    -0.07222904f, -0.07840505f, -0.01124663f, 0.00586535f, 0.06009090f, -0.03911626f, -0.03751477f, -0.02733477f, 
    0.02422285f, -0.04088345f, 0.05936855f, -0.03523161f, -0.05421951f, 0.06041448f, -0.06880248f, -0.02704249f, 
    0.05603684f, -0.02583672f, 0.00182586f, -0.06923228f, 0.04836578f, -0.03820994f, -0.02815016f, 0.05483712f, 
    -0.00399606f, 0.05315611f, -0.07586212f, 0.06360791f, 0.02060561f, 0.01275252f, -0.07999161f, 0.01332967f, 
    0.06566197f, -0.06598540f, 0.01697224f, 0.02497112f, 0.04510253f, 0.05070044f, -0.06066957f, 0.05391150f, 
    0.05229429f, 0.00322289f, 0.05773152f, -0.03711859f, -0.03557847f, 0.03101927f, -0.02403174f, -0.03482698f, 
    -0.06757160f, 0.03127438f, 0.04342454f, 0.06169245f, -0.01997100f, -0.07436132f, -0.00001366f, 0.05954562f, 
    -0.02512109f, 0.04024896f, -0.04086174f, -0.00185893f, 0.05097682f, 0.05986734f, 0.00246080f, 0.03345960f, 
    -0.00543207f, 0.00895572f, -0.01677741f, 0.00963323f, 0.01564858f, -0.01172321f, -0.00426916f, -0.01828522f, 
    -0.06221353f, -0.05999558f, -0.07457361f, -0.03730636f, 0.03147674f, -0.06771244f, -0.03205674f, -0.01770372f, 
    -0.01249534f, 0.01911895f, -0.04317424f, 0.04591661f, -0.01306529f, -0.03981782f, 0.04994671f, 0.02910163f, 
    0.01109406f, 0.02751844f, -0.07749220f, 0.01142340f, 0.03303643f, 0.01157485f, 0.04609288f, 0.00382757f, 
    -0.05635258f, -0.05043603f, -0.05754312f, -0.05908774f, -0.01489563f, -0.05000521f, -0.07091510f, 0.02619124f, 
    -0.02431398f, 0.04072588f, 0.05394852f, -0.06100836f, 0.03144465f, 0.00999524f, -0.04975877f, -0.06174193f, 
    0.03074765f, -0.01645631f, 0.00229653f, -0.04517669f, -0.05211091f, -0.06751071f, -0.05801901f, -0.04278045f, 
    0.01452715f, 0.00805307f, 0.04072718f, 0.02988010f, -0.01186572f, 0.00044730f, 0.02060177f, -0.07789237f, 
    0.02354566f, -0.01144074f, -0.07575154f, 0.02287268f, 0.03784970f, -0.03097161f, -0.01315292f, 0.00253593f, 
    -0.01970903f, -0.06942020f, -0.00639511f, -0.04878129f, -0.03363044f, -0.05979319f, -0.01917574f, -0.04800071f, 
    -0.04875911f, 0.01156617f, 0.04451996f, -0.04924013f, 0.03755610f, 0.03210353f, -0.04866849f, 0.00524084f, 
    -0.02163008f, -0.02671117f, -0.07496829f, 0.00663324f, -0.03509681f, -0.03087897f, 0.03541164f, 0.01881637f, 
    -0.00502515f, -0.04336868f, -0.07892334f, -0.00323548f, -0.03799898f, -0.07049902f, -0.03975208f, 0.00330502f, 
    -0.00296972f, 0.03414457f, 0.04466617f, 0.06267832f, 0.00743542f, -0.06119956f, 0.06048839f, -0.00225436f, 
    0.03035130f, 0.04686888f, -0.06240292f, 0.05978907f, -0.05257595f, 0.00842904f, -0.05431392f, -0.00028246f, 
    0.42655972f, 0.21444778f, 0.09261362f, -0.09429784f, 0.09125247f, -0.10686339f, -0.00830125f, 0.02328921f, 
    0.06234645f, -0.05044473f, 0.02851505f, -0.11552488f, 0.03384787f, 0.21696198f, 0.01088411f, -0.03904825f, 
    0.03085700f, 0.04856012f, -0.05908474f, 0.01653581f, -0.17682268f, -0.05996926f, 0.04573731f, 0.07883538f, 
    -0.49599472f, -0.20460747f, 0.15422499f, 0.18521629f, -0.03894018f, 0.13598844f, 0.02885546f, 0.00500663f, 
    -0.02275257f, -0.10504495f, 0.05539637f, 0.14754155f, 0.00094942f, 0.02984693f, -0.16344564f, -0.06970589f, 
    0.05176132f, 0.06174122f, 0.17446262f, -0.05618929f, -0.12331785f, 0.01274807f, -0.16297996f, -0.03424998f, 
    0.18581231f, 0.06775580f, -0.13965164f, 0.04145977f, 0.10428568f, -0.07966767f, -0.02254157f, -0.09153093f, 
    -0.04459449f, 0.00476492f, 0.08581070f, 0.01208661f, -0.07059992f, 0.16688927f, 0.09346745f, 0.00873474f, 
    0.12548748f, 0.03767540f, -0.07176922f, -0.06934951f, 0.00007252f, -0.06532425f, 0.02371006f, -0.03395251f, 
    0.02802476f, 0.01986885f, 0.05534036f, -0.11609539f, 0.04798583f, -0.04898483f, 0.05631321f, 0.11454163f, 
    -0.14334127f, 0.03339594f, 0.00649793f, -0.04711147f, 0.34437254f, 0.29175663f, -0.02600341f, -0.09589840f, 
    0.07374961f, -0.03607711f, -0.01944604f, 0.05441115f, 0.02917686f, -0.01722381f, 0.06986231f, -0.14943036f, 
    -0.05866009f, 0.17833097f, 0.01810468f, -0.02276926f, 0.05862658f, 0.05595949f, -0.11780939f, -0.02590271f, 
    -0.06335151f, 0.07492044f, -0.13605632f, 0.06314489f, 0.41152957f, -0.08190428f, -0.07356419f, 0.01125393f, 
    0.10161825f, 0.06210283f, -0.05760424f, -0.01364609f, 0.13766181f, 0.01644585f, -0.05983721f, -0.09945801f, 
    0.16363336f, -0.07306304f, 0.04474456f, 0.25851062f, -0.01528967f, 0.09050350f, -0.03078247f, -0.07085221f, 
    -0.03204302f, 0.16324498f, -0.06349191f, -0.10541301f, 0.25161019f, 0.09214780f, -0.14866458f, -0.17845546f, 
    0.13993700f, -0.11902530f, 0.06962811f, -0.11357649f, 0.03471551f, 0.04042044f, 0.08189305f, -0.02337139f, 
    0.29491740f, -0.08381570f, -0.16524513f, 0.11463972f, 0.03448704f, 0.10729490f, -0.08278697f, -0.11006434f, 
    -0.13391428f, -0.02381284f, -0.10013692f, -0.06056502f, 0.42905176f, -0.07369090f, -0.01152014f, 0.28965375f, 
    -0.02578910f, 0.00104622f, 0.04366523f, -0.02009907f, -0.00562057f, -0.00388483f, -0.01705131f, -0.08581980f, 
    -0.18785898f, -0.09881514f, -0.08316806f, -0.28103811f, 0.02763236f, -0.07360504f, 0.02649618f, 0.07361461f, 
    0.01090586f, 0.04378317f, -0.07825326f, -0.10077859f, 0.27469701f, 0.10640609f, -0.12486617f, -0.03002304f, 
    -0.03454642f, 0.15082905f, 0.07567276f, 0.01410984f, -0.05545542f, 0.08992932f, 0.02045088f, -0.13469638f, 
    -0.23058881f, 0.12176201f, 0.25755119f, 0.19580099f, 0.11068007f, -0.09161254f, 0.02775759f, 0.03687651f, 
    0.16180958f, -0.03336591f, 0.07106113f, -0.10756836f, -0.05390033f, -0.19298682f, 0.05115459f, 0.10441620f, 
    0.20153663f, 0.08757836f, -0.09112978f, 0.00915004f, 0.01103026f, -0.02842120f, -0.02617255f, 0.03563808f, 
    0.39291304f, -0.00281605f, 0.26155695f, 0.18669039f, 0.07116672f, 0.02134817f, 0.06754825f, -0.06555740f, 
    0.06843659f, 0.04445528f, -0.03627336f, 0.01450047f, -0.03608872f, -0.03562345f, -0.18485050f, -0.08091056f, 
    -0.06255988f, 0.00205533f, -0.13720940f, -0.05988972f, -0.01565010f, -0.01735888f, 0.03559785f, -0.00575230f, 
    0.03416238f, -0.12606880f, -0.18542469f, 0.13361709f, -0.01826273f, -0.01219925f, 0.02622072f, 0.06125342f, 
    -0.00605318f, 0.07004707f, -0.11384632f, -0.01973900f, -0.43793193f, 0.17670408f, -0.12774082f, -0.14595604f, 
    0.08491570f, -0.00119083f, 0.02504007f, 0.01514662f, -0.01517042f, 0.09095308f, 0.05495179f, 0.05643479f, 
    0.31333718f, 0.08039928f, -0.13622893f, -0.15367213f, -0.08055139f, 0.13769174f, 0.06438876f, -0.11369350f, 
    0.11814092f, -0.07407647f, -0.01388244f, 0.07361364f, -0.06476118f, 0.09001782f, -0.10078835f, -0.00361268f, 
    -0.07696917f, 0.16892061f, -0.01390572f, -0.05696652f, 0.03983119f, 0.12979048f, -0.11075424f, 0.18150705f, 
    -0.12657736f, -0.07610832f, 0.00406080f, -0.16723302f, 0.06482314f, 0.07662150f, 0.08956455f, -0.06792586f, 
    -0.08763733f, 0.03013620f, 0.04460807f, -0.13771592f, 0.29341814f, 0.00136564f, 0.08782267f, 0.14316709f, 
    0.14658843f, 0.10418725f, 0.02709089f, -0.00471143f, 0.09723379f, 0.08820406f, 0.08902209f, 0.07056932f, 
    0.08578628f, -0.08619168f, -0.09450519f, -0.04605194f, -0.05026896f, -0.07724982f, 0.04567343f, 0.05548044f, 
    -0.00189587f, 0.02770281f, 0.05694466f, -0.17309275f, 0.01834706f, 0.24305531f, -0.02854139f, -0.13792579f, 
    -0.05082114f, 0.07266839f, -0.14047515f, 0.11345212f, -0.18580194f, -0.12502290f, -0.03134353f, -0.03714294f, 
    -0.29301596f, 0.01445448f, 0.05085333f, -0.18891698f, 0.10913325f, -0.11329986f, -0.16783455f, 0.01983280f, 
    -0.08838981f, 0.09322204f, 0.02514133f, -0.01192506f, -0.18642697f, 0.09428488f, -0.23897751f, -0.08652796f, 
    0.00793724f, 0.02868937f, -0.00137587f, 0.02207366f, -0.09289825f, 0.11149642f, -0.03979062f, 0.02696465f, 
    -0.11677010f, 0.16159402f, 0.08327945f, 0.04607946f, 0.05049359f, -0.01476380f, -0.12918660f, -0.04075962f, 
    -0.03569720f, 0.02952864f, -0.06396807f, 0.01699884f, 0.08161729f, 0.02539201f, -0.07271843f, -0.11443264f, 
    0.05447589f, -0.16739668f, -0.02692794f, -0.10186683f, -0.04046742f, 0.03729128f, 0.08888631f, 0.02681642f, 
    0.20738843f, -0.13440137f, -0.07294736f, 0.01772897f, -0.01139206f, 0.14310671f, 0.11908185f, 0.09093475f, 
    -0.12727162f, 0.19133249f, -0.10772914f, 0.16751073f, 0.21825400f, 0.04714117f, 0.23031749f, 0.03930469f, 
    -0.07631466f, 0.06524112f, -0.08809320f, -0.04781850f, 0.06781774f, 0.13423888f, -0.01344276f, -0.11147816f, 
    -0.08527135f, -0.16664037f, 0.08980758f, 0.17074013f, 0.04991622f, 0.00924037f, 0.06329632f, 0.01144073f, 
    -0.16647616f, 0.07369423f, 0.01027636f, 0.05451707f, -0.04218584f, -0.05074405f, 0.13194528f, 0.18803574f, 
    0.06922407f, -0.05511638f, 0.04666169f, -0.01033081f, -0.00696110f, -0.11870942f, 0.09390491f, 0.06642344f, 
    0.17011325f, 0.02017660f, 0.16312702f, 0.03824684f, -0.05898781f, -0.04990667f, -0.04076542f, 0.33565605f, 
    -0.03721369f, -0.12297312f, -0.14512047f, 0.10906116f, -0.01048957f, 0.05805338f, -0.08049026f, -0.06590538f, 
    -0.01382550f, -0.04124770f, -0.05153326f, -0.11033256f, -0.10109862f, -0.05043947f, 0.14154854f, 0.12621303f, 
    -0.06114912f, 0.29658493f, -0.07223777f, -0.08823387f, 0.21795988f, -0.08082423f, -0.14671579f, -0.08414827f, 
    0.09743516f, -0.01351077f, 0.05601869f, -0.11480407f, 0.03372042f, -0.24202292f, -0.04195522f, -0.00948910f, 
    0.01405113f, -0.06292149f, -0.13891198f, -0.02250514f, 0.09251257f, 0.01983604f, -0.17148805f, -0.01735877f, 
    0.42048147f, 0.22315364f, 0.23976432f, -0.01025299f, -0.20672868f, -0.02308873f, 0.03553637f, 0.07679191f, 
    -0.07997897f, 0.01415950f, 0.00670845f, -0.05920236f, -0.16348390f, -0.27290493f, -0.00565186f, 0.01535598f, 
    0.20658787f, 0.05568390f, -0.08252427f, -0.15660271f, 0.04642097f, -0.17666702f, -0.16023035f, -0.01322223f, 
    0.23410648f, 0.12111104f, 0.28850508f, 0.31634301f, -0.29147679f, 0.08609641f, -0.19568451f, -0.00570799f, 
    -0.28705996f, -0.12992248f, -0.14120042f, 0.11183769f, -0.07791372f, -0.16544685f, -0.03106469f, 0.01658933f, 
    0.04389342f, -0.02579849f, -0.06571231f, 0.08358905f, -0.01486812f, -0.07871764f, 0.09409111f, 0.10337517f, 
    -0.18728128f, -0.18397175f, -0.01617574f, -0.20687401f, 0.11905378f, -0.15166508f, 0.12077331f, 0.00435148f, 
    0.08105892f, -0.15729405f, -0.07501673f, -0.09165039f, 0.42991608f, -0.11858372f, 0.27020746f, 0.06277989f, 
    -0.08507334f, 0.22341822f, -0.11198203f, 0.05326911f, -0.11484113f, 0.13971350f, -0.07094301f, 0.10440478f, 
    -0.05943957f, 0.06327591f, 0.23855701f, 0.03122893f, -0.05969301f, 0.09940192f, 0.03954555f, 0.22844149f, 
    -0.06550071f, 0.08215514f, 0.02466045f, 0.13182662f, -0.28704220f, -0.16550350f, -0.13097949f, -0.07813598f, 
    0.02081098f, 0.01353337f, 0.09719829f, 0.00027649f, 0.03685854f, -0.07252954f, -0.08813952f, -0.10561754f, 
    0.03982385f, -0.04881394f, 0.03600982f, -0.03189782f, 0.03797384f, 0.01770696f, 0.03859088f, 0.01553146f, 
    0.06210478f, -0.02282525f, 0.02574273f, -0.00849673f, -0.04489264f, -0.05906826f, 0.00324026f, -0.06406626f, 
    -0.03048502f, -0.04869731f, -0.04715334f, -0.05494062f, -0.00072902f, -0.06150182f, 0.05088131f, 0.02446614f, 
    -0.00540632f, -0.05019129f, 0.05029120f, 0.02848981f, 0.04309124f, -0.01968094f, -0.03980479f, -0.05641678f, 
    -0.04694935f, -0.08070028f, 0.04105685f, 0.00917992f, -0.05109324f, -0.00830922f, -0.05373867f, 0.05020893f, 
    -0.01039820f, 0.05536531f, -0.02475590f, -0.07472025f, -0.06372401f, 0.03904616f, -0.01311591f, 0.04472978f, 
    -0.03421063f, 0.03111370f, -0.02167320f, -0.02642270f, 0.02677372f, -0.02286163f, 0.03901843f, 0.04813148f, 
    -0.02463241f, 0.02751856f, 0.03628381f, 0.04432254f, -0.01658074f, 0.05231526f, 0.04753463f, 0.01459817f, 
    0.04104813f, 0.04927257f, -0.03375600f, -0.06805745f, 0.02388096f, 0.04412311f, 0.02152781f, 0.01782235f, 
    -0.03005037f, -0.05263637f, 0.00348525f, -0.07228841f, -0.08619687f, -0.06436960f, 0.05430685f, -0.01164420f, 
    0.00241424f, -0.02154253f, -0.01952984f, 0.01205471f, 0.06305586f, -0.06385860f, -0.05132773f, 0.01428120f, 
    -0.06003901f, -0.05056714f, -0.05214675f, 0.03943966f, -0.06152974f, -0.02607003f, -0.03259104f, 0.06406429f, 
    -0.00070000f, -0.02776888f, -0.07002388f, 0.05084909f, -0.05489497f, 0.04774620f, -0.00396723f, -0.01868412f, 
    0.01991243f, 0.05887422f, 0.01391007f, -0.04918205f, -0.06669213f, 0.03316044f, -0.01095242f, 0.01100138f, 
    -0.02684572f, -0.00025067f, 0.02875803f, -0.04742493f, -0.04895104f, -0.00152974f, -0.00939537f, -0.01028144f, 
    -0.08305716f, -0.04547219f, 0.03777643f, -0.00952871f, 0.03172286f, -0.07462964f, -0.05263984f, -0.05973421f, 
    -0.07172395f, 0.04149761f, -0.01034240f, 0.01314314f, -0.03204819f, 0.05255142f, 0.06071949f, -0.03004799f, 
    -0.08275049f, 0.00711267f, -0.05735344f, -0.05305235f, -0.01117385f, -0.06361286f, 0.01797205f, 0.04967348f, 
    -0.04788517f, -0.00943288f, -0.03784846f, -0.02793609f, 0.01071728f, -0.01703979f, -0.02148530f, -0.02942660f, 
    0.00015738f, 0.04401829f, -0.01024693f, -0.08001605f, 0.04582550f, -0.06785803f, -0.04273449f, 0.02860766f, 
    -0.05816826f, -0.05128216f, 0.01313679f, 0.03590093f, -0.06508704f, -0.00997361f, -0.01377826f, -0.00145086f, 
    -0.05514019f, 0.05010644f, 0.00734316f, -0.00397194f, -0.05989611f, -0.02850282f, 0.04145974f, -0.06842025f, 
    -0.02609872f, 0.01439809f, 0.01301902f, -0.01244066f, 0.04761553f, 0.01857827f, -0.05270560f, -0.06190744f, 
    -0.07301768f, -0.06683260f, -0.06867436f, -0.01942979f, -0.02728902f, 0.06345176f, -0.03870386f, -0.04137425f, 
    -0.08750445f, -0.18540141f, -0.10143945f, -0.28118291f, -0.00459806f, -0.01545599f, 0.01719526f, 0.01533580f, 
    -0.10158767f, -0.07163863f, -0.00828130f, -0.09481443f, 0.08353446f, 0.05363346f, -0.04782715f, -0.10013813f, 
    -0.09507754f, -0.05349907f, 0.16697855f, -0.02483715f, 0.06864162f, 0.00091917f, 0.01861777f, 0.09959900f, 
    -0.22222322f, -0.03109916f, -0.27223605f, -0.09748064f, -0.18939222f, 0.00458914f, -0.16244256f, 0.09975010f, 
    0.06936260f, -0.09151113f, -0.04929921f, -0.22517112f, 0.24124366f, -0.03229642f, 0.00642728f, 0.00621194f, 
    -0.01925829f, -0.06785191f, -0.04478234f, 0.05073551f, -0.08286609f, 0.21331435f, 0.09709562f, 0.09935166f, 
    0.05393432f, -0.02255648f, -0.04306784f, 0.06046216f, 0.03176759f, 0.02644267f, -0.08908952f, -0.10273957f, 
    0.01331371f, -0.20586675f, -0.07589440f, -0.07820382f, 0.07544108f, -0.33935872f, 0.02994286f, 0.09067941f, 
    0.07160430f, -0.10303093f, -0.08665457f, 0.04625310f, 0.02525025f, -0.02670195f, 0.00423597f, 0.01541938f, 
    0.03333262f, 0.26147008f, 0.01323419f, 0.16428602f, -0.09510316f, -0.14218159f, -0.05245113f, 0.15332636f, 
    -0.04021546f, -0.13963801f, 0.02418231f, -0.17360394f, 0.08415184f, -0.18810479f, -0.10222158f, 0.01538723f, 
    -0.05645181f, -0.05172064f, -0.14446726f, -0.14946003f, -0.05268815f, -0.07829751f, 0.08913779f, -0.01655735f, 
    0.17366222f, 0.03580947f, 0.14184241f, 0.20064022f, -0.06739934f, -0.06799070f, -0.14801365f, 0.06725988f, 
    0.01818632f, 0.02307521f, -0.05489840f, -0.03229815f, -0.09843182f, 0.13734417f, 0.00131288f, -0.20775741f, 
    0.04928497f, -0.08446879f, 0.03037856f, 0.07987607f, -0.00923589f, -0.04856058f, -0.07326876f, -0.00095788f, 
    0.20859791f, 0.01168480f, 0.00209121f, 0.13681950f, 0.03554544f, -0.09534533f, -0.05154457f, -0.03283601f, 
    -0.03633187f, 0.03202159f, -0.03052497f, -0.02443810f, -0.19320865f, -0.29431266f, -0.08518036f, 0.11981429f, 
    0.01438912f, -0.00073786f, 0.01808270f, -0.17864197f, 0.02834347f, 0.06155965f, -0.10445283f, 0.02804772f, 
    -0.19918980f, -0.25900224f, -0.15328932f, 0.19021437f, 0.06552874f, 0.00888737f, 0.08238021f, -0.04916643f, 
    0.00902285f, 0.03162286f, 0.06062344f, -0.01001952f, 0.34070095f, -0.03553322f, 0.17122313f, 0.32979092f, 
    -0.14313507f, -0.10964184f, -0.06083501f, 0.02399244f, 0.03867095f, -0.02197719f, -0.05318576f, -0.09833660f, 
    -0.04351966f, -0.07764534f, -0.25647256f, -0.11652428f, 0.10193182f, -0.01012692f, 0.05844112f, 0.04799904f, 
    0.11219285f, -0.11403182f, 0.06665049f, -0.00367501f, -0.01243914f, -0.15925689f, -0.06163918f, -0.06523138f, 
    0.02531901f, 0.10773967f, 0.12447035f, 0.11178017f, -0.06713699f, -0.05311108f, -0.13698916f, -0.05062976f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.00672199f, 0.01578668f, 0.00342153f, 0.00584986f, 0.01338999f, -0.03353706f, -0.05819237f, 0.02449124f, 
    0.03415443f, 0.00951452f, 0.04514373f, 0.01052704f, -0.03579406f, 0.07813106f, 0.01237920f, 0.01307882f, 
    0.09570446f, -0.09513974f, 0.04740299f, 0.02440502f, 0.01909861f, 0.01325285f, 0.00703676f, 0.06428503f, 
    -0.11015551f, 0.04720202f, 0.03163152f, -0.01371706f, 0.19276242f, -0.03318408f, 0.01105619f, -0.01377382f, 
    0.02756254f, 0.05536647f, -0.06946211f, 0.13035546f, 0.04895732f, 0.16946231f, 0.03558842f, 0.01122476f, 
    0.06070220f, 0.07150250f, -0.06110945f, -0.05950623f, 0.11816480f, 0.06085668f, -0.08356855f, 0.10853662f, 
    -0.07875551f, -0.01574935f, -0.01095515f, -0.02451799f, -0.01387646f, -0.01348963f, 0.01700500f, -0.02894889f, 
    0.03012031f, -0.00332934f, 0.05048016f, -0.02695918f, -0.07724746f, -0.04151889f, 0.05405527f, -0.01732462f, 
    -0.05279407f, -0.01659253f, -0.06885257f, -0.08379544f, -0.00483728f, 0.01832321f, 0.22653048f, 0.08285537f, 
    0.02679224f, 0.07571903f, -0.02663846f, 0.06917799f, -0.01266678f, 0.00271130f, -0.08334392f, 0.04374684f, 
    0.15191059f, -0.08207271f, 0.02397089f, 0.07503877f, 0.05892718f, 0.11051247f, -0.01918533f, 0.01399503f, 
    0.00585364f, 0.04358518f, -0.03572964f, -0.14846246f, -0.00924584f, 0.04599069f, 0.09494199f, 0.07305508f, 
    0.02070880f, -0.05501930f, 0.04621350f, 0.00960125f, -0.03789014f, 0.14684616f, -0.00792179f, 0.01677974f, 
    -0.02090530f, -0.01046486f, -0.01075990f, 0.02406378f, 0.11442858f, -0.00239044f, -0.00551905f, -0.08300572f, 
    -0.03557803f, 0.17068225f, 0.16564681f, -0.00342621f, -0.03443297f, 0.16650961f, -0.02901961f, -0.04251733f, 
    0.06798261f, 0.03989559f, -0.01821654f, 0.01865181f, -0.03047030f, -0.00550362f, -0.03111237f, 0.04113745f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.05641745f, -0.02628157f, -0.34946641f, -0.18010183f, 0.00968503f, -0.04109444f, 0.05622613f, -0.06184396f, 
    0.05597337f, -0.19550779f, 0.00265708f, -0.01050491f, -0.06944750f, -0.35520560f, 0.16087839f, 0.06005371f, 
    -0.14701204f, -0.08339498f, -0.42026532f, -0.03718310f, -0.02857746f, 0.19153342f, -0.04274601f, -0.03762878f, 
    0.23327377f, -0.43147427f, -0.00494087f, 0.30107269f, -0.20273507f, 0.24334863f, 0.10472186f, 0.12383511f, 
    -0.10156905f, -0.28286934f, 0.00824397f, 0.06924339f, -0.03467412f, -0.07752036f, 0.19318229f, -0.06275842f, 
    -0.32148674f, 0.13951984f, 0.23900260f, 0.04221774f, 0.21078062f, -0.27495462f, -0.22693616f, -0.03155246f, 
    -0.06352207f, -0.00403863f, -0.10007641f, 0.11947017f, 0.03585833f, -0.48854223f, 0.14643617f, 0.23665018f, 
    0.03068604f, 0.00321623f, -0.29928795f, 0.00416463f, 0.28215867f, 0.18490024f, -0.34483981f, 0.02486588f, 
    -0.00517125f, -0.02645379f, 0.07182825f, 0.15356973f, 0.07565694f, -0.01339022f, -0.21131313f, -0.20186244f, 
    0.06242338f, 0.13202888f, 0.01781782f, -0.29893765f, -0.42147911f, 0.01248493f, 0.11473268f, -0.01336826f, 
    -0.43682340f, 0.06898864f, 0.06986978f, 0.04799591f, 0.03377978f, -0.28826493f, 0.02255242f, -0.07302883f, 
    -0.05791886f, -0.03056393f, -0.00976090f, 0.11529419f, -0.51272076f, -0.14777547f, -0.31720150f, -0.06561865f, 
    0.04090560f, 0.57224059f, -0.03868144f, 0.06672352f, -0.13413535f, -0.07983628f, 0.18207823f, 0.09843975f, 
    0.04904278f, 0.06087498f, -0.15497303f, 0.04578077f, -0.18639469f, 0.06594070f, -0.04263535f, 0.12517561f, 
    -0.23330668f, -0.03492212f, -0.31042117f, -0.14906418f, 0.00004482f, -0.14348462f, 0.37217829f, 0.23701635f, 
    0.21485290f, 0.04454062f, -0.01113097f, -0.08066510f, 0.18077107f, -0.25905308f, 0.04707345f, -0.13589393f, 
    -0.00639243f, -0.05114435f, -0.25332239f, 0.08962587f, 0.14958245f, -0.00209659f, 0.04084301f, -0.01366333f, 
    0.01336407f, -0.31281391f, -0.10557824f, -0.27168959f, -0.03215868f, -0.23331143f, -0.04830288f, 0.13024047f, 
    -0.01952491f, 0.09948768f, 0.00548817f, 0.05953866f, 0.24375771f, 0.12827194f, 0.07521859f, -0.03656551f, 
    -0.17358983f, -0.21609168f, 0.21269509f, -0.54267275f, 0.09334127f, -0.48793402f, -0.16885340f, 0.19817203f, 
    -0.09243613f, -0.21403138f, -0.07082976f, 0.04272895f, -0.20144314f, 0.21271244f, 0.19611032f, -0.04951414f, 
    0.08475296f, 0.18145888f, 0.00252618f, -0.07878061f, 0.17904389f, -0.01319678f, 0.33448997f, 0.05951522f, 
    -0.05699176f, -0.26725924f, -0.18662818f, -0.10721961f, -0.00105389f, -0.27195570f, 0.08518519f, 0.10497981f, 
    -0.02207696f, -0.03789145f, -0.06276705f, -0.06876612f, 0.02974864f, -0.15128429f, -0.06753825f, -0.02637920f, 
    0.06099657f, 0.03354910f, 0.07530553f, -0.04035142f, 0.08722202f, -0.27385852f, -0.09751904f, -0.12115420f, 
    0.00261131f, 0.09842667f, 0.06581962f, -0.15072475f, 0.03841561f, -0.07564020f, -0.16181473f, -0.04199981f, 
    0.13283478f, 0.00610497f, 0.07982822f, 0.19532512f, 0.03454493f, 0.09899787f, 0.26902786f, -0.00413636f, 
    -0.03404238f, 0.04796179f, 0.15332340f, 0.00261268f, 0.09759158f, 0.06032233f, -0.21137087f, 0.02242349f, 
    0.12958515f, -0.07978047f, 0.06336991f, -0.05434401f, 0.02580539f, 0.07452549f, 0.19915760f, 0.22586091f, 
    -0.06444512f, 0.00031331f, -0.01115474f, 0.00310547f, 0.12674510f, 0.03125856f, 0.04767534f, 0.25012383f, 
    -0.22967242f, -0.06091541f, 0.30109933f, -0.35375085f, -0.07263117f, 0.17454205f, -0.61526775f, 0.06654614f, 
    0.23329890f, 0.04192460f, 0.00412134f, 0.15769571f, -0.42447594f, 0.47378400f, -0.02543839f, 0.06943565f, 
    0.07675754f, -0.02808432f, 0.21056445f, -0.02059211f, 0.23661232f, 0.08767610f, 0.01114582f, 0.04933625f, 
    -0.12757424f, 0.20306636f, 0.02692416f, -0.02787977f, -0.06245528f, 0.09153438f, -0.16680141f, 0.13122870f, 
    0.16119218f, -0.35262942f, 0.33053285f, -0.05974998f, -0.08627329f, 0.17488427f, -0.25279170f, 0.02807422f, 
    -0.09492980f, 0.23848641f, -0.26568434f, -0.07155805f, -0.09679403f, -0.12996149f, -0.30590001f, 0.05481056f, 
    0.11141832f, -0.32743222f, 0.04995707f, -0.20306435f, 0.39073980f, 0.02144407f, -0.39643350f, -0.08722525f, 
    -0.26927412f, 0.03963108f, -0.14684190f, -0.01182905f, 0.08720811f, 0.27269351f, 0.27511874f, 0.25289693f, 
    0.07642946f, -0.03164898f, 0.23647328f, -0.37792808f, -0.02053539f, -0.23305082f, 0.10770421f, 0.16850786f, 
    -0.01750097f, 0.01592330f, -0.01617131f, -0.06533840f, -0.47239488f, 0.18021807f, -0.33689761f, -0.00076303f, 
    0.00369421f, 0.02733987f, -0.06845710f, 0.31270856f, -0.29177535f, -0.38805723f, 0.12794641f, -0.37170231f, 
    -0.00881067f, -0.43159771f, 0.07503054f, -0.09303030f, 0.25374514f, -0.05138224f, -0.44469646f, -0.07277863f, 
    0.04255414f, -0.33267522f, 0.00016518f, -0.00887010f, -0.04092921f, -0.48776117f, 0.19742383f, 0.02969132f, 
    0.06892762f, 0.06165089f, 0.19556788f, 0.13390429f, 0.23377037f, 0.11714965f, -0.02568554f, -0.10098857f, 
    -0.18426092f, -0.25279635f, -0.07254634f, -0.37069067f, 0.32974786f, 0.08905459f, -0.02387051f, 0.16901407f, 
    0.09483779f, 0.04412287f, 0.14101492f, -0.16988465f, -0.39733502f, -0.54060876f, -0.04461817f, 0.12455860f, 
    -0.10620660f, -0.46930131f, 0.00549164f, -0.01653888f, 0.01852130f, 0.10533489f, 0.37305817f, -0.06570836f, 
    -0.19261789f, 0.00163556f, 0.03815892f, 0.22511947f, 0.09813423f, -0.62185210f, 0.05979190f, 0.18407625f, 
    -0.00942618f, 0.07415886f, -0.10799192f, -0.31747708f, -0.00719319f, -0.36299515f, 0.00424982f, 0.05565918f, 
    -0.28460211f, -0.34480214f, -0.24606654f, 0.07481460f, -0.02845617f, -0.04558173f, -0.39067358f, -0.33525336f, 
    0.06264995f, 0.08481584f, -0.48307052f, 0.04463005f, 0.03748451f, -0.51297402f, 0.11011212f, -0.60742503f, 
    0.08912462f, -0.21325466f, 0.17469516f, 0.09163634f, 0.10638368f, 0.34466425f, 0.18687931f, -0.06011398f, 
    -0.21795738f, 0.29173473f, -0.02159305f, -0.25265831f, -0.13912229f, 0.10701628f, 0.20333609f, 0.02926063f, 
    -0.00491540f, -0.01195914f, 0.05611619f, -0.07538000f, -0.05020408f, 0.15166131f, 0.38669389f, -0.11680766f, 
    0.03591226f, -0.04405899f, -0.01893789f, -0.12013112f, 0.04865105f, 0.00074105f, -0.14305517f, -0.13622177f, 
    -0.00597677f, -0.03118715f, -0.15980639f, -0.01673647f, 0.10418246f, 0.08798297f, 0.17454757f, 0.08381116f, 
    -0.02904860f, 0.01890798f, -0.05518249f, 0.26185092f, -0.12283367f, 0.26302418f, -0.25943309f, 0.12278218f, 
    0.02940174f, -0.54344028f, -0.08637919f, 0.21932645f, 0.12054946f, -0.02646623f, 0.11220767f, 0.06919925f, 
    0.19699514f, -0.04696464f, 0.07858285f, -0.08675499f, -0.07349094f, 0.15670295f, 0.09113564f, 0.03336990f, 
    0.05359263f, 0.07244454f, 0.22119811f, -0.22268170f, -0.09251638f, -0.26817092f, 0.09712089f, 0.20018896f, 
    0.33647665f, -0.35243210f, -0.07465476f, 0.06015241f, 0.19637002f, -0.29830852f, -0.42124051f, -0.65975267f, 
    0.23829520f, 0.06935637f, -0.41128922f, 0.04127676f, 0.13285345f, 0.01210871f, 0.02734953f, -0.19739805f, 
    0.22212744f, -0.16973615f, 0.02009830f, -0.00050563f, -0.04298559f, 0.16364907f, 0.01082590f, -0.60932392f, 
    -0.05011418f, 0.03649236f, -0.01932338f, -0.06999280f, -0.13183135f, 0.06480725f, -0.04973649f, 0.07600330f, 
    -0.08732718f, 0.03398331f, 0.09044304f, 0.11642813f, 0.16001914f, 0.20086813f, 0.02783551f, 0.05575718f, 
    -0.07857463f, 0.04290746f, 0.06140161f, 0.11448012f, -0.09207872f, 0.29609168f, 0.12169559f, -0.24899407f, 
    -0.01406505f, 0.07565021f, -0.07433360f, 0.09283951f, 0.13356036f, -0.24400814f, -0.08080973f, -0.26851693f, 
    -0.00480949f, 0.16054837f, 0.00897322f, 0.09161311f, 0.17249596f, 0.07877803f, -0.13809587f, 0.01852532f, 
    -0.06543733f, -0.27225009f, -0.06848472f, 0.19154808f, -0.47888842f, -0.14300981f, 0.04041526f, -0.01591710f, 
    0.34889996f, -0.02136318f, -0.26589850f, 0.00726718f, -0.18977965f, 0.28146234f, -0.00114573f, -0.48275688f, 
    -0.07399710f, 0.14951582f, -0.09234649f, -0.10698540f, 0.02149012f, 0.11871552f, 0.02509512f, -0.12705758f, 
    0.06330846f, 0.01103622f, -0.31395110f, -0.06299587f, 0.08332226f, -0.10166370f, 0.31505617f, 0.05017150f, 
    -0.02080619f, -0.07293171f, -0.02539161f, 0.20650719f, 0.11038784f, 0.08321431f, -0.01403112f, 0.06788350f, 
    -0.05006306f, 0.28054097f, -0.08637232f, -0.03942295f, -0.07498318f, -0.06330895f, 0.15400541f, -0.01338826f, 
    -0.44857788f, 0.15560065f, 0.03440578f, 0.35775778f, -0.00880790f, -0.17494684f, -0.26790023f, 0.01413087f, 
    -0.07141855f, -0.08464269f, 0.07846621f, -0.00801545f, -0.10294146f, -0.28102410f, 0.02817695f, 0.14182034f, 
    -0.22097526f, 0.03153972f, -0.02168385f, 0.03193376f, -0.54745513f, 0.14089216f, -0.01583692f, 0.08985360f, 
    0.23441727f, -0.09339588f, 0.03406931f, 0.07100795f, 0.18367599f, 0.21813282f, -0.08627202f, -0.03992632f, 
    -0.34838438f, 0.02400987f, -0.19934697f, -0.01266354f, 0.06034072f, 0.07630415f, 0.05824453f, -0.09387893f, 
    0.05053145f, -0.00327732f, 0.03544998f, -0.46332556f, -0.21271107f, -0.08798846f, 0.08093656f, -0.00704630f, 
    -0.04683505f, 0.03280273f, -0.27951416f, 0.08690710f, -0.55804044f, 0.24486329f, 0.05835273f, 0.08132418f, 
    0.09368854f, 0.06060635f, -0.04747987f, 0.07977834f, -0.00321713f, -0.09774392f, 0.15542857f, 0.03695567f, 
    -0.19634172f, 0.17031294f, 0.11207964f, -0.03310886f, -0.27987480f, 0.00942540f, -0.07005737f, 0.05072228f, 
    -0.23428932f, -0.23607345f, -0.10629044f, -0.25614202f, -0.13797747f, 0.33339664f, 0.11418139f, 0.16764452f, 
    0.27275327f, 0.19704014f, 0.01834258f, -0.11246876f, 0.26541132f, -0.07282358f, 0.06662339f, -0.02721619f, 
    -0.24526523f, 0.13622242f, -0.15134189f, -0.06811575f, 0.02709031f, -0.41546991f, -0.31755218f, 0.44007659f, 
    0.06459054f, -0.23467186f, -0.34333670f, 0.24214838f, 0.04465371f, -0.06888024f, 0.00549891f, -0.03646925f, 
    -0.09091482f, 0.04690674f, 0.16688929f, -0.07875782f, 0.22765863f, -0.17696542f, 0.13198994f, 0.05861162f, 
    0.07004455f, 0.05208606f, 0.07879139f, -0.44456306f, 0.19904111f, -0.27317926f, 0.12064978f, -0.09679037f, 
    0.07391202f, -0.29709992f, -0.05874966f, -0.01102493f, -0.31426948f, -0.05944165f, 0.01906928f, 0.03005848f, 
    -0.02252492f, 0.14970769f, 0.04195522f, -0.33486637f, 0.03453908f, 0.27808356f, -0.14842196f, -0.00612454f, 
    0.06392897f, 0.08037060f, -0.46322498f, -0.02793639f, -0.06014812f, 0.12695812f, 0.10945414f, -0.04597877f, 
    0.07412033f, -0.25517398f, 0.07574664f, 0.02949306f, -0.11621036f, 0.04724812f, 0.12585978f, -0.00641975f, 
    -0.08109079f, -0.03267947f, -0.10875027f, 0.04503392f, 0.18422954f, 0.05019860f, 0.01509153f, 0.16441496f, 
    -0.17036101f, 0.21813001f, -0.30328351f, 0.19994198f, -0.02201972f, -0.28530934f, 0.03420826f, 0.09317632f, 
    0.21891165f, 0.05870876f, 0.00838793f, -0.03753116f, 0.16951257f, -0.24527290f, -0.03515777f, -0.01267537f, 
    0.02143876f, -0.02450643f, -0.34797043f, 0.04395543f, 0.05169029f, -0.12776349f, 0.01773330f, 0.03298240f, 
    0.01360677f, 0.16333605f, 0.20159514f, 0.18807431f, -0.05884472f, 0.27302879f, 0.15578672f, -0.03346680f, 
    0.07944003f, 0.14677848f, 0.09936282f, 0.00105484f, -0.80624396f, 0.01848782f, 0.14505915f, -0.08672199f, 
    0.18407135f, -0.09887598f, 0.02018660f, -0.07454424f, 0.04834998f, -0.32361072f, -0.35373172f, -0.24844274f, 
    -0.19623585f, 0.10270531f, -0.08498871f, -0.29681388f, -0.45439214f, 0.22707479f, -0.38782707f, 0.02706209f, 
    -0.41511053f, -0.25744203f, -0.07210086f, 0.08879270f, -0.28724644f, 0.03648651f, 0.07294713f, -0.48340049f, 
    -0.08665183f, -0.09964030f, 0.15489507f, 0.24814691f, -0.05006384f, 0.17627075f, 0.03170990f, 0.10432301f, 
    -0.08534089f, -0.02040920f, 0.17156823f, -0.01035307f, -0.18015794f, -0.41283432f, -0.39824101f, 0.00293722f, 
    -0.06961796f, 0.07504329f, 0.03254155f, -0.24900945f, -0.32565430f, 0.20879337f, -0.19914606f, 0.20974781f, 
    0.02251149f, -0.43527678f, -0.00002450f, -0.01131390f, 0.40602374f, 0.04450199f, 0.14589331f, -0.08425105f, 
    0.01981261f, 0.27201054f, -0.08734146f, -0.21351837f, -0.02642655f, -0.32349303f, -0.21603014f, -0.03407752f, 
    -0.03441752f, 0.00843292f, 0.17296387f, -0.20475052f, 0.17955154f, 0.24765389f, 0.29109311f, -0.09750798f, 
    0.12706439f, -0.17772657f, -0.08473258f, -0.01128812f, -0.27173460f, 0.04257037f, -0.20841783f, -0.04614236f, 
    -0.08514006f, -0.07084648f, 0.09387391f, -0.42411959f, -0.14529052f, -0.14391743f, -0.06984801f, -0.08249358f, 
    0.48201972f, 0.10969099f, -0.23598145f, -0.00820794f, -0.00753811f, -0.01612849f, 0.21033339f, 0.20706761f, 
    -0.33124873f, -0.05354762f, -0.00994646f, -0.30554438f, 0.23354916f, 0.10650846f, 0.04777318f, -0.41888681f, 
    -0.07837755f, 0.07373557f, 0.23062018f, -0.06167191f, 0.20228109f, 0.22179271f, 0.03273138f, -0.00200271f, 
    -0.26057971f, 0.25667137f, -0.24715522f, 0.09851401f, -0.08524477f, -0.03411315f, -0.28999928f, 0.02468936f, 
    0.09631525f, 0.11937011f, 0.28247777f, -0.00265046f, 0.25327873f, 0.11745522f, -0.36766595f, 0.11066576f, 
    0.04065435f, -0.08980696f, -0.34989879f, 0.08108869f, -0.27507758f, 0.15784454f, 0.10807719f, -0.01466414f, 
    -0.28216106f, 0.05412564f, -0.01824540f, -0.18584926f, 0.08378165f, -0.37516707f, 0.05513089f, 0.05377231f, 
    0.18807584f, -0.41314062f, 0.09979191f, 0.06328969f, -0.47785658f, 0.04035711f, 0.14162229f, -0.19576021f, 
    -0.04187301f, 0.25667948f, 0.07898138f, -0.09158446f, 0.00976366f, 0.25246149f, -0.35399765f, -0.03634114f, 
    -0.01891292f, 0.05143086f, -0.06079257f, 0.06738528f, 0.06352011f, -0.18210571f, 0.13899572f, 0.06594250f, 
    0.00574376f, -0.07857054f, -0.05263665f, -0.19854347f, 0.00866650f, -0.07796868f, -0.24504347f, -0.24994515f, 
    -0.03922459f, 0.06259663f, 0.05137838f, 0.08225010f, 0.21927157f, -0.03543331f, 0.05627096f, 0.02663261f, 
    -0.03525293f, -0.17323242f, -0.02509980f, 0.04529458f, -0.00157269f, -0.02222701f, -0.32512584f, -0.03920117f, 
    -0.01656628f, 0.06993511f, 0.09476734f, 0.23122169f, -0.05975383f, -0.05379451f, -0.10642909f, -0.28181159f, 
    -0.30840915f, -0.05668600f, -0.10477404f, 0.15661541f, 0.14898635f, -0.25253889f, -0.14718044f, 0.14540449f, 
    -0.29660320f, -0.00314142f, 0.15048139f, -0.30976284f, 0.07609429f, 0.01475564f, -0.05850478f, 0.01063992f, 
    0.24691935f, -0.11213141f, 0.02980884f, 0.15928563f, 0.00940919f, -0.47149223f, -0.14017530f, 0.05682164f, 
    -0.13060668f, 0.05065686f, -0.01821486f, 0.09282054f, -0.01196390f, 0.19832250f, -0.04925122f, 0.08563666f, 
    -0.05150677f, 0.00303436f, -0.12264454f, -0.23541370f, 0.11620436f, 0.02440741f, 0.05739260f, -0.05360774f, 
    0.05123561f, 0.26994434f, -0.27818120f, -0.20478787f, -0.08893024f, -0.05245275f, 0.10885751f, -0.15141512f, 
    0.18269044f, 0.18517089f, -0.10338971f, -0.06258672f, -0.40683198f, 0.22646689f, -0.14195964f, 0.31987885f, 
    0.12733781f, 0.16846520f, 0.17096283f, -0.36811572f, -0.43827870f, 0.03143542f, 0.19422336f, -0.26338103f, 
    0.06123134f, 0.18038005f, -0.09956633f, -0.19883916f, 0.03187519f, -0.49413475f, -0.36012012f, -0.08444007f, 
    -0.24980065f, 0.12611856f, -0.20204131f, -0.02293037f, -0.21433514f, -0.09417757f, -0.01448390f, -0.25566316f, 
    0.06314027f, -0.14432292f, -0.23052773f, -0.10795245f, 0.08066425f, 0.02740223f, 0.03151330f, -0.43126893f, 
    -0.06080373f, -0.00346025f, 0.12131318f, -0.07279274f, -0.03628883f, 0.12812489f, -0.12976019f, 0.05063649f, 
    0.03155832f, 0.01014095f, 0.05060674f, 0.07867432f, 0.28665879f, 0.09418280f, 0.04677744f, 0.11495878f, 
    0.00194673f, 0.43232733f, 0.00229034f, -0.21184227f, -0.32791883f, -0.06996088f, -0.15640172f, 0.00943439f, 
    0.02629488f, 0.09470663f, -0.09339712f, -0.07189686f, 0.08091098f, 0.17917202f, -0.07393076f, 0.07022491f, 
    -0.02725502f, -0.03638610f, 0.12865755f, -0.05366722f, 0.01551889f, 0.05201413f, -0.27432275f, 0.28965199f, 
    -0.02961855f, -0.05654865f, -0.07323200f, -0.19109215f, 0.19344239f, -0.21912199f, 0.10188895f, 0.09944733f, 
    -0.11575090f, -0.01159284f, -0.14601849f, 0.31747949f, -0.19783641f, -0.02866899f, 0.04683447f, -0.23662415f, 
    0.16681324f, -0.06230879f, 0.25520724f, -0.25701910f, -0.08644027f, -0.19226158f, 0.23678555f, -0.20468196f, 
    -0.26970634f, 0.03927731f, 0.06102597f, 0.17018284f, 0.05300102f, -0.18421645f, -0.05417003f, 0.09696636f, 
    -0.07697127f, -0.02806324f, 0.21211579f, 0.14573655f, -0.18802807f, -0.05405312f, -0.04698358f, -0.04984238f, 
    0.08011778f, 0.13259271f, 0.14404629f, 0.18601912f, 0.06864215f, 0.06993420f, 0.10925119f, 0.28556338f, 
    0.17153049f, -0.34740990f, 0.18590274f, 0.02985647f, 0.06483584f, -0.29224616f, 0.15275764f, 0.07877713f, 
    0.20442021f, 0.15986679f, -0.26989788f, 0.06085382f, 0.19540833f, -0.09691683f, -0.11723791f, -0.03416387f, 
    0.18602178f, 0.28994641f, -0.03676838f, 0.24498932f, 0.03350188f, -0.05601468f, -0.26441094f, 0.07181604f, 
    -0.23008822f, -0.26849917f, -0.30914715f, 0.01320745f, -0.37435248f, -0.33957517f, -0.06070925f, 0.32304347f, 
    -0.01368304f, 0.28886795f, 0.17894486f, -0.35176688f, -0.04631579f, 0.01970616f, -0.10297916f, 0.17883484f, 
    -0.04419076f, -0.01325833f, -0.07092424f, -0.07791487f, -0.32698974f, 0.02610279f, 0.04015788f, -0.04264031f, 
    0.08284492f, -0.03655015f, 0.04273223f, -0.23650214f, -0.42578360f, -0.18258041f, 0.19745047f, -0.41305974f, 
    0.03672219f, 0.15861636f, -0.00304504f, 0.00933878f, -0.23210359f, -0.06024308f, 0.07362186f, 0.06438445f, 
    0.17018917f, -0.16798721f, -0.04801528f, 0.15524876f, -0.04252066f, -0.27799034f, -0.44494551f, -0.04955091f, 
    -0.01963248f, -0.01836031f, -0.30365065f, 0.27648807f, -0.20412737f, -0.27052566f, 0.11696949f, -0.32917121f, 
    -0.11961930f, -0.29298949f, -0.07143554f, 0.22908144f, -0.10524532f, 0.15619352f, -0.05860315f, -0.45429790f, 
    0.18816541f, -0.00878954f, 0.06626695f, -0.27802023f, -0.11623552f, 0.10593493f, -0.02047197f, -0.10788283f, 
    -0.04111027f, 0.10671888f, -0.06503444f, -0.14517127f, -0.05376051f, 0.21351182f, -0.00937767f, -0.01506421f, 
    -0.09111449f, -0.00459706f, 0.01374285f, 0.23699287f, 0.30258662f, 0.09375476f, -0.06371346f, -0.37164840f, 
    0.04247938f, -0.04078396f, 0.18233091f, -0.33586371f, -0.32318014f, -0.38621312f, -0.07307030f, -0.07090650f, 
    0.06589012f, -0.06961182f, 0.00616266f, -0.08919611f, 0.03449548f, 0.00829185f, -0.30355719f, 0.04345114f, 
    0.26969153f, -0.19052963f, 0.31347418f, -0.01609178f, 0.01026492f, 0.10592877f, -0.15625827f, -0.06521690f, 
    -0.59263110f, 0.06831515f, 0.06018283f, -0.03773597f, 0.21417207f, -0.30565307f, 0.10238770f, -0.31549755f, 
    -0.14223605f, -0.46809766f, 0.03907063f, -0.10825740f, 0.16338274f, 0.25649545f, 0.16304147f, -0.06750186f, 
    0.19139296f, 0.06492635f, 0.13986105f, 0.02496300f, 0.29725266f, 0.01951990f, -0.17764921f, -0.17939661f, 
    -0.02515518f, 0.05115344f, 0.20323806f, 0.00173079f, -0.02149936f, -0.19458617f, -0.28176185f, 0.07855323f, 
    -0.07429561f, -0.07126989f, 0.04319616f, -0.04840034f, 0.21577099f, 0.13144843f, 0.27253425f, 0.07207728f, 
    0.04129898f, -0.08259113f, 0.00005124f, -0.09485231f, -0.27683333f, -0.09354545f, 0.35006997f, 0.26404774f, 
    0.00435634f, -0.21739183f, 0.05072746f, -0.00032374f, 0.16160250f, 0.06051604f, -0.22093959f, -0.04737795f, 
    0.40273356f, -0.27610484f, 0.00925568f, -0.15594338f, 0.07604174f, 0.19388919f, 0.02834973f, 0.06864274f, 
    -0.02290540f, -0.00047779f, -0.08340678f, -0.40557936f, -0.19976397f, 0.28857112f, 0.33343309f, 0.03835047f, 
    -0.41082093f, -0.20759892f, 0.04998485f, -0.31549117f, 0.00732736f, 0.06145736f, 0.10319077f, 0.25682700f, 
    -0.18423218f, 0.08296012f, -0.42008480f, -0.03637271f, 0.22318816f, -0.16133420f, 0.08208082f, -0.49999610f, 
    0.18496066f, 0.22051537f, 0.18870345f, 0.18581446f, 0.02151055f, 0.05418310f, -0.36367074f, -0.05279983f, 
    -0.24990000f, -0.02792934f, 0.05600066f, -0.44440964f, 0.18157962f, 0.04123626f, -0.02272544f, 0.20365249f, 
    -0.08464255f, 0.00887316f, -0.17614551f, 0.10406239f, 0.05058167f, -0.09726264f, 0.05265390f, 0.05183047f, 
    0.11060233f, -0.15747786f, 0.23791742f, 0.11531793f, -0.00472993f, -0.18541321f, -0.56162995f, 0.14280692f, 
    -0.47874305f, 0.08827215f, -0.41501141f, -0.03489870f, 0.21376435f, -0.20120566f, 0.28671515f, 0.15486194f, 
    -0.30228022f, 0.24428575f, 0.11409795f, 0.17515701f, -0.15280372f, -0.25183797f, 0.20741448f, -0.04833978f, 
    -0.01883448f, 0.02734807f, -0.07969135f, 0.21597020f, -0.14230274f, 0.03538068f, -0.26188731f, -0.08226854f, 
    -0.12570147f, 0.05318826f, 0.19034821f, -0.04469021f, 0.16499783f, -0.09963866f, -0.34372830f, -0.16456796f, 
    0.04081846f, -0.01855946f, 0.15804841f, 0.30971316f, -0.06996706f, 0.05178505f, -0.01096735f, -0.32266602f, 
    -0.07675978f, -0.07009490f, 0.14484857f, -0.01230452f, -0.28976989f, 0.20311542f, -0.40980673f, 0.01702384f, 
    -0.04259161f, -0.02357793f, -0.01864118f, -0.09549151f, 0.24155521f, 0.27467516f, -0.14464314f, 0.08933645f, 
    0.05476293f, -0.32621872f, 0.04867125f, 0.14850138f, 0.02026628f, -0.01998437f, 0.19389164f, 0.01897740f, 
    -0.28458166f, -0.31892306f, -0.06234343f, -0.43681619f, -0.01735507f, 0.18239765f, -0.01700332f, -0.00759547f, 
    0.01108659f, -0.03027300f, -0.14093685f, -0.36664537f, 0.32804951f, 0.09335758f, -0.25267097f, -0.23184769f, 
    0.00064019f, 0.12839569f, 0.02848418f, -0.08842436f, -0.02860827f, 0.01478447f, -0.20412512f, -0.20827888f, 
    0.03337073f, -0.01049381f, 0.32116535f, -0.00454912f, -0.23351510f, 0.07459691f, 0.02046610f, -0.38241178f, 
    -0.25068456f, 0.15023616f, 0.10468111f, 0.11617555f, -0.01051662f, 0.20250639f, 0.17395848f, -0.15638147f, 
    -0.18132842f, -0.04589318f, 0.00547531f, 0.24837340f, -0.04888743f, -0.41184008f, 0.00317813f, -0.03733292f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.09357121f, 0.05483199f, -0.06467892f, -0.01048357f, -0.02681748f, 0.00611900f, 0.07203004f, -0.04334418f, 
    -0.07200646f, -0.01932583f, 0.13451380f, 0.02953448f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
