#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.78285128f, -0.19581333f, -0.79434001f, -0.65409225f, 1.19895446f, 0.76994842f, -0.39032304f, -0.36043060f, 
    0.02758716f, -0.92583901f, 0.12390097f, 0.70294768f, 0.83760583f, 1.26065195f, 0.29188529f, -0.39226839f, 
    -0.48051435f, 0.30792964f, -0.26169759f, -1.38996744f, 0.06157535f, 0.98640788f, -0.64871222f, 0.43486148f, 
    0.33699280f, -0.41514152f, 0.12282459f, 1.70996773f, 0.65870684f, -1.36998129f, 0.15369804f, 0.37489471f, 
    -0.13034491f, 0.01770959f, -0.27862281f, 0.22695738f, -1.53896368f, 0.58597493f, 0.89383763f, -0.65871626f, 
    0.82290363f, -0.09673249f, -0.37034163f, 0.45687255f, -0.44636446f, -0.82981658f, -0.70399809f, -0.88177162f, 
    0.07344966f, -0.21013774f, 0.71064579f, 0.52778697f, -0.09938299f, 0.62427258f, -0.56247783f, -1.15946126f, 
    0.71447051f, -0.85947710f, 0.09345178f, 0.74715549f, 0.61906868f, -0.24906880f, -0.07609458f, -1.13464534f, 
    -0.45278835f, -0.89944875f, 0.56866676f, -0.15350981f, 0.49948382f, -0.55624354f, 0.13984668f, -0.53924960f, 
    0.57478350f, -0.23488092f, -0.47140163f, 0.92231387f, -0.89370507f, 0.62999147f, 0.54443002f, 0.28795382f, 
    0.41297886f, -0.78603721f, 1.33504486f, 1.32941532f, 0.51120818f, 0.40713522f, 0.55129814f, -0.39738423f, 
    -0.01881951f, -0.24571724f, -0.26834312f, -1.81241024f, -0.38393819f, -0.19715989f, 1.42976272f, 0.79362172f, 
    -0.10466374f, 0.19436546f, -0.45363241f, -0.98640352f, 0.27561972f, 1.20082951f, -0.67272651f, -0.85904032f, 
    0.38496599f, -0.16332306f, 0.17133224f, 0.27087599f, 0.21891703f, -1.28687549f, -0.81023031f, 0.84270412f, 
    -0.71841902f, -0.12183940f, -0.51486045f, -0.14186692f, -0.50138819f, 0.23738602f, 0.54318959f, 1.00415134f, 
    -1.62830877f, 0.18352640f, -0.69075894f, 0.36841935f, 0.34932077f, -0.43093893f, 1.30341208f, -0.19985594f, 
    -0.41092917f, -0.68600976f, -0.19103099f, -0.51489478f, -0.38195604f, -0.42916393f, 0.73750454f, 1.37858367f, 
    0.39537963f, 0.48907509f, -0.50515288f, 0.02775139f, 0.50644314f, 0.02272747f, 0.56319630f, 0.44733900f, 
    -0.88055676f, -0.61435688f, 0.07260660f, -1.08719778f, -0.84609640f, -0.52199405f, -0.33078688f, 0.11905444f, 
    -0.90167063f, 1.11174560f, 0.79062021f, 1.12930191f, 0.32821640f, -1.21923852f, 0.30192837f, 0.31825748f, 
    -0.16911085f, 0.16793409f, 1.32581997f, -1.33850956f, 0.09480727f, -0.57113057f, 0.51621562f, -0.13949396f, 
    0.02905426f, -0.05315834f, -0.34777734f, -1.35896802f, 0.19687840f, -0.36591509f, -0.43051875f, 0.64410794f, 
    -0.06009213f, 0.44356465f, 0.72611099f, 0.62875617f, 1.18130708f, -0.51033002f, -0.80950671f, 0.90994227f, 
    0.71450502f, -0.02360250f, -0.25687194f, 0.73662561f, -0.19197305f, 0.92079425f, 1.20398426f, 0.88332123f, 
    -0.57968050f, 0.24452473f, 0.12842448f, 0.50207317f, 0.43993065f, -0.57780248f, 0.93564111f, 0.76783603f, 
    0.64354408f, -0.27263528f, 0.75906479f, 1.03496587f, -0.54330301f, -0.41568542f, -0.55109984f, 0.71826911f, 
    -0.46546811f, -1.06879079f, -0.87525409f, -1.08141148f, -0.19468963f, 0.59473330f, -0.26201975f, -0.30374709f, 
    -1.14111173f, -0.83185023f, 0.24233641f, 0.71929842f, -0.46925524f, -1.10216522f, -0.22229448f, 0.42906374f, 
    -0.11667509f, -1.07142329f, 0.31688604f, -0.19356073f, -1.19567645f, -0.54060400f, -0.70902938f, -0.44251382f, 
    -0.29830003f, 0.43194696f, 0.50396740f, 0.76320136f, 0.91356802f, 1.13715172f, -0.41674173f, -1.01265466f, 
    -0.50069743f, 0.03140167f, -0.27447036f, -0.73353195f, -0.63929921f, -0.55268496f, 1.09129381f, 1.22388732f, 
    0.34023681f, -0.09774206f, -0.08558378f, 0.16518834f, 0.02176324f, 1.16185236f, -0.86938888f, -0.40579584f, 
    -1.02784550f, -0.70788825f, 0.69562715f, 0.52665859f, 0.28483924f, -0.83411402f, -1.03327906f, -1.01172364f, 
    -0.78822720f, -0.06647574f, 0.44308236f, -0.13205916f, -0.13054509f, 0.17075479f, -0.73326105f, 1.67913198f, 
    -0.74013382f, -0.20428312f, 0.42102563f, -0.74525064f, -0.26935041f, -0.44566202f, 0.02682049f, 1.02459073f, 
    0.64519191f, 1.13228583f, -1.01485944f, -0.53552961f, -0.75420588f, -0.52699584f, 0.42689437f, -0.14912528f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.04299974f, 0.05769750f, 0.30184790f, 0.25780195f, 0.15562007f, 0.31031933f, 0.21326947f, 0.09438080f, 
    0.36273000f, 0.38547191f, 0.36560380f, 0.27832565f, 0.22264391f, 0.33483583f, -0.02848556f, 0.03279175f, 
    0.16693355f, 0.09391828f, 0.08064955f, 0.45411006f, -0.09186091f, 0.21191996f, 0.30122635f, 0.05258605f, 
    0.15181017f, -0.29462653f, 0.38197008f, 0.34542856f, 0.09336945f, 0.46475965f, 0.01827172f, 0.09514569f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.03372404f, 0.52727842f, 0.09435397f, -0.28533563f, -0.07227170f, 0.04576494f, 0.09327481f, -0.03986908f, 
    0.13922802f, -0.06992941f, 0.03265545f, 0.03421234f, 0.02258685f, 0.07601237f, 0.05144218f, -0.00335864f, 
    0.07322492f, -0.06376865f, 0.08969031f, -0.01233144f, 0.43524638f, 0.17001230f, 0.28936002f, 0.05010659f, 
    -0.07538734f, -0.02590465f, 0.08489016f, 0.03632832f, -0.02889460f, -0.02278812f, -0.02189496f, -0.04520854f, 
    -0.00410501f, -0.05488553f, 0.02880739f, 0.08729704f, 0.04555837f, -0.02193524f, -0.02106182f, 0.11743173f, 
    0.02406907f, -0.24259716f, 0.11288092f, -0.12352280f, -0.41059971f, 0.15885238f, 0.16629803f, -0.05866074f, 
    0.00611420f, 0.04154868f, -0.14986044f, -0.01280309f, -0.07518361f, -0.01101239f, 0.08782004f, 0.07420653f, 
    0.12481559f, -0.04010818f, -0.01337720f, -0.00214921f, -0.22970751f, 0.05516899f, 0.02597553f, -0.03011357f, 
    0.46839452f, -0.27563077f, 0.07520083f, -0.06237223f, 0.15954562f, -0.09698232f, -0.03860446f, -0.06316584f, 
    0.01444319f, -0.01911033f, -0.20718703f, 0.07740226f, -0.06868048f, -0.01383466f, -0.03037638f, -0.07160072f, 
    -0.22063380f, -0.10449734f, 0.26095232f, 0.11664975f, -0.04556539f, 0.01479899f, 0.05823826f, 0.06730509f, 
    -0.00463214f, 0.05675988f, 0.02908970f, -0.02081415f, 0.04064149f, 0.02124099f, -0.06248381f, 0.09656318f, 
    -0.10476197f, -0.00718480f, 0.01128335f, -0.08770458f, -0.11713763f, -0.08642271f, -0.15434922f, -0.05722248f, 
    -0.26686713f, 0.01017422f, 0.13836773f, -0.07638089f, 0.04994182f, -0.00831660f, -0.00108935f, 0.05244499f, 
    -0.06457528f, 0.07548726f, 0.01490440f, 0.07528496f, -0.06733684f, 0.07489785f, 0.03335637f, -0.10557953f, 
    -0.19223262f, -0.00248689f, -0.18311107f, 0.16925631f, -0.40383253f, -0.05539273f, -0.04494747f, 0.02792157f, 
    -0.01166106f, -0.10740072f, 0.07572315f, -0.05513299f, -0.08200675f, -0.01278309f, 0.01104333f, -0.17819421f, 
    0.03982720f, -0.03170561f, 0.09711780f, 0.08158287f, 0.17077219f, -0.08864485f, -0.08422740f, -0.15806651f, 
    -0.48441008f, 0.10949299f, 0.15305051f, 0.00624883f, 0.04057072f, -0.10878273f, 0.01889912f, -0.08746895f, 
    -0.05612911f, -0.00509730f, -0.11438130f, -0.02130894f, -0.04165020f, -0.00778222f, -0.04078820f, -0.03671191f, 
    0.28885627f, -0.51100338f, -0.04593069f, -0.04372006f, -0.06557282f, -0.07549229f, 0.07560477f, 0.03178717f, 
    -0.17468937f, 0.03214689f, -0.10667221f, 0.07157280f, -0.10223072f, 0.13185377f, 0.07001216f, -0.02480252f, 
    -0.10424740f, 0.09636465f, -0.02491234f, -0.05058402f, -0.16009821f, 0.07466430f, 0.19197558f, 0.11977649f, 
    0.35072064f, -0.08397865f, -0.13429759f, 0.08747516f, -0.02806521f, -0.03224317f, 0.05385337f, -0.17562339f, 
    -0.00179919f, -0.02800709f, 0.00953470f, 0.09848643f, -0.03697417f, -0.10392103f, -0.00922138f, 0.03777981f, 
    -0.33244550f, 0.17780986f, -0.01009258f, -0.13749133f, -0.43239522f, 0.00472382f, 0.05948174f, -0.01215387f, 
    0.00532212f, -0.04107421f, 0.04761980f, -0.01762742f, -0.02656358f, -0.00963231f, -0.08877902f, -0.00797695f, 
    -0.06363191f, -0.00458018f, -0.05994281f, 0.00129869f, -0.59586900f, 0.26331115f, -0.16867092f, 0.16071375f, 
    0.02939630f, 0.02013943f, 0.07638799f, -0.03465686f, 0.04213196f, -0.04595600f, 0.01791301f, -0.04714677f, 
    0.05913101f, -0.04864243f, 0.00440086f, -0.08174499f, 0.04213089f, 0.00116818f, -0.06181104f, 0.02913772f, 
    0.26279989f, -0.32084206f, 0.08326191f, 0.11847383f, -0.32988420f, 0.14045022f, 0.02760423f, 0.14937836f, 
    -0.00177096f, -0.11851563f, 0.00263248f, -0.10187711f, 0.06435031f, 0.07839751f, 0.07397924f, 0.15679193f, 
    0.04041948f, 0.05949824f, -0.06136674f, 0.06084172f, 0.12056332f, -0.06838072f, -0.06783670f, 0.12641346f, 
    0.00177997f, -0.11410472f, -0.01511677f, -0.15378767f, -0.08866540f, -0.02891524f, 0.01589006f, 0.09683512f, 
    -0.01355844f, -0.02638291f, -0.02316410f, -0.01787198f, -0.05537380f, -0.04286042f, 0.02083210f, -0.07541899f, 
    0.07415286f, -0.04389725f, 0.25188375f, 0.12959981f, 0.03025374f, -0.01458521f, 0.04713682f, -0.04224614f, 
    0.09282365f, 0.10575202f, -0.04513597f, 0.04484508f, 0.07023825f, 0.01299155f, 0.05374453f, 0.05812763f, 
    -0.07518294f, -0.09854043f, 0.04714074f, -0.12504695f, 0.25852606f, 0.06222028f, -0.13769861f, -0.30008578f, 
    -0.03058772f, -0.05908721f, -0.07788931f, -0.15931165f, 0.13436235f, -0.04592278f, -0.03840757f, 0.03551079f, 
    0.08335064f, 0.03602495f, 0.05310390f, -0.00722704f, -0.06227066f, -0.04171998f, -0.00006958f, 0.07329327f, 
    -0.14697374f, -0.42776236f, -0.24139552f, 0.20380598f, -0.17895997f, -0.03905536f, 0.01852553f, 0.01806791f, 
    0.07189114f, 0.06283630f, -0.02543688f, 0.05021769f, 0.06309822f, -0.09798516f, -0.11770431f, 0.12881462f, 
    0.10681812f, -0.04464051f, 0.00315858f, 0.04853987f, 0.14640741f, -0.01691844f, 0.07291048f, -0.18133494f, 
    -0.00591773f, -0.29701847f, -0.20180193f, -0.10260738f, 0.07843993f, 0.08911029f, -0.02226282f, -0.09838500f, 
    -0.06694067f, 0.00882722f, -0.04352891f, 0.17836720f, 0.01754420f, -0.04541888f, -0.02442799f, 0.10738784f, 
    0.22338600f, -0.29816350f, 0.22640449f, 0.33536610f, -0.17691801f, -0.16502988f, -0.12081803f, -0.05579243f, 
    -0.05595718f, 0.01166688f, -0.04987368f, 0.13809787f, -0.01051644f, -0.13518235f, 0.00055969f, -0.03484484f, 
    -0.16009495f, 0.03735029f, 0.00474957f, -0.02246615f, 0.11109996f, -0.02970296f, -0.01203821f, 0.07219102f, 
    -0.07052315f, 0.09486084f, -0.14585394f, -0.00096555f, 0.08304842f, -0.02241676f, 0.04385068f, 0.04605003f, 
    -0.08367744f, 0.00063412f, 0.21785527f, -0.00567168f, 0.01463766f, 0.05728546f, -0.08409981f, -0.22092581f, 
    0.26170653f, 0.00711876f, -0.10100587f, -0.04291627f, 0.29185736f, -0.06765655f, -0.02143532f, -0.03542757f, 
    0.01392879f, 0.00463807f, -0.09992875f, 0.12213706f, 0.16214590f, 0.06929603f, 0.02793273f, -0.04817004f, 
    0.07968073f, 0.08192436f, 0.02577005f, 0.11160637f, 0.09675094f, 0.22671786f, -0.04823749f, -0.12176637f, 
    0.27522185f, -0.15531124f, -0.12117768f, -0.07814444f, 0.10707002f, -0.05786561f, -0.09475530f, -0.01819951f, 
    0.00288132f, -0.04959621f, 0.01438600f, -0.09188616f, -0.01657409f, -0.00833583f, 0.02643024f, -0.04819018f, 
    0.09184695f, 0.10491320f, -0.07317069f, -0.00874526f, 0.21001397f, -0.35587835f, -0.06762306f, -0.06481814f, 
    0.02551313f, -0.08897079f, -0.00390000f, 0.05297801f, 0.08964016f, -0.14842723f, -0.01246910f, 0.07295062f, 
    0.11585324f, -0.23475717f, -0.00249673f, 0.06609903f, 0.02543433f, -0.62553734f, 0.19682226f, 0.31389472f, 
    -0.00117449f, 0.00968605f, 0.05261898f, -0.02650689f, 0.05066543f, -0.01525135f, 0.02462346f, -0.21578851f, 
    0.11867110f, -0.03870327f, -0.04319022f, 0.02472554f, -0.14292632f, 0.01407729f, 0.08817209f, -0.04490363f, 
    -0.52718717f, -0.34690866f, 0.09076962f, -0.06456926f, -0.11037900f, 0.04733698f, -0.23308986f, -0.02964658f, 
    0.01631313f, 0.00383253f, -0.11138551f, 0.03690248f, -0.03012409f, -0.08361966f, 0.01603053f, -0.06802679f, 
    0.02728144f, 0.00764792f, -0.07275499f, -0.00867167f, -0.31783581f, -0.19037654f, -0.19847843f, 0.19950049f, 
    0.04072544f, -0.00403023f, -0.05948748f, 0.01473425f, 0.06234016f, 0.04727359f, 0.06225996f, 0.09974445f, 
    -0.03573883f, -0.04472451f, 0.08266594f, -0.07292116f, 0.01053316f, 0.09526003f, 0.14518833f, -0.01865485f, 
    -0.08440081f, -0.01607652f, 0.12891872f, -0.02330053f, -0.02192026f, -0.06253818f, -0.40408322f, 0.02525542f, 
    -0.03831724f, -0.03083432f, -0.07195765f, 0.05732259f, -0.15395708f, 0.09151255f, -0.12321208f, 0.07178511f, 
    -0.01347240f, -0.01711511f, -0.09890864f, -0.07035924f, 0.16285509f, 0.26667026f, 0.22216126f, -0.15560545f, 
    -0.20837310f, 0.03842802f, 0.06022390f, -0.05572156f, 0.00206500f, -0.21821743f, 0.05569970f, -0.02217630f, 
    -0.08714278f, 0.04409216f, -0.03665404f, 0.06925081f, 0.06186464f, -0.01408899f, 0.08946413f, -0.03491573f, 
    0.11940203f, -0.03653822f, 0.22247940f, 0.07414547f, 0.23304945f, -0.09735887f, -0.01510112f, 0.06968015f, 
    -0.05841767f, 0.07355045f, 0.04504899f, 0.08403303f, -0.04505630f, 0.01995707f, 0.01745277f, 0.04364546f, 
    0.03488367f, 0.08256361f, 0.04879653f, -0.12386347f, -0.31743363f, 0.15218672f, -0.27556643f, 0.00055287f, 
    -0.17251422f, 0.01184352f, -0.01837488f, -0.03633130f, 0.02271817f, -0.03622039f, 0.08364180f, -0.02566369f, 
    0.01262519f, 0.02844801f, -0.03848214f, 0.02070227f, -0.10179197f, -0.03988789f, -0.04481691f, -0.01032727f, 
    0.49742255f, 0.01208066f, -0.03317166f, -0.14464231f, 0.33629450f, -0.14283961f, -0.01702405f, 0.06261257f, 
    -0.14081523f, 0.02053053f, 0.06098567f, 0.01969417f, -0.12861830f, -0.08292358f, 0.09170302f, -0.11377846f, 
    -0.09720587f, 0.11975912f, -0.11588144f, -0.00441595f, 0.21747421f, 0.00236899f, -0.04577104f, -0.01987294f, 
    0.01966067f, -0.08994082f, -0.14651394f, -0.14131069f, 0.11419230f, 0.05311899f, -0.05923637f, -0.04202934f, 
    -0.06726444f, 0.00219121f, 0.00466685f, 0.00997058f, 0.09243198f, 0.02357601f, 0.09160625f, -0.05532765f, 
    0.19281003f, -0.16316177f, -0.14432013f, -0.22055604f, -0.21479000f, 0.02356272f, 0.09781840f, -0.17696939f, 
    -0.00013708f, 0.06170134f, 0.04550275f, -0.05874292f, 0.00387125f, -0.03824807f, 0.21822748f, -0.01363255f, 
    -0.07085340f, 0.09737402f, -0.22341616f, 0.13894373f, -0.47151822f, 0.22522466f, 0.00377204f, 0.00654100f, 
    0.10839010f, -0.03661082f, 0.07731490f, -0.02009509f, -0.04332156f, 0.07452373f, 0.05552330f, 0.20171560f, 
    -0.00635986f, -0.10593735f, -0.01318935f, -0.08448977f, -0.07938654f, -0.03584559f, 0.04169843f, -0.03568184f, 
    0.06176030f, 0.25280547f, 0.00798106f, 0.18527539f, -0.31799856f, 0.04622371f, 0.07202575f, 0.03385046f, 
    -0.11515602f, 0.12786992f, 0.16705993f, -0.04102093f, -0.01714332f, 0.09919663f, 0.05393165f, -0.04658373f, 
    0.16562904f, -0.05882663f, 0.07822001f, 0.04128399f, 0.38396710f, -0.57521087f, 0.19526701f, -0.31578073f, 
    -0.18111807f, -0.07058554f, -0.23744407f, -0.07842054f, -0.00195976f, -0.03668207f, -0.00816341f, 0.03374765f, 
    -0.21109489f, 0.05936658f, 0.11771026f, -0.19476154f, 0.00736093f, -0.11531444f, 0.08463793f, -0.11895519f, 
    -0.67945164f, 0.08176424f, -0.29187983f, -0.43193734f, 0.12739508f, 0.00398130f, 0.09353046f, -0.04923198f, 
    -0.02269916f, 0.12371943f, -0.05425666f, 0.06551449f, 0.04540100f, -0.21532300f, -0.20381074f, -0.09404579f, 
    0.05673419f, 0.17426243f, -0.17393988f, 0.06824590f, 0.18535826f, 0.22322160f, -0.06182418f, 0.11220574f, 
    -0.15436968f, 0.02801610f, 0.00184840f, 0.15948814f, 0.00107897f, 0.08848790f, 0.08991360f, -0.10805628f, 
    0.03004572f, -0.02989432f, 0.01672311f, 0.09783394f, 0.13281988f, -0.13718607f, 0.07564087f, 0.20531659f, 
    -0.27623287f, 0.02999900f, 0.05980555f, 0.15476291f, -0.29563838f, -0.05712787f, -0.00176176f, -0.16405049f, 
    0.08628934f, 0.09052683f, 0.01308575f, -0.14480537f, -0.09035315f, 0.05368445f, -0.06513543f, 0.06512966f, 
    -0.02106795f, 0.03753000f, -0.05540599f, -0.02346943f, -0.11210392f, -0.02590934f, -0.25101206f, -0.02398091f, 
    -0.19109713f, 0.04890537f, -0.10984953f, -0.05252886f, -0.01290296f, -0.01963616f, 0.17537692f, 0.11414968f, 
    0.04328510f, -0.02822911f, -0.02633934f, -0.04735528f, 0.11051259f, -0.05847318f, -0.10496987f, 0.05796192f, 
    -0.10597862f, 0.10923414f, 0.20778723f, 0.10036643f, 0.11529999f, 0.00163719f, -0.02316579f, -0.03997828f, 
    0.03947841f, 0.03871953f, 0.13515556f, 0.02346694f, 0.04084902f, -0.01221034f, -0.07554984f, -0.08820280f, 
    0.09094612f, -0.06033753f, 0.06640495f, 0.05833589f, 0.11636262f, 0.25398013f, -0.04051239f, -0.07504988f, 
    0.18710470f, -0.01707352f, 0.15786314f, -0.00954886f, -0.11579277f, 0.14585353f, -0.00089936f, 0.05399555f, 
    0.08837294f, 0.08109470f, 0.00891683f, 0.04637452f, -0.07194703f, 0.16275895f, -0.00564186f, -0.00035858f, 
    0.46200138f, -0.42990869f, -0.10158356f, 0.02391355f, -0.06630593f, -0.11919147f, 0.03245366f, 0.03988992f, 
    0.00636414f, 0.07829996f, 0.08124354f, 0.02043814f, -0.03802795f, 0.01287916f, -0.07696323f, 0.12748958f, 
    -0.01845093f, -0.02578376f, -0.07676900f, 0.02663365f, -0.10441978f, -0.12593441f, -0.16904199f, -0.29775611f, 
    -0.43949068f, -0.06327412f, -0.03200095f, -0.12401603f, -0.14067554f, 0.06950751f, -0.04094770f, 0.09058090f, 
    0.02697519f, 0.02501279f, 0.02303003f, 0.04567367f, -0.08641804f, -0.01235410f, 0.12281221f, 0.06441794f, 
    0.02784192f, -0.03885863f, 0.12806964f, -0.15944517f, -0.14981851f, -0.03096418f, 0.12928088f, -0.04302289f, 
    0.09237077f, 0.04469807f, 0.11936772f, -0.04101709f, 0.03824991f, -0.10484286f, -0.06151288f, -0.07085452f, 
    -0.03043654f, -0.16844141f, 0.00078641f, -0.02931832f, -0.13907683f, 0.03524353f, -0.25014454f, 0.11629765f, 
    -0.04486857f, 0.12755755f, -0.02913903f, 0.05992043f, 0.04515231f, -0.02280061f, 0.08686195f, 0.01416298f, 
    0.05557613f, 0.10136983f, -0.20783941f, -0.05357196f, 0.02569644f, -0.00924475f, -0.11471412f, 0.01613359f, 
    0.23237884f, -0.44650957f, -0.05229882f, -0.21041736f, -0.09667284f, 0.01310239f, -0.17030285f, 0.09855539f, 
    -0.03826727f, -0.06363700f, 0.00688549f, 0.01186793f, -0.06925567f, -0.15014492f, -0.02899623f, -0.16163354f, 
    -0.09633479f, -0.11733076f, -0.07104758f, -0.06199038f, 0.27330804f, 0.09816375f, 0.14284144f, 0.29708937f, 
    -0.09157706f, -0.03094326f, -0.17979279f, -0.08507355f, 0.02568165f, 0.01359077f, 0.03744657f, 0.02997165f, 
    -0.08875406f, 0.02483415f, -0.07194997f, 0.15041238f, -0.01517027f, 0.13440889f, -0.07023109f, -0.10751438f, 
    -0.09524480f, -0.07121697f, 0.06320006f, -0.20910038f, -0.31690332f, 0.11528245f, 0.02216662f, -0.10975763f, 
    -0.02923290f, 0.04555764f, -0.06012103f, -0.03394761f, 0.00807460f, 0.07243691f, -0.14444269f, -0.04730008f, 
    0.08318525f, -0.02532262f, -0.22062175f, -0.09636806f, 0.08438855f, 0.25375372f, 0.16828446f, 0.11518198f, 
    0.31651950f, -0.13399918f, -0.13523722f, 0.14260274f, -0.04217003f, 0.06671529f, -0.12503301f, 0.05779501f, 
    0.15886393f, 0.14464270f, -0.04575685f, -0.04636623f, -0.13709086f, -0.01490289f, 0.01802594f, 0.02537312f, 
    0.34200507f, -0.62606424f, -0.06682567f, -0.09096787f, 0.21463482f, 0.01497761f, 0.00020480f, -0.01593054f, 
    -0.05048334f, 0.01355068f, 0.06908740f, 0.04489891f, 0.03187503f, -0.04571270f, -0.21175778f, 0.04796759f, 
    -0.02845358f, -0.00750309f, -0.08961616f, 0.00498384f, -0.19710360f, 0.12877962f, -0.17018409f, -0.03477594f, 
    0.05853583f, -0.09478418f, -0.02194092f, -0.02119635f, 0.00262168f, 0.08295105f, -0.09144086f, -0.13829961f, 
    0.03973678f, -0.07198102f, -0.08986317f, 0.18593960f, 0.10367400f, 0.05304039f, -0.01406960f, 0.02141457f, 
    0.40863970f, -0.49657378f, 0.15283795f, -0.14643665f, -0.19124024f, -0.10635419f, -0.01784618f, -0.18165313f, 
    -0.01075893f, -0.12159541f, -0.04682444f, -0.09097216f, -0.12386598f, 0.07597614f, -0.11871725f, 0.04190635f, 
    0.07465429f, -0.09913246f, 0.04956016f, 0.04444023f, 0.14878140f, 0.16812709f, 0.00933896f, 0.14246663f, 
    0.09473059f, -0.03731953f, -0.06662969f, 0.04388564f, 0.02982761f, 0.02047808f, 0.07095551f, 0.06235038f, 
    -0.03736353f, 0.13231541f, -0.15320002f, -0.04569612f, 0.05614201f, 0.03706467f, -0.07681410f, 0.02426648f, 
    0.28475422f, 0.33136219f, 0.11108680f, 0.18038917f, 0.16367266f, 0.02156642f, -0.06294470f, -0.04056900f, 
    0.01790030f, 0.06527118f, -0.03564367f, 0.11608835f, -0.19582516f, 0.05046306f, -0.09440048f, 0.00623267f, 
    0.01525136f, 0.22135314f, 0.05484771f, -0.04576858f, -0.00166403f, -0.28136399f, 0.03087142f, -0.13419285f, 
    -0.12682164f, -0.05457093f, 0.01275992f, 0.10015043f, 0.12057126f, -0.05942434f, -0.08269376f, 0.07297438f, 
    -0.04074863f, 0.26783860f, -0.02169486f, 0.08113731f, -0.25336966f, -0.07808344f, -0.04688707f, -0.15013063f, 
    0.05355557f, 0.11004235f, -0.19784155f, 0.08927203f, -0.30941510f, 0.05727761f, -0.02699816f, 0.13708426f, 
    -0.03790854f, 0.07366743f, -0.01390410f, -0.06439929f, 0.06698349f, 0.09832639f, -0.01795097f, -0.04023147f, 
    0.05102773f, -0.06578323f, -0.04155021f, 0.09427831f, -0.08298379f, -0.06876776f, 0.01557618f, -0.34160221f, 
    -0.17589343f, -0.04102683f, 0.10518666f, 0.02790940f, 0.08176388f, 0.03091798f, -0.22300906f, -0.19238639f, 
    0.05548299f, 0.13692483f, 0.01313643f, -0.09793410f, -0.00690356f, -0.07411642f, -0.12893760f, -0.27095351f, 
    0.06223221f, -0.01613162f, 0.10553300f, -0.04224136f, 0.27583957f, -0.15393984f, 0.00345522f, 0.03021075f, 
    -0.03254750f, -0.00340281f, -0.02337104f, -0.01432969f, 0.17152807f, -0.15532352f, 0.10544129f, -0.12192290f, 
    -0.00161255f, -0.03009271f, 0.03450919f, 0.20476657f, -0.01010768f, 0.00566528f, -0.12446010f, 0.05556573f, 
    -0.15175910f, 0.03594829f, 0.05786713f, -0.03614110f, -0.03948137f, 0.04039397f, 0.02453559f, 0.11853121f, 
    -0.03369565f, 0.00584835f, 0.00327067f, 0.07128426f, 0.04665050f, -0.00876467f, -0.06064307f, -0.02759722f, 
    -0.20936891f, -0.39516857f, -0.11768493f, -0.10365127f, 0.12219179f, 0.02049582f, -0.10843369f, 0.10713723f, 
    -0.03679269f, -0.05735983f, 0.09221917f, 0.13146971f, 0.17482387f, -0.06414027f, 0.14178771f, -0.10221540f, 
    -0.11487726f, -0.34893456f, -0.03107201f, -0.01625732f, 0.27316561f, -0.15412599f, 0.04823541f, -0.00107376f, 
    -0.14181052f, 0.01283480f, -0.07687044f, 0.09687638f, 0.09179859f, 0.08398157f, -0.03926156f, -0.11086529f, 
    0.03001475f, 0.09530997f, -0.02640421f, 0.05839384f, 0.01640563f, -0.00473532f, -0.08170806f, -0.12323035f, 
    -0.31570014f, -0.09446745f, -0.32456219f, -0.36261892f, 0.19013712f, -0.00913330f, -0.09412745f, -0.00237131f, 
    0.04303151f, 0.11876484f, 0.19833142f, -0.10588233f, 0.11303442f, -0.02517723f, 0.13347378f, -0.05624388f, 
    0.04760060f, -0.09796312f, 0.01688553f, -0.03802766f, 0.20225750f, 0.07950830f, -0.13374862f, 0.19200347f, 
    0.00872691f, 0.08638375f, -0.18333647f, 0.06590474f, 0.06210269f, 0.02401634f, 0.01954542f, -0.11324551f, 
    -0.06577668f, 0.08701444f, 0.11248314f, 0.10019396f, 0.04597596f, -0.14947820f, -0.13725732f, 0.09900416f, 
    0.31891587f, 0.16614433f, -0.11687166f, 0.22329926f, 0.10253187f, -0.13485152f, 0.02409072f, -0.08958130f, 
    0.06191384f, 0.10619964f, 0.03761842f, 0.03042916f, 0.05741089f, 0.08505786f, -0.01307464f, -0.07634464f, 
    -0.05321360f, -0.09530138f, -0.07724085f, -0.04476992f, 0.47072279f, -0.10139110f, 0.24935959f, -0.06429026f, 
    0.07297599f, 0.02908061f, -0.09982946f, 0.03541138f, 0.08812571f, 0.12042604f, 0.09319816f, 0.09981043f, 
    0.05627301f, -0.00275797f, 0.09637883f, 0.02109239f, -0.13084760f, -0.05069155f, -0.06482494f, -0.08740608f, 
    -0.24572325f, 0.09499130f, 0.11363077f, 0.06922919f, 0.14125825f, -0.15118505f, -0.04571223f, -0.24849539f, 
    0.03544380f, -0.01533777f, -0.05457078f, -0.07391416f, -0.02891879f, -0.07238870f, 0.15781276f, 0.03043649f, 
    0.03388430f, 0.05413641f, 0.07257064f, 0.10169435f, 0.21454428f, -0.38458133f, -0.06570690f, -0.09961127f, 
    -0.22670802f, 0.02612221f, -0.24989600f, 0.07198305f, 0.03614225f, 0.06670032f, -0.05373017f, 0.02323703f, 
    0.07841978f, 0.01223615f, -0.00015721f, 0.03823681f, -0.00950898f, 0.13057615f, 0.07897205f, -0.02656799f, 
    0.52267146f, -0.03594055f, -0.47525784f, -0.16813494f, -0.10461306f, -0.07980639f, -0.06280932f, 0.02414291f, 
    -0.03335657f, -0.02267663f, -0.04644794f, -0.02153862f, 0.07367215f, -0.10351310f, 0.01779848f, 0.08253166f, 
    0.04154027f, -0.15581611f, 0.04175321f, -0.01608601f, 0.09048405f, 0.08760612f, 0.11144599f, 0.14927615f, 
    0.03679702f, -0.08039387f, -0.01781990f, -0.10761189f, -0.06447773f, 0.10624527f, 0.00026995f, -0.04580974f, 
    -0.03601904f, -0.04474885f, 0.06537613f, 0.04484747f, -0.03482332f, 0.05736150f, 0.01718794f, -0.01352157f, 
    0.30170983f, -0.11084346f, -0.04275013f, 0.04749070f, -0.12858248f, -0.16426012f, 0.06231332f, 0.05695136f, 
    -0.00842996f, 0.02231095f, 0.02933657f, -0.00544901f, 0.00057862f, -0.05153722f, 0.03722997f, 0.17165218f, 
    -0.09007783f, -0.08855650f, 0.17203292f, -0.08449338f, 0.19967608f, -0.04114430f, 0.10592826f, 0.11492772f, 
    0.10241751f, -0.12564908f, -0.12204985f, -0.17513397f, 0.02457155f, 0.09539738f, 0.01834465f, -0.07152453f, 
    -0.10145982f, -0.02961344f, 0.00194943f, -0.04410075f, 0.04561156f, -0.02439558f, 0.06952763f, -0.01426648f, 
    -0.16066332f, 0.07947826f, 0.11038816f, -0.03519886f, -0.06494104f, -0.01823327f, -0.09084796f, 0.00211217f, 
    -0.06114543f, 0.06917192f, -0.09284107f, -0.04538839f, -0.00537709f, -0.08498299f, 0.08259393f, 0.03849627f, 
    0.07863477f, -0.00770132f, 0.03340665f, 0.03980530f, 0.28222415f, -0.03273420f, -0.26545316f, -0.02128450f, 
    -0.03279309f, -0.05321855f, -0.02898734f, 0.05096741f, 0.01148612f, -0.02141989f, -0.03957899f, 0.04743521f, 
    0.01786055f, -0.00330453f, -0.06152880f, -0.01160352f, -0.04427066f, -0.10150811f, -0.08305965f, 0.05984584f, 
    0.25551584f, 0.03328996f, 0.17224322f, 0.08211236f, 0.15428533f, -0.10833986f, -0.03268262f, 0.03471846f, 
    -0.00531390f, 0.04048701f, 0.07400012f, -0.02728304f, 0.04559205f, -0.01980438f, 0.00403130f, 0.05938154f, 
    -0.09417146f, -0.01627718f, 0.02483481f, -0.02818525f, 0.30354363f, 0.08580352f, -0.34993163f, 0.04744720f, 
    -0.25677174f, -0.06087235f, 0.09279852f, 0.12398040f, 0.03118953f, -0.02369331f, -0.02936546f, 0.02193314f, 
    0.01953001f, -0.04820025f, -0.04947308f, 0.01476874f, 0.12610003f, -0.04520673f, 0.09854377f, -0.07191093f, 
    -0.47386315f, -0.19911776f, -0.01607815f, 0.16229706f, -0.06701954f, 0.00584816f, -0.00232199f, -0.15666753f, 
    -0.00298910f, 0.12265268f, 0.00538750f, -0.06814091f, -0.05050556f, 0.07544728f, 0.10926183f, -0.00052208f, 
    0.04923092f, -0.09656131f, -0.03921164f, -0.03176743f, 0.21218744f, 0.17030774f, -0.14371485f, -0.11711263f, 
    -0.04210764f, 0.00386458f, 0.12406833f, -0.00077261f, -0.07697031f, -0.09628201f, -0.00485823f, -0.04322508f, 
    -0.01560201f, -0.02387732f, -0.00532391f, 0.04303070f, 0.03210108f, -0.12454121f, -0.00769056f, -0.09343244f, 
    -0.25434449f, -0.01676205f, -0.08271977f, -0.16468082f, -0.18339808f, 0.01451361f, 0.05002644f, 0.07092009f, 
    0.00482596f, 0.08354792f, -0.02112847f, 0.04902776f, -0.00572243f, -0.03903447f, -0.09179323f, -0.05970770f, 
    0.02460866f, 0.11751354f, 0.02656600f, -0.01740935f, -0.14421473f, 0.20997962f, 0.03413925f, -0.15911709f, 
    -0.00090284f, 0.06851769f, 0.02510642f, 0.19133052f, 0.01692298f, -0.00856545f, -0.09756551f, 0.11277252f, 
    -0.04840759f, -0.07479321f, -0.00607683f, -0.02949259f, -0.11850155f, -0.05150772f, 0.08128510f, -0.01786310f, 
    -0.00032775f, -0.29135472f, -0.19492680f, -0.07408496f, -0.41058725f, -0.10570433f, 0.00310033f, -0.00585555f, 
    0.01347562f, -0.10198826f, 0.00856917f, 0.00319848f, 0.04562140f, 0.06386539f, -0.07996459f, 0.02472426f, 
    -0.03359390f, -0.04715207f, 0.05289145f, -0.10007189f, -0.32299864f, 0.13483924f, -0.03328103f, -0.03709159f, 
    0.14604220f, 0.16647311f, 0.07501910f, 0.00422123f, -0.04918629f, -0.09237049f, -0.08409584f, 0.04303976f, 
    -0.07202330f, -0.06829292f, 0.01360718f, -0.06048629f, 0.07423021f, -0.07104592f, -0.21890090f, 0.03000186f, 
    0.11473085f, -0.01436469f, -0.10711021f, -0.28455207f, -0.03096272f, -0.01010559f, -0.00375297f, 0.04567840f, 
    0.12372321f, -0.01491569f, 0.02393076f, -0.02237087f, -0.07162400f, -0.06787913f, -0.03205916f, -0.00725286f, 
    -0.02386087f, -0.01850253f, 0.12076759f, -0.02005996f, 0.20133018f, -0.01476344f, 0.00786839f, -0.08438718f, 
    -0.09680331f, -0.01883929f, 0.01194913f, -0.18294781f, 0.01158403f, -0.05729862f, -0.01774713f, -0.07762019f, 
    -0.02668830f, -0.15561447f, -0.03860340f, -0.08979908f, 0.00534985f, -0.01722996f, 0.09328165f, -0.00109245f, 
    -0.01674332f, -0.10186607f, 0.16862108f, -0.11204662f, -0.03354896f, -0.06218639f, -0.15920019f, 0.05306921f, 
    0.03054573f, 0.10883819f, -0.01561028f, -0.03418947f, 0.13997376f, 0.02642190f, 0.01898185f, 0.11284626f, 
    -0.15088905f, -0.01537531f, -0.00579524f, -0.04945457f, 0.02990693f, 0.08649366f, -0.02424969f, -0.02953106f, 
    0.11523784f, 0.11763853f, 0.06054385f, 0.07817212f, -0.04897068f, -0.14671221f, 0.00303458f, -0.03063924f, 
    0.08288866f, -0.02191702f, -0.03055387f, 0.01497925f, -0.01417571f, -0.07939551f, 0.00296189f, -0.02903251f, 
    -0.18130246f, -0.00464678f, -0.09201486f, -0.03236721f, -0.05221567f, 0.08890489f, -0.07428540f, 0.08130176f, 
    0.01747607f, -0.01777765f, -0.12421881f, -0.01305555f, 0.05066003f, 0.02244432f, -0.04780025f, -0.17910203f, 
    -0.03905125f, -0.04434853f, -0.13256451f, -0.01246978f, -0.09034208f, -0.40934232f, -0.11994368f, 0.01139927f, 
    -0.41071084f, -0.01091862f, 0.05342424f, 0.15671138f, -0.02971174f, 0.11943486f, -0.02504619f, 0.06287473f, 
    -0.01623817f, -0.09737615f, -0.04514504f, 0.06774811f, 0.00912189f, 0.10194535f, 0.11747594f, -0.05984841f, 
    0.29744363f, -0.44719097f, 0.05488019f, -0.16114272f, -0.07556037f, -0.13419884f, -0.06899272f, -0.06000658f, 
    0.07547887f, 0.03046200f, -0.04935287f, 0.01419319f, -0.05113868f, -0.02035621f, 0.16394109f, -0.05316866f, 
    -0.09384415f, 0.15368094f, 0.08273566f, -0.04714179f, -0.30642918f, -0.04626832f, -0.13226953f, -0.18515101f, 
    -0.23989971f, 0.07026113f, 0.12327948f, -0.08177544f, -0.04143850f, -0.00634348f, 0.05505267f, 0.04346282f, 
    -0.01179141f, 0.00963383f, -0.07461911f, -0.12135419f, 0.04151619f, -0.01928618f, 0.11083569f, -0.02087110f, 
    0.04794458f, -0.30653366f, 0.05160479f, -0.00890175f, -0.02077858f, 0.08715393f, 0.12850812f, -0.00237043f, 
    -0.04040315f, -0.03090049f, -0.07360940f, 0.02792349f, -0.06814706f, -0.09442140f, -0.04849349f, 0.02588826f, 
    -0.10572445f, -0.00924714f, -0.21076633f, -0.07510055f, 0.37371328f, 0.00304855f, 0.24960415f, 0.07355891f, 
    0.24009095f, -0.09066427f, -0.14906241f, -0.13227756f, 0.09430332f, 0.10066107f, 0.08244129f, -0.05987113f, 
    -0.02959302f, -0.05320577f, -0.00936487f, -0.03248384f, -0.12981190f, 0.02607432f, 0.00602646f, -0.05166527f, 
    -0.12773882f, -0.04686038f, -0.05600753f, -0.19561914f, -0.19407788f, 0.17520954f, -0.13095428f, 0.15905516f, 
    -0.14370739f, 0.09168252f, -0.11807309f, 0.01367677f, -0.05043009f, -0.09173577f, 0.00160050f, 0.05780445f, 
    -0.08301782f, 0.18489860f, 0.02944111f, -0.07037136f, 0.44659615f, -0.28305438f, -0.26211119f, 0.15270883f, 
    -0.19709510f, -0.22567745f, 0.04112661f, -0.09541106f, -0.03380895f, 0.03564822f, 0.04662266f, 0.02835558f, 
    0.03409557f, -0.02131994f, -0.03977121f, -0.04098719f, -0.03348144f, 0.03415396f, 0.06972952f, 0.05715826f, 
    0.07922912f, -0.11947095f, -0.27899843f, -0.27801517f, -0.13126065f, 0.10404915f, 0.01067537f, 0.05239691f, 
    -0.11807334f, 0.02973533f, -0.03438391f, -0.04777570f, -0.00316725f, -0.04699079f, -0.00658735f, -0.02596768f, 
    -0.05723682f, 0.13182406f, -0.06640141f, -0.09537212f, -0.24590097f, 0.18853050f, -0.13113882f, -0.09314647f, 
    0.08822614f, 0.03926798f, 0.15353632f, 0.04420525f, -0.05830874f, -0.14753948f, -0.01315045f, 0.08289985f, 
    -0.05761145f, -0.10976322f, -0.05929526f, 0.01682360f, 0.11175767f, 0.02237617f, -0.05349286f, 0.00440602f, 
    -0.27216488f, 0.08592188f, 0.00292619f, -0.00781159f, -0.12944417f, -0.14685020f, -0.15714751f, 0.19151722f, 
    -0.07489401f, -0.03797455f, -0.05677772f, 0.13024017f, -0.12728687f, -0.00727602f, -0.02804801f, 0.15331452f, 
    -0.04856924f, 0.07113405f, 0.19031541f, -0.05329700f, -0.55854136f, -0.06847095f, 0.00063684f, -0.01498672f, 
    -0.31577188f, -0.01035449f, -0.15454446f, -0.01244469f, 0.08945625f, -0.11431866f, 0.02681270f, -0.12901814f, 
    -0.03864558f, -0.01639376f, -0.00809543f, 0.07759316f, 0.04852097f, 0.03582869f, -0.01618261f, 0.07441761f, 
    0.15953657f, 0.06890656f, -0.11332593f, -0.03767125f, -0.07091708f, -0.03221731f, 0.04987731f, -0.13185321f, 
    0.01755804f, -0.02845282f, 0.06695310f, 0.08331849f, 0.02811641f, -0.02506019f, 0.00336228f, 0.00429654f, 
    0.04305993f, 0.00146988f, -0.06766687f, -0.06045266f, 0.16451940f, -0.14865875f, 0.13485540f, -0.04262856f, 
    -0.00146234f, -0.16527867f, 0.03811540f, -0.01036792f, -0.00302780f, 0.06076002f, 0.03509085f, -0.01607495f, 
    -0.06525237f, 0.00812460f, -0.04860553f, -0.04684473f, 0.04675873f, -0.10409506f, -0.02834943f, 0.05811812f, 
    -0.28706914f, 0.42587522f, 0.07300480f, -0.03952024f, -0.00479160f, -0.07021175f, -0.01617106f, -0.08342236f, 
    0.09472911f, -0.03124087f, -0.04441558f, -0.02121775f, -0.05658054f, 0.04167937f, -0.14010398f, -0.13651836f, 
    0.03556317f, -0.06381745f, 0.18379910f, 0.10151631f, 0.14702399f, 0.01648080f, -0.14407468f, -0.09260915f, 
    -0.15219039f, -0.11860219f, -0.05465037f, 0.00777242f, -0.03275652f, 0.00555665f, -0.02232167f, -0.04241708f, 
    0.03235655f, -0.01303395f, 0.08674803f, -0.05383042f, -0.07112054f, 0.11715878f, -0.06436928f, 0.09055518f, 
    0.29552042f, -0.07122468f, 0.22038400f, 0.03789680f, 0.03467601f, 0.02972331f, -0.02507216f, -0.12839469f, 
    -0.10460237f, -0.16546716f, -0.10697704f, -0.09669519f, 0.00858316f, 0.02308283f, 0.06985939f, -0.02491319f, 
    0.13206376f, -0.11231986f, 0.01328484f, -0.04009973f, -0.02379660f, 0.03330212f, -0.11643840f, -0.03624472f, 
    0.03169085f, -0.21630023f, -0.23294190f, -0.00732118f, 0.05735048f, 0.05628577f, -0.11613581f, -0.04910739f, 
    0.06328096f, -0.04154906f, 0.05289400f, -0.01934214f, -0.02570562f, 0.06923009f, 0.00605601f, 0.00525917f, 
    0.12160588f, 0.18391533f, -0.29524571f, 0.13075188f, -0.15863191f, -0.07239012f, 0.04917314f, 0.02679050f, 
    -0.01537812f, -0.08669433f, 0.01109590f, 0.00153300f, -0.03565365f, -0.02519319f, 0.00870302f, 0.03817739f, 
    0.02355532f, 0.01050851f, -0.08502462f, 0.01720148f, -0.27729598f, -0.19631895f, -0.00737375f, -0.16155294f, 
    -0.10623362f, -0.09112419f, -0.06729541f, -0.01303170f, 0.11020269f, -0.03476004f, 0.02676107f, -0.03612468f, 
    0.00828054f, 0.03547883f, -0.03345093f, 0.02662136f, 0.01949224f, -0.05519423f, 0.04762971f, 0.08674385f, 
    0.05634220f, -0.13964623f, 0.03405182f, -0.03399385f, -0.17775264f, -0.03357573f, -0.13052683f, -0.04619954f, 
    -0.03770737f, -0.01367614f, -0.04777911f, 0.06322832f, 0.03273096f, -0.01033760f, 0.04946484f, -0.03913748f, 
    0.01083682f, 0.00449291f, 0.02692451f, 0.08064673f, -0.11667552f, 0.04966279f, 0.18908352f, 0.10602453f, 
    0.15950842f, 0.09885507f, 0.03809388f, 0.11291149f, 0.00151282f, -0.01206774f, -0.05086102f, 0.04737767f, 
    -0.04521309f, 0.02756978f, -0.14202006f, -0.04699295f, 0.05741719f, -0.05743454f, 0.01229781f, -0.02442734f, 
    0.04037483f, 0.07167041f, -0.16636498f, 0.08038746f, -0.07034821f, -0.06048440f, 0.06897552f, -0.04278823f, 
    -0.02726755f, 0.03465193f, 0.02028149f, -0.02447171f, -0.00003905f, -0.05893262f, 0.07133771f, 0.03552140f, 
    0.04823997f, 0.02473303f, 0.04068455f, -0.03190295f, -0.50202727f, 0.36007795f, -0.07186841f, 0.14661637f, 
    0.24943164f, 0.09710734f, 0.14844632f, 0.01913512f, 0.05937487f, 0.08562466f, -0.05479140f, -0.03231669f, 
    0.01179173f, -0.12095249f, -0.02467124f, -0.04021819f, 0.01631366f, -0.07880045f, 0.10361551f, -0.04537824f, 
    0.15735301f, -0.00198472f, 0.19905220f, -0.08907203f, 0.12419103f, -0.00204703f, 0.06134564f, -0.05260764f, 
    0.00349044f, 0.01874606f, 0.08627975f, 0.01815234f, -0.01010014f, 0.03574356f, -0.06348365f, 0.13486539f, 
    -0.07253407f, 0.10426673f, -0.00265368f, 0.03912437f, -0.05620809f, -0.61516225f, -0.27506194f, -0.03961771f, 
    0.05980266f, -0.12175849f, -0.06668060f, 0.16398643f, 0.07026306f, -0.13346192f, 0.00690096f, 0.03515305f, 
    0.00580447f, -0.07517413f, 0.05557253f, 0.01689398f, -0.06593288f, -0.02337124f, -0.05508832f, -0.06106661f, 
    -0.11926580f, 0.25101882f, 0.27180836f, 0.20971279f, 0.02284804f, 0.01152209f, -0.04733266f, -0.05893078f, 
    -0.05331355f, -0.01244779f, -0.07976804f, -0.13157417f, 0.04774661f, -0.02317456f, -0.04322202f, -0.03071867f, 
    0.02469143f, 0.10177607f, 0.18170264f, 0.07606918f, -0.00881230f, -0.92039376f, -0.50885499f, 0.18630984f, 
    0.07451293f, -0.01900651f, 0.06683242f, 0.05706477f, -0.05200941f, -0.15970105f, 0.06042760f, -0.01556594f, 
    -0.01213046f, -0.10933924f, -0.03466436f, 0.01723680f, 0.06350213f, 0.09076507f, 0.02088851f, -0.04400932f, 
    -0.06949535f, 0.13551961f, 0.14739841f, 0.16872229f, 0.03187060f, -0.03827414f, 0.15586036f, 0.04878377f, 
    -0.02014678f, 0.04146435f, 0.00019953f, 0.08530492f, -0.06701772f, 0.05452742f, -0.01003011f, -0.02450616f, 
    -0.01667061f, -0.01745298f, 0.03648980f, 0.07777496f, -0.31373721f, 0.21821858f, 0.05080764f, -0.05830861f, 
    -0.09191550f, -0.01838508f, -0.05893879f, -0.10405284f, 0.00340436f, -0.03824287f, -0.03795926f, 0.00041756f, 
    -0.13162056f, 0.00542379f, 0.01090553f, -0.02108127f, 0.07726993f, -0.07051495f, 0.04693158f, -0.08029944f, 
    -0.07004607f, 0.05862219f, -0.19948326f, 0.06981967f, -0.22633660f, -0.10797666f, -0.05500837f, -0.03523050f, 
    0.04221308f, -0.02410279f, -0.17058122f, -0.05784123f, 0.04494742f, 0.06249736f, 0.02982605f, 0.00516057f, 
    -0.11292996f, -0.05761544f, -0.04734351f, -0.00819476f, -0.52641582f, -0.14011331f, -0.21315362f, 0.05178142f, 
    0.22702453f, -0.11403413f, 0.05314806f, 0.07755543f, 0.00001950f, 0.01950597f, -0.05589509f, 0.10185912f, 
    -0.04402129f, -0.17482936f, 0.10566906f, -0.08390538f, -0.11793071f, -0.08403421f, 0.02711177f, -0.05277081f, 
    -0.39955524f, -0.38567364f, -0.10372239f, -0.19382489f, -0.09956446f, -0.06163733f, 0.04776477f, 0.03337966f, 
    0.00522570f, -0.07110204f, -0.14092703f, -0.01321403f, 0.05150309f, 0.02063715f, 0.07013549f, -0.02235969f, 
    -0.05305233f, -0.06228067f, -0.01426294f, 0.13976490f, 0.28328556f, 0.06329802f, 0.18672118f, 0.18373488f, 
    0.12679265f, -0.04774460f, 0.09668321f, -0.00873379f, -0.04691322f, -0.00285839f, 0.00769884f, 0.02553263f, 
    -0.14568979f, -0.23159911f, 0.02512529f, -0.04579906f, 0.09099940f, -0.01637194f, 0.08512668f, -0.03753677f, 
    0.16590209f, 0.00104619f, 0.04032780f, 0.04480441f, 0.09369837f, 0.05217791f, -0.09038072f, -0.15861315f, 
    0.09143544f, 0.03039472f, -0.01727802f, 0.10203034f, -0.04742050f, -0.02054544f, -0.01785867f, -0.02906377f, 
    -0.10802995f, 0.01277557f, 0.07991234f, -0.15593411f, -0.06931869f, 0.30296031f, 0.07923880f, 0.16179407f, 
    0.00891456f, 0.01509496f, 0.04005047f, 0.00057733f, -0.08204871f, 0.01152361f, -0.02206381f, -0.05712784f, 
    0.02441292f, -0.03230339f, -0.09359173f, 0.09441356f, 0.00157493f, 0.14441861f, 0.17898043f, 0.10546210f, 
    0.29102677f, -0.39550930f, -0.25414497f, 0.21567142f, 0.01619847f, -0.01136448f, -0.12238886f, 0.01132025f, 
    -0.01834947f, -0.05671556f, -0.01011939f, -0.07211985f, -0.05988430f, 0.06924987f, -0.09131570f, -0.05800428f, 
    0.10598513f, 0.09428207f, -0.00256477f, -0.06439987f, -0.17577761f, -0.11077095f, -0.09136052f, -0.15563659f, 
    -0.11076184f, -0.05869138f, -0.18726496f, 0.04491175f, 0.03403167f, 0.00202719f, -0.09038432f, -0.02089283f, 
    -0.02030879f, -0.05785895f, 0.00426278f, -0.04329891f, -0.02439142f, -0.05550314f, 0.02721659f, 0.04762549f, 
    0.33089942f, 0.16120532f, -0.19132416f, 0.20486031f, 0.11033186f, 0.10650682f, 0.10135642f, 0.07172912f, 
    0.07139575f, 0.08402216f, 0.00574018f, -0.01142449f, -0.08789013f, -0.12875384f, -0.06228580f, -0.10193922f, 
    -0.00171026f, 0.08699621f, 0.01080496f, -0.03524989f, 0.15231486f, -0.07758894f, 0.03167441f, 0.02527540f, 
    0.02461236f, -0.13500611f, -0.09311775f, -0.02289573f, -0.09563978f, -0.00820853f, -0.09123659f, -0.01443708f, 
    -0.02360851f, -0.03382293f, 0.09697149f, 0.00372526f, 0.06465571f, 0.13512906f, 0.02950740f, -0.00205113f, 
    0.51275712f, 0.23300989f, -0.12577091f, -0.01513174f, 0.05384164f, 0.02711784f, -0.00560859f, -0.03414281f, 
    0.03061960f, 0.08122317f, -0.12094411f, -0.05579543f, -0.01586064f, 0.12544365f, -0.12685323f, 0.02538519f, 
    0.02398635f, -0.00774754f, 0.19578953f, 0.19994555f, -0.32456037f, 0.04559821f, -0.27438217f, 0.15754226f, 
    0.24124692f, 0.10821909f, 0.00510497f, 0.09895544f, -0.08463779f, 0.01971276f, 0.05421046f, 0.04795286f, 
    -0.05656618f, -0.06346036f, -0.09596258f, 0.11608785f, -0.05535577f, 0.03860083f, 0.03460426f, -0.01012748f, 
    -0.37269652f, -0.13284716f, 0.06564435f, 0.08714060f, 0.24152875f, 0.05600576f, -0.16721846f, -0.02352070f, 
    -0.11187329f, 0.08234243f, -0.08022776f, -0.07998445f, 0.08550788f, 0.11831564f, -0.06578860f, -0.06785437f, 
    0.06607358f, 0.13210680f, 0.08685812f, -0.25915092f, -0.36246532f, 0.21519589f, -0.38966036f, -0.01890916f, 
    0.05375042f, 0.13150573f, -0.09450447f, 0.10637282f, 0.17226563f, -0.09576535f, 0.00491214f, -0.05042322f, 
    -0.13250172f, 0.07150649f, 0.07018081f, 0.10067867f, 0.09756731f, -0.00917628f, -0.04148840f, -0.14191625f, 
    -0.15830201f, 0.11997861f, -0.05218598f, -0.12167633f, 0.09426342f, 0.04913700f, -0.08365764f, 0.00487588f, 
    0.04782660f, -0.03981779f, 0.02148143f, -0.13075648f, -0.10849164f, -0.09904564f, -0.06329334f, -0.03791659f, 
    -0.10961661f, 0.01417514f, -0.12431764f, 0.07747015f, 0.38657194f, -0.07318109f, -0.26922905f, -0.14875218f, 
    -0.48651794f, -0.00932956f, 0.02357627f, 0.02127779f, 0.03358582f, 0.03241839f, -0.14286247f, 0.03361034f, 
    0.03523408f, -0.01318510f, 0.00836874f, 0.05370709f, 0.03599700f, 0.03793284f, -0.08606542f, -0.03130384f, 
    0.21924520f, 0.34869140f, 0.03565757f, -0.10654738f, -0.23589736f, -0.19218063f, -0.10562628f, 0.03306923f, 
    -0.00243613f, -0.04204643f, -0.03820964f, 0.00001700f, -0.06934193f, 0.03810611f, 0.03553301f, 0.06699190f, 
    0.00314025f, -0.06647978f, -0.03972073f, -0.03925102f, -0.02662642f, 0.22063021f, -0.16418533f, 0.11887497f, 
    0.14491852f, 0.05516916f, 0.00691155f, -0.03050623f, -0.03624919f, -0.03893433f, 0.05604414f, 0.13283364f, 
    -0.00559519f, -0.10738806f, -0.07375262f, -0.01014725f, -0.10526395f, -0.05544356f, 0.01231994f, -0.04404465f, 
    -0.14763147f, -0.11548174f, -0.01652665f, -0.12504579f, 0.15353784f, 0.01875448f, -0.03779908f, 0.00865439f, 
    -0.00162154f, 0.10326765f, -0.08518751f, 0.15343677f, -0.04461099f, -0.06385211f, -0.18461327f, -0.11290170f, 
    0.09498775f, -0.10919106f, 0.03624114f, -0.01902272f, 0.13228413f, -0.17851460f, -0.18961719f, 0.00037517f, 
    0.24291258f, 0.02905929f, 0.04895058f, 0.05879906f, 0.14344677f, 0.15557538f, 0.09851314f, -0.06773954f, 
    0.05795011f, 0.01334580f, 0.08027812f, -0.06597242f, -0.03055773f, 0.06972915f, 0.16389202f, 0.01901481f, 
    -0.02357766f, 0.00572430f, -0.29110238f, 0.00854309f, -0.09789238f, -0.01073574f, -0.13681817f, -0.04800988f, 
    -0.13770474f, -0.10845640f, -0.02084437f, -0.11491548f, -0.01554239f, 0.01753235f, 0.01074895f, -0.00897390f, 
    -0.05005233f, 0.04555321f, -0.02923392f, -0.04159508f, 0.37642562f, 0.32363144f, -0.18679672f, -0.13552445f, 
    0.02848501f, -0.07472452f, 0.01767633f, 0.15686898f, 0.12296017f, 0.02094295f, -0.04060267f, 0.00671683f, 
    0.01743550f, 0.05829375f, -0.01128530f, 0.03197439f, 0.03863040f, 0.01466080f, -0.11496840f, 0.07718641f, 
    -0.94996488f, 0.22852580f, 0.05302848f, 0.06030019f, 0.20270976f, 0.07663351f, 0.01373897f, -0.02104088f, 
    0.06311853f, 0.06571269f, -0.12126076f, 0.00026393f, 0.09681179f, 0.07803237f, 0.09670681f, -0.02464049f, 
    0.14663778f, 0.07892144f, 0.11612595f, -0.16960715f, 0.19256310f, -0.07729694f, 0.01364279f, 0.08022825f, 
    0.10256732f, -0.17953186f, -0.01297947f, 0.04544043f, 0.03498182f, -0.14891373f, -0.01527259f, 0.02240666f, 
    -0.09163099f, 0.02662040f, 0.00352270f, -0.13726166f, -0.05140568f, 0.00655896f, 0.01648740f, -0.06805079f, 
    -0.44610038f, -0.06112407f, -0.13894036f, 0.28760764f, 0.04388434f, -0.01202971f, -0.07945912f, 0.06841968f, 
    0.06890946f, 0.00379518f, 0.06224568f, -0.04599839f, -0.07868417f, 0.02287491f, -0.00499337f, -0.00428647f, 
    -0.05075761f, -0.02645279f, 0.04354386f, 0.14431605f, -0.57112843f, -0.20141660f, 0.25001508f, 0.17111097f, 
    -0.04430470f, -0.12692927f, -0.01785486f, 0.08620998f, -0.16758035f, -0.03486621f, 0.05526315f, -0.01847602f, 
    -0.01338593f, -0.18972509f, 0.02450676f, 0.07180250f, -0.05824496f, 0.01030738f, 0.02152535f, -0.03322803f, 
    0.20402122f, -0.02223706f, -0.06973177f, 0.11779784f, -0.18539281f, -0.05621347f, -0.01384488f, -0.04686698f, 
    -0.07423478f, -0.17401472f, 0.18913959f, 0.09302284f, 0.03119671f, -0.00274324f, 0.00128372f, -0.10484222f, 
    0.16073714f, 0.02570070f, 0.12406707f, 0.01336154f, 0.01436488f, -0.44925013f, 0.24631779f, -0.02547267f, 
    0.04180485f, -0.25319853f, -0.02570097f, -0.03448969f, -0.00700517f, 0.06067190f, 0.09032258f, 0.10155857f, 
    0.00134487f, 0.04049312f, 0.02721603f, -0.20674469f, 0.02628569f, -0.13269520f, 0.00033386f, 0.02299052f, 
    0.05259423f, -0.13892896f, -0.01719623f, 0.19423549f, 0.10401045f, 0.04984650f, 0.08322102f, 0.02048638f, 
    0.06036263f, 0.04563285f, 0.09773904f, 0.03055062f, 0.00146177f, 0.05940038f, 0.09386091f, -0.03268600f, 
    -0.07167710f, 0.09203876f, 0.18210317f, 0.05553784f, -0.16929004f, -0.16890182f, 0.21951191f, 0.01786822f, 
    0.08699854f, -0.06782627f, 0.09162677f, -0.14340121f, 0.00064367f, 0.05579181f, 0.15598670f, 0.09399084f, 
    -0.00877053f, -0.00131905f, -0.04618264f, -0.09833512f, -0.01904680f, -0.08595659f, 0.01784174f, -0.07840024f, 
    -0.24169539f, 0.22742224f, 0.03043479f, -0.15683356f, -0.25242490f, 0.02459341f, -0.03238438f, 0.00361238f, 
    0.02114417f, -0.13995196f, 0.02192617f, -0.05787224f, -0.00107879f, -0.07318524f, 0.07158810f, 0.08841114f, 
    -0.02693770f, -0.01868626f, 0.02214223f, 0.08362879f, -0.11300904f, 0.13704310f, 0.16732778f, -0.03442486f, 
    0.08694878f, 0.22044675f, 0.07298119f, 0.05017868f, -0.04666382f, 0.02813953f, 0.07701198f, 0.08713184f, 
    -0.03899011f, 0.07025924f, -0.11730146f, -0.00029328f, -0.00683464f, 0.02738304f, 0.02204119f, -0.10760815f, 
    -0.06067816f, 0.28703430f, -0.05946459f, 0.08684918f, -0.15906152f, 0.09519692f, -0.05107616f, 0.11715761f, 
    -0.18847512f, -0.05317960f, 0.02217539f, 0.05603852f, -0.04498349f, 0.01373451f, 0.04915527f, 0.11896639f, 
    -0.17203270f, -0.14846870f, -0.18033962f, 0.02183693f, -0.28435239f, -0.25014439f, 0.16457118f, -0.02637652f, 
    0.02514969f, -0.12169591f, -0.01574215f, 0.13479023f, 0.02105251f, 0.06675225f, 0.12374827f, -0.06168463f, 
    -0.01376873f, -0.04840513f, 0.05069966f, 0.12044789f, -0.04419366f, -0.05250361f, -0.01870507f, -0.00461684f, 
    0.05708336f, -0.04140991f, 0.14786251f, -0.07119840f, -0.00935379f, -0.05749850f, -0.01591795f, 0.05743968f, 
    0.04589488f, 0.08132645f, 0.04981312f, -0.08632736f, 0.06772859f, -0.00282777f, 0.06697257f, 0.03727239f, 
    0.06931857f, -0.07035889f, -0.00978843f, 0.01238811f, -0.00919148f, 0.10868342f, -0.35551414f, 0.06773496f, 
    -0.16652372f, -0.08968111f, -0.09041503f, 0.15655260f, 0.03620619f, -0.09092503f, -0.11922921f, 0.03038342f, 
    0.07770789f, -0.06506413f, 0.04426893f, -0.08924755f, 0.01405200f, 0.16716500f, -0.13054112f, 0.13202818f, 
    -0.02318397f, -0.01805921f, 0.09514837f, -0.32582682f, -0.10787946f, -0.06600876f, 0.07511692f, -0.13456811f, 
    0.07747952f, -0.15955006f, 0.10702170f, -0.12041204f, -0.04825278f, 0.10078266f, -0.05435143f, 0.05613719f, 
    0.00714455f, -0.02786204f, 0.04882183f, 0.10442221f, -0.04225315f, -0.20966794f, 0.24025542f, 0.18934417f, 
    -0.04376370f, 0.06605460f, 0.12713599f, 0.04543908f, 0.01768334f, -0.00706288f, 0.16163914f, 0.05763436f, 
    -0.02644961f, -0.00522660f, 0.05226571f, -0.00163745f, -0.05673638f, 0.01952710f, -0.04217071f, 0.05445626f, 
    -0.10070126f, 0.21979997f, 0.09521902f, -0.15905726f, -0.00093265f, -0.04112866f, 0.12483315f, -0.20100521f, 
    0.10486794f, 0.04586614f, -0.06011568f, -0.11288401f, 0.00170226f, 0.12262969f, -0.09846086f, -0.16420861f, 
    0.11314302f, -0.03363325f, -0.10150760f, -0.02321567f, -0.55398315f, 0.02272516f, -0.19131312f, 0.01039939f, 
    0.14426558f, 0.08024533f, -0.03506406f, 0.14864445f, -0.01127110f, 0.05885816f, -0.01193839f, -0.01298233f, 
    0.00254647f, -0.00782640f, 0.06594054f, 0.06963725f, 0.12203974f, 0.08603406f, 0.08158393f, -0.02629191f, 
    -0.17376408f, -0.37219846f, 0.01853891f, 0.05403359f, -0.15553677f, -0.11172667f, -0.00979816f, -0.12588525f, 
    -0.11531955f, -0.15550192f, -0.14356160f, 0.00483586f, -0.00051469f, 0.05925320f, 0.08834878f, -0.13831033f, 
    -0.03158412f, 0.15514548f, -0.09184766f, 0.08974509f, -0.01867382f, -0.01003849f, -0.08426022f, 0.13554914f, 
    0.10682515f, 0.12657952f, 0.02455517f, -0.01492018f, 0.10075872f, 0.11211071f, 0.05674970f, 0.07282347f, 
    -0.02027002f, -0.05238922f, 0.05924021f, 0.01852256f, -0.02241899f, -0.01076857f, 0.13631123f, -0.08639708f, 
    -0.00990281f, 0.17215078f, 0.10895707f, -0.14614531f, -0.26903018f, 0.12191913f, 0.09643484f, 0.10261940f, 
    -0.07821947f, -0.04365249f, -0.00374042f, 0.03242066f, -0.09666925f, 0.03353263f, 0.01612255f, -0.04548948f, 
    0.23179232f, -0.09633870f, 0.01490205f, 0.05804208f, -0.24193512f, -0.29244238f, 0.22537807f, 0.29607135f, 
    -0.05275022f, -0.15471698f, 0.02286886f, 0.02070727f, -0.09094609f, -0.03768096f, 0.09173191f, 0.01443765f, 
    0.09014654f, -0.05430305f, -0.04391922f, 0.10286691f, -0.11784508f, 0.08317542f, 0.01254224f, 0.00473719f, 
    -0.30360627f, 0.10253802f, -0.23888539f, -0.17112172f, 0.01584709f, 0.09878388f, 0.19357127f, 0.13578863f, 
    -0.06590629f, -0.09998098f, 0.24588130f, 0.01377841f, -0.17256476f, -0.10398821f, -0.12959310f, -0.00163296f, 
    -0.05205309f, -0.01964901f, -0.00621903f, 0.00572083f, -0.36048260f, 0.13619278f, 0.14972948f, 0.10950302f, 
    -0.08007518f, -0.05465817f, 0.05495810f, -0.03298918f, -0.13099404f, -0.15485533f, 0.07916245f, -0.09296368f, 
    0.02440254f, -0.05288906f, -0.09179329f, -0.00754173f, -0.02846780f, 0.02485340f, 0.13433114f, 0.02240461f, 
    -0.40390784f, -0.28719747f, -0.31088695f, 0.15627483f, -0.02905476f, 0.02472478f, 0.03524241f, 0.06318963f, 
    0.07787156f, -0.06729816f, 0.05693989f, 0.19766191f, 0.06825113f, 0.02989865f, -0.01529193f, 0.21653560f, 
    -0.02114457f, 0.07830648f, 0.00123098f, -0.08178455f, -0.04656729f, 0.11435968f, -0.03454243f, 0.01357408f, 
    0.20084366f, 0.05668928f, -0.16269058f, 0.00170574f, -0.13173020f, 0.10942364f, -0.03638522f, 0.00736087f, 
    -0.01703602f, 0.00569274f, 0.01989289f, 0.06589552f, 0.01890607f, -0.03964189f, 0.02289253f, 0.06482683f, 
    -0.10560236f, -0.15989083f, -0.15677047f, 0.00628522f, -0.35297036f, 0.14553992f, -0.06401929f, 0.00684525f, 
    0.10943308f, -0.08486983f, 0.06777681f, -0.04514784f, -0.08701195f, 0.07885382f, 0.01603027f, -0.07652958f, 
    -0.09707418f, 0.08829002f, -0.02245713f, -0.02298325f, -0.47674754f, -0.25669134f, -0.05850087f, -0.17768283f, 
    0.02945858f, 0.12706013f, 0.08346883f, -0.04492914f, 0.04999416f, -0.09298652f, -0.01583927f, 0.04097877f, 
    -0.03581302f, 0.05325414f, -0.07248073f, 0.08188535f, 0.10095390f, -0.01328349f, -0.10445827f, 0.07815256f, 
    -0.31967971f, -0.06602486f, -0.19460881f, -0.25749755f, -0.18503223f, 0.09388602f, -0.07447059f, 0.07667385f, 
    0.05828528f, 0.00718156f, -0.00171090f, 0.02083189f, 0.04326486f, -0.01614087f, -0.01039002f, 0.05968341f, 
    -0.17850155f, 0.08121328f, -0.25636506f, 0.00447748f, -0.28680226f, 0.29930481f, 0.03671279f, -0.22772650f, 
    0.00420796f, 0.12856008f, 0.16464823f, 0.19838998f, -0.20530878f, 0.06392051f, -0.04837774f, 0.02565118f, 
    -0.03972538f, -0.07169529f, -0.05868756f, 0.07822289f, -0.06373654f, -0.03570757f, 0.01333635f, -0.08508717f, 
    -0.06186319f, 0.00197380f, 0.14594771f, 0.00571304f, -0.10525791f, -0.04207920f, -0.00228158f, -0.04694456f, 
    0.11779695f, 0.10486479f, 0.02174849f, 0.06713476f, 0.08717419f, -0.10657942f, -0.06122591f, 0.12364645f, 
    0.04980746f, -0.16928931f, 0.01445676f, 0.09777144f, -0.18580309f, -0.07631799f, 0.23494299f, 0.20791616f, 
    -0.46332926f, 0.08231935f, -0.04034625f, -0.06257103f, -0.02319933f, 0.00250890f, -0.03927642f, 0.06905560f, 
    -0.10052770f, -0.00045926f, 0.00468002f, -0.07221232f, 0.00635889f, 0.15454574f, 0.10690973f, -0.10983643f, 
    -0.30909550f, 0.39087021f, -0.15304092f, -0.11976229f, -0.12614533f, 0.07235369f, 0.00769623f, 0.01222666f, 
    -0.08142930f, -0.21853946f, -0.02166471f, -0.05243515f, -0.17705366f, -0.04564463f, -0.04444734f, 0.04211044f, 
    -0.02487830f, -0.01133001f, 0.21063022f, 0.02985488f, 0.18399172f, -0.15991662f, -0.01011028f, 0.14086446f, 
    -0.09118678f, 0.03847996f, -0.03370312f, -0.00733462f, 0.07865688f, 0.06213193f, -0.05488825f, -0.15379879f, 
    -0.04695516f, 0.10752030f, 0.07242077f, 0.04893788f, 0.10164328f, -0.01167983f, -0.18066172f, 0.00589302f, 
    -0.19141443f, 0.13659586f, -0.29182333f, -0.10454302f, -0.05004803f, 0.09507088f, 0.02482260f, 0.00696680f, 
    0.02543639f, 0.13531116f, 0.07317445f, 0.22656456f, 0.14929681f, -0.14858182f, -0.04771513f, -0.05249367f, 
    -0.03380548f, -0.03929387f, 0.14789613f, -0.17890602f, 0.15253168f, 0.02336770f, -0.04063235f, -0.08856539f, 
    0.05195571f, -0.10623263f, -0.00640009f, 0.00084830f, 0.10480764f, -0.00414059f, -0.12094976f, -0.03168761f, 
    0.03646147f, 0.05921196f, 0.26741013f, -0.11469634f, 0.00886650f, 0.06462730f, -0.03422864f, 0.08389586f, 
    0.00986284f, -0.08217257f, -0.01081431f, 0.01465089f, 0.32837236f, -0.15767071f, -0.20194578f, 0.06430434f, 
    -0.02373934f, 0.10842296f, -0.08428725f, -0.16597098f, 0.07814187f, 0.11932155f, -0.08039417f, 0.03975057f, 
    -0.18320255f, -0.12462185f, -0.09414230f, 0.09358273f, 0.09460196f, 0.11188481f, 0.09875724f, 0.07750554f, 
    0.07727640f, -0.01590203f, -0.01030300f, 0.11108063f, -0.07713529f, 0.04757346f, 0.09172154f, -0.25124437f, 
    -0.06116756f, -0.07173865f, -0.01901444f, 0.11942083f, -0.04460644f, 0.06851684f, 0.02317796f, 0.14782365f, 
    0.02863424f, 0.16515015f, -0.09333336f, -0.02734048f, 0.24453838f, -0.03703421f, -0.06793229f, 0.09273341f, 
    0.08334941f, 0.08423331f, 0.05953050f, -0.00366908f, -0.01187738f, 0.04069415f, 0.20983295f, -0.20050614f, 
    -0.07329860f, -0.00041482f, -0.29874200f, -0.12491195f, 0.09097800f, 0.01380089f, 0.03436394f, 0.26218960f, 
    -0.13088350f, -0.00846906f, 0.07902373f, 0.08086861f, -0.00408227f, -0.01538272f, 0.04564844f, -0.11892007f, 
    0.00247860f, 0.07582520f, 0.12514651f, 0.03420853f, -0.00160807f, 0.18855432f, 0.01555441f, -0.05700204f, 
    -0.34129608f, -0.09862973f, 0.01190713f, 0.09972434f, 0.06900546f, 0.05698934f, 0.00368686f, -0.03054662f, 
    0.02094141f, 0.06267050f, 0.05952239f, -0.06442329f, 0.01529474f, -0.00728681f, 0.03741837f, -0.18948647f, 
    0.01514397f, -0.00431464f, -0.16809846f, -0.20123124f, -0.34837618f, -0.19443794f, -0.15512903f, -0.10411003f, 
    0.04476142f, 0.07018873f, -0.02138472f, 0.08598380f, 0.05866653f, 0.02033454f, 0.04878316f, 0.15071531f, 
    0.10324049f, 0.14984602f, 0.03050474f, -0.05895023f, -0.05112615f, -0.20652117f, -0.15426721f, 0.11974823f, 
    -0.23840792f, -0.04332425f, 0.07810385f, -0.07155023f, 0.06352834f, 0.02526128f, -0.01130745f, 0.01291427f, 
    -0.05076640f, 0.05085498f, 0.10680041f, 0.02540676f, 0.08907612f, -0.02348447f, 0.04118234f, -0.04633168f, 
    0.06427285f, 0.05997555f, 0.12337259f, -0.08596921f, 0.06822833f, 0.03343229f, 0.01701144f, 0.07714979f, 
    -0.14191529f, -0.08483690f, 0.10417894f, -0.09145559f, 0.03701530f, 0.03391729f, -0.08171073f, -0.07346519f, 
    0.13996938f, -0.00311603f, 0.14619873f, -0.03452445f, 0.01574270f, 0.13967142f, 0.00169348f, 0.01067140f, 
    0.24187165f, 0.02025967f, 0.11572866f, -0.05513969f, -0.01118469f, -0.08422077f, 0.04441358f, -0.11523296f, 
    -0.02970785f, 0.10520235f, 0.03302887f, 0.07938037f, 0.09832105f, 0.07492182f, 0.01939063f, 0.01067061f, 
    -0.06061334f, 0.21894318f, 0.09095217f, 0.03539222f, -0.15005760f, -0.08068866f, 0.07794335f, -0.00324123f, 
    0.14184840f, -0.03699871f, -0.08599056f, -0.35137627f, 0.01585390f, 0.05064084f, 0.04840936f, -0.01294699f, 
    0.08640820f, 0.03669621f, 0.01098601f, 0.06918000f, 0.14293164f, -0.08897094f, -0.21048263f, 0.05889387f, 
    -0.31500077f, 0.10871112f, -0.22034714f, -0.02080113f, 0.00431791f, -0.04534751f, 0.11215476f, -0.07448579f, 
    -0.14601682f, 0.03935245f, -0.00328686f, 0.23327397f, 0.09744971f, -0.07290858f, 0.23902728f, -0.03192263f, 
    0.09374437f, -0.07820818f, 0.13649741f, -0.13053513f, 0.23482138f, 0.17165127f, 0.10713897f, 0.16824047f, 
    -0.09436107f, 0.09428902f, -0.07674900f, -0.12015626f, -0.14845565f, 0.14499232f, 0.01569032f, 0.08476476f, 
    0.06598037f, 0.05344211f, -0.01937240f, -0.06359884f, -0.05346151f, -0.17999817f, -0.18319479f, 0.06524070f, 
    0.02543513f, -0.18366084f, 0.11096624f, 0.21753944f, 0.04084739f, -0.00884793f, -0.02155811f, 0.10292656f, 
    -0.02331062f, -0.07747420f, -0.00084698f, 0.04741206f, -0.03615139f, -0.06895104f, 0.12054238f, 0.01250468f, 
    0.01415684f, -0.00945876f, 0.15544061f, -0.06894535f, -0.31993344f, 0.19265953f, -0.09724046f, -0.11902424f, 
    -0.05910514f, -0.02885733f, 0.00548125f, 0.03640544f, -0.08851860f, -0.21702757f, 0.07097669f, -0.07068797f, 
    0.04539207f, -0.10918596f, 0.03543294f, 0.06761623f, 0.09647891f, -0.12197431f, 0.05252354f, 0.04540212f, 
    -0.01234721f, 0.01487141f, 0.08605549f, 0.34781772f, -0.05066772f, -0.16587414f, 0.02820253f, 0.01667280f, 
    0.07916923f, 0.18974285f, -0.07000174f, -0.23649503f, -0.13584138f, 0.18522114f, -0.03873635f, 0.07291832f, 
    0.14578423f, -0.25815105f, -0.09070694f, -0.05572323f, -0.50849372f, -0.19908997f, -0.29591480f, -0.16467732f, 
    0.01701035f, 0.04510210f, 0.17668723f, 0.01540197f, -0.02168434f, -0.01677410f, -0.04837504f, 0.10817108f, 
    -0.01976905f, 0.01717726f, -0.13177139f, -0.04450493f, 0.05231979f, 0.00710205f, -0.14979288f, 0.11237638f, 
    -0.05301698f, -0.08264988f, 0.44109046f, 0.34257010f, -0.22293374f, -0.17539330f, -0.08569182f, -0.01986592f, 
    -0.04404869f, 0.14586924f, -0.02973245f, 0.11285474f, 0.07242134f, -0.03649939f, -0.12368338f, -0.10372175f, 
    -0.13839984f, -0.18120268f, 0.06268754f, -0.04751190f, 0.07478566f, 0.06152518f, 0.01684424f, -0.02342728f, 
    0.11046541f, -0.11627603f, -0.00175537f, 0.04456354f, 0.01212627f, 0.11787853f, -0.13412753f, -0.03514348f, 
    0.12599093f, 0.14770162f, 0.09761793f, -0.10724809f, -0.00491907f, -0.04513353f, -0.06696054f, -0.10513121f, 
    -0.43203276f, -0.34100604f, -0.10968436f, -0.15081003f, 0.04512776f, 0.03170870f, -0.10348684f, 0.06899089f, 
    -0.10374137f, -0.09332962f, -0.10256238f, -0.07476567f, 0.07525445f, 0.13773912f, 0.00651477f, 0.09077392f, 
    -0.06384063f, -0.06793649f, -0.04871409f, 0.13847303f, 0.34702510f, -0.77943146f, -0.17580007f, 0.10896764f, 
    -0.08300643f, -0.03263559f, 0.03785787f, 0.02288381f, -0.01503892f, 0.15289588f, -0.09633022f, 0.01344777f, 
    0.01906074f, 0.10866100f, 0.04740931f, -0.02718706f, 0.04067504f, 0.05789432f, -0.27498373f, 0.00040214f, 
    -0.12856588f, -0.26003498f, -0.02775263f, -0.29624298f, 0.10015278f, -0.03108572f, 0.07099050f, 0.09961364f, 
    -0.11542493f, 0.01264852f, -0.19692121f, 0.07384021f, -0.07643557f, 0.00332422f, 0.01681036f, -0.17512862f, 
    -0.11246310f, 0.05909709f, 0.02339434f, 0.06348921f, -0.26272458f, 0.00906343f, -0.25880054f, 0.40111512f, 
    -0.02829682f, 0.01783746f, 0.09860986f, -0.02414028f, 0.08537738f, -0.00775481f, -0.01537513f, -0.01065465f, 
    -0.01725595f, -0.02027240f, -0.18303777f, 0.07038957f, -0.04175735f, 0.02366561f, -0.10240625f, 0.03108843f, 
    0.26498815f, -0.53345156f, -0.03878870f, 0.18166544f, 0.11076967f, 0.07702857f, 0.02567367f, 0.03192372f, 
    -0.14529729f, -0.03701947f, -0.11438563f, 0.01488475f, 0.03571586f, 0.02505543f, 0.05061761f, 0.03122498f, 
    0.03211200f, 0.16264650f, 0.14951165f, -0.06146546f, -0.14474893f, -0.21628948f, 0.04021650f, -0.28591672f, 
    0.00704226f, -0.02792291f, -0.01560457f, -0.01112278f, -0.02373256f, 0.08711459f, 0.00892734f, 0.01874593f, 
    -0.13649951f, 0.09345548f, 0.01286201f, -0.08904162f, -0.07289184f, -0.02482508f, 0.14205445f, -0.07996339f, 
    0.35758314f, -0.06648102f, 0.15719710f, 0.06796297f, -0.10472284f, -0.09601833f, 0.05222896f, 0.04023667f, 
    -0.06480294f, -0.02310750f, 0.01830021f, -0.10666709f, 0.00484412f, -0.03732464f, 0.15338324f, -0.05047124f, 
    0.05427153f, 0.06209128f, 0.06524488f, 0.05940991f, -0.06816611f, -0.13642025f, 0.05657785f, -0.23618189f, 
    0.06380277f, -0.13434650f, -0.12455266f, -0.13413523f, -0.03565994f, -0.10557979f, 0.00458193f, 0.01583450f, 
    -0.06586888f, 0.13485014f, 0.05362267f, 0.10633481f, 0.02292610f, -0.03868700f, 0.01580874f, -0.01018146f, 
    0.03071371f, -0.27005607f, -0.06832149f, 0.02406868f, 0.16432481f, 0.06777500f, 0.11149063f, 0.04787536f, 
    0.00857834f, 0.03145942f, -0.10828760f, -0.06981862f, -0.03124475f, -0.09536152f, 0.05147954f, -0.09020993f, 
    -0.02906350f, 0.08549924f, 0.00737773f, -0.08580742f, 0.18747929f, -0.01248410f, -0.01964899f, 0.13498868f, 
    -0.05508143f, -0.01814005f, -0.06532285f, 0.06786885f, 0.06170920f, 0.12772121f, 0.09733804f, -0.07134390f, 
    -0.00587889f, -0.09842384f, 0.02983845f, -0.04877121f, -0.06304615f, -0.08332419f, -0.00123890f, -0.09002486f, 
    0.46941540f, -0.43962690f, 0.05794620f, -0.17424199f, 0.14562705f, 0.02985874f, 0.00109160f, 0.01405265f, 
    -0.00414510f, -0.03558854f, 0.03962905f, 0.03629007f, 0.21745020f, 0.00474532f, -0.04458757f, 0.00862954f, 
    -0.03112864f, -0.01609942f, -0.18859053f, 0.10715653f, 0.06580673f, 0.04758621f, 0.09823021f, -0.26166174f, 
    0.08494118f, 0.03304698f, -0.05641357f, 0.01923941f, 0.00817299f, 0.08627051f, 0.15217601f, 0.05423069f, 
    -0.03672760f, -0.09677054f, -0.06797624f, -0.04400597f, -0.06419497f, -0.05847199f, 0.14630529f, -0.08709596f, 
    -0.14478172f, -0.09369209f, -0.23325630f, -0.57705659f, 0.28602669f, -0.17643169f, -0.14399014f, -0.00620848f, 
    0.00726878f, -0.15198094f, -0.04884166f, -0.09290475f, -0.11103454f, 0.05307783f, -0.00545741f, -0.01821453f, 
    0.08409067f, 0.11894976f, -0.05254270f, 0.05836881f, 0.09272612f, 0.18886961f, 0.19685130f, 0.00792612f, 
    -0.13940825f, 0.17978714f, 0.03132325f, -0.00005521f, -0.04650944f, 0.00982104f, -0.09397228f, 0.02292236f, 
    -0.08681103f, 0.09237901f, -0.05614765f, 0.03114303f, -0.04181894f, 0.02703194f, -0.00837917f, 0.02567462f, 
    -0.09677459f, 0.01798211f, -0.09383601f, -0.00790221f, -0.10503432f, 0.10971265f, 0.20500328f, -0.06738412f, 
    0.04854450f, 0.11098135f, -0.05191333f, -0.08163969f, 0.07681146f, 0.04267101f, -0.14686753f, 0.14428188f, 
    0.05127281f, 0.07436857f, 0.03744358f, 0.01664051f, -0.17352553f, 0.17868896f, 0.15175855f, 0.19452643f, 
    0.04358692f, -0.04203498f, 0.05106458f, -0.20709397f, 0.02874638f, 0.03865258f, -0.25679725f, 0.11752805f, 
    0.10424098f, 0.00489561f, -0.08621679f, -0.02610556f, 0.21698801f, -0.08737935f, -0.04410157f, -0.30311739f, 
    -0.04657995f, 0.13677928f, -0.31792763f, -0.38283628f, -0.02873083f, 0.04911854f, 0.01997030f, 0.10105920f, 
    -0.21046761f, -0.01371373f, -0.05001391f, -0.00685580f, -0.12943609f, -0.13186806f, 0.00538101f, 0.04784811f, 
    -0.04293425f, 0.03335343f, 0.13405582f, 0.11820202f, -0.35866976f, 0.41654405f, 0.03627480f, 0.16165788f, 
    -0.23187071f, 0.04015625f, -0.00194985f, 0.00126726f, 0.05844005f, 0.03174637f, -0.08821417f, 0.14100893f, 
    -0.01157052f, -0.05509497f, -0.05593738f, 0.00628561f, 0.05130069f, 0.03115627f, 0.06121124f, 0.01680569f, 
    0.50066149f, 0.18396398f, 0.00822479f, -0.05858885f, 0.26205620f, -0.01917643f, -0.03526777f, 0.02089762f, 
    0.03488421f, -0.12315644f, -0.09791277f, -0.07773045f, 0.03636336f, 0.08927727f, -0.04182106f, 0.12330498f, 
    0.02726739f, 0.00445678f, 0.07300158f, 0.08586598f, -0.09243447f, -0.09358753f, 0.01330599f, 0.22199729f, 
    0.02402144f, -0.00156889f, -0.03974547f, 0.06190716f, -0.10553604f, -0.06687833f, 0.06679663f, -0.06266493f, 
    -0.06287116f, -0.07852624f, 0.05521910f, -0.09924356f, -0.02005376f, 0.05245004f, -0.01993717f, -0.03396013f, 
    -0.15394111f, -0.55892897f, -0.00767882f, -0.11776789f, 0.31348222f, -0.05340549f, 0.06687706f, 0.02174219f, 
    0.17042015f, 0.01317370f, -0.09336395f, -0.05424113f, -0.11824416f, 0.02033361f, -0.04585281f, -0.09077557f, 
    -0.10300276f, 0.02604682f, -0.25509214f, -0.04336053f, -0.20597449f, 0.29380023f, 0.02536708f, 0.13334179f, 
    -0.23810662f, 0.09977301f, -0.10873895f, -0.03985296f, 0.01048025f, -0.01165185f, 0.04339512f, 0.03777588f, 
    -0.01776557f, 0.02645848f, -0.15986468f, -0.00502029f, 0.04876135f, -0.06241535f, -0.02136190f, -0.04341786f, 
    -0.36073357f, 0.11604670f, 0.04303430f, 0.11098039f, -0.03155601f, 0.10416984f, -0.14405404f, 0.00870679f, 
    0.03971289f, -0.13304636f, -0.10826414f, -0.04245647f, -0.07284103f, 0.05409581f, -0.00605817f, 0.04174943f, 
    0.04097679f, -0.27800146f, -0.04207652f, -0.17956693f, 0.00038036f, -0.06186115f, -0.45249745f, -0.19663736f, 
    0.14970431f, 0.07180517f, 0.06148876f, 0.13098669f, -0.09847312f, 0.03801972f, 0.03548418f, -0.07384738f, 
    -0.07778636f, -0.04237374f, -0.04275630f, -0.04594428f, 0.05917095f, -0.03371093f, 0.27044314f, 0.11770205f, 
    0.17690772f, -0.08360285f, 0.05885337f, -0.15902032f, 0.15639204f, -0.01160709f, 0.10089356f, 0.05969268f, 
    -0.07743298f, -0.20873368f, 0.04492772f, -0.02991947f, 0.02275179f, -0.05581852f, -0.08678111f, 0.07327378f, 
    -0.08621448f, 0.08372729f, -0.12526372f, 0.14395386f, 0.05675277f, -0.05197495f, -0.11165288f, -0.43221608f, 
    0.41601467f, -0.03393871f, -0.04928273f, 0.05257614f, -0.00162325f, -0.06365017f, -0.09059231f, 0.04515163f, 
    -0.18414673f, -0.15923078f, 0.01815539f, 0.03133630f, 0.01728912f, 0.04668158f, 0.11546368f, -0.04750971f, 
    -0.08907627f, 0.25140539f, -0.14157541f, 0.06442187f, -0.16276777f, -0.01743789f, 0.10834052f, 0.12983860f, 
    0.11059851f, 0.03793034f, 0.06065373f, 0.00779372f, 0.02642290f, 0.01129809f, -0.01457020f, -0.02398758f, 
    0.00202798f, 0.08910675f, -0.13017549f, 0.12268689f, 0.15495788f, -0.68169862f, -0.12693913f, -0.05662306f, 
    -0.01205635f, -0.08530608f, 0.06409717f, -0.00993587f, 0.00374610f, 0.11317429f, -0.03970832f, 0.13793512f, 
    0.05778342f, 0.11907779f, 0.06547401f, -0.04073001f, 0.00304469f, -0.02838255f, -0.18735991f, 0.03113924f, 
    -0.02156955f, 0.05387781f, -0.03369733f, 0.15847073f, -0.12254807f, 0.06853576f, 0.03125880f, -0.01960414f, 
    -0.07715947f, 0.03353481f, -0.07667573f, 0.02514338f, -0.03567396f, 0.04346620f, -0.08957995f, -0.01516285f, 
    -0.00036489f, 0.19596232f, -0.03776797f, 0.10191829f, -0.21997957f, 0.16757439f, -0.01352645f, -0.39077267f, 
    0.15641542f, -0.03469448f, -0.09272750f, 0.02246193f, -0.11014128f, -0.02137654f, 0.05293795f, -0.13084197f, 
    0.06048234f, 0.00231273f, -0.02167615f, 0.01197162f, -0.01624477f, -0.12753330f, 0.08737563f, 0.04902043f, 
    -0.23186301f, 0.19074810f, 0.03491842f, 0.18330133f, 0.08856610f, 0.08883345f, 0.21784298f, 0.12480802f, 
    0.13313302f, -0.11823799f, -0.16302851f, 0.13435067f, -0.10131198f, 0.07617303f, 0.01569558f, 0.06438123f, 
    -0.10767211f, 0.15323630f, 0.15419948f, 0.09733885f, -0.14620763f, 0.31590843f, 0.05444156f, -0.03424097f, 
    -0.43419817f, 0.09345086f, 0.07119354f, 0.04325789f, -0.03299940f, 0.10440738f, 0.03744116f, -0.03565110f, 
    -0.06550571f, 0.08248453f, -0.06939593f, 0.09342822f, -0.11870761f, -0.09359011f, 0.01626382f, 0.05029315f, 
    0.26331899f, -0.15932575f, 0.28901607f, 0.02888248f, 0.06777226f, 0.04363673f, 0.08691238f, -0.05568076f, 
    0.06210398f, 0.03263605f, -0.04153108f, 0.04404041f, -0.03656435f, 0.03778331f, -0.10429861f, -0.03289769f, 
    0.02872598f, -0.02800653f, 0.05365161f, 0.08375417f, 0.08180569f, 0.11308665f, 0.06132989f, -0.07456812f, 
    -0.06654518f, 0.05119872f, 0.02776039f, -0.06842839f, -0.07266447f, -0.10635179f, 0.06917083f, 0.04089178f, 
    -0.02047830f, 0.04689851f, -0.14504296f, 0.04131017f, 0.01410488f, -0.01175476f, -0.04068501f, -0.01154959f, 
    -0.13568723f, 0.05162798f, 0.03574951f, 0.12410184f, 0.22680064f, -0.04394611f, 0.01554194f, -0.13663453f, 
    0.02130391f, -0.10841952f, -0.06090474f, 0.00809834f, 0.02280429f, -0.05428072f, -0.03144350f, 0.08769991f, 
    -0.05160188f, 0.03339929f, -0.03294378f, -0.04512119f, -0.23885821f, 0.22050655f, -0.03203931f, -0.05184138f, 
    0.02640237f, 0.00211526f, 0.20800182f, -0.06764723f, 0.00884655f, -0.08253453f, -0.04724715f, 0.07109654f, 
    -0.02284444f, -0.16059804f, -0.09658190f, 0.06933393f, 0.00436219f, 0.00278815f, -0.00036020f, -0.04099412f, 
    0.25417909f, -0.19316170f, 0.23312537f, 0.14229658f, -0.07773152f, 0.27194425f, 0.04271916f, -0.03746233f, 
    0.00340824f, 0.02376528f, -0.01510215f, -0.07427755f, 0.01191415f, -0.01805046f, -0.00164937f, -0.04074370f, 
    0.11746762f, -0.07391573f, -0.07807545f, -0.03365684f, 0.02668009f, 0.08314922f, 0.14069763f, 0.08268317f, 
    0.08347611f, -0.00920625f, 0.03335745f, 0.00879777f, -0.03634180f, -0.01020128f, 0.03806477f, 0.04215223f, 
    -0.02692096f, 0.04906753f, -0.03476038f, 0.02107596f, -0.00644341f, -0.01073505f, 0.06359100f, -0.09553448f, 
    0.20245118f, -0.06409975f, 0.04566145f, 0.05623275f, 0.30751187f, -0.04690149f, -0.03391800f, -0.10282937f, 
    -0.05853529f, 0.03025926f, -0.02720781f, 0.09021548f, -0.01469729f, -0.01700815f, -0.06807934f, -0.06863046f, 
    -0.08548335f, -0.02482775f, 0.06529430f, -0.01358331f, 0.08142614f, 0.12365175f, 0.24737427f, 0.15187815f, 
    0.16250929f, 0.12096573f, 0.01666873f, 0.05754566f, 0.05912032f, -0.01025226f, 0.00259085f, 0.04648609f, 
    -0.03618140f, 0.04752546f, -0.09728440f, 0.00664968f, 0.01151151f, 0.03996520f, -0.00004828f, -0.06660083f, 
    -0.09668545f, 0.05723370f, -0.18356045f, -0.02581921f, -0.01100610f, -0.02495814f, 0.05728474f, -0.09392066f, 
    0.04366149f, 0.01311956f, -0.09272547f, 0.00138905f, -0.06945375f, -0.05762063f, 0.00701145f, -0.02776747f, 
    -0.07455141f, 0.10592227f, -0.09399322f, -0.09300276f, -0.01176702f, -0.23809581f, 0.07280779f, -0.11736218f, 
    -0.18538597f, 0.08637766f, -0.02432098f, -0.05576014f, -0.10152134f, -0.06314677f, 0.04361928f, -0.07219090f, 
    -0.15624698f, 0.05600008f, -0.11591630f, 0.02753209f, -0.00681803f, -0.08278931f, -0.14794323f, -0.05507290f, 
    0.19784459f, 0.02176028f, 0.26420182f, -0.02320456f, 0.09523125f, -0.11609711f, 0.09330326f, -0.06775013f, 
    0.05714778f, -0.02270090f, -0.01862570f, 0.08630966f, -0.04767180f, -0.00307608f, -0.08560003f, -0.06801698f, 
    -0.03662489f, -0.00861220f, 0.04408434f, -0.11708524f, 0.14020707f, -0.18511450f, -0.05010013f, 0.08851284f, 
    -0.03335447f, 0.07184357f, -0.13244730f, -0.11258641f, -0.09265484f, -0.03513301f, -0.00001913f, 0.04181408f, 
    -0.02621621f, -0.10249129f, -0.02056435f, -0.11726890f, 0.10397793f, 0.00913825f, 0.07860434f, -0.00599503f, 
    0.11455253f, 0.20774068f, 0.19146986f, 0.21132635f, 0.18558748f, -0.06264106f, 0.11931265f, -0.06553909f, 
    0.02407340f, -0.05350014f, -0.17590344f, 0.02512894f, -0.07062081f, -0.05873569f, -0.12261496f, -0.00196676f, 
    0.04412217f, 0.05822812f, -0.04506094f, -0.03368397f, 0.12395424f, -0.46579376f, -0.04354485f, -0.02140109f, 
    0.03768106f, -0.02321823f, -0.11083151f, 0.02261929f, -0.00552476f, 0.01333295f, -0.10892546f, -0.07707445f, 
    -0.09832232f, 0.02492699f, 0.02284371f, -0.05989731f, 0.04952623f, -0.00024155f, 0.00923302f, 0.00393255f, 
    0.03643392f, 0.21332145f, -0.08947181f, 0.01925078f, 0.14895482f, -0.12550223f, 0.02270636f, -0.06287936f, 
    0.05581796f, -0.04101758f, -0.07526041f, -0.05088963f, 0.04664104f, -0.07298019f, 0.00059395f, -0.05104468f, 
    0.07642339f, -0.04583428f, -0.07273096f, -0.00144265f, -0.20898634f, 0.16667119f, -0.30459568f, -0.12028889f, 
    -0.17738657f, -0.07542573f, 0.03600634f, -0.10013974f, -0.05827165f, -0.04014309f, -0.06739318f, -0.09965082f, 
    0.02817298f, -0.02777242f, 0.01418295f, 0.01808373f, -0.01112691f, -0.01340061f, -0.02215619f, 0.11967891f, 
    0.12212429f, 0.00069607f, 0.11558420f, 0.03417139f, 0.14550048f, 0.08108833f, 0.06758581f, -0.02253825f, 
    -0.08598223f, -0.00739277f, -0.02644223f, 0.07387477f, -0.05649453f, -0.04552799f, -0.03219344f, -0.10214263f, 
    -0.01210403f, 0.02592749f, 0.06611879f, 0.04301240f, -0.31368452f, -0.08514106f, -0.39423549f, -0.32618618f, 
    -0.10198443f, 0.00375072f, -0.08146963f, -0.05102927f, 0.01616394f, -0.04826253f, -0.12205763f, 0.04739863f, 
    0.07707758f, -0.10461895f, -0.05136999f, -0.00109778f, -0.05549531f, 0.00313534f, -0.02503184f, 0.10654598f, 
    0.02228491f, 0.14313400f, -0.10294574f, 0.01457352f, 0.20235309f, -0.25675708f, -0.00510034f, -0.03938178f, 
    0.04920758f, -0.00456294f, -0.09396469f, 0.02354584f, -0.09321712f, -0.02929515f, -0.00223519f, 0.12369455f, 
    -0.02676020f, -0.00170734f, -0.09085666f, -0.01949963f, 0.17796712f, -0.17480159f, 0.18255779f, -0.02603425f, 
    -0.14733322f, 0.00266021f, -0.00725839f, 0.03439714f, -0.04587013f, -0.04413611f, -0.05553972f, 0.02442980f, 
    0.03713650f, 0.04601757f, -0.03801821f, -0.03292685f, -0.04823961f, 0.05810457f, 0.01166294f, 0.01590880f, 
    -0.20025675f, -0.05485577f, 0.00469514f, -0.03386928f, 0.13407655f, -0.19604222f, 0.12316304f, -0.10130253f, 
    -0.00033484f, -0.00516881f, 0.06055801f, 0.16330935f, -0.13456328f, -0.07325469f, 0.00834296f, -0.03423431f, 
    0.06208207f, 0.09992420f, -0.05356222f, 0.03190488f, -0.20196356f, -0.31148773f, -0.07364734f, -0.16085877f, 
    -0.17345101f, 0.05896654f, -0.10261449f, 0.01963778f, -0.09054253f, -0.10870098f, -0.03890214f, -0.05100195f, 
    -0.04622107f, 0.00160692f, -0.05422776f, 0.00602378f, 0.07106891f, -0.01200868f, 0.01642097f, -0.00950675f, 
    0.11361980f, -0.25768989f, -0.10024690f, -0.23548132f, -0.20504639f, -0.07794587f, -0.10632166f, -0.00813849f, 
    -0.05791394f, -0.06373794f, 0.04523203f, -0.07329780f, -0.06256924f, -0.05399716f, -0.02681775f, 0.02314589f, 
    0.00068959f, -0.09882983f, -0.06122346f, -0.02727496f, 0.06544526f, 0.32050791f, -0.04564685f, -0.11259905f, 
    0.21688984f, -0.05915047f, 0.09972658f, -0.20210990f, -0.10145221f, -0.02599545f, -0.00238927f, 0.00363370f, 
    0.01994876f, -0.11528786f, -0.08732675f, -0.00780958f, -0.04218486f, 0.13778903f, 0.03693658f, 0.03614814f, 
    -0.06955758f, 0.09543486f, 0.12052979f, 0.17475991f, 0.21798542f, 0.15068692f, 0.14666583f, -0.01917897f, 
    0.05604326f, 0.00649874f, -0.07387813f, -0.03797912f, 0.03646459f, 0.01842717f, -0.03563635f, 0.01541101f, 
    0.02260237f, 0.05211879f, 0.04508366f, 0.05251471f, 0.09883332f, -0.05915486f, -0.06053270f, -0.00383332f, 
    0.12278927f, 0.11217249f, -0.12205771f, -0.09882437f, -0.05835900f, 0.00834802f, 0.00214939f, 0.07056626f, 
    0.05824599f, -0.03641549f, -0.01458799f, -0.08634099f, 0.00990178f, -0.05818063f, 0.02671448f, 0.03287521f, 
    -0.05682332f, 0.12078654f, -0.20222935f, -0.03194337f, -0.05119849f, 0.00995688f, -0.13966352f, 0.01059476f, 
    -0.06426977f, -0.07665931f, -0.01331329f, 0.06171961f, -0.00436047f, -0.00453935f, -0.14586519f, 0.02647043f, 
    -0.09214500f, -0.04265395f, -0.01572911f, -0.04544903f, -0.03723709f, 0.09338234f, 0.26106837f, 0.02947800f, 
    -0.01604126f, 0.00680348f, 0.02144554f, -0.03432928f, -0.00140764f, -0.10579492f, -0.03492669f, 0.07083617f, 
    0.04463731f, -0.01157860f, -0.09163779f, -0.01193362f, 0.05682845f, 0.06816187f, 0.02478404f, -0.03775268f, 
    -0.37324423f, 0.15154810f, -0.03013543f, -0.05890396f, 0.11340749f, 0.00968559f, -0.20364125f, -0.16531837f, 
    0.00898827f, -0.02822621f, 0.03410126f, -0.03043302f, 0.14476404f, -0.06575830f, -0.07472424f, -0.07036951f, 
    -0.00078398f, 0.13555816f, 0.01034548f, 0.00731320f, 0.12677254f, 0.08570853f, 0.26216137f, 0.01947780f, 
    0.05100537f, 0.08774284f, 0.09209128f, -0.08603387f, -0.07331004f, -0.00874207f, -0.01935091f, 0.04373313f, 
    -0.04801969f, -0.04896020f, -0.02922332f, -0.06177189f, 0.03136532f, 0.00619340f, 0.08499932f, -0.06503163f, 
    -0.32870072f, 0.07687185f, 0.12990788f, 0.08911524f, 0.04668026f, 0.07570301f, -0.15023494f, -0.06583589f, 
    0.10558145f, 0.04110874f, -0.07843868f, 0.03782469f, 0.00403787f, 0.11657619f, -0.12371155f, 0.02562696f, 
    -0.12432127f, -0.05645852f, -0.07179345f, -0.01990961f, -0.16164584f, -0.28753850f, -0.27098116f, -0.04402414f, 
    -0.00061951f, -0.04329267f, -0.15297084f, -0.02731006f, 0.01583194f, -0.03789905f, -0.11095850f, 0.03927055f, 
    0.04363994f, -0.03765076f, -0.02145765f, -0.06429193f, 0.08276805f, -0.11764766f, 0.01309044f, 0.01287260f, 
    -0.01790820f, 0.01061448f, 0.06420301f, 0.09233496f, 0.18227294f, -0.11526769f, -0.05901039f, 0.07777999f, 
    -0.19671872f, 0.05309848f, -0.00629874f, -0.04859422f, -0.15276515f, 0.00814068f, -0.00876208f, 0.08020893f, 
    -0.11241790f, 0.00570920f, 0.01339662f, -0.07226031f, 0.17593195f, -0.01386321f, -0.06734908f, 0.01028451f, 
    0.15498824f, -0.13375537f, -0.04506427f, -0.14320661f, -0.10670587f, 0.07436275f, -0.15711419f, -0.15350741f, 
    0.01526068f, -0.11536708f, 0.01776678f, 0.01515919f, 0.05191065f, -0.02334892f, 0.16555914f, 0.07789333f, 
    -0.22718102f, 0.09049211f, 0.22696282f, -0.05825747f, 0.03064824f, -0.10589704f, -0.05607462f, -0.01825625f, 
    0.00943371f, -0.05525935f, 0.04120768f, 0.00051113f, 0.00811938f, -0.03491145f, 0.07017504f, -0.12150963f, 
    0.01816924f, -0.05422626f, 0.01061092f, -0.07742868f, -0.10815386f, 0.11778364f, -0.02999192f, 0.01032563f, 
    -0.15732494f, -0.04139602f, 0.02161396f, -0.12180429f, -0.08592289f, -0.05172434f, 0.08952692f, 0.04351630f, 
    0.02347504f, -0.15574504f, 0.07487068f, -0.07912272f, -0.03454901f, -0.09771167f, 0.10959671f, -0.02168433f, 
    -0.12090048f, -0.09399132f, -0.08353917f, 0.09059247f, 0.05046220f, -0.05983476f, -0.06549019f, 0.00541108f, 
    -0.16656677f, -0.01633433f, 0.01993125f, 0.02130653f, -0.16604753f, -0.00517052f, 0.07916218f, -0.00544448f, 
    0.01892496f, -0.09345978f, 0.07792544f, -0.01999018f, -0.18118417f, 0.02946825f, 0.14660932f, 0.00145770f, 
    0.03104018f, -0.09021114f, -0.01723219f, 0.05838551f, -0.03923127f, -0.00018216f, 0.00193602f, -0.00769650f, 
    0.10471714f, -0.01701101f, 0.01218672f, -0.02081802f, 0.00089426f, 0.01505989f, -0.07226423f, 0.03116813f, 
    -0.12719846f, -0.21966580f, 0.20788051f, 0.01079248f, 0.07678171f, 0.14517923f, -0.00889770f, -0.03541267f, 
    -0.11984055f, -0.08223239f, 0.06018983f, -0.02927726f, -0.03226142f, 0.09317537f, 0.04612013f, 0.01744815f, 
    0.01398755f, 0.15177742f, -0.26125926f, 0.09101842f, -0.24132039f, -0.15809765f, 0.16052340f, -0.01594821f, 
    -0.05538328f, -0.02799709f, -0.01081139f, -0.08180571f, -0.08025303f, -0.05869595f, 0.00275766f, 0.02283953f, 
    -0.12630163f, 0.01173248f, 0.01956182f, -0.01683027f, 0.05965474f, 0.00804505f, -0.03342662f, 0.00929165f, 
    -0.03355148f, 0.12246121f, 0.07612343f, -0.04242515f, -0.08206825f, -0.03203756f, 0.00582433f, -0.04446947f, 
    -0.02150480f, -0.01425008f, 0.09502552f, 0.03089398f, 0.02922260f, 0.13192751f, -0.01249909f, -0.00815830f, 
    -0.01800120f, -0.06943677f, -0.00999005f, -0.04348044f, 0.16202861f, 0.12957700f, 0.04951446f, 0.11120882f, 
    0.16540162f, -0.01219324f, -0.09241912f, -0.11909893f, -0.02704418f, -0.05235710f, -0.02359370f, 0.02127740f, 
    -0.07453080f, -0.04557032f, 0.02726863f, -0.03262466f, -0.01173225f, 0.04106859f, 0.03676504f, -0.00604736f, 
    -0.04570080f, 0.02467817f, 0.11216149f, 0.03360160f, 0.14621529f, -0.04204401f, -0.04736240f, 0.06890619f, 
    -0.05248963f, 0.10462131f, 0.07650812f, -0.03811319f, -0.05936726f, -0.03032750f, 0.08265755f, -0.01682685f, 
    0.05546771f, -0.01044025f, 0.12015982f, 0.04403368f, -0.02926117f, -0.14066686f, 0.20853950f, -0.24953072f, 
    0.05896062f, -0.04303693f, -0.01303194f, -0.01824668f, -0.06194364f, -0.05861608f, 0.05759144f, 0.07265329f, 
    -0.00023250f, -0.04003656f, 0.06534518f, 0.11250748f, -0.06585938f, 0.06682392f, -0.20684054f, 0.03958971f, 
    -0.21940421f, 0.04836778f, 0.31459281f, -0.19281550f, -0.12214414f, -0.02648304f, -0.02278519f, 0.01995876f, 
    -0.05191359f, -0.08216245f, 0.05593495f, 0.05665318f, 0.00460923f, -0.00476133f, 0.01296056f, -0.14862597f, 
    0.07979554f, -0.13026613f, -0.00295758f, -0.13767608f, -0.05828305f, -0.17562799f, -0.30381227f, -0.12076937f, 
    0.07347324f, 0.14411740f, -0.05162492f, -0.03818821f, -0.00178434f, -0.03667652f, 0.02477274f, 0.02727185f, 
    -0.02712278f, 0.06516091f, -0.04482820f, 0.06040669f, -0.03626652f, -0.00595855f, 0.01007056f, -0.03180154f, 
    -0.19538482f, -0.02984845f, -0.23648024f, -0.08896338f, -0.22365928f, -0.10156182f, -0.07291649f, 0.00455068f, 
    -0.03837170f, -0.08441907f, 0.12832956f, 0.04458539f, -0.00534944f, 0.04411293f, 0.09726441f, -0.00845512f, 
    0.04210100f, -0.02895186f, 0.05119760f, -0.00724637f, 0.22353785f, -0.00532106f, -0.19930525f, -0.03533757f, 
    0.13192040f, 0.12382066f, 0.00436479f, -0.00369498f, -0.06553879f, 0.00931050f, 0.13202327f, 0.03968266f, 
    0.05254778f, 0.05928356f, -0.07821392f, -0.03580542f, 0.08141042f, 0.12335032f, 0.03881698f, 0.03105375f, 
    -0.12731580f, -0.10758102f, 0.02695409f, -0.54120141f, -0.22323512f, 0.02677475f, 0.10092164f, -0.01682488f, 
    0.01469314f, -0.01988030f, 0.07993056f, 0.01284355f, 0.01620093f, 0.08756468f, -0.04777628f, -0.08448017f, 
    0.04896211f, -0.00878547f, -0.37591562f, -0.02080051f, 0.08277825f, 0.08973877f, -0.05902321f, 0.03298720f, 
    0.16407900f, 0.09045386f, 0.08301881f, -0.15944767f, -0.02382578f, -0.08428786f, 0.07623317f, 0.03340226f, 
    0.00633513f, -0.03724696f, -0.01721351f, -0.12930253f, 0.09849372f, 0.06497724f, 0.02533701f, -0.02710099f, 
    -0.09000248f, 0.14376177f, -0.06507797f, -0.23427345f, -0.12269120f, 0.04239465f, 0.02678473f, 0.02402571f, 
    -0.06984995f, -0.04744634f, 0.08444886f, -0.03345220f, 0.00931843f, -0.09476345f, -0.01531640f, -0.20216808f, 
    0.08365823f, -0.10083845f, -0.01908513f, -0.01822383f, 0.01712538f, -0.06085523f, 0.04734472f, 0.08539834f, 
    -0.02594056f, -0.08031050f, 0.09875445f, -0.11876165f, -0.06702591f, -0.04608955f, 0.01857035f, -0.01217752f, 
    0.00292715f, 0.11906543f, -0.07378132f, 0.09902629f, -0.01243401f, -0.10141372f, 0.01598216f, 0.08229912f, 
    0.17312257f, 0.28104636f, -0.06643198f, 0.00357502f, 0.04582291f, -0.14902081f, -0.00258316f, -0.05055704f, 
    -0.06953814f, -0.08096463f, 0.08834445f, -0.02359537f, 0.09122921f, 0.00365855f, -0.01044641f, -0.09367365f, 
    0.02951185f, -0.02676878f, 0.18049073f, 0.00340040f, 0.13158950f, -0.04520259f, -0.17913471f, 0.08504162f, 
    0.18603550f, 0.13940775f, 0.02161653f, -0.00842238f, -0.04589341f, 0.00576713f, -0.04422553f, -0.00765639f, 
    -0.05661592f, 0.08814169f, -0.07860643f, 0.04525885f, 0.03134804f, 0.08560033f, 0.01212048f, -0.09897627f, 
    0.24979056f, 0.13481243f, -0.02874800f, 0.09904985f, 0.08163829f, 0.07259672f, 0.07871094f, -0.10110327f, 
    -0.03151552f, -0.08451203f, 0.00973061f, 0.08307135f, -0.08468970f, -0.12622499f, 0.04738639f, -0.13841422f, 
    -0.04603160f, 0.10801542f, 0.04070727f, -0.05796761f, -0.24797773f, 0.10213071f, 0.02070396f, -0.36112165f, 
    -0.29469863f, 0.03629242f, -0.01819647f, 0.00966891f, 0.20571877f, -0.07440538f, 0.04050060f, -0.00077070f, 
    -0.12206230f, 0.00429549f, 0.07887147f, -0.01535374f, -0.05177049f, -0.15853769f, -0.01460040f, 0.07765506f, 
    -0.20920457f, -0.32005101f, 0.17937359f, -0.34634730f, -0.32161218f, -0.14392711f, 0.02469082f, 0.11558177f, 
    -0.04084105f, -0.00396859f, 0.08019000f, 0.05908073f, -0.03366777f, -0.04253681f, -0.00887992f, -0.05419808f, 
    -0.12448591f, -0.10756845f, -0.14917988f, -0.01334957f, -0.21778852f, 0.00434558f, -0.05727341f, -0.32553259f, 
    -0.17229293f, -0.05157219f, -0.07109050f, -0.04923578f, -0.01684652f, -0.07455488f, 0.10818112f, 0.04123538f, 
    0.09906717f, -0.00047811f, 0.03545259f, -0.11865895f, -0.05445329f, -0.08037809f, -0.13840351f, -0.07957684f, 
    -0.00500758f, -0.01286175f, 0.01953690f, 0.09016178f, 0.18349618f, -0.03247450f, -0.00479264f, -0.05581753f, 
    -0.06249509f, -0.02978029f, 0.09790421f, -0.02838712f, 0.04497690f, -0.01038843f, 0.17514622f, -0.07397124f, 
    0.02398010f, 0.01355479f, 0.08278849f, -0.05146890f, 0.08745044f, -0.05988861f, 0.05622859f, 0.06729019f, 
    0.13358936f, -0.12512404f, -0.06783243f, -0.00505202f, -0.02948353f, 0.03906200f, -0.03257963f, -0.12008686f, 
    -0.06188727f, -0.10329726f, 0.00480403f, 0.04773812f, -0.04995988f, -0.06094344f, 0.08998851f, 0.04347957f, 
    -0.11840602f, 0.27204421f, -0.31088412f, -0.19649537f, -0.13321808f, 0.14330235f, 0.01325389f, -0.16884895f, 
    0.02622510f, -0.02665306f, 0.07718631f, -0.01955195f, 0.09272524f, 0.04316654f, 0.01208232f, 0.17596512f, 
    -0.01835437f, -0.07756974f, 0.07276202f, 0.01394569f, -0.34647706f, -0.02905958f, 0.25047979f, -0.15246564f, 
    -0.02673548f, 0.06561659f, 0.08518300f, 0.04332599f, -0.05879210f, -0.07893132f, -0.00171265f, -0.05167390f, 
    0.01239069f, -0.00251035f, -0.02105550f, -0.04348082f, 0.00805878f, 0.07090200f, -0.14591597f, -0.08663636f, 
    0.05804127f, 0.10601968f, -0.38797420f, 0.12816353f, -0.06821152f, 0.10215823f, -0.03859993f, -0.26252016f, 
    -0.17123306f, 0.01114433f, 0.07010876f, -0.00350558f, 0.17624867f, -0.12603644f, 0.05970269f, -0.05189482f, 
    -0.13496870f, -0.16850266f, 0.15860447f, -0.04907174f, -0.09871146f, -0.26526350f, -0.10280713f, -0.08732080f, 
    0.17549869f, -0.02346751f, 0.07262648f, -0.03668526f, -0.07482639f, 0.00461654f, 0.08863122f, -0.00185811f, 
    0.11111588f, 0.03792187f, 0.07820145f, -0.00400984f, 0.04084515f, 0.12851746f, -0.06724259f, -0.02221940f, 
    0.28139159f, -0.30308545f, -0.11650692f, 0.17854339f, -0.15805687f, -0.05831381f, -0.01697714f, -0.00770461f, 
    0.11894338f, 0.03406163f, -0.13849813f, 0.03566682f, -0.02934534f, -0.10208327f, -0.00462970f, 0.01868477f, 
    0.09638464f, -0.03554419f, -0.01595916f, -0.01775063f, 0.09606172f, -0.11784057f, 0.09821717f, -0.14775936f, 
    0.15120272f, 0.15583494f, 0.00951803f, -0.11271559f, -0.03297748f, 0.01399657f, -0.00696131f, 0.11172615f, 
    -0.00881896f, 0.09136364f, -0.04955589f, -0.06655519f, 0.00060475f, -0.04035063f, -0.09048419f, -0.14328958f, 
    0.56539190f, 0.00078850f, -0.22310266f, -0.09954719f, 0.14818892f, 0.09131686f, -0.11295789f, 0.04935191f, 
    0.00133277f, 0.09295653f, -0.04411149f, -0.01810049f, 0.17479958f, 0.06187547f, -0.01848841f, -0.02731996f, 
    0.01095464f, -0.04947121f, 0.02776200f, -0.02694784f, -0.72626984f, 0.34401146f, 0.32142943f, -0.08359665f, 
    0.02907527f, 0.09373377f, 0.07577249f, 0.00264127f, 0.05321054f, 0.02044714f, 0.07754651f, 0.01502659f, 
    0.14453793f, 0.12984663f, 0.10606761f, 0.09678076f, 0.02733135f, 0.16048893f, -0.18997267f, 0.11900435f, 
    0.26335913f, -0.50268847f, 0.26646253f, 0.06676215f, 0.35307556f, -0.05567808f, -0.00914355f, -0.01670157f, 
    -0.01183842f, -0.00723076f, 0.06804105f, -0.08209001f, 0.04480434f, -0.03340136f, 0.14216344f, -0.01480216f, 
    0.06565552f, -0.18314484f, -0.08879197f, 0.09609635f, 0.00500033f, -0.11103759f, 0.03577555f, 0.11573092f, 
    0.00354920f, 0.02781824f, -0.02551185f, -0.11356442f, 0.12514348f, 0.02266589f, -0.09650543f, -0.00461270f, 
    0.08925904f, -0.05249855f, 0.06543531f, -0.09758007f, -0.05552439f, 0.02978924f, -0.06957204f, 0.03934820f, 
    0.29903030f, 0.02892629f, -0.24256098f, 0.03954534f, 0.12124521f, -0.02807814f, -0.05737636f, 0.15588661f, 
    -0.06726516f, 0.01761045f, 0.03306715f, 0.09507934f, 0.03457908f, -0.04041884f, -0.00920361f, 0.15684517f, 
    -0.05220969f, -0.07994866f, 0.15449832f, 0.09314743f, -0.34032613f, -0.26266465f, -0.14747557f, 0.28480974f, 
    -0.10145126f, -0.03488309f, 0.02756461f, -0.00763662f, -0.04389235f, -0.00424123f, -0.15615144f, -0.00028849f, 
    0.03960051f, 0.07503244f, 0.11932333f, -0.05668380f, -0.20503095f, 0.00687044f, 0.03060601f, 0.06914397f, 
    0.18216267f, 0.10774328f, 0.07129052f, 0.00563941f, -0.01794201f, -0.09986708f, 0.05373165f, 0.04360989f, 
    0.07721816f, -0.18664254f, 0.00233245f, -0.00632758f, 0.06085570f, 0.03881371f, 0.09344051f, -0.02706817f, 
    0.02746815f, -0.06656119f, -0.10210932f, -0.01098788f, -0.00342095f, -0.33268294f, 0.15027842f, -0.08780906f, 
    -0.03333240f, 0.11092336f, 0.08220173f, -0.04688710f, -0.07076126f, -0.12121188f, -0.04231732f, 0.04172652f, 
    -0.01653283f, 0.06858755f, -0.05506592f, -0.01255027f, 0.02824199f, -0.24887146f, -0.09413484f, -0.10751320f, 
    0.04619243f, -0.15917176f, -0.17021689f, 0.01740552f, -0.01745864f, 0.01136895f, 0.04232307f, -0.09373256f, 
    0.02018670f, 0.09904004f, -0.03593286f, 0.01395589f, -0.01961977f, 0.03230545f, 0.06453130f, -0.00685481f, 
    -0.07001104f, -0.05449548f, -0.00470112f, -0.05450682f, -0.05681001f, -0.18041429f, 0.00946374f, -0.05880797f, 
    -0.10047539f, 0.09868071f, -0.00795222f, 0.01009144f, -0.03974999f, 0.07634607f, -0.00928977f, 0.03699882f, 
    0.12903036f, 0.01928084f, -0.00143816f, 0.17522068f, -0.06684954f, 0.05777983f, 0.01925589f, 0.00373976f, 
    0.23465498f, -0.01622587f, 0.10341281f, -0.06900722f, 0.05956237f, 0.05996960f, 0.09195349f, -0.01230421f, 
    -0.14125858f, 0.12553309f, -0.18824671f, -0.03412502f, -0.01852923f, 0.07651468f, 0.16616248f, 0.14903420f, 
    -0.04865574f, 0.13207985f, -0.08146524f, 0.02402120f, -0.12216425f, -0.10939211f, 0.21069056f, -0.28361249f, 
    -0.21915607f, -0.13440453f, -0.02598927f, -0.00856605f, -0.01912646f, 0.05525077f, 0.04828187f, -0.02614558f, 
    0.14037453f, -0.09885100f, -0.06726502f, -0.09908170f, 0.01554473f, 0.09777813f, 0.10694891f, 0.08238278f, 
    -0.46849030f, 0.10434736f, -0.09730864f, -0.08182174f, -0.15736657f, 0.06131087f, 0.05911810f, -0.10264453f, 
    -0.05362063f, -0.01097256f, -0.14296368f, 0.03769373f, -0.03713921f, -0.01921424f, 0.10186034f, -0.01477663f, 
    -0.00995264f, 0.13345926f, -0.00577215f, 0.03586081f, -0.10406189f, -0.14509182f, -0.03643296f, 0.05029075f, 
    -0.39666110f, 0.14981107f, 0.11147768f, 0.17825294f, -0.12908687f, -0.12082135f, -0.13183677f, -0.13896275f, 
    -0.13833065f, -0.11472623f, 0.11275048f, -0.07569034f, -0.05529143f, -0.06429842f, 0.11840723f, -0.07583676f, 
    0.08792608f, -0.14754832f, 0.02220771f, 0.15714744f, -0.05589939f, -0.17324525f, 0.09680926f, -0.05096311f, 
    -0.08438773f, -0.05048891f, 0.10001574f, 0.02243001f, 0.05797727f, -0.10791146f, -0.02791284f, 0.03155448f, 
    0.04435574f, -0.04544052f, 0.04721381f, 0.08627485f, 0.22451530f, -0.09113219f, 0.05931520f, -0.31132805f, 
    -0.49132028f, -0.08774819f, 0.03091241f, 0.03535215f, -0.03771422f, -0.03289054f, 0.01295076f, -0.12262179f, 
    -0.16391017f, -0.09481665f, 0.01993430f, 0.07951364f, -0.00681596f, -0.24328776f, -0.13028222f, -0.04102009f, 
    -0.06829745f, -0.00673229f, -0.40628627f, 0.08171231f, -0.51701814f, -0.04298770f, 0.01063520f, 0.00664552f, 
    0.05805974f, 0.14511044f, -0.18076274f, -0.02769985f, 0.07218596f, 0.23651871f, 0.14309520f, 0.02681727f, 
    -0.00390100f, 0.05406692f, -0.03766597f, 0.00119321f, 0.31816676f, -0.52847439f, -0.16266237f, 0.16986381f, 
    0.09861797f, -0.04763888f, 0.10554943f, -0.04631925f, 0.01319071f, 0.02196202f, -0.03971368f, -0.10900319f, 
    -0.06122178f, -0.13608594f, -0.03367521f, -0.05934255f, -0.13242427f, -0.00172830f, 0.01763693f, 0.21610394f, 
    -0.49772504f, 0.48224583f, -0.06912228f, 0.33396742f, -0.13530114f, 0.07795969f, -0.01651956f, 0.08783318f, 
    0.20175654f, -0.00846174f, 0.08315748f, 0.04392666f, 0.06276751f, -0.10366353f, 0.16219984f, 0.08817049f, 
    -0.00793354f, 0.25985089f, -0.12562962f, 0.00010258f, 0.09783895f, -0.22616832f, 0.32631591f, -0.14732468f, 
    -0.29997987f, 0.08968045f, 0.10723455f, 0.01631741f, -0.09647594f, -0.02015035f, -0.11080547f, -0.00717005f, 
    0.07117829f, -0.14863271f, 0.06966879f, -0.05203273f, 0.01396222f, 0.05486334f, 0.04148884f, -0.00988379f, 
    0.06561016f, -0.17955185f, 0.01444038f, 0.18831319f, -0.16754666f, 0.12256385f, 0.13296531f, 0.08609369f, 
    -0.08126703f, -0.16145013f, 0.04986290f, 0.00485765f, -0.04162007f, -0.10738780f, 0.02480431f, 0.07420055f, 
    -0.10806265f, 0.03252861f, -0.06522734f, 0.05812921f, -0.02573470f, -0.07512657f, 0.28236881f, 0.02433553f, 
    -0.31487340f, -0.12993813f, -0.01841865f, 0.11515485f, -0.08123245f, 0.06176184f, 0.09097318f, 0.07166690f, 
    -0.04156055f, -0.00747480f, 0.11301430f, 0.01042090f, 0.05607849f, -0.10119854f, -0.00854353f, -0.08586449f, 
    -0.18373777f, -0.16802034f, -0.29188448f, 0.16933782f, 0.28406432f, 0.03441223f, -0.11239161f, 0.08073851f, 
    -0.01318568f, 0.16353846f, 0.04959358f, 0.05375290f, 0.06960678f, 0.01400058f, -0.12454513f, 0.02309697f, 
    -0.04732006f, 0.09249430f, 0.03463192f, -0.06426379f, 0.26748982f, -0.18671641f, -0.06512886f, 0.06491327f, 
    -0.13268089f, -0.09270018f, 0.00481594f, 0.09099749f, 0.01915843f, -0.07201218f, 0.04159150f, -0.16043778f, 
    0.00805086f, -0.06784304f, -0.08123668f, 0.13920954f, -0.00913317f, 0.15170230f, 0.04046618f, 0.04768481f, 
    -0.11173791f, 0.17133948f, 0.10308500f, -0.43161178f, -0.08185318f, -0.03254778f, 0.01484026f, -0.22092427f, 
    0.03609654f, 0.11095951f, -0.04939708f, -0.03839400f, 0.00919841f, -0.00512571f, 0.04251547f, 0.17350031f, 
    0.02853679f, -0.02032287f, 0.03030115f, -0.03219829f, -0.04876433f, -0.07401308f, -0.10537345f, 0.16575739f, 
    0.09880189f, 0.12618400f, -0.04925658f, -0.09412943f, -0.02165060f, 0.18689080f, -0.06509416f, -0.00632226f, 
    -0.01904452f, 0.00686757f, -0.10395734f, -0.05979918f, -0.14346309f, 0.01732187f, -0.02554986f, -0.00311062f, 
    -0.16904996f, -0.07262276f, 0.15778828f, -0.34869310f, -0.09424113f, -0.08627547f, 0.08500317f, 0.03226329f, 
    0.12283444f, -0.03943571f, -0.03232056f, -0.11637125f, 0.11183583f, -0.10369015f, -0.21761291f, -0.04433614f, 
    -0.00620789f, 0.04798550f, 0.15245262f, 0.03546294f, 0.01279418f, -0.10849678f, -0.02876366f, 0.18342896f, 
    0.03481852f, -0.07534521f, 0.04796709f, -0.01050086f, 0.01891819f, 0.03070960f, -0.06667887f, 0.00868547f, 
    -0.08217668f, -0.01069912f, 0.15841599f, 0.02573186f, 0.01179995f, 0.05637327f, 0.02071953f, 0.09656204f, 
    0.15966174f, -0.48358187f, 0.08464961f, -0.25109586f, 0.17778404f, -0.05048236f, -0.00609196f, -0.11169951f, 
    0.04509484f, -0.11985745f, 0.00987742f, -0.19406904f, -0.13223600f, -0.02258795f, -0.02846042f, 0.14382145f, 
    0.17233627f, 0.14244360f, -0.22011466f, 0.13407122f, 0.03690346f, -0.22212282f, 0.24703637f, -0.32047805f, 
    -0.30960974f, -0.04162281f, 0.09378694f, -0.10527372f, 0.00004850f, -0.01659556f, -0.05458537f, 0.16891107f, 
    -0.07564425f, -0.12927437f, -0.02083722f, -0.25820708f, 0.13952780f, 0.06285437f, 0.17102888f, -0.03800949f, 
    0.29357523f, -0.08669300f, -0.08794276f, 0.03433870f, 0.06471597f, -0.16739544f, -0.04424877f, -0.20528381f, 
    -0.02654148f, -0.03669429f, 0.02404084f, 0.10584351f, 0.01992575f, -0.07661226f, 0.00745326f, -0.13610174f, 
    0.08746978f, -0.05078506f, -0.20802045f, -0.01974070f, -0.02181206f, 0.17905013f, -0.41705358f, 0.00854135f, 
    -0.06379227f, -0.07475426f, -0.00066147f, -0.07794608f, -0.02314237f, -0.04875471f, 0.04356853f, -0.01101350f, 
    0.00185264f, -0.15885624f, -0.03780589f, -0.17906679f, -0.00195258f, 0.13211218f, 0.01923644f, 0.04182248f, 
    0.09940481f, 0.09382366f, 0.09634268f, 0.03684412f, -0.04056133f, -0.02123050f, -0.19381025f, 0.15157470f, 
    -0.05480638f, 0.08907478f, -0.00941739f, -0.01644729f, 0.01498566f, -0.03625317f, 0.03504940f, -0.02056850f, 
    0.01131831f, 0.11571996f, 0.02508055f, 0.06694528f, -0.43276101f, -0.38382554f, -0.08453387f, 0.00893421f, 
    0.19936749f, 0.07173397f, 0.04101485f, 0.10519592f, -0.11084560f, -0.13037576f, 0.17492892f, 0.01172461f, 
    -0.02767763f, -0.03729988f, 0.06635609f, 0.01813537f, 0.00669178f, 0.00901045f, 0.09647672f, 0.02414325f, 
    -0.47405288f, 0.07502081f, -0.26862282f, -0.03740204f, 0.27218914f, -0.02163319f, -0.01341474f, -0.08402422f, 
    0.02563299f, 0.08496580f, 0.04627823f, 0.05618113f, -0.05105392f, -0.04590559f, 0.05207026f, 0.06694281f, 
    -0.08041102f, 0.05417834f, -0.20182881f, 0.14278035f, 0.14374189f, 0.06066906f, 0.03465552f, -0.04737684f, 
    -0.04089759f, -0.04544659f, -0.01086592f, 0.09544232f, 0.01895162f, 0.03914351f, 0.04795134f, -0.00448268f, 
    0.05047246f, 0.02978306f, 0.02516402f, -0.04831297f, 0.13456078f, 0.01255912f, 0.00390634f, 0.02756084f, 
    -0.17165008f, 0.13832897f, 0.01644851f, -0.15138113f, 0.04410141f, 0.09960083f, 0.03907819f, -0.00350250f, 
    0.00505974f, 0.03223366f, -0.04894965f, 0.07447462f, -0.04503446f, 0.04459193f, -0.06617239f, 0.01580275f, 
    0.09827995f, 0.08470807f, -0.10240072f, 0.10434332f, 0.26654008f, 0.06179468f, 0.09255682f, -0.04184823f, 
    -0.09500586f, -0.01542194f, 0.02432506f, 0.01574555f, 0.05696312f, -0.04221075f, -0.00441921f, 0.05424577f, 
    -0.11596590f, -0.03737989f, -0.07390065f, -0.06836239f, -0.01790021f, -0.01776513f, -0.00769988f, -0.01040023f, 
    -0.06294323f, -0.18276621f, 0.11926868f, 0.00134433f, 0.16284652f, 0.02142565f, 0.03108472f, 0.01767425f, 
    0.06445479f, 0.04007573f, 0.00113700f, -0.08619151f, 0.01861677f, 0.05555052f, 0.07632739f, 0.07966738f, 
    0.13116875f, 0.08572397f, 0.17988645f, 0.14400460f, -0.57645208f, 0.08538307f, -0.33539850f, -0.18637790f, 
    -0.02507818f, 0.10523912f, 0.04625737f, -0.13456009f, -0.05456109f, 0.06846906f, 0.04380856f, -0.01669432f, 
    -0.07535461f, -0.03217758f, 0.06256609f, -0.10501128f, -0.02729646f, 0.11471880f, -0.00068012f, 0.11212911f, 
    0.32169119f, -0.08327185f, -0.16753194f, -0.00162206f, 0.10430055f, -0.12716807f, -0.01902949f, 0.02220690f, 
    -0.00955149f, -0.06710561f, -0.04445640f, -0.07138241f, -0.12245885f, -0.08530112f, -0.09295253f, -0.12408543f, 
    0.03885962f, 0.07105000f, -0.04695165f, 0.05044974f, 0.09300300f, 0.30178329f, 0.01434473f, -0.09945507f, 
    0.04039757f, -0.03721743f, -0.04547618f, 0.00957543f, 0.05809573f, 0.07266799f, 0.02062011f, 0.01723006f, 
    0.08860698f, 0.05788857f, 0.02657988f, -0.02509233f, 0.03612912f, 0.16376765f, 0.02319062f, 0.09955766f, 
    0.06235928f, 0.05248532f, 0.05433438f, 0.00483912f, -0.00390880f, 0.04006577f, -0.08661085f, 0.07329378f, 
    0.04342755f, 0.05056855f, 0.01570196f, 0.07981509f, 0.00087680f, -0.07431075f, -0.06040048f, -0.05702676f, 
    -0.08993775f, -0.11145415f, -0.03069578f, -0.04958974f, 0.02926910f, 0.10662218f, 0.11438753f, -0.00155271f, 
    -0.08574439f, 0.05080442f, -0.00902143f, 0.03858380f, 0.06411836f, 0.10978054f, -0.04104898f, 0.05404315f, 
    0.02434080f, 0.07692202f, -0.01579152f, 0.15265098f, 0.04610325f, 0.02456190f, -0.10472877f, 0.03478795f, 
    -0.41948369f, -0.34106022f, 0.16690078f, -0.00718732f, -0.13270968f, 0.02672480f, 0.09633752f, 0.10981116f, 
    -0.01951415f, 0.02110914f, -0.02097369f, 0.05846620f, 0.02376816f, 0.00991420f, 0.14175922f, -0.00000723f, 
    0.01841403f, -0.14371188f, -0.05122120f, -0.13007286f, -0.78735262f, -0.56432688f, -0.16150846f, -0.09525761f, 
    -0.00122057f, 0.10123640f, 0.01832483f, -0.12550472f, -0.05466133f, -0.06257966f, 0.12471933f, 0.05210095f, 
    -0.01157576f, 0.18537368f, 0.05587786f, 0.10980126f, 0.00323287f, 0.14198554f, -0.02076063f, 0.14078617f, 
    0.31124085f, 0.14538850f, 0.06909060f, -0.02967104f, 0.00280132f, -0.01806585f, 0.03252922f, 0.06228762f, 
    0.02219977f, -0.07352606f, -0.10140915f, 0.05498243f, -0.05039620f, -0.01235700f, -0.02839195f, 0.13474719f, 
    -0.02088384f, -0.21825191f, -0.20444210f, 0.04018313f, -0.77825540f, -0.31256664f, -0.12954161f, -0.14800094f, 
    -0.19740194f, 0.10457376f, -0.05761090f, -0.07431860f, -0.15748091f, 0.00985730f, 0.03857232f, -0.00889362f, 
    -0.07933458f, 0.18246971f, 0.03931331f, 0.06655148f, -0.08134045f, 0.00059956f, -0.02602175f, -0.08360060f, 
    -0.25301856f, -0.29389974f, 0.06545880f, 0.04146277f, -0.09053659f, 0.03104992f, 0.04732852f, -0.00082388f, 
    -0.01278273f, 0.04407142f, 0.06928781f, -0.01253229f, 0.11484409f, -0.10393163f, 0.02010657f, -0.08577041f, 
    0.02920607f, -0.07197431f, 0.01430020f, 0.07894770f, 0.08208744f, 0.09296328f, -0.03949444f, -0.02929019f, 
    0.00969699f, -0.05153410f, 0.04059894f, 0.04493985f, 0.17251681f, 0.07221021f, -0.10224237f, -0.00737901f, 
    0.09678885f, 0.03758789f, 0.06017116f, 0.18594217f, 0.05873504f, 0.14068413f, 0.03004288f, 0.08910251f, 
    -0.13974032f, -0.12851094f, -0.27570584f, -0.00629710f, -0.01513996f, -0.02286660f, -0.06070095f, -0.06251200f, 
    0.01712359f, -0.04830060f, 0.03777084f, -0.14508611f, 0.06094059f, -0.05452784f, 0.00465047f, -0.01266467f, 
    0.13269989f, 0.06255458f, 0.23280784f, 0.04994872f, -0.45557585f, -0.14460851f, -0.22212398f, -0.08158302f, 
    -0.20748870f, 0.06323814f, -0.03373022f, -0.00293169f, -0.07295306f, 0.03755742f, -0.01630196f, 0.07606553f, 
    -0.04933801f, 0.16301998f, -0.01192568f, 0.00352989f, 0.03870418f, 0.08046042f, -0.06290618f, 0.05378241f, 
    -0.30376875f, -0.30521786f, -0.20520480f, -0.10462885f, -0.03483297f, 0.04786446f, 0.06750038f, -0.05386164f, 
    -0.12019693f, -0.01351168f, 0.00060216f, -0.10707159f, -0.08551268f, -0.04254895f, 0.03046274f, -0.11306418f, 
    0.05006155f, 0.16220862f, 0.09893937f, 0.10481954f, -0.07485890f, -0.11347053f, 0.12303782f, -0.01236242f, 
    0.07583377f, 0.20538288f, 0.09620099f, -0.02239076f, 0.06531301f, -0.02079269f, -0.01333851f, -0.04542498f, 
    -0.06717665f, 0.07203104f, -0.14460430f, 0.01365697f, -0.05314211f, -0.15788773f, -0.12297092f, 0.11102206f, 
    0.25911722f, 0.23644900f, -0.09176841f, 0.10910613f, -0.06905650f, -0.01274746f, -0.09506158f, 0.13279435f, 
    -0.09188500f, 0.02888189f, -0.02604327f, -0.02420558f, 0.07277440f, -0.04430949f, -0.02851165f, -0.07826227f, 
    0.08697880f, -0.00367753f, -0.00802668f, 0.05271443f, 0.37652639f, 0.30497628f, 0.01864377f, 0.02140669f, 
    0.10363501f, -0.01218352f, -0.06899054f, -0.01585653f, 0.04307762f, 0.06179149f, -0.13502510f, -0.03492028f, 
    -0.01667888f, 0.02698710f, -0.02221124f, 0.00960384f, -0.02477757f, -0.15530466f, -0.23061906f, -0.02120187f, 
    -0.52592611f, -0.25463551f, -0.06680218f, -0.13021387f, -0.11316680f, 0.14183311f, 0.08121856f, -0.01229165f, 
    -0.14910407f, 0.10201587f, 0.05136716f, -0.07973440f, 0.04186605f, 0.04285952f, 0.02150579f, -0.05658746f, 
    -0.04910213f, -0.09620449f, 0.05455583f, -0.01104482f, 0.28477305f, 0.17198911f, -0.13112661f, 0.10791631f, 
    -0.09238186f, -0.14237046f, -0.09550208f, 0.04878928f, 0.05000476f, -0.06871866f, 0.01047090f, 0.06707818f, 
    -0.02742014f, -0.09751517f, -0.05373029f, -0.09458395f, 0.02340254f, 0.10377715f, -0.02561603f, -0.04478317f, 
    0.18764575f, 0.07752494f, -0.10681227f, 0.05649706f, 0.10390899f, 0.08905660f, -0.03556776f, 0.07555884f, 
    0.05089897f, -0.09053892f, 0.00031476f, 0.10758644f, 0.08518984f, 0.04985688f, 0.03061082f, 0.09298415f, 
    0.10587677f, -0.12134039f, 0.04092890f, -0.00341191f, 0.12675191f, 0.04395922f, -0.02137068f, -0.04521667f, 
    -0.10134757f, 0.05745442f, 0.09986268f, 0.04761575f, 0.06599970f, -0.03326692f, 0.03466193f, 0.04998174f, 
    0.02108382f, 0.04912323f, -0.05132883f, -0.05136722f, -0.03889596f, -0.15612401f, -0.21862277f, 0.01834006f, 
    -0.46055302f, -0.12109288f, -0.10120285f, 0.14308098f, 0.13558935f, 0.08312428f, -0.01309420f, -0.07607820f, 
    -0.01340431f, -0.00576535f, 0.02294110f, 0.04852191f, 0.07556306f, -0.18028276f, 0.19268814f, -0.00327852f, 
    -0.10668718f, -0.18402301f, -0.07543438f, -0.17647846f, -0.27896956f, -0.11506356f, 0.17018792f, -0.15451683f, 
    -0.29531249f, 0.04614383f, -0.08522642f, 0.01379646f, -0.05187283f, 0.12480882f, 0.07955127f, 0.03016988f, 
    0.01375981f, 0.09758246f, -0.03776002f, -0.00531397f, -0.04273138f, -0.11243170f, -0.13960065f, -0.04563682f, 
    -0.26228759f, 0.09124567f, 0.02571363f, 0.06344517f, -0.18247716f, 0.01932946f, -0.05386809f, -0.10461776f, 
    0.03305969f, -0.06088238f, -0.09173202f, -0.04783633f, 0.04185522f, -0.16198383f, -0.02617447f, -0.05917241f, 
    0.08884162f, -0.04224749f, -0.10212389f, -0.04187677f, -0.45276481f, -0.28919947f, -0.04178110f, -0.07212427f, 
    -0.08700643f, -0.08453535f, 0.16947913f, -0.00839287f, 0.04771141f, 0.12871954f, -0.18075463f, -0.00868257f, 
    0.05310825f, -0.00136096f, 0.01036005f, -0.09205500f, -0.07162823f, -0.11857464f, -0.16955936f, 0.02222323f, 
    0.12429128f, -0.18665805f, 0.08725879f, -0.03856777f, 0.07524198f, -0.08410319f, -0.09528589f, -0.00071221f, 
    0.01694549f, -0.08280431f, -0.01153919f, -0.06359179f, 0.02338501f, -0.00336631f, -0.12194487f, -0.01464222f, 
    -0.11839527f, -0.05864993f, -0.04914848f, -0.06485611f, -0.01085295f, 0.20633374f, -0.05551688f, 0.22028282f, 
    -0.01684337f, 0.17610519f, 0.10267533f, -0.02906330f, -0.01329118f, -0.04693075f, 0.05063367f, 0.02364562f, 
    0.04069605f, 0.01713384f, 0.02964616f, -0.16223234f, 0.02896043f, -0.03084634f, -0.03294623f, 0.02460334f, 
    -0.41393563f, 0.20960642f, 0.03152290f, -0.03884345f, -0.07339416f, -0.15594527f, -0.05883299f, -0.09024650f, 
    0.00825525f, -0.10789937f, 0.01021371f, 0.06586641f, 0.11928839f, 0.10699544f, 0.09108147f, 0.03257611f, 
    -0.00930963f, -0.10981870f, -0.04978460f, -0.01448611f, 0.08492389f, -0.06452336f, 0.08861451f, -0.02336159f, 
    0.03937835f, -0.04949617f, -0.02479009f, 0.08983974f, -0.09520477f, -0.05554093f, 0.07591009f, -0.02702923f, 
    -0.02324077f, -0.10913792f, -0.09699418f, -0.01514507f, -0.04217252f, -0.03161921f, -0.02107101f, -0.09478125f, 
    -0.69300091f, 0.44632846f, -0.02426826f, -0.16675027f, 0.27635205f, 0.07975060f, 0.09169845f, 0.03269924f, 
    -0.06543119f, 0.04464352f, 0.01293341f, 0.01853133f, 0.08801254f, -0.01970976f, 0.06647242f, -0.00927580f, 
    -0.04176083f, -0.04426803f, -0.02945343f, -0.08106054f, 0.16754691f, 0.08540545f, -0.04773078f, -0.11260962f, 
    0.04793343f, -0.12070751f, 0.04566943f, -0.13533354f, -0.07122324f, -0.19104475f, -0.18211021f, 0.03065303f, 
    0.15963870f, 0.09538055f, -0.11958297f, -0.02991159f, -0.01297467f, 0.04285323f, -0.09501215f, -0.07836446f, 
    0.01872051f, -0.14116012f, 0.02183676f, -0.04281670f, 0.02737410f, 0.12659259f, -0.02068459f, 0.03842809f, 
    -0.03681860f, 0.04761828f, -0.03672095f, 0.02015005f, -0.00102202f, -0.02426202f, 0.00818509f, 0.02661477f, 
    -0.09700332f, 0.03946951f, -0.05734385f, -0.13064711f, -0.16357014f, -0.29704732f, -0.00731348f, -0.08735824f, 
    -0.07938670f, -0.06560078f, 0.10222146f, -0.03862496f, 0.00472990f, 0.06231844f, 0.01896189f, -0.03475266f, 
    0.08871775f, 0.04374708f, -0.00924191f, 0.03359795f, 0.08497149f, -0.09566971f, -0.02108058f, 0.03465267f, 
    -0.45680684f, 0.14878762f, -0.07189141f, 0.04484378f, -0.05556635f, 0.08962362f, -0.01119084f, 0.07456306f, 
    -0.00551765f, -0.00759545f, -0.04116535f, -0.01603677f, 0.04699641f, -0.04096688f, 0.03564725f, -0.00101500f, 
    -0.07768955f, -0.03757004f, -0.11381226f, -0.05479242f, -0.27408668f, 0.06197245f, 0.11494049f, -0.00070148f, 
    0.17064250f, -0.20744185f, 0.17824610f, -0.10657803f, 0.11924243f, 0.01599761f, 0.08621256f, -0.06234080f, 
    -0.04618572f, 0.01026116f, -0.05768721f, -0.02564622f, -0.04938393f, -0.09183470f, 0.08535527f, 0.06700561f, 
    0.26334029f, -0.17255442f, -0.01762847f, 0.01129520f, 0.01499994f, -0.11979566f, -0.21144290f, -0.06964950f, 
    0.05600563f, -0.17822908f, -0.09298889f, -0.01420699f, 0.04011973f, 0.01487672f, -0.08052482f, -0.01561410f, 
    -0.02206852f, -0.00615470f, 0.05153348f, 0.02407291f, 0.44242197f, 0.06137024f, -0.16808373f, -0.01296789f, 
    0.18624754f, -0.06163335f, -0.02716383f, -0.00319426f, 0.09124530f, -0.01347077f, 0.02632203f, -0.02143524f, 
    0.00857328f, 0.11781968f, 0.01454272f, 0.05029853f, -0.02692424f, -0.03968270f, 0.02797503f, 0.05210299f, 
    -0.02944265f, 0.33512139f, -0.08730549f, -0.00619522f, 0.12622175f, 0.20423880f, 0.00131732f, -0.07819244f, 
    0.01043295f, 0.02048965f, -0.01148339f, 0.10353430f, -0.12227102f, -0.09489784f, 0.10911401f, 0.04046129f, 
    0.19822760f, 0.16473609f, 0.00768243f, 0.06997088f, -0.02390434f, 0.29343918f, -0.18142985f, -0.16763006f, 
    0.09495824f, 0.12313393f, 0.03593301f, 0.00660898f, 0.01198131f, 0.04771062f, 0.01113769f, 0.17242819f, 
    -0.03958518f, -0.04663669f, 0.05921769f, 0.03076568f, -0.05885199f, 0.05009535f, -0.14997117f, 0.00369329f, 
    -0.14466254f, 0.13272683f, -0.10567485f, -0.26003459f, 0.09247062f, -0.06956316f, -0.20827436f, 0.07313965f, 
    0.04898272f, -0.22404228f, -0.01191223f, -0.00863243f, -0.07682846f, 0.04818869f, 0.06570622f, 0.18516877f, 
    -0.12410922f, -0.02232924f, 0.11129193f, -0.04830949f, 0.52790064f, -0.06443437f, -0.27395669f, -0.24461015f, 
    -0.17342860f, 0.00886819f, -0.02313117f, -0.05905648f, 0.11852311f, 0.04827483f, 0.03842314f, -0.01990516f, 
    -0.00784605f, 0.02485406f, 0.00184713f, 0.05797448f, -0.01588400f, -0.05134838f, -0.02894928f, 0.04317255f, 
    -0.30707392f, 0.15347193f, 0.12195524f, -0.09860445f, 0.35194656f, 0.21904072f, -0.02727306f, 0.06758130f, 
    0.13473769f, 0.09602828f, -0.02069215f, 0.09412147f, -0.03888974f, 0.11365342f, 0.07817870f, -0.05244125f, 
    0.11759873f, 0.02121635f, 0.01285600f, -0.06896183f, -0.08016819f, 0.17899325f, 0.02710151f, -0.07748690f, 
    -0.05642392f, -0.04166999f, 0.02816157f, 0.01172388f, -0.07008224f, -0.03190255f, -0.10198919f, -0.07564115f, 
    0.05986634f, -0.04157637f, -0.02818450f, 0.00286514f, 0.02513746f, 0.02641243f, -0.02594594f, -0.19505025f, 
    -0.23886254f, -0.47665352f, -0.13796347f, 0.01638976f, -0.11176606f, 0.14411324f, 0.13688685f, 0.06408322f, 
    -0.05806119f, 0.11547506f, 0.00662907f, 0.06179474f, -0.12290089f, -0.03177311f, -0.06781424f, -0.10449985f, 
    0.11708259f, -0.04485350f, -0.15900035f, -0.03739055f, 0.55889571f, -0.01676770f, -0.17467983f, -0.05954782f, 
    -0.11597005f, -0.01436175f, 0.05514512f, 0.04375434f, 0.00556665f, 0.05829655f, 0.07425661f, -0.03228906f, 
    0.02818439f, -0.03581025f, 0.03089315f, 0.05055608f, -0.11434305f, -0.01391215f, -0.01075572f, 0.04134047f, 
    -0.29387894f, -0.00894971f, -0.15114616f, -0.16627647f, -0.35855719f, 0.03948712f, 0.04276217f, 0.06588098f, 
    0.09148028f, 0.17599274f, 0.01352961f, -0.06718613f, -0.07020473f, -0.05583076f, -0.01358603f, -0.03107092f, 
    -0.02644401f, -0.07537200f, -0.11666853f, -0.00500262f, 0.02021964f, 0.30709866f, -0.13566509f, -0.09163620f, 
    0.36534345f, 0.22588195f, -0.24773930f, 0.01371088f, -0.03125735f, -0.00091765f, 0.02298553f, 0.15567701f, 
    -0.04634470f, 0.04650517f, -0.07717927f, 0.02957510f, 0.05431035f, -0.03758245f, 0.13106883f, 0.00597497f, 
    0.12575534f, -0.00596782f, 0.04539809f, 0.14306603f, 0.14545253f, -0.20068310f, 0.00932421f, 0.07438000f, 
    0.06168282f, -0.10576615f, 0.01450608f, -0.14058529f, -0.17994033f, 0.08281818f, -0.00724986f, 0.02267388f, 
    0.01238711f, 0.00601623f, 0.02088947f, -0.02830596f, -0.46473941f, 0.02472210f, -0.19732963f, -0.11201261f, 
    0.02048963f, -0.24047641f, -0.07715519f, -0.05785139f, 0.11063144f, -0.17105757f, 0.05023421f, -0.06091104f, 
    -0.03280777f, -0.02428384f, -0.00606522f, 0.09442635f, -0.02269622f, -0.02645584f, 0.09945359f, 0.10394377f, 
    0.28706139f, -0.12208152f, -0.22925538f, 0.11037745f, -0.18726763f, 0.00115677f, 0.08198779f, 0.06765746f, 
    -0.05568259f, -0.01433614f, 0.10231609f, -0.01380127f, -0.02006834f, -0.01464157f, -0.03552194f, 0.14816059f, 
    0.03233435f, -0.05989497f, 0.07606497f, -0.00541928f, -0.13865231f, -0.14845149f, 0.14786075f, 0.01179280f, 
    -0.08119112f, -0.00368318f, 0.13649270f, 0.07049216f, 0.03130844f, 0.02153334f, -0.17314057f, -0.06654406f, 
    0.07639063f, 0.07188432f, -0.09475604f, -0.07975096f, -0.03985360f, -0.03409516f, -0.16020334f, 0.04783080f, 
    0.24465281f, 0.14206588f, -0.01268205f, 0.00250463f, 0.17434907f, 0.05191427f, 0.16411538f, -0.08978602f, 
    -0.01479096f, -0.09645168f, 0.09206420f, 0.16638684f, -0.02087706f, 0.02462018f, -0.00476211f, -0.00966065f, 
    -0.04309396f, 0.04710982f, -0.03127379f, -0.02372874f, 0.09559152f, 0.23545948f, 0.03580559f, -0.14116782f, 
    -0.00595299f, -0.05362969f, -0.15846422f, -0.03235753f, -0.23020001f, -0.10754722f, 0.06117160f, 0.02278509f, 
    0.10479946f, -0.03094282f, 0.02255449f, 0.08716200f, 0.06621340f, -0.03744617f, 0.03688955f, 0.00157233f, 
    -0.09035555f, -0.05317491f, -0.34222835f, 0.15790595f, -0.43933341f, -0.08233323f, 0.06581564f, -0.05818408f, 
    0.02505483f, -0.16545875f, 0.02500525f, -0.05070622f, 0.00708642f, 0.00706096f, 0.03118298f, 0.09662239f, 
    0.15095806f, -0.02613985f, -0.11064247f, -0.16967811f, 0.43639550f, 0.14063276f, -0.23933785f, -0.13745590f, 
    0.20781453f, -0.05047195f, -0.04758144f, -0.05364542f, -0.01746251f, -0.04427956f, 0.00531256f, -0.02526066f, 
    0.04675809f, 0.00934574f, -0.06160865f, 0.09798499f, -0.06253578f, 0.04778227f, 0.05092200f, 0.15864751f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.05248056f, 0.01813018f, -0.04080571f, -0.06209438f, -0.00348717f, 0.04782951f, -0.00690694f, -0.04075041f, 
    0.00757947f, 0.02439327f, 0.05242901f, 0.00540489f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
