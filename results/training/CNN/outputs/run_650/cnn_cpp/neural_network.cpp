#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    1.38007534f, 1.27923012f, -0.26084241f, 0.18999258f, 0.42578194f, -0.33706030f, 0.38640988f, 0.21571258f, 
    0.59175247f, -1.47644031f, 1.50112784f, -0.59783101f, 1.24548149f, -0.58653307f, -0.92992258f, -0.02168357f, 
    0.38448325f, 0.08047508f, -1.45916224f, 0.44778660f, -0.28463671f, 1.24186230f, 1.74772513f, 0.83991557f, 
    -0.43353298f, -0.63566118f, -0.22049588f, 1.48038244f, -0.57375914f, -1.40910769f, -0.84591013f, 0.36933479f, 
    0.85201329f, -0.48527372f, -0.52921456f, 0.28966334f, 0.49863908f, 1.65303659f, -0.01604228f, -1.23123169f, 
    -1.31859803f, -0.42760175f, 0.37610641f, -0.18770859f, 0.25821462f, -0.40669531f, -1.56255960f, 1.14421523f, 
    -1.12504876f, 0.28859982f, -0.95842242f, 0.27905113f, -0.44839257f, -0.56251615f, 0.82528710f, -1.81177306f, 
    -0.32755885f, 1.33266890f, 1.07456923f, 0.70502055f, -0.29498741f, 0.60750264f, -0.62125194f, -1.25938404f, 
    -0.69221443f, -0.75623554f, -1.19063401f, -0.58769274f, 0.22638419f, -0.47241524f, -0.07953111f, -0.68092781f, 
    -1.26756597f, -1.81971800f, -0.91016322f, -0.40968758f, 0.15993004f, 0.82473052f, 0.51976138f, -0.05444666f, 
    0.53925717f, 0.63923061f, 1.38873053f, 1.40415561f, -1.23034501f, 1.18060863f, -0.24844390f, 0.38873035f, 
    0.28802654f, -0.38372532f, 1.49159038f, 0.62500244f, 0.65500712f, 0.01842376f, -1.02824938f, 0.86951166f, 
    0.26638481f, 0.62440163f, -0.43063179f, 0.94810849f, 1.35020185f, -1.38139880f, 0.80402058f, 0.22167580f, 
    -0.34533277f, 0.56790084f, -0.33983472f, 0.27854803f, 1.03986216f, 0.60963792f, -1.14696729f, 0.78901583f, 
    -1.28757787f, 0.10426310f, -0.93599313f, -0.23522495f, -0.23982963f, 1.51096356f, 0.55279899f, -0.26931080f, 
    0.75068343f, 1.08142734f, -0.36623153f, -0.79711396f, -0.18031736f, -0.66309065f, -0.10047847f, 1.57307875f, 
    1.07558382f, 0.21790718f, 0.60097802f, 0.78716499f, -0.72076976f, 0.52266145f, -0.17182468f, 1.36075771f, 
    0.09971812f, 1.79232681f, 1.11240828f, -0.09670702f, -0.44140613f, -0.31053752f, -0.20613264f, -0.08513524f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.29181570f, 0.07009623f, 0.00520475f, 0.01123475f, 0.01153339f, -0.01964700f, 0.26936185f, 0.52235663f, 
    0.58278036f, 0.24297102f, 0.37536502f, 0.13884817f, 0.04681117f, 0.22107007f, 0.38483438f, 0.10960251f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.12498786f, 0.07945179f, -0.04042977f, -0.41688073f, 0.32372260f, -0.22273403f, -0.06610874f, 0.07518571f, 
    0.15933982f, -0.04880934f, 0.02604996f, -0.07170612f, 0.00028477f, 0.10512925f, 0.05716998f, 0.02418796f, 
    -0.18775912f, 0.05946493f, 0.04120664f, 0.05905960f, 0.25438440f, -0.00440256f, 0.19243515f, -0.04065235f, 
    -0.02605057f, -0.10802355f, -0.17254981f, 0.08239236f, -0.21114527f, -0.06785978f, 0.03948550f, 0.14425261f, 
    -0.06712514f, 0.11208847f, 0.04816118f, -0.04433901f, -0.02937117f, 0.09497693f, -0.07045107f, -0.15891296f, 
    0.61058784f, 0.12526399f, 0.48283732f, -0.18630423f, -0.20754376f, 0.06578119f, 0.08910814f, 0.08877314f, 
    0.20487446f, -0.11490267f, -0.01305021f, -0.09850932f, -0.15500246f, 0.06414349f, 0.10716224f, -0.06551414f, 
    0.09914106f, -0.11164007f, 0.15725717f, -0.01037909f, -0.11685199f, 0.00685398f, 0.01993693f, 0.28075597f, 
    0.08829639f, 0.00304105f, 0.04920636f, 0.03058273f, 0.03215283f, -0.13738444f, -0.07121621f, 0.00663057f, 
    0.18572336f, 0.08100028f, 0.04739547f, -0.04964872f, 0.15305018f, -0.02830073f, -0.09444015f, -0.19194452f, 
    -0.05641507f, 0.06377655f, 0.36602020f, -0.20832227f, 0.14239232f, -0.09903313f, -0.10083137f, -0.01785377f, 
    -0.05776530f, -0.03028115f, 0.11720295f, -0.00644607f, 0.11960242f, -0.15608431f, 0.00459354f, 0.13155518f, 
    0.07317726f, 0.16064081f, 0.04581727f, -0.00309265f, -0.02997988f, -0.81127304f, -0.08524404f, 0.23996055f, 
    -0.66568643f, -0.22328426f, -0.18431251f, 0.17361793f, 0.18814877f, -0.07737491f, 0.11687475f, 0.06240650f, 
    -0.23919035f, -0.08079266f, -0.08613592f, -0.07078703f, -0.26892576f, 0.03168944f, -0.09676439f, 0.18350552f, 
    0.18364662f, 0.19361998f, 0.03080496f, -0.22335546f, -0.30860189f, -0.01936111f, 0.09310457f, -0.12229500f, 
    -0.00519457f, -0.09477167f, 0.00625266f, -0.03202130f, 0.09606587f, -0.06948615f, -0.10673705f, 0.10715287f, 
    0.00134396f, 0.07402560f, -0.00251923f, 0.09909318f, -0.29857701f, 0.03350110f, -0.24767168f, 0.13077459f, 
    -0.16876209f, -0.14798632f, -0.08897606f, -0.00452891f, 0.05772518f, -0.02345226f, 0.01781241f, -0.04716223f, 
    -0.04493340f, 0.03714275f, -0.12189145f, 0.02620431f, -0.13016336f, -0.04926550f, -0.09303169f, -0.05901086f, 
    -0.54424918f, 0.14240000f, -0.32356104f, -0.05449479f, -0.52482611f, -0.01317552f, -0.01735963f, -0.11055117f, 
    0.12503867f, 0.00532011f, -0.02791683f, 0.02717754f, -0.14594990f, -0.00361703f, 0.15967686f, 0.06193044f, 
    -0.12328406f, 0.06287258f, 0.05591743f, -0.03405860f, 0.11012290f, 0.21836956f, -0.11888430f, -0.25641811f, 
    0.06589853f, -0.20631349f, -0.27923742f, -0.15444097f, -0.02345822f, -0.09149615f, -0.00947357f, 0.02021333f, 
    -0.10668686f, -0.07069439f, 0.04675725f, -0.06557623f, -0.11806231f, 0.03373388f, -0.01498589f, -0.15195239f, 
    0.46173733f, -0.16782881f, 0.04627649f, -0.42694727f, -0.03195734f, -0.30557853f, 0.03660652f, -0.29346976f, 
    0.04414605f, 0.03965804f, -0.20141198f, -0.19999024f, 0.04754755f, -0.03275708f, 0.03208179f, 0.03132707f, 
    -0.02432917f, -0.23086944f, 0.05439963f, 0.07495417f, -0.07682010f, 0.05201976f, 0.14578263f, -0.20622726f, 
    0.54686654f, -0.37294370f, 0.12760404f, 0.10915653f, 0.11070097f, -0.15809642f, -0.01906453f, 0.01829891f, 
    -0.02766425f, 0.13712622f, -0.07141789f, 0.08246639f, -0.01397931f, 0.16388547f, -0.36191863f, -0.03440764f, 
    0.41052511f, -0.37352908f, 0.22547576f, 0.13115598f, 0.33524841f, -0.04821695f, 0.11220117f, -0.04466435f, 
    0.07458545f, -0.00282514f, -0.04518718f, 0.02779203f, -0.03789859f, 0.07089766f, 0.04594975f, 0.02161912f, 
    0.10635980f, 0.07795045f, -0.12161065f, -0.12356406f, 0.06677662f, -0.05026507f, 0.10840207f, 0.01652803f, 
    0.49379700f, -0.07989192f, -0.36107239f, -0.04015298f, 0.16422670f, 0.07760695f, 0.11101642f, 0.14235282f, 
    -0.04118678f, -0.04910347f, -0.11933411f, 0.04191938f, -0.00362890f, -0.04016843f, -0.09569552f, 0.04748366f, 
    -0.47320011f, 0.26039243f, 0.05133165f, -0.00521238f, 0.48176724f, -0.03270552f, -0.32648218f, 0.03164847f, 
    -0.08493703f, -0.04993992f, 0.03919977f, -0.10030997f, 0.03506425f, -0.05082257f, -0.01911107f, 0.03211073f, 
    0.05354347f, -0.13434730f, -0.07738645f, 0.01807978f, 0.38473937f, -0.12301417f, 0.06784531f, 0.03708447f, 
    -0.08269963f, -0.18785369f, -0.48697987f, 0.16002648f, 0.09429022f, -0.04887263f, -0.01658427f, 0.08524882f, 
    -0.15358779f, 0.09278570f, -0.07166450f, 0.13684563f, -0.01053164f, 0.21191970f, -0.08326829f, 0.08617226f, 
    0.46742472f, -0.07139795f, 0.31245250f, 0.06710409f, -0.04692477f, -0.10230585f, -0.29633072f, -0.06850345f, 
    -0.07815076f, -0.06051883f, -0.03493687f, -0.01093508f, 0.04554938f, 0.05667707f, 0.07740398f, 0.00731759f, 
    -0.04503712f, -0.10727448f, -0.04761733f, -0.10557955f, -0.59274232f, -0.38494730f, -0.23914503f, -0.16210461f, 
    0.41125926f, 0.14764668f, -0.07601354f, -0.06196243f, -0.18384796f, 0.05752089f, 0.05091329f, 0.08571356f, 
    -0.02882619f, -0.08785217f, -0.02304505f, 0.06459730f, -0.13073257f, -0.12137819f, -0.04658847f, -0.06854777f, 
    -0.61529624f, 0.09083011f, -0.11841585f, -0.09411810f, 0.06572558f, -0.08210151f, 0.02207136f, -0.18494186f, 
    -0.09812112f, -0.05076745f, 0.20156039f, 0.25453943f, -0.00481947f, -0.14435139f, 0.04186236f, 0.08657814f, 
    -0.08354293f, 0.05678785f, -0.04196339f, 0.05965168f, 0.21603720f, -0.98411763f, 0.10614579f, -0.45898160f, 
    -0.03450381f, -0.29388762f, -0.08780989f, -0.08784427f, 0.05687412f, -0.12906466f, -0.00776164f, 0.04661864f, 
    -0.19894937f, 0.05527724f, -0.16355900f, -0.16696894f, -0.10414681f, 0.10277423f, 0.06926318f, -0.05744984f, 
    0.14696355f, -0.08660580f, -0.34561133f, -0.31865978f, -0.02767487f, 0.01652108f, -0.08389655f, 0.07514068f, 
    0.01383703f, -0.10808501f, -0.12822762f, 0.04400126f, -0.09788114f, 0.27345806f, 0.08246508f, -0.08133324f, 
    -0.12693048f, -0.22834763f, -0.16320658f, -0.15599944f, -0.35516700f, -0.06536409f, 0.00326261f, 0.00877614f, 
    -0.57729453f, 0.03177096f, 0.16223301f, -0.15352273f, -0.04147023f, 0.06438882f, 0.11339706f, -0.08769898f, 
    0.01279217f, -0.03535904f, 0.09007226f, -0.05640951f, -0.01038531f, -0.13077535f, -0.21694575f, -0.05157904f, 
    0.65798068f, -0.59549993f, 0.08109598f, -0.03889680f, -0.23093879f, -0.03093755f, 0.12078024f, -0.00320748f, 
    0.07016874f, 0.10388586f, 0.09041190f, -0.11928413f, -0.01533056f, -0.01017252f, -0.13023803f, 0.11533070f, 
    0.16149376f, -0.11939288f, 0.06907529f, 0.12522419f, 0.02231039f, -0.18026990f, -0.24996848f, -0.14626727f, 
    -0.11552781f, 0.10782101f, 0.08967531f, -0.08605432f, 0.05669548f, 0.11218639f, 0.12222975f, 0.04561735f, 
    0.05251181f, 0.11717845f, -0.14911631f, -0.05155511f, 0.16924490f, -0.08225757f, -0.13685492f, -0.12425673f, 
    0.48929232f, 0.11531978f, -0.14639655f, 0.08058301f, -0.17698616f, 0.07683572f, 0.04329590f, 0.04699699f, 
    0.21606304f, 0.10208454f, -0.01957153f, -0.09080095f, -0.01174663f, 0.12285016f, 0.11161181f, 0.17061399f, 
    0.11097589f, -0.01417163f, 0.01429948f, -0.07462608f, 0.03331085f, 0.35986799f, -0.10709766f, 0.11462571f, 
    0.41657117f, -0.11774722f, -0.05517311f, 0.05374621f, 0.07349275f, 0.03784374f, 0.13426319f, 0.04978955f, 
    0.04957647f, 0.12920503f, -0.30540803f, 0.11933608f, 0.06146860f, 0.07964086f, -0.16048619f, 0.09632974f, 
    0.13594490f, 0.18435395f, 0.22279009f, 0.25116441f, 0.03369891f, -0.06168592f, -0.08344278f, 0.08894755f, 
    -0.04823510f, 0.00757915f, -0.01704130f, 0.01122947f, 0.00838431f, 0.12541446f, -0.17731924f, 0.06287989f, 
    -0.04520931f, 0.06820995f, -0.02972914f, -0.04556951f, 0.25266507f, -0.45981899f, -0.01849193f, -0.19590773f, 
    -0.05790897f, -0.00656542f, -0.14061852f, -0.01866183f, 0.01057416f, -0.07445546f, -0.03810688f, 0.06374229f, 
    -0.07486900f, -0.13605861f, 0.08647743f, -0.04839201f, -0.03822642f, -0.11896271f, 0.16720079f, 0.04495829f, 
    -0.16083859f, -0.52995926f, -0.01034028f, -0.35573226f, 0.26042497f, -0.25874451f, -0.11607099f, 0.05795233f, 
    -0.05332698f, -0.19342217f, 0.00655064f, -0.16114673f, 0.09339925f, -0.00581853f, -0.28848571f, -0.10048589f, 
    -0.03210134f, -0.14655240f, 0.21192850f, -0.18659998f, 0.43094802f, -0.04324319f, 0.26744998f, 0.05004907f, 
    0.07581156f, -0.09051932f, -0.14299637f, -0.13529006f, -0.03947890f, -0.10326202f, -0.15615802f, -0.05034532f, 
    -0.05527668f, -0.06090413f, 0.01102659f, -0.11347148f, 0.12591611f, -0.00057343f, 0.21927500f, 0.09073953f, 
    0.17205895f, 0.53249860f, -0.00221254f, 0.01474579f, 0.22770801f, 0.09586092f, 0.14681172f, -0.01313386f, 
    -0.07936337f, -0.06836808f, -0.02681609f, 0.06858602f, 0.00342665f, -0.01064803f, -0.06656754f, -0.01581123f, 
    -0.01934767f, 0.14660665f, 0.01469147f, 0.02540944f, 0.12475803f, -0.12900789f, 0.24716854f, -0.08116060f, 
    0.14799309f, -0.22803727f, -0.02863910f, -0.03461162f, -0.05223817f, 0.03224260f, 0.16775741f, -0.13435762f, 
    0.05614704f, -0.11671690f, 0.24283575f, -0.06549237f, 0.04303214f, -0.03505135f, -0.02501604f, 0.21385880f, 
    0.19103366f, 0.04050707f, 0.18366091f, -0.25750458f, -0.04243070f, 0.03547141f, -0.13815694f, 0.20521817f, 
    -0.20961574f, -0.12715593f, -0.11071838f, 0.15397558f, 0.13731444f, -0.10517938f, -0.04047532f, 0.08407801f, 
    -0.02886629f, 0.24196209f, 0.08337503f, 0.00423556f, 0.06042244f, 0.05874166f, -0.10037532f, -0.17705220f, 
    -0.18328135f, 0.05168162f, -0.07413755f, 0.05454361f, 0.04604904f, -0.04050646f, -0.12418545f, 0.03487376f, 
    -0.12190186f, 0.02968913f, -0.02251555f, -0.05505865f, -0.05036448f, 0.12357402f, 0.11059809f, 0.12292356f, 
    0.65281165f, 0.17084250f, 0.18936497f, 0.12639445f, 0.30600613f, -0.08461395f, -0.13351940f, -0.07342988f, 
    0.20033403f, 0.27094856f, -0.02305902f, -0.06184684f, -0.09362752f, 0.12518863f, 0.01536057f, 0.02068984f, 
    -0.15652944f, -0.15158039f, -0.07507201f, -0.14432183f, 0.39700294f, -0.09984092f, -0.36889628f, 0.32689276f, 
    -0.43704408f, -0.04021682f, -0.25469133f, 0.29053715f, 0.13284940f, 0.23704715f, 0.02653603f, 0.00618839f, 
    -0.09206015f, 0.07800596f, -0.05384034f, -0.01827003f, 0.00335947f, -0.07230695f, 0.14210756f, 0.03980051f, 
    -0.28127813f, 0.05638845f, -0.35432011f, -0.26121047f, -0.11301596f, 0.10697199f, 0.19144486f, 0.16096133f, 
    -0.29300514f, -0.02327606f, -0.00745537f, 0.03388195f, -0.03528753f, -0.20521742f, -0.08171973f, 0.06732550f, 
    0.02381132f, 0.14692493f, -0.10355406f, -0.09389830f, 0.52190655f, -0.28531599f, -0.38121587f, -0.14613576f, 
    -0.38746095f, -0.08892655f, 0.03551327f, -0.05361184f, 0.14362909f, -0.04041112f, 0.10144528f, -0.02279212f, 
    0.09544429f, 0.03923523f, -0.13517812f, 0.23759055f, 0.02478680f, 0.04935475f, 0.20534520f, -0.15296693f, 
    -0.04811715f, 0.02311783f, 0.37573019f, 0.01599285f, 0.26760277f, -0.23655377f, -0.04759269f, -0.09725370f, 
    0.10586192f, 0.10431560f, 0.03502974f, -0.06118044f, 0.08672109f, -0.00129152f, 0.09702190f, 0.08829945f, 
    -0.09378806f, -0.16427302f, 0.01840926f, 0.00361863f, 0.45218989f, -0.76923585f, -0.39401487f, 0.11004236f, 
    -0.45414805f, -0.14530773f, -0.01034840f, -0.05433397f, -0.15902428f, -0.05338155f, -0.06811373f, 0.15572299f, 
    0.04753243f, -0.00683831f, -0.13054980f, 0.01957928f, -0.11962927f, -0.18690237f, -0.03982400f, 0.03352973f, 
    0.65956718f, -0.36272091f, 0.12693897f, 0.22993237f, 0.07101896f, -0.26001441f, 0.11423647f, -0.21417901f, 
    -0.21927281f, -0.00216877f, 0.09886102f, -0.16232248f, -0.03675562f, -0.06577017f, -0.04484985f, 0.01240852f, 
    -0.05123083f, 0.12886584f, 0.06823403f, 0.17041370f, 0.26904231f, 0.31140056f, -0.21335372f, 0.04179598f, 
    0.13926859f, 0.08213501f, 0.04505328f, 0.02422026f, -0.04697293f, -0.26512444f, -0.03140579f, -0.08578180f, 
    -0.11109334f, -0.03993675f, -0.06952111f, 0.08304274f, 0.02760864f, -0.26445618f, -0.04090282f, -0.05300139f, 
    -0.41473123f, 0.22987454f, 0.22522143f, -0.15496084f, 0.20975019f, 0.02644776f, 0.02994978f, 0.00844466f, 
    0.02756801f, -0.03439492f, -0.07962624f, 0.03475666f, -0.00141496f, -0.01825729f, -0.05785940f, -0.00235435f, 
    -0.12494811f, -0.17024522f, -0.00752358f, -0.06357612f, 0.39031047f, -0.14735992f, -0.08975059f, -0.45458987f, 
    -0.15993598f, 0.06517886f, -0.25736734f, 0.11174376f, 0.04215277f, -0.03268410f, -0.03252495f, -0.01430587f, 
    0.06789795f, 0.03997606f, 0.05668782f, 0.06880336f, -0.16893037f, 0.13075434f, -0.00257722f, -0.04019419f, 
    -0.08609734f, -0.30203176f, -0.20114517f, -0.17252606f, -0.34033707f, 0.12466331f, -0.06606814f, -0.07930403f, 
    -0.02236153f, 0.02071720f, -0.19305478f, -0.06767695f, -0.04982775f, -0.13454951f, -0.13385552f, 0.01304161f, 
    0.05094614f, 0.04428233f, -0.10968066f, -0.07339283f, 0.10845320f, -0.41070786f, 0.19384840f, -0.38437033f, 
    0.01787178f, 0.09708676f, -0.21769696f, -0.07452875f, 0.02448565f, 0.08755013f, -0.11791627f, 0.10382194f, 
    0.05660644f, -0.02468039f, -0.10302142f, 0.03535949f, -0.06196416f, 0.01187870f, -0.23060340f, -0.07313448f, 
    0.43423417f, -0.02666382f, -0.23864697f, -0.20312575f, -0.09536745f, 0.07029434f, -0.12682644f, 0.05689603f, 
    -0.12065828f, 0.00338792f, -0.03583824f, -0.00405660f, 0.09526630f, 0.08180512f, -0.04019816f, -0.06040785f, 
    -0.08995678f, -0.04018462f, -0.06355398f, 0.08555906f, -0.53116101f, -0.03625531f, 0.10249913f, -0.09301714f, 
    0.12927660f, 0.16189575f, 0.20404762f, 0.08424729f, -0.00228150f, -0.28180757f, -0.08427142f, 0.10985263f, 
    -0.10025597f, -0.13308553f, -0.07300136f, -0.12254722f, -0.08098146f, 0.04514762f, -0.23988464f, -0.08032354f, 
    -0.17666836f, -0.69746828f, -0.21162844f, -0.00076969f, -0.03206395f, -0.13961615f, -0.19622765f, 0.05638348f, 
    0.19641510f, 0.04274617f, -0.12128336f, 0.08601852f, -0.07671041f, 0.00467504f, -0.00609373f, -0.12924378f, 
    0.08721133f, 0.01663983f, -0.02747382f, -0.08764154f, 0.78491652f, 0.39230430f, -0.09636810f, 0.21728240f, 
    0.07216100f, 0.17736727f, 0.02285688f, -0.04769276f, 0.13473159f, -0.04420285f, -0.11750811f, -0.06882204f, 
    -0.10141244f, -0.02552645f, 0.02258254f, -0.08050536f, -0.07504822f, -0.08607605f, 0.08600179f, -0.05980801f, 
    -0.63757128f, 0.15837714f, 0.04898897f, -0.10188922f, -0.38981870f, -0.14775877f, -0.14874464f, 0.03388919f, 
    -0.06660080f, -0.07668157f, -0.05079525f, -0.11552851f, -0.04049699f, -0.07479978f, -0.08905300f, -0.06369328f, 
    0.06626259f, 0.01608596f, 0.10872716f, 0.10590339f, 0.15169898f, -0.13117692f, 0.36566889f, 0.13897307f, 
    -0.05990624f, -0.08248037f, -0.03385700f, 0.18650839f, -0.07667517f, 0.02941751f, -0.08809572f, 0.09436867f, 
    -0.11030952f, -0.04691975f, -0.02726906f, 0.09096859f, -0.00833823f, -0.00955184f, 0.08582261f, 0.05364916f, 
    0.34289697f, -0.03565880f, -0.39850849f, 0.18003763f, 0.36842155f, 0.19469084f, 0.32115781f, -0.04774496f, 
    0.04656595f, 0.10149327f, 0.15490571f, -0.09537104f, 0.05067302f, -0.13438219f, -0.16198215f, 0.00538398f, 
    0.03114171f, 0.07902641f, 0.12294802f, -0.04129109f, -0.41242507f, 0.32801867f, 0.22783974f, 0.26113841f, 
    0.09162851f, 0.07954767f, 0.03679399f, 0.02159813f, -0.03276517f, -0.01852753f, 0.00731470f, 0.05786973f, 
    0.12815301f, -0.05995744f, -0.06936648f, -0.06807832f, 0.04600935f, -0.03735438f, 0.19145150f, -0.11697578f, 
    -0.13999270f, 0.04138895f, -0.38379288f, -0.05782767f, -0.46048713f, 0.00799523f, -0.12535363f, -0.08697175f, 
    -0.14537241f, -0.08145863f, -0.08465236f, 0.12710932f, 0.11353426f, 0.02029283f, 0.10064916f, 0.02274114f, 
    -0.10080828f, 0.00623210f, -0.09532528f, 0.00104050f, -0.10896766f, 0.06782857f, 0.20420897f, 0.08201367f, 
    -0.04697666f, -0.15266833f, -0.08212076f, 0.06743748f, -0.03748997f, 0.02174043f, -0.11206008f, -0.10500460f, 
    0.04945568f, -0.02216274f, 0.05177798f, 0.02702825f, 0.06757938f, 0.24168897f, 0.14476292f, 0.12394114f, 
    0.34924585f, -0.05206257f, 0.07737746f, -0.00206008f, -0.10546534f, -0.08123329f, -0.10383318f, -0.12000533f, 
    -0.16747099f, 0.03639437f, -0.06216836f, -0.08402301f, 0.04105668f, 0.07243542f, 0.03958083f, -0.10271908f, 
    0.12880579f, 0.04397123f, -0.00584604f, 0.02530924f, -0.79458374f, 0.38981286f, -0.25723535f, 0.05512285f, 
    0.33455557f, -0.03651607f, 0.11565510f, 0.04826548f, 0.04451522f, 0.02681779f, 0.01476661f, -0.01905297f, 
    0.08115561f, -0.00444667f, -0.03913041f, -0.09101201f, 0.01699467f, -0.25079769f, 0.04436458f, 0.12092055f, 
    0.04221901f, -0.92377323f, -0.57087582f, 0.09603734f, 0.20425686f, -0.03623315f, 0.06415171f, 0.04017906f, 
    0.03634145f, -0.15698220f, 0.10395633f, 0.04019687f, -0.15587269f, 0.01827815f, 0.15813336f, -0.15228112f, 
    -0.05022046f, 0.10173976f, -0.08122031f, -0.16385801f, 0.22274642f, 0.25635597f, -0.10922106f, 0.00924881f, 
    -0.09784491f, -0.04751820f, -0.02492102f, -0.02520954f, 0.04542850f, 0.02461742f, 0.09861284f, -0.13178925f, 
    -0.02833140f, -0.00696829f, 0.03232413f, -0.18710573f, -0.02897616f, 0.11190318f, -0.04878591f, -0.03398491f, 
    0.11799508f, 0.03862332f, -0.05968665f, 0.11086735f, 0.23462182f, -0.05100232f, 0.28072107f, 0.02131806f, 
    -0.06074021f, 0.10489120f, 0.07383668f, 0.03841706f, -0.02461444f, 0.11251368f, 0.12685612f, 0.03887608f, 
    0.08470233f, -0.00588055f, -0.02946434f, 0.05755651f, -0.33909234f, -0.39618388f, -0.35657936f, 0.07236977f, 
    -0.17452067f, -0.25378183f, -0.07984646f, -0.06303579f, -0.06650171f, 0.05990114f, -0.08149878f, -0.01310878f, 
    0.19967256f, 0.11348937f, 0.00596894f, 0.05876092f, -0.14653444f, -0.13140175f, -0.04565737f, 0.20760038f, 
    -0.45681539f, -0.69866681f, -0.08094282f, -0.25103357f, -0.19711517f, -0.30973372f, 0.05074399f, 0.00738465f, 
    0.19057445f, -0.17290244f, 0.01925766f, 0.02806324f, -0.11912294f, 0.15239680f, 0.16823711f, 0.09084304f, 
    -0.02240605f, -0.05276355f, 0.03677879f, 0.03961971f, -0.42293108f, -0.69835323f, -0.57787991f, 0.29095250f, 
    -0.07879967f, -0.13080660f, 0.01649668f, 0.09180624f, 0.02025216f, -0.20277540f, 0.05499683f, -0.13231865f, 
    -0.07384091f, 0.14207847f, -0.16941570f, -0.00142248f, 0.11632377f, 0.16045603f, 0.00756806f, -0.01493697f, 
    -0.08760733f, -0.38148373f, -0.12092352f, -0.15041660f, 0.00677870f, -0.18502729f, -0.10374432f, -0.01383572f, 
    0.06371272f, 0.00761057f, 0.01510069f, -0.05711617f, -0.10111311f, 0.00698382f, -0.01979050f, -0.11924452f, 
    0.15392622f, -0.09710513f, 0.03202357f, -0.11782942f, 0.43990108f, 0.11214509f, 0.11962079f, -0.56230748f, 
    -0.26051095f, 0.02902534f, 0.16644266f, -0.05086722f, 0.21427342f, -0.02916209f, -0.05597512f, -0.08002895f, 
    0.05946760f, -0.01548961f, 0.05590802f, -0.17168829f, 0.07626705f, -0.02382807f, -0.07187635f, 0.06136912f, 
    -0.22320770f, -0.27147001f, -0.31331709f, 0.27778021f, 0.26240617f, 0.16389270f, 0.00331864f, 0.31231934f, 
    0.10344957f, 0.11156053f, -0.00158130f, 0.03457884f, 0.11128442f, 0.16078487f, -0.05977507f, -0.05181683f, 
    0.16003165f, 0.08393288f, 0.17541635f, -0.14003377f, 0.36778262f, 0.09981445f, -0.11259208f, -0.20217466f, 
    -0.41774762f, -0.02585242f, -0.15465270f, -0.14641002f, -0.12854205f, 0.11410059f, -0.13126722f, -0.02436426f, 
    0.11563726f, -0.00808131f, 0.09921825f, 0.07694861f, -0.16000256f, 0.08748323f, 0.06273245f, -0.24719247f, 
    -0.52416599f, -0.62379342f, 0.18901457f, 0.48248371f, 0.03769386f, -0.26833528f, -0.04146844f, 0.02352835f, 
    -0.21881485f, -0.12280997f, -0.07950322f, 0.19237837f, -0.16011600f, -0.06138398f, 0.15156955f, -0.06806839f, 
    -0.06696061f, 0.09153707f, 0.07303549f, 0.14540893f, -0.38881329f, -0.12987748f, 0.16462855f, -0.13512592f, 
    0.07125670f, -0.03070550f, -0.02320559f, -0.01937695f, -0.01495754f, 0.11949595f, -0.03460836f, 0.02336928f, 
    -0.10125189f, -0.08395970f, 0.09703694f, -0.01844071f, 0.01998101f, 0.04062851f, 0.20286143f, 0.00876217f, 
    -1.06568968f, 0.42008162f, 0.03695525f, 0.14637543f, -0.03809142f, 0.11647573f, -0.12593752f, 0.06418882f, 
    -0.34763780f, 0.01559629f, 0.05779733f, 0.05586016f, 0.00849959f, -0.01090887f, 0.02143290f, 0.13002780f, 
    -0.09194829f, -0.02117533f, -0.10427870f, -0.07295214f, 0.07352603f, -0.11703923f, -0.07138670f, 0.21321379f, 
    0.30506799f, 0.07013371f, -0.00162177f, 0.06049969f, 0.12506798f, 0.04968427f, 0.04102656f, -0.02521275f, 
    0.11255963f, -0.07870140f, 0.10103537f, -0.02366264f, 0.07841798f, 0.02105599f, 0.21012060f, -0.02949927f, 
    -0.52955842f, 0.20227762f, -0.11366522f, 0.11340892f, 0.25323951f, 0.10732511f, 0.06372851f, 0.02017957f, 
    0.09893882f, 0.14137265f, 0.00700920f, 0.00910821f, -0.01316629f, -0.03591615f, -0.14518978f, -0.07903770f, 
    -0.06881102f, 0.05824265f, -0.03153374f, -0.07409723f, -0.78782696f, 0.04644926f, 0.29070556f, 0.09932598f, 
    0.17700824f, -0.09544493f, -0.09287770f, -0.02812117f, 0.03806026f, -0.03617907f, 0.07302947f, -0.01378030f, 
    -0.05377617f, -0.25476691f, -0.02050653f, 0.08726027f, -0.03075689f, -0.20940575f, -0.02477317f, 0.03298286f, 
    -0.05673721f, -0.44682318f, 0.08465722f, -0.05271387f, -0.03874495f, -0.11597618f, 0.02372624f, -0.02076048f, 
    -0.20538273f, 0.15050092f, 0.26910153f, 0.01123570f, -0.00859617f, 0.00575649f, -0.09001300f, -0.02229496f, 
    0.01963033f, -0.06827556f, -0.07908582f, -0.02799959f, 0.02318406f, -0.09851574f, -0.28920430f, -0.01752908f, 
    -0.36675522f, 0.10087582f, -0.11215051f, -0.01717565f, -0.11459129f, -0.03345251f, -0.17607184f, -0.09800266f, 
    0.10108202f, -0.05273366f, -0.16369417f, 0.02073561f, 0.00725971f, -0.03665083f, -0.00703478f, 0.03979759f, 
    -0.14018291f, -0.02408833f, -0.13616633f, 0.41091305f, -0.27160320f, 0.02280263f, -0.11703957f, 0.09761384f, 
    -0.03318419f, 0.05367240f, 0.13643268f, 0.07117957f, 0.13678177f, -0.07023999f, -0.00859911f, -0.07127934f, 
    -0.07695886f, 0.00537205f, -0.11551978f, 0.01993390f, 0.07980982f, 0.43327716f, 0.12680855f, 0.00891082f, 
    -0.23083769f, 0.20617951f, -0.11587187f, 0.00442034f, 0.10501090f, 0.02363712f, 0.06384573f, 0.09624247f, 
    -0.00918287f, -0.00333503f, 0.20323010f, -0.00820721f, -0.02002788f, 0.00829567f, -0.20117424f, -0.02455705f, 
    0.29016137f, 0.08212367f, 0.08173674f, -0.06736462f, -0.01808496f, -0.16389094f, -0.05194472f, 0.27927965f, 
    0.16964582f, 0.08883192f, -0.11080277f, -0.05074976f, 0.03303503f, 0.06631431f, -0.04570542f, 0.14969639f, 
    0.10899738f, 0.01553873f, -0.08770890f, 0.00268737f, -0.18225203f, 0.64137292f, 0.05439133f, -0.36009425f, 
    -0.09840326f, 0.09754174f, 0.13300419f, -0.20074920f, 0.08790478f, 0.00414448f, -0.00765388f, -0.06366413f, 
    0.01180944f, 0.16091961f, -0.09115660f, -0.05018731f, 0.05012779f, -0.03714019f, 0.10460271f, -0.00698844f, 
    0.08514041f, 0.01136397f, -0.01804977f, 0.17333108f, 0.21443765f, 0.10393605f, 0.04911589f, 0.17064059f, 
    -0.09733335f, 0.21242933f, -0.07214158f, -0.27684271f, -0.03254201f, -0.05208685f, 0.04346752f, 0.08272044f, 
    0.10952122f, -0.09517615f, 0.17256598f, 0.08502261f, -0.51771998f, -0.27983350f, 0.31551597f, 0.05394443f, 
    -0.38115868f, -0.08427753f, 0.03102349f, -0.03582757f, -0.08515085f, 0.14726877f, -0.10930425f, 0.07501911f, 
    0.06928584f, -0.00916528f, -0.11637208f, 0.07475777f, -0.05832937f, -0.11143290f, 0.03851342f, 0.02488426f, 
    -0.42970946f, 0.45575559f, 0.14871210f, -0.09771468f, -0.31965661f, 0.04461068f, -0.01656551f, 0.15289731f, 
    -0.19991341f, -0.25655940f, 0.20919779f, -0.04840121f, -0.09157725f, -0.16431171f, -0.18143663f, 0.10062670f, 
    0.04376834f, -0.00257971f, -0.00159995f, 0.15443474f, -0.06589674f, -0.19831392f, -0.01117021f, -0.27198780f, 
    0.15212196f, -0.04240336f, 0.09240231f, -0.14717273f, -0.04402084f, 0.11755884f, 0.08794811f, 0.09598149f, 
    -0.03489213f, -0.07533495f, -0.15199906f, -0.01151875f, -0.09157272f, 0.09193848f, -0.04550251f, 0.13028288f, 
    0.23121196f, 0.10713360f, 0.05323488f, 0.43285686f, -0.02963939f, -0.11745156f, -0.18244506f, -0.07390133f, 
    0.05545126f, 0.17919976f, -0.09610896f, -0.27170709f, -0.03792910f, 0.36203295f, 0.20608515f, -0.00501365f, 
    -0.02481352f, -0.16101189f, -0.08193310f, 0.00837856f, -0.17092423f, 0.32253656f, -0.12500626f, 0.08777355f, 
    0.17728595f, -0.01458340f, 0.08415612f, 0.02933225f, -0.01720848f, -0.06629629f, -0.22363074f, 0.24098100f, 
    0.15046169f, 0.07559842f, 0.12765923f, -0.13530965f, -0.05890932f, 0.05188731f, -0.21455592f, -0.14279284f, 
    -0.57629055f, 0.16686085f, -0.20262909f, -0.00720521f, -0.04936938f, 0.03099346f, 0.00721231f, -0.02313096f, 
    0.06267499f, -0.17693037f, 0.09544555f, 0.04365577f, -0.01709156f, -0.06996503f, 0.00316781f, -0.05131009f, 
    0.04363060f, 0.05067151f, 0.12311932f, -0.11344837f, -0.05134837f, 0.20101906f, -0.10778083f, -0.12703250f, 
    0.08583996f, 0.10293528f, 0.05464121f, 0.10469676f, -0.06525806f, 0.24288169f, 0.01811793f, 0.03491281f, 
    -0.07057256f, 0.01339820f, 0.09364726f, -0.13799454f, -0.18631239f, 0.20642599f, -0.30371958f, -0.04423884f, 
    -1.03018272f, -0.55141234f, -0.35789371f, -0.39394760f, 0.02223681f, 0.17776653f, 0.08722737f, 0.04743670f, 
    -0.06846463f, -0.24103907f, -0.00889629f, 0.15421019f, 0.01666353f, 0.06116406f, -0.11085795f, 0.08296070f, 
    0.11622765f, -0.03363780f, -0.14594693f, 0.10608831f, 0.07516619f, -0.14525914f, -0.08419933f, 0.01486111f, 
    -0.53246850f, -0.16478601f, 0.10465990f, -0.03285554f, -0.02161642f, -0.03441742f, -0.00600479f, 0.08548553f, 
    0.21290480f, 0.15579149f, 0.18683223f, -0.10211059f, -0.04266081f, 0.12907709f, 0.02980473f, 0.02572373f, 
    -0.09324189f, 0.16790709f, -0.05987122f, 0.18601909f, 0.05804754f, -0.07608302f, 0.00476957f, -0.13416636f, 
    -0.01574965f, 0.01516960f, -0.04039144f, -0.06303467f, -0.01746931f, -0.03062567f, 0.16055605f, 0.00630706f, 
    0.01846349f, 0.30334875f, -0.02569826f, 0.03345017f, -0.17752731f, 0.23949748f, 0.00191435f, 0.00273562f, 
    -0.03292540f, -0.03671058f, -0.22788136f, -0.09206865f, -0.02261743f, 0.17250971f, 0.03667144f, -0.07865722f, 
    -0.10891028f, -0.07858597f, -0.08241110f, 0.00765822f, 0.06689987f, -0.14966528f, 0.11664913f, 0.02506214f, 
    0.07055530f, 0.02877084f, 0.09081036f, -0.14384416f, -0.25062549f, 0.05907013f, -0.22437629f, -0.02258128f, 
    0.14349873f, 0.22317524f, -0.04924382f, 0.14161240f, -0.12411709f, -0.10608077f, -0.11109589f, -0.00023280f, 
    -0.18205304f, -0.05666619f, 0.09120239f, 0.03918630f, 0.46078765f, -0.17054233f, 0.05963644f, -0.03020057f, 
    0.12782070f, -0.11293218f, 0.03722440f, 0.00098632f, -0.10890661f, -0.07193197f, 0.10020754f, -0.00422325f, 
    0.17148113f, 0.14502598f, 0.07768468f, -0.05517841f, -0.06026492f, 0.05567097f, -0.05451847f, -0.04822507f, 
    -0.11627784f, -0.13817197f, 0.24151900f, 0.03358591f, -0.39641643f, 0.14211258f, 0.25441992f, -0.20568471f, 
    0.09617192f, -0.00366260f, -0.07965282f, 0.09077558f, -0.08427977f, 0.10373642f, -0.00250422f, 0.06327045f, 
    -0.00071503f, 0.14590830f, 0.26478827f, 0.02703284f, 0.26160488f, -0.03757470f, 0.28838080f, 0.44039187f, 
    0.03029831f, 0.02802744f, 0.10755295f, -0.05333641f, -0.03913613f, -0.08416689f, -0.07697950f, 0.05406559f, 
    -0.04695087f, -0.06182707f, 0.02719934f, -0.00454933f, -0.10101852f, -0.07588874f, 0.02818028f, -0.16066575f, 
    -0.44298372f, 0.26395574f, -0.11857238f, 0.29462379f, -0.56450891f, -0.04420168f, 0.18811625f, -0.08186889f, 
    0.03633371f, 0.00312340f, 0.01840034f, 0.10991435f, 0.07055616f, -0.04542406f, -0.24244069f, 0.05339973f, 
    -0.07609094f, -0.08158195f, -0.18311213f, -0.26224637f, 0.19885409f, -0.07636206f, 0.10352877f, 0.24202727f, 
    0.39095703f, -0.14572835f, 0.06168612f, -0.02858196f, 0.04467057f, -0.25881478f, 0.00443664f, 0.03755894f, 
    0.03090918f, 0.22576827f, 0.02703849f, 0.07237881f, 0.19612338f, 0.09908306f, 0.06034603f, -0.05303473f, 
    0.34176973f, -0.79399192f, -0.13070434f, 0.03823262f, -0.13046581f, -0.12617499f, 0.05567757f, -0.08230890f, 
    0.13861375f, 0.09545621f, -0.18097199f, 0.07187181f, 0.09973094f, 0.12589175f, 0.08992925f, 0.12217322f, 
    -0.10917448f, -0.03898439f, -0.20282285f, -0.09291860f, -0.14077942f, -0.35642773f, 0.01273704f, -0.00664861f, 
    0.37848645f, 0.21476226f, -0.03004481f, 0.03754980f, -0.03230578f, -0.08708909f, 0.03847618f, -0.13854423f, 
    0.18478517f, 0.06937023f, -0.24459547f, 0.17166083f, 0.03819602f, -0.24094088f, 0.08591945f, 0.10063726f, 
    -0.20158194f, 0.36759138f, 0.05678428f, -0.36605102f, -0.49763107f, 0.06652620f, -0.16249628f, 0.10892498f, 
    -0.18524943f, 0.03631891f, -0.09687056f, 0.06467807f, -0.13236104f, -0.20648362f, -0.25070623f, 0.08938649f, 
    -0.00672584f, 0.10540063f, 0.05525035f, 0.08030304f, 0.51819485f, 0.04113242f, -0.16398247f, -0.33821255f, 
    -0.08849093f, -0.04788005f, -0.04025390f, -0.00202402f, -0.08731459f, -0.07547851f, -0.03166341f, 0.04466568f, 
    0.05600409f, -0.14709449f, 0.01352670f, 0.00382658f, 0.03796672f, 0.17174241f, 0.12945816f, 0.17734601f, 
    0.29403237f, -0.71003973f, 0.03810357f, -0.24514490f, 0.61568993f, -0.07963561f, 0.03450737f, 0.10610152f, 
    0.09889980f, -0.15541326f, -0.08340798f, -0.02014229f, -0.14037609f, 0.01005626f, 0.24441873f, -0.12551440f, 
    -0.03726574f, 0.02005901f, -0.17525131f, 0.15497366f, -0.40087807f, 0.01289618f, -0.21411256f, -0.48764637f, 
    0.10943658f, -0.06781697f, -0.01325489f, -0.03043713f, -0.03280083f, -0.16199628f, 0.01646850f, -0.13156833f, 
    -0.03015121f, -0.02203669f, -0.02490123f, 0.07577499f, -0.04043853f, -0.04710542f, 0.21758495f, 0.23013972f, 
    -0.29789796f, -0.33284348f, 0.20667714f, -0.37787777f, 0.00457971f, -0.13198777f, -0.05700367f, 0.13601226f, 
    -0.04341609f, 0.06628983f, 0.19135058f, -0.09019168f, -0.00562134f, 0.11158055f, -0.02369443f, -0.12804306f, 
    0.03283446f, -0.07250696f, 0.11159272f, -0.11628463f, 0.15480901f, 0.28765672f, 0.44468147f, 0.03681732f, 
    -0.46959844f, 0.25228953f, -0.17700672f, 0.19120903f, -0.06957970f, 0.04810043f, 0.00171166f, -0.00162714f, 
    -0.10337653f, 0.04203193f, -0.11697402f, 0.03919408f, 0.13109319f, -0.11201131f, 0.03443288f, -0.19800487f, 
    -0.18058419f, 0.35361949f, -0.02077732f, 0.14255577f, -0.01004334f, 0.11702915f, 0.06882018f, 0.03037785f, 
    0.16409630f, -0.05595065f, -0.09346845f, 0.00652395f, -0.05026481f, 0.05963326f, -0.02227604f, 0.05333540f, 
    0.14119150f, -0.05957907f, -0.00166454f, -0.03059859f, 0.04029923f, -0.01288117f, -0.13980635f, 0.43271092f, 
    -0.06081843f, 0.11852451f, 0.16225305f, -0.06919339f, 0.03419765f, 0.08813823f, 0.06323119f, 0.02287004f, 
    0.00238756f, 0.12172944f, 0.04427566f, -0.04290704f, 0.00292824f, 0.16778052f, -0.10384642f, -0.02399760f, 
    0.07552695f, 0.17988366f, -0.25702694f, -0.06429014f, -0.12548259f, -0.19039008f, 0.15956023f, 0.07816067f, 
    -0.07060448f, 0.06398526f, 0.09987543f, -0.18128733f, -0.04982395f, -0.08275751f, 0.07055886f, -0.04088479f, 
    -0.05991882f, 0.23911749f, -0.13647532f, 0.05736337f, -0.49148148f, -0.05579692f, 0.02132072f, -0.08242168f, 
    -0.21711004f, -0.18526736f, 0.10848849f, -0.03500845f, -0.02069596f, -0.02245855f, -0.20825174f, -0.17375293f, 
    0.00567011f, 0.03444043f, -0.00765736f, 0.04038880f, -0.06511293f, -0.03073204f, -0.12527537f, 0.08827908f, 
    -0.06252149f, 0.27562743f, -0.21136145f, 0.25949180f, -0.30567122f, -0.07665151f, -0.27717525f, 0.23957199f, 
    -0.00069157f, 0.13662018f, 0.14997508f, -0.05876441f, -0.02425556f, -0.10927041f, 0.00190074f, -0.17175087f, 
    -0.21512359f, -0.08959196f, -0.14931159f, -0.26167771f, -0.56253183f, 0.47294644f, -0.11297062f, 0.18043463f, 
    0.04014911f, -0.07473844f, -0.11686480f, -0.00447839f, 0.10307862f, 0.12263317f, -0.09455956f, 0.17728771f, 
    0.13714522f, -0.10544462f, 0.12649551f, -0.00187375f, -0.08061428f, -0.06379985f, 0.03329670f, 0.07015100f, 
    -0.78914797f, 0.29752943f, 0.28052473f, -0.22825143f, -0.23579328f, 0.12989800f, 0.14206639f, -0.04846445f, 
    0.06518341f, -0.08254312f, -0.02446994f, 0.02774939f, 0.00266609f, 0.05529731f, 0.01699512f, -0.09157026f, 
    0.08519321f, 0.01606960f, -0.04910761f, 0.05290237f, -0.40411684f, 0.26255885f, -0.08067010f, 0.22495829f, 
    0.13887963f, -0.01101952f, -0.18428980f, 0.09127239f, 0.02477744f, -0.04645411f, 0.01056718f, 0.07396698f, 
    0.09315772f, -0.08202098f, -0.06283574f, -0.03315122f, 0.00647996f, 0.06407970f, -0.01696518f, -0.13012028f, 
    -0.01281682f, 0.02698280f, 0.07116734f, -0.02205141f, -0.10464564f, -0.01184182f, -0.01799164f, -0.11287107f, 
    -0.00058546f, -0.11553132f, -0.02830612f, -0.01797211f, 0.16884872f, 0.07821421f, -0.13894089f, -0.01149617f, 
    0.03524723f, 0.00847922f, 0.01944375f, -0.01405558f, 0.21288744f, 0.55997562f, 0.11058065f, -0.15083629f, 
    0.32130671f, -0.10473686f, 0.24403393f, 0.00955497f, -0.10213161f, -0.01843957f, -0.05638033f, -0.10601173f, 
    -0.05601365f, -0.17704800f, 0.12476005f, 0.05262973f, 0.06867392f, 0.07494213f, -0.08162528f, 0.10939523f, 
    -0.61248177f, -0.11681366f, 0.19679275f, 0.07169947f, 0.13845327f, 0.13792659f, -0.00675482f, -0.22877644f, 
    0.08620411f, -0.04451616f, -0.12115441f, 0.00695544f, 0.09359691f, -0.12149870f, -0.13242541f, -0.14823696f, 
    -0.03075461f, 0.10258013f, 0.00977100f, 0.06472050f, 0.35828990f, 0.09332737f, 0.34141779f, 0.07414422f, 
    0.61446148f, -0.11760418f, 0.08471449f, 0.00585630f, 0.10096505f, -0.04063732f, -0.09333125f, 0.05614750f, 
    -0.05881783f, 0.07913288f, -0.05744962f, -0.03417841f, 0.00722984f, 0.02070914f, 0.05775717f, 0.03538421f, 
    -0.08233432f, -0.15419067f, 0.05008039f, 0.00618285f, 0.09820434f, -0.23815095f, 0.13263433f, -0.09005039f, 
    -0.00537309f, 0.05979589f, 0.01791000f, 0.12888835f, -0.22736326f, -0.02421489f, -0.02019736f, -0.11479295f, 
    0.08393230f, 0.03832123f, -0.04461253f, -0.07718981f, 0.31396338f, 0.17020823f, 0.42911187f, 0.15347134f, 
    0.11301456f, 0.20446727f, 0.02213720f, -0.05340732f, -0.08063020f, -0.02482030f, -0.00852045f, -0.02957878f, 
    -0.09653132f, -0.14714573f, -0.08848996f, -0.02913691f, -0.08806515f, -0.07843893f, 0.03803483f, -0.12597322f, 
    0.23168097f, 0.13949899f, 0.27454752f, 0.23072597f, 0.21221103f, -0.02991431f, -0.06235122f, -0.04515000f, 
    -0.07672531f, -0.09869385f, -0.04918238f, -0.00571980f, -0.10149295f, -0.01817486f, -0.02383675f, -0.05840436f, 
    -0.11371803f, -0.04394009f, 0.06665668f, -0.23564510f, 0.14106421f, -1.08677793f, 0.09627382f, -0.26907125f, 
    -0.34887990f, -0.04593544f, 0.05510848f, 0.02826547f, -0.05222865f, -0.04628186f, -0.05137775f, -0.13420333f, 
    -0.16835578f, 0.01894212f, 0.06745955f, -0.13611427f, 0.14922206f, 0.01329651f, 0.00292511f, 0.03295365f, 
    -0.40114817f, 0.05110383f, -0.43911517f, -0.14905195f, -0.35774216f, 0.07112458f, 0.05228294f, -0.10783415f, 
    -0.00686270f, -0.10855279f, -0.14695422f, 0.03011639f, -0.02896937f, -0.08468565f, 0.05907501f, -0.05365216f, 
    -0.04088983f, -0.02464877f, -0.10250099f, 0.10865757f, -0.64966184f, 0.25967652f, 0.26849130f, 0.01407089f, 
    0.01599178f, 0.00674838f, 0.06489436f, -0.06268914f, 0.03361828f, -0.05000088f, -0.02919553f, 0.02456294f, 
    -0.02749132f, 0.04301243f, -0.14280300f, -0.01985597f, -0.01161006f, 0.01335892f, -0.05208854f, -0.09435001f, 
    0.30276898f, 0.25664720f, -0.00742129f, 0.10491723f, 0.08619826f, -0.04990452f, 0.07100676f, -0.30576193f, 
    0.12894194f, 0.02927834f, -0.14119212f, 0.09945022f, -0.00715045f, 0.06237322f, -0.11981140f, 0.05828594f, 
    0.03434408f, -0.02412897f, 0.06626308f, 0.02565601f, -0.27105314f, 0.10721894f, -0.32369819f, -0.04051268f, 
    -0.25523350f, -0.03807211f, 0.08441433f, 0.10368501f, -0.03713620f, -0.06047527f, 0.17841737f, -0.01269103f, 
    -0.08688456f, -0.02479535f, -0.07604740f, -0.05976427f, -0.12109333f, -0.07166942f, -0.13412791f, -0.03256467f, 
    -0.05098826f, -0.43517503f, 0.02200476f, -0.16736871f, -0.26498562f, -0.01967823f, -0.13751733f, 0.03836712f, 
    -0.07668887f, -0.17199869f, 0.10052221f, -0.04539125f, -0.24746719f, -0.03301675f, -0.04022566f, 0.08407499f, 
    0.12714988f, -0.07080567f, -0.04722005f, -0.02401797f, -0.00495578f, -0.08375457f, -0.40215868f, -0.05390330f, 
    0.06583153f, -0.00748412f, -0.07489830f, 0.07754299f, -0.07265604f, -0.09401740f, -0.09547593f, -0.03762591f, 
    0.02128697f, 0.02335732f, -0.10240620f, 0.03303640f, -0.05225010f, -0.15187450f, -0.00882982f, 0.01460014f, 
    0.09160206f, 0.14188501f, -0.40593335f, 0.23702991f, 0.08652059f, 0.12809223f, 0.09688397f, -0.06625964f, 
    -0.08282726f, -0.01240019f, -0.00973711f, -0.01205460f, 0.08017974f, -0.02998621f, -0.12171517f, 0.04536556f, 
    0.02668972f, 0.02146584f, 0.15400350f, 0.05544800f, -0.14486323f, 0.00565890f, -0.23459810f, -0.00070963f, 
    -0.42727599f, -0.01219499f, -0.22541794f, -0.23557390f, -0.03144065f, -0.07555525f, 0.13856778f, -0.03431096f, 
    -0.00511531f, 0.04067574f, 0.05503581f, 0.08493685f, -0.05352100f, -0.14141542f, 0.10828769f, 0.18523452f, 
    0.09006404f, 0.06532954f, -0.07776080f, 0.13509892f, 0.26354685f, -0.27689826f, -0.14279632f, -0.20950255f, 
    -0.23279622f, 0.07978608f, -0.20353520f, -0.21778075f, -0.14809568f, -0.17404512f, 0.14396082f, 0.02910282f, 
    0.16639331f, 0.09054095f, 0.11089046f, -0.03860006f, -0.47953221f, 0.30871832f, -0.18608159f, -0.32843482f, 
    -0.33750781f, 0.00854088f, 0.06704198f, 0.10004693f, -0.02472002f, -0.02472021f, 0.19559216f, -0.09999092f, 
    -0.25236097f, 0.01193387f, 0.09938154f, -0.08295397f, 0.01921861f, -0.05357908f, 0.07310014f, 0.08493842f, 
    -0.26739591f, 0.02076391f, -0.52680063f, -0.35557967f, -0.05241488f, 0.05020151f, -0.14728968f, -0.20836987f, 
    -0.00777953f, -0.14466694f, 0.09984315f, 0.05202070f, 0.27173683f, -0.08943383f, 0.05461130f, 0.01768994f, 
    0.00429145f, -0.00150954f, 0.12774269f, -0.17818333f, -0.37752566f, -0.41861272f, -0.20277207f, -0.45941585f, 
    -0.39552918f, 0.14115418f, -0.13823038f, -0.07909690f, -0.29862130f, -0.04127455f, -0.02101629f, 0.06316655f, 
    0.00352003f, 0.10548663f, -0.10584998f, -0.06056837f, 0.10044552f, 0.01449695f, -0.08553638f, -0.06778668f, 
    0.09538057f, 0.28080118f, 0.03532591f, 0.02506376f, 0.15541045f, -0.27091956f, -0.15469523f, 0.06307284f, 
    -0.10517782f, -0.11237937f, 0.03311938f, 0.01468194f, 0.04578441f, 0.01092011f, -0.05863487f, 0.05331753f, 
    0.10977182f, -0.01349668f, 0.14577734f, 0.06837253f, -0.36840531f, -0.14022255f, 0.28260946f, -0.23035075f, 
    -0.05541590f, 0.06878550f, 0.00720502f, -0.03887898f, -0.26908264f, -0.13220203f, 0.05763883f, -0.04443839f, 
    -0.18633243f, 0.02011754f, 0.01452336f, -0.20893827f, -0.01941712f, 0.02788863f, -0.28807199f, -0.09801348f, 
    -0.40867329f, -0.26436710f, 0.49400765f, -0.14724888f, 0.14518476f, -0.13546903f, -0.04245209f, 0.15537515f, 
    -0.11736658f, -0.27840963f, -0.03382019f, 0.04904356f, 0.19401146f, 0.07844961f, 0.07552626f, -0.08190831f, 
    0.00866609f, 0.06470380f, -0.21827467f, 0.10439841f, 0.13415992f, -0.25288346f, -0.32757634f, 0.15136793f, 
    0.27630511f, 0.17554915f, 0.07937291f, -0.02536523f, -0.06083261f, -0.10471962f, 0.00705469f, 0.02572092f, 
    0.06757668f, 0.07765368f, -0.07126582f, 0.11737775f, 0.01076917f, 0.03938402f, 0.05890814f, -0.01701112f, 
    -0.04152915f, 0.18317866f, -0.17901707f, 0.01608116f, 0.12030225f, 0.06512471f, 0.13279314f, -0.07330874f, 
    -0.05505936f, -0.00362381f, 0.19934152f, 0.11193881f, -0.12400740f, 0.15926738f, -0.16887358f, -0.16688164f, 
    -0.02650609f, 0.08619959f, 0.10187392f, -0.03354223f, -0.06485832f, 0.27094781f, -0.19333574f, 0.22277096f, 
    -0.16593254f, -0.00562553f, 0.06475987f, -0.27500099f, -0.09617077f, -0.02867459f, 0.10081848f, 0.00549703f, 
    0.06994376f, 0.01046930f, 0.00053066f, 0.01640807f, -0.05255921f, -0.05757587f, 0.23707283f, -0.07590239f, 
    -0.25220251f, 0.03174628f, -0.09018783f, 0.04576995f, -0.19027103f, -0.01209047f, 0.11623229f, -0.22551036f, 
    -0.00729663f, -0.20961675f, 0.07771824f, 0.01401846f, -0.02377498f, -0.10043187f, 0.14444697f, -0.11110393f, 
    0.04874150f, -0.21116954f, 0.08964717f, -0.09265131f, 0.39949957f, 0.14557739f, 0.02786627f, 0.07353906f, 
    0.07205091f, -0.01003296f, -0.00188192f, -0.13299695f, -0.16901766f, -0.12432490f, 0.05474523f, -0.05647718f, 
    0.00893653f, -0.07093231f, 0.05842969f, -0.18312624f, -0.00670916f, -0.04376087f, 0.12665784f, -0.17225185f, 
    0.27330986f, 0.16969657f, -0.00481483f, 0.05549446f, 0.24596359f, 0.07821380f, -0.02447575f, -0.15870833f, 
    -0.09105018f, -0.02891895f, -0.08578989f, -0.04034788f, -0.22286735f, -0.00730700f, 0.05320396f, -0.00718687f, 
    -0.10631777f, 0.16900852f, 0.14261600f, 0.15047491f, 0.06243999f, 0.21244736f, 0.06649257f, 0.24750109f, 
    0.16436093f, 0.05343816f, 0.07653738f, -0.23147836f, -0.19901186f, -0.06921709f, -0.00443409f, 0.07181937f, 
    0.04527030f, -0.16327767f, -0.01362403f, -0.14185739f, 0.09059688f, 0.04502935f, 0.18381982f, -0.08769625f, 
    -0.34664553f, 0.12238683f, 0.27341089f, -0.07684673f, -0.27046210f, 0.05494776f, 0.02711298f, -0.07673469f, 
    -0.13965549f, -0.12172044f, 0.03755903f, -0.00290076f, -0.07709125f, 0.01252737f, 0.08780196f, 0.06695388f, 
    -0.12297930f, 0.12030527f, -0.24907967f, 0.01756242f, -0.49764010f, -0.20449188f, -0.08934522f, 0.01099765f, 
    0.01934144f, -0.03234702f, -0.03561306f, -0.05175149f, -0.00812501f, 0.06331686f, -0.09038520f, -0.14454164f, 
    -0.00286552f, -0.04544472f, -0.03182463f, 0.07726157f, -0.00200295f, 0.04866050f, -0.12193736f, 0.06062374f, 
    0.17717820f, -0.19637616f, -0.24105115f, 0.08961238f, 0.18330288f, 0.14336480f, 0.15246285f, -0.06897129f, 
    0.04149755f, 0.07890585f, -0.00698816f, -0.00127940f, 0.00969150f, 0.03391460f, -0.10933545f, -0.13046959f, 
    -0.05154917f, 0.01067965f, -0.14543083f, 0.12724899f, -0.75815618f, 0.46459076f, -0.14377932f, 0.38115907f, 
    -0.34996501f, -0.01543261f, 0.09952453f, -0.15381336f, 0.01771003f, 0.01828611f, -0.03168939f, -0.07461762f, 
    0.12652157f, 0.05950583f, 0.10796265f, 0.06859701f, -0.03068651f, 0.06352890f, -0.33257931f, -0.01591980f, 
    0.10167255f, -0.36107171f, 0.30273333f, -0.34767190f, -0.38454387f, -0.18149078f, 0.08205561f, 0.06092066f, 
    0.03921272f, 0.11432142f, 0.08219334f, -0.24079707f, 0.18748578f, -0.26312795f, -0.15279646f, -0.00873314f, 
    0.03978060f, 0.10514595f, 0.11582172f, -0.07875820f, 0.22095990f, -0.31788972f, -0.28890285f, -0.19287883f, 
    0.03774571f, -0.01149524f, 0.05470081f, -0.02704163f, 0.02319729f, 0.09715860f, 0.10045478f, -0.17129764f, 
    -0.02867043f, 0.18513003f, -0.10091034f, -0.02111006f, -0.03487666f, 0.12818778f, 0.02868188f, 0.12097134f, 
    0.31179798f, 0.24986014f, -0.34888089f, 0.31805936f, -0.13389230f, 0.27542651f, 0.02186494f, -0.00187962f, 
    0.12436221f, 0.13756077f, -0.13651109f, 0.12534182f, 0.00369622f, 0.14663357f, 0.14156896f, -0.09821164f, 
    -0.12760948f, 0.02609646f, -0.04171761f, 0.00557634f, 0.01998701f, -0.29565823f, 0.06824669f, 0.26542357f, 
    -0.22110473f, -0.11721243f, 0.08203395f, -0.09454910f, -0.08814164f, -0.02410759f, -0.18829173f, -0.03805318f, 
    0.17797211f, -0.08774787f, 0.08958668f, 0.05624402f, 0.04205888f, -0.06309790f, 0.09261709f, 0.04038353f, 
    0.38925707f, -0.18846922f, -0.15962923f, 0.29127029f, 0.21449891f, 0.03391312f, -0.01796061f, -0.15238495f, 
    0.01199858f, 0.10447501f, -0.09093633f, 0.08040705f, -0.03838724f, -0.18105236f, 0.06948516f, 0.01953602f, 
    -0.06378368f, 0.02689960f, 0.03359314f, 0.21087958f, -0.00498939f, -0.63751131f, 0.33879182f, -0.28763714f, 
    -0.34451145f, 0.00976638f, 0.03726356f, -0.16845120f, -0.03605968f, 0.01215899f, -0.06526729f, -0.08712567f, 
    0.02967193f, -0.06213435f, -0.01150311f, -0.11616728f, -0.09086142f, -0.06991334f, 0.15805216f, 0.10297004f, 
    0.43543389f, 0.03440521f, 0.19186637f, -0.00268480f, -0.47264093f, -0.06175810f, -0.10045131f, 0.36501348f, 
    -0.05683634f, -0.01462179f, -0.08701166f, 0.04932031f, -0.15120216f, -0.28899089f, 0.12442507f, -0.13503315f, 
    0.05582069f, -0.20733713f, 0.00873138f, -0.05729358f, -0.74041545f, -0.01288449f, 0.59694719f, -0.28747031f, 
    0.10630311f, 0.02619985f, 0.09776665f, 0.06460083f, -0.05226561f, -0.01398632f, 0.05771029f, 0.06882809f, 
    0.05087018f, 0.02218195f, 0.17597213f, 0.00934935f, 0.05036641f, 0.14764617f, -0.30872807f, -0.06916973f, 
    -0.43863592f, 0.38028234f, 0.29538602f, -0.10597656f, 0.04108941f, -0.02638086f, 0.03651934f, -0.22843321f, 
    -0.00222198f, -0.01923206f, -0.16183721f, 0.06695237f, -0.18661334f, 0.25509572f, 0.24868116f, 0.03466222f, 
    0.21153262f, 0.06255673f, 0.00542303f, 0.16943102f, -1.05572653f, 0.63804078f, -0.22873117f, 0.21325147f, 
    -0.03013966f, 0.08604538f, 0.11439104f, 0.00962796f, 0.33853695f, -0.04599101f, 0.00958843f, 0.04818152f, 
    0.00617743f, -0.03744039f, 0.08206804f, 0.26929858f, -0.05651965f, 0.15871598f, 0.00522575f, 0.07460120f, 
    0.35940671f, -0.66506189f, 0.30613390f, 0.09062731f, -0.00830562f, 0.04509494f, 0.09891377f, -0.03648269f, 
    -0.07236151f, -0.30172384f, -0.13990745f, 0.21004167f, 0.15219416f, -0.02325024f, -0.01388152f, -0.05000610f, 
    0.04662535f, -0.41798225f, -0.18199770f, -0.03247146f, 0.38274431f, -0.06538365f, 0.02635153f, -0.61870211f, 
    -0.19707440f, -0.07922111f, 0.06911895f, -0.29434136f, 0.01148528f, -0.10332059f, -0.05589531f, -0.08307125f, 
    0.09010208f, 0.01985119f, -0.18581156f, 0.06733337f, 0.07654306f, 0.02376230f, -0.12073737f, -0.05135745f, 
    -0.82336736f, -0.66121906f, -0.34249124f, -0.06530981f, 0.06902068f, 0.14697139f, -0.03248926f, -0.23636593f, 
    0.07017639f, -0.06574529f, 0.22850522f, 0.07068891f, -0.01392459f, 0.04614543f, 0.03187410f, 0.07936732f, 
    -0.08234326f, 0.08154594f, 0.02299650f, 0.01065497f, -0.08867277f, 0.03261916f, -0.17768797f, 0.08786248f, 
    0.00198493f, 0.04658121f, -0.01676459f, 0.06758001f, -0.04273928f, 0.13200788f, 0.05932591f, 0.17967759f, 
    0.05772457f, -0.06401119f, 0.05474031f, 0.09134544f, 0.02784310f, 0.08029594f, 0.03439979f, 0.10788037f, 
    0.42645496f, 0.09807242f, -0.19814508f, 0.01656525f, -0.11029526f, -0.16194983f, -0.03524165f, -0.23453104f, 
    -0.02387300f, -0.16636309f, 0.04413192f, 0.15229464f, -0.09138905f, -0.11275388f, 0.13710800f, -0.08392073f, 
    -0.07973076f, 0.09727757f, -0.20486636f, -0.07160386f, -0.22695920f, -0.49675646f, 0.09739821f, -0.16799504f, 
    0.41400906f, 0.14132954f, 0.24068671f, 0.00547242f, -0.01375634f, -0.21822114f, 0.07682312f, -0.03844048f, 
    0.12702362f, -0.04321745f, 0.09107670f, -0.14906725f, 0.06016834f, -0.10787883f, -0.07637338f, 0.10451782f, 
    -0.10468931f, 0.23001124f, 0.01337946f, 0.07829770f, -0.13113205f, 0.25626111f, 0.01585292f, 0.03648796f, 
    0.03769433f, -0.07844093f, -0.02696020f, 0.23092580f, 0.04986777f, 0.23380302f, 0.18476409f, -0.05244339f, 
    0.02077213f, -0.20797530f, -0.40023023f, -0.07116818f, 0.19127950f, 0.19821937f, 0.07132901f, -0.02068280f, 
    -0.05652911f, -0.06110846f, -0.00735797f, -0.01921013f, 0.02051735f, 0.08105280f, -0.08643349f, -0.10153369f, 
    -0.14313574f, -0.09363750f, -0.08669182f, 0.18044987f, -0.07691279f, -0.18469660f, -0.19059382f, 0.12194174f, 
    0.24113646f, 0.05223499f, 0.12318975f, 0.11440713f, 0.04820488f, -0.12426768f, -0.03848385f, 0.02948540f, 
    0.19840042f, 0.11309024f, 0.07315097f, -0.05874898f, -0.04169077f, -0.16193314f, -0.03478288f, -0.08557334f, 
    0.05877326f, 0.17012107f, 0.14449133f, 0.01123900f, 0.32514259f, 0.11580987f, 0.04407009f, -0.09032447f, 
    0.02810845f, 0.25311884f, 0.15674214f, -0.02653684f, 0.09604569f, -0.01195895f, 0.04062833f, 0.08959085f, 
    -0.09521462f, 0.12098667f, -0.14247690f, -0.01582838f, -0.04309571f, -0.13775872f, -0.23272125f, 0.13467132f, 
    0.23980017f, 0.23086357f, 0.05242722f, -0.08283979f, -0.11393552f, 0.02600764f, 0.04185770f, 0.12924509f, 
    0.07615224f, 0.05652604f, -0.04427359f, 0.02508560f, 0.04329479f, 0.03524986f, -0.02401849f, 0.04702865f, 
    0.17280155f, 0.06307036f, -0.13690855f, 0.14119640f, -0.91984826f, -0.10757382f, -0.38098243f, -0.18748286f, 
    -0.22142495f, 0.11041284f, 0.05936649f, -0.08115239f, 0.10560643f, 0.10246162f, -0.02644690f, 0.13579021f, 
    -0.03494790f, 0.19906606f, 0.06922179f, 0.17270093f, -0.08081408f, 0.18129425f, -0.12745804f, 0.12006970f, 
    -0.82118493f, -0.21098489f, 0.02153792f, -0.04417964f, -0.10203178f, 0.11598212f, 0.02939594f, -0.03324702f, 
    -0.03549531f, 0.05278670f, 0.12157151f, 0.10973636f, 0.07956158f, 0.18561135f, 0.05162024f, 0.15509626f, 
    0.07044940f, 0.05223883f, 0.04148957f, 0.07274340f, -0.35399246f, -0.43593946f, -0.26037312f, 0.08371706f, 
    0.14713776f, 0.08666954f, -0.00863536f, 0.01844564f, 0.02016740f, -0.11959600f, 0.18955183f, 0.07253475f, 
    0.03506549f, -0.01211867f, 0.15410046f, -0.01447887f, 0.04670618f, 0.07719621f, 0.25349009f, 0.07452632f, 
    -0.53706360f, -0.51861250f, 0.07856126f, -0.03163009f, 0.20933093f, 0.20801884f, 0.13028881f, 0.04425836f, 
    -0.12857710f, -0.19924545f, 0.11195484f, 0.13096039f, -0.11734213f, -0.02953570f, -0.10075328f, 0.10700914f, 
    -0.24373257f, -0.11765786f, -0.04058457f, 0.06762780f, -0.68841797f, -0.58595681f, -0.23268017f, -0.17780058f, 
    -0.49152294f, 0.03704326f, 0.17232686f, 0.06285954f, -0.19774537f, -0.12593558f, 0.09014525f, -0.13756225f, 
    -0.01006892f, -0.21370463f, -0.09412992f, -0.00841833f, -0.01318868f, 0.03765696f, 0.30630663f, -0.09751032f, 
    -1.08670604f, -0.15161000f, -0.34257019f, -0.28227660f, 0.03390628f, 0.08358996f, 0.17180957f, -0.33502126f, 
    -0.09631538f, 0.06721839f, 0.09770261f, -0.03419410f, -0.06017065f, -0.04808993f, 0.08968962f, -0.03427992f, 
    0.12308982f, 0.08882941f, 0.10257037f, 0.14146735f, -1.20810676f, -0.65663385f, -0.07431209f, -0.39280227f, 
    -0.56891125f, 0.16835527f, 0.01648340f, -0.03922945f, -0.17451710f, 0.21171509f, -0.01640712f, -0.07383092f, 
    0.04907654f, 0.10089996f, -0.00946065f, -0.02808546f, -0.12272362f, -0.06811081f, 0.01630953f, 0.07743668f, 
    0.44298741f, -0.13233493f, -0.21659060f, 0.14995418f, -0.07218725f, 0.15475537f, 0.08862604f, -0.05203823f, 
    -0.02775406f, 0.06443130f, 0.06135971f, 0.14399126f, -0.07075597f, 0.17945972f, 0.25688997f, -0.01787635f, 
    0.00911875f, -0.00826056f, -0.23940417f, 0.20181024f, -0.08117037f, -0.19489542f, 0.00803094f, 0.30359864f, 
    -0.08091027f, -0.02325381f, 0.06312145f, -0.01618116f, -0.11508552f, -0.30002460f, 0.08795089f, -0.25075921f, 
    0.07033512f, 0.02057387f, -0.10787038f, 0.06779911f, -0.05812972f, 0.02438304f, -0.07168664f, -0.25695714f, 
    -0.38289472f, -0.30359209f, 0.01162028f, -0.11653733f, -0.09988564f, -0.05509528f, 0.12658714f, -0.05943186f, 
    0.10465344f, -0.08917242f, -0.42752182f, 0.01134595f, 0.15195334f, 0.09682759f, -0.04008372f, -0.21277736f, 
    -0.07901219f, -0.07625795f, -0.21781544f, -0.08858773f, -0.57303768f, 0.54806328f, -0.04118073f, 0.27182823f, 
    -0.07900805f, 0.30414966f, -0.15232627f, 0.20870800f, -0.01886144f, -0.00287447f, 0.17312573f, 0.19120346f, 
    -0.02429319f, -0.00174550f, 0.17537993f, -0.17643671f, 0.18091772f, -0.10622057f, 0.07906172f, 0.07082970f, 
    0.68552029f, 0.39388552f, -0.44795021f, -0.10113955f, 0.27558002f, -0.10897592f, 0.28847188f, -0.07019497f, 
    0.16801080f, -0.19607048f, 0.23822707f, 0.06725265f, -0.03456478f, -0.01261182f, -0.02846668f, 0.09177507f, 
    0.11045807f, 0.09505930f, 0.06621226f, 0.18954337f, -0.27696770f, 0.25745115f, -0.22940987f, -0.12160030f, 
    0.76070637f, 0.20383713f, -0.13992523f, 0.08493669f, 0.07382204f, 0.00922000f, -0.11164359f, -0.20790678f, 
    0.04190017f, 0.14777815f, 0.04010830f, -0.04882310f, -0.00183140f, 0.02542976f, 0.15444750f, -0.00489914f, 
    -0.38188341f, -0.30528200f, -0.15565287f, -0.00278723f, -0.00264180f, -0.01076498f, -0.09494531f, 0.10357407f, 
    -0.14136159f, 0.18238820f, -0.17320755f, -0.01191865f, 0.00385370f, -0.07284252f, -0.12999611f, -0.05572989f, 
    -0.04894790f, 0.01815361f, -0.14640680f, -0.02785802f, -0.02501344f, 0.37843579f, -0.13526286f, -0.29570404f, 
    -0.25854865f, -0.10687038f, -0.21683681f, 0.01980950f, -0.01009436f, -0.31511527f, -0.07620165f, -0.03965846f, 
    -0.04297803f, 0.00706005f, 0.05470230f, 0.28215334f, -0.02195785f, -0.10646423f, 0.05328605f, 0.00162534f, 
    0.01158264f, 0.35324332f, 0.04168389f, -0.12827379f, -0.01007786f, -0.08968524f, -0.07053520f, 0.22236161f, 
    -0.35059127f, -0.10230988f, 0.05912187f, -0.07143180f, -0.01588212f, -0.20764552f, -0.09433527f, -0.06557488f, 
    -0.06182994f, -0.07204107f, 0.04037914f, -0.08207805f, 0.88259202f, 0.16767339f, -0.46040335f, 0.09403945f, 
    -0.06568288f, -0.09499019f, -0.07745980f, 0.00081371f, 0.03989088f, 0.07076612f, 0.10676232f, -0.02911399f, 
    -0.00192197f, 0.12081420f, 0.11791631f, 0.03206171f, -0.01509980f, -0.08679459f, -0.03961541f, -0.04372535f, 
    0.25025520f, 0.03884343f, -0.21917105f, -0.26143077f, -0.08360805f, 0.20077036f, -0.05951669f, 0.00598505f, 
    -0.03579337f, 0.10521540f, 0.12200627f, -0.01983883f, 0.10679676f, -0.08142895f, 0.03287604f, -0.01995821f, 
    -0.09962244f, 0.15893763f, -0.03476277f, 0.11039439f, 0.15307011f, -0.56413025f, -0.06943958f, 0.15847419f, 
    0.05705173f, 0.10902294f, 0.15770413f, 0.00760526f, 0.05922110f, -0.06743602f, 0.05354917f, 0.08394973f, 
    -0.02474052f, 0.15808034f, -0.16134919f, -0.04359004f, 0.00905782f, -0.20390616f, -0.15769944f, -0.13578388f, 
    0.08837420f, 0.36837101f, -0.18276915f, 0.10056086f, 0.12346608f, 0.40522492f, 0.05096582f, -0.05622220f, 
    -0.00656255f, -0.12323035f, -0.06939818f, -0.10976389f, 0.14020951f, -0.01570871f, 0.01589801f, -0.06635321f, 
    0.06871656f, -0.13419756f, -0.04689143f, 0.16283701f, -0.17761797f, -0.62533754f, -0.32328588f, -0.09077968f, 
    -0.51412308f, 0.01150577f, 0.15293474f, 0.20343855f, -0.07671477f, 0.12370726f, 0.08728676f, 0.06538613f, 
    -0.07215451f, -0.06589928f, 0.02104982f, -0.16681020f, 0.05834288f, 0.00574260f, -0.13713735f, -0.10339817f, 
    -0.64992726f, -0.09792472f, -0.15490654f, 0.00389008f, -0.40601587f, -0.01153811f, 0.14632505f, -0.02415279f, 
    0.02442737f, 0.12668064f, 0.20494515f, -0.10160907f, 0.13637239f, -0.18815023f, 0.06657489f, -0.15959918f, 
    0.03882439f, -0.12119200f, 0.00454575f, 0.04152894f, 0.44058552f, -0.18683097f, -0.47620857f, -0.15089805f, 
    -0.05020670f, -0.18718582f, -0.09495389f, 0.13711077f, -0.04636288f, 0.12914659f, 0.11262717f, 0.02701314f, 
    -0.05728187f, 0.02107489f, -0.03614167f, 0.13937674f, 0.16503419f, -0.10188824f, 0.05705313f, -0.19446978f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.21793701f, 0.05835814f, -0.08823070f, -0.01515140f, 0.03497089f, 0.02486048f, -0.02807925f, -0.07990513f, 
    -0.03249634f, 0.05241644f, 0.16313264f, 0.08714168f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
