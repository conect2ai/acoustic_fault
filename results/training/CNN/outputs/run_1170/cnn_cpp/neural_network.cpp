#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.01981963f, 0.31015211f, -0.55702978f, -0.05598324f, 0.45381281f, 0.20781538f, -0.35437322f, 0.00996979f, 
    -0.21220115f, -0.42254329f, 0.35054871f, -0.02048067f, 0.03797400f, 0.06422351f, -0.00113003f, 0.41798180f, 
    -0.17241277f, -0.11225680f, -0.16512938f, -0.21890947f, -0.13334955f, 0.31584123f, 0.12576719f, 0.21688949f, 
    -0.00553237f, -0.38387251f, -0.01934598f, 0.31150040f, -0.44866416f, 0.33329082f, -0.29518077f, -0.32552892f, 
    0.26686364f, 0.53578907f, -0.05826772f, -0.08891666f, -0.04316096f, -0.38512030f, 0.06322748f, 0.31629550f, 
    0.16166778f, -0.10137490f, -0.01103541f, 0.31155640f, -0.28843877f, -0.01283797f, -0.29183587f, -0.14464658f, 
    0.00625313f, 0.35905027f, 0.72347987f, -1.14764595f, 0.22671810f, -0.16958950f, 0.34779647f, -0.70735753f, 
    -0.29858714f, 0.02155867f, 0.39532924f, 0.44795176f, 0.08234479f, 0.07797095f, -0.33057126f, -0.24473725f, 
    0.18580487f, -0.01316246f, -0.05285965f, -0.20005268f, 0.02301127f, -0.22993620f, -0.10651465f, 0.14211813f, 
    -0.15185162f, -0.19638279f, 0.18295801f, 0.58844888f, -0.35466063f, -0.25118712f, -0.09494860f, 0.32561442f, 
    -0.13605416f, 0.30450231f, 0.42671651f, 0.04344204f, -0.46967447f, -0.12544900f, -0.05425785f, -0.20448181f, 
    -0.19940312f, 0.07151336f, -0.22565584f, 0.14185230f, 0.12804347f, 0.10364060f, -0.30593455f, 0.32922524f, 
    -0.14969555f, -0.50702232f, -0.19786760f, 0.43885532f, -0.51490343f, 0.51604491f, 0.47024846f, -0.27400422f, 
    -0.02084647f, -0.31761962f, -0.47823688f, -0.39640445f, 0.03598788f, 0.40787628f, 0.03730687f, -0.25334367f, 
    -0.31061161f, -0.26319951f, 0.52336103f, -0.04339466f, -0.05902762f, -0.15174073f, 0.10821953f, 0.24898003f, 
    -0.06779134f, 0.05654326f, -0.39468575f, -0.18128902f, -0.52610147f, 0.24913260f, 0.33325648f, 0.33302414f, 
    0.27232853f, 0.07566421f, -0.18268439f, -0.13149896f, -0.02070903f, -0.17666142f, -0.12185658f, 0.09750169f, 
    0.13580056f, 0.11157682f, 0.18415040f, 0.01740564f, -0.18345626f, -0.21646541f, 0.03120130f, 0.06280237f, 
    0.01778567f, 0.01666677f, 0.00189159f, 0.05667438f, -0.06209745f, -0.02947990f, -0.31248084f, -0.10986718f, 
    0.46275997f, -0.07399847f, -0.16505048f, -0.24481305f, -0.37453023f, -0.37307480f, -0.02699970f, 0.32208666f, 
    -0.12659332f, 0.34962389f, -0.38683623f, -0.11930346f, 0.00366966f, -0.16763608f, 0.22586595f, 0.03832288f, 
    -0.18520354f, 0.11969917f, 0.18559012f, 0.25717247f, 0.25155899f, -0.15438847f, -0.09392758f, -0.59670812f, 
    -0.33532557f, 0.16205038f, 0.35343155f, 0.31547233f, -0.03303978f, 0.44635335f, 0.36333358f, -0.26031116f, 
    -0.22150859f, -0.07202137f, 0.11436705f, -0.01828205f, -0.18303241f, 0.00485944f, -0.04486858f, -0.08450255f, 
    0.05826592f, -0.26053089f, -0.05338063f, -0.07822830f, 0.39377993f, -0.18057348f, -0.22379705f, 0.34832522f, 
    0.26188642f, -0.86736459f, -0.52651948f, -0.56489438f, -0.23576918f, -0.61662138f, -0.36836419f, 0.51293987f, 
    -0.06275118f, 0.35476899f, -0.07450396f, -0.04716450f, -0.09207519f, -0.33296436f, 0.21241584f, 0.08000695f, 
    -0.15554948f, -0.07492954f, 0.33314011f, -0.18520932f, -0.01558045f, -0.30071363f, -0.29878595f, -0.27353641f, 
    0.07820968f, -0.66441494f, -0.49559510f, -0.28596103f, 0.11917180f, 0.07641802f, 0.53722674f, 0.31411138f, 
    0.15410902f, -0.03368011f, 0.01474978f, -0.12236185f, 0.10415800f, -0.04335000f, 0.07394028f, -0.03741014f, 
    -0.29293349f, 0.08563560f, -0.21167876f, 0.01580707f, 0.07926837f, 0.19882894f, -0.08701536f, 0.07250273f, 
    0.15307140f, 0.01588765f, -0.65001899f, -0.19092853f, -0.03421803f, 0.20820813f, -0.02901251f, 0.55359674f, 
    0.37470829f, -0.34306145f, -0.19439305f, -0.22288002f, -0.29743195f, -0.17575185f, 0.17428075f, 0.45093024f, 
    0.00833021f, 0.03000774f, -0.34818983f, -0.25883228f, 0.23221011f, -0.03387856f, 0.28125268f, -0.21406035f, 
    -0.12726112f, 0.36625922f, 0.00001148f, -0.11450455f, -0.37793216f, -0.65046841f, -0.43327093f, -0.46128389f, 
    0.10152075f, 0.01991986f, 0.17075551f, -0.35442612f, -0.28929833f, 0.10876080f, 0.29668349f, -0.17980208f, 
    -0.27825794f, -0.24581458f, -0.40997350f, -0.08115219f, -0.00328373f, -0.15671928f, -0.10098699f, -0.20936643f, 
    0.20982894f, 0.27781877f, 0.30435532f, -0.21800578f, -0.17388636f, -0.03470997f, 0.14904331f, 0.28528732f, 
    0.21979293f, 0.15960650f, -0.06740767f, 0.11280629f, -0.23660490f, -0.00118878f, -0.20296508f, 0.14056589f, 
    -0.12098909f, -0.28301233f, -0.05338417f, 0.25556901f, 0.02698195f, -0.11453947f, 0.20369096f, 0.15815522f, 
    -0.09443037f, 0.13936569f, -0.15413089f, -0.23582156f, -0.25908256f, -0.76227707f, 0.04813853f, -0.39054656f, 
    -0.04411077f, 0.07583727f, 0.23291822f, 0.03506271f, 0.24378754f, 0.01444335f, 0.09450647f, 0.21008046f, 
    0.08035961f, -0.24356063f, -0.06004402f, 0.05284340f, -0.11817269f, -0.37281644f, -0.10905696f, -0.10754168f, 
    0.09770622f, 0.19215530f, 0.32594827f, 0.22813241f, 0.14830008f, -0.05516733f, -0.45540223f, -0.09576251f, 
    -0.95071417f, -0.02182547f, -0.01246479f, -0.44943380f, 0.28950891f, -0.42361629f, -0.01222431f, -0.00428697f, 
    0.24180180f, 0.41394335f, 0.35170370f, 0.31896538f, -0.19525407f, 0.21320219f, -0.11698602f, -0.23915753f, 
    -0.47146031f, -0.25395808f, -0.04170088f, 0.24012947f, 0.03192930f, -0.15054385f, 0.06934085f, -0.50650001f, 
    -0.36441761f, -0.18034624f, -0.17562021f, -0.05845492f, 0.51631093f, -0.18374974f, -0.18306199f, -0.04460691f, 
    0.65702826f, 0.15404226f, 0.14758614f, 0.12542111f, 0.02961074f, -0.42016646f, -0.16027807f, -0.06633400f, 
    -0.08853453f, -0.20939100f, 0.31402317f, -0.19763876f, 0.11823052f, 0.34695318f, 0.22131172f, -0.24281116f, 
    -0.77377975f, -0.51322895f, -0.22638203f, 0.38921791f, -0.19053118f, 0.07848436f, 0.13303982f, -0.24068500f, 
    -0.13277283f, 0.11685901f, 0.08517750f, -0.13834344f, 0.05736043f, 0.25336203f, -0.09038475f, 0.08537077f, 
    0.19640633f, -0.23326021f, -0.26036122f, -0.09834016f, 0.20953308f, 0.20554438f, 0.21400180f, 0.07227878f, 
    0.22669920f, -0.00472404f, -0.19085677f, -0.49729493f, -0.63201857f, -0.57270432f, 0.06584761f, 0.00453156f, 
    -0.09066541f, 0.08187567f, 0.27321854f, 0.11572698f, 0.31252408f, 0.27557415f, 0.25430995f, 0.12622812f, 
    -0.11143657f, -0.09192707f, -0.07386249f, -0.00987540f, -0.00423065f, -0.03388246f, -0.14956413f, -0.09839911f, 
    -0.03240384f, 0.03421073f, 0.12399468f, 0.26693663f, -0.14127567f, 0.30584177f, 0.24037732f, 0.46261775f, 
    0.26120341f, 0.08475314f, -0.15422967f, -0.27369088f, -0.02672015f, 0.40681985f, 0.25983235f, -0.28514916f, 
    -0.26776472f, -0.31423035f, -0.02127926f, -0.20589472f, 0.09764519f, 0.16014196f, -0.12450331f, -0.02289954f, 
    -0.09974647f, 0.06520095f, 0.10763428f, -0.42999551f, -0.35087189f, 0.18713933f, -0.29541674f, 0.19127749f, 
    -0.44359061f, -0.12899670f, 0.32288906f, 0.10719581f, -0.38110939f, 0.13911794f, 0.50726086f, -0.02046224f, 
    0.36601174f, -0.40415394f, -0.33788460f, -0.20883276f, -0.27680686f, -0.18104127f, -0.20892729f, -0.06909528f, 
    0.00311144f, 0.22482461f, 0.18301451f, 0.03737054f, 0.47850069f, 0.68088323f, -0.36374688f, -0.44251174f, 
    -0.60086626f, -0.62610608f, -0.28700054f, -0.01469067f, 0.04313114f, 0.14060065f, 0.06203631f, 0.33543938f, 
    0.16994251f, 0.34848461f, 0.25173962f, -0.09115170f, -0.03078884f, -0.05462033f, -0.09511133f, -0.10903984f, 
    0.04048485f, -0.15059985f, -0.18277720f, -0.31571916f, -0.00613359f, -0.18771167f, -0.65117365f, -0.67609000f, 
    0.02421157f, -0.34368834f, 0.83765745f, 0.37703338f, 0.00875250f, -0.47132966f, 0.10418170f, 0.17202801f, 
    0.06924387f, -0.24109857f, -0.11686002f, 0.11692791f, 0.14694670f, -0.07729673f, 0.23132578f, 0.15961795f, 
    -0.18266958f, 0.08564837f, -0.19766295f, 0.08491578f, -0.03379647f, -0.06372426f, -1.21286309f, -0.71427095f, 
    -0.56275886f, -0.55313057f, -1.07203782f, 0.32060808f, 0.47989208f, 0.33119473f, 0.03012750f, -0.00636228f, 
    -0.05175608f, 0.09395021f, 0.02716444f, 0.34670091f, -0.24574044f, -0.43559337f, 0.13288258f, -0.27247986f, 
    -0.43422994f, 0.06577913f, -0.21968186f, -0.07576725f, 0.16159007f, -0.09806488f, 0.01083149f, 0.45890704f, 
    -0.11207563f, 0.47363943f, 0.26519382f, -0.01041571f, -0.38815340f, -0.01343297f, -0.52577734f, -0.44704980f, 
    -0.13787475f, 0.28426287f, -0.02227286f, 0.06506858f, 0.15001349f, 0.29013705f, 0.23958600f, -0.28625134f, 
    -0.29173622f, 0.17744650f, -0.09627693f, -0.13696621f, 0.17965481f, -0.22468387f, 0.02167412f, 0.04194981f, 
    0.26257792f, 0.10290252f, -0.00875750f, 0.05440854f, -0.32764444f, 0.15991415f, -0.10504684f, -0.04793711f, 
    0.15223151f, 0.07920440f, -0.23132980f, -0.26365921f, 0.04527755f, -0.27160272f, -0.03005732f, 0.17664610f, 
    -0.02996581f, 0.02758727f, 0.06021495f, 0.01461032f, -0.24176639f, -0.32785743f, -0.25157565f, -0.17448741f, 
    -0.60952330f, -0.32428965f, -0.65961659f, 0.07505507f, 0.49522251f, -0.23936577f, 0.02349197f, 0.25541052f, 
    -0.05871398f, 0.17076536f, 0.06481888f, 0.35405952f, -0.24662462f, -0.18897618f, -0.26662025f, -0.32641670f, 
    -0.02321178f, 0.39340982f, -0.26443791f, -0.07355390f, 0.07033116f, -0.14913985f, -0.19050454f, -0.11369131f, 
    -0.00142925f, -0.35459173f, -0.77556020f, -0.80897582f, 0.01058400f, 0.71459824f, 0.82726026f, -0.66008818f, 
    -0.68558484f, -0.47698483f, -0.04261828f, -0.13768265f, 0.16340305f, 0.20169951f, 0.03705762f, 0.11959251f, 
    -0.37393287f, 0.11418086f, 0.19533782f, 0.25292432f, -0.15543318f, -0.17922473f, -0.10809229f, -0.12880236f, 
    0.05591223f, 0.01136609f, -0.05734985f, -0.23875380f, -0.01154643f, 0.24693108f, -0.03716772f, 0.24036217f, 
    0.07791293f, -0.09565365f, 0.01599048f, 0.04943821f, 0.25352201f, 0.06183493f, -0.22525798f, -0.24626727f, 
    0.23899001f, -0.06200347f, 0.22046381f, -0.31227884f, -0.20495717f, 0.28600278f, -0.13052101f, -0.10327781f, 
    0.27628744f, 0.02346220f, -0.19435906f, -0.34153941f, 1.12723589f, 0.46025094f, -0.56502718f, -0.61269253f, 
    -0.86798263f, -0.20088549f, 0.07043725f, 0.00253177f, 0.04792320f, 0.48928726f, 0.03684788f, 0.34121615f, 
    0.19001812f, -0.22357272f, -0.00455524f, 0.22111733f, -0.17553963f, 0.14776351f, -0.14446963f, -0.44391739f, 
    -0.00708552f, -0.16643073f, -0.09276228f, 0.00784256f, 0.11308216f, 0.47892818f, -0.16447151f, 0.17134131f, 
    0.28407004f, -0.41663656f, -0.05858631f, -0.15175347f, -0.14335036f, -0.26444134f, -0.33361316f, 0.71285576f, 
    -0.44895944f, -0.23663828f, 0.11934246f, 0.23039423f, -0.19577679f, 0.34239283f, 0.01122702f, 0.09944180f, 
    -0.24260379f, -0.24372979f, 0.23090106f, -0.08548929f, 0.05349602f, -0.22684936f, -0.08991142f, -0.68128121f, 
    0.46606848f, -0.14626309f, -0.18352824f, 0.13229823f, -0.73294771f, -0.68224627f, -0.45727277f, -0.24440238f, 
    -0.14399762f, 0.01712841f, -0.22189490f, -0.15104222f, -0.08452632f, -0.25395513f, -0.35462791f, -0.28840181f, 
    0.09130142f, -0.33182412f, -0.05726622f, -0.07761746f, -0.22834149f, 0.16789463f, 0.08202476f, -0.43592072f, 
    0.22123329f, 0.17179070f, 0.40728620f, -0.35122025f, -0.42082179f, -0.61051542f, -0.14004807f, -0.10999425f, 
    0.11783952f, 0.16178416f, 0.28908652f, -0.01147211f, 0.43562791f, -0.08276055f, -0.06791420f, -0.20631300f, 
    0.04021982f, -0.26195991f, 0.08585651f, 0.33958235f, 0.12850259f, 0.06576511f, 0.13522232f, 0.03691379f, 
    -1.07004392f, -0.74456996f, -0.44694230f, 0.36183807f, 0.53137845f, 0.24168769f, -0.29237774f, -0.02840335f, 
    0.41636452f, 0.05606896f, -0.39182031f, -0.30740356f, -0.61590886f, -0.16889036f, 0.04077838f, -0.28596097f, 
    0.02421129f, 0.01230985f, 0.36526048f, -0.32654181f, 0.05074537f, 0.07617333f, -0.19357382f, -0.32777536f, 
    -0.04612900f, 0.32680678f, -0.34372956f, -0.21826772f, -0.28899676f, -0.57954270f, 0.25996652f, -0.02308615f, 
    0.03294303f, 0.25360495f, -0.08082709f, 0.33317655f, -0.00488162f, -0.10121327f, -0.06469533f, -0.15659355f, 
    0.04097337f, -0.22515383f, -0.02120559f, -0.29389739f, -0.42111087f, -0.25987700f, -0.16489194f, -0.15852930f, 
    -0.15641364f, -0.46603566f, -0.90702868f, -0.54290795f, -0.24181899f, -0.18154541f, -0.01449741f, 0.21379808f, 
    0.08641180f, -0.16862160f, -0.66468734f, -0.36891395f, 0.15667768f, -0.02238521f, -0.18090841f, -0.28514588f, 
    -0.22582825f, 0.06940152f, -0.20255235f, 0.01474354f, 0.03826614f, -0.34986010f, -0.04497420f, -0.12496235f, 
    -0.06215877f, -0.24412698f, 0.08195747f, 0.50913316f, -0.89286542f, -0.64858383f, 0.34577358f, -0.12565419f, 
    0.68367720f, 0.73760319f, -0.42328095f, -0.58474320f, 0.34902331f, -0.34991625f, -0.11279769f, -0.30003744f, 
    -0.33661887f, 0.25175655f, 0.09143614f, 0.08844366f, 0.20649792f, 0.23525201f, -0.03104902f, -0.07399707f, 
    -0.29849511f, -0.18280250f, -0.20857748f, -0.29322734f, 0.66669524f, 0.60368735f, 0.42199224f, -0.28839153f, 
    -0.44970486f, -0.63392889f, -0.12518139f, 0.21596220f, -0.59761751f, -0.70068073f, 0.05781479f, 0.09037609f, 
    -0.08538603f, -0.08809206f, 0.03794266f, 0.17250539f, 0.08056787f, 0.28935224f, 0.23853232f, 0.06756744f, 
    -0.21081211f, -0.08048264f, -0.30097377f, -0.01814781f, -0.00825325f, 0.51504868f, 0.49959132f, -0.18301596f, 
    -0.27175319f, 0.01334985f, 0.30650696f, -0.44551075f, -0.33102316f, -0.32039112f, -0.53008169f, -0.05840360f, 
    -0.07474610f, 0.02773807f, 0.43183863f, -0.03000460f, 0.37944782f, -0.13379568f, 0.01896387f, -0.10552946f, 
    0.01378985f, -0.28969598f, 0.13848183f, 0.21947461f, 0.01793105f, 0.25975245f, -0.39335212f, -0.13775857f, 
    0.12402339f, 0.03106624f, -0.19717966f, -0.31785017f, -0.40526450f, -0.40602326f, -0.00551460f, 0.59093666f, 
    -0.27581871f, -0.09117287f, -0.23493467f, -0.15483800f, -0.07998632f, -0.25893411f, -0.45654559f, -0.17178963f, 
    0.14495741f, -0.03689075f, -0.22634611f, -0.37307802f, -0.14643990f, -0.31184849f, -0.35208791f, -1.18387032f, 
    0.09813629f, -0.51383543f, -0.38375628f, 0.47989082f, 0.12882185f, 0.45929503f, 0.20941770f, 0.49001208f, 
    0.23684299f, 0.11659642f, 0.00642978f, -0.18094924f, -0.05543439f, -0.35275376f, 0.07288276f, 0.01106201f, 
    0.20389450f, 0.18019237f, 0.08370923f, 0.21386592f, -0.09270158f, -0.27053371f, -0.06159183f, -0.28336793f, 
    -0.20288177f, 0.13888451f, 0.31660703f, 0.40119049f, -0.51525217f, -0.17689253f, -0.33506814f, -0.08976746f, 
    -0.27992550f, 0.18485776f, 0.00450337f, 0.07491246f, 0.18164179f, -0.40973499f, 0.43467921f, 0.05930612f, 
    0.11442003f, 0.13151038f, 0.06922791f, -0.35156253f, -0.03582137f, -0.05576523f, -0.01169138f, 0.23825604f, 
    -0.18274124f, -0.27396166f, -0.41273466f, -0.75639766f, -0.42005384f, 0.20961639f, 0.05769863f, 0.09130029f, 
    -0.06424249f, 0.23209986f, -0.03276924f, -0.14862251f, -0.34949252f, 0.12366425f, 0.05836340f, 0.35395414f, 
    -0.24149959f, -0.00434299f, 0.06955977f, -0.16589889f, -0.34940091f, -0.24669428f, 0.02820728f, -0.08800376f, 
    -0.05816259f, -0.04549057f, -0.20569712f, -0.65407300f, -0.40509969f, 0.30632594f, 0.54484648f, -0.15497170f, 
    -0.23129301f, -0.22629268f, -0.34278193f, 0.25080714f, -0.14322199f, -0.12991425f, 0.17007525f, -0.37061322f, 
    0.25381687f, 0.20345528f, -0.18125387f, 0.15094368f, 0.06206692f, 0.17911063f, 0.13395897f, -0.35922697f, 
    -0.03189892f, -0.18078883f, -0.23781243f, 1.04601836f, -0.75407213f, -0.89857709f, -0.51716334f, 0.11206157f, 
    0.64643234f, 0.42899424f, 0.54799974f, -0.07263416f, -0.23926999f, -0.24068728f, -0.12464766f, -0.24259424f, 
    -0.29486877f, -0.15677774f, 0.20758048f, -0.03904062f, -0.01965641f, -0.17864162f, -0.34404495f, -0.04872156f, 
    0.00224148f, -0.32715124f, -0.24266009f, -0.20222731f, 0.33104354f, 0.62354016f, -0.09567024f, -0.12218677f, 
    0.05659971f, -0.45059597f, -0.78431499f, -0.18267736f, 0.50792682f, 0.14776780f, -0.21948645f, -0.16469574f, 
    -0.02926047f, -0.24229629f, -0.23775730f, -0.06674200f, 0.03565321f, 0.08110368f, 0.11760079f, 0.06099028f, 
    -0.05754278f, -0.21238960f, 0.06163285f, 0.21249771f, -0.14802919f, -0.03992081f, 0.21882960f, 0.00766067f, 
    0.09858280f, 0.16354971f, -0.21116143f, 0.18207465f, 0.20805490f, 0.14325517f, -0.01360554f, 0.04251834f, 
    0.28591910f, 0.28907391f, -0.51822251f, -0.07773282f, 0.09448837f, 0.09566130f, -0.09754632f, -0.20102771f, 
    -0.06934812f, -0.09374353f, 0.23166601f, 0.09386774f, -0.17734952f, 0.08384384f, 1.18722594f, -0.49723232f, 
    -0.45684415f, -0.04488406f, -0.41709533f, 0.70307326f, -0.13343097f, 0.07820632f, -0.18399143f, -0.05924061f, 
    -0.12239046f, -0.16017069f, 0.16584754f, 0.03427426f, 0.00398826f, -0.02099553f, -0.10217115f, 0.20408267f, 
    -0.14223421f, 0.13394225f, -0.04778507f, 0.15949640f, 0.09867177f, -0.01412630f, -0.15361018f, -0.34612486f, 
    0.86090046f, 0.64469916f, -0.57727289f, -0.28378478f, -0.27120700f, -0.23645945f, 0.27590191f, 0.33471614f, 
    -0.68201107f, -0.58626217f, -0.22918659f, 0.00561622f, -0.14312781f, -0.28560576f, 0.31545669f, -0.04093876f, 
    -0.03196256f, 0.26261571f, -0.06285466f, -0.06296483f, -0.07317092f, 0.02647478f, -0.04193023f, 0.01449792f, 
    -0.52687162f, -0.68554896f, -0.16945288f, 0.23435073f, 0.47381631f, 0.46181831f, 0.06339310f, -0.78058785f, 
    -0.79968542f, -0.67758220f, 0.06124814f, -0.00985023f, 0.20672029f, -0.34413293f, -0.18153931f, -0.15242332f, 
    -0.51877058f, -0.16882572f, -0.23919438f, 0.09174007f, 0.17456760f, -0.28126699f, -0.36464942f, 0.15590499f, 
    0.04102208f, 0.61910665f, -0.17820878f, -0.00215617f, -0.26519722f, -0.59769768f, 0.39114180f, 0.13334413f, 
    -0.17338321f, -0.14699619f, -0.06895088f, 0.27794421f, 0.20509422f, -0.19611137f, -0.25366190f, -0.25242403f, 
    -0.08068434f, -0.16867284f, 0.26919165f, -0.28989384f, -0.38401580f, -0.17078690f, 0.32994142f, 0.22819750f, 
    0.38145968f, 0.07026725f, 0.15893725f, -0.15739775f, 0.06439111f, 0.04712504f, 0.00085399f, 0.17672780f, 
    0.09349564f, -0.45228881f, -0.29348925f, 0.26804367f, -0.01387464f, -0.21383613f, -0.03381925f, 0.00786166f, 
    0.24724494f, 0.03019149f, -0.02247348f, -0.07688541f, 0.12609978f, -0.13939460f, -0.04802043f, 0.24056385f, 
    0.21015562f, -0.39713892f, -0.03470626f, -0.35147783f, -0.19661632f, -0.46502352f, -0.53454220f, -0.45488173f, 
    -0.48820019f, -0.36819473f, -0.56510782f, -0.62729621f, -0.53132415f, -0.16200599f, -0.11632347f, 0.31968290f, 
    -0.05494998f, -0.21573175f, 0.22396663f, -0.00881316f, -0.30066377f, 0.26894754f, 0.17580242f, 0.01183310f, 
    0.26013914f, -0.02434304f, 0.07476118f, 0.05021862f, 0.79175442f, 0.07689159f, 0.11342146f, 0.20622352f, 
    -0.42529762f, 0.28339869f, 0.37487999f, 0.04695007f, -0.04310250f, 0.01050476f, -0.09043019f, -0.07461964f, 
    -0.21282642f, -0.22542973f, -0.36173183f, -0.17798044f, -0.03531310f, -0.00130732f, -0.05270596f, 0.13495734f, 
    0.10593538f, -0.33057034f, -0.08594724f, -0.11123294f, 0.26456124f, -0.22029959f, -0.06608997f, -0.12046515f, 
    -0.48610741f, -0.49090311f, 0.39086387f, -0.07236101f, 0.12088289f, 0.41259688f, 0.50877553f, -0.21074094f, 
    -0.32817709f, 0.07502270f, 0.08109898f, -0.10500496f, -0.04419697f, -0.05931817f, 0.08155505f, -0.16487025f, 
    0.26457170f, 0.03023330f, 0.23047684f, -0.19123600f, -0.02328186f, 0.20824021f, -0.17722416f, -0.42180145f, 
    -0.12980889f, 0.50141805f, 0.22014417f, -0.17552915f, -0.15981340f, -0.10287706f, -0.26305431f, -0.52788496f, 
    0.22605436f, 0.19219400f, 0.18774301f, 0.29480210f, 0.20332338f, -0.25146323f, -0.27362922f, 0.09282580f, 
    -0.25625601f, 0.16979779f, 0.03658531f, 0.14398122f, 0.05912962f, -0.02352043f, -0.11616199f, -0.45202756f, 
    -0.51855588f, -0.10831887f, -0.01543001f, -0.09612688f, -0.50255692f, -0.65927100f, -0.55363929f, -0.55725771f, 
    -0.39609715f, -0.02270631f, -0.19236334f, 0.32164136f, 0.07684024f, -0.42016286f, -0.13926494f, -0.30683726f, 
    0.01879327f, -0.09178008f, -0.10484838f, -0.00704938f, -0.21730469f, -0.27848634f, -0.04850329f, -0.47506011f, 
    -0.51406914f, 0.40138292f, -0.21579953f, -0.10721182f, 0.37463608f, -0.33972782f, 0.14984232f, -0.05683026f, 
    0.02552024f, -0.03129134f, -0.01683569f, 0.04609747f, -0.19430962f, -0.11721361f, 0.26850677f, 0.01145279f, 
    -0.00392077f, -0.21033098f, -0.04103976f, -0.16234939f, -0.25427982f, -0.01155819f, 0.25143868f, 0.14602101f, 
    0.17901151f, 0.05188733f, 0.18338709f, -0.06754658f, -0.10696559f, -0.52571499f, 0.02806865f, 0.19711009f, 
    -0.10871352f, -0.11921725f, 0.27172974f, -0.33303264f, 0.24038760f, -0.03864476f, 0.15293781f, -0.09592252f, 
    -0.20700108f, 0.07514202f, -0.14800161f, 0.17984895f, 0.17296764f, 0.07167008f, 0.21553682f, 0.02166751f, 
    -0.03871376f, -0.15513030f, 0.21511267f, 0.37727773f, 0.34719604f, -0.50891507f, -0.49028835f, 0.09950953f, 
    0.32121345f, 0.07872119f, -0.23227623f, -0.20361994f, -0.41871533f, 0.57539445f, -0.01746362f, -0.25244039f, 
    0.17776571f, 0.26794353f, 0.17430633f, -0.04235078f, -0.27511322f, -0.36526880f, 0.03888389f, 0.24512947f, 
    -0.22298361f, -0.08927527f, 0.32947338f, 0.53995937f, 0.24891450f, -0.17191102f, -0.43250906f, -0.21298832f, 
    -0.37050378f, -0.12756722f, 0.17631453f, 0.49984813f, -0.14936674f, 0.00840023f, 0.11736564f, -0.37092257f, 
    0.33428574f, 0.04018487f, -0.14422800f, -0.18890627f, 0.26548672f, 0.03074996f, -0.05246015f, 0.25608233f, 
    0.01380272f, 0.12323658f, -0.22712159f, -0.03189334f, 0.09419795f, -0.44015688f, -0.19595605f, 0.22829635f, 
    0.25893235f, 0.17099988f, 0.42460930f, 0.23096927f, -0.44550523f, -0.39119726f, -0.12613332f, -0.30209279f, 
    0.07800973f, 0.01187545f, 0.03123283f, -0.28189117f, -0.01589000f, 0.18483207f, 0.04955556f, -0.26323593f, 
    0.10923444f, -0.05772383f, 0.10267701f, 0.11721583f, -0.10192589f, -0.97327483f, 0.69326800f, 0.55694914f, 
    -0.01861382f, 0.34179324f, -0.79827785f, -0.39769211f, -0.04380813f, 0.30926287f, 0.35706726f, -0.25531268f, 
    -0.16285682f, -0.16895528f, 0.15099083f, 0.19808808f, 0.24832498f, -0.03229348f, -0.10397584f, -0.02824628f, 
    0.00893685f, -0.17175974f, 0.03948531f, -0.23234364f, 0.06273153f, -0.22417034f, -0.03007008f, -0.11090829f, 
    -0.20897645f, 0.04862222f, -0.18268028f, 0.31526905f, -0.33533779f, -0.09697462f, 0.51642126f, 0.07507189f, 
    -0.28950202f, 0.10475024f, 0.52497506f, -0.25777307f, -0.13104580f, -0.48549664f, -0.35572663f, 0.40445188f, 
    0.20491555f, -0.18266732f, -0.17333697f, 0.33419606f, -0.09219476f, 0.02894298f, 0.33103162f, 0.32842496f, 
    0.05296182f, -0.33333999f, -0.32410803f, 0.00036829f, 0.25263736f, 0.00315256f, 0.24397296f, 0.14207384f, 
    0.10037167f, 0.26552328f, -0.33368602f, 0.04269752f, 0.29823631f, -0.33559126f, -0.30027604f, 0.15214266f, 
    0.01350222f, 0.06035566f, -0.25731611f, 0.20431671f, 0.19484201f, 0.16824843f, 0.05631900f, -0.14088187f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.06499006f, 0.23659988f, 0.33566415f, 0.12521987f, -0.13730569f, -0.06529062f, 0.28777963f, 0.32642013f, 
    0.00347625f, 0.23836270f, 0.10769853f, -0.27658579f, -0.13612379f, 0.21238607f, 0.43314305f, 0.04306409f, 
    -0.05398684f, 0.24019790f, -0.16558973f, 0.12053935f, -0.02005624f, 0.14905135f, 0.03581575f, 0.05534310f, 
    -0.15547933f, -0.05867575f, 0.09043511f, 0.34349558f, 0.27507052f, 0.08200977f, 0.07530662f, 0.00453121f, 
    -0.02379176f, -0.14513305f, -0.28149700f, -0.01057319f, 0.10479354f, 0.26606333f, -0.14794700f, 0.01562771f, 
    0.02749902f, -0.18656921f, -0.03829581f, -0.05543703f, 0.15941048f, -0.12746724f, 0.14607488f, 0.12059317f, 
    -0.04520932f, 0.18566936f, -0.04882947f, -0.34992665f, 0.03284481f, 0.09178156f, -0.02137144f, -0.41260543f, 
    0.13632698f, 0.25429907f, 0.26748371f, 0.05019590f, 0.10542340f, 0.17083277f, 0.03730889f, 0.00279110f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.04036822f, 0.09896129f, -0.04581454f, 0.07969687f, -0.08515536f, -0.02112305f, 0.02791584f, -0.11482896f, 
    -0.02024467f, 0.04678663f, -0.03585529f, -0.03104748f, -0.39901510f, 0.05789755f, 0.23139365f, -0.03012175f, 
    -0.13458508f, 0.05780480f, -0.06372860f, -0.02074063f, 0.07211074f, -0.02535660f, -0.02058344f, -0.25838456f, 
    -0.23474234f, 0.11656921f, 0.02436906f, -0.24116710f, -0.03924467f, -0.09301061f, 0.08672314f, -0.14843203f, 
    -0.12420841f, -0.14574759f, 0.06229023f, 0.00739617f, -0.35288486f, -0.82465959f, -0.40073976f, 0.03945323f, 
    -0.00139898f, 0.04239807f, 0.06917510f, -0.01258514f, -0.04775212f, 0.00399813f, -0.03640691f, -0.07638486f, 
    -0.10257948f, 0.27217856f, 0.07104759f, -0.05324697f, -0.07635758f, 0.02776214f, -0.01233799f, -0.19255696f, 
    0.09266299f, -0.09090707f, 0.01790602f, -0.00631784f, -0.01438793f, -0.04296414f, -0.01461269f, 0.02892285f, 
    0.04356975f, 0.00483103f, 0.02026856f, 0.05596614f, -0.03998091f, 0.06748520f, 0.05888079f, 0.04547779f, 
    0.11832811f, 0.08293945f, 0.04741824f, -0.31795514f, -0.03734004f, 0.04098194f, -0.10020114f, -0.02182108f, 
    0.04368158f, -0.05005838f, -0.01380679f, 0.00480694f, -0.08041497f, -0.33261570f, -0.17085943f, -0.09044968f, 
    -0.06927739f, -0.05426367f, 0.10886631f, -0.01085085f, -0.08135201f, -0.10436436f, -0.03090650f, -0.13717747f, 
    0.20224987f, 0.16350426f, -0.04213545f, -0.09572114f, 0.13779110f, 0.11012312f, 0.18240899f, 0.00505073f, 
    -0.03001535f, -0.00459242f, 0.01289756f, -0.00315216f, 0.05660018f, 0.00565931f, -0.12929274f, -0.03602393f, 
    0.08743803f, 0.04558099f, 0.05564099f, -0.07057678f, -0.10763463f, -0.06586708f, -0.06981928f, -0.05982775f, 
    0.31807581f, -0.10365286f, -0.17335306f, -0.15682493f, 0.04076127f, -0.03363667f, -0.10545263f, -0.06814894f, 
    -0.07921423f, -0.11539336f, 0.04716666f, -0.02667073f, 0.26377562f, 0.07308956f, -0.22701272f, -0.04324971f, 
    0.14151038f, 0.16785571f, 0.05800321f, 0.10789984f, -0.01695533f, 0.01160381f, -0.02380027f, -0.00122189f, 
    -0.10018625f, -0.01410019f, -0.00718644f, 0.01728079f, 0.04325648f, -0.00083544f, 0.06723651f, -0.08652460f, 
    -0.09932888f, 0.00692159f, 0.08203878f, 0.04299777f, -0.01188093f, 0.02256113f, -0.01922229f, -0.01570427f, 
    0.07099601f, 0.06482085f, 0.03531111f, -0.05216805f, -0.13990283f, -0.14592485f, -0.18733928f, -0.01374228f, 
    0.21056247f, 0.28149864f, -0.10808098f, -0.20363021f, -0.00085773f, 0.02894030f, -0.03055470f, -0.17155457f, 
    -0.07607550f, -0.05019258f, -0.06177040f, -0.00041825f, 0.20631853f, 0.02887115f, 0.03171169f, -0.03909870f, 
    0.01374006f, 0.00313936f, 0.00349171f, -0.07406906f, -0.01086680f, 0.00336693f, -0.00574300f, -0.02266794f, 
    0.19777964f, 0.17028300f, 0.00152998f, -0.17159885f, 0.07153437f, 0.07433788f, 0.01627654f, 0.03514684f, 
    -0.00519870f, -0.03061600f, 0.00437161f, -0.02030273f, 0.21278146f, 0.03885692f, 0.01120903f, 0.04263979f, 
    0.03777160f, 0.05504500f, 0.00451462f, -0.07397433f, 0.02852924f, -0.03626154f, 0.00054095f, 0.04439283f, 
    -0.16909537f, -0.14911132f, -0.36979726f, 0.05608132f, 0.01133552f, 0.04222061f, 0.04736308f, 0.01698853f, 
    -0.04502952f, 0.03080285f, 0.10078122f, 0.01038287f, 0.11444964f, 0.23805550f, -0.00744396f, -0.17383555f, 
    0.03179741f, 0.02936392f, 0.02660589f, 0.00880527f, -0.02933639f, -0.08715976f, -0.22057803f, -0.13852417f, 
    0.15273295f, 0.00907609f, 0.01801634f, -0.01581369f, -0.03412783f, -0.04398074f, -0.08163301f, 0.02921769f, 
    -0.02247534f, 0.05044873f, 0.05166995f, -0.03181402f, 0.27395910f, 0.08352455f, -0.29806924f, 0.01224647f, 
    0.00986145f, 0.14135435f, -0.04890531f, -0.14060609f, 0.02227113f, -0.00819993f, 0.00140933f, 0.06366336f, 
    0.16766500f, -0.00016996f, -0.13196294f, -0.06606542f, 0.19477108f, 0.16724929f, -0.06751187f, 0.12126514f, 
    -0.13195048f, -0.08780047f, 0.03826232f, -0.01226896f, 0.04809885f, 0.01128279f, -0.11550908f, -0.10652190f, 
    -0.13291687f, -0.01484266f, -0.02609194f, -0.15244819f, -0.01710222f, 0.08753978f, 0.01489195f, -0.01345985f, 
    -0.12909779f, 0.06606870f, 0.04738969f, 0.03784488f, 0.08617805f, 0.02713652f, -0.06303640f, -0.11178624f, 
    0.02548158f, -0.01872785f, 0.09317525f, 0.19594727f, 0.41008148f, -0.20787148f, -0.09383737f, -0.20815679f, 
    0.02796808f, 0.00106027f, 0.00935791f, -0.09692359f, -0.10374550f, 0.04418046f, 0.08001441f, -0.01505099f, 
    0.39704031f, 0.24615790f, 0.07823975f, -0.27157965f, 0.07877081f, -0.09005801f, 0.01881334f, -0.02266067f, 
    0.06284610f, -0.10340991f, -0.08453374f, -0.00069789f, -0.32672825f, -0.09144430f, -0.04395515f, -0.07459948f, 
    0.04414794f, 0.01390381f, -0.00555482f, 0.01915164f, -0.10624599f, -0.15523389f, -0.10426517f, 0.02305459f, 
    -0.16911072f, -0.12520629f, -0.21995075f, 0.14360906f, 0.03878849f, -0.05425486f, -0.14222215f, -0.06041675f, 
    -0.21190464f, -0.08851296f, -0.15077871f, 0.06440940f, -0.01119996f, -0.15471587f, 0.00161165f, -0.31640726f, 
    -0.04114469f, -0.13150217f, -0.12763515f, -0.06375514f, -0.03302030f, 0.12493999f, 0.01203425f, 0.06005061f, 
    0.29449818f, 0.13093923f, -0.22382843f, -0.19152969f, 0.04690402f, -0.09774041f, 0.08650442f, 0.02206259f, 
    -0.06364911f, -0.06508885f, -0.01963641f, -0.16460660f, 0.03889750f, 0.11595008f, 0.23362838f, -0.20570765f, 
    -0.10368520f, -0.00350899f, -0.07517312f, -0.01738942f, 0.00327568f, 0.01017207f, -0.06191558f, -0.00375786f, 
    0.36561933f, 0.13338293f, 0.27501795f, -0.17883672f, 0.00035846f, 0.00624637f, 0.18865640f, 0.06982394f, 
    0.02186417f, 0.02488156f, -0.12646565f, -0.06523757f, -0.00908366f, -0.24272253f, -0.26501796f, 0.02419236f, 
    0.06426014f, 0.00867607f, 0.06488089f, 0.05058360f, -0.11273237f, 0.06241279f, 0.04947426f, 0.20918338f, 
    0.38456249f, 0.22204958f, -0.16237241f, -0.09527920f, 0.06737991f, 0.10837236f, 0.17308827f, 0.14195262f, 
    0.01946224f, -0.04069078f, -0.03677791f, 0.01183543f, 0.23997088f, 0.06597073f, -0.15226385f, -0.01261860f, 
    0.06008957f, -0.06590743f, 0.08961950f, -0.12987737f, 0.08319846f, 0.02373384f, 0.01104472f, 0.13853106f, 
    0.07299599f, -0.07891560f, -0.09063143f, -0.16042972f, 0.07546182f, 0.00438249f, -0.02195616f, -0.16318366f, 
    0.04361737f, 0.19505538f, 0.03524483f, 0.02831551f, 0.03422591f, 0.01535988f, -0.22200957f, -0.03765053f, 
    -0.07554040f, -0.08921815f, 0.03443744f, -0.07028189f, -0.03806948f, 0.06029563f, 0.00571097f, 0.02541504f, 
    0.18066065f, 0.17033118f, 0.06539053f, -0.18761383f, -0.03365268f, -0.14567624f, -0.05115872f, -0.04190005f, 
    -0.06820416f, -0.20202391f, -0.01952946f, 0.02654991f, 0.00872556f, 0.13015975f, 0.01565131f, 0.03317672f, 
    0.01952228f, 0.12086963f, 0.09493747f, 0.09772953f, 0.10222603f, 0.08699199f, 0.05745513f, 0.00169217f, 
    0.12309369f, 0.16152699f, -0.00518611f, -0.18336338f, -0.15361607f, 0.04957953f, -0.12983221f, -0.08393109f, 
    -0.03702094f, -0.03909306f, -0.03863144f, 0.04979853f, 0.20845275f, 0.04392007f, 0.00247522f, -0.06592086f, 
    0.09598278f, 0.13130483f, -0.00117008f, -0.18383683f, -0.03897883f, -0.09383068f, -0.00125507f, -0.01504700f, 
    0.28599796f, 0.16200674f, 0.02431515f, -0.07858709f, 0.03707906f, 0.00608107f, 0.12610410f, -0.08226835f, 
    -0.00704808f, 0.01318208f, 0.02137794f, 0.02141394f, 0.16689229f, -0.19425008f, -0.35048699f, 0.02665989f, 
    -0.00505300f, 0.09672020f, 0.03340541f, -0.11945774f, -0.00309929f, 0.09474415f, -0.07670300f, 0.08479316f, 
    -0.66116232f, 0.30305472f, -0.04414450f, -0.05017549f, 0.01658459f, 0.00521153f, -0.00146790f, -0.00297288f, 
    0.03956867f, 0.00022952f, -0.00668757f, 0.02388206f, -0.10104872f, -0.03435258f, -0.01625694f, 0.02617664f, 
    0.04122007f, 0.00451290f, 0.07267794f, -0.01032848f, -0.04303335f, -0.04107849f, 0.04167996f, -0.00790374f, 
    0.05711355f, -0.07702900f, -0.23852026f, 0.07462545f, -0.16573443f, -0.08894026f, -0.00186295f, -0.05778822f, 
    -0.08640298f, 0.02744973f, -0.04106097f, -0.05593840f, -0.26119855f, 0.15688966f, 0.02237798f, 0.18711129f, 
    -0.12121547f, 0.02560930f, -0.18711768f, 0.01248765f, 0.02310081f, 0.02126763f, 0.00420828f, -0.00831918f, 
    0.35415223f, 0.13896540f, -0.32915750f, -0.09810850f, -0.04379263f, -0.12644094f, 0.18414718f, -0.05265584f, 
    -0.09061098f, -0.11095615f, -0.02679251f, -0.19661546f, -0.01899293f, -0.52227032f, -0.38616136f, 0.08112409f, 
    0.04442462f, 0.08936813f, -0.01741294f, -0.00620119f, -0.07350765f, -0.10308067f, -0.09282885f, 0.07549097f, 
    -0.00142799f, 0.03560974f, -0.02855130f, 0.03856472f, -0.17406936f, -0.21257047f, 0.10007530f, -0.03918006f, 
    -0.05464554f, -0.00530732f, -0.02435012f, 0.00502403f, 0.25171697f, 0.18612219f, -0.07062910f, -0.08687929f, 
    0.19063561f, 0.12052125f, -0.04222843f, 0.11008897f, -0.00378032f, -0.00186087f, 0.03658305f, 0.01049039f, 
    -0.26442203f, -0.29651153f, -0.68363196f, -0.07093371f, 0.03205075f, 0.06971341f, 0.07174125f, 0.02329732f, 
    -0.03096961f, 0.00439094f, 0.00497985f, 0.04168515f, -0.01652264f, -0.11137232f, 0.10180023f, -0.01944627f, 
    0.01154197f, 0.09913696f, -0.10075504f, -0.00927529f, 0.05300156f, -0.07392711f, -0.00386400f, -0.14131087f, 
    0.16696534f, 0.13855657f, -0.00972292f, -0.13116038f, -0.24371281f, 0.04275189f, 0.06839561f, -0.02246252f, 
    0.06216757f, 0.03538745f, 0.01220395f, -0.09069793f, 0.33871266f, 0.22711954f, -0.02753397f, -0.16410600f, 
    0.11464147f, 0.08532926f, 0.12616929f, 0.17513436f, -0.02399976f, -0.10922527f, -0.01716407f, -0.07971963f, 
    -0.07636487f, 0.09355548f, 0.06412641f, -0.03184791f, 0.04196903f, 0.03556015f, 0.01452596f, -0.07721513f, 
    -0.00003564f, -0.06054959f, -0.11120249f, -0.06027463f, -0.06076280f, -0.10071644f, 0.04205407f, 0.06970959f, 
    0.00200451f, -0.08958955f, -0.08274306f, -0.19009256f, -0.03034552f, -0.00321089f, -0.04882837f, -0.01628727f, 
    0.02915991f, -0.21211693f, -0.00124768f, 0.03916696f, -0.21294066f, 0.01248313f, -0.21549357f, -0.12280393f, 
    0.00550519f, -0.10882798f, 0.05340413f, -0.23160712f, -0.03418037f, -0.17386110f, -0.04049170f, 0.01179410f, 
    -0.13420416f, -0.37624177f, 0.06793415f, -0.01681932f, 0.02698033f, -0.02140098f, -0.12769094f, -0.12662299f, 
    0.05836558f, -0.32674956f, 0.00889762f, -0.08919597f, -0.14998797f, -0.07738087f, 0.00424383f, 0.00557153f, 
    0.00231323f, -0.11062759f, -0.03247015f, 0.06804467f, -0.80179793f, 0.18010022f, 0.21697977f, -0.19310594f, 
    0.04824126f, -0.05522956f, 0.00196025f, 0.01395980f, -0.00759552f, 0.00559530f, -0.04605037f, 0.01893599f, 
    -0.00118532f, -0.01328948f, 0.09311233f, -0.07025508f, 0.04005358f, 0.01096989f, -0.08006760f, -0.17742874f, 
    0.10995489f, -0.15501733f, -0.03492951f, -0.04177044f, -0.03742468f, -0.14507543f, -0.07568602f, 0.07172442f, 
    -0.01316590f, 0.01571481f, 0.03021313f, -0.01503343f, -0.02567235f, -0.22642873f, -0.26276895f, -0.33435330f, 
    0.02893308f, -0.07436374f, 0.00025285f, 0.10113709f, 0.06271575f, -0.07312138f, 0.10475513f, -0.18459707f, 
    -0.10988604f, 0.09686146f, -0.01937267f, 0.09594920f, -0.25504833f, 0.20218427f, 0.07876693f, -0.05385114f, 
    0.05832772f, 0.13624960f, -0.00922401f, 0.00516073f, 0.12347955f, 0.04945512f, 0.00867813f, -0.17871144f, 
    -0.42537060f, 0.28138646f, -0.16824667f, -0.00200779f, 0.01380173f, 0.14861232f, -0.05499225f, 0.00504604f, 
    0.02241083f, 0.12931207f, -0.29474536f, 0.04952312f, 0.46158284f, 0.42957285f, 0.19843554f, 0.22442237f, 
    -0.02662480f, -0.01737755f, 0.03889922f, -0.04793485f, 0.11546659f, 0.02856632f, -0.13393891f, -0.03681522f, 
    -0.10980708f, 0.01534789f, 0.02286376f, -0.06620913f, 0.20548499f, -0.07340734f, -0.11741627f, 0.04042357f, 
    -0.34300247f, -0.02443140f, 0.18196425f, -0.11679359f, 0.05850071f, 0.08384880f, 0.08231132f, 0.06806108f, 
    -0.00994385f, -0.06001629f, -0.00670668f, -0.02874637f, 0.03896333f, -0.01905465f, 0.01560634f, 0.01277707f, 
    -0.05016313f, 0.15564096f, -0.05871358f, -0.09740090f, 0.14663279f, -0.07609139f, -0.11247448f, 0.21033721f, 
    -0.10809182f, -0.01456368f, -0.04573951f, 0.06257071f, 0.03190020f, -0.11786424f, 0.17356503f, 0.27311370f, 
    -0.02377956f, -0.02176689f, -0.06295060f, -0.00340689f, 0.02310188f, 0.21244775f, -0.10849681f, 0.07892201f, 
    -0.01553987f, 0.20236315f, -0.08399256f, 0.08174172f, -0.12540424f, 0.00470207f, -0.15941562f, -0.57050902f, 
    0.05511298f, -0.05985728f, -0.11542881f, 0.02209266f, -0.00852288f, -0.01969625f, 0.02096016f, -0.02303304f, 
    -0.02119241f, -0.00204953f, 0.04581931f, 0.02845527f, 0.12710993f, -0.05102624f, 0.04056510f, -0.02381149f, 
    -0.27931547f, -0.53026974f, 0.20875205f, 0.13374163f, 0.07192027f, -0.09323439f, 0.08903554f, 0.04532292f, 
    0.02950973f, -0.14019069f, 0.10013092f, 0.05051924f, 0.24505740f, 0.13250101f, 0.11263903f, 0.03661367f, 
    -0.05970329f, 0.03985842f, 0.07893872f, 0.07039805f, -0.08065161f, -0.01629200f, -0.08487325f, 0.03152635f, 
    0.00344532f, 0.06345589f, 0.05580607f, 0.07469476f, -0.04096916f, 0.00532302f, -0.01451686f, 0.12559384f, 
    0.18092653f, 0.05894814f, 0.08687140f, 0.00770049f, -0.13573724f, 0.00551764f, 0.03522996f, 0.03021689f, 
    0.06013290f, -0.00609348f, 0.04164249f, 0.10154329f, -0.15738541f, 0.00882552f, 0.05916473f, 0.06403642f, 
    -0.56349200f, -0.36341178f, -0.22349630f, -0.11832786f, -0.01271843f, 0.10165224f, 0.11587103f, 0.00663503f, 
    0.12749188f, -0.08161741f, 0.04746068f, 0.09016244f, 0.05436923f, 0.08699600f, -0.13420817f, -0.09015432f, 
    -0.07323559f, 0.03507227f, 0.02945127f, -0.06533315f, -0.07184180f, 0.00033855f, -0.10624435f, -0.02128464f, 
    -0.13485724f, 0.15333213f, 0.17026645f, 0.04720690f, 0.07052859f, -0.07793374f, 0.12554577f, -0.02878359f, 
    -0.04538951f, -0.06977326f, 0.04369486f, -0.02805701f, -0.05727397f, -0.13183546f, -0.08944578f, -0.07061061f, 
    0.04189554f, 0.06107097f, 0.03711708f, 0.03093100f, 0.21529853f, 0.02553187f, 0.04546107f, -0.00056403f, 
    0.22594127f, 0.13146617f, 0.15111080f, 0.12851283f, -0.00095911f, -0.00849562f, -0.04316580f, -0.07811524f, 
    -0.03469080f, 0.05248911f, -0.04707642f, 0.20742886f, -0.45950973f, -0.44163418f, -0.25747964f, -0.04589053f, 
    -0.09452357f, 0.11126844f, 0.10472070f, 0.13377449f, 0.04867880f, -0.01631652f, -0.11585236f, 0.17144725f, 
    -0.12698418f, -0.21636134f, -0.00758513f, -0.15087129f, 0.00748508f, 0.10079607f, -0.08700842f, 0.18917340f, 
    0.05110748f, 0.13420340f, -0.16922507f, 0.07775109f, 0.27536079f, 0.02713573f, -0.10775672f, -0.03356380f, 
    0.01386130f, -0.05772038f, -0.05065266f, -0.03796902f, 0.02505568f, -0.03416231f, 0.06378245f, -0.03370409f, 
    0.11072665f, 0.03573960f, 0.09960358f, -0.19980350f, 0.05454239f, 0.13568424f, 0.12714767f, -0.28475654f, 
    0.07827181f, -0.05197193f, 0.01962692f, -0.04732980f, 0.06977054f, 0.04402049f, -0.04577202f, -0.09036700f, 
    -0.14420465f, 0.16002758f, -0.05347789f, 0.04305878f, -0.03839536f, -0.02341734f, 0.11635993f, 0.00418942f, 
    0.01704905f, 0.04645282f, 0.05477502f, -0.06152264f, -0.00578782f, 0.03679929f, -0.07483897f, -0.00899646f, 
    -0.14506139f, -0.26156676f, -0.08225606f, -0.08078283f, 0.18657196f, -0.01583541f, 0.02194508f, -0.07136511f, 
    -0.02778194f, -0.01153802f, -0.00522640f, -0.07628438f, 0.03928522f, -0.40790603f, -0.28691906f, -0.06708629f, 
    -0.59077162f, 0.08877888f, -0.31828716f, -0.04530121f, -0.04644303f, -0.04430713f, 0.16811620f, 0.00432326f, 
    -0.02876268f, -0.03755493f, -0.08283516f, 0.02366596f, -0.01553946f, 0.11734557f, -0.03937895f, 0.16181558f, 
    0.00736438f, 0.02497531f, 0.02269867f, 0.04292056f, -0.05688117f, 0.11376860f, 0.13224643f, 0.19092213f, 
    0.32800144f, -0.38957408f, 0.15788707f, -0.33139274f, 0.07210509f, 0.11136194f, 0.00919921f, 0.00306505f, 
    0.28381440f, -0.08794768f, -0.03073945f, -0.07710244f, -0.02758714f, 0.04653917f, -0.02110687f, -0.38879529f, 
    -0.19197069f, -0.00500631f, 0.17104787f, 0.04343595f, 0.01726725f, 0.07850400f, -0.06777202f, 0.01704911f, 
    -0.08227170f, -0.11186136f, -0.09468304f, 0.10975464f, -0.11010610f, 0.13098267f, -0.13244890f, 0.03684716f, 
    -0.01808893f, -0.04939427f, 0.02545745f, 0.01828178f, -0.46732691f, -0.03945815f, -0.11908666f, -0.06599930f, 
    0.05755516f, -0.16563679f, -0.06274183f, 0.10280558f, -0.07412826f, -0.16090089f, 0.07941390f, -0.02057113f, 
    -0.09247807f, 0.23415969f, -0.04956512f, -0.10536984f, 0.04982148f, -0.11305331f, -0.08260433f, 0.10201092f, 
    0.06109081f, -0.04006735f, -0.07722245f, -0.14533536f, -0.01746718f, -0.08073612f, -0.08819951f, -0.15681636f, 
    -0.03081880f, -0.02533516f, -0.03279651f, 0.03012503f, -0.16439037f, -0.36726549f, -0.31141326f, -0.23864670f, 
    0.18953146f, 0.06406121f, 0.26238829f, 0.12683627f, 0.04385402f, -0.05217249f, 0.00788894f, -0.00968851f, 
    0.03339973f, 0.03516072f, -0.05996909f, 0.05915013f, 0.40043896f, -0.09816231f, -0.15129407f, -0.00335682f, 
    0.05733509f, 0.13517120f, -0.26223651f, -0.17315212f, 0.24420166f, -0.12611078f, 0.26240465f, 0.05000603f, 
    0.17286013f, -0.06087897f, 0.07679712f, -0.20259465f, -0.25145054f, -0.04112497f, -0.06291553f, -0.08852105f, 
    -0.05725932f, -0.01880423f, 0.01313983f, 0.03570195f, 0.21855581f, -0.04236085f, -0.11381535f, 0.06273951f, 
    -0.12749694f, -0.18109360f, 0.07287446f, -0.12528005f, -0.07503847f, 0.07907870f, -0.01159347f, 0.07211953f, 
    0.10043742f, 0.24011478f, 0.01429990f, -0.04571718f, 0.07310587f, 0.08488259f, -0.13239272f, -0.01203309f, 
    -0.11159674f, -0.09286842f, 0.07518960f, -0.16370140f, -0.05901872f, -0.07990919f, 0.02423347f, -0.00624288f, 
    -0.06663032f, -0.02814219f, -0.02337448f, 0.02168591f, -0.09951568f, -0.15481828f, -0.15816525f, 0.17404962f, 
    -0.16515638f, -0.01967702f, 0.12803383f, -0.18100785f, -0.04666484f, 0.05606515f, -0.04641604f, -0.00382923f, 
    -0.01624327f, -0.02218422f, -0.05959897f, -0.02130331f, -0.11325202f, 0.09570245f, 0.07679529f, 0.04493013f, 
    0.10585551f, 0.07112157f, 0.03251599f, -0.08987848f, -0.07550546f, 0.06738269f, 0.01570738f, -0.17709818f, 
    -0.15131687f, 0.09026500f, -0.17290173f, 0.12127491f, -0.08206112f, 0.05833909f, -0.00166399f, -0.00124334f, 
    0.03907668f, -0.10007422f, -0.03677513f, 0.02712959f, 0.77997524f, -0.07775720f, -0.05540628f, 0.08098369f, 
    -0.02365646f, -0.00362872f, -0.04048168f, -0.03211308f, -0.08122988f, -0.15714259f, -0.50007910f, -0.13301684f, 
    -0.18087494f, 0.19184893f, 0.27476218f, 0.13575867f, 0.05511854f, -0.03797759f, -0.05619727f, -0.06768716f, 
    -0.00035931f, -0.00629542f, 0.04584926f, 0.01217623f, 0.05542966f, 0.03154917f, 0.13476714f, 0.05204706f, 
    0.05388454f, 0.03599037f, -0.00710430f, -0.00321265f, -0.03093262f, 0.07870772f, -0.06331360f, 0.05908450f, 
    0.67272699f, 0.07715109f, -0.01802039f, -0.12630904f, -0.04456528f, -0.08519646f, -0.05903497f, 0.05012327f, 
    -0.00036498f, 0.05504016f, 0.14800835f, -0.06239824f, -0.14431593f, -0.15057756f, -0.05104148f, -0.39654645f, 
    0.07875840f, -0.01120517f, 0.04546530f, -0.21712016f, -0.00153767f, 0.04849271f, -0.02836111f, -0.04206648f, 
    -0.18453224f, -0.38191599f, -0.06694408f, 0.09816145f, 0.05377866f, -0.02069520f, 0.20431125f, -0.01677274f, 
    0.07721934f, -0.05473951f, -0.06943612f, 0.19837853f, 0.36728567f, -0.02483726f, 0.08167672f, -0.19587950f, 
    -0.03246610f, -0.07898730f, 0.04466733f, 0.13038994f, -0.06825206f, 0.07299401f, -0.15368672f, 0.09401713f, 
    0.07319493f, -0.02491379f, 0.03501872f, 0.03758319f, 0.10672527f, 0.06316790f, -0.05314513f, 0.01891817f, 
    -0.03929752f, 0.02710472f, 0.12689814f, -0.11250196f, 0.19605832f, 0.14996397f, 0.21840914f, 0.20997064f, 
    -0.19364454f, -0.07814194f, -0.20508088f, -0.23502773f, -0.04793204f, -0.02221619f, -0.00987176f, 0.00650132f, 
    0.63590854f, 0.31055394f, 0.21761292f, 0.21791710f, -0.06380145f, -0.00688186f, -0.02035644f, -0.02837173f, 
    0.03581955f, -0.01616181f, 0.02135858f, 0.03927562f, -0.09779432f, 0.14860483f, 0.01834558f, -0.03937903f, 
    -0.14541666f, 0.09348384f, -0.08321150f, 0.03306987f, -0.07477026f, 0.03508709f, 0.04566709f, -0.25773862f, 
    -0.20793535f, 0.05450217f, 0.00327828f, -0.12015345f, 0.01337997f, 0.00265379f, 0.12016538f, 0.01581631f, 
    -0.04919614f, 0.02235206f, 0.10551365f, 0.06844062f, 0.04952987f, 0.09476862f, -0.02504806f, 0.14903705f, 
    -0.05329043f, -0.16543946f, 0.06850194f, -0.08560746f, -0.03045181f, 0.00628397f, 0.06165850f, 0.01032678f, 
    -0.05646920f, -0.06970008f, 0.07275882f, -0.01066944f, 0.12932482f, 0.08568516f, -0.02411229f, -0.01630355f, 
    -0.05001251f, 0.07622779f, 0.02347565f, 0.03216482f, 0.05292527f, -0.02194206f, 0.01922319f, 0.00006591f, 
    -0.03970148f, 0.03052199f, -0.08616520f, 0.06818313f, -0.06304206f, -0.01196229f, 0.00983043f, 0.06304037f, 
    0.30221626f, -0.12960160f, 0.02807286f, 0.04286659f, 0.00336478f, 0.04794605f, 0.07917798f, -0.00078543f, 
    -0.00010786f, 0.17031974f, -0.18520656f, 0.06933197f, 0.08849291f, -0.02209535f, 0.06383597f, -0.06038991f, 
    -0.04455511f, 0.12654546f, 0.01100652f, 0.04521748f, -0.07185658f, 0.05828638f, -0.09158092f, -0.09528864f, 
    0.09559810f, -0.13562247f, 0.23116849f, 0.09635014f, 0.00782643f, -0.12152415f, 0.08407833f, -0.03879410f, 
    0.04260517f, 0.05628675f, 0.06740588f, -0.02583006f, -0.25234911f, -0.08781768f, 0.10494886f, 0.03143246f, 
    0.01575682f, -0.03997483f, -0.00563112f, 0.11013488f, 0.04771744f, 0.06105875f, 0.02960631f, -0.08661677f, 
    -0.11037186f, 0.15177117f, -0.09172204f, 0.00973729f, -0.00579184f, 0.08517803f, -0.06693260f, 0.05922604f, 
    -0.11321341f, 0.25829118f, 0.05155946f, -0.07040538f, 0.09249634f, 0.03895620f, 0.08469871f, 0.00204765f, 
    -0.03649447f, 0.00281084f, 0.07130015f, 0.06743303f, -0.09074149f, 0.05920276f, 0.12697895f, -0.08394596f, 
    -0.00690601f, -0.11286293f, 0.02424097f, 0.01849632f, -0.06409093f, -0.10133717f, -0.02219252f, -0.08891401f, 
    0.00327006f, 0.02163306f, -0.00686752f, 0.03996412f, 0.14722542f, 0.02927425f, -0.10042632f, -0.00968099f, 
    -0.01751019f, 0.02742436f, 0.07211255f, 0.05623940f, -0.13832980f, 0.19315894f, -0.00809342f, 0.07630748f, 
    -0.17449275f, 0.27179596f, -0.06440027f, 0.13547067f, -0.04025369f, 0.06473617f, -0.12903860f, -0.11235243f, 
    0.13585819f, 0.12451969f, 0.00409535f, 0.21851595f, 0.01273070f, 0.09709553f, 0.07404955f, 0.20054705f, 
    0.04879458f, 0.07777166f, -0.03567428f, 0.02607778f, 0.00828102f, 0.02150177f, 0.02238236f, -0.05318090f, 
    0.08090950f, -0.05063417f, -0.03028720f, 0.05393380f, -0.04273626f, 0.01950672f, -0.07590717f, -0.06245272f, 
    -0.07661173f, 0.07034534f, -0.23874521f, 0.00551683f, -0.23252064f, 0.06804302f, 0.04357415f, -0.05062028f, 
    -0.01540115f, -0.03300498f, -0.03546390f, 0.03996890f, 0.00472206f, -0.03551199f, 0.01223670f, -0.05053763f, 
    0.14928047f, -0.01349918f, -0.13900608f, -0.00001132f, 0.15115935f, 0.06197975f, 0.02615065f, 0.15230495f, 
    0.04367029f, -0.00715487f, -0.00960869f, 0.01798330f, 0.08484585f, 0.11067256f, -0.28273410f, 0.01747157f, 
    0.02575350f, 0.07317023f, 0.00711710f, 0.09941714f, 0.00334221f, 0.00474311f, -0.08781962f, -0.04253029f, 
    -0.16164264f, 0.27144665f, 0.06539010f, 0.09877580f, -0.01628737f, 0.15589620f, 0.02072049f, -0.04761678f, 
    -0.01981004f, 0.01811444f, 0.10896543f, -0.02635786f, -0.01771573f, -0.13174742f, 0.27619320f, 0.08752209f, 
    0.01379653f, -0.06656097f, 0.07424719f, 0.09442101f, 0.06269601f, 0.01468645f, -0.02857270f, -0.01078062f, 
    0.13753487f, 0.00826383f, 0.14765525f, 0.14743365f, 0.05222579f, -0.01447061f, 0.03553795f, 0.11013111f, 
    0.06156066f, -0.03840361f, 0.08877624f, -0.17127389f, -0.44679427f, 0.26898378f, 0.26673716f, -0.11004969f, 
    -0.19142066f, -0.11424385f, 0.07544132f, -0.12045944f, 0.01292223f, -0.02401869f, -0.09250882f, -0.06060862f, 
    -0.04330155f, -0.04041333f, -0.24352828f, 0.01237251f, 0.02159420f, 0.03518878f, -0.00104666f, 0.04195673f, 
    -0.02236224f, -0.10241050f, 0.01960779f, 0.07197130f, 0.03625334f, -0.06365492f, 0.00957368f, 0.02694272f, 
    0.12224039f, -0.02934772f, 0.09532958f, -0.01289191f, -0.00171130f, -0.04377387f, -0.20337231f, 0.03690138f, 
    0.29257908f, -0.35105309f, -0.13821815f, -0.08721349f, 0.03081334f, -0.08956234f, -0.05108796f, -0.03883466f, 
    -0.12516655f, -0.17781277f, 0.06200966f, 0.01857421f, 0.02094946f, -0.02441673f, -0.02310773f, 0.14317544f, 
    0.12318893f, -0.08427333f, 0.05450876f, -0.00913915f, 0.10200687f, 0.04158822f, 0.10276395f, -0.02082888f, 
    -0.05889760f, -0.39370561f, 0.20161147f, 0.16970943f, 0.02153841f, 0.00070719f, -0.04756783f, 0.06573620f, 
    0.03278423f, -0.06503709f, 0.00596814f, -0.00926014f, 0.11830440f, 0.14013290f, 0.05993764f, 0.13958205f, 
    -0.05293868f, 0.01648412f, -0.03490965f, -0.08868357f, -0.10303000f, 0.07024131f, 0.04950034f, 0.06761267f, 
    -0.11955740f, -0.07876218f, -0.39657146f, -0.01944809f, -0.05111250f, -0.02654917f, 0.03413814f, 0.07175257f, 
    0.07186175f, -0.06059109f, -0.02608989f, -0.15358612f, 0.24228390f, 0.04642614f, -0.52190864f, -0.06303468f, 
    -0.06193043f, -0.03290095f, -0.04831233f, -0.13466246f, -0.08292578f, -0.08510705f, -0.32377324f, -0.04314953f, 
    -0.04303428f, 0.04548295f, 0.06790394f, -0.07137959f, -0.05553804f, 0.06087546f, -0.11304736f, -0.28196535f, 
    0.11214616f, 0.03367915f, -0.22280730f, 0.04478148f, -0.00746144f, -0.16339304f, 0.58308679f, -0.00620409f, 
    -0.01684299f, -0.10652174f, 0.09267776f, 0.10785655f, 0.07241695f, 0.06356309f, -0.02941962f, 0.03891603f, 
    0.27818334f, 0.54224956f, 0.64166951f, 0.48721504f, -0.19807965f, -0.04696026f, 0.13667597f, 0.11124546f, 
    0.02424889f, -0.10809969f, -0.02410850f, -0.04744489f, -0.21933444f, 0.05347228f, 0.05198298f, 0.01386601f, 
    -0.04946355f, -0.19823080f, -0.38722640f, 0.02825152f, 0.06900205f, -0.00987175f, 0.03420424f, -0.00961970f, 
    -0.10300994f, 0.03854382f, -0.03788252f, 0.05415464f, 0.02869791f, -0.01070964f, 0.11266054f, -0.17421255f, 
    0.04476874f, 0.15176274f, 0.15682653f, -0.00292357f, -0.00117514f, 0.00689093f, 0.03017074f, 0.00705778f, 
    0.01168880f, -0.02371181f, 0.06899132f, -0.00470223f, 0.11704737f, -0.03605859f, -0.13072363f, 0.33845195f, 
    -0.20429647f, -0.30428457f, -0.48719189f, 0.09431035f, -0.13703172f, 0.00221840f, -0.06209492f, 0.06365673f, 
    -0.03406583f, -0.00747120f, 0.01201485f, 0.00627022f, 0.05706312f, 0.03426238f, -0.04534002f, 0.10817848f, 
    0.01787457f, 0.01655035f, 0.05896731f, 0.02835662f, -0.09873781f, -0.10422530f, 0.21181516f, 0.12969366f, 
    -0.31593785f, 0.32074037f, 0.10664428f, -0.18691695f, -0.02021340f, 0.11950174f, -0.08901432f, -0.31419617f, 
    -0.04200053f, 0.11904283f, -0.00490933f, 0.11709662f, -0.21751784f, 0.06024451f, -0.07325903f, -0.07330564f, 
    -0.00289971f, -0.08553220f, -0.05395833f, -0.00026646f, 0.10276235f, -0.03856304f, -0.06384069f, 0.15285841f, 
    -0.12419683f, 0.09301076f, -0.15250821f, -0.26179406f, 0.24040027f, -0.10533220f, -0.15478295f, 0.02724290f, 
    0.00249260f, -0.04789891f, 0.06322404f, -0.07196377f, -0.04854218f, -0.30450526f, -0.26647100f, -0.02373882f, 
    0.17234345f, -0.07256468f, -0.01603522f, -0.04631197f, 0.05503333f, -0.01787259f, -0.05098324f, -0.00704447f, 
    -0.24065721f, -0.08090691f, 0.17886218f, 0.25123000f, -0.06463246f, 0.09002567f, -0.08867579f, 0.03718746f, 
    -0.00758772f, 0.00229455f, 0.01517477f, -0.05560747f, -0.12463519f, 0.19060376f, 0.03962165f, -0.04144384f, 
    0.02515592f, -0.00659043f, 0.05134090f, -0.02863691f, 0.11659920f, 0.15993348f, 0.09724597f, 0.24516037f, 
    -0.48521173f, -0.26052701f, 0.26292109f, -0.05969545f, 0.01443178f, -0.15193774f, -0.13166070f, 0.10901643f, 
    0.04017388f, -0.01249114f, 0.01171206f, -0.01334695f, -0.01034672f, -0.20365715f, 0.26835760f, -0.13095245f, 
    0.04985860f, -0.00368848f, -0.03437457f, -0.03483676f, 0.05675592f, 0.19101733f, 0.02387148f, -0.03067523f, 
    -0.20901138f, -0.13630418f, 0.17372097f, -0.46498507f, 0.03323961f, -0.09176271f, -0.23721781f, -0.26892930f, 
    0.14995761f, -0.04168367f, 0.00325237f, 0.00188837f, -0.24294478f, -0.13837831f, 0.12653609f, -0.08400875f, 
    0.07934809f, 0.00525799f, -0.06704886f, -0.18471479f, 0.03721142f, -0.03253790f, -0.01323665f, 0.02036611f, 
    0.07138691f, -0.09140418f, 0.02835315f, 0.11292444f, -0.06054430f, 0.07749527f, 0.04937615f, 0.08037333f, 
    -0.13375983f, -0.06711064f, 0.08307678f, -0.06010534f, 0.03149074f, -0.05231275f, 0.02025727f, 0.11070848f, 
    0.00519144f, -0.02538429f, 0.02667854f, 0.07218055f, 0.16340661f, 0.00014734f, 0.06120031f, -0.02288722f, 
    0.01961222f, -0.11920280f, -0.03564954f, 0.11618565f, -0.04194704f, -0.00905619f, -0.00545881f, -0.07249837f, 
    -0.02464275f, -0.01054277f, 0.00567157f, 0.01078760f, -0.19907230f, 0.13031483f, 0.34093791f, 0.21259482f, 
    0.00197391f, -0.01690939f, 0.03616934f, 0.19566163f, -0.12671877f, 0.05985779f, 0.03052007f, -0.23870827f, 
    0.04492395f, -0.22474001f, -0.05942784f, 0.13419440f, -0.06524989f, 0.00932705f, -0.04180937f, 0.11276989f, 
    0.04287894f, 0.04330361f, 0.03283682f, 0.00688381f, -0.08941584f, 0.27317768f, 0.46232307f, 0.00341427f, 
    0.02900300f, -0.09581440f, -0.00134514f, 0.02647620f, 0.06925537f, 0.09296814f, 0.05159106f, 0.15367466f, 
    -0.38083762f, -0.03781007f, 0.46892348f, -0.07790522f, -0.04240601f, 0.02221920f, 0.06869683f, 0.03737982f, 
    0.01286530f, 0.01781621f, 0.00232595f, -0.02035484f, -0.02005306f, -0.20166908f, -0.02438950f, 0.06843820f, 
    -0.04741232f, 0.01979897f, 0.04389751f, -0.00009147f, 0.05229666f, -0.06851855f, -0.01779553f, -0.02699025f, 
    -0.44360659f, 0.26627138f, 0.14771095f, -0.05351951f, -0.00348879f, -0.17836578f, -0.00128457f, -0.04430823f, 
    0.08790973f, -0.02533529f, -0.01529123f, -0.01315097f, 0.06555919f, -0.25051820f, 0.14215912f, -0.28428692f, 
    -0.07054354f, 0.00438865f, 0.04868803f, 0.05774405f, -0.10705165f, -0.01839983f, 0.01690658f, -0.02595736f, 
    0.07369933f, 0.21460946f, -0.28049707f, -0.10423636f, 0.13843295f, -0.09730713f, -0.04680930f, 0.10469767f, 
    -0.03352628f, 0.04298671f, -0.00244554f, -0.13017488f, -0.34012824f, 0.08544645f, 0.11252164f, -0.55200285f, 
    0.02187009f, -0.03468071f, -0.03155448f, 0.01915361f, 0.01381267f, 0.05982149f, 0.06310037f, 0.04286067f, 
    -0.05846064f, -0.04721142f, 0.01426798f, 0.09452777f, -0.00043913f, -0.03288803f, 0.03758590f, 0.08378586f, 
    -0.01796282f, -0.06893495f, -0.03296096f, -0.01255278f, -0.76139063f, -0.68789703f, -0.33773291f, -0.44466913f, 
    -0.05947747f, -0.10320062f, 0.08837664f, -0.04103855f, -0.00117338f, -0.00789053f, 0.03077576f, -0.00625881f, 
    -0.43710196f, 0.20164554f, -0.14614752f, -0.43121728f, -0.00064388f, -0.01700291f, 0.01018480f, 0.02515738f, 
    0.01268700f, -0.06114077f, -0.02836582f, 0.01626067f, -0.06935213f, 0.27566409f, 0.11719263f, 0.22630082f, 
    0.07687674f, 0.16621362f, -0.37129566f, 0.15822342f, 0.07251345f, 0.00873221f, -0.01929537f, 0.05240756f, 
    -0.07567666f, 0.17251217f, -0.23026077f, 0.05968036f, -0.07876691f, -0.32423958f, -0.04523761f, 0.06877642f, 
    -0.00123054f, 0.09877432f, -0.05832194f, -0.05722859f, -0.73789805f, -0.59993297f, -0.34255323f, -0.31867981f, 
    -0.02921263f, 0.00479683f, 0.04586975f, 0.02824249f, 0.00515950f, -0.01011742f, 0.07494076f, -0.06548242f, 
    0.10883834f, -0.12212832f, -0.01838388f, 0.08266226f, 0.01403232f, 0.05347838f, 0.05064669f, -0.17416368f, 
    -0.06110222f, 0.04192802f, -0.00840447f, 0.04254313f, 0.12764321f, 0.02448302f, 0.05720487f, 0.02040021f, 
    0.10011046f, 0.02599761f, -0.04087943f, 0.20372623f, 0.02135567f, -0.06430423f, 0.04054583f, 0.05064805f, 
    0.04358649f, -0.16113000f, 0.00187965f, -0.06248959f, -0.01881096f, -0.04073138f, -0.16438755f, 0.15684560f, 
    0.04712134f, -0.04444874f, -0.08563553f, 0.07089729f, -0.26124701f, 0.13315637f, 0.00099958f, 0.04428237f, 
    -0.08412469f, 0.12482759f, -0.16513138f, -0.02198971f, -0.01375253f, 0.07379489f, -0.06031278f, 0.04790572f, 
    0.07254177f, 0.04451695f, 0.00690686f, 0.09887754f, 0.05976282f, -0.08221778f, 0.03670286f, -0.05144391f, 
    0.00136711f, 0.02695963f, 0.02187816f, -0.06245730f, 0.15837340f, -0.01093755f, -0.02874354f, 0.02250919f, 
    -0.03088650f, 0.04088146f, -0.00895919f, -0.02722494f, -0.04371760f, -0.03524949f, -0.03437765f, 0.07815175f, 
    -0.26816005f, 0.15238903f, -0.09825720f, 0.07340113f, 0.13415414f, 0.04463195f, -0.18727821f, -0.01951191f, 
    -0.00122131f, -0.04265866f, 0.21945840f, 0.01140859f, -0.13120693f, -0.02082492f, -0.00155095f, 0.03081551f, 
    0.00006867f, 0.02778399f, 0.03523915f, -0.02578110f, -0.04488752f, -0.27699518f, -0.00705690f, -0.02598737f, 
    0.04662548f, -0.16403778f, 0.05768970f, 0.05454377f, 0.01998243f, -0.03357397f, -0.02447015f, -0.03161418f, 
    0.03632353f, -0.09264341f, 0.15719135f, -0.09466880f, 0.41147494f, -0.21009405f, -0.26225045f, -0.37358093f, 
    -0.18258953f, -0.05992186f, -0.18169734f, -0.06914488f, -0.01963126f, -0.20998648f, -0.15334889f, 0.01055565f, 
    -0.75842315f, 0.14958189f, -0.12547016f, -0.07348757f, -0.05111676f, 0.03944619f, -0.07955120f, -0.19799750f, 
    -0.09894255f, 0.11278427f, -0.08740917f, -0.06414974f, 0.16488889f, 0.53604931f, 0.01147525f, 0.18005610f, 
    0.00090845f, -0.19298376f, 0.07625899f, -0.04466497f, -0.01724658f, -0.00277879f, -0.04720132f, -0.00782751f, 
    0.33628982f, -0.11853441f, 0.15280809f, -0.13613817f, -0.01039701f, 0.09795587f, 0.05700097f, -0.07986847f, 
    0.01394580f, 0.02547438f, -0.04684684f, -0.08330461f, -0.39672932f, -0.32246637f, -0.19050314f, -0.17747022f, 
    0.05293614f, -0.07291654f, -0.15069668f, -0.15637474f, 0.06320829f, -0.02399152f, 0.03457738f, 0.08754349f, 
    0.05173242f, 0.01475890f, -0.05724806f, -0.11970578f, -0.02280146f, -0.01547064f, 0.01162252f, -0.03241779f, 
    -0.03118781f, 0.05214772f, -0.18412770f, -0.01057929f, -0.05780022f, 0.44728136f, -0.32421654f, -0.64620972f, 
    0.09997174f, -0.09257667f, -0.04420998f, 0.02457457f, -0.14664517f, -0.06821512f, -0.06458392f, 0.09556008f, 
    -0.14987925f, -0.03553034f, -0.16309641f, 0.15778929f, -0.03371642f, -0.04474390f, -0.07524159f, 0.01635977f, 
    -0.04304126f, 0.02161890f, 0.09042033f, 0.03289728f, -0.18099208f, 0.17906414f, -0.01286323f, -0.15311466f, 
    0.21938866f, 0.10726605f, 0.06069199f, -0.03143327f, -0.20189981f, -0.00590920f, -0.01652252f, 0.03281596f, 
    -0.27376994f, 0.33152956f, -0.07114083f, -0.04509045f, 0.05198015f, 0.09178116f, 0.03312401f, -0.05424963f, 
    -0.18677160f, -0.14578781f, 0.00557748f, -0.07152742f, -0.05404726f, -0.04387617f, -0.03000716f, 0.23383786f, 
    0.04021955f, -0.15927771f, 0.12897129f, 0.11196472f, 0.04355544f, 0.03193749f, 0.00575758f, 0.04481557f, 
    -0.03887515f, 0.29218233f, -0.05813649f, -0.09336349f, -0.05798802f, 0.00565787f, -0.04668054f, 0.16447715f, 
    0.09507585f, -0.04108367f, -0.06894310f, 0.12801547f, 0.18767661f, -0.02003269f, -0.03260762f, -0.07111596f, 
    0.11716674f, -0.00138303f, 0.01746495f, -0.03219729f, 0.02149648f, -0.01218154f, 0.11582018f, -0.04750543f, 
    0.00417905f, -0.02349055f, -0.14725141f, -0.02449629f, 0.08744531f, 0.01819722f, -0.03534132f, 0.11962529f, 
    -0.04841565f, 0.03301146f, 0.02601194f, -0.04706058f, -0.21627168f, -0.21949162f, -0.09496962f, -0.30369642f, 
    0.09254823f, 0.13364288f, 0.05621673f, 0.11750618f, -0.01400275f, 0.00286449f, -0.13518997f, 0.06660290f, 
    0.05365649f, 0.06386053f, -0.05428748f, 0.05327621f, 0.03438591f, -0.01692912f, -0.12163445f, -0.04157853f, 
    -0.00684905f, 0.14076205f, -0.09170648f, 0.02523517f, -0.26995054f, -0.16139792f, -0.03165016f, 0.28199682f, 
    0.10491397f, 0.07760756f, 0.04260122f, 0.05766929f, -0.05695911f, -0.08072975f, -0.04615981f, -0.01748090f, 
    -0.24276039f, -0.17443793f, 0.00112444f, -0.24079177f, 0.07658247f, -0.16334322f, -0.19538794f, 0.04589419f, 
    0.06363968f, 0.09107517f, -0.12809002f, 0.11418886f, 0.01472858f, -0.01200627f, -0.10892785f, -0.05523515f, 
    0.06636101f, 0.00522487f, -0.02713046f, 0.05613039f, -0.12880976f, 0.05311723f, -0.05370727f, -0.19414397f, 
    -0.20410603f, 0.04854855f, 0.01385762f, 0.13942358f, -0.02153323f, 0.05744838f, -0.17926975f, 0.10920355f, 
    -0.11673089f, -0.23025180f, 0.00747017f, 0.04714461f, -0.20239213f, 0.05267135f, -0.01004219f, 0.14414090f, 
    0.14189419f, -0.05111183f, 0.01416645f, -0.08117350f, -0.13301158f, -0.00485746f, 0.14099073f, -0.03391691f, 
    0.06915598f, -0.15220304f, 0.07921951f, 0.22790067f, 0.05738008f, 0.00871396f, 0.03698879f, 0.13182467f, 
    -0.02971562f, 0.11951277f, -0.12832639f, -0.00465377f, -0.13711938f, -0.21342026f, 0.05145905f, 0.23461968f, 
    0.05890356f, 0.03623708f, 0.02591719f, 0.17093149f, -0.00226997f, -0.10354479f, 0.13294758f, -0.04593920f, 
    -0.08220638f, -0.07935394f, 0.14496617f, 0.08355622f, -0.15473323f, 0.03098037f, 0.07138963f, 0.05613506f, 
    0.17098993f, 0.14955139f, 0.03162995f, -0.01760991f, -0.16969989f, 0.31280544f, 0.15988348f, -0.12565227f, 
    0.06159442f, 0.01878071f, 0.03474341f, -0.02115823f, -0.02967278f, 0.06366206f, 0.07454764f, 0.06266710f, 
    -0.02199295f, 0.20353350f, -0.32034576f, 0.12134749f, 0.01044032f, 0.03087596f, 0.02488605f, 0.09689337f, 
    -0.15066062f, 0.07125663f, -0.08034793f, 0.05500244f, 0.14159645f, 0.05693873f, -0.08394530f, -0.25638565f, 
    -0.22125366f, 0.14398381f, -0.04109883f, -0.00285522f, -0.05295679f, -0.30058432f, 0.11456867f, -0.14603718f, 
    -0.39306188f, 0.10456753f, -0.00893836f, 0.31784377f, -0.08290116f, 0.04163834f, -0.13201645f, -0.01534470f, 
    0.03088950f, 0.04675917f, 0.23029320f, -0.02543515f, -0.13311076f, -0.16516940f, 0.18582578f, 0.23614328f, 
    -0.12647980f, 0.07636072f, 0.03192504f, 0.02728308f, 0.05179398f, 0.07864310f, 0.04025443f, 0.15933338f, 
    -0.20362505f, 0.04665300f, 0.02960037f, 0.19449729f, 0.03056071f, -0.01194177f, -0.04344382f, 0.13255331f, 
    -0.10568386f, -0.04712141f, -0.13030137f, -0.07859142f, 0.16973571f, 0.13794628f, -0.12292521f, -0.07165995f, 
    0.16770707f, -0.00047743f, -0.01941360f, 0.01819653f, -0.01016345f, 0.13076399f, -0.02983019f, -0.13743129f, 
    0.11095902f, 0.19743103f, -0.20592333f, -0.22957230f, 0.12626149f, -0.00176681f, -0.03615472f, 0.13540751f, 
    -0.10674644f, 0.09950170f, 0.11162094f, 0.00424488f, -0.19936289f, -0.03009094f, 0.19086595f, 0.10480680f, 
    0.04478646f, 0.09982206f, -0.03848893f, -0.04478179f, 0.07357363f, 0.09898252f, 0.08535559f, 0.07953805f, 
    -0.07770037f, 0.00505449f, -0.17841813f, 0.10811875f, 0.13175939f, -0.03421966f, -0.07486567f, 0.07089699f, 
    0.01428845f, 0.05425709f, 0.03561202f, 0.09869783f, -0.25088719f, 0.43727994f, -0.27308452f, 0.23282480f, 
    0.14736110f, -0.04444683f, 0.01491080f, -0.03431332f, -0.05557734f, 0.04848145f, -0.07737670f, -0.07570055f, 
    -0.02220866f, -0.22621635f, 0.48365241f, 0.33364743f, -0.12297173f, 0.05627687f, 0.06051791f, 0.08098112f, 
    0.09886988f, -0.05909726f, 0.02511139f, -0.04543902f, -0.13305153f, -0.27446261f, 0.09841566f, 0.25331786f, 
    -0.06338661f, -0.02510382f, -0.14655411f, -0.07121333f, 0.00130107f, -0.05038134f, 0.01041861f, -0.08959406f, 
    0.02768945f, -0.00745438f, 0.00933824f, 0.05993903f, -0.05161544f, 0.01144430f, -0.06493106f, -0.11299718f, 
    0.00936676f, -0.07741033f, 0.04772591f, 0.04811557f, 0.69629550f, -0.08327851f, -0.19188593f, -0.26038903f, 
    0.12470081f, 0.02298614f, 0.16645449f, -0.06658092f, -0.24832846f, -0.06804258f, -0.07113668f, 0.02039139f, 
    0.08247070f, -0.02142190f, -0.10379455f, 0.08740195f, 0.08258207f, -0.16525666f, 0.05057257f, -0.10020177f, 
    -0.08772270f, 0.14988637f, -0.16557835f, -0.02772101f, 0.08511619f, 0.10304686f, -0.22098002f, 0.20745127f, 
    0.06123923f, -0.13201097f, -0.16585110f, 0.04204561f, 0.09905770f, 0.10297486f, -0.12702292f, 0.05522697f, 
    -0.00283291f, 0.24798596f, -0.28636038f, 0.09052000f, 0.06889895f, -0.00874483f, -0.02236052f, -0.14062384f, 
    0.10215680f, 0.07306717f, -0.09591185f, -0.00795350f, 0.08084176f, 0.57300735f, -0.02202081f, 0.20359795f, 
    0.17264786f, 0.05390256f, 0.05390326f, 0.00325011f, -0.11873151f, -0.02094056f, 0.03830316f, 0.00389880f, 
    -0.00232502f, -0.23439501f, 0.17312443f, -0.24291390f, -0.21345609f, -0.07657135f, -0.14082493f, -0.12487465f, 
    0.03435275f, 0.07022098f, -0.10728755f, 0.05656369f, -0.22119357f, -0.33711827f, -0.01544363f, -0.07677402f, 
    -0.03316404f, 0.03121276f, -0.21016508f, 0.07194629f, 0.00112762f, 0.26996613f, -0.11345410f, -0.25509626f, 
    -0.78181541f, -0.07507229f, 0.08908823f, 0.17965284f, 0.06151272f, 0.11081479f, -0.13332634f, -0.18237616f, 
    0.02443978f, -0.16062902f, 0.10309695f, -0.01710905f, 0.42576912f, -0.18485114f, 0.36731207f, -0.15452428f, 
    -0.20237157f, 0.04603209f, -0.13881022f, 0.03898201f, 0.02489931f, -0.01599587f, 0.15545508f, -0.04400497f, 
    -0.19230919f, 0.36770520f, -0.13015369f, 0.15673588f, 0.11254284f, 0.16267288f, -0.01287733f, 0.03455569f, 
    -0.15496124f, -0.00726274f, -0.02536099f, 0.07892577f, -0.22372024f, 0.05233891f, 0.11298047f, 0.24355921f, 
    0.04179620f, -0.09566406f, 0.11844776f, -0.23184355f, -0.04516950f, 0.24170434f, 0.10494957f, 0.10997701f, 
    -0.19336784f, 0.04647800f, 0.03707128f, -0.23495732f, 0.09655505f, -0.05334336f, -0.12917899f, -0.19776879f, 
    0.05336395f, -0.27443635f, -0.06087682f, -0.01158072f, 0.02876135f, -0.11273497f, -0.09879345f, 0.14634737f, 
    -0.00480033f, 0.00250951f, 0.10274673f, 0.00723035f, -0.03908623f, -0.01767540f, -0.08368871f, -0.07721153f, 
    -0.71908289f, -0.00483772f, -0.19015369f, -0.16130105f, 0.22058082f, 0.03777287f, 0.18748912f, 0.07146470f, 
    0.04781897f, 0.09471056f, 0.03920340f, -0.13635269f, 0.42331332f, -0.23358084f, -0.00142624f, 0.03065854f, 
    0.05364341f, 0.06656607f, -0.06135318f, 0.00708890f, -0.07305665f, 0.05912547f, 0.04369654f, 0.02733496f, 
    0.03588006f, 0.06374764f, -0.25292957f, 0.14264934f, 0.16031253f, 0.06611983f, -0.04850126f, 0.19979785f, 
    0.00730970f, -0.18545534f, 0.10247265f, -0.01323523f, -0.18360323f, -0.00844386f, -0.10271127f, 0.18365805f, 
    0.05196826f, 0.08177329f, 0.04694923f, 0.04386926f, -0.08929876f, 0.05102318f, -0.04075884f, -0.05373385f, 
    0.33013421f, -0.01726340f, -0.04851805f, -0.10843881f, -0.02102901f, 0.03619576f, -0.07279426f, -0.19525972f, 
    -0.01524359f, -0.03042670f, 0.08462480f, -0.02814049f, -0.07599228f, -0.08140583f, -0.08591817f, 0.20704949f, 
    -0.15113287f, 0.02318118f, -0.07065232f, -0.08612935f, -0.04919122f, -0.16695222f, -0.00433315f, 0.20037451f, 
    -0.02479129f, -0.18209711f, 0.24787082f, 0.10902909f, -0.03302389f, -0.18050110f, -0.15512520f, -0.01997118f, 
    -0.01593086f, -0.01749844f, -0.08793705f, 0.00741959f, -0.16968903f, 0.14934491f, 0.08425140f, -0.05094434f, 
    -0.22520165f, 0.17161179f, -0.16990785f, 0.05961705f, -0.18359289f, -0.29733557f, 0.10227069f, -0.22312348f, 
    -0.03782716f, 0.55258954f, -0.33772722f, 0.25509658f, 0.12960489f, -0.02373568f, -0.01470681f, -0.15832756f, 
    -0.03492279f, -0.16638020f, -0.00962773f, 0.01488915f, 0.52255255f, 0.32511586f, 0.08007784f, -0.50768399f, 
    -0.35094392f, -0.08904910f, 0.02716501f, -0.16286239f, 0.03554288f, -0.04238218f, 0.15019982f, -0.04070442f, 
    0.00293380f, -0.13525021f, -0.04853365f, -0.06948634f, 0.13630468f, 0.07005903f, -0.27405861f, 0.04483759f, 
    -0.03580750f, 0.10845161f, 0.05664599f, -0.10597692f, 0.03563704f, -0.19499031f, 0.07553287f, 0.07030626f, 
    0.07766882f, 0.10916594f, 0.03126960f, -0.24464019f, 0.00924281f, -0.04452073f, 0.06039644f, 0.07294235f, 
    0.14859299f, 0.04742859f, 0.07371932f, 0.00163422f, 0.04455581f, -0.05039115f, -0.34368998f, 0.21794952f, 
    0.05387007f, -0.09206632f, -0.01310699f, -0.03240828f, -0.23755273f, -0.07340522f, -0.17717430f, 0.00922815f, 
    -0.17252019f, -0.09771678f, -0.02289401f, -0.08014843f, -0.13537952f, -0.06391834f, -0.22298515f, -0.14849867f, 
    0.03903133f, -0.28992265f, -0.03532710f, -0.32927498f, -0.07250044f, -0.03865185f, -0.01238474f, 0.06377685f, 
    -0.16443373f, -0.12965773f, -0.14315014f, -0.07381382f, -0.19433813f, -0.04473424f, -0.07801794f, -0.68996221f, 
    0.06443541f, 0.10631134f, -0.10646956f, 0.09221295f, 0.00008994f, 0.00901164f, -0.01826801f, -0.19751418f, 
    0.03924756f, 0.04130456f, -0.17739244f, 0.21578379f, -0.05532649f, 0.02954989f, -0.12393120f, -0.29471546f, 
    0.10306710f, 0.01859402f, 0.13159619f, 0.38064587f, -0.02050096f, -0.05443904f, -0.00332429f, 0.06990968f, 
    0.06966477f, 0.04802351f, 0.06798895f, 0.03010788f, 0.06597754f, 0.05248017f, -0.03699957f, 0.07490349f, 
    -0.12695408f, 0.02473917f, 0.00425011f, 0.15101191f, 0.01636804f, 0.00586850f, 0.00916931f, -0.28013560f, 
    0.04670732f, -0.09548526f, -0.02024471f, -0.06531483f, -0.00515648f, -0.36297214f, 0.11077178f, -0.02141494f, 
    0.03796308f, 0.07042130f, -0.08750346f, -0.06832823f, -0.08465292f, -0.10718442f, -0.08247139f, -0.23902717f, 
    -0.06179179f, 0.06052871f, 0.10696579f, -0.01346972f, -0.09263900f, 0.09849683f, 0.00190338f, -0.10602769f, 
    0.06020880f, -0.00885262f, -0.03620430f, 0.03324363f, 0.19080588f, -0.15205552f, 0.02690993f, 0.02862991f, 
    -0.06862590f, -0.08306896f, -0.03980806f, -0.06233498f, 0.07023968f, -0.01911266f, -0.13998535f, -0.11288276f, 
    0.07241379f, -0.13803957f, -0.16678733f, -0.06208009f, -0.19254874f, -0.14330928f, -0.07349606f, 0.10152122f, 
    -0.05162801f, 0.11490580f, -0.15086254f, -0.09220053f, 0.00145010f, 0.09562150f, 0.10885201f, 0.07843103f, 
    -0.05942429f, -0.03311300f, -0.12252107f, -0.17657360f, 0.00026824f, 0.00282934f, 0.08517570f, -0.00883820f, 
    0.08512461f, -0.15410873f, 0.12850361f, 0.04764097f, -0.00570815f, 0.00372595f, 0.01077685f, -0.04706958f, 
    -0.01860788f, 0.00935456f, -0.02505028f, 0.07248206f, 0.10899185f, -0.01545928f, -0.09835296f, 0.02454009f, 
    -0.06135676f, 0.04523541f, -0.13851956f, -0.02019591f, 0.12206395f, -0.11812805f, -0.22589587f, 0.05361147f, 
    0.31293234f, 0.15518047f, 0.18287036f, 0.18315785f, -0.08369570f, 0.00095410f, -0.00729500f, -0.05541972f, 
    0.18166736f, -0.05049141f, 0.05042207f, -0.07680577f, 0.05272545f, 0.14214332f, -0.01582535f, 0.06560526f, 
    -0.02711902f, 0.00301550f, -0.05863872f, -0.03113082f, 0.02738430f, -0.06501380f, -0.10827976f, 0.03104271f, 
    0.17149541f, 0.01401217f, 0.01339471f, 0.06532259f, -0.07163434f, 0.02386684f, 0.13250071f, -0.18430971f, 
    0.06878895f, 0.02076239f, 0.04017683f, -0.01478647f, 0.08250190f, 0.11063142f, 0.05654956f, 0.08769505f, 
    -0.01275151f, -0.08410537f, 0.01857184f, 0.00136410f, 0.07515236f, -0.00953044f, 0.00902286f, 0.04815795f, 
    -0.02078331f, -0.05802674f, -0.05607720f, -0.08702707f, 0.07687590f, 0.02050977f, 0.01820802f, 0.01276302f, 
    -0.04287147f, -0.00182389f, 0.02595445f, -0.07208890f, 0.08400339f, 0.08936993f, 0.18449405f, 0.17133932f, 
    0.04669290f, -0.08078030f, -0.05375671f, -0.14019741f, -0.00834573f, -0.13564917f, 0.05937399f, -0.05921712f, 
    0.00117452f, 0.06536954f, 0.06640898f, 0.15114598f, 0.12598418f, 0.01860468f, 0.06849721f, -0.14483918f, 
    0.13384899f, 0.01217421f, 0.15525377f, -0.05004325f, 0.02091963f, -0.00368450f, 0.03554689f, 0.04087092f, 
    -0.09052351f, -0.00504415f, -0.00214300f, -0.17611282f, 0.02833709f, 0.04372832f, -0.10530749f, 0.00174281f, 
    0.17915328f, 0.10574383f, 0.24596652f, 0.13266267f, -0.05428461f, -0.21474108f, 0.07627624f, -0.17064627f, 
    0.00339667f, -0.02529454f, 0.00559380f, -0.03189776f, 0.00313910f, 0.06960066f, 0.18903868f, 0.19432664f, 
    -0.12345555f, -0.07096020f, -0.04289647f, 0.07729924f, -0.01942292f, -0.00068114f, -0.12696052f, 0.03912497f, 
    0.09335899f, -0.00643434f, -0.02756312f, 0.00378067f, 0.00778335f, -0.07789801f, -0.02510816f, 0.08042634f, 
    0.10903713f, 0.07047198f, 0.09412487f, 0.30605975f, -0.02871837f, -0.14702033f, -0.05391167f, -0.06505612f, 
    -0.13734728f, -0.06854670f, 0.09128641f, 0.12183255f, -0.10137151f, 0.15661030f, -0.04709997f, 0.04461223f, 
    0.05497101f, -0.06390869f, 0.39708009f, 0.14238329f, -0.14044596f, 0.03733168f, -0.17547162f, -0.00676818f, 
    -0.09339627f, 0.03277552f, 0.11976664f, -0.00802221f, -0.04127711f, -0.10145238f, -0.01818187f, -0.09091853f, 
    0.07050741f, -0.07447502f, -0.00511818f, -0.03477201f, 0.00349619f, 0.01150330f, -0.19268240f, 0.07903107f, 
    -0.13880357f, -0.15924786f, -0.09015090f, 0.06405964f, 0.08673380f, -0.04644935f, -0.08217528f, -0.16991898f, 
    -0.11749271f, -0.01400830f, 0.00006745f, 0.00833836f, 0.14617509f, 0.22580382f, -0.00169413f, 0.01343258f, 
    0.06383857f, -0.08381203f, -0.09755300f, 0.01363469f, 0.02664501f, -0.06479361f, -0.07143445f, -0.24690172f, 
    0.04627389f, 0.02754814f, 0.16517761f, 0.06132470f, 0.06062002f, 0.12371697f, 0.00883410f, -0.10189159f, 
    -0.12583573f, 0.02656417f, -0.04730080f, 0.03157753f, -0.08075478f, 0.07393428f, 0.00975608f, 0.20693357f, 
    -0.12808505f, 0.09547710f, -0.07225841f, 0.11843593f, 0.00035379f, -0.03506739f, -0.01128084f, 0.01376459f, 
    -0.22413707f, -0.27268806f, -0.08653665f, 0.05520191f, -0.23310415f, 0.14652374f, -0.14171812f, -0.14636104f, 
    -0.13815296f, 0.00403620f, -0.06494217f, 0.05096950f, 0.15123937f, 0.13096000f, 0.03089361f, 0.11433723f, 
    0.03355596f, -0.04261001f, 0.00394484f, -0.04057866f, 0.14248301f, -0.07440440f, 0.00179496f, 0.16209602f, 
    -0.04763096f, -0.08908809f, 0.07122876f, 0.06078806f, -0.12019302f, -0.03069219f, -0.09614941f, -0.06882095f, 
    -0.06384505f, 0.02567241f, -0.00430661f, 0.05093904f, -0.02747530f, -0.08079557f, -0.03860670f, -0.06522999f, 
    -0.08207348f, 0.07256371f, -0.05902634f, -0.12665804f, -0.11369709f, 0.06191592f, 0.03842412f, 0.21654215f, 
    0.13914324f, 0.41629332f, -0.15184975f, 0.23796628f, 0.12800074f, 0.12238070f, 0.01639420f, 0.07352834f, 
    0.05286598f, -0.02499463f, 0.01270074f, -0.10477844f, 0.04836114f, 0.28785318f, 0.23877132f, 0.11591372f, 
    0.10881099f, 0.18350184f, -0.09690882f, 0.14184245f, 0.04548296f, -0.07699404f, -0.08215415f, -0.11004437f, 
    -0.04925128f, -0.01011783f, -0.07194230f, 0.05431380f, 0.06856334f, -0.06292360f, 0.12376858f, 0.01292001f, 
    0.07621229f, 0.24092405f, 0.01658381f, 0.15482581f, -0.07683343f, -0.13225384f, 0.02299174f, 0.10965259f, 
    -0.08300025f, -0.03362048f, -0.06764456f, 0.14457810f, 0.08377226f, 0.14936855f, -0.02724191f, -0.14480370f, 
    -0.08983526f, 0.16996434f, -0.08423689f, 0.01812837f, -0.14591572f, -0.07890498f, -0.07381620f, 0.01634271f, 
    0.02518542f, 0.06793842f, -0.02030763f, -0.02947461f, -0.07340708f, -0.07299678f, 0.17834935f, 0.00309438f, 
    -0.12769042f, 0.03486339f, -0.09106785f, 0.06676119f, -0.02478712f, -0.01294553f, 0.07208169f, -0.00302308f, 
    -0.02418593f, -0.11502055f, 0.17199612f, 0.06392083f, -0.12748231f, -0.00514230f, -0.11361283f, -0.12177470f, 
    -0.06043068f, -0.03060197f, -0.05421694f, 0.05697732f, -0.24978699f, -0.33737278f, 0.01601780f, -0.08792867f, 
    0.01045960f, 0.09794032f, -0.15065749f, 0.01047951f, 0.13050890f, -0.07402768f, 0.06329133f, 0.21335953f, 
    0.17795458f, -0.23623304f, -0.30428094f, -0.01413037f, -0.05673050f, -0.00549209f, 0.00688334f, 0.09191918f, 
    -0.01311111f, -0.00171990f, 0.01934943f, -0.00305624f, 0.09841954f, 0.07437760f, -0.13665597f, -0.03123441f, 
    0.03823077f, -0.00263881f, 0.06851467f, 0.07141260f, 0.01936016f, -0.06244130f, -0.08311053f, -0.03255954f, 
    0.02961921f, -0.05376266f, 0.10610795f, -0.13969275f, 0.06138435f, 0.04544225f, 0.13973974f, -0.13467866f, 
    0.00101958f, -0.08361148f, 0.03415166f, 0.11895189f, 0.29511109f, 0.05052683f, -0.13796720f, 0.17349780f, 
    0.08914845f, -0.04311971f, -0.00965803f, -0.03236734f, 0.04046263f, -0.05546339f, -0.00328977f, -0.03520922f, 
    0.16816752f, -0.05220018f, 0.18470740f, 0.05497258f, 0.11635495f, -0.07998288f, -0.06560532f, -0.11474687f, 
    -0.02527025f, 0.08106393f, -0.06718806f, 0.08837514f, -0.08593591f, 0.06661047f, -0.02399621f, 0.20406610f, 
    0.01834706f, 0.04850044f, 0.07638070f, -0.00559527f, -0.06437061f, -0.05232072f, 0.03480263f, -0.29015601f, 
    0.07955022f, -0.03816206f, 0.00146963f, 0.02242576f, -0.07673442f, -0.00585905f, -0.10132634f, -0.03838280f, 
    -0.01796707f, 0.05876015f, -0.08066501f, -0.05689032f, 0.00964702f, 0.17731376f, 0.19881068f, 0.15877227f, 
    -0.04732282f, -0.00310038f, 0.01505921f, 0.20003042f, 0.10199499f, -0.00281614f, 0.04240081f, 0.03933350f, 
    -0.01908737f, -0.08256710f, -0.27140576f, -0.15137210f, 0.09184151f, 0.06053337f, -0.01162213f, 0.12667282f, 
    0.04854931f, 0.02928690f, -0.08409778f, -0.01744944f, -0.09339551f, 0.04924982f, -0.13152725f, -0.01167707f, 
    -0.14429204f, -0.17093888f, 0.16294123f, 0.02426621f, -0.00728708f, -0.03869498f, -0.00886194f, 0.07044079f, 
    -0.05237287f, -0.21671505f, 0.26495874f, 0.05138982f, 0.00032994f, -0.16930462f, -0.01261748f, 0.07629023f, 
    -0.03251936f, 0.04852522f, -0.00410991f, 0.08910535f, 0.00093478f, 0.04309505f, 0.16951066f, 0.13838702f, 
    -0.06819084f, 0.07486764f, 0.07767391f, 0.06050745f, 0.03711468f, 0.00069694f, 0.04224026f, 0.06924387f, 
    -0.07632510f, -0.03825410f, -0.08411411f, 0.17900918f, 0.03058865f, -0.11981160f, -0.02245181f, 0.09287226f, 
    0.00353846f, -0.09460302f, -0.08829985f, -0.09674003f, -0.02375365f, 0.12758943f, -0.00081724f, -0.13614954f, 
    0.01475731f, -0.14849363f, -0.10566559f, -0.01039446f, 0.02371733f, -0.00215133f, -0.01088130f, -0.14387573f, 
    0.13940661f, 0.09479986f, -0.18546683f, 0.03399930f, 0.05472713f, 0.01715265f, 0.10175802f, -0.03241794f, 
    -0.07084539f, 0.03217955f, 0.04599649f, -0.33707348f, -0.08413737f, -0.08610907f, -0.04587283f, -0.05549652f, 
    -0.05953584f, 0.13657396f, 0.09055466f, -0.07674113f, 0.08409790f, 0.04254152f, -0.09877079f, -0.09055431f, 
    -0.16358639f, -0.19108102f, 0.03730218f, -0.13166542f, 0.06536989f, 0.04457086f, -0.03045807f, 0.07212835f, 
    -0.00937469f, -0.02883344f, -0.03491435f, -0.16389902f, -0.01827774f, -0.21448025f, -0.32722729f, 0.20028926f, 
    -0.01929777f, 0.02230106f, -0.05641060f, -0.05911570f, 0.11170125f, -0.09801278f, -0.00209011f, 0.06859867f, 
    0.04201838f, -0.01094096f, -0.15924895f, 0.07535151f, -0.13434757f, -0.16718021f, 0.19032276f, -0.02968173f, 
    -0.16537666f, -0.33376899f, -0.13953964f, -0.20538941f, 0.08770696f, 0.10886095f, -0.04904912f, 0.01573274f, 
    0.06316435f, 0.03325205f, -0.00846036f, 0.05231268f, 0.07164440f, -0.13182943f, -0.26615056f, -0.01780589f, 
    -0.07918537f, 0.12948720f, 0.00591275f, -0.22901666f, 0.02994749f, 0.21182227f, 0.30003846f, -0.05909212f, 
    0.05998733f, -0.07557113f, -0.10036332f, 0.02690116f, -0.43614358f, -0.24461773f, 0.17640303f, 0.21160756f, 
    -0.02964314f, -0.01673699f, -0.12841934f, 0.12560830f, -0.03023808f, -0.10672629f, 0.05575399f, 0.34581891f, 
    0.69584608f, -0.34595165f, 0.20701337f, 0.18683237f, 0.04538262f, -0.06865851f, 0.06122454f, 0.09845085f, 
    0.23655680f, -0.15433986f, 0.02904066f, -0.01470796f, -0.22163203f, -0.62041885f, -0.01437629f, -0.01641222f, 
    -0.01885679f, -0.02796778f, 0.02179609f, 0.00974319f, -0.15240861f, 0.00073954f, 0.13761304f, 0.24676876f, 
    -0.25295299f, -0.04520250f, 0.10894573f, 0.06254452f, -0.03561904f, -0.24947158f, -0.02064863f, 0.29654667f, 
    -0.08559918f, -0.07353924f, -0.16404688f, -0.27023032f, -0.05090157f, -0.11392481f, -0.06312777f, 0.08067582f, 
    0.05873966f, -0.02986669f, -0.04360504f, -0.02872127f, -0.05731639f, -0.03570394f, -0.02760008f, -0.00855793f, 
    0.02161501f, -0.03782090f, 0.21600157f, 0.10573392f, -0.12976231f, -0.06672881f, 0.09053411f, 0.28567308f, 
    0.04588422f, 0.02073892f, 0.11899338f, -0.03954205f, 0.00721776f, -0.10734572f, 0.01599780f, 0.06940915f, 
    0.04432853f, -0.13207945f, 0.12916413f, 0.04220540f, 0.02754297f, -0.08252458f, 0.14504179f, 0.13107291f, 
    0.24262184f, -0.17822699f, 0.26004913f, 0.02321739f, 0.13202299f, -0.16162689f, -0.02925484f, 0.30196339f, 
    -0.02667112f, -0.06920464f, 0.01594835f, 0.05915847f, -0.22222084f, -0.03495538f, -0.20371078f, 0.05893512f, 
    -0.01960617f, 0.02605951f, -0.06925031f, -0.03241018f, 0.15152901f, 0.16952749f, 0.06008820f, -0.01954832f, 
    0.04567180f, 0.24272683f, -0.05308387f, -0.11690046f, 0.08091422f, 0.00425920f, -0.11459713f, -0.04800314f, 
    0.10852636f, 0.12569098f, -0.07020500f, -0.11919423f, 0.00229219f, 0.07268699f, -0.08861753f, -0.14745526f, 
    0.09322103f, 0.13211653f, 0.02561901f, -0.06310292f, 0.08847418f, -0.02729256f, 0.08408667f, -0.03567071f, 
    -0.10630126f, -0.09280371f, 0.01909511f, 0.00350239f, 0.04579505f, -0.05905674f, -0.00472383f, 0.00389007f, 
    -0.15701999f, 0.04972450f, -0.01357698f, -0.17811529f, -0.24910167f, 0.05402794f, -0.01394953f, -0.02894623f, 
    -0.17989740f, 0.00095030f, 0.02224717f, -0.12680331f, 0.33437446f, 0.12955678f, 0.07496238f, -0.09873298f, 
    0.04170584f, 0.06655376f, 0.20435250f, 0.00838885f, 0.10175084f, -0.01540613f, 0.05624310f, 0.00949770f, 
    -0.03696134f, 0.03004680f, -0.05073650f, -0.04174589f, -0.32338384f, -0.26722986f, 0.12732987f, 0.00729543f, 
    -0.02021109f, 0.07189202f, 0.00135788f, 0.03725170f, 0.01468606f, 0.08866369f, 0.21564849f, -0.06254321f, 
    -0.13538693f, -0.04646140f, 0.01382897f, -0.11271338f, 0.13179889f, 0.03652571f, -0.02697638f, 0.13830121f, 
    0.06113416f, 0.02270659f, 0.01343843f, 0.03854682f, -0.02292765f, -0.01925967f, -0.08758657f, -0.15387410f, 
    0.01461195f, 0.05633640f, 0.06792198f, 0.08277074f, -0.18979205f, 0.01326760f, -0.00022404f, -0.02272808f, 
    0.10506523f, -0.06062156f, -0.11613967f, 0.04968001f, -0.05366442f, -0.01984803f, 0.04362569f, -0.01036076f, 
    0.11976079f, -0.06218014f, 0.11699229f, -0.02190160f, 0.14232920f, 0.03449488f, 0.03364924f, 0.07511342f, 
    -0.05117108f, 0.03153582f, 0.04530419f, -0.08413122f, 0.05521074f, 0.15613747f, 0.16124484f, -0.05860217f, 
    0.12772836f, 0.00051567f, -0.11444227f, 0.14660183f, -0.02160149f, -0.02686991f, 0.04896482f, -0.09993377f, 
    -0.21117498f, 0.03861564f, -0.03653726f, -0.13132869f, -0.27939525f, 0.12516691f, -0.06217878f, -0.36332485f, 
    0.06790256f, 0.07573494f, 0.02846299f, 0.08698005f, 0.00357594f, 0.01196417f, -0.02673717f, -0.08921943f, 
    -0.32484046f, -0.08934645f, -0.46357223f, -0.07130013f, 0.03482272f, 0.08848897f, -0.08938458f, -0.02736320f, 
    0.10672298f, 0.02840069f, -0.01571846f, 0.00581091f, -0.12775643f, 0.02304585f, -0.02657140f, 0.01670440f, 
    0.23898542f, -0.10992256f, 0.08205102f, -0.14621291f, 0.01731972f, -0.02116827f, -0.14505187f, 0.07440697f, 
    0.07229504f, -0.10208355f, -0.01383185f, -0.01013453f, -0.01424869f, 0.00399062f, 0.07069401f, 0.04251591f, 
    -0.35291877f, -0.16686279f, -0.26068667f, -0.50852275f, -0.14228615f, -0.25891083f, -0.12722017f, 0.06644361f, 
    0.06537567f, 0.00031105f, -0.02310264f, 0.04732624f, -0.09607413f, -0.07885111f, 0.00735733f, -0.07370620f, 
    0.21832795f, -0.15913922f, 0.41222495f, -0.07981890f, 0.17556393f, -0.03703577f, 0.04300318f, -0.13650092f, 
    0.08985540f, -0.01792657f, 0.14839904f, 0.06356200f, -0.16525744f, -0.16150214f, 0.08530495f, -0.03748306f, 
    0.04938332f, -0.03493472f, 0.02835072f, 0.03829443f, -0.02899603f, 0.13180275f, -0.21475849f, -0.21641096f, 
    0.41167155f, 0.00632263f, -0.33952820f, 0.04018577f, -0.07712261f, -0.00932450f, -0.02044027f, 0.06155976f, 
    0.21392927f, -0.16736029f, -0.21838002f, -0.05606094f, 0.05214890f, 0.00431845f, 0.02816282f, -0.01785250f, 
    0.27168557f, 0.03927989f, 0.07471140f, 0.01893415f, -0.06879056f, -0.17311729f, 0.13290633f, -0.10590517f, 
    0.22303915f, 0.16609816f, 0.19755441f, -0.25507426f, 0.02485299f, -0.00218003f, 0.04093634f, 0.02203494f, 
    0.10780239f, 0.06327581f, -0.04890878f, 0.10343763f, 0.23438010f, -0.09167766f, 0.11216526f, 0.02651164f, 
    -0.06449594f, 0.15557133f, 0.11871928f, 0.04074968f, -0.03870254f, 0.04917389f, -0.01758776f, -0.03374125f, 
    -0.31201932f, -0.01212894f, 0.25652358f, 0.03081356f, -0.01684089f, -0.14827880f, 0.04344330f, -0.09212743f, 
    0.04032799f, 0.00299843f, 0.07716145f, -0.05428043f, 0.11946364f, -0.21221498f, -0.31437743f, -0.15639184f, 
    0.02050650f, 0.02790587f, 0.02797180f, 0.01709439f, -0.01295711f, -0.12248007f, -0.11033981f, -0.33393696f, 
    -0.20015360f, 0.16942087f, 0.03845216f, -0.06615145f, 0.07988396f, 0.08083173f, 0.11641164f, -0.13066234f, 
    0.03173803f, -0.00251047f, 0.06956907f, 0.03161238f, -0.10183914f, 0.03065834f, 0.11693428f, -0.33234400f, 
    -0.12742671f, -0.18042937f, 0.01827441f, 0.19483276f, -0.16181293f, 0.04012463f, -0.27615494f, -0.37835479f, 
    -0.06181489f, 0.00594049f, -0.30761239f, 0.19647506f, 0.19664608f, -0.10886467f, 0.02482379f, 0.08325743f, 
    -0.02599795f, 0.01960916f, 0.02382795f, -0.02593180f, -0.05869960f, 0.13209902f, -0.18154585f, -0.13760370f, 
    0.10518363f, 0.18697256f, 0.11265741f, 0.05979550f, 0.05597192f, -0.03662816f, 0.03465083f, 0.03826502f, 
    -0.13383971f, -0.15236637f, 0.16092247f, 0.11595012f, 0.01798855f, -0.00949499f, 0.04818176f, 0.02548375f, 
    0.03378313f, -0.03095396f, -0.26038224f, -0.22099742f, -0.44991887f, 0.07440811f, -0.11360084f, -0.01998415f, 
    0.01669745f, -0.08604221f, 0.03436613f, 0.01309976f, -0.17902948f, -0.15447602f, 0.11240044f, 0.03308767f, 
    0.08834539f, 0.01114249f, 0.04788819f, -0.00067656f, 0.21893771f, 0.01630990f, 0.01693793f, 0.12929705f, 
    -0.00948198f, 0.01145409f, 0.18123360f, 0.00650040f, 0.01325714f, -0.04817030f, -0.00190360f, -0.15142974f, 
    -0.07524879f, -0.08144456f, 0.01321453f, -0.10835879f, 0.08295060f, -0.23825233f, -0.13534644f, 0.07615843f, 
    0.00029346f, -0.04079202f, 0.27531144f, -0.20661056f, 0.14843123f, -0.12514409f, -0.06715338f, 0.19852598f, 
    -0.12098962f, 0.06556848f, 0.07349894f, 0.04595711f, -0.24444896f, 0.01860675f, -0.09141280f, -0.35842428f, 
    -0.04488699f, -0.04759173f, 0.06524800f, 0.09059430f, -0.06614591f, -0.23666707f, -0.04026062f, -0.40378726f, 
    0.37503636f, 0.18660417f, -0.15026996f, -0.12731451f, 0.09059364f, -0.05221237f, -0.02265543f, 0.06626111f, 
    0.00365207f, 0.00504878f, -0.01516421f, 0.02735459f, -0.11093821f, -0.01899230f, -0.12931630f, 0.17403246f, 
    0.04859990f, -0.04218194f, -0.06321106f, -0.04702088f, 0.02152281f, -0.11381056f, 0.25176600f, 0.13455079f, 
    -0.15787104f, -0.07085144f, -0.13118109f, -0.03204175f, -0.01877167f, 0.11759395f, -0.04580044f, 0.00624571f, 
    0.03023189f, 0.04153503f, -0.11090410f, -0.13807401f, -0.21995515f, 0.23524499f, -0.22471544f, 0.19909875f, 
    0.16514006f, -0.01448436f, -0.01542506f, 0.04214329f, 0.03298358f, 0.06882779f, 0.06327517f, 0.06388412f, 
    0.05057745f, 0.25261143f, 0.21294498f, -0.23738737f, -0.19411249f, 0.04924185f, -0.11049201f, 0.11851022f, 
    0.08122019f, 0.00173525f, 0.00487673f, -0.02831290f, 0.11943112f, -0.00736682f, -0.30435479f, -0.39102766f, 
    -0.08427433f, 0.09318446f, -0.03420247f, -0.03789554f, 0.14687954f, -0.19979101f, -0.01795465f, -0.01660884f, 
    0.00694195f, -0.00919673f, -0.04535087f, -0.01148301f, -0.05124380f, -0.07871822f, 0.13712001f, 0.16252990f, 
    0.04971934f, -0.00821957f, -0.07050396f, 0.07103372f, -0.01101339f, 0.06830428f, 0.08809071f, -0.10042951f, 
    0.28901070f, 0.12989959f, 0.18569019f, 0.02665882f, 0.00306627f, 0.03382260f, 0.06870688f, 0.05369361f, 
    -0.12250578f, -0.37953228f, -0.21559311f, 0.11527047f, 0.01518580f, -0.03474133f, 0.03113875f, -0.07188423f, 
    0.03080191f, 0.03648797f, -0.03072285f, 0.07079756f, -0.15791416f, -0.16566321f, -0.13531289f, -0.09554411f, 
    0.19435364f, -0.09586484f, -0.01141527f, -0.00325525f, -0.08660138f, -0.00984000f, -0.03838643f, 0.25258860f, 
    0.35738727f, -0.00661264f, 0.02154165f, 0.03554282f, -0.04326141f, 0.03072109f, 0.09572898f, -0.06530026f, 
    0.00372466f, -0.07525398f, -0.06813263f, -0.03058315f, 0.05644600f, 0.12407868f, 0.26749593f, -0.07727519f, 
    0.15568557f, 0.01308911f, -0.14208108f, -0.15907149f, 0.05981366f, 0.00407400f, 0.03376451f, -0.00180311f, 
    -0.11005307f, 0.23661450f, 0.12020954f, -0.05810059f, -0.21789318f, 0.08480125f, 0.03567707f, 0.06488494f, 
    0.02406289f, -0.00464654f, -0.00005724f, 0.09929974f, -0.02425157f, -0.10708557f, -0.06902203f, 0.10721292f, 
    0.03544070f, 0.01786495f, 0.16153525f, 0.13823795f, -0.01130622f, 0.16076468f, 0.02318650f, -0.00747376f, 
    -0.21805125f, 0.13362320f, -0.40587479f, 0.02355739f, 0.25282550f, -0.06351379f, -0.02618629f, 0.10522790f, 
    0.06018967f, -0.14229868f, 0.17317654f, 0.23453592f, 0.03759957f, -0.07533643f, -0.21311677f, 0.08878774f, 
    0.08860195f, -0.27458274f, -0.03379750f, 0.07998621f, 0.06049306f, 0.07988741f, 0.14403929f, 0.16265334f, 
    0.10363221f, 0.11235397f, -0.17594443f, -0.17363785f, -0.13161448f, 0.09261755f, -0.03805390f, 0.01190144f, 
    -0.07138117f, 0.04547762f, -0.07323452f, -0.03238653f, -0.62124848f, -0.38250908f, 0.32367629f, 0.24210307f, 
    0.12916963f, -0.06097870f, -0.02184925f, 0.06521320f, 0.00253378f, 0.06942791f, -0.02464407f, -0.03612119f, 
    0.11084761f, -0.15799218f, -0.01659706f, -0.11918153f, -0.15983872f, 0.06938557f, -0.07229008f, -0.03498963f, 
    0.19572562f, -0.00187762f, 0.07300064f, 0.24479796f, -0.00967146f, -0.06076840f, 0.00654347f, -0.05001569f, 
    0.01517912f, 0.00740203f, -0.17663358f, -0.06696287f, 0.04545022f, 0.11263591f, 0.13639645f, 0.02331208f, 
    -0.11221105f, -0.10009561f, 0.06023395f, -0.04394215f, 0.00711848f, -0.12869610f, -0.07635088f, 0.09111878f, 
    -0.00728294f, -0.05264258f, -0.00146558f, -0.12800641f, 0.10972158f, -0.00623241f, -0.05758011f, 0.14085698f, 
    0.01767128f, -0.09049908f, 0.10402662f, 0.11079776f, 0.07368866f, -0.01062769f, 0.25334996f, -0.02357846f, 
    0.17374910f, 0.21035379f, -0.14333846f, 0.16741672f, -0.01769313f, -0.05690882f, 0.09865559f, 0.23402314f, 
    -0.05317055f, 0.03225611f, 0.18340021f, -0.07221712f, -0.29118767f, 0.12386647f, -0.07734261f, -0.22988205f, 
    0.07790978f, -0.04056418f, 0.10588428f, -0.12935625f, 0.05325766f, -0.03505056f, 0.03234796f, 0.15880850f, 
    0.02304178f, -0.17942375f, -0.11969604f, 0.17896932f, -0.10898536f, 0.15937178f, 0.21719187f, 0.10793339f, 
    0.12982014f, -0.06189116f, 0.14382413f, -0.01125411f, -0.03161173f, -0.14404894f, -0.12927368f, 0.09268098f, 
    0.01597694f, 0.08443122f, 0.06640796f, -0.03249694f, -0.06990949f, -0.09197528f, -0.09893943f, -0.04604699f, 
    -0.28553584f, -0.27456099f, -0.42632318f, 0.30000317f, 0.02361410f, 0.12798192f, -0.05026969f, -0.19105846f, 
    -0.00158461f, -0.02604898f, 0.03225999f, -0.02307492f, -0.05866498f, -0.03742290f, 0.08508161f, -0.06202138f, 
    0.01490418f, -0.01150474f, 0.05374758f, 0.00524708f, 0.03625770f, -0.09816831f, 0.08375983f, 0.09940641f, 
    -0.12538810f, -0.14426987f, -0.53576791f, 0.01198679f, -0.21476378f, 0.06897285f, 0.22507180f, 0.17864466f, 
    0.04542079f, 0.03315654f, 0.02471323f, -0.02574979f, -0.20477776f, 0.05962555f, 0.19144090f, 0.03661861f, 
    0.00150530f, -0.00601929f, -0.03635193f, -0.02034301f, -0.12781250f, 0.17013520f, -0.03648787f, 0.09786636f, 
    -0.12050522f, 0.04502363f, 0.09281369f, 0.10155418f, 0.01104298f, 0.01445443f, 0.11319260f, -0.03662237f, 
    -0.01908737f, 0.06011589f, -0.01138477f, 0.17095615f, -0.57868052f, -0.60855192f, -0.05596316f, -0.06046131f, 
    -0.24387366f, -0.06914191f, -0.21068680f, -0.17793806f, -0.03568759f, -0.05404127f, -0.05859871f, -0.02586959f, 
    0.05208827f, -0.04712732f, -0.01166313f, 0.02578145f, 0.00946942f, 0.03342866f, 0.11664548f, 0.03511565f, 
    0.02651451f, -0.05686835f, 0.15656492f, -0.03629003f, -0.20236880f, 0.02984793f, 0.04184688f, 0.12756033f, 
    -0.02969170f, -0.00041773f, -0.10557161f, 0.09651488f, 0.00704796f, -0.03867669f, 0.06031631f, -0.01378775f, 
    -0.41479722f, 0.24729422f, 0.30326805f, -0.06672659f, -0.05257148f, -0.04432193f, -0.17270610f, 0.01211881f, 
    -0.09028030f, 0.10240692f, 0.06076967f, -0.02413267f, -0.11606297f, 0.02535039f, 0.26358831f, 0.14592537f, 
    -0.01968770f, -0.01061322f, -0.27985942f, 0.07166003f, -0.02927668f, -0.09109478f, 0.04597750f, 0.02802830f, 
    -0.46899897f, -0.40700135f, -0.07227960f, -0.11170059f, -0.15818736f, -0.34734699f, -0.14306778f, -0.33049199f, 
    -0.03592714f, -0.00656851f, -0.02114723f, 0.00283502f, 0.21232218f, 0.24410519f, 0.14196883f, 0.01258157f, 
    0.00241050f, -0.11201205f, -0.08112366f, -0.07160502f, -0.01952993f, 0.05486904f, -0.00583461f, 0.11497249f, 
    -0.33240429f, -0.05451238f, 0.13290486f, -0.03696215f, 0.06804515f, -0.02859253f, -0.02001537f, -0.03293680f, 
    -0.00226234f, -0.03263480f, -0.08552879f, -0.05653745f, 0.02238306f, 0.10589716f, 0.38805148f, -0.39652440f, 
    0.04928725f, -0.02125212f, -0.17431420f, 0.03394268f, -0.04451662f, 0.07046705f, -0.04951321f, 0.01626428f, 
    0.42717946f, 0.17762384f, -0.24946535f, -0.17154814f, -0.07037073f, 0.00952880f, -0.01238533f, 0.10986620f, 
    0.08788064f, -0.06279641f, 0.05453144f, 0.06966101f, -0.30912662f, 0.12322427f, 0.27282760f, 0.06804807f, 
    -0.09109151f, -0.02471922f, 0.03563119f, 0.06356506f, -0.03231727f, 0.11125825f, 0.06599475f, -0.05859985f, 
    -0.86831647f, 0.07900110f, 0.67447782f, 0.11461232f, -0.04852891f, -0.03184925f, -0.02329074f, -0.13518363f, 
    -0.01788759f, 0.05551801f, -0.00198034f, 0.09980159f, 0.04104504f, -0.13256675f, -0.25286895f, 0.04503147f, 
    0.17908466f, 0.01203805f, 0.19219674f, -0.09728697f, 0.05128997f, -0.09635504f, -0.05518297f, 0.01984381f, 
    0.08667025f, 0.01540587f, -0.00951267f, 0.07881643f, -0.03014733f, 0.02948577f, 0.02368421f, 0.05496400f, 
    0.11919639f, 0.16209809f, 0.08166256f, 0.06428358f, -0.15763062f, 0.06705406f, 0.08098058f, 0.00852704f, 
    0.00962491f, 0.04310820f, 0.09440824f, -0.05111727f, 0.01777314f, 0.08251440f, 0.06566031f, -0.17624058f, 
    -0.54896468f, -0.55980694f, -0.44523409f, -0.06734325f, -0.23249395f, -0.13268164f, -0.02387093f, -0.10878468f, 
    -0.09577054f, 0.07458328f, -0.03837708f, -0.02241444f, 0.08098467f, 0.07373199f, 0.00037459f, -0.02169283f, 
    -0.02950221f, 0.06355313f, 0.03383493f, 0.10793965f, 0.04334094f, 0.06246314f, 0.13361835f, -0.00414332f, 
    0.69543409f, 0.09797948f, -0.43756932f, -0.06567253f, 0.01255985f, -0.07838942f, 0.17360562f, 0.11164469f, 
    0.04286671f, 0.17400028f, 0.00717666f, -0.24927254f, 0.14428420f, -0.12801111f, -0.03420372f, -0.23841794f, 
    0.14013453f, -0.02496864f, 0.03398501f, -0.16036537f, 0.06885468f, -0.03967068f, 0.07281904f, 0.00722956f, 
    -0.65747434f, -0.81585741f, -0.51972169f, -0.11309643f, 0.04477305f, -0.09080295f, -0.07759129f, -0.07565004f, 
    0.03749131f, 0.02593418f, 0.01276344f, 0.01431009f, -0.37139851f, -0.52141720f, -0.18742411f, 0.10069619f, 
    -0.03200884f, -0.06967969f, -0.06611717f, -0.20385902f, 0.01276741f, -0.04228408f, -0.08932754f, -0.03335318f, 
    -0.03726746f, -0.25465858f, -0.48202893f, -0.11890002f, 0.00314185f, -0.03112252f, 0.07415200f, -0.11129384f, 
    -0.03241386f, -0.01013131f, 0.11092775f, 0.04755555f, 0.05293042f, 0.27837884f, 0.09025967f, 0.02539681f, 
    -0.03335411f, 0.02748734f, -0.03248038f, 0.04246151f, 0.12943953f, 0.11677068f, 0.08588376f, 0.15408966f, 
    -0.60266161f, -0.63421381f, -0.13795879f, -0.18505681f, -0.25911787f, -0.27984226f, 0.08280341f, -0.32974336f, 
    -0.03171371f, 0.02105597f, 0.00652006f, -0.05801288f, -0.06873265f, -0.10980505f, 0.01983066f, 0.22513923f, 
    0.06149635f, 0.10615480f, 0.13028187f, -0.08030666f, 0.11537283f, 0.13486904f, 0.16918479f, 0.01421586f, 
    0.06784397f, -0.17966029f, -0.25310832f, -0.27903295f, -0.06770904f, 0.04301815f, 0.17364958f, -0.22598603f, 
    0.06313760f, -0.01613407f, 0.03673632f, 0.09461322f, -0.09660432f, -0.09979281f, 0.06420837f, -0.09899647f, 
    0.08986769f, 0.02493219f, 0.09794758f, -0.05696972f, 0.01307403f, 0.00394916f, -0.00247373f, 0.06403226f, 
    -0.05348568f, -0.27824017f, -0.35025391f, 0.06771228f, -0.04610647f, 0.03462482f, 0.04465577f, 0.07280849f, 
    0.03825084f, 0.06771230f, 0.07919109f, 0.05537507f, -0.12423815f, -0.00312893f, 0.15126030f, 0.03798139f, 
    0.07455444f, -0.01371957f, 0.08643656f, -0.05387430f, 0.08537221f, 0.20777266f, -0.05056531f, -0.22860718f, 
    0.18600327f, -0.22056203f, -0.19852380f, 0.10215339f, -0.15137549f, 0.08770790f, 0.05502845f, 0.02973747f, 
    0.10221633f, -0.03035858f, -0.00419884f, -0.02293940f, -0.45968366f, 0.12593256f, -0.09566652f, -0.21029921f, 
    -0.04322537f, 0.08929553f, 0.01716570f, 0.14801016f, 0.06627274f, 0.07599346f, 0.11879627f, 0.14731935f, 
    -0.05457891f, -0.11077683f, 0.02418972f, 0.30579782f, -0.09814270f, 0.10498682f, 0.10621230f, 0.06315786f, 
    0.08946258f, 0.03426423f, 0.06517567f, 0.04460561f, -0.12248437f, 0.20434947f, -0.03775583f, 0.00036380f, 
    0.00514905f, -0.01280164f, 0.05588890f, 0.03671296f, 0.13478792f, 0.08394679f, 0.16337280f, 0.06116225f, 
    -0.02149996f, -0.25548768f, -0.47340167f, -0.17748052f, -0.09725253f, 0.07489046f, 0.06226920f, 0.13777398f, 
    -0.02371341f, 0.00396481f, -0.02035614f, 0.00707047f, -0.01491486f, -0.10339603f, -0.06431370f, -0.09066404f, 
    -0.04241165f, -0.08585902f, -0.03566871f, 0.03070797f, -0.03480390f, -0.02003917f, -0.15732583f, -0.22265609f, 
    0.14394532f, 0.32650527f, 0.15089671f, 0.01568320f, 0.06924207f, -0.00650288f, 0.10595062f, 0.03926854f, 
    0.07681912f, -0.08332330f, 0.00722285f, 0.08721634f, -0.53225344f, -0.19615428f, 0.10513614f, -0.42188939f, 
    -0.03762360f, 0.18354954f, 0.06643420f, 0.05403415f, 0.01334404f, 0.00931466f, 0.02066578f, 0.05901554f, 
    -0.69433761f, -0.76512051f, -0.04206294f, 0.41521895f, 0.07607882f, -0.18038596f, -0.11046325f, -0.36030892f, 
    0.02867483f, 0.05024768f, 0.06396454f, -0.03267159f, 0.20441878f, -0.00798939f, -0.04237942f, -0.26344171f, 
    0.00864421f, -0.12334202f, 0.07599863f, 0.01530936f, 0.04552931f, 0.18828407f, -0.01268907f, -0.19961160f, 
    -0.00555673f, -0.05422508f, -0.03822761f, 0.11081859f, -0.01234927f, 0.00160666f, 0.11523593f, 0.00853877f, 
    0.01789066f, -0.10285926f, -0.01854478f, 0.00836068f, -0.41407984f, -0.38109729f, -0.44960630f, -0.25718933f, 
    -0.08449761f, -0.12917629f, -0.18461996f, -0.38061473f, -0.00980701f, 0.01846291f, -0.05603176f, 0.02052498f, 
    -0.19579205f, -0.03615439f, -0.06592432f, -0.09376784f, 0.06169335f, -0.00349878f, 0.04617900f, -0.08737683f, 
    -0.04111274f, 0.00563790f, -0.07000453f, 0.01541613f, -0.02297787f, 0.08347052f, 0.03290840f, 0.32053056f, 
    0.10711115f, -0.10345114f, 0.22794092f, 0.09630969f, 0.06877169f, -0.02452473f, -0.04306282f, 0.07257747f, 
    -0.49159345f, -0.14879432f, 0.07274295f, 0.24152245f, 0.08584677f, 0.13056277f, -0.05568792f, -0.14992961f, 
    -0.00456905f, -0.10432996f, -0.06181835f, 0.05711775f, -0.46344721f, -0.63607365f, -0.50252342f, -0.09032813f, 
    -0.11355762f, 0.08250766f, -0.16005951f, -0.35103059f, -0.04477658f, 0.00804433f, -0.06388673f, 0.04892590f, 
    -0.00421326f, -0.07601688f, -0.11092726f, -0.02952724f, -0.15138444f, -0.13722341f, -0.00493263f, 0.22225118f, 
    -0.03104131f, -0.04083807f, 0.05554646f, -0.08717337f, 0.07420509f, 0.03499657f, 0.03440895f, 0.14952032f, 
    0.12876286f, 0.08086337f, 0.05229998f, 0.00617030f, 0.02873266f, -0.06754319f, -0.09282494f, 0.01605612f, 
    0.09489827f, -0.06545626f, 0.17243308f, -0.20486976f, 0.05949718f, -0.04998381f, 0.19001220f, -0.14954279f, 
    0.04857245f, -0.01391839f, 0.06625853f, -0.06799925f, 0.33047274f, 0.22900364f, -0.09736245f, -0.10942940f, 
    0.04841641f, -0.06365457f, 0.06687503f, -0.08774169f, 0.14749287f, -0.11186811f, -0.01852576f, -0.03275477f, 
    -0.19829796f, 0.03500915f, -0.03487893f, 0.04856244f, 0.13519092f, -0.01016447f, -0.06977390f, 0.02585103f, 
    0.02930873f, 0.02869091f, -0.05222576f, 0.05159518f, 0.01924339f, -0.09638482f, -0.40765131f, 0.03830421f, 
    -0.08195089f, 0.12397579f, 0.06202220f, 0.07715856f, -0.09406278f, 0.03665750f, 0.03612370f, -0.06506101f, 
    -0.15170558f, 0.17157666f, 0.14087437f, 0.03014190f, 0.03368218f, -0.14114869f, 0.14791189f, 0.02230835f, 
    0.01647223f, 0.00011029f, -0.28934622f, 0.22532396f, -0.03157956f, 0.14806013f, -0.03976016f, -0.14484276f, 
    0.02739865f, -0.02971144f, -0.07562727f, 0.03231691f, 0.04556454f, 0.04366860f, -0.07520440f, 0.05275630f, 
    -0.05996982f, 0.13385393f, 0.08547814f, -0.01159608f, -0.07344285f, -0.03252865f, 0.09673475f, 0.08675280f, 
    0.05371191f, 0.00633080f, -0.00613980f, -0.02516864f, 0.21278334f, 0.04341731f, -0.08659336f, -0.07572321f, 
    0.09861811f, 0.09971616f, -0.05207346f, -0.12639366f, -0.09496416f, 0.06211622f, -0.15532765f, -0.10101271f, 
    0.02208754f, -0.67650932f, 0.09210676f, -0.12059598f, -0.05562032f, -0.00154211f, 0.02349138f, -0.21298184f, 
    -0.06975342f, -0.02916285f, 0.03168675f, -0.04715469f, 0.11515608f, -0.05934989f, -0.00774726f, -0.05443752f, 
    0.00206091f, 0.00575458f, 0.07759022f, -0.05431480f, -0.05477738f, 0.03850288f, 0.02540246f, -0.00806913f, 
    0.05511961f, -0.17896564f, -0.02542315f, 0.04105154f, -0.03833265f, 0.11175836f, 0.09310309f, -0.05844285f, 
    0.03544316f, 0.02039087f, 0.06438383f, 0.14307080f, -0.04151886f, 0.02279453f, 0.01363408f, -0.07580543f, 
    -0.02767594f, -0.00985995f, -0.02109769f, -0.00032321f, 0.06926621f, -0.00485440f, -0.01589868f, -0.04421053f, 
    -0.04326566f, -0.47573856f, -0.03322699f, 0.18101674f, -0.01222788f, 0.03459076f, -0.05452429f, -0.04121792f, 
    0.02949475f, 0.00620020f, 0.04334670f, -0.01042756f, 0.19234976f, 0.12236688f, -0.14642717f, -0.07805090f, 
    -0.01071925f, -0.06915222f, 0.09832056f, -0.07849202f, -0.00271385f, 0.04183583f, -0.19980691f, -0.23075959f, 
    -0.48935854f, -0.24579637f, -0.29220271f, -0.19898193f, -0.05283576f, -0.02792766f, 0.10185448f, -0.02655970f, 
    0.01058649f, 0.04893284f, -0.08673523f, -0.03519243f, 0.25727654f, 0.07658134f, -0.16746196f, -0.18144019f, 
    -0.08366895f, 0.00555728f, -0.03792684f, 0.01266225f, -0.02679043f, 0.01313833f, 0.00393862f, -0.00386511f, 
    0.23109694f, -0.05233046f, 0.08094438f, -0.29329225f, -0.12286068f, 0.11603902f, -0.06317601f, -0.02509268f, 
    -0.15177648f, 0.13225707f, 0.05540207f, 0.06003992f, -0.36177078f, -0.11032794f, -0.26734909f, -0.13229275f, 
    0.08065680f, -0.12963524f, 0.09102726f, 0.02066094f, 0.01916867f, -0.01926559f, 0.01565548f, -0.00273612f, 
    0.10075006f, 0.07027448f, 0.05771975f, 0.01298819f, 0.07356361f, -0.08904079f, -0.03008029f, -0.03829048f, 
    -0.06307378f, 0.04451289f, 0.04343116f, -0.00003967f, 0.31254038f, 0.03991756f, -0.07987078f, -0.12590975f, 
    -0.04888344f, -0.11003684f, 0.08980808f, 0.05396732f, -0.02957734f, -0.00886623f, -0.01490880f, -0.01973405f, 
    0.16627653f, -0.35495111f, -0.09539910f, 0.06727336f, 0.00259505f, -0.06809998f, 0.06073250f, -0.03652116f, 
    -0.03393244f, -0.10985089f, 0.01662482f, 0.02086534f, 0.20513009f, -0.03760355f, -0.01202015f, -0.17244481f, 
    -0.11004151f, 0.00821470f, -0.04573843f, 0.06107928f, -0.03376627f, -0.02327057f, 0.02177778f, 0.02412910f, 
    0.43711698f, -0.55611569f, -0.27304599f, -0.24399759f, -0.04391531f, -0.11163097f, -0.04610217f, 0.06075237f, 
    0.02202880f, 0.10435838f, 0.04371726f, 0.01320796f, -0.09554848f, -0.18178816f, -0.10970126f, -0.09467424f, 
    0.05684863f, 0.06710750f, 0.02434047f, 0.05386555f, 0.03204206f, -0.02225657f, -0.00241518f, 0.01524619f, 
    0.04808255f, 0.20106710f, 0.01423676f, -0.01403717f, 0.03772104f, -0.01266387f, -0.00899465f, -0.02453322f, 
    -0.00487749f, 0.02761433f, -0.06139958f, -0.10259061f, -0.17395528f, 0.09476625f, -0.40887067f, 0.33828121f, 
    0.10477152f, -0.04375510f, -0.02246242f, -0.01385849f, -0.08229131f, -0.05646155f, 0.01908283f, -0.00417418f, 
    -0.24004118f, -0.10186516f, -0.26410171f, 0.09945752f, 0.05820721f, 0.00259534f, 0.10254013f, 0.07152364f, 
    0.14675406f, 0.04372026f, 0.07880726f, -0.06686831f, 0.02100816f, -0.25462469f, -0.06806523f, 0.00426043f, 
    -0.13203691f, -0.01548318f, -0.00675992f, 0.00818931f, 0.09749008f, -0.02281130f, 0.04503806f, -0.01247018f, 
    0.33432248f, -0.56816775f, -0.41664407f, -0.53376508f, -0.01555638f, -0.22367458f, -0.09653278f, 0.11778829f, 
    0.04097009f, 0.03226607f, 0.02774634f, -0.00847108f, -0.07476005f, -0.04036944f, 0.01571340f, -0.05514235f, 
    -0.02762834f, -0.07121348f, 0.08483308f, 0.06015767f, 0.04558267f, 0.05782760f, -0.04760259f, -0.01762662f, 
    0.02752089f, 0.10930824f, -0.00069737f, 0.09597676f, 0.03822167f, -0.03260553f, -0.04360128f, -0.00010151f, 
    -0.09714710f, -0.03997417f, -0.05960895f, 0.07618155f, 0.17879389f, -0.06791939f, 0.06384829f, -0.18749699f, 
    -0.03300069f, -0.08034624f, 0.00930290f, 0.01926998f, -0.01382499f, 0.11771586f, 0.00365075f, -0.16247796f, 
    0.44016701f, -0.51421666f, 0.22980323f, 0.14696366f, 0.04948757f, 0.20175311f, -0.02211179f, -0.01861477f, 
    -0.04225270f, -0.04339944f, -0.04528717f, -0.02923833f, 0.09966268f, -0.05931728f, 0.06486886f, -0.06199794f, 
    -0.03012730f, -0.00197700f, -0.11863169f, -0.07680344f, -0.04842073f, -0.13596447f, -0.13924909f, -0.13730466f, 
    -0.43048769f, -0.15745041f, 0.08255634f, 0.12880190f, -0.07550749f, 0.00147112f, -0.00254039f, 0.05628429f, 
    -0.03435597f, 0.10289929f, 0.06174891f, -0.03282321f, -0.03787149f, -0.00874189f, 0.17756374f, -0.05588336f, 
    -0.14624041f, 0.06417540f, -0.03549619f, -0.03245460f, 0.02241845f, -0.05024404f, 0.03078174f, -0.01358062f, 
    -0.37575951f, -0.20564610f, 0.51851374f, 0.18270712f, -0.04054010f, -0.00815546f, -0.09840874f, 0.05447967f, 
    -0.05484614f, -0.05747667f, -0.02263425f, -0.04172053f, -0.12428380f, -0.27092612f, 0.14738469f, 0.22859651f, 
    -0.02224874f, -0.09667857f, -0.02404777f, 0.00283316f, 0.01062649f, 0.04153618f, 0.08036245f, 0.07040068f, 
    0.47259891f, -0.53616995f, 0.01364142f, -0.45452914f, -0.04859238f, 0.11026956f, -0.14249247f, 0.21988562f, 
    0.04021270f, -0.02593715f, -0.04387166f, -0.02724049f, 0.17274220f, -0.20581132f, 0.07332373f, -0.03897071f, 
    -0.02749015f, 0.04372806f, 0.01278745f, 0.00261037f, 0.13845681f, 0.06458983f, 0.05231518f, 0.01122273f, 
    -0.03894673f, -0.21293040f, -0.11441514f, -0.20818588f, 0.02863424f, 0.00168712f, -0.02360201f, 0.22652973f, 
    0.04787942f, -0.02098941f, -0.03980307f, 0.00233760f, -0.01370534f, -0.22522227f, 0.24032731f, 0.07156576f, 
    0.03207096f, -0.22991632f, 0.13718593f, 0.06109719f, -0.14689443f, -0.09106561f, 0.06491367f, -0.12793101f, 
    -0.07160525f, 0.29534104f, -0.18633096f, 0.00633896f, 0.09122491f, -0.16187826f, 0.03319875f, 0.07708287f, 
    -0.04416757f, 0.06714574f, 0.01931449f, 0.08135413f, -0.40279958f, 0.18828806f, 0.07584205f, -0.12690100f, 
    -0.06566417f, -0.10620058f, -0.04631056f, 0.02039246f, -0.01532615f, -0.04605218f, 0.04325560f, -0.03767177f, 
    0.17039803f, -0.42438671f, 0.01782276f, -0.05073018f, -0.08366761f, -0.07213051f, -0.10190054f, 0.11933275f, 
    0.06530629f, -0.00691590f, 0.00929583f, 0.09758510f, 0.36391753f, 0.11435260f, -0.07367154f, -0.13321063f, 
    -0.02180713f, -0.07900012f, -0.17698400f, -0.12061217f, 0.02124485f, -0.15948577f, -0.07653555f, -0.06250599f, 
    -0.28302863f, -0.20258409f, -0.02335953f, 0.29504734f, 0.01316498f, 0.02827885f, -0.05509982f, -0.09230801f, 
    -0.04170676f, -0.01531618f, 0.05806953f, -0.00026762f, 0.18641907f, -0.36274123f, -0.25396141f, -0.30512834f, 
    -0.06417456f, -0.09168502f, 0.09596052f, 0.03724008f, 0.15187755f, -0.02511859f, 0.03154489f, -0.02190324f, 
    0.08255228f, -0.37715858f, -0.02983580f, -0.23657085f, 0.05927201f, 0.03118367f, -0.01970016f, -0.07522133f, 
    -0.01107291f, 0.00395906f, 0.01200822f, -0.03241343f, -0.24793600f, -0.10239448f, -0.16437541f, 0.22289206f, 
    0.03051666f, -0.11668988f, 0.15501624f, -0.06731878f, 0.04359518f, 0.06397284f, 0.15153126f, -0.04372264f, 
    -0.02271389f, 0.00553272f, 0.05398406f, -0.15131183f, 0.08758501f, -0.00195586f, -0.03248464f, -0.11519635f, 
    0.06678608f, 0.05147006f, 0.06715144f, 0.01634831f, 0.07370941f, 0.04995670f, 0.01064565f, -0.03242202f, 
    0.02278859f, -0.05941331f, 0.04136961f, -0.04794262f, -0.03591551f, -0.05400988f, 0.00780737f, -0.04723012f, 
    -0.06866840f, 0.05179439f, 0.16517350f, -0.04498797f, -0.07278536f, 0.00046526f, 0.15282656f, -0.08649465f, 
    -0.06708872f, -0.01086455f, -0.01474632f, 0.02800914f, -0.47479621f, 0.63864058f, -0.35650438f, 0.23403242f, 
    0.08093017f, 0.15785973f, -0.00711880f, 0.02525677f, -0.01488134f, -0.00349813f, 0.03941348f, -0.01631107f, 
    -0.21537913f, -0.26666376f, 0.52840805f, -0.23488525f, -0.02250974f, 0.04047549f, 0.08123487f, 0.16475655f, 
    -0.12723961f, -0.00887534f, -0.04593635f, 0.01380762f, -0.05286456f, 0.08779905f, 0.16259152f, 0.06341038f, 
    -0.05533070f, 0.13757940f, 0.03741819f, 0.05220784f, 0.07172519f, -0.11559481f, 0.06817967f, -0.10078713f, 
    0.03873447f, -0.02786571f, 0.05111340f, -0.07681250f, -0.05978915f, -0.07186887f, -0.03615540f, -0.00782730f, 
    0.01745871f, 0.01809725f, -0.00530830f, 0.04796953f, -0.28779212f, -0.23718657f, -0.18220574f, 0.08577555f, 
    0.19646804f, 0.08261834f, 0.10087942f, 0.12683792f, 0.00754490f, -0.00445944f, -0.03553512f, 0.02511553f, 
    0.04105715f, 0.09667093f, 0.05471149f, -0.01233105f, 0.03926350f, 0.04214793f, 0.05852361f, 0.00162504f, 
    -0.05237915f, 0.03285056f, 0.04412525f, -0.02637596f, 0.12381265f, -0.17580988f, -0.05338044f, -0.09894349f, 
    -0.03010304f, 0.21571302f, 0.05025748f, 0.01447134f, -0.01877744f, -0.01270680f, -0.01751993f, 0.02140379f, 
    -0.04841908f, 0.02222831f, 0.09970109f, -0.01290893f, 0.13482167f, 0.12125980f, 0.09300084f, 0.10982199f, 
    0.03462004f, 0.03489557f, 0.04049286f, 0.00485012f, -0.20430504f, -0.32587507f, 0.11460909f, 0.31381798f, 
    0.05460924f, 0.07037006f, 0.01777273f, 0.12494581f, -0.01630891f, -0.09357642f, -0.08541959f, 0.02114595f, 
    0.02215944f, 0.00539660f, -0.03542812f, 0.05967058f, -0.01236954f, -0.11971822f, 0.08874235f, -0.06928775f, 
    -0.00339219f, -0.00521440f, -0.03975247f, -0.05600459f, -0.05077254f, -0.05607609f, 0.02746313f, 0.01800912f, 
    -0.13391893f, -0.09735647f, -0.01679583f, -0.17125569f, 0.01255564f, -0.03332768f, 0.04806686f, -0.03241913f, 
    -0.10877175f, 0.21786441f, 0.02525438f, 0.09626581f, -0.07448646f, -0.00862982f, 0.06860401f, -0.03777665f, 
    -0.00860959f, 0.00022114f, 0.02338263f, -0.02117452f, -0.07367555f, 0.12340862f, -0.00603028f, -0.04435703f, 
    0.04136568f, -0.11324841f, -0.02250142f, -0.09965455f, -0.03122932f, 0.04030273f, 0.08119022f, -0.00550424f, 
    0.11915228f, 0.08386846f, -0.00396677f, 0.00580800f, -0.05503024f, -0.06335218f, 0.05179267f, -0.01148207f, 
    0.01456580f, 0.03289517f, 0.03557774f, -0.01321924f, 0.19039266f, -0.09627314f, -0.08462222f, -0.05946275f, 
    -0.05564055f, -0.01089963f, -0.06877521f, -0.09323227f, -0.06999367f, 0.00052806f, 0.03039124f, 0.00830593f, 
    0.17434724f, -0.11381069f, 0.21516739f, -0.24508518f, -0.08038740f, 0.05443715f, 0.09777921f, 0.06308997f, 
    -0.01206376f, -0.17201281f, 0.05686400f, -0.15627858f, -0.00613135f, -0.01201962f, 0.03289028f, -0.02902345f, 
    -0.00134385f, -0.00662721f, 0.02008954f, -0.01530914f, -0.02326384f, -0.07921703f, -0.12108650f, -0.05614681f, 
    -0.09464902f, -0.00795406f, -0.09342162f, -0.06703340f, -0.04066165f, -0.10811204f, -0.04367096f, -0.05813344f, 
    0.07188321f, 0.14551941f, 0.06669337f, 0.05578929f, 0.29704720f, 0.05838231f, 0.01962479f, -0.13852014f, 
    0.23763943f, -0.19901657f, -0.03363474f, -0.01846569f, 0.16298985f, -0.05078486f, 0.14635108f, 0.06492174f, 
    0.85461992f, 0.26812190f, -0.05361585f, -0.16193178f, 0.04360127f, -0.00775085f, 0.02368038f, -0.01830280f, 
    0.15081009f, 0.03855632f, -0.00041560f, 0.12744197f, 0.06716157f, 0.06767964f, 0.16392328f, 0.02627570f, 
    -0.08074421f, -0.08461399f, -0.05484597f, -0.07354279f, -0.08758017f, -0.08964784f, -0.00123830f, -0.11344496f, 
    0.03048714f, -0.06070537f, 0.11593893f, -0.08913675f, 0.23329683f, 0.08124348f, -0.00773704f, 0.13466394f, 
    -0.23033346f, 0.00042229f, -0.09509612f, -0.14548466f, 0.03351305f, 0.09655289f, 0.00385047f, -0.02321510f, 
    -0.09401876f, -0.01532056f, 0.05106717f, -0.01595437f, 0.04670621f, 0.02300372f, 0.00155576f, 0.03002950f, 
    0.07519539f, 0.08454157f, 0.00614346f, 0.13611510f, 0.19235286f, 0.04709980f, -0.04962676f, 0.00439436f, 
    -0.09086575f, -0.00853095f, 0.03886106f, 0.10660783f, 0.03975247f, 0.07298121f, -0.22211221f, -0.23852505f, 
    -0.10656780f, -0.00030087f, 0.01705975f, 0.04972397f, 0.08544166f, 0.06762214f, 0.11744744f, 0.15143934f, 
    0.21905494f, -0.36851940f, -0.27888775f, 0.14413488f, -0.03352164f, 0.08207762f, 0.14680742f, 0.06090498f, 
    -0.00543508f, -0.10799136f, -0.02521907f, -0.05604122f, -0.02550619f, -0.08882192f, -0.07185105f, 0.01687513f, 
    -0.07473498f, 0.05491427f, 0.13876373f, 0.03370497f, 0.07692315f, -0.01527071f, 0.16758719f, 0.06992782f, 
    0.13861151f, -0.12743089f, -0.08014707f, -0.08353503f, -0.16433412f, 0.05911224f, 0.17047493f, 0.05036409f, 
    0.15426745f, 0.02485600f, 0.01694771f, -0.02545071f, -0.31452248f, -0.43202838f, -0.35761526f, 0.07065961f, 
    0.03602067f, 0.08653852f, 0.00062045f, -0.06347803f, -0.03327772f, 0.01014153f, 0.02478067f, 0.09038858f, 
    0.02662360f, -0.03939064f, -0.02871050f, -0.24508898f, -0.03544964f, -0.06439750f, 0.00877748f, -0.10878140f, 
    -0.15988740f, -0.07250238f, -0.16200410f, -0.10903380f, 0.02104936f, -0.21784174f, -0.03304161f, -0.01624146f, 
    -0.03780294f, 0.08219656f, 0.12375550f, 0.01368294f, 0.04033533f, 0.08662187f, 0.12352720f, 0.09424352f, 
    -0.09858411f, -0.40045533f, -0.28586864f, -0.24747093f, -0.06265064f, 0.13744704f, -0.02340215f, 0.06802921f, 
    -0.05089090f, 0.01830911f, -0.07282677f, -0.02128011f, -0.06132121f, -0.03979253f, -0.10520021f, -0.00151789f, 
    0.00112414f, 0.02296041f, 0.09963754f, 0.02100916f, 0.04160675f, -0.03917326f, 0.00442577f, -0.01632779f, 
    -0.12070283f, -0.35306081f, -0.24404116f, -0.18357934f, 0.02639184f, 0.00812391f, 0.07893264f, 0.09924648f, 
    -0.07798675f, -0.02149419f, 0.01177174f, 0.07414554f, -0.14644720f, -0.23745030f, -0.13429275f, -0.05116285f, 
    -0.01690708f, 0.05190762f, 0.06188937f, 0.12417376f, -0.11604627f, -0.07535183f, -0.08625145f, -0.13108681f, 
    -0.10292722f, -0.11770397f, -0.07051133f, -0.11597344f, -0.15272743f, -0.03814045f, 0.08077247f, -0.06082197f, 
    0.00339387f, 0.03620416f, -0.01827981f, 0.01504424f, 0.21289541f, -0.02208235f, -0.29147640f, -0.03036255f, 
    0.03016768f, -0.00956153f, 0.07265114f, 0.05409183f, 0.14964397f, 0.13990299f, 0.16506030f, 0.12399645f, 
    -0.26161996f, -0.18023963f, -0.04608431f, -0.04500606f, 0.02387712f, 0.02289944f, -0.07495684f, 0.11167514f, 
    -0.25583789f, -0.14278725f, 0.04661530f, -0.12712866f, -0.00187267f, -0.20852970f, -0.22031295f, 0.06353700f, 
    -0.01804808f, -0.01267129f, 0.11093817f, 0.20390929f, -0.02200709f, -0.10338646f, -0.05702952f, -0.03680485f, 
    -0.74164963f, -0.65721321f, -0.49796101f, 0.04432017f, 0.05864745f, 0.21157312f, 0.11762293f, 0.16751404f, 
    -0.07616689f, 0.00567660f, -0.01208710f, 0.07060286f, 0.12870139f, -0.02139191f, 0.13517493f, 0.01481762f, 
    -0.00970046f, -0.01842853f, -0.00705597f, -0.14703359f, 0.03178851f, 0.03963996f, 0.05834526f, -0.06308347f, 
    -0.17014718f, -0.11638729f, -0.03977326f, 0.06879727f, 0.03245416f, -0.00358108f, 0.01154016f, -0.01992621f, 
    -0.05532901f, -0.13774915f, -0.16440535f, -0.40362117f, -0.13911848f, 0.07963969f, -0.01108927f, -0.07044477f, 
    0.02236039f, 0.00778730f, 0.07683019f, 0.05478724f, 0.08389906f, -0.16173145f, -0.18842603f, -0.21480434f, 
    0.37973654f, 0.21187353f, -0.39792842f, -0.06793864f, -0.04477528f, -0.10670603f, -0.06551892f, -0.22450286f, 
    0.08705089f, 0.09415197f, 0.04197678f, 0.08095389f, 0.03487416f, 0.01622172f, -0.00397037f, -0.18713483f, 
    -0.03705965f, -0.03993901f, -0.00690504f, 0.04567138f, 0.04339737f, 0.19439217f, -0.08654442f, -0.00199177f, 
    -0.63359511f, -0.16749245f, 0.16067085f, 0.20786361f, 0.03186103f, 0.02401430f, -0.03308473f, 0.01354010f, 
    -0.12240279f, -0.10953143f, -0.08590417f, 0.15678498f, -0.03985764f, 0.10275435f, 0.01966223f, 0.01173050f, 
    0.06403841f, -0.04899294f, -0.04632771f, 0.01364060f, -0.09691508f, 0.01889519f, -0.07229738f, -0.10230443f, 
    0.32966411f, -0.31871685f, -0.12320724f, -0.29848447f, -0.11158341f, -0.02793561f, -0.05019739f, -0.05229542f, 
    0.11891428f, 0.06601734f, 0.06934252f, 0.04271393f, 0.32836443f, -0.20094287f, -0.20553374f, 0.01276061f, 
    0.09332711f, 0.01403895f, 0.01690564f, -0.07700344f, -0.01350941f, 0.14936621f, 0.10158464f, 0.02588363f, 
    0.23251401f, 0.23234521f, -0.41617781f, -0.40212169f, 0.13170333f, -0.09270845f, 0.26367474f, 0.11742855f, 
    0.02323738f, 0.02053582f, -0.00182917f, 0.13263445f, -0.17931767f, 0.00049973f, -0.04840207f, -0.02864869f, 
    0.00734299f, 0.04132042f, 0.02278513f, -0.00085557f, -0.12357409f, -0.13749035f, -0.25792590f, -0.55208516f, 
    0.06264724f, 0.09096748f, -0.58680618f, -0.37698948f, -0.11346366f, -0.11073691f, 0.06116862f, -0.10918598f, 
    -0.01459017f, -0.00048815f, -0.08902960f, 0.01242028f, 0.02978069f, -0.21176320f, -0.03388310f, 0.07281179f, 
    -0.04868000f, 0.09428088f, 0.16282380f, 0.03232751f, -0.02596417f, -0.18024087f, -0.13112083f, -0.24846649f, 
    -0.29119897f, -0.05136558f, 0.04885234f, 0.19312812f, 0.00714281f, 0.20008858f, -0.12982003f, -0.11852420f, 
    -0.02620407f, -0.07713848f, -0.02557304f, -0.05395720f, -0.41574007f, -0.04222145f, 0.18998143f, 0.03765279f, 
    0.08097228f, -0.07708046f, -0.06114770f, 0.01677636f, 0.10672385f, 0.02375717f, 0.09454863f, 0.04774605f, 
    0.06990831f, -0.00904024f, 0.05348837f, -0.00655830f, 0.09525826f, -0.00489368f, 0.01773598f, 0.11298373f, 
    0.08743354f, -0.01650846f, 0.00231874f, -0.21388683f, 0.05624459f, -0.08680231f, -0.08542161f, -0.20905274f, 
    -0.08508865f, -0.05079947f, 0.10334013f, -0.00361307f, 0.06206463f, 0.08560666f, -0.04267165f, -0.10436893f, 
    0.07820358f, -0.20821439f, 0.08807325f, 0.17566316f, 0.15091880f, -0.04245752f, 0.12554486f, 0.14247282f, 
    -0.04186162f, -0.00871766f, -0.05280829f, -0.14055502f, -0.21821223f, -0.44987452f, -0.22794971f, -0.14601828f, 
    0.08420817f, 0.08710314f, 0.08096732f, 0.07781224f, -0.10313221f, -0.12044957f, -0.07815428f, 0.10685952f, 
    0.18669665f, -0.10522421f, -0.10447882f, 0.04753000f, -0.00427804f, 0.14300418f, 0.09178245f, -0.09446297f, 
    0.03842084f, -0.05578904f, -0.09726036f, -0.06842274f, -0.20498709f, -0.17691152f, 0.08824951f, 0.00614017f, 
    -0.03655538f, -0.01080572f, 0.03572960f, -0.04223958f, -0.04592408f, 0.07873504f, -0.08781428f, -0.18851417f, 
    0.06387965f, 0.17234367f, 0.05018601f, 0.06587016f, 0.00680703f, -0.09605319f, 0.01226053f, -0.06161058f, 
    0.01097358f, -0.08147132f, -0.03325371f, -0.01994595f, -0.04065206f, 0.02330501f, -0.03566483f, -0.06633381f, 
    -0.03853610f, 0.03097158f, 0.00236409f, -0.05301040f, 0.00799800f, 0.03136348f, 0.02484793f, 0.09640442f, 
    -0.31340167f, -0.20253296f, 0.07951241f, 0.11912668f, 0.07581306f, 0.06829943f, 0.03432266f, -0.01671810f, 
    0.01500746f, 0.09797139f, -0.03613872f, 0.13372651f, -0.20898989f, 0.10786492f, 0.25551826f, 0.20973721f, 
    0.06873842f, -0.01579143f, -0.02743980f, 0.14674732f, 0.04155336f, -0.06437940f, -0.00455674f, 0.00104060f, 
    0.25469899f, -0.07561892f, -0.37226295f, -0.55663222f, -0.26040953f, -0.00818947f, 0.09326279f, -0.13707632f, 
    0.02419252f, 0.02887094f, 0.09384506f, 0.05934057f, -0.47024307f, 0.02732711f, 0.05514162f, 0.38093382f, 
    -0.07594895f, -0.01114808f, -0.04601678f, 0.01589945f, 0.09037139f, 0.12824096f, 0.10143559f, 0.22883616f, 
    -0.05020481f, -0.02351427f, 0.06727434f, -0.04453448f, 0.02593444f, 0.09280318f, 0.01787498f, 0.02716311f, 
    -0.02192229f, 0.06285771f, 0.04298338f, 0.09008183f, -0.24269199f, -0.48258662f, -0.28549394f, 0.07405416f, 
    -0.15570524f, 0.01178807f, 0.00757519f, -0.01567333f, -0.05615608f, 0.01136015f, 0.04648871f, -0.02338406f, 
    -0.39228347f, 0.11407692f, 0.17955510f, 0.12857108f, -0.14317563f, -0.04446068f, -0.10278400f, -0.08593728f, 
    -0.09653804f, 0.00343881f, 0.06228934f, 0.01672693f, -0.17349403f, -0.02533313f, 0.00749728f, 0.16344294f, 
    0.04483994f, -0.00780729f, 0.06664314f, 0.00255769f, 0.05131586f, 0.02572207f, 0.06021721f, -0.02286744f, 
    0.20831060f, -0.04856167f, -0.07837607f, -0.17424037f, -0.12726755f, 0.09593800f, -0.04196824f, -0.24419227f, 
    0.01532239f, 0.07140868f, -0.03581717f, 0.01771960f, 0.09308726f, -0.07706257f, -0.36829209f, -0.23291814f, 
    -0.15003200f, -0.12198793f, -0.20852084f, -0.15665963f, -0.00440987f, 0.01484224f, -0.02448803f, 0.00891212f, 
    0.18648230f, -0.07964358f, -0.04520019f, -0.10821291f, 0.04207153f, 0.03918945f, -0.03920173f, -0.02926309f, 
    0.10634846f, 0.08191323f, 0.12609239f, 0.14443776f, -0.04603925f, -0.02393719f, 0.05833481f, 0.08348657f, 
    0.03509786f, 0.11281407f, 0.03463243f, 0.09591074f, 0.02373864f, -0.01389736f, 0.03746055f, 0.01014142f, 
    -0.27607915f, -0.01780695f, 0.17662299f, 0.15353487f, -0.01046467f, 0.01582086f, -0.14866289f, 0.03376922f, 
    -0.01827029f, 0.05302108f, 0.04524869f, 0.08923612f, -0.21836662f, 0.06918228f, 0.11054831f, 0.02131076f, 
    0.19366580f, 0.01935350f, -0.01352874f, 0.11016516f, -0.11999935f, -0.02853218f, 0.03296038f, 0.11887273f, 
    -0.07285996f, 0.03310442f, -0.02389846f, -0.08640540f, -0.10727193f, -0.01528846f, -0.01370103f, -0.02279541f, 
    -0.02070130f, 0.03916194f, 0.05858693f, 0.21191050f, 0.57992876f, 0.13231717f, 0.06017628f, -0.22969595f, 
    0.05484337f, -0.05337694f, -0.05712540f, 0.00723729f, 0.03992060f, -0.03384554f, 0.07142220f, 0.01504070f, 
    0.07683396f, -0.14212275f, -0.18479614f, 0.03732795f, 0.14648101f, -0.11834551f, 0.12560153f, -0.00608231f, 
    0.01724645f, 0.02187533f, -0.02400652f, 0.21803911f, -0.17711374f, -0.03573893f, 0.01821959f, -0.03436290f, 
    -0.01086653f, -0.01202055f, 0.02485212f, 0.01256283f, 0.06672938f, 0.15812659f, 0.03685212f, 0.14531557f, 
    0.16086124f, -0.13000309f, -0.06984735f, -0.03831950f, 0.08157703f, 0.01799193f, -0.01634718f, 0.05222581f, 
    0.06957129f, -0.13549043f, -0.11167200f, -0.15496795f, -0.24215923f, 0.01565621f, -0.08496725f, 0.22148901f, 
    0.03873713f, -0.17988484f, -0.11275476f, -0.18276963f, 0.03267855f, 0.02113552f, 0.02060374f, 0.02402165f, 
    -0.09281879f, -0.25006819f, 0.41052246f, -0.02817509f, 0.06313037f, -0.15827730f, -0.07280958f, -0.18058300f, 
    0.02278881f, -0.02444591f, 0.08362905f, -0.07912419f, 0.03374075f, -0.33927277f, -0.03952964f, -0.01424744f, 
    0.07986601f, -0.00723197f, 0.09171834f, 0.08352632f, -0.00083676f, 0.00090343f, -0.06375942f, -0.11855827f, 
    0.07450223f, -0.04311271f, -0.02578596f, -0.09970672f, -0.08761122f, 0.10713993f, -0.09242693f, -0.17107168f, 
    0.02899882f, -0.03859963f, 0.07409690f, 0.07590645f, 0.02596532f, -0.15799423f, -0.11575762f, -0.02766610f, 
    0.12933181f, 0.21469536f, 0.11746240f, 0.08577207f, 0.08565727f, 0.02009287f, 0.02530816f, -0.05275458f, 
    0.08086620f, -0.10381722f, -0.08167258f, -0.22045213f, -0.20940825f, 0.04618675f, -0.08811723f, -0.06825129f, 
    0.01840430f, -0.07887092f, -0.07504743f, 0.07318917f, -0.26152125f, 0.10366596f, 0.20791705f, 0.33071208f, 
    0.06801132f, 0.15672763f, -0.19226313f, -0.03289283f, 0.01327835f, 0.04169541f, -0.04220714f, -0.13768153f, 
    -0.03949302f, -0.09936326f, 0.29867914f, -0.20413581f, 0.06881882f, -0.22118783f, -0.00980386f, -0.10015712f, 
    -0.04204627f, 0.02135061f, 0.05379835f, 0.03225422f, 0.11521525f, 0.14766230f, 0.15651278f, 0.17738672f, 
    0.05915872f, 0.01311526f, -0.28642195f, -0.05823100f, -0.07548297f, -0.17009217f, 0.07198446f, 0.03625558f, 
    -0.14858432f, -0.09604277f, -0.00187439f, 0.13967150f, -0.25578153f, 0.13230588f, -0.14515230f, -0.06215482f, 
    -0.05356198f, -0.10749485f, -0.02131031f, 0.05438097f, -0.07349870f, 0.06148805f, 0.07300210f, -0.43826437f, 
    0.16637121f, -0.06147029f, -0.11537480f, 0.20800933f, -0.00437767f, 0.01539531f, 0.08351042f, 0.07977342f, 
    -0.09289398f, -0.12310348f, 0.00074853f, 0.10517206f, 0.11775026f, 0.20137446f, -0.09703033f, 0.02125261f, 
    0.06964517f, -0.05923615f, -0.04270100f, 0.07037766f, 0.05308731f, 0.17103380f, 0.27147153f, 0.16268370f, 
    0.11263304f, 0.02982483f, -0.13112161f, -0.11614426f, -0.01863027f, -0.06316786f, 0.03255923f, -0.01884461f, 
    -0.09706165f, 0.34015208f, 0.14523219f, -0.00053976f, 0.05728146f, -0.15140623f, -0.06729367f, 0.00703102f, 
    0.04468935f, -0.00219062f, -0.00271350f, -0.04049081f, 0.17309570f, -0.00635961f, 0.18761577f, -0.10789102f, 
    0.01551084f, 0.00094993f, -0.18289997f, -0.16034245f, 0.03156395f, -0.03972045f, 0.05376540f, 0.12381548f, 
    -0.02069908f, 0.10742463f, -0.10521442f, 0.02539732f, -0.14475018f, 0.18250786f, -0.10146935f, 0.07469395f, 
    -0.00512908f, -0.10939093f, -0.00732765f, -0.06859890f, 0.14095263f, 0.27745408f, 0.36830744f, -0.17854428f, 
    -0.06679932f, -0.15499128f, -0.11067038f, -0.06060450f, -0.02253681f, 0.04510397f, 0.08264352f, 0.11212137f, 
    -0.09575307f, -0.28443214f, 0.14918484f, -0.09723036f, 0.14327113f, 0.08720086f, -0.01145218f, 0.12652904f, 
    0.01063899f, 0.08104909f, 0.02008874f, 0.00961873f, -0.33106223f, 0.01246700f, -0.09425689f, 0.27353555f, 
    0.15168664f, -0.21011570f, -0.06807826f, 0.02352439f, 0.04454387f, -0.00400270f, 0.01820151f, -0.08868781f, 
    -0.09145707f, 0.43238747f, 0.09324058f, -0.28475243f, -0.03922698f, -0.14403698f, 0.14892042f, 0.02976014f, 
    0.03850140f, -0.00617528f, 0.09629039f, 0.10737219f, 0.20931448f, -0.20774633f, 0.07027835f, -0.07466145f, 
    -0.07309123f, 0.05565718f, -0.22143030f, 0.03042185f, 0.09933019f, -0.01840077f, 0.00843301f, 0.04161622f, 
    -0.08385231f, 0.15555692f, -0.40800455f, -0.20716654f, -0.14424683f, -0.27946463f, -0.16775832f, 0.02602710f, 
    0.02955854f, -0.00245219f, 0.15337911f, 0.02175306f, 0.23914969f, -0.12411726f, -0.08017696f, -0.18135636f, 
    0.07534741f, 0.12534542f, 0.13534130f, 0.13523860f, -0.01166020f, 0.03571640f, -0.09799906f, -0.07161204f, 
    0.03125378f, -0.07505417f, -0.10371532f, -0.07014699f, 0.05394572f, 0.00035943f, 0.08854761f, 0.10869088f, 
    0.02902341f, 0.00011026f, 0.14974628f, 0.23083080f, -0.06529195f, 0.11100063f, 0.15708360f, 0.28262305f, 
    -0.00358259f, 0.04796057f, -0.18601386f, 0.03155414f, 0.22246420f, 0.16091368f, 0.08833677f, -0.02007645f, 
    -0.36324918f, -0.48381492f, 0.00401976f, 0.17113838f, 0.18296792f, -0.09398208f, 0.05656192f, 0.16557617f, 
    0.05130235f, 0.03976052f, -0.00047239f, -0.07894248f, 0.04935864f, -0.00218577f, 0.03457105f, 0.19961521f, 
    -0.07409528f, 0.03774081f, -0.03783607f, -0.09397788f, 0.13522393f, -0.08945685f, 0.09818177f, -0.08041132f, 
    -0.17557493f, 0.40814960f, 0.57003510f, -0.72780651f, -0.04264459f, -0.14885834f, 0.04222306f, 0.01943379f, 
    -0.09143702f, 0.08889198f, -0.04653492f, 0.07653635f, 0.23142251f, -0.37086326f, -0.16017172f, -0.22927159f, 
    -0.00848690f, 0.10337261f, -0.06831981f, 0.07247593f, -0.09399845f, 0.04202531f, -0.01958457f, -0.15693696f, 
    -0.10358440f, -0.33416745f, -0.07443282f, -0.12440064f, -0.26618034f, 0.06544109f, -0.02413441f, 0.03456367f, 
    0.05019547f, 0.08726060f, 0.09256200f, -0.01980571f, 0.16408253f, 0.45031351f, -0.22924863f, -0.06220611f, 
    -0.21006264f, -0.00692987f, 0.09787677f, -0.12416515f, 0.12103550f, -0.02815758f, -0.08199105f, -0.01977992f, 
    0.00494401f, -0.08093175f, 0.33566537f, 0.43381232f, 0.00086634f, 0.02809342f, -0.07378351f, -0.03412019f, 
    0.10510598f, 0.01766453f, 0.01672025f, 0.09534003f, 0.19959207f, 0.10641088f, 0.32357961f, 0.03864146f, 
    -0.04840642f, -0.03934491f, -0.03783512f, -0.08361686f, 0.05626807f, 0.16907619f, 0.11203356f, 0.03116149f, 
    -0.28156942f, 0.00148914f, -0.01866229f, -0.00134464f, 0.00314676f, 0.11621030f, -0.03591464f, 0.12832525f, 
    0.10034406f, 0.04737849f, 0.05207516f, -0.00961323f, 0.04855041f, -0.41819951f, 0.12017182f, -0.18638074f, 
    -0.08252931f, 0.07749400f, -0.30109850f, 0.10583949f, 0.15101138f, -0.00833180f, 0.06483623f, 0.16485758f, 
    -0.04258558f, 0.05107823f, -0.32754704f, -0.13539340f, 0.05040141f, 0.07831275f, 0.16585870f, 0.19125998f, 
    -0.18500951f, -0.04983753f, -0.04090067f, 0.01491998f, 0.19547714f, -0.01334141f, -0.18473253f, -0.19011168f, 
    0.07528301f, -0.05262300f, 0.06742415f, 0.16275054f, 0.06111469f, -0.01749122f, -0.09403602f, -0.11084689f, 
    -0.25673443f, -0.19241890f, -0.00104042f, -0.05222765f, 0.04518156f, 0.02876526f, -0.00480705f, -0.01498033f, 
    0.00977634f, 0.02878477f, 0.13400064f, 0.11262490f, -0.08190680f, 0.06277221f, 0.33177894f, 0.22870541f, 
    0.07441697f, -0.13663487f, -0.15491332f, -0.24673630f, 0.16405542f, 0.00722041f, -0.08327983f, 0.18789728f, 
    0.24279168f, -0.05909248f, -0.36720383f, -0.20845009f, -0.06484031f, -0.07611923f, 0.04327245f, 0.02955236f, 
    0.10665099f, -0.03370943f, -0.09448116f, 0.09014081f, 0.32784110f, -0.17815661f, 0.20137651f, 0.25571275f, 
    -0.00193374f, -0.10801115f, 0.05372388f, -0.17372103f, -0.09325285f, -0.00516981f, 0.05985296f, 0.05461768f, 
    -0.14246942f, -0.17332599f, 0.12125896f, -0.14285542f, 0.00201553f, -0.03036904f, -0.01263115f, 0.03231031f, 
    0.01298407f, 0.02768593f, -0.05482086f, 0.08452767f, 0.03665999f, -0.08727987f, 0.25201541f, -0.02857912f, 
    0.08272532f, -0.01294189f, -0.01640614f, -0.06086252f, -0.04254241f, 0.17343448f, 0.07252915f, 0.08003061f, 
    -0.17581423f, -0.19671129f, -0.55876833f, 0.15568635f, 0.17110910f, 0.06110953f, 0.16496196f, -0.13974509f, 
    -0.05160969f, 0.01943659f, -0.03673367f, -0.04088504f, -0.23533028f, -0.00729277f, -0.05029235f, 0.05692454f, 
    0.13793892f, 0.03324310f, -0.00665139f, -0.00079417f, 0.13068825f, 0.01898990f, -0.02536506f, 0.02582346f, 
    0.06679665f, -0.23614097f, -0.05959502f, -0.47627103f, 0.04121254f, -0.03378662f, -0.03062356f, -0.08680078f, 
    -0.01497597f, -0.02447701f, -0.01223389f, 0.08121573f, -0.95723450f, 0.08390234f, -0.58617687f, 0.18183947f, 
    0.02976551f, -0.16938390f, 0.15992054f, 0.10373499f, 0.04710591f, -0.00500131f, -0.01172801f, 0.03340803f, 
    -0.47280091f, -0.32583371f, 0.12647308f, -0.29016972f, -0.14319915f, 0.18740177f, -0.16380705f, 0.09976982f, 
    -0.00922401f, 0.09074291f, 0.04317935f, -0.06619901f, 0.04646897f, -0.10388986f, 0.12359330f, -0.00265265f, 
    -0.01442854f, 0.12240376f, -0.02627051f, 0.08045269f, 0.00721193f, 0.03574339f, -0.08418889f, -0.10880550f, 
    0.16980387f, -0.25192940f, 0.09520438f, -0.17586006f, 0.09565255f, 0.10504664f, -0.08830082f, -0.07760704f, 
    0.05722447f, 0.02277328f, -0.05114388f, 0.01351977f, -0.29945716f, 0.23482367f, -0.00047219f, -0.37602866f, 
    -0.28210583f, -0.08979420f, 0.06425270f, 0.17855370f, 0.06074950f, 0.03371700f, 0.02076961f, -0.01153013f, 
    0.00963315f, -0.30952057f, 0.00444609f, -0.06387655f, 0.06331950f, 0.08790306f, 0.10718956f, 0.13089389f, 
    -0.09937344f, 0.03958021f, -0.04939753f, -0.15186854f, 0.18950404f, 0.06047230f, -0.07705474f, -0.35187572f, 
    -0.24706922f, -0.14042200f, -0.05509983f, -0.27083328f, 0.10680959f, -0.01787435f, 0.04316314f, -0.01543076f, 
    0.09107440f, -0.23964214f, 0.14667493f, -0.07310120f, 0.18798995f, 0.02075083f, -0.09700373f, -0.03756566f, 
    0.05187425f, -0.09852889f, -0.05366454f, -0.04426147f, -0.18316577f, -0.00223261f, -0.00974431f, -0.00353504f, 
    -0.13613431f, -0.09716876f, 0.03650399f, 0.18146884f, 0.01366187f, 0.12263063f, 0.08597358f, -0.01364609f, 
    -0.36336303f, -0.06779204f, -0.00790498f, -0.13220619f, 0.15698789f, -0.04706013f, 0.06409146f, -0.05670256f, 
    -0.08996737f, -0.10427263f, -0.06927340f, -0.06210509f, -0.04971263f, 0.24595729f, -0.03933749f, -0.41851676f, 
    0.02724420f, -0.01151847f, -0.08241305f, -0.01739439f, 0.09898963f, -0.03835912f, 0.01308321f, 0.03824894f, 
    -0.30244434f, 0.19214350f, -0.05833317f, -0.22498025f, 0.01716377f, 0.03657534f, 0.00251105f, 0.09755874f, 
    0.12800834f, -0.04900588f, -0.10287814f, -0.02552798f, -0.34258971f, 0.08666047f, -0.34141886f, -0.10900043f, 
    0.02474826f, -0.07994156f, 0.15436375f, -0.17665015f, 0.09898230f, -0.00320742f, -0.08691630f, -0.04052453f, 
    -0.05950025f, -0.31654051f, 0.10378425f, -0.10622220f, 0.09124783f, 0.13246870f, -0.15450495f, 0.10277796f, 
    -0.08559853f, -0.07556997f, -0.04885655f, 0.06180274f, -0.46393546f, -0.00302920f, -0.44086805f, 0.11289256f, 
    0.15413135f, 0.04452271f, 0.01795200f, -0.13020833f, 0.06621666f, -0.13204391f, 0.02872243f, 0.04573045f, 
    0.19218133f, -0.10651749f, -0.12424724f, -0.20915155f, 0.01006881f, -0.03518816f, 0.01343689f, -0.09639748f, 
    -0.03675089f, 0.13389193f, -0.24414559f, 0.06572973f, 0.18564558f, -0.00002676f, 0.08183409f, 0.04024121f, 
    0.08413459f, -0.05719290f, 0.10538724f, -0.07520677f, 0.10948616f, 0.02713928f, -0.13931137f, -0.09614041f, 
    -0.04466284f, -0.13457423f, -0.18924236f, 0.32463241f, -0.03967020f, -0.00566006f, 0.00878177f, -0.04828493f, 
    0.09122048f, 0.15949002f, 0.14847691f, 0.23827843f, 0.06604055f, 0.02829125f, 0.05208258f, -0.17217106f, 
    -0.14657086f, 0.04786666f, 0.26578322f, 0.05595885f, 0.10713275f, 0.00683480f, -0.01551799f, -0.00028036f, 
    -0.56212008f, 0.23927195f, -0.18213727f, 0.01166148f, 0.05284515f, -0.05472675f, 0.29714423f, 0.23816781f, 
    -0.15325829f, -0.19021599f, 0.11615795f, -0.12651524f, -0.13921370f, 0.28103492f, 0.13984570f, 0.20361292f, 
    0.08608260f, 0.01550401f, -0.10287410f, 0.18296033f, 0.07249977f, -0.04579089f, 0.26647741f, 0.03854634f, 
    -0.01500250f, 0.03463377f, -0.00731136f, -0.13150063f, -0.12214850f, -0.15696475f, 0.14014052f, 0.01728355f, 
    0.07131665f, 0.08843903f, -0.15073732f, -0.07810193f, -0.36042842f, -0.47710866f, -0.17711289f, -0.40370768f, 
    -0.23638257f, 0.00843391f, -0.04384870f, -0.09130349f, 0.05465195f, 0.01143293f, -0.02998924f, -0.11263013f, 
    -0.09885839f, -0.04983799f, 0.08313766f, 0.05186852f, 0.03321025f, -0.12016374f, 0.05984978f, 0.00842753f, 
    -0.06386166f, 0.09699880f, 0.11681216f, 0.20798093f, 0.11031911f, -0.16342218f, 0.32200593f, 0.02134794f, 
    -0.16787688f, 0.03411361f, 0.03997478f, 0.03633345f, 0.00033205f, 0.03564000f, 0.12423460f, 0.21508381f, 
    -0.19923966f, 0.08206303f, 0.08302277f, 0.10529496f, 0.08911763f, 0.02469960f, -0.10335551f, 0.12618028f, 
    0.11260471f, 0.01127414f, -0.06003992f, -0.14095497f, -0.02469279f, 0.15240255f, 0.02460548f, 0.07927708f, 
    0.03069792f, -0.01699182f, -0.18733321f, 0.08542540f, -0.05256569f, 0.13915218f, 0.07646233f, -0.01064618f, 
    0.14181836f, 0.29877645f, 0.17785165f, -0.05179994f, 0.07832883f, 0.07962302f, -0.18512666f, 0.08074839f, 
    0.05510011f, 0.10849469f, -0.18053767f, -0.04400226f, -0.03996395f, -0.35495818f, -0.00229257f, 0.05236008f, 
    -0.19759563f, -0.01509891f, -0.12814339f, 0.07528906f, 0.06245220f, 0.04571851f, 0.03641601f, 0.01568034f, 
    -0.11646833f, -0.16921255f, 0.12770613f, -0.09152341f, -0.20704450f, -0.00850337f, -0.09722320f, -0.13738614f, 
    -0.11407517f, -0.12170596f, -0.17832606f, -0.21739885f, 0.09387102f, 0.03361475f, 0.09687998f, -0.00394780f, 
    -0.14849587f, -0.06941871f, 0.07732522f, 0.09553461f, -0.01871535f, 0.07421247f, 0.09176738f, 0.14325553f, 
    -0.06950595f, 0.20655349f, 0.16257036f, 0.08508550f, -0.01056093f, 0.04664990f, 0.00657371f, -0.03476644f, 
    -0.10452608f, 0.00579125f, -0.07771239f, 0.04029245f, -0.29403633f, 0.22042234f, 0.02239132f, 0.09803934f, 
    0.06081578f, -0.05218272f, 0.09931122f, 0.02437891f, -0.23654246f, 0.05619946f, 0.01448073f, 0.04170429f, 
    -0.27160639f, 0.31224716f, -0.23009315f, 0.05321860f, 0.06839514f, 0.12441195f, -0.09611385f, 0.17104743f, 
    -0.13092534f, 0.15082455f, 0.01014509f, 0.16347638f, -0.13641824f, -0.01121335f, -0.08367126f, -0.07503610f, 
    0.04091667f, -0.04521403f, -0.02530981f, -0.00714919f, 0.05401107f, 0.00949658f, -0.01499798f, -0.10611732f, 
    -0.07620928f, -0.27403474f, -0.08226316f, -0.05667772f, -0.04396138f, 0.06078666f, -0.10639872f, -0.04837812f, 
    0.11299710f, -0.25788409f, -0.06410429f, -0.08489873f, -0.11963036f, 0.20984265f, 0.34890175f, -0.11844413f, 
    -0.06531906f, 0.05105757f, 0.05189918f, -0.01939559f, 0.06472454f, -0.05793974f, 0.13629767f, 0.07973818f, 
    -0.15062052f, -0.13872783f, -0.01340271f, 0.01912945f, 0.05307456f, -0.20672692f, 0.26225427f, -0.10692248f, 
    -0.05510006f, -0.15594147f, -0.14741065f, -0.12393883f, -0.06495886f, 0.07803219f, -0.02382689f, 0.23643476f, 
    0.05302155f, 0.13427937f, -0.06384715f, 0.03899828f, -0.08471795f, 0.07234765f, 0.01562872f, -0.03169374f, 
    0.17522687f, 0.14222659f, 0.00622349f, -0.19938305f, -0.09281605f, -0.05003133f, -0.12610942f, 0.10013211f, 
    -0.10979536f, 0.16964230f, 0.03769165f, -0.21743651f, -0.25615677f, -0.15997592f, 0.05478467f, 0.05528553f, 
    -0.05888956f, -0.07912577f, -0.04111218f, -0.03465415f, -0.04268756f, 0.08996601f, 0.00454919f, -0.14315960f, 
    -0.05802872f, 0.05021716f, -0.10160337f, -0.01426417f, 0.06398717f, 0.03206720f, -0.18963206f, -0.11115097f, 
    -0.02123309f, -0.15755066f, -0.16270119f, -0.15056516f, -0.21538395f, 0.19025478f, -0.13082491f, 0.14333978f, 
    0.04214141f, 0.12016965f, -0.22853631f, -0.01622148f, -0.29990178f, -0.17813866f, -0.01770798f, -0.37129515f, 
    -0.62371147f, 0.40655178f, -0.27063969f, 0.15242599f, 0.06149229f, 0.14827634f, -0.00632563f, -0.03075926f, 
    -0.09279463f, 0.05624158f, -0.02143736f, 0.04353153f, -0.03522825f, 0.14803381f, 0.03416865f, -0.09895948f, 
    -0.16956456f, -0.10018989f, 0.08351829f, -0.02992294f, -0.09625334f, 0.15286119f, -0.36822221f, -0.06704769f, 
    -0.13271412f, 0.13439150f, -0.05593025f, 0.13361777f, -0.01973904f, -0.03169808f, -0.00375536f, 0.04750315f, 
    -0.11631389f, -0.18621995f, -0.01439671f, -0.03851769f, 0.03001614f, 0.07128596f, -0.16214356f, 0.28327462f, 
    0.05902634f, 0.03297341f, -0.01370407f, 0.11760059f, -0.16848639f, 0.03415912f, -0.14783481f, -0.07936127f, 
    -0.21306489f, -0.07589570f, -0.05062345f, 0.17780174f, -0.08335190f, -0.10649984f, 0.17205866f, 0.04075575f, 
    0.14974721f, 0.12531103f, 0.04318950f, 0.01348943f, -0.37993595f, 0.22411516f, 0.17212310f, -0.30773652f, 
    0.00071470f, 0.15457559f, 0.18752998f, -0.03668501f, -0.06602505f, 0.12486181f, 0.23567633f, 0.11714563f, 
    -0.35590285f, 0.09707297f, -0.46103078f, 0.12888899f, -0.03316150f, 0.10066534f, 0.01549551f, -0.04661411f, 
    -0.10012610f, 0.03658218f, 0.00997815f, -0.12032668f, -0.20326307f, 0.10692228f, -0.35392627f, 0.10459659f, 
    0.04582459f, -0.08432003f, -0.15671095f, 0.07340319f, -0.32170734f, -0.52277261f, -0.35474610f, -0.40380004f, 
    0.02412623f, -0.34864506f, -0.28548086f, 0.05347768f, -0.08824365f, 0.00132951f, -0.16656980f, 0.20059910f, 
    -0.02151690f, 0.03899140f, 0.07051441f, -0.04342988f, -0.33000627f, 0.30807823f, 0.17244099f, 0.10119087f, 
    0.07540922f, 0.08069959f, -0.23559439f, -0.01734793f, -0.13920003f, -0.12575360f, -0.12448111f, -0.17127360f, 
    -0.07388203f, -0.41065207f, 0.06041813f, -0.12880670f, 0.07232139f, -0.03683667f, -0.03603318f, -0.01417801f, 
    -0.15455894f, 0.03507008f, 0.02255747f, -0.17352740f, -0.00957633f, 0.00306560f, -0.19709764f, 0.22324702f, 
    -0.11001591f, -0.03132087f, 0.01562933f, -0.04668911f, 0.09037869f, 0.09410362f, 0.01225990f, 0.01084258f, 
    -0.13012375f, 0.21635993f, -0.06830998f, -0.08511858f, -0.02768894f, 0.05725552f, 0.02544506f, 0.07409225f, 
    0.04016556f, 0.12406341f, -0.16312581f, -0.15996711f, -0.00660097f, -0.00345282f, 0.14913863f, -0.24201086f, 
    0.02218494f, 0.08309658f, -0.09811749f, -0.15772162f, -0.05099863f, -0.00942191f, 0.02753470f, -0.25336641f, 
    -0.25288841f, -0.10863242f, 0.29802316f, -0.03195201f, 0.00183387f, 0.14916565f, -0.06139992f, -0.03092939f, 
    -0.01553268f, -0.03272605f, -0.03351170f, 0.12755047f, -0.16757704f, 0.26221848f, -0.17823771f, 0.04510595f, 
    -0.03675643f, 0.02934147f, 0.07414966f, 0.06801568f, -0.03371670f, 0.05195190f, -0.02919668f, -0.08560731f, 
    -0.29996470f, 0.16913022f, 0.00399099f, -0.14971188f, -0.02423038f, 0.14663309f, -0.18757077f, -0.01479173f, 
    -0.09536734f, -0.13177806f, 0.05845536f, 0.02190333f, -0.25910044f, -0.05691729f, -0.20633711f, 0.07938224f, 
    0.09294731f, -0.07419176f, -0.07936292f, -0.01077693f, -0.03770492f, -0.15181476f, -0.23481944f, -0.14660338f, 
    -0.02795615f, 0.13201432f, -0.44411018f, 0.01347908f, -0.06967093f, -0.07905873f, -0.01508236f, -0.02685378f, 
    0.04526943f, 0.04193481f, -0.03442866f, 0.00471273f, -0.05922946f, -0.18003160f, 0.17658736f, -0.35667884f, 
    -0.23510458f, -0.05787465f, -0.03790515f, -0.08972975f, -0.15729487f, -0.14325079f, 0.07696767f, 0.08274641f, 
    -0.20887698f, 0.06887641f, -0.25737977f, 0.46672052f, 0.09143111f, -0.06783842f, -0.05347644f, 0.27991018f, 
    -0.05262732f, 0.16292500f, -0.00191970f, 0.04180757f, 0.32276699f, -0.20653176f, -0.00389551f, 0.06918460f, 
    -0.15681949f, 0.09466843f, 0.02427991f, -0.06884906f, -0.02603105f, 0.07072832f, -0.19976014f, -0.01913586f, 
    -0.13351764f, -0.14201994f, -0.22428727f, 0.11759430f, 0.00991880f, 0.10956166f, -0.19411038f, -0.05850611f, 
    0.07271687f, 0.03524134f, 0.02204813f, -0.04392181f, 0.14152512f, 0.12940390f, 0.06149423f, 0.07693668f, 
    0.00541707f, 0.11166837f, 0.00207257f, -0.00835300f, -0.09723367f, 0.03193239f, 0.01061915f, 0.22662129f, 
    -0.16361301f, 0.14528137f, 0.10740267f, -0.02020044f, -0.02736535f, -0.23218781f, -0.01287099f, -0.05954242f, 
    -0.02327989f, 0.07038608f, 0.08466284f, 0.05485414f, -0.07420958f, -0.37777469f, -0.13642319f, 0.01387637f, 
    -0.11044100f, 0.11252820f, 0.04181171f, 0.07100861f, 0.04729461f, 0.08238167f, 0.05797593f, 0.08404620f, 
    -0.10944072f, -0.22472371f, 0.02424020f, -0.00402374f, -0.06986108f, -0.03336490f, -0.23283125f, -0.10851050f, 
    0.11397844f, -0.08956471f, 0.01278850f, 0.00519613f, 0.08120527f, 0.08146822f, 0.04277623f, 0.11598865f, 
    -0.07525236f, -0.09562091f, -0.00458349f, -0.14453715f, 0.04837723f, 0.12401963f, 0.06682917f, -0.21720119f, 
    -0.46071890f, 0.07164325f, -0.07517541f, 0.14480081f, -0.05436067f, 0.10369803f, -0.17088549f, -0.00640173f, 
    -0.00518493f, 0.15138000f, 0.04708369f, 0.04366713f, -0.18764171f, -0.17474577f, -0.28524277f, -0.04604471f, 
    -0.04627581f, -0.10870530f, -0.12205977f, -0.13767223f, 0.02245006f, 0.12066994f, -0.04479327f, 0.01319972f, 
    -0.00484895f, 0.02611726f, 0.10889903f, 0.18367282f, 0.01350065f, -0.05824392f, 0.20507260f, 0.18839201f, 
    0.05825028f, 0.17926411f, 0.19359532f, 0.23437755f, 0.07874934f, 0.08794003f, 0.13384700f, 0.06743759f, 
    0.00379084f, 0.06627426f, 0.11734945f, 0.00939000f, -0.00154093f, 0.09261502f, 0.03221745f, -0.01043864f, 
    0.05570833f, -0.23487657f, 0.26295093f, 0.16481411f, -0.05147432f, 0.04995254f, 0.21811047f, 0.04472917f, 
    -0.13315038f, -0.03638581f, 0.02809529f, 0.16853195f, -0.07521416f, 0.20077860f, 0.21282762f, 0.00331332f, 
    -0.13898143f, -0.17838317f, 0.10766783f, 0.04240329f, 0.00099445f, 0.06394258f, 0.12228360f, 0.11459702f, 
    -0.18423072f, 0.08420995f, -0.04849472f, 0.15928802f, -0.05264131f, 0.14156914f, -0.12986216f, 0.26496840f, 
    0.03160378f, 0.09782523f, 0.08578460f, 0.19754477f, -0.09884460f, 0.01223073f, -0.07842169f, -0.07867637f, 
    -0.22456741f, 0.00410439f, 0.09532918f, 0.13826993f, -0.12081217f, 0.07374685f, -0.15013844f, -0.06331764f, 
    -0.15558109f, 0.15784092f, 0.21511117f, 0.13744043f, -0.06491175f, 0.07672299f, 0.13477804f, 0.00811957f, 
    0.12723318f, -0.01224552f, 0.14725229f, 0.10509687f, 0.10019922f, -0.02677484f, -0.20562965f, 0.13711557f, 
    -0.17428234f, -0.04294009f, 0.05713531f, -0.08536569f, -0.02765715f, 0.15017366f, -0.10234641f, 0.11104257f, 
    0.16494109f, -0.01494988f, 0.02383305f, -0.13805956f, -0.06570695f, 0.16936827f, -0.20555665f, 0.21251696f, 
    -0.09574009f, -0.07505158f, -0.00626025f, -0.11020267f, 0.29395309f, -0.27899599f, 0.03131168f, -0.09566499f, 
    0.05319810f, 0.02802072f, 0.10395349f, -0.03356468f, -0.11613700f, 0.03029289f, 0.07938295f, 0.04103681f, 
    -0.12744632f, -0.01518774f, -0.18966351f, 0.19973022f, 0.13867708f, 0.11007120f, 0.06436040f, 0.10806222f, 
    -0.12154398f, 0.06564405f, 0.13046603f, -0.00616291f, -0.04828643f, 0.07501602f, -0.11508938f, 0.07945882f, 
    -0.08083612f, 0.04521253f, -0.10771842f, -0.01400617f, 0.00774330f, -0.06253417f, -0.03359139f, 0.02124155f, 
    0.19263370f, 0.11097697f, -0.00994371f, -0.14963201f, -0.01240841f, -0.04862523f, 0.02080582f, 0.03161209f, 
    0.18762453f, 0.07638086f, -0.04958939f, 0.11832434f, 0.37620974f, 0.20232330f, 0.20428042f, -0.18496859f, 
    -0.01334168f, -0.05053695f, -0.04463311f, -0.02548176f, -0.02623706f, -0.06500647f, 0.01757693f, -0.02572017f, 
    0.05536036f, 0.09465314f, 0.08596010f, -0.02176784f, -0.08681585f, -0.04992971f, 0.18872884f, -0.22127992f, 
    -0.03346678f, -0.00728618f, -0.06522023f, -0.05632296f, -0.16208908f, 0.08130662f, -0.13649812f, -0.01673553f, 
    0.10582128f, 0.11404828f, -0.01788980f, 0.06982644f, 0.00946187f, -0.04688214f, 0.14247431f, -0.08450013f, 
    0.17014436f, -0.08711700f, 0.18935418f, -0.58717942f, 0.00755562f, -0.22288397f, 0.03083842f, 0.04363394f, 
    0.04298969f, 0.13861494f, 0.04919773f, -0.03327289f, -0.41663766f, -0.07178468f, -0.24960586f, 0.10639965f, 
    0.13057667f, 0.00663686f, -0.01093086f, -0.01762567f, -0.13776374f, -0.11910179f, -0.12141241f, -0.06065189f, 
    -0.33440292f, 0.01387407f, -0.23089337f, 0.27390409f, 0.14582700f, -0.06203806f, 0.17617299f, -0.04626620f, 
    -0.01813174f, -0.03620964f, -0.05461684f, 0.16857520f, -0.06030401f, 0.01094284f, 0.08049399f, -0.09455191f, 
    -0.09702057f, -0.04759868f, -0.05951188f, 0.04015673f, -0.03152894f, 0.07739612f, -0.06430192f, -0.11185116f, 
    -0.05068147f, 0.11730499f, -0.09006021f, -0.12542415f, -0.00220450f, 0.00080970f, 0.07008526f, 0.03531869f, 
    0.07709169f, -0.02167003f, -0.10400196f, 0.00942279f, -0.28062224f, -0.10760608f, -0.19358182f, -0.00336632f, 
    0.05280971f, 0.01655434f, -0.06488475f, -0.00470318f, -0.18070218f, -0.08592042f, -0.02246176f, -0.06754442f, 
    -0.40017611f, -0.41989535f, -0.28674689f, 0.25926945f, -0.02199835f, 0.00991015f, -0.02743548f, 0.00580515f, 
    0.13429683f, 0.09871691f, 0.06374074f, -0.12560095f, -0.15995009f, 0.08733243f, -0.17020559f, 0.14913310f, 
    0.03901286f, 0.00357428f, 0.04897569f, -0.14613673f, -0.04087284f, 0.00446352f, -0.09994967f, -0.05655471f, 
    -0.21523644f, 0.11883456f, -0.04252815f, 0.19994889f, 0.02088995f, -0.06606093f, 0.00997718f, -0.09304658f, 
    0.01304960f, -0.05117700f, -0.00750310f, -0.06362808f, -0.26326063f, -0.17778818f, -0.12292716f, -0.05933884f, 
    -0.05255699f, -0.05237726f, -0.01619514f, -0.10870934f, 0.01855133f, 0.05526359f, -0.11898814f, -0.02906398f, 
    0.10465816f, 0.13112757f, -0.06041434f, -0.10388119f, -0.12562045f, 0.03473058f, -0.03744230f, 0.10388222f, 
    -0.08634812f, 0.08153718f, -0.08305310f, -0.06952587f, -0.02707881f, -0.42835239f, 0.12981543f, -0.26146710f, 
    -0.04737980f, 0.04793708f, 0.06539994f, 0.09965467f, -0.09141253f, 0.00890007f, 0.05863117f, 0.06988350f, 
    0.02167843f, -0.37581256f, 0.16549051f, -0.11014111f, 0.02622005f, 0.12645341f, -0.07269718f, -0.04355076f, 
    0.02390785f, 0.03838105f, -0.05283671f, 0.10394718f, -0.32440448f, 0.27007446f, -0.22054814f, 0.27540940f, 
    -0.04267196f, -0.05178134f, 0.08532672f, -0.04645072f, -0.10353629f, -0.03981172f, 0.04411305f, 0.04240697f, 
    -0.18398808f, -0.18345439f, -0.22922641f, -0.40293217f, -0.15215217f, -0.15758327f, 0.04609936f, -0.02121889f, 
    -0.06298531f, 0.06222932f, -0.01915401f, 0.06480344f, 0.20173629f, 0.26525626f, 0.14831738f, 0.02993563f, 
    -0.02320077f, 0.00282736f, -0.05926132f, 0.03630964f, -0.01216750f, -0.04483300f, 0.12384384f, 0.02939517f, 
    0.08912738f, -0.02973000f, 0.13754043f, -0.05047711f, 0.01222182f, -0.05884567f, 0.14006703f, 0.07764038f, 
    0.12445843f, 0.12252992f, -0.00637914f, 0.08352423f, -0.00769258f, -0.00865555f, -0.10583663f, 0.20491333f, 
    0.10846921f, 0.09085920f, 0.10806094f, 0.02907645f, 0.04670195f, 0.07290851f, 0.15925127f, 0.21205223f, 
    -0.16605768f, -0.35678080f, -0.12083594f, 0.16052116f, -0.02051093f, -0.00701067f, -0.06629541f, -0.07734903f, 
    -0.00990839f, 0.10764374f, 0.04141719f, -0.17937115f, -0.00853569f, 0.01167119f, -0.04300151f, 0.04939743f, 
    0.04182054f, 0.04386858f, -0.01668260f, -0.10931178f, 0.10931610f, 0.04570723f, 0.18307669f, 0.10846765f, 
    -0.11908887f, -0.08579540f, 0.23915784f, 0.18900324f, -0.03811235f, 0.13086113f, 0.13077708f, 0.09506264f, 
    -0.19224085f, -0.00185694f, 0.09384907f, 0.04665755f, -0.09469815f, 0.22951280f, 0.07636188f, 0.58903456f, 
    -0.17979385f, -0.01538929f, 0.00167100f, -0.09754480f, 0.08732185f, -0.01305036f, 0.13680567f, 0.18059978f, 
    -0.16956970f, -0.22487773f, -0.15057950f, 0.26833066f, -0.06536024f, -0.20342529f, 0.18330966f, -0.27269325f, 
    -0.05485687f, 0.08602086f, -0.04381162f, 0.05388708f, 0.10411646f, -0.08521876f, 0.29735893f, -0.08554622f, 
    0.08771714f, -0.25348178f, -0.06561264f, 0.02381234f, 0.00619259f, 0.01729917f, -0.01488504f, -0.02149677f, 
    0.03698077f, -0.31533727f, 0.00671210f, 0.30171141f, 0.16060281f, 0.05700422f, 0.08895177f, -0.04261801f, 
    0.00220566f, 0.06972656f, 0.24348319f, 0.09330588f, -0.28694320f, -0.10763859f, 0.00720021f, 0.02093495f, 
    0.02949585f, 0.00148284f, 0.00846253f, -0.02102088f, -0.31382924f, 0.18790556f, 0.12321769f, 0.20003629f, 
    -0.01737403f, -0.13233744f, 0.14203799f, 0.15855116f, -0.18250372f, 0.11896307f, -0.10365376f, -0.13321030f, 
    -0.04843938f, 0.05528837f, 0.05797076f, -0.07414430f, -0.48784202f, 0.41355360f, -0.41986635f, 0.34923503f, 
    0.08725999f, -0.00583009f, 0.29442257f, 0.14834650f, -0.08714795f, 0.09386891f, -0.01197700f, 0.11572419f, 
    0.30616429f, 0.04433687f, 0.47850722f, -0.10153057f, -0.18619786f, -0.06593863f, -0.31492344f, 0.03290306f, 
    -0.03521605f, -0.05830655f, -0.11116993f, -0.00479218f, 0.43258440f, -0.18118948f, 0.31283042f, -0.04404509f, 
    0.00283391f, 0.13263616f, -0.26653573f, 0.05297728f, -0.03980479f, -0.06068158f, -0.01718289f, 0.08435843f, 
    -0.00978858f, -0.13728745f, -0.21712005f, -0.17307352f, 0.01744919f, -0.01920756f, 0.11914285f, -0.15470389f, 
    0.15273274f, 0.06056044f, 0.05423930f, 0.10529792f, -0.25803274f, -0.15833989f, -0.19897589f, -0.07383033f, 
    0.06768370f, 0.13510171f, -0.03725978f, 0.06113197f, -0.06039195f, 0.03352627f, 0.21471898f, 0.13541123f, 
    -0.05419565f, 0.42875186f, -0.03434086f, -0.04120671f, 0.10638973f, -0.11558067f, 0.06491672f, -0.11660550f, 
    0.02332665f, 0.04078145f, -0.05290774f, 0.09721693f, -0.15412694f, -0.09515809f, 0.07366814f, -0.18607292f, 
    -0.11927553f, -0.09367418f, -0.12573422f, 0.07126258f, -0.00354859f, 0.13167593f, 0.06567849f, 0.03888426f, 
    -0.09316804f, -0.04776483f, -0.21612087f, 0.11769311f, -0.04599268f, -0.15266430f, 0.17502807f, -0.04493763f, 
    -0.06978584f, 0.11197009f, 0.04025273f, 0.01168480f, -0.44552591f, 0.06756631f, 0.05839948f, -0.13523485f, 
    0.02335477f, 0.11929198f, -0.03262034f, 0.11409602f, -0.27778104f, 0.11751777f, 0.14682080f, 0.12099840f, 
    0.58288974f, -0.25058177f, 0.33592248f, 0.25145131f, 0.08983552f, 0.04439607f, -0.09662504f, 0.09721949f, 
    -0.14474396f, 0.00662392f, -0.04188971f, -0.06248700f, 0.02261688f, 0.10072799f, 0.07558925f, -0.10588005f, 
    -0.04624335f, 0.07145426f, -0.05164538f, 0.18051048f, -0.18251935f, 0.10796685f, 0.16524215f, -0.23744664f, 
    -0.28099868f, -0.10009892f, -0.01970609f, 0.19215998f, -0.07054493f, 0.04235657f, -0.04183277f, 0.21848376f, 
    -0.14188451f, 0.04049520f, -0.00321421f, -0.00369367f, 0.49554515f, -0.56011486f, 0.41789404f, -0.21870893f, 
    0.05044120f, -0.10101900f, -0.02738555f, -0.06320860f, -0.07996048f, 0.03236037f, -0.00292737f, 0.13170445f, 
    -0.59653652f, -0.36155349f, -0.14400545f, 0.31372613f, -0.03030675f, 0.06168177f, 0.08553319f, -0.23421808f, 
    0.02337819f, 0.02153804f, 0.00148004f, -0.07236814f, -0.22159685f, 0.16636580f, -0.06367009f, 0.12291592f, 
    0.00924686f, -0.05563500f, 0.03895131f, -0.06526212f, -0.10714417f, 0.01394313f, 0.03897070f, -0.08988559f, 
    -0.12738287f, 0.23366389f, -0.09122658f, 0.05058603f, -0.00430010f, 0.03631317f, 0.03973543f, -0.11674915f, 
    -0.01167550f, -0.06305116f, 0.02691137f, -0.07773119f, 0.07767176f, -0.30118835f, -0.04811018f, -0.23968947f, 
    -0.18492052f, -0.17266864f, -0.22733080f, -0.12933390f, 0.04563431f, -0.05267926f, -0.06396031f, -0.04437405f, 
    -0.10046768f, -0.03983130f, -0.04353305f, 0.05131330f, -0.01330269f, -0.03075311f, 0.02360265f, 0.06826562f, 
    -0.13357204f, -0.08085231f, -0.06354443f, -0.11986526f, 0.06612233f, -0.06395397f, 0.06326736f, -0.01152234f, 
    0.03000923f, -0.01924509f, 0.11262707f, 0.04514674f, 0.05385633f, -0.04165825f, -0.02222671f, -0.06165203f, 
    0.01003338f, 0.09505758f, -0.01477079f, -0.01864546f, 0.02039322f, -0.01510171f, -0.06592043f, 0.04170034f, 
    0.08795509f, -0.08858372f, 0.01192465f, -0.05699009f, 0.03569523f, -0.39515299f, -0.03680718f, 0.03144601f, 
    -0.14658630f, -0.11745741f, 0.01269397f, -0.10268368f, -0.03721951f, 0.00872917f, -0.00611243f, -0.06251170f, 
    0.08827880f, 0.01451579f, -0.08618418f, -0.06364498f, 0.04068927f, 0.09222096f, -0.24682564f, 0.09430404f, 
    -0.04665653f, -0.00420721f, -0.16479868f, -0.08610690f, 0.04057884f, 0.08252135f, -0.02734978f, 0.01534240f, 
    -0.04520121f, -0.01539810f, 0.07746676f, -0.07788873f, 0.06847546f, 0.03073212f, -0.08823756f, -0.07752057f, 
    -0.11462566f, 0.12819043f, -0.04300091f, -0.05735109f, -0.10909318f, 0.13378865f, 0.12103257f, -0.10198181f, 
    0.01655014f, -0.01455514f, 0.15041007f, -0.00006311f, 0.36508530f, -0.47700435f, 0.32283911f, 0.24474721f, 
    0.08879398f, 0.26526871f, -0.12540215f, 0.01134091f, -0.11308002f, -0.08342111f, 0.13009739f, -0.02529405f, 
    -0.09086375f, 0.15802164f, -0.07169460f, -0.04143086f, 0.04544448f, 0.03973947f, -0.01064343f, -0.03186345f, 
    0.02886443f, -0.10243717f, -0.04529997f, 0.01046105f, 0.38670313f, 0.02362896f, 0.07522077f, -0.02518263f, 
    -0.00827990f, -0.05054793f, 0.04914591f, 0.05303247f, -0.09538329f, 0.03692221f, 0.04738709f, -0.02008368f, 
    0.04666310f, -0.03785555f, 0.19306143f, 0.34308818f, 0.05706374f, 0.00750872f, -0.04547667f, 0.13894701f, 
    0.01850597f, -0.02469165f, -0.08227732f, -0.38714904f, -0.01576839f, -0.17915003f, 0.08733798f, 0.17989278f, 
    -0.10056982f, 0.03681653f, -0.05904036f, 0.02561034f, -0.05080596f, -0.07115980f, 0.07574572f, 0.08352116f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.16121285f, 0.08306222f, 0.04482254f, -0.07109068f, -0.06476679f, 0.04776467f, 0.06626515f, -0.12000380f, 
    0.03895152f, 0.04419361f, 0.04045295f, 0.00065454f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
