#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.50855327f, 0.22725961f, 0.53003091f, -0.08545487f, -0.04059521f, -0.84939736f, 0.36087149f, 0.33045536f, 
    -0.84323019f, -0.58573443f, 0.05463928f, 0.09960325f, -0.12739360f, 0.45297691f, 0.18277220f, -0.20670377f, 
    0.00609461f, -0.01603984f, -0.21554476f, -0.10189715f, 0.02020252f, 0.13367485f, 0.21733028f, 0.36668810f, 
    -0.21583579f, 0.78214705f, 0.57151145f, -0.18932186f, 0.06980077f, 1.16000772f, 0.04415426f, -0.25987616f, 
    0.16148725f, 0.56491691f, -0.02133412f, -0.14408147f, -0.05569904f, 0.22903241f, 0.12413106f, 0.16139670f, 
    -0.20684509f, -0.07103205f, -0.02568441f, -0.03573762f, 0.05572159f, 0.20654173f, -0.18280889f, 0.10116180f, 
    0.18930712f, 0.12194547f, -0.09010530f, -0.24682501f, -0.48962083f, -0.35558727f, -0.05212890f, -0.24824914f, 
    0.09399001f, -0.23379980f, 0.05342164f, 0.06441175f, 0.51204371f, 0.43118000f, -0.44875363f, -0.12862644f, 
    0.20702027f, 0.31947160f, 0.13574348f, -0.61664289f, -0.24588104f, -0.19384317f, 0.20123960f, -0.22726880f, 
    -0.00516816f, -0.03122451f, -0.02149380f, -0.86548400f, -0.33011281f, 0.09984478f, -0.37934047f, -0.34988165f, 
    0.49101448f, -0.20029622f, 0.27559936f, -0.04288429f, -0.23568904f, 0.16116549f, 0.07670763f, 0.03265667f, 
    0.28038949f, 0.38243166f, -0.43020940f, -0.31103316f, -0.40662348f, -0.15483651f, -0.38221142f, 0.37969145f, 
    0.41530666f, 0.12199929f, 0.28007391f, 0.01629824f, -0.61153132f, -0.44491446f, -0.54531181f, -0.54325372f, 
    -0.45469102f, -0.34151477f, -0.01785403f, 0.22239186f, 0.18957734f, 0.36420962f, 0.23343992f, -0.05842664f, 
    -0.12578321f, -0.14292192f, 0.18628846f, 0.17222688f, 0.06096368f, 0.21891272f, -0.07455681f, -0.40995994f, 
    -0.31073204f, -0.33398804f, 0.23848207f, -0.15751263f, -0.07483204f, -0.66872531f, -1.07292759f, -0.43892956f, 
    0.11223616f, 0.40219557f, 0.49931586f, 0.83732873f, 0.17389658f, 0.22130872f, 0.08240323f, -0.07828221f, 
    0.31983861f, -0.10950491f, 0.05125503f, -0.18005024f, -0.06070560f, -0.11043542f, -0.29947478f, -0.26135644f, 
    0.05264338f, -0.04154246f, -0.17404541f, 0.21875031f, -0.09698147f, -0.17455938f, 0.36963776f, 0.75466424f, 
    0.47067350f, -0.60425073f, -0.56018698f, 0.09908809f, 0.15651241f, -0.39556128f, -0.36375588f, 0.47819573f, 
    0.38234559f, 0.41582650f, 0.16995339f, -0.02074381f, -0.24987429f, -0.28606555f, -0.14797212f, 0.15532343f, 
    0.05153773f, -0.24940662f, 0.09718045f, -0.00484031f, -0.02408520f, 0.17892905f, 0.03805741f, -1.21386909f, 
    1.07205224f, 0.19990122f, -0.51972735f, -0.17960078f, -0.11715388f, 0.65026683f, -0.29512483f, 0.06468750f, 
    0.07385520f, -0.27151299f, 0.08529675f, -0.12480501f, -0.16324508f, 0.06591074f, -0.07131827f, 0.02442381f, 
    -0.14586866f, -0.23794731f, -0.19246939f, 0.16859105f, 0.13319404f, 0.09901195f, 0.03370860f, 0.09885939f, 
    0.85081249f, 0.40615472f, 0.17702043f, 0.20753327f, 0.64206970f, 0.35580114f, 0.37849650f, -0.40347266f, 
    0.39276823f, 0.02111954f, -0.00696246f, 0.26464441f, -0.27076450f, -0.02312528f, -0.17010345f, -0.10279477f, 
    -0.05911732f, 0.05325362f, -0.07049536f, 0.07657631f, 0.16695486f, 0.30182388f, 0.44166437f, 0.14707045f, 
    0.13146785f, -0.78918892f, 0.51573348f, -0.24819851f, -0.08619332f, 0.37584054f, -0.18338518f, -0.56936502f, 
    -0.68460065f, -0.28709620f, -0.09508117f, -0.04556706f, 0.17666902f, 0.28110057f, 0.08200562f, -0.08616422f, 
    -0.38353959f, -0.17440805f, -0.01545856f, -0.34330234f, -0.29490024f, 0.17865440f, 0.03592135f, 0.14895244f, 
    -0.02361223f, 0.07204099f, 0.27275720f, 0.67365569f, -0.12268494f, 0.57643753f, 0.13189024f, -0.01840573f, 
    0.02490918f, 0.57055950f, 0.23500381f, 0.49337006f, -0.37736756f, -0.19573662f, -0.06829397f, -0.42339811f, 
    -0.20990716f, 0.19800957f, 0.18386291f, -0.43007019f, -0.20539440f, -0.17583114f, -0.41509876f, -0.28505033f, 
    -0.06675462f, -0.10258075f, -0.22015224f, -0.42539477f, -0.37784636f, -0.08559489f, -0.06285316f, -0.15933892f, 
    -0.43063393f, -0.52287257f, -0.37491894f, -0.22704282f, -0.41079649f, 0.04089818f, 0.25335857f, 0.16711135f, 
    0.38207808f, -0.23660514f, -0.24596605f, -0.40648100f, 0.46215093f, 0.31095105f, 0.26893023f, 0.27998346f, 
    0.03145902f, -0.33146268f, 0.17915180f, 0.22917134f, -0.20908019f, -0.08437760f, -0.59062493f, -0.47516784f, 
    -0.59382671f, 0.56519264f, 0.22333151f, 0.13723734f, 0.36704272f, 0.49517196f, 0.39736265f, -0.11207216f, 
    -0.30714536f, -0.05100924f, -0.05048954f, 0.08625405f, -0.02828810f, 0.00662940f, 0.17709427f, 0.32669947f, 
    0.22159193f, -0.04482985f, -0.30803379f, 0.04844508f, -0.32365075f, -0.60831505f, 0.76724362f, 0.17423110f, 
    -0.63051361f, 0.23406121f, 0.66381681f, -0.44759807f, -0.50006217f, -0.34610352f, -0.53292233f, 0.27356017f, 
    -0.24686208f, -0.28833723f, 0.23036100f, -0.23321719f, 0.20076272f, -0.12554944f, -0.38079631f, -0.20706007f, 
    -0.04398329f, -0.10961416f, -0.01673012f, 0.29789549f, -0.11132910f, 0.09100033f, 0.29727367f, -1.24345565f, 
    -0.49624300f, 0.18818557f, 0.40994486f, -0.65419656f, 0.02210499f, -0.00889925f, -0.27049556f, 0.31876346f, 
    0.03847504f, 0.38104641f, -0.07697181f, -0.01474498f, 0.15766852f, -0.31763992f, -0.04527882f, 0.08388923f, 
    0.03120137f, -0.25124866f, -0.14226109f, -0.19033320f, -0.08076782f, -0.11244654f, -0.01589772f, 0.82244688f, 
    1.08635843f, 0.52205604f, 0.43813935f, -0.58969003f, -0.37937003f, 0.04323851f, -0.71350151f, -0.28311044f, 
    0.20123203f, 0.45623913f, -0.12858716f, -0.18826474f, 0.01780178f, -0.04202914f, 0.08966728f, -0.07715163f, 
    0.15233774f, 0.06656211f, -0.15533033f, 0.10705029f, 0.31262562f, 0.17514892f, 0.07017810f, -0.06650898f, 
    0.18019919f, 0.19729534f, 0.00757424f, 0.78007370f, 0.50799757f, -0.54008973f, -0.50601667f, -0.61120421f, 
    -0.42315680f, 0.35901144f, 0.51893669f, 0.01553351f, -0.04455446f, 0.00210512f, -0.02064952f, -0.21347803f, 
    0.05296639f, 0.33851233f, -0.08241408f, 0.29123104f, 0.27395236f, -0.39974445f, 0.02044746f, -0.10964630f, 
    0.13325354f, -0.94644004f, 0.42149138f, -0.11477233f, 0.33701277f, 0.50809228f, -0.54442286f, 0.58834046f, 
    -0.41627875f, 0.03641230f, -0.13975005f, 0.14160563f, -0.28002352f, 0.26263300f, -0.18908270f, 0.03171431f, 
    0.19839363f, 0.17870380f, 0.03871034f, 0.22886659f, 0.12765378f, -0.06201493f, 0.10394752f, -0.02567211f, 
    0.20336145f, -0.02333807f, -0.45555025f, -0.59102970f, -0.40864727f, -0.42238483f, -0.05566232f, 0.19986463f, 
    -0.42327604f, -0.24599886f, -0.10772871f, 0.41341841f, -0.41069806f, -0.03882932f, 0.43152362f, 0.34550315f, 
    0.29571831f, -0.16339344f, -0.08961362f, 0.24367042f, -0.20754763f, -0.00385536f, 0.34583166f, 0.08203621f, 
    -0.13269714f, 0.00376642f, -0.12420589f, 0.86101389f, -0.05318339f, -0.66331506f, -0.92986244f, 0.20031196f, 
    0.44033700f, -0.23875888f, -0.28968057f, -0.03156902f, -0.20926026f, -0.39295807f, 0.16945630f, -0.08094018f, 
    -0.05646793f, -0.34780502f, 0.11317734f, -0.05305206f, -0.10767785f, 0.21627679f, 0.03771238f, -0.05410043f, 
    0.28173870f, -0.32195383f, -0.09453496f, 0.32995495f, -0.53924847f, -0.31578755f, -0.72371972f, -0.37814793f, 
    0.37761340f, -0.13778074f, 0.94298917f, 0.10865299f, -0.03568479f, 0.51482314f, 0.19290236f, -0.37420011f, 
    0.02205409f, 0.07905714f, 0.29239115f, -0.22922185f, -0.04587661f, -0.03920074f, 0.16013114f, -0.25513962f, 
    0.34785199f, 0.33138379f, -0.32541552f, 0.11019935f, -0.23772664f, 1.02823424f, 0.01274159f, 0.23969725f, 
    0.80096066f, 0.37384203f, -0.28125131f, 0.21451956f, -0.23215050f, -0.46704379f, -0.10422789f, 0.18874142f, 
    0.06661581f, 0.12843634f, 0.04586695f, 0.12752785f, 0.18724214f, -0.04126767f, 0.21624406f, 0.25988927f, 
    0.40739641f, -0.14430484f, 0.07557178f, 0.21079893f, -0.00268705f, 0.10457021f, 0.01581113f, 0.38896635f, 
    -0.14377342f, -0.76024240f, -0.55409384f, 0.53247142f, -0.08383032f, -0.00510354f, -0.22918452f, -0.15268628f, 
    0.23443773f, 0.08553876f, -0.11281950f, 0.29381901f, 0.45325774f, 0.07524380f, 0.00467833f, 0.18057735f, 
    0.05684925f, 0.37746158f, -0.06483756f, -0.06135519f, -0.17052190f, -0.34859908f, 0.32016587f, -0.41548917f, 
    -0.32546580f, 0.21647048f, -0.56333452f, -0.55694973f, 0.14946224f, -0.77006274f, 0.01769567f, -0.37922388f, 
    -0.09269598f, 0.18154003f, 0.06895374f, 0.05480168f, -0.05510989f, -0.07957562f, -0.01481321f, 0.46883476f, 
    -0.18236183f, 0.11834837f, 0.14014095f, -0.02530576f, 0.19546349f, 0.19342659f, 0.40692985f, 0.11299153f, 
    -0.08830613f, 0.19048908f, 0.38258505f, -0.34335065f, -0.40750292f, -0.44399694f, -0.16729939f, 0.08328305f, 
    0.18025962f, -0.15434293f, 0.36796889f, 0.50004345f, 0.20674616f, 0.16737893f, 0.17923079f, 0.44369608f, 
    -0.27341843f, 0.12753238f, -0.11378078f, -0.28651604f, 0.26296484f, 0.14902265f, -0.11978006f, 0.14169690f, 
    0.34779182f, 0.28265634f, 0.20161636f, 0.70558172f, 0.52204776f, 0.56507260f, 0.49497914f, 0.26455998f, 
    -0.04182228f, 0.17896082f, 0.31231344f, 0.13796845f, 0.16183144f, -0.21384719f, 0.41631570f, -0.03874931f, 
    -0.03229350f, -0.04886114f, 0.38520965f, -0.03912645f, -0.26501429f, 0.18309177f, -0.30385044f, -0.07686401f, 
    0.02730271f, 0.24487790f, -0.43571308f, -0.53337759f, -0.50431788f, -0.28218898f, -0.17073531f, -0.29931039f, 
    -0.48209387f, -0.41735691f, 0.00172482f, 0.33921692f, 0.38147461f, -0.05357911f, -0.21962595f, 0.14881492f, 
    -0.09593873f, 0.03762944f, 0.00538756f, 0.03105277f, 0.28588930f, 0.11777686f, 0.31385982f, -0.20451775f, 
    -0.01057050f, 0.14820190f, 0.16052976f, 0.37633952f, -0.25458670f, 0.47489384f, 0.76948529f, 0.57143050f, 
    -0.47520941f, 0.10621956f, -0.10148535f, -0.33209410f, 0.06015318f, 0.12666193f, -0.04039284f, -0.64270329f, 
    -0.12671284f, -0.32522702f, -0.18266590f, -0.31412116f, -0.47470501f, -0.15324125f, -0.27795631f, -0.02668443f, 
    0.00877307f, 0.06355427f, 0.04514530f, -0.01105555f, 0.32185212f, -0.55945045f, 0.36621836f, 0.76917398f, 
    0.50491351f, 0.72609794f, 0.38850608f, 0.08803998f, 0.10153134f, 0.04702705f, -0.35970780f, -0.16799451f, 
    -0.29423195f, 0.04413141f, -0.02802535f, 0.05629291f, -0.08863493f, -0.22291310f, 0.00165602f, -0.00657305f, 
    -0.04643196f, 0.10080740f, 0.04006783f, -0.23456649f, 0.03815774f, 0.80166459f, 0.42492715f, 0.07787418f, 
    0.92136127f, 0.56267840f, 0.08827147f, 0.10474794f, -0.17151761f, 0.01958752f, 0.07311963f, -0.41560465f, 
    -0.06388093f, -0.02563460f, 0.18844818f, 0.19107001f, -0.00686747f, -0.12348600f, 0.19296941f, 0.14030227f, 
    0.24776857f, -0.06111134f, -0.13614289f, -0.24623156f, -0.13548686f, -0.19498095f, 0.11835448f, 0.23713645f, 
    -0.47630805f, -0.58256602f, 0.11537145f, 0.23802677f, -0.12388198f, -0.67565960f, -0.45491457f, 0.34728792f, 
    0.25912857f, -0.47515142f, -0.04647378f, -0.23051032f, -0.12323672f, -0.18325029f, -0.04892020f, 0.54872543f, 
    0.21417247f, -0.14613743f, -0.41577503f, 0.06580338f, -0.03935333f, -0.15792085f, -0.03631540f, -0.47162339f, 
    -0.08194579f, -0.68957847f, -0.78819215f, -0.22569969f, 0.04441540f, 0.30044076f, 0.61688375f, 0.42641068f, 
    0.37364843f, -0.41363585f, -0.09003849f, -0.17726783f, -0.40443715f, -0.18878274f, -0.04550625f, 0.05460475f, 
    -0.07111467f, 0.24443966f, -0.22739395f, -0.04090939f, 0.16458647f, -0.25940615f, 0.17075309f, 0.25073069f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.11305211f, 0.16486990f, 0.18270545f, 0.17782877f, -0.06833502f, 0.05403700f, 0.01471133f, 0.08167590f, 
    0.28414232f, 0.04207299f, 0.15977629f, 0.21342507f, 0.01458532f, 0.11231552f, 0.24876931f, 0.02554405f, 
    0.17735112f, 0.18524176f, 0.20886295f, 0.24748236f, 0.08584387f, -0.02917132f, 0.45694205f, 0.32106468f, 
    -0.00325915f, -0.01296492f, 0.07818129f, -0.03187485f, 0.17547709f, 0.10283983f, 0.13171683f, -0.05139665f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.17833500f, -0.23255873f, 0.23366748f, 0.06401274f, -0.01719402f, 0.02210652f, 0.04397259f, 0.09369309f, 
    0.00591406f, -0.11702099f, -0.06602497f, 0.01527738f, -0.12356415f, 0.02256183f, -0.28073987f, 0.03173056f, 
    -0.02988319f, 0.00326382f, -0.07833114f, 0.03948440f, 0.03685488f, -0.03832444f, -0.13310416f, -0.03506801f, 
    0.07579035f, 0.16179915f, -0.02938185f, 0.06950493f, -0.04677712f, 0.12032939f, -0.00385692f, -0.05872092f, 
    -0.04340046f, -0.07498542f, -0.03637340f, -0.04869250f, 0.15850164f, -0.01047310f, -0.02813922f, 0.19338942f, 
    0.09683478f, -0.00120528f, 0.04533599f, 0.04656539f, -0.12612036f, -0.07155859f, -0.05074749f, 0.07939334f, 
    0.07336467f, 0.25341314f, 0.15701784f, 0.10209746f, 0.02241324f, 0.08880618f, 0.10349351f, 0.08077478f, 
    -0.13945816f, -0.05569285f, 0.12684047f, 0.05053226f, 0.03880999f, 0.02653192f, -0.13433684f, 0.11220144f, 
    0.09781507f, -0.14355658f, 0.04552180f, -0.00833250f, 0.01025567f, 0.04416222f, 0.01852477f, 0.14887632f, 
    0.18573833f, -0.04443709f, -0.04986007f, 0.12208138f, 0.04660613f, -0.21514624f, -0.10489151f, 0.07411284f, 
    0.05244814f, 0.01091900f, -0.00251696f, 0.01406188f, -0.37310636f, -0.06780901f, 0.03520994f, 0.26851559f, 
    -0.02903616f, -0.15340333f, 0.01853964f, -0.01663068f, -0.01577256f, 0.01101235f, 0.11557490f, 0.03231752f, 
    -0.30672935f, 0.18284924f, -0.11916643f, -0.00419437f, 0.02476577f, 0.06824522f, 0.08266408f, -0.11654096f, 
    0.01125336f, 0.00576885f, -0.01347736f, -0.00917193f, 0.09890419f, -0.04559008f, -0.06441146f, 0.19362436f, 
    0.00692115f, 0.08452535f, 0.04462188f, 0.21126528f, -0.02657584f, -0.10784410f, 0.10408085f, 0.09175164f, 
    -0.02589531f, -0.01143964f, 0.05967772f, -0.14174934f, 0.07863689f, -0.05981242f, -0.03680376f, 0.00211567f, 
    0.11210751f, -0.00783226f, -0.02187158f, 0.08718187f, 0.29459175f, 0.13066499f, 0.11666065f, 0.02313926f, 
    0.03827120f, 0.01861527f, -0.05909221f, -0.07244371f, 0.00469802f, 0.05442068f, 0.00974324f, -0.04629865f, 
    -0.10685509f, 0.18380982f, 0.02740365f, 0.04141227f, 0.11636703f, 0.00607743f, 0.09793048f, -0.04415168f, 
    0.13925302f, 0.08499719f, 0.03131770f, 0.05878649f, -0.18118511f, -0.00660421f, 0.02677687f, 0.17440653f, 
    0.02094964f, -0.03740317f, 0.00177512f, 0.06308971f, -0.04731407f, 0.07060215f, 0.18679270f, 0.01919154f, 
    -0.19245583f, 0.20419334f, -0.04958765f, 0.01032208f, 0.03925980f, -0.13852967f, 0.12269726f, 0.07478116f, 
    0.03838669f, -0.02297218f, -0.02423397f, 0.01314027f, 0.06377809f, 0.00466387f, 0.17056006f, -0.00770376f, 
    0.04292315f, -0.01676976f, -0.03066189f, -0.03275710f, -0.01502453f, -0.05220420f, 0.03380005f, 0.08722122f, 
    -0.25826120f, 0.09337720f, -0.12116834f, -0.30423740f, 0.01185949f, -0.04768915f, -0.06834161f, 0.16452192f, 
    0.04585784f, -0.04664877f, 0.08743586f, -0.01770667f, 0.04241808f, -0.10201252f, -0.01228182f, -0.01799634f, 
    0.01964386f, 0.05073546f, 0.03340092f, 0.04227367f, -0.04381160f, 0.02324334f, 0.06840133f, -0.09924650f, 
    0.16083665f, 0.21105067f, -0.12142519f, 0.24975371f, 0.04550359f, 0.09060923f, 0.17782409f, 0.04375258f, 
    0.08892059f, -0.05361742f, 0.02726234f, 0.02241551f, 0.18755791f, 0.32273757f, 0.11019752f, 0.28923175f, 
    0.00845600f, 0.18761390f, -0.04195137f, 0.04217187f, -0.01950060f, 0.02528686f, 0.08115007f, -0.03204357f, 
    0.02362188f, -0.16745783f, -0.06356089f, 0.10833143f, -0.02876564f, -0.04870494f, -0.01151392f, 0.03172173f, 
    0.06391432f, -0.05000535f, 0.16459298f, -0.01245376f, -0.42657259f, 0.05695199f, -0.03154641f, -0.21752973f, 
    0.09478527f, -0.05383921f, 0.00934414f, -0.18867415f, 0.10353824f, -0.04072298f, -0.00875164f, -0.04831346f, 
    0.19912113f, -0.12356278f, 0.03337433f, 0.19605984f, 0.16999112f, 0.09640014f, 0.07746140f, -0.08949557f, 
    0.02505573f, 0.09260110f, -0.01028522f, -0.09441794f, 0.37439537f, 0.14130887f, -0.07605086f, 0.27105996f, 
    0.04940212f, 0.01021158f, 0.03487246f, 0.03449972f, -0.00632052f, 0.10357038f, -0.05646843f, 0.08689480f, 
    0.14579928f, -0.18867300f, -0.00177103f, 0.03549665f, -0.08468401f, -0.03514146f, 0.00624343f, -0.03777989f, 
    -0.00317047f, -0.06095601f, -0.03507626f, 0.06604250f, -0.14860351f, 0.15135410f, -0.06814516f, -0.22925833f, 
    0.11565309f, -0.01589893f, -0.07669090f, -0.03339829f, -0.07007491f, 0.04992343f, -0.02139048f, 0.02338268f, 
    0.41789469f, 0.26299912f, 0.01902352f, -0.01690184f, 0.16640200f, 0.14081472f, 0.07467148f, -0.07896447f, 
    -0.11557543f, 0.00001894f, -0.00416531f, 0.02778101f, -0.12819518f, 0.06398840f, -0.05328424f, -0.23668185f, 
    0.00357984f, 0.04672425f, 0.07575839f, 0.04567650f, -0.00926333f, -0.03618703f, -0.02448092f, 0.04112692f, 
    0.17013903f, 0.06028578f, -0.21358630f, -0.28587332f, 0.08861781f, -0.06763876f, 0.08912437f, -0.03737481f, 
    0.01065845f, 0.00413277f, 0.04172605f, 0.08895246f, -0.36676192f, 0.20968582f, -0.03590802f, -0.15681145f, 
    -0.01939351f, -0.06511548f, 0.00008568f, 0.01273176f, -0.00513569f, -0.06152981f, -0.06027054f, 0.02526624f, 
    0.17539991f, 0.17154199f, -0.22991729f, 0.14890596f, -0.08157937f, 0.03280782f, -0.03267078f, 0.08395019f, 
    -0.01808140f, -0.00307982f, 0.01149216f, 0.06630892f, -0.17220697f, -0.18750918f, 0.25102052f, 0.11824957f, 
    0.06629514f, 0.09467454f, -0.00573081f, 0.05676807f, 0.08298470f, 0.08551835f, 0.16678664f, -0.00275161f, 
    -0.20366065f, -0.08084155f, 0.32572836f, 0.14732654f, 0.00189423f, -0.04476621f, -0.07747990f, 0.04715169f, 
    -0.07495947f, -0.07522782f, 0.05759919f, 0.00939517f, 0.39219606f, -0.01253229f, -0.03045966f, -0.04393655f, 
    -0.09738164f, -0.03172417f, -0.00018285f, 0.02361236f, -0.00878162f, -0.03906585f, 0.03684136f, -0.04090831f, 
    -0.17603496f, 0.06260397f, 0.05927182f, 0.06277401f, 0.07600968f, -0.04540965f, -0.03532132f, 0.03296506f, 
    -0.04657095f, 0.11220563f, -0.08391129f, 0.09419804f, -0.10012683f, -0.05794180f, -0.04475237f, 0.05648849f, 
    0.09045190f, -0.05794955f, 0.01542710f, 0.08668576f, 0.05383862f, -0.00029419f, 0.02874045f, -0.02488055f, 
    0.18142721f, 0.05710304f, -0.03417793f, 0.03174509f, 0.22757585f, 0.03507352f, 0.06879888f, 0.00822665f, 
    0.06058945f, 0.06109695f, -0.07094970f, 0.11573282f, -0.52549142f, 0.32888809f, -0.14963247f, -0.19404399f, 
    0.18372136f, 0.05156812f, 0.05965231f, -0.16512482f, -0.06316079f, 0.10937160f, 0.06977474f, -0.09464842f, 
    -0.10302418f, -0.06628776f, 0.08400203f, -0.17241636f, 0.05886562f, -0.07959348f, 0.08674940f, 0.00949378f, 
    -0.02348529f, -0.07256176f, -0.05860394f, 0.03930344f, -0.02677774f, 0.02753277f, 0.26901409f, 0.19157217f, 
    0.03601672f, -0.05330873f, -0.00047318f, 0.02770255f, 0.07645241f, -0.02576951f, 0.00969610f, -0.04318785f, 
    0.00960661f, -0.05706046f, 0.06089228f, 0.02660550f, -0.09437769f, -0.06183882f, -0.03803458f, 0.06789657f, 
    -0.03310044f, 0.04429940f, -0.13416888f, -0.06069531f, -0.16420217f, 0.05110422f, 0.30492586f, 0.34139547f, 
    -0.06126134f, -0.00691521f, -0.00334394f, 0.02016682f, -0.10828549f, -0.00419395f, -0.08641817f, 0.13955846f, 
    0.18579388f, 0.06174657f, 0.15248598f, 0.04683280f, -0.13075614f, 0.05318842f, 0.04249749f, -0.06572159f, 
    -0.03121287f, 0.10094415f, -0.11098004f, 0.09464459f, 0.03149044f, -0.01575938f, 0.05959167f, 0.26636606f, 
    0.07831894f, -0.03066270f, 0.01910888f, 0.06410493f, 0.08165453f, 0.03012437f, 0.09088273f, 0.01402139f, 
    0.13007082f, 0.06560197f, -0.14083791f, 0.04314273f, 0.12588069f, 0.02360819f, -0.09251041f, -0.03017089f, 
    0.08185951f, 0.06007180f, 0.00700315f, -0.05311660f, -0.05033555f, -0.01223682f, 0.29415372f, 0.04397689f, 
    -0.13907613f, 0.00160151f, 0.05683434f, 0.04196575f, -0.01457758f, -0.04333769f, 0.04924449f, 0.04757863f, 
    -0.49824813f, -0.00577670f, 0.01089561f, 0.14432880f, 0.02162208f, -0.11935348f, 0.02923929f, -0.13862266f, 
    -0.03221151f, 0.01954661f, 0.02749562f, -0.00387054f, -0.02591936f, -0.11011019f, -0.02059254f, 0.01912120f, 
    -0.11933942f, -0.04545921f, -0.06971532f, 0.08989228f, -0.01692846f, -0.00122431f, 0.06366219f, 0.00631859f, 
    -0.13335241f, -0.18214644f, 0.15309998f, 0.02737763f, -0.11532047f, 0.04363864f, -0.01057775f, -0.04132592f, 
    0.03226800f, -0.06080783f, 0.04354667f, -0.09439255f, -0.25200143f, 0.07033178f, 0.28999504f, -0.11793380f, 
    -0.00886334f, 0.00706506f, 0.02977093f, -0.02349956f, 0.09786002f, 0.01587685f, 0.02530443f, 0.03000219f, 
    -0.03567792f, -0.09838467f, 0.01603742f, 0.23130488f, 0.13683946f, 0.03340081f, 0.04301361f, 0.03803859f, 
    0.07940894f, -0.03615338f, 0.03490788f, -0.02837316f, 0.46254024f, -0.02354496f, 0.05620738f, 0.06893659f, 
    0.02915759f, -0.00989284f, 0.01713944f, 0.08626386f, -0.00608621f, -0.02910702f, 0.03273847f, -0.01953720f, 
    -0.25860828f, 0.21748322f, -0.02233903f, -0.25283054f, 0.08135518f, -0.00408820f, -0.01571078f, -0.06034983f, 
    -0.00874323f, -0.08462992f, 0.01784832f, -0.03178510f, 0.04968184f, -0.05338692f, 0.13041119f, 0.22858684f, 
    -0.08279067f, -0.03658428f, 0.07854622f, -0.00489716f, 0.11165585f, -0.04874158f, 0.03481722f, 0.01665743f, 
    -0.03476169f, -0.12516673f, 0.03068672f, -0.03602635f, 0.02504911f, 0.06610090f, 0.06419654f, -0.05453364f, 
    -0.04457032f, 0.12232982f, 0.04122421f, 0.04321640f, 0.13814709f, -0.04725691f, 0.04105565f, 0.42413130f, 
    0.08281274f, -0.04815511f, 0.05876932f, 0.15298417f, 0.01780925f, 0.01204775f, -0.00640667f, 0.00592235f, 
    -0.02760019f, 0.00483321f, 0.04726507f, 0.15570444f, -0.11050066f, -0.13069119f, -0.01512810f, -0.04476178f, 
    0.10850355f, 0.04300638f, 0.03697710f, 0.11105648f, -0.08186010f, 0.06132571f, -0.05881584f, 0.04842814f, 
    -0.07746810f, 0.02754504f, -0.00223311f, -0.02559416f, 0.00280279f, 0.01208775f, -0.05149961f, -0.04267088f, 
    0.08471307f, 0.07131707f, -0.08391324f, 0.26977527f, 0.11345483f, -0.03251820f, 0.07380006f, 0.12618896f, 
    0.06084133f, 0.11645545f, 0.07763276f, 0.02864815f, -0.08709571f, -0.03734675f, 0.09131709f, 0.28352609f, 
    -0.10233922f, 0.00990529f, 0.11548371f, -0.02684062f, -0.02007219f, -0.03402556f, -0.00995615f, -0.02471970f, 
    -0.07961758f, 0.25519669f, -0.03699567f, 0.18375763f, -0.03118570f, 0.03685126f, 0.10326327f, 0.01368642f, 
    -0.06554599f, 0.08255124f, 0.01226697f, -0.03196078f, 0.14366031f, 0.04153264f, 0.15532596f, -0.00444424f, 
    -0.13986467f, 0.03124667f, 0.12958594f, -0.00160023f, -0.08933330f, -0.01361814f, 0.01397726f, 0.00740070f, 
    0.04352438f, 0.04969429f, 0.14557794f, -0.02156348f, 0.08864959f, -0.07152408f, -0.04349698f, 0.12010932f, 
    0.03010824f, -0.01673939f, 0.02817616f, 0.00508694f, 0.08532811f, -0.05533253f, 0.00605580f, -0.17247026f, 
    0.17529744f, 0.07879182f, 0.09013855f, -0.05808154f, 0.00286612f, -0.04590367f, 0.05843405f, 0.08791937f, 
    0.06223090f, -0.04873939f, 0.01520354f, 0.03286197f, 0.08867958f, -0.08348607f, 0.00494535f, 0.06167275f, 
    0.06925193f, 0.05466477f, 0.00271819f, 0.11498836f, -0.12851453f, 0.13641036f, 0.21611443f, -0.12973681f, 
    -0.08916132f, -0.00037938f, 0.04631786f, -0.03718273f, -0.11670670f, -0.05726955f, 0.17689946f, -0.05241809f, 
    -0.08522071f, -0.04863563f, -0.06541864f, 0.00736258f, -0.07540113f, -0.05344590f, -0.10876611f, -0.01768019f, 
    0.00038495f, 0.10439540f, -0.02137528f, 0.13140211f, -0.11163240f, 0.06904520f, 0.18350852f, 0.18618520f, 
    0.01844320f, -0.16262834f, -0.04785544f, -0.05515622f, 0.02708270f, 0.11960366f, 0.04896649f, -0.01063308f, 
    -0.19528891f, -0.13854524f, -0.02170203f, -0.18997580f, 0.02865647f, 0.08197126f, -0.10270328f, 0.04215346f, 
    0.08140273f, 0.03793421f, 0.02398218f, -0.00541656f, 0.26264772f, -0.08979696f, -0.00849404f, 0.02112196f, 
    0.13065946f, 0.07736637f, -0.00711077f, -0.04673288f, 0.02385386f, 0.01112351f, 0.09385713f, -0.08561314f, 
    0.12541090f, 0.28915712f, -0.19584323f, 0.07517183f, -0.06284422f, 0.02703419f, 0.08460303f, -0.00127105f, 
    -0.05702241f, 0.02416410f, 0.00919791f, 0.04818311f, -0.04771990f, 0.01629742f, 0.01730877f, -0.17295484f, 
    0.08716109f, 0.15699433f, 0.01087766f, 0.07546607f, 0.05652963f, 0.00339829f, -0.03090172f, -0.10766006f, 
    0.05970798f, 0.01247864f, 0.09393122f, 0.01331075f, -0.06699634f, -0.08831730f, -0.01051303f, 0.01883344f, 
    -0.07013475f, -0.06739905f, -0.02389821f, -0.01069972f, -0.08950349f, 0.03615784f, 0.12583691f, -0.06279127f, 
    0.00371882f, -0.22225162f, 0.00823413f, 0.01121173f, -0.02596113f, 0.00324566f, -0.03339998f, -0.07554258f, 
    0.19921586f, 0.11039425f, -0.01791890f, 0.14826123f, -0.02993988f, -0.00223756f, -0.08355696f, -0.09441612f, 
    0.00440305f, 0.00264877f, -0.04569340f, 0.04471882f, -0.08568477f, -0.12718731f, 0.10137589f, 0.02284505f, 
    -0.02329120f, 0.03588054f, 0.08457832f, 0.00901463f, -0.23073661f, 0.07479410f, 0.02847444f, 0.21416622f, 
    -0.16659799f, -0.08383365f, -0.16137633f, -0.23447521f, 0.00355146f, 0.02395034f, 0.00783608f, 0.00228905f, 
    0.02136229f, -0.08421720f, 0.00613309f, 0.03362639f, 0.00349849f, 0.08255797f, 0.05059389f, 0.02345435f, 
    0.05589360f, 0.00602457f, 0.00210073f, -0.01635369f, -0.04597351f, -0.04026350f, -0.03216026f, -0.00496442f, 
    -0.06888296f, 0.04140102f, 0.09009562f, -0.05244082f, -0.11773520f, 0.07258607f, -0.08898496f, 0.05631642f, 
    0.05500826f, 0.00643098f, 0.11410456f, -0.04482448f, 0.00929177f, 0.02298242f, -0.43750152f, 0.00979399f, 
    0.09686086f, 0.04027449f, 0.03449511f, 0.09707232f, -0.01906206f, -0.16795804f, -0.01762726f, 0.02541994f, 
    -0.03893119f, -0.04258820f, 0.02600947f, 0.07266680f, 0.10540950f, -0.14162019f, 0.01063318f, -0.02459569f, 
    0.00989193f, 0.05685791f, -0.07043123f, 0.01192883f, 0.03400732f, 0.04716832f, -0.06721917f, -0.03078088f, 
    0.10362095f, 0.02254732f, 0.06793755f, 0.07512666f, -0.02435380f, -0.12496892f, -0.04766355f, 0.15116787f, 
    -0.19819316f, 0.08362650f, 0.16875429f, -0.10040395f, -0.13063280f, -0.01799458f, -0.08107191f, 0.00999268f, 
    0.02030617f, 0.10861444f, 0.13060173f, -0.03743009f, 0.15462606f, 0.05261659f, 0.14541264f, -0.34732756f, 
    -0.14111830f, 0.01493196f, -0.09393405f, 0.11571283f, 0.12110325f, -0.02725112f, 0.07254118f, -0.00780138f, 
    -0.16839337f, 0.13357237f, -0.11161075f, -0.08358273f, 0.00892162f, -0.09734525f, -0.11189671f, 0.07996098f, 
    0.09989724f, 0.01924423f, 0.04837528f, -0.06717545f, 0.22427636f, 0.01034375f, -0.05648825f, 0.03615889f, 
    0.06407790f, 0.04484516f, 0.06895159f, -0.00493129f, -0.10626855f, -0.00498975f, 0.07003715f, 0.21920274f, 
    -0.08950520f, 0.26756737f, -0.08434684f, -0.23172918f, -0.00507214f, 0.01915271f, -0.04528117f, -0.03353146f, 
    0.05821859f, 0.09032404f, 0.07644937f, 0.08759451f, -0.14321464f, 0.08832757f, 0.07815222f, 0.02953175f, 
    0.06905606f, -0.14790781f, 0.21169685f, 0.09847982f, -0.02722398f, -0.11144230f, -0.04015617f, 0.09130950f, 
    -0.09762939f, 0.14844653f, 0.05431262f, 0.13515446f, -0.01250270f, -0.06285653f, -0.04052879f, 0.04581149f, 
    0.00132372f, 0.05325700f, 0.03175791f, 0.08503678f, 0.14083995f, 0.12169904f, 0.13646865f, 0.14925475f, 
    -0.04471183f, 0.08105273f, -0.00627762f, 0.02570520f, 0.02529961f, -0.13107586f, 0.13324668f, -0.00944662f, 
    -0.21217127f, 0.09700421f, 0.01243667f, -0.09872787f, 0.03541465f, -0.00402945f, 0.00859355f, -0.04607917f, 
    0.02437088f, 0.06784501f, 0.05980331f, 0.11909445f, -0.24071249f, -0.22485341f, 0.01119327f, 0.24103175f, 
    -0.02136924f, 0.05749571f, 0.07626496f, -0.06653552f, 0.09700552f, 0.07020682f, -0.03116918f, -0.02477369f, 
    0.17193094f, 0.02815127f, 0.04119960f, 0.24050105f, 0.01061616f, -0.01081824f, -0.03722657f, -0.01464350f, 
    0.08182144f, 0.04746777f, 0.07529300f, -0.06193915f, 0.20176667f, -0.04752178f, 0.10960086f, 0.04821390f, 
    -0.04369465f, 0.00711251f, -0.04968575f, -0.09724735f, -0.02291011f, -0.07817509f, 0.16512871f, 0.00889983f, 
    -0.08007459f, 0.23499736f, 0.06620665f, -0.27515650f, 0.05247995f, -0.05170228f, -0.05300656f, -0.08184554f, 
    0.08214369f, -0.11800750f, 0.08578428f, 0.02948564f, -0.10535733f, -0.01690591f, -0.05907459f, -0.17431641f, 
    0.03432133f, 0.13220362f, -0.00671934f, 0.09579506f, -0.00741619f, -0.06881027f, -0.01431460f, 0.14551648f, 
    0.02423864f, -0.01090585f, -0.02582861f, 0.00164304f, 0.03598103f, 0.03820621f, 0.00943593f, 0.04054467f, 
    0.00937668f, -0.04921768f, -0.02557303f, -0.00022019f, -0.01962115f, -0.03141723f, -0.04376781f, -0.00450359f, 
    -0.02368222f, -0.02925257f, -0.04412562f, -0.02349443f, -0.03302079f, -0.04914934f, -0.01507602f, 0.03645553f, 
    0.00032659f, 0.03073621f, 0.02417179f, -0.02737457f, -0.02180124f, -0.01913670f, 0.01324778f, 0.02719367f, 
    -0.05182230f, 0.02215455f, 0.01316658f, 0.02969534f, 0.03125548f, -0.05825936f, -0.02978675f, -0.02606819f, 
    -0.03508647f, 0.04173056f, 0.02070579f, 0.03863704f, 0.01809775f, 0.02481448f, -0.01354316f, -0.03100291f, 
    -0.06151694f, -0.03654125f, 0.02984135f, -0.03389229f, -0.03962451f, -0.04189776f, -0.00970555f, 0.02166904f, 
    0.01185665f, -0.02496274f, 0.02102631f, 0.01711679f, -0.02380468f, 0.03713212f, 0.00641098f, -0.04369274f, 
    0.01756543f, -0.00729439f, -0.03455604f, -0.03953946f, -0.03949739f, -0.02368205f, 0.01134011f, -0.01077419f, 
    0.00140815f, -0.02569321f, -0.02616395f, -0.03758498f, 0.01149584f, -0.00071866f, -0.03481715f, 0.01275180f, 
    0.03016399f, -0.03523833f, -0.02094114f, -0.01227516f, -0.02071765f, -0.00557256f, -0.04441194f, -0.04045097f, 
    -0.03538235f, -0.01273230f, -0.03849745f, -0.00468729f, 0.01942396f, -0.02232995f, -0.05616650f, -0.02152886f, 
    0.00482560f, 0.02817715f, -0.02780509f, -0.00387600f, -0.01909331f, 0.04070975f, -0.02066314f, -0.00697211f, 
    -0.00468770f, 0.02040956f, -0.01295062f, -0.00316203f, -0.00431656f, 0.01692410f, 0.00986200f, 0.03692956f, 
    0.01783122f, -0.03674540f, 0.01629691f, -0.04811185f, 0.02807466f, -0.01486709f, -0.03819629f, -0.01347018f, 
    0.03959948f, -0.03859479f, 0.01557574f, 0.03056618f, 0.00172954f, -0.05130572f, -0.02091866f, -0.05230414f, 
    0.00896942f, -0.02615844f, 0.01773298f, 0.04558011f, -0.05497891f, -0.03641256f, 0.03301675f, 0.01913464f, 
    -0.03151545f, -0.00487195f, 0.02530374f, -0.02882772f, 0.04352482f, -0.03226782f, 0.02160900f, 0.02841054f, 
    -0.05202681f, 0.00257368f, -0.00895125f, 0.00912956f, -0.00863113f, 0.03558818f, -0.02021648f, 0.00321248f, 
    0.03249983f, -0.01054290f, -0.00212675f, -0.03833758f, -0.02292029f, -0.04306471f, 0.01616328f, -0.03868603f, 
    0.02747453f, -0.03954539f, 0.00901700f, -0.03106641f, -0.00847746f, 0.02377082f, 0.02421426f, -0.01893903f, 
    0.00562959f, -0.02481728f, -0.01950790f, -0.05504927f, 0.00764979f, 0.03841730f, 0.04182871f, 0.00492828f, 
    0.01184034f, -0.03239585f, 0.00394395f, -0.00819245f, 0.03529384f, 0.00620333f, -0.02765350f, 0.03697505f, 
    0.04457730f, 0.03935050f, -0.02187583f, -0.01329681f, -0.02403973f, 0.05317846f, 0.03475115f, -0.04675457f, 
    0.02169948f, 0.04507830f, 0.04404625f, 0.01044840f, -0.01459129f, 0.03284800f, -0.01695222f, -0.04294101f, 
    0.01564121f, 0.01257033f, -0.00925862f, 0.00927299f, 0.00227312f, 0.03411628f, 0.03455874f, -0.04646728f, 
    0.04356981f, 0.01159416f, 0.03091419f, 0.02410095f, -0.03483495f, -0.00990767f, -0.04341407f, -0.01395302f, 
    0.00036362f, -0.02196314f, -0.03124807f, 0.01239815f, 0.04769505f, -0.02400463f, -0.00414253f, -0.05893208f, 
    -0.00952156f, 0.01422812f, 0.00753803f, 0.01731262f, 0.00804703f, -0.00089942f, -0.04203219f, 0.01621640f, 
    -0.03796478f, -0.02493066f, 0.02063671f, 0.04863252f, 0.02784034f, -0.03597121f, 0.03102497f, 0.00421680f, 
    0.04663477f, -0.04081948f, 0.04750174f, 0.01119814f, -0.02229941f, -0.01344320f, -0.02289335f, 0.02906036f, 
    0.03238931f, -0.05346396f, 0.01066644f, -0.03192406f, -0.03457106f, -0.04350255f, 0.03161182f, 0.03821340f, 
    -0.00917663f, 0.00191847f, 0.04273149f, -0.06074480f, 0.00831894f, 0.03786248f, -0.00812728f, 0.00760696f, 
    0.01860214f, -0.03809791f, 0.01156530f, 0.03144499f, 0.02343272f, 0.03219648f, -0.00755320f, -0.01411221f, 
    0.04616570f, -0.03083928f, -0.03320430f, -0.03843413f, -0.01119381f, -0.00803754f, -0.01271329f, -0.05720803f, 
    -0.02224736f, -0.00422762f, -0.01675665f, 0.00230145f, 0.00340197f, -0.04388629f, 0.04459513f, 0.00592781f, 
    -0.05440488f, 0.04208792f, -0.04118120f, 0.02488775f, -0.05568045f, -0.01185966f, -0.04540022f, -0.00816595f, 
    0.04719353f, -0.04304757f, 0.03179467f, 0.01138531f, -0.02210658f, 0.03808505f, -0.01298565f, -0.01386844f, 
    -0.03989180f, -0.00907050f, -0.00172425f, 0.04479463f, -0.03762361f, -0.00020727f, -0.01563390f, 0.03384802f, 
    -0.00049142f, -0.03143418f, -0.04382145f, -0.00579062f, 0.04127400f, -0.01841117f, 0.00306336f, -0.02062084f, 
    0.03804796f, -0.02307181f, -0.00919145f, -0.01420781f, -0.04093864f, 0.03753413f, 0.02650849f, 0.02016592f, 
    -0.00452019f, -0.01201618f, -0.03555720f, -0.00167141f, 0.02272885f, 0.02111880f, -0.02457772f, -0.00486179f, 
    0.02693077f, -0.02366844f, 0.02321584f, -0.05264015f, 0.03059280f, 0.02083671f, -0.01637887f, 0.02296529f, 
    -0.03234058f, -0.02968562f, 0.04166922f, 0.01678419f, -0.05014445f, -0.00155097f, -0.05174387f, -0.03991749f, 
    -0.01922842f, 0.01279537f, 0.02450896f, 0.02053587f, -0.03682164f, 0.00600240f, -0.04667283f, 0.02296245f, 
    -0.02096867f, -0.02796038f, -0.03736144f, -0.02448014f, -0.00231698f, -0.00948585f, -0.02596530f, -0.03846685f, 
    0.02777224f, -0.01617693f, 0.03566125f, -0.00991855f, 0.04351185f, -0.03445349f, -0.00253737f, -0.02990768f, 
    0.03289876f, -0.02897321f, -0.04801269f, 0.02090682f, 0.04000095f, -0.00127562f, -0.00017342f, 0.01088741f, 
    -0.28466722f, -0.09106138f, -0.04296621f, 0.02477626f, 0.02072599f, -0.03168430f, -0.08439389f, -0.05827640f, 
    -0.03759303f, 0.03443075f, 0.10548443f, 0.15458147f, 0.39478821f, -0.14513503f, 0.04244180f, 0.13018203f, 
    -0.08489669f, -0.03298563f, 0.00373975f, -0.08674345f, -0.05537803f, -0.01237829f, 0.03177033f, 0.01366691f, 
    -0.09737570f, 0.05429389f, -0.08997106f, -0.04727294f, 0.00696965f, -0.01223192f, -0.00970657f, 0.09387779f, 
    -0.07201623f, 0.06335246f, 0.05987520f, 0.02564149f, -0.17345099f, -0.10824105f, -0.14913878f, -0.25569883f, 
    0.08759605f, 0.06935275f, 0.03866689f, 0.11074623f, -0.10050609f, -0.02278964f, -0.17498562f, 0.03605656f, 
    -0.11459165f, -0.21623230f, -0.17781262f, 0.01659794f, 0.16704588f, 0.04737923f, -0.02192811f, 0.14217977f, 
    -0.12586963f, -0.02040082f, 0.03368398f, 0.08329365f, -0.50258994f, -0.01803974f, -0.07104182f, -0.10649123f, 
    0.13280286f, 0.11718661f, 0.03346137f, -0.08841811f, 0.07017393f, 0.06789818f, 0.04547836f, 0.04509346f, 
    -0.09948883f, 0.10122073f, -0.06941997f, -0.12841786f, 0.05238532f, 0.04180994f, 0.02256271f, -0.07285890f, 
    0.02709227f, -0.04377467f, -0.04428770f, 0.02223237f, 0.10198248f, -0.00760042f, 0.01580316f, -0.10164706f, 
    0.16687265f, 0.00037176f, 0.08626871f, -0.06399696f, 0.02042531f, -0.06668756f, -0.15424234f, -0.00767995f, 
    0.19530803f, 0.03964807f, 0.22687900f, -0.02502281f, 0.01914048f, -0.08964089f, 0.07981191f, 0.07360159f, 
    -0.07203916f, -0.01626434f, -0.07689709f, 0.03053003f, -0.37748978f, -0.18434513f, 0.17124505f, -0.02402390f, 
    0.00265779f, 0.00868077f, -0.09647784f, -0.07435782f, 0.10835745f, 0.00933589f, -0.01614133f, -0.05943086f, 
    0.22750632f, -0.06508794f, 0.20443448f, 0.26836938f, -0.01054362f, 0.04239777f, 0.01259159f, -0.04651239f, 
    0.01600503f, 0.08261554f, 0.03384332f, 0.12694985f, -0.15433067f, -0.17897911f, -0.00275592f, -0.00314356f, 
    0.12339830f, -0.12738882f, 0.03585382f, 0.05446670f, -0.00305664f, -0.00207906f, 0.01927206f, 0.03957381f, 
    -0.03992363f, -0.13317634f, -0.07454532f, 0.04803666f, 0.06110700f, 0.08232556f, 0.03685694f, 0.03869947f, 
    -0.01504071f, -0.03020252f, 0.03547898f, 0.05958318f, -0.05306868f, 0.17728195f, 0.07266498f, -0.32932311f, 
    -0.09705087f, -0.03281567f, -0.04868148f, 0.02860935f, 0.01071024f, -0.02945852f, 0.01211785f, 0.02077946f, 
    -0.44306481f, -0.11164622f, 0.03270907f, 0.01700461f, -0.08214511f, -0.05797413f, -0.03894686f, 0.02898278f, 
    -0.02810245f, -0.00707301f, -0.07182486f, 0.02516240f, -0.33612832f, 0.05169421f, 0.35348469f, 0.05676427f, 
    0.00862131f, 0.09810980f, 0.10074406f, -0.01190750f, 0.11229721f, -0.03628082f, -0.05596086f, -0.04960759f, 
    -0.14656240f, -0.10363474f, 0.29227555f, 0.10344296f, -0.06604508f, -0.10194062f, -0.01376664f, -0.04010459f, 
    0.08027934f, -0.00045136f, -0.02347329f, -0.03023970f, -0.03332829f, 0.09815904f, 0.14755550f, 0.02404667f, 
    0.09050325f, 0.04881891f, -0.00693821f, -0.07821904f, 0.15793322f, 0.17325537f, -0.01115266f, -0.00388443f, 
    -0.24485606f, -0.17977260f, 0.16159824f, -0.04743057f, 0.10814707f, -0.03212902f, -0.01306127f, 0.01526700f, 
    0.00706051f, 0.01102439f, -0.01145145f, -0.03972757f, -0.07518337f, -0.04653639f, -0.01755268f, -0.12408759f, 
    -0.04641835f, -0.00123173f, 0.04358280f, 0.05367567f, 0.08043613f, -0.10336357f, 0.04973340f, 0.02949971f, 
    -0.22468844f, -0.04523628f, 0.00061085f, -0.23593548f, 0.05994601f, 0.04750618f, 0.03539038f, -0.07207062f, 
    0.01121428f, -0.11458229f, -0.02595701f, -0.00293657f, 0.33965063f, 0.21398616f, 0.19316059f, 0.21248569f, 
    -0.05753575f, 0.00370097f, 0.08931595f, 0.01129068f, 0.16547820f, 0.06180583f, 0.08490594f, -0.00439651f, 
    0.11023301f, 0.04272418f, -0.05817323f, -0.07857946f, 0.04553939f, 0.06778464f, -0.01123595f, -0.00529782f, 
    0.00041248f, 0.03259222f, -0.04982327f, 0.02566258f, 0.00085260f, -0.03623187f, 0.01221350f, -0.01654631f, 
    0.04013758f, 0.00578465f, 0.01485114f, -0.05959329f, 0.01118095f, -0.01843353f, -0.08084422f, 0.03634226f, 
    0.12746382f, -0.02760908f, -0.18478969f, 0.07338447f, 0.03782915f, -0.06085264f, -0.06832200f, -0.02103497f, 
    0.08713794f, 0.05273969f, -0.01701809f, 0.00915073f, 0.13058333f, 0.26011229f, -0.02941288f, 0.16592377f, 
    -0.00455600f, -0.05557172f, 0.07557839f, -0.01219673f, 0.06395549f, 0.05294459f, 0.13580561f, -0.02781045f, 
    -0.16876696f, -0.07436611f, 0.09051972f, 0.01364667f, 0.09718384f, -0.07462896f, 0.07576250f, 0.24901363f, 
    -0.02735111f, 0.07902943f, 0.07585875f, 0.04472173f, 0.13380799f, 0.15272374f, 0.20453449f, 0.28724620f, 
    -0.00416022f, -0.04391494f, 0.01817728f, 0.02276687f, -0.05204545f, 0.04751494f, -0.03452291f, 0.11267794f, 
    0.32787675f, 0.49107906f, -0.05949534f, 0.11945040f, 0.07794917f, -0.05795118f, 0.02712535f, 0.06123285f, 
    0.02431043f, 0.06954421f, 0.02556517f, 0.04757782f, 0.51548427f, 0.28145644f, 0.15395038f, 0.22990571f, 
    0.00127693f, -0.03730527f, 0.03782178f, -0.02376184f, -0.06926179f, 0.14345437f, 0.03702784f, 0.06812338f, 
    -0.15373369f, -0.01037563f, 0.08402164f, -0.09381105f, 0.07516175f, -0.02013633f, 0.13152437f, 0.00715684f, 
    -0.01668407f, -0.10228174f, -0.01653546f, 0.02826067f, 0.05043266f, -0.21110441f, -0.01132690f, -0.12166588f, 
    0.11604340f, -0.03206957f, 0.03274307f, 0.11626612f, -0.03078546f, -0.07820763f, 0.08268572f, 0.09948935f, 
    0.35865098f, 0.09304003f, -0.07437416f, 0.13343383f, -0.02232697f, 0.01547173f, -0.07526834f, 0.14368537f, 
    0.01488649f, -0.06529649f, -0.06029380f, -0.00945103f, 0.13070513f, 0.17287639f, -0.14952262f, -0.14186716f, 
    0.16806871f, 0.08190953f, -0.03951425f, -0.02904753f, 0.05751652f, -0.10407006f, 0.06241376f, -0.05452129f, 
    0.01639581f, -0.26289016f, 0.15750735f, -0.01760752f, 0.03538778f, 0.03447405f, 0.04145817f, -0.11033603f, 
    0.15857381f, 0.03988997f, -0.04935289f, -0.13306813f, -0.06917756f, 0.03850916f, -0.00508950f, 0.19701813f, 
    0.00914712f, -0.04308037f, 0.04256766f, 0.01008608f, 0.15297341f, 0.07904507f, 0.03627568f, 0.02064815f, 
    0.17157118f, -0.01300811f, -0.00378308f, 0.10515980f, 0.03652440f, 0.08677872f, 0.05880268f, 0.14591156f, 
    0.13609400f, -0.09349099f, -0.09393431f, -0.09674302f, -0.09233306f, 0.34104574f, -0.12292231f, -0.01403668f, 
    0.17722327f, 0.05489499f, 0.04120298f, -0.03928853f, 0.01025772f, 0.07362307f, 0.04416960f, -0.14661856f, 
    0.19653055f, -0.01488781f, 0.25275433f, -0.17966691f, -0.08310475f, 0.00765024f, 0.02801071f, 0.11321153f, 
    0.01259392f, -0.00520672f, -0.02102291f, -0.02282862f, 0.40733552f, -0.21131782f, 0.23703443f, 0.07923817f, 
    -0.05560339f, 0.02272957f, -0.07996123f, 0.05745517f, 0.01241249f, 0.01238506f, 0.18911061f, 0.08893742f, 
    -0.00412837f, 0.09708574f, -0.12413532f, -0.12315649f, 0.07495413f, -0.01431865f, -0.03298054f, -0.03407537f, 
    0.04410574f, -0.02951431f, -0.09267769f, -0.14345925f, 0.02324432f, 0.03115960f, -0.00635859f, 0.19906974f, 
    -0.03706864f, 0.02742146f, 0.12523457f, 0.08784826f, -0.11615926f, 0.01703098f, -0.04562173f, 0.09280386f, 
    0.22797307f, 0.00036504f, -0.18921287f, -0.18027490f, -0.13732223f, 0.10273149f, 0.09805112f, 0.05478462f, 
    0.01316867f, 0.08182560f, -0.00494614f, -0.01497715f, 0.11363766f, 0.10536229f, -0.06699020f, 0.19423622f, 
    -0.03633226f, -0.01588449f, 0.07083574f, -0.00700701f, 0.06696659f, 0.09981578f, -0.08045663f, 0.00507496f, 
    0.21557939f, 0.00659756f, 0.18596041f, -0.05664538f, 0.04828217f, 0.10912000f, 0.08937280f, -0.06630862f, 
    0.04274586f, -0.08559638f, 0.03060953f, -0.10987918f, -0.29280686f, -0.13796256f, 0.18869720f, 0.21727981f, 
    0.02381768f, 0.08597810f, 0.00894585f, 0.07363889f, -0.04915515f, -0.02839557f, -0.01763667f, 0.00750227f, 
    -0.00207931f, -0.10102879f, -0.14979053f, 0.10996700f, 0.06630537f, -0.02516472f, 0.14266667f, -0.05761893f, 
    -0.07003462f, 0.09665902f, 0.08307250f, -0.00383427f, 0.42714006f, 0.12076358f, -0.00914345f, -0.14177491f, 
    -0.07973326f, -0.00006670f, -0.13979293f, -0.07122659f, -0.10156762f, -0.05825897f, -0.00650806f, 0.00714669f, 
    0.02756266f, -0.08745484f, 0.07585695f, -0.06453113f, 0.02830544f, -0.12908368f, 0.05193308f, -0.00272696f, 
    -0.07917737f, -0.09076048f, -0.02904933f, 0.00809481f, 0.20158739f, -0.18136576f, 0.10143854f, -0.08843048f, 
    -0.09936671f, -0.03199477f, -0.02346751f, 0.01425084f, -0.06366343f, -0.05545523f, 0.18461932f, 0.00979921f, 
    0.10419436f, -0.09042239f, -0.15248239f, 0.05715916f, 0.02639222f, 0.03464699f, 0.02399616f, 0.02545519f, 
    0.09689488f, -0.12928554f, -0.15417676f, 0.16010009f, 0.08267513f, 0.23506880f, 0.22536388f, 0.13500877f, 
    0.17303860f, -0.09308475f, 0.01711819f, -0.02587519f, -0.04394131f, 0.09866263f, -0.09255491f, 0.07714020f, 
    0.16163687f, 0.09929851f, 0.17964795f, -0.00652042f, 0.09783695f, -0.04358710f, -0.02728561f, 0.04565526f, 
    -0.05482749f, -0.09648483f, 0.09551497f, -0.02287688f, -0.12955330f, -0.02772799f, -0.14641957f, 0.06763357f, 
    0.05640284f, -0.04694146f, 0.04128858f, -0.02338345f, 0.00549035f, -0.15432933f, -0.01451793f, -0.09974383f, 
    -0.21188249f, -0.09848185f, 0.31808791f, -0.10322056f, 0.06712699f, -0.00944465f, 0.07318758f, -0.03925799f, 
    0.03289105f, -0.04762827f, -0.04657969f, -0.04233473f, -0.05772204f, -0.00834478f, 0.04043726f, 0.13489951f, 
    0.09342088f, -0.06255328f, -0.10375630f, 0.05097341f, -0.09025195f, 0.00936640f, 0.07839552f, -0.02678515f, 
    0.10385737f, 0.22640878f, 0.19400798f, 0.02925756f, -0.18143076f, -0.06151248f, -0.06351288f, -0.04343287f, 
    0.03424396f, 0.01473927f, -0.05474657f, -0.04082041f, -0.17552133f, -0.07136147f, -0.14128952f, -0.06650550f, 
    0.04360977f, -0.01065600f, 0.09016831f, -0.08461324f, -0.04245935f, 0.13754968f, -0.08743364f, -0.15862066f, 
    0.08860897f, -0.15106170f, 0.04710329f, 0.11846386f, 0.01280155f, -0.00228119f, 0.09379435f, -0.08614891f, 
    0.08757752f, -0.06683585f, -0.02255955f, 0.01289457f, -0.17207070f, -0.10334402f, -0.16021758f, -0.08760200f, 
    0.00367424f, -0.01340056f, 0.02971679f, -0.14663152f, 0.01649913f, -0.04535376f, 0.16319324f, 0.00731529f, 
    -0.24612123f, 0.02011751f, -0.03445802f, -0.12014091f, 0.07372046f, 0.00686067f, -0.03716915f, -0.06783617f, 
    -0.03752669f, -0.10930483f, -0.00884033f, 0.04158650f, -0.23342949f, -0.06531082f, -0.04355029f, -0.05777891f, 
    0.05412804f, 0.00620838f, 0.04272258f, -0.08654070f, -0.01250166f, -0.10580827f, 0.05856931f, 0.07003083f, 
    0.03630090f, -0.15394302f, 0.20395733f, -0.03092423f, 0.10513628f, -0.02117206f, -0.07098314f, 0.06411116f, 
    0.08160925f, 0.11159647f, 0.08004670f, -0.08696572f, 0.35917184f, 0.05728506f, 0.01958037f, 0.03640588f, 
    0.16440007f, 0.04823801f, -0.03624594f, 0.09159557f, -0.07270898f, 0.11101945f, 0.04204031f, 0.12354895f, 
    0.02887568f, -0.01654346f, 0.01731233f, 0.00983239f, 0.01938657f, -0.03254107f, 0.04004272f, -0.01213718f, 
    -0.03536005f, -0.00321169f, -0.01334654f, -0.04111557f, 0.01653125f, -0.00237667f, -0.05183715f, -0.05939162f, 
    -0.03853701f, -0.04211575f, 0.01864750f, -0.04614577f, -0.03608326f, 0.03568531f, 0.02131228f, -0.03757326f, 
    -0.05014051f, -0.00317106f, -0.04389760f, -0.03957278f, -0.03513274f, 0.03620514f, -0.00596587f, 0.00011429f, 
    -0.00849795f, -0.04687006f, -0.00932908f, -0.05834833f, 0.00556690f, -0.02792783f, 0.00092698f, 0.03448096f, 
    -0.05206503f, 0.02126942f, -0.03235570f, 0.04195141f, -0.03114058f, -0.04328232f, 0.01175475f, -0.04900678f, 
    -0.02737120f, -0.02917271f, -0.00907646f, -0.05050546f, -0.02477163f, -0.05125934f, 0.01560338f, -0.03849710f, 
    0.00653332f, 0.03536656f, -0.01512874f, 0.00865705f, -0.02798586f, 0.03742337f, -0.03941750f, 0.02299098f, 
    -0.03556361f, -0.04042410f, 0.01911236f, 0.02527572f, -0.04603785f, -0.02795110f, -0.01159221f, 0.01507643f, 
    -0.01388985f, -0.03991171f, 0.00376829f, 0.01510904f, -0.00485888f, -0.04080577f, 0.03331145f, 0.00729036f, 
    -0.00565758f, -0.04175080f, -0.04314436f, 0.01385476f, -0.03866181f, -0.03431156f, -0.01250109f, 0.02190166f, 
    0.02637791f, -0.02705283f, 0.00443119f, 0.00194861f, 0.02949282f, 0.00952359f, -0.02318084f, 0.03079844f, 
    0.02237875f, 0.00081969f, -0.02844913f, 0.03977586f, 0.01760453f, 0.03016748f, -0.04016678f, -0.04077024f, 
    0.03946728f, -0.03381854f, -0.03722701f, -0.01566360f, -0.04485427f, -0.01003440f, -0.01829481f, 0.02634961f, 
    -0.00165688f, -0.03099812f, 0.00602323f, -0.04100166f, 0.00146488f, -0.01799668f, -0.05307975f, -0.03588413f, 
    0.00718795f, -0.01460201f, -0.03697803f, -0.05475857f, -0.00958408f, 0.03711028f, 0.03118248f, -0.01530247f, 
    0.01568921f, -0.05463447f, 0.03687891f, 0.03282711f, 0.00178295f, -0.02350586f, -0.05006838f, 0.00608528f, 
    -0.00384816f, -0.05586201f, -0.04144871f, 0.02501795f, 0.00167144f, 0.04019419f, 0.00305911f, -0.02383023f, 
    0.03560200f, -0.01371536f, -0.01841540f, 0.03782029f, -0.01275794f, -0.01155378f, -0.03013241f, -0.05527668f, 
    -0.05480957f, -0.02764018f, 0.01523756f, -0.01984991f, -0.02852201f, -0.02945828f, -0.02042181f, 0.02164217f, 
    0.03361368f, 0.01652914f, 0.00645474f, -0.00275604f, 0.04240781f, 0.02305193f, -0.04033422f, -0.05641684f, 
    0.01572600f, 0.02800878f, -0.02717368f, 0.03730188f, -0.04901032f, -0.05438628f, -0.01055374f, 0.01721569f, 
    0.02889059f, -0.05996107f, 0.03160316f, -0.01057424f, -0.01373584f, -0.05201446f, -0.01339772f, -0.05498886f, 
    0.03501255f, 0.00017142f, -0.02333824f, 0.01649108f, 0.02805320f, 0.00255682f, 0.01509110f, -0.02185063f, 
    -0.02582393f, -0.05676465f, -0.00296684f, 0.01267299f, -0.01469249f, -0.01177501f, 0.02272590f, -0.00178624f, 
    0.03156215f, -0.03480171f, 0.00240784f, -0.01608003f, -0.03645316f, 0.02348911f, -0.05768691f, -0.00938689f, 
    -0.02726127f, -0.05403719f, -0.04305820f, -0.03417675f, 0.02528853f, 0.01286471f, -0.01495232f, -0.01822287f, 
    -0.00433679f, 0.01005782f, -0.02319008f, 0.03734396f, 0.03430679f, -0.02718619f, 0.03557912f, 0.01237432f, 
    -0.04434115f, -0.04341990f, 0.01031327f, -0.00691002f, -0.00954153f, -0.02166467f, -0.02453510f, -0.02467880f, 
    -0.05092188f, -0.00979117f, -0.05071482f, 0.02299982f, -0.04422612f, 0.02590475f, 0.00093936f, -0.01507757f, 
    -0.00697088f, -0.02936737f, -0.00375692f, 0.01055869f, 0.03253669f, 0.03417442f, -0.03004690f, 0.00098477f, 
    0.00076532f, 0.00855140f, -0.03594994f, 0.03354558f, -0.02904564f, -0.05688059f, 0.03839609f, -0.01186645f, 
    -0.00384627f, 0.03537485f, -0.01514946f, 0.00224642f, -0.03737677f, -0.00150840f, -0.01601778f, -0.04490741f, 
    -0.03977818f, 0.04171652f, 0.04218698f, -0.04556878f, 0.01860090f, 0.00671818f, 0.02453614f, 0.00939908f, 
    0.03517319f, -0.05710995f, 0.00011257f, 0.00554948f, -0.04134424f, -0.01804732f, 0.04107505f, -0.05177886f, 
    -0.05690355f, -0.03020675f, 0.04069157f, 0.03486904f, -0.05923465f, 0.01762608f, -0.05437515f, 0.02665504f, 
    0.01614897f, 0.04145581f, -0.02202483f, -0.01970007f, -0.03462043f, -0.05299777f, -0.00160307f, -0.00468393f, 
    -0.03269605f, 0.03576745f, 0.00280725f, -0.02002938f, -0.03042392f, -0.05509035f, -0.05402837f, -0.04817879f, 
    -0.03679359f, 0.01461960f, 0.00673443f, -0.02769065f, -0.02970416f, -0.01850833f, -0.05530135f, -0.02478133f, 
    0.03211810f, 0.01768891f, -0.04437927f, 0.02330047f, 0.01366084f, -0.04348091f, 0.01950831f, 0.03485470f, 
    -0.03441455f, 0.00769159f, -0.01162329f, 0.01214332f, 0.02293259f, -0.04071696f, 0.01984948f, -0.02326536f, 
    -0.00663689f, 0.01202830f, -0.02452506f, 0.03901675f, -0.00320781f, 0.02042291f, 0.03480504f, -0.01557699f, 
    0.00098704f, 0.03591631f, -0.01769694f, -0.05569464f, -0.04689373f, 0.02080131f, 0.04011899f, 0.03664989f, 
    -0.05064702f, -0.04999843f, 0.02715413f, -0.05136554f, -0.03694831f, -0.04271211f, -0.00500732f, 0.03367476f, 
    0.03011231f, 0.00317469f, 0.00987467f, -0.01677324f, -0.00227488f, -0.03334327f, -0.01081228f, 0.03475354f, 
    0.02743642f, -0.05174818f, 0.01259261f, 0.03971290f, -0.05967019f, 0.00349989f, -0.04024366f, -0.01447379f, 
    0.02449510f, 0.02540870f, 0.02550792f, -0.01429687f, -0.01624905f, 0.02201822f, 0.02003258f, -0.01494321f, 
    -0.00923451f, 0.03208308f, -0.01345327f, -0.00917855f, 0.03285050f, 0.02819978f, -0.02278591f, 0.02686072f, 
    -0.00964949f, -0.24487634f, 0.16367094f, -0.03264983f, 0.01987758f, -0.17307793f, 0.09896207f, 0.07942159f, 
    0.06652972f, 0.06834036f, 0.06646747f, 0.03158295f, 0.01982372f, -0.09895944f, 0.14818273f, -0.05720799f, 
    -0.00392074f, 0.00928375f, -0.03511593f, -0.00026768f, 0.11908413f, 0.02015543f, 0.15065269f, -0.01435529f, 
    -0.14223950f, 0.11749417f, -0.02343955f, -0.01247718f, 0.13705818f, -0.04426311f, 0.04205301f, 0.02566275f, 
    0.04439840f, 0.22369809f, -0.13865755f, 0.25610083f, -0.29276451f, -0.11536153f, 0.14945103f, 0.02863689f, 
    -0.00837909f, 0.00934044f, 0.02165934f, 0.18013263f, -0.02548633f, 0.19786762f, 0.10358948f, -0.02610983f, 
    -0.26047406f, 0.01427022f, 0.11228667f, -0.14368507f, 0.18277077f, 0.02808213f, 0.00571954f, -0.22641246f, 
    0.08727216f, 0.09351535f, -0.03583359f, 0.10995984f, -0.35586086f, 0.02115051f, 0.10524723f, -0.04513215f, 
    -0.00763851f, -0.07658488f, 0.13582760f, -0.16332245f, -0.06132217f, -0.03463868f, 0.02556136f, 0.03895845f, 
    0.28424755f, 0.01203965f, -0.21958929f, 0.09242948f, 0.14248367f, -0.06405768f, 0.10312127f, 0.03845656f, 
    -0.02873322f, -0.12644497f, 0.06569768f, 0.12058283f, -0.18965405f, 0.02887725f, 0.11386486f, 0.33245733f, 
    0.05741084f, 0.04358946f, -0.06422000f, 0.03889322f, 0.02148831f, -0.05899136f, -0.06802700f, -0.13180925f, 
    -0.02633894f, -0.01810550f, -0.01046955f, 0.04488700f, -0.01187940f, 0.03752507f, 0.07745937f, 0.05945743f, 
    0.07743840f, 0.05252958f, -0.07591528f, -0.00484135f, -0.18327387f, 0.07802342f, 0.16987802f, 0.29155815f, 
    -0.00108976f, -0.02084330f, 0.00928969f, -0.05097004f, 0.01012816f, 0.01358179f, 0.03537593f, 0.05920026f, 
    0.00440656f, 0.19805786f, 0.10523407f, -0.02629885f, 0.03184477f, -0.05182328f, -0.02177954f, -0.16283965f, 
    -0.03364962f, 0.06940603f, -0.19562674f, 0.02442798f, 0.00185840f, 0.00784533f, 0.03988619f, -0.02933617f, 
    0.04856760f, -0.10980278f, -0.04696072f, -0.08230717f, 0.05601104f, 0.00201061f, 0.11401232f, 0.10652138f, 
    -0.02939237f, 0.11982242f, -0.17320043f, 0.04580922f, -0.03440520f, -0.06160556f, -0.12699665f, -0.11245102f, 
    0.04640459f, 0.06542438f, -0.00826638f, 0.06531430f, -0.13904332f, -0.07533507f, 0.18206382f, 0.26230836f, 
    0.00135254f, 0.03168269f, -0.02156242f, -0.00138645f, -0.00979799f, -0.11034394f, 0.08522117f, 0.13855095f, 
    -0.45016637f, 0.29297432f, -0.00183431f, -0.12156976f, 0.01496499f, -0.06231972f, -0.03219742f, -0.10218060f, 
    0.06903936f, -0.04125227f, 0.01950174f, 0.06601655f, 0.24897884f, 0.05429757f, -0.05756372f, 0.12359361f, 
    0.14057194f, 0.02876801f, 0.00066273f, 0.05862901f, 0.02774388f, 0.02896570f, 0.07994972f, -0.00347737f, 
    0.07279101f, 0.04204093f, 0.05260567f, -0.10010336f, 0.10272809f, 0.05418896f, 0.03717692f, 0.19952051f, 
    0.07775345f, -0.05388850f, 0.01582642f, 0.08205293f, -0.24509895f, 0.11174683f, 0.21390522f, -0.00423657f, 
    0.08690444f, -0.10049233f, 0.12051297f, -0.05391040f, 0.10424018f, -0.03448939f, -0.01971189f, 0.23179148f, 
    -0.19779120f, -0.03868049f, 0.05106985f, 0.11655974f, 0.14975163f, 0.08618285f, -0.08840702f, 0.03926622f, 
    0.14522809f, 0.10674403f, 0.25043681f, -0.09994710f, 0.15450065f, 0.15182555f, -0.13045362f, -0.02571639f, 
    -0.10105848f, 0.11393560f, -0.10446616f, 0.00158584f, 0.11380842f, -0.02941105f, 0.01766780f, -0.04039290f, 
    -0.35394242f, 0.06208834f, 0.02682568f, -0.07533740f, -0.00114828f, -0.08226416f, 0.04798877f, -0.10838692f, 
    -0.05437909f, -0.02077723f, 0.02196465f, -0.11292065f, 0.05263681f, -0.00737962f, 0.02432291f, 0.04645820f, 
    0.08028071f, 0.09791163f, 0.13382992f, -0.11766307f, 0.01101079f, -0.02983081f, 0.04868817f, 0.14647330f, 
    0.08187515f, -0.09708319f, -0.24717636f, 0.06251562f, -0.03506598f, 0.03877027f, -0.10498790f, -0.15294671f, 
    -0.03000107f, 0.13745967f, 0.09015489f, 0.07686599f, -0.02499965f, 0.08258224f, -0.04779321f, 0.15706936f, 
    -0.13748962f, -0.09826535f, 0.02380663f, -0.01062271f, 0.10279110f, -0.11345387f, -0.06031480f, 0.07812066f, 
    0.09951579f, 0.16448826f, -0.06274259f, 0.06717450f, -0.03230296f, -0.07988836f, 0.04959727f, -0.01758790f, 
    -0.03240409f, 0.02183480f, 0.19455944f, 0.14091980f, 0.08866145f, 0.03118831f, 0.12708659f, 0.14471640f, 
    0.00767957f, 0.04528951f, -0.05654505f, 0.07369807f, 0.08782602f, -0.06534433f, 0.08886512f, 0.09688614f, 
    -0.12600017f, 0.12806956f, -0.03430575f, -0.01327465f, 0.00506497f, -0.11783929f, -0.08966447f, -0.05847089f, 
    -0.00706893f, 0.02985804f, -0.02729841f, 0.05761923f, -0.01345292f, 0.00042378f, 0.06867740f, 0.10888735f, 
    0.02689737f, -0.12946859f, 0.09668396f, -0.03921851f, 0.05448081f, 0.02302342f, -0.04459110f, -0.00353956f, 
    0.04771609f, 0.08227913f, 0.20147300f, 0.07284892f, -0.00160947f, -0.10688162f, 0.03306421f, -0.06459513f, 
    0.03675107f, 0.03803486f, -0.10634041f, -0.07915149f, -0.02622479f, 0.11355551f, 0.18975312f, 0.01805693f, 
    -0.02106151f, 0.05656819f, -0.01999255f, 0.01770941f, -0.07051399f, 0.08893910f, 0.14536348f, -0.00784001f, 
    -0.09204195f, 0.06677029f, -0.05700647f, -0.00000339f, 0.15564004f, -0.00068715f, -0.15664873f, 0.06886928f, 
    -0.03734078f, -0.03801111f, 0.05532577f, 0.12413289f, -0.09704255f, 0.00805559f, -0.11384699f, -0.01426212f, 
    0.06182569f, 0.04909179f, -0.02865401f, -0.15861072f, 0.01020809f, -0.05740900f, -0.02458977f, -0.03098731f, 
    0.00805914f, -0.16382469f, 0.31583658f, 0.04371941f, 0.04191834f, -0.02671865f, 0.00093354f, -0.03666906f, 
    -0.07068373f, -0.00975427f, -0.05100911f, 0.05389208f, -0.23890109f, 0.01169051f, 0.01759945f, -0.00933237f, 
    0.08031964f, 0.00583410f, 0.04408145f, 0.00904445f, -0.09395166f, 0.00335756f, -0.03515675f, 0.06897770f, 
    0.13704415f, 0.18949704f, -0.02441547f, -0.00742618f, -0.07877900f, 0.03208291f, 0.08997344f, -0.02773134f, 
    -0.01892314f, -0.04375745f, 0.01957450f, -0.03044695f, 0.24254356f, 0.09524591f, 0.07781284f, -0.02358463f, 
    0.00475751f, 0.00007346f, -0.12609886f, -0.08862386f, -0.14210653f, -0.00447985f, -0.04525625f, -0.00237536f, 
    -0.07710619f, 0.21059531f, 0.15425883f, -0.04413585f, -0.15429161f, -0.03243347f, -0.01102026f, -0.01755645f, 
    -0.11510920f, 0.07524123f, 0.05529676f, 0.11122267f, 0.26838887f, -0.21756895f, -0.05264845f, 0.04023337f, 
    -0.05178886f, -0.06220585f, 0.15319791f, 0.11020862f, -0.01635253f, -0.04522821f, -0.01753998f, 0.14229333f, 
    0.06450420f, 0.04752320f, -0.13687418f, 0.31256351f, 0.08053828f, 0.01689802f, -0.17204453f, 0.14457507f, 
    0.01595853f, 0.13719395f, -0.08718683f, 0.07717001f, -0.18483666f, 0.20418127f, -0.08480559f, 0.10386962f, 
    0.02134996f, 0.06214716f, -0.02014420f, 0.10096353f, -0.15129024f, 0.01491182f, -0.03920067f, 0.04658983f, 
    -0.12833914f, -0.08088696f, -0.09837303f, 0.08892076f, 0.01360909f, 0.01542512f, -0.09642144f, -0.07374154f, 
    -0.05680909f, -0.04742428f, 0.12258662f, 0.03247788f, 0.18599676f, 0.14361261f, -0.00841528f, 0.12409523f, 
    0.06396742f, -0.06992263f, -0.11379341f, -0.04132319f, 0.06525538f, 0.02168124f, 0.03209400f, 0.03001594f, 
    -0.33262897f, 0.04903662f, -0.02881632f, -0.09037303f, 0.09267128f, -0.09873975f, -0.03302562f, 0.13943271f, 
    0.00484334f, 0.00707927f, 0.13669147f, -0.01796339f, 0.07004231f, 0.12920226f, 0.17916530f, -0.04308435f, 
    0.02209573f, -0.02410147f, 0.00054828f, -0.05322850f, 0.03730348f, -0.08926520f, -0.13325596f, -0.00092916f, 
    -0.05473607f, 0.08565785f, -0.14886653f, 0.11425681f, -0.11903952f, -0.02330998f, 0.05046165f, -0.05238292f, 
    -0.02754795f, 0.09240740f, -0.01175734f, -0.01530613f, 0.35720813f, 0.12664491f, -0.05927312f, 0.27543578f, 
    0.07052322f, -0.06646675f, -0.11625015f, 0.05669035f, -0.00720228f, 0.09063118f, 0.11449759f, 0.01534228f, 
    0.28299904f, 0.19460565f, 0.07800922f, -0.06063066f, -0.01888206f, 0.05117554f, -0.00166550f, 0.07409548f, 
    0.08341463f, -0.04794469f, -0.07086311f, -0.05116766f, 0.04104930f, -0.04229505f, -0.19097444f, 0.06424166f, 
    0.13238451f, 0.01282505f, -0.03777068f, 0.04370964f, -0.00007988f, 0.02949156f, -0.01122837f, 0.01842955f, 
    0.12919709f, 0.12225117f, -0.24261031f, -0.06116510f, 0.13738887f, 0.07208839f, -0.06631071f, -0.02526613f, 
    -0.01932864f, 0.01815932f, 0.07802057f, -0.04287631f, -0.08493871f, 0.19881517f, 0.10613760f, 0.17502324f, 
    0.14481053f, 0.04520998f, 0.01194607f, 0.03389315f, -0.13910618f, 0.04156119f, -0.03673776f, -0.07262310f, 
    0.19066063f, 0.15326262f, 0.09044240f, 0.02787303f, -0.08739700f, 0.04584574f, -0.00163808f, -0.12480804f, 
    -0.07080832f, 0.07367359f, 0.08848128f, 0.09665470f, 0.13056062f, -0.10640337f, -0.24594812f, 0.19660948f, 
    -0.07419003f, 0.09346868f, -0.09223130f, -0.07903352f, 0.00898807f, 0.02158371f, 0.06624548f, -0.01498620f, 
    -0.13813116f, 0.05504946f, -0.06441212f, 0.17902659f, -0.05445406f, 0.03375762f, 0.06709155f, 0.08154399f, 
    -0.01036064f, -0.03787618f, -0.00996026f, 0.10183802f, 0.04369115f, 0.06962340f, 0.14300692f, -0.19401315f, 
    0.07639606f, 0.02000529f, -0.06599262f, -0.13147266f, -0.02088535f, 0.00043102f, -0.00047782f, -0.08304668f, 
    0.31037372f, 0.07392836f, -0.20130223f, 0.28142011f, 0.03510738f, -0.02602674f, 0.02323356f, 0.06669626f, 
    0.01459628f, -0.01432638f, 0.00349579f, -0.13785590f, 0.20506622f, 0.13573867f, 0.05993496f, 0.10859757f, 
    -0.09968102f, 0.06877565f, 0.01928474f, 0.09004226f, 0.10192606f, -0.09015745f, -0.13277915f, -0.06042894f, 
    0.01327592f, -0.25775179f, -0.01598291f, 0.03806110f, 0.13705987f, -0.07293504f, -0.00908017f, -0.02809591f, 
    -0.05294454f, -0.07241599f, -0.06161946f, -0.05299033f, 0.09095488f, -0.07797697f, 0.00659024f, -0.11937248f, 
    -0.07110602f, -0.05686906f, -0.01775436f, 0.18986903f, 0.07070790f, -0.06052588f, -0.00378367f, 0.11486957f, 
    0.11807673f, 0.38802829f, 0.07786438f, -0.05019562f, 0.01317912f, 0.01576833f, -0.01107529f, -0.13557443f, 
    -0.05485914f, -0.04530548f, -0.08666544f, -0.04111789f, 0.18981580f, -0.02088116f, -0.03200721f, -0.04019824f, 
    -0.00003264f, -0.04241700f, -0.00430553f, 0.05001766f, 0.00424070f, 0.05674703f, 0.05854354f, 0.00307197f, 
    0.01070881f, -0.32502985f, -0.08437000f, -0.11306833f, -0.06767755f, 0.02429236f, 0.02858059f, 0.05825552f, 
    0.02564765f, 0.04241805f, 0.07776822f, 0.04723810f, -0.04179556f, 0.05378748f, 0.03053567f, -0.08590931f, 
    -0.03136690f, 0.02288814f, -0.03648794f, 0.03660808f, 0.05101896f, -0.05448749f, -0.00660730f, -0.08250891f, 
    0.10419502f, 0.16119373f, -0.16188374f, 0.27647635f, -0.22631453f, 0.09053173f, 0.08098388f, -0.03613869f, 
    -0.08176024f, 0.02296315f, 0.02963575f, 0.07743552f, -0.30995136f, 0.10598697f, 0.00422480f, 0.11235988f, 
    -0.10577734f, 0.02717307f, 0.05195934f, -0.17436458f, 0.00712921f, 0.03493857f, -0.02757361f, -0.01496011f, 
    0.00647730f, -0.03379669f, 0.07494665f, 0.05177362f, 0.02078293f, -0.09796558f, 0.04759057f, 0.01063379f, 
    0.05139067f, 0.04444417f, -0.00184484f, -0.01421055f, 0.26289481f, -0.24946825f, 0.06297857f, 0.01812617f, 
    0.02445059f, -0.07435799f, -0.01720541f, 0.05243115f, 0.03502661f, 0.07693938f, 0.08668849f, 0.01249950f, 
    -0.11711174f, 0.05442070f, 0.07431760f, -0.08595107f, 0.09484964f, -0.06069467f, 0.02887571f, 0.06258702f, 
    0.00794604f, 0.13895221f, -0.07159980f, 0.24334829f, -0.10123936f, -0.04247246f, 0.10624900f, -0.10342012f, 
    0.01835369f, 0.05878263f, 0.02914635f, 0.23165914f, 0.08612818f, 0.12123610f, -0.00508765f, -0.03861861f, 
    -0.00511378f, 0.10070828f, 0.18414851f, -0.06785173f, 0.22084931f, -0.01022261f, 0.13723691f, -0.21154796f, 
    0.02014625f, 0.01825870f, -0.11452322f, 0.17169793f, -0.41696152f, 0.20629992f, 0.23075230f, -0.20648018f, 
    -0.11813810f, -0.11330633f, 0.08911368f, -0.08489510f, 0.00129918f, -0.16557233f, -0.01018489f, 0.01253622f, 
    -0.18889660f, -0.00999713f, -0.21938710f, -0.03894830f, 0.14081953f, -0.00291885f, 0.05221365f, -0.05117527f, 
    -0.03924231f, -0.13442972f, 0.08243265f, 0.01729014f, -0.14962596f, 0.16522744f, -0.04294525f, 0.16762489f, 
    0.13987331f, -0.04307612f, -0.03817863f, -0.04459315f, 0.12433492f, 0.03564258f, -0.07103695f, -0.14972189f, 
    -0.00591329f, -0.17965028f, -0.01878115f, 0.02736213f, -0.02654150f, 0.00557062f, 0.03030566f, 0.09544718f, 
    0.11917847f, 0.15681854f, 0.00771654f, 0.09592581f, 0.04678115f, 0.22844668f, 0.04394999f, 0.12246422f, 
    0.01234331f, 0.04589055f, -0.08939558f, -0.08403793f, -0.01487876f, 0.11375774f, -0.01548845f, 0.02737167f, 
    0.09424987f, -0.06725857f, 0.01134523f, -0.12663150f, -0.02694939f, -0.04832031f, -0.06847444f, -0.20261936f, 
    -0.07728729f, 0.04962644f, -0.23198971f, -0.01542742f, 0.15712917f, -0.05863585f, -0.01935356f, 0.00602286f, 
    -0.01577506f, -0.01850234f, 0.04862097f, 0.07508025f, 0.05212776f, 0.10311797f, 0.18721409f, 0.06500741f, 
    0.34099266f, 0.27564636f, -0.00232735f, 0.15618606f, -0.08777449f, -0.14716250f, 0.00363366f, -0.01917928f, 
    0.08609411f, 0.07438926f, 0.04762923f, -0.02442535f, -0.14750734f, 0.24395227f, 0.13986382f, 0.02647558f, 
    0.03330054f, 0.01628971f, 0.03374620f, -0.08083578f, 0.02847297f, 0.04922521f, -0.00307211f, 0.07802276f, 
    -0.13734476f, -0.00563486f, 0.08052756f, -0.08993001f, 0.08499613f, -0.02269235f, -0.09002036f, -0.01239876f, 
    -0.04831440f, -0.05521219f, 0.04152585f, -0.03690973f, -0.33282226f, -0.13671355f, 0.05679059f, -0.00671957f, 
    0.10442829f, 0.00135751f, 0.05146557f, -0.04790822f, -0.03289928f, 0.02698028f, 0.07617241f, 0.07589684f, 
    0.06876577f, -0.06212172f, 0.07766546f, 0.08480169f, -0.05965594f, 0.03833752f, -0.03463042f, 0.12335676f, 
    -0.04807983f, -0.00472753f, 0.03406916f, 0.18303613f, -0.34078911f, 0.02772231f, 0.16092975f, -0.05927270f, 
    0.01149419f, -0.12167297f, -0.00828941f, -0.04700181f, 0.09350944f, 0.01880930f, 0.03593716f, 0.27078152f, 
    -0.12026701f, 0.03675050f, -0.05047933f, 0.15172333f, 0.14990194f, 0.08607389f, 0.01661265f, 0.08639935f, 
    -0.03279114f, 0.10276273f, 0.13491106f, -0.19567434f, -0.11512850f, -0.06587640f, -0.00335059f, -0.07494334f, 
    -0.00250012f, 0.05460082f, -0.06797268f, -0.04657004f, 0.09093815f, -0.12839240f, 0.12710300f, 0.04448805f, 
    -0.10239548f, 0.21700139f, 0.00604809f, -0.06592951f, -0.03937498f, -0.07394923f, 0.12775590f, -0.00588947f, 
    -0.06588127f, 0.02610320f, -0.07685392f, -0.03755623f, -0.03199252f, -0.09645177f, -0.03671359f, 0.16338736f, 
    -0.10475230f, 0.06215598f, 0.08297466f, -0.02224499f, 0.02347745f, 0.07889599f, 0.11940831f, 0.07539938f, 
    0.06499526f, 0.03177507f, -0.17639405f, -0.05732770f, -0.06553758f, -0.03109704f, -0.02899533f, -0.00843107f, 
    -0.03263448f, 0.20902097f, 0.05185819f, 0.20376857f, 0.00703441f, 0.18799466f, 0.08906375f, 0.18332350f, 
    0.05142500f, -0.02229128f, 0.09389894f, -0.14470883f, 0.06545071f, 0.00337961f, -0.03310148f, 0.07242367f, 
    0.10702162f, 0.15515177f, -0.02770836f, -0.05846725f, -0.04724789f, -0.04340231f, 0.03168971f, 0.05894260f, 
    0.01582625f, -0.01060141f, 0.11381102f, 0.15399130f, -0.04590770f, -0.00543278f, -0.03752370f, 0.14230643f, 
    0.04516407f, 0.06929205f, -0.05868565f, -0.00765732f, 0.01968024f, -0.02549208f, 0.18483520f, 0.00788424f, 
    -0.02043994f, -0.00463156f, 0.15489250f, 0.08211005f, 0.08482844f, -0.11753059f, 0.02189475f, 0.05447064f, 
    0.11831073f, 0.04281092f, 0.09913141f, -0.00754411f, 0.10421494f, 0.07530107f, -0.06944475f, 0.25462073f, 
    0.00561104f, -0.16066028f, -0.01534885f, -0.02185809f, 0.05456444f, -0.06987436f, -0.16527374f, -0.09279285f, 
    -0.20819491f, 0.20444186f, 0.16443361f, 0.11720916f, -0.09374344f, -0.04845512f, -0.07776197f, -0.04641306f, 
    0.08112589f, 0.08175138f, -0.12033794f, 0.00540600f, 0.08199200f, -0.07196893f, 0.05520968f, 0.05656858f, 
    0.03838804f, 0.00060818f, -0.06230177f, 0.01562552f, -0.03988276f, 0.14731158f, 0.11903048f, -0.05715685f, 
    -0.25068405f, 0.10625085f, 0.00014245f, 0.02767509f, 0.22606403f, -0.03966657f, -0.04452847f, 0.09498435f, 
    -0.03306668f, -0.07642958f, -0.03442068f, -0.01463743f, 0.21232034f, 0.14149565f, -0.04501694f, 0.11981474f, 
    0.00820864f, 0.04133486f, 0.06322613f, -0.08073290f, -0.01603678f, -0.04067579f, -0.12201851f, -0.03381345f, 
    -0.25552505f, 0.13162859f, 0.16199155f, -0.04575612f, -0.02138978f, -0.05670505f, -0.12890705f, -0.05873905f, 
    0.01120162f, -0.03836127f, 0.02624265f, 0.04676950f, 0.18904461f, -0.03794961f, -0.15197811f, 0.24498969f, 
    0.04556834f, -0.03125268f, 0.03896540f, -0.00391727f, -0.08333083f, -0.01865111f, -0.07263599f, -0.00036938f, 
    0.09353775f, 0.06152008f, -0.13075799f, -0.03214669f, -0.17595147f, 0.00594902f, -0.04206703f, 0.01208318f, 
    -0.15547544f, 0.00634195f, -0.09953495f, 0.02769708f, 0.06390021f, 0.17515136f, -0.04496776f, -0.07039180f, 
    -0.03996568f, 0.00057105f, 0.04290650f, -0.04063320f, -0.03515357f, -0.16084993f, -0.09656063f, 0.01442751f, 
    0.10609049f, -0.07307423f, 0.11287584f, 0.05748365f, -0.03908796f, 0.03459656f, -0.04271516f, 0.16322286f, 
    -0.03723936f, 0.04889460f, 0.04997946f, 0.09383268f, 0.05855099f, 0.00928769f, -0.10968833f, 0.01521360f, 
    -0.05299542f, 0.05984899f, 0.08228716f, -0.12385527f, -0.02561391f, 0.04952681f, -0.12689862f, 0.12081623f, 
    0.14193074f, -0.06310587f, -0.00584750f, -0.04844731f, -0.15498739f, 0.03384158f, 0.01789147f, -0.05533122f, 
    0.00690503f, -0.05147288f, 0.10773361f, -0.01772642f, -0.32565290f, 0.30321163f, -0.20857535f, -0.28953388f, 
    -0.04505831f, 0.04141085f, 0.04782664f, 0.13890313f, 0.13554864f, 0.12066947f, -0.01687392f, 0.02840916f, 
    0.38182080f, -0.12892140f, 0.11297857f, 0.14008933f, -0.05862980f, -0.08449296f, 0.05845451f, -0.02070125f, 
    -0.12487474f, -0.02722425f, -0.00183334f, 0.06599776f, -0.00402335f, 0.08071060f, 0.01828837f, -0.27856642f, 
    -0.00375526f, 0.13232696f, 0.05418370f, -0.00897377f, 0.15800402f, 0.04902722f, -0.03164176f, -0.13189586f, 
    0.23928972f, -0.18852209f, 0.06990445f, 0.22151247f, -0.07651088f, -0.02774545f, -0.02273156f, 0.03699915f, 
    0.01769098f, -0.03072250f, 0.07598621f, 0.12051343f, -0.16778763f, -0.00302070f, 0.06613054f, 0.04786685f, 
    0.04139789f, -0.05434044f, -0.08799134f, 0.12804194f, -0.07140765f, 0.08066711f, 0.12852140f, 0.08421420f, 
    -0.20125876f, -0.12796633f, 0.12276396f, -0.00211905f, 0.03424529f, 0.06204709f, -0.13304704f, 0.14281867f, 
    0.11010429f, -0.03580398f, -0.06350823f, 0.09981006f, 0.40167356f, -0.08430736f, -0.14329886f, -0.10899682f, 
    0.08580001f, 0.01509182f, 0.02308101f, -0.00650927f, -0.04354632f, 0.06086137f, -0.09519950f, -0.00532225f, 
    -0.06862524f, 0.11324120f, -0.04941081f, 0.07909788f, -0.03100628f, 0.01201528f, -0.01787294f, 0.03150797f, 
    -0.03175272f, -0.03224520f, 0.09560316f, -0.00677741f, 0.19008659f, -0.27502707f, -0.24322055f, 0.13363524f, 
    -0.21035819f, -0.05936062f, 0.06376533f, 0.00466046f, 0.09516080f, -0.09452666f, 0.00918553f, -0.05761949f, 
    -0.19034261f, -0.11430162f, -0.05880231f, 0.24767971f, 0.05345215f, 0.04055146f, 0.02498434f, -0.04245078f, 
    -0.02532100f, 0.10263646f, 0.06429938f, -0.12318411f, -0.12108871f, 0.15657866f, -0.19416291f, -0.14990899f, 
    0.08150189f, 0.12247034f, -0.02945779f, -0.15367255f, 0.01907142f, -0.00198958f, -0.00533427f, -0.05061309f, 
    0.04537265f, -0.03219492f, -0.00162056f, -0.07475212f, -0.20211358f, 0.03472003f, 0.02923253f, -0.02651262f, 
    -0.00981996f, -0.05705941f, -0.05233863f, -0.00354440f, 0.08250901f, -0.19462387f, -0.01343550f, -0.08769833f, 
    -0.08574112f, -0.00750539f, -0.00830900f, -0.02259440f, -0.07721445f, 0.02663411f, 0.02531468f, -0.01575404f, 
    0.15236974f, -0.00319103f, -0.17967108f, 0.05814535f, -0.06444396f, -0.05948079f, 0.03152444f, 0.05370246f, 
    0.18046647f, 0.01045215f, -0.03521720f, -0.02391289f, 0.04156528f, -0.19412333f, 0.22563007f, 0.25404283f, 
    0.10606974f, 0.06722288f, 0.03506368f, -0.08470461f, 0.06259213f, 0.01506782f, 0.06047225f, 0.08333863f, 
    -0.07575293f, 0.09584989f, 0.07391071f, -0.12099662f, 0.04185586f, 0.00343558f, -0.03605899f, 0.03729502f, 
    -0.05433032f, 0.01615245f, 0.02388876f, 0.03480507f, 0.18947557f, 0.03612825f, 0.03219493f, -0.05780637f, 
    -0.04249990f, -0.00534225f, 0.12850156f, 0.18086624f, 0.15210189f, 0.02743571f, 0.04665861f, 0.08154824f, 
    -0.00490785f, -0.03836713f, -0.06808763f, -0.13004655f, 0.09489029f, 0.05521971f, 0.00795455f, 0.04753041f, 
    0.10381522f, -0.04653961f, 0.01498700f, -0.00540140f, 0.28466633f, -0.02866751f, 0.11006765f, 0.07581415f, 
    0.01262710f, 0.07024339f, -0.00835363f, 0.02948088f, -0.03410778f, -0.08855197f, 0.00737163f, -0.02878232f, 
    0.17273255f, 0.10082957f, 0.06834697f, -0.00532945f, 0.00055544f, 0.09258559f, 0.08497055f, 0.11406572f, 
    -0.05889888f, 0.01245231f, -0.02850219f, 0.13563024f, -0.33404276f, 0.03617039f, 0.26101542f, 0.20457825f, 
    0.10583523f, 0.14742635f, 0.00946981f, 0.00641773f, 0.05993632f, 0.12976488f, -0.03736727f, 0.06829447f, 
    0.14917044f, 0.02445582f, -0.00808583f, 0.03982076f, -0.11069476f, 0.10602361f, 0.03064085f, -0.01017774f, 
    0.04908242f, 0.20169537f, 0.13575827f, 0.07688603f, 0.31914672f, -0.06721164f, 0.08154593f, 0.23187748f, 
    0.09615771f, -0.03038706f, -0.03902615f, -0.06456475f, 0.02867227f, -0.08066343f, 0.09844592f, 0.02298451f, 
    0.13308316f, 0.11258031f, -0.04424411f, -0.21956140f, -0.05807130f, -0.07587805f, 0.06021817f, -0.02592648f, 
    -0.01202508f, -0.19322036f, 0.04777244f, 0.12164922f, -0.12120647f, -0.16169439f, 0.05731502f, 0.02810954f, 
    -0.00443736f, 0.00446731f, -0.04951916f, 0.10151186f, 0.02086709f, 0.02085322f, 0.06411165f, 0.05599993f, 
    -0.06376367f, 0.30557963f, 0.01817758f, 0.01826358f, 0.04423824f, 0.13839401f, -0.05452387f, -0.13804334f, 
    0.00705132f, -0.03523884f, 0.03464908f, -0.00206649f, 0.08455146f, 0.02405784f, -0.08265591f, 0.02435323f, 
    0.15787119f, 0.06279714f, 0.07899570f, 0.09208832f, -0.02669943f, 0.05524446f, -0.02864684f, 0.03214572f, 
    0.04989451f, 0.04177305f, 0.10003299f, 0.00396341f, -0.00021599f, 0.01967726f, 0.07107221f, -0.00989148f, 
    0.01815610f, -0.17532715f, 0.25586838f, -0.12834853f, 0.21939854f, 0.15104456f, 0.04516400f, -0.07794251f, 
    -0.00426571f, 0.17366979f, -0.02272387f, -0.15174146f, -0.00953066f, -0.03090685f, 0.05202238f, 0.02846454f, 
    0.19545582f, 0.10715234f, 0.00626333f, -0.01369787f, -0.12537767f, -0.02988589f, 0.03299562f, 0.05009629f, 
    0.02512914f, 0.08183919f, 0.03044188f, -0.04084963f, 0.15272935f, -0.05413295f, 0.10108955f, -0.01333607f, 
    -0.11813471f, 0.10448249f, 0.01028795f, 0.18478644f, 0.03041722f, 0.07492509f, 0.04339440f, 0.07751281f, 
    -0.14753930f, -0.03237326f, 0.12686637f, -0.01846207f, 0.02519925f, 0.05872270f, -0.09151511f, 0.08720122f, 
    0.08106035f, 0.13185048f, -0.07679083f, 0.00333293f, 0.27895135f, 0.33319074f, -0.07295044f, -0.09945459f, 
    0.04030143f, 0.05770702f, 0.08088179f, 0.00877241f, -0.00751633f, 0.06817109f, -0.02595942f, 0.03002337f, 
    0.15133178f, -0.13808921f, -0.08548257f, 0.00810356f, -0.02094455f, -0.00127962f, -0.04041119f, 0.00114851f, 
    -0.05191186f, -0.00877371f, 0.03562910f, 0.05010157f, 0.20804958f, 0.07866671f, -0.09707561f, -0.08692262f, 
    0.06954260f, -0.08496768f, -0.06668920f, -0.11116815f, 0.18159354f, 0.10176491f, 0.00345185f, 0.00311449f, 
    -0.20727988f, -0.09585324f, -0.08940832f, -0.08210549f, -0.01102042f, 0.03125288f, 0.01061615f, 0.16552347f, 
    0.00432743f, -0.03028374f, 0.09285142f, -0.08289178f, -0.04846628f, 0.13654070f, 0.00063116f, 0.00975724f, 
    -0.06119253f, 0.09640872f, 0.01057820f, 0.04674673f, 0.04729226f, -0.09665452f, -0.15269060f, -0.09892913f, 
    0.17247365f, 0.02954856f, 0.07805594f, 0.04362850f, -0.12656243f, 0.02458686f, 0.10500938f, -0.00515582f, 
    -0.08871891f, -0.05401943f, 0.02237297f, -0.06239759f, 0.36066711f, 0.10342836f, -0.15938580f, 0.03304587f, 
    0.03361449f, -0.09094943f, 0.00627195f, 0.02705020f, 0.05145827f, 0.01927061f, -0.01249913f, -0.07803097f, 
    0.48890284f, -0.14958979f, 0.03993079f, -0.01470395f, 0.08774222f, -0.00923360f, 0.03740994f, 0.07464779f, 
    0.01746726f, 0.15733045f, -0.08294979f, 0.01784946f, 0.12557125f, -0.06461525f, -0.14690317f, -0.05554132f, 
    -0.06508283f, 0.01762006f, -0.06377138f, -0.02614650f, 0.02675033f, 0.07963101f, -0.05430035f, 0.05104985f, 
    0.29606247f, 0.05260525f, -0.12996040f, 0.34219620f, 0.01503669f, 0.10307241f, 0.03842571f, -0.08726997f, 
    -0.10710432f, 0.04453078f, 0.00231403f, -0.01038960f, -0.00436408f, 0.12586676f, 0.06783869f, 0.14808258f, 
    0.01481304f, -0.00802129f, -0.09326601f, 0.09171303f, -0.13941929f, 0.02499287f, 0.00934502f, -0.10188253f, 
    0.31421411f, 0.12187964f, -0.02057743f, -0.08221149f, -0.07197578f, 0.00628025f, 0.02856420f, 0.04687618f, 
    -0.11990284f, -0.08449842f, -0.05652370f, 0.09856959f, -0.19152743f, -0.19208592f, -0.04315530f, 0.01770059f, 
    0.00684281f, -0.10090288f, 0.09904004f, -0.06576009f, -0.02320856f, 0.02961113f, 0.01096079f, -0.04535065f, 
    0.12826063f, 0.17481470f, 0.11850008f, 0.14504062f, -0.05749445f, 0.08671682f, 0.05101269f, 0.07310171f, 
    0.03379597f, -0.04872758f, 0.01528622f, 0.11270916f, 0.19451560f, -0.02176553f, -0.06253865f, 0.00525049f, 
    -0.04640889f, -0.01406999f, -0.11635688f, 0.11099050f, 0.01358674f, 0.00773607f, -0.04414375f, -0.16627052f, 
    0.12049978f, 0.05220819f, 0.00360430f, 0.07440186f, -0.05591371f, -0.02732242f, 0.09813420f, 0.09976500f, 
    0.02534361f, -0.09523086f, -0.05530866f, -0.02874281f, 0.03925955f, -0.01479913f, -0.01982041f, -0.09657713f, 
    -0.04307032f, 0.19949406f, -0.04171215f, 0.00255342f, -0.03019049f, 0.03757139f, -0.03984637f, -0.17190067f, 
    -0.07744708f, -0.12285989f, -0.00978994f, -0.02599203f, 0.05883829f, 0.01678387f, 0.08817318f, 0.03253898f, 
    -0.00622117f, 0.02623279f, -0.02971812f, -0.13856742f, -0.04341692f, -0.22989388f, -0.15385306f, -0.07506746f, 
    -0.07916778f, -0.04457177f, 0.07213721f, -0.00787851f, -0.02258861f, 0.09583834f, -0.07011452f, 0.04462672f, 
    0.07161545f, 0.09570709f, -0.03117083f, -0.05176083f, -0.05170148f, -0.05939724f, 0.03290068f, 0.00990286f, 
    0.06130394f, -0.06092724f, -0.05041844f, -0.14090642f, 0.31081316f, 0.05140138f, -0.16079357f, 0.02991792f, 
    -0.02249397f, 0.00121518f, -0.10877768f, 0.06116552f, 0.00830387f, 0.03928641f, 0.09318352f, 0.02407329f, 
    -0.14481297f, -0.27874246f, -0.07456208f, 0.02683791f, -0.07440679f, 0.04572006f, -0.04712129f, 0.00506335f, 
    -0.03243542f, -0.07108819f, 0.04858387f, 0.03595065f, 0.04343697f, -0.09885985f, -0.16646712f, 0.05459690f, 
    0.02414926f, 0.00570359f, -0.05325674f, 0.04375599f, 0.10813371f, -0.09261864f, -0.12063198f, -0.06457024f, 
    0.09064005f, 0.06423726f, 0.06890284f, 0.17831172f, -0.08289731f, 0.02220045f, 0.21926159f, -0.09112682f, 
    0.01210203f, 0.01290805f, 0.00547065f, -0.08864487f, 0.07690536f, 0.23047790f, -0.04934182f, 0.18139084f, 
    -0.04465023f, -0.02763328f, 0.19677863f, -0.06248442f, -0.10104294f, 0.03811842f, 0.01398400f, -0.03615598f, 
    -0.01168268f, -0.01674126f, 0.00940011f, 0.00671071f, 0.01525732f, 0.01330169f, -0.02025268f, 0.00050393f, 
    0.01729714f, -0.02482950f, -0.04389245f, -0.02787510f, 0.03532090f, -0.01155913f, 0.00266619f, 0.00423906f, 
    -0.02196105f, -0.03470802f, 0.04220794f, -0.00656412f, 0.01439864f, -0.00988393f, -0.05102437f, 0.03453257f, 
    0.02363436f, 0.02227714f, 0.03367442f, 0.03365663f, -0.01838716f, -0.03069599f, -0.03953711f, -0.05085203f, 
    -0.03396370f, 0.01072158f, -0.00250246f, -0.05000163f, 0.01552613f, 0.01072048f, 0.01770439f, 0.03675265f, 
    -0.00293340f, -0.04271068f, -0.02902119f, -0.04712038f, -0.02481606f, -0.03887561f, -0.02621777f, -0.00304855f, 
    -0.03578426f, 0.04292059f, 0.00065737f, -0.03474921f, -0.01502258f, -0.00844364f, 0.03434317f, -0.04292048f, 
    -0.04519939f, 0.01185806f, -0.02572931f, 0.04587254f, -0.03990312f, 0.04560200f, 0.03445981f, 0.02350925f, 
    -0.04849806f, -0.03958330f, -0.04330291f, -0.00940620f, -0.00177790f, 0.02655814f, 0.02208824f, -0.04003408f, 
    0.02136415f, -0.01719873f, 0.02841917f, -0.04693759f, -0.00247532f, -0.01793256f, -0.04705241f, -0.03457178f, 
    -0.01296869f, -0.00452938f, 0.03768383f, -0.03936379f, -0.00466901f, -0.04624123f, -0.03871193f, -0.00897958f, 
    -0.00516106f, -0.02872746f, 0.01536281f, -0.01691135f, 0.01519283f, -0.01402087f, 0.01174067f, -0.04708564f, 
    -0.02492482f, 0.04195617f, 0.04318056f, 0.02756310f, -0.02471815f, -0.02912665f, -0.00454833f, -0.04511067f, 
    0.03645583f, -0.04177829f, 0.04703387f, -0.01356531f, -0.03610590f, 0.00850450f, 0.02642485f, 0.04379814f, 
    -0.02267268f, -0.02023279f, 0.04060002f, -0.00709841f, -0.03599117f, 0.04780409f, -0.04749770f, 0.02057384f, 
    0.02442753f, -0.02315282f, -0.03123739f, -0.04795899f, -0.01312296f, -0.03718849f, 0.01183658f, -0.01433992f, 
    0.04509129f, -0.04942084f, 0.00703653f, 0.00406377f, 0.03879474f, 0.01486421f, 0.03619150f, 0.02424515f, 
    -0.01955743f, 0.03387358f, -0.03255964f, 0.02404256f, 0.00047948f, -0.04146795f, -0.00226810f, -0.01104752f, 
    -0.00478494f, -0.00057003f, -0.02988095f, 0.02841189f, 0.04090762f, -0.04696306f, 0.00955549f, 0.04610018f, 
    -0.04169066f, 0.00935369f, 0.04614860f, 0.01250480f, -0.02964442f, 0.00817261f, -0.00459225f, -0.03932482f, 
    -0.02076947f, 0.04380879f, -0.02101361f, -0.00709963f, 0.02874676f, -0.03631400f, -0.02600124f, 0.03902556f, 
    0.02132723f, -0.00876576f, 0.01304533f, -0.02735190f, -0.00364490f, 0.01669246f, -0.01904050f, 0.01649342f, 
    -0.01838900f, -0.05097135f, -0.04215786f, -0.02582734f, 0.01456032f, -0.00740688f, 0.00298135f, -0.04875160f, 
    0.02462133f, 0.04601046f, -0.02863740f, -0.02103600f, 0.01638624f, -0.01052462f, 0.04869162f, -0.01661776f, 
    -0.03076425f, -0.04716400f, -0.00636374f, -0.00443704f, 0.03688797f, -0.02163220f, 0.02312888f, -0.03584141f, 
    0.01246629f, 0.04426455f, 0.01067383f, 0.03773810f, -0.01042365f, 0.03027118f, 0.03613144f, 0.03417009f, 
    0.02991871f, -0.00002219f, 0.01494631f, 0.03199236f, -0.01888097f, 0.04550952f, 0.03929380f, 0.01944678f, 
    -0.01704907f, 0.00942417f, 0.00224529f, -0.04902790f, -0.04195043f, 0.04655138f, -0.01848807f, -0.03489186f, 
    -0.04897922f, 0.00652618f, -0.04812129f, -0.01313175f, 0.00353721f, -0.01744135f, -0.01469724f, 0.02277357f, 
    -0.03620140f, 0.00176060f, 0.03688685f, 0.02495554f, -0.02496321f, -0.02010721f, -0.02263277f, 0.02093240f, 
    -0.03747907f, 0.01812202f, -0.02775215f, -0.00594495f, 0.03366788f, 0.00290874f, -0.00234755f, -0.01697335f, 
    -0.00888626f, -0.04847381f, 0.00693423f, 0.04877685f, 0.04138308f, 0.02570631f, -0.02326723f, 0.02139989f, 
    0.02946693f, -0.04887597f, -0.02772695f, -0.00169438f, 0.02263106f, -0.04495574f, 0.02040095f, -0.02134172f, 
    0.00530742f, -0.03312166f, -0.04049413f, 0.01706754f, -0.02124835f, -0.03764351f, 0.00272703f, 0.00872928f, 
    -0.02292178f, 0.02424352f, -0.00292073f, -0.03401833f, -0.01114644f, -0.03997770f, 0.04372633f, -0.04051012f, 
    -0.03089763f, 0.01564489f, -0.01769971f, 0.00660685f, -0.02530130f, -0.00348395f, 0.01961239f, 0.02022376f, 
    0.02640943f, -0.01598885f, 0.02728763f, -0.01699577f, -0.02976276f, -0.04622689f, -0.03575693f, -0.04634568f, 
    0.04080429f, 0.01537095f, 0.03340651f, 0.01755399f, 0.01209993f, -0.04963173f, 0.02292908f, -0.01922387f, 
    0.03511723f, 0.04112642f, -0.02196038f, -0.03930280f, -0.00739149f, 0.02695181f, -0.03609597f, -0.02653782f, 
    -0.04010342f, -0.00479871f, -0.00891977f, -0.00751952f, -0.04098030f, 0.05087155f, 0.03300216f, -0.02878856f, 
    -0.00915971f, -0.00372226f, 0.04476659f, 0.03158052f, -0.03434216f, 0.04989983f, 0.03334469f, 0.04158295f, 
    0.03087747f, -0.01082972f, 0.01067622f, 0.01983625f, -0.00645165f, -0.00765972f, -0.02933500f, -0.03448980f, 
    0.01437755f, -0.01667211f, 0.02116905f, 0.00917233f, -0.00796134f, 0.03469685f, -0.00894764f, -0.00730994f, 
    -0.00237569f, 0.01630339f, -0.04295246f, 0.01068033f, 0.00409994f, -0.04560455f, -0.04664889f, -0.03977213f, 
    0.00200019f, -0.01116352f, -0.02128520f, -0.01964371f, 0.02224734f, -0.01940540f, -0.00808716f, -0.00587970f, 
    0.04241804f, -0.01742214f, -0.00029796f, -0.04349874f, -0.04116698f, 0.03404919f, -0.01048042f, 0.01062624f, 
    0.03514599f, 0.00911043f, 0.04040064f, 0.03706071f, -0.04746833f, -0.01730700f, -0.04143388f, -0.02219808f, 
    -0.00533410f, -0.02831790f, 0.01006396f, -0.03923206f, -0.02039964f, 0.01103209f, 0.04500291f, -0.01060704f, 
    -0.03078132f, 0.03042975f, -0.02045461f, -0.02565324f, -0.05026857f, 0.04631231f, -0.01854529f, -0.04467389f, 
    -0.03638277f, -0.01676439f, -0.04541472f, 0.00538331f, -0.00200453f, 0.02888175f, -0.04157557f, 0.02012031f, 
    -0.04880890f, 0.01920193f, -0.03020534f, -0.00653287f, -0.02790857f, -0.00534044f, 0.00728362f, -0.04488773f, 
    0.01471908f, -0.03003492f, -0.00196214f, -0.02766372f, 0.03192050f, -0.00126517f, 0.04795112f, -0.03639998f, 
    -0.04721478f, 0.04910319f, -0.02076960f, -0.01232686f, 0.00096646f, 0.01489666f, -0.00949612f, -0.04491624f, 
    -0.04243812f, -0.03991927f, -0.04598462f, -0.00683259f, 0.02317020f, -0.02654904f, -0.02906754f, 0.02760627f, 
    0.01862030f, -0.00576119f, 0.04571591f, -0.04935065f, -0.02555124f, 0.01187400f, 0.01877402f, 0.00453983f, 
    0.03388794f, -0.02615705f, -0.03368833f, 0.02007495f, 0.03930378f, -0.01899376f, 0.00539795f, 0.00535016f, 
    0.00515532f, -0.04355247f, -0.03585942f, -0.04476051f, 0.02197161f, 0.01970389f, 0.01824985f, -0.03140626f, 
    -0.00224324f, -0.00954547f, 0.00297150f, -0.01460268f, 0.02218525f, -0.04070764f, -0.04086880f, -0.04253543f, 
    -0.02225858f, -0.04646283f, 0.03866315f, -0.05075670f, 0.02736896f, 0.02824245f, 0.00219363f, 0.03216705f, 
    -0.01555100f, -0.02383339f, -0.01524357f, 0.04601540f, -0.00289764f, 0.04582534f, -0.04726693f, 0.02245819f, 
    -0.04865333f, -0.03089277f, -0.00751313f, -0.03818852f, -0.00154729f, -0.00249421f, 0.02846907f, 0.00651499f, 
    -0.04529358f, -0.00231630f, -0.04834304f, -0.03678367f, 0.02901767f, -0.00316803f, 0.04565062f, 0.00490468f, 
    -0.02654366f, 0.00614544f, 0.02019145f, 0.04629998f, -0.02889660f, 0.01170035f, 0.01778004f, 0.03654300f, 
    0.01024848f, -0.02720879f, -0.03307261f, -0.03919660f, -0.02912284f, -0.00927472f, -0.02857477f, 0.00391671f, 
    -0.00662623f, 0.02666733f, -0.01468197f, 0.04262352f, 0.03837887f, 0.05013736f, -0.02756565f, 0.00905247f, 
    0.01910476f, -0.04404597f, -0.02530609f, 0.00990188f, -0.02881689f, 0.00278045f, 0.04344232f, 0.01711092f, 
    -0.03009769f, -0.03295771f, 0.01385976f, 0.03232993f, 0.01940198f, -0.04607881f, -0.04365641f, 0.01401973f, 
    -0.03941076f, -0.00500971f, -0.04566535f, -0.04889602f, 0.01562606f, -0.01711264f, 0.00361868f, -0.02314297f, 
    0.01530127f, 0.02575578f, -0.04706889f, -0.00858438f, -0.03245662f, 0.04690544f, 0.03709674f, 0.02761686f, 
    0.03829335f, 0.00031377f, 0.02075528f, 0.02583790f, 0.01634632f, 0.04427890f, -0.01092018f, -0.03203562f, 
    -0.01513027f, 0.02756147f, -0.00876976f, 0.01545372f, -0.02396664f, -0.02258057f, 0.00052051f, -0.02931308f, 
    -0.00247233f, -0.00447869f, 0.02429588f, -0.00151310f, 0.00421525f, 0.00624169f, -0.03879829f, 0.01878537f, 
    0.03529692f, -0.04892509f, 0.02630302f, -0.01892267f, 0.00540451f, -0.01209885f, -0.03162014f, -0.03933527f, 
    0.02675287f, 0.02192826f, -0.04017501f, 0.00239620f, 0.01591870f, 0.00032330f, -0.02896503f, -0.03119280f, 
    -0.00414535f, 0.04842144f, -0.02103929f, 0.04407692f, 0.02072449f, -0.03363460f, 0.00280986f, -0.03264587f, 
    -0.00464522f, 0.02380366f, 0.04402511f, -0.04456979f, -0.00723915f, -0.02133959f, 0.00732446f, 0.05043283f, 
    -0.01075171f, 0.03520902f, -0.00728782f, -0.00263234f, 0.04860634f, -0.00946196f, -0.04303983f, -0.04902526f, 
    -0.04366554f, 0.04893505f, 0.02923663f, -0.02798453f, 0.02689772f, 0.02408910f, -0.00846964f, 0.03303373f, 
    -0.03771268f, 0.01366926f, -0.04747310f, -0.00554237f, -0.01126262f, 0.00153398f, -0.03490968f, -0.02144131f, 
    0.00564552f, 0.04699207f, -0.04076527f, -0.03337187f, 0.00517212f, 0.05093299f, -0.02489020f, 0.02178924f, 
    0.04104724f, -0.01771280f, -0.03253013f, 0.04119297f, -0.01161885f, -0.01348079f, 0.01760671f, -0.00037436f, 
    0.03548026f, -0.05014665f, 0.04851442f, -0.02136471f, -0.02566454f, -0.00330893f, -0.02756300f, 0.03443420f, 
    0.01540215f, 0.02384204f, -0.00792664f, -0.00301592f, 0.01664594f, 0.02272184f, -0.04782671f, 0.03230491f, 
    -0.05047236f, 0.01446907f, 0.00796440f, -0.04082909f, -0.03338523f, 0.01427885f, -0.04536586f, -0.04337945f, 
    0.03039504f, -0.00416312f, -0.01958089f, -0.03752664f, 0.00216699f, 0.01226925f, 0.04813522f, -0.02528854f, 
    -0.03629577f, -0.02205846f, -0.00970414f, -0.00600545f, 0.04637984f, 0.03269257f, 0.03833508f, 0.04565215f, 
    0.04998490f, -0.04002559f, 0.04199912f, -0.04250073f, -0.01789190f, -0.00371827f, -0.03522357f, -0.03490939f, 
    0.00129781f, -0.01811011f, -0.00153918f, -0.03922428f, -0.00279766f, 0.02205691f, -0.00371000f, -0.01786355f, 
    -0.03907004f, 0.02040619f, -0.04236483f, 0.01967755f, 0.02925984f, 0.04292125f, 0.00529345f, 0.04160371f, 
    -0.01510972f, -0.03761776f, 0.03130421f, -0.02912233f, -0.00331598f, -0.03371854f, -0.04110793f, 0.02760801f, 
    -0.03054489f, -0.04321921f, -0.04259539f, -0.00412484f, 0.04591126f, 0.02603974f, 0.02058386f, -0.05100811f, 
    -0.01709543f, -0.01560672f, -0.02973651f, 0.03259653f, 0.00828893f, 0.02370236f, 0.03924050f, -0.03394882f, 
    -0.03887028f, 0.01076573f, -0.02288130f, 0.01597816f, -0.02164634f, -0.02103542f, 0.03435454f, 0.00630831f, 
    -0.04274862f, -0.04417377f, -0.01280940f, -0.03189194f, -0.03647202f, 0.00231138f, -0.01824842f, -0.04080999f, 
    0.01884421f, -0.00841864f, -0.02992359f, -0.02892841f, 0.03022334f, 0.00983469f, -0.03296273f, -0.02754640f, 
    -0.03023106f, -0.05021474f, -0.00280998f, 0.01994972f, -0.00436765f, -0.00009502f, 0.04133011f, 0.03064970f, 
    -0.04557937f, 0.01749425f, -0.00209426f, -0.02217872f, -0.04334736f, -0.05660667f, -0.04521226f, -0.03088128f, 
    -0.01086384f, -0.05359166f, -0.04013601f, -0.01065029f, 0.01777818f, -0.01020697f, 0.00892517f, -0.01581314f, 
    0.04475490f, -0.01446560f, -0.00566487f, 0.04345023f, -0.02709273f, 0.00718992f, -0.03273205f, 0.02053111f, 
    0.03684036f, 0.01936306f, 0.02592551f, -0.03801272f, -0.04208357f, 0.03324808f, -0.00822067f, 0.03732160f, 
    0.01212845f, -0.00975685f, -0.00081657f, -0.04520026f, -0.05009757f, 0.01869805f, 0.00587518f, -0.02755782f, 
    0.01905728f, 0.02183315f, -0.03418257f, -0.04763067f, 0.00270234f, -0.05498964f, -0.02818954f, -0.05242827f, 
    -0.04658657f, -0.05241082f, 0.00271175f, -0.03398932f, -0.04963628f, -0.05391407f, 0.03095705f, -0.01870072f, 
    -0.05590504f, -0.00988512f, -0.01878287f, -0.00107737f, 0.02970070f, 0.00061139f, -0.02886054f, -0.02576286f, 
    -0.03904433f, 0.01882908f, 0.00681973f, -0.03460891f, 0.02246956f, 0.00927562f, -0.00472863f, 0.04191923f, 
    -0.05441993f, -0.00221521f, 0.00120230f, -0.04711011f, 0.02400743f, 0.04432783f, -0.05426796f, -0.03868164f, 
    -0.02816067f, 0.02466649f, 0.02429188f, -0.03192323f, -0.00581386f, -0.00934506f, -0.02124355f, -0.01650253f, 
    0.02878298f, -0.04566975f, 0.00249484f, 0.03160834f, -0.04142998f, -0.04763938f, -0.02784947f, -0.00837498f, 
    0.01772131f, -0.04847116f, -0.01102588f, -0.03090802f, -0.01871637f, 0.02501281f, 0.01328493f, 0.02697481f, 
    -0.05494789f, -0.05227752f, -0.04947774f, 0.00350508f, -0.00537927f, -0.01634298f, 0.03893008f, 0.02446894f, 
    -0.02007283f, 0.02143966f, -0.00790061f, -0.02892458f, 0.02897958f, -0.02451603f, 0.01793705f, -0.01869335f, 
    0.01837508f, -0.02953022f, 0.03122223f, 0.03775190f, -0.00732604f, 0.02912522f, -0.00712942f, -0.03720784f, 
    0.01281131f, -0.01088260f, 0.00153814f, -0.01333073f, -0.05349022f, 0.01140456f, -0.04051161f, 0.01975097f, 
    0.01655727f, -0.05033981f, 0.03286596f, 0.02980010f, 0.00612016f, 0.00490176f, -0.02367828f, -0.01725059f, 
    -0.04164855f, -0.04916923f, -0.02694100f, 0.03465156f, -0.04776341f, 0.02849136f, -0.04169211f, 0.03033195f, 
    -0.01625660f, 0.04353420f, 0.01557387f, -0.05506159f, 0.00261010f, 0.00352237f, 0.02786831f, 0.02498885f, 
    0.01386984f, -0.01122783f, -0.00514080f, -0.02644490f, 0.03144509f, -0.03841908f, 0.00755275f, 0.00325730f, 
    0.02053530f, -0.03636744f, 0.04051985f, -0.05188590f, 0.03615325f, 0.01492759f, 0.03770231f, -0.04004196f, 
    -0.00684200f, -0.03637253f, 0.04023316f, 0.01424287f, -0.05475532f, 0.00522576f, -0.05308184f, 0.00608869f, 
    0.03891455f, 0.01855128f, 0.03919198f, 0.04091078f, 0.00844536f, 0.00826619f, -0.00151060f, 0.03190206f, 
    -0.00123928f, 0.01340971f, -0.05530322f, 0.01137108f, -0.03453166f, 0.00151464f, -0.05536485f, -0.00708752f, 
    -0.00185492f, -0.00956740f, 0.04353591f, 0.03835063f, 0.03261880f, 0.01723077f, 0.00433796f, 0.03734415f, 
    -0.04175257f, -0.02028968f, -0.04281564f, 0.03466742f, -0.05391347f, 0.02597699f, -0.03176797f, -0.04891520f, 
    -0.03454357f, 0.02959820f, 0.03895475f, -0.04344916f, -0.05610356f, -0.04984763f, -0.03561692f, 0.02422216f, 
    -0.00764614f, -0.03159264f, 0.00591294f, 0.00178220f, -0.04046831f, -0.01327782f, 0.00549786f, -0.00653305f, 
    -0.04257081f, -0.02604534f, 0.01627417f, -0.03397565f, 0.02418697f, 0.01991419f, -0.01700213f, -0.00924641f, 
    -0.05554771f, 0.02270370f, -0.03792760f, 0.02975913f, 0.02366281f, -0.03830265f, 0.00063554f, 0.01328007f, 
    -0.03708301f, 0.03311800f, -0.00588595f, -0.01899787f, 0.04443139f, -0.05097858f, -0.03708907f, -0.05406627f, 
    0.01716011f, -0.02115739f, 0.02043707f, -0.02398454f, -0.04037655f, -0.03909554f, -0.02794927f, -0.00298985f, 
    0.01037311f, 0.01899971f, 0.02093037f, 0.01559813f, -0.03612210f, 0.03369698f, -0.03785596f, -0.03616565f, 
    -0.02854645f, -0.03072233f, -0.03207620f, 0.02342269f, -0.04650281f, 0.02941601f, 0.01834143f, -0.03780858f, 
    0.02969997f, -0.03084120f, 0.03987375f, -0.02512370f, 0.01755885f, -0.00132862f, -0.03678912f, 0.00072970f, 
    -0.03814845f, 0.04110941f, 0.01390130f, 0.03563615f, 0.01276561f, 0.02050411f, -0.00566034f, 0.03853891f, 
    -0.04520467f, -0.01071679f, 0.02038656f, -0.01509480f, -0.02574801f, -0.03597575f, -0.03457757f, -0.00937933f, 
    -0.03076877f, -0.04467405f, 0.02807604f, 0.01463698f, 0.02827278f, -0.05114124f, 0.03347286f, 0.01790254f, 
    -0.04687905f, -0.02250890f, -0.03132406f, -0.01313796f, 0.00334824f, 0.02361974f, -0.02343947f, -0.02172958f, 
    -0.05096805f, 0.02916679f, -0.01554738f, -0.00191985f, 0.02285770f, 0.02269931f, -0.03716700f, 0.01498707f, 
    0.04011968f, -0.02280095f, -0.01928022f, -0.04876965f, -0.04919236f, 0.02756325f, -0.05620874f, -0.00399300f, 
    -0.05558643f, -0.03843353f, 0.02697282f, 0.00148578f, -0.00947001f, 0.00228615f, 0.03418930f, 0.01737317f, 
    0.00845985f, 0.02052326f, -0.04674255f, -0.05632364f, -0.00377642f, 0.02406173f, -0.03329776f, 0.02874712f, 
    -0.05000842f, -0.03839988f, -0.02296114f, -0.00421611f, 0.03903101f, 0.03225980f, 0.02049207f, 0.02579689f, 
    0.03415742f, 0.01233679f, 0.04182917f, -0.04896252f, -0.04280151f, -0.03672748f, -0.05390607f, -0.01923275f, 
    0.04415153f, -0.03058318f, -0.01850115f, -0.02590459f, -0.00728545f, -0.02143536f, -0.00693132f, -0.01387376f, 
    -0.00269265f, -0.02674344f, -0.04081509f, 0.02715448f, 0.01977753f, -0.02119223f, -0.00962899f, -0.02937094f, 
    -0.05509697f, 0.17871512f, -0.13821737f, -0.08793292f, 0.00710070f, 0.07023455f, 0.06267615f, 0.12960744f, 
    0.08208874f, 0.10214423f, -0.00758687f, 0.07974347f, -0.28776005f, 0.19301297f, 0.12185177f, 0.04552967f, 
    0.07768837f, -0.05239861f, 0.14015846f, 0.04033640f, -0.00323480f, -0.02481842f, -0.04458261f, 0.10160382f, 
    0.13548972f, -0.06273735f, -0.03073450f, 0.03366635f, -0.06136844f, 0.00316245f, 0.01041150f, 0.01716097f, 
    -0.02638225f, -0.07386990f, -0.05604208f, -0.07787099f, 0.12056295f, 0.06766480f, -0.08018280f, 0.08872951f, 
    -0.08297297f, -0.03706301f, -0.13497443f, -0.09663225f, -0.01421625f, -0.06408089f, 0.00103335f, 0.03269950f, 
    -0.03696154f, -0.03111972f, -0.01288308f, -0.01519066f, -0.20742245f, 0.01708714f, -0.13495633f, 0.05144159f, 
    0.00436135f, 0.01777454f, 0.09330425f, -0.01725863f, 0.54991782f, -0.19053596f, -0.08010400f, 0.04052498f, 
    -0.04085941f, 0.07133202f, 0.06969316f, 0.15059601f, 0.03692050f, -0.05682663f, -0.01285541f, 0.09087997f, 
    0.07111041f, -0.02675322f, 0.04682493f, 0.19165741f, -0.06753072f, 0.13255213f, -0.01044424f, 0.07981442f, 
    0.13679484f, 0.06828362f, 0.05612807f, 0.08036162f, -0.37081170f, -0.01991519f, -0.23999296f, -0.18542448f, 
    -0.10661603f, 0.12925188f, 0.05243244f, 0.11677856f, -0.00383708f, 0.10151704f, 0.09194667f, 0.06577283f, 
    0.10792250f, -0.04650649f, 0.14891747f, 0.05737093f, 0.06688756f, 0.01303467f, -0.02328206f, 0.03603109f, 
    0.06234848f, -0.05992195f, 0.06392187f, 0.11955953f, 0.28096408f, 0.05590190f, -0.11069444f, -0.10086471f, 
    0.00230894f, 0.10918473f, 0.08673299f, 0.05872805f, 0.08250777f, 0.02012340f, 0.01411146f, -0.04130636f, 
    -0.11230310f, 0.08273917f, 0.05137646f, 0.07735340f, 0.15863331f, 0.08633617f, 0.06939637f, 0.16656919f, 
    -0.05417587f, -0.00164434f, 0.12234731f, -0.00530286f, -0.02750367f, 0.00315187f, -0.08874248f, -0.01582870f, 
    -0.00277648f, 0.01837195f, 0.02639505f, -0.02279223f, 0.00639988f, -0.03990755f, 0.02926809f, 0.04178231f, 
    -0.11575659f, -0.23030832f, -0.07951590f, -0.16958188f, -0.05688192f, -0.04002442f, -0.02160696f, 0.14716552f, 
    -0.02888455f, 0.09020969f, -0.04223351f, 0.04889816f, 0.26088676f, -0.29702315f, -0.17144543f, 0.12259565f, 
    0.10672125f, -0.04267114f, 0.09202456f, 0.01834791f, -0.02737005f, 0.08336916f, -0.07282936f, 0.06019061f, 
    0.33972093f, 0.00328954f, 0.00313734f, -0.09092315f, 0.07244119f, 0.17474277f, 0.02582619f, 0.14963683f, 
    0.09118079f, -0.06250658f, 0.07139963f, 0.02374682f, 0.28348616f, 0.01562911f, -0.01580605f, 0.14620289f, 
    0.09410585f, 0.04544953f, 0.10365108f, 0.10356933f, -0.03407658f, 0.04778868f, -0.00668931f, 0.00887133f, 
    0.31214046f, 0.11607145f, -0.07429049f, 0.04287633f, 0.17233478f, 0.05892970f, 0.11884678f, 0.06665642f, 
    0.00394151f, 0.02385211f, 0.05135921f, 0.07228526f, 0.30363727f, 0.07594141f, -0.16658795f, 0.13401295f, 
    0.01862307f, 0.13840613f, 0.11185232f, 0.00681569f, -0.13382532f, -0.03016189f, 0.05912603f, -0.06956690f, 
    0.06413601f, 0.04720447f, -0.03733093f, -0.14125593f, -0.09927268f, 0.00863352f, 0.03905164f, -0.01891180f, 
    0.01602984f, 0.05301500f, -0.00901674f, 0.12903056f, -0.00082528f, -0.21105009f, 0.00165463f, -0.00979224f, 
    0.00272982f, -0.04233810f, 0.01155799f, -0.11943634f, 0.01401543f, 0.04023781f, 0.06579674f, 0.02568075f, 
    0.28729129f, -0.15973832f, -0.17247777f, 0.00293013f, -0.03961821f, 0.03071383f, 0.01608669f, 0.10051037f, 
    0.07936381f, 0.06583627f, 0.00813942f, 0.06413265f, 0.12703335f, 0.06889316f, 0.18559849f, -0.06805968f, 
    0.15137546f, 0.03933521f, -0.05120499f, 0.11860774f, 0.04218813f, 0.12730052f, 0.00452597f, 0.08629524f, 
    -0.02465276f, -0.05595225f, 0.00527559f, 0.06213033f, 0.03062085f, -0.04357179f, 0.03957850f, -0.01565749f, 
    0.01863181f, 0.03985405f, 0.05883801f, -0.05398200f, -0.16218004f, -0.16386798f, -0.02155399f, -0.15601046f, 
    -0.13953860f, -0.05335874f, 0.03258025f, 0.06139196f, 0.14705935f, -0.04507013f, 0.04955656f, 0.02681899f, 
    -0.26589194f, -0.03002805f, -0.02864450f, 0.05322135f, 0.04522547f, 0.04927580f, -0.02709522f, 0.00437588f, 
    -0.01280718f, 0.01188969f, -0.03726374f, -0.09817571f, 0.25872943f, 0.04688668f, 0.22465590f, -0.10155771f, 
    0.09159557f, 0.04082980f, 0.03308865f, 0.09670319f, 0.08082587f, -0.03474664f, 0.05132563f, 0.04586811f, 
    -0.02672159f, -0.06115841f, -0.06816831f, -0.10885464f, -0.04599868f, 0.12235977f, -0.04052648f, -0.09319218f, 
    -0.01531455f, 0.01566491f, -0.11837968f, 0.07388743f, 0.11862646f, 0.00570862f, 0.12004762f, -0.12727380f, 
    0.13889134f, 0.13713527f, 0.02222936f, 0.11806665f, 0.11556593f, 0.15402129f, 0.01988476f, 0.00487775f, 
    0.14378710f, -0.29713988f, 0.05828166f, -0.06994569f, 0.05359686f, 0.07814527f, 0.07513890f, 0.07027148f, 
    0.03423097f, 0.03519868f, 0.14188308f, 0.00725637f, 0.04969953f, -0.07274617f, 0.16047694f, -0.16327617f, 
    0.15099566f, 0.10359284f, -0.03113935f, 0.04907018f, 0.10400800f, -0.02675738f, -0.02470229f, 0.13665383f, 
    0.21554390f, -0.17956708f, -0.06366020f, -0.06440265f, -0.11535647f, 0.06254110f, 0.04945502f, -0.06205815f, 
    -0.03806677f, 0.02332117f, -0.09873686f, 0.11351189f, -0.16262889f, -0.02103874f, -0.16825978f, -0.07441055f, 
    -0.13730140f, -0.03001580f, -0.02772416f, 0.00516924f, 0.03840892f, -0.02951551f, 0.06054852f, 0.04985531f, 
    0.00932809f, 0.03615781f, -0.04322034f, -0.03766228f, -0.04041778f, -0.05302612f, 0.01472188f, 0.03607818f, 
    -0.04856706f, 0.01616324f, 0.03820582f, -0.02349957f, 0.01120957f, -0.05861211f, 0.03177184f, -0.00014504f, 
    -0.02650152f, 0.03538243f, 0.00387457f, -0.00932791f, -0.03627549f, 0.02846006f, 0.00066634f, 0.03281301f, 
    -0.05856742f, -0.00627261f, 0.03592320f, 0.03698495f, -0.04226876f, -0.05992510f, -0.06012021f, -0.02156748f, 
    -0.01861665f, 0.02873645f, -0.00446933f, -0.01030977f, -0.05317830f, -0.02313453f, -0.03863017f, -0.04292104f, 
    -0.05676546f, 0.02528700f, 0.03556174f, 0.01682342f, -0.01414552f, -0.01823960f, -0.01778486f, -0.04718788f, 
    0.02235000f, -0.02622910f, 0.01171247f, -0.00366461f, -0.03981582f, -0.03147303f, -0.03109317f, 0.03514647f, 
    0.02815582f, 0.00100613f, 0.01684971f, -0.01459722f, 0.02695950f, -0.04972909f, -0.05147750f, -0.00456284f, 
    -0.03307500f, 0.00505220f, -0.00646004f, -0.04913113f, 0.01815991f, -0.03590158f, -0.00550582f, 0.01771280f, 
    -0.04434550f, 0.00362847f, -0.03423512f, 0.01487383f, -0.01094524f, -0.03176928f, 0.02703519f, -0.04248543f, 
    -0.05893248f, -0.04937895f, -0.01406186f, 0.02727608f, -0.00900882f, -0.01911752f, -0.03763938f, -0.05060656f, 
    -0.03410178f, -0.01070693f, 0.00442397f, 0.01217859f, 0.02760530f, 0.01478472f, 0.01147662f, -0.00075028f, 
    -0.02410874f, -0.05500397f, -0.02980696f, -0.03726415f, 0.00101087f, -0.03919712f, 0.01481995f, -0.05095803f, 
    0.03351017f, 0.00632994f, 0.01886768f, -0.01063810f, -0.05635747f, -0.00507403f, -0.01450339f, -0.04774950f, 
    -0.05831460f, -0.02229641f, -0.02061767f, 0.00016849f, -0.03843162f, -0.01560621f, -0.05386686f, -0.00280136f, 
    -0.00470030f, 0.01972932f, 0.02490129f, -0.03863753f, 0.02703969f, -0.04544684f, 0.02348687f, 0.02746186f, 
    -0.00309376f, -0.04938272f, -0.00714885f, -0.05898754f, 0.01241712f, 0.00690602f, -0.02390776f, -0.00587936f, 
    -0.01385374f, 0.00077629f, -0.02468745f, -0.03167190f, -0.03831588f, -0.02387740f, 0.02338508f, 0.01279974f, 
    -0.03031672f, -0.03620224f, 0.00673397f, -0.02272601f, -0.05570318f, 0.03057132f, -0.02431221f, 0.01335219f, 
    0.02410735f, -0.05705725f, 0.03583935f, -0.04394131f, 0.02330451f, -0.05376223f, -0.04701839f, 0.02158437f, 
    -0.03501783f, 0.02222665f, -0.02102000f, -0.02391788f, 0.01110565f, -0.01060390f, -0.03052253f, 0.02835933f, 
    0.01203863f, -0.02438318f, 0.03679945f, 0.01168409f, 0.00201198f, 0.00094953f, 0.03371510f, -0.02886032f, 
    -0.00283532f, 0.02476402f, 0.02821076f, 0.01907448f, 0.00538106f, -0.01005474f, -0.05376275f, -0.02735963f, 
    -0.04990791f, -0.00643817f, -0.02937899f, -0.03907771f, -0.01377573f, 0.02924128f, -0.04658770f, -0.02307805f, 
    0.02049023f, -0.01970884f, 0.01601459f, -0.01852826f, 0.01322452f, -0.06142187f, -0.05613359f, 0.02342996f, 
    0.00106792f, -0.00471733f, -0.01264791f, -0.02638037f, 0.03888441f, 0.01643904f, 0.01334896f, 0.03019946f, 
    -0.03238453f, -0.04835070f, -0.02662415f, -0.02588240f, 0.02119393f, 0.00040996f, -0.02270989f, 0.01504905f, 
    0.01528043f, -0.01882249f, 0.00068265f, 0.03523857f, -0.03507890f, -0.02793008f, -0.02003935f, 0.03735659f, 
    -0.02507609f, -0.02702906f, -0.04494545f, -0.05616545f, -0.04039827f, -0.00010864f, -0.04131803f, -0.04193569f, 
    0.03950289f, -0.03912447f, -0.00102872f, -0.05758036f, -0.05715340f, 0.02915270f, -0.01586278f, -0.01915031f, 
    0.00800306f, 0.01308389f, 0.02536302f, -0.02015512f, -0.01283164f, 0.00504884f, 0.01792868f, 0.01302244f, 
    0.03934388f, -0.00662077f, -0.05320849f, -0.05855221f, -0.05417058f, -0.00836416f, -0.03100989f, -0.00102924f, 
    -0.03986193f, -0.02690926f, -0.03292384f, -0.02662172f, -0.01717597f, 0.02448348f, 0.00513615f, -0.02343461f, 
    0.02723321f, 0.00384031f, -0.02377512f, 0.00274075f, 0.02091519f, 0.01236396f, 0.01510339f, 0.01482702f, 
    0.02587252f, 0.01448160f, -0.04156867f, -0.01028117f, -0.03234197f, -0.04463568f, -0.00302402f, -0.03571434f, 
    0.01439305f, -0.01183837f, -0.06015521f, 0.00921102f, -0.01651053f, 0.03551323f, 0.03792819f, -0.05298782f, 
    -0.03906720f, -0.02054903f, 0.01783429f, -0.02085531f, -0.05897336f, -0.01406197f, -0.05899030f, 0.02298595f, 
    0.04051384f, -0.00943179f, -0.00344309f, 0.00225659f, 0.00758438f, -0.01034744f, 0.03900505f, -0.01412512f, 
    0.02127482f, -0.04701178f, -0.05224324f, -0.02048915f, -0.04628035f, -0.00356134f, 0.01320652f, -0.00054156f, 
    -0.05334276f, 0.03438521f, -0.05133728f, 0.03148214f, -0.04665526f, -0.03463146f, 0.02235750f, -0.03555213f, 
    -0.00014993f, -0.03069252f, 0.02745738f, 0.01593319f, 0.03001297f, 0.04042221f, -0.00491332f, -0.04621462f, 
    -0.04116857f, -0.05656156f, 0.03922071f, 0.01445449f, -0.00323690f, -0.05062636f, 0.01214411f, -0.04045483f, 
    -0.04023607f, 0.01196044f, -0.02669096f, 0.03145664f, 0.01321815f, 0.00405783f, -0.02975820f, -0.01613680f, 
    -0.00794410f, -0.00955248f, 0.02136550f, 0.03439337f, -0.03730884f, 0.02531075f, -0.01305610f, 0.01081168f, 
    0.00179840f, -0.02070726f, -0.00785131f, -0.05515774f, -0.03225197f, -0.01548970f, -0.00015907f, 0.03716659f, 
    0.01388958f, 0.02225895f, 0.03244482f, -0.02757452f, -0.05204177f, -0.04733966f, 0.00764873f, -0.05717787f, 
    0.01392002f, 0.01740444f, 0.00549947f, -0.04450679f, 0.03296788f, 0.00087554f, 0.00199364f, 0.03486350f, 
    -0.01462668f, -0.01618008f, -0.04143543f, 0.01627614f, -0.00146578f, -0.04055820f, -0.03041382f, 0.02280039f, 
    -0.57778305f, 0.33363652f, 0.13809936f, -0.00633601f, 0.02247372f, 0.07245716f, -0.06471548f, 0.00315677f, 
    -0.03564950f, -0.05986241f, 0.09307579f, -0.07090336f, 0.33725202f, -0.28357014f, -0.07598525f, 0.10176771f, 
    -0.07197664f, -0.06386761f, 0.04718748f, 0.04693065f, 0.10469374f, 0.12279719f, -0.07305191f, 0.16167748f, 
    -0.02585853f, 0.04272539f, 0.07678214f, -0.08444011f, 0.02014982f, -0.04747349f, -0.01479467f, 0.02120457f, 
    -0.12351791f, -0.01689884f, 0.00047837f, 0.09611560f, 0.04601586f, 0.01710752f, -0.04908585f, -0.13309631f, 
    -0.05649630f, 0.07855519f, -0.04716637f, -0.01579533f, 0.05799437f, 0.00746223f, 0.01583032f, 0.04263173f, 
    0.14527731f, -0.04525728f, -0.01150664f, -0.21471460f, -0.11363994f, -0.06034024f, 0.01713731f, 0.03131535f, 
    0.00438115f, -0.00412306f, -0.00142461f, 0.11043652f, -0.09287257f, 0.23785383f, -0.14058363f, -0.07887153f, 
    -0.02860739f, -0.07682386f, 0.00911198f, 0.06911495f, -0.10270280f, -0.08475434f, 0.08921459f, 0.06669737f, 
    -0.44447646f, -0.04677280f, 0.08829587f, -0.12438882f, -0.03148390f, -0.02843874f, -0.02346572f, 0.04357449f, 
    0.05611805f, 0.06736179f, -0.04056776f, 0.04744241f, -0.26171869f, 0.34335604f, 0.03071577f, -0.16339989f, 
    -0.05202099f, -0.02393601f, 0.02967557f, -0.00687287f, 0.08012624f, 0.12249298f, -0.04077034f, -0.01271195f, 
    0.15018493f, -0.29435003f, -0.01816430f, 0.01710327f, -0.03687186f, -0.08900345f, 0.04176213f, 0.12636593f, 
    0.08415555f, 0.10967834f, 0.06627547f, 0.06574814f, 0.22545731f, 0.19198161f, 0.04793496f, -0.04053968f, 
    -0.05805982f, 0.00956814f, 0.05595450f, -0.04472484f, 0.00953915f, 0.06083255f, 0.00723995f, -0.02619467f, 
    -0.04395672f, -0.21499111f, -0.08783923f, 0.13510171f, -0.00897440f, 0.00796822f, 0.04294711f, 0.00167060f, 
    -0.02086531f, -0.06568612f, -0.00206671f, 0.08396578f, 0.01484330f, 0.05663285f, 0.03481005f, -0.01608124f, 
    0.01833701f, 0.02781667f, 0.04629957f, 0.14869437f, 0.04388991f, -0.01977591f, 0.11211774f, 0.02877207f, 
    0.26193982f, -0.13997012f, -0.04186017f, -0.19368540f, -0.03399979f, -0.07131536f, 0.04984787f, 0.08779993f, 
    0.01170797f, -0.02751897f, -0.02047710f, 0.05294191f, 0.21888253f, 0.08883144f, -0.00737925f, -0.32273653f, 
    0.04514286f, -0.01959699f, 0.05651265f, 0.03162132f, 0.06818560f, 0.06608386f, -0.09106077f, -0.02812225f, 
    -0.05614745f, -0.15154137f, -0.02134939f, 0.21738172f, 0.11225232f, -0.06463327f, 0.02969091f, 0.06369930f, 
    -0.07053915f, -0.01726183f, -0.04772639f, 0.05823261f, -0.30521721f, -0.16144498f, 0.03126546f, 0.01200760f, 
    -0.06725685f, -0.00047333f, 0.05422078f, 0.05173877f, -0.02697803f, 0.06623550f, 0.03715236f, 0.06862824f, 
    0.23621091f, -0.03841456f, 0.16624984f, 0.30884257f, -0.03413301f, 0.04586557f, 0.09191594f, -0.04874775f, 
    -0.02997799f, 0.05736910f, 0.12730372f, -0.04489327f, -0.18119782f, 0.21435982f, 0.00199972f, 0.10975615f, 
    0.06952392f, 0.00179702f, -0.00491939f, 0.08887944f, 0.08959188f, 0.06274923f, 0.00150680f, 0.11285002f, 
    0.17014618f, -0.03859493f, -0.04261885f, -0.04514046f, -0.07747433f, 0.00513253f, 0.09770422f, 0.11402880f, 
    -0.07255664f, 0.03995449f, -0.03300521f, -0.00413145f, -0.06179426f, -0.32339400f, 0.16647510f, -0.05371850f, 
    0.04885098f, -0.06480645f, 0.13275212f, -0.04137849f, -0.14674211f, -0.02927975f, 0.12255012f, 0.03551329f, 
    0.17578265f, 0.18672997f, -0.12226776f, -0.06833281f, -0.10328672f, -0.01026021f, 0.12506241f, 0.01917268f, 
    0.06663305f, 0.12788148f, -0.02890459f, 0.06558369f, -0.04597354f, -0.21758452f, 0.20139821f, 0.13829362f, 
    -0.11410920f, 0.05229276f, -0.05824978f, 0.08842649f, 0.12592529f, 0.02598950f, 0.05823927f, 0.00085474f, 
    0.03655720f, -0.08088579f, -0.00247359f, -0.18683273f, -0.01439453f, 0.08300863f, 0.10656340f, 0.15774237f, 
    0.00174297f, 0.05861061f, 0.00135722f, 0.18185447f, 0.00345460f, -0.00188605f, 0.06983362f, -0.04970270f, 
    0.01699703f, 0.18628579f, 0.07760837f, 0.02068801f, 0.07735524f, 0.08237470f, -0.05649950f, 0.01787808f, 
    -0.21347767f, 0.00602890f, -0.00540757f, -0.10294250f, 0.03556190f, -0.01410148f, 0.07299846f, 0.01703467f, 
    0.12608346f, 0.12776776f, -0.02504135f, 0.00643659f, -0.10155699f, -0.11370422f, -0.15685509f, 0.02666630f, 
    -0.10705072f, -0.03817380f, 0.04419846f, 0.02958459f, 0.04540568f, 0.02906770f, 0.09720571f, -0.02670812f, 
    0.17478694f, 0.06031214f, -0.03369401f, 0.05449460f, 0.00778401f, -0.03909104f, 0.10558397f, 0.15712151f, 
    -0.03087891f, 0.00793012f, -0.01115698f, -0.03731805f, 0.03866412f, 0.17682078f, 0.13863415f, 0.29081783f, 
    -0.03378847f, -0.03306825f, -0.01648694f, 0.08974419f, -0.02074192f, 0.01652380f, -0.05112694f, 0.00422610f, 
    -0.08165951f, -0.07927240f, -0.15965517f, 0.21750154f, -0.10899124f, 0.05915055f, 0.08278693f, 0.00658739f, 
    0.04700396f, 0.04732073f, 0.08124780f, 0.03063008f, 0.20549548f, -0.14706708f, -0.10727440f, 0.15800855f, 
    -0.14916436f, -0.06725392f, -0.08656991f, 0.05715453f, 0.06222116f, 0.04100252f, 0.00158822f, 0.08520915f, 
    0.02829673f, 0.08681407f, 0.00606625f, -0.09034329f, -0.01178257f, 0.01171489f, 0.14672443f, 0.10143583f, 
    0.11127514f, -0.03319896f, -0.05451621f, -0.01575414f, 0.10538317f, 0.08516654f, 0.03284116f, -0.22255993f, 
    -0.05097682f, -0.03593036f, 0.08754395f, -0.09558555f, -0.00425570f, -0.00863928f, -0.11775389f, -0.05389543f, 
    0.18634647f, -0.05361132f, -0.26038194f, -0.09058970f, 0.04128388f, -0.02571816f, 0.00817725f, 0.17425159f, 
    0.14899968f, 0.04374703f, 0.02235445f, 0.00648338f, -0.19921114f, -0.05309071f, -0.01316591f, 0.04989026f, 
    -0.02281860f, -0.05473740f, 0.03122333f, 0.07777154f, -0.04531583f, -0.02882453f, -0.00126236f, 0.08789600f, 
    0.08956406f, -0.02066200f, -0.10343529f, 0.03381796f, 0.05878285f, 0.05403211f, -0.05886968f, 0.03641791f, 
    0.05086547f, -0.01967432f, -0.10163575f, 0.07107431f, -0.06695902f, 0.04041293f, -0.00068412f, 0.09311755f, 
    0.08781634f, -0.09405328f, 0.04800398f, 0.11940950f, 0.09146573f, 0.03992430f, -0.10831827f, 0.04344354f, 
    -0.09010948f, -0.06588629f, 0.05639445f, 0.06907364f, 0.02356603f, 0.04568419f, 0.00786353f, -0.06926787f, 
    -0.00390902f, -0.16077323f, 0.01290948f, 0.00903690f, 0.34652609f, -0.07527656f, 0.01010927f, 0.08486391f, 
    0.02796893f, -0.02230247f, -0.04447065f, -0.00138478f, 0.01147411f, -0.12136317f, -0.11707108f, 0.05304428f, 
    0.05660219f, 0.04892191f, -0.01238633f, -0.00143704f, 0.00536838f, -0.03344462f, 0.11056986f, 0.01431937f, 
    0.06643420f, -0.01080825f, 0.12716939f, -0.02385391f, -0.50480026f, -0.24491312f, -0.22415373f, -0.07524236f, 
    0.05368479f, 0.02412457f, 0.03265381f, 0.05502734f, -0.05018728f, 0.01744266f, 0.08997584f, -0.00258005f, 
    -0.08722551f, 0.10174736f, 0.07932214f, 0.03466772f, 0.06054894f, 0.00428284f, 0.13892765f, -0.01783249f, 
    0.03726127f, 0.06536638f, 0.09673113f, 0.14773022f, 0.07589628f, 0.02934840f, -0.08474677f, -0.14152892f, 
    0.03142146f, 0.08327672f, 0.18178672f, 0.09743604f, -0.07259724f, -0.10976300f, 0.13858002f, -0.12034939f, 
    0.23994079f, 0.05808581f, -0.00531800f, 0.08467856f, 0.11479291f, -0.02213102f, 0.00081937f, -0.16930059f, 
    0.03110739f, -0.02869310f, -0.03756870f, 0.09563593f, 0.18439130f, -0.15265468f, -0.01079422f, -0.05006342f, 
    -0.02331736f, 0.05964477f, 0.04937844f, -0.01882679f, -0.04621553f, 0.13121949f, 0.14988710f, 0.04175767f, 
    -0.05480435f, -0.11289722f, 0.13307337f, -0.07835037f, 0.04683849f, -0.05669607f, -0.03046701f, 0.09187635f, 
    0.10668165f, 0.05378474f, -0.01198041f, 0.06514525f, -0.36857662f, -0.05175670f, -0.02427904f, -0.08987508f, 
    0.09145864f, 0.05818582f, 0.05084130f, -0.12026579f, 0.00778362f, 0.06235565f, -0.14255284f, 0.08863685f, 
    -0.02015882f, -0.09776486f, 0.01462068f, 0.01246844f, -0.05286452f, 0.05982051f, 0.07152629f, 0.12420109f, 
    0.00042978f, -0.13081914f, 0.09367148f, -0.07599713f, -0.25208074f, 0.03541097f, 0.26797029f, 0.06743819f, 
    0.23142417f, 0.01209767f, 0.17195781f, 0.05614376f, -0.03352900f, -0.00861372f, -0.01233076f, 0.01807040f, 
    -0.10187299f, 0.05803766f, 0.00702713f, -0.22142573f, 0.12382364f, -0.07061602f, 0.05314317f, 0.12507541f, 
    0.07039148f, -0.01351074f, 0.08868854f, 0.10334229f, 0.34147960f, -0.17310871f, -0.22622703f, -0.03488141f, 
    -0.04322974f, 0.07781933f, -0.01262391f, -0.04983106f, 0.04834608f, -0.03342298f, 0.08183800f, 0.10217054f, 
    -0.22281154f, -0.05569174f, -0.05742414f, 0.02510172f, -0.04688793f, 0.06399298f, 0.10113798f, 0.01077372f, 
    0.03055725f, 0.04384845f, 0.04883755f, -0.08797158f, -0.00899650f, 0.06711809f, 0.15453425f, -0.07040992f, 
    0.08023881f, 0.14883246f, 0.00140899f, -0.04628460f, -0.02935378f, -0.07681152f, 0.05212265f, 0.05428949f, 
    0.36542511f, -0.12497280f, -0.19177869f, -0.05280981f, -0.00027170f, -0.05002659f, -0.04785879f, 0.06972215f, 
    0.10947709f, 0.10237440f, 0.02100605f, -0.04593740f, -0.14824174f, 0.04202623f, -0.02774196f, -0.04243616f, 
    0.12573606f, -0.04329548f, 0.11316024f, 0.02605516f, 0.10516706f, 0.21092735f, 0.02758211f, 0.12473226f, 
    -0.09453301f, 0.02349178f, 0.10463809f, -0.02604779f, 0.03711275f, 0.01071772f, -0.03349376f, 0.05194936f, 
    -0.02863901f, 0.16540831f, -0.04844322f, 0.09798004f, -0.16647507f, 0.09852573f, 0.07661296f, -0.05483110f, 
    0.10302196f, -0.12387923f, 0.08345585f, 0.02817823f, 0.10023219f, 0.03866297f, 0.07796579f, 0.15520315f, 
    0.01171229f, 0.08090898f, -0.00454411f, -0.02618971f, 0.00381064f, 0.02072698f, -0.04476263f, 0.05198176f, 
    -0.06436858f, 0.01738513f, 0.01519281f, 0.11894445f, 0.04382684f, 0.21956795f, 0.23071988f, 0.09418416f, 
    0.21638930f, 0.11582444f, -0.08531007f, -0.00634589f, -0.08071849f, -0.04665913f, 0.16574399f, 0.08857884f, 
    -0.03338500f, -0.08696474f, 0.13475679f, -0.07381290f, 0.15562569f, 0.13830794f, 0.05157221f, 0.03520568f, 
    0.01765552f, 0.06011577f, 0.02114882f, 0.22109684f, -0.14632526f, 0.02240596f, 0.07838079f, -0.10632430f, 
    0.03476715f, 0.08418555f, -0.02254553f, -0.08748277f, 0.02812099f, -0.01877623f, -0.09789249f, -0.07216176f, 
    0.28104717f, 0.13472350f, 0.06484250f, -0.07211131f, 0.15612777f, 0.00916593f, -0.04188311f, 0.04519424f, 
    0.05122104f, 0.14686164f, 0.07892857f, 0.00211418f, -0.05411171f, 0.00112229f, 0.07700923f, -0.06697153f, 
    0.08417015f, 0.00114397f, -0.07213312f, 0.02524751f, 0.01373743f, 0.11155728f, 0.04862910f, 0.06783283f, 
    -0.02270446f, -0.03893093f, -0.17122263f, -0.17018989f, 0.10681986f, 0.01120888f, -0.03077843f, 0.03767598f, 
    -0.01493361f, -0.08460784f, 0.03453742f, -0.00474630f, 0.12727405f, -0.14564560f, -0.01882649f, -0.00066715f, 
    -0.00130006f, 0.09931842f, -0.17322674f, 0.15483318f, 0.12066310f, -0.03206669f, -0.00320993f, -0.03786161f, 
    -0.00336649f, 0.03115238f, -0.00059625f, -0.05528698f, -0.03266997f, 0.03863750f, -0.00783562f, 0.01345036f, 
    0.05109065f, -0.01875947f, 0.01164081f, -0.05222170f, -0.00017690f, -0.03270874f, 0.03773662f, -0.03465704f, 
    -0.05593827f, -0.01723816f, -0.04893220f, 0.04150497f, -0.00554678f, 0.04165459f, -0.04530856f, 0.00323066f, 
    0.00336477f, 0.02808588f, 0.00816109f, -0.02368132f, 0.00106004f, -0.01817699f, -0.04401550f, 0.04040368f, 
    -0.03136067f, 0.01893916f, 0.02214661f, 0.00079674f, -0.04522537f, -0.03291287f, -0.00983616f, -0.00156143f, 
    -0.02183549f, 0.00026687f, 0.00437676f, -0.03609926f, 0.03363786f, -0.03868806f, 0.01363612f, -0.04106613f, 
    0.02324962f, 0.03454264f, -0.01743237f, 0.00544285f, 0.01744045f, 0.00148602f, -0.03569850f, -0.03473172f, 
    0.00505038f, -0.00983994f, -0.04414930f, -0.00795803f, -0.03508420f, 0.00096657f, 0.00211512f, 0.00303550f, 
    -0.03341405f, 0.04500236f, -0.03016379f, 0.03399251f, 0.03241592f, -0.01315973f, -0.00447716f, 0.01034646f, 
    0.01136685f, -0.00875341f, 0.02777796f, -0.03906611f, 0.03142317f, -0.04205106f, -0.05517261f, 0.00676375f, 
    0.00674298f, 0.03392154f, -0.04239846f, 0.01319959f, 0.03226668f, -0.03138189f, -0.01967586f, 0.01875557f, 
    0.02098652f, -0.03404856f, 0.02551906f, 0.01859637f, -0.02749446f, 0.04241417f, -0.04530149f, 0.00928101f, 
    -0.03174261f, 0.03523489f, 0.00957974f, -0.04592721f, 0.02117076f, 0.03443703f, 0.01123302f, -0.00405422f, 
    0.03444855f, 0.03774519f, 0.02988244f, -0.03890970f, -0.05259801f, 0.02883438f, -0.01069293f, 0.03074393f, 
    -0.00722932f, -0.00112860f, -0.02433247f, 0.01864335f, 0.00873474f, -0.02976166f, -0.04503777f, -0.04931254f, 
    0.03922879f, -0.02381009f, -0.02262959f, 0.03343668f, 0.03825683f, 0.01584629f, 0.00060367f, 0.01005998f, 
    -0.00429132f, -0.05135635f, 0.00206131f, -0.00965338f, 0.03509011f, 0.02532400f, 0.00987938f, -0.05579156f, 
    -0.00361258f, -0.03961384f, -0.04525954f, -0.03980709f, -0.03958356f, 0.01877159f, 0.02626572f, -0.01640622f, 
    -0.05488143f, -0.05513341f, 0.01981744f, -0.01509720f, -0.02580846f, -0.00866979f, -0.00721575f, -0.03010275f, 
    0.03880420f, -0.01284772f, 0.04204535f, -0.01498939f, -0.05931529f, 0.01869210f, 0.02953711f, -0.04699276f, 
    -0.03847402f, 0.02830215f, 0.03975113f, -0.05919514f, -0.04722518f, -0.04630993f, -0.02514285f, -0.00067883f, 
    -0.06059906f, -0.01552092f, -0.00141646f, -0.03372484f, 0.01870419f, -0.03253005f, -0.00522066f, -0.03831448f, 
    -0.02047683f, 0.00693928f, -0.05205807f, -0.03403808f, 0.04715465f, 0.01440797f, 0.04016408f, 0.01175945f, 
    0.01498445f, 0.01983375f, -0.03503012f, -0.00252041f, 0.04827613f, 0.00613519f, 0.01207430f, -0.02596867f, 
    -0.02909587f, 0.01973120f, 0.03724929f, -0.03045405f, -0.02560304f, 0.00566904f, -0.02152668f, -0.02746404f, 
    0.02049533f, 0.01777287f, 0.04634767f, -0.00574007f, 0.01034282f, 0.00399076f, 0.01064715f, -0.01790142f, 
    -0.01975224f, 0.02288293f, -0.02623054f, 0.04106895f, -0.01512556f, 0.03440530f, -0.02651982f, -0.03670472f, 
    0.02610948f, -0.02150079f, -0.01565400f, 0.04000071f, 0.01564929f, 0.03271103f, -0.01243254f, 0.02924401f, 
    -0.03328407f, -0.01939222f, 0.02643944f, -0.01633162f, -0.01494041f, -0.02854998f, 0.00932569f, 0.03792015f, 
    0.02882631f, 0.02313866f, 0.00466973f, 0.01911099f, -0.03517032f, -0.00305809f, -0.02324475f, -0.04181235f, 
    -0.05898238f, 0.03554560f, 0.02590510f, -0.01270450f, -0.05104293f, -0.01704248f, -0.05661553f, -0.04523925f, 
    -0.01221262f, -0.05330906f, -0.01208185f, -0.05815456f, 0.00536188f, 0.01835001f, 0.02614138f, -0.02610497f, 
    -0.01807986f, 0.03675665f, 0.02495897f, -0.03120130f, 0.02904140f, -0.00336891f, 0.03881785f, -0.04089111f, 
    -0.01916181f, -0.01257407f, 0.03498371f, -0.04227928f, 0.00008321f, -0.04610415f, -0.04925778f, -0.03098596f, 
    -0.00394007f, 0.00633449f, -0.01315229f, -0.05370174f, -0.04276302f, -0.04435690f, 0.00407223f, 0.03102331f, 
    0.04305470f, -0.03950741f, 0.00042515f, 0.01598305f, -0.01007004f, -0.03226839f, -0.05155323f, -0.01964703f, 
    0.01634294f, -0.00313593f, 0.03735282f, -0.03727483f, -0.02098754f, -0.00821884f, -0.01497404f, -0.04355960f, 
    -0.00132402f, -0.00430463f, 0.01774321f, -0.01836657f, 0.02715109f, -0.03847779f, 0.03960783f, -0.04460814f, 
    0.01673773f, 0.02903748f, -0.01568341f, -0.00989054f, -0.05616226f, 0.01622625f, -0.02988759f, 0.00867247f, 
    -0.04056403f, -0.03327553f, -0.03732190f, -0.01803419f, 0.01681238f, 0.02978544f, 0.02759821f, 0.03825993f, 
    -0.03823921f, -0.00584905f, 0.02363250f, -0.05140075f, -0.01634123f, -0.04993575f, -0.02992111f, 0.03252725f, 
    0.03735143f, 0.02840041f, -0.01713967f, 0.02842860f, 0.02021507f, 0.00302900f, -0.01221386f, -0.04248569f, 
    0.03385818f, -0.02391271f, -0.04367047f, 0.04649725f, -0.02302356f, 0.02819047f, 0.02329222f, 0.02540972f, 
    -0.03385816f, -0.00413709f, 0.00164932f, -0.00692890f, 0.04168693f, -0.05232160f, -0.04722018f, -0.05448199f, 
    -0.05634559f, -0.01230814f, -0.04088979f, 0.01924388f, -0.05775372f, 0.01670211f, 0.04784191f, 0.03973730f, 
    -0.04144361f, 0.02354675f, -0.01684947f, -0.05695727f, 0.00024763f, -0.03939270f, 0.03058894f, -0.01025983f, 
    0.02603901f, -0.02696665f, -0.00787148f, 0.00699485f, 0.00380669f, 0.03560451f, 0.04475069f, -0.00941160f, 
    -0.02577064f, -0.02155514f, 0.00918364f, -0.03096183f, -0.02096365f, 0.01592873f, 0.03185889f, -0.05076700f, 
    -0.02125083f, 0.01165803f, -0.00520468f, 0.02068781f, -0.02590794f, -0.00291000f, 0.02973440f, 0.02119979f, 
    0.03974604f, -0.02089408f, -0.01323271f, -0.04371090f, 0.02767222f, 0.03464791f, -0.01707844f, -0.05230064f, 
    -0.04701724f, 0.02025544f, 0.04394872f, -0.00038125f, 0.03152108f, -0.04871110f, -0.02617538f, 0.00264637f, 
    0.03234850f, 0.02066505f, -0.04597310f, 0.01690993f, 0.02565470f, -0.03697255f, 0.04301837f, -0.04059802f, 
    -0.03665566f, -0.02408993f, -0.05197993f, -0.01681308f, 0.01343682f, 0.04067457f, -0.03044516f, -0.00022523f, 
    -0.04599404f, 0.01089374f, 0.03280296f, -0.04816205f, -0.05523339f, -0.04038470f, -0.00626558f, -0.04294612f, 
    0.00647180f, -0.04399024f, 0.01990269f, -0.02134993f, -0.04310491f, 0.02620860f, 0.00315426f, -0.01212419f, 
    0.04094632f, -0.02593825f, 0.03565652f, -0.00943362f, -0.00319571f, 0.01152432f, -0.05016354f, -0.04198176f, 
    -0.03171597f, -0.01892096f, -0.03284904f, -0.01383144f, -0.01966461f, 0.01883232f, -0.00028475f, -0.03768394f, 
    0.03974597f, -0.04966836f, 0.01039165f, -0.00321197f, 0.01127041f, -0.04354179f, 0.00741381f, -0.05109763f, 
    -0.04451913f, -0.05827670f, 0.04100263f, -0.05401976f, 0.02440079f, -0.03906989f, 0.04179059f, 0.02129519f, 
    0.02914504f, 0.02620092f, 0.03096096f, -0.04268475f, -0.03781983f, -0.00584920f, -0.02411945f, 0.03213259f, 
    -0.00834606f, 0.02440824f, 0.02829232f, -0.05078769f, 0.00720538f, -0.04960601f, -0.05486164f, 0.04288307f, 
    -0.02282208f, 0.02565533f, -0.02789257f, 0.03859671f, 0.01729110f, -0.04451084f, 0.02606156f, -0.04487529f, 
    -0.05091124f, 0.01935069f, 0.03815122f, 0.00710729f, -0.02215149f, 0.03378278f, -0.03574255f, -0.00522557f, 
    0.04308897f, -0.01336263f, 0.04320459f, 0.03405807f, 0.00660663f, 0.01781330f, -0.05345513f, -0.03802327f, 
    0.01714952f, 0.04386831f, -0.04953413f, -0.00725311f, 0.02315020f, -0.04561773f, 0.01754518f, 0.03863198f, 
    -0.00457921f, -0.01972759f, -0.00947294f, -0.03139544f, -0.02348415f, -0.01491031f, 0.01000287f, 0.03898681f, 
    -0.01992374f, 0.02207111f, -0.02499862f, -0.05449936f, 0.03680749f, -0.04260185f, -0.01784788f, -0.05479851f, 
    -0.00474657f, 0.01359320f, 0.01547521f, -0.00071259f, -0.01252129f, -0.05128308f, -0.03356186f, -0.01068505f, 
    -0.02149957f, -0.00892578f, 0.01729190f, -0.03287780f, -0.04014183f, -0.03854474f, 0.00500221f, -0.01399064f, 
    -0.04553548f, 0.00089743f, -0.02318952f, -0.00290690f, -0.03968270f, -0.05653130f, 0.02000070f, 0.00214730f, 
    -0.02496561f, -0.03908942f, 0.00246777f, -0.04275950f, -0.03808979f, 0.04246326f, 0.02950600f, -0.04160539f, 
    0.03627894f, 0.03288341f, 0.04231421f, 0.01020816f, -0.01788967f, 0.03130904f, 0.02813747f, 0.04470435f, 
    0.01328765f, -0.00851704f, 0.01344026f, 0.02050928f, 0.03141150f, 0.00974072f, -0.00032347f, -0.02514659f, 
    0.01666064f, 0.01100558f, -0.01992005f, 0.02288492f, 0.00663545f, -0.00740476f, 0.01621852f, 0.03670802f, 
    0.02587636f, -0.04243100f, -0.04211491f, -0.02340782f, 0.00473266f, 0.03772194f, -0.00743064f, -0.04998082f, 
    -0.00383101f, 0.03473744f, -0.04902744f, 0.02098302f, -0.00173817f, 0.02889808f, 0.01168562f, -0.00570660f, 
    0.00975145f, -0.02954117f, 0.02996623f, 0.03837377f, 0.03975252f, 0.02972606f, 0.01517667f, -0.04235990f, 
    -0.00367907f, 0.02789676f, -0.03066308f, -0.00502826f, -0.00658838f, -0.00602509f, -0.04186340f, 0.01154271f, 
    0.00999674f, 0.00341734f, 0.01281259f, 0.03712576f, -0.04666756f, -0.04833877f, -0.02237896f, 0.01489632f, 
    -0.00113184f, -0.03492907f, -0.05422055f, 0.03529757f, -0.05543355f, -0.04526933f, 0.04749170f, 0.02515949f, 
    -0.03512796f, -0.05130680f, 0.03344999f, -0.04717413f, -0.01333554f, -0.03700942f, 0.03440876f, 0.04283694f, 
    0.04021537f, 0.01948572f, -0.04137671f, -0.01399416f, -0.04782464f, 0.01070603f, 0.04159920f, -0.03319108f, 
    0.01288879f, 0.00168822f, -0.02994461f, -0.01113491f, -0.03223006f, 0.02729653f, 0.04201541f, -0.02414709f, 
    -0.05660493f, -0.01014112f, -0.04135198f, 0.00454615f, -0.03052007f, -0.01494311f, -0.04409792f, -0.01065968f, 
    0.00184016f, 0.03386527f, 0.04321171f, 0.01211792f, -0.00606454f, -0.00147766f, 0.02199277f, -0.00572636f, 
    -0.04124496f, -0.00434073f, -0.01005274f, 0.01967586f, 0.02653657f, -0.05087260f, -0.01290941f, 0.02693664f, 
    -0.01302372f, 0.03628648f, 0.02173420f, -0.00871458f, 0.02624306f, -0.00815666f, 0.02827505f, 0.01244289f, 
    -0.01937455f, -0.03702091f, 0.00055915f, 0.01768833f, 0.00832559f, -0.00927613f, 0.03666054f, 0.00725522f, 
    -0.00860049f, -0.05708125f, 0.03982683f, 0.03275189f, 0.00888456f, -0.02098448f, 0.00125760f, -0.03510140f, 
    -0.03510670f, -0.01577224f, -0.02994519f, 0.03378683f, -0.01327743f, 0.00974226f, -0.02183080f, -0.02603516f, 
    -0.01915119f, -0.05755255f, 0.01181613f, 0.01363026f, 0.04116241f, -0.05502785f, -0.00048612f, -0.02845639f, 
    -0.00906867f, 0.02311539f, -0.01767093f, -0.01694426f, -0.05570499f, 0.02696780f, -0.04980293f, -0.01817241f, 
    -0.00637438f, 0.01667378f, 0.02102817f, 0.03248978f, -0.05432520f, -0.05073202f, -0.01269797f, 0.03319113f, 
    -0.00887946f, 0.03423119f, -0.03611665f, 0.01172316f, 0.00725076f, -0.02069943f, 0.03396609f, -0.04988677f, 
    -0.03959878f, 0.03748452f, -0.01186481f, -0.00246775f, 0.04093056f, -0.01249426f, -0.02680674f, 0.01674312f, 
    -0.02335964f, -0.00508993f, -0.05359037f, -0.01676358f, -0.01280390f, -0.03139012f, -0.00152203f, -0.05131947f, 
    0.00862340f, -0.05098368f, -0.03278492f, 0.00286381f, -0.04193150f, -0.00959715f, 0.03758555f, 0.03119574f, 
    -0.00715105f, -0.02454879f, 0.02690012f, -0.05447461f, 0.04063408f, -0.00987753f, 0.00099309f, 0.03087798f, 
    0.02473751f, -0.01504020f, -0.05427866f, 0.02422190f, -0.00310507f, -0.00997649f, 0.03702701f, -0.04005751f, 
    -0.00299509f, -0.03596301f, -0.03888224f, 0.02085569f, 0.02835134f, 0.00353125f, 0.03716084f, -0.03516258f, 
    0.03472905f, -0.05495492f, 0.00747777f, -0.00482160f, -0.01915053f, -0.00511439f, 0.03267653f, 0.00138618f, 
    -0.01125461f, 0.04394973f, -0.05205604f, 0.03925575f, 0.00051468f, -0.04052707f, -0.05750667f, -0.04830284f, 
    0.03713902f, 0.04338489f, -0.04917434f, -0.03685276f, 0.00635446f, -0.04858687f, -0.01649205f, 0.02684575f, 
    -0.04911819f, 0.04542670f, -0.02992503f, -0.03423245f, -0.01055652f, 0.03163592f, 0.01815611f, -0.02274847f, 
    0.02655050f, 0.00639323f, -0.03893768f, -0.04561604f, 0.01711711f, 0.01375800f, 0.01960931f, -0.03072642f, 
    -0.02903738f, -0.01554568f, -0.03760368f, -0.02641726f, 0.03127028f, 0.00565582f, 0.02249895f, 0.04425863f, 
    -0.03840448f, -0.01618557f, 0.01646648f, 0.04312269f, -0.00866218f, -0.02623100f, 0.04173139f, 0.03509939f, 
    0.01792913f, -0.00914038f, -0.05157902f, 0.02278391f, -0.00929334f, -0.01927907f, -0.03362101f, 0.03786574f, 
    -0.05364292f, -0.02658631f, 0.01795151f, -0.03253750f, 0.01677183f, 0.02133915f, -0.03033572f, 0.01855100f, 
    -0.03701537f, 0.01527735f, -0.00473041f, 0.01070442f, -0.03779314f, -0.02405870f, -0.02937985f, 0.01880578f, 
    0.00132807f, 0.01664546f, -0.02581821f, 0.03254005f, -0.02432737f, -0.02723038f, -0.03208322f, 0.00753977f, 
    0.04308951f, 0.01552634f, 0.03060715f, -0.03380653f, -0.02297262f, 0.00354534f, -0.04797240f, -0.02821157f, 
    -0.01937558f, -0.00332761f, -0.03236897f, -0.00787525f, 0.02771619f, 0.03357981f, 0.03724124f, -0.02529767f, 
    0.02699100f, -0.00141275f, 0.02359679f, -0.02990005f, -0.04477727f, 0.02548274f, -0.02290152f, 0.00417221f, 
    -0.02430228f, -0.05744398f, 0.03423073f, 0.03951936f, -0.00082812f, -0.00532854f, 0.02852806f, -0.03258441f, 
    -0.03186855f, 0.00525744f, 0.00179038f, 0.02706068f, -0.00821614f, 0.02004338f, 0.02796822f, -0.00732368f, 
    0.00135931f, -0.04450288f, 0.00862025f, -0.02783910f, -0.02161781f, -0.02605157f, -0.00702419f, -0.00917722f, 
    0.00267158f, 0.03315321f, 0.00255004f, 0.01964374f, -0.03566043f, 0.01060448f, -0.01568861f, -0.04367900f, 
    0.04094405f, 0.00678629f, 0.01102953f, -0.04638247f, -0.01513452f, 0.04074748f, 0.00911258f, -0.03095923f, 
    -0.01088660f, -0.05592186f, -0.03642762f, -0.03270049f, 0.01002483f, 0.02245620f, 0.00654489f, 0.00171922f, 
    -0.04567120f, 0.01674817f, 0.01523418f, 0.03290114f, -0.01067698f, -0.01555264f, -0.00658931f, 0.03282166f, 
    0.03700683f, 0.02324488f, -0.05103587f, -0.04426968f, -0.05451116f, -0.05236974f, 0.03169420f, 0.03700183f, 
    0.03591684f, -0.05107429f, -0.05472558f, -0.00561536f, -0.02092361f, 0.02337496f, -0.03231665f, 0.01460696f, 
    0.00620992f, -0.05209835f, -0.04926850f, -0.02398403f, -0.03063316f, 0.04835927f, -0.05004898f, 0.01314031f, 
    0.04022218f, 0.00095516f, 0.03745009f, 0.03904962f, -0.00253458f, 0.00796782f, 0.04091071f, -0.03646352f, 
    -0.04005642f, -0.04427888f, -0.00253551f, 0.02345884f, -0.03546394f, -0.03085861f, 0.00639557f, -0.03740032f, 
    -0.05521591f, 0.03938819f, -0.00158071f, -0.02485939f, -0.03856431f, -0.00815877f, 0.00290763f, -0.05072462f, 
    -0.02778009f, 0.00174071f, 0.02016230f, 0.03484228f, 0.00871185f, 0.00631477f, -0.00365038f, 0.02343105f, 
    0.03497297f, -0.01295183f, 0.00244989f, 0.01139117f, -0.02258473f, -0.00702628f, -0.02436053f, 0.02424410f, 
    0.02886040f, 0.01878436f, -0.04986809f, 0.00251989f, 0.02336342f, -0.04574476f, -0.01757854f, -0.01571000f, 
    0.03155394f, 0.00419948f, 0.02720648f, -0.03570304f, -0.01443612f, -0.03846426f, -0.04311702f, -0.01700134f, 
    0.03164875f, -0.04193195f, 0.04221634f, 0.00304171f, 0.03465299f, -0.04107225f, -0.04261247f, 0.03163632f, 
    -0.01071539f, -0.04321720f, -0.03516551f, -0.01717364f, 0.02777624f, -0.00636617f, -0.04085544f, 0.02222814f, 
    -0.04347703f, 0.01101955f, -0.01180630f, -0.01031468f, -0.05010914f, 0.00322873f, -0.00329060f, 0.03322732f, 
    0.02667627f, -0.00883291f, -0.04748557f, -0.00979050f, -0.01980811f, -0.01662202f, 0.03101061f, -0.04053172f, 
    0.01143810f, 0.01934756f, -0.00296894f, -0.04259234f, -0.04889790f, -0.00522836f, 0.03422126f, -0.00046369f, 
    0.00573474f, -0.03760454f, -0.01656871f, 0.03597723f, -0.05177225f, 0.04513682f, 0.01992283f, -0.01312977f, 
    0.04197172f, 0.00859476f, -0.01938861f, 0.01515192f, -0.02858902f, 0.04746360f, -0.05282360f, -0.02633756f, 
    -0.01949074f, 0.00139632f, 0.00157991f, 0.03269683f, 0.01292753f, 0.00425623f, 0.01844438f, -0.01958963f, 
    -0.00321759f, 0.04280671f, -0.04302519f, -0.04202687f, 0.03530561f, -0.04091540f, -0.01772962f, -0.00413767f, 
    0.02900247f, 0.04214392f, -0.01719103f, 0.01013305f, 0.00664298f, -0.00728038f, -0.02961616f, -0.04920384f, 
    -0.05528708f, 0.02253396f, -0.04191834f, 0.02519372f, -0.00193612f, -0.03045162f, -0.05641450f, -0.00050322f, 
    0.00628124f, 0.02697201f, -0.02962638f, 0.01378718f, -0.03225806f, -0.01170312f, 0.01098823f, -0.01083329f, 
    0.02212076f, 0.03533525f, -0.00419491f, 0.01788051f, -0.01053994f, -0.02229154f, -0.00240113f, 0.01274771f, 
    0.02070214f, 0.08011856f, -0.09995570f, 0.01898323f, -0.08048486f, 0.00524487f, -0.03274233f, -0.02914303f, 
    -0.00261984f, -0.06727550f, 0.04790402f, -0.03578941f, 0.51921046f, -0.00366416f, -0.14822178f, 0.37772456f, 
    0.18648298f, -0.01083763f, 0.01753039f, 0.02576096f, -0.06307921f, -0.02564391f, -0.00789126f, -0.10666373f, 
    0.12867451f, 0.03097407f, 0.04059140f, -0.18301642f, -0.16150704f, -0.01192300f, -0.00988223f, 0.04006255f, 
    -0.02813469f, -0.00718132f, -0.03057139f, -0.09595174f, -0.12909946f, 0.09701001f, 0.03796284f, -0.08178326f, 
    0.00686075f, 0.06115969f, 0.03927001f, 0.02356179f, 0.07605927f, -0.14061022f, -0.11418255f, -0.00460613f, 
    0.20161523f, 0.13478401f, 0.16714598f, 0.24908125f, -0.01821900f, 0.01446696f, 0.12522967f, 0.08608510f, 
    -0.01008650f, 0.09463608f, 0.02619168f, -0.04851144f, -0.19170088f, 0.05756928f, 0.19342606f, -0.05621795f, 
    -0.02060183f, 0.06675740f, 0.05042132f, -0.05091158f, -0.00379339f, 0.07855664f, -0.11013653f, 0.07476457f, 
    0.24386801f, -0.01867322f, 0.09291867f, -0.31337816f, -0.00551211f, 0.07034189f, 0.02858482f, 0.00143848f, 
    -0.01585222f, 0.01828891f, 0.10777544f, -0.03528481f, 0.13729195f, 0.15800071f, -0.15801677f, -0.17010577f, 
    -0.11219861f, 0.00824390f, 0.02273697f, -0.12017744f, 0.16710195f, 0.11401236f, 0.04958801f, 0.02957208f, 
    0.57059729f, -0.08272897f, 0.08795056f, 0.13107042f, 0.05750947f, -0.02919467f, 0.07542240f, -0.06149405f, 
    -0.08076100f, -0.06371895f, -0.04932697f, -0.04081427f, -0.29109570f, -0.16361369f, 0.01659104f, -0.23578607f, 
    -0.01407575f, 0.13603644f, -0.05538753f, -0.03568340f, 0.18943855f, 0.01939821f, -0.13966843f, -0.06132512f, 
    0.27441585f, -0.21867809f, 0.05448881f, 0.08272289f, 0.00355719f, 0.06638411f, 0.03523232f, 0.02802659f, 
    -0.04459345f, 0.03914582f, 0.04866865f, -0.06024049f, -0.19590570f, -0.18029594f, -0.09116080f, 0.08888259f, 
    -0.03372457f, -0.08003071f, -0.00521275f, 0.10712612f, 0.02763532f, 0.03899668f, 0.10197455f, -0.03450201f, 
    0.20175515f, 0.14067110f, 0.32884547f, 0.15303855f, 0.08022929f, 0.03522077f, -0.00717210f, 0.07658379f, 
    -0.03443686f, -0.03729161f, 0.00819957f, -0.03669857f, -0.02509728f, -0.11284315f, -0.17322703f, -0.17551710f, 
    0.05465246f, 0.04256867f, -0.09328031f, -0.07903336f, 0.00664751f, -0.02699381f, -0.02226169f, -0.05463655f, 
    0.02324158f, -0.05324664f, -0.05077238f, 0.02296301f, 0.03837893f, -0.07048816f, -0.04489206f, -0.00147526f, 
    -0.09835013f, 0.09182568f, 0.04803425f, 0.02309056f, 0.50874579f, -0.15408309f, -0.00816988f, -0.11812310f, 
    -0.23064762f, -0.11462847f, 0.03125521f, -0.02217987f, 0.01369550f, -0.06262898f, -0.03568968f, 0.09640320f, 
    -0.21288110f, -0.23914851f, -0.00754857f, 0.19635126f, -0.02461478f, 0.03558252f, -0.09085466f, -0.01875267f, 
    -0.10901255f, 0.02047030f, -0.07312052f, 0.00282603f, -0.08855685f, -0.12634853f, -0.03853243f, -0.24625435f, 
    -0.01978747f, 0.01970434f, -0.12980939f, -0.25123331f, 0.04206352f, -0.04127618f, 0.05304561f, 0.01938578f, 
    0.10364620f, -0.03475867f, 0.15111364f, 0.00496687f, -0.08054287f, -0.03235377f, -0.03733463f, 0.05650426f, 
    0.09964076f, -0.10923497f, -0.12087665f, -0.03629247f, -0.06773078f, 0.00097448f, -0.04930043f, -0.07748304f, 
    0.08705724f, -0.12238429f, -0.00963586f, -0.02727283f, -0.04625737f, 0.01966029f, 0.03533006f, -0.05074564f, 
    0.18506242f, 0.16375054f, 0.13822801f, 0.12705985f, -0.02113472f, 0.01086454f, 0.03717453f, -0.02028106f, 
    0.11694355f, -0.14739680f, -0.00825005f, -0.06309675f, 0.30522850f, 0.02287376f, -0.01457073f, 0.26608723f, 
    0.11978409f, 0.05718008f, 0.06722451f, -0.01089708f, 0.06403518f, -0.10295291f, -0.05121754f, 0.03090958f, 
    -0.09017265f, 0.08777975f, 0.11559409f, -0.09774246f, 0.04118356f, -0.07811305f, -0.01901070f, 0.01435386f, 
    -0.13412848f, -0.00465586f, 0.04041649f, 0.06078373f, -0.02311473f, -0.06284650f, 0.08838651f, -0.07559787f, 
    0.01199661f, -0.02805870f, 0.01737889f, -0.00799830f, -0.01164113f, 0.09791742f, 0.04899424f, -0.02732717f, 
    0.25787130f, 0.00184118f, -0.02577394f, -0.13825466f, -0.01108381f, 0.00287996f, 0.05737274f, 0.07980822f, 
    0.03101806f, 0.04341313f, -0.17302640f, 0.05679712f, 0.30457172f, -0.11030174f, -0.07079447f, 0.21910214f, 
    0.05622976f, -0.01308431f, 0.01817646f, -0.00011124f, -0.07467467f, 0.05483266f, -0.05064543f, -0.03121568f, 
    0.07138079f, -0.05126803f, 0.19990467f, 0.10479544f, -0.12540443f, 0.11438082f, 0.07354989f, 0.03523708f, 
    0.04116776f, -0.01213444f, 0.06699113f, -0.10813301f, -0.03974974f, 0.11318936f, -0.19857626f, 0.07930373f, 
    0.04774258f, 0.08343891f, 0.09921518f, 0.02124648f, 0.03223107f, 0.01561940f, -0.04725873f, 0.01272831f, 
    0.06251536f, 0.02050295f, 0.09352939f, 0.00754709f, -0.11787406f, 0.02904216f, 0.07926037f, 0.04802188f, 
    -0.08726214f, 0.11648037f, -0.02142236f, 0.02734438f, 0.40016532f, -0.00392155f, -0.06231218f, 0.25568724f, 
    0.22810234f, 0.02770136f, 0.00449029f, -0.01831143f, 0.07214645f, -0.02941386f, 0.01369609f, -0.02020009f, 
    -0.07439849f, -0.13814895f, 0.03090087f, -0.04007873f, 0.13174354f, -0.13999967f, 0.12367115f, -0.01635077f, 
    -0.02034729f, -0.03344775f, 0.05450594f, -0.03184383f, 0.22462396f, 0.06404764f, 0.12677649f, 0.28914541f, 
    0.07313042f, -0.02919810f, -0.02420422f, 0.12364458f, 0.00064043f, -0.00723299f, 0.02390316f, 0.01058489f, 
    0.25089097f, -0.00181952f, -0.00920815f, 0.00564247f, 0.00991861f, -0.04131090f, 0.14196041f, 0.15154853f, 
    0.04406069f, 0.11491770f, -0.06632628f, 0.03139555f, -0.31597760f, -0.09240670f, 0.18611801f, -0.25524452f, 
    -0.01844215f, -0.00914843f, -0.01865407f, -0.02271858f, 0.15676931f, 0.03130149f, 0.15898752f, 0.02905307f, 
    -0.10696753f, -0.11256304f, -0.02564996f, -0.03205643f, 0.14967094f, -0.04630518f, -0.03502654f, -0.04100965f, 
    0.12981686f, 0.10106792f, -0.13283461f, 0.16618049f, -0.02634287f, -0.10974596f, 0.10591824f, 0.10477557f, 
    -0.02938806f, -0.05846211f, 0.01423590f, 0.11556549f, 0.16769491f, 0.28747743f, 0.16910431f, -0.05023142f, 
    -0.20904729f, -0.04037578f, -0.03227543f, -0.15553151f, 0.06727997f, 0.05570806f, -0.06438562f, -0.24929386f, 
    0.07944009f, -0.06363447f, -0.08525707f, 0.04504601f, 0.23529437f, 0.05662633f, 0.08216303f, -0.02483837f, 
    -0.10234636f, -0.14447968f, 0.00745175f, -0.05626755f, 0.04654816f, -0.18260154f, 0.01297907f, -0.07828495f, 
    -0.07603904f, -0.06024916f, -0.11026640f, 0.22655785f, 0.02759006f, 0.00762730f, 0.13310170f, 0.03692736f, 
    -0.02386165f, -0.06021856f, 0.13364230f, 0.00307826f, -0.21187149f, -0.15773810f, 0.09511200f, 0.16559608f, 
    -0.00302935f, 0.07064303f, -0.07533514f, -0.02846147f, -0.02660288f, 0.00234711f, 0.03140718f, -0.13588238f, 
    -0.28473693f, -0.01007083f, -0.05938780f, -0.06703463f, 0.11769418f, 0.11278903f, 0.03124760f, -0.00070031f, 
    0.17701210f, 0.08080819f, 0.14110644f, 0.11291743f, 0.31146100f, 0.24862742f, -0.08959666f, 0.18557113f, 
    -0.02745848f, -0.09710597f, 0.10943969f, -0.01485729f, -0.16270685f, 0.03026601f, 0.12372150f, 0.04887552f, 
    -0.02967281f, 0.21204410f, -0.08196866f, -0.13475065f, 0.01896264f, -0.01325751f, 0.03790839f, -0.15320048f, 
    -0.00703291f, 0.02811427f, -0.20579742f, -0.00231537f, 0.21464787f, 0.05728285f, -0.01305019f, -0.10817683f, 
    -0.06778791f, -0.00717596f, 0.09439202f, -0.08438460f, 0.02508347f, 0.09907235f, 0.11002156f, 0.12149840f, 
    0.12169921f, 0.08289711f, -0.07735551f, -0.04488458f, -0.05902687f, -0.08338960f, -0.06059753f, -0.06813384f, 
    0.08025860f, 0.06933761f, 0.02302431f, -0.02763310f, -0.12440399f, 0.13199040f, 0.18386269f, 0.25547200f, 
    0.08521431f, 0.08005787f, 0.14295182f, -0.07233908f, 0.07471490f, -0.01033068f, -0.08567724f, 0.00055493f, 
    0.08635581f, 0.11756378f, -0.01188134f, -0.17152824f, 0.04322508f, 0.08974866f, 0.05365564f, 0.06816392f, 
    0.02047576f, -0.11544620f, 0.08510377f, -0.03278416f, -0.30926740f, 0.09183447f, 0.05757182f, 0.21539006f, 
    0.25400120f, 0.14491646f, -0.03429952f, -0.05126681f, -0.04210601f, 0.09184559f, 0.10670925f, 0.02423937f, 
    0.26877537f, 0.20027836f, 0.05670696f, -0.07939477f, 0.09332964f, 0.03102790f, 0.11393128f, 0.11648450f, 
    0.09178801f, -0.01360596f, 0.03327035f, 0.18718947f, 0.06254721f, 0.02919055f, 0.10488753f, 0.12956274f, 
    -0.03430521f, -0.11711392f, 0.07165205f, 0.06318161f, 0.05125602f, 0.03309999f, 0.05178495f, 0.25235569f, 
    -0.15993650f, 0.05610373f, -0.13033479f, 0.00184670f, 0.11253459f, 0.09887853f, 0.00531392f, -0.01510308f, 
    0.04951333f, 0.08786877f, 0.17507260f, -0.05122267f, -0.09659760f, 0.07408912f, 0.12622078f, 0.05050208f, 
    0.03329998f, 0.11517669f, -0.04115830f, 0.00188564f, 0.09419231f, -0.09889180f, 0.08070447f, 0.10119547f, 
    0.07363043f, 0.01835052f, 0.03349964f, -0.04481065f, 0.04752683f, -0.08242429f, 0.06358241f, 0.05825209f, 
    -0.03778819f, 0.12691239f, -0.09230120f, -0.05085782f, -0.23419532f, -0.15742882f, 0.01754794f, -0.04191475f, 
    0.04121279f, 0.10043835f, 0.06052792f, 0.05795082f, -0.11930875f, 0.05743127f, 0.09615613f, 0.12066279f, 
    -0.05030459f, 0.01941738f, -0.05981981f, -0.02109284f, -0.05608397f, -0.03937335f, 0.02294182f, -0.12879236f, 
    0.05164712f, 0.08543753f, 0.01639540f, 0.05563229f, -0.18282834f, 0.09302678f, -0.00782157f, 0.02130873f, 
    0.01239274f, -0.05934219f, 0.04153690f, -0.07341927f, 0.02784146f, -0.08626489f, 0.02608822f, 0.11006635f, 
    -0.02170349f, 0.24781147f, -0.00134337f, 0.01605728f, -0.00467678f, -0.00569464f, 0.00737169f, 0.03921119f, 
    -0.08053147f, 0.01426871f, 0.18425652f, 0.13390967f, -0.23291677f, 0.07488374f, 0.13787679f, 0.08840137f, 
    0.09835215f, 0.15317985f, -0.11898553f, -0.02347531f, 0.04228364f, -0.11409288f, 0.12193588f, 0.02947974f, 
    -0.16382374f, -0.07906003f, -0.04809478f, -0.00404811f, 0.08187549f, -0.08870229f, -0.04053205f, -0.10329358f, 
    -0.00474645f, 0.00234997f, -0.04557739f, 0.15804580f, -0.02141668f, 0.01156082f, 0.05158874f, -0.03518445f, 
    0.00901169f, -0.15954217f, -0.09110763f, -0.04791370f, 0.06452607f, -0.01188603f, -0.11794292f, -0.08431964f, 
    -0.22561225f, -0.00328768f, 0.17214173f, 0.00925109f, 0.11800709f, -0.05263196f, -0.09427065f, -0.07831099f, 
    0.16510315f, 0.00060257f, 0.01669888f, -0.02158755f, -0.31817126f, -0.14329411f, 0.22891293f, -0.21353540f, 
    0.03246838f, 0.01259641f, -0.08780487f, -0.07286987f, -0.12237257f, 0.06548683f, 0.14215498f, 0.00334061f, 
    -0.07178365f, 0.04889542f, -0.05433514f, 0.02885713f, 0.20259112f, 0.10013716f, -0.22000925f, 0.09387676f, 
    -0.01966424f, -0.00642291f, -0.06709508f, -0.02504486f, 0.15706097f, 0.05510877f, -0.13957012f, -0.02844895f, 
    -0.12786309f, 0.07375449f, 0.01409400f, -0.02998024f, -0.00673658f, -0.08403440f, -0.12749070f, -0.04038858f, 
    0.29139951f, -0.16345927f, 0.06833359f, 0.01482472f, 0.01397399f, 0.06813405f, 0.06771722f, 0.01491411f, 
    0.09167182f, -0.01245078f, 0.11448790f, 0.00524112f, -0.26187381f, 0.29800799f, 0.04078324f, -0.10088822f, 
    0.10071670f, 0.20026094f, -0.02999414f, -0.01921169f, 0.05951444f, -0.00841720f, 0.12095534f, -0.12521918f, 
    -0.03879470f, 0.03962786f, -0.02377943f, 0.12864383f, 0.06808498f, 0.10964524f, 0.08186588f, 0.01996574f, 
    0.13226788f, 0.01936263f, 0.10536975f, -0.05248227f, 0.14702444f, 0.05220185f, 0.15993360f, 0.14723791f, 
    0.03903684f, 0.02258480f, 0.08000009f, -0.07025740f, 0.01664740f, 0.04078660f, 0.13325696f, 0.06554565f, 
    -0.09178843f, -0.05455934f, 0.00976605f, -0.03964622f, -0.03759082f, 0.04641128f, 0.02864943f, 0.09920111f, 
    0.04261493f, 0.01857308f, 0.02869693f, -0.13509277f, 0.05708381f, -0.12021013f, 0.08529302f, 0.21066305f, 
    0.11464141f, -0.01264319f, 0.03306188f, -0.01697112f, 0.09467193f, 0.06027599f, 0.10618134f, -0.02264961f, 
    0.39854643f, 0.07556357f, 0.07671069f, 0.13754480f, 0.00539696f, 0.02888960f, 0.06353983f, 0.00941448f, 
    -0.01412407f, 0.09531064f, -0.07469667f, 0.01823118f, 0.50851113f, -0.07613291f, 0.22859164f, 0.14394318f, 
    0.13302581f, 0.06770734f, -0.07387035f, 0.12556118f, -0.10772613f, -0.03866958f, 0.07043518f, 0.15130590f, 
    -0.28800255f, 0.29119602f, -0.15350859f, -0.01830130f, 0.01057099f, 0.10881382f, -0.03189772f, -0.05215208f, 
    -0.05257765f, -0.08666574f, 0.00886371f, -0.04831643f, -0.03988724f, -0.10840648f, 0.02562207f, 0.04914881f, 
    -0.01069269f, -0.08705530f, -0.04260497f, 0.06158633f, 0.06521776f, 0.03418640f, 0.05621886f, 0.07380327f, 
    -0.10414852f, 0.15507028f, -0.09355826f, -0.07745384f, -0.01201409f, 0.00906135f, 0.00684100f, 0.03612082f, 
    0.16355544f, 0.01194375f, 0.13814357f, 0.02421381f, 0.01724900f, 0.03894978f, 0.07282655f, 0.00794987f, 
    0.05414754f, -0.05208333f, 0.07089780f, -0.12514822f, 0.02377161f, -0.00383154f, -0.19918153f, -0.02305863f, 
    -0.15533620f, 0.12948030f, -0.03733913f, 0.00491119f, -0.00395990f, 0.16612582f, 0.04014421f, 0.00654756f, 
    -0.06523959f, 0.00177759f, 0.04335761f, -0.01075257f, 0.01182199f, 0.12404390f, 0.05960747f, 0.17165120f, 
    -0.04523234f, -0.05756539f, -0.05671866f, 0.09943561f, -0.02721197f, -0.07699493f, 0.21693391f, -0.09453323f, 
    0.01129993f, 0.26418495f, 0.04466360f, -0.06638443f, -0.03379500f, 0.01074475f, 0.07028916f, -0.04741936f, 
    -0.00163748f, 0.11002821f, 0.00820375f, 0.04379750f, 0.17964311f, 0.10583805f, -0.17592113f, 0.05900086f, 
    0.06197076f, 0.13176978f, -0.09478421f, 0.01841826f, 0.00553527f, -0.01712696f, 0.01644856f, -0.02571796f, 
    -0.18088682f, 0.09703021f, 0.04426287f, -0.09777077f, 0.00776161f, -0.02939590f, 0.01716017f, -0.02359024f, 
    0.09195094f, 0.11319271f, -0.07635079f, -0.06122008f, 0.07447810f, -0.04198698f, 0.12260484f, 0.10186593f, 
    -0.04193415f, 0.00721859f, 0.04304511f, 0.14381512f, -0.06347958f, 0.00794184f, 0.01682636f, -0.01612122f, 
    0.05357971f, 0.05234838f, 0.02854090f, -0.08424217f, 0.05234556f, -0.06854642f, -0.01365257f, -0.03441326f, 
    0.03066674f, -0.03873986f, 0.01076179f, 0.10134280f, 0.01125188f, 0.45856297f, -0.10205089f, 0.21989749f, 
    0.02111519f, 0.04585423f, -0.00942005f, 0.08917724f, 0.10753857f, 0.16962321f, -0.02821039f, 0.04001908f, 
    -0.20037282f, -0.00887120f, 0.10972659f, 0.16396724f, 0.08753689f, 0.00237840f, -0.10371295f, 0.05664637f, 
    -0.12583253f, 0.02678657f, 0.12417649f, 0.06179178f, -0.05517020f, 0.17670326f, -0.29061899f, -0.10853698f, 
    0.03923243f, 0.02576110f, 0.01377612f, -0.03419523f, -0.16277026f, -0.09381338f, -0.04241123f, -0.04487094f, 
    0.05896263f, 0.12110618f, 0.17762235f, 0.04486069f, 0.03055849f, 0.02492055f, -0.06204351f, 0.01316343f, 
    0.06627339f, -0.15549575f, -0.04335335f, -0.12478193f, 0.12253425f, 0.01972081f, -0.08917867f, -0.03627998f, 
    0.00177660f, -0.02937348f, -0.01071343f, 0.00861469f, -0.14328474f, -0.00349223f, 0.01134944f, -0.06036988f, 
    0.12445924f, 0.03687147f, 0.14800185f, 0.06764798f, 0.03271050f, 0.01893685f, 0.02200550f, -0.07141359f, 
    -0.01125477f, 0.05124335f, 0.07700800f, -0.04241432f, -0.23446056f, 0.10066551f, -0.08586724f, -0.04686557f, 
    0.02252663f, -0.04366621f, -0.00264224f, -0.08989044f, 0.08689868f, 0.08836789f, -0.11686561f, 0.03042154f, 
    -0.09678481f, 0.05550014f, -0.01636705f, -0.12008516f, 0.00040913f, -0.05824741f, -0.03399240f, -0.05631644f, 
    0.06322166f, -0.10208054f, 0.03096618f, 0.02073568f, -0.08310781f, -0.16642325f, -0.07143823f, -0.09576998f, 
    -0.03337279f, 0.00424602f, -0.05861692f, -0.03293257f, -0.00020501f, -0.02973166f, 0.24512878f, 0.14031598f, 
    -0.03575255f, -0.01054468f, -0.03063250f, -0.07764594f, 0.12424220f, -0.03563906f, -0.02654425f, -0.11011652f, 
    -0.08181632f, -0.17950626f, -0.01162368f, 0.02168311f, -0.31010494f, 0.15602276f, -0.03539678f, 0.03615031f, 
    0.00507504f, 0.04038620f, 0.13016073f, -0.02152507f, 0.02097566f, -0.10826284f, 0.06130160f, -0.07489025f, 
    -0.06116013f, 0.11300370f, 0.15449663f, 0.07902969f, -0.02116995f, 0.03261890f, -0.04626688f, -0.01027643f, 
    0.15670532f, 0.18513539f, 0.14329688f, -0.05372870f, -0.05090722f, 0.06825215f, 0.09647196f, 0.08245263f, 
    0.03702113f, -0.06222656f, 0.01199741f, 0.03106942f, -0.10856724f, 0.09528624f, 0.03072372f, 0.05549583f, 
    -0.32228178f, 0.02639534f, 0.16878957f, 0.04766193f, -0.04534340f, 0.10845807f, -0.07835002f, 0.01812854f, 
    -0.15166889f, -0.04062732f, 0.06212110f, 0.03472599f, 0.16854446f, 0.10300741f, -0.15092832f, -0.07535199f, 
    -0.17557237f, 0.08042736f, -0.03184112f, 0.04152599f, 0.01147434f, -0.04831649f, -0.03365242f, -0.00336105f, 
    -0.03288238f, 0.08303707f, 0.01017503f, 0.20194122f, -0.10351604f, 0.06481117f, 0.06027348f, -0.04120448f, 
    -0.10223052f, -0.03308621f, 0.17830983f, -0.14159238f, 0.18905106f, 0.01250597f, -0.14794309f, -0.09707704f, 
    0.00711178f, 0.00463635f, -0.03864196f, -0.07445444f, -0.11415201f, -0.14976265f, -0.01241990f, 0.03320204f, 
    0.10822999f, -0.08992736f, -0.17909217f, 0.05904270f, -0.02183500f, -0.04337664f, -0.00002079f, 0.35891405f, 
    -0.01426968f, -0.00758471f, 0.10874735f, -0.06219179f, -0.06470378f, 0.02999365f, -0.20961097f, 0.20286313f, 
    0.14416696f, 0.07090263f, -0.05329261f, 0.04510753f, -0.00497806f, 0.13751915f, 0.19806112f, -0.06568986f, 
    -0.27220100f, 0.03588070f, 0.21674615f, -0.06579251f, -0.03566515f, 0.03118247f, -0.05429619f, 0.02674987f, 
    -0.02565490f, 0.05963255f, -0.13370864f, 0.05404194f, 0.32213467f, 0.01303195f, 0.25056502f, -0.21417490f, 
    0.04860594f, 0.03062701f, 0.15535261f, -0.00621486f, 0.01181177f, 0.02521893f, -0.05877131f, 0.17835744f, 
    -0.05069529f, 0.23724075f, -0.02874112f, -0.02314047f, -0.03790872f, -0.11433820f, -0.07458384f, 0.04364363f, 
    -0.13653496f, 0.00347624f, -0.02074991f, -0.00067835f, -0.00650906f, -0.05665793f, 0.16250773f, 0.01068140f, 
    -0.14941964f, -0.04960107f, -0.01413320f, 0.10414570f, 0.00076346f, -0.03697700f, -0.00879240f, 0.02711018f, 
    0.03851099f, -0.18109471f, 0.05000709f, 0.27028778f, -0.00333377f, 0.01485539f, 0.04516009f, 0.08834108f, 
    0.15078656f, 0.01817275f, 0.20163491f, 0.08701204f, -0.15283245f, 0.01528756f, 0.15127331f, 0.04341366f, 
    0.08790861f, 0.04903901f, 0.04476678f, 0.02880568f, 0.06251597f, -0.03490802f, -0.01091845f, 0.02268417f, 
    -0.17450248f, -0.13819697f, -0.02155120f, -0.11121266f, 0.08088066f, 0.07033754f, 0.06436120f, 0.06469757f, 
    0.04110977f, -0.03004827f, 0.12140910f, 0.03460653f, 0.29198170f, 0.14027420f, 0.05337929f, -0.27338329f, 
    -0.10566529f, -0.01461148f, -0.06437461f, 0.09968366f, -0.04320458f, -0.00743645f, 0.03656922f, -0.06965917f, 
    -0.20636906f, -0.07065644f, 0.08004969f, 0.17182924f, -0.05242791f, -0.02494636f, 0.04428680f, -0.01109258f, 
    -0.00211054f, 0.01753106f, -0.05131008f, 0.03367090f, -0.41144207f, -0.01360552f, 0.07645784f, -0.02916316f, 
    -0.10308584f, 0.08644977f, -0.07388548f, 0.10960097f, 0.02805617f, -0.04204913f, -0.08628733f, -0.02424482f, 
    -0.20840061f, -0.05684337f, 0.22423846f, 0.13884220f, -0.03577142f, -0.03594077f, -0.05944225f, -0.20215338f, 
    -0.00340676f, 0.09430426f, -0.04086175f, -0.18145461f, 0.04495503f, 0.14358494f, -0.05862554f, 0.05641505f, 
    0.06846908f, 0.12231398f, 0.08483851f, 0.11776250f, 0.03918784f, 0.12097561f, -0.11802168f, -0.18871205f, 
    0.12863009f, -0.06013719f, 0.09415886f, 0.00119409f, -0.03987648f, -0.08305768f, 0.01201974f, -0.01612056f, 
    -0.02026520f, -0.11199611f, -0.14506140f, 0.13103135f, 0.07275292f, 0.03460761f, 0.11027327f, 0.09050898f, 
    0.03732635f, 0.00058205f, 0.11862245f, 0.11527722f, -0.10418915f, 0.07124960f, -0.06054784f, -0.00936470f, 
    -0.07848463f, -0.03134019f, 0.02863930f, -0.03163705f, -0.05870201f, 0.03093089f, -0.05293124f, -0.06564468f, 
    -0.00296788f, 0.07305505f, 0.05112148f, 0.11101695f, -0.02426775f, 0.05524940f, 0.10653067f, -0.03011056f, 
    -0.05978869f, 0.02866046f, -0.03496100f, 0.08172265f, 0.10673061f, -0.05575249f, -0.05389193f, -0.10484249f, 
    0.05676246f, 0.03838485f, 0.21822590f, -0.05985086f, 0.09890269f, 0.03178185f, 0.11534991f, 0.11874282f, 
    0.03537544f, -0.12912261f, -0.11423201f, -0.05098594f, 0.18093580f, -0.10610242f, 0.03445985f, -0.06588646f, 
    0.09582525f, 0.11933801f, 0.02417757f, 0.13050763f, -0.12208495f, 0.10601078f, -0.02370408f, 0.06964679f, 
    -0.08620138f, -0.24533781f, 0.01445328f, 0.10575463f, 0.00117474f, -0.00002088f, 0.06028058f, -0.07090036f, 
    0.11592148f, 0.07824501f, 0.01211915f, -0.08526254f, -0.13709140f, 0.12551036f, -0.12915133f, -0.01814046f, 
    -0.11392082f, -0.08461381f, 0.09664990f, 0.06721005f, -0.00357372f, 0.14076789f, -0.05705852f, -0.03404250f, 
    0.07110558f, 0.12858956f, -0.07750809f, 0.03177400f, 0.08835308f, 0.01095608f, 0.11890174f, 0.17472388f, 
    -0.02457763f, 0.07218489f, 0.12765159f, 0.03060354f, -0.05828874f, 0.01831537f, 0.28430417f, 0.10054991f, 
    0.02423940f, 0.12635055f, 0.04959589f, 0.04540708f, -0.03419257f, 0.07056983f, 0.15295473f, 0.10715668f, 
    0.10648578f, 0.14907369f, -0.23276322f, 0.15751623f, 0.10731781f, 0.01004533f, 0.11826874f, 0.12515238f, 
    -0.03180283f, -0.02173967f, 0.11817207f, 0.01545105f, 0.10175048f, 0.05747839f, -0.13032472f, 0.10583898f, 
    -0.09920764f, -0.02192849f, 0.18748371f, 0.08406733f, 0.11835862f, -0.05917178f, -0.00146620f, 0.09141022f, 
    0.06372674f, 0.08297991f, 0.21859697f, -0.04241502f, -0.18059002f, 0.01582928f, 0.14679749f, -0.01723890f, 
    0.09991161f, 0.07850899f, 0.04307802f, -0.01087038f, -0.06646864f, -0.14485751f, 0.09369808f, -0.21745363f, 
    0.00103138f, -0.10198539f, 0.10291258f, 0.10603508f, -0.07823375f, 0.04937270f, 0.13111916f, 0.04773651f, 
    -0.03122948f, 0.03274547f, -0.29507294f, -0.03764246f, -0.00055463f, 0.09825757f, -0.09567014f, -0.08979680f, 
    0.07249800f, 0.12973607f, 0.02124403f, -0.04945787f, -0.08408491f, 0.26849142f, 0.17666656f, 0.19638722f, 
    0.03431095f, 0.08055773f, 0.01367068f, 0.12375392f, -0.09137470f, -0.01244532f, -0.02098187f, 0.00385106f, 
    0.04774673f, 0.04549209f, -0.04292908f, 0.06773331f, -0.06140669f, 0.03321915f, 0.01338906f, -0.00719740f, 
    -0.00148983f, -0.15090716f, 0.11112348f, -0.03252137f, 0.00702624f, 0.08356146f, 0.02700319f, 0.07644017f, 
    0.02942239f, 0.04576123f, -0.11800591f, -0.05988878f, -0.01531921f, -0.05771784f, -0.04290856f, 0.01981409f, 
    0.03313613f, 0.08658017f, -0.02464292f, -0.01846505f, -0.11353087f, -0.04689139f, -0.04960463f, 0.08412142f, 
    0.01261794f, -0.06332703f, 0.06719305f, -0.10668308f, 0.52224749f, -0.07611916f, 0.19396617f, 0.15219897f, 
    -0.07507715f, 0.10737450f, -0.15006287f, 0.15215506f, 0.05291196f, 0.12185875f, -0.02018505f, 0.03624670f, 
    0.11212794f, 0.26073310f, 0.11937418f, -0.11642397f, 0.02562824f, 0.01656792f, -0.02920589f, -0.10691027f, 
    0.02448191f, 0.08415148f, 0.02502944f, -0.05203520f, 0.24579960f, -0.15369949f, -0.12442676f, -0.32415223f, 
    0.07481847f, -0.00093695f, 0.07031670f, 0.01755632f, -0.08212885f, -0.03473290f, 0.04881676f, 0.02823181f, 
    0.08757244f, 0.20572738f, 0.15996464f, 0.08731289f, -0.03708929f, -0.03828126f, 0.02957045f, 0.03145522f, 
    -0.08194019f, -0.07953952f, 0.07042340f, -0.02703646f, -0.40873286f, -0.30508977f, -0.05407465f, -0.34446600f, 
    0.16663745f, -0.16736081f, -0.02599814f, -0.00924852f, 0.09733079f, 0.02079830f, -0.00604601f, -0.08006076f, 
    -0.04374939f, 0.05529864f, 0.01275060f, 0.19086923f, 0.12964675f, 0.10249571f, 0.03962541f, 0.02165714f, 
    0.09476318f, 0.00755668f, 0.09656812f, -0.06293588f, -0.22859722f, -0.19153324f, -0.11012097f, -0.12246633f, 
    -0.05671822f, 0.07322659f, 0.06963333f, 0.03277608f, -0.03863630f, 0.02202154f, -0.10803807f, -0.08265673f, 
    0.13530926f, 0.05725300f, -0.01617200f, -0.06162816f, 0.01830500f, -0.06265125f, 0.20160301f, 0.04781057f, 
    -0.08243778f, -0.05385918f, 0.01251355f, 0.06854336f, -0.22946201f, 0.11889767f, -0.14968120f, -0.32855150f, 
    0.05333114f, -0.14427288f, 0.02370880f, -0.06090575f, -0.00379167f, 0.07417665f, 0.01639893f, 0.01807572f, 
    0.36304107f, -0.31258574f, 0.17559093f, 0.10475802f, -0.23077436f, 0.06664415f, -0.07574683f, 0.04625956f, 
    -0.02419587f, 0.04168696f, -0.11438191f, -0.02385381f, 0.06071552f, 0.13366468f, 0.08945934f, -0.10591560f, 
    0.02030119f, -0.00068218f, 0.15564850f, -0.00625117f, -0.10344128f, 0.05066609f, -0.02400059f, 0.09155986f, 
    -0.07244309f, -0.02367165f, -0.10624588f, -0.06443930f, 0.00480285f, -0.13006189f, -0.05964500f, -0.13016936f, 
    -0.03650354f, 0.00110112f, -0.09718034f, -0.05556964f, 0.28968292f, -0.08609127f, -0.22388250f, 0.01958969f, 
    -0.06570365f, 0.13426638f, -0.07568769f, 0.03448540f, -0.07754942f, 0.03330984f, -0.01985496f, -0.21076970f, 
    -0.03600529f, 0.00398977f, 0.26598638f, -0.12777832f, -0.09087396f, -0.05639231f, 0.04160058f, -0.02712803f, 
    -0.09894254f, 0.00310423f, -0.13829952f, 0.03230670f, 0.04898453f, -0.13719676f, -0.03209068f, -0.18586101f, 
    0.10554580f, 0.00094948f, 0.05591871f, -0.01630293f, -0.02523377f, -0.01915880f, 0.14108260f, 0.03192175f, 
    0.30708718f, 0.06618369f, 0.12666044f, 0.03590225f, -0.02686685f, 0.02538591f, -0.04200678f, 0.06579383f, 
    0.16973931f, 0.00356131f, 0.01919399f, 0.12047761f, 0.45593470f, 0.29508603f, -0.08745456f, 0.06855106f, 
    -0.15257345f, -0.02405572f, -0.09991567f, 0.13425060f, -0.01280409f, 0.09964830f, -0.06101741f, -0.02956064f, 
    0.06440973f, 0.18396012f, 0.05646348f, -0.04572210f, -0.05406595f, 0.08019570f, 0.03556289f, 0.13485393f, 
    0.04614386f, -0.05822892f, -0.01177492f, 0.02723530f, -0.19173189f, 0.19624907f, -0.01197897f, -0.17450757f, 
    0.03622707f, 0.05672731f, 0.02736099f, 0.03611892f, -0.06980316f, 0.10006585f, 0.06580520f, -0.04247822f, 
    -0.08581991f, -0.16229378f, 0.01138550f, 0.08970959f, 0.12926456f, 0.17103362f, -0.14224327f, 0.10095401f, 
    -0.09687044f, 0.04495628f, -0.11989042f, -0.11956292f, 0.18553863f, 0.08887821f, 0.13644248f, 0.14731556f, 
    0.01044499f, -0.04125330f, 0.07605001f, -0.01950277f, -0.03074940f, 0.11245568f, -0.02343197f, -0.03612215f, 
    -0.21973963f, -0.02468903f, 0.03205508f, -0.07275526f, -0.10887919f, 0.04045380f, 0.04175338f, 0.08902756f, 
    0.02256861f, -0.07451951f, -0.00458950f, -0.03649850f, 0.28748170f, -0.01367687f, -0.02883545f, 0.11010945f, 
    -0.05359795f, 0.09378143f, 0.03050332f, 0.05879203f, -0.01823466f, -0.04413071f, 0.01986141f, 0.00676965f, 
    0.32576293f, -0.03789254f, 0.05996419f, 0.16912469f, -0.02503591f, 0.04330393f, 0.03423292f, 0.02179415f, 
    -0.07403034f, 0.03595563f, 0.11439282f, -0.03975864f, 0.19749199f, 0.08774482f, -0.10623973f, 0.15495193f, 
    0.03466029f, 0.01354465f, -0.04274030f, 0.03505019f, 0.14088191f, -0.00837980f, -0.17200275f, -0.06260698f, 
    -0.02849848f, -0.10858507f, 0.00260979f, -0.13412467f, -0.00146057f, -0.01189512f, 0.13790375f, -0.11434679f, 
    0.04072816f, -0.06800931f, 0.07180590f, -0.09724408f, 0.25230414f, 0.25924489f, 0.11963110f, -0.06768374f, 
    -0.03012656f, -0.11294983f, 0.03689580f, 0.01920922f, 0.12039194f, 0.11656167f, 0.01951694f, -0.02347509f, 
    0.04393300f, 0.04038190f, 0.00677672f, 0.03087941f, 0.03761181f, 0.02160867f, -0.00140674f, 0.03303254f, 
    -0.03042908f, 0.03937398f, -0.01652585f, 0.02648983f, -0.00172910f, 0.02704473f, 0.04328196f, 0.01313790f, 
    0.03345901f, -0.01752620f, 0.02449102f, 0.01512269f, -0.02322305f, -0.01991162f, 0.03057024f, -0.04928579f, 
    -0.01575418f, -0.00417293f, -0.02986980f, -0.01856597f, 0.03296739f, -0.04454307f, -0.04845750f, 0.03475706f, 
    -0.03835742f, -0.02916226f, -0.04170100f, -0.02685902f, -0.03691088f, -0.02240258f, 0.02071403f, -0.00868931f, 
    -0.04078149f, 0.03947328f, -0.01798479f, 0.02882383f, 0.02793519f, -0.00356804f, -0.00533096f, -0.03801389f, 
    -0.02709000f, -0.02373490f, -0.04589693f, -0.02344714f, -0.05180276f, -0.02762604f, -0.03477338f, 0.00686578f, 
    -0.00876423f, 0.02907475f, -0.05613573f, 0.03838602f, -0.04870395f, 0.02621242f, 0.02359801f, -0.03152274f, 
    0.03997800f, 0.01432352f, -0.04787024f, -0.02582342f, -0.02282343f, 0.02267555f, -0.04224458f, -0.01971729f, 
    0.03081235f, -0.04201041f, 0.01337940f, 0.03669879f, 0.02107334f, -0.04892560f, -0.02444797f, 0.01337483f, 
    -0.02578599f, -0.02791776f, -0.04286035f, 0.02862500f, 0.00764996f, 0.00811284f, 0.04058449f, -0.05016722f, 
    0.01678085f, -0.02612936f, -0.02216315f, -0.05380352f, -0.03582127f, -0.02616726f, -0.04810461f, -0.04789962f, 
    -0.01747074f, 0.04004103f, 0.02700506f, 0.03869615f, 0.01517073f, 0.02992221f, 0.03570168f, 0.00916439f, 
    -0.03726603f, 0.04232645f, -0.03424483f, 0.02421504f, -0.03795720f, -0.04069592f, 0.01346081f, -0.02729870f, 
    0.03456618f, 0.00596535f, -0.02885853f, -0.04025479f, -0.01769521f, 0.04286340f, 0.03187945f, 0.00690083f, 
    -0.04153297f, 0.01026601f, 0.02185198f, -0.05239280f, 0.02515018f, -0.01964698f, 0.03076832f, 0.00957111f, 
    0.01501479f, -0.01965044f, -0.04704640f, 0.00402260f, 0.03359382f, -0.03381317f, -0.02286031f, -0.05378675f, 
    0.00884898f, 0.00812353f, -0.04055264f, 0.00331538f, 0.04232394f, 0.02982414f, -0.05362615f, 0.00531867f, 
    0.04086336f, -0.01967702f, -0.04807745f, -0.02294522f, 0.02523246f, 0.03256835f, 0.00486444f, 0.01020382f, 
    0.02728125f, 0.01174724f, -0.03617102f, 0.04041851f, -0.03704547f, -0.04955521f, -0.01398090f, 0.03983259f, 
    -0.04289910f, -0.00181748f, -0.05385448f, -0.00865693f, 0.00704594f, -0.05242990f, -0.04937492f, 0.00138269f, 
    -0.02773085f, -0.02204237f, -0.00403082f, -0.04758278f, -0.04761561f, -0.02496771f, -0.03844308f, -0.05503453f, 
    0.03735665f, -0.01518770f, -0.04334879f, -0.04597649f, 0.02216010f, -0.03855082f, 0.01888038f, -0.00329977f, 
    0.01097471f, -0.00629740f, -0.04486913f, 0.02620990f, -0.04541121f, 0.02040654f, -0.04546393f, -0.01824021f, 
    0.01978812f, -0.00953403f, 0.01638214f, 0.03248561f, -0.01890729f, 0.00160420f, -0.01042511f, -0.05697469f, 
    -0.02900360f, 0.03040439f, -0.05535265f, 0.00682432f, -0.03292165f, 0.03921302f, -0.01529886f, 0.03356982f, 
    -0.01363763f, -0.03775998f, -0.05620404f, -0.03315935f, -0.00292573f, 0.03550962f, -0.01427291f, 0.00827301f, 
    0.03330298f, -0.01233910f, 0.04406778f, 0.00813304f, 0.01536020f, -0.00042314f, -0.04094070f, -0.04623804f, 
    -0.05772604f, 0.00842501f, 0.02697379f, -0.00260475f, 0.03170647f, -0.05154600f, 0.04023998f, -0.00642658f, 
    -0.02267494f, 0.03917761f, -0.00561654f, 0.01147542f, -0.04998722f, -0.04314543f, -0.05439324f, 0.04109772f, 
    0.03101882f, -0.00967901f, 0.03041684f, -0.04625204f, -0.04333119f, -0.04549386f, -0.01289760f, -0.01723647f, 
    0.01586739f, -0.04627838f, -0.00772651f, -0.04764524f, 0.02220064f, 0.00728663f, -0.00958929f, 0.01711056f, 
    -0.03639245f, 0.03101125f, -0.03729400f, -0.01428127f, 0.04199490f, -0.02306770f, 0.01515741f, -0.02373083f, 
    0.01891973f, 0.02110121f, 0.01608282f, -0.00381642f, 0.02878318f, -0.05143420f, 0.02800579f, 0.02445065f, 
    -0.01428253f, -0.01080129f, 0.01123274f, -0.00545937f, -0.00887533f, 0.00635044f, -0.03639051f, 0.01306993f, 
    -0.02663764f, -0.02405737f, -0.05304573f, -0.01118380f, 0.01553978f, -0.02389396f, -0.04191522f, 0.03001492f, 
    0.01708665f, 0.03405261f, -0.05651459f, 0.03904835f, 0.00222837f, 0.02449931f, -0.00694345f, 0.00383145f, 
    0.03196198f, 0.02562910f, -0.00686234f, 0.01136773f, -0.03309414f, 0.01073138f, -0.04376284f, 0.00073171f, 
    -0.05250912f, 0.02348759f, 0.00341058f, -0.02115190f, 0.00044823f, -0.01141166f, 0.02506490f, -0.03528518f, 
    -0.04020875f, 0.02594552f, 0.00844297f, -0.03548859f, -0.04665054f, -0.04542575f, -0.00254057f, 0.00070043f, 
    0.01656392f, -0.05352739f, -0.01990836f, 0.01150209f, 0.00058977f, -0.02554090f, -0.00469849f, 0.02902425f, 
    0.01213129f, 0.00733208f, 0.02488250f, 0.03103972f, -0.00498909f, 0.00073010f, 0.02348339f, 0.01779852f, 
    -0.05776823f, -0.01067971f, -0.03351089f, -0.00145792f, 0.00008970f, -0.02218036f, -0.00548031f, -0.02811064f, 
    -0.04383754f, 0.02470390f, 0.01870975f, -0.03539822f, -0.05409027f, -0.05447040f, 0.02162359f, -0.05538686f, 
    0.02095675f, 0.03684587f, 0.01838579f, -0.02652070f, 0.02120098f, -0.00346482f, 0.02138425f, -0.02989994f, 
    -0.00246329f, 0.02179917f, -0.03368137f, -0.01628922f, 0.00607184f, 0.03174565f, -0.04065992f, -0.01009640f, 
    -0.04894122f, 0.00773658f, -0.04589185f, 0.02757335f, -0.00747311f, -0.04558875f, -0.04568222f, -0.03513742f, 
    0.01428722f, 0.03361765f, 0.02357182f, -0.05454819f, -0.04067257f, 0.00065516f, 0.02372623f, 0.03422965f, 
    -0.11481100f, 0.07522076f, 0.01553165f, -0.18723069f, -0.00368862f, 0.09761312f, 0.06909336f, -0.06703648f, 
    -0.02432241f, 0.04206110f, 0.12331014f, 0.12748703f, -0.10427688f, 0.02683705f, 0.00283735f, 0.05428213f, 
    0.00515648f, 0.06290066f, 0.07991714f, -0.00917813f, 0.03266041f, -0.00236323f, -0.03704857f, -0.01274815f, 
    0.14104654f, 0.08705184f, -0.08866238f, -0.00997788f, -0.05186477f, 0.05036505f, 0.03409105f, 0.00305117f, 
    0.02500459f, -0.04267923f, 0.17783028f, -0.17627268f, 0.13926667f, 0.03025659f, -0.05230769f, -0.19277613f, 
    -0.02403190f, 0.08224022f, -0.07565692f, -0.10935827f, -0.16018742f, -0.07924245f, 0.10687060f, 0.05635842f, 
    -0.11123622f, -0.16617343f, -0.03758279f, 0.05887721f, -0.24251533f, -0.13043442f, -0.05402157f, 0.16038880f, 
    0.03171836f, 0.14353897f, 0.13181607f, -0.03285543f, 0.15780319f, -0.21658939f, 0.06751571f, 0.29125470f, 
    0.00079162f, 0.00992694f, -0.00464698f, 0.04869271f, 0.20321968f, 0.10903010f, 0.10996547f, 0.08620480f, 
    0.23826706f, 0.06732382f, 0.09301836f, 0.08825493f, -0.02995114f, 0.07793912f, -0.09929084f, 0.03492917f, 
    -0.00329785f, 0.09168657f, -0.06382833f, 0.08368949f, 0.26842541f, 0.15147683f, -0.07079446f, -0.21396789f, 
    -0.00969244f, 0.04273620f, 0.02105802f, 0.07637835f, 0.04517486f, 0.02098758f, -0.02598631f, 0.10950836f, 
    0.21918541f, 0.10256094f, 0.00153391f, 0.03443305f, 0.08928124f, 0.02648459f, -0.04874002f, 0.02507609f, 
    -0.05309837f, -0.05088406f, 0.00265606f, 0.06144404f, -0.01492390f, -0.12874629f, 0.07636073f, -0.18188229f, 
    -0.09773079f, 0.11182740f, -0.03020036f, 0.05295721f, 0.22186700f, 0.01060146f, -0.01538532f, 0.05196285f, 
    -0.14775018f, -0.09723046f, 0.01035990f, 0.16823423f, 0.14013514f, 0.05200731f, 0.08678614f, 0.25330225f, 
    0.11883049f, 0.16944104f, 0.27767178f, 0.02161959f, -0.20754349f, -0.01268653f, 0.08749432f, -0.07469983f, 
    -0.02906950f, 0.01621388f, 0.03576295f, -0.04715402f, 0.03019150f, -0.12923412f, -0.16585083f, 0.01363818f, 
    -0.28136897f, -0.14576001f, 0.17198141f, -0.00040782f, -0.11665163f, 0.13908033f, 0.06112105f, 0.04681475f, 
    -0.13901858f, -0.11914758f, 0.05623860f, 0.06716008f, 0.41291285f, -0.00302714f, -0.18253891f, -0.16126408f, 
    -0.01570437f, -0.06788874f, -0.11381460f, 0.11004668f, -0.00356828f, -0.08036911f, 0.12847088f, -0.07015041f, 
    0.05073942f, 0.20804852f, -0.08345069f, 0.05709548f, -0.01815845f, 0.02358319f, 0.02603566f, 0.02413616f, 
    0.11625743f, 0.17349885f, 0.00144748f, 0.14587826f, 0.10072131f, 0.10441267f, -0.06824381f, 0.02880754f, 
    0.06836632f, 0.18341728f, -0.05379574f, 0.06868865f, 0.07639175f, 0.04456402f, -0.06445707f, -0.15028848f, 
    0.07853476f, 0.08435860f, 0.10074512f, 0.16992326f, 0.15087099f, 0.11502997f, 0.04839863f, -0.09728014f, 
    0.07437655f, 0.15880370f, -0.07451999f, -0.02927127f, 0.07736477f, 0.13235113f, -0.13044146f, 0.15956312f, 
    -0.00205234f, 0.09736581f, 0.02167392f, 0.09685595f, 0.01063922f, -0.04192288f, -0.11339216f, -0.17413402f, 
    0.09805450f, -0.07321861f, 0.08214851f, -0.15114897f, -0.00468964f, -0.10392806f, -0.12406951f, -0.01885327f, 
    0.00029821f, -0.02967782f, -0.09213220f, 0.09704312f, -0.25155932f, 0.08897696f, -0.24611506f, 0.06599614f, 
    -0.06054488f, -0.03872637f, 0.08462051f, 0.07870333f, 0.10824203f, 0.05698836f, -0.04195245f, -0.01526656f, 
    -0.00453528f, -0.12433623f, -0.00061737f, 0.24366024f, -0.08113986f, 0.03441489f, 0.05107496f, -0.02808938f, 
    -0.00638178f, -0.05242294f, 0.06294812f, 0.05225460f, 0.06074454f, 0.17378817f, 0.02537981f, -0.10805677f, 
    0.17039882f, 0.12138197f, -0.04469209f, 0.06790940f, -0.04505491f, -0.06407436f, -0.05859205f, -0.08467082f, 
    0.14146811f, 0.08504232f, 0.11055794f, 0.03035075f, -0.00509584f, 0.02587993f, -0.00421324f, 0.03136402f, 
    0.06237942f, -0.21649289f, 0.02797198f, -0.03379915f, 0.06829891f, -0.14210652f, -0.09616484f, -0.37758803f, 
    -0.14560911f, 0.07842267f, -0.02758364f, 0.01099060f, -0.07730670f, -0.08000821f, -0.00353012f, 0.01290052f, 
    0.08331254f, -0.09015245f, -0.01197116f, -0.05793841f, 0.18208727f, 0.04219210f, 0.03443549f, -0.04622692f, 
    -0.04148314f, 0.09479645f, 0.00284441f, -0.11659117f, 0.22300495f, -0.02786500f, -0.12093779f, 0.05988277f, 
    -0.00193590f, -0.10586668f, 0.11081871f, 0.05930227f, 0.11351956f, 0.04222060f, -0.06541199f, 0.08428761f, 
    -0.10218436f, -0.08599816f, -0.08343306f, -0.23083869f, -0.15567346f, 0.02734599f, 0.02286301f, -0.01606572f, 
    -0.07492002f, -0.05922816f, -0.04320717f, -0.05448239f, 0.07834189f, 0.11538658f, 0.08880419f, -0.13174315f, 
    0.23216027f, -0.02828766f, 0.00198328f, 0.17309892f, 0.07617290f, 0.11764786f, 0.22074685f, 0.19001415f, 
    0.03201402f, -0.11175379f, -0.10435109f, -0.09130616f, 0.14089920f, 0.02571964f, 0.06929265f, 0.08274627f, 
    0.00890358f, -0.08220059f, 0.10802720f, 0.06833260f, 0.13654436f, 0.00909496f, -0.06209605f, 0.09077820f, 
    0.08528522f, 0.06718556f, 0.06984183f, 0.09032001f, 0.17746942f, -0.08186806f, 0.08517643f, 0.04719178f, 
    0.00794561f, 0.05175056f, 0.00171201f, 0.04225097f, -0.15308116f, 0.06874220f, 0.04903242f, -0.05067137f, 
    0.10233780f, 0.20758699f, 0.02884948f, 0.12658611f, -0.36230978f, -0.10986141f, -0.06634237f, 0.09789786f, 
    -0.21816266f, -0.11919821f, 0.03758390f, 0.10052796f, -0.09232358f, 0.03144322f, 0.09016635f, 0.00091159f, 
    0.03030055f, 0.02843548f, 0.01766069f, 0.04079660f, -0.01696863f, 0.00293150f, -0.04352358f, 0.03425901f, 
    -0.03213489f, 0.01725356f, 0.00910653f, -0.01811239f, -0.04605033f, -0.04569610f, 0.04622155f, -0.03568450f, 
    -0.01356994f, -0.00660822f, 0.04507966f, 0.03083124f, 0.02513612f, -0.00183278f, 0.02179233f, -0.03312729f, 
    0.00759621f, -0.05438885f, -0.04983343f, -0.04129405f, 0.01404746f, -0.03580462f, 0.04146352f, 0.03284611f, 
    -0.00934425f, -0.04268918f, -0.05770203f, -0.04496503f, -0.06071580f, 0.03266526f, -0.05076491f, 0.02622970f, 
    -0.03918537f, 0.02818702f, -0.01936229f, 0.03155825f, 0.02668777f, -0.02056926f, -0.04442277f, 0.02243589f, 
    0.03158486f, -0.04979315f, 0.03557396f, 0.01093787f, -0.00978110f, -0.04227296f, -0.03775713f, -0.04193949f, 
    0.02362606f, -0.03355160f, -0.03381488f, 0.02004460f, 0.01338458f, 0.02955092f, -0.02469619f, -0.02309178f, 
    -0.04447493f, 0.03345116f, -0.02625202f, 0.00487511f, -0.02646371f, 0.00888033f, 0.00810274f, -0.03048874f, 
    -0.05511463f, 0.00003328f, -0.03130498f, -0.05789391f, -0.02146000f, 0.01168534f, -0.02773897f, -0.00102905f, 
    -0.00082197f, -0.04470946f, 0.01958571f, -0.03620354f, -0.06128636f, 0.02455647f, -0.01957332f, -0.02026229f, 
    0.04457429f, 0.03621843f, -0.03781912f, 0.03608669f, 0.01560103f, 0.01853268f, -0.01787525f, -0.04852094f, 
    -0.03533015f, -0.01018139f, -0.03637131f, -0.03001536f, -0.05257102f, -0.01825608f, -0.04423226f, -0.03000405f, 
    0.00033672f, 0.04310434f, 0.03894958f, -0.00906005f, -0.02596456f, -0.00312231f, -0.04477678f, 0.02286856f, 
    0.03134282f, -0.01753362f, -0.02385847f, -0.01016543f, 0.04171854f, -0.01913810f, 0.01042931f, 0.00175364f, 
    0.02900964f, -0.01756943f, -0.05899239f, 0.01895392f, 0.03573149f, -0.01025073f, 0.01384699f, -0.00493944f, 
    0.02706631f, -0.01956369f, -0.00038489f, 0.00628830f, -0.01661260f, 0.01703375f, 0.00340172f, 0.02519893f, 
    0.01336103f, 0.01168092f, -0.04917409f, -0.05521204f, 0.04378249f, -0.00644098f, 0.01994833f, -0.02252930f, 
    -0.03880597f, 0.00324984f, 0.04369179f, 0.03952552f, 0.02219934f, -0.02863238f, 0.01006056f, -0.03677947f, 
    0.02463402f, -0.03640569f, -0.02016818f, 0.01001122f, 0.00260561f, -0.05558230f, -0.01481689f, -0.01584956f, 
    -0.05710385f, 0.03513604f, -0.01467073f, -0.00810129f, -0.04190899f, 0.04197499f, -0.05343303f, -0.01929982f, 
    0.01003416f, 0.01259922f, -0.05003342f, -0.05626411f, 0.01706076f, 0.02825433f, 0.02515727f, 0.03718588f, 
    0.01628868f, -0.02536090f, 0.01560538f, -0.02267868f, 0.00402691f, 0.02772222f, -0.01746962f, 0.00464756f, 
    0.00986610f, -0.04133056f, 0.03246621f, -0.04521382f, 0.03048270f, -0.05180664f, 0.03466574f, 0.01374398f, 
    -0.04270574f, -0.03341266f, 0.01114369f, 0.03383764f, 0.04719924f, 0.01390363f, -0.00172304f, -0.05587041f, 
    -0.04128329f, 0.02466836f, 0.00011498f, -0.03011694f, -0.02155402f, 0.02692656f, -0.04324525f, -0.00217164f, 
    -0.01413991f, 0.00697715f, 0.01580837f, -0.03566610f, -0.00743773f, -0.01030841f, 0.00236374f, -0.04318091f, 
    -0.01659379f, 0.00736798f, -0.01210579f, -0.04082535f, -0.01534049f, 0.04228554f, 0.03092985f, 0.01164625f, 
    0.00222416f, -0.01120563f, -0.02292833f, -0.06146320f, -0.00398860f, -0.01273886f, 0.01826129f, -0.00399981f, 
    0.01355473f, -0.00256343f, 0.02256662f, 0.03389056f, -0.03496164f, 0.00029240f, -0.04190465f, 0.02552765f, 
    -0.05250591f, 0.01878642f, -0.02053790f, -0.03459369f, 0.01573289f, -0.02142917f, 0.03292489f, -0.01273636f, 
    0.01000681f, -0.01684477f, 0.01185650f, 0.00429938f, -0.00342033f, -0.05614855f, -0.04191559f, 0.04503116f, 
    0.02600351f, -0.03351159f, -0.05054783f, -0.03478046f, 0.00073410f, 0.04429888f, -0.05823000f, -0.03898602f, 
    -0.01485163f, -0.00901959f, -0.04848507f, -0.05405266f, -0.03716618f, 0.02504930f, -0.04992553f, 0.03385626f, 
    0.03709464f, 0.02069821f, 0.03864595f, -0.02525062f, 0.02459250f, -0.00813713f, -0.00098424f, 0.00224048f, 
    -0.04173932f, -0.04209661f, 0.02854224f, -0.04727961f, -0.03147487f, 0.00600193f, 0.01974768f, 0.03329355f, 
    0.02662730f, -0.04886643f, -0.02415747f, 0.01245861f, 0.01726071f, -0.02343479f, -0.05544789f, 0.05054158f, 
    -0.01270886f, -0.04653576f, 0.03430201f, -0.03520591f, -0.03389125f, -0.01425470f, 0.00677820f, 0.00479506f, 
    -0.02769738f, -0.00391432f, 0.02867626f, -0.04703332f, -0.01748352f, 0.03928513f, 0.01994365f, -0.03283288f, 
    -0.00942382f, -0.00661705f, -0.03663610f, -0.00931580f, -0.01618901f, -0.00673428f, -0.04648980f, -0.01382364f, 
    -0.03794525f, 0.04639842f, -0.04478559f, 0.00363750f, 0.03956331f, 0.02932641f, 0.02913300f, 0.04105167f, 
    -0.02949201f, 0.01482585f, 0.02430261f, 0.04039956f, -0.04797167f, -0.02462711f, 0.03790383f, -0.05438105f, 
    -0.02253900f, -0.06041425f, 0.04528344f, -0.03102667f, -0.01294359f, 0.04512926f, -0.02128967f, 0.00451383f, 
    -0.01698434f, -0.05199251f, 0.00229174f, -0.03736220f, -0.01577937f, -0.04322842f, -0.01878542f, -0.05285069f, 
    0.02496090f, -0.00871724f, 0.04614877f, -0.04274948f, -0.03418865f, -0.01399790f, 0.03254972f, -0.05316078f, 
    -0.02277623f, 0.01276645f, -0.00770136f, 0.04026986f, 0.04034453f, -0.03120150f, -0.00185279f, 0.00482330f, 
    0.03132040f, 0.00276755f, 0.03069737f, -0.00784419f, 0.00270459f, 0.02383718f, -0.03367110f, -0.00622479f, 
    -0.01851268f, -0.02318100f, -0.03173074f, 0.01419960f, 0.03250537f, -0.00077763f, -0.05513589f, 0.01325084f, 
    0.08421954f, -0.16580129f, 0.02489504f, 0.01872158f, -0.04658499f, -0.03819061f, 0.08652542f, 0.08680112f, 
    -0.08485147f, 0.02704254f, -0.07855811f, -0.01455580f, 0.07933396f, 0.07832514f, 0.02280486f, -0.00230507f, 
    0.05691205f, -0.08936673f, 0.08893813f, -0.03322981f, 0.12889194f, 0.08439779f, -0.03441371f, 0.02524676f, 
    0.04523352f, -0.04822740f, 0.01247088f, -0.03730738f, 0.08046558f, -0.03887656f, 0.04689005f, 0.07705543f, 
    -0.00851208f, 0.01163448f, -0.00263245f, -0.13168687f, -0.15231921f, -0.14944507f, -0.25239033f, -0.10716870f, 
    0.07513682f, 0.00110894f, -0.00993710f, 0.01073332f, -0.07737135f, -0.10143618f, -0.13089070f, 0.03443597f, 
    -0.15206836f, -0.19026555f, -0.19624640f, 0.17222844f, 0.05378663f, -0.01127525f, 0.05173835f, 0.11389078f, 
    -0.11486621f, 0.07065645f, 0.09749126f, 0.10040627f, -0.22862975f, -0.17872071f, -0.13168359f, -0.18331489f, 
    0.16173010f, 0.01273525f, 0.12936442f, 0.06979227f, 0.10733222f, -0.01291457f, 0.05841913f, 0.17501457f, 
    0.04786410f, -0.08618179f, -0.01684945f, 0.18958518f, -0.00216378f, 0.01025400f, 0.05456415f, 0.03745116f, 
    0.06363317f, 0.03024676f, -0.02878091f, -0.00002453f, -0.28132299f, -0.13937320f, -0.16581799f, 0.17094338f, 
    0.00258709f, -0.00685607f, 0.09557729f, -0.05384669f, -0.03389388f, 0.10619688f, 0.06643391f, 0.01654493f, 
    0.06334788f, 0.12424231f, 0.18049994f, -0.05658649f, 0.05155263f, 0.02539634f, 0.04992294f, -0.03423151f, 
    0.09669244f, 0.02306660f, 0.01672848f, 0.01967744f, -0.14111720f, -0.20366983f, 0.00401481f, 0.27755576f, 
    -0.16535005f, 0.11901647f, -0.01972717f, 0.12236620f, -0.01998061f, 0.07396237f, -0.05796790f, 0.09914540f, 
    0.02647224f, 0.13687193f, 0.16555838f, -0.10092297f, 0.07574085f, 0.01590162f, 0.09164099f, 0.03715318f, 
    -0.02626874f, 0.17137150f, 0.15670207f, 0.06466609f, 0.03060979f, -0.10190405f, -0.08663043f, 0.08994956f, 
    0.12016742f, -0.02760025f, -0.13386153f, 0.05312032f, 0.05335953f, -0.05662166f, -0.06029002f, 0.00700197f, 
    -0.28245220f, -0.15559530f, -0.06457788f, 0.24860942f, 0.08800461f, -0.00654636f, 0.02929327f, 0.07534675f, 
    0.05241791f, -0.02540818f, -0.04974351f, -0.14774272f, -0.09465418f, -0.25616315f, -0.00387449f, 0.29580536f, 
    -0.03097424f, 0.04046756f, 0.04981853f, -0.01551694f, -0.02855589f, 0.09295721f, 0.12160525f, 0.23409574f, 
    -0.19366692f, -0.04237700f, -0.10721206f, -0.28589839f, 0.15144484f, -0.07197964f, 0.05970460f, 0.09842533f, 
    0.17002450f, 0.11848856f, 0.08113861f, -0.01290098f, 0.22715510f, 0.12459829f, 0.41864976f, 0.04825657f, 
    0.04868779f, -0.00674518f, -0.00296291f, -0.05817040f, 0.12633476f, -0.01878853f, 0.03202877f, -0.04538039f, 
    0.12290005f, 0.06306089f, 0.02916234f, -0.12192146f, 0.02034527f, 0.11646260f, 0.00913527f, 0.02351162f, 
    0.15856972f, -0.05802507f, -0.01386983f, 0.05464222f, 0.08763484f, -0.01653837f, 0.05773527f, 0.11140016f, 
    0.08599183f, 0.02068692f, 0.02735591f, -0.13322179f, 0.00770708f, 0.05633144f, -0.01679988f, -0.08532141f, 
    -0.12187165f, -0.09997303f, -0.17248213f, 0.02040070f, 0.12690224f, 0.05220680f, 0.00496263f, -0.06613216f, 
    0.04622100f, 0.00434052f, 0.05212356f, 0.05772637f, -0.12557639f, -0.06643593f, -0.14020906f, 0.07259538f, 
    -0.04420596f, -0.03402254f, 0.09845007f, -0.00034707f, 0.04420946f, -0.02438622f, 0.02749126f, -0.02341785f, 
    -0.21633363f, -0.33127472f, -0.19208032f, -0.10670104f, 0.04642698f, 0.07337951f, 0.13663889f, -0.01246088f, 
    -0.03127348f, -0.10079248f, 0.14992101f, -0.02096615f, 0.01524689f, 0.30999926f, 0.31684786f, -0.04288178f, 
    0.13638030f, 0.05357835f, 0.02742206f, -0.08954979f, 0.09930439f, -0.00109569f, 0.02916422f, 0.04350419f, 
    -0.11450019f, -0.10455129f, -0.14848606f, 0.32122508f, 0.13849145f, 0.02383835f, 0.06470177f, -0.16153722f, 
    -0.01243040f, -0.02684258f, 0.05798060f, -0.13256162f, -0.01655159f, -0.18207698f, -0.06437545f, 0.07962745f, 
    -0.06656867f, -0.03805209f, -0.16313399f, -0.05421880f, 0.01612739f, -0.12133055f, -0.03582469f, 0.04610658f, 
    0.06798327f, -0.01600356f, -0.04586607f, 0.05355596f, 0.02258228f, -0.05982612f, 0.12995592f, -0.07079785f, 
    -0.04642181f, -0.03477216f, -0.15176977f, -0.10719293f, 0.35834625f, 0.21918863f, 0.09992041f, -0.17162968f, 
    0.19894773f, 0.07173964f, 0.01176925f, 0.08902234f, 0.04691936f, 0.04159499f, 0.05063428f, 0.14780855f, 
    0.05711351f, -0.13568194f, -0.08383232f, -0.02514975f, 0.05194041f, 0.04632174f, -0.02164252f, 0.03019685f, 
    -0.05028171f, 0.13856088f, -0.13123529f, 0.03640377f, 0.16036135f, 0.17904420f, 0.15870203f, -0.27773613f, 
    0.10455894f, -0.02397836f, 0.03852887f, 0.08775114f, 0.14363019f, 0.22732298f, 0.09887118f, 0.16971961f, 
    0.07319938f, 0.16517189f, 0.04854814f, -0.36596704f, 0.07291018f, 0.05056759f, 0.04469636f, 0.12280940f, 
    0.14256196f, 0.13040513f, 0.00338982f, 0.08250320f, 0.17830497f, 0.29027659f, 0.17698294f, -0.30854815f, 
    0.10643145f, 0.08880184f, 0.07162835f, -0.02260602f, -0.08506668f, 0.06749657f, -0.04453773f, 0.09158772f, 
    0.00561242f, -0.18949780f, -0.14837618f, 0.12640558f, -0.03166805f, -0.08243602f, 0.01659434f, 0.02936849f, 
    -0.14721248f, 0.02266840f, -0.02656861f, 0.13692789f, -0.28334379f, -0.30142123f, -0.14846058f, 0.07652916f, 
    0.01974019f, 0.05744966f, -0.00364393f, 0.07316326f, 0.00073239f, -0.02052432f, 0.12859757f, 0.09997205f, 
    -0.35889164f, 0.17945600f, 0.21279237f, 0.18949716f, 0.08063306f, -0.02631665f, -0.12079188f, -0.07480485f, 
    -0.06361580f, -0.01271980f, 0.00672720f, -0.08941153f, 0.36928847f, -0.05436420f, 0.07030040f, 0.14799531f, 
    -0.06097708f, -0.13620858f, 0.10181573f, 0.03916068f, 0.03616847f, 0.04257837f, -0.07389303f, 0.05164003f, 
    -0.15937564f, 0.02414715f, 0.12644242f, -0.03758018f, -0.03438302f, -0.05946312f, 0.02671462f, -0.00997104f, 
    -0.10435434f, 0.01646487f, -0.08124948f, 0.05570759f, -0.08130770f, 0.02205907f, 0.05420713f, 0.02990440f, 
    -0.03452969f, 0.01219196f, -0.08368629f, 0.02496052f, 0.03629625f, -0.00808097f, -0.04112672f, -0.08367714f, 
    0.22144271f, 0.17925227f, 0.03364789f, -0.09941392f, 0.08469957f, 0.01074587f, 0.00891909f, -0.03050600f, 
    0.05039708f, 0.03804838f, 0.03556209f, 0.21691960f, -0.29699355f, 0.21976410f, -0.13630156f, -0.21225588f, 
    0.01411022f, 0.14415364f, 0.09385520f, -0.00972121f, -0.12349036f, 0.04622619f, 0.06689995f, -0.00148270f, 
    -0.20886190f, -0.05623667f, 0.02966106f, -0.13299002f, -0.03947500f, 0.00159889f, 0.03277529f, 0.05624967f, 
    0.05793106f, -0.10666517f, -0.03506992f, 0.04753519f, -0.17187057f, 0.28115487f, 0.01333585f, 0.01122417f, 
    0.00178716f, -0.00933821f, 0.02047970f, 0.08280291f, 0.08645310f, 0.09360221f, -0.00901150f, -0.09169646f, 
    0.23756614f, -0.28750581f, 0.16322021f, 0.13249445f, -0.15763652f, -0.16771325f, -0.03290030f, 0.10372803f, 
    0.05004166f, -0.01637126f, -0.01526675f, -0.06001856f, -0.00842916f, 0.18531752f, 0.11476581f, 0.23212096f, 
    0.04399724f, -0.08564351f, -0.01077769f, -0.07642931f, -0.00243972f, 0.05436979f, -0.11369749f, 0.06321639f, 
    0.13825652f, 0.00790660f, 0.07613837f, 0.03795312f, -0.10319212f, 0.02914673f, 0.00127891f, -0.05753308f, 
    -0.07936722f, -0.00497766f, -0.04265982f, -0.04954714f, -0.11991699f, 0.03466593f, 0.08107094f, 0.23443915f, 
    0.01607667f, -0.01152397f, -0.02370909f, 0.12799492f, -0.02444637f, -0.03603141f, 0.08834560f, 0.02520745f, 
    0.18697563f, 0.00149199f, -0.20472181f, -0.04345673f, 0.04803519f, -0.15466954f, -0.11368527f, -0.01011048f, 
    0.08510555f, 0.04746049f, 0.05467965f, -0.04460016f, 0.21188481f, -0.12781845f, 0.14029479f, 0.15474862f, 
    -0.01410277f, 0.06371647f, 0.13808908f, 0.01966280f, 0.01787295f, 0.03099070f, -0.11532179f, 0.07111234f, 
    0.05417811f, -0.16543163f, 0.04526900f, 0.09676330f, 0.05784475f, 0.02461894f, -0.13575625f, -0.02343818f, 
    -0.05279913f, -0.06908652f, -0.08223014f, 0.04576676f, 0.25823799f, -0.17757329f, -0.23085153f, 0.12726569f, 
    -0.17411755f, -0.14687112f, 0.01666747f, 0.07862136f, 0.00025585f, 0.03798350f, 0.05087522f, 0.14563705f, 
    0.20640215f, -0.16651024f, -0.05567702f, 0.28007698f, -0.01955260f, 0.08236721f, -0.04214252f, -0.04302018f, 
    -0.04405231f, -0.10417192f, 0.05642780f, -0.05552024f, -0.28725851f, 0.14886582f, 0.17574285f, -0.12391961f, 
    0.03789023f, 0.07358368f, -0.05189123f, -0.09456421f, -0.00487133f, 0.07767630f, 0.06929084f, 0.08568726f, 
    0.13105634f, 0.07238989f, -0.00831666f, 0.06186725f, -0.07351176f, 0.10444143f, 0.07310634f, 0.01971067f, 
    -0.03777964f, 0.02573878f, 0.04697976f, -0.02338747f, 0.40455601f, -0.41860831f, 0.05737345f, -0.07709232f, 
    0.05334792f, -0.06395376f, -0.00863420f, -0.00975692f, -0.04916811f, -0.00150086f, 0.08281104f, 0.02746822f, 
    -0.11624060f, 0.26811561f, -0.07737619f, -0.21306457f, 0.06078045f, -0.07731435f, 0.07783052f, 0.04282252f, 
    0.07093886f, -0.02855185f, -0.05176601f, 0.11985709f, 0.31401023f, -0.14693896f, 0.30094734f, 0.31234717f, 
    -0.13117383f, 0.09402981f, -0.01123386f, 0.00425941f, 0.08668938f, 0.03601638f, 0.10005139f, 0.03515920f, 
    0.03237893f, -0.09442987f, -0.11863397f, 0.04850852f, -0.02569173f, 0.02726445f, 0.06498707f, 0.04276361f, 
    -0.04139160f, 0.17359549f, 0.13726531f, 0.10442052f, -0.02337153f, -0.06975616f, 0.07629279f, 0.34226242f, 
    -0.03405616f, 0.01835309f, 0.08997573f, 0.10754330f, 0.11503240f, 0.09162267f, -0.05350313f, -0.02661907f, 
    -0.22651587f, 0.04969678f, 0.01615729f, 0.09681445f, -0.04021413f, -0.09162206f, 0.01521784f, 0.03822087f, 
    0.13664564f, -0.03157320f, 0.02274825f, -0.01537181f, 0.12073783f, -0.12420473f, 0.02461286f, 0.01354694f, 
    -0.17932272f, 0.02135818f, 0.06261283f, 0.08148859f, 0.01457188f, 0.02568755f, -0.02213240f, -0.10671571f, 
    0.09536731f, 0.25043806f, -0.11343016f, 0.21329907f, 0.02087809f, -0.03727114f, -0.03330227f, 0.03382161f, 
    0.04707042f, 0.05783381f, -0.02907518f, -0.06613927f, 0.22618866f, -0.07283615f, 0.06229111f, 0.40639263f, 
    -0.17744911f, 0.11834002f, 0.07763257f, 0.06944150f, -0.00104026f, 0.06494012f, -0.08488901f, -0.02663094f, 
    -0.08676753f, -0.05804863f, 0.14338009f, 0.26613322f, -0.31183237f, 0.09317099f, 0.01904527f, 0.00846870f, 
    -0.03735643f, 0.09118537f, 0.04089066f, -0.01960409f, 0.36861667f, -0.05627461f, 0.07626770f, 0.05631363f, 
    -0.11440363f, 0.01301626f, -0.09423385f, -0.01047412f, -0.00797315f, 0.02193023f, -0.07579049f, 0.04705561f, 
    0.17734823f, -0.07571629f, 0.09273048f, -0.02650185f, -0.02639426f, -0.02002087f, 0.08235112f, 0.05448670f, 
    -0.06617685f, -0.21051660f, 0.00318827f, -0.03003450f, 0.11131100f, 0.20386678f, -0.04553777f, -0.28611642f, 
    0.18069047f, 0.07847282f, 0.17991610f, -0.09347944f, 0.07438619f, -0.02767110f, -0.05656371f, 0.12863536f, 
    0.02226564f, -0.00055357f, 0.34160951f, 0.09145339f, -0.07320703f, -0.12058660f, -0.02089217f, -0.07318793f, 
    -0.09199282f, -0.06699226f, -0.04729343f, 0.09186948f, 0.25882921f, -0.27311528f, -0.30379701f, 0.26672158f, 
    0.10434424f, -0.09089298f, 0.09127185f, 0.01468401f, -0.08584283f, -0.01387057f, -0.00377930f, 0.06621610f, 
    0.10178198f, 0.12641227f, 0.00130574f, -0.13908066f, -0.11336417f, -0.12933344f, 0.04533008f, 0.03549431f, 
    -0.20486546f, 0.09225958f, -0.08033161f, -0.03127833f, 0.23834881f, 0.21161549f, -0.03697786f, -0.09581251f, 
    -0.06260671f, 0.06604116f, -0.03244770f, 0.07539755f, -0.01918141f, -0.08043121f, -0.20986842f, -0.00326580f, 
    0.13003796f, 0.03919805f, 0.27676022f, 0.18889478f, -0.05766360f, 0.00528954f, 0.02022398f, 0.04862664f, 
    -0.10726850f, 0.10424022f, 0.02084860f, 0.08846758f, -0.12276214f, 0.05069560f, -0.07340930f, -0.03499207f, 
    -0.03383653f, -0.14590174f, 0.07753785f, 0.00763898f, -0.03850825f, -0.09409925f, -0.09236035f, -0.00445431f, 
    -0.00802663f, -0.09450091f, -0.05115686f, -0.08370825f, -0.05336066f, 0.02343474f, 0.05023714f, 0.05452541f, 
    0.05473658f, -0.07759630f, -0.00328157f, -0.01841713f, -0.16719855f, 0.41521111f, -0.22361597f, 0.07142634f, 
    -0.00953419f, -0.00849251f, 0.04669813f, 0.04034875f, 0.07541168f, 0.17282778f, -0.06188207f, -0.01084676f, 
    0.20241416f, -0.27379277f, -0.10397239f, 0.06779972f, 0.07046710f, -0.04474922f, -0.00433939f, -0.02855139f, 
    -0.08185221f, 0.00432397f, 0.00501286f, 0.04043870f, 0.12976234f, 0.35340244f, 0.03112347f, -0.03413599f, 
    0.06835555f, 0.08842021f, -0.13984087f, -0.02320908f, 0.12489396f, 0.17725369f, -0.00355183f, -0.00608424f, 
    0.06799195f, -0.20466605f, 0.04379909f, -0.06052545f, -0.01364004f, 0.05500038f, -0.05448997f, 0.02772513f, 
    -0.04478102f, 0.01699401f, -0.03168994f, -0.02792320f, 0.03927536f, 0.15554544f, 0.07914965f, 0.03170426f, 
    0.06503862f, -0.10300581f, -0.16290063f, 0.11713530f, -0.01548392f, 0.05124057f, 0.09027898f, 0.05439195f, 
    0.02241466f, 0.27870131f, 0.26805162f, 0.28277400f, -0.08320717f, -0.01696394f, 0.00825893f, 0.02700707f, 
    -0.03190120f, -0.01545731f, -0.09059994f, -0.07430500f, 0.38700402f, 0.21728033f, -0.06026362f, 0.16923475f, 
    0.08475444f, -0.02959906f, -0.06457476f, 0.07434179f, -0.06471319f, 0.00909769f, -0.04591456f, -0.03304287f, 
    -0.03227679f, 0.28416103f, -0.01667818f, -0.02483967f, 0.10646990f, -0.00362973f, -0.09478963f, 0.10213476f, 
    0.08400229f, 0.05366134f, 0.06297918f, -0.04116490f, -0.16159989f, -0.30714300f, -0.10875770f, 0.04109813f, 
    -0.10914518f, -0.05643777f, -0.06180645f, 0.04215485f, 0.09288690f, -0.08417717f, 0.07287597f, -0.13388613f, 
    -0.13805494f, -0.04513580f, -0.11526905f, 0.20370975f, 0.01718394f, 0.16226414f, -0.01988584f, -0.06956828f, 
    -0.07883921f, 0.04578350f, 0.06687129f, -0.06283294f, -0.32782736f, 0.12121119f, 0.15814276f, 0.00523980f, 
    0.10973957f, -0.07765777f, -0.08734387f, -0.05057823f, -0.03585810f, 0.11477616f, 0.03471057f, 0.04039866f, 
    0.24480785f, 0.13299140f, -0.03503321f, 0.07766479f, -0.13181223f, 0.06477190f, -0.04307142f, -0.01894301f, 
    0.08974625f, 0.01490049f, 0.01636022f, -0.02814794f, -0.06052428f, -0.05378022f, -0.03796867f, 0.16130930f, 
    -0.16484784f, -0.00628950f, -0.04642930f, -0.04815279f, 0.06061027f, 0.07640956f, 0.07624297f, -0.00041574f, 
    -0.06842906f, 0.11405390f, -0.08626275f, 0.17421558f, -0.14751139f, -0.09264077f, 0.10427264f, 0.07436959f, 
    -0.00020255f, -0.10464675f, -0.04735962f, -0.08744829f, -0.09151790f, -0.08086023f, 0.28951102f, 0.10795546f, 
    0.12453778f, 0.07209966f, 0.02122734f, -0.13524908f, 0.05788536f, -0.09241650f, -0.01608066f, -0.13408791f, 
    0.13436718f, 0.08847394f, -0.05898675f, 0.08590380f, 0.04141698f, -0.07902306f, -0.00667745f, -0.01464227f, 
    -0.06374273f, -0.00043392f, 0.02830184f, -0.00094269f, 0.30382556f, 0.09611277f, 0.03231490f, 0.06402332f, 
    0.01546336f, 0.01747464f, -0.02153574f, 0.07146015f, 0.12785317f, -0.01608860f, 0.01528207f, -0.01640977f, 
    0.22168374f, -0.14875177f, -0.01489661f, -0.13794820f, -0.00379590f, -0.07930144f, -0.02239259f, -0.04687602f, 
    0.09470505f, -0.01045615f, -0.01633636f, 0.08637198f, 0.05743661f, -0.07811188f, -0.10402740f, 0.02847425f, 
    -0.00832085f, 0.14793520f, -0.02123607f, 0.05210650f, 0.05927774f, -0.10992267f, 0.00214552f, -0.02132043f, 
    0.26318645f, 0.30151373f, 0.19310291f, 0.07677971f, -0.00910966f, 0.01571863f, 0.03192994f, 0.02521840f, 
    0.04167046f, 0.03203170f, 0.10656947f, -0.00636134f, -0.23645207f, 0.07451883f, 0.04355318f, 0.03268103f, 
    0.12551183f, 0.11838425f, 0.05017513f, 0.05924775f, 0.04069840f, 0.10729898f, -0.04777072f, -0.07252833f, 
    -0.17016201f, 0.03049759f, -0.11172302f, -0.15863769f, -0.04160662f, -0.03239638f, -0.07175944f, 0.06407890f, 
    0.08516480f, 0.08999218f, -0.03879813f, -0.03087195f, 0.16036667f, -0.10009954f, 0.05643132f, 0.10334464f, 
    0.16055897f, 0.01397204f, -0.01053287f, -0.11324229f, 0.10284536f, -0.09119546f, 0.16418572f, -0.11435147f, 
    -0.10946835f, 0.23997718f, -0.10202132f, 0.11685327f, -0.05024340f, -0.09833301f, 0.01820400f, 0.05716686f, 
    0.00275032f, -0.12625004f, 0.04432308f, 0.12218975f, -0.09943022f, -0.01434510f, 0.03965127f, 0.37582511f, 
    -0.03496680f, 0.00754875f, 0.07459539f, 0.00782217f, -0.12617005f, -0.02850664f, -0.02706729f, 0.01045355f, 
    0.03159853f, 0.02767684f, -0.02196275f, -0.06141729f, 0.01607003f, -0.03205482f, 0.01859852f, 0.01620993f, 
    0.00343969f, 0.03245765f, 0.00306723f, 0.02097840f, 0.01066945f, -0.06006182f, 0.02762485f, 0.02379812f, 
    -0.05103095f, -0.06093545f, 0.00245195f, -0.04614178f, -0.05194807f, 0.02665907f, -0.05057273f, 0.02210480f, 
    -0.03628112f, -0.04523598f, -0.03378173f, -0.00759096f, -0.05617439f, 0.02388603f, -0.03449341f, -0.00094182f, 
    -0.04154284f, -0.00513100f, -0.00993926f, 0.01702298f, 0.03891917f, -0.04516794f, -0.01718316f, 0.03525271f, 
    0.01111716f, 0.00487355f, -0.03781555f, -0.02068995f, -0.05376779f, -0.00973972f, -0.02758295f, 0.02711087f, 
    -0.02926338f, -0.01649318f, -0.00682057f, -0.00810193f, 0.01222994f, 0.01954991f, 0.02655319f, 0.01276159f, 
    0.04973196f, -0.03784135f, 0.01824958f, -0.02847154f, 0.02353175f, 0.03178757f, 0.02582134f, 0.00172461f, 
    -0.03842092f, 0.00232026f, -0.05792653f, -0.05511169f, -0.03850480f, 0.02128433f, -0.03383085f, -0.04243831f, 
    0.02293401f, -0.04766444f, 0.02367962f, -0.06270862f, 0.03624327f, -0.00479189f, -0.00464381f, 0.01588547f, 
    -0.01526135f, -0.05569641f, -0.01362189f, 0.01629285f, 0.02162646f, -0.00033452f, -0.03708604f, -0.01227418f, 
    0.01983386f, -0.00506909f, -0.02394217f, -0.02334030f, 0.02053324f, 0.02395171f, 0.02975278f, -0.03782142f, 
    -0.04930831f, -0.00587623f, 0.05712947f, 0.00992263f, -0.04386352f, -0.01754735f, 0.02458936f, -0.04729056f, 
    0.03111356f, -0.04059757f, 0.00523400f, -0.03407682f, -0.04734302f, -0.03956868f, 0.00455956f, -0.00548008f, 
    -0.04074786f, -0.01924329f, -0.00916475f, 0.03196811f, -0.04810376f, 0.02272387f, -0.03891037f, -0.00808977f, 
    0.00890206f, 0.00493198f, -0.04763344f, -0.05545536f, 0.02147326f, -0.02655401f, -0.01230854f, -0.05025063f, 
    0.01456720f, -0.05750268f, -0.01695543f, -0.00330314f, 0.00149343f, -0.00028644f, -0.01886654f, 0.02678205f, 
    0.03733960f, -0.04687089f, -0.03913593f, -0.02578518f, -0.05738312f, -0.01755156f, 0.04334522f, -0.03293382f, 
    -0.00926584f, 0.00354612f, -0.00280537f, -0.04992759f, 0.01436577f, -0.02439880f, 0.02185881f, -0.04478001f, 
    -0.05764734f, -0.04719594f, 0.00296492f, -0.00046139f, -0.03429231f, -0.04391121f, -0.01723326f, 0.02825061f, 
    -0.03864079f, 0.00395156f, 0.00261896f, -0.00757697f, 0.03524209f, 0.02026161f, -0.02279972f, 0.01395020f, 
    -0.04235394f, -0.02501209f, 0.03005681f, -0.05084850f, 0.03667683f, 0.00065629f, 0.03794982f, 0.03129568f, 
    -0.05185964f, -0.02149918f, -0.04178876f, -0.04054914f, -0.05727561f, -0.00958439f, 0.00981764f, -0.02975760f, 
    0.01420711f, 0.01689616f, -0.03861037f, -0.04260774f, -0.05021211f, -0.03024581f, 0.02149575f, 0.03006798f, 
    -0.05580027f, -0.01640792f, -0.03054908f, 0.00569845f, 0.03853877f, 0.03944826f, -0.00279407f, -0.03679034f, 
    0.04663572f, -0.05456992f, -0.05886618f, 0.03145977f, 0.03230217f, 0.03356365f, -0.01111957f, 0.01096970f, 
    -0.01545135f, -0.00363246f, 0.00154446f, -0.01882318f, 0.03721187f, -0.05126306f, -0.02516473f, 0.03406630f, 
    0.03564316f, -0.02806879f, 0.02417482f, -0.04442544f, -0.00100373f, 0.02358687f, -0.02465896f, -0.04683186f, 
    0.00830367f, 0.02634583f, 0.01219050f, -0.03941595f, -0.00312244f, 0.00518762f, 0.02019318f, -0.05299487f, 
    -0.00083221f, 0.02001130f, -0.03313364f, 0.01937014f, 0.01574393f, -0.02116287f, -0.04094304f, -0.04267965f, 
    -0.03241360f, -0.02389973f, -0.04717252f, -0.03396414f, 0.02406036f, -0.03521718f, -0.04706871f, -0.00861533f, 
    0.02045215f, -0.01722891f, 0.00824933f, -0.05226506f, 0.03727553f, 0.03551273f, -0.03797191f, 0.00168836f, 
    -0.01828770f, 0.03418960f, -0.04323309f, 0.01181166f, -0.04010221f, 0.03484154f, -0.02259508f, -0.04522145f, 
    0.04096345f, -0.01236598f, -0.01793926f, 0.00414858f, 0.02554527f, -0.04821907f, -0.01066673f, -0.04018560f, 
    0.00767264f, -0.01006979f, -0.01053108f, -0.01092357f, 0.01770802f, -0.05082363f, 0.02306952f, -0.02423850f, 
    0.02583007f, -0.00832413f, -0.02146715f, 0.02932286f, -0.02591755f, -0.01937291f, 0.01242058f, -0.02047894f, 
    -0.01213717f, -0.03841925f, -0.05038568f, 0.03625267f, -0.00618017f, 0.01570069f, -0.05771663f, -0.02700610f, 
    0.01192701f, -0.00117877f, -0.01397620f, -0.04672509f, 0.05027600f, -0.02917872f, 0.03365332f, -0.03708315f, 
    -0.03554351f, 0.04269629f, -0.00588676f, 0.03033713f, 0.01233949f, 0.01926095f, -0.01901260f, 0.02435427f, 
    0.01142343f, -0.03795934f, -0.02509217f, -0.03308648f, 0.02891983f, 0.03831597f, -0.02758699f, 0.03083050f, 
    -0.03715963f, -0.04398437f, -0.03563474f, -0.00257859f, -0.01714863f, 0.02173068f, -0.05419885f, 0.02596484f, 
    -0.01279759f, -0.05184598f, -0.00304993f, 0.03305672f, 0.02444432f, -0.05140116f, -0.04382129f, -0.03846268f, 
    0.03054219f, -0.02039530f, 0.00881102f, -0.05144927f, 0.03594541f, 0.01139074f, 0.01255822f, -0.04358207f, 
    0.01361272f, 0.02221575f, 0.01469060f, 0.01010211f, 0.02825930f, -0.03033760f, -0.00544710f, -0.03393340f, 
    0.01023309f, -0.04926034f, -0.01681585f, 0.01080241f, -0.01330199f, -0.02464192f, 0.03075997f, 0.02924660f, 
    -0.00378470f, 0.00304965f, -0.02173424f, 0.01767847f, 0.02503946f, -0.04587938f, -0.02077605f, 0.01276624f, 
    -0.05195889f, 0.04208092f, -0.04103291f, -0.02647629f, -0.01179205f, -0.03435565f, 0.00644346f, -0.02508331f, 
    -0.06132409f, 0.02988434f, 0.03698399f, -0.05937576f, -0.01934734f, 0.01418246f, -0.03702988f, 0.00676777f, 
    -0.22614813f, 0.12083640f, -0.01557701f, 0.01760943f, 0.00082611f, 0.04046737f, 0.02876784f, -0.04530683f, 
    -0.04085497f, -0.15000306f, 0.01862616f, -0.07593843f, 0.01316224f, -0.07935359f, -0.01214686f, 0.08314567f, 
    0.02365110f, 0.03527570f, 0.04985205f, 0.11090822f, 0.11246517f, 0.13819203f, -0.00689334f, 0.06110768f, 
    0.04305030f, 0.13889903f, 0.15136929f, -0.05797115f, 0.14478676f, 0.00971607f, 0.10491684f, -0.07384513f, 
    0.09599967f, -0.06178096f, 0.08451436f, 0.00035526f, -0.08684491f, -0.04967571f, 0.02468171f, -0.02599686f, 
    -0.00014386f, 0.14856660f, -0.06097933f, -0.09151086f, 0.00774427f, 0.03421680f, 0.16546930f, 0.04257569f, 
    -0.01732207f, 0.11588489f, -0.00998717f, -0.24817504f, -0.09657199f, -0.12427293f, 0.07556467f, -0.13626391f, 
    -0.05599726f, 0.00226467f, -0.03147611f, 0.02797341f, -0.19336034f, 0.07818531f, -0.01433770f, -0.08305525f, 
    0.00008540f, -0.08248886f, 0.12209722f, 0.19909111f, 0.11078441f, -0.08631723f, 0.05322723f, 0.05589520f, 
    -0.02395825f, -0.05584378f, -0.06462334f, -0.00090875f, 0.09472869f, -0.08962499f, -0.17951982f, 0.12733434f, 
    0.09970155f, 0.04946360f, -0.01567484f, 0.04079285f, -0.14931263f, 0.15057534f, 0.00037186f, 0.13896887f, 
    -0.12215066f, -0.03772369f, -0.02980904f, -0.01078320f, 0.03496725f, 0.04600831f, 0.01162324f, 0.04470012f, 
    0.02412776f, -0.05831753f, -0.08485146f, 0.10646800f, 0.06286028f, 0.13046511f, 0.08091832f, 0.10206137f, 
    0.13143845f, 0.16063127f, 0.07522607f, 0.00687619f, -0.02016442f, -0.00253046f, -0.07717099f, 0.10607693f, 
    0.01004645f, 0.14995663f, -0.02806244f, 0.03881451f, 0.19876227f, -0.00742805f, 0.11283483f, 0.08905961f, 
    -0.42616236f, -0.01802636f, -0.14848033f, -0.11854076f, 0.15161216f, 0.06489474f, 0.00313402f, 0.15216000f, 
    0.10353699f, -0.02124159f, 0.04564421f, -0.03472043f, 0.08626966f, 0.15307744f, 0.09218126f, -0.04406046f, 
    -0.06718653f, 0.06845422f, -0.02462642f, 0.00507993f, 0.22981308f, -0.16152938f, -0.04599857f, -0.16138120f, 
    0.17286149f, -0.06484071f, -0.09544280f, -0.05766289f, -0.11877929f, -0.02124441f, 0.13167720f, -0.07243039f, 
    -0.12502575f, 0.05272586f, -0.08877640f, 0.02360508f, -0.10066081f, -0.17976004f, -0.05109155f, -0.09439266f, 
    0.06501611f, -0.00191536f, -0.00348935f, 0.01468187f, 0.01954056f, -0.02507181f, 0.16512877f, 0.05549810f, 
    0.00052048f, -0.07058340f, -0.00851725f, 0.09329166f, 0.19525763f, -0.12432059f, 0.07145648f, 0.09020153f, 
    0.05146579f, 0.00866454f, -0.02058270f, 0.09443570f, 0.26166600f, 0.14047399f, 0.12706952f, -0.10086519f, 
    0.11328817f, 0.01734760f, -0.04111491f, -0.03031864f, 0.02227283f, 0.18773393f, -0.03864861f, 0.17099442f, 
    0.38799283f, 0.12625510f, -0.00997846f, 0.04867919f, 0.01918739f, 0.02399334f, 0.01473741f, 0.13745351f, 
    0.04081987f, 0.05255813f, 0.00264942f, 0.08314940f, -0.09791876f, 0.10665187f, 0.08961700f, 0.21165520f, 
    0.02287215f, 0.00131812f, 0.04176971f, 0.07541209f, -0.07179605f, 0.02128341f, -0.07572708f, 0.03952031f, 
    0.21281047f, -0.04283425f, -0.10906841f, 0.03476479f, 0.11333258f, -0.00058047f, 0.01183861f, 0.10298540f, 
    -0.01117681f, 0.03003488f, -0.01119161f, 0.03199070f, -0.12644464f, 0.00373529f, -0.06434042f, 0.07192611f, 
    -0.02518635f, -0.08112802f, 0.06975227f, 0.02508705f, -0.00653221f, -0.01185889f, -0.01691414f, -0.03341440f, 
    0.11806381f, -0.01308024f, 0.04566463f, 0.11735310f, 0.03168480f, 0.05303353f, 0.09503722f, -0.03487647f, 
    -0.02475890f, -0.03876782f, 0.06548208f, 0.14111495f, -0.09807406f, 0.00444524f, -0.10375561f, -0.13511427f, 
    0.06630293f, -0.04854030f, -0.11350925f, -0.05435836f, 0.02031636f, 0.03460579f, -0.04386190f, -0.02112844f, 
    0.23889546f, -0.20549934f, -0.06826764f, 0.10304904f, -0.00043273f, 0.06185563f, 0.13418548f, 0.01413566f, 
    0.03072157f, 0.03317754f, 0.05747414f, 0.03417444f, 0.07376117f, -0.03120570f, -0.03502277f, -0.09264527f, 
    -0.16589840f, 0.13670176f, -0.09199094f, -0.12002914f, -0.03112053f, 0.05954994f, -0.01993274f, -0.05955989f, 
    0.06210193f, -0.07797910f, 0.06939240f, -0.07254529f, 0.07120233f, 0.01159256f, 0.09075254f, -0.00601250f, 
    0.08764187f, 0.04061753f, -0.04373210f, 0.00743425f, -0.09002653f, -0.17800774f, -0.11831637f, -0.14442827f, 
    -0.08961382f, -0.07468901f, 0.03326816f, 0.14283845f, -0.01719197f, 0.11628340f, 0.00654790f, 0.16069746f, 
    0.20489545f, -0.07099145f, -0.08061096f, -0.13791627f, -0.01568809f, -0.14637904f, -0.06093577f, -0.08642053f, 
    0.01041740f, -0.10276136f, -0.04034195f, -0.17215672f, 0.49163228f, 0.09394483f, -0.22490366f, -0.20121801f, 
    0.04813325f, -0.23217602f, -0.04549703f, 0.09810494f, -0.05671135f, -0.05941876f, 0.05870531f, 0.11778290f, 
    -0.00198531f, -0.33759579f, -0.02736367f, -0.05580118f, 0.01821155f, -0.04212328f, 0.10844656f, -0.01747434f, 
    0.05079300f, -0.08710455f, 0.01270650f, 0.09278729f, -0.11966428f, -0.04303969f, -0.17133763f, 0.00562843f, 
    -0.08787188f, -0.03622079f, -0.05775840f, 0.12569746f, 0.07087277f, -0.03383233f, -0.12489527f, 0.05075181f, 
    0.04446860f, -0.03203197f, -0.08658659f, 0.18160647f, 0.02143804f, 0.13140476f, 0.09722564f, -0.00996856f, 
    -0.07154877f, 0.19648476f, -0.10518287f, -0.09369598f, -0.15954146f, 0.09578861f, -0.06103686f, -0.10824908f, 
    -0.08621036f, -0.04838613f, -0.03888027f, -0.17530319f, 0.05293182f, -0.03884511f, 0.06699705f, -0.09215823f, 
    0.01895546f, 0.03364997f, 0.01673423f, -0.04278619f, 0.02503598f, 0.02026397f, -0.03435061f, 0.02079805f, 
    -0.01100271f, 0.01606722f, -0.00624546f, 0.02874409f, 0.02383980f, -0.04110121f, 0.02584925f, 0.04079983f, 
    0.03313072f, -0.03292612f, -0.04396126f, 0.03410874f, -0.01335814f, 0.00456029f, 0.01961393f, -0.04672467f, 
    -0.05636040f, 0.01017199f, -0.02043870f, 0.03250383f, -0.04789599f, -0.04985124f, -0.04679451f, 0.03420243f, 
    0.00859594f, 0.01872529f, 0.04737676f, 0.02197741f, 0.02963489f, -0.05177365f, 0.01425682f, -0.04789206f, 
    -0.02439791f, -0.02556001f, 0.00175518f, 0.02931874f, 0.01865410f, 0.01147911f, 0.01329853f, -0.00692519f, 
    -0.04078940f, -0.04063256f, -0.01529643f, 0.00582805f, -0.04268636f, 0.04593293f, 0.02049129f, 0.02772844f, 
    -0.04344666f, 0.03258093f, 0.02763526f, -0.03801896f, 0.00194366f, 0.02960565f, -0.00345479f, -0.00518686f, 
    0.01717072f, -0.05222921f, -0.02444649f, -0.01972723f, -0.01767543f, -0.00867770f, -0.03293029f, 0.00781668f, 
    -0.00796710f, -0.05030640f, 0.01298240f, -0.01266233f, -0.04862339f, -0.01225362f, -0.02038806f, -0.02596420f, 
    0.00968830f, -0.01313125f, -0.00787242f, 0.03528366f, -0.01503519f, 0.02603411f, 0.04338808f, -0.06272130f, 
    -0.05111275f, -0.02282469f, -0.00316831f, -0.02260531f, -0.02714680f, 0.00999615f, 0.04403523f, 0.04018727f, 
    -0.03782567f, 0.00327307f, -0.00345628f, 0.00446561f, 0.00202152f, -0.01798059f, -0.03308621f, 0.00834331f, 
    -0.03222194f, -0.03885702f, -0.01971200f, 0.02280020f, 0.03593671f, 0.02005461f, -0.03605853f, -0.04520658f, 
    -0.04834833f, 0.01575655f, -0.04785896f, -0.01202982f, -0.04508842f, -0.03112565f, -0.01240498f, 0.00354575f, 
    -0.04549464f, 0.03041666f, 0.03073333f, 0.06089655f, -0.04438462f, 0.03546190f, -0.02684604f, -0.01728631f, 
    0.01484371f, -0.01882236f, -0.04261044f, 0.03002156f, 0.03277582f, -0.03477607f, 0.01075259f, 0.00908780f, 
    0.04692635f, -0.02185515f, -0.00962777f, 0.03659084f, 0.03010094f, -0.01206393f, 0.03550251f, 0.00830469f, 
    0.02278817f, -0.00718612f, 0.04989761f, -0.01593108f, -0.05477114f, 0.00601819f, -0.03723833f, 0.01538871f, 
    0.00580553f, -0.00588576f, 0.01661187f, 0.02398649f, -0.05178111f, -0.01338763f, 0.00363548f, -0.02012789f, 
    -0.02062118f, -0.04432588f, -0.04417585f, 0.04009429f, -0.00517269f, 0.03438450f, -0.00934865f, -0.04309743f, 
    0.01194873f, -0.00849841f, -0.02587882f, 0.04624923f, 0.00491806f, -0.01474972f, 0.01017981f, -0.03104077f, 
    0.04192599f, -0.02135728f, 0.01391607f, 0.01684922f, -0.01499422f, -0.05470306f, 0.00426780f, 0.01249247f, 
    -0.01496346f, 0.02528278f, 0.02225222f, 0.03054036f, -0.03348126f, -0.00915937f, -0.00829160f, 0.01531647f, 
    -0.04793172f, 0.00272128f, -0.03592742f, 0.00658753f, 0.00467748f, 0.00172437f, -0.00818329f, -0.02104005f, 
    0.01827724f, -0.00393344f, -0.00703282f, 0.01579382f, -0.04090193f, 0.01268980f, -0.02103108f, -0.04514629f, 
    -0.03887116f, -0.04752310f, -0.05107499f, -0.02680492f, -0.03441664f, 0.00716325f, -0.03357245f, -0.05321025f, 
    0.02621616f, 0.00961871f, 0.02424222f, 0.01037879f, 0.00133508f, -0.02723504f, 0.02602115f, -0.03431562f, 
    -0.01677220f, 0.02087357f, 0.02076369f, 0.03372683f, 0.02700193f, 0.02415485f, 0.00573896f, -0.01574635f, 
    -0.01789716f, -0.02841133f, -0.02482752f, -0.04675769f, 0.01417615f, 0.04632386f, 0.02912666f, 0.01722659f, 
    0.03933449f, 0.03765152f, -0.04433879f, 0.02210192f, 0.03927362f, -0.02045520f, -0.00879629f, -0.01080548f, 
    -0.03016561f, 0.02846082f, -0.01843714f, -0.04337581f, 0.01897362f, 0.03714098f, 0.02641801f, 0.01965139f, 
    0.00664357f, -0.03242359f, -0.05458663f, 0.02792077f, -0.04334151f, -0.06067419f, 0.02412125f, -0.02922893f, 
    -0.02593700f, 0.00233119f, 0.00644466f, -0.04200117f, -0.01717796f, -0.03277217f, -0.00913111f, -0.02726471f, 
    -0.02973621f, -0.03943038f, 0.00994835f, 0.02458909f, -0.03507992f, -0.03231750f, 0.03330110f, 0.03150067f, 
    -0.04466882f, -0.00613829f, -0.00617853f, 0.01779167f, -0.02553749f, 0.00546868f, -0.04983503f, 0.03853997f, 
    -0.05781339f, 0.02353490f, -0.04145452f, 0.03270501f, -0.05118276f, -0.00027408f, 0.00662945f, -0.03931116f, 
    -0.01927672f, 0.03785891f, -0.04863035f, -0.04414980f, -0.01596737f, 0.04670753f, -0.02894736f, 0.01738130f, 
    -0.05256271f, 0.03932107f, 0.00492917f, -0.01851162f, -0.05788106f, -0.02886153f, 0.01224302f, -0.01824066f, 
    -0.01124950f, -0.03035552f, -0.00117033f, 0.01669678f, 0.03180454f, 0.03087465f, 0.03214263f, -0.04196659f, 
    0.00989365f, 0.01151291f, -0.03613721f, -0.04966394f, 0.01069455f, -0.01940944f, 0.01178342f, 0.06271265f, 
    0.03547278f, -0.03724848f, -0.03419594f, -0.04660944f, 0.00452894f, -0.04385348f, -0.00992868f, -0.00832838f, 
    0.01544649f, -0.03921690f, -0.03605680f, 0.04376768f, 0.02733140f, 0.01316885f, -0.02970852f, -0.02526061f, 
    0.01468288f, -0.00883789f, 0.03635136f, -0.01718808f, -0.00960884f, 0.04377074f, 0.02455373f, 0.03386866f, 
    -0.03151353f, 0.00618982f, -0.03907353f, -0.00615231f, 0.01668185f, 0.01895306f, -0.01701013f, 0.01974618f, 
    0.01939327f, 0.01630128f, -0.00660566f, -0.01369976f, -0.02505101f, -0.00596501f, 0.01877620f, -0.03450101f, 
    0.01010640f, -0.05202779f, -0.01528771f, -0.05378728f, 0.02899314f, 0.00569954f, 0.01345276f, -0.01764930f, 
    0.00295663f, 0.02504429f, -0.01523262f, -0.04016860f, 0.02955314f, -0.02371890f, -0.01435641f, 0.04281445f, 
    -0.04300068f, 0.04078687f, 0.03111825f, -0.01960480f, -0.02211982f, 0.02435846f, 0.02777955f, 0.03827559f, 
    -0.04183217f, -0.03050424f, 0.00350515f, -0.03957985f, -0.04490427f, 0.03026831f, -0.05153774f, -0.04697544f, 
    -0.00998076f, -0.00052906f, 0.03750144f, 0.03308800f, 0.01921402f, 0.00746728f, 0.03069411f, -0.03729471f, 
    0.02694692f, 0.03541164f, 0.03365185f, 0.01445037f, 0.03714730f, -0.03965245f, -0.03085540f, -0.02514173f, 
    -0.03656052f, -0.01605332f, 0.02808998f, 0.03756133f, -0.00750522f, 0.00940521f, 0.04054615f, -0.01301293f, 
    0.03854771f, -0.03329884f, 0.01846409f, 0.03092130f, -0.02932776f, -0.01182929f, -0.04096864f, -0.00859341f, 
    -0.04639152f, 0.01173541f, -0.02841149f, 0.03038758f, 0.00297852f, 0.03330532f, -0.05134793f, -0.03907374f, 
    -0.04742963f, -0.00837639f, -0.05756584f, 0.02746228f, 0.02943083f, 0.02844370f, -0.01971689f, -0.03126055f, 
    0.02936455f, -0.01085413f, 0.03019851f, 0.03794185f, -0.01198734f, 0.00299869f, 0.02288951f, 0.01966148f, 
    0.01839543f, -0.02677198f, -0.04681845f, -0.01246531f, -0.00755704f, 0.03523802f, 0.01130848f, -0.01740880f, 
    -0.01631738f, -0.01740992f, 0.01403349f, 0.00932348f, 0.00773925f, 0.03943434f, -0.01743256f, -0.02320801f, 
    -0.02387844f, 0.00399454f, 0.00000809f, 0.00108430f, -0.03371146f, 0.03749173f, -0.04569048f, -0.05098849f, 
    0.01942980f, 0.03978304f, -0.01881645f, 0.02004675f, 0.04405796f, 0.02413989f, -0.03148234f, -0.01935378f, 
    0.03184593f, -0.02010451f, 0.01405562f, 0.02923742f, -0.03813852f, 0.01959160f, 0.03799521f, -0.02963649f, 
    0.03924144f, -0.02454811f, -0.04089277f, -0.00878153f, 0.03979727f, -0.00472417f, -0.00907710f, -0.03577286f, 
    -0.03876426f, 0.03194878f, 0.01535409f, 0.00775823f, -0.01735303f, -0.02787348f, -0.04010123f, 0.00910212f, 
    -0.04669654f, -0.03896438f, 0.00168312f, 0.03722574f, -0.02734708f, 0.00220488f, -0.01672748f, -0.02859592f, 
    -0.03454718f, 0.04042444f, 0.03156535f, -0.03706833f, -0.04624432f, -0.05809909f, 0.01424138f, -0.05517231f, 
    0.04152596f, -0.03083278f, -0.01700182f, 0.00519777f, -0.03718353f, 0.00216952f, 0.00904743f, 0.01672357f, 
    0.02460481f, -0.00568743f, 0.00723497f, -0.00694933f, 0.00686195f, -0.00368844f, -0.04486117f, 0.01283557f, 
    0.01091940f, -0.05269483f, -0.01859479f, -0.02022798f, -0.02587127f, -0.00315677f, -0.00191177f, 0.03119664f, 
    -0.02384987f, -0.00851861f, 0.00378900f, -0.05466352f, 0.02748728f, 0.03488666f, 0.00736349f, -0.00630601f, 
    0.00098836f, -0.04153765f, 0.01678310f, 0.00380587f, 0.00005834f, 0.02288723f, -0.05553490f, 0.03799647f, 
    -0.00208037f, -0.02241444f, -0.02404603f, -0.00857090f, 0.03304261f, -0.02951891f, 0.03264264f, -0.04531787f, 
    -0.02348160f, 0.00580338f, 0.03886716f, 0.00295288f, 0.01196209f, -0.03214051f, 0.02966192f, -0.00436544f, 
    -0.04388120f, -0.02150370f, -0.05053084f, 0.03205663f, 0.02990646f, 0.02934944f, -0.04202081f, -0.04039014f, 
    0.00355949f, 0.02330158f, 0.00391631f, 0.03432905f, -0.03480830f, 0.00178502f, 0.00502795f, 0.01480315f, 
    -0.02857132f, -0.03041960f, -0.02731881f, -0.01918419f, -0.00152946f, -0.02407091f, -0.04094091f, 0.04209033f, 
    0.01582322f, 0.00293639f, 0.02264472f, -0.03020902f, -0.00537377f, -0.01363628f, -0.05354084f, -0.00539885f, 
    0.03304954f, -0.01006899f, -0.01531899f, -0.01098499f, 0.01807511f, 0.02648225f, 0.01294599f, -0.00062312f, 
    -0.04819042f, -0.00265207f, -0.00775108f, -0.02203516f, -0.00783609f, -0.03826169f, -0.01228940f, 0.00265195f, 
    0.01694793f, -0.04512698f, -0.01400050f, 0.01611275f, 0.00022631f, -0.01138511f, 0.02744053f, 0.02087462f, 
    0.01777224f, -0.01100307f, 0.01637981f, -0.01830042f, -0.05434571f, -0.00592698f, -0.00312426f, 0.01673241f, 
    -0.00765196f, -0.04879714f, -0.05058818f, 0.01147317f, 0.01123801f, 0.00001735f, -0.03580910f, 0.00613776f, 
    -0.02006800f, -0.03956006f, -0.02018392f, -0.02079165f, 0.02896841f, 0.02461183f, -0.03379724f, -0.03970550f, 
    -0.05201432f, -0.01446354f, 0.03948690f, -0.01020381f, -0.04913745f, -0.00204495f, -0.00315005f, -0.01890691f, 
    -0.00567908f, -0.04410257f, 0.00499356f, -0.04893030f, -0.01051571f, -0.00811500f, 0.01855076f, -0.02647488f, 
    -0.00644908f, -0.00829861f, 0.04426943f, 0.02299125f, -0.02809065f, 0.02682358f, -0.03912879f, 0.02245778f, 
    -0.05415685f, -0.03457063f, -0.05531677f, 0.01035112f, 0.04135266f, -0.02842581f, 0.01531425f, -0.00823024f, 
    -0.00221831f, -0.00713872f, -0.04428237f, 0.02293975f, -0.01610228f, -0.04313457f, 0.03491289f, -0.02922055f, 
    -0.02643210f, -0.03854107f, -0.04482001f, -0.04983675f, 0.01318059f, -0.03495713f, -0.03237214f, -0.05895861f, 
    0.00565903f, -0.02113910f, -0.01027939f, 0.00957412f, -0.05134425f, 0.00825325f, -0.00309613f, -0.00107772f, 
    -0.00060064f, 0.02077888f, -0.02983145f, 0.00314240f, 0.02228393f, 0.03751293f, 0.02289194f, -0.05344126f, 
    0.03564229f, 0.00323460f, 0.03188645f, -0.00368928f, 0.01504463f, 0.00672960f, -0.00083634f, 0.03236569f, 
    -0.00382942f, 0.03251048f, -0.02119078f, 0.02782273f, -0.02145471f, 0.04098934f, -0.05417122f, 0.03036818f, 
    0.01472842f, 0.04552494f, 0.04145643f, -0.01162705f, 0.01626733f, 0.01332587f, 0.02688556f, 0.03979994f, 
    -0.00577547f, 0.03743731f, 0.01124611f, -0.00454523f, -0.03674625f, -0.03598024f, 0.00806472f, 0.02933461f, 
    -0.02702448f, -0.05131706f, 0.03784231f, -0.04902048f, -0.03825141f, -0.05203912f, -0.04119613f, 0.00240894f, 
    0.23206912f, -0.32822627f, 0.22807617f, -0.00207165f, 0.02371418f, -0.06440986f, 0.06220045f, 0.00206762f, 
    -0.11202896f, -0.01622662f, -0.00378450f, 0.09244670f, 0.09695616f, 0.14963740f, 0.00576919f, -0.14533575f, 
    0.02421176f, 0.06055515f, -0.00055336f, -0.06557065f, 0.10607811f, 0.01185178f, 0.17993788f, -0.09015965f, 
    -0.10813071f, 0.05474443f, -0.01835856f, 0.05299329f, 0.02937853f, 0.04894731f, 0.08262786f, 0.09744570f, 
    0.08341395f, 0.05514678f, 0.14060333f, -0.04191062f, 0.08895373f, -0.13127971f, -0.04013951f, -0.12280620f, 
    0.08799875f, -0.02972316f, 0.05804214f, 0.02789478f, -0.04480114f, -0.00093257f, 0.02071306f, 0.02463352f, 
    -0.15040608f, -0.09440310f, -0.02239296f, 0.16680886f, 0.09912914f, 0.03027882f, 0.03832892f, 0.08962670f, 
    -0.00882205f, 0.11368483f, 0.08030409f, 0.09399264f, -0.39067885f, -0.09311968f, 0.01054872f, 0.05316623f, 
    0.12401042f, -0.01106810f, -0.00419633f, -0.02521580f, 0.09732885f, 0.10696417f, 0.13713613f, 0.05914930f, 
    0.12024279f, -0.09783807f, 0.07899581f, 0.16623373f, 0.07865449f, -0.04240052f, 0.00941541f, 0.03151018f, 
    -0.08187167f, 0.00350509f, -0.14901729f, 0.02867706f, 0.52526015f, -0.04564360f, 0.31680298f, 0.34306806f, 
    0.09426809f, 0.01620078f, -0.00881488f, -0.09333961f, -0.02700620f, -0.04290028f, -0.03735106f, 0.08025468f, 
    -0.29733440f, 0.34256229f, -0.06631777f, -0.13064493f, 0.09220736f, 0.03294820f, -0.04398580f, 0.01942248f, 
    0.04084707f, -0.02163162f, -0.15981510f, -0.13586967f, -0.11060224f, -0.15369287f, 0.16349560f, 0.27356893f, 
    -0.05952886f, 0.01249960f, -0.13436930f, 0.01754220f, -0.03283035f, 0.02847235f, -0.01490082f, 0.22790216f, 
    0.03371334f, 0.06780422f, 0.15777086f, -0.11583108f, -0.02115357f, 0.02912022f, 0.03911017f, 0.07122885f, 
    0.10133929f, 0.16995707f, 0.06087314f, 0.03747337f, -0.02805910f, 0.08953498f, 0.04419420f, 0.08217820f, 
    0.10152836f, -0.00479657f, -0.04302945f, -0.08699325f, 0.13828003f, -0.14722481f, -0.09490474f, 0.02816122f, 
    -0.21093258f, 0.13379517f, -0.01510266f, 0.30251449f, -0.02488229f, 0.16863436f, -0.03067662f, 0.00388196f, 
    -0.00179225f, -0.02893698f, 0.07456662f, 0.00642814f, 0.07385092f, 0.12006813f, 0.17275603f, 0.25553602f, 
    -0.09575830f, -0.01393738f, -0.02556187f, 0.16035508f, -0.08445875f, -0.07306539f, 0.30241343f, -0.02223207f, 
    -0.28637916f, 0.17503411f, 0.01932453f, -0.07928448f, 0.02086741f, -0.09212296f, 0.07530245f, -0.13636222f, 
    0.07490644f, 0.14222141f, 0.02241981f, 0.13240592f, -0.26765263f, 0.06377234f, 0.24129745f, 0.04617025f, 
    0.04771824f, 0.19009371f, -0.05229810f, 0.01987935f, 0.03695279f, 0.02921303f, -0.01528338f, -0.12448241f, 
    -0.14131589f, 0.03054130f, 0.08552852f, -0.14360151f, -0.07349914f, 0.11362059f, 0.00565830f, -0.05386264f, 
    0.02435627f, -0.03425620f, -0.09343895f, 0.01689671f, -0.02843227f, -0.04209720f, 0.28808171f, -0.01552457f, 
    0.07950656f, -0.05238576f, 0.08737247f, 0.00223077f, 0.11966622f, 0.00479837f, -0.05396961f, -0.06192910f, 
    -0.18294926f, -0.07701893f, 0.04261561f, 0.09286252f, 0.19033644f, -0.03713949f, -0.13264887f, 0.04035506f, 
    0.11211175f, -0.02332452f, 0.03677615f, 0.03642557f, -0.07022245f, 0.27405444f, -0.23473886f, 0.31605136f, 
    -0.04988741f, -0.01999044f, 0.08251989f, 0.16439651f, 0.16082337f, 0.15371850f, -0.14938472f, -0.05472293f, 
    -0.47987488f, -0.06394701f, 0.12792009f, 0.05767380f, 0.03853530f, 0.08016412f, 0.07823169f, -0.05554157f, 
    -0.11416660f, -0.10354897f, 0.05725830f, -0.02498697f, -0.21139954f, 0.26679817f, -0.04467119f, -0.22492662f, 
    0.03804309f, 0.02781717f, 0.02730155f, 0.02393110f, -0.08597578f, -0.18288253f, -0.05809507f, -0.07711569f, 
    -0.01890762f, 0.07889317f, 0.09380598f, 0.17138495f, 0.06773221f, 0.03433787f, -0.00460363f, -0.16889448f, 
    0.01499012f, -0.15262468f, -0.02845442f, -0.15054990f, 0.18866074f, -0.17680514f, -0.07752786f, 0.11524619f, 
    -0.03692920f, 0.08653008f, -0.15684998f, -0.01611621f, -0.14370219f, -0.08674861f, -0.04486966f, 0.00137475f, 
    0.29797500f, -0.09013938f, 0.06136409f, 0.09304064f, -0.05445699f, -0.03407639f, 0.11875749f, -0.15796584f, 
    -0.05929124f, -0.07499024f, 0.06561540f, -0.04230507f, -0.15593584f, 0.20710789f, -0.09850403f, -0.05681923f, 
    0.02838875f, -0.07215703f, 0.04924761f, 0.01885439f, 0.10846981f, 0.07833318f, -0.06984405f, 0.04243644f, 
    -0.12059268f, -0.02227773f, -0.02295304f, 0.05922918f, 0.04979826f, -0.08554706f, 0.03525964f, -0.00201238f, 
    0.03625934f, 0.08076629f, 0.06302962f, -0.09228064f, 0.00016666f, 0.05833713f, 0.02686752f, -0.18214425f, 
    0.09858574f, -0.05097907f, 0.01299628f, 0.07005782f, 0.04554095f, 0.05645425f, 0.16620860f, 0.18987526f, 
    -0.14256333f, 0.27167860f, -0.06436385f, -0.19020636f, 0.17559779f, -0.03917186f, 0.04674770f, 0.00816641f, 
    -0.02736100f, -0.17654227f, -0.11538142f, 0.04599778f, -0.16807605f, 0.35316259f, 0.07098892f, -0.16799606f, 
    -0.02373644f, 0.13160901f, 0.21734132f, 0.04871849f, -0.04048053f, 0.03226994f, -0.02604609f, 0.02327901f, 
    -0.18690743f, 0.12792009f, 0.13216195f, 0.24327840f, 0.04242805f, 0.07462371f, 0.02313789f, 0.04531121f, 
    -0.04519860f, 0.26798549f, 0.03127968f, 0.11835707f, -0.14595120f, -0.16701764f, 0.04114620f, 0.24529894f, 
    0.08948676f, 0.00476675f, 0.01184369f, -0.00675255f, -0.15648596f, 0.05636132f, 0.17503318f, 0.13312618f, 
    0.00164958f, 0.01161598f, -0.03952410f, 0.02382812f, -0.02533154f, 0.04483846f, -0.04144430f, -0.01125618f, 
    -0.04742476f, 0.03755792f, -0.01828573f, -0.00090547f, 0.03418664f, 0.03197727f, -0.02035114f, 0.03805676f, 
    0.02423432f, 0.02172472f, 0.03475833f, -0.02223271f, 0.00144873f, 0.04101462f, -0.04457674f, 0.03124430f, 
    0.02382756f, -0.04936902f, -0.04448406f, -0.02499484f, -0.01260726f, -0.02389182f, 0.02151225f, -0.00912338f, 
    0.01613224f, -0.01538078f, -0.00654874f, -0.03987934f, -0.03783730f, -0.00003839f, -0.00379446f, 0.02195382f, 
    -0.01279604f, -0.01778452f, 0.03603071f, -0.05628628f, -0.01157090f, -0.03473006f, -0.01689283f, -0.01555257f, 
    -0.02356211f, -0.04269180f, -0.01870760f, -0.00328117f, -0.03168228f, -0.06368268f, -0.06263588f, -0.01862031f, 
    -0.01269290f, 0.00117039f, -0.02591443f, -0.06003530f, 0.04294148f, -0.05074708f, 0.03054127f, -0.04839458f, 
    -0.05620176f, -0.03652592f, 0.01068457f, 0.03709797f, -0.01943327f, 0.03261959f, 0.02048945f, -0.03301542f, 
    0.01785322f, 0.02006079f, -0.01099381f, -0.03825748f, -0.00918298f, -0.04670843f, -0.03007921f, 0.04669147f, 
    0.04434313f, -0.01510054f, 0.00389012f, -0.00364048f, -0.00039808f, -0.01645732f, -0.03423207f, 0.00812545f, 
    0.01335380f, 0.02939075f, -0.01353019f, -0.03797908f, -0.00438538f, -0.02937552f, -0.04595951f, -0.00137502f, 
    0.02441970f, -0.03991698f, -0.00631508f, 0.00973616f, -0.00281179f, 0.02621469f, 0.00316961f, 0.03871698f, 
    0.00038912f, 0.01632584f, 0.01750485f, 0.01180093f, 0.00156599f, -0.03422459f, -0.04713600f, -0.01407993f, 
    -0.03134614f, -0.00192409f, 0.03328232f, 0.03340979f, 0.00210906f, 0.00057831f, 0.01916608f, 0.03469726f, 
    -0.03584415f, -0.01045158f, -0.01068791f, -0.00026871f, 0.00937861f, -0.00067128f, -0.03833317f, -0.05866465f, 
    -0.05676535f, 0.00712599f, -0.02589242f, -0.05325228f, -0.03424629f, 0.03600231f, -0.06241899f, 0.01312155f, 
    -0.02457109f, 0.03821824f, -0.03737446f, 0.03135278f, -0.00308739f, -0.04546192f, -0.04959244f, -0.02916174f, 
    -0.03762565f, -0.03307366f, -0.04830137f, -0.01164766f, 0.02095152f, -0.01725720f, -0.01885326f, -0.01186160f, 
    0.04543143f, 0.00426521f, 0.00033720f, -0.03663010f, 0.03515843f, -0.02551609f, 0.02552577f, 0.02387595f, 
    -0.03985136f, 0.03439790f, 0.01481437f, 0.01406078f, -0.00964055f, -0.03908803f, 0.01116985f, 0.03934238f, 
    0.02937744f, -0.01430727f, -0.03149647f, -0.00853392f, -0.02760333f, -0.04812983f, -0.00589297f, 0.01000006f, 
    0.03237916f, -0.05426421f, 0.02612559f, 0.00881053f, -0.04254707f, 0.03665152f, 0.03642315f, 0.02947273f, 
    -0.02811427f, 0.02977424f, 0.02070561f, -0.00857677f, 0.05171729f, -0.01110464f, -0.03387604f, 0.04589360f, 
    -0.02557075f, -0.05709744f, 0.03452244f, 0.00101059f, 0.02119728f, 0.02076423f, -0.03724035f, 0.03245938f, 
    -0.02817341f, 0.03591593f, 0.00490913f, -0.04907166f, -0.02779421f, -0.00913128f, -0.01295280f, -0.00549555f, 
    0.00535567f, -0.04982051f, 0.03065387f, 0.03807960f, -0.00196518f, 0.00435610f, 0.02288717f, 0.01159157f, 
    -0.02718738f, -0.02618086f, -0.04076412f, 0.03638602f, 0.00415601f, 0.00551671f, 0.02605938f, -0.01077832f, 
    -0.03433277f, 0.01964414f, 0.03108232f, 0.00355630f, 0.00245409f, -0.01347269f, -0.03979221f, -0.02773437f, 
    0.03007641f, 0.02888594f, 0.01201257f, 0.03331314f, -0.01774916f, 0.00819980f, 0.01110689f, 0.02256965f, 
    -0.04938775f, 0.02516608f, -0.01515243f, -0.03411714f, 0.00888882f, 0.01682731f, 0.01227107f, 0.03002168f, 
    0.00853468f, 0.03601209f, 0.00528098f, -0.04835839f, -0.03713142f, 0.03276299f, -0.03485747f, -0.06020791f, 
    0.00236364f, 0.02742390f, -0.03312908f, 0.00097536f, 0.02966282f, -0.03096435f, -0.01038902f, 0.01285005f, 
    -0.00945895f, 0.00323522f, 0.03802088f, 0.03438005f, -0.02998929f, 0.02225192f, -0.03932465f, 0.00726324f, 
    0.03238877f, -0.00536564f, 0.01696564f, -0.01540003f, 0.01102189f, 0.00839927f, -0.00563284f, 0.01062064f, 
    -0.04616582f, 0.01032360f, -0.02717847f, 0.04253336f, -0.01800065f, 0.04806755f, -0.01898384f, -0.04573119f, 
    -0.00472467f, -0.00093778f, 0.03240988f, 0.00716243f, 0.02353958f, 0.03380701f, -0.04134773f, -0.04091355f, 
    -0.03104309f, 0.00619424f, -0.01547588f, -0.02645786f, 0.01914113f, -0.00412455f, 0.02248148f, 0.00153275f, 
    0.00470682f, 0.03951688f, -0.00502596f, 0.01912951f, 0.03562468f, 0.04819543f, 0.04616804f, -0.04011397f, 
    0.03763954f, -0.04048133f, -0.05524956f, 0.00425648f, -0.05458404f, 0.03051534f, -0.05294578f, -0.02558648f, 
    0.02204611f, 0.01692434f, 0.01330842f, -0.00074976f, -0.01077872f, -0.00354243f, 0.02191846f, 0.02349286f, 
    -0.04609646f, -0.01535037f, -0.00556488f, -0.00272182f, 0.02733533f, -0.04587265f, -0.00492359f, -0.05126422f, 
    0.03523313f, -0.03641340f, -0.01693479f, -0.05448141f, -0.01641065f, 0.01286457f, -0.02517009f, -0.04437777f, 
    0.02015263f, -0.01935156f, -0.00300988f, -0.02307810f, -0.01735834f, 0.00271762f, -0.03674567f, -0.04114821f, 
    0.01726047f, 0.03688396f, 0.00348180f, -0.02966915f, -0.03237419f, 0.00455322f, 0.00762090f, -0.00992254f, 
    -0.05374769f, -0.04819762f, -0.05013604f, -0.03468203f, -0.00048259f, 0.02291309f, 0.00482777f, 0.02083190f, 
    -0.01791363f, 0.02089700f, -0.04562308f, 0.02548499f, -0.02406851f, -0.02381660f, -0.02636994f, -0.04250927f, 
    0.00215801f, 0.03968171f, -0.02624150f, -0.02400853f, 0.00022087f, -0.05579244f, 0.01799031f, -0.05137013f, 
    0.02688004f, 0.02255704f, -0.01541286f, -0.00041807f, -0.04284913f, -0.02102838f, 0.00049170f, -0.04126514f, 
    -0.01028659f, -0.02431599f, 0.01111172f, 0.01821467f, 0.02792381f, -0.00422394f, -0.01880148f, -0.05448889f, 
    -0.03155457f, -0.00765610f, 0.01624662f, 0.00056530f, -0.03242687f, 0.03052897f, 0.02569339f, -0.01789299f, 
    0.03793145f, -0.03442054f, 0.01955027f, -0.04714608f, -0.01770500f, -0.05494332f, 0.03847899f, -0.00087991f, 
    0.00804862f, -0.04097420f, -0.01999014f, -0.00655778f, 0.03019535f, 0.02082989f, -0.02767825f, 0.03071553f, 
    0.02552753f, -0.01303715f, 0.02307105f, -0.01561647f, -0.01209224f, -0.05769126f, 0.00448777f, 0.03386847f, 
    -0.01627932f, 0.05025737f, -0.04076845f, -0.00988354f, -0.04929352f, 0.01212294f, -0.05331394f, 0.04122704f, 
    -0.02251009f, -0.00803057f, -0.05035079f, -0.04312501f, -0.04145778f, 0.04258894f, 0.03642384f, -0.04287940f, 
    0.03505236f, -0.03632855f, -0.02239339f, -0.05636926f, -0.05106808f, 0.02789261f, -0.01704062f, 0.02971991f, 
    0.00689162f, 0.01522731f, -0.02926121f, 0.01553224f, 0.01455735f, 0.00151743f, -0.02608868f, -0.02728266f, 
    0.00910750f, -0.02299867f, 0.01594424f, -0.03954800f, 0.01374949f, 0.00216289f, -0.02017602f, -0.03868139f, 
    0.01764740f, 0.01957259f, 0.00171634f, -0.01477481f, 0.03192909f, 0.00833414f, -0.00225100f, -0.01188313f, 
    0.00978641f, 0.03766600f, 0.03584492f, -0.01916095f, 0.01988365f, -0.00606625f, -0.04030477f, 0.00841467f, 
    0.02249386f, 0.02715020f, 0.02945422f, -0.03574792f, 0.01670980f, 0.03168681f, 0.04915796f, -0.03874893f, 
    -0.05379124f, -0.00007041f, -0.03940493f, 0.04312979f, -0.01835350f, 0.02004503f, 0.02619611f, 0.03838536f, 
    -0.03317023f, -0.04153812f, 0.03755449f, -0.02796181f, 0.00164569f, -0.03019865f, -0.03213821f, -0.00650255f, 
    -0.02063590f, -0.03113061f, 0.01749112f, 0.03183470f, 0.00277688f, -0.01115519f, -0.03308633f, -0.03235079f, 
    0.00992190f, 0.03756103f, -0.00121375f, 0.00514016f, 0.02636891f, -0.04833876f, 0.03327395f, -0.00684450f, 
    -0.02756156f, 0.00431731f, -0.04904143f, 0.00670509f, 0.01394264f, -0.02956882f, -0.01053069f, 0.02029031f, 
    0.03254258f, 0.00657866f, -0.00590939f, 0.01195416f, 0.03529808f, 0.02364939f, -0.05313215f, 0.03800493f, 
    0.01416929f, -0.05442508f, -0.00780364f, 0.00729799f, -0.04001399f, -0.03108862f, -0.02316800f, -0.04805204f, 
    -0.00106526f, -0.02894805f, 0.04127261f, 0.03951780f, -0.01989557f, 0.04467700f, -0.02641465f, 0.04024588f, 
    -0.01742133f, -0.00385555f, -0.03070774f, 0.00979769f, -0.01568710f, -0.03507179f, 0.03351201f, 0.02997514f, 
    0.01166634f, -0.05787582f, -0.01077439f, -0.05174901f, -0.00996517f, -0.04651356f, -0.00792103f, 0.04507685f, 
    -0.03569501f, -0.03239838f, -0.03928800f, -0.04150188f, 0.00744471f, -0.03780292f, 0.01145301f, -0.03461277f, 
    0.02183208f, -0.01784667f, 0.00742340f, -0.00520936f, -0.00777649f, 0.00237921f, -0.01494263f, -0.03910344f, 
    0.02795915f, -0.04255825f, -0.01661492f, -0.01865386f, -0.03788570f, -0.01439273f, 0.00098240f, -0.02670559f, 
    -0.03470289f, 0.04122071f, 0.02150506f, -0.01430699f, 0.02852546f, -0.01477446f, -0.03636243f, 0.02946334f, 
    0.01653581f, -0.00105061f, 0.02435627f, -0.00521558f, -0.01751978f, 0.02494861f, 0.00999800f, 0.04436683f, 
    -0.00108432f, 0.04022497f, 0.01157326f, 0.02474636f, -0.05646038f, -0.01436460f, -0.05045329f, -0.05302653f, 
    0.00886312f, 0.04442378f, 0.01744302f, 0.02937273f, -0.01214732f, -0.04218273f, 0.04496228f, 0.00233632f, 
    -0.00953455f, -0.01051891f, -0.05062558f, -0.01442212f, -0.02513778f, 0.02362577f, -0.04294967f, 0.02820125f, 
    -0.01920391f, -0.00363588f, -0.00201042f, -0.04844280f, -0.00459504f, -0.02198429f, -0.00287825f, 0.01968537f, 
    -0.03127198f, 0.01951978f, -0.03022184f, -0.00392267f, -0.01093498f, -0.02212976f, 0.04141217f, -0.00064424f, 
    -0.03291748f, -0.00183687f, 0.01622240f, 0.01859994f, -0.04432791f, 0.04798664f, -0.05317841f, 0.03244714f, 
    0.02789091f, 0.03777865f, -0.00490631f, -0.04561726f, 0.03254802f, -0.02180694f, -0.02660184f, -0.03906985f, 
    -0.03649036f, 0.00084452f, 0.00154398f, -0.02854838f, -0.00364020f, -0.01194453f, -0.04488632f, -0.02716079f, 
    -0.01206383f, 0.03507567f, -0.00695084f, -0.02581343f, -0.03611034f, 0.03997836f, -0.04224899f, 0.02399214f, 
    0.02436630f, -0.04580414f, 0.04542701f, 0.01937419f, 0.01028175f, 0.03445984f, -0.04902784f, -0.03951233f, 
    0.00330989f, 0.01742658f, -0.01132279f, -0.04060039f, -0.05119973f, 0.02963243f, 0.03949995f, -0.04355303f, 
    0.02428775f, 0.02529703f, -0.00264425f, 0.03984430f, 0.02438721f, -0.05519439f, 0.01277585f, -0.03420955f, 
    -0.02292380f, -0.01807646f, -0.02467782f, 0.03810705f, -0.01974502f, -0.03539538f, 0.01818325f, 0.03516167f, 
    -0.00184158f, 0.01128526f, -0.03987517f, -0.05119959f, -0.03778376f, -0.00183827f, 0.04162198f, -0.04505352f, 
    -0.04401628f, 0.02619542f, -0.04246593f, -0.01231496f, 0.02100785f, 0.02834041f, 0.01216637f, 0.03387209f, 
    -0.04266228f, 0.00963196f, -0.00477781f, -0.01093210f, -0.02479820f, 0.01349828f, 0.03296855f, -0.02570123f, 
    -0.04344013f, -0.04295708f, -0.00944349f, -0.01180224f, 0.01883418f, 0.01438659f, 0.00186144f, 0.01909868f, 
    0.00470128f, -0.02196221f, 0.02826045f, -0.02386474f, -0.03880677f, -0.03823103f, 0.04281211f, -0.04085132f, 
    -0.04239265f, 0.02409402f, -0.02374736f, -0.05295249f, -0.05177777f, 0.01111560f, -0.01352514f, 0.02934133f, 
    0.03130548f, 0.01191804f, -0.01782075f, 0.03912148f, 0.00179083f, 0.02699486f, -0.02958389f, 0.00556929f, 
    0.02445701f, 0.02866292f, -0.01032988f, -0.00433736f, 0.04027100f, -0.04478751f, -0.01300501f, -0.02906364f, 
    -0.04531190f, -0.01754900f, -0.01766792f, -0.03120115f, -0.01904336f, -0.00013841f, -0.01536775f, -0.01929860f, 
    0.01741968f, -0.00654161f, -0.04680924f, 0.01831719f, -0.00373126f, -0.00481275f, -0.02131716f, -0.02382843f, 
    -0.00715445f, 0.02242796f, -0.03290544f, -0.02010662f, 0.03291925f, 0.04418341f, 0.02236291f, -0.00950060f, 
    0.03808348f, -0.01171872f, 0.01784686f, -0.00788525f, -0.01261015f, -0.00377441f, -0.00022116f, -0.05777391f, 
    0.01189137f, -0.03491701f, -0.03142819f, 0.01474853f, 0.02646286f, 0.02992860f, 0.00597644f, 0.03993902f, 
    0.01938675f, -0.03219402f, -0.04464518f, 0.03007175f, -0.03813057f, -0.03378449f, 0.02407729f, 0.01555264f, 
    -0.03319022f, -0.03754047f, 0.01332951f, -0.03986347f, 0.02863534f, 0.00293151f, 0.03026698f, -0.00489101f, 
    0.01698392f, 0.02566678f, -0.00429248f, -0.05428766f, 0.02183600f, -0.00493928f, 0.03392608f, 0.04158854f, 
    0.03409262f, -0.01586907f, 0.00725054f, -0.00639898f, 0.04705833f, 0.03570743f, 0.02614610f, 0.00080907f, 
    -0.01147683f, 0.03930998f, 0.00531604f, 0.03671287f, 0.03931171f, -0.04418721f, 0.01789751f, 0.02664783f, 
    -0.01824639f, -0.04015986f, -0.00676736f, -0.04947234f, -0.02064271f, 0.02065317f, 0.00711345f, 0.01153518f, 
    0.02954662f, -0.01191457f, -0.04503768f, 0.02240965f, 0.01196744f, -0.00207884f, -0.03257136f, 0.04048602f, 
    0.00819757f, 0.03614463f, 0.04387131f, -0.03419890f, -0.03337976f, -0.02913834f, -0.03355177f, 0.03463888f, 
    -0.02898617f, -0.03089938f, 0.00505842f, -0.00448810f, -0.00761541f, -0.01206680f, -0.03233264f, -0.04734094f, 
    0.03709463f, -0.05141379f, -0.05526520f, -0.00430015f, -0.00488315f, 0.02882847f, -0.02985863f, -0.03895006f, 
    -0.01917026f, -0.01978230f, 0.00698236f, 0.00471455f, -0.02763909f, -0.04035061f, -0.03341188f, -0.04946203f, 
    0.02013205f, 0.01304291f, -0.01847681f, 0.01788452f, -0.03091110f, -0.04882385f, -0.00912436f, -0.05018539f, 
    0.00162521f, -0.03707436f, 0.03220200f, 0.02328947f, -0.02374237f, -0.04574786f, -0.03813424f, 0.00376358f, 
    -0.01943643f, -0.03077738f, 0.00320827f, -0.01225217f, 0.04467669f, -0.02180872f, -0.03492499f, -0.03174543f, 
    -0.04631188f, -0.04380526f, 0.00713457f, -0.02332244f, -0.02885289f, -0.02194244f, -0.04846977f, 0.03977962f, 
    -0.04654759f, -0.03388418f, 0.04020405f, -0.04496551f, -0.01427086f, 0.02766640f, 0.00649370f, 0.00403955f, 
    -0.00812785f, 0.02330281f, -0.00477590f, 0.02194774f, -0.03036673f, -0.02375989f, 0.03972077f, 0.02173533f, 
    -0.05583426f, -0.02391602f, -0.03286318f, -0.03043583f, -0.05113214f, -0.04916594f, -0.04072665f, 0.00597988f, 
    0.00256908f, 0.04028329f, -0.05528214f, 0.01061449f, -0.03256799f, 0.01537107f, -0.04905431f, -0.04436740f, 
    -0.02146598f, -0.02771640f, 0.02142096f, -0.03990751f, 0.00154782f, -0.03612676f, -0.00827747f, -0.04701466f, 
    -0.02441438f, -0.04719487f, -0.04125287f, 0.00601484f, 0.00790498f, -0.02293139f, -0.05194823f, 0.02911073f, 
    -0.01660505f, -0.05293125f, -0.04059074f, -0.00985717f, 0.00974301f, 0.02840308f, -0.05524836f, -0.01333857f, 
    -0.04476601f, -0.02325444f, 0.03571694f, -0.04372595f, 0.02078015f, 0.01036474f, -0.00401278f, 0.03954657f, 
    0.04259478f, -0.03503503f, -0.01792191f, 0.03620609f, -0.03853787f, -0.03893129f, 0.02069327f, -0.04075802f, 
    -0.04545662f, -0.04003629f, -0.00131907f, -0.01945018f, 0.01174787f, 0.01716832f, 0.02144784f, -0.00507183f, 
    0.03666490f, 0.01994095f, 0.03371913f, -0.03717195f, -0.04618248f, 0.03741248f, -0.02146467f, -0.03677743f, 
    0.03833145f, 0.00239485f, 0.02665132f, -0.04628541f, 0.01503169f, 0.02873117f, 0.00978381f, 0.03458615f, 
    -0.04087654f, -0.03659025f, -0.01628873f, -0.04548541f, 0.03377130f, 0.03815726f, -0.00202621f, -0.04544506f, 
    0.00932396f, -0.03153224f, -0.01376020f, 0.04064469f, -0.03223341f, -0.04206870f, 0.03789434f, -0.00994126f, 
    0.02276410f, 0.01722155f, 0.01204194f, 0.00949755f, 0.02638018f, 0.00727900f, -0.02626559f, -0.00788547f, 
    -0.05357294f, -0.02702664f, -0.01042354f, 0.03023695f, -0.01354723f, -0.02621806f, -0.01609909f, -0.05367189f, 
    0.01958372f, -0.03860122f, -0.05753608f, -0.01083284f, -0.04421731f, -0.01726136f, 0.01055100f, -0.00819955f, 
    0.01395903f, -0.02318690f, -0.02389597f, -0.04665700f, -0.01795005f, 0.00699059f, 0.01284416f, -0.04791102f, 
    -0.02760861f, 0.01753604f, -0.00830196f, 0.01319235f, -0.01383913f, -0.02139601f, 0.02699671f, -0.00287383f, 
    -0.01935631f, 0.00474095f, 0.00064699f, -0.00067410f, -0.00165587f, 0.04525721f, -0.01655367f, -0.04267414f, 
    -0.05724459f, -0.02166465f, -0.02674869f, 0.00525751f, 0.04058124f, 0.02545455f, -0.04375528f, -0.04694548f, 
    -0.00090352f, 0.00230504f, 0.03097620f, -0.02032180f, 0.04370490f, -0.02679079f, -0.05543557f, 0.00320592f, 
    0.00091329f, -0.03976133f, 0.00375698f, 0.03760539f, -0.03920077f, 0.04471760f, -0.01384692f, 0.02305227f, 
    0.01585923f, -0.00621081f, -0.00896368f, -0.00967158f, -0.01034938f, -0.02939874f, 0.01964070f, 0.02210003f, 
    0.00465200f, 0.00077625f, -0.01515951f, 0.01325326f, 0.02982995f, 0.04403683f, 0.02695645f, -0.02501797f, 
    -0.01281611f, -0.02755097f, -0.05738981f, -0.01468519f, 0.02639685f, -0.00256060f, 0.03704549f, -0.03208699f, 
    -0.03804804f, -0.03565912f, -0.01480520f, -0.02003215f, -0.04611733f, -0.02565851f, 0.03133704f, -0.00563424f, 
    -0.02163606f, 0.01288472f, -0.03879540f, -0.04625640f, 0.03591669f, 0.04326932f, 0.02539549f, 0.02178830f, 
    0.02135808f, 0.04146052f, 0.02552761f, -0.02486902f, -0.03945546f, 0.04333374f, -0.04271267f, 0.00427592f, 
    -0.03608007f, -0.05047491f, -0.02208017f, 0.00167024f, 0.00366305f, -0.02353389f, -0.00273680f, -0.00762900f, 
    -0.01610152f, 0.04289221f, 0.02553428f, 0.00714292f, 0.03072133f, 0.00171251f, -0.02448874f, 0.03603038f, 
    -0.04999219f, -0.03743447f, -0.01111732f, -0.04500853f, -0.03048528f, -0.04748327f, 0.02729479f, -0.01373699f, 
    0.03787354f, 0.04622332f, -0.00928290f, -0.04626195f, -0.01682603f, 0.02085802f, 0.03658709f, -0.03090299f, 
    0.02704039f, -0.00558876f, -0.02185573f, -0.03043558f, 0.00816272f, 0.02134935f, 0.02359868f, -0.02689246f, 
    -0.00124009f, 0.01366303f, 0.03329875f, -0.05247203f, 0.04049905f, -0.05488097f, 0.04115101f, 0.03065457f, 
    -0.02164548f, 0.04338039f, -0.02701909f, 0.02750751f, -0.02254684f, -0.03372983f, -0.00242732f, 0.03692463f, 
    -0.04586123f, 0.04246137f, 0.04300270f, 0.00657807f, -0.00377989f, -0.02448382f, 0.00945450f, -0.03001292f, 
    0.01885571f, -0.03528087f, -0.01047904f, -0.03391533f, 0.00562818f, 0.03045163f, -0.04089146f, -0.02409207f, 
    -0.03326760f, -0.02728333f, -0.03049552f, 0.00115630f, 0.00517973f, 0.01552968f, 0.00840337f, 0.02988852f, 
    -0.00638183f, 0.02952859f, 0.04324578f, -0.01631022f, -0.05370539f, -0.03335882f, 0.01714186f, -0.02331437f, 
    0.00056527f, 0.00145411f, 0.01692019f, -0.03347370f, -0.00765678f, 0.02755432f, 0.01392629f, -0.03375621f, 
    0.01180264f, -0.01711414f, -0.04480931f, -0.01454776f, -0.02854156f, 0.00720957f, -0.02369905f, -0.04735696f, 
    -0.02509855f, 0.03771394f, 0.01269276f, -0.01658694f, -0.03720255f, 0.02954275f, -0.01161227f, 0.03399355f, 
    -0.02263168f, -0.05259479f, 0.00377058f, -0.03871586f, -0.04270070f, -0.04678277f, 0.02599175f, 0.03778065f, 
    -0.01603360f, -0.04879433f, 0.02544865f, -0.04344496f, -0.01559265f, -0.00519315f, 0.03057102f, 0.03927845f, 
    -0.03809894f, 0.01937068f, 0.03012665f, -0.01636998f, 0.01079800f, -0.00313158f, 0.03992609f, 0.04499657f, 
    -0.04162610f, 0.02932659f, -0.03983129f, -0.00138882f, -0.05038466f, -0.01449648f, -0.04869096f, -0.03190344f, 
    -0.03575983f, -0.00045921f, -0.04502736f, -0.05656116f, -0.03025514f, -0.03461588f, -0.03438740f, 0.03397617f, 
    -0.01328980f, -0.01023863f, 0.00018305f, -0.04992480f, 0.01282092f, 0.00655207f, 0.03097013f, -0.00207856f, 
    0.00332512f, 0.03634258f, -0.02128799f, 0.01251262f, 0.02986470f, 0.01763553f, -0.04279757f, -0.02129358f, 
    -0.03163699f, -0.02224083f, -0.03950921f, -0.04341487f, -0.00230696f, -0.00639714f, -0.00946176f, 0.02521869f, 
    0.04433968f, -0.04798530f, 0.02536599f, -0.02640729f, 0.02071934f, -0.05056138f, 0.00213097f, -0.04629074f, 
    0.01263134f, 0.00666983f, 0.04691200f, 0.03535838f, 0.00456604f, 0.04477241f, 0.03000273f, 0.01690589f, 
    -0.03708114f, -0.01255114f, -0.02850375f, -0.02012001f, -0.01037835f, 0.01970834f, -0.02195050f, 0.01724291f, 
    0.03094723f, -0.01810650f, 0.02160610f, -0.03044505f, -0.03709760f, -0.00467781f, -0.03837554f, 0.01868381f, 
    -0.00773685f, -0.01178489f, 0.04703708f, -0.00186865f, 0.01581985f, 0.00939402f, -0.05164284f, 0.03417717f, 
    -0.00633310f, 0.01113916f, 0.02155957f, -0.01729818f, -0.00800239f, 0.00532578f, 0.00369873f, 0.00996744f, 
    -0.03012028f, 0.03263039f, -0.03528881f, -0.04973441f, 0.04149771f, 0.03027826f, -0.02803764f, -0.02301585f, 
    0.04536036f, -0.00529388f, -0.03303328f, -0.01779482f, 0.00985270f, 0.01871035f, 0.00242765f, 0.04335166f, 
    -0.00096608f, 0.01932256f, -0.02351283f, -0.04146451f, 0.02280697f, 0.02397248f, 0.02476718f, 0.00275726f, 
    -0.00929548f, -0.00976190f, 0.01578099f, -0.01670747f, 0.02275580f, -0.04500275f, 0.02359732f, 0.01633607f, 
    -0.03329018f, 0.04429959f, -0.03505089f, 0.04097298f, 0.04511078f, -0.02134930f, -0.02983609f, 0.01814189f, 
    0.03148070f, -0.03244261f, -0.03790265f, 0.03829296f, -0.02727187f, -0.00404592f, -0.03289454f, -0.04183983f, 
    -0.02468018f, 0.01108351f, 0.02733278f, 0.01406673f, 0.04526591f, 0.02686928f, -0.04294773f, 0.03167745f, 
    -0.01616509f, 0.01986457f, -0.01993809f, 0.02452976f, -0.03278047f, 0.01911601f, 0.02166044f, -0.05303640f, 
    0.03664679f, -0.02504984f, 0.01645989f, -0.02125335f, -0.03971590f, 0.02416458f, 0.03931581f, -0.01747626f, 
    0.04339195f, 0.02036574f, 0.02832133f, -0.04155388f, -0.01339364f, -0.03118245f, -0.02157812f, 0.00254158f, 
    0.00777687f, -0.02376027f, -0.00361368f, -0.02924103f, -0.00413690f, -0.04969457f, -0.03400354f, 0.04499169f, 
    -0.02218651f, -0.05136073f, 0.02714268f, 0.00677593f, -0.02958480f, 0.02178566f, -0.02655202f, 0.00116865f, 
    -0.04767168f, 0.01898049f, -0.04069937f, -0.01624639f, 0.00895540f, -0.05226764f, -0.00925953f, -0.02381781f, 
    0.02452131f, 0.04382648f, -0.05506210f, -0.03025351f, 0.01604824f, -0.01322784f, -0.04380240f, -0.05116577f, 
    -0.05333604f, -0.00286180f, 0.03575516f, -0.02086045f, 0.03059501f, 0.00666301f, 0.03057151f, -0.05393200f, 
    0.03351551f, 0.01394020f, -0.02566884f, 0.03961951f, 0.02925742f, 0.04357155f, -0.04031431f, -0.01656641f, 
    0.01555931f, 0.03375167f, 0.00894902f, -0.00529042f, 0.02860584f, -0.00459494f, 0.01823566f, -0.05514170f, 
    -0.09191915f, 0.22567926f, 0.03903151f, -0.01346131f, 0.02937932f, 0.01071401f, 0.05544697f, 0.10361061f, 
    -0.01363402f, -0.02345525f, 0.00624310f, 0.02697317f, 0.27711022f, -0.31639123f, -0.10075248f, 0.13147892f, 
    0.02563884f, -0.04948850f, 0.07288877f, 0.06636476f, 0.16460608f, 0.04439101f, 0.05094474f, 0.12092818f, 
    0.14699490f, -0.04465644f, 0.09092226f, -0.14535536f, 0.13864538f, -0.06090793f, 0.02452063f, 0.06587242f, 
    0.06013135f, 0.07391811f, -0.11785219f, 0.06520417f, -0.21632618f, -0.00199109f, -0.10709361f, -0.09224386f, 
    -0.03385596f, 0.01752248f, -0.01740730f, 0.15233701f, 0.12583534f, 0.00359146f, -0.01934441f, -0.02292688f, 
    -0.04247908f, -0.06465953f, 0.08973154f, 0.01847831f, 0.03465915f, -0.05750747f, 0.04892742f, -0.15531693f, 
    -0.01324438f, 0.06176763f, -0.06827538f, 0.12570220f, -0.28894433f, 0.27706707f, -0.04414243f, -0.12298333f, 
    -0.04442983f, -0.17807530f, 0.11788340f, -0.04654920f, -0.04151599f, -0.08802985f, -0.07465369f, -0.02437528f, 
    0.00812461f, -0.18767346f, -0.07129910f, -0.08232132f, 0.03445020f, -0.00151187f, -0.03055298f, 0.04104389f, 
    0.07830562f, -0.07090847f, 0.14518094f, 0.03732266f, -0.38547540f, 0.16695641f, -0.09650782f, -0.01664652f, 
    -0.19233802f, -0.00479601f, -0.08373139f, -0.01410488f, 0.11942432f, 0.13481703f, 0.04202120f, -0.00897705f, 
    0.30192193f, -0.18227004f, -0.02282641f, 0.06439530f, 0.13232474f, 0.06411929f, 0.15781876f, 0.08105160f, 
    0.12493072f, 0.07990412f, -0.01585519f, 0.07579392f, 0.07079822f, 0.19036464f, -0.08709317f, -0.00920409f, 
    -0.05936045f, 0.26918045f, 0.14143342f, -0.01897303f, 0.01754721f, 0.04047952f, 0.05247570f, 0.08022071f, 
    0.06469105f, -0.05327074f, -0.03081638f, -0.04347847f, 0.00970187f, 0.06956887f, 0.09596368f, -0.06572237f, 
    -0.06790768f, 0.03727451f, -0.11088051f, 0.00062793f, 0.13863814f, 0.04938086f, -0.06536409f, 0.04569808f, 
    -0.05315701f, -0.03284398f, 0.02698557f, 0.08982127f, 0.02679339f, 0.07499930f, 0.17129391f, -0.01738094f, 
    0.15885195f, -0.08258748f, 0.20525277f, -0.05671471f, -0.07668816f, -0.06345812f, -0.04542105f, 0.03600289f, 
    0.00108285f, 0.03502693f, -0.03091727f, -0.02574554f, -0.05734790f, -0.23631470f, -0.06131957f, -0.08692412f, 
    0.11167574f, 0.03523256f, 0.07474261f, 0.01294112f, 0.09977598f, -0.03910597f, -0.00687208f, 0.02290240f, 
    -0.29373783f, 0.03939286f, -0.13143121f, 0.11091986f, 0.22523710f, 0.01655176f, -0.00370840f, 0.07059341f, 
    0.05943690f, -0.03213510f, 0.13743737f, 0.06893614f, 0.20139772f, 0.00034703f, 0.20575768f, -0.03125191f, 
    0.07005761f, -0.04234905f, -0.00666052f, -0.04862424f, 0.00876708f, -0.06182237f, 0.05059712f, 0.08315290f, 
    0.24446280f, -0.02957561f, 0.12177056f, 0.13979699f, 0.08452427f, 0.05461588f, 0.06770259f, 0.19342133f, 
    0.00387721f, -0.01488416f, 0.05731008f, 0.17441852f, -0.16409607f, 0.06898524f, 0.00394664f, -0.02040864f, 
    -0.01338666f, -0.04743239f, 0.00961529f, -0.05758100f, 0.09676321f, -0.00377441f, 0.06524939f, 0.15738147f, 
    0.07423910f, -0.06345247f, -0.12167714f, 0.05149057f, -0.00702935f, 0.13729903f, -0.01680386f, 0.05194307f, 
    0.16984914f, -0.00372075f, 0.03124108f, 0.01562590f, -0.16342740f, 0.03379925f, 0.05684497f, 0.00396235f, 
    0.01022870f, -0.06103837f, 0.04558001f, -0.04696445f, 0.00255012f, -0.03282411f, 0.04129785f, -0.01195908f, 
    0.29450396f, -0.00920683f, -0.03132040f, 0.00045595f, -0.02985820f, -0.06508677f, 0.17476420f, -0.03405263f, 
    -0.01297848f, -0.00173656f, -0.00874485f, -0.04907953f, -0.18918994f, -0.22237489f, 0.17393912f, 0.13523591f, 
    0.22551830f, 0.10855936f, 0.07813359f, 0.03691847f, 0.06806758f, -0.01812699f, 0.07528851f, 0.12453065f, 
    -0.00744433f, -0.18267721f, 0.04505404f, -0.07554390f, -0.01716520f, 0.01612029f, 0.01993669f, -0.11464198f, 
    -0.07648476f, 0.12648630f, 0.07843513f, 0.18469222f, -0.03978902f, -0.13376895f, 0.01714099f, -0.04849554f, 
    -0.05094061f, -0.05985370f, -0.05118664f, -0.00028910f, 0.07378288f, 0.08667093f, 0.08960627f, 0.07366198f, 
    0.12566984f, 0.23799622f, -0.02463670f, -0.09144336f, -0.04425614f, -0.00451977f, 0.03034402f, 0.04704776f, 
    0.09499124f, 0.01315483f, -0.01705568f, 0.05174555f, 0.00650283f, -0.12704025f, -0.07937746f, 0.05643895f, 
    0.00427227f, 0.11544622f, -0.04990919f, 0.03586696f, -0.01539872f, -0.02314496f, 0.12123264f, 0.08618931f, 
    0.15631405f, -0.11294211f, 0.00186254f, 0.04660850f, -0.01940317f, 0.04866695f, 0.08459831f, -0.01572035f, 
    0.07744476f, -0.01865008f, 0.03897986f, 0.09555255f, -0.22101036f, 0.22998096f, 0.02274271f, -0.01078645f, 
    0.13488153f, -0.04669328f, 0.02023587f, 0.03765819f, 0.04996696f, 0.05131227f, -0.08854479f, -0.04606598f, 
    -0.14057724f, 0.08275024f, 0.08855903f, 0.07149515f, 0.02630531f, 0.01170135f, 0.06450167f, 0.05209234f, 
    0.06002332f, 0.01526245f, -0.01122851f, 0.08419622f, 0.02975545f, -0.14960650f, 0.01348454f, 0.04047359f, 
    0.07999237f, 0.01927969f, -0.03169178f, 0.01882759f, -0.04296792f, 0.10877625f, 0.11126461f, 0.16735487f, 
    0.03974715f, -0.07190933f, -0.08246189f, -0.05404346f, 0.14343709f, -0.00072335f, -0.10669485f, 0.09355842f, 
    -0.07770620f, -0.03054440f, -0.14619094f, 0.14474081f, 0.05388055f, -0.09692746f, -0.09560630f, 0.03522813f, 
    -0.05130726f, -0.01924750f, -0.13034354f, -0.00248568f, -0.06434322f, -0.08163310f, -0.01736998f, -0.03273468f, 
    0.00796369f, 0.01465172f, -0.39282653f, 0.00503972f, 0.06982493f, 0.02357828f, -0.01939769f, 0.05693344f, 
    0.06687325f, 0.14136164f, 0.06470223f, -0.02289256f, -0.09764410f, 0.17921892f, 0.33054763f, 0.06878041f, 
    0.00349433f, -0.05608257f, 0.06818512f, 0.04071337f, -0.01908073f, -0.04838040f, -0.08746287f, 0.00541199f, 
    -0.06684531f, -0.03668498f, 0.06545434f, 0.08035654f, -0.00547511f, 0.02454895f, -0.03067042f, -0.03956879f, 
    0.02369262f, -0.01126298f, -0.01725787f, -0.03250203f, -0.18911803f, -0.03987484f, 0.03683141f, 0.11758689f, 
    0.05611428f, -0.01642807f, -0.07526659f, 0.03565951f, 0.11530180f, 0.03268449f, -0.09972528f, -0.01652277f, 
    0.03399646f, 0.04536689f, 0.01665185f, 0.01532446f, 0.09298362f, 0.10707071f, -0.05417898f, -0.02596730f, 
    0.07866812f, -0.11864704f, -0.02377885f, -0.01948567f, 0.33668688f, -0.03783457f, 0.15446211f, 0.00521092f, 
    -0.04216120f, 0.17571573f, -0.10059566f, 0.10887244f, -0.02023917f, 0.05153080f, -0.06427680f, 0.07385455f, 
    -0.01810583f, 0.19280672f, 0.09278274f, -0.04798280f, -0.00938899f, 0.09604868f, 0.09822495f, -0.02285662f, 
    0.04214197f, 0.01777149f, 0.12485840f, -0.04390317f, -0.07108303f, -0.28879195f, -0.03161476f, -0.22698779f, 
    0.01955423f, 0.06411204f, 0.07930604f, -0.03189913f, -0.07474226f, -0.03763149f, 0.03649211f, -0.01509148f, 
    0.04542066f, 0.11011419f, 0.22843793f, 0.06050363f, -0.02246681f, -0.01527991f, -0.00683781f, 0.05087942f, 
    -0.04538570f, -0.02427091f, 0.07689682f, 0.04094300f, -0.26216590f, -0.14587623f, -0.04509858f, -0.16933687f, 
    0.11506283f, -0.12494569f, 0.10276360f, -0.05627599f, -0.01429093f, -0.11263680f, -0.03009794f, -0.11725976f, 
    0.13412462f, 0.11400606f, 0.02173061f, 0.21711281f, 0.10314491f, 0.07300197f, 0.01919773f, -0.00609515f, 
    -0.00630067f, -0.00734844f, 0.03215269f, -0.03323058f, -0.08293829f, -0.20996208f, -0.12831989f, -0.03334093f, 
    0.01806543f, 0.10815368f, 0.14958483f, 0.02292974f, -0.07652721f, 0.10577272f, 0.04640544f, 0.09900121f, 
    0.17520604f, -0.12573329f, -0.00978427f, -0.08026740f, 0.05031168f, 0.00190822f, 0.15641811f, 0.07558712f, 
    -0.00402404f, 0.02142826f, 0.04450759f, 0.00962174f, -0.26205671f, -0.04249449f, 0.02016186f, -0.23908930f, 
    0.00675740f, 0.03814779f, 0.12264849f, -0.05686256f, -0.02091738f, 0.11442657f, -0.14025210f, 0.01198404f, 
    0.32238829f, -0.27319193f, 0.10127416f, 0.03894794f, -0.14356045f, 0.10156783f, -0.02457539f, 0.04792056f, 
    -0.06119325f, -0.10335355f, -0.06310075f, 0.00035811f, 0.00153935f, 0.20882316f, 0.19782454f, -0.02921080f, 
    0.05224510f, 0.03595574f, 0.16512619f, 0.06363589f, -0.04572157f, -0.00825126f, -0.00838131f, 0.02125202f, 
    0.00724067f, -0.06246028f, 0.05258092f, -0.12471811f, -0.07604226f, -0.12597072f, -0.02395665f, 0.01172075f, 
    0.04776846f, -0.05331344f, -0.05668004f, 0.08272213f, 0.32550815f, -0.23811519f, -0.20877710f, -0.03288645f, 
    -0.04722315f, 0.07357252f, 0.01082794f, -0.03697664f, -0.00259320f, -0.01419193f, -0.05867194f, 0.03077786f, 
    -0.21677306f, -0.09715405f, 0.14056525f, -0.02336069f, 0.03338932f, 0.03559643f, 0.10290124f, -0.00131617f, 
    -0.06519935f, 0.03793697f, -0.01423063f, 0.00912196f, 0.17048891f, -0.17468700f, 0.16280571f, -0.24491665f, 
    0.11259508f, 0.04383967f, 0.02436179f, 0.02011338f, -0.06210492f, -0.11919962f, 0.13166332f, 0.00136394f, 
    0.22020853f, 0.07036331f, 0.05176163f, -0.19174057f, 0.07021819f, 0.04537546f, -0.08496621f, 0.00353671f, 
    0.09578211f, 0.08794422f, -0.02058462f, 0.00919234f, 0.49059913f, 0.19018234f, -0.05220390f, 0.06022423f, 
    -0.10697478f, -0.04064580f, -0.05193652f, 0.08845567f, -0.01942751f, 0.11996195f, 0.01314278f, 0.06924580f, 
    -0.03425729f, 0.03913441f, 0.01555150f, -0.13246427f, 0.00801787f, 0.03975396f, 0.07355679f, 0.06966551f, 
    0.01193451f, 0.06194291f, 0.01224048f, 0.12621850f, -0.30943936f, 0.07646076f, 0.16205196f, -0.03741005f, 
    0.12848626f, -0.04911167f, 0.09405372f, -0.00665916f, 0.05570376f, -0.01537309f, 0.02107407f, 0.06467595f, 
    -0.20541148f, 0.01927436f, -0.08427803f, 0.07756725f, 0.02477563f, 0.05417682f, -0.09402976f, 0.08870916f, 
    -0.01922906f, 0.03728819f, -0.04878136f, -0.01998704f, 0.14721572f, 0.09682517f, 0.14024021f, 0.12181973f, 
    0.06460539f, 0.00459242f, -0.00636190f, 0.00244687f, -0.06663024f, 0.02732989f, 0.11043858f, -0.10025974f, 
    -0.19000950f, -0.10237673f, 0.09581756f, 0.06326295f, 0.11754543f, 0.10751190f, 0.08426534f, 0.10722414f, 
    0.00734898f, 0.04245906f, -0.01196868f, 0.08150519f, 0.22207274f, 0.00252755f, 0.02687228f, 0.17665154f, 
    -0.11133112f, 0.08846428f, 0.05576142f, -0.02341796f, -0.03968455f, -0.08528098f, -0.07043357f, -0.09385574f, 
    0.21004599f, -0.00622003f, 0.12514453f, 0.15265568f, 0.02443306f, -0.03751819f, 0.02158466f, 0.11414348f, 
    0.09077716f, 0.07912078f, 0.02985154f, -0.05595525f, 0.20672913f, -0.01074607f, 0.08145580f, -0.03876862f, 
    -0.01085790f, 0.05143362f, -0.06748033f, 0.03792210f, 0.02022181f, 0.10702795f, -0.12007743f, -0.04442976f, 
    0.05544499f, -0.18713062f, 0.03507242f, -0.20189103f, 0.08623926f, -0.01989949f, 0.13283536f, -0.00379093f, 
    0.08076818f, -0.02683354f, 0.04966168f, -0.11415014f, 0.29870155f, 0.06968371f, 0.02554876f, -0.11403394f, 
    0.10255534f, 0.11246185f, 0.02485068f, 0.08723941f, 0.15043280f, 0.00636938f, -0.05563712f, 0.09726726f, 
    0.26818961f, 0.17606129f, -0.11166981f, 0.11864815f, 0.04381306f, 0.12231818f, -0.06637511f, -0.07186954f, 
    0.15505041f, 0.02354369f, 0.07290431f, -0.05491219f, -0.00240723f, 0.08919363f, -0.13722922f, -0.04878636f, 
    0.16872276f, 0.09000594f, -0.04199222f, 0.01177428f, -0.15434971f, -0.00649266f, 0.03525106f, -0.03316082f, 
    0.06119144f, -0.09729530f, -0.00386145f, -0.07350215f, -0.03001225f, -0.10767958f, -0.03971799f, 0.09551369f, 
    0.06753747f, 0.05525492f, -0.02681911f, 0.07466089f, 0.02818363f, 0.22979337f, 0.15492591f, 0.15861885f, 
    -0.06848469f, 0.03981402f, 0.11707790f, -0.06148858f, 0.22976919f, 0.10390203f, -0.02909091f, -0.00291754f, 
    0.19024923f, -0.01467898f, 0.09471148f, 0.03766630f, -0.10649142f, -0.00008059f, -0.04476061f, 0.04150977f, 
    0.03712262f, -0.06594060f, -0.00831532f, -0.09841355f, 0.31565204f, 0.11515715f, 0.15495676f, 0.00046985f, 
    -0.02291745f, -0.01625484f, -0.04876535f, 0.02915118f, -0.01291251f, 0.05559645f, -0.16665292f, -0.10922038f, 
    0.15651232f, 0.17943677f, 0.14230460f, -0.10241996f, -0.02454530f, 0.04603335f, 0.17392133f, 0.00181865f, 
    0.05439308f, -0.00216209f, 0.23541312f, -0.09596064f, 0.06702000f, 0.08461120f, -0.13661878f, -0.09180191f, 
    0.14189287f, 0.13125618f, -0.10309196f, 0.03549593f, 0.02827781f, -0.00377736f, 0.04860740f, 0.08559251f, 
    0.23597348f, -0.05712727f, -0.00459164f, 0.05462343f, 0.04375276f, 0.06431317f, 0.10810260f, -0.04791746f, 
    -0.04992764f, 0.03429501f, 0.10235012f, 0.10249023f, -0.02401724f, 0.04097041f, -0.20901304f, -0.21750183f, 
    0.11860825f, -0.09733174f, 0.07733731f, -0.06901550f, 0.02185552f, 0.10992663f, -0.00818865f, -0.17135352f, 
    0.22789690f, -0.04205755f, -0.16201882f, -0.04773243f, -0.01200123f, -0.06692097f, -0.10741371f, -0.11089790f, 
    0.01269149f, -0.05157353f, -0.08903255f, 0.00295644f, -0.07079725f, -0.03738327f, 0.02340240f, -0.06767841f, 
    -0.11782399f, -0.00388685f, 0.07607996f, -0.07511127f, -0.06072616f, 0.17520280f, 0.00849788f, 0.02169740f, 
    0.16615947f, 0.08644805f, 0.19340974f, -0.12153154f, -0.03830174f, -0.04429167f, 0.10030910f, 0.06727569f, 
    0.00988502f, -0.08957462f, 0.00951278f, 0.05940460f, -0.15311928f, 0.13317363f, 0.01364401f, -0.01885362f, 
    0.16446069f, -0.06783371f, -0.02422290f, -0.04888554f, 0.03941553f, 0.08352175f, -0.05812090f, -0.08464517f, 
    0.14912470f, -0.03558613f, 0.02097991f, 0.09396220f, -0.13354920f, 0.04991924f, -0.07945972f, 0.15193117f, 
    -0.08882369f, 0.08235358f, 0.03776149f, -0.08108845f, 0.03508196f, -0.01136462f, -0.23347926f, -0.03689337f, 
    -0.02176082f, -0.06139642f, 0.04297514f, -0.03967886f, -0.05769096f, -0.13003525f, 0.07686117f, 0.12732568f, 
    -0.13241005f, -0.17916140f, -0.16302046f, 0.12294087f, 0.09702092f, -0.12018925f, -0.01933790f, -0.04186696f, 
    -0.07149008f, 0.18082123f, 0.06745497f, -0.04537781f, 0.07639877f, -0.15895626f, -0.07327408f, -0.06220262f, 
    -0.04137727f, -0.04994782f, -0.15477239f, -0.02691310f, 0.04583557f, -0.08201642f, 0.00681557f, 0.11199853f, 
    0.06202813f, 0.03361150f, 0.02882229f, -0.10178179f, -0.15376869f, 0.08076450f, -0.04404396f, -0.03039020f, 
    0.08462052f, -0.00870894f, -0.05967786f, -0.06894501f, -0.09907740f, 0.17296484f, 0.26214319f, -0.07877383f, 
    0.01240360f, 0.02114988f, -0.03421481f, -0.01498492f, -0.02861520f, 0.09544314f, 0.14330308f, 0.15395752f, 
    0.30681443f, 0.15500486f, 0.04529939f, 0.10393184f, -0.05222093f, -0.11277084f, -0.08651119f, 0.13865523f, 
    0.04416388f, 0.06681831f, -0.13143112f, -0.04788728f, 0.13813221f, -0.15424061f, -0.23671098f, 0.17611863f, 
    0.10988192f, -0.06161075f, 0.08884810f, 0.03148637f, -0.03729542f, 0.00754101f, 0.04706464f, 0.04858612f, 
    -0.16111763f, 0.18385758f, 0.11381803f, -0.27624217f, 0.02609406f, -0.01783372f, -0.02482167f, 0.08944375f, 
    0.01548114f, 0.07650433f, 0.00641185f, 0.07983632f, -0.15713893f, 0.21165529f, 0.08724090f, 0.00261446f, 
    0.11297440f, -0.13450852f, 0.17980242f, -0.04141988f, 0.05805275f, 0.00090736f, 0.08895510f, -0.00953156f, 
    0.02958604f, 0.19784959f, 0.11168265f, -0.16726381f, 0.00116642f, 0.08498903f, -0.06364052f, 0.13679688f, 
    0.01714162f, 0.11284286f, 0.07866887f, 0.04040414f, 0.03282875f, -0.07581368f, 0.03751219f, 0.07974261f, 
    0.04995984f, 0.11442038f, -0.00822218f, -0.13984649f, -0.08194066f, -0.00489147f, 0.06285447f, -0.14893863f, 
    -0.20805785f, -0.04905285f, 0.24170972f, -0.00803576f, -0.10820881f, 0.02142126f, -0.03724474f, -0.03377312f, 
    0.02869269f, -0.05546979f, 0.07404973f, 0.05967385f, -0.33382618f, -0.24733862f, -0.17214909f, 0.20422965f, 
    0.05088410f, 0.01779849f, -0.08346697f, -0.08304156f, 0.01166398f, -0.01458674f, 0.06731278f, -0.02819584f, 
    0.01080197f, -0.04031950f, 0.05766919f, 0.08645403f, 0.09505914f, 0.06245776f, -0.07532035f, -0.06697025f, 
    0.00126988f, 0.05772765f, 0.06119994f, -0.04821974f, -0.02471388f, -0.17450401f, -0.15101685f, 0.21388640f, 
    0.13202727f, -0.03101862f, -0.10094912f, -0.07348185f, 0.05002565f, -0.03437792f, 0.15381525f, -0.07398199f, 
    -0.16785520f, 0.14526151f, 0.14246516f, -0.07424980f, 0.15244195f, -0.13241725f, -0.08892432f, 0.02225026f, 
    0.20664792f, -0.05327405f, 0.14714466f, -0.03047661f, 0.24703547f, 0.21096563f, 0.02191139f, 0.01410780f, 
    -0.01858973f, -0.05415763f, -0.00073871f, 0.20961890f, 0.06981356f, 0.00220320f, -0.08097060f, 0.00277712f, 
    0.02105836f, -0.03675890f, -0.00509697f, 0.00076218f, -0.03777051f, 0.04312904f, -0.04007616f, -0.02201710f, 
    -0.03471625f, -0.04886217f, -0.03321087f, 0.04502212f, 0.00596302f, 0.01218589f, 0.04482542f, -0.01633920f, 
    0.00943310f, 0.00185476f, -0.01620392f, -0.03552768f, 0.03034884f, 0.00735678f, -0.05577457f, -0.01436630f, 
    -0.05650456f, -0.00725493f, -0.03593431f, -0.01630588f, 0.01068911f, -0.00257116f, 0.00506606f, -0.01063765f, 
    -0.01474302f, -0.01152081f, -0.02820149f, -0.04577544f, -0.04039687f, -0.02797696f, 0.00864180f, -0.00663796f, 
    -0.03992875f, -0.02431721f, 0.01110876f, -0.01723041f, -0.00536500f, 0.00427367f, 0.03837116f, -0.02889329f, 
    0.00426073f, -0.01244207f, 0.00763781f, 0.01492559f, -0.05094547f, -0.05280451f, 0.02566173f, -0.00849012f, 
    0.02473930f, -0.01585451f, -0.00828070f, -0.04242038f, -0.05284673f, 0.03912707f, 0.03689820f, -0.00341386f, 
    0.01167531f, 0.02974034f, 0.03607082f, -0.01581257f, 0.00980255f, 0.00504741f, 0.02653331f, 0.04146089f, 
    -0.03320037f, 0.04594593f, -0.03580070f, -0.01125409f, 0.02763496f, -0.02890840f, -0.04444192f, -0.04698290f, 
    0.01330397f, 0.03562516f, 0.04257649f, -0.05420581f, 0.00664973f, -0.00953497f, 0.02682017f, -0.02119609f, 
    -0.01165704f, 0.03979757f, -0.04346339f, 0.04602800f, -0.03357628f, -0.03291474f, -0.02910730f, 0.02409015f, 
    -0.05016008f, -0.02020929f, 0.03970924f, -0.00289665f, 0.00536888f, 0.03626886f, 0.03376403f, 0.02498115f, 
    -0.04536665f, -0.01815222f, -0.03355283f, 0.00116203f, -0.00702313f, -0.04605741f, 0.00405918f, -0.01894852f, 
    -0.01936544f, -0.03130821f, 0.03299629f, 0.03727450f, -0.05011738f, -0.03552518f, -0.03605373f, -0.03569996f, 
    -0.01129629f, 0.04958218f, -0.00578961f, 0.01635839f, 0.00936175f, 0.02421751f, 0.00654193f, 0.04375685f, 
    -0.02239933f, -0.00994177f, 0.03217900f, 0.04289691f, -0.02564198f, 0.01544548f, -0.03634952f, 0.02566222f, 
    0.03623599f, 0.02664263f, 0.01049196f, -0.03234271f, -0.01108569f, -0.04484184f, 0.02972363f, -0.01883748f, 
    -0.04946261f, 0.03238423f, 0.02324197f, 0.03988757f, 0.00013985f, 0.01704909f, 0.01570329f, -0.04435715f, 
    0.01315444f, -0.04007949f, 0.04385440f, -0.05065362f, -0.04014025f, 0.02529319f, -0.00348199f, 0.00803625f, 
    0.01744546f, -0.01401048f, 0.04391281f, 0.03359152f, -0.03367318f, 0.00533998f, 0.02803794f, 0.01043185f, 
    -0.05102190f, -0.03752578f, -0.05540553f, -0.02082303f, 0.03197403f, -0.04369868f, 0.04307070f, -0.00677255f, 
    -0.02179695f, -0.02398980f, 0.03553621f, 0.04811420f, 0.00945718f, 0.05208435f, -0.05335913f, -0.01350183f, 
    -0.02831687f, -0.01418331f, 0.01383825f, -0.05628983f, 0.02767131f, -0.02336417f, 0.01743300f, 0.03752726f, 
    0.00596976f, 0.01054394f, -0.05215751f, 0.03132083f, 0.02300143f, -0.02094677f, -0.04765593f, -0.04201698f, 
    0.00400367f, -0.03089909f, -0.00905128f, 0.02194091f, 0.00965232f, -0.02434338f, 0.00411919f, -0.05202045f, 
    -0.04214022f, -0.00955865f, -0.05301107f, -0.05672185f, 0.02494077f, -0.01496382f, 0.01098260f, -0.00389772f, 
    0.01259423f, 0.00632778f, 0.00309593f, -0.03001614f, 0.03771735f, -0.03705377f, -0.02064593f, -0.04325977f, 
    0.03018885f, -0.00818774f, 0.03092788f, 0.04260137f, -0.00340410f, -0.04917105f, 0.00187803f, -0.04969417f, 
    -0.05624096f, -0.00597046f, -0.01443769f, 0.02750142f, -0.00989353f, 0.01357548f, 0.04924607f, -0.01091870f, 
    -0.02593927f, -0.01079831f, 0.01075607f, 0.03562703f, 0.01903838f, 0.00295835f, 0.03686271f, -0.00886235f, 
    0.03726587f, -0.00336559f, -0.05136655f, -0.00992542f, 0.02097721f, -0.00498980f, -0.03803001f, -0.00748548f, 
    0.03063286f, -0.02837704f, 0.01100563f, -0.04486667f, 0.02705633f, -0.00259144f, 0.02888462f, -0.03583306f, 
    -0.04333758f, -0.04045184f, 0.00786763f, -0.03990347f, 0.05084037f, -0.01028920f, 0.01208800f, 0.00239920f, 
    0.04290282f, 0.01570779f, -0.00631796f, -0.02629106f, 0.04010491f, 0.03310583f, 0.00076066f, -0.02723854f, 
    0.00079171f, 0.03149080f, -0.03025490f, -0.03512421f, 0.01065529f, 0.02124532f, 0.00295610f, -0.04802924f, 
    -0.00058574f, 0.04485578f, 0.00287263f, -0.00286710f, -0.02093658f, -0.01448683f, 0.04578868f, -0.01287939f, 
    -0.02858016f, 0.03462836f, -0.05082432f, 0.01338719f, -0.03693379f, 0.03855778f, -0.00464870f, -0.04898177f, 
    -0.00827780f, -0.04345685f, -0.02905761f, -0.04979133f, -0.04199399f, -0.01624903f, -0.04484864f, 0.00407451f, 
    0.03460949f, 0.01878464f, 0.02711323f, -0.00396951f, 0.03576506f, -0.03286374f, 0.03673298f, -0.03371007f, 
    0.03292008f, 0.01246220f, 0.00549549f, -0.03070180f, -0.03671168f, -0.02575735f, -0.02849502f, -0.05115674f, 
    0.01067748f, 0.01426869f, 0.01853522f, 0.02354517f, 0.04719059f, -0.01088592f, 0.01955252f, 0.00561241f, 
    -0.01952497f, 0.02474366f, 0.00289465f, -0.01980097f, -0.04505758f, -0.00567726f, 0.00645863f, 0.00656739f, 
    0.01210167f, 0.01872517f, 0.01549490f, -0.04897680f, 0.03854726f, -0.01401285f, -0.04375279f, -0.01124348f, 
    0.02658101f, -0.04565099f, 0.00932858f, -0.02235542f, 0.02358204f, 0.02929678f, 0.02552998f, -0.03134266f, 
    0.02092661f, -0.01856782f, 0.02016074f, -0.00954964f, 0.03026966f, -0.03244970f, 0.04088474f, -0.01027242f, 
    0.00277802f, -0.01167937f, -0.05173253f, -0.02097254f, -0.02154946f, -0.04322735f, -0.01586295f, -0.02759255f, 
    -0.03842650f, -0.04165614f, 0.02117138f, 0.02060836f, -0.04297888f, -0.04262144f, 0.03784525f, -0.04356753f, 
    0.00585249f, 0.01885468f, -0.01305182f, 0.03830279f, 0.05268097f, -0.00877708f, -0.00280609f, 0.00921273f, 
    -0.04159879f, -0.04313013f, -0.00790191f, -0.00975549f, -0.03826427f, -0.00983272f, 0.01741432f, 0.02781543f, 
    -0.04553657f, 0.01193789f, -0.00738887f, -0.01058653f, -0.02773257f, -0.05462507f, -0.04109225f, 0.01844120f, 
    -0.02799791f, 0.04172977f, -0.02231174f, 0.03317951f, 0.00092941f, -0.01887780f, -0.01115084f, -0.02334492f, 
    0.03343934f, -0.00738223f, -0.01796807f, 0.00028001f, -0.03940500f, -0.01796151f, -0.02464091f, 0.03161430f, 
    -0.02150758f, -0.01977381f, -0.01196229f, 0.03878511f, 0.03656927f, 0.00017050f, 0.01066087f, -0.01400181f, 
    0.04104791f, -0.02062136f, 0.02572107f, 0.03898735f, -0.02051800f, 0.02691891f, 0.03415588f, 0.03741452f, 
    0.02317273f, 0.00695348f, -0.01626596f, 0.03242844f, 0.03814239f, 0.01349980f, 0.00704451f, -0.03440163f, 
    -0.04875438f, 0.02648711f, 0.00969469f, 0.00809530f, -0.01497826f, 0.01464118f, 0.01858714f, -0.00032519f, 
    -0.02838585f, -0.05075946f, 0.02159918f, -0.00000800f, -0.01198731f, -0.02789552f, -0.00250868f, 0.03390774f, 
    -0.04490338f, 0.01274019f, 0.00073653f, -0.01562018f, -0.05548434f, -0.02855469f, -0.04977239f, -0.01042113f, 
    0.01751952f, -0.05610157f, -0.03913233f, -0.02422091f, -0.03201956f, -0.00198896f, -0.05618862f, -0.04699291f, 
    0.02375646f, -0.02153522f, -0.03576016f, 0.02789957f, 0.01760329f, 0.01556204f, -0.02595257f, 0.01871599f, 
    -0.04948445f, -0.03402012f, -0.01044351f, 0.02339930f, 0.05129468f, 0.02769226f, 0.01728914f, 0.02950394f, 
    -0.03173998f, 0.03997641f, -0.03196112f, -0.03854912f, 0.00666556f, 0.01648691f, 0.02240320f, 0.01791585f, 
    -0.05749547f, 0.00632755f, -0.00936621f, 0.00662190f, -0.01628917f, 0.02979892f, -0.02825995f, 0.03651677f, 
    0.04258313f, 0.01233273f, -0.01320310f, -0.03271237f, -0.04310754f, -0.04677023f, -0.00848596f, -0.02998176f, 
    0.02434291f, 0.01888934f, -0.05877150f, 0.03541448f, -0.02122574f, -0.00871013f, -0.00927291f, -0.04640548f, 
    0.04414036f, 0.02205866f, -0.03103073f, -0.05651102f, 0.00338857f, -0.04449920f, -0.03862386f, -0.01116777f, 
    -0.04342712f, 0.02384809f, -0.03512090f, -0.04746247f, 0.04739394f, -0.05506882f, -0.02336113f, -0.00297441f, 
    -0.05063832f, -0.05106617f, 0.00691412f, 0.01386918f, -0.03607573f, -0.01310633f, -0.00206475f, -0.05675012f, 
    -0.01366894f, 0.03668421f, -0.03427050f, 0.02862902f, 0.00809800f, -0.03999403f, -0.01202535f, 0.01288454f, 
    0.03379227f, -0.00945902f, -0.04678029f, -0.00160057f, -0.00576656f, -0.00556046f, 0.01963229f, -0.01127476f, 
    -0.03455113f, -0.03733268f, 0.01623303f, 0.04034123f, 0.02027888f, 0.00055828f, -0.00604921f, 0.04568850f, 
    -0.04361536f, -0.00580556f, -0.05239028f, -0.00420366f, 0.01641934f, -0.03600905f, 0.04970979f, -0.03476248f, 
    0.02275686f, -0.02347679f, 0.00705266f, -0.04519378f, 0.02449579f, 0.03367677f, -0.04445812f, 0.00671717f, 
    -0.03684999f, -0.02410004f, -0.00346718f, 0.04185141f, 0.03135304f, -0.01312498f, 0.00469087f, -0.04471220f, 
    -0.02952722f, 0.00705370f, -0.03509343f, 0.01665146f, -0.03330704f, 0.01552275f, -0.02765529f, 0.03753217f, 
    0.02559430f, -0.00378543f, 0.01445312f, -0.02325508f, 0.03149276f, 0.04529624f, -0.02613812f, 0.00314770f, 
    0.01901080f, -0.03155957f, -0.02354503f, -0.02008904f, -0.01570727f, -0.03191335f, -0.02378745f, 0.03235486f, 
    -0.04353940f, 0.02755122f, 0.00850249f, 0.01863833f, -0.00498262f, -0.01831797f, -0.05780179f, -0.02403213f, 
    0.02630325f, -0.02067391f, 0.02282410f, -0.03390628f, 0.00782015f, -0.05235321f, -0.00157051f, 0.04147782f, 
    0.02517662f, 0.04104039f, 0.01933516f, -0.04192160f, -0.03962144f, 0.04100618f, -0.02192977f, 0.04499663f, 
    -0.00264173f, -0.03414602f, -0.03320476f, -0.03757298f, 0.00796934f, -0.03243127f, -0.04195976f, 0.02784465f, 
    0.02256903f, -0.03505177f, -0.01282221f, 0.03323973f, 0.01803373f, -0.01104176f, 0.00725351f, 0.01058436f, 
    -0.00086255f, -0.02218409f, 0.03376715f, 0.04048516f, -0.03199788f, -0.05332483f, 0.00673772f, -0.00784893f, 
    0.01374988f, -0.01133537f, 0.00161807f, -0.00152270f, 0.01573771f, 0.04222430f, 0.00885253f, -0.02673039f, 
    0.01125393f, -0.04766082f, -0.03573344f, 0.00965374f, 0.03747932f, 0.01142075f, 0.01358535f, -0.05507788f, 
    -0.03964384f, -0.03971469f, -0.04275374f, -0.04224705f, 0.00641085f, -0.01780953f, 0.03226911f, 0.02748576f, 
    -0.00992786f, 0.01819377f, -0.03184021f, -0.00805102f, -0.01318586f, -0.05591800f, 0.01116462f, -0.03919954f, 
    -0.02088186f, -0.04839135f, -0.04657768f, -0.00395613f, -0.03185517f, 0.05087410f, -0.00011088f, 0.01611844f, 
    -0.02353457f, -0.02294741f, 0.01408282f, 0.00442655f, -0.02777290f, 0.02995384f, -0.04076671f, 0.01944267f, 
    -0.01108182f, -0.04776433f, -0.04938726f, 0.01126742f, -0.01453867f, -0.01496585f, 0.03510682f, 0.03014068f, 
    0.00003203f, 0.00445965f, -0.01977383f, 0.00247789f, 0.04281127f, 0.03419500f, -0.02167761f, 0.00979969f, 
    0.01696007f, -0.03792306f, 0.02028134f, -0.01938562f, -0.04619648f, 0.00638013f, 0.01221315f, 0.03737998f, 
    0.02098696f, -0.01801021f, -0.03221077f, -0.00074510f, -0.04741350f, -0.05971316f, 0.04363972f, -0.05052073f, 
    0.03867974f, -0.01243603f, 0.01249354f, -0.04164433f, 0.03960222f, 0.00996021f, -0.01294987f, 0.03036230f, 
    -0.04570614f, 0.02417527f, -0.03226509f, 0.01731944f, -0.01462214f, -0.03319197f, -0.05637350f, -0.03074400f, 
    -0.01894376f, 0.01929303f, 0.00333491f, -0.04917355f, -0.05465763f, -0.04163719f, 0.03453984f, -0.01025026f, 
    0.02728148f, 0.03802343f, -0.00169553f, 0.00511078f, 0.03157312f, -0.04904409f, 0.03440642f, 0.00894857f, 
    0.03663148f, 0.00435270f, 0.02579542f, 0.01700650f, -0.00040305f, 0.02267274f, 0.00008377f, -0.03632399f, 
    -0.04489530f, 0.03373536f, 0.00897783f, 0.01548302f, -0.04721561f, 0.03776318f, -0.02150352f, 0.02772165f, 
    0.05002802f, -0.03185730f, -0.02119260f, 0.02481704f, -0.03068308f, -0.03179383f, 0.01942696f, -0.04769589f, 
    -0.04021447f, -0.05138623f, -0.01125363f, -0.05392841f, 0.03504421f, 0.00498600f, 0.00515839f, 0.04324451f, 
    0.03783307f, -0.04476698f, 0.02510464f, 0.03990340f, 0.02091768f, -0.03238029f, 0.01828581f, 0.02557097f, 
    -0.04777141f, 0.02393242f, 0.01943447f, -0.05088603f, 0.00732169f, -0.03893896f, -0.04256095f, -0.04623466f, 
    -0.00498488f, -0.04288751f, -0.03942252f, -0.04168663f, -0.04560149f, -0.04644448f, -0.03696869f, -0.05567160f, 
    0.00372384f, -0.01658975f, 0.04416586f, -0.05385591f, 0.04487431f, 0.00762459f, 0.01634143f, -0.00892285f, 
    -0.01643782f, -0.00041988f, -0.02784859f, -0.03167950f, -0.02052922f, -0.01276397f, -0.04569042f, 0.04795555f, 
    0.04652141f, 0.04163891f, 0.04081882f, -0.04379339f, 0.02183338f, -0.00478331f, -0.00970600f, -0.03174698f, 
    -0.05611544f, -0.01034927f, -0.00517303f, -0.01243283f, 0.03192072f, 0.04300472f, -0.04938947f, 0.01115834f, 
    0.01382242f, -0.03513421f, 0.03592725f, -0.04846979f, 0.02853443f, -0.02211705f, -0.04122097f, 0.01300703f, 
    -0.03743649f, 0.00860935f, -0.03110173f, 0.02329083f, -0.02322236f, 0.03080454f, 0.01562992f, -0.03170700f, 
    0.03149094f, 0.02434244f, 0.04017900f, 0.03253038f, 0.01066961f, -0.03191869f, -0.02275677f, -0.00368888f, 
    0.03784343f, 0.02376443f, -0.05316738f, 0.03856982f, 0.03335298f, -0.04552695f, -0.04103786f, 0.00173073f, 
    -0.04521190f, -0.04771248f, 0.04237137f, -0.02405869f, -0.01541525f, 0.04008657f, -0.02663191f, 0.03377779f, 
    0.01237556f, -0.05503806f, -0.04033653f, 0.04323296f, 0.00708339f, -0.05178721f, -0.04849993f, -0.03560427f, 
    0.02209920f, 0.03771314f, 0.01346737f, -0.05104187f, 0.02813604f, -0.03210255f, -0.05225514f, 0.01775431f, 
    0.03238109f, 0.00774940f, 0.00048302f, 0.03150409f, 0.03951639f, -0.00551553f, -0.03646540f, -0.01170337f, 
    0.04283987f, 0.02429063f, -0.01511745f, 0.00830625f, 0.02620046f, 0.00150720f, -0.04944040f, 0.02515798f, 
    0.01001795f, 0.00063280f, 0.01571828f, -0.03018995f, 0.00474010f, -0.00675660f, 0.03414506f, -0.03843433f, 
    0.03940831f, -0.00001480f, -0.01126125f, 0.00957259f, -0.02809678f, -0.03912238f, -0.04787040f, 0.04363748f, 
    -0.03175440f, 0.03780421f, 0.03510634f, 0.02104663f, -0.03080595f, 0.00835889f, 0.00484122f, -0.05308791f, 
    -0.03040793f, -0.03788156f, -0.00786153f, -0.04721815f, -0.02897959f, 0.01702522f, -0.02591036f, -0.02077797f, 
    -0.00240580f, -0.03028765f, -0.04152288f, 0.01195180f, -0.01243347f, 0.04400181f, -0.04283688f, 0.01726609f, 
    -0.03578393f, 0.00975826f, -0.01213362f, -0.00241462f, 0.01288550f, -0.04874967f, -0.00255886f, -0.04509340f, 
    -0.02458829f, 0.03302456f, -0.00961261f, 0.01260370f, 0.02671382f, -0.04009982f, 0.00852727f, -0.01934680f, 
    -0.01893192f, 0.03962092f, -0.05288572f, -0.03380927f, -0.04492966f, -0.00775765f, 0.02491454f, -0.00630629f, 
    0.00670698f, 0.01928047f, -0.04489916f, 0.03540895f, -0.05631470f, -0.02892541f, -0.04097461f, -0.04947365f, 
    -0.01028697f, 0.01890864f, -0.04891757f, -0.05028328f, -0.01318064f, -0.05410478f, -0.02131093f, 0.00395942f, 
    -0.04313557f, -0.05111613f, -0.02804929f, 0.03831439f, 0.00651390f, 0.02856853f, -0.01312675f, -0.02259618f, 
    0.01141481f, 0.03763670f, -0.03444393f, 0.01156829f, -0.04763355f, -0.03651973f, 0.00297613f, -0.00928930f, 
    0.02983449f, -0.01896868f, 0.01601142f, 0.03485188f, -0.03586257f, -0.01362252f, 0.04102667f, -0.02638230f, 
    -0.01190195f, -0.04790770f, -0.03381031f, -0.05457976f, -0.04018920f, -0.03160398f, -0.02536931f, -0.00928350f, 
    0.03662167f, -0.01979145f, 0.01117057f, -0.01008829f, 0.04248236f, -0.00277887f, -0.02805847f, 0.02911169f, 
    0.01257305f, -0.00708142f, -0.00749465f, -0.00149490f, 0.00912143f, -0.01336251f, -0.03749954f, 0.01618612f, 
    -0.03856345f, -0.01729905f, -0.01208051f, 0.00516804f, -0.00963561f, 0.01009944f, -0.05650195f, 0.01313969f, 
    -0.03744102f, -0.04107069f, -0.02422054f, 0.01061533f, 0.00893788f, 0.02252916f, -0.00944605f, 0.00529981f, 
    0.01980632f, -0.04651497f, 0.02881339f, -0.02213658f, -0.03316744f, -0.00569639f, -0.04356219f, 0.02115086f, 
    -0.03620880f, 0.00839937f, -0.00234624f, -0.02800114f, -0.02975782f, -0.00154296f, -0.02677507f, -0.04264249f, 
    0.04121036f, -0.02952075f, 0.01823450f, 0.00087117f, -0.01794562f, 0.00975399f, 0.03582413f, -0.04528828f, 
    -0.04940609f, 0.02809064f, -0.05109598f, 0.01916930f, -0.05089492f, -0.00818339f, -0.04585458f, 0.02545176f, 
    -0.02775458f, -0.00006300f, 0.01391198f, -0.05135886f, 0.03663466f, 0.03583086f, -0.01643772f, 0.01995004f, 
    -0.03389387f, 0.03048168f, 0.02654526f, -0.04875927f, 0.02405739f, -0.02858046f, 0.03811926f, 0.01205861f, 
    0.02758630f, 0.00561421f, -0.00230294f, -0.01040919f, 0.02647682f, -0.04458381f, 0.04494851f, 0.02563530f, 
    0.01201911f, -0.04072830f, -0.04653995f, 0.00539702f, 0.04269801f, -0.01816040f, -0.04984769f, -0.04960975f, 
    0.02810163f, -0.01950855f, -0.03636261f, 0.00921032f, 0.04755210f, -0.02476620f, -0.00449493f, -0.04638100f, 
    -0.03570199f, 0.01417343f, -0.02205153f, 0.04043696f, 0.00704024f, -0.03018763f, 0.03339713f, 0.00493062f, 
    -0.03106258f, 0.01399332f, -0.05160788f, 0.04432378f, -0.01210014f, -0.03279635f, -0.05057767f, -0.05135000f, 
    0.00695290f, 0.04792839f, 0.01481667f, -0.05402152f, -0.04387389f, -0.02186733f, 0.01156777f, -0.00830910f, 
    -0.07229034f, 0.01842528f, -0.05827654f, -0.04085113f, -0.03556572f, 0.02494839f, -0.05317964f, -0.01564657f, 
    -0.00711505f, 0.03676320f, 0.03370155f, 0.04334556f, -0.02020976f, 0.03184779f, -0.00200421f, 0.03089893f, 
    -0.05301474f, -0.04513901f, -0.05374842f, 0.02512941f, -0.04350881f, -0.03250679f, -0.03021457f, -0.05229232f, 
    0.03082364f, -0.01154850f, -0.04542965f, -0.01689925f, -0.03488657f, -0.03563941f, 0.03520873f, -0.03317259f, 
    0.03096847f, -0.06219819f, -0.03651986f, -0.00630045f, -0.03114330f, -0.01011637f, -0.03212365f, -0.02624610f, 
    0.04979411f, -0.01696460f, 0.02874280f, -0.04811867f, -0.04853660f, -0.02854561f, 0.01803219f, -0.04775593f, 
    -0.05590843f, -0.06438401f, -0.00706939f, -0.01188561f, 0.05268255f, -0.04520859f, 0.00406346f, 0.04893805f, 
    -0.04040892f, -0.04851796f, 0.01993895f, 0.01472427f, -0.01172346f, 0.00811347f, -0.02695888f, -0.02635612f, 
    -0.01442891f, -0.00359363f, -0.01045091f, 0.01817327f, 0.00234477f, 0.00153180f, -0.04513607f, -0.01146444f, 
    -0.01434787f, -0.05155737f, 0.00113409f, -0.05418015f, 0.01534737f, -0.01439777f, -0.02743795f, 0.01202533f, 
    -0.03898347f, 0.03113988f, -0.01570363f, -0.02242626f, 0.01449346f, 0.00280177f, 0.01895216f, -0.04048971f, 
    -0.05034113f, 0.03189719f, 0.04251907f, 0.01795971f, -0.01018051f, -0.00679154f, 0.00717348f, -0.00443232f, 
    -0.04596885f, 0.00400513f, 0.02212089f, -0.06606180f, 0.04794333f, -0.05481596f, 0.02016010f, -0.03057151f, 
    -0.05148061f, -0.04243147f, -0.01876684f, 0.01983803f, -0.04669242f, -0.02201498f, -0.01684929f, -0.05010890f, 
    0.00867093f, -0.02255976f, 0.01408394f, -0.06117718f, 0.01733421f, -0.01084599f, 0.01798411f, -0.01167669f, 
    0.00120679f, -0.02825381f, -0.00283081f, -0.02181984f, -0.02480087f, -0.00032659f, -0.01444295f, -0.02175262f, 
    -0.04735465f, -0.04105842f, 0.00108035f, -0.01199599f, -0.05156173f, 0.02537372f, -0.01966013f, -0.02793427f, 
    -0.04484000f, -0.05296322f, 0.03689954f, 0.00538005f, 0.02326414f, 0.04040416f, -0.02362633f, 0.02878800f, 
    0.02039401f, 0.03031501f, 0.03126116f, 0.01173352f, 0.00654752f, -0.02927573f, 0.03048063f, -0.00048592f, 
    -0.04393973f, 0.00233382f, -0.02594972f, 0.01297486f, 0.03072101f, 0.00219404f, -0.05721083f, 0.03640303f, 
    0.01360151f, -0.00423746f, 0.02187815f, -0.05927167f, 0.03429094f, 0.02334263f, -0.05684125f, 0.02982393f, 
    -0.05487495f, 0.00005048f, 0.00143805f, -0.00072676f, -0.00127589f, -0.03408076f, -0.01806395f, 0.00744429f, 
    0.03735963f, 0.01577728f, 0.03174528f, 0.02693689f, -0.04265736f, -0.02256738f, 0.00121287f, 0.01055494f, 
    -0.02557241f, 0.03868944f, -0.02141478f, 0.01544257f, -0.02739587f, 0.03768462f, 0.02948686f, -0.02169577f, 
    -0.03074771f, 0.01219058f, 0.01034178f, -0.05851965f, -0.04046094f, 0.04321070f, -0.00954271f, 0.00818603f, 
    -0.01396244f, 0.04590769f, 0.03117125f, 0.02883185f, -0.02485627f, -0.04220795f, -0.06076958f, 0.03631236f, 
    -0.02263564f, -0.02665436f, -0.04406244f, -0.04426337f, -0.03207814f, 0.03253223f, -0.01624290f, 0.01191405f, 
    -0.01754555f, 0.00010503f, -0.03039867f, -0.00366583f, -0.01720242f, -0.03440509f, -0.04422046f, 0.01818016f, 
    -0.02111466f, -0.05973108f, 0.00626249f, 0.01871268f, 0.02272185f, 0.02477549f, -0.04116864f, -0.04827480f, 
    -0.00980136f, 0.03270900f, 0.00598089f, 0.03320769f, 0.01620073f, 0.04533825f, -0.05401592f, -0.06055879f, 
    0.01230224f, -0.02221552f, -0.01170842f, -0.00374006f, -0.01296332f, 0.05575102f, -0.03890635f, 0.04325878f, 
    0.04511446f, 0.03514715f, 0.04676419f, -0.02153393f, -0.03080844f, -0.03703282f, -0.01391285f, 0.03819731f, 
    -0.04146980f, -0.03015381f, -0.01516800f, 0.03166499f, 0.04196391f, -0.03678508f, -0.04289754f, -0.01144487f, 
    -0.01513251f, -0.02349749f, -0.04060308f, -0.05638189f, -0.05924012f, -0.02927880f, -0.03111229f, 0.03375571f, 
    0.01772869f, 0.03658755f, -0.02778811f, -0.05148150f, -0.05175005f, -0.01696131f, -0.02010178f, 0.00624461f, 
    0.00501327f, 0.02277883f, 0.01880213f, -0.03547224f, -0.04341821f, 0.01306837f, -0.03692267f, -0.01745082f, 
    -0.01368573f, 0.02949858f, 0.04181381f, -0.00147623f, -0.03915009f, 0.00757815f, -0.02965843f, 0.02384221f, 
    0.01389898f, -0.03301819f, -0.04229429f, 0.00951998f, -0.04277961f, 0.01318136f, 0.00086005f, -0.04944599f, 
    0.00040920f, 0.04097924f, 0.04393098f, -0.05500162f, -0.03188252f, -0.02856247f, 0.01660683f, 0.03736994f, 
    -0.04389565f, 0.00183230f, 0.01203719f, 0.00609643f, 0.00962768f, 0.03783433f, 0.01860998f, 0.03142796f, 
    -0.01631830f, -0.05527163f, -0.02527130f, 0.02934631f, 0.03424204f, -0.03426016f, -0.02691532f, 0.00411317f, 
    -0.01999850f, 0.03281431f, 0.01680052f, -0.01289120f, -0.05122263f, 0.04900291f, 0.01029009f, 0.01283860f, 
    0.02135296f, -0.06154056f, 0.00336378f, 0.01721293f, 0.00585511f, 0.00507033f, -0.03187900f, -0.02863977f, 
    0.03671214f, 0.02446938f, 0.02484167f, -0.03955431f, 0.02178862f, -0.00177727f, -0.02492516f, -0.00960089f, 
    -0.02000559f, 0.00101718f, -0.02085763f, -0.02131839f, -0.00061972f, -0.03510266f, -0.00180307f, 0.00611234f, 
    0.00307042f, -0.04065343f, 0.00983021f, -0.04630451f, -0.00147389f, 0.04136934f, -0.00029705f, 0.00360405f, 
    -0.02814918f, 0.04039290f, -0.01539588f, 0.00856224f, 0.01042048f, -0.05203569f, 0.01842927f, -0.01423473f, 
    -0.04981517f, 0.03167497f, -0.04798851f, 0.00353592f, -0.04165469f, 0.03676508f, 0.03740039f, 0.00377125f, 
    0.02260262f, -0.00983054f, 0.02074604f, 0.02203756f, -0.04124088f, 0.03651900f, -0.04917337f, 0.04477989f, 
    -0.01644994f, 0.00326104f, -0.04302767f, 0.03705618f, -0.01053965f, -0.03402135f, -0.00098752f, 0.04058945f, 
    -0.00043261f, -0.05241677f, -0.05039345f, -0.00632361f, -0.02798586f, -0.01818315f, 0.02762425f, -0.02326427f, 
    0.00798135f, -0.03808194f, -0.01123478f, -0.03639751f, -0.02845124f, -0.05221367f, 0.01562759f, -0.01462701f, 
    -0.02570740f, 0.00005128f, -0.01390503f, -0.04415974f, -0.03813013f, 0.03850440f, -0.03223433f, 0.02811920f, 
    -0.04247794f, 0.03557567f, -0.04190538f, -0.00847399f, -0.02289637f, 0.03967236f, -0.01279056f, -0.02813815f, 
    0.02377654f, -0.03555119f, 0.03463844f, -0.04764519f, 0.01150022f, -0.03798664f, -0.01680949f, -0.01023849f, 
    -0.04487595f, -0.04308750f, -0.02550367f, 0.02006080f, 0.01677619f, -0.04847799f, -0.04468861f, 0.00113747f, 
    -0.00478880f, 0.04360428f, -0.04402660f, 0.01253736f, -0.02179731f, 0.04538553f, 0.03779097f, -0.03744565f, 
    0.01477596f, 0.03706732f, 0.01788353f, -0.03944848f, 0.00125598f, 0.00958130f, 0.01617652f, 0.01098443f, 
    0.00968026f, -0.00418812f, 0.00014729f, -0.04145282f, -0.01543567f, 0.00580845f, -0.00426099f, 0.02755470f, 
    -0.03702967f, -0.05095329f, 0.00156256f, -0.04521250f, 0.00059459f, -0.05424566f, -0.04723557f, 0.03812637f, 
    -0.03163773f, -0.03752023f, 0.03601532f, 0.02409057f, 0.03610703f, 0.03910084f, 0.03163928f, -0.00775068f, 
    -0.01824159f, -0.04433011f, -0.02929877f, -0.03684869f, -0.02243312f, -0.00715791f, 0.04397272f, -0.01334818f, 
    0.02091133f, 0.03838644f, -0.01123739f, -0.03775227f, -0.02974437f, -0.04554651f, -0.02906154f, 0.02801271f, 
    -0.04633271f, -0.02765535f, -0.03997106f, -0.02468023f, 0.02539041f, 0.02193113f, 0.02024980f, -0.04602527f, 
    0.00141530f, -0.03828709f, 0.01650015f, -0.03257149f, 0.03362285f, -0.03018466f, -0.03623543f, 0.01159323f, 
    0.02989536f, 0.02933650f, -0.02118648f, -0.04745867f, 0.03274770f, 0.01987635f, -0.03922278f, -0.05357518f, 
    -0.02717184f, 0.03726850f, -0.04258533f, -0.04555999f, -0.00392032f, 0.03810372f, 0.01627611f, 0.03246847f, 
    -0.04012612f, -0.03742516f, -0.04645747f, -0.03111912f, 0.02063446f, 0.02885341f, -0.02726023f, 0.03131550f, 
    0.00458863f, -0.00074478f, -0.01504234f, -0.02571480f, -0.02063339f, 0.01544964f, -0.04589868f, 0.00456595f, 
    0.02780404f, 0.04416707f, 0.02908109f, 0.01753158f, -0.03490798f, -0.00437638f, 0.00229476f, -0.02717568f, 
    0.00477920f, 0.01382965f, -0.00055368f, 0.00785212f, 0.00024928f, -0.03101576f, 0.01868933f, 0.00272116f, 
    0.01876759f, 0.02612470f, -0.05452317f, -0.00541648f, -0.04358074f, -0.04634712f, -0.05306890f, -0.04369939f, 
    -0.03133674f, -0.03503232f, 0.00239202f, -0.00021362f, -0.03134908f, 0.03491160f, 0.03730277f, 0.00825876f, 
    -0.05526020f, -0.00103274f, 0.00622326f, -0.00072611f, -0.02442137f, -0.03059032f, -0.02452289f, 0.01112295f, 
    -0.01155550f, 0.00372861f, -0.03093816f, -0.02952988f, -0.01050118f, -0.01392388f, -0.04243842f, -0.03761950f, 
    -0.04403234f, 0.01885730f, 0.02156823f, -0.04208130f, 0.00978765f, -0.05467199f, 0.02612654f, 0.03660888f, 
    0.03973353f, 0.01520916f, 0.03227411f, -0.00897896f, -0.01745259f, 0.04307392f, -0.02695499f, 0.00732464f, 
    0.00321206f, -0.03371656f, -0.00779318f, -0.02202136f, 0.00952759f, -0.03437083f, 0.04243161f, 0.00053141f, 
    0.03844862f, -0.00269511f, 0.02192149f, -0.01572477f, -0.00043288f, -0.04028893f, 0.01149616f, 0.04384572f, 
    -0.02731031f, 0.01050161f, -0.01277454f, -0.01263439f, -0.00127376f, -0.02966139f, -0.04876978f, 0.03237611f, 
    -0.01748552f, -0.02425075f, -0.05560064f, 0.04588995f, -0.02673612f, -0.00302724f, -0.00772614f, -0.05329861f, 
    -0.05544877f, -0.02961187f, 0.02316715f, -0.02761023f, -0.00329128f, -0.02346906f, -0.04707063f, -0.02435241f, 
    -0.04000743f, 0.03214875f, -0.00891113f, -0.02266188f, -0.05019116f, 0.00098024f, 0.00135372f, -0.02705699f, 
    0.01100727f, -0.01175169f, -0.03899697f, -0.01992661f, 0.04482329f, 0.00147939f, -0.05418297f, 0.00213192f, 
    -0.04967697f, 0.01980197f, -0.02545680f, -0.04982385f, 0.00383846f, 0.00230897f, 0.01510333f, 0.02303094f, 
    -0.03393994f, 0.00974066f, 0.02883792f, -0.02029156f, -0.00162845f, 0.01128366f, -0.00713303f, 0.00810244f, 
    -0.02695856f, 0.03111818f, 0.00438274f, -0.02023600f, 0.03418429f, -0.04491585f, -0.05331239f, -0.05483199f, 
    0.01705668f, -0.04344123f, -0.01807756f, 0.00460263f, -0.03178639f, 0.01283775f, 0.01664277f, -0.02111905f, 
    0.01700262f, -0.04613613f, 0.03397786f, 0.01796242f, -0.04214621f, -0.03129618f, 0.03405917f, 0.04336829f, 
    0.02167754f, -0.02251703f, 0.02398057f, 0.04006549f, 0.03270222f, -0.02542298f, 0.03625795f, -0.00949502f, 
    -0.03416814f, -0.00272737f, -0.04346723f, 0.01545874f, -0.02335974f, 0.03790794f, -0.04428581f, -0.03435628f, 
    0.03143619f, -0.01734937f, 0.03919699f, -0.02740282f, -0.01683590f, -0.01858101f, -0.02997440f, -0.04139346f, 
    -0.29794452f, 0.16232842f, 0.01766525f, 0.06177028f, 0.04951064f, 0.06063188f, -0.05255216f, 0.20248902f, 
    -0.04489909f, -0.05924712f, 0.08451491f, -0.02169011f, 0.16702756f, -0.03203170f, -0.02914426f, -0.12621343f, 
    -0.14610735f, 0.03930839f, 0.00934047f, 0.06850266f, 0.11725659f, -0.05395398f, 0.04577778f, 0.06655487f, 
    -0.16439274f, -0.10275169f, 0.04519144f, 0.10899104f, 0.03580988f, 0.11597314f, 0.05885661f, -0.08097414f, 
    -0.00380603f, 0.06661917f, -0.03633989f, -0.05028639f, -0.02216834f, -0.11849809f, -0.05998933f, 0.00889640f, 
    -0.02342630f, -0.08778340f, 0.07957754f, 0.06994617f, 0.11393987f, 0.07835819f, 0.04405388f, -0.04254874f, 
    0.04117752f, -0.10918392f, -0.12045767f, -0.11339568f, 0.00809939f, 0.02198278f, 0.06542504f, 0.14881559f, 
    0.02669933f, -0.03974578f, -0.09957106f, -0.00524312f, -0.09794600f, 0.35666877f, -0.18366209f, 0.06256782f, 
    0.10360910f, -0.03157838f, -0.10653498f, 0.00950380f, -0.01306104f, -0.01465686f, 0.11891643f, -0.10838348f, 
    -0.31634229f, -0.05681118f, 0.16714263f, -0.15788592f, -0.04838307f, -0.04115939f, 0.02509330f, 0.04720500f, 
    0.07317775f, -0.01541682f, -0.00846182f, -0.02831504f, -0.06847341f, -0.13050972f, 0.22540313f, -0.09514168f, 
    -0.05031903f, -0.00803237f, 0.02838531f, 0.02762344f, 0.00307915f, -0.01604990f, 0.01298810f, -0.01591621f, 
    -0.08343719f, 0.06832713f, 0.04526930f, -0.12677985f, -0.00357482f, -0.02422693f, 0.05457281f, 0.06442201f, 
    -0.01276000f, 0.08891375f, 0.01974235f, 0.02588265f, 0.08843217f, 0.15057480f, 0.01577463f, 0.08655560f, 
    -0.11076389f, -0.02936061f, 0.07290237f, 0.05856220f, -0.09117610f, -0.04194966f, 0.09390417f, 0.03252074f, 
    0.17651738f, -0.07546434f, -0.02001136f, 0.19229481f, -0.06373213f, -0.00217585f, 0.09919819f, -0.01375362f, 
    0.06037430f, -0.03252525f, -0.00463363f, 0.13138202f, 0.12057935f, 0.05207257f, 0.02832057f, 0.09631420f, 
    -0.05522855f, 0.01545011f, 0.09425981f, 0.04527301f, 0.05399213f, 0.10151924f, 0.04157520f, 0.05576827f, 
    0.18913165f, -0.14517415f, -0.09432514f, -0.30461198f, 0.08287939f, -0.02185454f, 0.02199063f, 0.03299040f, 
    0.02194800f, -0.04165470f, 0.09153684f, 0.06450940f, -0.11995785f, -0.00084670f, 0.20115206f, -0.28378105f, 
    -0.11181802f, 0.12037726f, 0.08439199f, 0.04118202f, -0.04245930f, -0.05079707f, -0.07757532f, -0.03621846f, 
    -0.25433055f, -0.14910851f, -0.02863470f, 0.29258421f, 0.06634586f, -0.02731642f, 0.12998131f, 0.02809727f, 
    -0.03289394f, -0.01653788f, 0.00530943f, 0.02475047f, -0.35958862f, 0.04835162f, 0.24165580f, 0.06153370f, 
    0.06931803f, 0.15050778f, -0.01813430f, 0.03056734f, -0.04415873f, -0.02065725f, -0.05799488f, -0.03321902f, 
    0.02767061f, -0.04208199f, 0.29986793f, 0.02561570f, -0.07936304f, -0.03916666f, 0.02731887f, -0.04449593f, 
    -0.02428375f, 0.06836353f, 0.03599579f, -0.01508821f, 0.12221964f, 0.08972195f, -0.03411186f, 0.02758742f, 
    -0.07150294f, 0.06988160f, 0.07463966f, 0.13386650f, 0.07932357f, 0.06103511f, 0.00659850f, 0.06981225f, 
    -0.06766646f, -0.11736125f, -0.09560275f, 0.01820176f, 0.04144926f, -0.01318120f, 0.06077986f, 0.04254327f, 
    0.01404118f, 0.00560585f, -0.08409983f, 0.04994646f, 0.02910846f, 0.01114873f, 0.27807698f, -0.04837762f, 
    0.08633058f, 0.08315633f, 0.08543474f, 0.12940660f, -0.10334743f, -0.03508496f, 0.06371913f, 0.09493492f, 
    0.09882920f, 0.03583682f, 0.01219267f, -0.21533760f, 0.00256140f, 0.05734320f, -0.03202962f, 0.01306859f, 
    0.04263484f, 0.13459790f, -0.02541066f, 0.05549189f, -0.13258323f, -0.06492285f, 0.01536544f, 0.02648605f, 
    -0.07452022f, -0.07023366f, 0.01271163f, 0.08592201f, 0.02684003f, 0.03847527f, 0.04967382f, 0.05513670f, 
    -0.05834577f, -0.10716894f, 0.24700901f, -0.21392967f, 0.04756328f, 0.11061093f, 0.05615246f, 0.09995335f, 
    0.09331921f, 0.12012896f, -0.03221053f, 0.13309136f, -0.06414416f, 0.00388586f, 0.07493038f, 0.06342445f, 
    0.09568327f, -0.01680050f, 0.00739200f, 0.04479598f, -0.07072496f, 0.10736392f, 0.03214230f, 0.10592172f, 
    -0.18538046f, 0.03626805f, 0.09297603f, 0.08016337f, -0.13486278f, -0.04090161f, -0.06292843f, -0.08821209f, 
    0.09226788f, 0.03900994f, -0.02144121f, 0.08149338f, -0.29801372f, 0.01451720f, -0.09799566f, -0.00772097f, 
    -0.09093601f, -0.03689660f, 0.03012166f, -0.02650991f, -0.00170710f, 0.10148700f, 0.03259044f, -0.12440921f, 
    0.06500641f, -0.13149454f, -0.11308732f, 0.04150027f, 0.15729268f, -0.05177357f, 0.11651921f, 0.12744094f, 
    0.04867453f, 0.04636689f, 0.02648263f, 0.10611218f, -0.20723844f, 0.09087189f, 0.16812561f, 0.11523071f, 
    -0.03542385f, 0.01043223f, -0.02254551f, 0.03017066f, -0.06629420f, -0.06709760f, -0.03051121f, -0.02055779f, 
    -0.05724074f, 0.22501954f, -0.12605496f, 0.26501754f, 0.18448824f, 0.04700351f, 0.06047912f, -0.00998655f, 
    0.08866337f, -0.04630952f, 0.06736480f, 0.08931220f, -0.02688196f, -0.09720027f, -0.04003074f, 0.03140952f, 
    -0.06376027f, -0.04355426f, 0.07933419f, 0.05004124f, -0.00779216f, 0.02974952f, 0.11357808f, 0.12390231f, 
    0.01967732f, 0.01640571f, 0.18295304f, -0.19974682f, 0.06168969f, 0.03054452f, -0.03301999f, 0.08032066f, 
    0.13129972f, 0.02719523f, -0.03571892f, -0.08253933f, 0.22933918f, -0.06536436f, -0.01035556f, -0.34655619f, 
    0.06941878f, 0.01004444f, 0.02174193f, 0.08334915f, -0.01146826f, -0.05291311f, -0.03540945f, 0.07603122f, 
    -0.02185619f, -0.04140228f, 0.03323109f, -0.02741445f, -0.03065724f, 0.03832081f, -0.02292363f, -0.00446135f, 
    -0.00580129f, 0.00755496f, -0.03984221f, -0.02804743f, -0.01814188f, -0.04122512f, 0.03497035f, -0.03106223f, 
    -0.02195833f, -0.02903883f, 0.01112660f, -0.05356551f, 0.01896759f, -0.00020907f, -0.05328525f, -0.01595649f, 
    0.00261395f, -0.03684641f, -0.03159320f, 0.01470488f, -0.02023195f, -0.03289422f, -0.00774546f, -0.01738235f, 
    0.01051435f, 0.02929960f, 0.01331165f, 0.01734956f, 0.01267960f, 0.00737741f, -0.00179527f, -0.03852625f, 
    0.03921532f, 0.02910660f, 0.04214188f, -0.04092378f, 0.02123043f, -0.00435599f, -0.03853243f, -0.04413432f, 
    0.03629496f, 0.03279160f, -0.04254514f, 0.00488016f, -0.04772059f, 0.01562443f, -0.00664933f, 0.02326310f, 
    0.02681815f, 0.03180144f, -0.02260188f, -0.01115056f, -0.01941846f, -0.04968520f, 0.03196036f, -0.04446225f, 
    -0.05581393f, -0.02286743f, 0.03089681f, 0.02735267f, -0.05505057f, -0.01904228f, 0.03231785f, -0.04339613f, 
    -0.04231301f, -0.02100046f, -0.03826773f, -0.00130908f, -0.01315485f, -0.02024897f, 0.00592003f, 0.02465821f, 
    0.02512697f, -0.02188065f, -0.00865908f, 0.04221774f, -0.00417092f, -0.00181259f, 0.01421460f, -0.04629240f, 
    -0.00435173f, -0.04250071f, -0.04438435f, -0.02641809f, -0.00572157f, 0.02495575f, 0.01149649f, 0.01846493f, 
    0.01026064f, -0.02031020f, 0.04381818f, 0.01124492f, -0.03631062f, 0.02383920f, 0.00193485f, -0.02234127f, 
    -0.00648098f, 0.03569163f, 0.00395845f, -0.00894449f, -0.00795304f, 0.03269089f, -0.04285017f, 0.04010659f, 
    -0.03186720f, -0.03089084f, 0.04366330f, -0.02613125f, -0.05252342f, -0.00214572f, 0.00316984f, 0.03023888f, 
    -0.03506264f, 0.02919407f, 0.03371144f, -0.04942944f, -0.01674626f, -0.00962333f, -0.02473688f, -0.03561215f, 
    -0.01386704f, -0.04652700f, -0.02095672f, 0.04053176f, 0.00537852f, 0.01880067f, -0.00627084f, -0.02399974f, 
    0.03717295f, -0.03398504f, -0.03126834f, 0.03307602f, 0.01122042f, 0.03315216f, -0.01350495f, 0.03504163f, 
    -0.02127801f, -0.03427560f, -0.00625001f, -0.04873658f, -0.02880904f, 0.00631698f, -0.02673169f, -0.01092090f, 
    0.01658350f, -0.00597231f, 0.02025866f, 0.01133786f, 0.03818663f, 0.01371447f, 0.04475310f, 0.02813516f, 
    0.00322250f, 0.01256434f, 0.04416336f, 0.00977624f, -0.04038829f, 0.03374731f, -0.00384486f, -0.02552217f, 
    0.00407220f, -0.02650791f, 0.00367262f, -0.01534110f, 0.02558892f, 0.00481221f, 0.00194626f, 0.04462197f, 
    -0.04324518f, -0.05151106f, -0.00915130f, -0.02482367f, 0.02542051f, -0.03914842f, -0.00143081f, -0.02679817f, 
    -0.03224177f, 0.00720546f, -0.03743864f, 0.02025459f, -0.04485746f, -0.04645789f, 0.03724216f, -0.03473859f, 
    -0.02536922f, -0.03398666f, -0.04143288f, -0.03155001f, -0.02177703f, 0.00605890f, 0.01614198f, -0.02157138f, 
    0.02574054f, -0.00194661f, -0.00705230f, -0.00065875f, -0.01342485f, -0.04884697f, 0.03118081f, -0.05495242f, 
    -0.05360262f, -0.02698102f, 0.04145312f, -0.02484380f, -0.03486925f, -0.04987757f, 0.00535176f, -0.05406628f, 
    0.02278618f, 0.00443890f, 0.01579905f, -0.01926630f, 0.03230105f, 0.00344923f, -0.02285690f, 0.02921388f, 
    -0.03351208f, 0.01132635f, 0.03276295f, 0.03972847f, -0.00352577f, -0.01714895f, -0.01153737f, -0.00475493f, 
    0.03819282f, -0.02818231f, 0.03480154f, -0.05225359f, 0.02717879f, 0.00174368f, -0.02060673f, -0.00954415f, 
    -0.01712671f, -0.01479246f, -0.05334302f, -0.01243941f, -0.01766380f, 0.03229461f, 0.04539469f, -0.02332031f, 
    0.03586740f, -0.01965691f, 0.02370967f, 0.03335930f, 0.04371104f, -0.05434598f, 0.02342229f, -0.04086747f, 
    0.03672469f, 0.02486567f, 0.03440303f, -0.01874959f, -0.03701615f, -0.04056719f, 0.03289246f, -0.04759743f, 
    -0.05121310f, -0.02847161f, 0.04438341f, -0.00966725f, -0.03639678f, 0.00011449f, 0.04126979f, -0.04250277f, 
    0.00140000f, 0.01537641f, -0.03715210f, 0.03266865f, -0.01603236f, 0.03243032f, 0.03559626f, 0.02971935f, 
    0.00300988f, 0.00513385f, -0.04774659f, 0.01058509f, -0.05373800f, -0.04951045f, 0.03018162f, 0.03394090f, 
    0.00174237f, 0.02532536f, -0.00594730f, 0.04472467f, -0.04595008f, -0.02447810f, 0.00589275f, -0.01989735f, 
    -0.03787433f, -0.04415081f, 0.02943324f, 0.04525208f, 0.01391156f, -0.03077964f, -0.05411568f, 0.01502099f, 
    -0.04006640f, -0.02964598f, -0.04051505f, -0.04764214f, 0.01175344f, -0.01697795f, -0.01085924f, 0.01701085f, 
    -0.02412347f, -0.00191498f, 0.02969352f, 0.00711449f, -0.03162146f, 0.01875354f, 0.01414734f, 0.04196284f, 
    0.02506113f, -0.02806258f, -0.00625022f, 0.02085902f, 0.01899305f, -0.02010616f, -0.03890999f, -0.01645228f, 
    -0.04767558f, 0.01261836f, -0.03913487f, -0.03611427f, 0.00201233f, -0.01780165f, -0.01695744f, -0.05447106f, 
    0.04204902f, -0.05014043f, -0.00069546f, -0.03271299f, 0.03256329f, -0.03113532f, 0.01965554f, 0.00530378f, 
    -0.03006561f, -0.04881502f, 0.04024665f, -0.05093772f, -0.00873881f, -0.04731057f, -0.03369062f, 0.03911617f, 
    0.00486983f, -0.00639120f, -0.04851609f, -0.04442075f, -0.00947890f, 0.03939216f, -0.03142872f, -0.02143029f, 
    0.01013291f, 0.01254289f, -0.00864701f, 0.01874623f, -0.04960536f, 0.03970658f, 0.01631036f, 0.01003764f, 
    0.00372326f, 0.02543316f, 0.03392450f, 0.02026186f, 0.03120429f, -0.01608029f, -0.00865148f, 0.04330916f, 
    -0.00571785f, 0.05774484f, -0.05120464f, -0.05042309f, -0.00335566f, 0.03406311f, 0.02455609f, -0.03045388f, 
    0.04852177f, 0.12422389f, 0.02753791f, -0.09691773f, 0.02834453f, 0.09930503f, -0.02281624f, -0.09778427f, 
    -0.03916140f, -0.07706565f, 0.09517114f, 0.10169303f, 0.07585127f, -0.03154759f, -0.19130577f, -0.07927614f, 
    0.00955426f, 0.13088509f, -0.05947623f, -0.00514636f, 0.09123079f, 0.07293301f, 0.11814047f, -0.04011540f, 
    0.02245110f, 0.00655573f, 0.03120729f, 0.00441748f, 0.03812496f, 0.02318405f, 0.09864497f, 0.06802924f, 
    0.09246751f, -0.03113875f, 0.21859632f, -0.13261218f, 0.27659005f, 0.09018964f, 0.03183291f, -0.24472640f, 
    0.02521298f, -0.01304853f, 0.05554761f, -0.03138971f, 0.01663205f, 0.00335889f, 0.15390660f, 0.05796535f, 
    0.03186020f, -0.06843874f, 0.01600279f, -0.00312161f, -0.07392905f, -0.05518703f, 0.14056447f, 0.13031159f, 
    -0.00836055f, 0.03369005f, -0.00339405f, -0.09852508f, -0.10598119f, 0.09229741f, 0.04811390f, 0.17012018f, 
    -0.03956974f, -0.10921664f, -0.09611858f, 0.01541713f, 0.13715173f, 0.04842265f, 0.15783308f, -0.04277920f, 
    -0.07143387f, -0.02288142f, 0.19729264f, -0.02757618f, 0.09421533f, 0.06563438f, 0.01756650f, 0.00218474f, 
    -0.04448050f, 0.07770077f, -0.11349411f, 0.00947264f, 0.60357165f, 0.13288036f, 0.15517934f, -0.00856369f, 
    0.08390100f, 0.02410953f, 0.07158037f, 0.00918484f, -0.00652885f, 0.02188076f, -0.01129993f, 0.04557440f, 
    -0.05597505f, 0.15930738f, -0.19081804f, -0.10411621f, 0.10278982f, 0.04265202f, -0.04196220f, -0.04032588f, 
    0.02369216f, 0.07290452f, -0.06641418f, -0.04560253f, 0.13679999f, 0.06993974f, 0.00960648f, -0.10711523f, 
    -0.05731753f, 0.02781335f, -0.05590836f, 0.01087539f, 0.10633253f, 0.07042336f, 0.04120194f, 0.04690649f, 
    -0.09938234f, -0.23280078f, -0.12794943f, 0.02039809f, -0.01015688f, 0.00960096f, 0.03976712f, 0.09534190f, 
    0.11178876f, 0.12962167f, 0.09146465f, 0.07752469f, 0.06283303f, 0.18256764f, 0.07925549f, -0.09413151f, 
    -0.00965016f, 0.00374754f, 0.02996372f, 0.03687557f, 0.12757315f, -0.07389206f, -0.13293788f, -0.08153199f, 
    -0.00408958f, 0.03100230f, 0.23937067f, 0.03564805f, -0.11775351f, 0.11213268f, 0.07384831f, 0.03857931f, 
    -0.09587225f, -0.10257471f, 0.07013065f, -0.04251358f, 0.17298184f, 0.29863384f, 0.01305567f, -0.23241314f, 
    0.02937965f, 0.01168984f, -0.05154187f, 0.11750307f, 0.08560090f, -0.10759291f, 0.16886979f, -0.09927414f, 
    -0.04190112f, 0.12592708f, -0.07537039f, 0.07338458f, 0.03605884f, -0.03742445f, 0.13296609f, -0.07942232f, 
    0.04287561f, 0.14637139f, -0.01018302f, 0.13976848f, -0.35771567f, -0.00506620f, 0.07617610f, -0.07619448f, 
    0.02206975f, 0.13507548f, -0.14674670f, -0.01718387f, 0.06721311f, -0.03295135f, -0.02207124f, -0.09931888f, 
    -0.04896707f, 0.02826212f, 0.17314288f, 0.16515741f, -0.03960308f, -0.02583900f, 0.02387160f, -0.13406098f, 
    0.03080171f, 0.14626992f, -0.05780907f, 0.00224136f, 0.03815940f, 0.07588090f, 0.04728400f, 0.08495066f, 
    -0.00371484f, -0.05056331f, 0.03602071f, 0.16600586f, 0.09087110f, 0.07016890f, -0.11250432f, -0.06474423f, 
    0.14931846f, 0.01991208f, 0.07404586f, -0.01449618f, 0.06776262f, -0.04746400f, -0.00700035f, 0.02647758f, 
    0.01159251f, -0.07238893f, -0.08329508f, 0.02677083f, -0.32154348f, 0.26942122f, 0.02097857f, 0.13851979f, 
    0.02012972f, -0.03865188f, 0.13919368f, 0.06852391f, 0.09473794f, 0.11418704f, 0.00002845f, 0.03037219f, 
    -0.03915012f, 0.11780193f, 0.12083483f, 0.21487679f, -0.06959741f, 0.04144024f, 0.00190935f, -0.03537392f, 
    -0.13563904f, 0.08325595f, 0.04416546f, 0.03579948f, -0.22664498f, 0.09321395f, -0.21730241f, -0.11609455f, 
    0.03152275f, 0.05690230f, -0.01288546f, 0.09994780f, -0.07624257f, -0.08960838f, -0.03324831f, -0.09308840f, 
    0.07939529f, 0.05114614f, 0.21463035f, -0.12302057f, -0.01323659f, 0.01096184f, 0.03458625f, 0.02555727f, 
    0.06650218f, -0.12057929f, -0.04628249f, 0.00464230f, 0.19674981f, -0.03911153f, -0.05328543f, -0.24391133f, 
    0.05221317f, 0.16763823f, -0.06382824f, -0.09967189f, -0.11746417f, 0.03053153f, 0.07722193f, -0.00429463f, 
    0.21530549f, 0.01059766f, 0.05167296f, -0.04934075f, -0.02138298f, 0.07387889f, 0.04687164f, -0.09106421f, 
    0.04382754f, 0.07765308f, 0.01082636f, -0.00004803f, -0.26170331f, -0.04169726f, -0.28769392f, -0.05200685f, 
    0.04810264f, -0.02450303f, 0.06053762f, -0.07716163f, 0.03851000f, 0.15757056f, -0.03007550f, -0.01385233f, 
    0.02454161f, -0.13915551f, 0.08923964f, -0.10785118f, -0.02137945f, -0.08237864f, 0.10673089f, 0.01412257f, 
    0.08595569f, -0.05563615f, 0.06429136f, -0.05447251f, -0.16437393f, 0.01927191f, -0.00299695f, -0.08419887f, 
    0.08529389f, -0.09445638f, -0.07273122f, -0.03000687f, 0.03575598f, 0.00274238f, 0.18137754f, 0.16200803f, 
    -0.18985318f, 0.12256532f, -0.16608663f, -0.00059289f, 0.19475336f, -0.00738732f, -0.04251255f, 0.02504553f, 
    0.04278360f, -0.10173253f, 0.04614703f, 0.03124954f, -0.13854459f, -0.06070519f, -0.22328089f, 0.14270966f, 
    0.06569391f, -0.01609531f, 0.13672383f, 0.04480918f, 0.01871564f, 0.03428068f, 0.07915419f, -0.02785737f, 
    -0.13824908f, 0.10961195f, 0.16547799f, 0.17852634f, 0.03352450f, 0.04286083f, 0.05641704f, -0.01004938f, 
    0.17999265f, 0.25925899f, 0.03519425f, 0.03205713f, 0.09612370f, 0.04164015f, 0.06437091f, 0.19123928f, 
    -0.19123055f, -0.18232267f, 0.10037083f, 0.09125984f, -0.17426975f, 0.02881279f, 0.05203867f, 0.01561892f, 
    0.20269568f, 0.09227363f, 0.05486491f, -0.08504231f, 0.00290622f, 0.05657779f, 0.00877926f, -0.00592738f, 
    -0.01829454f, 0.06447234f, 0.02873651f, 0.06593901f, -0.10251104f, 0.17775021f, 0.09921660f, -0.11039406f, 
    0.13302547f, -0.00765847f, 0.08512001f, -0.09414414f, -0.08717047f, -0.01861785f, 0.11172451f, -0.00726279f, 
    0.06938272f, -0.08486698f, 0.10531091f, -0.02955678f, -0.12435228f, -0.08090727f, 0.04170780f, 0.00699459f, 
    0.12736495f, 0.01594243f, 0.17431898f, -0.08701364f, 0.30803972f, 0.16458984f, 0.09051800f, -0.04961149f, 
    -0.05076863f, -0.04251534f, 0.01415269f, -0.01120051f, -0.02045601f, 0.00035234f, 0.01404398f, -0.03471772f, 
    0.09840883f, -0.08290377f, 0.01275458f, 0.04123800f, -0.10594559f, -0.05365160f, -0.03722320f, 0.14213344f, 
    0.02050742f, 0.02413650f, 0.05469649f, -0.01526467f, 0.39142877f, -0.06777135f, 0.06694009f, 0.00812915f, 
    -0.11993144f, 0.11994132f, -0.12639692f, 0.06015211f, 0.05262035f, 0.03397732f, 0.06865676f, 0.03616704f, 
    -0.21476856f, -0.01786376f, 0.10044676f, 0.12436672f, -0.04662540f, 0.23910578f, 0.06265139f, -0.02926082f, 
    -0.08806084f, 0.05141644f, -0.04925562f, 0.02918378f, 0.47578758f, 0.07368989f, -0.03862787f, -0.05405280f, 
    0.13430950f, 0.09781219f, -0.00468583f, 0.05927835f, -0.05715317f, 0.04507948f, -0.03619142f, -0.03390013f, 
    -0.03975488f, 0.01213268f, 0.06040848f, -0.17471100f, 0.06207218f, -0.04533181f, -0.14323615f, -0.03807936f, 
    -0.01848605f, -0.03728994f, 0.03750617f, 0.01880219f, 0.31869215f, 0.15518507f, -0.05427809f, -0.07028043f, 
    0.09493730f, -0.12950687f, -0.05928953f, -0.16716157f, -0.03552836f, 0.14067395f, -0.04593506f, 0.04268948f, 
    -0.07169891f, 0.02473272f, -0.06519741f, -0.00949857f, -0.06354199f, -0.00316546f, 0.08957265f, 0.15364882f, 
    -0.11618320f, -0.03553603f, 0.11285383f, -0.01011603f, -0.14208287f, 0.01740863f, -0.02403437f, -0.00908054f, 
    0.02946803f, 0.06572642f, 0.06502770f, 0.04203272f, 0.01248188f, -0.06045469f, -0.08753024f, 0.13724500f, 
    0.01750687f, 0.06780839f, 0.08273166f, 0.05889481f, -0.05758053f, -0.06309099f, 0.04276252f, 0.05516255f, 
    -0.00660961f, -0.08547986f, 0.12065735f, -0.05118910f, 0.43304542f, 0.30339622f, 0.04846918f, 0.15559693f, 
    0.10700170f, -0.03359298f, 0.06790742f, 0.04611442f, 0.00270011f, 0.02636502f, -0.04587799f, -0.09924145f, 
    0.51131684f, 0.02413029f, 0.05462137f, -0.11562318f, -0.16273758f, 0.18910891f, -0.00405853f, -0.04504967f, 
    0.02670404f, 0.08890487f, 0.03747840f, -0.04213986f, -0.44642356f, -0.07756846f, -0.20005853f, 0.05530357f, 
    -0.03542094f, 0.07837492f, -0.03157119f, -0.03479601f, -0.10596065f, 0.06625862f, 0.01308952f, -0.06552738f, 
    0.16000935f, -0.04815710f, -0.04776824f, 0.15652493f, -0.02450429f, 0.07842405f, 0.05480267f, -0.15613425f, 
    -0.08715982f, -0.00376903f, -0.03826306f, -0.00114733f, 0.01766312f, 0.10835530f, 0.02160529f, 0.08770154f, 
    0.09140643f, 0.04604542f, -0.11063160f, 0.07513791f, -0.07470098f, -0.01580797f, -0.04418526f, -0.02340535f, 
    0.02439116f, 0.06514188f, 0.01887605f, -0.09512673f, -0.06512264f, -0.02252663f, -0.11033291f, -0.08825050f, 
    -0.04904205f, 0.04818573f, 0.01824721f, 0.07302178f, -0.24788219f, -0.19898140f, -0.08825906f, 0.00342808f, 
    0.00065403f, -0.13529469f, 0.16259781f, -0.10462624f, 0.05855067f, 0.03313059f, -0.00236024f, 0.08540386f, 
    -0.02292210f, 0.15462215f, 0.08365855f, 0.08125491f, -0.07185949f, -0.03957674f, -0.05292774f, -0.01564219f, 
    -0.02285340f, 0.04208642f, -0.04919890f, 0.10926362f, 0.10724458f, -0.03268463f, 0.08891306f, -0.11366840f, 
    0.05063276f, 0.14273338f, -0.02470564f, 0.14851175f, -0.20204577f, -0.01555153f, 0.03021199f, -0.12774609f, 
    -0.08344164f, 0.10614517f, 0.02469818f, -0.01119265f, -0.02821241f, -0.19571970f, -0.02911481f, -0.02020493f, 
    -0.00088935f, -0.09579431f, 0.00291359f, -0.07454371f, -0.02933340f, -0.04337084f, -0.00528715f, -0.15924831f, 
    0.06271552f, 0.05861915f, -0.10867056f, -0.02482026f, -0.02946692f, -0.12913600f, 0.03144539f, -0.10047389f, 
    -0.05291606f, -0.04704668f, 0.06394543f, 0.00335437f, 0.07675995f, -0.00890018f, -0.02300273f, -0.05497982f, 
    0.03043797f, -0.03777672f, 0.02870630f, -0.08593608f, -0.02845040f, -0.06141582f, 0.08535043f, -0.01031684f, 
    -0.01619128f, 0.04671437f, 0.11339833f, -0.11063389f, 0.07388937f, 0.03221794f, 0.03331765f, 0.04966318f, 
    -0.23745057f, 0.05744038f, -0.00320205f, 0.00976276f, -0.13794163f, -0.02625586f, -0.08426503f, -0.02006812f, 
    0.09358668f, 0.01618366f, 0.01342552f, -0.06063324f, 0.02344713f, -0.08003493f, 0.07005209f, 0.08627019f, 
    0.06639055f, 0.12409431f, -0.09652507f, -0.05048491f, 0.13699873f, 0.14758350f, 0.11968248f, -0.05111547f, 
    -0.37754005f, -0.15545987f, 0.06082537f, 0.04507915f, -0.07667901f, 0.08344916f, -0.06735297f, 0.00069562f, 
    0.07371997f, -0.06685711f, 0.01822033f, -0.09871857f, 0.01574918f, -0.04625297f, 0.15198486f, -0.11301804f, 
    0.04027994f, 0.00560826f, 0.00129277f, -0.06010566f, 0.01716443f, -0.01221316f, 0.06992988f, -0.14863561f, 
    -0.10591450f, 0.07169902f, 0.12857093f, 0.09021857f, 0.01682391f, 0.01397865f, 0.03361820f, -0.12005418f, 
    0.01829576f, -0.08513168f, 0.05380890f, 0.03653272f, 0.04424496f, 0.21087258f, -0.06022379f, 0.23818296f, 
    -0.08544551f, -0.07376617f, 0.23785260f, -0.03973805f, -0.16782713f, 0.05915423f, 0.00187090f, 0.12512808f, 
    -0.03457636f, -0.00570952f, -0.13571386f, 0.04541374f, 0.02859820f, 0.10828192f, -0.00838487f, -0.06305711f, 
    0.03897569f, -0.02511654f, 0.09096122f, 0.01490000f, -0.08091938f, 0.12454875f, 0.31067842f, -0.01541915f, 
    0.10512743f, 0.02270390f, -0.01923972f, -0.07091931f, 0.10330151f, 0.04888768f, 0.01582734f, -0.11954294f, 
    -0.02701714f, 0.11724953f, 0.08683647f, -0.00931355f, 0.14319555f, 0.10897566f, 0.16426554f, -0.08864476f, 
    0.03016795f, -0.03240829f, 0.03083038f, -0.08332868f, -0.23412907f, -0.09679069f, 0.18950306f, 0.07525425f, 
    -0.04669058f, 0.02224293f, -0.04661807f, -0.17759673f, -0.00073710f, 0.12024353f, 0.25300053f, 0.07630903f, 
    -0.15504116f, 0.06169384f, -0.00347595f, -0.12939213f, -0.06624362f, -0.01660485f, -0.04311363f, -0.13258789f, 
    0.10261010f, 0.11113407f, 0.03342957f, -0.07828616f, -0.02608181f, 0.02641677f, 0.10445298f, 0.01474675f, 
    0.09182956f, -0.01196607f, 0.13398403f, 0.14583747f, -0.03989948f, 0.06091344f, 0.14313239f, 0.04183654f, 
    0.41444221f, 0.18955909f, -0.11801513f, 0.08055283f, 0.00493298f, 0.03738192f, -0.12723237f, 0.07663910f, 
    0.05360064f, 0.06910389f, -0.05665780f, 0.02067911f, 0.37325180f, -0.02180737f, 0.12200954f, 0.08223088f, 
    0.02599715f, 0.11951721f, -0.14279081f, 0.06225221f, -0.01363328f, -0.04808746f, 0.11973029f, 0.12467882f, 
    0.17425048f, -0.01730217f, -0.06797877f, 0.09207647f, 0.09469007f, 0.02550949f, -0.10628006f, -0.06575273f, 
    0.06862546f, -0.04619113f, -0.04830872f, -0.10128348f, -0.18034387f, -0.19159321f, 0.10338828f, 0.13532998f, 
    0.03006251f, -0.08915959f, -0.01440392f, -0.00303792f, 0.03533802f, -0.01543970f, -0.01287857f, 0.10007270f, 
    -0.21240571f, 0.18524368f, -0.10026232f, -0.11682792f, -0.02019932f, -0.11599352f, 0.03994315f, 0.16286346f, 
    0.09587315f, 0.18231478f, 0.11629378f, -0.08414041f, -0.17170146f, 0.06329841f, 0.05586060f, 0.01998455f, 
    -0.04159169f, 0.01556160f, 0.06632160f, -0.09926540f, 0.08697138f, -0.06669146f, -0.19726487f, -0.06452636f, 
    0.20035051f, -0.08594181f, -0.23400442f, -0.16178405f, -0.05954721f, 0.11054864f, 0.10783834f, -0.09052685f, 
    -0.14930563f, -0.04764073f, -0.01040703f, -0.03416358f, -0.04811435f, -0.27785218f, -0.01544689f, 0.02065902f, 
    -0.04523097f, -0.03310955f, -0.09225487f, 0.09250762f, -0.07522853f, -0.05214273f, 0.13670129f, 0.00494248f, 
    0.05331603f, 0.02857905f, -0.03625709f, -0.06736817f, 0.06975606f, -0.06533378f, 0.03080505f, 0.03914877f, 
    0.02326305f, 0.12906565f, -0.01416370f, 0.02265208f, 0.76721692f, 0.26625913f, -0.24646211f, -0.01185623f, 
    0.03158541f, 0.12746012f, -0.12452138f, 0.00032944f, -0.01180535f, 0.11454163f, 0.03081666f, 0.05519393f, 
    0.25666738f, 0.07958524f, -0.04960230f, 0.12539859f, 0.03833726f, -0.13876486f, 0.04042019f, -0.00564672f, 
    -0.04490504f, -0.00194120f, -0.13565847f, -0.09151539f, 0.05434030f, 0.02672910f, 0.09636318f, 0.14133640f, 
    -0.03368966f, -0.06122239f, 0.06008597f, 0.10086338f, -0.17710519f, -0.01864564f, -0.02636143f, -0.00512622f, 
    0.07528987f, -0.05654424f, 0.12338162f, -0.05071578f, 0.04848648f, 0.01390758f, -0.06075846f, -0.02435327f, 
    0.03828591f, -0.05439956f, 0.00278626f, 0.09285820f, 0.15321635f, 0.13337122f, -0.08954632f, -0.06309795f, 
    -0.06511028f, -0.03985856f, -0.03642570f, -0.02124303f, 0.12666582f, 0.05594584f, 0.03458432f, -0.03574605f, 
    -0.13160893f, 0.12968363f, 0.16498818f, 0.06340486f, 0.15370429f, 0.05547750f, -0.00277809f, 0.06966100f, 
    -0.06507538f, -0.05438973f, 0.10978700f, 0.10202555f, 0.43814293f, 0.11059512f, -0.21661879f, 0.07020412f, 
    0.04167690f, -0.04585998f, -0.09977267f, -0.07442287f, -0.15327986f, -0.11172489f, -0.11589799f, -0.03969078f, 
    0.13059399f, -0.05449286f, 0.01751765f, 0.01020753f, -0.04790930f, 0.00566455f, 0.02327281f, 0.03872543f, 
    0.04031524f, -0.11869060f, 0.04349473f, -0.01291380f, -0.17435198f, 0.00057783f, -0.05656407f, -0.11632368f, 
    -0.13023716f, -0.00158928f, -0.04984773f, -0.06525136f, -0.08958729f, -0.07073173f, -0.05637538f, -0.09868132f, 
    0.00015740f, 0.10619445f, -0.04365443f, 0.02355082f, -0.00110377f, 0.01256454f, -0.11670631f, -0.04796669f, 
    -0.03257307f, 0.16495098f, -0.05348036f, -0.18807146f, 0.09949020f, -0.17108780f, -0.02694367f, -0.01531039f, 
    0.00318781f, -0.20822451f, 0.05988566f, -0.00781000f, 0.06430893f, -0.00642178f, -0.09885738f, -0.02673574f, 
    -0.14411348f, -0.14673631f, -0.10355325f, -0.19574846f, -0.07170611f, -0.08798314f, 0.00598365f, -0.10156602f, 
    -0.05177596f, -0.03118649f, -0.13084435f, -0.13596882f, 0.42116979f, -0.05449120f, -0.15320307f, 0.09312823f, 
    -0.02092899f, -0.25272352f, 0.00767171f, 0.08490813f, -0.05219069f, -0.00153858f, 0.15905015f, 0.06096647f, 
    0.01671326f, -0.32272369f, 0.21365368f, 0.14658520f, -0.02729169f, -0.11997420f, 0.05354750f, -0.03098190f, 
    -0.04234695f, -0.07925270f, 0.02961796f, -0.07236288f, 0.03229367f, 0.05228756f, -0.06106034f, 0.05658500f, 
    -0.01687897f, 0.04660735f, -0.04195085f, -0.02615736f, 0.13154639f, -0.10635790f, -0.03960685f, -0.01607708f, 
    0.17621452f, -0.05127601f, 0.14982469f, 0.04376749f, 0.07404634f, 0.09634311f, -0.02019774f, -0.02204763f, 
    0.06958627f, 0.21503583f, 0.07411384f, -0.04146814f, -0.04296888f, 0.30668840f, -0.18732119f, -0.11973069f, 
    -0.01606156f, -0.01553317f, -0.00011776f, -0.05316693f, -0.00900849f, 0.02403393f, 0.09374983f, 0.04936036f, 
    -0.02935654f, 0.00935109f, 0.00555597f, -0.03015076f, 0.00256680f, -0.04181364f, -0.01020123f, 0.04104589f, 
    -0.00330406f, -0.05093581f, 0.01351077f, -0.03306012f, -0.03758432f, -0.02026123f, -0.00524732f, -0.02940429f, 
    0.00800865f, -0.03639489f, -0.02396445f, 0.04504975f, 0.03288479f, -0.04421514f, -0.01847175f, -0.00240162f, 
    -0.00624359f, 0.02363860f, -0.02512163f, 0.02907159f, -0.02045719f, 0.02214002f, -0.01232595f, -0.00700912f, 
    0.00363696f, -0.00097393f, 0.04252227f, 0.01663730f, -0.03215458f, -0.00276147f, 0.04124621f, -0.03200190f, 
    -0.00967218f, 0.03393333f, -0.00860559f, 0.03865832f, -0.04114880f, 0.04230638f, -0.03075713f, 0.03210227f, 
    0.02095388f, -0.04800947f, -0.03468423f, 0.02451103f, 0.00361371f, -0.01380945f, -0.04220542f, -0.02123200f, 
    0.00548264f, -0.03222631f, -0.05290986f, 0.03491678f, 0.04399517f, -0.04332396f, -0.03751023f, 0.04509965f, 
    0.04517487f, -0.04448269f, -0.01747398f, -0.02790942f, 0.04218757f, -0.01376712f, 0.02187723f, 0.04505213f, 
    -0.04385674f, 0.03519033f, 0.01000706f, -0.03038718f, 0.01416863f, 0.03686544f, 0.00584568f, 0.01477068f, 
    -0.04785474f, -0.04120416f, -0.01911738f, -0.01389314f, -0.05258799f, 0.02263285f, -0.02690327f, -0.03412670f, 
    0.00948596f, -0.05649869f, 0.01621949f, 0.02223305f, -0.02199192f, -0.00941884f, 0.01345812f, -0.01620959f, 
    0.00655700f, 0.01038325f, 0.01879415f, -0.03448876f, -0.00237952f, -0.01165098f, -0.04057037f, 0.00419469f, 
    -0.02562989f, -0.04504556f, -0.05045052f, -0.02439457f, 0.01657782f, -0.03475447f, 0.00445460f, -0.02770050f, 
    -0.00262468f, -0.03454749f, -0.05414866f, -0.02794124f, -0.01054921f, 0.03704853f, 0.02553026f, -0.04977505f, 
    -0.03081463f, -0.04283265f, 0.00506540f, -0.05522966f, 0.04112466f, 0.03805157f, -0.04057632f, 0.01170258f, 
    -0.01602233f, -0.04632362f, 0.01033054f, -0.02510241f, -0.01978618f, -0.01454036f, -0.01877932f, 0.01577234f, 
    -0.02140802f, -0.00301879f, -0.05421723f, -0.02704281f, -0.03520290f, 0.03203744f, 0.02563424f, -0.02748151f, 
    -0.04267225f, -0.01359490f, -0.05395878f, -0.05288932f, 0.03160614f, 0.00701233f, 0.02805423f, -0.05013274f, 
    -0.04758926f, -0.03893159f, -0.00232913f, 0.02852109f, -0.02187683f, -0.01944504f, -0.04726807f, -0.00221654f, 
    -0.03165735f, 0.00750190f, -0.03159938f, 0.01567171f, 0.04350530f, -0.04587811f, 0.00079834f, -0.00448150f, 
    -0.00646665f, 0.04537557f, 0.00661785f, -0.00463883f, -0.04825499f, -0.00056694f, 0.00423419f, 0.02886997f, 
    -0.02628019f, -0.04677624f, 0.04418585f, 0.01939392f, -0.03004554f, 0.04500779f, -0.01396569f, -0.04486645f, 
    0.02486924f, 0.01491849f, 0.03593863f, 0.00196812f, 0.00044828f, 0.02613050f, 0.03542754f, -0.01064993f, 
    0.04218054f, 0.01340154f, 0.03534423f, 0.00255083f, -0.05137606f, -0.01445266f, 0.01609334f, -0.01185289f, 
    0.03007383f, -0.05631910f, -0.01772685f, -0.01059972f, -0.03083097f, -0.02291394f, 0.01265203f, -0.05587950f, 
    -0.02574349f, 0.02678172f, 0.01633011f, 0.01645531f, 0.00760457f, -0.02753202f, -0.03645948f, -0.04811339f, 
    -0.02822584f, -0.04437477f, 0.00682183f, 0.03708201f, 0.02935713f, -0.00360693f, 0.01023777f, 0.02921374f, 
    -0.04936700f, 0.02897141f, -0.00153738f, -0.00169479f, -0.05451002f, -0.01625726f, -0.01541524f, -0.04294108f, 
    0.00783653f, -0.01680498f, 0.03554228f, -0.01936526f, -0.01351630f, 0.03549740f, -0.04265806f, -0.04206267f, 
    0.03290946f, 0.01753567f, 0.03345675f, -0.02044602f, -0.03990463f, 0.03924090f, 0.00689379f, -0.01060904f, 
    -0.00639699f, -0.05630596f, -0.03623844f, -0.02220314f, -0.04112298f, -0.00438136f, 0.02182236f, -0.02585110f, 
    -0.01842001f, -0.02222792f, -0.03418167f, 0.01979941f, 0.00772603f, 0.03964868f, -0.03505474f, -0.00560375f, 
    0.02336303f, -0.03628378f, -0.04351138f, 0.00898173f, -0.05381763f, -0.05564604f, -0.04302125f, 0.03899239f, 
    -0.01128043f, -0.03085873f, 0.01948227f, -0.05283260f, -0.00657635f, 0.00274341f, 0.01661581f, -0.03808442f, 
    -0.03150525f, 0.01467483f, -0.05382208f, -0.05560087f, 0.01462442f, 0.02957264f, 0.04314676f, 0.02639555f, 
    -0.03134274f, -0.03354079f, -0.00968246f, -0.04469611f, 0.01398113f, -0.03305797f, 0.04256808f, -0.02829035f, 
    0.03277080f, -0.05597120f, 0.01420922f, -0.01012861f, 0.04010420f, 0.00152349f, -0.00431963f, 0.03779365f, 
    -0.00860088f, -0.00478979f, -0.02004502f, -0.00310725f, 0.01253405f, -0.01502770f, 0.03386483f, 0.04331646f, 
    -0.03879583f, -0.00631875f, -0.02394303f, 0.01594917f, 0.02312719f, -0.01191645f, -0.04847725f, -0.00923998f, 
    -0.05274052f, -0.03441094f, 0.01842364f, -0.02062842f, -0.05116954f, 0.00342319f, 0.01460409f, -0.05507214f, 
    0.00137459f, -0.01981045f, -0.00243793f, 0.03274114f, -0.03925423f, -0.03936893f, -0.02164993f, 0.02717457f, 
    -0.01082340f, -0.05051506f, 0.01690587f, -0.04570674f, -0.02601290f, -0.04369497f, 0.02871503f, 0.01910975f, 
    0.00920736f, -0.04034583f, 0.02795767f, -0.02826750f, 0.02201051f, -0.04164586f, 0.03790618f, -0.04978057f, 
    0.04362530f, 0.02237896f, -0.03324874f, -0.01467249f, -0.03015747f, -0.00384225f, 0.02225618f, -0.00895460f, 
    0.03424999f, 0.00041561f, 0.03456479f, 0.00591729f, -0.01928409f, 0.01505206f, -0.04505381f, -0.05428958f, 
    -0.02465844f, -0.03977963f, 0.00523317f, 0.00248115f, 0.03556972f, -0.00504633f, -0.02666659f, -0.03136704f, 
    0.02771717f, -0.00392859f, -0.00998254f, -0.04532593f, -0.03275383f, -0.03577641f, 0.00124729f, 0.00392028f, 
    -0.00103229f, -0.02109430f, -0.04384226f, 0.00415210f, -0.01099119f, 0.04177175f, 0.02387904f, -0.00850516f, 
    -0.02203440f, -0.05325598f, -0.03342185f, -0.00694764f, 0.04524023f, -0.04218928f, -0.02177956f, 0.00926473f, 
    -0.03321427f, -0.04757350f, 0.00352835f, 0.00797544f, -0.00075886f, -0.03621720f, -0.03661732f, -0.02854997f, 
    -0.03640045f, 0.00646285f, -0.00014927f, -0.02717000f, 0.03489329f, -0.04178182f, 0.00837921f, -0.01478045f, 
    -0.02355860f, 0.00432619f, -0.01401245f, 0.00355590f, -0.01917718f, 0.04355460f, -0.01640087f, -0.01989972f, 
    -0.02312963f, 0.00903972f, 0.04642886f, -0.04807976f, 0.00949110f, -0.04102891f, 0.04399921f, 0.00171138f, 
    0.01995904f, 0.00056812f, -0.01863908f, -0.04147394f, -0.04834076f, 0.01027653f, 0.04231122f, -0.04275398f, 
    -0.02397565f, -0.04385734f, 0.02086685f, 0.02599938f, -0.03466819f, 0.00281174f, -0.03057444f, -0.02088354f, 
    0.04184938f, -0.00880810f, 0.00614597f, 0.04066504f, 0.01073182f, -0.02665193f, -0.02973036f, 0.02335558f, 
    0.00254634f, 0.04138014f, -0.03581624f, -0.04319496f, -0.00108894f, 0.03835576f, 0.03249768f, 0.04110694f, 
    -0.00196665f, -0.03752390f, -0.05359057f, -0.04879011f, 0.00059504f, 0.00194686f, -0.05215262f, 0.01506016f, 
    -0.02428989f, 0.01063076f, -0.01301996f, -0.02122056f, 0.03411777f, -0.01591880f, -0.04173793f, -0.00426165f, 
    -0.01217479f, 0.02191845f, 0.03900618f, 0.01130936f, -0.00134066f, -0.00189604f, -0.02529870f, -0.00635373f, 
    -0.02508411f, 0.02564318f, -0.02953547f, -0.02003021f, -0.05397411f, 0.03140287f, -0.05407012f, 0.00448210f, 
    -0.02962626f, -0.05134455f, -0.03099568f, -0.04883380f, 0.01853628f, -0.01141972f, -0.05491778f, 0.01534697f, 
    -0.04463561f, 0.00392224f, 0.03762281f, 0.01745796f, -0.03867117f, -0.00691534f, -0.02177286f, -0.02465031f, 
    -0.04673379f, -0.04447895f, 0.01942782f, 0.01028645f, -0.01204481f, 0.01875569f, -0.03416277f, 0.02535176f, 
    -0.05036179f, 0.00227563f, -0.05149399f, 0.00664491f, -0.04205438f, 0.01254269f, -0.02611093f, 0.02929199f, 
    -0.03637277f, 0.03270814f, -0.02469463f, 0.01984655f, 0.04769712f, -0.02134200f, -0.00437078f, 0.01175444f, 
    -0.03803496f, -0.02196594f, -0.00952718f, -0.05466961f, -0.02405710f, -0.04393646f, -0.04134802f, -0.01605633f, 
    0.01944248f, -0.05353720f, 0.00629917f, 0.00413012f, -0.01795728f, -0.01939290f, -0.04683039f, 0.04742220f, 
    -0.04808741f, -0.05118991f, -0.01862641f, 0.00526595f, -0.02406638f, -0.00478182f, -0.00228079f, -0.05033351f, 
    -0.00671261f, 0.02499061f, -0.01124222f, -0.05602748f, -0.04621660f, 0.01081874f, -0.03350348f, -0.02807811f, 
    0.02507475f, -0.01759851f, 0.00225320f, -0.00828475f, 0.03091306f, 0.03645580f, 0.03078376f, 0.00126819f, 
    -0.02081635f, -0.05021996f, 0.01677687f, -0.00727936f, -0.02661728f, 0.01072635f, 0.03234383f, 0.03312571f, 
    -0.04329074f, 0.01975300f, -0.01636070f, 0.02837060f, 0.01959495f, -0.02081832f, -0.03265603f, 0.01068995f, 
    -0.01532899f, 0.01531717f, -0.02332344f, 0.01532419f, -0.00322687f, 0.02997767f, -0.01121760f, 0.03201439f, 
    -0.00990503f, -0.02966456f, 0.03291169f, 0.00324020f, 0.05076801f, 0.03392122f, -0.02456936f, 0.02056045f, 
    -0.03806389f, -0.03756073f, -0.04959365f, -0.03837063f, 0.03296075f, 0.02744074f, 0.04156039f, 0.00575848f, 
    0.03035472f, -0.03904624f, 0.04215636f, 0.03089434f, -0.00905253f, -0.01830957f, -0.00223662f, 0.01613381f, 
    -0.02877655f, -0.00538027f, -0.03487802f, -0.02149767f, -0.01776712f, -0.01136827f, -0.01482234f, -0.04041617f, 
    -0.03925282f, -0.03554900f, -0.00971268f, -0.01011193f, 0.02889086f, -0.05094720f, -0.01480637f, -0.03497709f, 
    -0.00169832f, 0.00648430f, -0.02371882f, -0.01981324f, -0.00588922f, 0.00368751f, -0.02014956f, 0.04191065f, 
    0.03373981f, -0.00302128f, -0.01676370f, 0.01359361f, -0.02150971f, -0.05552294f, -0.02197499f, 0.03931695f, 
    0.01423107f, 0.03795615f, -0.04415823f, -0.05175976f, 0.02317498f, -0.03736978f, 0.02659099f, -0.00935182f, 
    -0.01955493f, -0.00251209f, -0.04392165f, -0.01494936f, -0.02942304f, 0.03840978f, -0.05542350f, -0.02985808f, 
    0.00780231f, 0.02321736f, 0.00058117f, 0.01770879f, -0.05587336f, 0.01988797f, 0.02015031f, -0.00833060f, 
    -0.01131030f, 0.04413405f, 0.00863091f, 0.01685479f, 0.04330548f, 0.03372243f, 0.02242634f, 0.00097435f, 
    -0.01732231f, -0.03919775f, -0.03963391f, -0.00538299f, 0.03937427f, 0.04231069f, 0.01846409f, 0.03367689f, 
    0.02438272f, 0.01137098f, -0.04165156f, 0.04067386f, 0.02584584f, -0.04988461f, -0.00100398f, 0.02365993f, 
    -0.03441650f, 0.00575099f, -0.04480939f, 0.04278487f, 0.00304100f, -0.03257221f, -0.03790077f, 0.02346109f, 
    0.02929771f, 0.02657254f, 0.02131260f, -0.04673333f, -0.03052280f, 0.00905763f, 0.01797133f, 0.02248962f, 
    -0.01721074f, 0.01464549f, -0.03684334f, -0.03205058f, 0.02474266f, 0.00597062f, 0.03495612f, -0.00074222f, 
    0.00976243f, -0.05604625f, 0.01498346f, 0.01105608f, -0.01809765f, 0.02144457f, 0.01321085f, 0.00930833f, 
    -0.01260716f, 0.04182313f, 0.02534525f, -0.01156381f, 0.03119428f, 0.02698291f, -0.01140016f, -0.04156456f, 
    -0.02252574f, 0.00597728f, -0.05273567f, -0.02442225f, -0.03313371f, 0.02821443f, 0.01258820f, -0.05569771f, 
    0.04211467f, -0.05273141f, -0.04616359f, -0.02812885f, -0.02314006f, -0.00139801f, -0.02023127f, -0.01901645f, 
    -0.04515437f, -0.04442590f, 0.02420011f, 0.02124711f, 0.01527720f, 0.00860685f, -0.03028045f, -0.04960342f, 
    -0.03704588f, -0.04013190f, -0.06206902f, 0.03373175f, -0.03132806f, 0.01301803f, -0.03355350f, 0.04048469f, 
    -0.01102019f, -0.00160700f, -0.02892443f, -0.01464443f, -0.02544587f, -0.05559810f, -0.04156302f, 0.01645292f, 
    -0.04739172f, 0.03077179f, 0.01142995f, -0.01955506f, -0.01692956f, 0.02911574f, -0.01559662f, -0.04839547f, 
    -0.04287025f, -0.02844823f, -0.05301384f, -0.00607587f, -0.02762718f, -0.03557520f, -0.02322563f, -0.03807152f, 
    0.03525890f, -0.00623455f, 0.01017145f, -0.02354905f, 0.02366663f, -0.06103395f, -0.03394060f, 0.01958636f, 
    -0.04141096f, -0.05009942f, 0.00082156f, 0.03715101f, -0.03269543f, -0.00068136f, -0.03801980f, -0.05222305f, 
    0.03952282f, -0.03790030f, 0.00913422f, -0.05302299f, -0.03417262f, 0.03765723f, 0.00519315f, 0.03869168f, 
    0.03600278f, 0.04182041f, 0.04209249f, -0.01327641f, -0.02298321f, 0.00125566f, -0.00902615f, 0.01774320f, 
    0.01507483f, -0.04972922f, -0.03855086f, -0.03877748f, 0.02296594f, -0.04912767f, -0.03947846f, 0.02699905f, 
    -0.05927311f, -0.01424283f, -0.02762920f, -0.03866262f, -0.00170570f, 0.01010472f, -0.05922897f, 0.00776028f, 
    -0.01116048f, 0.00092784f, -0.00009653f, -0.02922504f, -0.03666497f, 0.03664842f, -0.05251038f, 0.01168231f, 
    -0.00171039f, 0.03326245f, 0.02097924f, -0.05621619f, 0.01508765f, -0.00360333f, 0.03001587f, -0.04523305f, 
    0.04461621f, 0.03634104f, -0.05148646f, 0.01889314f, -0.01144164f, 0.00753287f, -0.04874470f, -0.00052876f, 
    0.03812381f, 0.00521483f, 0.02130571f, -0.02571646f, -0.03172441f, -0.00528731f, -0.03083156f, 0.00264473f, 
    -0.00623570f, -0.02515220f, -0.05846548f, 0.00929191f, 0.03691217f, 0.03430339f, -0.05311437f, 0.02242425f, 
    0.00079872f, 0.03321116f, 0.00249511f, -0.02786965f, 0.01841443f, 0.02055038f, 0.01102626f, -0.03916172f, 
    0.01252524f, 0.00433626f, 0.00996207f, -0.01933322f, -0.05285429f, 0.01205389f, 0.03596026f, -0.06036507f, 
    0.01800893f, 0.00191075f, -0.05974608f, 0.00311201f, -0.00891881f, -0.04654017f, 0.01105581f, -0.00066403f, 
    -0.05749381f, 0.03948105f, -0.02779973f, -0.02579456f, -0.02062955f, 0.01514765f, -0.01825719f, -0.04090149f, 
    -0.04839220f, -0.00353172f, -0.02096434f, 0.02630994f, 0.00017425f, -0.02125749f, 0.03271813f, 0.03029216f, 
    -0.01932774f, 0.01951779f, 0.02740997f, -0.01759178f, -0.01301772f, 0.02254713f, -0.00586562f, -0.00099020f, 
    -0.02139732f, 0.03033178f, -0.00906675f, 0.04143524f, -0.02654881f, -0.03606176f, 0.00299924f, -0.03650105f, 
    0.03776954f, -0.01288485f, -0.03738367f, -0.01578319f, 0.00883228f, 0.03203290f, -0.05046379f, 0.02303222f, 
    0.00780615f, 0.03739215f, -0.01830728f, -0.00752056f, 0.03232305f, 0.03278410f, 0.02899354f, -0.05278230f, 
    0.03545896f, -0.00171334f, 0.03275500f, 0.00793287f, 0.00200835f, 0.00859318f, -0.01663026f, 0.02401522f, 
    -0.01925216f, 0.02690127f, 0.01790819f, -0.00374635f, 0.01146656f, -0.03921912f, 0.01012483f, 0.01921741f, 
    0.03342308f, -0.05769490f, 0.02298356f, 0.04074562f, 0.01096945f, -0.02438524f, 0.04114385f, 0.02823685f, 
    -0.01846171f, -0.00656932f, 0.00300453f, -0.01731012f, 0.03083472f, -0.05714766f, 0.03998850f, -0.03384661f, 
    -0.00714896f, -0.02312461f, 0.02676207f, 0.00266335f, 0.00319369f, -0.03421763f, -0.00670352f, 0.00485561f, 
    0.00984405f, -0.03301572f, -0.00647881f, 0.00640048f, -0.04547995f, 0.03271601f, 0.00621652f, -0.04486140f, 
    -0.01526901f, -0.00127032f, -0.06007340f, -0.05551174f, 0.01472194f, 0.02500852f, -0.06514383f, 0.01134639f, 
    -0.03770664f, 0.02972966f, 0.03646126f, -0.01312265f, -0.01080003f, 0.03363827f, -0.03038484f, -0.02659920f, 
    -0.01663546f, 0.02959915f, 0.03216318f, -0.03469072f, 0.00669944f, 0.03192373f, 0.01391056f, 0.04454068f, 
    0.03346362f, -0.05054969f, 0.02240695f, -0.02181297f, 0.02532336f, -0.02862726f, -0.01698311f, 0.01503537f, 
    0.02520148f, 0.01301379f, 0.03900844f, -0.01384033f, -0.01429541f, -0.05245502f, -0.04069676f, -0.04456478f, 
    -0.01249357f, 0.00573619f, 0.02773967f, -0.01885368f, -0.01623368f, -0.03115880f, -0.02697041f, 0.04075794f, 
    0.00352853f, -0.04278434f, -0.04905272f, -0.00862767f, -0.03179004f, -0.02752303f, 0.00360800f, -0.03312301f, 
    0.02860307f, 0.02838416f, -0.06005566f, 0.00491161f, 0.02555119f, -0.05175191f, -0.02996158f, -0.02161328f, 
    -0.01939111f, 0.03585554f, 0.04929972f, -0.02732987f, -0.02886052f, 0.03164664f, -0.02102347f, -0.01217832f, 
    -0.01850760f, 0.02410937f, 0.03634689f, 0.01129005f, -0.03416005f, -0.05938332f, -0.00222350f, 0.02437392f, 
    -0.01624650f, -0.03717016f, -0.05736644f, -0.03289269f, -0.00712601f, 0.01384117f, -0.05713641f, -0.05257908f, 
    0.00218834f, 0.00786111f, -0.01370925f, -0.00439559f, -0.01189244f, -0.03996568f, 0.02512868f, -0.00924864f, 
    -0.01261129f, -0.05254364f, 0.02342062f, 0.03009344f, -0.00000582f, -0.01246244f, -0.03830388f, 0.01876945f, 
    0.03627432f, -0.04293860f, -0.03181313f, 0.00739494f, -0.03658356f, -0.02554397f, -0.05436074f, -0.04414798f, 
    0.02329626f, -0.05516994f, -0.02674982f, -0.00623629f, 0.01836460f, -0.00455864f, -0.02171824f, -0.03544170f, 
    -0.04445005f, -0.03619961f, -0.04541707f, 0.03497933f, 0.00057223f, 0.02736854f, 0.01416525f, -0.02234084f, 
    0.00447338f, 0.04440326f, 0.00324340f, 0.01154520f, 0.01473729f, -0.02969061f, -0.03307959f, -0.01230201f, 
    -0.01412456f, -0.04869134f, -0.02204297f, -0.02169125f, 0.02763060f, -0.02062578f, -0.01618522f, -0.04969588f, 
    -0.20366108f, 0.04427760f, -0.05600034f, 0.15199253f, -0.00801047f, -0.00023475f, 0.05625761f, 0.09800654f, 
    0.05409029f, 0.06743257f, 0.02466291f, -0.05920452f, -0.19736357f, 0.12386303f, 0.27827322f, 0.04904133f, 
    -0.00215606f, -0.03637009f, 0.04187116f, 0.05655570f, 0.09823268f, 0.00903452f, -0.04907356f, 0.05422190f, 
    -0.08044194f, 0.04086635f, 0.00600739f, 0.06541231f, 0.06733805f, 0.06714173f, 0.01890947f, -0.07784886f, 
    -0.12110988f, -0.00256862f, -0.08220913f, 0.09185163f, -0.16520548f, -0.10959470f, 0.13804188f, 0.18640479f, 
    -0.01735274f, 0.00407025f, -0.05228006f, 0.03831749f, -0.01747249f, 0.06232372f, 0.01390286f, 0.01316185f, 
    -0.11616442f, 0.13793764f, 0.03917438f, -0.19765890f, -0.00206538f, -0.04648204f, -0.11474163f, -0.18763627f, 
    0.03077352f, 0.00971994f, -0.02134534f, 0.13810603f, 0.19670770f, -0.04241956f, -0.09565368f, -0.21430209f, 
    -0.00212187f, 0.06992904f, 0.08013298f, 0.10419571f, -0.05529045f, -0.08713543f, 0.04951632f, 0.10806231f, 
    0.01854493f, 0.08575943f, -0.21440190f, 0.16358040f, 0.03783561f, 0.01344586f, -0.07968606f, 0.09932978f, 
    0.08078267f, 0.02348105f, 0.04542376f, 0.09431779f, -0.50045216f, -0.03417128f, -0.12605016f, 0.12673637f, 
    -0.09265230f, 0.05350726f, -0.06113889f, 0.08880975f, -0.00031085f, 0.03057914f, 0.03963002f, -0.02052137f, 
    0.04263788f, -0.18068461f, 0.08622301f, 0.16586345f, -0.03721980f, -0.00835111f, 0.06877320f, 0.08764755f, 
    0.14259839f, 0.05680760f, 0.13039072f, 0.03943199f, 0.10323498f, 0.02246988f, 0.03705844f, 0.21187924f, 
    0.13687852f, -0.04012307f, 0.08463624f, -0.04925307f, -0.07359533f, -0.00581326f, 0.05524142f, -0.03078206f, 
    -0.17839961f, 0.27890027f, 0.06735030f, -0.09136854f, 0.05378480f, -0.06451449f, 0.03833335f, -0.02589019f, 
    -0.09602418f, -0.08485875f, -0.01411569f, -0.06024197f, -0.02814873f, 0.02258904f, -0.01982190f, 0.01660482f, 
    -0.02594575f, 0.07762277f, 0.03841981f, -0.06227527f, -0.01032896f, 0.03984533f, 0.08377973f, 0.08512536f, 
    0.15100591f, -0.17014854f, -0.30083945f, -0.24677716f, 0.00312255f, -0.16541213f, -0.05836831f, -0.01027450f, 
    0.02754965f, 0.12209542f, -0.04998110f, 0.05398560f, -0.07144280f, -0.36249873f, -0.02508280f, 0.25859609f, 
    -0.00830335f, 0.08122300f, 0.07124002f, -0.07722033f, 0.02499219f, 0.03866091f, -0.11188431f, 0.11931826f, 
    0.12660615f, -0.09678873f, 0.01223759f, -0.07842378f, -0.01001305f, 0.01983787f, -0.05991777f, 0.11394012f, 
    0.07551657f, -0.07289684f, -0.00414489f, 0.02407223f, 0.46024138f, 0.07060364f, -0.12455964f, 0.09916072f, 
    0.11772016f, -0.05341384f, 0.12444177f, 0.00145361f, -0.07767334f, 0.13814254f, 0.02890095f, 0.12147072f, 
    0.28190008f, 0.10726190f, -0.13456088f, -0.04048233f, 0.07584943f, 0.04225006f, 0.00637078f, 0.09931435f, 
    -0.00196503f, -0.07773225f, 0.06454588f, 0.10045309f, 0.03272106f, 0.09013168f, -0.00279604f, 0.02458407f, 
    0.07508823f, 0.01250764f, 0.03859469f, 0.02713765f, -0.05573586f, 0.01960901f, 0.00527610f, 0.05350769f, 
    0.01665370f, 0.06070557f, -0.07207815f, -0.02163531f, -0.03676093f, 0.07929581f, 0.05094730f, 0.04672502f, 
    -0.05402685f, 0.10527098f, 0.16075087f, 0.00885866f, 0.28891355f, -0.34492472f, 0.00055602f, -0.11847517f, 
    -0.02492097f, 0.00836316f, -0.04871687f, -0.04476168f, -0.04039628f, -0.09068360f, 0.09875473f, -0.01006209f, 
    0.05403537f, -0.02981407f, -0.12943304f, -0.17804389f, 0.02075481f, -0.02171344f, 0.02669891f, 0.08828980f, 
    0.05264578f, 0.01363457f, 0.00712616f, 0.00778367f, 0.24090976f, -0.06162664f, 0.19913718f, 0.07551739f, 
    -0.02223901f, -0.01635684f, -0.04065005f, -0.05644110f, 0.07645643f, 0.06864181f, 0.06098498f, 0.11818002f, 
    0.07201120f, -0.12186372f, -0.21463814f, 0.17198379f, -0.06915564f, 0.05675907f, 0.07294630f, -0.01413055f, 
    0.02677957f, 0.13030882f, 0.12525149f, 0.10972266f, -0.22883016f, 0.03124898f, -0.03287308f, 0.21084233f, 
    -0.14249101f, -0.05308702f, 0.08264732f, 0.07048565f, 0.15313005f, 0.01802373f, -0.09226372f, 0.01008375f, 
    -0.35894549f, 0.00980818f, -0.04610191f, 0.06100836f, 0.02239863f, -0.07678741f, -0.03080135f, 0.12381292f, 
    0.04100735f, -0.03383154f, -0.03283413f, -0.01053015f, 0.17942619f, -0.09461656f, 0.23214164f, 0.00209380f, 
    -0.07043934f, 0.01891882f, 0.02433336f, 0.15539418f, 0.01893480f, -0.12899752f, 0.06775960f, 0.08675937f, 
    0.05148828f, 0.08250851f, -0.15226923f, -0.04046654f, -0.01910522f, 0.05077909f, -0.06597970f, -0.04317377f, 
    -0.08247835f, 0.04811457f, -0.18798061f, 0.04501227f, 0.36495897f, -0.04999740f, -0.03522974f, 0.01268838f, 
    -0.11385590f, 0.06238972f, 0.09790849f, 0.03876036f, -0.00851686f, 0.01615658f, -0.03040531f, -0.09260950f, 
    0.08665030f, -0.31213412f, 0.24536932f, 0.15486526f, -0.12298815f, 0.08393111f, 0.00759766f, 0.06930831f, 
    0.06434086f, 0.12767273f, -0.03293027f, 0.01252913f, 0.06471238f, 0.01354422f, 0.16940010f, -0.11919089f, 
    -0.03576139f, 0.03490619f, -0.10728003f, -0.02646934f, -0.03052349f, 0.03279356f, -0.11656146f, 0.00739983f, 
    0.32786930f, -0.09830669f, -0.14196491f, -0.02248734f, 0.00609669f, 0.06894636f, -0.00575669f, -0.04965000f, 
    -0.10716390f, -0.07769367f, -0.05476926f, 0.00177359f, -0.13295537f, 0.08312932f, -0.12779522f, -0.31240422f, 
    0.03138545f, 0.13606490f, 0.01320041f, -0.13971125f, 0.19174241f, -0.01028800f, -0.00305326f, -0.03083077f, 
    0.32863101f, -0.08836542f, -0.06465632f, 0.01081273f, 0.03279249f, 0.03867195f, 0.08318511f, 0.03003929f, 
    -0.12616834f, 0.02532441f, -0.04683422f, 0.04917408f, 0.01597409f, 0.24825901f, 0.28176686f, -0.23229811f, 
    0.03594529f, 0.07678431f, 0.07700618f, -0.07035371f, 0.12733485f, -0.02151691f, 0.17871740f, -0.07135314f, 
    -0.06077159f, -0.14479838f, 0.07809032f, 0.14620936f, 0.03654785f, 0.00666140f, 0.02353684f, -0.05077578f, 
    0.13602585f, 0.06706613f, 0.15706447f, -0.08683635f, 0.14370254f, -0.12461185f, -0.07505013f, -0.09400836f, 
    -0.00108386f, -0.02665022f, 0.00661957f, 0.00274098f, -0.02984372f, 0.04738140f, -0.00279511f, 0.00684382f, 
    -0.03710932f, -0.08256740f, -0.17593405f, 0.06945824f, 0.12324452f, 0.08113045f, 0.06324128f, 0.14033362f, 
    0.07334353f, -0.00053669f, -0.05205125f, 0.04244192f, -0.11927395f, -0.00774170f, -0.01943971f, -0.12735212f, 
    0.04737231f, 0.11476388f, -0.01298924f, 0.07600546f, 0.10501210f, 0.10449645f, 0.15426426f, 0.00358062f, 
    -0.21425435f, -0.01933746f, 0.18182407f, 0.05931205f, 0.11130533f, 0.09649563f, 0.09146012f, 0.04717013f, 
    -0.08650286f, 0.05439739f, -0.17179503f, -0.03860530f, 0.66247243f, -0.30240732f, 0.33340415f, 0.16493274f, 
    0.09695704f, -0.04019409f, 0.08015690f, -0.05725708f, -0.07951196f, -0.03890611f, 0.00350506f, 0.05928682f, 
    -0.25235578f, 0.30659476f, 0.08311059f, -0.17811356f, 0.03397693f, -0.06319787f, -0.04266445f, 0.08528631f, 
    -0.02211521f, -0.00306779f, -0.04218135f, -0.04830389f, -0.13655418f, -0.13252980f, 0.12364876f, 0.33813587f, 
    -0.02205047f, -0.16191940f, -0.00945181f, -0.07064345f, -0.14766540f, -0.02005475f, -0.04110561f, 0.15162142f, 
    -0.09806442f, 0.18645400f, 0.05299228f, -0.01378226f, -0.02266221f, 0.11226261f, 0.16151531f, 0.15980724f, 
    0.03453022f, 0.05969637f, 0.08635445f, -0.01448662f, -0.11027828f, -0.02685734f, -0.03906675f, 0.15402026f, 
    0.04470796f, 0.01531873f, 0.07202381f, -0.10780746f, 0.17301655f, -0.09326294f, -0.13813430f, 0.11308265f, 
    0.07838009f, 0.04528636f, -0.05561636f, 0.13670908f, 0.08234280f, 0.03077079f, 0.10518999f, -0.03345814f, 
    0.03593039f, 0.00282029f, 0.23257262f, -0.13059182f, -0.06109323f, 0.03377973f, 0.15459439f, 0.19506626f, 
    -0.11232208f, 0.04904026f, 0.14591476f, 0.08372141f, -0.04127124f, 0.01411365f, 0.08537880f, 0.08611660f, 
    0.19923230f, -0.13745943f, 0.08417813f, -0.11847760f, 0.03814349f, -0.03036842f, 0.06173836f, -0.15303941f, 
    0.09236585f, 0.11235350f, -0.05404725f, -0.02922434f, -0.34670603f, 0.25574529f, 0.19708982f, -0.07114926f, 
    0.02733570f, 0.15705819f, -0.04265127f, 0.07364316f, -0.03276634f, 0.01931514f, -0.06506392f, -0.09904678f, 
    0.05303887f, -0.02229669f, 0.08767188f, -0.04961317f, -0.08439166f, 0.06854127f, -0.03714072f, -0.08673960f, 
    0.02544551f, -0.13514026f, -0.16823469f, 0.01314959f, 0.14121298f, -0.09127460f, 0.23551092f, 0.05263696f, 
    0.02192398f, -0.02416465f, 0.06868153f, 0.03935939f, 0.07111134f, 0.07683533f, 0.05574024f, -0.07186706f, 
    -0.18088786f, -0.08479154f, -0.01505618f, 0.00580730f, 0.12197144f, -0.08067873f, -0.10183335f, -0.00372963f, 
    0.02274729f, 0.06228421f, -0.00137153f, 0.16271901f, 0.12013988f, -0.05123184f, -0.17935839f, 0.07931660f, 
    0.09942356f, -0.08273433f, 0.17256550f, 0.04473789f, 0.11369491f, 0.02147592f, -0.13101390f, 0.06606404f, 
    -0.26596445f, 0.03316927f, 0.17949528f, -0.10193773f, 0.06976699f, 0.08661574f, -0.02023570f, -0.00254028f, 
    -0.10320210f, -0.00716704f, 0.09466493f, 0.10478055f, 0.12555178f, 0.32543391f, 0.03157686f, -0.13633350f, 
    -0.10888050f, 0.10165309f, -0.04771912f, 0.07944381f, -0.08266514f, -0.14532246f, -0.00219485f, -0.05351040f, 
    -0.01348139f, 0.06285990f, 0.02306410f, 0.12564971f, -0.01964325f, -0.02580000f, 0.15848741f, -0.11951323f, 
    0.04216564f, -0.09640663f, -0.02387097f, -0.08828975f, -0.22644170f, -0.13758063f, 0.03715314f, 0.05707071f, 
    0.02165947f, 0.10604656f, -0.21546489f, -0.07076532f, -0.12524746f, -0.02632690f, 0.05344063f, -0.02209262f, 
    -0.00906229f, -0.07008238f, 0.03816855f, 0.20855553f, -0.06519923f, -0.06149229f, 0.03393790f, -0.14598742f, 
    0.00967026f, -0.05164983f, 0.02999606f, -0.06330513f, -0.08764499f, 0.09549699f, 0.03065877f, -0.09084602f, 
    -0.02688850f, -0.07210964f, 0.12626711f, 0.00593650f, 0.09180424f, 0.10386449f, -0.08990691f, 0.07251335f, 
    -0.30990359f, -0.15895991f, -0.06091261f, 0.11870925f, 0.03081035f, -0.14233962f, -0.05130208f, 0.01423751f, 
    0.04884504f, 0.10234106f, 0.02763516f, -0.12815633f, 0.28467888f, 0.08386318f, 0.01385624f, -0.12210244f, 
    0.04090560f, 0.06519697f, 0.03297283f, 0.06844799f, -0.00306097f, -0.01920833f, 0.10281569f, 0.04411506f, 
    -0.18523665f, 0.15803620f, 0.03696831f, -0.00360446f, 0.12527372f, 0.06166436f, -0.00120584f, 0.09817240f, 
    0.00261787f, -0.13980621f, -0.01960316f, -0.08196830f, -0.02061246f, 0.22731622f, 0.15799557f, -0.21536051f, 
    -0.06193221f, 0.11004823f, 0.14238036f, -0.03519851f, -0.11750929f, 0.08853817f, -0.05966957f, 0.00277931f, 
    -0.06255229f, -0.10069727f, 0.26040024f, 0.13900977f, 0.04046035f, 0.04324195f, 0.05615092f, -0.04830650f, 
    -0.06448923f, 0.11310605f, 0.00447624f, -0.07541855f, 0.24623387f, 0.04477676f, -0.11940993f, 0.00053875f, 
    0.12060255f, 0.05420321f, 0.13207044f, -0.07622969f, -0.02243294f, 0.04077517f, 0.10025628f, 0.20693928f, 
    -0.02211490f, -0.02450918f, -0.01344112f, 0.03128397f, -0.03337435f, -0.01860323f, -0.05478316f, -0.02078945f, 
    0.00092786f, 0.03889708f, -0.00076973f, 0.04139999f, -0.01040021f, 0.01430269f, -0.04548021f, -0.02025154f, 
    -0.00190703f, -0.02436119f, 0.01182472f, -0.01698838f, -0.04316333f, 0.04007458f, -0.03886266f, -0.03242367f, 
    -0.00906025f, -0.01859918f, 0.01891856f, -0.00546027f, -0.04634863f, -0.01056202f, -0.00321045f, -0.01690156f, 
    0.00279754f, 0.01060718f, -0.02169987f, 0.02057387f, 0.02743893f, -0.04239965f, -0.00723837f, 0.03412377f, 
    -0.02661004f, 0.01617541f, 0.00161816f, -0.05097517f, -0.01071374f, -0.04352846f, 0.03579953f, 0.04093728f, 
    -0.01985385f, -0.02937919f, 0.01902272f, 0.01717191f, 0.02370402f, -0.04389932f, -0.03572938f, 0.04101901f, 
    0.04828075f, 0.01664078f, -0.01785277f, 0.01831954f, -0.02419002f, 0.04051649f, 0.03844498f, 0.02412675f, 
    -0.02835632f, -0.03965677f, -0.05079011f, 0.01465487f, -0.00469555f, -0.04628878f, -0.04584255f, 0.00924786f, 
    -0.02227538f, -0.05301214f, 0.01594296f, 0.03239014f, -0.03860965f, -0.03013332f, -0.01536531f, 0.00334791f, 
    0.01188093f, -0.01762035f, -0.01771764f, -0.04240661f, 0.03075881f, 0.02431994f, -0.05015937f, 0.01776325f, 
    0.00382434f, 0.04377248f, 0.03942686f, 0.04499664f, -0.01383053f, 0.04121481f, 0.03232320f, 0.02681860f, 
    -0.01211253f, 0.00402481f, -0.05359539f, -0.00234806f, 0.01598018f, -0.04985502f, -0.01061791f, -0.02879510f, 
    -0.04094267f, 0.03885684f, 0.01154888f, -0.00031357f, -0.02391252f, -0.00674701f, -0.04484140f, -0.03852214f, 
    0.03291561f, -0.00071774f, -0.01551691f, 0.03329483f, 0.01322003f, -0.00048534f, 0.00682760f, -0.03581203f, 
    -0.03962568f, -0.01122478f, 0.00554654f, 0.00830210f, -0.01123975f, -0.00735218f, -0.01247750f, 0.03618276f, 
    0.03401339f, -0.03636917f, -0.01787007f, -0.02187058f, -0.02504422f, -0.02994477f, 0.00417539f, -0.03723288f, 
    -0.03659644f, -0.02844944f, 0.03645620f, 0.01556488f, -0.01875786f, -0.01415970f, -0.04374598f, -0.04542819f, 
    -0.02680428f, 0.00731765f, 0.04984224f, -0.01924707f, -0.01448480f, -0.02733634f, 0.01727978f, 0.03409537f, 
    -0.03873371f, 0.01758797f, 0.01974016f, 0.02103028f, 0.04854446f, -0.02057086f, -0.01356296f, 0.05141165f, 
    -0.02246862f, 0.01877742f, 0.02919235f, 0.00696722f, -0.04753939f, -0.03130410f, -0.03501667f, 0.03475917f, 
    0.01105498f, -0.04731297f, 0.03012669f, 0.00416479f, 0.00607492f, 0.01991714f, 0.00374465f, 0.04202448f, 
    0.00903966f, -0.04958629f, -0.02608567f, 0.00297840f, 0.00202497f, -0.03432939f, -0.03242308f, -0.02756488f, 
    0.03771139f, -0.05065696f, 0.03777743f, 0.02990116f, 0.02315520f, -0.02991006f, 0.03818649f, 0.00606276f, 
    -0.02155967f, 0.01184204f, 0.01759936f, -0.02143393f, -0.01898463f, 0.03046697f, 0.00657807f, 0.01479068f, 
    -0.05208356f, -0.01235288f, -0.02569298f, -0.04842034f, -0.01079992f, 0.00962289f, -0.03246085f, -0.03451687f, 
    -0.02550434f, 0.01197678f, -0.03677435f, -0.02985664f, 0.03684075f, -0.01160418f, 0.01820710f, -0.01217917f, 
    -0.01279579f, 0.04595697f, 0.01369069f, -0.00754555f, 0.01721173f, 0.03361344f, -0.02801599f, 0.01180023f, 
    -0.02028647f, -0.02889584f, -0.01824106f, 0.03177312f, 0.02063820f, -0.04906190f, 0.01943448f, 0.00319459f, 
    -0.02212034f, 0.03218790f, -0.04659483f, -0.03250403f, 0.04081327f, -0.02398977f, -0.00614153f, 0.02748736f, 
    0.01705452f, -0.05139406f, -0.04033796f, -0.02098478f, 0.00695411f, -0.01612550f, 0.02959619f, 0.04430289f, 
    0.04865492f, 0.01110112f, 0.04623388f, -0.01994332f, -0.04917683f, -0.02728001f, -0.03455273f, 0.01308136f, 
    0.04272552f, -0.04072195f, -0.05347722f, -0.02857307f, 0.00971028f, -0.05152568f, -0.05736416f, -0.00249229f, 
    0.00247985f, 0.00461646f, -0.00636709f, 0.02491091f, 0.03630389f, -0.03476364f, -0.01056918f, -0.02021059f, 
    0.00184359f, -0.01701047f, -0.03853011f, -0.04913817f, -0.01881331f, 0.04291208f, 0.01228661f, 0.03469502f, 
    0.02806255f, -0.03397273f, -0.00661982f, -0.00201789f, -0.04828005f, 0.04196317f, -0.01844458f, -0.00072050f, 
    -0.05573461f, -0.02928972f, -0.03345012f, 0.02369081f, -0.01273005f, -0.03844346f, -0.04508535f, -0.01851784f, 
    0.01598183f, -0.01172583f, 0.02550903f, -0.01190966f, -0.02564864f, -0.01763604f, -0.03898162f, -0.03667584f, 
    0.04368677f, 0.03854066f, 0.03817094f, 0.01640198f, -0.00004043f, -0.01194725f, 0.01502905f, 0.03322522f, 
    -0.05113163f, -0.02474723f, -0.03296779f, 0.00006154f, -0.01281332f, 0.01366583f, -0.05108450f, 0.04255883f, 
    -0.01457228f, 0.01050905f, 0.01330445f, -0.01076600f, 0.01458737f, 0.04579903f, -0.00416065f, 0.04521759f, 
    0.04013674f, -0.00691479f, 0.02533717f, -0.00831178f, -0.04295505f, -0.03074088f, -0.04658141f, -0.03613722f, 
    0.02259382f, -0.02365719f, 0.02346712f, -0.01406208f, 0.04127406f, -0.05411210f, 0.01131697f, 0.01961328f, 
    0.03716670f, -0.02423619f, -0.05349271f, 0.01598032f, 0.02357898f, 0.02901035f, -0.01083366f, -0.02573606f, 
    -0.05076200f, -0.05323311f, -0.03742509f, 0.01023772f, 0.00667910f, -0.03081358f, -0.04395227f, 0.02669896f, 
    -0.01134592f, -0.02549760f, -0.02440476f, 0.02547018f, 0.02091410f, -0.02457601f, -0.00919086f, 0.00097828f, 
    0.00662451f, -0.01123743f, 0.00756646f, 0.01115233f, 0.00733801f, 0.02909630f, 0.03148627f, -0.00673953f, 
    0.04778574f, -0.01493977f, 0.00711577f, -0.04597168f, 0.00505759f, -0.00707584f, 0.01345969f, -0.00297547f, 
    -0.04070351f, 0.03980129f, -0.04155160f, 0.02969368f, 0.03788658f, -0.00271032f, 0.01026605f, -0.00660409f, 
    0.02370853f, -0.04351372f, -0.04352341f, 0.03984200f, 0.03472228f, -0.05352175f, -0.04022609f, -0.05099951f, 
    -0.01613028f, -0.04782839f, 0.01153817f, -0.00036070f, -0.02842482f, -0.04897057f, 0.03284065f, -0.04526303f, 
    -0.04369678f, -0.00022054f, -0.00847883f, 0.03035477f, -0.01962833f, -0.03542471f, -0.01226385f, 0.01059896f, 
    -0.04408550f, 0.01175562f, -0.00039658f, 0.00752821f, -0.04978146f, -0.05460757f, -0.00290728f, -0.02465881f, 
    0.03719890f, -0.05170636f, 0.00060106f, 0.01018726f, -0.00202496f, -0.04203191f, -0.03077838f, -0.01935810f, 
    0.02679891f, 0.03117058f, -0.03570561f, 0.01448502f, -0.01764290f, 0.04282225f, -0.00790794f, -0.03635028f, 
    -0.05545089f, 0.00573461f, -0.05639938f, -0.04106208f, -0.00097162f, 0.01141634f, -0.00314399f, 0.00444453f, 
    -0.01129362f, -0.02882262f, -0.04294711f, 0.02913883f, -0.01283787f, -0.03796295f, 0.04146446f, -0.03358462f, 
    -0.04273158f, 0.03658285f, -0.00855861f, -0.02026429f, -0.03814711f, -0.03806031f, 0.03619080f, -0.02846983f, 
    -0.04990674f, -0.03145877f, 0.03931359f, -0.02854804f, -0.04282638f, 0.00128592f, -0.04496820f, -0.05620251f, 
    -0.03406166f, -0.01573774f, -0.01297267f, -0.03383222f, 0.00590253f, -0.04437748f, 0.00412188f, 0.02325899f, 
    -0.01413284f, -0.02832742f, -0.03500507f, 0.04201577f, 0.00022831f, -0.05656645f, -0.05088096f, -0.01805067f, 
    0.03105357f, -0.00693847f, -0.02418944f, 0.04023237f, -0.05744839f, 0.01678872f, -0.03925391f, 0.01382482f, 
    0.02591161f, 0.02278214f, 0.04535485f, -0.02669019f, -0.02163685f, -0.03862045f, -0.03533231f, -0.00727347f, 
    0.02265580f, 0.00938090f, 0.02279820f, -0.02628281f, -0.03128790f, -0.02816616f, -0.03351533f, 0.02839498f, 
    0.03502241f, 0.01560028f, -0.03681886f, -0.00500013f, 0.01488686f, -0.01377282f, -0.00097424f, -0.04216851f, 
    0.01750072f, -0.00747133f, -0.00818646f, -0.03833757f, 0.00855180f, -0.04747525f, 0.03339154f, -0.04280016f, 
    0.04246219f, -0.02499140f, -0.00494676f, -0.00090038f, 0.04227308f, 0.00247076f, 0.01613286f, -0.03391274f, 
    -0.03871136f, -0.04418593f, -0.04076097f, -0.05245917f, -0.01523910f, -0.01284385f, -0.01004056f, -0.03954801f, 
    -0.02958971f, -0.03879924f, -0.04949538f, -0.04004139f, -0.05094986f, -0.02870192f, -0.02854970f, 0.03915886f, 
    0.00157475f, 0.00858794f, 0.02736429f, -0.01881147f, -0.04128245f, -0.04368749f, -0.01274662f, 0.02363719f, 
    0.02831443f, 0.02148710f, -0.01563933f, 0.02401596f, -0.03038643f, 0.00447621f, 0.01163296f, 0.02205218f, 
    0.01512442f, 0.02186758f, 0.00715068f, 0.02696314f, -0.05618272f, 0.00972068f, 0.03901539f, 0.04007148f, 
    -0.00918760f, -0.01222501f, 0.00185945f, 0.02146114f, 0.00580157f, 0.01061258f, -0.01582749f, -0.02935494f, 
    -0.01241237f, 0.00369230f, 0.02678491f, 0.01695579f, -0.03769286f, 0.04079446f, 0.00536693f, 0.00145196f, 
    0.03500678f, 0.01245543f, 0.03421855f, -0.01536927f, -0.05652463f, 0.03668172f, -0.03890074f, 0.00952249f, 
    -0.04666213f, 0.03427130f, 0.02599795f, -0.01303458f, -0.03241884f, -0.03246183f, 0.03558676f, -0.02499041f, 
    0.03478839f, 0.02579577f, -0.02619009f, 0.00230701f, -0.00513257f, -0.05104809f, -0.01231856f, -0.03776965f, 
    -0.04292594f, -0.04351356f, -0.03383198f, -0.01230810f, -0.02827298f, 0.03937189f, 0.01898093f, -0.04017257f, 
    0.02602003f, 0.01411031f, 0.01314381f, -0.02274430f, 0.02360053f, 0.00879768f, -0.04411274f, 0.00236415f, 
    0.03679026f, -0.04736742f, 0.01852029f, -0.02485374f, 0.01070532f, 0.03491815f, 0.03515806f, -0.00716683f, 
    -0.00013826f, -0.01689661f, 0.00539621f, -0.01041228f, -0.02328100f, -0.02177960f, 0.03697102f, -0.00939055f, 
    -0.02556376f, 0.01598801f, -0.02999183f, -0.02750035f, -0.05198417f, -0.02658387f, -0.03011358f, -0.02878004f, 
    0.01427135f, 0.03191411f, -0.04245144f, -0.01722231f, 0.01454042f, -0.05578451f, 0.03575847f, -0.05594281f, 
    -0.05691904f, -0.02441848f, -0.04895778f, 0.03731744f, -0.02424924f, -0.02671296f, 0.03803055f, -0.04045136f, 
    -0.03183148f, -0.02342503f, -0.00908858f, -0.02899200f, -0.04955437f, 0.01181370f, 0.00148691f, 0.02023377f, 
    -0.04668738f, -0.04457258f, -0.03336937f, -0.02755631f, -0.00899697f, 0.02995226f, -0.02625696f, -0.02220929f, 
    0.03588684f, -0.00321440f, -0.03358847f, 0.02011687f, -0.01567417f, 0.04161464f, -0.00713283f, -0.03084451f, 
    -0.01043663f, 0.00454391f, -0.03446975f, -0.02201938f, 0.01206317f, -0.05077605f, -0.01216435f, 0.03237609f, 
    -0.01885294f, -0.03427430f, -0.02120004f, -0.04464993f, 0.03423279f, 0.03915099f, -0.04774695f, -0.01168182f, 
    0.00852578f, -0.04899275f, 0.04185053f, 0.03122478f, 0.03015718f, 0.04424368f, 0.01489306f, 0.03257325f, 
    0.04138002f, 0.03404099f, -0.04445673f, -0.05086408f, 0.02040674f, 0.04151375f, -0.04680576f, 0.00912764f, 
    -0.04491658f, -0.00962090f, -0.04683176f, -0.02356391f, -0.00872309f, -0.02470825f, -0.04240320f, 0.01290846f, 
    0.01029614f, -0.00355875f, 0.00104424f, 0.02323575f, -0.05172892f, -0.04470742f, 0.02885571f, -0.01238097f, 
    -0.03626074f, -0.02276057f, -0.04380867f, -0.02793250f, 0.00142552f, 0.01412957f, 0.01778110f, -0.03600610f, 
    -0.04720853f, 0.02825960f, -0.03226329f, 0.01253324f, 0.02711168f, 0.03704106f, -0.03269499f, -0.03068308f, 
    0.01299405f, -0.00498794f, -0.01299518f, -0.04871462f, -0.01625546f, -0.00634468f, -0.02786549f, -0.00511399f, 
    -0.30726445f, 0.01878724f, -0.01578435f, -0.12895411f, -0.02011133f, 0.00053931f, 0.04832206f, -0.04935854f, 
    -0.09356995f, 0.08325157f, 0.05484301f, 0.15039736f, -0.04272133f, -0.21241120f, 0.00025856f, 0.12533611f, 
    -0.08387179f, -0.02566406f, -0.04212316f, 0.07179937f, -0.05645831f, -0.03403096f, -0.09567077f, -0.04223915f, 
    0.18655223f, 0.17894575f, -0.10843350f, 0.02075590f, -0.09002437f, 0.00819217f, -0.01340450f, -0.03411079f, 
    -0.07672177f, -0.02367188f, 0.02488467f, 0.12406814f, 0.34777322f, 0.20648062f, -0.06476816f, -0.19711627f, 
    -0.04483012f, -0.05301111f, -0.06275930f, 0.00635203f, -0.04099501f, -0.02419762f, -0.01708079f, -0.02661614f, 
    0.12184346f, 0.03824901f, 0.01374763f, 0.01312441f, -0.05195564f, -0.12347299f, -0.10170726f, 0.05766628f, 
    -0.16908775f, 0.09202173f, 0.13517958f, 0.13174833f, 0.20129447f, -0.10658905f, 0.01235685f, 0.08924135f, 
    -0.14968583f, -0.02562660f, -0.05613566f, -0.02361864f, -0.00704711f, -0.08316727f, 0.03733888f, 0.08236597f, 
    -0.16610967f, 0.10206085f, -0.14016831f, 0.06975111f, 0.07206392f, 0.00057693f, 0.02419973f, -0.02720109f, 
    0.03663748f, 0.02779902f, 0.02213166f, 0.01316489f, -0.18414348f, 0.28652695f, -0.21314412f, -0.09960431f, 
    0.06590425f, 0.08891042f, 0.15674593f, -0.02692662f, 0.06011671f, 0.00306677f, -0.09520251f, -0.05029846f, 
    0.02571621f, -0.07910705f, 0.09584364f, 0.07856080f, 0.00882229f, -0.02172689f, -0.01555855f, 0.03312500f, 
    0.00559084f, 0.04333919f, 0.13014950f, 0.13187453f, 0.10316748f, -0.00847014f, 0.02768918f, -0.30172879f, 
    0.08864077f, -0.03601959f, -0.06778627f, 0.04528679f, 0.19899701f, 0.07801343f, 0.12142652f, -0.05657777f, 
    -0.05906086f, -0.18162665f, 0.02778486f, 0.28312579f, 0.11688711f, -0.02178674f, -0.08034383f, 0.03872527f, 
    0.04162514f, -0.04661752f, -0.04155855f, 0.09730768f, -0.02225549f, -0.03531216f, 0.18327130f, -0.14098035f, 
    0.00628317f, -0.01627740f, -0.12811479f, 0.10035479f, -0.09439991f, -0.05659351f, 0.04996565f, 0.07668531f, 
    -0.09499072f, -0.04617731f, 0.02955088f, 0.02818208f, -0.01718135f, -0.06605422f, -0.01352509f, 0.01936220f, 
    -0.03291294f, -0.00802382f, -0.01046426f, 0.05039391f, 0.40348676f, 0.29793409f, 0.00682328f, -0.32348102f, 
    0.06917588f, 0.07207500f, 0.04730239f, 0.01550845f, 0.21380349f, 0.00264428f, 0.05351583f, -0.03171015f, 
    0.09915683f, 0.11009125f, 0.10949465f, 0.05500064f, -0.16594291f, 0.01461574f, -0.02570162f, 0.04502439f, 
    -0.07268504f, -0.08583260f, -0.07430561f, 0.00151555f, -0.59681088f, -0.10499110f, -0.05666333f, 0.03914427f, 
    0.03345033f, 0.03625916f, 0.12967500f, 0.01924921f, 0.05691727f, 0.02253763f, -0.07484418f, 0.03362535f, 
    -0.08747790f, -0.07608902f, 0.13220337f, 0.10426635f, 0.06965233f, 0.05420775f, -0.04372888f, -0.05552936f, 
    0.07141715f, 0.03345455f, 0.02370615f, 0.02288203f, -0.04635388f, 0.16186711f, -0.12930678f, 0.07361394f, 
    0.16983920f, 0.01033144f, 0.02079512f, -0.02157334f, -0.01431511f, 0.15033667f, -0.04299088f, -0.01601042f, 
    0.02004809f, 0.14544494f, 0.13057518f, -0.01235366f, -0.12681073f, -0.06667575f, 0.03480138f, -0.07091110f, 
    -0.07464876f, 0.07247896f, 0.14024788f, -0.04800094f, -0.06393627f, -0.21583770f, -0.01072897f, -0.29171434f, 
    -0.05503397f, 0.06006102f, 0.06776852f, 0.01387368f, 0.10917763f, -0.05086459f, 0.09554721f, -0.13112189f, 
    0.04266443f, -0.04274382f, -0.11391665f, 0.12342620f, -0.05337833f, -0.03762502f, -0.00239059f, -0.02675916f, 
    -0.01094817f, 0.02778575f, -0.00088892f, 0.01509316f, 0.07128862f, -0.15847571f, 0.08786230f, -0.03685590f, 
    0.08974861f, 0.04279575f, -0.02298830f, -0.00529443f, 0.09648280f, 0.14729619f, 0.07223807f, 0.02155624f, 
    0.20418563f, 0.10018258f, -0.16893512f, -0.02979020f, -0.00630755f, 0.02056636f, 0.01278332f, 0.09680887f, 
    0.02445689f, -0.04686547f, 0.02870687f, 0.04192953f, 0.17667201f, 0.06015348f, -0.09465040f, -0.20430310f, 
    -0.04433743f, -0.00969375f, 0.11562771f, -0.03144816f, 0.08362893f, -0.00345381f, 0.04250560f, 0.04918044f, 
    -0.01058373f, -0.16952094f, -0.17406794f, -0.05087189f, 0.14914708f, 0.03711563f, -0.02601515f, -0.02907691f, 
    -0.01599351f, -0.01566938f, -0.00697492f, 0.03629927f, 0.10757315f, 0.09492371f, 0.05658639f, 0.09543516f, 
    0.02403214f, -0.01924521f, -0.02126850f, -0.00142609f, 0.02170802f, -0.21960606f, 0.06968080f, 0.11665244f, 
    -0.01574712f, 0.16989572f, 0.11851685f, -0.12833051f, -0.06688660f, 0.01879009f, -0.01512873f, 0.11065754f, 
    -0.11389458f, 0.04986984f, 0.08206495f, 0.08538537f, -0.00198264f, 0.04518822f, 0.24601772f, 0.20762913f, 
    0.08246665f, 0.11712876f, -0.00127711f, 0.07622906f, -0.04252575f, -0.01282966f, -0.07193699f, 0.09052741f, 
    0.16666491f, -0.06697893f, -0.04248216f, 0.08599631f, -0.07468232f, 0.01653057f, 0.05439994f, 0.02667410f, 
    -0.00733680f, 0.01764251f, -0.00652575f, 0.01491547f, 0.14433908f, 0.03300428f, 0.04615524f, 0.10696910f, 
    -0.08210913f, -0.14143296f, 0.00607108f, 0.01642810f, 0.04427037f, 0.00450065f, 0.04159676f, -0.02782273f, 
    -0.06019881f, 0.25030848f, -0.08794166f, -0.09945975f, -0.04358476f, 0.01699303f, 0.19548243f, -0.06901223f, 
    0.00754513f, -0.07050579f, 0.06727515f, 0.03929842f, -0.20425846f, -0.06874157f, 0.10760972f, 0.04116113f, 
    -0.06352818f, -0.08362154f, 0.03766010f, -0.02092773f, -0.02063770f, -0.06088817f, 0.03446135f, -0.02806415f, 
    0.35297185f, 0.00089312f, -0.24521120f, -0.00300420f, -0.02554652f, 0.00930053f, 0.06668817f, 0.10416745f, 
    0.13023053f, -0.00275566f, -0.06490085f, -0.01623004f, -0.03440402f, -0.10079155f, -0.22657949f, 0.29260206f, 
    0.15857911f, 0.05114681f, 0.03423177f, 0.06148897f, -0.03403726f, 0.03804069f, 0.00497472f, 0.01279999f, 
    0.22601828f, -0.00541450f, -0.05411713f, -0.08961606f, 0.00466749f, 0.01395323f, -0.08203045f, 0.04135345f, 
    0.04502440f, -0.03269273f, -0.15725067f, 0.04844128f, -0.10553971f, 0.01197865f, -0.04276709f, 0.20788062f, 
    0.01236574f, -0.01509564f, 0.01701678f, 0.04908937f, 0.14999169f, -0.01438826f, -0.01579872f, 0.06049949f, 
    0.07286780f, 0.17981194f, 0.23854983f, 0.24916676f, 0.03571227f, 0.03024755f, 0.03898329f, -0.06352407f, 
    -0.11275811f, -0.11966655f, 0.04540166f, -0.11975257f, 0.16803347f, 0.00563809f, 0.14728802f, -0.03284056f, 
    -0.03481384f, -0.01780841f, -0.02538933f, -0.01350628f, 0.01947377f, -0.03085172f, -0.19392541f, 0.12727748f, 
    0.32904473f, -0.03440137f, -0.02598248f, -0.08953755f, -0.00570670f, -0.03073996f, -0.00036796f, 0.07658732f, 
    0.12513998f, 0.02780277f, 0.20991667f, -0.07338049f, -0.38717273f, -0.08363201f, -0.26462674f, 0.00728707f, 
    -0.01785894f, -0.04615100f, -0.07416575f, -0.08253077f, 0.07761879f, 0.09880955f, 0.15082303f, 0.00639322f, 
    0.11166260f, 0.05842199f, 0.02192624f, 0.13686843f, 0.16545035f, 0.08647776f, 0.21497346f, -0.07073431f, 
    0.07055382f, -0.02646577f, 0.10530273f, 0.00172363f, -0.09633816f, -0.06702513f, -0.21034059f, -0.17780092f, 
    0.03395582f, 0.20462279f, 0.14038908f, 0.09509625f, 0.02570317f, -0.02490860f, 0.06145797f, -0.10657089f, 
    0.15245765f, -0.00409716f, -0.01656429f, -0.08958481f, 0.18770957f, 0.00222550f, -0.00287693f, -0.16325511f, 
    0.00308545f, -0.02771033f, -0.09632598f, -0.01297821f, 0.26474112f, -0.12253808f, -0.10002498f, -0.10544806f, 
    -0.04074353f, 0.00835272f, 0.03764395f, 0.00996620f, -0.04165162f, 0.20716405f, 0.13121229f, -0.04294432f, 
    -0.02701191f, 0.05465112f, 0.22555614f, 0.12776287f, 0.04849331f, 0.03909281f, 0.01977519f, 0.05566943f, 
    0.05093524f, 0.09286201f, -0.11964986f, 0.06973094f, -0.39754084f, -0.19903944f, -0.10940760f, 0.00276510f, 
    0.14680515f, 0.10344826f, -0.05434259f, -0.12346763f, -0.01416962f, 0.11886159f, -0.11527315f, 0.10034973f, 
    -0.03812166f, 0.01437857f, -0.08300011f, -0.00686285f, 0.05233464f, -0.01303409f, 0.05703902f, 0.12027266f, 
    -0.02575794f, 0.00201125f, 0.12891917f, -0.04890386f, 0.35039213f, 0.00363473f, 0.26610008f, -0.13807350f, 
    0.14488959f, -0.07624383f, 0.12587158f, -0.06158845f, 0.06773137f, -0.01963600f, -0.01528259f, 0.14193089f, 
    -0.09989496f, 0.01597106f, -0.08791543f, -0.19575854f, 0.13560566f, -0.06175837f, -0.00910968f, 0.16304842f, 
    -0.00661594f, 0.02810434f, 0.08139118f, 0.17901202f, 0.28510690f, -0.16523537f, -0.21738191f, -0.06431350f, 
    -0.01341976f, -0.04366572f, -0.02369830f, -0.09140931f, 0.03690887f, -0.04051553f, 0.21291272f, 0.07006294f, 
    -0.00085643f, 0.00979345f, -0.10724234f, 0.09604497f, -0.06429247f, 0.06492070f, 0.13301985f, 0.03902526f, 
    0.13127102f, 0.01753427f, -0.04680619f, -0.05094705f, -0.09914128f, 0.17440474f, 0.13528618f, 0.01743166f, 
    0.14149196f, 0.11465224f, -0.14912605f, -0.09993769f, -0.05120004f, -0.03782664f, 0.08646008f, -0.04708734f, 
    0.41350576f, -0.17840604f, -0.09846458f, 0.11156769f, 0.05115217f, 0.00418710f, 0.07021406f, 0.08553990f, 
    0.09647676f, 0.06654957f, 0.02205775f, -0.10349953f, -0.20335127f, 0.01010076f, -0.09271283f, -0.05186620f, 
    0.17925240f, -0.09322555f, 0.11144529f, -0.04797908f, 0.06713734f, 0.12758698f, 0.01747232f, 0.09895179f, 
    -0.03977517f, 0.02004573f, 0.07825866f, 0.03790088f, 0.12866083f, 0.02241930f, 0.02174758f, -0.02641269f, 
    0.02056628f, 0.17616741f, 0.02585158f, 0.06606051f, -0.04939603f, 0.10561645f, 0.02954528f, -0.00346202f, 
    0.03046134f, -0.15379658f, 0.06701651f, -0.05266316f, 0.15839389f, 0.08235846f, 0.08589085f, 0.11711977f, 
    0.21705587f, 0.15625277f, -0.02252706f, -0.12127910f, -0.03461786f, 0.07546814f, -0.00677770f, 0.16497071f, 
    -0.03015166f, -0.02710094f, -0.01748495f, 0.16824035f, 0.17632325f, 0.07238177f, 0.17174049f, 0.07382651f, 
    0.25019959f, 0.13695601f, -0.13895112f, 0.01786541f, -0.11017504f, -0.02691296f, 0.07289618f, 0.03254665f, 
    0.25526729f, -0.09522594f, 0.17189680f, 0.00978082f, 0.04020486f, 0.21939661f, 0.01189430f, -0.06339552f, 
    -0.05091282f, -0.00501960f, 0.01950913f, 0.10684654f, -0.19719926f, 0.10077540f, -0.18341222f, -0.24771000f, 
    0.06880466f, 0.02053412f, -0.03596213f, -0.09757275f, 0.03098295f, -0.03227842f, -0.10494815f, -0.04393901f, 
    0.25353357f, 0.07764876f, 0.03780655f, -0.21281545f, 0.14594251f, 0.03242828f, -0.01982296f, 0.02722964f, 
    -0.00044353f, 0.06066012f, 0.02383837f, 0.10715356f, -0.20355004f, -0.09674092f, -0.04222406f, -0.06052422f, 
    0.13933201f, -0.05832450f, -0.06483064f, -0.00748582f, -0.01044007f, 0.07117398f, -0.04291420f, 0.07960006f, 
    0.02418450f, -0.17826064f, -0.18583047f, -0.04522332f, 0.07230714f, -0.03559958f, -0.08028340f, 0.04373460f, 
    -0.01082320f, -0.01872344f, 0.04430229f, 0.08073761f, 0.10427300f, -0.14867805f, 0.06634104f, 0.25143015f, 
    0.00599851f, 0.10297328f, -0.14189507f, 0.10928887f, 0.15483642f, 0.03032254f, -0.00722819f, -0.09744260f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.12398955f, -0.02402471f, -0.04600661f, 0.00128023f, -0.04656070f, -0.05885908f, 0.00224285f, 0.00224639f, 
    0.04592441f, 0.04041569f, 0.01923562f, 0.01427152f, 0.04097669f, 0.03019459f, -0.01736966f, 0.09759587f, 
    -0.03770320f, 0.06269421f, 0.13966925f, 0.02734481f, 0.02212354f, -0.04495934f, -0.03557270f, 0.08574926f, 
    -0.07217635f, -0.01073318f, -0.07406859f, -0.00743610f, -0.00187329f, 0.02384236f, 0.08322431f, -0.02857000f, 
    0.02963807f, 0.02833921f, 0.11033407f, -0.03917808f, -0.00907622f, -0.06170954f, -0.00402684f, -0.01883488f, 
    -0.00143952f, -0.03048559f, 0.07934766f, 0.05770295f, -0.03167607f, 0.00843151f, -0.02661256f, -0.04678646f, 
    0.00329121f, -0.04611153f, 0.11063560f, -0.04271204f, -0.03654600f, -0.05923893f, -0.05200732f, 0.01090293f, 
    -0.01384747f, -0.03224473f, 0.03702641f, -0.02557906f, -0.03922615f, 0.02699755f, 0.04751178f, 0.08973732f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.51610518f, 0.23141897f, 0.04049784f, 0.04950845f, 0.16703875f, 0.14475752f, -0.03565306f, -0.07013886f, 
    -0.52868593f, 0.10254665f, -0.22880609f, 0.12475796f, -0.10546717f, 0.09224103f, -0.09035297f, -0.21784340f, 
    0.11272252f, 0.18598630f, -0.19413495f, -0.02134381f, -0.01247750f, 0.00013811f, 0.06531171f, -0.16520755f, 
    -0.03405297f, 0.20883197f, 0.27483293f, -0.02075883f, -0.08882786f, 0.03588691f, -0.30252519f, 0.24870618f, 
    -0.57153893f, 0.12114980f, 0.09128829f, 0.09738874f, -0.09236228f, -0.14576523f, -0.02912881f, -0.05707875f, 
    -0.01765250f, -0.06484849f, -0.06697904f, 0.23614676f, -0.00783589f, -0.08683033f, -0.09239423f, 0.01788682f, 
    -0.00263392f, -0.12463228f, 0.25179315f, 0.02265641f, 0.10734303f, -0.04464110f, 0.38069698f, -0.01097835f, 
    -0.11351163f, -0.02942780f, 0.01814754f, 0.12704214f, 0.01000765f, -0.03095461f, -0.08867227f, -0.36034045f, 
    0.08211706f, 0.01412607f, 0.14148389f, 0.03235702f, 0.09705079f, -0.09283303f, -0.07920154f, -0.15925613f, 
    0.04172989f, -0.16491680f, 0.39124033f, -0.08739659f, -0.10776395f, 0.04315485f, 0.01708265f, 0.11870325f, 
    -0.00963497f, 0.06340142f, 0.22848594f, 0.01909867f, 0.03884196f, -0.10780005f, 0.12229632f, -0.26262996f, 
    -0.28999862f, 0.05798778f, 0.25953820f, -0.10217658f, -0.10943177f, -0.00716258f, 0.06668317f, 0.22244500f, 
    0.06203927f, 0.04470651f, -0.23151262f, -0.01380882f, -0.05732411f, -0.54879415f, 0.03731502f, -0.07298689f, 
    0.05675565f, 0.02401543f, -0.01149413f, 0.23809977f, 0.04317186f, -0.06924778f, -0.04720228f, -0.00415931f, 
    -0.01127463f, 0.06463227f, 0.02039107f, 0.09038831f, -0.43832967f, -0.14670448f, -0.33453995f, 0.11495022f, 
    0.11736955f, 0.00222923f, 0.24133652f, -0.25617114f, -0.04538804f, 0.10368226f, 0.16797706f, 0.19141015f, 
    -0.56690228f, -0.56478870f, -0.13116945f, -0.10164060f, -0.24250601f, 0.18163896f, 0.10671810f, -0.45660055f, 
    -0.26401815f, -0.13042003f, -0.01167215f, 0.30110541f, -0.02713731f, -0.04917490f, 0.01577037f, 0.12105586f, 
    0.10196575f, -0.18904628f, 0.08634402f, -0.02024879f, 0.06181709f, -0.11058821f, 0.29821023f, 0.01653046f, 
    -0.05441833f, -0.19287021f, 0.28253224f, 0.03741880f, 0.15145667f, -0.05564441f, -0.04711077f, -0.21511008f, 
    -0.02439114f, 0.08633817f, -0.21766965f, 0.08268005f, -0.02703764f, -0.15943377f, -0.01274484f, 0.08398391f, 
    -0.10305845f, -0.11772082f, 0.01309631f, 0.21848097f, 0.23123275f, -0.12088540f, 0.11319268f, 0.09048724f, 
    -0.05590208f, 0.07036513f, -0.19148958f, 0.07674172f, 0.16836120f, 0.53541112f, -0.08616816f, -0.00448553f, 
    -0.03543524f, -0.00166201f, -0.28505048f, 0.16072541f, 0.01882951f, 0.06393126f, -0.11183426f, 0.14431310f, 
    -0.08612601f, 0.00599063f, 0.33873439f, -0.05669898f, -0.50028557f, 0.00275839f, -0.02007930f, -0.08453756f, 
    0.15942441f, -0.14135838f, 0.37735918f, 0.17698136f, -0.02841644f, 0.02587678f, -0.05029663f, 0.05171194f, 
    0.11516950f, 0.19980597f, -0.30540258f, -0.02200632f, 0.04518021f, -0.08549597f, -0.39625269f, 0.08207221f, 
    0.12456200f, 0.28407353f, -0.73899311f, -0.07334942f, 0.23951808f, 0.04357448f, -0.57391179f, 0.13962351f, 
    0.23443906f, -0.03713360f, -0.09819707f, -0.00111986f, 0.04762686f, -0.04920756f, -0.07302837f, 0.04207781f, 
    0.02718820f, 0.04221438f, 0.01291785f, -0.56600904f, 0.03249664f, 0.07381453f, 0.12761325f, -0.10337015f, 
    -0.08423267f, -0.07616027f, 0.08858461f, 0.05744302f, 0.24712518f, 0.34190446f, -0.15683953f, -0.09016080f, 
    -0.06365094f, -0.01765420f, -0.09928845f, -0.18414822f, -0.13258979f, 0.10518164f, 0.20767021f, -0.48603237f, 
    0.07573640f, 0.19946837f, -0.41016304f, -0.06264977f, 0.32423532f, -0.09312153f, -0.04056012f, -0.05442839f, 
    -0.09519357f, 0.06620353f, 0.15465260f, -0.02598937f, -0.09733267f, 0.08116247f, 0.06355629f, -0.20523427f, 
    -0.03230772f, 0.09593862f, -0.12850922f, -0.02396881f, -0.07344127f, -0.10167965f, 0.18983591f, -0.42647386f, 
    -0.15293194f, 0.29467639f, -0.14793472f, 0.10401347f, 0.12097803f, -0.11960639f, 0.21536086f, 0.02727343f, 
    0.23721588f, 0.10223247f, 0.00636944f, 0.09660963f, -0.05161375f, 0.30035132f, -0.08921000f, 0.08156493f, 
    -0.10395949f, 0.10978248f, 0.11456511f, -0.17171270f, -0.44275525f, 0.06266870f, -0.08692551f, 0.05241942f, 
    0.00636299f, 0.08817618f, 0.04198410f, -0.07287467f, 0.19565633f, -0.11957476f, -0.43143746f, 0.10131719f, 
    0.08735542f, 0.03871655f, -0.39079300f, 0.06115755f, -0.02813370f, -0.09198947f, 0.24228024f, -0.09798712f, 
    0.01015400f, 0.29755941f, 0.04668270f, -0.06872767f, -0.00501658f, 0.16728424f, -0.05306826f, 0.30518699f, 
    -0.29616392f, 0.27758175f, -0.19946574f, -0.43651041f, -0.09836990f, 0.00362474f, 0.11621457f, -0.06101926f, 
    -0.03463177f, -0.13765813f, 0.15851304f, 0.08555968f, -0.12747511f, 0.03045838f, -0.20990117f, 0.40791404f, 
    -0.15294757f, -0.24926277f, -0.40460190f, -0.06630412f, -0.32140264f, -0.06703614f, 0.22813150f, 0.13846740f, 
    -0.15987258f, 0.02996618f, -0.15249498f, -0.08946616f, 0.01178488f, 0.10016587f, -0.05448090f, -0.11682840f, 
    0.01481984f, 0.12292267f, 0.22738037f, 0.05585979f, -0.22336350f, -0.09134554f, -0.10441776f, 0.03040284f, 
    0.10889284f, 0.09739878f, 0.12862048f, -0.09924429f, -0.34442475f, -0.20306459f, -0.13991164f, 0.10339037f, 
    -0.01277989f, -0.00372406f, 0.22410734f, 0.13433385f, 0.00021326f, 0.05936285f, -0.38616404f, 0.08176442f, 
    0.00805376f, -0.25391677f, 0.04571789f, 0.04065237f, -0.02357000f, -0.31301805f, 0.09207366f, 0.04333815f, 
    0.40401551f, -0.28782222f, -0.34870979f, 0.05882266f, 0.09532695f, 0.10501099f, -0.08752757f, 0.18288884f, 
    -0.07405698f, -0.23828515f, -0.01459983f, -0.00728617f, 0.04877533f, -0.01138543f, -0.59890413f, 0.08592742f, 
    0.10227507f, 0.04444188f, 0.22427601f, -0.10494534f, 0.23403758f, -0.11906053f, 0.26304662f, -0.14568888f, 
    -0.42544243f, -0.04819995f, 0.14841495f, 0.01011846f, -0.05964515f, 0.17508310f, -0.03652414f, 0.08107548f, 
    -0.04859836f, 0.02148865f, -0.27927741f, 0.12605123f, -0.62781578f, 0.08362067f, -0.05302306f, 0.05572456f, 
    -0.03129689f, 0.08973978f, -0.17998876f, -0.02260908f, -0.10193728f, 0.22569895f, 0.26051271f, -0.03907205f, 
    -0.05680291f, 0.00121842f, 0.29967502f, 0.20569904f, -0.08302107f, -0.11392260f, 0.28904533f, -0.23812908f, 
    0.27117544f, 0.17401020f, -0.05782006f, -0.02003719f, -0.20471506f, 0.17029078f, 0.07183135f, 0.03108280f, 
    0.19345297f, 0.15728267f, -0.31301636f, 0.13217944f, 0.01413625f, 0.08623376f, -0.01101156f, -0.41336605f, 
    0.10961409f, -0.36718312f, -0.28230333f, 0.09225655f, 0.08185486f, -0.05617248f, -0.00979718f, -0.06196952f, 
    0.28615868f, -0.08148214f, 0.18762386f, 0.01928779f, -0.40914845f, -0.09350318f, -0.26288423f, 0.11815937f, 
    0.12735355f, -0.10012586f, -0.16489483f, -0.03394778f, 0.08935677f, 0.27371150f, -0.01428038f, -0.00114224f, 
    0.10566933f, -0.04163982f, -0.49391013f, -0.13609630f, 0.10958017f, -0.00204303f, -0.07054944f, 0.05888381f, 
    0.11549307f, 0.02999782f, -0.37131056f, 0.07811915f, 0.02172482f, 0.16666698f, -0.11857078f, 0.10683910f, 
    0.11407750f, -0.10660873f, -0.19938478f, 0.13828519f, 0.08217245f, -0.02137004f, -0.12070697f, -0.06219069f, 
    -0.20055802f, -0.18757932f, 0.27987894f, -0.02916247f, 0.19748907f, -0.36772656f, -0.05242433f, 0.33985662f, 
    -0.07021461f, 0.33363926f, 0.19009174f, -0.28324178f, 0.11270998f, -0.01274030f, -0.09515556f, -0.21747951f, 
    0.03987558f, -0.25392401f, 0.15891047f, 0.04128759f, 0.02968272f, 0.06741525f, 0.22712764f, 0.14656040f, 
    0.04164213f, -0.52365720f, 0.03289037f, -0.10372524f, 0.08872529f, -0.01526908f, -0.24585912f, -0.24379866f, 
    0.13746054f, 0.03443911f, -0.20264708f, -0.05171420f, 0.09017954f, -0.04987073f, -0.03941862f, 0.11903863f, 
    -0.03683666f, 0.05409871f, 0.09692930f, 0.02045996f, 0.26782799f, -0.09925092f, -0.06073576f, -0.07920198f, 
    -0.02217669f, -0.12496532f, -0.38135394f, 0.01441424f, 0.01123765f, -0.18280742f, 0.13880290f, 0.00964574f, 
    -0.12667505f, 0.07622011f, -0.16041598f, -0.50763786f, -0.10255369f, 0.02861722f, 0.23947056f, 0.19319364f, 
    0.29703346f, -0.10277434f, 0.04706450f, 0.08052858f, -0.07357483f, 0.28469738f, -0.08102999f, -0.17342620f, 
    -0.33412346f, -0.53067869f, -0.21523187f, -0.27126825f, 0.02624695f, -0.02328931f, -0.12162474f, -0.07272797f, 
    0.05701167f, -0.41309476f, 0.22329669f, -0.07450264f, 0.03987685f, -0.01017839f, -0.14605814f, 0.00187349f, 
    0.35106787f, 0.24124667f, 0.12244642f, -0.07786402f, 0.12026916f, 0.03711310f, 0.03454738f, -0.60504186f, 
    -0.53015727f, -0.03292353f, -0.13011417f, 0.10311131f, 0.03878549f, 0.26750600f, 0.12285466f, 0.01397551f, 
    -0.07379223f, -0.07446183f, -0.10300609f, 0.04549332f, 0.08358271f, -0.07974377f, 0.02553845f, -0.05124714f, 
    -0.07883227f, -0.00608971f, 0.18517978f, -0.07088029f, 0.27632004f, -0.21360353f, -0.04152540f, -0.00208560f, 
    -0.01316860f, 0.05183455f, -0.41715312f, 0.08479974f, -0.03723130f, 0.09024294f, -0.38684618f, 0.21364310f, 
    0.22611634f, -0.28662077f, -0.46089104f, -0.10562730f, -0.54754311f, -0.05652509f, -0.01678865f, -0.16645654f, 
    0.06383032f, 0.30675563f, -0.26390350f, 0.13384029f, 0.03933775f, 0.05798195f, 0.01601330f, -0.01047978f, 
    0.00898218f, 0.29973283f, 0.28183043f, 0.04640165f, 0.05909526f, 0.09020209f, -0.40346387f, 0.40564501f, 
    -0.18747538f, -0.17105284f, -0.13066770f, -0.13168432f, -0.18409555f, -0.02501301f, -0.37462130f, -0.11413043f, 
    0.02792706f, -0.07322121f, 0.33414876f, -0.03595611f, 0.08830711f, -0.37026319f, 0.08380901f, 0.05367304f, 
    0.07829120f, -0.00267328f, 0.26235738f, -0.05899440f, 0.02324983f, 0.07825132f, 0.02199886f, 0.02871512f, 
    0.10918210f, -0.11868510f, 0.17625095f, 0.09417629f, 0.16467576f, -0.05158371f, -0.65383029f, 0.05111269f, 
    0.09392329f, 0.01004340f, 0.06587917f, -0.29587778f, 0.03222354f, 0.10061817f, 0.14052610f, 0.29114085f, 
    0.15722783f, -0.07349414f, -0.38284764f, -0.01013858f, -0.57114989f, 0.17905517f, 0.11372959f, 0.07412992f, 
    0.12983623f, -0.18152408f, 0.02756187f, 0.20596035f, 0.06917013f, 0.11126477f, 0.03345938f, 0.08445726f, 
    -0.07508814f, -0.09199355f, -0.24526967f, -0.06842424f, 0.06547764f, 0.04468947f, 0.27521229f, -0.25501272f, 
    0.05192488f, -0.28457731f, -0.23868424f, -0.02184826f, 0.15277010f, -0.00284697f, 0.14496072f, 0.11608195f, 
    -0.00589123f, -0.06837083f, 0.40917236f, -0.11178708f, 0.11609419f, -0.06084055f, -0.13171409f, 0.10043709f, 
    -0.04864536f, -0.02702346f, 0.25940263f, -0.27697697f, -0.22338194f, 0.03511284f, 0.09933549f, -0.04991268f, 
    0.01064235f, -0.06445119f, -0.28568447f, 0.03876242f, -0.05433372f, -0.33757401f, 0.53000271f, 0.02333943f, 
    0.08182837f, 0.02262606f, 0.26999846f, -0.20701467f, -0.06426941f, 0.02499186f, -0.38892254f, 0.22129913f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.07091184f, 0.01297995f, 0.01026826f, -0.06644842f, 0.00478029f, -0.05045475f, -0.06894293f, 0.02578087f, 
    -0.10210840f, 0.09914519f, 0.12512590f, 0.00732248f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
