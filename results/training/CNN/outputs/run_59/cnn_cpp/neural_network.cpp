#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.89220333f, 0.36205384f, 0.97457838f, -0.89204490f, 0.93475717f, 1.08428466f, -0.12343892f, -0.63325959f, 
    -0.48335287f, -0.90630823f, 0.01735678f, 0.33523399f, 0.25411150f, -0.08310412f, -0.60748088f, -0.16397518f, 
    0.17689930f, 0.30043352f, -0.47161615f, -0.44956315f, -0.15318924f, -0.03162935f, -0.03087239f, -0.05391306f, 
    -0.06375542f, 0.56392455f, -0.39258224f, 0.57956648f, 0.19839552f, 1.04834390f, -0.86595440f, -0.51687711f, 
    -0.31134993f, -0.94481766f, -0.19561784f, 0.32478902f, 0.50799030f, -0.10738130f, 0.31191462f, 0.00170613f, 
    -0.01489839f, -0.24043807f, -0.18612693f, 0.52652836f, -0.52289927f, 0.30271950f, 0.39079285f, -0.12993073f, 
    0.39669046f, 0.18968308f, 1.75440443f, 0.51235765f, -0.83285123f, -0.31617472f, -0.70152009f, -0.42284650f, 
    -0.05479007f, -0.01733514f, 0.25810260f, 0.12906007f, -0.07583088f, 0.52770770f, -0.02727718f, 0.03437956f, 
    0.07543238f, 0.05843281f, -0.05240926f, 0.05331224f, 0.18306245f, 0.15561874f, -0.22472879f, 0.41592613f, 
    0.44770721f, -0.15592909f, -0.06449423f, -0.29849386f, -0.81339711f, -0.80035204f, 0.10000230f, -0.58037579f, 
    0.58824426f, 0.25648627f, 0.08038097f, 0.11140901f, 0.38127685f, -0.52853584f, -0.48773965f, -0.04244003f, 
    -0.30138040f, -0.66436279f, 0.10906845f, -0.42591530f, 0.65773249f, -0.22701053f, 0.17551732f, 0.55221689f, 
    -0.33223632f, -0.38199058f, 0.05576096f, -0.15643857f, -0.33296344f, -0.10572419f, 0.17732260f, 0.09141688f, 
    0.20167372f, -0.05666802f, -0.15561458f, 0.02459835f, -0.11329735f, -0.14979200f, 0.02236596f, 0.47489271f, 
    0.64201123f, 0.17360975f, 0.06403697f, -0.18630509f, -0.16591062f, 0.44484672f, -0.08706281f, 0.68512970f, 
    -0.36395139f, 0.24440850f, -0.02535555f, 0.64705777f, 0.22761784f, 0.14618754f, 0.27546084f, -0.69544721f, 
    0.19651940f, 0.66705739f, 0.64288914f, 0.73615110f, 0.33199871f, -0.18328340f, 0.55371827f, 0.28179875f, 
    -0.41576028f, -0.12729900f, -0.32187086f, 0.02536467f, 0.21126108f, -0.21352448f, -0.05576804f, -0.21909851f, 
    0.10846303f, 0.04776366f, -0.24869767f, 0.27698487f, 0.45513871f, 0.04748636f, 0.08434552f, -0.54976696f, 
    -0.59423578f, -1.06037021f, 0.18785895f, 0.44909105f, -0.06819680f, 0.01664096f, -0.89939988f, -0.55134624f, 
    0.30836248f, 0.70568496f, 0.38889319f, -0.24703610f, 0.04363702f, -0.17065811f, -0.37189957f, -0.00862245f, 
    0.08252209f, 0.16427514f, 0.39052323f, -0.22185302f, 0.23744613f, 0.34524202f, -0.04281333f, -0.63569272f, 
    -0.29665124f, 0.19408616f, -0.04170843f, -0.65647745f, -0.81268138f, -0.31832269f, 0.32549825f, -0.01448913f, 
    0.54877377f, -0.43259376f, 0.18051170f, -0.28089058f, -0.30677581f, -0.22936787f, 0.31685036f, -0.28464925f, 
    -0.39816710f, 0.11399620f, 0.55679762f, 0.26966044f, -0.44580805f, 0.04522353f, -0.19558595f, -0.39750871f, 
    -0.49657741f, 1.09219909f, 0.61283237f, -0.59769553f, 1.07705986f, -0.13393837f, 0.81600296f, 0.92878580f, 
    -0.06211473f, 0.52826452f, -0.43442586f, -0.00122689f, 0.00788977f, -0.51728219f, -0.13199487f, 0.27377263f, 
    -0.21268614f, -0.27416980f, 0.35613015f, 0.10857333f, -0.09715828f, -0.13507272f, -0.23764820f, -0.31437275f, 
    0.22988299f, 0.02991132f, -0.60909593f, 0.75249255f, 0.78349668f, 0.35348180f, 0.48491445f, 1.07706809f, 
    0.43882030f, 0.14609727f, 0.52360952f, 0.04618287f, 0.07153679f, 0.17066351f, -0.18890545f, -0.47986096f, 
    -0.58825356f, -0.39780900f, -0.18262890f, 0.02579000f, -0.50539345f, -0.29676393f, 0.23914568f, -0.37880117f, 
    -0.11036873f, -0.15658072f, -0.52725720f, -0.87815833f, -0.78600436f, -0.32739931f, -0.13606554f, 0.25384706f, 
    1.11495543f, 0.33672738f, 0.78230965f, 0.47684187f, 0.22670415f, 0.26675457f, 0.22015581f, -0.03494505f, 
    -0.20966743f, -0.10066526f, 0.12012252f, 0.27455917f, 0.19256490f, -0.06318034f, 0.04391893f, -0.44040227f, 
    -0.01475996f, -0.36484605f, -0.04610637f, -0.11822259f, 0.54437137f, -0.65344036f, -0.95036042f, -1.07968175f, 
    0.53518248f, 0.28640383f, -0.41779634f, -0.63756347f, -0.06810118f, 0.11834066f, 0.32412732f, 0.05860643f, 
    0.13107137f, 0.19673723f, -0.20389256f, 0.13435268f, 0.15047246f, 0.12130343f, -0.48143744f, 0.10227472f, 
    -0.22982860f, 0.21916075f, -0.06154921f, 0.22907370f, -0.11690190f, -1.35600996f, 0.53965354f, 0.71786404f, 
    0.83936054f, 0.72670400f, 0.69268590f, 0.58267540f, 0.20619194f, -0.03628661f, -0.41096753f, 0.09297606f, 
    -0.09686411f, 0.63039547f, 0.02051308f, -0.06039237f, -0.24194856f, -0.24414127f, 0.05505341f, 0.16307162f, 
    0.11065029f, 0.16374476f, -0.19016407f, -0.02910013f, -0.24266540f, 1.55786991f, 0.42631444f, -0.24793474f, 
    0.67967623f, 0.95336425f, 0.45418909f, 0.22916408f, -0.74475205f, 0.50936812f, 0.06453509f, -0.19623588f, 
    -0.12550181f, 0.20081113f, 0.31495172f, -0.14910074f, 0.08162838f, 0.01192801f, 0.18850149f, 0.05795247f, 
    -0.13403739f, 0.45052379f, 0.32936749f, 0.03999469f, -0.10414575f, 0.01417218f, -1.52882171f, 0.77215707f, 
    0.40420675f, -0.78367859f, -0.66689122f, 0.63995951f, 0.66196108f, -0.15541339f, 0.21524617f, -0.10100620f, 
    -0.32984093f, -0.23134014f, -0.40492004f, 0.27219597f, -0.11157840f, -0.37709782f, -0.03601719f, -0.25704345f, 
    -0.16672449f, -0.24998122f, -0.01875328f, 0.02246042f, 0.19923382f, 0.30218968f, -0.00468695f, 0.26082316f, 
    0.47125742f, -0.79066539f, -0.68890423f, 0.93217736f, 0.05436784f, -1.14653015f, -0.47139895f, -0.74079919f, 
    -0.04035371f, -0.26752561f, 0.10754766f, 0.10589930f, 0.40712854f, 0.03367155f, 0.10736644f, -0.10496491f, 
    -0.62843770f, 0.03761855f, 0.35960284f, -0.09864011f, 0.48480439f, 0.06468882f, -0.20055754f, -0.53072470f, 
    -0.43436879f, 0.32732469f, -0.67904305f, -0.56700057f, -0.62048393f, -0.58642685f, -0.81176162f, -0.23507339f, 
    -0.29776609f, -0.94240141f, -0.03687771f, 0.22583716f, 0.61146080f, -0.05265578f, 0.50501764f, 0.14648023f, 
    0.43497112f, 0.04686917f, 0.52893770f, 0.09318417f, 0.14060609f, -0.23863882f, -0.19112632f, -0.02800450f, 
    -0.08684021f, -0.39299461f, -0.65117329f, 0.82918984f, -0.14511421f, -0.45743850f, 0.08723586f, -0.28494006f, 
    0.92612976f, 0.57226723f, -0.64079571f, -0.04108467f, 0.15326653f, 0.34754479f, 0.24278143f, -0.64319009f, 
    -0.02439781f, 0.38544917f, 0.38632381f, -0.55467826f, -0.45394361f, -0.01627418f, 0.24138446f, 0.18750790f, 
    0.10164174f, 0.10952604f, 0.34627330f, 1.12462533f, 1.05750000f, 0.54641688f, 0.78385270f, 0.88755459f, 
    -0.07600560f, -1.15169585f, 0.44176760f, -0.47757709f, 0.38579336f, 0.16528861f, -0.43223614f, 0.21693379f, 
    -0.35680380f, -0.07515878f, 0.03049442f, 0.03002481f, -0.08197732f, 0.03799323f, -0.01519861f, -0.03556615f, 
    0.13744719f, 0.09290168f, 0.24994311f, -0.21323681f, -0.44291306f, 0.45406616f, 1.29697299f, -0.98337877f, 
    -0.36236167f, -0.14693095f, -0.04484849f, -0.56043762f, 0.15108359f, 0.03266911f, 0.35710579f, -0.17005064f, 
    0.19328618f, 0.09103172f, -0.47823554f, 0.07322813f, 0.25916040f, -0.25131911f, 0.13210963f, 0.01803265f, 
    0.05888681f, 0.40639269f, 0.09128249f, -0.37396228f, 1.20359588f, 0.84698564f, 0.44546866f, 1.07254601f, 
    0.98203999f, 0.42471355f, 0.36073881f, 0.52520275f, -0.53987330f, -0.31750435f, -0.20985581f, 0.11431772f, 
    0.22010632f, 0.20739348f, 0.11826690f, 0.13169123f, 0.04660539f, 0.37475789f, 0.07883645f, 0.16584364f, 
    0.19010743f, -0.17467105f, 0.28299940f, -0.07582814f, 0.16478884f, 0.37936959f, -1.60074627f, 0.56160897f, 
    0.29809752f, -0.64518374f, 0.72496402f, 0.82768279f, 0.48085627f, -0.49196124f, 0.13044004f, -0.09535366f, 
    -0.31411138f, -0.18095954f, -0.17919321f, -0.23104259f, -0.19917756f, 0.04414275f, -0.23226932f, -0.09556974f, 
    -0.38862693f, -0.11672934f, 0.12732859f, 0.03758183f, -0.14524804f, 0.07580249f, 0.26089182f, 0.67565048f, 
    0.08998406f, 0.94439465f, 0.61846334f, -0.65744668f, 0.24711625f, 0.11007069f, 0.29515499f, 0.33618784f, 
    -0.60600555f, -0.53341115f, 0.04764216f, 0.11307211f, -0.26772001f, 0.04824502f, -0.04314568f, -0.03969691f, 
    -0.18409526f, -0.16022065f, -0.16788472f, -0.22343294f, -0.31676993f, -0.10209320f, -0.30413970f, -0.87590253f, 
    -1.30009067f, -0.82725883f, -0.39784995f, -0.19528651f, -1.15426898f, 0.50375313f, 0.84965748f, -0.23206584f, 
    0.21840771f, 0.29346609f, -0.12114502f, 0.12823914f, -0.20581280f, -0.06564204f, 0.05556097f, 0.07388364f, 
    0.11387397f, -0.27670792f, -0.31478173f, 0.22598612f, 0.24770765f, -0.16253689f, 0.40034410f, 0.23295829f, 
    0.33829293f, 0.97931606f, 0.69011074f, 0.72855306f, 0.40785617f, -1.03568578f, 0.57470930f, -0.96351987f, 
    -0.19791420f, 0.14909136f, 0.65945739f, 0.52077621f, 0.04047094f, -0.23276041f, -0.17114326f, 0.18347551f, 
    -0.14962897f, -0.08766945f, 0.22832352f, -0.29714587f, -0.40671158f, -0.18226112f, 0.12084845f, -0.30721071f, 
    -0.45830312f, -0.73245180f, 0.78587562f, -0.47616851f, 0.31417957f, 0.46838954f, 0.07707975f, 0.77677065f, 
    0.01176797f, 0.27141318f, 0.52041936f, -0.21257226f, -0.02600224f, 0.42889610f, -0.54860276f, 0.49736223f, 
    0.12967835f, 0.08025672f, -0.00503629f, 0.06393359f, -0.17530079f, -0.17185156f, 0.31418109f, -0.22307888f, 
    0.14954405f, -0.01046719f, 0.09323528f, 0.62147778f, 0.65724099f, -0.01871634f, 0.51654172f, -0.35463858f, 
    -0.87389034f, -0.75397372f, -0.86048675f, -0.75140065f, 0.00789264f, 0.51451355f, 0.34534827f, -0.02701815f, 
    0.38469529f, 0.39234853f, -0.01388254f, -0.03770331f, 0.25412703f, 0.36467090f, 0.34104380f, -0.09200586f, 
    -0.05456666f, -0.08673471f, 0.31982863f, 0.83053291f, -0.29354632f, -0.82803893f, -0.34264067f, 0.36142334f, 
    0.29139781f, 0.81374538f, 0.03656731f, 0.30275872f, -0.74220681f, -0.48262879f, -0.14268285f, -0.14910766f, 
    -0.09044500f, -0.65411639f, -0.28529990f, -0.00150210f, -0.17531554f, -0.26774523f, 0.03572527f, -0.31025505f, 
    0.04746931f, -0.38706654f, -0.09874314f, 0.24569468f, 0.63296008f, 0.37992558f, 0.65664244f, 1.08841872f, 
    0.87633276f, -0.06182533f, 0.34877172f, -0.05908899f, -0.08392593f, 0.36705738f, -0.55502427f, -0.33397382f, 
    0.27766266f, -0.33043224f, -0.10299176f, 0.17425191f, 0.40393800f, 0.04848753f, 0.11391427f, 0.34983414f, 
    0.26331899f, 0.41631621f, 0.10981530f, 0.06147425f, 0.19172673f, -0.29854339f, -0.86897576f, 0.08681949f, 
    0.90552872f, 0.51522028f, -1.05063152f, -0.10494500f, 0.54523951f, -0.47164240f, -0.16010265f, 0.54620653f, 
    0.14315437f, -0.13786612f, 0.29528990f, -0.03610094f, -0.20346102f, 0.40077212f, 0.38323784f, -0.13589729f, 
    0.06220593f, 0.16191995f, 0.05641420f, -0.35141671f, -0.16790681f, -0.39159003f, -1.27614701f, -0.60126966f, 
    0.19001497f, 1.12749326f, -0.88388687f, 0.50532746f, 0.53779155f, -0.32116407f, 0.05839803f, 0.01962230f, 
    0.22649936f, -0.16606818f, 0.12839082f, 0.15108410f, 0.38416415f, -0.11147153f, -0.19948167f, -0.05525905f, 
    -0.38213998f, -0.33121935f, -0.05679763f, -0.09978399f, 0.05820790f, -0.02150430f, -0.07749059f, -1.35062122f, 
    -0.20324101f, -0.81051785f, -0.73110622f, -0.54337263f, 0.96567410f, 0.43673596f, 0.04348905f, 0.64818406f, 
    0.74135232f, -0.14530112f, -0.71127862f, 0.39387953f, 0.05426751f, 0.46651641f, 0.10471705f, 0.17354152f, 
    0.19103956f, 0.20592457f, -0.23094119f, 0.12086192f, -0.01843939f, 0.28066692f, 0.22740048f, 0.39171103f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.32654697f, 0.08754310f, 0.16161537f, -0.14521305f, 0.18859161f, 0.29435816f, 0.54834592f, 0.32997856f, 
    0.07805178f, 0.10380287f, 0.05954534f, 0.42780483f, 0.42035255f, 0.15246215f, -0.05759592f, 0.34033483f, 
    0.29652578f, 0.13502158f, 0.31094655f, 0.32867762f, 0.35523558f, 0.22206080f, 0.01382938f, 0.25460643f, 
    0.10926171f, 0.17651086f, 0.16888762f, -0.00837407f, 0.32396215f, 0.33433327f, 0.15561181f, 0.27919489f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.75100952f, -0.08113149f, 0.25611192f, -0.36982694f, -0.02375275f, 0.05202318f, 0.00798088f, -0.25740674f, 
    0.07590635f, -0.03347923f, 0.02088920f, -0.00320665f, 0.16171660f, -0.15485388f, 0.10335080f, 0.09497984f, 
    -0.22956121f, 0.11592397f, 0.01442832f, -0.12444112f, -0.17322636f, 0.08198732f, 0.11590616f, -0.00576667f, 
    0.06920701f, -0.31829849f, 0.10766437f, -0.29679683f, -0.22833210f, -0.15882796f, -0.14887947f, 0.14806256f, 
    -0.11340932f, -0.03793336f, 0.10047253f, -0.04945146f, 0.12766019f, 0.16970074f, -0.23989134f, -0.04623951f, 
    0.00494257f, 0.23165928f, 0.08531430f, 0.03504186f, -0.08852769f, -0.20959355f, -0.02435260f, 0.21637188f, 
    -0.12262769f, -0.10354011f, -0.13736191f, 0.01185865f, 0.16139226f, -0.03362518f, 0.05247446f, 0.08221797f, 
    -0.03087096f, -0.06544451f, -0.13415030f, 0.05170609f, -0.01230851f, 0.10590308f, 0.20203686f, -0.08346176f, 
    -0.01328421f, -0.01300114f, -0.08028584f, -0.00486437f, -0.00560883f, 0.17116155f, 0.10097472f, 0.00571953f, 
    -0.37798494f, -0.10208745f, 0.10496654f, -0.25256094f, -0.00632673f, -0.00880148f, 0.06436958f, -0.04581122f, 
    0.00580744f, -0.07797143f, 0.01876733f, 0.05568127f, 0.05465800f, -0.05130225f, -0.19050734f, 0.24350843f, 
    0.05114735f, -0.00124581f, -0.08539604f, -0.02222318f, 0.12902497f, -0.16648382f, -0.07116768f, -0.09618837f, 
    -0.13095699f, -0.04541564f, 0.17375121f, -0.12998646f, -0.13083707f, 0.00124274f, 0.07483310f, -0.21856235f, 
    0.00341345f, -0.16010898f, -0.07609050f, 0.03014416f, -0.09995412f, 0.15019521f, -0.08705609f, 0.26614431f, 
    -0.14975640f, 0.03800467f, 0.12102722f, -0.04594756f, -0.08541798f, 0.06529082f, -0.12266006f, -0.01824711f, 
    0.10846058f, 0.26075265f, -0.13125996f, -0.42789072f, 0.06238091f, 0.07437788f, 0.15598932f, 0.04213041f, 
    -0.00917373f, 0.11366953f, -0.07341651f, 0.05807288f, 0.00634065f, 0.05672280f, 0.11916488f, -0.35356236f, 
    0.07862987f, -0.05626015f, 0.10561064f, -0.05093098f, 0.03799703f, -0.13023028f, -0.15975209f, 0.04700924f, 
    -0.16602927f, 0.03862262f, -0.09189845f, 0.13590299f, -0.03694764f, 0.00156635f, -0.01350703f, -0.17684288f, 
    0.04747336f, -0.17368232f, 0.05123013f, -0.04324984f, 0.30201873f, 0.00823842f, 0.01323667f, 0.21221870f, 
    -0.02000427f, 0.00955829f, -0.00405518f, 0.06876119f, -0.08189196f, 0.12089666f, 0.00580171f, -0.10217390f, 
    0.31656951f, 0.19991636f, 0.11740015f, -0.04179268f, 0.00315306f, 0.02441151f, 0.01869689f, 0.12107265f, 
    0.09072904f, -0.05725143f, 0.02751324f, 0.04780186f, 0.17277952f, -0.06995408f, 0.26476386f, -0.44813859f, 
    -0.02860578f, 0.10438879f, 0.01517878f, -0.09389921f, 0.04626781f, -0.18848343f, -0.11435127f, -0.10928475f, 
    -0.56146240f, 0.17229329f, 0.16808583f, 0.11221182f, -0.05136609f, -0.00821657f, 0.06549063f, -0.05742459f, 
    -0.04232271f, -0.00616216f, -0.07460109f, -0.12975577f, 0.02744094f, 0.02229320f, 0.07265925f, 0.10470997f, 
    -0.00641464f, 0.13343011f, 0.14302105f, -0.16306071f, -0.05688401f, 0.21810168f, -0.16662095f, -0.00114079f, 
    -0.04458252f, -0.01775338f, 0.06900456f, 0.07495335f, -0.26250488f, -0.21222866f, -0.02128626f, 0.01139052f, 
    0.04621798f, -0.04699149f, -0.06829985f, 0.00484650f, 0.09846313f, -0.01772732f, -0.54189843f, 0.36866677f, 
    0.00964668f, -0.11776684f, -0.04874839f, -0.14258970f, -0.09586789f, 0.06204512f, -0.02312410f, -0.01421686f, 
    0.21302444f, -0.00754997f, -0.16049789f, 0.09461684f, -0.29119077f, 0.02153872f, -0.01038524f, 0.09747791f, 
    -0.11933371f, -0.01419997f, -0.02839964f, -0.01675810f, -0.07598371f, 0.24467649f, 0.32326058f, 0.04360572f, 
    -0.02700271f, 0.04732201f, 0.07865504f, -0.13495798f, -0.14785938f, 0.03270457f, -0.09128647f, -0.04150788f, 
    0.09822320f, -0.05784076f, -0.01903184f, 0.31914586f, -0.15207878f, 0.06749149f, 0.04472879f, -0.06784839f, 
    -0.00166449f, -0.10475723f, 0.13318627f, -0.15367380f, -0.77650142f, 0.23567581f, -0.23351324f, -0.19859791f, 
    0.03204136f, 0.06419899f, -0.12344080f, 0.10109266f, 0.03218652f, -0.06501437f, -0.10178933f, 0.08910153f, 
    0.07485554f, -0.17322479f, -0.05643200f, 0.15597934f, -0.08096256f, -0.08005117f, -0.07256114f, 0.11044425f, 
    0.07425037f, 0.19454670f, -0.06025076f, -0.14519219f, 0.33423778f, 0.04192572f, 0.08130299f, -0.07647971f, 
    -0.13134529f, -0.04768058f, 0.10098322f, -0.19441536f, -0.02683120f, 0.09748866f, -0.02540236f, -0.03243843f, 
    -0.18172324f, 0.31101918f, 0.26341587f, -0.13436988f, -0.03284340f, -0.00756879f, 0.05762436f, -0.04697251f, 
    0.04666677f, -0.18065216f, -0.07155002f, 0.06450237f, -0.18310599f, 0.27767000f, -0.04739349f, -0.27116778f, 
    0.11930843f, 0.09748959f, -0.07804712f, 0.04536670f, -0.04471285f, 0.02064428f, -0.01163216f, -0.18419322f, 
    0.03777881f, -0.00875221f, -0.22315460f, 0.47532302f, -0.15293798f, -0.03156160f, -0.02114633f, 0.05429445f, 
    -0.07302808f, 0.02253677f, -0.09937967f, 0.09562065f, -0.03280871f, 0.01323514f, -0.12780766f, 0.23191431f, 
    -0.10252535f, 0.05631350f, 0.03106940f, -0.13046472f, -0.06871829f, -0.20618916f, -0.00082190f, 0.05999609f, 
    0.32758620f, 0.11815335f, -0.17572640f, 0.18967435f, -0.00354318f, 0.07766314f, 0.01473212f, 0.01161910f, 
    0.10149115f, -0.06443933f, 0.27461058f, 0.03582019f, 0.59840244f, 0.07388449f, -0.14089461f, -0.34811997f, 
    0.18957815f, 0.09785983f, -0.11823251f, 0.07111406f, 0.03192638f, -0.05952175f, -0.11261076f, 0.06780516f, 
    0.16218613f, -0.14068958f, -0.16489458f, -0.30941036f, -0.21223122f, 0.03884593f, -0.01589498f, -0.09538314f, 
    -0.04962379f, -0.07215077f, -0.11297619f, -0.03020701f, -0.34529123f, -0.07692725f, 0.02262813f, 0.04183104f, 
    0.12541732f, 0.00407676f, 0.03506523f, 0.22203250f, 0.09269535f, 0.20192303f, -0.26748323f, 0.07189196f, 
    0.61445832f, -0.32815573f, -0.01279954f, -0.21957441f, 0.07429484f, -0.25513506f, 0.12301183f, -0.00637294f, 
    -0.24561104f, 0.09438540f, -0.04542996f, 0.05595088f, -0.08176555f, -0.10968544f, 0.12965511f, -0.00103794f, 
    0.10233878f, -0.14415774f, 0.00954653f, 0.03120515f, 0.10207302f, 0.06785046f, -0.02069627f, 0.00213132f, 
    -0.06658603f, 0.04525809f, 0.01256068f, -0.17413887f, -0.00648247f, -0.04657761f, -0.16828464f, -0.32811427f, 
    0.06657193f, -0.11311820f, 0.06729084f, -0.06058994f, 0.14653844f, -0.07800202f, -0.04849215f, 0.02773311f, 
    -0.17050964f, 0.00998234f, -0.11024716f, -0.11399601f, 0.00773055f, 0.00127978f, -0.04220508f, 0.22240129f, 
    0.38332212f, -0.12238562f, 0.02899807f, -0.22603153f, 0.08743819f, -0.06653246f, 0.00943128f, 0.04323475f, 
    0.02273521f, 0.01159502f, -0.01749175f, -0.17052427f, -0.17334192f, -0.05737333f, -0.11763251f, -0.30838442f, 
    0.08050400f, -0.03992327f, -0.13006806f, -0.03485866f, -0.13897006f, 0.06515322f, -0.05607614f, 0.10136940f, 
    0.01900428f, 0.33466965f, -0.04478448f, -0.07972369f, 0.23277839f, 0.11324958f, -0.02046689f, 0.09042890f, 
    0.11487130f, 0.05798081f, 0.05609333f, -0.02914902f, 0.14021432f, 0.15041542f, 0.11043424f, 0.11907589f, 
    -0.08205061f, 0.19104277f, -0.00944294f, 0.04910203f, -0.03882813f, -0.09622853f, -0.03165628f, -0.09985273f, 
    0.26586223f, -0.20136465f, -0.09016215f, -0.04244810f, 0.08593287f, -0.09406490f, -0.04362483f, 0.14069065f, 
    0.00373354f, 0.02603801f, 0.04552318f, 0.10591700f, -0.02564095f, -0.08586942f, -0.13656029f, -0.28521219f, 
    0.03088178f, 0.03715564f, 0.08093935f, 0.08204052f, -0.01476894f, -0.03190490f, 0.09776784f, -0.06973429f, 
    0.37527028f, -0.01619998f, -0.13026568f, 0.11658473f, -0.15627125f, 0.07805322f, 0.04218697f, 0.03308062f, 
    -0.04709562f, 0.20859134f, -0.06813904f, -0.09992819f, 0.31810731f, -0.43908519f, 0.14633094f, 0.07812870f, 
    -0.28381547f, -0.09993356f, -0.19322076f, -0.02170698f, -0.08689392f, 0.06448962f, -0.15395606f, 0.00495337f, 
    -1.09393907f, 0.02201634f, -0.21707578f, -0.15236057f, -0.05287787f, -0.07380237f, -0.08343299f, -0.18692330f, 
    -0.10646366f, 0.06579009f, -0.13680632f, -0.17462754f, 0.00264089f, -0.20950711f, 0.03279773f, -0.41942778f, 
    -0.00954995f, -0.20887621f, 0.16658631f, -0.03998119f, -0.04298366f, 0.04856138f, 0.03808702f, -0.02805736f, 
    -0.14277782f, -0.10930443f, -0.00746203f, -0.08743257f, 0.08562094f, 0.14046542f, 0.13104092f, 0.00794306f, 
    -0.04600339f, 0.23034510f, 0.00397512f, 0.11951877f, -0.47229791f, -0.04047497f, -0.28245592f, -0.12435748f, 
    -0.11704069f, -0.04985259f, -0.01253287f, -0.00344212f, 0.07693812f, -0.37650621f, 0.06042694f, -0.01151292f, 
    0.24738842f, -0.15210344f, 0.33579686f, 0.19998562f, -0.12803957f, 0.13131092f, 0.05308333f, 0.04324383f, 
    -0.18591364f, 0.02796552f, 0.15038349f, -0.08265819f, -0.52494693f, -0.02796465f, -0.37761280f, 0.20606610f, 
    0.02779752f, 0.02502977f, -0.07549226f, 0.02459959f, 0.11509304f, -0.29684016f, 0.06326657f, 0.20579423f, 
    0.23145600f, 0.18746364f, 0.10601132f, 0.29222530f, -0.12746422f, -0.10622178f, 0.00632216f, -0.01474703f, 
    0.08405644f, 0.01597811f, 0.01508911f, 0.11774076f, 0.01804090f, -0.16952096f, -0.18635935f, 0.15248176f, 
    -0.05299713f, 0.12517495f, 0.01760613f, -0.02764557f, 0.11282786f, -0.05819575f, 0.02886507f, -0.03168630f, 
    0.30205145f, -0.08022422f, -0.07627890f, 0.12066077f, -0.05795480f, 0.11990190f, 0.02129548f, 0.08922100f, 
    -0.01469335f, -0.03376060f, -0.16755985f, 0.00803373f, 0.45536596f, -0.14937083f, -0.14815597f, 0.08207713f, 
    -0.03447013f, 0.00896842f, -0.04080910f, 0.00076803f, 0.13537487f, -0.15042108f, -0.05676297f, 0.07469603f, 
    0.17527875f, 0.04137497f, 0.00789222f, 0.06449794f, -0.12061538f, -0.08709560f, 0.06125162f, -0.09798911f, 
    0.09069855f, -0.08412208f, -0.12042545f, -0.02965002f, -0.02472131f, 0.13797155f, -0.05281617f, -0.03759711f, 
    0.06646428f, 0.22467826f, -0.09681208f, -0.02484132f, -0.05651594f, -0.08880631f, 0.17017822f, 0.03984329f, 
    -0.13191418f, -0.10579710f, -0.19146679f, -0.16751173f, -0.05329782f, 0.04440649f, 0.09082023f, -0.12193310f, 
    0.06681474f, 0.10555323f, -0.00696833f, 0.15967338f, 0.42501539f, -0.57925874f, 0.07909755f, 0.11224022f, 
    0.08685513f, 0.01343684f, -0.26038826f, 0.00686282f, -0.12750627f, -0.07097922f, -0.02119812f, -0.07487172f, 
    0.37336195f, 0.11853550f, 0.04682146f, 0.25976372f, -0.13901095f, 0.17205235f, 0.06072691f, 0.04606143f, 
    0.09334657f, -0.06206853f, 0.05787814f, -0.03863287f, -0.41848812f, -0.13238668f, 0.01308927f, 0.33823708f, 
    0.07500114f, -0.12606707f, -0.15846957f, 0.06761640f, -0.05382156f, -0.09841334f, 0.19648112f, 0.03419672f, 
    -0.32908344f, 0.26062849f, -0.19892129f, 0.26705939f, 0.04234681f, 0.03593480f, -0.02758937f, 0.03169416f, 
    -0.09755254f, -0.17631719f, -0.05002767f, 0.13321511f, -0.14003165f, 0.12085693f, -0.07321081f, -0.26142105f, 
    0.09165592f, -0.06642608f, 0.01788231f, 0.06225373f, 0.17760332f, 0.15040761f, 0.02841058f, 0.02277569f, 
    0.17292638f, -0.36365438f, -0.05145214f, 0.04235949f, -0.07771030f, -0.25369614f, 0.06294139f, -0.07849948f, 
    -0.10498099f, 0.06506654f, -0.14240508f, 0.08198803f, 0.13999611f, 0.17429580f, -0.11050609f, -0.21790752f, 
    0.06199030f, 0.14348732f, 0.05885149f, -0.12765777f, 0.01621185f, -0.11109719f, 0.08571710f, -0.18792121f, 
    -0.06109817f, 0.04990340f, 0.08470197f, -0.25763795f, -0.08237788f, -0.08186621f, 0.22916807f, 0.07568382f, 
    -0.03588656f, 0.05988827f, 0.08897082f, 0.00114444f, -0.11257292f, -0.10203072f, 0.02928317f, 0.18265896f, 
    -0.11198815f, 0.02449098f, -0.02767164f, 0.03922353f, 0.04614748f, 0.19766511f, 0.05900263f, -0.22774926f, 
    0.03083684f, 0.08892648f, -0.09702921f, 0.05725252f, -0.04495396f, 0.01576815f, 0.06509956f, 0.04093352f, 
    -0.17925584f, -0.03073901f, 0.15407528f, -0.16636170f, 0.00265939f, 0.00326514f, 0.16236909f, -0.06800623f, 
    0.01239507f, -0.11355384f, 0.00390422f, 0.01558656f, 0.02032404f, -0.09386321f, 0.00081271f, -0.02250545f, 
    -0.31537500f, -0.11910767f, 0.17519917f, -0.17499983f, -0.11106405f, -0.14316639f, -0.05686489f, -0.05863830f, 
    -0.18896672f, -0.00043958f, -0.06276748f, -0.06050826f, 0.13741980f, -0.23264217f, 0.05645638f, -0.13525133f, 
    -0.10413571f, 0.11068706f, 0.03552479f, 0.03498768f, -0.10595617f, -0.04552095f, -0.08506056f, 0.01992959f, 
    0.41319990f, -0.14015968f, -0.22401784f, 0.01812843f, 0.06952097f, 0.09335761f, 0.17187925f, 0.01049411f, 
    -0.04740993f, 0.02553027f, -0.04155448f, 0.09063070f, 0.14965823f, 0.02890801f, 0.10115699f, 0.01155228f, 
    -0.05376076f, 0.02164416f, 0.04319306f, 0.14193651f, -0.01628002f, 0.16929284f, -0.09358870f, -0.01286799f, 
    0.39902183f, 0.08354622f, 0.20604280f, 0.29720160f, -0.24872066f, -0.14321227f, -0.04982726f, 0.15097061f, 
    -0.01065887f, -0.05269044f, -0.02333068f, -0.04988153f, -0.16064022f, -0.14729899f, 0.02508069f, -0.24067870f, 
    -0.05686030f, -0.20147833f, 0.06886367f, 0.01363476f, -0.05096242f, 0.02721644f, 0.01922234f, 0.00916519f, 
    0.02915025f, -0.12813476f, 0.07279993f, 0.02046946f, -0.03838579f, 0.00742396f, -0.02596642f, -0.05212583f, 
    0.02656621f, -0.09291568f, -0.06709891f, -0.02633784f, 0.18828821f, -0.20286147f, 0.09322009f, -0.23251334f, 
    0.27700984f, -0.11676138f, 0.05949944f, -0.04353910f, -0.12529641f, 0.12366206f, -0.06781205f, -0.11943954f, 
    0.62717909f, 0.25162601f, -0.22779918f, -0.26443526f, -0.01078707f, 0.01785441f, 0.02003285f, 0.02603211f, 
    -0.01199183f, 0.01533095f, 0.11927305f, 0.12842657f, -0.58911014f, -0.11435165f, 0.05969174f, -0.31864020f, 
    0.08425968f, 0.14963484f, 0.16880718f, -0.13587111f, -0.00954930f, 0.05144303f, 0.02221301f, -0.14360225f, 
    -0.27477407f, -0.05581075f, -0.34191880f, -0.26262885f, 0.03679895f, -0.10758194f, -0.05488572f, -0.04883314f, 
    -0.11192539f, -0.02729131f, -0.13987313f, -0.12888625f, -0.39636934f, 0.04195704f, 0.02947456f, 0.10823386f, 
    -0.04755103f, -0.01017766f, -0.00883083f, -0.00300339f, 0.09051028f, 0.18257153f, 0.00789572f, -0.13047656f, 
    0.21500449f, -0.28794980f, -0.12445306f, 0.13014038f, 0.10971080f, 0.05704876f, 0.10549344f, -0.14101335f, 
    -0.00338721f, 0.06096574f, 0.00396386f, 0.00308316f, -0.00207016f, -0.19658419f, -0.21026421f, -0.25523365f, 
    -0.27654067f, 0.08645517f, -0.04767660f, 0.03071129f, 0.02493819f, 0.06161522f, -0.05136363f, -0.10030816f, 
    -0.07685133f, -0.05099560f, 0.02417413f, -0.06983813f, 0.14029077f, -0.01695105f, -0.00248174f, -0.02051142f, 
    -0.01712010f, -0.10134351f, -0.08605201f, -0.01517086f, -0.06015982f, -0.19917691f, 0.17880058f, -0.07666866f, 
    -0.05547305f, -0.01285205f, -0.03227699f, 0.06304348f, 0.06784216f, 0.04197884f, 0.01929259f, -0.18864985f, 
    -0.08720297f, -0.21850975f, -0.09331615f, -0.07244018f, 0.21882662f, 0.01833127f, 0.03869545f, -0.12860256f, 
    -0.04999145f, 0.01905798f, 0.10380655f, -0.09237159f, 0.65682971f, -0.04629291f, -0.14994855f, 0.37091535f, 
    -0.20835142f, -0.15400696f, -0.05865872f, 0.08171484f, 0.01927676f, -0.03657442f, 0.09111327f, 0.02169873f, 
    0.33684924f, 0.06495678f, -0.10009687f, -0.05467311f, 0.08069497f, 0.13483943f, 0.02678723f, -0.18124978f, 
    -0.09399743f, -0.17066264f, 0.06438368f, -0.22860132f, 0.06421039f, -0.11623112f, 0.04321223f, -0.07177218f, 
    0.04147626f, -0.01299836f, -0.02754745f, -0.04416516f, -0.02406877f, -0.06507961f, -0.19108212f, -0.09855819f, 
    -0.07968193f, 0.11470501f, -0.31698018f, -0.06614026f, 0.14119221f, -0.02053938f, -0.01091707f, -0.03306739f, 
    -0.09968708f, -0.07163808f, -0.03618090f, -0.22482306f, -0.26700044f, -0.23889449f, 0.08645722f, -0.08505803f, 
    -0.05656016f, -0.07318381f, 0.10547019f, 0.13066638f, -0.06127004f, 0.06402393f, 0.01481484f, 0.07408974f, 
    -0.05341237f, -0.14991176f, -0.01304210f, 0.13738030f, 0.11229961f, 0.03470484f, -0.02287933f, -0.03545529f, 
    0.10730213f, 0.05835444f, -0.05869959f, 0.06110646f, 0.56096089f, -0.05930365f, -0.24753502f, 0.14866148f, 
    -0.20892513f, 0.10053191f, -0.01081123f, 0.05018182f, 0.01354434f, -0.01602577f, -0.01358858f, 0.09191737f, 
    0.58364445f, -0.29524589f, -0.10068642f, -0.30298221f, -0.01810055f, 0.03907132f, -0.23914818f, 0.23443520f, 
    0.12285575f, 0.06523690f, -0.12819788f, -0.12859352f, 0.28108180f, 0.29663906f, 0.15558968f, 0.42227849f, 
    -0.06922428f, -0.18339476f, -0.08499469f, 0.00677507f, -0.16236973f, 0.02795433f, -0.09362062f, 0.02375282f, 
    0.48557922f, 0.07929567f, 0.25728863f, 0.07618611f, 0.08034897f, -0.07936896f, -0.01548657f, 0.11316702f, 
    -0.02890169f, 0.06322213f, -0.20369613f, -0.08053716f, -0.27616227f, 0.04669297f, 0.26808894f, 0.32647949f, 
    0.03959865f, 0.11320589f, 0.12123792f, -0.20058343f, -0.10137617f, 0.00552562f, 0.14300740f, -0.17372546f, 
    0.02747054f, -0.56619900f, -0.01265512f, 0.09686561f, -0.17308955f, 0.08537468f, -0.03652887f, 0.19912609f, 
    0.03629996f, -0.05202045f, -0.16571777f, 0.12762110f, 0.01923984f, -0.10326387f, -0.14324339f, -0.20084529f, 
    -0.01826644f, -0.11388953f, 0.09442427f, 0.11263309f, 0.03031724f, 0.11969691f, 0.02890519f, -0.05511912f, 
    -0.22412407f, 0.04009562f, 0.08928322f, -0.06217427f, 0.07977121f, -0.17901126f, -0.00001054f, 0.16975383f, 
    0.01908786f, -0.20390683f, -0.04404768f, -0.01461241f, -0.36741871f, 0.15108581f, 0.08877248f, 0.00633491f, 
    -0.07254536f, 0.06985769f, 0.04771892f, -0.04060517f, -0.00779351f, -0.04434336f, 0.11178719f, 0.03548537f, 
    0.13787068f, 0.03919992f, 0.02271962f, -0.07081128f, -0.09196071f, 0.01608079f, 0.17510454f, 0.10853386f, 
    -0.01872044f, -0.04901493f, 0.09979804f, 0.00593383f, -0.14131770f, 0.31201497f, 0.16534971f, 0.01594475f, 
    0.07495714f, 0.00630484f, -0.21070614f, 0.10022587f, -0.04183052f, -0.02685289f, 0.06349272f, 0.08722977f, 
    -0.69071913f, -0.05939998f, -0.06300850f, -0.14716597f, 0.05258198f, -0.09788378f, -0.07371976f, 0.12025601f, 
    0.12653573f, 0.06870369f, 0.02040263f, -0.03498146f, -0.51488143f, -0.23874125f, -0.23028982f, -0.11307630f, 
    0.02163615f, 0.08532700f, -0.00644724f, -0.03587120f, -0.03965186f, -0.03477842f, 0.13218676f, 0.06959545f, 
    -0.22956747f, 0.06071083f, -0.20775758f, -0.13939255f, -0.15318374f, -0.09165835f, -0.03144776f, -0.02118913f, 
    -0.11110287f, -0.00113823f, 0.05682369f, -0.02378216f, 0.08126565f, -0.07654922f, 0.06106928f, -0.06573354f, 
    -0.20227116f, 0.03144276f, -0.00604829f, -0.13425030f, -0.05226136f, 0.07299163f, -0.13665934f, 0.10872965f, 
    0.05092630f, -0.07255312f, -0.01449331f, 0.04939098f, -0.03539374f, 0.00012998f, -0.04070516f, -0.08233676f, 
    0.00851886f, -0.11457900f, 0.08797619f, -0.03686867f, 0.03878294f, -0.45716590f, -0.04630221f, -0.25029442f, 
    0.06959075f, 0.05081711f, -0.00575203f, -0.17656903f, -0.03294367f, -0.18221098f, 0.06471439f, 0.07082417f, 
    0.00777058f, 0.42988321f, 0.27795067f, -0.05827392f, -0.04598305f, 0.05273794f, -0.10121873f, 0.21609011f, 
    0.08798551f, -0.04728962f, 0.00119829f, -0.00630284f, 0.37761661f, 0.17741677f, 0.03386136f, 0.16741820f, 
    -0.07410447f, 0.02817056f, -0.29034272f, 0.03832569f, 0.02796259f, -0.05047663f, 0.01048965f, 0.01192736f, 
    0.17602517f, -0.06707261f, 0.13321786f, -0.05464155f, 0.01436533f, 0.08812463f, 0.03939499f, -0.00649428f, 
    0.15096802f, 0.04387818f, 0.02676615f, 0.06731678f, 0.22349192f, -0.06551831f, 0.06530498f, -0.08792177f, 
    0.00029820f, 0.05196477f, -0.08527504f, 0.03312605f, -0.09910887f, 0.05778847f, -0.11555342f, -0.01882960f, 
    0.60065317f, -0.46897361f, -0.21242923f, 0.22575150f, -0.01454895f, -0.03320013f, -0.00932694f, -0.00558174f, 
    -0.03136942f, 0.02054652f, 0.02473069f, -0.15840264f, -0.07298603f, -0.02126057f, 0.10597870f, -0.02977568f, 
    -0.05577127f, 0.16322178f, 0.02227006f, 0.09178519f, 0.02909449f, 0.04111006f, 0.03508842f, 0.02437469f, 
    -0.37478927f, -0.76456362f, 0.12042012f, 0.04867835f, -0.09122868f, 0.04113908f, 0.12061866f, -0.00091629f, 
    0.05836642f, -0.17999160f, 0.12656161f, -0.05959864f, 0.25572655f, -0.23218271f, -0.09584815f, 0.01686303f, 
    0.03301001f, 0.06903965f, -0.04754447f, 0.04779071f, -0.03550084f, -0.00869330f, -0.07381468f, -0.04506283f, 
    0.02054322f, -0.06183077f, -0.19696383f, 0.00171063f, -0.10714827f, -0.09055137f, 0.13908604f, -0.09599147f, 
    -0.03666355f, 0.09460147f, 0.07984177f, 0.03960711f, 0.22040877f, -0.00247174f, 0.09652440f, 0.04525444f, 
    0.00771808f, -0.19900428f, 0.04573685f, -0.09034491f, -0.16522054f, -0.01151764f, -0.05637861f, 0.01032943f, 
    -0.54062974f, 0.11753470f, 0.02463526f, 0.20425150f, 0.09902769f, 0.19153504f, 0.03837461f, 0.07847031f, 
    -0.10507485f, 0.13218677f, 0.04656737f, -0.01723609f, -0.38597786f, 0.22113444f, -0.19200379f, -0.16668776f, 
    -0.14174788f, -0.05944458f, -0.08208194f, 0.09767476f, -0.00207081f, -0.14106911f, -0.04416535f, 0.10847253f, 
    -0.01379711f, -0.13548711f, 0.06960754f, 0.20937984f, 0.09075184f, 0.05642211f, 0.03180328f, 0.04233168f, 
    -0.02694016f, -0.08546408f, -0.10375597f, -0.28722677f, -0.22199085f, -0.02286035f, 0.08757385f, 0.11339483f, 
    -0.11059836f, -0.20634012f, 0.09144682f, 0.05304777f, -0.03934097f, 0.18039483f, 0.12640603f, 0.03093382f, 
    -0.88079780f, -0.53788185f, -0.11948404f, 0.18863001f, -0.13613524f, -0.13932493f, 0.07075205f, -0.12218419f, 
    -0.00406765f, -0.04592722f, -0.15386619f, 0.07750136f, -0.19937699f, -0.03735261f, 0.37408686f, 0.11929467f, 
    -0.01031774f, 0.13553558f, 0.16535768f, -0.01211328f, -0.07180601f, 0.02987925f, -0.06080498f, 0.00137310f, 
    0.14300010f, 0.14350016f, -0.09759258f, -0.15441635f, 0.13601044f, -0.00016543f, 0.09039954f, 0.02161791f, 
    -0.03007798f, 0.04507624f, 0.04790941f, -0.01416543f, -0.16069736f, 0.12178940f, -0.08021606f, -0.40402225f, 
    -0.01363169f, -0.21557486f, 0.05035672f, -0.07706546f, 0.04368506f, -0.15301718f, -0.07633311f, 0.01005817f, 
    0.17182697f, 0.50831831f, -0.15034755f, -0.39655837f, 0.03992262f, -0.02512707f, -0.02094859f, 0.00711749f, 
    -0.02675822f, 0.00135115f, -0.00863638f, 0.11663683f, -0.37850904f, -0.35032496f, 0.26574552f, 0.02489522f, 
    0.10590027f, -0.19383331f, -0.15116309f, -0.16805361f, 0.18929115f, -0.14165175f, -0.01121103f, -0.18088064f, 
    -0.12283407f, 0.00080790f, 0.00092342f, -0.02501851f, -0.20256259f, 0.17925997f, 0.07184065f, -0.14658605f, 
    0.01705778f, 0.05888062f, 0.06387487f, -0.12016476f, -0.39442247f, -0.05760504f, 0.00342566f, 0.36133969f, 
    0.02464075f, 0.09737572f, -0.16973625f, 0.07741552f, -0.18351170f, 0.09630989f, 0.12299855f, 0.11012021f, 
    -0.09991554f, -0.17707454f, -0.00977302f, 0.00054722f, 0.00271085f, 0.10103348f, 0.30565861f, 0.03080162f, 
    -0.01775579f, 0.08096556f, -0.03643523f, -0.09859230f, 0.04636950f, -0.29618576f, -0.52023149f, 0.12303992f, 
    -0.00905740f, 0.02598551f, -0.13320084f, -0.07132279f, -0.15941304f, -0.17933553f, 0.06724329f, -0.09183002f, 
    -0.12503344f, 0.08774089f, -0.07341030f, -0.06382331f, 0.13288519f, 0.12388518f, -0.03141601f, 0.03157030f, 
    -0.17276482f, -0.16551328f, -0.02963949f, 0.05687808f, 0.24539688f, -0.25120491f, 0.05831446f, 0.24479568f, 
    -0.16628805f, 0.05447359f, 0.04849977f, 0.05741853f, 0.04051718f, 0.06989589f, 0.17763664f, 0.10841994f, 
    -0.00680858f, 0.34330305f, -0.15926668f, 0.07630729f, -0.14014727f, 0.02718069f, 0.10511348f, 0.04645991f, 
    -0.12047080f, -0.04715981f, 0.06536645f, 0.04522256f, -0.43686658f, 0.30665094f, -0.02381493f, 0.02792344f, 
    0.12972647f, -0.17038555f, 0.17051697f, 0.07538801f, -0.04062314f, 0.10614119f, 0.01950468f, 0.04481892f, 
    -0.50190616f, 0.22304653f, 0.14332077f, 0.31713420f, 0.06743937f, 0.01811390f, -0.00360393f, -0.09935719f, 
    0.08710773f, 0.03625901f, 0.08611042f, 0.01631497f, -0.05097416f, -0.30611092f, 0.17663269f, 0.14856212f, 
    0.09124741f, 0.08655225f, 0.24085185f, 0.08575726f, 0.22307591f, 0.12310281f, -0.15198341f, 0.01611247f, 
    -0.48508659f, 0.26863897f, -0.35013714f, -0.08443680f, 0.01427852f, -0.09486637f, 0.19129102f, 0.13970686f, 
    -0.02291486f, 0.01577270f, 0.02587942f, 0.00211517f, 0.29048142f, -0.03063783f, -0.06693710f, 0.22510161f, 
    -0.11236994f, 0.02139823f, 0.02156526f, 0.04541564f, 0.02430292f, -0.08721940f, -0.05079209f, 0.10103731f, 
    0.62998015f, 0.01364559f, -0.08753708f, -0.09308213f, -0.00109186f, -0.04893861f, 0.19701195f, 0.14461821f, 
    0.18339323f, -0.05412372f, -0.02648447f, 0.04479279f, -0.02485109f, -0.10573094f, -0.18185395f, 0.29716238f, 
    -0.08656655f, -0.00802359f, -0.08992616f, -0.12486231f, -0.14026313f, 0.08051189f, 0.03918688f, 0.07242277f, 
    0.33499283f, -0.03076470f, 0.07958234f, 0.04105925f, 0.02487216f, 0.01926339f, 0.06965310f, 0.17210315f, 
    0.00026815f, 0.10681444f, 0.04865328f, 0.05012851f, 0.33511284f, 0.13982198f, -0.33994991f, -0.30038902f, 
    -0.11374908f, -0.00554737f, -0.01107325f, -0.05365464f, -0.06075455f, 0.06829227f, -0.07082254f, 0.07787435f, 
    -0.10844716f, 0.35925704f, -0.00596744f, -0.02420197f, -0.14452001f, 0.01171208f, -0.06872011f, 0.07839903f, 
    0.00453864f, -0.12018262f, -0.02370309f, 0.03829442f, -0.25775024f, -0.25448465f, 0.14089547f, -0.41120946f, 
    -0.17899635f, 0.15330973f, -0.17905842f, -0.00422919f, -0.10444192f, -0.10903352f, -0.17519765f, 0.02832909f, 
    0.27761045f, 0.05764674f, -0.16185315f, 0.04003106f, 0.02596445f, -0.04182668f, 0.00794453f, 0.05490901f, 
    -0.08938044f, 0.00181380f, 0.12533662f, -0.17729989f, -0.85821444f, 0.30093387f, 0.01430633f, -0.08073664f, 
    0.11834049f, -0.02007642f, -0.20110707f, 0.03858891f, 0.10132886f, 0.01989510f, -0.04704941f, 0.08365579f, 
    -0.04967633f, 0.24639472f, 0.05603870f, 0.13087770f, -0.02800666f, 0.21327285f, 0.08070480f, 0.03559406f, 
    0.08841426f, 0.05651469f, -0.01930333f, 0.08025021f, -0.25279826f, 0.03356311f, -0.08557885f, 0.07636393f, 
    0.11949002f, 0.05670767f, 0.20495154f, 0.15181266f, -0.04284848f, -0.01572264f, 0.05230296f, -0.01892111f, 
    -0.73109293f, -0.11047935f, 0.16702528f, 0.09631634f, -0.02752274f, 0.05168905f, 0.05365428f, -0.01541395f, 
    0.02723963f, 0.14471544f, -0.06110846f, -0.04824186f, -0.20694278f, -0.14367492f, -0.02825834f, 0.04434762f, 
    0.02012497f, 0.07908875f, 0.04546339f, -0.07528154f, -0.00582930f, 0.02644625f, -0.09156097f, 0.05038486f, 
    -0.37449804f, -0.05675667f, 0.33844161f, 0.13709582f, -0.10757785f, 0.10275263f, -0.07010654f, -0.06691949f, 
    0.02740018f, -0.23182696f, 0.04018496f, -0.09651440f, 0.14164977f, -0.01358031f, -0.02211617f, 0.00894792f, 
    0.05303449f, -0.06783415f, 0.11254593f, 0.20961110f, -0.04069703f, -0.09627842f, 0.10883247f, 0.06686771f, 
    -0.05662707f, 0.15858912f, -0.15511920f, -0.08343095f, -0.04726933f, -0.00273497f, -0.01200440f, 0.08534466f, 
    0.06877869f, -0.07007682f, -0.12290782f, 0.04790175f, -0.16793303f, 0.15383753f, -0.00728783f, -0.01260061f, 
    -0.01994683f, 0.08443818f, -0.00515664f, -0.11087140f, -0.01012950f, 0.03930186f, -0.20752113f, -0.03920295f, 
    -0.61571431f, -0.17618601f, -0.13540189f, -0.38402957f, 0.02679355f, 0.00373475f, -0.12045220f, 0.03085173f, 
    0.04095939f, -0.09187117f, -0.19337027f, 0.04872274f, -0.09681543f, -0.20088625f, -0.03390341f, 0.21674964f, 
    -0.00682998f, -0.09109870f, 0.01808171f, -0.00619614f, -0.03996488f, -0.18898845f, 0.05887518f, 0.00890161f, 
    -0.37966621f, -0.28943574f, 0.46798989f, 0.40058267f, 0.11536181f, 0.09817699f, -0.01509931f, 0.11167147f, 
    0.00422093f, -0.09081689f, 0.12859327f, 0.00530191f, 0.20367524f, 0.15319359f, 0.36855525f, 0.02015576f, 
    -0.13966036f, 0.00600851f, -0.09044954f, 0.06240191f, -0.25590530f, -0.18448512f, 0.00591146f, -0.00316521f, 
    0.00035598f, 0.21804135f, -0.17099027f, -0.04014710f, 0.05792267f, -0.24378484f, 0.08454163f, -0.04223554f, 
    -0.05167432f, 0.00104736f, 0.00033007f, -0.10540354f, 0.19835313f, 0.10382392f, -0.17264786f, -0.13388616f, 
    0.14874882f, 0.05680854f, -0.19233343f, 0.00748314f, 0.06604909f, -0.06584298f, 0.01638481f, -0.50447327f, 
    0.01207104f, -0.04417470f, 0.02720843f, 0.10127454f, -0.13659061f, 0.02425622f, 0.05942411f, -0.03070639f, 
    -0.16589475f, 0.06079042f, 0.05910559f, 0.28110173f, -0.01851021f, 0.31818524f, 0.12084757f, -0.20833437f, 
    0.02501279f, -0.04803847f, 0.19516996f, -0.04059572f, 0.21468250f, -0.03614982f, -0.31050321f, -0.11520594f, 
    -0.22509369f, -0.25538889f, 0.09734681f, 0.20429146f, -0.04784197f, -0.03741390f, -0.06139834f, 0.05538214f, 
    0.18382907f, 0.12818816f, 0.27106106f, 0.10839129f, 0.16416691f, 0.03349286f, -0.34991053f, 0.04663644f, 
    -0.11331938f, -0.23625867f, 0.04951645f, -0.15343884f, -0.07930036f, -0.03330613f, -0.11935784f, -0.06367868f, 
    0.11159405f, -0.03506936f, 0.36095276f, -0.17712654f, -0.07136206f, -0.09078082f, -0.12040439f, -0.19207938f, 
    -0.12965895f, 0.20474461f, 0.06949880f, 0.16633172f, -0.00193169f, 0.07559447f, 0.16480890f, -0.07884280f, 
    -0.02253568f, -0.26531157f, -0.10835443f, -0.08481524f, -0.07646843f, -0.11659776f, 0.09026364f, -0.24530247f, 
    -0.40618616f, -0.02823986f, -0.20030190f, -0.19448352f, 0.07206900f, 0.19865812f, -0.10203327f, -0.29896078f, 
    0.11005875f, -0.24065487f, 0.01761839f, -0.04816931f, -0.43616223f, 0.03450268f, -0.12916040f, 0.10731804f, 
    0.07402935f, 0.09128902f, -0.14232826f, 0.06907548f, 0.07364787f, -0.08100495f, 0.18643621f, -0.03299929f, 
    -0.60750061f, 0.32069966f, 0.25389123f, -0.19878063f, 0.12955114f, 0.02518474f, -0.06267082f, -0.04995237f, 
    0.03074007f, -0.00709505f, -0.04237917f, 0.07953659f, 0.02100030f, -0.08579171f, 0.13066171f, -0.26965889f, 
    0.00786255f, -0.04205967f, 0.02994679f, -0.06258410f, 0.19271033f, -0.02280205f, 0.15292613f, 0.08748255f, 
    -0.22702728f, -0.29448783f, 0.16774385f, 0.16371089f, 0.05583693f, -0.05680224f, 0.21580242f, -0.07418831f, 
    -0.02018318f, 0.02322352f, -0.06563111f, -0.15513681f, -0.07450554f, -0.02287281f, 0.28086841f, 0.19536652f, 
    -0.03333910f, -0.12987509f, 0.03329737f, -0.03022247f, -0.00978460f, 0.07079232f, 0.06783776f, 0.04108160f, 
    -0.15123057f, -0.15291269f, 0.03696973f, 0.08625316f, 0.03525782f, -0.22879638f, -0.06749976f, -0.08631326f, 
    0.09202665f, 0.00259310f, 0.23932168f, 0.21220025f, -0.40862477f, -0.29623434f, -0.02412033f, 0.32029045f, 
    0.15885445f, -0.03153555f, 0.04882563f, -0.04340471f, 0.06302789f, -0.01407806f, 0.04108134f, 0.19962570f, 
    0.00029548f, -0.13204059f, 0.06146887f, 0.12503701f, 0.06113436f, -0.03186765f, 0.07743829f, -0.02121500f, 
    0.00006440f, 0.06389924f, -0.26060930f, 0.03140639f, 0.10028225f, 0.03498721f, -0.09745629f, -0.07925308f, 
    0.29246163f, -0.06414115f, 0.07674555f, 0.16443460f, 0.02467643f, 0.04388313f, 0.02609937f, -0.08087187f, 
    0.04842278f, 0.09639737f, 0.30544224f, 0.02941908f, 0.03570033f, 0.08549891f, 0.08210702f, -0.09838609f, 
    -0.01064947f, 0.00831380f, 0.08646255f, 0.14780743f, -0.21314807f, 0.26322028f, -0.16628651f, 0.06222499f, 
    0.01134167f, -0.08418652f, -0.08105527f, -0.02018894f, -0.04223694f, -0.14543080f, 0.01176548f, -0.17837727f, 
    0.02882875f, 0.00117714f, 0.34521216f, -0.15868226f, -0.14078739f, -0.16935283f, -0.14839573f, -0.10432938f, 
    -0.05626586f, -0.06940618f, 0.01250542f, -0.07761720f, -0.65702760f, -0.12710527f, -0.26128381f, -0.20174804f, 
    0.15365595f, 0.04475359f, 0.03658348f, -0.03016425f, 0.11557589f, 0.06973798f, -0.09985655f, -0.06660537f, 
    0.05759003f, -0.01962129f, 0.04895067f, -0.08661842f, -0.00576205f, -0.03141390f, 0.03630532f, 0.03072457f, 
    -0.08242640f, -0.18904348f, -0.04392841f, 0.19105299f, -0.28302333f, -0.02816743f, 0.10952007f, -0.21799758f, 
    -0.11162423f, -0.11738335f, 0.15546241f, -0.10470213f, 0.06178903f, 0.04683315f, 0.08571476f, -0.03165726f, 
    0.15651180f, -0.07644100f, -0.01588242f, 0.18140346f, -0.13699302f, -0.01549250f, 0.03402629f, 0.07586021f, 
    -0.23215701f, 0.17039706f, 0.21138205f, 0.34336299f, 0.29854286f, 0.26576275f, 0.02716601f, -0.02140424f, 
    -0.13712655f, 0.13270685f, -0.00629307f, -0.26648846f, 0.03769934f, 0.02995967f, -0.02161020f, -0.05099246f, 
    -0.04926442f, 0.02647376f, 0.24099410f, -0.39414981f, 0.07043141f, -0.17386386f, 0.00981280f, 0.04616594f, 
    -0.00064882f, 0.24232119f, 0.07097157f, 0.14247034f, -0.10240006f, -0.17129117f, -0.14499743f, -0.39326110f, 
    0.11068634f, -0.03524964f, -0.07063463f, 0.01164659f, 0.09588829f, 0.14210336f, 0.08032882f, 0.03552044f, 
    -0.65014291f, -0.00977641f, 0.17790364f, -0.20895332f, 0.05382612f, -0.02954064f, 0.04517494f, 0.02935056f, 
    -0.10822438f, -0.05563664f, 0.02927337f, -0.07447094f, -0.46115169f, -0.08265663f, -0.20058489f, -0.10852018f, 
    0.05568768f, 0.17761756f, 0.04796273f, -0.10876992f, 0.07820871f, -0.01994571f, 0.04792464f, 0.04103267f, 
    0.17562997f, -0.41073048f, -0.30596489f, 0.13786851f, -0.13086942f, -0.01573373f, 0.02405574f, 0.04886260f, 
    0.12400454f, 0.04349578f, -0.13135949f, 0.04874629f, 0.35923710f, 0.00350890f, -0.24231832f, -0.20940332f, 
    0.05565630f, 0.08418676f, 0.01620526f, 0.00010033f, 0.08623786f, 0.01820510f, -0.07130022f, 0.08730930f, 
    -0.24689673f, -0.21332836f, 0.11970276f, 0.26590514f, 0.04502637f, 0.18487893f, -0.04904110f, 0.16903165f, 
    0.07407993f, -0.16618423f, -0.04577997f, -0.04701699f, -0.13253896f, 0.00475836f, -0.00310268f, -0.28923652f, 
    -0.36497477f, -0.13963519f, -0.08729181f, -0.04207657f, 0.05508035f, 0.02580095f, 0.16141751f, 0.24884661f, 
    0.03074231f, -0.05211714f, 0.05307346f, 0.13582893f, 0.05284669f, -0.02496846f, -0.05619399f, -0.07692432f, 
    0.18740579f, -0.16005787f, -0.33657902f, -0.30221680f, -0.19172010f, -0.23231168f, 0.11965768f, 0.09097373f, 
    -0.01459841f, -0.03302589f, 0.06334353f, 0.08133756f, -0.05283221f, 0.06630091f, 0.06120470f, 0.08748128f, 
    0.00551294f, -0.10060485f, -0.37729344f, -0.01218801f, 0.00452490f, 0.13882835f, 0.06205961f, 0.03026151f, 
    0.07258359f, -0.06539910f, -0.16753173f, -0.10112267f, -0.15162270f, 0.01077762f, -0.15805607f, -0.20055814f, 
    -0.03551880f, 0.11214940f, 0.03876243f, 0.01921466f, 0.11890056f, 0.02033924f, 0.16136441f, -0.12363269f, 
    -0.39237359f, -0.06619354f, 0.04695584f, 0.29649076f, -0.05658298f, 0.05863443f, 0.09496212f, -0.01198413f, 
    0.06273138f, -0.22283396f, -0.18913896f, -0.02391131f, 0.45461553f, -0.58054024f, 0.06603333f, 0.01802752f, 
    -0.07080954f, 0.07740422f, -0.00246499f, -0.00754867f, 0.10010517f, 0.06582312f, 0.15010431f, 0.27517670f, 
    -0.29306984f, -0.53432417f, -0.22135085f, -0.18215778f, 0.00006678f, 0.00975910f, -0.01786948f, 0.01722364f, 
    0.03781113f, 0.05809732f, -0.00048407f, 0.12753604f, 0.12985457f, -0.12901966f, -0.26000687f, 0.36501062f, 
    -0.02625448f, 0.04481388f, -0.00959153f, -0.06396696f, -0.01266283f, 0.07468936f, -0.15211639f, 0.00585601f, 
    0.33617413f, -0.54559636f, 0.13052839f, 0.14356801f, -0.04026099f, 0.01687501f, -0.01790907f, 0.00839257f, 
    0.03735201f, -0.07241409f, -0.06002481f, -0.06723773f, -0.36121073f, 0.26435986f, 0.10165881f, -0.16599503f, 
    -0.09453001f, 0.02700213f, 0.01733486f, 0.06694799f, -0.06404368f, 0.06856895f, 0.08167022f, -0.03601204f, 
    0.44084644f, -0.28223637f, -0.14895000f, 0.19648749f, -0.02583908f, 0.14959233f, -0.03564547f, 0.00322648f, 
    -0.12180523f, 0.01079966f, 0.08620162f, 0.13997622f, -0.10613424f, 0.10943179f, -0.07927470f, -0.23395120f, 
    -0.02852038f, 0.07422037f, -0.01013361f, 0.05179485f, -0.03143919f, 0.02343975f, 0.12920345f, -0.06387480f, 
    -0.00114709f, -0.06819018f, -0.00481493f, 0.40353408f, 0.05783042f, 0.09503347f, 0.00976003f, -0.04567556f, 
    -0.12903018f, -0.22408983f, -0.06997477f, 0.05028279f, -0.15727566f, -0.36009267f, 0.09699417f, 0.09465642f, 
    -0.05738346f, -0.06203709f, 0.05941835f, 0.09623366f, 0.08142518f, 0.12930858f, -0.07998487f, -0.12829494f, 
    -0.09032180f, 0.16071376f, 0.08406925f, -0.26180083f, -0.05428901f, -0.12085214f, 0.10236275f, 0.05802694f, 
    0.13545309f, 0.03973919f, 0.02772884f, 0.03970870f, 0.16419479f, 0.05044301f, 0.16442585f, -0.25370425f, 
    0.01764014f, -0.00914817f, -0.10036317f, -0.13278353f, -0.10155322f, -0.08168825f, -0.10726964f, -0.07993946f, 
    0.01415742f, 0.11839519f, 0.34513214f, -0.37160644f, -0.13930358f, 0.08827028f, -0.13106500f, 0.06466574f, 
    0.02252316f, -0.02279657f, -0.04095701f, -0.11381567f, 0.40755454f, -0.55766451f, 0.10719784f, -0.08929609f, 
    0.04686814f, 0.14316343f, 0.14460747f, -0.03702297f, -0.16865648f, -0.00161844f, 0.20494792f, 0.18759637f, 
    -0.17021590f, 0.39480495f, 0.05166125f, -0.09329156f, 0.11909930f, 0.03877863f, 0.13683115f, 0.10307461f, 
    -0.08917679f, 0.12386788f, 0.00369049f, 0.16952121f, -0.07909999f, -0.28806233f, -0.18671516f, -0.42461500f, 
    -0.10347977f, -0.01958484f, 0.02759554f, -0.22128996f, -0.04798206f, -0.13447067f, 0.17371814f, 0.00743364f, 
    0.08791380f, 0.25331053f, 0.36015156f, -0.24352717f, 0.00452240f, 0.10201473f, 0.00641189f, 0.02132933f, 
    -0.08808836f, -0.04522862f, -0.03726919f, 0.12207941f, -0.23371789f, 0.11240672f, -0.08758879f, 0.18922062f, 
    -0.07053530f, -0.00970001f, 0.11602093f, 0.09083803f, -0.15323704f, -0.02036988f, -0.12784241f, 0.03500236f, 
    -0.00755723f, 0.10085317f, -0.11809641f, -0.22269011f, -0.01692317f, 0.11371389f, -0.05202222f, -0.03724098f, 
    0.07704957f, -0.16630699f, -0.07101876f, -0.20626941f, -0.23879662f, -0.20180082f, -0.12584737f, -0.00956049f, 
    0.01839177f, -0.07881557f, 0.30764723f, 0.05160223f, 0.05589657f, -0.12189008f, -0.10703228f, 0.06028683f, 
    0.08530156f, 0.20920797f, 0.22922638f, -0.41178659f, 0.03570812f, 0.14080562f, 0.02474193f, 0.07058468f, 
    -0.13560450f, -0.09200264f, 0.13403571f, -0.15845105f, 0.41641968f, 0.03762436f, 0.09629098f, -0.10474406f, 
    -0.06202910f, 0.10835622f, 0.24326463f, 0.07640250f, -0.03571842f, 0.00055584f, -0.17050339f, -0.04585204f, 
    0.48794520f, -0.10752554f, 0.31822950f, -0.30288419f, -0.19252953f, -0.02691923f, -0.11310811f, 0.05941908f, 
    0.11710219f, 0.13552527f, 0.15081704f, -0.07717530f, 0.03849696f, -0.16235165f, -0.03270501f, -0.05893007f, 
    -0.22402054f, 0.11691944f, -0.12300379f, -0.02574313f, -0.23041001f, 0.17467304f, -0.14979339f, 0.04789673f, 
    -0.03239064f, 0.07590076f, 0.08874401f, 0.09952793f, 0.04567480f, -0.03277710f, 0.07111426f, 0.01168193f, 
    -0.04080924f, -0.01807951f, 0.10567176f, -0.11640428f, 0.07845271f, -0.19532295f, -0.35001117f, 0.13003653f, 
    -0.05581568f, -0.18588725f, 0.00695376f, -0.16804001f, -0.06377660f, 0.04786596f, -0.07370682f, -0.01349968f, 
    -0.22249079f, 0.22471003f, -0.28816444f, 0.01839096f, -0.11334410f, 0.14391136f, 0.03501758f, 0.01671257f, 
    0.00248228f, 0.06725886f, 0.04757263f, -0.11901172f, 0.08223570f, 0.23051362f, 0.14385046f, 0.14824179f, 
    0.00482536f, 0.10781306f, 0.10976008f, 0.01482133f, -0.15839033f, 0.01557649f, -0.03991386f, -0.15372492f, 
    -0.03944539f, -0.20561409f, 0.02318021f, -0.17931290f, 0.07799464f, 0.04449011f, -0.08063179f, -0.18666410f, 
    -0.21410237f, 0.12329861f, -0.11509624f, 0.03595452f, -0.32913944f, -0.11708946f, 0.02447049f, -0.12602986f, 
    -0.10474904f, -0.13720630f, -0.11750903f, 0.07740428f, -0.03303277f, -0.05270945f, -0.07520731f, -0.14728260f, 
    0.16120754f, 0.03504419f, 0.16755353f, 0.14995973f, -0.14923303f, -0.02794407f, -0.07362165f, -0.12278786f, 
    -0.10743399f, -0.00292393f, -0.10296308f, -0.04021549f, 0.33795497f, -0.13319212f, 0.09838048f, 0.15205662f, 
    0.15557122f, 0.04016469f, 0.03561619f, -0.06402802f, 0.03271115f, 0.02947295f, -0.04248654f, -0.14950305f, 
    0.16791336f, -0.19777249f, 0.08866952f, 0.09000265f, -0.13559902f, -0.04845492f, 0.00542840f, -0.11860449f, 
    0.05958055f, -0.03749051f, -0.12568977f, 0.03195324f, -0.12133266f, -0.04763531f, -0.09979546f, -0.28061736f, 
    -0.00764357f, -0.00527925f, -0.13169245f, -0.13206407f, 0.05617357f, -0.07076189f, -0.13864990f, -0.01549190f, 
    -0.05037547f, 0.16189580f, 0.25213706f, -0.01946919f, 0.04987421f, 0.09745093f, -0.00142273f, -0.10458668f, 
    -0.05766052f, 0.07776292f, 0.01282682f, -0.08323263f, 0.25677410f, 0.19935593f, 0.11836598f, 0.28862152f, 
    0.00964140f, -0.08742320f, 0.02812198f, 0.01172854f, 0.11219694f, -0.05808901f, -0.07980905f, 0.01445319f, 
    -0.14727248f, -0.44669229f, -0.07643110f, -0.28507838f, -0.04582145f, -0.02376565f, -0.09601419f, -0.18920577f, 
    0.04681196f, -0.05858299f, -0.02123032f, -0.10483886f, -0.44141823f, 0.43603033f, -0.25092682f, -0.04123821f, 
    -0.09070660f, 0.07330760f, 0.07480424f, -0.08000317f, -0.11296445f, 0.07195681f, -0.03089745f, -0.13724469f, 
    0.27602309f, 0.25797036f, 0.14234829f, 0.31914529f, 0.31016856f, 0.07480446f, 0.07025601f, 0.09507462f, 
    -0.03245234f, -0.00073265f, 0.03577356f, 0.09450465f, -0.15136935f, 0.14416029f, -0.25174814f, 0.23230973f, 
    0.00160676f, -0.12616451f, -0.07998711f, -0.11362803f, -0.19312842f, -0.09266105f, 0.00240516f, -0.12373608f, 
    0.05132905f, 0.13613203f, 0.04661441f, 0.17683230f, 0.02294413f, -0.14218865f, -0.18504977f, 0.11905172f, 
    0.01472299f, -0.09820890f, -0.17839865f, -0.14326696f, 0.07886750f, 0.01255109f, 0.07019909f, 0.13649072f, 
    0.14855693f, -0.01622144f, 0.04811831f, -0.01117600f, 0.01487703f, -0.03371175f, -0.02304791f, -0.13334367f, 
    -0.66522515f, 0.24418665f, -0.19117706f, -0.12411989f, -0.11247376f, -0.02362603f, -0.00861114f, -0.16688125f, 
    -0.16643767f, 0.00056905f, 0.10816310f, 0.11355975f, 0.41331053f, -0.01905526f, -0.00316272f, 0.06988914f, 
    0.05479750f, -0.02690164f, -0.01902743f, -0.05043453f, -0.01293778f, -0.01745259f, -0.04849629f, -0.15034641f, 
    -0.38953322f, 0.13624609f, 0.07955549f, -0.11717100f, -0.06210110f, -0.09509157f, 0.09383553f, -0.06630261f, 
    -0.00818151f, 0.03573943f, 0.02851820f, -0.02673293f, 0.01358105f, 0.02654030f, -0.05342853f, -0.03151823f, 
    -0.11166259f, -0.00844217f, -0.13112663f, 0.14338246f, -0.05152985f, 0.06294265f, -0.07528486f, 0.00957817f, 
    0.13625251f, 0.13598984f, 0.02856869f, -0.21645917f, 0.00024061f, 0.01813138f, -0.09988112f, -0.06742884f, 
    -0.06446735f, -0.10779482f, -0.06896002f, -0.12347370f, 0.31300688f, 0.04501549f, 0.36256212f, 0.04981746f, 
    0.07445238f, 0.06745142f, -0.02788167f, -0.00142848f, -0.03963013f, 0.13126782f, 0.03618884f, -0.00388046f, 
    -0.19943726f, -0.40678877f, 0.00830474f, 0.07071759f, -0.05997507f, -0.00887398f, -0.10798394f, 0.04835902f, 
    -0.22666833f, -0.11985882f, 0.03532068f, -0.07030354f, -0.15200414f, 0.10536899f, 0.12017105f, -0.11454779f, 
    0.03835204f, -0.12563926f, -0.11342763f, 0.12005685f, -0.03907466f, -0.00176752f, 0.02731370f, -0.10970049f, 
    -0.08516520f, -0.18103181f, -0.04388594f, 0.23886187f, -0.11380378f, -0.13761565f, -0.08612113f, 0.00290644f, 
    0.02030258f, -0.00081656f, 0.07977340f, -0.10071494f, 0.17175642f, 0.10133137f, 0.16303828f, -0.05318496f, 
    -0.05644283f, 0.04550323f, 0.09533285f, -0.08306979f, -0.04311643f, 0.01751093f, -0.03862190f, -0.07642316f, 
    -0.20173545f, 0.03979982f, -0.09741445f, -0.14203787f, 0.05954994f, 0.01929235f, -0.08546598f, -0.13124686f, 
    -0.02704834f, 0.06546519f, 0.00912347f, 0.04093688f, 0.42052332f, -0.36378610f, -0.07648534f, -0.15060644f, 
    -0.15088677f, 0.05308069f, 0.02675021f, -0.24764836f, 0.02841065f, 0.08084285f, -0.05435517f, -0.13848384f, 
    0.11091360f, 0.07828612f, 0.23177040f, 0.03875761f, 0.04353226f, 0.05758331f, 0.05732174f, -0.06775197f, 
    -0.12523918f, 0.05950246f, -0.07300130f, -0.06503925f, -0.29915497f, 0.21750934f, 0.02072375f, 0.24567156f, 
    0.15245312f, 0.07650980f, 0.07936735f, 0.02870897f, -0.00239776f, 0.01659414f, 0.02269797f, 0.00245690f, 
    -0.01131378f, -0.10736700f, -0.13697627f, -0.05783291f, -0.00670382f, -0.11798157f, -0.12133718f, -0.01754176f, 
    0.03934076f, -0.05007918f, 0.02914836f, -0.04080033f, -0.27500892f, -0.01032451f, -0.25236863f, -0.12643537f, 
    -0.08438497f, -0.06574931f, 0.00286870f, -0.08082412f, 0.08387194f, 0.02369558f, 0.14291592f, 0.06871762f, 
    0.07009080f, 0.31487000f, -0.38200668f, -0.12312009f, -0.01563073f, -0.03543093f, -0.10867592f, 0.03758839f, 
    0.26127478f, 0.14245743f, -0.03954617f, 0.04894643f, -0.13689293f, -0.05610765f, 0.29613531f, -0.14483444f, 
    0.00123887f, 0.01083542f, 0.04319866f, 0.07617813f, 0.09363865f, -0.04381589f, -0.07395083f, -0.13690180f, 
    0.06645373f, -0.01070069f, 0.08109499f, -0.08427556f, 0.11203633f, -0.03591465f, 0.11880253f, 0.01512532f, 
    -0.06125423f, -0.00687049f, 0.15379366f, -0.05448897f, 0.25556403f, 0.09447704f, -0.21607190f, 0.08395297f, 
    0.00821784f, -0.00097221f, 0.03775396f, -0.19273546f, -0.15403771f, 0.04771784f, -0.09012077f, 0.00553505f, 
    -0.25966364f, 0.36720872f, -0.11290551f, -0.12638345f, -0.09799249f, -0.01007167f, 0.01323270f, -0.07838013f, 
    0.05979723f, -0.14777091f, 0.05609147f, 0.14160623f, -0.13969193f, -0.05369612f, 0.14874136f, -0.02131073f, 
    0.03913918f, -0.11163549f, 0.11048694f, -0.06230509f, 0.00158822f, -0.00173016f, -0.15452342f, 0.01574539f, 
    0.40022942f, 0.25568655f, -0.05172177f, 0.14633426f, 0.01803826f, -0.07409211f, -0.19628936f, -0.13294807f, 
    -0.09918687f, 0.04975140f, 0.00371310f, -0.15347220f, 0.26946962f, -0.02576090f, 0.09916496f, 0.11127861f, 
    -0.02545208f, -0.06353052f, -0.09404722f, -0.03818984f, 0.03246349f, -0.20256360f, 0.03949492f, -0.19303681f, 
    -0.02137300f, -0.01249636f, 0.27189013f, 0.22752778f, -0.22046900f, -0.07446401f, -0.15899010f, -0.01908462f, 
    0.05751361f, -0.09180693f, 0.11526128f, 0.04096786f, 0.20918885f, 0.27813715f, -0.21697915f, -0.12991129f, 
    -0.11049817f, -0.06935941f, -0.04962425f, -0.17580171f, -0.16033480f, -0.05138932f, 0.08637252f, -0.00267916f, 
    0.04873831f, 0.00565755f, 0.15335566f, 0.10472145f, -0.01676705f, -0.08558755f, -0.09359863f, -0.00907037f, 
    -0.12163706f, 0.01267589f, 0.09280825f, -0.13193998f, 0.06722303f, -0.17542577f, -0.02268772f, 0.23656271f, 
    -0.00846342f, 0.09912178f, 0.09360000f, -0.00907482f, 0.08361001f, 0.01683003f, 0.19759412f, -0.12998976f, 
    0.01864785f, -0.14884877f, -0.10260553f, -0.28537586f, 0.05214556f, -0.13343592f, 0.06117089f, -0.06481005f, 
    0.02886722f, -0.09060165f, -0.15518682f, -0.21083786f, -0.39827877f, 0.10376837f, -0.31157270f, -0.19478510f, 
    -0.07030598f, -0.11792865f, -0.16501358f, 0.18151769f, 0.05194898f, 0.14111544f, -0.00436748f, -0.15591238f, 
    -0.13145028f, 0.10452659f, -0.23246333f, -0.39553955f, 0.05529015f, -0.05180145f, -0.12129071f, -0.05436954f, 
    0.04985386f, 0.06033178f, 0.16720144f, -0.01375831f, 0.02267571f, -0.00257824f, 0.22111870f, -0.04380090f, 
    -0.06024770f, 0.07852188f, 0.06749952f, -0.07330911f, -0.16347371f, -0.06011193f, 0.12279987f, 0.00560068f, 
    -0.07224709f, -0.12995586f, -0.09886175f, 0.28896073f, 0.22751445f, 0.08754656f, -0.01997243f, -0.09797926f, 
    0.14326902f, -0.13838983f, 0.04613671f, 0.05043194f, 0.09054101f, -0.41313666f, 0.03520970f, -0.16589987f, 
    -0.11597589f, -0.21083514f, 0.13132387f, 0.05430856f, 0.01431404f, 0.06456989f, 0.04296798f, 0.00058951f, 
    0.18253882f, -0.01641353f, -0.05406114f, 0.22431195f, 0.08327299f, 0.02377890f, -0.07857390f, -0.00499113f, 
    0.04077119f, 0.02345129f, 0.05155902f, 0.03587756f, 0.16459571f, 0.01860717f, 0.01952571f, -0.14868878f, 
    0.05405839f, -0.11839666f, -0.04526425f, 0.00341680f, 0.21850735f, -0.07326506f, -0.26860890f, 0.09116528f, 
    0.12222530f, -0.03809869f, -0.13643417f, 0.04176552f, 0.10430106f, -0.07299810f, -0.19710159f, -0.06572472f, 
    0.12153365f, -0.06501358f, 0.03677459f, -0.20023736f, -0.28332758f, -0.11929181f, 0.36739817f, -0.08066567f, 
    -0.04923752f, 0.04197278f, -0.00830921f, 0.07110208f, 0.05879017f, -0.14963721f, 0.04344721f, 0.05734434f, 
    0.00184101f, -0.05923063f, -0.40612194f, 0.05027599f, 0.16197152f, -0.09637509f, 0.03094785f, -0.05869460f, 
    -0.11587296f, 0.00308241f, -0.03109692f, 0.02008089f, 0.10584837f, 0.13600001f, -0.01462524f, 0.19472927f, 
    -0.06110699f, 0.00451371f, -0.08176447f, -0.07415263f, 0.05529691f, -0.03440880f, -0.04226783f, -0.04946830f, 
    0.01153523f, -0.31030679f, -0.22636853f, -0.15820463f, 0.01292270f, -0.02747545f, -0.03988376f, 0.01302149f, 
    0.21387143f, 0.09170331f, 0.07415243f, -0.04137215f, 0.16698103f, 0.02518023f, 0.00521050f, -0.01298365f, 
    -0.08247524f, 0.04260305f, -0.04470325f, -0.00661023f, 0.12485408f, 0.05460478f, 0.01668745f, -0.09279232f, 
    0.16513783f, -0.09133405f, 0.04718401f, 0.24345478f, 0.10486289f, -0.05912483f, 0.00319183f, -0.04843881f, 
    0.05151090f, -0.00946393f, -0.03882723f, 0.00246108f, -0.19149077f, -0.29726091f, 0.18887907f, -0.08966623f, 
    0.07401214f, -0.15800229f, -0.01563961f, 0.05195128f, 0.00861631f, 0.02776734f, -0.02995843f, 0.13326629f, 
    0.07542861f, -0.53807652f, 0.24534537f, -0.20099998f, -0.07643182f, -0.09713102f, 0.03231222f, -0.02774604f, 
    -0.19576702f, 0.15128222f, -0.07270143f, -0.05182581f, -0.19884650f, -0.06989111f, 0.23022455f, 0.07394495f, 
    -0.18780376f, 0.10957491f, -0.00373209f, -0.09985355f, -0.04199909f, 0.04604624f, 0.14271612f, -0.18392509f, 
    -0.36477551f, 0.08698862f, -0.18302968f, -0.14103089f, 0.12696098f, -0.04254229f, 0.01088003f, 0.03413403f, 
    0.08892623f, -0.01470559f, 0.00167243f, 0.03508019f, -0.15025704f, 0.24210180f, -0.27324033f, -0.35733706f, 
    -0.07699726f, -0.04904267f, 0.04579749f, -0.25456589f, -0.06741033f, -0.09984057f, 0.09988264f, 0.02343287f, 
    -0.15460527f, 0.31849450f, 0.20922896f, 0.18470411f, 0.06764264f, 0.11553653f, -0.07954255f, -0.06626800f, 
    0.00059088f, -0.07540837f, -0.09938644f, -0.05772942f, -0.11778378f, 0.03144631f, 0.13395238f, 0.04975031f, 
    0.23216435f, 0.11866287f, 0.26415873f, 0.04967905f, -0.15816955f, -0.01580398f, -0.01869133f, 0.23995669f, 
    0.13753971f, 0.12778303f, -0.10114516f, -0.10909102f, -0.06078138f, -0.00276115f, -0.05174199f, 0.09840078f, 
    0.05947727f, -0.03152818f, -0.13953122f, -0.04297700f, -0.03070266f, 0.18817943f, 0.07615306f, 0.07078759f, 
    0.04229519f, 0.05732646f, -0.13238521f, 0.09225524f, -0.00757039f, 0.10302606f, 0.12961803f, -0.03872722f, 
    -0.25823161f, 0.04230055f, -0.04908996f, 0.34189051f, 0.00093904f, 0.00848626f, -0.01595137f, 0.00794319f, 
    -0.04590047f, 0.18789104f, 0.00073588f, -0.06664608f, -0.02905138f, -0.15911494f, 0.22902283f, -0.09277327f, 
    0.07007626f, 0.02944017f, 0.12627317f, 0.03129900f, -0.03772365f, -0.14791353f, 0.02650358f, 0.05001257f, 
    0.33822241f, -0.69681185f, 0.02525110f, 0.01017499f, 0.09818321f, -0.01609991f, 0.08646071f, -0.13074164f, 
    -0.00123153f, -0.06669490f, 0.06416117f, -0.04602044f, -0.08730131f, 0.08781389f, -0.07221717f, -0.14820081f, 
    0.08914007f, 0.09262822f, 0.06939027f, -0.11769491f, -0.07224617f, 0.16542992f, -0.01493152f, 0.12841596f, 
    -0.11466548f, -0.24323733f, 0.04175170f, 0.08340238f, 0.12511803f, 0.06784305f, -0.00467552f, 0.05870616f, 
    0.03686542f, -0.00962129f, -0.13516225f, -0.05341832f, -0.37873998f, -0.13481158f, 0.42019919f, -0.04140528f, 
    -0.02608835f, 0.00128532f, -0.10800518f, 0.01311781f, -0.14397542f, -0.00726263f, 0.02102818f, 0.00599576f, 
    0.47623006f, 0.06099508f, -0.22413582f, -0.07051539f, 0.11943135f, 0.04050007f, -0.00077904f, -0.06260765f, 
    -0.10673016f, -0.06170780f, 0.00955080f, 0.17073306f, -0.68144441f, 0.65099239f, -0.14425912f, -0.10922752f, 
    0.20649362f, 0.17925788f, -0.02181552f, 0.12283061f, -0.10742413f, -0.07346442f, -0.11288892f, 0.11031893f, 
    -0.31255844f, -0.37291113f, 0.18030584f, 0.04065804f, -0.01167225f, -0.05773818f, -0.15683284f, -0.04385183f, 
    0.08630632f, -0.06571925f, 0.12430253f, 0.14759809f, -0.22547390f, 0.05396731f, -0.17442663f, -0.02636878f, 
    -0.03181348f, 0.19767568f, 0.01472537f, 0.04600944f, 0.00613622f, -0.11093791f, -0.12001751f, 0.15203984f, 
    -0.12647909f, -0.23150373f, -0.09966773f, -0.10651141f, -0.14514425f, -0.11387765f, 0.05702392f, 0.03421617f, 
    0.14694591f, -0.12583290f, -0.06362571f, -0.16552538f, 0.62261212f, 0.18890765f, -0.00085390f, 0.08867425f, 
    0.09828877f, -0.01261899f, -0.10500779f, 0.12506303f, -0.17949723f, -0.03740727f, 0.05697029f, 0.07680708f, 
    -0.33451152f, 0.28873548f, 0.04164545f, -0.54191065f, 0.09470933f, -0.03548970f, -0.09729678f, 0.00340541f, 
    -0.14942530f, -0.06614099f, 0.06860436f, -0.09348969f, -0.31680179f, 0.18920347f, 0.07104976f, 0.02793730f, 
    -0.09606316f, 0.04127316f, 0.06590214f, -0.02055664f, -0.06031208f, 0.10620470f, 0.04866358f, -0.06829793f, 
    -0.27055448f, 0.19811074f, -0.49301094f, -0.04670390f, 0.05427024f, 0.00031827f, 0.12686086f, 0.06539279f, 
    -0.08161039f, 0.08094192f, -0.24578406f, -0.10128157f, 0.62568349f, 0.04137174f, -0.11208750f, 0.01035022f, 
    0.11036354f, -0.04658638f, 0.15936418f, 0.04396171f, -0.15112928f, 0.14972404f, 0.01489965f, 0.12842864f, 
    0.20386066f, -0.37987062f, 0.05583841f, -0.02155718f, 0.00534947f, -0.02016075f, 0.11601575f, 0.08495198f, 
    0.10362707f, 0.07344506f, 0.03398431f, 0.08352724f, 0.02310124f, -0.39219677f, -0.13791108f, 0.23205672f, 
    -0.07598854f, -0.03478224f, 0.04230404f, 0.06708175f, -0.17035963f, 0.14900206f, -0.03916971f, -0.03686792f, 
    -0.23628730f, 0.02511491f, -0.01662896f, -0.29288468f, -0.09530716f, -0.00683808f, -0.09688678f, 0.03561176f, 
    0.09491827f, 0.11406766f, 0.07379579f, 0.00450205f, 0.51849258f, -0.52007902f, 0.14057359f, -0.04195081f, 
    0.01211471f, 0.13126941f, 0.09447524f, 0.00856787f, 0.02618168f, -0.04726184f, 0.05491789f, -0.03240301f, 
    0.00861680f, 0.04709837f, -0.04621628f, -0.47012249f, -0.02758127f, -0.12744419f, 0.06848188f, 0.02009974f, 
    -0.10848887f, 0.01370468f, -0.09337538f, -0.22050381f, -0.67420024f, 0.37952447f, -0.01482635f, 0.24111895f, 
    0.09639309f, -0.09850289f, -0.24942861f, 0.13718072f, 0.03098925f, 0.05511715f, 0.03373139f, 0.11556831f, 
    -0.00917561f, 0.04651969f, -0.15148394f, -0.21256861f, 0.10187786f, -0.02443936f, -0.07579602f, -0.11281396f, 
    -0.10222404f, -0.14717685f, -0.14599368f, -0.09546852f, 0.07142466f, 0.13572730f, -0.04073816f, 0.05083640f, 
    -0.06023305f, -0.16592704f, 0.02340272f, -0.03492854f, 0.20912115f, -0.01447593f, 0.16140810f, -0.12139609f, 
    -0.10620103f, 0.21977398f, -0.19247796f, 0.22464921f, -0.00648464f, -0.07838811f, -0.00711478f, -0.14702101f, 
    0.11459439f, 0.08687200f, -0.14314216f, -0.02077345f, -0.17087993f, -0.45095065f, 0.14124341f, -0.14156809f, 
    0.15792581f, -0.15654455f, 0.14748956f, 0.08587058f, -0.00368686f, -0.14260249f, -0.01028767f, 0.11434282f, 
    0.02526398f, 0.26097709f, -0.24265908f, -0.22117656f, 0.22076514f, -0.04847500f, 0.00982134f, -0.01215095f, 
    0.05602204f, -0.25312924f, 0.09509439f, -0.00751712f, 0.30389014f, 0.14365785f, 0.05610510f, -0.13588586f, 
    0.13545200f, 0.04934784f, 0.00908077f, 0.24222879f, 0.03438388f, 0.08416943f, 0.01033222f, 0.08752606f, 
    -0.86483651f, -0.67328483f, 0.15991125f, 0.13753204f, 0.15994838f, -0.01743975f, 0.07703313f, -0.12372962f, 
    0.33775499f, 0.09030394f, 0.09104077f, 0.04247221f, 0.18138634f, 0.11703847f, -0.10624365f, 0.13796552f, 
    -0.12374732f, -0.09585135f, -0.13166846f, -0.01648524f, -0.03761902f, -0.15808094f, 0.01145589f, -0.01091896f, 
    0.26660731f, 0.15886486f, -0.03814822f, 0.01562913f, -0.10973024f, 0.03562277f, -0.00441642f, -0.01303364f, 
    0.08657259f, 0.19038476f, 0.29869631f, 0.12449050f, 0.19046842f, -0.12158086f, -0.36186600f, -0.02751101f, 
    0.00785767f, 0.10268339f, 0.05680073f, 0.07135165f, 0.15245262f, 0.11128404f, -0.06591160f, 0.17536993f, 
    0.30300918f, -0.05021878f, 0.10773814f, 0.03512431f, 0.06354062f, 0.00523729f, -0.04565959f, -0.11193502f, 
    0.04973375f, 0.12069040f, -0.07071688f, -0.00755616f, 0.03985520f, 0.07222332f, 0.03167666f, 0.02322359f, 
    -0.00925286f, -0.10228505f, 0.07613361f, -0.09557448f, 0.08260868f, -0.10305985f, -0.21174777f, -0.02921381f, 
    -0.41144264f, 0.22078504f, -0.17140220f, -0.26185182f, -0.02006582f, 0.06568716f, -0.21666077f, -0.08409545f, 
    0.01271550f, 0.08777316f, -0.15109926f, 0.05663446f, 0.40291029f, 0.02059446f, -0.12368304f, -0.10279213f, 
    -0.09907760f, -0.05319710f, -0.16764267f, -0.17245671f, -0.03219849f, -0.04457226f, -0.21301618f, -0.10714078f, 
    0.30028278f, 0.09625822f, -0.06046388f, -0.14090151f, -0.18592812f, -0.11676925f, -0.01795518f, 0.03649808f, 
    -0.00360060f, -0.10976944f, -0.08533782f, -0.10600755f, 0.01251076f, 0.05342522f, -0.09196780f, -0.08574984f, 
    -0.08092212f, -0.04746902f, -0.00812499f, 0.15525493f, 0.00648523f, -0.04184633f, 0.06187047f, -0.10886329f, 
    0.19584976f, -0.03233330f, -0.01699367f, 0.05106878f, -0.08616338f, -0.13295332f, 0.02137277f, 0.18744823f, 
    0.08095435f, 0.00793655f, -0.13986941f, -0.03334697f, -0.77040398f, -0.81955647f, -0.05086707f, 0.00673066f, 
    -0.03489010f, -0.16743930f, 0.03202093f, 0.06626793f, 0.07908403f, 0.15293972f, -0.02582708f, 0.06346297f, 
    -0.29490823f, -0.07592865f, -0.36705884f, -0.16177358f, -0.15718949f, -0.00384892f, -0.12878732f, -0.06785138f, 
    -0.08471203f, -0.06036480f, -0.09692429f, -0.28548774f, 0.37582853f, -0.17209172f, 0.07612041f, -0.12346891f, 
    0.08306368f, 0.14597785f, 0.23299475f, 0.01268763f, 0.11620523f, 0.12268719f, -0.09803093f, -0.04035123f, 
    0.30931494f, 0.04710504f, 0.03341182f, -0.05244808f, 0.01560508f, 0.04228096f, -0.02433208f, -0.06766494f, 
    -0.17739214f, 0.03747218f, 0.00878573f, 0.02653420f, 0.01382000f, 0.25850767f, 0.18271431f, -0.18558398f, 
    -0.04655224f, 0.13870543f, 0.05071361f, 0.08956826f, 0.12027832f, 0.06715061f, 0.22265483f, 0.00481018f, 
    -0.68937272f, -0.05851777f, -0.17471437f, -0.38781056f, 0.18138996f, 0.08610862f, -0.01527921f, 0.00494432f, 
    0.19233006f, -0.08667011f, -0.01213097f, 0.15414520f, 0.06066948f, 0.27438509f, 0.15933253f, 0.28689972f, 
    0.03426626f, 0.00040470f, 0.16219664f, -0.00691557f, 0.09949142f, 0.15616788f, 0.10070868f, 0.15051378f, 
    -0.77810532f, -0.47699979f, -0.24924853f, -0.31931108f, -0.11235435f, 0.01978532f, -0.11208254f, -0.03151767f, 
    -0.00973204f, 0.12027580f, 0.09846738f, 0.10218681f, 0.08448338f, 0.04730167f, -0.05838803f, 0.14518429f, 
    -0.16502942f, -0.08476347f, 0.08424230f, -0.11103548f, 0.10963970f, -0.04464620f, 0.05010456f, -0.14043580f, 
    -0.53978997f, -0.28260335f, -0.20498207f, -0.03237754f, 0.01127796f, -0.03611555f, -0.25323582f, 0.02825103f, 
    -0.04163706f, -0.14100505f, 0.02113002f, -0.05143061f, 0.21509606f, 0.02898281f, 0.03526350f, -0.20859163f, 
    0.04744948f, 0.20428677f, -0.03059811f, -0.01521908f, -0.03364234f, 0.05719009f, 0.02858401f, 0.00905789f, 
    -0.16604686f, -0.01666589f, -0.02467452f, 0.00240024f, 0.04077923f, -0.12893237f, -0.14632259f, -0.00895045f, 
    0.01865883f, -0.10406774f, -0.03686427f, -0.05460177f, -0.01672546f, -0.02080702f, -0.20785499f, 0.12450597f, 
    0.09609698f, 0.00264733f, 0.02600020f, 0.09761380f, 0.02323173f, 0.14199744f, 0.01835906f, 0.00691538f, 
    0.23911053f, 0.18844782f, 0.04425908f, -0.22638437f, 0.06583560f, -0.06140757f, 0.06263396f, 0.01867293f, 
    0.00351620f, 0.10465054f, 0.12555923f, 0.17108452f, -0.03715536f, -0.21262756f, -0.02258040f, -0.02079690f, 
    -0.19096272f, 0.08512545f, -0.05910281f, -0.02989558f, -0.00706716f, -0.23497088f, -0.13590235f, -0.23928027f, 
    -0.27989087f, -0.11465262f, -0.22322647f, -0.26693726f, -0.05014285f, -0.01330101f, -0.08683205f, 0.10572061f, 
    0.08002695f, 0.10602663f, 0.22617537f, 0.06768791f, 0.14098926f, 0.14384630f, -0.11191738f, -0.15438750f, 
    0.12183733f, -0.10046231f, -0.14291133f, 0.15462030f, -0.01379255f, 0.02958776f, 0.14501333f, 0.11081981f, 
    0.09262398f, 0.03524660f, -0.19076096f, 0.37099922f, -0.03922863f, -0.15409824f, 0.03306957f, -0.11551938f, 
    -0.02781443f, -0.10147800f, -0.08557550f, 0.02656708f, 0.20147070f, 0.13917921f, -0.10557104f, 0.03892081f, 
    -0.17659676f, -0.02322236f, 0.05029485f, -0.07225356f, 0.03533005f, 0.12416333f, 0.11441252f, -0.04079321f, 
    -0.07423680f, -0.04197454f, 0.07135459f, 0.58360350f, -0.11941694f, 0.11810963f, 0.06035456f, -0.09945052f, 
    -0.09437625f, 0.04830037f, 0.06640058f, 0.07590402f, 0.04056672f, -0.13429318f, -0.34028450f, 0.10317791f, 
    0.18074587f, -0.15640846f, 0.12022665f, 0.09947804f, -0.00515845f, 0.02390582f, -0.16446202f, 0.00978553f, 
    0.14033833f, 0.59030801f, -0.07853454f, -0.03350141f, 0.18948357f, 0.00880202f, -0.29306394f, -0.07907136f, 
    -0.04652996f, 0.05471890f, -0.09680836f, 0.07721269f, 0.09825627f, -0.17691733f, -0.08169018f, -0.10613539f, 
    -0.10459528f, 0.03499673f, -0.08133745f, -0.26167268f, 0.07560612f, -0.12569614f, -0.24075702f, -0.09058309f, 
    -0.24889465f, 0.12064838f, -0.00462960f, 0.13979174f, 0.04277104f, -0.11150251f, -0.00867587f, 0.08290705f, 
    0.00441106f, -0.03063586f, -0.08358244f, 0.02239391f, 0.08356178f, -0.33108783f, 0.08148572f, 0.08568674f, 
    0.13870110f, 0.12312736f, 0.05458534f, 0.10152058f, -0.07543930f, -0.03408626f, 0.02185558f, -0.08221558f, 
    -0.11878420f, 0.03348827f, -0.17453529f, 0.15619513f, 0.12852496f, -0.02878791f, 0.07160185f, 0.03366282f, 
    -0.06039060f, 0.00411848f, -0.15254481f, 0.02363659f, -0.40902907f, 0.28326094f, 0.07753186f, -0.15641840f, 
    -0.06142714f, 0.14224163f, -0.11655623f, 0.10069842f, 0.05166112f, 0.17532730f, 0.01518437f, 0.05243821f, 
    -0.66014659f, -0.02742496f, -0.24060990f, -0.03844122f, -0.06579591f, -0.08291820f, 0.07991803f, 0.13129085f, 
    0.03862773f, -0.05701770f, 0.17133346f, -0.04105888f, -0.56858742f, -0.07860205f, -0.25710550f, -0.33532754f, 
    0.17494993f, -0.04092850f, 0.05056959f, 0.12911320f, 0.12291857f, -0.03560057f, 0.02568365f, 0.09125488f, 
    0.05712068f, 0.04255699f, 0.02415881f, -0.06982096f, -0.03140215f, -0.05264456f, 0.11715512f, -0.01061711f, 
    -0.11455842f, 0.02639883f, -0.02979887f, -0.09266642f, 0.22336434f, -0.24162380f, -0.28307757f, 0.10688613f, 
    -0.03774757f, 0.12823635f, -0.14829221f, -0.18707173f, 0.06402833f, 0.01774341f, 0.03696487f, -0.11163521f, 
    -0.21344666f, -0.06225123f, 0.15043004f, -0.09054219f, -0.01684927f, 0.03915413f, 0.00158838f, 0.01043893f, 
    -0.04864171f, 0.01177986f, 0.05009772f, 0.18438743f, 0.33549020f, 0.12080427f, -0.08098635f, 0.14177872f, 
    0.06543921f, 0.08412107f, 0.08373591f, -0.08544594f, 0.12718175f, -0.09877940f, -0.05408718f, -0.04247120f, 
    -0.52558178f, -0.01595682f, -0.02225432f, 0.11945233f, -0.14546433f, 0.15035369f, -0.23175585f, -0.04604875f, 
    0.02678443f, 0.17769158f, 0.08705197f, 0.17916784f, 0.16929950f, 0.07448500f, -0.12732309f, 0.42157745f, 
    0.21061833f, -0.11552341f, 0.02524118f, 0.06563266f, 0.16292897f, -0.04731199f, -0.02508175f, 0.06868672f, 
    -0.15664108f, 0.17639709f, -0.06853877f, -0.00029977f, -0.06152534f, 0.18718290f, -0.13960052f, -0.14110790f, 
    -0.06202309f, -0.13114013f, -0.11482783f, -0.37606841f, -0.47013515f, 0.16418269f, 0.04386894f, -0.19378765f, 
    -0.06708363f, -0.04764999f, -0.11301071f, 0.06607964f, -0.04234629f, -0.09369197f, -0.02493950f, -0.32313910f, 
    0.51143384f, -0.19279553f, -0.25995642f, 0.20459755f, -0.04435685f, -0.04819509f, 0.02117470f, -0.08030333f, 
    0.08244125f, 0.00146385f, -0.03600211f, 0.07173798f, 0.25422776f, 0.10322081f, 0.16003063f, 0.03716823f, 
    0.17957610f, 0.00953887f, 0.00404288f, -0.15536466f, 0.07686917f, 0.00231779f, 0.07079408f, -0.06458693f, 
    0.01309784f, -0.22355483f, -0.08961955f, -0.05460022f, 0.23321572f, -0.04790875f, 0.01968127f, -0.15087663f, 
    0.03910172f, -0.09137981f, -0.05845810f, -0.07096256f, -0.38314575f, -0.26012179f, -0.06720392f, -0.09864912f, 
    0.11984190f, -0.00495300f, 0.02571665f, 0.13718335f, 0.14236890f, 0.02728782f, -0.00074038f, -0.04884074f, 
    -0.50532740f, 0.13469066f, -0.09018145f, -0.44065115f, 0.04387395f, -0.12903410f, -0.04674004f, 0.09251221f, 
    0.15386193f, 0.01459375f, -0.06370342f, 0.03334920f, -0.48202643f, 0.48151872f, 0.00760111f, -0.08169089f, 
    -0.13251260f, -0.06211004f, 0.01571899f, -0.28495055f, -0.05634772f, 0.07300368f, 0.15325981f, -0.14200543f, 
    0.64250380f, 0.07031791f, -0.38032511f, -0.03625907f, 0.01540364f, -0.14859912f, -0.02251821f, 0.09416615f, 
    -0.01927968f, 0.01291912f, 0.19026062f, 0.13917309f, -0.05578135f, -0.13394828f, 0.01162699f, 0.12276604f, 
    0.02590488f, -0.09848340f, -0.05525918f, 0.10425686f, 0.01784551f, -0.03228873f, -0.06423450f, -0.14920314f, 
    0.35118666f, -0.05983570f, -0.23490353f, 0.26360747f, 0.16551474f, -0.05984651f, -0.03650125f, 0.13093731f, 
    -0.03511707f, -0.01022954f, -0.09005711f, -0.14977051f, -0.22124703f, -0.29198930f, -0.12920655f, 0.16149633f, 
    0.00228364f, -0.04239079f, 0.11609501f, -0.14912651f, 0.13247162f, 0.12400921f, -0.00434513f, 0.08863954f, 
    -0.09127298f, -0.03902921f, -0.12468592f, -0.19679479f, 0.09105876f, -0.06542046f, 0.03796848f, 0.03710184f, 
    -0.02879875f, -0.09787530f, -0.00715582f, -0.14355370f, -0.64589465f, 0.33769080f, -0.05747676f, -0.10277642f, 
    0.02440125f, 0.06742700f, -0.08738945f, -0.11079145f, -0.09659803f, -0.11614043f, -0.04378815f, -0.02432985f, 
    -0.12179430f, 0.00583276f, 0.06055553f, 0.03276420f, -0.00950642f, 0.10458206f, 0.08904227f, 0.05554850f, 
    0.02287422f, 0.13588604f, 0.17634317f, 0.12100703f, 0.22753470f, -0.29347911f, 0.14949623f, 0.16427022f, 
    -0.09800369f, 0.09422615f, -0.16023383f, 0.08755767f, -0.07754912f, 0.01327488f, -0.05558142f, -0.07410821f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.13119994f, 0.05678542f, -0.00842496f, -0.00198301f, -0.02254159f, 0.01598527f, 0.00420293f, -0.03434234f, 
    -0.04576982f, 0.04226607f, 0.13917965f, 0.07473231f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
