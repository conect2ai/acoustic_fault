#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    1.19174933f, -0.48039564f, -0.06796604f, -0.54283297f, -0.48023641f, -0.17959709f, -0.11120252f, 0.21910536f, 
    0.19190376f, 0.12260199f, -0.04696849f, -0.01870556f, 0.55210185f, -0.39540970f, -0.08680713f, 0.03632731f, 
    -0.09549204f, 0.14672507f, 0.11663924f, -0.24124542f, 0.01848482f, -0.11902551f, -0.12649661f, 0.10347462f, 
    0.40760085f, -1.11608136f, 0.74970388f, 0.49746677f, 0.17795703f, 0.10130783f, 0.16519102f, -0.70993698f, 
    -0.36052483f, 0.39380252f, 0.11631340f, -0.18100670f, -0.16570489f, -0.08345876f, 0.10012383f, 0.07674365f, 
    0.05364360f, -0.07555575f, 0.27889752f, -0.23825124f, -0.09393717f, -0.02349443f, -0.04098239f, 0.21585362f, 
    0.04066572f, -0.00229106f, -1.03940308f, -0.38219205f, -0.39176363f, 0.44775125f, 0.83886570f, 0.02690632f, 
    -0.32370237f, -0.48970982f, -0.22806501f, 0.13771619f, 0.30335990f, 0.12141706f, 0.02330508f, -0.05605254f, 
    -0.39295104f, 0.01394649f, -0.34957683f, -0.04537344f, -0.21366537f, -0.37937129f, -0.12645467f, -0.14134543f, 
    -0.03006952f, -0.15127783f, -0.36153719f, -1.04636121f, -0.35878369f, -0.53314286f, -0.59149778f, -0.52840930f, 
    0.45893961f, 0.37359414f, -0.45007664f, -0.59521765f, 0.14570110f, -0.14038126f, -0.11773912f, -0.12730658f, 
    -0.36125532f, -0.21995178f, 0.17835462f, -0.04453091f, -0.31335488f, -0.25246638f, -0.06818645f, -0.09234674f, 
    -0.22470844f, -0.13229313f, 0.00271625f, -0.11444116f, -1.11094725f, -0.71856862f, 0.08464541f, 0.46040073f, 
    0.39841071f, 0.41785845f, 0.20429581f, -0.00316395f, 0.10589505f, 0.17032607f, -0.20672157f, -0.01824715f, 
    -0.20450738f, 0.30616581f, -0.16771722f, 0.03969054f, 0.24587615f, 0.00308112f, 0.02112293f, 0.07617705f, 
    -0.27993682f, 0.09049230f, 0.05062807f, -0.06586534f, -0.23455818f, 0.26701620f, 0.74229246f, -0.17266202f, 
    0.22126423f, -0.41099265f, 0.09852035f, -0.27688876f, -0.42202431f, 0.04465547f, 0.21301240f, 0.02470062f, 
    -0.09243805f, 0.42952806f, -0.01715853f, -0.53546959f, -0.13222744f, 0.14697526f, -0.03111715f, 0.03246034f, 
    -0.35640359f, 0.04971165f, 0.09790172f, -0.11506144f, -0.09820039f, -0.09413150f, 0.42180118f, 0.08180562f, 
    0.11592961f, 0.02043316f, 0.03359476f, 0.37384844f, 0.24497634f, -0.29175848f, -0.51471645f, -0.61192161f, 
    -0.02927427f, -0.06703158f, -0.12158851f, -0.19784056f, -0.34064397f, -0.26358181f, 0.17142886f, 0.14593601f, 
    -0.29070577f, -0.00573623f, -0.07111269f, 0.20795919f, -0.11301035f, -0.34069687f, -0.41439003f, 0.39923814f, 
    0.65432650f, -0.05887285f, -0.53043580f, -0.09766308f, -0.08439504f, 0.19511808f, 0.42476866f, -0.14075863f, 
    -0.08800836f, -0.02926186f, -0.13602841f, 0.18189985f, -0.30328909f, -0.22093470f, 0.19919538f, 0.07938291f, 
    -0.52394760f, 0.22178327f, -0.04486717f, -0.23695230f, 0.07051890f, 0.22189412f, 0.08929240f, 0.03839601f, 
    -0.10216713f, -0.48545158f, -0.05493650f, 0.07281691f, 0.48360389f, -0.00770772f, 0.07569220f, 0.04225716f, 
    0.36474878f, -0.29472256f, -0.24921654f, 0.00754990f, -0.24930933f, 0.04390571f, 0.24610163f, -0.30939502f, 
    0.11573379f, -0.05883090f, 0.06528975f, -0.04547133f, 0.12707633f, -0.17305942f, -0.45674670f, 0.25799146f, 
    0.52452010f, 0.11194631f, -0.47158453f, -0.29158676f, 0.10066205f, -0.16975383f, -0.38783047f, -0.31314260f, 
    0.48942789f, -0.48233053f, 0.11068147f, -0.18730147f, 0.28920296f, -0.26223287f, 0.02956129f, 0.25344917f, 
    -0.07841659f, 0.16136982f, -0.23697153f, -0.31349629f, -0.13418722f, 0.24959588f, -0.12421551f, 0.34380618f, 
    0.14999796f, 0.21347703f, -1.24087393f, -0.07257172f, 0.53235227f, -0.50468028f, -0.13356285f, -0.09289621f, 
    -0.22607152f, 0.78817618f, 0.04833482f, -0.12807317f, -0.51034838f, -0.34853595f, -0.36647341f, 0.23847118f, 
    0.19597185f, 0.26956299f, -0.26628542f, -0.24558565f, -0.26079857f, 0.05971074f, -0.11393769f, 0.03872922f, 
    0.03975185f, -0.31470871f, -0.36478293f, 0.64294451f, 0.30935562f, 0.32327974f, 0.68987846f, 0.47174487f, 
    0.26980171f, -0.10421760f, -0.24763758f, -0.13684024f, -0.03879304f, 0.26025012f, 0.04214185f, 0.04505313f, 
    -0.18764575f, -0.01611501f, -0.14770700f, -0.37998563f, 0.12335888f, 0.26831314f, 0.02597564f, -0.11720437f, 
    0.10171731f, 0.06944793f, 0.08893768f, -0.11466049f, 0.82678586f, 0.38537511f, -0.23286992f, -0.85973114f, 
    -0.64320344f, -0.21124227f, -0.05266938f, 0.18820868f, 0.26372376f, 0.13404343f, -0.17415740f, 0.15666918f, 
    0.20857941f, 0.08204056f, -0.37530118f, -0.19023128f, -0.23516536f, -0.23342930f, -0.19299699f, -0.10639178f, 
    -0.18685798f, -0.22356097f, -0.10738137f, -0.18628906f, -0.59198278f, 0.68651986f, 0.19000372f, -0.28539401f, 
    0.35603353f, -0.58761436f, 0.56732595f, -0.31854814f, -0.03297333f, 0.33352494f, -0.09630263f, 0.39216331f, 
    -0.10616427f, -0.23142360f, -0.19969735f, -0.14549659f, 0.11896905f, 0.09380991f, -0.10349825f, -0.16539007f, 
    -0.12238337f, -0.16687150f, 0.05715542f, 0.00137063f, -0.08348121f, -0.01805711f, -0.36071181f, -0.49075580f, 
    -0.25520936f, 0.19422929f, 0.16304393f, -0.55327898f, -1.12421846f, -0.63914382f, -0.49200776f, -0.16375972f, 
    0.16703679f, -0.17479326f, 0.21826966f, 0.71868169f, 0.07618628f, 0.13341461f, -0.20406684f, 0.22069906f, 
    -0.25170350f, -0.20384865f, -0.16206726f, 0.37450075f, 0.01102149f, -0.20913862f, 0.19556250f, -0.94370294f, 
    -0.55546564f, -0.03836982f, -0.42579359f, -0.72049248f, 0.74997377f, 0.46974123f, 0.46964321f, 0.29140583f, 
    0.12909780f, 0.09067414f, 0.03361866f, 0.04650791f, 0.51799673f, -0.32074732f, -0.17338933f, 0.00496655f, 
    -0.16097189f, -0.30897465f, 0.06785049f, 0.09000427f, -0.06458116f, 0.43466881f, -0.04707795f, -0.00897484f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.18945993f, 0.13269700f, -0.13926852f, -0.10672488f, -0.00953667f, 0.27243444f, 0.03056681f, 0.37662816f, 
    0.41565126f, 0.02608704f, 0.19880360f, -0.09274124f, 0.04982298f, 0.48747489f, 0.21581987f, 0.19187720f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.23956096f, 0.02549759f, -0.12217404f, -0.15900217f, -0.28776765f, 0.21977822f, -0.06121413f, -0.03883956f, 
    0.23151207f, 0.26377958f, 0.07855053f, -0.06470651f, -0.35021299f, 0.33606657f, 0.02604668f, -0.06849319f, 
    -0.11965436f, 0.13756935f, -0.02552756f, 0.05592025f, 0.05289548f, -0.05088931f, 0.18833251f, 0.04611489f, 
    0.38202301f, 0.18562900f, 0.30998033f, -0.05278231f, -0.03101687f, 0.03569902f, 0.00940173f, 0.01907182f, 
    0.10508326f, -0.13446669f, -0.21328391f, 0.02478193f, 0.35581851f, 0.24365550f, 0.32548818f, -0.00135836f, 
    0.13307722f, 0.09315548f, 0.03494947f, 0.21520841f, -0.01542197f, -0.08511416f, -0.10697086f, 0.02167298f, 
    0.27409655f, 0.00546855f, 0.18600044f, -0.07610237f, -0.08432754f, 0.09453703f, -0.10429542f, 0.03686134f, 
    -0.09753886f, -0.10926864f, -0.09012211f, -0.21832837f, 0.05421492f, 0.28311837f, -0.23248217f, -0.16173843f, 
    0.09552339f, 0.07446133f, -0.18343516f, 0.13868874f, 0.06086590f, -0.04802657f, 0.16871540f, 0.20815362f, 
    0.46048841f, -0.06002893f, -0.08700546f, -0.00064204f, 0.01331929f, -0.27469507f, -0.07667520f, 0.19410089f, 
    -0.01461360f, -0.01582419f, -0.11198206f, 0.06687756f, 0.09679580f, 0.11167343f, -0.16780870f, 0.25340515f, 
    0.09378646f, 0.01826180f, 0.21022551f, -0.11974005f, 0.11861826f, -0.06214238f, -0.09375330f, -0.12882009f, 
    -0.05452134f, 0.10853548f, -0.11465528f, -0.02498062f, -0.14428619f, 0.10121260f, 0.00910370f, -0.05959501f, 
    0.07487017f, 0.02736207f, -0.16392492f, 0.01881669f, -0.12334299f, 0.20201188f, -0.08334123f, 0.17173764f, 
    0.00784837f, 0.30036697f, 0.32814875f, -0.06224832f, 0.08203227f, 0.04797249f, -0.03074215f, 0.06802353f, 
    -0.26225170f, 0.30246964f, -0.14026862f, 0.07766829f, -0.02442843f, -0.11859827f, -0.31850979f, 0.01464864f, 
    -0.05058224f, 0.05309163f, -0.07359108f, -0.17601745f, -0.04395475f, -0.04060374f, 0.06024491f, 0.08516324f, 
    0.05694461f, -0.10862162f, -0.09094016f, -0.09028775f, 0.08213497f, 0.09771933f, 0.08901831f, -0.00592066f, 
    0.09976307f, -0.06286971f, -0.21132357f, 0.15280330f, 0.03784035f, -0.06772955f, -0.03882030f, -0.06084139f, 
    -0.10921479f, -0.01239839f, -0.04574819f, -0.02909692f, 0.34392798f, 0.19349854f, 0.18005344f, -0.27748615f, 
    0.02957198f, 0.06175125f, -0.09995278f, -0.06517625f, 0.25894377f, -0.12013592f, -0.08972383f, 0.06497630f, 
    -0.31110692f, 0.19228156f, 0.08155767f, 0.07032761f, 0.12963898f, 0.10846559f, 0.06629223f, 0.02685853f, 
    0.02139874f, -0.00355763f, 0.07921962f, 0.02491030f, 0.39262131f, 0.07828522f, -0.23374091f, -0.14173651f, 
    0.01940490f, 0.12559490f, -0.10252245f, -0.03239145f, -0.05393054f, 0.01581165f, 0.16956241f, -0.10153046f, 
    -0.23828071f, 0.30291495f, 0.53616148f, 0.06897783f, 0.17807469f, -0.00418749f, -0.10618945f, -0.27224952f, 
    0.10925567f, -0.04458991f, 0.23757249f, 0.05719995f, -0.10905242f, 0.37560648f, 0.16750598f, -0.15815215f, 
    0.07864038f, 0.00387745f, 0.07574795f, 0.00392577f, -0.06086061f, 0.08306386f, 0.03601794f, 0.03247830f, 
    -0.42851612f, 0.14692634f, -0.27593371f, -0.02346104f, 0.06390104f, 0.09219738f, 0.04806812f, 0.02353494f, 
    -0.00132056f, -0.12787376f, -0.16044846f, -0.06978339f, 0.04334310f, 0.03187512f, 0.03945082f, -0.07980981f, 
    0.06346010f, 0.04156218f, -0.00295816f, 0.04876193f, 0.08128048f, 0.12331829f, 0.08682605f, -0.06349210f, 
    -0.28069839f, 0.34492886f, -0.17753556f, 0.12882821f, 0.11629144f, 0.08153872f, -0.00888002f, 0.05907816f, 
    -0.00807540f, -0.12497181f, -0.06147752f, -0.01608883f, -0.31411359f, 0.12921771f, 0.12836330f, 0.30434576f, 
    0.01467138f, 0.06416921f, -0.10089795f, -0.04695881f, 0.01166385f, -0.10182728f, 0.03144589f, 0.07327114f, 
    -0.17234018f, 0.24831016f, -0.03936274f, 0.03122530f, -0.18296741f, 0.13686949f, -0.01404287f, 0.21591401f, 
    -0.05434075f, -0.05268700f, -0.16758460f, -0.00320607f, 0.03389244f, 0.04558869f, 0.22350691f, 0.11124413f, 
    -0.03249020f, -0.07754128f, -0.08234076f, -0.00243928f, -0.01462520f, -0.07980206f, -0.00432448f, 0.24287340f, 
    -0.12572961f, 0.31921035f, -0.09857347f, 0.17878392f, 0.00941737f, -0.05178251f, 0.00778243f, -0.04079259f, 
    0.14042211f, 0.06533992f, 0.17986034f, 0.01827247f, -0.14278565f, 0.13619958f, -0.01126134f, -0.05454719f, 
    0.11989452f, 0.03671928f, 0.05246003f, 0.03831659f, 0.01396660f, 0.06198492f, -0.16577794f, -0.02423728f, 
    0.31100753f, 0.34860799f, 0.21434286f, 0.25299755f, 0.15955967f, 0.03680933f, 0.05343692f, 0.32962251f, 
    0.07930870f, 0.10961094f, 0.04328518f, -0.11512360f, 0.09894072f, -0.05040453f, -0.02282672f, -0.01091386f, 
    -0.17122962f, 0.08197992f, -0.06627523f, 0.06328108f, -0.05615354f, -0.06179770f, 0.01015919f, -0.06786662f, 
    0.00915192f, -0.00769501f, 0.20489891f, -0.11657147f, 0.00865997f, -0.03611065f, -0.10309301f, -0.07170513f, 
    0.00285429f, -0.05814661f, -0.19511575f, 0.03376682f, -0.13584806f, 0.00224176f, -0.07986240f, 0.07996786f, 
    -0.14348523f, 0.05147733f, -0.05386740f, 0.04359304f, -0.07546635f, 0.19565423f, 0.10417032f, 0.06636278f, 
    -0.00117463f, 0.14719817f, -0.35608897f, -0.15177566f, 0.10683317f, 0.05199739f, 0.11269145f, 0.06005355f, 
    -0.05378353f, 0.05264819f, -0.05995421f, -0.02658537f, 0.02530613f, 0.07952711f, -0.25058070f, 0.10953903f, 
    0.07509986f, 0.06223118f, 0.10173208f, 0.01285726f, -0.06338375f, 0.04907869f, 0.00647697f, -0.18892790f, 
    -0.03645398f, -0.28884059f, -0.21832854f, 0.33553201f, 0.15092736f, 0.08746929f, 0.06782132f, -0.20672584f, 
    0.05482701f, 0.06022656f, -0.05814442f, 0.00619698f, 0.33138502f, 0.46636340f, 0.64443028f, -0.54132569f, 
    -0.03291284f, -0.11401146f, -0.18520585f, 0.14523663f, -0.03072543f, 0.20841187f, -0.01282626f, -0.10053561f, 
    0.04342369f, 0.38465962f, -0.10204744f, -0.12242580f, -0.07226525f, 0.06057881f, 0.10925359f, 0.04496340f, 
    0.07299833f, 0.05122323f, 0.11789373f, -0.00970808f, 0.09092242f, 0.18859008f, -0.14936373f, -0.11013696f, 
    0.10625393f, 0.06449316f, 0.07834981f, -0.04949518f, -0.05317573f, -0.06435857f, 0.01705663f, 0.02413502f, 
    -0.04157704f, 0.13975136f, -0.13259085f, -0.34069711f, 0.17246491f, 0.15022314f, 0.07223204f, 0.06587964f, 
    -0.05985164f, 0.10042827f, -0.07039408f, -0.05993352f, 0.04211785f, -0.09929638f, 0.06347223f, -0.00371483f, 
    0.06537841f, -0.08456470f, 0.03918110f, 0.02710486f, -0.05652034f, 0.05369579f, -0.00508202f, 0.01111067f, 
    -0.27170399f, 0.23518418f, 0.16286080f, 0.38647750f, -0.07084153f, 0.00437841f, 0.08583486f, -0.01350714f, 
    -0.05653635f, 0.11181463f, 0.05377322f, 0.07087766f, -0.19972818f, 0.23223242f, -0.00102324f, 0.15418561f, 
    -0.03807224f, -0.00898919f, -0.07560045f, 0.03848261f, -0.00397869f, 0.05758430f, 0.18796517f, -0.01289505f, 
    0.27823797f, 0.07857107f, -0.03919761f, -0.26272288f, 0.07666223f, -0.14007118f, 0.06924915f, -0.09590196f, 
    -0.06961490f, -0.06981692f, 0.16127865f, 0.15225369f, 0.08642063f, 0.03467576f, -0.06897288f, -0.01445732f, 
    0.15509234f, 0.07763303f, -0.04871002f, 0.08054000f, -0.01734358f, 0.05024407f, -0.03043178f, -0.01944621f, 
    0.27922887f, 0.07820311f, 0.09144922f, -0.16941342f, 0.01315608f, 0.06841975f, 0.05592891f, 0.01125601f, 
    -0.11455974f, 0.05046089f, 0.07305934f, -0.00804943f, -0.03613619f, 0.14114341f, 0.00852250f, -0.07077818f, 
    -0.03582908f, 0.00793241f, -0.10302467f, -0.09230723f, -0.04109488f, -0.05811175f, -0.07593273f, 0.04725766f, 
    0.02176558f, -0.28841341f, -0.10205593f, 0.15594687f, -0.05080586f, 0.02286701f, 0.01246513f, 0.13571045f, 
    0.01948912f, 0.13505009f, 0.03049082f, 0.07637539f, -0.40225321f, -0.04521405f, 0.08475676f, 0.01122395f, 
    -0.00935292f, -0.01660367f, -0.00744533f, 0.04745055f, -0.17245702f, -0.09098639f, 0.01965309f, 0.05252829f, 
    0.28111520f, 0.01115884f, 0.07072611f, -0.08919324f, 0.00009986f, 0.03681296f, 0.00982773f, -0.02031764f, 
    0.14295463f, 0.03691400f, 0.04373539f, -0.00469212f, -0.22692534f, -0.56343818f, -0.11522310f, -0.01564589f, 
    0.22110970f, 0.32071960f, -0.12275906f, 0.15300460f, -0.03191166f, 0.16680974f, 0.03043645f, 0.06571760f, 
    -0.36962500f, 0.31952661f, 0.30443096f, -0.21935266f, -0.14730932f, 0.03613209f, 0.05179939f, 0.24881637f, 
    -0.18242051f, 0.18702629f, 0.11517484f, -0.21798937f, -0.00356699f, -0.15416329f, -0.15726449f, 0.12769268f, 
    -0.01447471f, 0.16388802f, 0.25978175f, -0.13239068f, 0.00324901f, -0.05587833f, -0.03636410f, -0.00559528f, 
    -0.25933468f, -0.16453755f, -0.20471561f, 0.31484109f, 0.08175158f, 0.04495708f, -0.07891437f, -0.04253107f, 
    -0.13637915f, 0.19880816f, 0.08277081f, 0.02789399f, 0.01077011f, -0.17923707f, 0.14194325f, 0.22109523f, 
    0.06048125f, -0.03131764f, -0.09087043f, 0.16120587f, 0.00999714f, 0.05707766f, -0.05420221f, -0.00523415f, 
    0.00291053f, 0.42010105f, 0.22150792f, 0.19084378f, 0.17456965f, -0.02255868f, -0.14797424f, -0.00535791f, 
    -0.03901300f, 0.04415585f, 0.10134910f, -0.05689765f, -0.12718466f, -0.05431744f, 0.19864084f, -0.17076840f, 
    -0.00969351f, 0.08005165f, -0.07939127f, -0.01074671f, 0.03748603f, -0.00608257f, 0.06991903f, 0.08353692f, 
    0.29642630f, -0.07692716f, 0.20480260f, 0.09395016f, -0.06198741f, -0.03554866f, -0.07638713f, -0.04158294f, 
    -0.03829135f, 0.03037882f, 0.07038336f, 0.06709278f, 0.10308671f, -0.17389873f, 0.08604834f, -0.02593069f, 
    0.06026314f, -0.01367648f, 0.13674621f, 0.04989961f, -0.01110914f, -0.02595902f, -0.04440371f, -0.11202904f, 
    -0.12148631f, 0.14540689f, -0.21677405f, -0.00075657f, 0.00255832f, 0.11837513f, 0.03738332f, 0.06858008f, 
    -0.13288078f, -0.02732954f, -0.07798425f, -0.23251577f, -0.04257191f, 0.21038979f, 0.14105301f, 0.03889840f, 
    -0.18224220f, 0.05758514f, 0.20393008f, -0.17034547f, -0.07998243f, -0.02895962f, -0.00066634f, -0.10975757f, 
    0.06758647f, 0.02695622f, 0.08600795f, 0.12259027f, 0.05085615f, 0.19406159f, -0.12781179f, 0.12296706f, 
    0.02550855f, -0.03624437f, 0.15359186f, 0.22060427f, 0.13594832f, -0.10065476f, -0.00637567f, -0.06138654f, 
    -0.04613478f, 0.05568491f, -0.00219117f, 0.07886134f, 0.08319665f, 0.09488905f, 0.08078535f, -0.12594183f, 
    -0.02322971f, 0.23950467f, 0.20871137f, 0.05134930f, -0.11868868f, -0.11473054f, 0.01736806f, -0.06322595f, 
    0.03941758f, 0.10162497f, 0.25093049f, 0.20525661f, -0.06425025f, 0.18389317f, 0.24659483f, -0.02189787f, 
    0.05014647f, 0.07451525f, 0.14028360f, -0.03294214f, -0.03536073f, 0.15440841f, 0.12665005f, 0.01835163f, 
    -0.27075118f, -0.05506096f, -0.24090554f, 0.41957787f, -0.10488991f, 0.06683841f, -0.16313189f, 0.12485152f, 
    -0.01033298f, 0.09945282f, -0.01311497f, -0.12356729f, 0.58791757f, 0.50484407f, 0.35415280f, 0.08788396f, 
    -0.08205893f, -0.24403042f, 0.02953163f, -0.13279828f, -0.27191797f, 0.09443675f, 0.05338777f, 0.10774177f, 
    -0.03645922f, -0.05016423f, 0.02137557f, 0.00550963f, 0.04323017f, -0.00730526f, -0.01403353f, 0.00201545f, 
    -0.03638379f, -0.07902522f, -0.00787940f, 0.04523965f, 0.01338926f, 0.03711408f, 0.01294361f, 0.01946685f, 
    0.02494995f, -0.05874439f, -0.05461941f, -0.00010012f, 0.01919707f, 0.00050313f, 0.05974373f, 0.02929488f, 
    0.05868617f, -0.06831717f, -0.06829855f, -0.01571575f, -0.00213723f, 0.00235407f, 0.00564587f, 0.05018267f, 
    -0.02539243f, -0.00861766f, -0.04521139f, 0.05335331f, -0.03408878f, 0.03228566f, 0.05859622f, -0.04574499f, 
    -0.02083007f, 0.01180682f, -0.01383759f, -0.01762609f, -0.08107762f, -0.00777250f, -0.06777558f, -0.04985858f, 
    -0.05346517f, -0.02739016f, -0.03579513f, -0.01636575f, -0.02135265f, -0.00759801f, 0.04512261f, 0.00874815f, 
    -0.04322817f, 0.03464672f, 0.00619347f, 0.01635176f, -0.04531872f, 0.05943668f, 0.02205149f, 0.02837293f, 
    0.05015653f, -0.03524829f, -0.07915854f, -0.08231778f, -0.08320395f, 0.05008122f, -0.01843661f, 0.03480539f, 
    0.03294886f, -0.04685564f, 0.01310204f, -0.03631423f, -0.02319471f, -0.03869851f, -0.01481730f, 0.02419836f, 
    0.00448931f, 0.03119925f, -0.04558155f, -0.04880180f, 0.04513094f, -0.00954762f, -0.03493763f, -0.03895307f, 
    0.02348609f, 0.03200303f, -0.05000174f, 0.02258951f, 0.02015169f, -0.06332186f, -0.00789965f, -0.05675649f, 
    -0.04553779f, 0.03856131f, -0.07542856f, 0.02864158f, 0.00112162f, 0.01121878f, -0.07104932f, -0.02906317f, 
    -0.00893509f, -0.03981507f, -0.06822261f, -0.08079311f, 0.01152330f, 0.04422050f, 0.00012170f, -0.07460110f, 
    0.00459981f, -0.02524132f, -0.08278985f, -0.01037907f, -0.01287217f, 0.03257880f, 0.02881390f, -0.00826292f, 
    0.05858622f, 0.00434922f, -0.06315190f, -0.01794122f, -0.00909780f, 0.05810176f, 0.03204897f, -0.05133564f, 
    -0.04218127f, -0.00016402f, 0.01818595f, 0.05872373f, 0.00953962f, 0.02642724f, -0.04573661f, 0.00956627f, 
    -0.08015101f, 0.00608886f, -0.07565132f, 0.00703037f, 0.05253784f, -0.07554501f, -0.00367799f, 0.02798049f, 
    0.04904101f, 0.01655833f, 0.05789864f, -0.03609906f, 0.03353803f, 0.04980530f, 0.02183672f, -0.00865431f, 
    -0.02673141f, -0.04631564f, -0.07330264f, -0.08183015f, -0.01007136f, -0.04794867f, -0.05164702f, -0.04272210f, 
    -0.04345204f, -0.01590008f, 0.03764359f, 0.01555288f, 0.02574220f, -0.00052231f, -0.00536770f, -0.04169230f, 
    0.04880525f, 0.00866073f, -0.07251805f, -0.04864780f, -0.00879998f, 0.01056865f, -0.03209412f, -0.05741707f, 
    0.02992177f, -0.00593631f, 0.03829241f, 0.00694430f, 0.00477740f, -0.04962065f, 0.00235046f, 0.03803552f, 
    -0.05258088f, -0.06900248f, -0.07139776f, 0.05101614f, -0.01648473f, -0.01273179f, -0.05018350f, 0.02018377f, 
    -0.33835405f, 0.22470495f, 0.50319535f, 0.02190499f, -0.04529745f, -0.14566790f, -0.12504791f, -0.05568116f, 
    -0.07505000f, -0.07597495f, 0.11432929f, -0.06439445f, -0.39851183f, -0.12513684f, -0.03964477f, 0.27438426f, 
    -0.04482811f, -0.03928476f, -0.03479551f, -0.01762293f, -0.11400858f, 0.05102251f, -0.03950283f, -0.02993325f, 
    -0.49402472f, 0.19813566f, 0.39510217f, 0.24301025f, 0.08862661f, 0.10225122f, -0.19256793f, -0.06939220f, 
    -0.02915169f, -0.12515511f, -0.08945788f, 0.04086296f, -0.49129182f, 0.17919926f, -0.05022455f, -0.16892664f, 
    0.13145363f, -0.00814786f, -0.07014730f, 0.11686777f, 0.04858552f, 0.09638245f, 0.09800668f, -0.03528852f, 
    -0.36163086f, 0.18531568f, 0.09400238f, 0.16297185f, 0.08814668f, -0.09776180f, -0.07223500f, -0.06746896f, 
    -0.12124129f, 0.13735534f, 0.10665829f, 0.10644218f, 0.02513323f, -0.11774867f, 0.01590771f, 0.25435543f, 
    -0.03899989f, 0.03067314f, 0.06172046f, -0.22817837f, 0.06335891f, 0.05458424f, -0.02011023f, -0.06068836f, 
    -0.09861562f, -0.09659847f, 0.04544277f, 0.22756907f, -0.05005746f, 0.24359691f, 0.21052466f, 0.17569536f, 
    -0.04176420f, 0.04887874f, 0.09635117f, -0.02888171f, 0.26276299f, -0.07647291f, -0.02401925f, 0.00332232f, 
    0.05059608f, 0.02545629f, -0.14898145f, -0.04322053f, 0.02266496f, -0.00734945f, 0.10991979f, 0.12036313f, 
    -0.23899603f, -0.14971475f, 0.14623164f, 0.20937859f, 0.04611760f, -0.02400234f, -0.08670502f, 0.07704896f, 
    -0.20902628f, -0.03173888f, 0.04478017f, 0.16201693f, 0.14879481f, 0.30788928f, 0.35193062f, -0.09134129f, 
    0.17770363f, -0.15520497f, -0.05831577f, 0.18912587f, -0.02906145f, -0.06080644f, -0.15464282f, 0.01051445f, 
    0.20082840f, 0.33510819f, 0.25231704f, 0.08973627f, 0.03324125f, -0.04736192f, -0.01489738f, 0.08071604f, 
    0.06533623f, -0.01190085f, 0.00655582f, 0.08170472f, 0.10080171f, -0.26780817f, -0.09050594f, 0.05796718f, 
    0.05405923f, 0.23133461f, -0.02269275f, -0.04146232f, 0.00302036f, -0.01982331f, -0.05936865f, 0.03858877f, 
    0.17832534f, 0.05028957f, 0.20364079f, -0.17480676f, -0.02953387f, 0.00798058f, 0.08218240f, -0.06467631f, 
    0.15511867f, -0.03370162f, 0.10209188f, 0.12357402f, 0.24240750f, -0.20110779f, -0.24723826f, 0.15736994f, 
    -0.02204690f, 0.14941640f, -0.09432201f, 0.02004810f, -0.10142022f, 0.08687661f, 0.34376478f, -0.04720652f, 
    0.17704941f, 0.50163323f, -0.00929848f, 0.04577251f, 0.08744112f, 0.09167473f, 0.09281933f, 0.04729599f, 
    -0.04050902f, -0.02213570f, -0.00734157f, -0.01654159f, -0.01208982f, 0.24014780f, -0.37990010f, 0.14727436f, 
    0.14164065f, -0.20332898f, -0.17532213f, -0.14323024f, 0.03812313f, 0.10033166f, 0.01596115f, -0.02518831f, 
    -0.03432034f, -0.00311603f, 0.05068017f, -0.00300605f, -0.02191078f, -0.01484176f, -0.06822964f, -0.06842837f, 
    -0.00439787f, 0.02327462f, -0.01262589f, -0.01179902f, -0.06420576f, 0.02910591f, -0.05885198f, -0.07647333f, 
    -0.06925321f, -0.04719827f, -0.01185426f, 0.04060870f, 0.03803598f, 0.01443080f, -0.06854340f, -0.02532962f, 
    0.04374503f, 0.04692160f, 0.00165288f, -0.02804260f, -0.05792240f, -0.06455357f, -0.06688509f, -0.02634595f, 
    -0.03318419f, -0.04649059f, 0.04382959f, 0.04306282f, -0.03023362f, -0.07026778f, 0.00352119f, 0.05718980f, 
    -0.02731473f, 0.03348807f, 0.03921220f, 0.02982945f, -0.00209290f, 0.01980198f, 0.02849496f, 0.02442125f, 
    0.00138037f, 0.05247572f, 0.01741531f, 0.02419200f, -0.00336667f, 0.02892255f, -0.01276132f, -0.02754254f, 
    -0.03476560f, -0.03395412f, -0.02252157f, -0.07714786f, -0.02578306f, -0.00423282f, 0.02854726f, -0.05146029f, 
    -0.06152741f, -0.00211660f, 0.05044658f, -0.05564428f, 0.06426112f, -0.02323407f, -0.06409824f, 0.02080524f, 
    -0.04781943f, 0.06162696f, 0.00306764f, -0.05591278f, 0.05119254f, -0.04624606f, -0.03044091f, 0.03673860f, 
    0.04423409f, -0.04865962f, 0.02016541f, 0.05968354f, -0.02788406f, -0.05143918f, -0.01651047f, -0.07461852f, 
    -0.06777012f, -0.04315045f, 0.00673742f, -0.00386052f, -0.07895261f, -0.03727961f, -0.07170221f, -0.06687627f, 
    0.02261545f, -0.04789576f, 0.01427483f, 0.03555202f, -0.00628936f, 0.00113825f, 0.02901504f, -0.01817497f, 
    -0.05252976f, -0.04843332f, 0.01225151f, -0.00449071f, -0.01468608f, -0.03234322f, 0.03522462f, 0.02674066f, 
    -0.07517128f, -0.03625114f, -0.06124335f, -0.05282284f, -0.00655695f, 0.05795845f, -0.01932796f, 0.02723288f, 
    0.06199450f, 0.04716876f, 0.04295642f, -0.05975600f, 0.01886978f, -0.02104597f, -0.02404648f, -0.02805800f, 
    -0.03508205f, -0.00939002f, -0.05820119f, -0.07705878f, -0.05893099f, -0.04404987f, -0.06027741f, -0.02720772f, 
    0.06242824f, 0.03666315f, -0.02637039f, -0.03668385f, -0.03007761f, -0.01969977f, 0.00885740f, 0.04328222f, 
    0.01917788f, 0.01358598f, 0.04756835f, 0.03257047f, -0.06847126f, 0.06123893f, -0.01095234f, 0.05028330f, 
    0.02252075f, -0.06923927f, 0.03023517f, -0.04123901f, -0.03911922f, -0.04049922f, -0.07651214f, -0.07777181f, 
    -0.06723475f, -0.01321457f, 0.04509880f, -0.05790604f, -0.02759878f, 0.04121203f, -0.01642618f, -0.06087422f, 
    -0.07372402f, 0.03833768f, 0.00102930f, 0.02965918f, 0.00655823f, -0.05833977f, 0.02649670f, -0.02893525f, 
    -0.02818184f, 0.00475150f, -0.02372099f, -0.05521144f, 0.04882972f, 0.00958949f, -0.05099413f, -0.00879054f, 
    0.06130892f, -0.05679802f, 0.00482628f, -0.04506656f, -0.03268970f, 0.01845951f, -0.01320149f, 0.00109371f, 
    -0.07405156f, -0.01971878f, 0.02240664f, -0.07476979f, -0.07836764f, 0.01550580f, -0.04192646f, 0.02378040f, 
    -0.08744119f, -0.06811766f, -0.09451108f, 0.01156865f, 0.01676405f, -0.07140280f, -0.08693909f, -0.04930987f, 
    -0.00758037f, -0.06392370f, 0.03021675f, -0.00580713f, -0.01410066f, -0.00977144f, 0.00901788f, -0.07522556f, 
    -0.03454756f, -0.03165377f, 0.04374094f, -0.01235089f, -0.04302919f, -0.02772133f, 0.05452954f, -0.04895121f, 
    -0.02735356f, 0.00363653f, -0.04601299f, -0.05699711f, 0.07119353f, 0.01742518f, -0.01338118f, 0.02535270f, 
    -0.03900858f, -0.00098103f, -0.00988896f, 0.05204793f, -0.06092694f, 0.01974669f, -0.05534112f, -0.02417424f, 
    -0.00055532f, -0.01283226f, 0.02310895f, 0.00938437f, -0.01274257f, -0.07816808f, -0.04716068f, 0.00024125f, 
    0.02313241f, 0.04758476f, -0.01234009f, 0.02504491f, -0.05414132f, -0.03506940f, -0.01196159f, -0.03187259f, 
    -0.01172910f, -0.08774145f, -0.00919825f, -0.00067101f, -0.09171344f, -0.02028571f, -0.05159819f, -0.08526401f, 
    0.04713440f, 0.02962008f, -0.05518944f, -0.00802323f, -0.06364150f, -0.00166169f, -0.02976573f, -0.01500563f, 
    -0.00179119f, 0.06184502f, -0.05091091f, 0.01783969f, -0.02626672f, -0.03501026f, 0.02436713f, -0.04308958f, 
    -0.07335141f, -0.00971509f, -0.08193772f, -0.02329999f, -0.08114672f, -0.02364798f, 0.02586981f, -0.07780164f, 
    -0.06108608f, 0.00773318f, -0.05953921f, 0.04405124f, -0.05018558f, 0.01950376f, 0.01912033f, -0.00857715f, 
    -0.03141837f, 0.02416795f, -0.03063359f, 0.01485145f, -0.03682529f, 0.01899021f, -0.03647140f, -0.02233851f, 
    -0.05158718f, 0.01401236f, -0.05751686f, -0.04309084f, 0.07152566f, -0.01635496f, -0.01418933f, 0.03053893f, 
    0.00388491f, 0.00724325f, 0.03014452f, -0.02966632f, 0.02315604f, -0.01307873f, -0.02256418f, -0.00824599f, 
    -0.05666037f, 0.02503528f, 0.01170690f, -0.02048998f, -0.09243136f, 0.04363732f, -0.07919946f, -0.06899283f, 
    -0.00524979f, 0.00139342f, -0.08104963f, -0.02813509f, -0.01507718f, 0.03720506f, 0.00675155f, -0.01797774f, 
    -0.03881820f, 0.03873789f, -0.04163311f, -0.02054375f, 0.04906716f, -0.07149017f, -0.03008122f, -0.01281860f, 
    0.06443057f, -0.03183120f, 0.07181671f, 0.01434105f, -0.05762741f, -0.05546433f, -0.03898392f, 0.00792728f, 
    -0.08166756f, -0.05269708f, -0.00401907f, 0.00196017f, -0.00289284f, -0.07482301f, 0.02467664f, -0.05141729f, 
    -0.04397907f, -0.06730648f, 0.03881427f, -0.01154253f, 0.03707071f, -0.04547906f, -0.03348300f, 0.04847208f, 
    0.05773577f, -0.02710379f, -0.06476635f, -0.05320293f, -0.06520746f, -0.07177033f, -0.03270686f, -0.02963113f, 
    -0.04845849f, -0.01617795f, -0.06143221f, 0.02288099f, -0.09687250f, -0.08767882f, -0.06267000f, -0.01103356f, 
    0.16091625f, -0.24582435f, -0.08122240f, 0.41946605f, 0.06884901f, -0.07879152f, 0.03781037f, 0.52648830f, 
    0.07970043f, 0.01905498f, 0.04532169f, 0.10322579f, 0.03311802f, -0.32250312f, -0.08769291f, 0.35121867f, 
    0.02297614f, 0.17567223f, -0.13234304f, 0.06028451f, -0.04570615f, 0.08115749f, 0.07151182f, 0.03720458f, 
    0.04037590f, -0.08509057f, 0.23851183f, -0.06096174f, 0.10270892f, -0.06802468f, -0.03461616f, 0.11345097f, 
    0.19869921f, 0.01398311f, 0.12835388f, -0.04194156f, -0.28987896f, -0.14236680f, 0.01401546f, -0.11161957f, 
    -0.14829640f, -0.10176061f, -0.06407632f, 0.12769330f, -0.06794993f, 0.00119787f, 0.12008897f, -0.07050211f, 
    -0.06078064f, -0.35212478f, -0.01148327f, -0.24443501f, 0.04960031f, -0.16925032f, 0.03375296f, 0.05800593f, 
    -0.15139472f, 0.19458102f, 0.03706609f, -0.02030755f, 0.52788013f, 0.05508141f, 0.00668895f, -0.02124721f, 
    -0.04854001f, 0.02624523f, 0.11922441f, 0.03060438f, -0.03492695f, 0.04603165f, 0.03338333f, -0.07005167f, 
    -0.06563413f, 0.03363438f, 0.11414985f, -0.02366040f, 0.09367628f, -0.08817337f, 0.10275982f, -0.03559966f, 
    0.14565165f, -0.10593013f, 0.17895243f, -0.14641301f, 0.25788024f, 0.03135232f, 0.09429989f, -0.07335441f, 
    -0.01190163f, 0.06716629f, -0.10711879f, -0.10458513f, 0.08496856f, 0.08742142f, 0.13916567f, 0.03864135f, 
    0.22143844f, -0.20566131f, 0.06705017f, -0.07501548f, 0.21844877f, -0.00409876f, -0.15286255f, -0.07511920f, 
    0.13391113f, 0.06128545f, 0.17758328f, 0.24039958f, -0.09057800f, -0.19418080f, 0.04890761f, 0.08462676f, 
    -0.00709743f, -0.16355823f, -0.06160145f, 0.34806779f, 0.11098909f, 0.01791159f, 0.21879698f, 0.05679358f, 
    0.06826952f, -0.06648619f, 0.12124573f, 0.03640024f, -0.19216782f, -0.08681902f, 0.23264609f, -0.08584306f, 
    0.06548537f, -0.12890041f, -0.15267847f, 0.03314685f, -0.02919506f, 0.31265825f, -0.00177552f, 0.04685944f, 
    0.06323610f, -0.05927926f, -0.01407770f, -0.05049599f, -0.00131600f, -0.01826840f, -0.12695071f, -0.14394172f, 
    0.29156947f, 0.14352062f, -0.19072662f, -0.08696802f, 0.00327247f, 0.13701689f, 0.03633662f, 0.10826872f, 
    -0.12267774f, 0.02705277f, -0.10568017f, -0.23720504f, 0.36700490f, 0.22406006f, 0.11111339f, 0.13940233f, 
    0.03186953f, 0.01458665f, 0.06507225f, 0.02205633f, 0.06765990f, -0.23984714f, -0.02996599f, 0.11253788f, 
    -0.13548368f, 0.07680267f, 0.23444858f, 0.30693346f, -0.01929829f, 0.00435777f, -0.08262535f, -0.04474595f, 
    0.09234618f, 0.04983483f, -0.00691482f, 0.09369854f, -0.05930952f, -0.00459216f, 0.04919835f, -0.13796213f, 
    -0.05596006f, -0.10348027f, -0.07088476f, 0.01197522f, 0.11957752f, 0.09448671f, -0.00028782f, 0.14263247f, 
    0.15217133f, 0.33871743f, 0.41372174f, -0.24790885f, -0.09673137f, 0.07101377f, -0.17371282f, -0.16312447f, 
    0.19490029f, -0.02718366f, 0.29757315f, 0.17945693f, -0.19083048f, 0.01494173f, 0.06812964f, -0.14181153f, 
    0.15971351f, -0.05750989f, 0.05242587f, -0.16161294f, -0.06241316f, -0.02044568f, 0.01514829f, 0.00787289f, 
    -0.06325050f, -0.20673956f, 0.00387715f, 0.08728649f, 0.04783293f, -0.04221762f, 0.18212423f, 0.01132161f, 
    -0.05216965f, -0.21346474f, -0.11464799f, -0.14712624f, 0.03314220f, -0.01608456f, 0.33512291f, 0.08474998f, 
    0.00955150f, 0.11910345f, -0.08560821f, 0.25286657f, 0.08340128f, 0.02660762f, -0.01770434f, 0.00382802f, 
    -0.00200567f, 0.07150812f, -0.09862653f, 0.17313263f, -0.10926613f, -0.02672236f, -0.29317978f, 0.00569385f, 
    0.09958506f, -0.09704025f, -0.05347126f, -0.04420894f, -0.17984755f, 0.36729276f, 0.17786670f, 0.05423464f, 
    -0.05242671f, -0.01162376f, -0.19661148f, 0.05753797f, 0.10246852f, -0.02341908f, 0.05340321f, 0.06293552f, 
    0.26548752f, 0.23091754f, -0.11472030f, -0.33676171f, -0.10865344f, -0.06769574f, -0.16548434f, 0.27590269f, 
    -0.18048331f, -0.21736065f, -0.18982185f, -0.26137725f, 0.17088845f, 0.06098692f, 0.20711002f, 0.21138485f, 
    -0.12342931f, -0.13056839f, 0.12975146f, -0.16632256f, 0.15488070f, 0.02542935f, -0.17624445f, 0.05299987f, 
    0.04540678f, 0.12994894f, 0.06418321f, 0.02555253f, -0.17522547f, 0.04823186f, 0.00064945f, 0.04527700f, 
    0.25271285f, 0.29717922f, 0.03018068f, 0.07533344f, -0.30808374f, 0.02997410f, -0.12344312f, 0.14779668f, 
    0.05569641f, 0.24305493f, 0.22147965f, -0.19840446f, 0.01780955f, 0.07958528f, 0.09859207f, 0.09954633f, 
    0.07279184f, 0.25522622f, -0.16852608f, 0.43360713f, 0.06079561f, -0.09295564f, -0.00592950f, 0.15319061f, 
    -0.04847786f, 0.10675497f, -0.15709312f, -0.16691945f, -0.05557364f, 0.02912096f, 0.21326594f, -0.28003642f, 
    -0.17524581f, -0.20586066f, -0.22148275f, -0.06143713f, 0.05030936f, -0.06089171f, -0.03013641f, -0.21481001f, 
    -0.25039202f, 0.03114642f, 0.02816558f, 0.02688958f, 0.00859951f, -0.03649147f, -0.02806812f, -0.02356071f, 
    -0.04477329f, -0.06129942f, -0.09604157f, -0.24587744f, 0.16804212f, 0.37083641f, 0.13580084f, -0.09195168f, 
    -0.01999179f, 0.01282805f, -0.07388471f, -0.07927607f, 0.08812442f, -0.03319529f, -0.12207495f, 0.18095136f, 
    -0.40560010f, -0.15354706f, -0.04478903f, 0.31084991f, 0.23515713f, -0.03256999f, 0.01116837f, 0.20017666f, 
    -0.11613163f, 0.02334714f, 0.07205273f, 0.07379904f, 0.25842351f, 0.25260714f, -0.26450467f, -0.11441918f, 
    -0.16455123f, -0.04645059f, 0.03864124f, -0.07812804f, 0.14473931f, 0.00532901f, 0.23429905f, -0.01983511f, 
    0.51031858f, 0.28059912f, 0.21655002f, -0.54424554f, 0.04724929f, 0.11557753f, 0.12365475f, -0.28649044f, 
    -0.00995473f, -0.04781395f, 0.00590621f, 0.02147190f, -0.21385273f, 0.06675748f, -0.37754300f, 0.02446960f, 
    0.28692898f, -0.01962880f, 0.08129746f, -0.01320301f, 0.04950326f, -0.07592770f, 0.00563131f, 0.00336835f, 
    -0.02952050f, -0.35521254f, -0.18036479f, 0.14706279f, 0.07829239f, 0.06680990f, 0.11894561f, -0.12547669f, 
    -0.09923912f, 0.07878590f, -0.00088081f, -0.00249325f, 0.30709335f, -0.05865846f, 0.06271437f, -0.02238134f, 
    -0.02283672f, 0.26887417f, 0.03197711f, -0.13124180f, 0.10948720f, 0.00987921f, 0.00687592f, -0.00280405f, 
    0.17417826f, -0.00731179f, 0.22800614f, 0.46240503f, -0.15470098f, -0.02542651f, -0.08338329f, -0.11823875f, 
    0.38666609f, -0.16426319f, -0.03060471f, 0.00537795f, -0.33029106f, -0.07895615f, 0.00869433f, 0.27281854f, 
    0.07845338f, 0.06602563f, -0.03980159f, -0.06370055f, 0.05748286f, -0.07049516f, 0.00231933f, 0.14978674f, 
    0.13795036f, -0.18293110f, -0.02889810f, -0.24939005f, 0.02250027f, -0.02222832f, -0.22275737f, 0.06658645f, 
    -0.11253199f, 0.02442223f, -0.06616716f, -0.00078488f, -0.24261704f, -0.12515546f, 0.11326330f, 0.12830104f, 
    -0.02741346f, -0.13406530f, 0.11298445f, -0.00477915f, -0.07444420f, -0.08941671f, -0.13310517f, -0.09714542f, 
    -0.04993605f, 0.16095650f, -0.02866955f, 0.23645648f, -0.08401952f, -0.07142633f, 0.12533994f, 0.21393053f, 
    0.09298850f, -0.00442280f, -0.09726665f, -0.11293241f, 0.13222151f, 0.03127620f, -0.16020666f, -0.17946656f, 
    -0.00212357f, 0.14255239f, 0.16972038f, -0.17827575f, -0.10223383f, -0.04797962f, 0.05182125f, 0.01856992f, 
    -0.51000404f, -0.10106459f, -0.16111521f, 0.14341174f, 0.13149963f, 0.14014055f, -0.09343845f, 0.02164090f, 
    0.09673850f, 0.07857209f, 0.23328032f, -0.12329196f, -0.02419191f, -0.38859090f, 0.01516104f, -0.00000214f, 
    -0.04967123f, 0.07790356f, -0.00011551f, -0.09741569f, -0.12475474f, -0.00014641f, 0.02768026f, -0.05589580f, 
    -0.10679822f, 0.28931561f, 0.46253797f, -0.10201427f, 0.08396062f, -0.12964916f, 0.04075171f, 0.02568197f, 
    0.12183364f, 0.11903590f, 0.11582380f, 0.09949486f, -0.23039484f, 0.08024497f, 0.02276080f, 0.00929233f, 
    0.01056835f, -0.11589909f, -0.02565324f, -0.01108294f, 0.16817230f, 0.12327099f, 0.14256912f, -0.04090729f, 
    0.09475537f, 0.04950882f, -0.07527174f, -0.19515464f, 0.02826505f, -0.11388604f, 0.18162633f, 0.18830155f, 
    0.00754417f, 0.06604099f, 0.00567155f, 0.04532436f, 0.23189457f, 0.36071157f, 0.20609507f, 0.27235198f, 
    -0.13600320f, -0.03740071f, 0.09114271f, -0.20384976f, 0.00600235f, -0.19694501f, 0.10037962f, 0.09650036f, 
    0.30898792f, 0.17961833f, 0.05331034f, 0.09000891f, 0.11190476f, -0.06146894f, 0.18838905f, -0.09165722f, 
    0.08531261f, 0.18120547f, 0.08853368f, -0.14714676f, 0.15634231f, 0.03075494f, 0.14062297f, -0.03552676f, 
    -0.02031944f, 0.13018602f, 0.03414908f, -0.13741456f, 0.00063125f, -0.02418336f, -0.08695329f, -0.09655533f, 
    -0.46633804f, -0.23154697f, -0.49883053f, 0.02241519f, 0.07361355f, 0.13513970f, 0.01765001f, 0.06583761f, 
    0.07376798f, 0.15646766f, -0.00938786f, -0.08720507f, -0.02765102f, -0.04960489f, 0.02107027f, 0.23012201f, 
    0.08972032f, 0.04233828f, -0.09279286f, -0.20844120f, -0.02052836f, 0.01652995f, 0.08904492f, 0.09273848f, 
    -0.38119790f, 0.45214799f, -0.21886525f, -0.12517352f, 0.10269681f, 0.13692720f, 0.04191470f, 0.06263184f, 
    -0.17433381f, -0.15595922f, -0.20943378f, -0.04147366f, -0.14932242f, -0.00723708f, 0.08391386f, -0.25556514f, 
    -0.13921618f, -0.02258052f, -0.09793318f, -0.05076219f, -0.03900591f, 0.14441867f, -0.00056814f, 0.03744514f, 
    -0.17564660f, 0.12112170f, 0.11714520f, 0.18812127f, -0.19831258f, 0.11742241f, -0.16265507f, -0.06203188f, 
    -0.05022988f, -0.01582588f, -0.09012152f, 0.25729209f, 0.23611119f, 0.17167063f, 0.30280870f, 0.01849435f, 
    -0.09721979f, -0.14496922f, -0.08445139f, -0.00351065f, -0.14675136f, 0.12276748f, 0.14156403f, -0.08337443f, 
    -0.23795682f, 0.27326515f, -0.03604617f, 0.06335814f, 0.17144655f, -0.19848552f, 0.04918858f, -0.06261063f, 
    0.15264031f, -0.03264735f, -0.01591181f, 0.11730680f, -0.06981097f, 0.09678674f, -0.02844661f, 0.05611997f, 
    -0.01402938f, -0.02224179f, 0.26207265f, 0.07236044f, -0.10145680f, -0.01112428f, 0.04965400f, -0.06484901f, 
    0.10839357f, 0.15141344f, -0.02415911f, -0.01010654f, 0.13676009f, -0.00043734f, -0.00616191f, 0.06112850f, 
    -0.05499735f, -0.05583207f, 0.19748446f, -0.04577578f, 0.30044293f, 0.19527057f, 0.00350544f, 0.08423239f, 
    -0.05966156f, -0.03812795f, -0.03915574f, -0.11773825f, -0.05198956f, 0.08835175f, -0.02809640f, -0.02378890f, 
    0.28083965f, 0.02368412f, 0.15661919f, -0.15713204f, -0.14383769f, 0.01591354f, -0.05700880f, 0.10279277f, 
    -0.02882597f, 0.18372749f, 0.05117818f, -0.16339754f, -0.00085878f, 0.17403702f, 0.33183974f, -0.18123886f, 
    -0.00969128f, -0.07786840f, 0.11130766f, -0.05348983f, 0.00125955f, 0.24600697f, 0.20717043f, 0.01567275f, 
    0.01017686f, -0.09010781f, -0.08414783f, 0.30689028f, -0.13328682f, -0.11409876f, 0.01039843f, 0.06140289f, 
    -0.01727105f, 0.00147134f, -0.07737338f, -0.04116222f, -0.11020919f, -0.19328126f, 0.34864736f, -0.08732169f, 
    0.01865791f, 0.03674037f, 0.09235940f, -0.03833802f, -0.05379360f, 0.36331892f, 0.03072802f, 0.05971230f, 
    -0.06864365f, -0.35059789f, 0.15503980f, 0.12738454f, -0.14507076f, 0.22261839f, -0.29070416f, -0.14109623f, 
    0.17058702f, -0.09557272f, 0.16163866f, -0.00465035f, 0.04156537f, 0.30391333f, 0.23670869f, 0.11166345f, 
    0.10389758f, -0.27570134f, -0.00007446f, 0.00492813f, 0.03684052f, 0.02881797f, 0.09759784f, 0.02997623f, 
    0.15121366f, 0.60881001f, 0.31098971f, 0.23079303f, -0.00959246f, 0.02376392f, 0.11489587f, 0.05878164f, 
    0.00320889f, -0.15154585f, -0.21238619f, 0.21813723f, 0.07580588f, 0.18055990f, 0.01694264f, 0.34326351f, 
    0.18459710f, 0.06023791f, -0.00524332f, 0.02855998f, 0.01479080f, 0.04903821f, 0.02013872f, -0.04180890f, 
    -0.10182811f, -0.05845239f, -0.01942459f, -0.14119714f, 0.00584749f, 0.12389553f, 0.06487560f, 0.09206825f, 
    -0.04438412f, 0.08496446f, -0.11948840f, 0.08744239f, 0.05278683f, 0.11160915f, 0.00766392f, 0.17606707f, 
    -0.06009529f, -0.00240589f, -0.08673228f, -0.09439175f, -0.02521526f, -0.00326583f, 0.10972732f, 0.09024401f, 
    0.40069816f, 0.56692261f, -0.14967270f, 0.06210127f, 0.01189227f, -0.09083815f, 0.17472823f, 0.05687935f, 
    -0.04694548f, 0.10852607f, 0.05485383f, -0.13696969f, 0.31689104f, -0.05069512f, -0.03990239f, -0.13466214f, 
    0.05440148f, -0.03002510f, -0.11112513f, -0.05302875f, 0.08512210f, -0.00190403f, -0.02219366f, 0.11953551f, 
    -0.06027615f, -0.14983653f, -0.05224576f, 0.06158299f, -0.07706639f, 0.10828237f, -0.03006186f, -0.02043586f, 
    0.10536342f, 0.06880887f, -0.03391474f, -0.02401553f, 0.30043578f, 0.38729849f, 0.43229350f, 0.33615774f, 
    0.23336795f, 0.29789788f, 0.29587090f, 0.15187770f, 0.02841508f, 0.10088753f, 0.02614811f, 0.07550889f, 
    0.21223728f, 0.06134118f, 0.43175662f, -0.11311105f, 0.01934219f, -0.21686883f, 0.04523339f, -0.02101448f, 
    -0.12306518f, -0.03200036f, -0.14685917f, 0.15874882f, -0.09582084f, -0.01110609f, -0.19495100f, -0.02119247f, 
    -0.10388301f, -0.17846164f, -0.15010849f, -0.04486813f, 0.01965988f, 0.05244503f, 0.03751332f, 0.08647327f, 
    -0.07281997f, -0.41873866f, -0.12801814f, 0.10557314f, 0.03158661f, 0.08072311f, -0.06846687f, 0.02817179f, 
    0.06436073f, -0.05284417f, -0.10931734f, -0.03007439f, -0.17105374f, -0.23925625f, -0.27770033f, -0.09198172f, 
    0.02138301f, -0.03258841f, -0.03472414f, -0.01713247f, 0.21723336f, -0.15155976f, -0.08559632f, 0.07951732f, 
    0.46086612f, 0.48996553f, 0.50340199f, 0.20768188f, 0.24378867f, 0.23710512f, 0.03736201f, 0.19918531f, 
    0.11706044f, 0.07040446f, 0.07791787f, 0.09878481f, 0.10000774f, -0.41308209f, -0.27645609f, -0.07961371f, 
    0.14309677f, 0.06242929f, 0.18716393f, 0.07085179f, 0.19330543f, 0.05178209f, -0.01916794f, -0.19215311f, 
    0.46720207f, 0.13365027f, -0.13752390f, -0.09959430f, 0.07935469f, 0.14850870f, 0.22235669f, 0.22946522f, 
    0.14714821f, 0.18925868f, 0.13188298f, 0.23441578f, -0.07491791f, 0.17494446f, -0.35909221f, -0.16269870f, 
    -0.10110022f, 0.16985726f, 0.06296314f, 0.03974124f, 0.03039301f, 0.00008454f, 0.06003634f, 0.05941886f, 
    0.01370807f, -0.02571323f, -0.38389531f, -0.10394071f, -0.03228670f, 0.01904040f, 0.08536171f, 0.14729032f, 
    0.00258057f, 0.09008769f, -0.04243869f, -0.07035326f, 0.37446308f, -0.07002742f, 0.10809703f, 0.15957023f, 
    -0.03870730f, 0.08942582f, -0.03084940f, -0.03704735f, 0.00545635f, -0.04146600f, -0.07008882f, -0.01352809f, 
    0.17412546f, 0.22347374f, -0.03627485f, 0.03368326f, -0.12869640f, 0.02202544f, 0.07767285f, -0.00696486f, 
    -0.02159766f, 0.02783046f, 0.10466529f, -0.05860698f, -0.26341036f, 0.09115781f, 0.05116645f, -0.00954318f, 
    -0.03942249f, 0.07757914f, 0.00456328f, -0.00070717f, -0.04116380f, 0.03277151f, 0.09737749f, 0.15638152f, 
    0.00464814f, -0.18619515f, -0.25624737f, -0.17587222f, -0.03193244f, -0.05958279f, -0.19394958f, -0.19737554f, 
    -0.00746494f, -0.02536002f, -0.11959704f, 0.04495781f, -0.02408303f, -0.22158870f, 0.27839887f, 0.21235670f, 
    -0.16128968f, -0.01902199f, 0.06457916f, 0.06405161f, -0.02102211f, -0.00498026f, -0.09379312f, -0.02184404f, 
    -0.22586699f, 0.46833727f, -0.09125813f, 0.11613885f, -0.10845748f, 0.00429951f, 0.05109064f, 0.01404466f, 
    0.43951851f, 0.08255339f, -0.03709630f, 0.00154287f, -0.18931216f, 0.06081204f, -0.08153914f, -0.08485889f, 
    -0.23170708f, 0.01965127f, 0.14264314f, -0.05903481f, -0.04951395f, 0.05325721f, 0.05336112f, -0.00889375f, 
    0.06357777f, -0.12603414f, -0.03548666f, -0.05178826f, -0.00407180f, 0.05563562f, 0.07618789f, 0.02816492f, 
    -0.13826501f, 0.10491973f, 0.10271470f, -0.10609261f, -0.19260094f, -0.11414222f, -0.14677358f, 0.21740787f, 
    0.03384487f, -0.01212955f, 0.03431523f, 0.02070918f, -0.02144323f, 0.08024459f, -0.04053901f, -0.03462787f, 
    -0.02612869f, 0.07089981f, 0.06527975f, -0.01972861f, 0.07246098f, -0.00430679f, -0.15095979f, 0.06560799f, 
    -0.03470836f, 0.08827554f, -0.18632403f, -0.05783714f, -0.24534751f, 0.16417576f, 0.08496984f, 0.16025516f, 
    -0.06028691f, -0.02138124f, 0.04747842f, -0.12705320f, -0.04910037f, 0.22576085f, -0.04091581f, -0.01607631f, 
    -0.40343398f, -0.11152425f, -0.53115922f, -0.14641964f, -0.08535590f, -0.10106047f, -0.11762615f, -0.12435496f, 
    -0.11186283f, -0.02139885f, 0.03064108f, 0.07692602f, 0.25669730f, 0.30064371f, 0.62832683f, -0.05761422f, 
    -0.18159601f, 0.06510869f, 0.06472410f, 0.02605520f, -0.00393081f, 0.14366248f, 0.02823846f, 0.08167921f, 
    0.03561612f, -0.01052078f, 0.00359877f, -0.00120879f, -0.07218990f, 0.01395192f, -0.02462693f, -0.03324778f, 
    -0.01839564f, 0.06070358f, -0.01861311f, -0.01477181f, 0.02003132f, -0.02036547f, -0.04411916f, -0.03157379f, 
    -0.00632983f, -0.07140290f, -0.06020136f, -0.07252767f, -0.02860201f, -0.06066430f, -0.02656079f, 0.03031241f, 
    -0.00929958f, 0.03691168f, -0.06957890f, 0.03959245f, -0.07088456f, -0.06837939f, 0.05948289f, -0.06832999f, 
    0.05400179f, -0.04824156f, 0.01598268f, 0.05697670f, -0.03062515f, 0.03062684f, -0.03541138f, 0.01041329f, 
    0.01146549f, -0.02180636f, -0.06429689f, -0.01997126f, 0.00723737f, -0.00233851f, -0.05950993f, -0.07812472f, 
    -0.02183812f, -0.05025767f, 0.03830661f, 0.05838546f, 0.01284190f, 0.02772716f, 0.01351070f, -0.03249000f, 
    0.03415835f, 0.01340986f, 0.05989654f, -0.04999466f, -0.03245274f, -0.07798483f, -0.00161578f, 0.05875912f, 
    0.02950632f, 0.00000332f, -0.07961210f, -0.05281470f, -0.06289063f, 0.01859375f, 0.03709446f, -0.07490191f, 
    0.04850384f, 0.03115981f, 0.03292116f, 0.05627092f, 0.04878942f, -0.02876607f, -0.06501725f, 0.02127114f, 
    -0.00245061f, -0.04340553f, -0.07368917f, 0.06361263f, -0.03636636f, -0.00914692f, -0.01374664f, 0.02709965f, 
    -0.06870004f, 0.03251861f, -0.04706627f, -0.01677641f, -0.07234517f, 0.04648193f, 0.02468562f, -0.04032816f, 
    -0.07196756f, 0.03007691f, -0.05050162f, -0.04456026f, -0.04363484f, -0.05891433f, 0.04495365f, 0.00845441f, 
    0.04777926f, -0.00207066f, 0.03029185f, -0.02765629f, 0.02962631f, -0.05981881f, 0.03168620f, 0.02377763f, 
    -0.05720716f, 0.03092461f, 0.05528609f, 0.03500627f, -0.05258150f, -0.05882336f, 0.03456805f, 0.01168365f, 
    -0.06261510f, -0.02600942f, 0.00222307f, -0.03335585f, -0.07945081f, 0.04980791f, -0.02120216f, 0.02248528f, 
    0.01215477f, -0.00628360f, 0.03042253f, -0.06822813f, -0.04251831f, 0.06483719f, 0.04273148f, -0.04221897f, 
    0.05151090f, -0.06986190f, 0.05271301f, -0.07453924f, -0.04895059f, -0.07501181f, -0.00947849f, 0.04076899f, 
    0.05623676f, -0.06986373f, 0.01167373f, 0.05421541f, -0.02856626f, -0.02058508f, -0.00383668f, 0.04064982f, 
    0.01584368f, -0.03913105f, -0.04453002f, -0.08285055f, 0.02815160f, 0.01526995f, 0.05307510f, -0.07106063f, 
    -0.02637101f, 0.05459636f, -0.07932263f, 0.02975517f, 0.04327353f, 0.05635619f, -0.04181832f, -0.07565390f, 
    -0.06031611f, -0.01923062f, -0.03986770f, -0.04831357f, 0.03707254f, -0.06061023f, -0.00891413f, 0.04908234f, 
    -0.03817174f, 0.06192099f, 0.01710813f, 0.01655131f, 0.00418340f, 0.02590800f, -0.06332374f, 0.05213888f, 
    -0.03477199f, -0.03913634f, 0.04446768f, 0.04201654f, 0.03859803f, -0.06037673f, 0.05219361f, -0.05514682f, 
    -0.20997570f, -0.07628945f, -0.19231379f, 0.31147599f, -0.07651460f, -0.00818755f, -0.16489293f, 0.09032007f, 
    0.11189725f, -0.12258303f, 0.18272144f, 0.37860757f, 0.02860865f, 0.40832531f, 0.09215260f, -0.20484415f, 
    -0.11255011f, -0.07900395f, -0.06645656f, 0.17188764f, 0.03417579f, 0.05694502f, 0.03091701f, 0.07983270f, 
    0.35421944f, 0.53839463f, 0.15983246f, -0.13461621f, 0.12767930f, 0.14125772f, 0.08155945f, 0.08613589f, 
    0.12806624f, -0.26341236f, -0.17712928f, 0.03401423f, 0.08295695f, 0.19048959f, -0.15270215f, -0.15878510f, 
    0.21286365f, 0.08054020f, 0.09447011f, 0.14143302f, -0.04992496f, -0.05925073f, -0.08271120f, 0.00526715f, 
    0.04980393f, 0.21302499f, -0.15997826f, -0.25652480f, -0.05126624f, 0.06712545f, 0.12400354f, 0.06144874f, 
    -0.13419510f, 0.18691744f, 0.06437539f, -0.11378127f, -0.02090233f, 0.10598491f, -0.18940333f, 0.18601926f, 
    0.05955263f, -0.01982761f, 0.08662891f, 0.05750114f, -0.00588334f, 0.08664317f, 0.13716990f, 0.16130254f, 
    -0.17034082f, 0.14538944f, -0.09002566f, 0.22855598f, -0.00547539f, -0.02820216f, 0.02281254f, 0.07375907f, 
    0.00007596f, -0.03110088f, -0.11706132f, 0.05165245f, -0.10498454f, 0.09099400f, -0.09290630f, 0.36282021f, 
    -0.04590886f, -0.06400059f, -0.06738459f, 0.00949942f, 0.09734404f, -0.02697816f, -0.05405810f, 0.22644322f, 
    -0.05764847f, 0.06594647f, 0.09685995f, -0.09541243f, -0.04923430f, -0.08537760f, -0.10122969f, -0.11591144f, 
    0.08825857f, 0.00514862f, 0.27992097f, 0.17763658f, 0.06729917f, 0.19540577f, -0.00792530f, 0.00981321f, 
    0.16980945f, 0.20818907f, -0.13838102f, 0.14036380f, 0.12307831f, 0.09564547f, 0.00577935f, 0.07403773f, 
    0.38241899f, 0.30227157f, 0.20315778f, 0.01691792f, -0.02602935f, 0.01246530f, 0.18048114f, 0.26494670f, 
    -0.07478539f, 0.05997085f, -0.17958632f, -0.11419475f, -0.38652366f, -0.19346192f, -0.20409971f, -0.01763910f, 
    -0.04575713f, 0.00987894f, -0.07902194f, -0.03048516f, -0.07290555f, -0.14044306f, -0.06650350f, 0.01453385f, 
    0.02634191f, -0.19242390f, -0.20105913f, 0.16522971f, 0.05864167f, -0.03714925f, -0.02217225f, -0.01243219f, 
    -0.09156670f, -0.00787892f, -0.31321824f, 0.01670809f, -0.20699441f, 0.09586976f, -0.33137381f, 0.12749535f, 
    -0.08732355f, 0.12053586f, -0.06575606f, -0.11055000f, -0.05885754f, -0.07294417f, -0.02992195f, 0.02965847f, 
    0.16378136f, 0.26510164f, -0.17424585f, -0.18125267f, 0.27479184f, 0.17213818f, 0.08147162f, 0.04417424f, 
    0.00015799f, 0.04052023f, -0.05456580f, 0.07893470f, -0.01227066f, -0.00644515f, -0.18882193f, 0.05151159f, 
    -0.01971185f, 0.12177507f, -0.07185766f, 0.27141261f, 0.11735199f, 0.14964086f, -0.11160487f, 0.00183313f, 
    0.03757317f, 0.05657955f, -0.00470660f, 0.00019199f, -0.06423365f, 0.03664136f, -0.01264997f, -0.07516368f, 
    0.05727408f, -0.06992532f, -0.05612381f, -0.00765646f, -0.00430277f, 0.05136082f, -0.07062871f, 0.04157522f, 
    0.00112623f, -0.07356706f, -0.06587938f, 0.02253666f, -0.05545634f, 0.01740236f, -0.01579862f, -0.00405202f, 
    0.02709922f, -0.04404684f, -0.00805822f, -0.00756696f, 0.01210602f, 0.02204219f, -0.06823489f, 0.03063583f, 
    0.02920487f, 0.03977986f, -0.00122214f, 0.04435752f, -0.03969300f, 0.02337640f, 0.05551397f, 0.04934681f, 
    -0.06347764f, 0.02568303f, 0.03940254f, 0.06209696f, -0.00428330f, -0.06345857f, -0.05038520f, 0.04152500f, 
    0.00249046f, 0.05738813f, -0.00768332f, -0.05172765f, 0.03069293f, -0.04923988f, -0.07481936f, 0.01149974f, 
    -0.05198728f, -0.05614176f, -0.05373257f, 0.04472323f, 0.06015501f, 0.01317630f, 0.04237823f, -0.01043079f, 
    -0.03722126f, -0.01086610f, -0.05266305f, 0.01098687f, 0.03541067f, 0.03683076f, -0.00681442f, -0.01026141f, 
    -0.04324677f, -0.08106365f, 0.01009172f, -0.06042478f, -0.01228294f, 0.00703027f, 0.01871435f, 0.06011348f, 
    -0.02079384f, -0.01717697f, 0.01237443f, -0.04643549f, -0.05650444f, -0.02181540f, -0.06790095f, -0.07348197f, 
    -0.07092481f, 0.01207544f, -0.07895542f, 0.00201688f, -0.05714071f, 0.04101840f, -0.02057840f, -0.06523632f, 
    0.02692764f, -0.07938199f, -0.05997039f, 0.03328640f, 0.00199562f, -0.01941918f, 0.00460767f, 0.04790843f, 
    0.04178619f, -0.01787273f, -0.05559139f, -0.05991951f, -0.07258832f, 0.04304591f, -0.02837728f, 0.01429814f, 
    0.02457532f, -0.02425312f, 0.02492973f, 0.02809485f, 0.04496562f, -0.06207069f, -0.04324164f, -0.06809862f, 
    -0.00912579f, -0.06836414f, -0.05969087f, -0.07034282f, 0.04416055f, -0.06013520f, -0.05102612f, -0.06481529f, 
    -0.07459681f, 0.05653516f, -0.07119106f, -0.04340674f, -0.00621756f, 0.05376672f, -0.05471766f, -0.03876681f, 
    0.05272418f, -0.06460541f, 0.03494367f, 0.02844260f, -0.05983302f, -0.00588172f, -0.03823388f, -0.02576283f, 
    -0.07688274f, 0.00039839f, -0.08218472f, 0.05817674f, -0.04112418f, -0.08038364f, 0.04021023f, -0.03581818f, 
    -0.01986303f, -0.07012770f, -0.02342986f, -0.04564041f, 0.06279209f, 0.04233857f, 0.00599915f, -0.05967752f, 
    -0.02502812f, -0.03949727f, 0.04122585f, 0.04939144f, 0.04551675f, -0.01592376f, 0.06172922f, -0.03116619f, 
    0.00842166f, 0.05663253f, -0.01425063f, -0.04346766f, 0.00590200f, 0.05881245f, 0.02721446f, -0.02811383f, 
    -0.00549333f, 0.01475271f, -0.04430631f, 0.03349536f, -0.04749154f, 0.01613415f, 0.03595622f, -0.07038062f, 
    0.02833069f, -0.02231424f, 0.00760517f, -0.04723217f, -0.03738284f, -0.05292193f, -0.02117448f, 0.04964150f, 
    -0.75265813f, 0.39003196f, -0.12534577f, 0.08040426f, 0.00583279f, -0.18382969f, 0.03547360f, -0.12170092f, 
    -0.01044783f, 0.08642899f, 0.05680972f, 0.01230739f, 0.38565782f, 0.02797211f, -0.01138217f, 0.00953929f, 
    0.09084120f, 0.09493389f, 0.03176924f, -0.18158968f, 0.11623590f, 0.02016313f, -0.05191163f, -0.04659173f, 
    -0.12139603f, -0.02985577f, 0.03626100f, -0.07793171f, 0.02836149f, -0.07207203f, -0.11914340f, -0.04536000f, 
    -0.01301611f, 0.12762825f, 0.01827548f, 0.13025248f, -0.25430089f, -0.20513330f, -0.01575549f, 0.16831422f, 
    0.09263825f, -0.08700367f, -0.01404759f, -0.02680510f, -0.06344967f, -0.06191080f, 0.08973616f, 0.11277794f, 
    0.01307927f, 0.26458529f, 0.10314167f, 0.09475987f, -0.03672357f, -0.10443656f, -0.08284634f, -0.04465576f, 
    0.17032319f, 0.16277990f, 0.02749878f, 0.10112794f, -0.09318843f, -0.08513395f, -0.07936868f, -0.07293839f, 
    0.07164421f, -0.02121636f, 0.01220119f, -0.12876697f, 0.07657058f, 0.03445174f, -0.01489990f, -0.04748349f, 
    0.00168631f, -0.15657108f, 0.22620410f, 0.28438583f, 0.12525447f, 0.01823363f, 0.19791755f, 0.04785567f, 
    -0.08231249f, 0.00439061f, -0.05907170f, -0.02164706f, -0.28892446f, 0.16865066f, -0.09179762f, 0.09557831f, 
    0.12133955f, 0.05395927f, 0.08089622f, -0.02088003f, 0.01687210f, -0.02027902f, -0.02265580f, -0.05074088f, 
    0.09025101f, 0.05389284f, -0.06700806f, -0.13945588f, 0.04552961f, -0.04569297f, 0.00577476f, 0.14007267f, 
    -0.25833982f, 0.02533857f, 0.07112084f, -0.09396385f, -0.08041668f, -0.13316177f, -0.20755224f, 0.01407452f, 
    -0.05898363f, 0.01765924f, 0.05093409f, -0.16138782f, 0.09066210f, 0.05721829f, -0.04429594f, 0.07321927f, 
    0.05640918f, 0.15831265f, -0.39383170f, 0.24552725f, 0.02275429f, 0.09327248f, 0.08936291f, -0.00824094f, 
    -0.00407318f, 0.01245986f, 0.06367826f, 0.03640012f, -0.08794384f, -0.26512745f, 0.28326082f, -0.12723231f, 
    0.11871810f, 0.09744472f, 0.00797267f, 0.01363274f, 0.00307246f, 0.01187647f, 0.02718013f, 0.00601574f, 
    -0.26230618f, 0.42621967f, 0.20190975f, 0.20500982f, -0.08066643f, -0.12078033f, 0.14243309f, -0.16226888f, 
    0.14580423f, -0.05733924f, -0.00322093f, 0.25751346f, -0.19727635f, 0.17860331f, 0.10874994f, -0.13877234f, 
    0.01164695f, 0.05830767f, -0.11128730f, 0.00466326f, -0.00917447f, 0.10751113f, 0.05455859f, 0.01013387f, 
    0.08070931f, -0.22364242f, -0.19638346f, 0.03639245f, 0.05002147f, 0.12109987f, 0.05407423f, 0.12136452f, 
    -0.04413997f, -0.06027019f, 0.02034990f, -0.06475891f, 0.30073875f, 0.34837574f, 0.09499691f, 0.32061604f, 
    0.02983809f, -0.04444533f, 0.00649980f, -0.01074150f, 0.17192727f, 0.07095451f, 0.17761852f, 0.16580909f, 
    -0.13698168f, 0.06390383f, 0.03093826f, -0.13407230f, -0.03541715f, -0.11819764f, -0.16682659f, -0.04986095f, 
    -0.00880664f, -0.19508903f, -0.04468803f, 0.11490332f, -0.38004231f, -0.27742299f, -0.22524774f, 0.30539393f, 
    0.21447527f, -0.02063994f, 0.03467122f, -0.02450693f, -0.01692606f, -0.07410613f, -0.03852391f, -0.02014325f, 
    0.11069191f, 0.22094423f, 0.73313868f, 0.11686960f, 0.08309475f, 0.07324474f, -0.10306426f, -0.08907076f, 
    0.09380702f, -0.05822685f, -0.06189721f, 0.21715042f, -0.19719471f, 0.25641075f, 0.18802263f, -0.12151267f, 
    0.00700539f, 0.15863302f, 0.02461588f, 0.18737002f, 0.04698442f, -0.05760883f, 0.02699237f, 0.05180753f, 
    0.03346746f, -0.33401617f, 0.25065461f, 0.24000268f, -0.04764517f, -0.18894206f, -0.03516476f, -0.10580377f, 
    0.26448742f, 0.18658355f, 0.07705976f, 0.11831453f, 0.19178146f, -0.10058385f, -0.32582602f, 0.20250514f, 
    0.06512968f, -0.00062459f, 0.09087509f, -0.02769041f, 0.00236808f, 0.03546731f, -0.11873721f, -0.05750698f, 
    0.09929393f, -0.22029495f, -0.07128341f, -0.10042342f, 0.04286524f, 0.03663023f, 0.26633337f, 0.18205371f, 
    -0.00454975f, -0.01171664f, -0.00503025f, -0.17911537f, 0.01643536f, -0.01989166f, -0.26650324f, -0.00796712f, 
    0.00925536f, -0.00731844f, -0.05104804f, -0.04837912f, 0.07900903f, 0.02295179f, -0.10149340f, 0.01751434f, 
    -0.00844402f, -0.42470869f, 0.20903677f, 0.24958950f, -0.01231981f, 0.03613650f, -0.04530289f, 0.09288158f, 
    -0.13593307f, -0.04464483f, 0.06510235f, 0.05298242f, 0.21607590f, -0.00852642f, 0.05650089f, -0.02119578f, 
    0.09597000f, 0.02910080f, -0.06103794f, 0.18928541f, 0.03307005f, 0.00871937f, -0.01134021f, -0.02984635f, 
    -0.16449445f, 0.12700459f, 0.07279595f, 0.13938178f, 0.01394425f, -0.02711513f, 0.01719212f, 0.00103719f, 
    0.08299261f, 0.08047633f, -0.09021729f, 0.08707156f, -0.16208538f, -0.43793488f, -0.01047341f, 0.09607480f, 
    0.10375414f, 0.09959090f, 0.07407553f, 0.03775144f, -0.03134218f, -0.07748337f, -0.07569675f, -0.00650357f, 
    0.01200978f, 0.23655528f, -0.07534667f, -0.05806178f, 0.07195628f, 0.02547313f, 0.02467826f, -0.09853461f, 
    0.12719551f, -0.09128065f, 0.06967792f, 0.08839095f, 0.35238028f, -0.18894041f, -0.46682027f, -0.03008388f, 
    -0.06754377f, 0.04563032f, -0.14052276f, -0.01885304f, 0.01441144f, -0.13612917f, 0.10013975f, 0.12674056f, 
    0.14859036f, 0.37857950f, 0.29233032f, -0.11590096f, 0.11041269f, 0.13565856f, 0.26075831f, 0.01799553f, 
    -0.00927168f, 0.06129409f, 0.06598569f, 0.00366542f, 0.00301476f, 0.47337741f, -0.27833498f, 0.18198723f, 
    -0.00563951f, -0.09836628f, -0.14741284f, -0.10078081f, 0.22881210f, -0.17294818f, -0.00190172f, 0.02255722f, 
    0.27551073f, 0.03670175f, -0.19111912f, -0.07286549f, -0.11636063f, 0.06079102f, -0.01571549f, 0.05489251f, 
    0.17636713f, -0.06644759f, 0.04960331f, -0.14093862f, 0.22323017f, 0.15183811f, 0.00738949f, -0.10950217f, 
    -0.20749401f, 0.10109475f, 0.24614187f, -0.16795057f, -0.07419790f, -0.07922632f, 0.08258151f, 0.10996610f, 
    0.09744003f, -0.16686490f, -0.07754989f, -0.09506129f, -0.01820286f, 0.16056791f, -0.08240266f, 0.03246596f, 
    0.14467990f, 0.11136875f, -0.07910780f, 0.08391286f, -0.61187786f, -0.70197552f, -0.79079139f, -0.31480870f, 
    0.19402038f, 0.01269543f, 0.02477560f, 0.14985594f, 0.00013672f, 0.04073756f, 0.05917697f, 0.08894189f, 
    0.30544212f, 0.10244325f, -0.03604290f, -0.42419499f, -0.09783007f, 0.25236976f, 0.02308896f, -0.03852256f, 
    -0.03066974f, -0.00957245f, -0.07824308f, 0.02213934f, 0.42612004f, 0.31861472f, -0.17502256f, -0.03727388f, 
    -0.07628012f, -0.03888814f, 0.16660379f, 0.02218846f, -0.00410577f, 0.04997475f, 0.01406799f, 0.09916605f, 
    0.34714344f, -0.19862045f, 0.32614684f, 0.35575333f, -0.02528084f, -0.00375578f, 0.11241603f, 0.11494797f, 
    0.04068548f, -0.04826668f, 0.17066166f, 0.27808413f, 0.54029042f, 0.35857236f, 0.22157225f, 0.29780221f, 
    -0.03977548f, -0.06432129f, 0.07600241f, -0.08307391f, -0.08320656f, 0.04069598f, -0.01234125f, -0.05698451f, 
    -0.14148986f, 0.09005955f, 0.05820574f, -0.01480938f, -0.02452577f, -0.02554590f, 0.07440172f, -0.12901726f, 
    -0.01896258f, -0.12976921f, -0.22361724f, 0.12446803f, -0.36368349f, -0.11100908f, -0.29601544f, -0.02325133f, 
    0.00704894f, 0.14159071f, 0.11911262f, 0.36833197f, -0.08814547f, -0.15882179f, -0.01430195f, -0.09906911f, 
    -0.38431486f, -0.26334801f, -0.32580951f, -0.55279374f, 0.07475187f, 0.25154677f, -0.02264201f, 0.00018554f, 
    0.05876074f, 0.08021973f, 0.15893035f, 0.01238776f, 0.26775816f, 0.22621566f, -0.00054059f, 0.25268140f, 
    -0.03305073f, -0.13234228f, -0.10560811f, -0.03221754f, 0.01075932f, -0.03238701f, -0.10373184f, -0.01130495f, 
    0.39415714f, -0.07994346f, 0.00170676f, -0.10937929f, -0.05312857f, -0.09256668f, -0.03431213f, 0.15198144f, 
    -0.18839289f, -0.05863306f, 0.18156116f, 0.09353282f, 0.51608646f, 0.18568194f, 0.16806655f, 0.03400945f, 
    0.05194898f, 0.02349134f, -0.09757108f, 0.10753921f, 0.38545120f, 0.35586181f, 0.15938802f, 0.00361158f, 
    -0.58229530f, -0.16193129f, -0.25482768f, -0.07745143f, -0.06823937f, 0.08836747f, -0.11430506f, 0.12773840f, 
    -0.02568177f, -0.10192572f, -0.01154161f, -0.15928371f, -0.00807264f, -0.32293105f, -0.26252696f, -0.37442049f, 
    -0.10001627f, -0.24006619f, -0.20992893f, -0.18828982f, 0.07935397f, 0.22689144f, -0.03293652f, 0.01216492f, 
    -0.49541026f, 0.24631099f, 0.17238973f, -0.12108015f, -0.02293429f, 0.00544029f, 0.13823743f, -0.19367045f, 
    -0.32154870f, 0.16851683f, -0.12617674f, -0.48579097f, 0.40380126f, 0.03875923f, 0.20105296f, 0.14743666f, 
    0.03650665f, 0.02726333f, -0.15446122f, -0.04427737f, -0.22282390f, -0.08811081f, -0.21601290f, -0.36539724f, 
    0.01430561f, 0.01142504f, 0.09582563f, 0.31569186f, -0.04850400f, 0.05024774f, -0.13422988f, -0.03139742f, 
    0.16640022f, 0.25750616f, 0.33018303f, 0.28001407f, -0.11740364f, -0.00177854f, -0.04646650f, 0.21525104f, 
    0.17836758f, -0.06886278f, 0.12747826f, 0.22808217f, 0.02548025f, 0.05502569f, 0.07417081f, 0.04638654f, 
    -0.15501861f, 0.11657288f, 0.22974968f, 0.28502193f, 0.22550182f, 0.12806571f, 0.04217065f, 0.06975580f, 
    0.21846889f, 0.10316317f, 0.12893419f, 0.09860241f, 0.14756696f, 0.00786103f, 0.23374008f, 0.08796600f, 
    0.03386023f, 0.06586313f, -0.02832593f, -0.12432588f, 0.07557163f, -0.05238283f, -0.13383964f, -0.04287008f, 
    0.13245298f, 0.16676043f, 0.28823119f, 0.33472845f, -0.13649568f, 0.11729155f, 0.21757244f, -0.09083903f, 
    0.15269510f, 0.21172714f, 0.42170849f, 0.15407392f, -0.04313597f, 0.13737510f, -0.01308828f, -0.19834688f, 
    0.19747293f, 0.13932650f, -0.29533887f, -0.06052941f, -0.25073299f, 0.00905778f, 0.16245230f, -0.07395359f, 
    -0.00999857f, -0.20875333f, -0.16688055f, -0.10171715f, 0.13743111f, -0.24958590f, -0.03828771f, 0.10944436f, 
    -0.38365713f, -0.09501725f, -0.41062143f, -0.21119757f, 0.21553117f, 0.01361527f, 0.07142191f, -0.08442039f, 
    -0.15105680f, -0.15897675f, 0.13658588f, -0.16570413f, -0.29028687f, -0.26663381f, -0.32604527f, -0.38740572f, 
    0.19444329f, -0.02478558f, 0.02830069f, 0.19005729f, 0.10214322f, 0.28140256f, 0.08867439f, -0.00203983f, 
    0.12020545f, -0.22378254f, 0.19520761f, 0.46211240f, 0.23015071f, 0.18718690f, 0.14001130f, -0.26377633f, 
    -0.05015892f, 0.01873913f, -0.07977284f, 0.05149576f, -0.22879910f, -0.13380148f, 0.01263850f, -0.02524346f, 
    -0.11544615f, 0.01004862f, 0.16158652f, 0.27160311f, -0.07655133f, -0.00712690f, 0.07389347f, -0.31928796f, 
    0.24119115f, 0.15318865f, 0.48032656f, 0.57728535f, -0.30087799f, -0.12547769f, 0.23204052f, 0.00011947f, 
    -0.20013009f, -0.04065190f, -0.00605746f, -0.04776065f, -0.03844824f, 0.20430206f, 0.31426844f, 0.18440849f, 
    0.01524687f, -0.14420247f, 0.17658238f, 0.16219631f, 0.06275460f, 0.17284121f, -0.16507764f, -0.00334786f, 
    0.15094863f, -0.24922203f, -0.05431259f, -0.26351741f, 0.11052452f, 0.15375572f, 0.26469138f, 0.34121299f, 
    0.13398843f, -0.06221221f, -0.12610789f, -0.08433677f, -0.06348438f, -0.05166426f, -0.03335560f, 0.02170124f, 
    -0.02881036f, 0.05787373f, -0.03677643f, -0.03072400f, 0.01658542f, -0.01060830f, -0.00569376f, -0.02258177f, 
    -0.00696636f, 0.05260581f, -0.03833511f, 0.05961239f, -0.05069866f, -0.07473285f, 0.06004402f, -0.01036658f, 
    -0.05247655f, -0.01995258f, -0.00106029f, 0.02052186f, -0.05053502f, -0.01114141f, -0.01330099f, -0.01934205f, 
    0.03205208f, 0.01513635f, -0.06078947f, -0.02949019f, -0.07745475f, -0.01577183f, 0.02969519f, -0.07006061f, 
    -0.03123664f, -0.04687257f, -0.07522683f, 0.05758741f, 0.05344278f, 0.01011830f, 0.05288228f, -0.01971187f, 
    -0.05525209f, 0.04287859f, -0.05101753f, 0.03902814f, 0.04344512f, 0.02648982f, -0.05583493f, 0.04357853f, 
    0.04470047f, -0.01990817f, 0.02755032f, 0.03250544f, -0.02919154f, 0.00023478f, -0.03275322f, -0.01135794f, 
    0.02823049f, -0.05148203f, -0.04174018f, -0.01170488f, -0.02458878f, 0.05216938f, -0.04991346f, 0.05361092f, 
    0.04728022f, -0.06178446f, -0.03000158f, 0.00407403f, 0.02395054f, -0.02062245f, 0.04829963f, 0.00798399f, 
    -0.02916826f, -0.07294857f, -0.03639301f, -0.08481686f, -0.03323757f, 0.00900626f, 0.03794400f, -0.02407223f, 
    -0.00800958f, 0.01934011f, -0.00213150f, -0.02323547f, -0.01964648f, -0.02982762f, -0.02647475f, -0.04707398f, 
    0.05728342f, -0.01249117f, 0.00000062f, -0.04308838f, 0.03697675f, -0.05949882f, 0.02914881f, -0.00225218f, 
    -0.06035238f, -0.05295400f, -0.02029381f, 0.07231213f, 0.02663347f, -0.07747672f, -0.05971749f, -0.05636548f, 
    -0.05614097f, -0.05405990f, 0.02726403f, 0.03843188f, 0.02782676f, 0.02151334f, 0.05383116f, -0.02777858f, 
    -0.05680731f, 0.04961034f, -0.01429589f, -0.07428991f, -0.05850032f, -0.02082359f, -0.00649016f, 0.03429420f, 
    0.02282634f, 0.03435396f, 0.05771660f, -0.05790102f, -0.01402247f, -0.03552685f, -0.01088150f, 0.01464845f, 
    -0.05210361f, -0.02683722f, -0.06369886f, 0.05303926f, -0.06255919f, -0.04632947f, 0.00034617f, -0.05827021f, 
    0.00887704f, 0.05251187f, 0.00292787f, -0.04178632f, 0.01475065f, -0.04339091f, -0.06330341f, -0.00904911f, 
    -0.04183343f, 0.06577369f, 0.01502572f, 0.05510818f, -0.03010132f, -0.04518997f, -0.00610077f, -0.04487853f, 
    -0.02301053f, -0.01434110f, -0.06268506f, 0.00015544f, 0.07231255f, 0.04374145f, 0.03825375f, 0.01318983f, 
    -0.07842632f, 0.05004964f, -0.00335813f, 0.05192302f, 0.06553895f, -0.03055274f, -0.05829853f, 0.01447146f, 
    -0.06110226f, 0.05693188f, -0.01070230f, 0.03527531f, -0.07702124f, 0.05000672f, -0.01547775f, -0.04292896f, 
    0.01137414f, -0.00940683f, -0.07227851f, -0.05715844f, -0.05005820f, 0.04008153f, 0.02385656f, -0.07421727f, 
    -0.02726056f, -0.03158480f, -0.07058454f, 0.04002692f, -0.06826551f, -0.00030984f, -0.06441916f, -0.02352640f, 
    -0.14011547f, 0.47159126f, 0.55976349f, -0.03950976f, 0.05536778f, 0.01696087f, -0.07775321f, -0.13579713f, 
    0.17252269f, -0.02183303f, 0.29283425f, -0.02576917f, -0.04127387f, 0.16709247f, 0.14420561f, -0.08087371f, 
    0.12207454f, -0.04296566f, -0.02231024f, -0.09760156f, -0.19320135f, 0.05284828f, -0.07129060f, 0.10213358f, 
    -0.42045921f, -0.04742195f, -0.31477502f, 0.02229474f, -0.03909951f, -0.00785525f, 0.14809357f, -0.02155794f, 
    -0.14412150f, -0.10781055f, -0.21442072f, -0.08444605f, -0.06660557f, -0.01618163f, 0.20421995f, 0.02655905f, 
    -0.07490695f, 0.01728942f, -0.13664880f, -0.02255891f, 0.05735252f, 0.19689934f, 0.00652716f, -0.03459371f, 
    -0.57399428f, 0.45800960f, -0.18603268f, 0.21160525f, 0.17224842f, 0.02006358f, -0.15476868f, -0.04587377f, 
    -0.10665061f, -0.13030368f, -0.10936535f, -0.02750387f, -0.24308078f, 0.16896310f, 0.37448889f, 0.16426422f, 
    -0.07929417f, 0.03489408f, -0.06389176f, -0.14011236f, -0.02666462f, 0.00476803f, 0.13687468f, 0.03701199f, 
    -0.12662658f, 0.34136492f, -0.13111795f, -0.15156122f, -0.15748827f, 0.12754732f, 0.01537863f, 0.07642500f, 
    -0.19542199f, -0.11984242f, -0.18468688f, -0.15246400f, 0.37268871f, -0.00133040f, 0.42973486f, -0.04471814f, 
    -0.13816778f, -0.13403420f, -0.19744031f, -0.00513827f, 0.03408304f, 0.09799678f, 0.02969591f, 0.23882605f, 
    -0.08415089f, 0.17215613f, -0.01476534f, 0.23898494f, 0.09827002f, -0.01766085f, -0.00105101f, -0.00368479f, 
    0.21964736f, 0.05040255f, 0.07793245f, 0.19753304f, -0.21967790f, 0.15770482f, 0.08651777f, -0.04314450f, 
    0.08889653f, 0.07337721f, 0.18622178f, 0.05112734f, 0.14067270f, -0.02382397f, -0.02732744f, 0.17818023f, 
    0.25786164f, 0.30160829f, 0.24600445f, 0.32575047f, 0.08525059f, -0.00857218f, 0.06548692f, 0.33005056f, 
    -0.03001688f, 0.04429600f, -0.07316342f, -0.06857471f, 0.26381582f, 0.19153796f, -0.04485416f, -0.12162381f, 
    -0.22055580f, -0.11137107f, -0.25223139f, -0.11535447f, 0.07115655f, -0.10305250f, -0.15495580f, -0.20200385f, 
    0.10898489f, -0.06134930f, 0.16362029f, -0.18109827f, -0.00651718f, 0.00313130f, -0.00807940f, 0.01225952f, 
    -0.03628287f, -0.04942457f, -0.09522568f, -0.02979849f, -0.01529384f, 0.25200915f, -0.05731494f, 0.13429645f, 
    -0.09936402f, 0.09445499f, 0.04085841f, -0.09496492f, 0.00846392f, 0.00419723f, 0.04716622f, 0.08281711f, 
    -0.09137130f, -0.09029570f, -0.22713675f, 0.05121161f, 0.03424555f, 0.05287252f, -0.02262492f, -0.03999818f, 
    -0.08523212f, 0.04841033f, 0.01693505f, 0.13543420f, 0.02692215f, 0.07279678f, -0.14097786f, -0.11949915f, 
    0.11141580f, 0.00669964f, 0.08167253f, -0.00712908f, 0.02875787f, 0.01975533f, 0.09738937f, -0.08940224f, 
    -0.05374207f, 0.05590161f, 0.04357210f, 0.01908567f, 0.05013640f, -0.00126189f, -0.02882449f, -0.02856263f, 
    0.00411757f, 0.02675791f, 0.05377343f, 0.01406157f, -0.07700853f, -0.06788696f, -0.01782357f, -0.05705909f, 
    0.02016785f, -0.00709121f, -0.06972665f, 0.00415454f, 0.01723173f, -0.07118078f, 0.01525499f, -0.07245726f, 
    -0.07186390f, 0.03366041f, -0.00440151f, 0.02614513f, 0.05006172f, -0.07578243f, 0.04752502f, -0.03131256f, 
    0.03420838f, 0.03755599f, -0.02638572f, -0.04832754f, 0.04419088f, -0.06319086f, -0.02724382f, -0.02551194f, 
    -0.04418622f, -0.07404371f, 0.03262739f, -0.06607584f, -0.00005789f, -0.03200677f, 0.05042704f, -0.07215108f, 
    0.07557279f, -0.04192585f, -0.05225988f, -0.05178848f, -0.01321076f, -0.02073305f, -0.00546217f, 0.03774800f, 
    -0.02527780f, 0.00560524f, -0.06337774f, 0.02519782f, -0.02507370f, 0.04945245f, -0.03783521f, 0.00931839f, 
    0.00210996f, -0.06268504f, -0.06819574f, -0.08227751f, -0.06611122f, -0.04843769f, 0.05266956f, 0.01596366f, 
    -0.01279054f, 0.06621896f, 0.03620357f, 0.03217394f, -0.04353048f, -0.07221489f, -0.02308120f, 0.00656756f, 
    -0.02081540f, 0.05872121f, -0.04291593f, -0.07135408f, 0.04626495f, -0.03992685f, 0.06217186f, -0.04379734f, 
    0.01958292f, -0.05524061f, -0.07645394f, -0.03663865f, 0.00660706f, 0.04975459f, 0.04896815f, 0.02197315f, 
    -0.00058451f, -0.00577594f, 0.01165253f, -0.07042528f, -0.05979534f, -0.02690251f, 0.01152477f, 0.00873339f, 
    0.01663379f, -0.03340853f, -0.00682044f, -0.07973400f, -0.04728517f, -0.06074263f, 0.01710590f, 0.00692454f, 
    0.04177148f, 0.00340298f, -0.06127322f, -0.07739093f, 0.00833336f, -0.01944539f, 0.03142217f, -0.01593336f, 
    -0.02492492f, 0.02651978f, -0.02473250f, 0.00652279f, -0.01595169f, 0.04946480f, 0.01227354f, -0.03342374f, 
    0.04498212f, 0.02223011f, -0.05953248f, 0.02362132f, -0.04014701f, -0.07521652f, -0.03248762f, 0.03051508f, 
    0.03013843f, 0.05754917f, -0.02262734f, 0.03746236f, -0.05247704f, -0.05787744f, -0.04571487f, -0.06786404f, 
    0.00365792f, 0.01151117f, -0.01856212f, -0.05954034f, -0.01950782f, 0.05378998f, 0.02388092f, -0.02984085f, 
    0.03584433f, -0.04374221f, 0.04741232f, -0.07130687f, -0.03710539f, -0.07010329f, -0.03511823f, 0.06006169f, 
    -0.01192039f, -0.00713472f, 0.03392121f, 0.05111668f, -0.02430117f, -0.06151723f, 0.02559107f, -0.00680092f, 
    -0.06384848f, 0.04796471f, -0.01856537f, -0.00762312f, -0.03170992f, 0.03477342f, 0.01666619f, 0.06137212f, 
    -0.00620263f, -0.06734648f, -0.05685305f, 0.05867099f, -0.01307384f, 0.02988642f, 0.03845701f, 0.00767882f, 
    0.02896637f, 0.03224462f, 0.05248210f, -0.03294638f, 0.04751111f, 0.04513013f, -0.05193444f, -0.06026088f, 
    0.48068416f, -0.01559917f, -0.25690961f, -0.07264819f, 0.20556347f, -0.22971399f, 0.29162511f, 0.00967049f, 
    0.03616907f, 0.07303238f, -0.04852790f, -0.07139964f, 0.54678428f, -0.01613919f, 0.07203300f, 0.07731438f, 
    -0.32574686f, 0.00592348f, 0.10713827f, 0.04855413f, -0.00841040f, -0.03321675f, 0.04330153f, 0.02028152f, 
    -0.18828890f, -0.46984312f, -0.22045170f, -0.15874943f, -0.09223643f, 0.05202993f, 0.03545517f, -0.06830299f, 
    0.00024090f, 0.28893661f, 0.07925258f, -0.06774338f, -0.10941466f, -0.29894453f, -0.39686462f, -0.34170288f, 
    -0.09933371f, 0.03782275f, 0.11588528f, -0.14885992f, -0.11813734f, -0.07389144f, 0.03838330f, 0.00294190f, 
    0.10416462f, 0.02875176f, 0.03295079f, -0.07411914f, -0.12969421f, 0.01937996f, 0.01916025f, -0.05218999f, 
    0.15553473f, -0.06955539f, 0.05106210f, 0.15533213f, 0.11292163f, 0.14768516f, -0.03114214f, 0.20206545f, 
    -0.08483391f, -0.07502148f, 0.19240512f, -0.10799030f, -0.06793732f, 0.20613846f, -0.20362182f, -0.10517137f, 
    -0.36949033f, -0.30382878f, 0.32823640f, 0.26059330f, 0.00142736f, 0.15792055f, -0.08342810f, -0.25770316f, 
    0.08522059f, 0.05677909f, 0.10944884f, 0.11136726f, 0.20317125f, 0.26524639f, 0.17771506f, -0.00370064f, 
    -0.01053250f, -0.03319759f, 0.00809000f, 0.03578441f, -0.05868059f, 0.16492982f, 0.01165065f, -0.17913054f, 
    0.17893583f, 0.02739192f, 0.14995314f, 0.06018723f, 0.13498032f, -0.02908083f, 0.04284089f, 0.08709349f, 
    0.02053939f, -0.02858217f, -0.02574802f, 0.17485224f, -0.01562821f, -0.09252573f, -0.13734202f, 0.01333189f, 
    -0.09267313f, -0.22005685f, -0.20505515f, 0.15743221f, -0.02902981f, -0.07763616f, 0.00455727f, -0.15308532f, 
    -0.26976585f, -0.27311060f, -0.40145007f, -0.13403864f, -0.05163400f, 0.24099843f, 0.03643030f, -0.09834348f, 
    0.08524930f, 0.01088609f, 0.29485646f, -0.01001169f, 0.30341312f, 0.03975234f, 0.08132521f, 0.31634161f, 
    0.10244215f, 0.09394222f, 0.09429470f, -0.10188928f, -0.04416842f, 0.01841884f, -0.09348248f, 0.01806208f, 
    0.06855524f, 0.07040270f, 0.22912931f, -0.29674974f, 0.01544208f, -0.05962301f, 0.01595921f, 0.13160874f, 
    0.02314560f, 0.25092456f, 0.13163756f, 0.20681478f, 0.19915849f, 0.14300837f, 0.19942236f, 0.07413562f, 
    -0.05791026f, -0.00910182f, 0.03266747f, 0.04635945f, 0.18843536f, 0.30747217f, 0.28337026f, 0.00427209f, 
    0.18815880f, 0.01453688f, 0.00607912f, -0.04703879f, -0.09716748f, -0.15953684f, -0.17622368f, -0.15761922f, 
    -0.09053973f, -0.03604983f, -0.06146172f, 0.04072923f, -0.21924733f, -0.16502552f, 0.12104221f, 0.01021451f, 
    -0.07692704f, -0.02068145f, -0.10288616f, 0.01363801f, 0.08808072f, 0.14820170f, 0.06664947f, 0.16571814f, 
    0.09184581f, 0.34258524f, -0.22507745f, -0.08520065f, -0.08150590f, 0.17731658f, 0.14901865f, -0.28462079f, 
    0.24538006f, 0.26906237f, 0.14509252f, 0.03433368f, 0.08810093f, 0.56661373f, 0.17738727f, -0.32358938f, 
    -0.06969452f, -0.11636728f, 0.15019485f, 0.04986033f, -0.04424195f, -0.05821570f, 0.00518658f, -0.01112484f, 
    0.09874307f, 0.02320495f, -0.45387417f, -0.08058149f, 0.00402544f, 0.01522247f, 0.12668926f, 0.10007986f, 
    -0.03869261f, -0.00519842f, -0.13733700f, -0.11610139f, 0.25511700f, -0.11052939f, -0.04021057f, 0.15926638f, 
    0.11481186f, -0.00971213f, 0.07920682f, 0.06004273f, -0.02936733f, 0.05662631f, 0.01567664f, 0.12008034f, 
    0.14741713f, 0.45206612f, 0.02858680f, -0.13480520f, 0.03213144f, 0.08157811f, -0.24880427f, 0.20029593f, 
    0.10600726f, -0.18819739f, -0.07257856f, -0.14633517f, -0.32928446f, 0.27260780f, 0.11787374f, -0.14671296f, 
    -0.15392093f, -0.09723853f, -0.20824897f, 0.08191972f, -0.01729356f, -0.03357099f, 0.03804116f, 0.19688730f, 
    0.17716826f, 0.15254028f, -0.06027414f, -0.14487070f, -0.13280149f, -0.23053920f, -0.13299350f, 0.10746600f, 
    -0.06799898f, -0.06818946f, -0.16162412f, -0.02052916f, -0.07108444f, 0.17040657f, 0.12720561f, 0.30936259f, 
    -0.02987075f, -0.17755513f, 0.05932983f, -0.06686204f, 0.05629504f, 0.05267443f, -0.11272664f, 0.01792607f, 
    -0.02893256f, 0.32983950f, -0.16909654f, -0.03886305f, -0.05180722f, -0.11910225f, 0.10227331f, -0.01729190f, 
    0.18916382f, 0.08733507f, -0.07253417f, 0.00021325f, -0.16705686f, -0.10937887f, -0.21448611f, -0.00146915f, 
    -0.03571467f, 0.22292851f, 0.31746638f, -0.36235762f, -0.06184524f, 0.06374066f, 0.01964404f, -0.02895882f, 
    0.05253583f, 0.15577756f, -0.19078876f, 0.27896506f, 0.11147586f, 0.16530553f, -0.14358991f, 0.06736194f, 
    -0.10294580f, 0.07419530f, 0.03670477f, -0.01116470f, 0.03780088f, 0.06498487f, 0.24949628f, -0.07323231f, 
    -0.05412139f, -0.20929575f, -0.11409359f, -0.08745427f, 0.00896139f, 0.04323264f, 0.12619154f, -0.04518213f, 
    -0.14809848f, 0.09473462f, 0.00973770f, 0.26862279f, -0.12826765f, -0.15951250f, 0.08506349f, 0.01513053f, 
    0.04717082f, 0.07765125f, -0.06372458f, 0.02970657f, -0.12280151f, 0.40928468f, 0.45736155f, -0.38156161f, 
    0.01370655f, -0.06051125f, -0.02271158f, -0.09643430f, 0.15510175f, 0.27675804f, -0.06834286f, 0.07647698f, 
    -0.22426178f, -0.28236538f, -0.16243139f, 0.06293134f, 0.03516686f, 0.01239293f, -0.04053602f, -0.01809658f, 
    -0.00139361f, -0.05190644f, 0.00405551f, -0.00232292f, 0.31439897f, 0.02813028f, 0.15973228f, -0.13662474f, 
    -0.20684920f, 0.09348447f, -0.00785844f, 0.25694585f, -0.01207981f, 0.07920598f, 0.05127164f, -0.00578617f, 
    -0.00220889f, 0.02016001f, -0.00857912f, -0.00397449f, -0.01254639f, -0.01469707f, 0.00497538f, -0.00520123f, 
    0.02666006f, -0.00209358f, 0.01939757f, -0.02308537f, -0.03810821f, 0.03299171f, 0.02406775f, -0.06684577f, 
    -0.05805371f, -0.03175697f, -0.06547643f, 0.03609293f, 0.01801706f, -0.04556713f, 0.03153818f, -0.00321799f, 
    -0.01580350f, -0.07593918f, 0.05336177f, -0.03156531f, -0.03040965f, -0.07528638f, -0.04133585f, -0.07308747f, 
    -0.03969017f, -0.06301229f, 0.02598586f, -0.02896414f, -0.05216411f, 0.02674583f, -0.03144432f, -0.02328485f, 
    -0.03326613f, 0.03043557f, -0.02688164f, -0.00502205f, -0.06025466f, 0.05723719f, 0.06290787f, 0.04631545f, 
    -0.07248524f, -0.01774898f, 0.03074620f, 0.02864213f, 0.00224377f, -0.06730229f, 0.02773956f, 0.01616453f, 
    -0.00241361f, 0.00555296f, -0.05621680f, -0.07092361f, -0.03750517f, -0.01386314f, 0.03277468f, -0.01434184f, 
    -0.00766962f, -0.03322107f, -0.07431386f, 0.01338794f, 0.00983416f, -0.01927271f, 0.01951178f, -0.04842614f, 
    -0.03279090f, 0.02447755f, 0.05397932f, 0.05920273f, -0.06711872f, 0.02557318f, 0.05419955f, -0.05470223f, 
    0.03810375f, -0.01608935f, -0.03384962f, 0.04075531f, -0.06891293f, 0.03644198f, -0.03974335f, -0.04313471f, 
    -0.05907745f, -0.08088773f, 0.00286084f, 0.02445971f, -0.06640662f, 0.02778698f, 0.02604826f, 0.00902816f, 
    -0.04080923f, 0.00681169f, -0.01626340f, -0.07027124f, -0.05770504f, 0.04656608f, -0.07519183f, -0.02431663f, 
    -0.08121898f, 0.04003558f, -0.06063882f, 0.05907889f, 0.06186870f, -0.03409069f, 0.03737500f, -0.08342382f, 
    -0.00697352f, -0.03273390f, 0.02584048f, -0.01748513f, 0.00518306f, 0.03795211f, -0.01789086f, -0.05770600f, 
    0.02142439f, 0.00645656f, -0.04224829f, 0.04975332f, 0.01778671f, -0.06081380f, -0.05072587f, 0.00462739f, 
    -0.05319712f, 0.00874097f, -0.00126978f, -0.00547269f, 0.04845465f, -0.05277553f, -0.01137298f, 0.01147120f, 
    -0.07816431f, 0.00473128f, 0.04813653f, -0.05071575f, 0.01166717f, -0.04637931f, 0.01902395f, 0.04237104f, 
    -0.00477268f, -0.00769386f, -0.01180293f, -0.03412544f, -0.03183619f, -0.02038746f, -0.02042490f, -0.05266961f, 
    -0.06430703f, 0.02389259f, -0.04654384f, -0.07477549f, 0.06214235f, -0.03976145f, -0.03991431f, -0.03908389f, 
    0.02130428f, -0.05839239f, -0.02932183f, -0.06349321f, 0.03289605f, -0.01779441f, 0.03749480f, 0.03216634f, 
    -0.05265457f, 0.05787190f, 0.02001072f, 0.00405969f, 0.01496091f, 0.01975362f, -0.01843360f, -0.01099344f, 
    -0.01267257f, -0.01119957f, -0.04086895f, -0.03935149f, 0.04167622f, -0.07634165f, 0.01908944f, -0.04815735f, 
    -0.06332586f, 0.05944568f, -0.03144794f, -0.00568167f, 0.02201866f, 0.05549734f, -0.01492584f, -0.06872663f, 
    0.56919342f, 0.04219854f, 0.44017631f, -0.00060147f, 0.24166228f, -0.15984695f, -0.00326224f, 0.05946992f, 
    0.08592260f, -0.06462917f, 0.12514275f, 0.19948702f, -0.37454888f, -0.12544511f, -0.00702331f, 0.06116479f, 
    -0.02808910f, 0.17780404f, 0.07747438f, 0.09489113f, 0.06396376f, 0.01250921f, 0.03247025f, 0.03091097f, 
    -0.27272087f, -0.12058099f, -0.01411341f, -0.03685140f, 0.08898550f, 0.12648654f, 0.01107600f, 0.00957146f, 
    0.12534818f, -0.07441586f, -0.09532121f, -0.22360754f, 0.06977223f, 0.12478777f, 0.00898569f, -0.35570300f, 
    -0.04503851f, 0.17422201f, -0.13166776f, -0.06623431f, 0.06636736f, -0.03726632f, 0.09021908f, -0.13926479f, 
    -0.03464128f, 0.02338406f, -0.35639828f, 0.15040089f, 0.12187308f, -0.02987894f, -0.15387067f, -0.07396232f, 
    0.06370065f, -0.12091146f, 0.30435801f, 0.12884912f, -0.08126474f, 0.14093953f, 0.07016464f, 0.29548973f, 
    -0.01883740f, -0.10194948f, 0.07138616f, 0.01431912f, -0.11796780f, 0.12281674f, -0.02025493f, 0.06531762f, 
    -0.29075113f, -0.13816278f, -0.18494993f, -0.23866867f, -0.00858810f, 0.12180540f, 0.11328597f, 0.18538110f, 
    -0.14293250f, -0.01528957f, -0.12177534f, 0.05757890f, 0.00647399f, 0.17984337f, 0.20682870f, 0.19367898f, 
    -0.15544063f, -0.12144025f, -0.02954369f, -0.01864030f, 0.02209886f, 0.11016522f, 0.00819096f, 0.19478808f, 
    -0.00675828f, 0.10565491f, 0.08901046f, 0.12990713f, 0.13254763f, 0.06143592f, 0.07133917f, -0.08474661f, 
    0.24756579f, -0.11344755f, 0.22684644f, 0.33716288f, -0.03499237f, 0.09232856f, -0.09966418f, -0.06564531f, 
    0.14062743f, -0.16500179f, -0.21716434f, 0.27832130f, -0.01692630f, 0.07301743f, 0.00212969f, 0.01362978f, 
    -0.03227827f, 0.14083381f, 0.12057892f, 0.05178339f, 0.06953398f, 0.08279311f, 0.04719320f, 0.28096822f, 
    0.17398217f, 0.08402494f, -0.05328801f, -0.12097592f, 0.29581273f, -0.10198732f, 0.07011835f, -0.04792564f, 
    -0.09542675f, 0.07965350f, 0.04119298f, -0.07510025f, -0.07241900f, -0.13015482f, -0.19479336f, -0.11037276f, 
    0.35013729f, 0.00565228f, 0.24343733f, -0.31261927f, 0.06064281f, -0.04399710f, 0.07725595f, 0.29622641f, 
    -0.11423741f, 0.10082140f, -0.04390333f, -0.29275566f, 0.39787945f, 0.03639230f, -0.13445792f, 0.24831851f, 
    -0.20623361f, -0.02672215f, -0.02497869f, -0.04238285f, -0.05778028f, 0.01527296f, 0.20051400f, 0.01786035f, 
    0.09822626f, 0.12272765f, -0.14136164f, -0.22511947f, -0.02830573f, -0.14670968f, 0.13356169f, -0.06029892f, 
    -0.06776942f, 0.04231487f, -0.01388758f, 0.08996966f, -0.43908638f, 0.07377775f, -0.26153305f, -0.25136390f, 
    -0.00886989f, -0.00071879f, -0.10557666f, -0.04315782f, 0.17237687f, 0.17001052f, 0.13427596f, 0.13191603f, 
    0.19933584f, -0.33835116f, -0.34427479f, 0.16305642f, 0.14435981f, -0.08360093f, -0.17762785f, 0.16142316f, 
    0.19708762f, -0.16447350f, -0.06354611f, 0.40669742f, 0.08191221f, -0.16439757f, -0.22107682f, 0.22747563f, 
    -0.01362936f, -0.10898575f, -0.14131807f, 0.05317813f, 0.00227439f, -0.01791924f, 0.01991263f, 0.10745230f, 
    0.42477632f, 0.05305992f, 0.67568690f, -0.03114472f, -0.00387272f, -0.05169898f, 0.04270161f, -0.00729758f, 
    0.14905721f, 0.02604597f, -0.02250646f, 0.12973493f, -0.07498888f, 0.11613861f, -0.09615441f, -0.22791012f, 
    0.03954584f, -0.03553380f, -0.00354524f, 0.10312299f, -0.08744134f, -0.19800888f, -0.02700528f, 0.07472365f, 
    0.28671211f, -0.43628278f, 0.04562262f, -0.14273824f, -0.17746170f, -0.24790892f, 0.00876094f, 0.02551992f, 
    0.18216561f, 0.24667208f, -0.04801948f, -0.01303915f, 0.38695601f, 0.05261214f, -0.44574252f, 0.22823060f, 
    0.02897039f, -0.09651766f, 0.07435940f, -0.01656598f, 0.01068731f, 0.01749578f, -0.08014205f, 0.02179736f, 
    -0.01863222f, -0.15859412f, 0.05855162f, 0.06467854f, 0.01816323f, -0.00857229f, 0.15538543f, 0.12620224f, 
    0.03463938f, -0.17104077f, 0.11723090f, -0.21590154f, -0.19922543f, 0.25743279f, -0.22408982f, 0.19687653f, 
    -0.05852253f, 0.08708123f, -0.01931656f, -0.04972499f, 0.14212692f, -0.00985112f, 0.02126224f, -0.02223216f, 
    0.34347194f, -0.26637048f, 0.19703951f, -0.02120544f, -0.09364424f, -0.04638198f, -0.17434300f, 0.06442422f, 
    -0.01705434f, 0.04637463f, 0.14013623f, 0.18115763f, 0.04848646f, -0.14871725f, -0.04316246f, 0.06981209f, 
    0.14644088f, 0.01110728f, -0.22035290f, 0.22355872f, 0.16773741f, 0.09437378f, 0.15123565f, 0.11935738f, 
    -0.16936719f, -0.06475963f, -0.18004638f, 0.01722509f, -0.08157111f, -0.17452247f, 0.15160106f, 0.01498619f, 
    0.08652164f, 0.00364538f, -0.16794720f, -0.07356392f, -0.20212257f, -0.13385709f, 0.04161236f, 0.18104750f, 
    0.17850395f, 0.06458829f, 0.04274294f, -0.06638796f, 0.02200439f, -0.07573775f, -0.13507040f, 0.11823396f, 
    -0.10268000f, 0.19868602f, -0.20196421f, -0.01567846f, 0.04331327f, -0.01997579f, 0.13830793f, 0.04909351f, 
    0.08731962f, 0.00691648f, -0.02885487f, -0.06069744f, 0.36376229f, 0.06446470f, -0.10484947f, -0.05515176f, 
    0.04152293f, -0.05854576f, -0.09909389f, -0.10719054f, 0.13830422f, -0.25397271f, -0.03501212f, 0.01207074f, 
    0.24598579f, 0.24300343f, 0.29639035f, -0.08426515f, 0.14442593f, 0.09033069f, 0.10913637f, 0.13448453f, 
    -0.03922122f, 0.03295887f, -0.05508212f, 0.14104247f, -0.10350800f, 0.11578675f, -0.22775598f, -0.02136750f, 
    -0.06407712f, 0.02845942f, -0.12714857f, 0.12595432f, 0.33468366f, -0.06029541f, 0.06243457f, 0.16172786f, 
    -0.05729732f, -0.38849914f, 0.69188112f, -0.05774045f, 0.16015913f, 0.06845450f, -0.08457505f, -0.21412143f, 
    -0.05780765f, -0.16538136f, 0.09571149f, -0.19479254f, 0.46391368f, -0.04421978f, 0.47550884f, 0.01006193f, 
    0.12285382f, -0.18173805f, -0.00433751f, -0.06086196f, -0.16926515f, 0.05943182f, -0.05972370f, -0.01597778f, 
    0.22091317f, 0.05177952f, 0.04672781f, 0.15462302f, -0.01954701f, 0.02354063f, -0.03383162f, -0.05388476f, 
    -0.07318857f, -0.00637817f, 0.03960746f, -0.02831165f, 0.03097544f, 0.02758439f, -0.38392377f, -0.11844499f, 
    0.04588887f, -0.00885476f, 0.03303056f, 0.18652712f, 0.03794887f, 0.07847986f, -0.03717876f, -0.09028938f, 
    0.23863868f, -0.12712856f, -0.29138950f, -0.07410495f, 0.02816026f, -0.06350752f, -0.13513863f, -0.17129907f, 
    -0.05093853f, -0.01497073f, 0.08092113f, 0.09267569f, 0.08833009f, 0.29819390f, 0.18410754f, 0.35987878f, 
    -0.02562095f, -0.10107189f, -0.01443373f, -0.10450295f, 0.05109029f, -0.04900787f, 0.00662636f, -0.06955247f, 
    0.26793048f, 0.39309007f, 0.18776402f, 0.32455906f, -0.08606403f, -0.01541918f, 0.13352440f, 0.16483869f, 
    0.01602223f, 0.01986326f, 0.00754271f, -0.02376226f, -0.00665153f, 0.31849530f, 0.02685836f, 0.18627843f, 
    0.05677314f, 0.01390050f, -0.04329564f, 0.00925801f, -0.02476557f, 0.08564398f, 0.08215388f, 0.05779095f, 
    0.28790599f, -0.21457130f, 0.02805080f, -0.13223882f, 0.02540963f, 0.01261887f, -0.11897942f, -0.12560353f, 
    -0.04257443f, 0.02390165f, -0.03233338f, 0.02215935f, -0.03424158f, 0.20058106f, 0.34305781f, 0.14634761f, 
    0.33863580f, 0.05889861f, 0.18979694f, 0.17144816f, 0.01571373f, 0.08577166f, -0.02889670f, 0.00743482f, 
    -0.15592793f, 0.01669095f, 0.28695387f, 0.00662835f, 0.07465349f, 0.02329101f, 0.00120338f, 0.31012312f, 
    0.11969788f, -0.02430316f, -0.11707274f, 0.12758368f, 0.46816447f, 0.38024911f, 0.11056023f, -0.03146772f, 
    -0.08461780f, -0.03541286f, -0.10535385f, -0.04304506f, 0.08816010f, 0.13384484f, 0.11938178f, 0.00558568f, 
    -0.13498381f, -0.36085871f, 0.07085520f, -0.03018796f, -0.07513753f, 0.10339002f, 0.09120316f, 0.04886074f, 
    -0.01802210f, -0.07749625f, 0.02254994f, -0.15395020f, 0.12498849f, -0.03753563f, 0.09015419f, 0.15845661f, 
    0.00589470f, 0.00475044f, -0.05849114f, 0.01909232f, 0.00558833f, -0.20201033f, 0.05189288f, 0.03696989f, 
    0.64994675f, 0.65291691f, 0.92457795f, 0.11173211f, 0.14518359f, 0.15961024f, 0.17580777f, 0.33353472f, 
    0.05298980f, 0.12116144f, 0.04347262f, -0.06266983f, 0.27075812f, -0.26396063f, -0.93250430f, -0.43019029f, 
    -0.04517800f, 0.05262180f, -0.12044663f, 0.08598054f, 0.03085419f, 0.00655106f, -0.03128449f, -0.05095110f, 
    0.02229148f, 0.06547444f, -0.06973297f, -0.02424983f, -0.06171182f, 0.02142812f, 0.03894377f, 0.04183675f, 
    0.04151756f, 0.04149967f, -0.02202303f, -0.07316178f, 0.05147481f, -0.02812496f, 0.04526301f, -0.05767021f, 
    0.03518897f, -0.05457519f, -0.03205311f, -0.02426570f, -0.03579047f, -0.06227829f, -0.04324827f, 0.00248865f, 
    0.02964347f, -0.08496942f, 0.02169995f, -0.06341514f, -0.05300496f, 0.02023779f, 0.02634586f, -0.07107369f, 
    0.03700469f, 0.02373401f, -0.01397461f, 0.03414563f, -0.04252707f, 0.01838233f, 0.00379846f, 0.01122270f, 
    -0.04209468f, -0.02892139f, -0.03847022f, 0.03848545f, 0.03162333f, 0.05015456f, 0.01281433f, 0.00475099f, 
    0.03853226f, -0.05346982f, 0.01467145f, 0.00237565f, 0.04159410f, 0.00665360f, 0.03566157f, -0.06209676f, 
    -0.03024665f, -0.06542007f, 0.01866958f, 0.02980188f, 0.04786805f, -0.03824642f, -0.01039147f, -0.03997602f, 
    -0.02533512f, -0.04283122f, 0.05186856f, 0.04618512f, 0.02544276f, 0.04118725f, -0.04756485f, -0.01136399f, 
    0.04323308f, -0.06343349f, -0.07969369f, -0.04077329f, -0.07076566f, -0.05237069f, -0.03230111f, -0.07302387f, 
    -0.05272204f, -0.01748402f, -0.07328162f, -0.04380851f, 0.04919403f, 0.04193614f, -0.02588644f, -0.04498269f, 
    0.04428120f, 0.04990305f, 0.05332043f, 0.04199979f, 0.02435429f, -0.02187714f, 0.03958477f, 0.05556918f, 
    -0.05391185f, -0.03220756f, -0.06096345f, 0.01037720f, 0.02293955f, 0.04480328f, 0.04515962f, -0.04773081f, 
    0.03132348f, -0.05481107f, 0.04727194f, -0.00017565f, -0.07522760f, -0.05228507f, 0.01108584f, 0.02206132f, 
    0.01115081f, 0.01032567f, -0.02156909f, -0.02837447f, 0.03678088f, -0.04733226f, -0.01666985f, -0.06434867f, 
    -0.06647853f, 0.00996011f, -0.07189522f, -0.01522082f, -0.07039397f, 0.04734429f, -0.01225966f, -0.03699626f, 
    0.05525867f, -0.03414972f, -0.02060739f, 0.01497349f, -0.06323255f, -0.01442255f, 0.00282518f, -0.03700272f, 
    -0.05394984f, 0.01586585f, 0.03237061f, 0.03185962f, -0.07962830f, 0.01393466f, -0.02509440f, -0.03762582f, 
    0.01010342f, 0.06809656f, -0.06730797f, -0.03756718f, -0.00642765f, -0.08279211f, -0.07817526f, 0.04533269f, 
    -0.05723425f, -0.02122223f, 0.04340619f, -0.08411962f, -0.03504874f, 0.01767051f, 0.00345192f, -0.02206011f, 
    -0.00271022f, -0.07964265f, -0.06901525f, -0.05555232f, -0.06825580f, 0.05070484f, 0.03840702f, -0.03005978f, 
    -0.03380411f, -0.07230899f, 0.04422511f, 0.03564226f, -0.06972751f, -0.00693559f, -0.01300723f, -0.03161564f, 
    0.05391906f, -0.08038190f, 0.02910091f, 0.02266966f, -0.07687704f, 0.00918162f, 0.03515563f, 0.01930716f, 
    -0.05069233f, -0.04566296f, 0.00701844f, -0.06358884f, -0.04182738f, 0.04640628f, 0.03547302f, 0.02245572f, 
    0.52676892f, 0.02520051f, -0.23427373f, 0.19540492f, 0.04119748f, -0.04400730f, 0.10086215f, 0.28336146f, 
    0.13703473f, 0.08318623f, 0.02957392f, 0.16233076f, 0.06736766f, 0.02811239f, -0.22517689f, 0.06821945f, 
    -0.12606262f, 0.00317912f, 0.08646578f, 0.11715578f, 0.09049174f, 0.03732805f, 0.08468873f, 0.05109358f, 
    -0.18503709f, -0.11301834f, -0.43568802f, -0.07531019f, -0.03164344f, 0.05277718f, 0.04565955f, 0.12602493f, 
    0.16810744f, 0.20141874f, 0.04860739f, -0.06539007f, 0.38118023f, -0.25068459f, 0.04170775f, 0.18297903f, 
    -0.09042638f, 0.08004744f, 0.04089077f, -0.22333230f, -0.02215349f, 0.02666515f, 0.08696889f, -0.00818599f, 
    -0.09666665f, -0.01292176f, -0.10571401f, -0.22442500f, -0.00745952f, -0.04047565f, 0.15896930f, 0.05907825f, 
    -0.04626824f, 0.04253789f, 0.10355005f, 0.07754756f, -0.01649274f, 0.06136920f, 0.20011178f, 0.07191411f, 
    -0.14067777f, -0.02333990f, 0.13930549f, 0.01412700f, -0.11808198f, 0.13463752f, 0.10258153f, 0.13603370f, 
    -0.14788656f, 0.04707599f, -0.09621165f, 0.00869827f, 0.00315507f, -0.04321691f, -0.21279190f, -0.18324280f, 
    0.00289721f, -0.07724822f, -0.16017587f, 0.12004949f, 0.20575231f, -0.07873452f, 0.31709015f, -0.09240402f, 
    -0.16825536f, -0.10735599f, -0.06323047f, 0.09434976f, -0.11199224f, 0.04762000f, 0.01321634f, 0.03377388f, 
    -0.13323563f, 0.26590273f, 0.04753496f, 0.21360011f, 0.11051022f, 0.02461525f, -0.02573171f, -0.00328844f, 
    0.29997814f, -0.04397180f, 0.04099699f, 0.03131256f, -0.04442595f, 0.05547304f, -0.00425526f, 0.06612682f, 
    -0.02122229f, 0.04186386f, -0.08573546f, 0.11692171f, -0.14116637f, -0.07356117f, -0.00643153f, -0.06673846f, 
    0.20836358f, -0.15473312f, 0.14428826f, -0.28690752f, -0.02375018f, 0.03982836f, 0.09776848f, -0.00014890f, 
    -0.07451718f, 0.04107413f, 0.07782734f, -0.10108463f, 0.13195652f, 0.24014163f, -0.06925962f, 0.32599115f, 
    0.04112041f, -0.12490310f, 0.01372301f, -0.00834140f, -0.16712373f, -0.07561291f, -0.02178564f, 0.00767266f, 
    0.26995531f, -0.04297535f, 0.00551243f, -0.17964959f, -0.05073974f, -0.01854380f, -0.12012135f, 0.06336313f, 
    -0.06795176f, 0.18853261f, -0.10912556f, -0.18753095f, -0.02748779f, 0.24670534f, -0.00050104f, 0.21947388f, 
    -0.04683072f, -0.08269745f, 0.12399066f, -0.04853986f, -0.01061136f, 0.27481294f, -0.02501692f, -0.01545997f, 
    -0.23451841f, -0.02879187f, -0.29464537f, 0.21292965f, -0.15471959f, -0.11766191f, -0.08874086f, -0.19450523f, 
    -0.12442429f, -0.14194708f, -0.05494201f, 0.02802776f, -0.29023749f, -0.17883372f, 0.63214886f, -0.29325286f, 
    -0.06888463f, -0.02810941f, 0.17529593f, 0.13115802f, 0.06915990f, 0.21588747f, -0.06740407f, 0.02212887f, 
    0.44675404f, 0.01984256f, -0.33869117f, -0.22432402f, -0.00339640f, 0.02746308f, 0.04428322f, 0.11926798f, 
    0.09440933f, 0.20166779f, -0.13557650f, 0.09165419f, -0.43551630f, -0.28514263f, -0.21613048f, 0.11148383f, 
    0.23648718f, 0.15135829f, -0.03689773f, 0.19209342f, 0.05603881f, -0.08626388f, 0.12721631f, -0.02045564f, 
    0.35490665f, -0.28180516f, 0.29701674f, -0.05500801f, -0.02873563f, -0.14195579f, 0.00773239f, 0.04920954f, 
    0.13555534f, 0.06766727f, 0.12802930f, -0.05936144f, -0.04691458f, 0.20903264f, 0.30504358f, -0.16526656f, 
    -0.14188763f, -0.05779654f, 0.05095953f, 0.00200144f, -0.06353726f, -0.08813787f, -0.01046341f, 0.11433998f, 
    0.46630579f, -0.63458014f, 0.14954005f, 0.31837249f, -0.06285907f, -0.08956147f, -0.00327821f, -0.01521256f, 
    0.15813030f, 0.07584485f, 0.13519453f, 0.06406863f, 0.18697791f, 0.05711572f, -0.05837663f, -0.22842510f, 
    0.04995428f, -0.09458537f, 0.03699028f, 0.20759091f, 0.01294455f, -0.01683544f, 0.04060394f, 0.03460995f, 
    0.05360737f, -0.02205385f, -0.15162610f, -0.40205717f, 0.10448144f, -0.04875064f, -0.02176990f, 0.07069381f, 
    0.01434920f, 0.02451154f, 0.07100820f, -0.09991009f, 0.01310986f, -0.00306512f, -0.00764238f, 0.01642500f, 
    0.08397877f, -0.00292306f, 0.05978737f, 0.05979697f, 0.07561576f, -0.02876118f, 0.09238903f, -0.06948277f, 
    0.29997316f, -0.26950657f, 0.11284406f, 0.17426740f, 0.11513656f, 0.01979475f, 0.08972090f, -0.04294186f, 
    -0.05611848f, 0.06792300f, 0.00595834f, 0.18409511f, 0.22379975f, -0.21464537f, -0.17046613f, 0.04592045f, 
    -0.03520430f, -0.00406726f, 0.05131653f, 0.06957488f, -0.07291333f, 0.02137217f, 0.01801356f, -0.03392230f, 
    -0.25512922f, -0.12852590f, -0.14980020f, -0.08506556f, -0.01950050f, 0.11356562f, 0.08890869f, -0.31954288f, 
    -0.03278688f, -0.10655440f, 0.03209043f, -0.10366251f, -0.10770326f, 0.15947127f, 0.05066408f, -0.13325928f, 
    0.08845545f, -0.03093236f, 0.03802653f, 0.10207065f, -0.07680395f, -0.07265835f, -0.01059226f, -0.01991155f, 
    0.06409438f, 0.14718902f, -0.32170665f, 0.11948729f, -0.02247133f, 0.05376942f, 0.09600764f, -0.15360838f, 
    0.11052484f, 0.13725623f, 0.17202652f, 0.11673964f, 0.20624763f, 0.05765796f, 0.15541528f, -0.15747850f, 
    0.02184943f, -0.01844242f, 0.05237817f, 0.06352489f, 0.08218749f, 0.04048153f, -0.03212981f, 0.13576087f, 
    0.01895846f, -0.10723092f, 0.31717515f, -0.12496486f, 0.13316520f, 0.05496238f, 0.12967032f, -0.22364716f, 
    -0.05851823f, -0.01803887f, -0.05576819f, -0.03990491f, -0.12277990f, 0.06743414f, 0.13886647f, 0.20239010f, 
    -0.10431212f, -0.00435408f, 0.06730874f, -0.12087471f, 0.07301161f, -0.08310860f, 0.20677613f, 0.05928260f, 
    0.23475990f, -0.24659677f, -0.12622774f, -0.22428377f, 0.00219154f, 0.26166892f, -0.11280727f, -0.16936328f, 
    0.00212336f, 0.16445376f, -0.10350116f, 0.16143064f, -0.56979966f, 0.02207124f, 0.17787598f, 0.06088246f, 
    0.22721763f, -0.13804892f, -0.22672273f, 0.16905528f, 0.04378844f, -0.03117194f, 0.01507104f, -0.13344817f, 
    0.12163299f, 0.13023041f, 0.20759799f, 0.34599596f, -0.01059375f, 0.03218457f, 0.08801979f, 0.01428723f, 
    -0.03648614f, 0.05654415f, 0.00921039f, 0.10620962f, 0.49553186f, 0.37187684f, 0.37126982f, 0.35474664f, 
    0.09041096f, 0.25850189f, 0.13978909f, 0.13755804f, 0.04601819f, -0.03026744f, -0.00912534f, 0.05400101f, 
    0.02375833f, -0.31488678f, 0.22561911f, 0.17582065f, 0.05440334f, 0.09155726f, 0.10414295f, -0.15665881f, 
    0.24977307f, 0.10150742f, 0.05953097f, 0.12735425f, -0.31224617f, -0.39357510f, -0.12937175f, -0.21956170f, 
    0.04936420f, -0.10647810f, -0.19423011f, -0.00893578f, 0.04505829f, -0.04105540f, 0.02671953f, 0.02856539f, 
    0.35174084f, 0.07300877f, -0.27473217f, -0.08100723f, -0.08657928f, -0.15082824f, 0.05327513f, 0.15046406f, 
    -0.14704821f, -0.00173308f, -0.00864700f, -0.05748612f, 0.00335094f, -0.41793194f, -0.30468416f, -0.03973271f, 
    -0.01276318f, 0.06017783f, -0.04782336f, 0.01920092f, 0.04080304f, -0.06715260f, -0.04309776f, -0.06241524f, 
    -0.01680747f, -0.30563173f, -0.13261433f, -0.05839886f, 0.05572686f, 0.12377301f, 0.03665288f, -0.09247224f, 
    0.02003108f, -0.08922759f, -0.32463115f, -0.13745187f, 0.46200138f, 0.28029951f, 0.27216217f, 0.21572959f, 
    0.07995819f, 0.24719836f, 0.22805175f, -0.00244889f, -0.10528844f, -0.08695900f, -0.03053153f, -0.03840490f, 
    -0.12957829f, 0.09557302f, 0.23042980f, 0.08943316f, 0.11176300f, 0.14372534f, -0.16919559f, -0.17265850f, 
    0.06337503f, 0.02021733f, 0.12066161f, -0.07521416f, -0.37487373f, -0.28028437f, -0.19880727f, -0.15928240f, 
    -0.00476762f, -0.16752008f, -0.13509727f, -0.01403633f, -0.06651203f, 0.05499856f, 0.18611306f, -0.10282364f, 
    0.08706940f, -0.14282820f, -0.01455890f, 0.30674121f, -0.02538234f, -0.06841788f, -0.03359767f, -0.07390159f, 
    -0.09154319f, 0.05681407f, 0.18765382f, 0.22414015f, -0.02535167f, -0.36078787f, 0.02567991f, -0.36969671f, 
    -0.07753302f, -0.04675092f, -0.04243830f, -0.01220952f, 0.01988434f, 0.18645585f, 0.16886337f, 0.14429732f, 
    0.47257280f, 0.27666730f, 0.59207094f, 0.30495363f, 0.13477637f, -0.10645574f, -0.01694685f, 0.02951123f, 
    0.00745081f, -0.04019434f, 0.03354409f, -0.01695366f, 0.12731721f, -0.14067556f, 0.10742897f, 0.04354994f, 
    0.10483769f, 0.17339368f, 0.20083503f, -0.02020116f, 0.17295402f, 0.01651868f, 0.09101278f, 0.11941580f, 
    0.54196280f, -0.18330604f, -0.01658318f, -0.02675961f, 0.05590998f, 0.16762112f, 0.01307022f, -0.21106869f, 
    0.13952945f, 0.35762191f, -0.18290465f, -0.08025593f, -0.07556287f, 0.26499838f, 0.49606284f, -0.23295812f, 
    0.13042927f, 0.01634739f, -0.10345420f, 0.08452009f, -0.07141141f, 0.00274472f, 0.18431564f, -0.06654709f, 
    0.05755109f, -0.00997449f, -0.30524924f, -0.10954765f, -0.01755890f, -0.01683671f, 0.12155848f, 0.10887570f, 
    0.10759974f, -0.06401864f, 0.05325283f, -0.16384265f, 0.16388266f, 0.17748830f, 0.20675594f, 0.06272028f, 
    -0.04437710f, 0.00124423f, 0.02959448f, 0.04016621f, -0.02642789f, 0.00194978f, -0.01042844f, 0.05522393f, 
    -0.02992403f, -0.09135684f, -0.19983447f, -0.15596782f, 0.02484136f, 0.09736754f, 0.01321962f, 0.09679904f, 
    -0.05104243f, -0.30961818f, -0.03183561f, -0.06557316f, -0.03314856f, 0.22808391f, 0.22429220f, -0.12886924f, 
    -0.06054289f, -0.02436017f, -0.12135669f, 0.05700416f, -0.01578753f, -0.12110280f, 0.11384106f, 0.11870436f, 
    0.00856657f, 0.43154687f, -0.05091690f, -0.06003540f, -0.01932882f, 0.02200134f, -0.00567933f, 0.03479793f, 
    0.00486899f, 0.00016256f, -0.12893102f, 0.10117055f, 0.23816720f, 0.07302551f, 0.34810111f, 0.08936140f, 
    -0.06334642f, -0.01452228f, 0.00856859f, 0.00042370f, 0.04832340f, 0.01502025f, 0.15310885f, 0.02474781f, 
    0.04029465f, 0.11964104f, 0.03427288f, 0.03564645f, 0.02306570f, -0.05113502f, 0.11647526f, -0.15768942f, 
    0.22657403f, 0.01463193f, -0.03844676f, 0.12113634f, -0.13718987f, -0.04221296f, -0.00473719f, 0.06116841f, 
    0.11387562f, 0.30157083f, 0.24023806f, 0.00559526f, 0.04712056f, 0.00883346f, -0.10112870f, 0.10786582f, 
    0.00997574f, 0.14588422f, -0.00104409f, 0.01606166f, 0.23088740f, 0.02092730f, -0.09651299f, -0.09309606f, 
    -0.01015904f, -0.05339159f, 0.09542052f, -0.17070387f, 0.15990506f, 0.34201169f, 0.06695186f, -0.05573363f, 
    -0.09623097f, -0.15996969f, -0.13412389f, 0.04555586f, 0.03411132f, 0.00726493f, 0.03542746f, -0.04881374f, 
    0.25848490f, -0.36171925f, -0.23067541f, 0.11155441f, -0.04976514f, 0.08705198f, -0.07514136f, 0.11960615f, 
    -0.06874865f, 0.19859700f, 0.01349753f, -0.23026057f, -0.01039826f, 0.05968368f, 0.27755144f, -0.12404853f, 
    -0.02355061f, -0.07370534f, 0.03493606f, 0.02083701f, 0.16840975f, 0.00741559f, -0.06272756f, 0.16008231f, 
    -0.11356209f, -0.25825712f, 0.20656200f, -0.03612401f, 0.09418833f, -0.02555268f, 0.03050788f, 0.05617821f, 
    0.05784029f, 0.01042556f, 0.02675135f, 0.08358763f, -0.27380487f, -0.63259625f, -0.06279392f, -0.16705534f, 
    -0.02640997f, 0.14744277f, 0.04170986f, 0.02315286f, 0.09650955f, -0.00671123f, -0.09463574f, -0.08276220f, 
    0.06344235f, 0.03268568f, -0.08347476f, 0.02692950f, 0.03236789f, 0.05837847f, -0.04313405f, 0.06043588f, 
    -0.04940375f, 0.00678953f, 0.05851094f, -0.00660661f, -0.04397967f, -0.05319702f, -0.07190103f, -0.01056586f, 
    -0.04550048f, -0.01161466f, -0.07904667f, -0.05607418f, 0.00047990f, 0.04063525f, -0.04527172f, 0.04744853f, 
    -0.07128663f, 0.01027991f, -0.02594811f, -0.01348778f, 0.05146258f, 0.00042726f, -0.01320533f, 0.04630957f, 
    0.05031026f, -0.01212869f, 0.01273960f, 0.04713792f, -0.04904898f, 0.03561012f, -0.00884905f, -0.00749107f, 
    -0.04117154f, -0.02579728f, -0.07499924f, 0.04648507f, -0.05020904f, -0.02116634f, -0.02286442f, -0.04588885f, 
    -0.06106478f, -0.03602017f, 0.03254623f, 0.03045451f, 0.02957227f, 0.05295305f, -0.02050676f, 0.02691146f, 
    -0.04859664f, -0.03825986f, 0.00829848f, -0.02561866f, 0.06197206f, -0.04177663f, -0.06735604f, 0.05017279f, 
    0.00366530f, 0.05602251f, -0.02921999f, -0.07518356f, -0.03447396f, -0.05798331f, 0.02562276f, 0.02080597f, 
    0.02570736f, -0.04847820f, 0.01089244f, -0.01191572f, 0.04036624f, -0.05449685f, -0.00379036f, 0.00804978f, 
    0.03681621f, 0.05805824f, -0.08075039f, -0.01980844f, -0.07331084f, -0.00424604f, 0.00901629f, -0.03400754f, 
    -0.07856295f, -0.07946568f, 0.02336946f, -0.05286524f, -0.01226153f, -0.08128559f, -0.01530230f, 0.05664309f, 
    -0.07562872f, -0.01379242f, -0.04145000f, -0.02844580f, 0.02359401f, -0.03793889f, -0.08119997f, -0.07727003f, 
    0.01847733f, 0.03574429f, -0.07476242f, -0.06701054f, -0.02568584f, -0.00558845f, -0.06032178f, 0.00079165f, 
    0.01007292f, -0.06861968f, 0.01343439f, 0.00308159f, 0.02763367f, -0.04751599f, 0.05056140f, 0.03243934f, 
    -0.05744899f, -0.01593727f, 0.00251667f, -0.05414453f, -0.04562906f, 0.05098793f, 0.01537973f, -0.04523331f, 
    0.03497896f, 0.04517878f, 0.04604466f, 0.03068741f, 0.04629454f, -0.06960469f, -0.04150556f, 0.03815458f, 
    0.05198767f, 0.01182071f, 0.03541440f, 0.01255311f, -0.03850424f, -0.06683636f, -0.02483771f, 0.06261825f, 
    0.05208492f, -0.07040486f, -0.02648834f, 0.03216736f, -0.06253087f, 0.05129034f, -0.02832129f, -0.04907788f, 
    0.00798352f, -0.04694154f, -0.01988010f, 0.05718736f, -0.00620623f, -0.00334488f, -0.02844606f, 0.01802385f, 
    0.04965005f, 0.00403648f, 0.05417048f, 0.04279192f, 0.05830915f, -0.00401291f, -0.01185298f, -0.05107584f, 
    -0.02578779f, -0.06509364f, 0.05964810f, -0.06145988f, -0.01367188f, -0.01641580f, -0.05527782f, -0.01823789f, 
    -0.08141080f, 0.02109916f, 0.02762862f, 0.03622786f, 0.00095880f, 0.00164397f, 0.05383033f, -0.07714745f, 
    -0.01390682f, -0.01514737f, -0.07160837f, -0.00089630f, -0.00918361f, 0.03231714f, 0.04704928f, -0.07671742f, 
    0.10177687f, -0.28866303f, -0.22304699f, 0.00601051f, 0.07807989f, 0.25077021f, -0.15038899f, -0.34423476f, 
    0.10575414f, -0.17573830f, 0.00130378f, 0.07893923f, 0.39701265f, 0.32503536f, 0.09057881f, -0.19574808f, 
    0.05249618f, -0.27993980f, -0.08638096f, 0.09197459f, 0.00290900f, 0.06995922f, -0.05788454f, -0.01245987f, 
    0.36884674f, 0.33963898f, 0.34292424f, -0.01116952f, 0.00743682f, 0.06810335f, 0.09118272f, 0.03489602f, 
    0.00605041f, 0.00861306f, -0.10973621f, 0.18713532f, 0.16634917f, 0.34510821f, -0.09337399f, 0.00132848f, 
    0.24103034f, 0.17858770f, 0.20209152f, -0.05079640f, -0.02324450f, -0.05553891f, 0.05099416f, 0.02235561f, 
    -0.03746140f, -0.14090785f, -0.03309637f, -0.03440120f, 0.01500632f, 0.06803922f, -0.01175084f, 0.03830859f, 
    0.00536424f, -0.08815929f, -0.16807343f, 0.17944731f, -0.21676834f, -0.02790554f, -0.13466683f, 0.13398981f, 
    -0.06599800f, -0.04887405f, -0.08215944f, -0.04577343f, 0.00643374f, 0.03140868f, 0.03632529f, 0.04051666f, 
    -0.15319195f, 0.03860586f, 0.08996370f, 0.08524365f, -0.05667630f, -0.08247531f, 0.10241176f, 0.05977082f, 
    -0.07945455f, 0.04105010f, 0.01212268f, -0.05629755f, -0.49176610f, 0.10734400f, -0.28487462f, -0.04444434f, 
    -0.04964835f, -0.09485738f, -0.09776270f, -0.03876154f, 0.10169838f, 0.07217160f, 0.07962882f, 0.13731812f, 
    0.16441639f, -0.18723923f, -0.02940910f, -0.05029207f, -0.15606515f, -0.05593168f, 0.01345034f, 0.04292803f, 
    0.03276654f, -0.00126667f, -0.00341212f, 0.04469552f, 0.33416039f, 0.19461714f, 0.13861835f, 0.23951791f, 
    0.32696828f, 0.14289528f, 0.05766127f, 0.01495419f, 0.05141797f, 0.10679957f, -0.03212313f, 0.02818437f, 
    0.07019202f, 0.30649570f, 0.01344274f, 0.09907515f, 0.05561278f, -0.02999705f, 0.22399557f, 0.10508541f, 
    -0.06595725f, -0.04546923f, -0.09943762f, 0.01965241f, -0.35552552f, -0.31543738f, -0.10576560f, -0.23246959f, 
    -0.04456405f, -0.20317064f, -0.06437089f, -0.20056507f, -0.07683731f, -0.07612437f, 0.10546599f, 0.07440578f, 
    -0.23297560f, -0.35133633f, -0.06923015f, 0.17161310f, 0.04062030f, 0.03137536f, 0.01361464f, -0.10733029f, 
    0.02279153f, 0.03174046f, -0.01514200f, 0.15724990f, -0.43782049f, -0.25081879f, -0.14199336f, -0.24933302f, 
    0.01244909f, -0.04057555f, -0.14486308f, 0.01977293f, 0.05706730f, 0.04585392f, 0.07962286f, 0.11220241f, 
    0.67669183f, 0.27602515f, 0.19454570f, -0.29785296f, 0.34553635f, 0.17627124f, 0.16616240f, 0.25001922f, 
    0.08769968f, -0.07413363f, -0.07000497f, 0.10956576f, -0.17122807f, -0.38045424f, -0.21362343f, 0.22563401f, 
    -0.01335533f, 0.13859503f, -0.00003323f, 0.05837551f, 0.11150454f, -0.06592519f, -0.03292937f, -0.01392905f, 
    -0.20887746f, 0.12758188f, -0.22264691f, 0.50088102f, -0.07185965f, 0.06101646f, -0.21496591f, 0.26273802f, 
    0.15514682f, 0.01114552f, 0.29014233f, 0.15586253f, -0.16459015f, 0.02553705f, 0.23416211f, 0.14500886f, 
    -0.03869420f, -0.00688135f, 0.00668967f, 0.10511030f, -0.02282802f, 0.20811778f, -0.07389848f, 0.00179073f, 
    -0.24944521f, 0.31987083f, 0.11320122f, -0.09335174f, 0.08824566f, -0.11669073f, 0.00416652f, 0.06628780f, 
    0.13391149f, -0.21521054f, -0.13462801f, 0.16049430f, -0.24880636f, 0.07442734f, 0.19540048f, 0.07502506f, 
    0.11616606f, 0.04923664f, -0.03746143f, 0.01952947f, -0.13179359f, -0.17461495f, -0.12551993f, -0.02246066f, 
    -0.37158418f, -0.00193573f, -0.05756687f, -0.26895371f, 0.18363647f, 0.07596084f, 0.10664042f, 0.01528389f, 
    -0.10795465f, 0.05965078f, 0.02251886f, 0.01300130f, 0.27509385f, 0.00233849f, 0.03904725f, -0.08539915f, 
    0.03519893f, -0.00541308f, 0.07590132f, 0.14473963f, -0.01377624f, -0.06046947f, 0.06671560f, -0.05520592f, 
    -0.22722693f, 0.09573554f, 0.00823895f, 0.11078095f, 0.09518777f, 0.01384398f, 0.15214457f, -0.10493584f, 
    -0.05877108f, -0.07476354f, -0.14811914f, -0.05852175f, 0.46461833f, -0.06573857f, 0.13804272f, -0.13211827f, 
    -0.01926043f, 0.03611495f, -0.42227775f, -0.02410915f, 0.01683688f, 0.02042538f, 0.11297329f, 0.24717064f, 
    -0.07241163f, 0.08839802f, 0.07928169f, 0.15324518f, 0.11309080f, 0.21169192f, 0.00330706f, -0.04150658f, 
    0.03865692f, 0.05466980f, 0.24064532f, 0.28201017f, 0.04109766f, -0.03069695f, 0.21012881f, 0.09761842f, 
    0.07595952f, 0.10306892f, -0.03502787f, 0.37584847f, 0.08470815f, 0.02442303f, -0.09665197f, 0.08828598f, 
    0.51165974f, 0.22393198f, 0.35163683f, -0.03883849f, 0.06191378f, -0.05393862f, 0.17938578f, -0.02771528f, 
    0.08632064f, 0.05238081f, -0.18214449f, -0.06421170f, -0.37217271f, 0.06438549f, -0.33351311f, 0.22553894f, 
    -0.03162885f, 0.02416849f, -0.12410321f, -0.14333959f, 0.05762035f, -0.25412631f, -0.23419726f, 0.00813147f, 
    0.45087367f, -0.02295486f, -0.22967952f, -0.05516180f, -0.20340940f, 0.05244729f, -0.09668907f, 0.02075749f, 
    -0.06933725f, -0.06841588f, -0.02168021f, 0.01928417f, 0.16993138f, 0.02215180f, -0.34326783f, 0.14002624f, 
    0.04440432f, 0.06360275f, -0.00138314f, 0.05255176f, 0.17697769f, 0.02063142f, 0.05298103f, 0.13449082f, 
    0.01740629f, 0.03107606f, -0.11552469f, -0.00818330f, 0.12242584f, 0.25334111f, -0.09644264f, -0.04204319f, 
    0.02901781f, -0.24900426f, -0.03570931f, -0.09604183f, -0.20142846f, -0.09383545f, 0.49905595f, 0.10109115f, 
    0.10575092f, -0.06919868f, 0.01652071f, 0.20384654f, 0.05527587f, 0.02961908f, 0.00582356f, -0.02575468f, 
    -0.14230157f, -0.10893861f, 0.51984310f, 0.04349176f, 0.06653353f, -0.07947493f, -0.05174749f, 0.41578594f, 
    -0.08294488f, -0.00581959f, 0.15401632f, -0.09195060f, 0.54849815f, -0.43899760f, -0.27183521f, 0.26608226f, 
    0.01853256f, -0.01834670f, 0.25055984f, -0.17940114f, 0.00918973f, -0.04481101f, -0.08492475f, 0.00199316f, 
    -0.23739602f, -0.23063990f, -0.25398010f, 0.20931309f, 0.09672692f, -0.00971726f, -0.13160460f, -0.06723628f, 
    -0.07736103f, 0.22417386f, 0.20818847f, -0.03997559f, -0.08809385f, -0.35903487f, 0.03125447f, 0.23191455f, 
    -0.16449285f, -0.22995885f, -0.04158434f, 0.07649844f, -0.05722133f, 0.12960090f, 0.12725052f, -0.02760370f, 
    -0.04713465f, 0.04856275f, 0.01169578f, -0.07685868f, -0.01065090f, -0.05680236f, -0.09327314f, -0.11532015f, 
    -0.02067213f, 0.07274277f, 0.14450037f, 0.15477841f, -0.10101356f, 0.03979383f, 0.28869569f, 0.24467239f, 
    -0.12940602f, 0.06362898f, 0.05557307f, -0.14445995f, -0.00354283f, 0.05282371f, -0.06355561f, -0.02167415f, 
    0.03961173f, 0.08385573f, 0.15994793f, 0.07911056f, -0.04809037f, -0.04030683f, -0.01632741f, -0.06796037f, 
    0.03518138f, 0.07902458f, 0.09649249f, -0.09714112f, 0.05833607f, -0.18123601f, 0.26398027f, -0.04564615f, 
    -0.00407472f, 0.00680858f, -0.04940613f, 0.02391660f, -0.08796326f, -0.07895683f, 0.05871621f, -0.06419846f, 
    -0.04336169f, 0.07105039f, -0.05281810f, 0.05441854f, 0.12953724f, 0.07731543f, -0.04702411f, 0.05847491f, 
    -0.06995290f, -0.01840194f, -0.11869462f, -0.30124050f, 0.02247983f, -0.00384711f, 0.24535374f, 0.12954599f, 
    -0.08748542f, -0.02385864f, 0.08796017f, -0.00047402f, -0.07041536f, -0.08145688f, 0.12480204f, -0.09442507f, 
    -0.06727868f, -0.26136354f, 0.08379661f, 0.01210129f, -0.03086195f, 0.04471816f, 0.15713646f, -0.02904303f, 
    -0.08551812f, 0.02669573f, 0.09192604f, 0.21550982f, 0.08939458f, 0.17357373f, -0.12244548f, -0.14220518f, 
    -0.11578624f, 0.02494289f, 0.06620095f, 0.03983856f, -0.01853317f, 0.00182932f, -0.01851253f, -0.13859932f, 
    -0.17992440f, 0.17807707f, 0.31226358f, -0.03013455f, -0.06604840f, -0.08526510f, 0.09312114f, 0.02579621f, 
    0.02169767f, -0.02069288f, 0.02679783f, 0.10488040f, -0.27535504f, 0.11335313f, 0.12204355f, 0.29998136f, 
    0.03578936f, 0.03785883f, 0.08918623f, 0.00437515f, 0.02684278f, 0.14666609f, 0.12974001f, 0.01743163f, 
    -0.22678909f, 0.04974689f, -0.04781729f, 0.38932148f, -0.10162842f, 0.10823233f, -0.17504671f, -0.00608219f, 
    0.01657226f, 0.06463467f, 0.02591226f, -0.01291959f, 0.47640750f, 0.36055183f, 0.28575629f, 0.08279699f, 
    -0.07243355f, -0.29066518f, 0.19032209f, 0.01778107f, -0.05380513f, 0.09526803f, -0.06723879f, 0.04128474f, 
    0.26062027f, -0.20735170f, 0.56208640f, -0.39302120f, -0.16264044f, 0.13644385f, -0.01307723f, 0.08441322f, 
    -0.16886185f, 0.02638669f, 0.21933240f, -0.18491885f, -0.21450189f, -0.05057463f, -0.06882127f, 0.02036670f, 
    0.13715738f, -0.07398934f, 0.10358186f, 0.02628772f, -0.14786550f, -0.08564936f, 0.14082539f, -0.07142251f, 
    0.03359279f, -0.09082229f, -0.19280472f, 0.32857579f, 0.05711622f, 0.04400470f, -0.00058007f, -0.01232454f, 
    -0.07981791f, 0.01943912f, -0.01902712f, -0.11053190f, 0.37289950f, 0.03733341f, 0.07585513f, -0.02347725f, 
    0.02982832f, 0.03474719f, 0.02395941f, 0.15367509f, 0.08679999f, 0.00366051f, -0.06506968f, -0.16286990f, 
    0.06555459f, 0.05457878f, -0.11449062f, 0.16025099f, 0.04220879f, 0.06788677f, -0.08519539f, -0.11250026f, 
    0.00214593f, -0.16128902f, 0.12991083f, 0.00983415f, -0.18823318f, 0.15666671f, 0.36234182f, 0.20090890f, 
    0.00556726f, -0.02459030f, -0.01662459f, 0.01248329f, 0.01547970f, -0.10253805f, 0.10077360f, 0.07385203f, 
    0.30367431f, 0.10014323f, -0.12862240f, -0.19751921f, -0.15611388f, -0.14001180f, -0.09882958f, -0.01427480f, 
    -0.03887261f, 0.07741654f, 0.07942508f, 0.10886998f, 0.12908334f, -0.17512593f, 0.29544327f, 0.10083970f, 
    -0.08847654f, 0.04648874f, 0.14790441f, -0.01027041f, -0.01858067f, -0.03621697f, -0.04213212f, 0.05690279f, 
    -0.05739683f, 0.10720315f, -0.04680455f, 0.04337491f, -0.06386719f, 0.19765413f, 0.08032975f, -0.03827194f, 
    0.25516301f, 0.03969042f, -0.18523902f, -0.11243039f, -0.02403637f, 0.23969063f, 0.21562672f, -0.17509180f, 
    -0.01355016f, 0.02474194f, 0.09926240f, 0.00206500f, -0.05182233f, -0.11267409f, 0.00683422f, -0.05411341f, 
    -0.10004259f, -0.09895976f, 0.27876890f, -0.05678222f, 0.03071981f, 0.00589107f, -0.10280074f, 0.11003508f, 
    0.09788512f, 0.10782453f, 0.05144459f, 0.11165212f, 0.21066734f, 0.12236910f, -0.01551516f, -0.07587143f, 
    -0.07995169f, 0.06037044f, -0.04860058f, 0.05276394f, -0.03065786f, 0.06678452f, 0.09641899f, -0.00537349f, 
    -0.08284706f, -0.24922495f, 0.16651674f, -0.12018850f, -0.03346080f, -0.06313488f, -0.02296638f, 0.07162844f, 
    0.08529388f, 0.06160982f, 0.09809852f, 0.02922155f, -0.00354635f, -0.02236881f, 0.04735231f, 0.29324818f, 
    -0.02111586f, 0.03264889f, 0.12179948f, -0.04949981f, -0.02482173f, -0.03475254f, -0.00653141f, 0.02617830f, 
    -0.06747317f, 0.26491305f, -0.05332257f, -0.05133040f, -0.04242807f, -0.14069572f, -0.10016187f, -0.01214110f, 
    0.02274251f, 0.12051391f, 0.07667910f, -0.04835252f, 0.36780542f, 0.26490963f, -0.11622079f, -0.22929810f, 
    -0.06529870f, -0.13256195f, 0.04250184f, -0.12988779f, -0.13006610f, -0.00717726f, 0.06497358f, -0.06723975f, 
    -0.85974646f, 0.16436362f, -0.14315747f, 0.28125948f, 0.03606959f, -0.18537678f, -0.13534123f, 0.11257394f, 
    0.03098030f, 0.01861214f, 0.01428315f, -0.05544206f, 0.46442425f, -0.18698071f, -0.02068335f, 0.14306882f, 
    -0.08145801f, 0.01624632f, 0.17418039f, -0.06339757f, 0.06940072f, -0.02584451f, -0.12025952f, 0.01643044f, 
    0.19700022f, 0.21388339f, 0.32039955f, 0.02187968f, 0.00723928f, 0.03535822f, -0.09540513f, -0.09894338f, 
    -0.11099405f, 0.04698454f, 0.27098602f, 0.34796259f, -0.22623576f, -0.05271827f, 0.01084233f, 0.17805442f, 
    0.10567886f, -0.18965873f, -0.03663925f, 0.00610203f, 0.00852208f, -0.00168515f, 0.04040748f, 0.13604271f, 
    0.04509569f, -0.02012617f, 0.07563490f, -0.03069058f, 0.05417607f, -0.01356438f, 0.02146786f, 0.00187337f, 
    0.05361831f, 0.41722131f, 0.10210105f, 0.06528237f, 0.33582389f, -0.24791496f, 0.01184199f, -0.06713491f, 
    0.06622221f, 0.04770999f, 0.15531363f, -0.04076523f, 0.10247812f, 0.10300718f, 0.01420630f, -0.14411525f, 
    0.06897262f, 0.07888533f, 0.29444075f, 0.31324944f, 0.11912806f, 0.15151785f, 0.32109010f, 0.05143050f, 
    0.09029759f, 0.01197046f, 0.18984234f, -0.09796233f, 0.08931211f, -0.14031085f, -0.18363707f, -0.26112044f, 
    0.13090020f, 0.03504421f, -0.06861383f, 0.05812115f, 0.01436094f, 0.01254600f, 0.00576506f, 0.03191425f, 
    -0.02880212f, -0.06865724f, 0.06470326f, -0.15248418f, 0.16159914f, 0.05515355f, -0.01645842f, 0.16800646f, 
    -0.28134936f, -0.05166922f, 0.05054316f, -0.10562446f, 0.23988068f, -0.21728335f, 0.05842171f, 0.05582133f, 
    -0.08069555f, -0.06943785f, -0.09179066f, -0.02222184f, -0.02623972f, -0.06954228f, -0.01395462f, 0.07403085f, 
    0.27392897f, -0.11676530f, -0.02177496f, -0.02847159f, -0.05702645f, 0.04240509f, 0.21449620f, -0.24967372f, 
    -0.10526455f, 0.03873942f, -0.00144248f, 0.45406479f, -0.15677181f, 0.02496156f, 0.02965833f, -0.07932635f, 
    0.14309536f, 0.04411684f, 0.00071565f, 0.07306005f, -0.05403482f, -0.04283393f, -0.03056757f, 0.06686161f, 
    -0.13761258f, 0.26250559f, -0.00350393f, 0.31580150f, 0.00739350f, -0.04109073f, 0.11273405f, -0.16691108f, 
    0.17704630f, 0.04481334f, 0.16985323f, 0.46156535f, -0.10873785f, -0.04576946f, -0.08429799f, -0.05005957f, 
    0.03111555f, 0.05108259f, 0.02665113f, 0.04708722f, -0.05272731f, 0.14953341f, -0.01951441f, 0.04108753f, 
    0.22987577f, -0.11676069f, -0.03052281f, 0.06171098f, -0.01857811f, 0.30325204f, -0.16562456f, 0.04211028f, 
    -0.00336380f, -0.09425866f, 0.04554803f, -0.00306830f, -0.01668663f, -0.06294103f, 0.44797331f, 0.44676849f, 
    0.12855309f, -0.02039594f, 0.08357737f, -0.07045755f, 0.07885320f, -0.03581975f, 0.02962263f, 0.14996344f, 
    -0.02566365f, -0.08520692f, 0.21249524f, -0.14054047f, 0.17342561f, 0.04199033f, -0.01202468f, -0.14296484f, 
    -0.15143183f, 0.07090835f, 0.16449390f, 0.21644415f, 0.22248128f, -0.09829363f, 0.22311817f, 0.01216586f, 
    0.25709233f, -0.02712531f, -0.05208820f, -0.01299442f, 0.10782240f, 0.04133984f, 0.03782924f, 0.05867437f, 
    0.28725800f, -0.26338747f, 0.24818970f, -0.11943159f, -0.05505856f, -0.06139440f, 0.01564791f, -0.15301228f, 
    0.18799432f, 0.05719392f, 0.10657440f, -0.09501085f, -0.46915478f, -0.02671731f, -0.14938009f, -0.63348025f, 
    -0.12012026f, 0.01574340f, 0.01280032f, 0.20084839f, -0.00915228f, -0.13322598f, -0.02272871f, 0.06325866f, 
    0.16710427f, -0.13378061f, -0.06573754f, 0.09590812f, -0.10166222f, -0.19177496f, -0.13868308f, -0.14387774f, 
    0.31275719f, 0.00535036f, 0.11948406f, 0.10448040f, 0.04524115f, 0.12403549f, -0.06915705f, 0.20303015f, 
    0.11515511f, -0.08136681f, -0.13301979f, 0.01091412f, -0.03326325f, -0.10996341f, -0.02981141f, -0.09612263f, 
    -0.15747915f, 0.01978534f, 0.03132475f, 0.02797715f, -0.02712199f, -0.08017892f, 0.10259593f, 0.18586940f, 
    -0.16371317f, -0.03046690f, 0.01274466f, -0.16610329f, -0.39518285f, 0.28562737f, 0.00724641f, 0.20085779f, 
    0.04135021f, -0.01864103f, -0.04328069f, -0.18403524f, 0.03100657f, -0.03741822f, 0.08547486f, 0.08519859f, 
    0.42445052f, -0.24239767f, 0.03208438f, -0.08283595f, 0.03455209f, 0.03245950f, 0.02912373f, -0.13201638f, 
    -0.01972965f, 0.03800150f, 0.17022745f, -0.01217208f, 0.02107287f, -0.22521210f, -0.23947519f, 0.13799706f, 
    0.09617259f, 0.10355224f, -0.00356774f, 0.03835069f, 0.06007929f, 0.10866085f, -0.00115520f, -0.02064028f, 
    -0.47052819f, 0.17434856f, -0.35622472f, 0.40741631f, 0.17729309f, 0.03293124f, 0.10940631f, 0.17144847f, 
    0.25333613f, -0.07170386f, -0.01384411f, -0.01275288f, -0.01340051f, -0.04369524f, 0.15027912f, -0.26196378f, 
    -0.09892924f, 0.07625558f, -0.05820744f, -0.04380526f, -0.00253136f, -0.09512160f, 0.05592074f, -0.05542682f, 
    -0.34531203f, 0.14191088f, -0.02711521f, -0.04564705f, 0.05879953f, -0.05947913f, 0.07193767f, 0.05465227f, 
    0.07597339f, 0.11094697f, -0.07085907f, -0.03188663f, -0.04954135f, 0.10591520f, 0.14617759f, -0.08475561f, 
    -0.10927479f, 0.02218141f, -0.11981624f, 0.01086282f, -0.14540111f, -0.19340499f, 0.16634823f, 0.21156694f, 
    0.17407934f, -0.01258593f, 0.36539710f, -0.22272293f, 0.13760664f, 0.04205221f, 0.38391322f, 0.18661024f, 
    0.06391744f, 0.02716502f, -0.07395865f, 0.01383246f, 0.12599744f, 0.15550125f, -0.70007932f, 0.05346407f, 
    -0.18157078f, -0.04308027f, -0.17027615f, 0.22698827f, 0.31255925f, -0.15004054f, 0.18093511f, 0.16327843f, 
    -0.13850182f, 0.19845253f, 0.08020196f, 0.24486980f, 0.15057239f, -0.12598778f, -0.14439827f, 0.21896860f, 
    0.05409504f, 0.04195756f, 0.23832728f, 0.19251131f, 0.81404525f, -0.19075653f, 0.01525827f, 0.14326322f, 
    0.11398675f, -0.19479857f, -0.01761681f, -0.15636453f, -0.00121337f, 0.05668544f, -0.10719202f, 0.14307570f, 
    -0.16690911f, -0.19201049f, -0.04330092f, -0.07675873f, 0.02489959f, -0.09692022f, 0.03528073f, 0.12084682f, 
    0.02512651f, 0.08181950f, -0.05650283f, 0.11162661f, -0.37520859f, -0.23523493f, 0.14938574f, 0.18704113f, 
    -0.09353431f, -0.15194993f, -0.10746632f, 0.01837288f, 0.06548880f, -0.05325639f, -0.00208671f, 0.06660856f, 
    -0.35115510f, 0.06653735f, 0.02437127f, -0.10516073f, -0.17594379f, -0.01499648f, -0.03114460f, 0.13927202f, 
    -0.10665439f, -0.04340525f, -0.15535702f, 0.02587179f, 0.33497968f, 0.18658203f, -0.11758538f, -0.02128867f, 
    -0.09260301f, 0.10786583f, -0.02463300f, -0.03674740f, 0.02139284f, 0.13159135f, 0.05420242f, -0.00194348f, 
    -0.17840369f, 0.25331098f, 0.36900330f, 0.03206813f, 0.06344714f, -0.05256955f, -0.10400277f, -0.12018231f, 
    0.17152506f, -0.08024511f, -0.07503216f, -0.13772808f, -0.06934205f, 0.10043035f, 0.15277514f, -0.22822616f, 
    -0.08026867f, -0.09429049f, -0.19902799f, -0.12167028f, 0.08932009f, 0.06439196f, 0.17749877f, 0.08629800f, 
    0.19228444f, 0.11092149f, -0.05102457f, 0.02048112f, -0.08833513f, -0.03466504f, -0.02000557f, 0.10178265f, 
    -0.02895637f, 0.18801267f, 0.20658535f, 0.15534155f, -0.02584793f, -0.15690444f, 0.03557470f, 0.40698603f, 
    -0.05038472f, -0.08032920f, -0.08980568f, 0.09474683f, 0.06162978f, 0.00771592f, 0.15887929f, 0.10121130f, 
    0.07617000f, 0.01194387f, -0.19200376f, 0.25475138f, 0.01041921f, -0.15540038f, 0.19621597f, 0.08151200f, 
    0.00969940f, 0.00735289f, -0.03472529f, -0.04052792f, -0.57437342f, -0.13274078f, -0.16561934f, -0.38347954f, 
    -0.15950227f, -0.17268139f, -0.00463410f, -0.09802061f, -0.03816742f, -0.16985132f, -0.05651431f, 0.13083018f, 
    -0.17614490f, 0.48221314f, -0.02612016f, -0.00982030f, 0.04261846f, 0.13670745f, -0.05232680f, 0.10564180f, 
    0.01288086f, -0.01699001f, -0.22738789f, -0.05066960f, -0.31174812f, 0.31988364f, -0.21462631f, -0.00423680f, 
    -0.00840896f, -0.02682326f, -0.11119936f, 0.02889010f, 0.36456373f, 0.06336791f, -0.00366195f, 0.17959590f, 
    -0.12578718f, -0.28264481f, -0.03609841f, 0.35360661f, 0.02540342f, 0.21900851f, -0.08506196f, 0.06929014f, 
    0.01359865f, -0.10133017f, -0.11350922f, 0.11441376f, 0.02686279f, 0.36156911f, 0.29309544f, 0.28052020f, 
    -0.02021118f, -0.16548268f, 0.04844088f, 0.12292981f, 0.10555514f, 0.02854427f, 0.10172003f, 0.00587755f, 
    -0.18208176f, 0.15133528f, -0.02407752f, -0.01819658f, 0.15701108f, -0.29874215f, 0.08989064f, 0.10563210f, 
    -0.09081679f, 0.12686971f, -0.03295786f, -0.12305038f, 0.28617841f, -0.35242024f, -0.04928628f, 0.41837898f, 
    -0.04194182f, 0.18226843f, -0.16524431f, -0.33927488f, -0.08422773f, -0.12549466f, -0.09941520f, -0.12443954f, 
    0.21761079f, -0.10294627f, 0.71761471f, 0.06338749f, 0.11198048f, 0.05580325f, -0.11987755f, -0.04245323f, 
    0.34131587f, 0.11776093f, 0.08722035f, 0.22213478f, -0.44618842f, -0.14735505f, 0.02860307f, -0.01124291f, 
    0.02878319f, -0.18245879f, -0.09360289f, 0.32292962f, 0.10976564f, -0.09883202f, 0.03082925f, 0.06915702f, 
    -0.20112979f, -0.27266234f, 0.04664003f, 0.06266557f, -0.23059037f, 0.07092317f, -0.04693916f, 0.07544098f, 
    0.19799320f, 0.00130715f, 0.04788772f, 0.13235112f, 0.43192017f, 0.03773583f, -0.20354880f, 0.07567324f, 
    0.11866291f, 0.14274298f, 0.14867668f, -0.18398491f, -0.07235577f, 0.04498373f, -0.19839416f, -0.20384429f, 
    -0.18396339f, -0.10105578f, 0.47737780f, 0.30299664f, 0.12449462f, 0.09496767f, 0.28904229f, 0.00176587f, 
    0.11710687f, 0.01959563f, 0.26022124f, -0.03703165f, -0.21331494f, 0.20485924f, -0.33188799f, -0.12330162f, 
    0.19909008f, 0.02534004f, -0.03736782f, -0.11639401f, 0.11250927f, 0.18816352f, 0.14166273f, 0.00197116f, 
    0.15036935f, -0.35391897f, 0.02534670f, -0.09560251f, 0.01153468f, -0.08341220f, -0.07559484f, 0.00435614f, 
    -0.35337171f, -0.10898723f, -0.03483557f, 0.13639578f, 0.02383881f, -0.11382671f, 0.05858937f, 0.27029771f, 
    0.05116320f, -0.24032344f, -0.04622370f, 0.21397483f, -0.02121126f, -0.17567451f, -0.14613901f, -0.29897615f, 
    -0.05959259f, 0.13737099f, -0.37569204f, 0.31328487f, 0.10612810f, -0.06169783f, 0.19008489f, 0.09499359f, 
    0.19706315f, -0.21369207f, 0.06330287f, 0.23224111f, -0.17322218f, -0.38768059f, -0.05351747f, -0.22182395f, 
    0.31809416f, 0.35049376f, 0.07297651f, -0.11517886f, 0.05471684f, -0.21676317f, -0.05319937f, 0.24656017f, 
    0.01114248f, 0.26770908f, -0.01862986f, -0.03540706f, 0.09664702f, -0.00255311f, 0.11444763f, -0.05742044f, 
    0.10933944f, -0.00828018f, 0.06194802f, 0.06935196f, 0.16671579f, -0.12289786f, -0.22733530f, -0.23205137f, 
    -0.17034370f, 0.05808750f, -0.15761717f, 0.16542843f, 0.16206187f, 0.00041909f, 0.23776767f, 0.02569896f, 
    0.14695239f, -0.08244454f, 0.30205366f, 0.35485268f, -0.00039942f, 0.10283725f, 0.00279900f, 0.09910493f, 
    0.13633929f, -0.25263122f, -0.15851894f, -0.17690545f, 0.09957236f, 0.33535126f, -0.17920426f, 0.46808609f, 
    0.00157196f, -0.26347700f, -0.31927741f, 0.02201810f, 0.09190363f, -0.01873158f, 0.07559910f, -0.00240620f, 
    0.51505756f, -0.40440863f, 0.09156371f, -0.17849052f, 0.08671567f, 0.08698980f, 0.12973963f, -0.01069204f, 
    -0.14631236f, 0.06772953f, -0.22510576f, -0.07939790f, -0.46192503f, -0.25897428f, -0.43079162f, 0.19030562f, 
    0.33692774f, -0.14254294f, -0.12350841f, 0.05460179f, 0.07241093f, -0.00656521f, -0.02363768f, -0.04466097f, 
    0.19995588f, -0.05336759f, 0.09025238f, 0.22318783f, 0.00514656f, 0.08504110f, 0.02354166f, -0.05984881f, 
    -0.10617686f, 0.28885064f, 0.25180581f, 0.11811982f, 0.46268573f, 0.12106542f, 0.21937004f, 0.11506818f, 
    0.12571551f, 0.32739863f, 0.04062957f, 0.02640914f, 0.08231231f, 0.02344901f, 0.03319504f, 0.05457419f, 
    0.15363705f, -0.23528828f, 0.01646698f, 0.13538444f, -0.03029863f, -0.08057630f, -0.01436754f, -0.03970497f, 
    0.19213350f, -0.00421477f, -0.00437771f, 0.13999695f, -0.53963101f, -0.49756378f, -0.30020800f, -0.06069731f, 
    0.05038184f, 0.04863531f, -0.04252946f, -0.04828213f, -0.13081217f, 0.04722799f, -0.16519754f, 0.21144509f, 
    0.37056017f, -0.21852851f, -0.29865167f, -0.06211745f, -0.04937876f, -0.03022814f, -0.14179945f, -0.04509785f, 
    -0.02829295f, 0.00963234f, -0.05764852f, 0.20428365f, -0.74714828f, -0.41633117f, -0.46350887f, 0.17412226f, 
    -0.04667159f, 0.06468816f, 0.08373548f, -0.00420199f, -0.10294162f, -0.23224375f, -0.10199995f, -0.20973259f, 
    -0.00979090f, -0.24040687f, -0.04633549f, -0.13942553f, -0.07075892f, -0.02705469f, -0.03715486f, -0.06268388f, 
    -0.00854790f, -0.17751840f, -0.32715690f, -0.42689729f, 0.31474534f, 0.13922720f, 0.17198741f, 0.11474363f, 
    0.03657726f, 0.06287506f, 0.21204482f, 0.01453096f, -0.03550770f, -0.06972309f, 0.13324322f, -0.05276589f, 
    -0.28688881f, 0.03347857f, 0.07686747f, 0.17329919f, 0.09493413f, 0.11447490f, -0.09286956f, 0.01877650f, 
    0.02264179f, 0.02537200f, 0.19088529f, 0.07199311f, -0.17685993f, -1.21633625f, -0.39970565f, -0.31136924f, 
    0.04596641f, -0.02575139f, 0.04886960f, -0.15816285f, -0.12625295f, 0.09699056f, 0.13750671f, -0.07283026f, 
    0.12772377f, -0.02372002f, 0.25563708f, 0.13263622f, 0.08477451f, -0.06842811f, -0.06113480f, 0.02025751f, 
    0.12160436f, 0.03527523f, 0.10190513f, 0.15905888f, -0.15500507f, -0.37197492f, -0.02755919f, -0.21836479f, 
    -0.02666801f, -0.17188536f, 0.07212102f, -0.01886646f, -0.17014773f, -0.08154353f, 0.11267438f, -0.09762539f, 
    0.21013151f, 0.32202187f, 0.28235823f, 0.23908985f, 0.02902405f, -0.01516264f, 0.25977179f, 0.13964665f, 
    -0.03939450f, 0.04473256f, 0.03168599f, 0.02418560f, 0.20585322f, 0.10497671f, 0.02474255f, 0.05540743f, 
    0.07563248f, 0.07363791f, -0.03482848f, -0.04312131f, -0.08031416f, -0.02904180f, 0.12832889f, 0.06775057f, 
    -0.01236198f, -0.06167787f, -0.01803854f, -0.04666426f, -0.01069736f, -0.03929857f, -0.07014110f, -0.04542801f, 
    0.02909246f, -0.05880883f, -0.03847847f, 0.02810673f, -0.02251478f, -0.04990033f, -0.07808818f, -0.00975640f, 
    0.05340054f, -0.03155548f, -0.05720032f, -0.03533629f, 0.04305818f, 0.02343053f, 0.03814770f, -0.05371088f, 
    -0.04915357f, 0.02901782f, 0.00102928f, -0.00362496f, 0.03953094f, -0.03706864f, 0.03023428f, -0.06116010f, 
    -0.00710389f, -0.04725809f, -0.01189715f, 0.03290696f, -0.01739060f, -0.02890258f, 0.04628626f, 0.03335882f, 
    -0.06145364f, 0.01383741f, 0.00851480f, -0.02841002f, -0.02278872f, 0.01133858f, -0.00197740f, -0.01397305f, 
    0.01011027f, 0.01191657f, -0.00210260f, 0.04403932f, -0.03321585f, -0.05237582f, -0.06240646f, -0.07314519f, 
    -0.02654354f, 0.05398592f, -0.07666862f, 0.03939509f, -0.05025370f, 0.06743777f, -0.01675684f, 0.04336210f, 
    0.00025020f, 0.02070932f, -0.04086055f, 0.03340159f, -0.04560010f, 0.03275743f, 0.01535907f, -0.02827780f, 
    0.02601521f, -0.00405044f, -0.03688757f, 0.03909428f, -0.06639667f, 0.01731566f, 0.00502457f, -0.02240007f, 
    -0.05115667f, 0.06571539f, -0.04007664f, 0.03845076f, -0.04985241f, -0.02436073f, -0.02398105f, -0.02203101f, 
    -0.07441825f, 0.04442755f, -0.04460340f, -0.04739390f, 0.02059160f, 0.02401857f, 0.02045815f, 0.04315746f, 
    -0.06285781f, 0.05692361f, -0.02274903f, 0.03190448f, 0.05285548f, -0.05451379f, 0.00379878f, 0.02712121f, 
    -0.06812504f, 0.00718116f, -0.00968096f, 0.06718519f, -0.00013349f, -0.05479776f, 0.02967822f, -0.04469058f, 
    -0.00154615f, 0.00318982f, -0.02876173f, 0.04661821f, -0.05905054f, 0.03616751f, -0.04560239f, 0.02635317f, 
    0.06217806f, -0.04311911f, 0.04641443f, -0.03916284f, 0.03331066f, -0.02392010f, -0.00092846f, -0.05037643f, 
    0.01468882f, -0.04774113f, 0.05500882f, 0.06280570f, -0.07100411f, -0.06075501f, -0.00768474f, 0.01091875f, 
    0.05005929f, -0.05459682f, 0.00406019f, 0.02391396f, 0.04380390f, 0.05058721f, -0.00549264f, 0.03156025f, 
    0.02373136f, 0.04026740f, -0.00594580f, -0.02131712f, 0.00205848f, -0.07643881f, -0.03346245f, 0.06030442f, 
    -0.07338753f, 0.01122790f, -0.05073730f, -0.01179078f, -0.02448144f, -0.02299765f, -0.02346355f, 0.06569122f, 
    0.02428495f, 0.02506812f, -0.06927530f, -0.01476972f, -0.06752609f, 0.02452814f, 0.00793971f, 0.00519632f, 
    -0.01282475f, 0.01307594f, 0.04454605f, -0.05898676f, 0.02496225f, 0.04414685f, -0.03272780f, -0.01439311f, 
    0.05329850f, -0.07405558f, -0.01370109f, -0.01712932f, -0.06589945f, -0.05761488f, -0.04441737f, -0.02727612f, 
    -0.04023720f, -0.06675436f, -0.06428697f, -0.04540028f, -0.03322675f, -0.06027552f, 0.01405569f, -0.01591041f, 
    0.08880754f, 0.20561270f, 0.31908396f, 0.04215296f, 0.07136259f, -0.05013035f, -0.01372847f, 0.01139213f, 
    -0.00781310f, 0.05786266f, 0.08639324f, -0.06106370f, -0.24195156f, -0.31597012f, 0.38352242f, 0.24689604f, 
    0.15954633f, 0.25678554f, -0.16666247f, 0.11794646f, 0.00135406f, 0.00088692f, -0.02869303f, -0.22387867f, 
    -0.25932726f, -0.08317235f, 0.29596546f, 0.20482583f, 0.00783148f, -0.10927170f, -0.18447572f, -0.02789614f, 
    -0.06896413f, -0.07529836f, 0.19259429f, -0.06213177f, -0.43988422f, 0.11667763f, 0.16927597f, -0.27197140f, 
    -0.17941447f, -0.13757467f, -0.09561776f, 0.17324176f, 0.07940311f, -0.06891146f, -0.01718956f, -0.03560132f, 
    -0.26375210f, -0.16087030f, -0.07872097f, 0.32722783f, 0.19775470f, 0.03691750f, -0.05320970f, 0.07156235f, 
    0.14305471f, 0.01788726f, 0.28314722f, 0.12610526f, 0.19054666f, 0.01101135f, 0.31636819f, 0.01959041f, 
    0.11073831f, -0.03251054f, 0.04177438f, 0.04978310f, 0.06213520f, 0.00257295f, -0.04395114f, -0.23904626f, 
    -0.29271248f, 0.16078320f, 0.02617542f, -0.19548504f, -0.02409444f, 0.23919949f, 0.19021027f, 0.07654959f, 
    0.03743011f, -0.01965817f, 0.10824516f, -0.10399274f, 0.23017143f, -0.02237918f, 0.08593185f, -0.16760445f, 
    0.05374493f, 0.09384332f, -0.03677595f, -0.00792131f, 0.06781633f, 0.12499017f, 0.17644283f, 0.11675452f, 
    0.09548496f, -0.30547586f, 0.09271073f, 0.13737270f, 0.19619009f, 0.02330362f, 0.12371130f, 0.00727505f, 
    -0.08300267f, 0.01303566f, 0.10309240f, 0.23069960f, 0.13962433f, -0.04800233f, -0.04076083f, -0.02506157f, 
    0.02432909f, -0.21155436f, -0.06951790f, 0.11084296f, 0.00744984f, -0.12736344f, -0.15794690f, -0.03786153f, 
    -0.03706942f, 0.11941806f, 0.04280762f, 0.21447544f, 0.12586111f, -0.06251056f, 0.05928152f, -0.13489453f, 
    0.19141750f, -0.13717285f, 0.00626778f, -0.01560462f, 0.20200603f, 0.02880769f, -0.03590069f, -0.30647975f, 
    0.07410806f, 0.15110606f, 0.08740739f, 0.11626945f, -0.01271790f, -0.13855065f, -0.05758011f, -0.05881570f, 
    0.22509937f, 0.03420127f, -0.07657925f, -0.16774039f, -0.00685483f, 0.07461000f, 0.06557453f, -0.10896477f, 
    0.17835400f, 0.15191665f, 0.20643137f, 0.04852378f, 0.25944847f, -0.17069669f, -0.09452651f, 0.19194724f, 
    -0.03788644f, 0.02813069f, -0.00621640f, 0.11794101f, 0.14342427f, 0.01805270f, 0.33184654f, 0.21489762f, 
    0.05619033f, -0.17906812f, 0.16921984f, -0.10888143f, 0.00483143f, -0.05184975f, 0.00308741f, -0.19525969f, 
    0.08582419f, -0.12296385f, -0.07469263f, -0.11102454f, -0.33916754f, 0.05366718f, -0.31847963f, 0.23623160f, 
    0.06412166f, 0.02104273f, -0.08526064f, -0.16518709f, -0.03264377f, -0.01487395f, 0.14440462f, 0.07899527f, 
    0.93203384f, 0.08389243f, 0.19766882f, -0.33841443f, 0.15223630f, 0.00933663f, 0.01435586f, -0.02180552f, 
    -0.00624909f, 0.05306923f, -0.12234882f, -0.03749640f, -0.54364234f, -0.16282572f, -0.19077027f, 0.12365455f, 
    0.05607921f, 0.22574452f, -0.13079777f, 0.18659543f, -0.00624358f, -0.05834243f, 0.07855497f, -0.07877830f, 
    -0.19993618f, -0.38980097f, 0.00514428f, 0.15138349f, 0.05825590f, -0.05589690f, 0.07873870f, 0.12613879f, 
    0.10334920f, 0.10950633f, -0.05555416f, -0.08220080f, 0.15816076f, 0.22453828f, 0.16460979f, -0.15847531f, 
    -0.17055865f, 0.19743510f, 0.07572285f, -0.11560830f, 0.16959216f, 0.00582882f, 0.03632422f, -0.13014725f, 
    -0.04207110f, -0.08219943f, -0.07366749f, 0.30893433f, -0.07136463f, 0.03682309f, -0.02536867f, 0.00392915f, 
    0.16343987f, -0.25159153f, 0.17429151f, 0.20481092f, -0.13616875f, 0.11989976f, 0.17616084f, 0.14133486f, 
    0.04979562f, 0.00904399f, 0.03701233f, 0.09416971f, 0.00945307f, 0.00506577f, -0.01318109f, 0.09151874f, 
    -0.02950188f, -0.19536081f, -0.11218721f, -0.51788771f, -0.01317447f, 0.18975599f, -0.22511719f, 0.02281879f, 
    0.00484159f, -0.00432582f, -0.07252362f, 0.16445298f, 0.16339706f, -0.16681954f, 0.29548496f, -0.05204462f, 
    -0.09244436f, -0.16467802f, 0.06826793f, -0.03743936f, -0.01292616f, 0.05908654f, 0.02734846f, 0.05632414f, 
    -0.10542584f, 0.08082214f, 0.07436036f, 0.34695435f, 0.05630852f, 0.03534155f, 0.19217856f, -0.03897203f, 
    0.24569257f, -0.04371974f, -0.03150611f, 0.16139074f, 0.03208468f, 0.08715180f, 0.01454071f, -0.21614100f, 
    0.04535265f, -0.09977301f, -0.06430330f, 0.11324868f, -0.02660370f, -0.13704251f, -0.05147387f, -0.02756512f, 
    -0.46854568f, -0.04365833f, 0.11012591f, -0.05325386f, 0.12330885f, -0.00411350f, -0.03356474f, -0.02717735f, 
    0.11458050f, 0.04464981f, 0.20196687f, -0.21127364f, 0.14827114f, -0.02521932f, -0.04476190f, 0.14488222f, 
    -0.05669627f, 0.08205611f, 0.00700896f, 0.00875548f, -0.12391265f, -0.08003445f, 0.01150490f, 0.00144779f, 
    0.35752806f, 0.01370539f, 0.28445399f, -0.29000005f, 0.10576563f, -0.02129124f, -0.08993392f, 0.15028128f, 
    0.03227171f, 0.13302781f, 0.17142494f, -0.17584604f, 0.24380621f, -0.11642102f, 0.03705953f, 0.09310509f, 
    -0.08205768f, -0.09025898f, 0.08674659f, -0.02878300f, 0.11279615f, 0.13461094f, 0.20072365f, -0.04627691f, 
    0.06855019f, -0.00372086f, 0.06678347f, -0.17506665f, 0.00515234f, -0.28532901f, 0.19269805f, -0.03482519f, 
    -0.00763094f, -0.02151619f, 0.04165635f, 0.03617239f, -0.45221528f, 0.11761335f, 0.04990683f, -0.03363423f, 
    -0.08319388f, -0.05328332f, 0.02803366f, -0.11078338f, 0.10678608f, -0.07034101f, -0.05378990f, 0.08685191f, 
    0.63923359f, 0.25155595f, -0.17986102f, -0.25329831f, -0.02212818f, -0.07165184f, 0.01581497f, 0.24389389f, 
    0.06983017f, 0.23823856f, -0.23815611f, 0.02760575f, -0.66196001f, -0.39647597f, -0.36412290f, 0.40889663f, 
    0.18200186f, 0.24051228f, -0.09378326f, 0.12403650f, -0.04319443f, -0.06175538f, 0.14199553f, -0.02000567f, 
    -0.22737537f, -0.35745159f, 0.26246655f, 0.12325198f, 0.06454103f, -0.21196602f, -0.04060893f, 0.15980422f, 
    0.13390648f, 0.03162174f, 0.04494932f, -0.04139144f, -0.12154309f, 0.08412685f, 0.36605182f, 0.06707145f, 
    -0.12888938f, -0.02784123f, -0.00528663f, 0.05517783f, 0.04904522f, 0.04997544f, 0.15546395f, 0.09242692f, 
    -0.23961501f, -0.31743339f, 0.25020790f, 0.26520109f, -0.05184208f, -0.14432348f, 0.05273398f, 0.04415467f, 
    -0.03502043f, -0.09437781f, 0.06757981f, 0.09694515f, 0.22617157f, 0.06943799f, 0.00052172f, -0.19941108f, 
    -0.03145418f, 0.02574758f, 0.03987490f, 0.10663891f, 0.11202671f, -0.02670017f, 0.02154563f, -0.03263947f, 
    0.11850267f, -0.14130642f, -0.14509876f, -0.63826406f, 0.00782108f, 0.10287279f, -0.10066898f, -0.02231483f, 
    0.10065427f, 0.01473717f, -0.02816473f, 0.04241676f, 0.53914487f, -0.20213021f, 0.11401153f, -0.22476710f, 
    -0.01400792f, -0.03667546f, 0.06823812f, 0.00514918f, 0.00093903f, 0.03572672f, 0.03946374f, 0.04805163f, 
    -0.18713331f, -0.08638921f, 0.06272057f, 0.34342539f, 0.09300999f, 0.02238388f, 0.12040302f, 0.09909485f, 
    0.10765853f, 0.06807905f, -0.01900342f, 0.18363431f, 0.17894347f, -0.12694447f, 0.07366280f, 0.04075403f, 
    -0.16346805f, -0.05040870f, 0.08924033f, 0.14865273f, 0.02414685f, -0.07605466f, 0.01808215f, 0.04683897f, 
    -0.33867529f, -0.09308996f, 0.04313280f, 0.06769464f, -0.11530950f, -0.06305472f, 0.05111161f, -0.16420755f, 
    0.17760208f, -0.10303500f, 0.03759361f, -0.12749676f, -0.04042032f, 0.00874258f, 0.00244051f, 0.10834008f, 
    0.07649250f, -0.04367382f, 0.03241760f, 0.04093982f, -0.09464072f, -0.02714607f, -0.01068516f, -0.07370927f, 
    0.36487553f, 0.35589403f, -0.06394381f, -0.13986963f, 0.02735564f, 0.11468489f, 0.10041875f, -0.03304073f, 
    0.06484975f, 0.06337190f, 0.13184284f, -0.07444156f, 0.48836190f, 0.09661291f, -0.02162101f, -0.03405707f, 
    0.01522716f, -0.01694289f, -0.00486523f, -0.05458116f, 0.26891404f, 0.12474518f, 0.20561393f, 0.07041112f, 
    -0.23748818f, -0.12115762f, 0.12200218f, 0.16776139f, -0.06448298f, -0.06065696f, -0.04412893f, -0.21863225f, 
    0.05338933f, -0.10361005f, -0.02318503f, -0.02447763f, -0.29551426f, 0.26495159f, 0.24517791f, -0.04841952f, 
    -0.03042915f, -0.12700196f, 0.02797125f, -0.19635452f, -0.00176989f, 0.03819553f, 0.14249244f, -0.06082272f, 
    0.05665514f, -0.06426997f, -0.03178731f, -0.26273209f, -0.12767112f, 0.06952664f, -0.20396787f, -0.15144838f, 
    0.17598593f, 0.14230859f, -0.10256328f, -0.15082484f, -0.02456794f, 0.16533858f, 0.23076433f, 0.38750869f, 
    0.01740601f, -0.19012570f, 0.07821038f, -0.20021397f, -0.04766519f, -0.04816432f, 0.07970078f, 0.11508548f, 
    0.06894073f, 0.00673643f, 0.22136286f, -0.14203107f, -0.01631037f, -0.15050794f, -0.14725630f, -0.12703958f, 
    0.01926618f, -0.10164389f, 0.02600523f, 0.19231743f, -0.09267407f, 0.11341205f, 0.04089068f, 0.08708794f, 
    0.07899736f, 0.06910276f, 0.06131864f, -0.10050847f, -0.05406186f, -0.06837232f, 0.00382509f, 0.07692751f, 
    0.01183488f, -0.05895321f, 0.13095540f, -0.06905530f, -0.13176271f, -0.17395349f, 0.01368319f, 0.03277574f, 
    -0.08643851f, -0.10856123f, -0.38106880f, -0.01451141f, 0.27485564f, 0.36408105f, -0.10854737f, 0.16147768f, 
    -0.00999946f, -0.01491364f, 0.03521420f, 0.01140911f, -0.00129669f, -0.06955681f, 0.06134227f, -0.04085646f, 
    0.67592025f, 0.12032705f, 0.13463901f, 0.08715819f, -0.08878738f, 0.04611696f, 0.10026539f, 0.12474396f, 
    0.00453405f, 0.00117046f, -0.02183435f, -0.05935508f, 0.55587298f, 0.21197060f, -0.07914896f, 0.12813322f, 
    0.06641508f, 0.01646839f, 0.08975577f, -0.01904045f, 0.05468743f, 0.05672240f, -0.12003194f, 0.04327859f, 
    -0.09506790f, -0.01566324f, 0.23949972f, 0.23008098f, -0.09307347f, -0.00824442f, -0.03793189f, 0.00056073f, 
    -0.08268564f, -0.05244713f, -0.03173996f, -0.10262948f, 0.09234476f, -0.09884811f, 0.07294703f, 0.18799736f, 
    0.22865410f, 0.21768482f, 0.36284879f, -0.03829751f, 0.07689814f, -0.00762898f, 0.00476715f, 0.06999771f, 
    -0.58856070f, 0.11011590f, -0.26440343f, -0.24999261f, -0.01894848f, -0.17328133f, -0.18609625f, -0.18457559f, 
    0.05624213f, -0.04806063f, -0.01071430f, 0.05563846f, 0.15366361f, 0.15777907f, 0.20863360f, 0.27598462f, 
    0.02883362f, 0.01178641f, -0.01882432f, -0.06308787f, -0.02250520f, -0.00513190f, 0.08113208f, 0.03528536f, 
    0.02820448f, -0.23820685f, -0.09590781f, 0.05154162f, -0.03145322f, -0.01719123f, -0.00716675f, -0.10474631f, 
    0.02655126f, -0.31258988f, -0.03939233f, -0.02225664f, 0.41797075f, 0.08713073f, 0.11997810f, -0.00572279f, 
    0.11409864f, 0.04962389f, -0.02659301f, 0.03402243f, 0.35656077f, 0.07248324f, -0.23721485f, -0.05199437f, 
    0.16999272f, 0.06591476f, 0.36699748f, 0.16164792f, 0.10634806f, 0.11991648f, 0.17251077f, 0.13209698f, 
    -0.01955511f, -0.08907333f, 0.04618516f, 0.01214140f, 0.09112597f, -0.12851536f, -0.45961154f, -0.34939066f, 
    -0.00925014f, -0.00247921f, 0.05572125f, -0.03034835f, 0.02953017f, -0.20589641f, -0.15788789f, -0.15140218f, 
    0.00867410f, -0.06080978f, 0.03209402f, -0.06705011f, -0.01023646f, -0.00369829f, 0.05859205f, 0.04113682f, 
    -0.03853125f, 0.00172526f, -0.06633775f, 0.00380371f, 0.00327918f, 0.05357333f, -0.03189963f, -0.03537646f, 
    -0.01032521f, -0.01133798f, -0.06322253f, -0.08429244f, 0.02885273f, -0.01189297f, 0.05460773f, -0.08215397f, 
    -0.08241431f, 0.05703916f, -0.02687659f, 0.00302866f, 0.04472950f, 0.00594494f, -0.00112346f, -0.00914128f, 
    0.04210478f, -0.00298027f, 0.01635188f, 0.04936887f, 0.00745592f, 0.05332339f, -0.00760482f, -0.01971325f, 
    -0.02375391f, -0.07905528f, 0.04130758f, -0.08036605f, 0.01871528f, -0.04401669f, -0.07537800f, -0.02971786f, 
    -0.04557813f, -0.07291341f, 0.00185965f, -0.04985145f, 0.03012265f, 0.05550020f, 0.04971392f, 0.03955846f, 
    0.01194241f, 0.01387608f, -0.04487690f, -0.00308790f, 0.02332823f, -0.07602492f, -0.03111859f, -0.04345771f, 
    -0.06735353f, -0.00252469f, -0.06465821f, -0.02756950f, -0.00067995f, 0.03596806f, -0.03759101f, -0.03625694f, 
    0.04071653f, 0.02413627f, 0.00317914f, -0.03595745f, 0.00326774f, -0.03813092f, -0.05712844f, -0.07578117f, 
    0.00344035f, -0.01179463f, 0.04760818f, -0.04269796f, -0.01460213f, 0.01563944f, -0.04406762f, -0.06135928f, 
    0.00301745f, -0.06758119f, 0.05747131f, -0.00836755f, -0.08046673f, -0.00600653f, -0.06384005f, -0.08230038f, 
    0.00449985f, -0.00765161f, 0.01115427f, -0.04546918f, -0.04222124f, -0.07418784f, 0.02362333f, -0.05959523f, 
    0.05040861f, -0.03958414f, -0.01934958f, 0.03169532f, -0.08131347f, 0.02095770f, -0.04203981f, -0.02600181f, 
    -0.04392553f, 0.05804973f, -0.07753114f, -0.04593304f, 0.01700984f, -0.01815223f, 0.00063076f, 0.03887524f, 
    0.01446692f, -0.02030203f, 0.01895374f, 0.05849662f, -0.04577021f, 0.04433103f, 0.00427797f, 0.04681436f, 
    -0.00116600f, 0.02746169f, -0.04552059f, -0.01406021f, -0.01573856f, -0.00386104f, -0.03181357f, -0.06904957f, 
    -0.01421714f, -0.04376155f, 0.01378069f, 0.02716637f, -0.06074253f, 0.01910042f, 0.04357771f, -0.01655112f, 
    -0.04539678f, 0.05118649f, 0.05573181f, 0.03845937f, 0.00688896f, -0.01579992f, 0.04521232f, -0.07011676f, 
    0.03985506f, -0.04017080f, -0.02009103f, -0.05492253f, -0.05587497f, -0.05062506f, -0.01592865f, -0.06336975f, 
    -0.03000102f, 0.04576927f, -0.02888898f, -0.05654719f, -0.04803297f, 0.04569404f, 0.03154521f, -0.06140038f, 
    0.01980749f, -0.07034463f, -0.06424426f, 0.02392218f, 0.00066188f, -0.06661578f, 0.04138930f, -0.06785475f, 
    -0.01168767f, 0.03460946f, 0.02027999f, -0.05756588f, -0.03941986f, 0.01599090f, -0.03631396f, 0.05771479f, 
    0.02049247f, -0.06187680f, 0.05130948f, 0.02242404f, 0.03906621f, -0.05114388f, -0.07165699f, -0.03302152f, 
    0.26387954f, -0.09381737f, 0.08087901f, 0.15038593f, 0.06042051f, -0.08828809f, -0.07673735f, 0.00183189f, 
    0.38918850f, 0.01771536f, 0.20702851f, 0.30917281f, 0.08450042f, 0.22762372f, 0.08906017f, -0.23446952f, 
    0.02402410f, -0.07896448f, 0.12580328f, 0.03849038f, 0.01600434f, 0.03294465f, 0.07407191f, 0.09344246f, 
    0.00215767f, 0.08286276f, -0.15926740f, -0.18430832f, -0.02392597f, -0.04985781f, 0.08727559f, 0.14851576f, 
    -0.00723275f, -0.16516800f, -0.15127362f, -0.24981359f, 0.08152754f, 0.08430418f, 0.11494382f, -0.15613483f, 
    -0.03039157f, 0.12990120f, -0.02088808f, 0.10095729f, 0.02784306f, -0.05852150f, -0.10054340f, 0.02527465f, 
    0.02254060f, -0.01757500f, -0.40898052f, -0.24853514f, -0.07770857f, -0.04859149f, -0.18478665f, -0.05579765f, 
    -0.04595521f, -0.21102424f, -0.13592644f, -0.01994919f, -0.08743698f, 0.28000724f, -0.04087611f, 0.06148203f, 
    -0.18361102f, -0.09500710f, -0.02146323f, 0.08877522f, -0.03100882f, -0.09096245f, 0.14899738f, 0.19252485f, 
    -0.16231249f, 0.20185256f, -0.09089161f, -0.08997328f, -0.07327242f, -0.05065020f, 0.11161660f, 0.20184737f, 
    -0.12404278f, -0.21983804f, -0.13236922f, -0.01773903f, 0.08172374f, 0.29125044f, 0.25486222f, 0.30499214f, 
    -0.14288178f, -0.04878852f, -0.02655344f, -0.08954667f, 0.13872191f, 0.16711105f, -0.02096952f, 0.20869783f, 
    0.03857478f, 0.05438953f, 0.07856675f, -0.06843450f, -0.04003590f, 0.06568509f, -0.07936895f, -0.15742198f, 
    0.31109235f, -0.01296315f, 0.22860745f, 0.19648199f, -0.33003053f, -0.01616901f, -0.09908649f, 0.10795769f, 
    0.27545434f, 0.22264001f, 0.11421338f, 0.20481600f, 0.10368876f, 0.17489097f, 0.09762527f, 0.09714331f, 
    0.10831954f, 0.22088486f, -0.00818612f, 0.13387655f, 0.12223499f, -0.10623434f, 0.04985923f, 0.22394334f, 
    -0.07365924f, 0.13450906f, -0.19579683f, -0.22373083f, -0.02052323f, 0.19089527f, 0.09428773f, -0.07821617f, 
    -0.17021911f, -0.20998615f, -0.20712513f, -0.08336844f, 0.04572583f, -0.11165086f, -0.05095927f, -0.11510264f, 
    0.10151046f, -0.27822337f, -0.10563532f, 0.04868232f, 0.03407616f, 0.02250541f, 0.04613821f, 0.22403790f, 
    -0.14522049f, -0.09808718f, -0.22640584f, -0.40234333f, 0.26534557f, 0.22748011f, 0.10043550f, 0.03049614f, 
    -0.09389888f, -0.04870661f, -0.05176503f, -0.06695302f, 0.06212263f, -0.06077879f, -0.07110840f, 0.08746611f, 
    -0.12513201f, 0.03668822f, -0.01708033f, 0.08985264f, 0.22123721f, 0.03858253f, 0.11927629f, 0.10413548f, 
    -0.17311247f, 0.03896154f, 0.06617295f, 0.18316010f, -0.16947247f, -0.26780453f, -0.42338228f, -0.45093986f, 
    -0.07766062f, 0.08395331f, -0.04529627f, 0.24915527f, 0.21422996f, 0.20161061f, 0.20722309f, 0.05049409f, 
    -0.02796231f, -0.02636690f, 0.18706809f, -0.03844584f, 0.02260466f, 0.14817280f, -0.08319288f, 0.14433908f, 
    0.03614508f, 0.00382838f, 0.19275966f, 0.07867594f, 0.10264476f, 0.10749413f, -0.08711535f, -0.02251221f, 
    0.03990312f, -0.14152713f, 0.15953863f, 0.15085818f, -0.03569518f, -0.01324270f, 0.12336574f, 0.10655303f, 
    0.08283004f, 0.24353294f, -0.49863678f, 0.12732111f, -0.06920341f, -0.02251148f, 0.02724035f, -0.04783370f, 
    -0.01687368f, 0.03060784f, 0.15505482f, 0.02034525f, 0.56087059f, -0.00812047f, 0.15752652f, 0.30208617f, 
    -0.05161333f, 0.04520620f, 0.05747486f, -0.04270618f, -0.02367696f, 0.09819956f, -0.05281455f, -0.02419952f, 
    -0.05843257f, 0.00962921f, -0.12528276f, 0.03804894f, 0.07792565f, 0.01749051f, 0.18699129f, 0.03763198f, 
    -0.05651061f, 0.09547967f, 0.04544466f, 0.11290541f, -0.16778265f, 0.04839178f, 0.38774958f, 0.15376343f, 
    -0.04219537f, -0.08449979f, -0.04392767f, 0.01108060f, -0.10655622f, 0.03704111f, 0.20986710f, 0.15990853f, 
    0.11137525f, 0.41397685f, -0.24061093f, -0.23209679f, -0.16416615f, -0.08055706f, 0.00926253f, -0.13134593f, 
    -0.09591818f, 0.07147579f, -0.07135931f, 0.01088200f, 0.28922346f, -0.24059792f, 0.30986539f, -0.07920429f, 
    -0.04220735f, 0.02679732f, -0.13237368f, 0.10439795f, -0.15818396f, -0.07090198f, 0.06946729f, 0.14716193f, 
    -0.15292202f, 0.31467339f, 0.03800061f, 0.21439637f, 0.05492548f, 0.13646762f, -0.01871527f, -0.05929768f, 
    0.30253333f, 0.07952271f, -0.02640079f, -0.15475711f, 0.04105105f, 0.08249167f, 0.15576731f, -0.05274810f, 
    -0.09301453f, 0.21155930f, 0.07737688f, -0.02175192f, -0.09125040f, -0.11441479f, -0.02390309f, -0.06437597f, 
    0.29683828f, -0.26601538f, 0.43626258f, -0.27529594f, 0.11575549f, 0.11743209f, 0.12995560f, 0.05986495f, 
    -0.05764542f, 0.07961911f, 0.09146248f, 0.13938259f, 0.04483406f, 0.36904591f, -0.18710400f, 0.02933056f, 
    -0.18862170f, -0.08387871f, 0.10279879f, 0.08973487f, -0.08842992f, 0.06542054f, -0.02263887f, 0.00818175f, 
    -0.13602409f, -0.31323653f, 0.03578947f, 0.05548470f, 0.01130471f, -0.03785142f, -0.14384383f, -0.02164303f, 
    -0.07323201f, 0.11896921f, -0.02757299f, 0.04766237f, -0.39260566f, 0.00423406f, -0.06861714f, 0.36127329f, 
    -0.04256787f, -0.06977424f, 0.08481239f, 0.06764967f, -0.03943933f, 0.12289865f, -0.18568332f, 0.09654195f, 
    -0.19893517f, 0.07930885f, -0.25054321f, -0.17886868f, 0.00579767f, 0.01570225f, -0.19957858f, -0.04313085f, 
    0.00984085f, 0.00652344f, 0.03688414f, -0.05293290f, 0.04096546f, -0.07429618f, 0.47729734f, 0.02489202f, 
    0.00463211f, 0.02882778f, 0.43614784f, 0.09922654f, -0.04298655f, -0.06326889f, -0.16651787f, -0.10452002f, 
    0.29088116f, 0.11614190f, 0.44303533f, -0.32163215f, 0.01091639f, 0.07112224f, -0.00551300f, -0.18363474f, 
    -0.03067978f, 0.07816903f, 0.09524123f, -0.16045043f, -0.37383509f, 0.26965377f, -0.08688881f, -0.01345156f, 
    -0.09359031f, -0.01428504f, 0.00882662f, 0.04135444f, -0.06230167f, -0.11057574f, -0.03262564f, 0.10351177f, 
    -0.21256462f, 0.05399637f, -0.00373665f, 0.22956181f, -0.03594026f, 0.18528400f, 0.06259799f, -0.15078448f, 
    -0.23369856f, -0.02902160f, -0.18589583f, 0.04178344f, 0.38863465f, -0.00175170f, -0.09781554f, 0.01530382f, 
    0.07227381f, 0.15248547f, -0.09675428f, 0.02764936f, 0.06688257f, -0.03178441f, -0.04016979f, -0.08243583f, 
    -0.08785973f, 0.28051713f, 0.06754683f, 0.08704995f, 0.05196188f, 0.06451613f, 0.00183869f, -0.03829750f, 
    -0.11044686f, -0.15663369f, 0.00376977f, -0.07863784f, -0.44000468f, -0.03758873f, -0.06007008f, 0.20758416f, 
    0.04779715f, 0.04631086f, -0.05353825f, -0.01454987f, -0.02429350f, 0.03032518f, 0.03569230f, 0.12345223f, 
    0.07216045f, -0.34135050f, -0.00582890f, -0.04379375f, -0.18563999f, -0.11924445f, -0.12140559f, -0.01806008f, 
    -0.12844680f, 0.00393653f, -0.06247947f, 0.05876800f, -0.33479017f, -0.14529514f, -0.16878910f, 0.20674343f, 
    -0.01966891f, -0.08693434f, 0.00213014f, -0.00831783f, -0.07519343f, 0.03092384f, -0.01895882f, 0.09287176f, 
    -0.12695144f, 0.18304367f, -0.00452822f, 0.07915337f, -0.02764469f, 0.10846621f, 0.06799231f, 0.11411732f, 
    0.10736647f, -0.07927271f, -0.01061172f, -0.09476737f, 0.07461841f, 0.49604970f, 0.24514571f, -0.06329519f, 
    0.04217485f, 0.04128931f, 0.14714375f, 0.00278740f, -0.08591276f, 0.06071134f, 0.00373966f, -0.02625398f, 
    -0.19439420f, 0.21511889f, 0.18773030f, 0.08183397f, 0.05428755f, -0.02853205f, -0.24761552f, 0.19660591f, 
    -0.08104762f, -0.06973107f, 0.10644738f, -0.05789733f, -0.07135708f, -0.35720149f, -0.11680350f, 0.09270190f, 
    -0.08355303f, 0.09210671f, 0.05278486f, -0.06223951f, 0.10833584f, 0.13856639f, 0.07087988f, 0.02554140f, 
    -0.00446235f, -0.13376063f, 0.28995976f, -0.17989741f, -0.02105031f, -0.14341329f, -0.11587177f, 0.06758680f, 
    0.04022486f, -0.03997955f, -0.04311116f, 0.03985187f, -0.14745247f, -0.18642752f, -0.01216939f, -0.06598317f, 
    0.01702490f, -0.01752090f, -0.01265323f, -0.00721073f, -0.01657084f, 0.19687939f, 0.25696909f, -0.08018851f, 
    0.13642497f, 0.37481558f, -0.10013486f, 0.08112567f, -0.12333091f, -0.07394303f, 0.10800378f, 0.24557589f, 
    -0.02751398f, 0.02348070f, 0.04010100f, -0.00148671f, 0.32188296f, 0.32213309f, -0.17029294f, -0.04203187f, 
    0.05687838f, -0.02170313f, 0.03343779f, 0.06937906f, -0.07554773f, 0.15509988f, 0.07337039f, 0.05897321f, 
    -0.18803687f, 0.07798451f, -0.28488564f, 0.48521817f, 0.05965609f, -0.04426774f, 0.01739413f, 0.17732759f, 
    -0.00884928f, 0.16840777f, 0.01443905f, -0.07321464f, 0.31381875f, -0.05130523f, 0.36094663f, -0.09373492f, 
    -0.15674055f, 0.09831200f, -0.04466049f, 0.08081421f, 0.03648158f, 0.08574684f, 0.00957412f, -0.12458625f, 
    -0.08215919f, 0.16924286f, -0.06652963f, -0.15864803f, 0.03435215f, -0.01419237f, 0.07730424f, 0.08816988f, 
    0.21592301f, 0.00721345f, 0.22028044f, 0.02701451f, -0.38646132f, -0.13727051f, -0.01265436f, 0.04624422f, 
    0.02855423f, -0.11830645f, -0.00173410f, -0.03519511f, -0.06110577f, 0.02412350f, 0.01834875f, 0.09001433f, 
    -0.20790601f, 0.11046975f, -0.08818118f, -0.24075983f, -0.00333814f, 0.06792202f, 0.09536881f, 0.07258479f, 
    -0.08556156f, 0.07916131f, 0.10485570f, 0.05046139f, 0.33085838f, -0.06828320f, 0.21163471f, -0.25074589f, 
    0.01473340f, -0.07637448f, 0.06600516f, 0.04610055f, 0.00077558f, -0.03531095f, -0.06893239f, -0.11971068f, 
    -0.27157536f, 0.32777596f, 0.18064290f, 0.09672669f, 0.04716653f, 0.07021860f, 0.00778165f, -0.20961320f, 
    0.05449533f, -0.04404245f, 0.05667383f, -0.04385240f, 0.24355590f, 0.07928471f, 0.12534818f, -0.17624381f, 
    -0.01951924f, 0.04278349f, -0.22743581f, -0.04415852f, -0.07687130f, 0.03104094f, 0.21125948f, 0.07530970f, 
    0.06551624f, -0.05280026f, -0.06810850f, -0.13950385f, 0.17180701f, 0.07789525f, -0.10358486f, -0.04297515f, 
    -0.12867007f, 0.04877399f, 0.14704502f, 0.11421323f, -0.12448038f, -0.24484929f, 0.02412847f, 0.07287246f, 
    0.06648279f, -0.05731837f, 0.00303909f, 0.11438178f, 0.10859451f, 0.11550536f, -0.02058710f, 0.00917273f, 
    0.44371131f, -0.00088600f, 0.04255525f, 0.04710222f, 0.05581883f, 0.06195410f, 0.21374738f, -0.04695600f, 
    -0.02590839f, -0.06382693f, -0.05256914f, 0.17338812f, -0.13933969f, 0.19315240f, -0.16273105f, -0.16840078f, 
    -0.05157260f, -0.10280459f, -0.10764786f, -0.03449556f, -0.13809375f, -0.19453636f, -0.17194389f, -0.08645771f, 
    0.32204577f, 0.07187616f, -0.20822507f, 0.19348715f, -0.15168117f, 0.12399361f, -0.00224316f, 0.11354778f, 
    -0.03415209f, 0.16788861f, 0.15003248f, -0.02716401f, 0.01643815f, 0.12142333f, 0.13518165f, -0.00049994f, 
    0.01406556f, -0.00619915f, 0.06493772f, -0.11530601f, 0.03281417f, -0.00762038f, 0.02688599f, 0.11554787f, 
    -0.15398507f, -0.31649753f, 0.03129058f, 0.20963609f, -0.02219015f, 0.04006742f, -0.22597295f, -0.12238001f, 
    0.16881327f, -0.04979430f, 0.01241937f, -0.11210109f, -0.26852453f, -0.31467506f, 0.37023956f, -0.06520890f, 
    0.10530981f, 0.07908835f, -0.03891489f, 0.16234398f, 0.03131933f, 0.23765261f, 0.09012964f, 0.16886559f, 
    -0.00972716f, -0.04296526f, 0.03952688f, -0.03766852f, -0.00530003f, -0.03506472f, -0.00008481f, -0.07426852f, 
    0.01230466f, -0.00098043f, -0.06637505f, -0.04825214f, -0.05763827f, -0.06319091f, 0.04350747f, 0.03955998f, 
    -0.01354628f, 0.00913300f, -0.07618073f, 0.01294088f, 0.04548319f, 0.04320179f, -0.05946419f, -0.02426165f, 
    0.00124694f, 0.04863321f, 0.03225396f, 0.03413165f, 0.03810351f, -0.04038623f, -0.04749511f, 0.02145499f, 
    0.00594797f, 0.02960455f, 0.06168098f, -0.04809972f, 0.02888286f, -0.01623478f, -0.07595160f, 0.03162223f, 
    -0.03108481f, -0.05443741f, -0.02665261f, -0.00640972f, -0.00621293f, -0.06017179f, 0.00858994f, -0.01854070f, 
    -0.02557624f, -0.04934569f, -0.05201818f, 0.05560740f, 0.01941888f, 0.00630702f, -0.07756815f, -0.03565415f, 
    0.04313857f, 0.03082421f, 0.05054143f, 0.01009571f, -0.06176317f, 0.01476404f, 0.04674607f, 0.00343238f, 
    0.00309895f, 0.00272304f, -0.04422846f, 0.02098793f, -0.07128959f, 0.00984967f, -0.05315203f, 0.04165117f, 
    -0.03418683f, -0.07066921f, 0.00003904f, 0.04695244f, -0.05088914f, 0.04961009f, 0.03372851f, 0.03608614f, 
    0.01590574f, -0.00277782f, -0.02781943f, -0.06891752f, 0.05834680f, -0.00911339f, -0.03699652f, 0.01322760f, 
    0.02928131f, -0.07968760f, -0.05035100f, 0.02560321f, -0.05160620f, -0.01320214f, -0.04975291f, 0.02971833f, 
    -0.05781322f, 0.04993783f, 0.02721955f, -0.03150188f, 0.00888050f, 0.02569514f, 0.03122382f, 0.03115631f, 
    -0.00658548f, -0.04695316f, -0.00243991f, 0.02178475f, -0.00992660f, 0.06508700f, -0.06827298f, -0.03401998f, 
    0.00723951f, 0.00045784f, -0.07736061f, 0.06041793f, -0.07187932f, -0.04656127f, 0.01542485f, 0.00957938f, 
    0.04265875f, -0.00183077f, 0.06003370f, 0.04662536f, 0.05699466f, -0.03115855f, -0.00956362f, -0.01280245f, 
    -0.07629889f, 0.06167794f, -0.03431409f, 0.01630522f, 0.00135987f, -0.02054737f, -0.02628212f, 0.00359020f, 
    0.00809491f, -0.07084945f, 0.02559132f, -0.05024136f, -0.07128614f, -0.04631915f, 0.00163518f, 0.01831208f, 
    -0.04534098f, 0.04857318f, -0.00935614f, -0.07376087f, -0.05844064f, -0.01052595f, 0.03721181f, 0.03633675f, 
    -0.04746523f, 0.01601627f, -0.05431664f, -0.06341879f, -0.04881144f, 0.05500792f, 0.03706567f, -0.03333307f, 
    0.05520612f, 0.05806576f, -0.04000293f, -0.02523712f, -0.04453381f, -0.07461359f, -0.06528620f, -0.03206841f, 
    -0.01399469f, 0.05214235f, -0.03671979f, -0.02971190f, 0.01821790f, -0.03713775f, -0.07665833f, -0.06282844f, 
    -0.03060568f, -0.00308775f, -0.04678607f, -0.06962816f, -0.06094375f, 0.04155675f, 0.02826812f, 0.02797695f, 
    0.03238273f, 0.03521561f, 0.02604314f, -0.04918704f, -0.04740923f, 0.01819880f, -0.06638175f, 0.01091342f, 
    0.17960408f, 0.42061749f, -0.24375473f, -0.09942670f, 0.10757992f, -0.14665399f, 0.14868653f, 0.02296621f, 
    -0.00748137f, 0.15285067f, -0.19625513f, -0.16117874f, 0.29106921f, -0.06336387f, -0.05597186f, -0.01243640f, 
    -0.10135785f, 0.14290856f, 0.11126800f, -0.09652504f, 0.12205976f, -0.12874681f, -0.12292361f, -0.06310073f, 
    -0.29083455f, -0.39535111f, -0.21664934f, 0.07955663f, 0.06132529f, 0.14423077f, -0.01637447f, 0.04138846f, 
    -0.04026132f, 0.19609465f, 0.02047252f, 0.03514089f, -0.12236314f, -0.26238084f, 0.07082517f, 0.32348108f, 
    -0.01988789f, 0.03602366f, -0.00209533f, -0.17612001f, 0.04751116f, 0.04840207f, 0.13628791f, 0.10824461f, 
    -0.16239296f, 0.26946029f, 0.11675650f, 0.07936065f, -0.00129514f, 0.11286265f, -0.05775720f, 0.08304562f, 
    0.09144478f, -0.09742930f, -0.01800085f, 0.06564064f, 0.06671052f, -0.15523612f, -0.05537519f, -0.23739977f, 
    -0.06282129f, -0.01723137f, -0.10914213f, -0.05448136f, 0.02032520f, 0.00984204f, -0.01328300f, -0.02659159f, 
    0.00694288f, -0.15271592f, 0.22334227f, 0.01333116f, 0.08918675f, 0.10475425f, -0.19880965f, -0.11072294f, 
    0.11366782f, 0.04791708f, 0.02773375f, 0.05527402f, 0.04855985f, -0.01743592f, 0.15760867f, -0.05189547f, 
    0.04040613f, -0.08473776f, 0.01792959f, -0.06942935f, -0.12137737f, 0.04454250f, -0.02470058f, -0.16452165f, 
    -0.01313089f, 0.20040844f, -0.10223231f, 0.00417392f, -0.06032990f, -0.05215541f, 0.06874458f, 0.21530189f, 
    -0.05563903f, 0.08496059f, -0.03845988f, -0.05125198f, 0.02442720f, -0.15028331f, -0.14546475f, 0.10068367f, 
    -0.16562577f, -0.07296781f, 0.07772950f, -0.11470529f, 0.06690416f, -0.01048858f, 0.05616353f, -0.04500745f, 
    -0.20553012f, 0.02014239f, -0.36788544f, 0.14913480f, 0.14160569f, 0.17841099f, 0.12245366f, -0.17842725f, 
    0.05838957f, -0.02066793f, 0.23058112f, 0.08734435f, -0.20577213f, -0.28569385f, 0.03401856f, -0.09773840f, 
    0.04154694f, -0.05913431f, -0.10957958f, -0.16288804f, -0.16897707f, -0.12294490f, 0.02011710f, -0.14649823f, 
    0.09750430f, 0.45779869f, 0.35815012f, 0.03746623f, 0.03803175f, 0.03604095f, 0.06979840f, 0.02239430f, 
    0.08166641f, 0.11315566f, 0.15608379f, 0.17323853f, -0.17503110f, 0.26411653f, 0.24826950f, -0.25589788f, 
    0.03262020f, -0.02852941f, 0.03322570f, -0.04810997f, 0.19914667f, 0.15165333f, 0.08043958f, 0.06578740f, 
    -0.20179117f, -0.34929225f, -0.10602736f, 0.22045042f, -0.12148516f, -0.01717643f, -0.01307193f, 0.09561642f, 
    -0.02354497f, 0.03989675f, -0.02689853f, 0.05428096f, -0.05323761f, 0.21096863f, 0.62934154f, 0.29401582f, 
    -0.04321457f, -0.06752710f, -0.06189523f, -0.19350488f, 0.11173376f, 0.10514840f, 0.27493897f, 0.23038620f, 
    0.37888092f, 0.23064490f, -0.08894369f, 0.05451152f, 0.12347397f, 0.11448231f, -0.23533212f, 0.13749537f, 
    0.22783086f, 0.02245109f, 0.24586707f, 0.10849936f, -0.05345044f, -0.15141283f, -0.07653588f, 0.17812905f, 
    0.24685667f, -0.13600573f, -0.13763824f, 0.03851631f, 0.03705662f, -0.04545066f, 0.03369588f, 0.04948236f, 
    -0.20528063f, -0.15888797f, -0.14441894f, -0.00474740f, 0.03659697f, -0.18254338f, 0.01553710f, 0.01023038f, 
    0.12175421f, -0.04132543f, 0.05463545f, 0.05392577f, -0.09679829f, -0.01288124f, 0.41647995f, 0.23868468f, 
    -0.10165136f, 0.00451081f, -0.04720506f, -0.11911843f, -0.03368596f, -0.04867617f, 0.02525197f, 0.11965059f, 
    -0.29273638f, -0.23617601f, 0.08790287f, 0.10821374f, -0.13212310f, -0.06771064f, -0.10241232f, -0.13330142f, 
    -0.08634958f, -0.03994174f, 0.01975766f, 0.05233289f, 0.23558331f, 0.01225888f, 0.27481472f, 0.03245439f, 
    0.04079687f, 0.03894353f, 0.02294915f, 0.10760134f, -0.03797544f, 0.05662668f, 0.06002234f, -0.07519528f, 
    0.00509677f, 0.12685068f, -0.03068193f, -0.30551052f, -0.02822554f, -0.03488053f, -0.10577440f, 0.00126808f, 
    -0.00034389f, -0.00640055f, -0.04409401f, -0.13638113f, 0.48410365f, -0.14001924f, 0.43131456f, -0.15680650f, 
    -0.03103424f, -0.00458258f, -0.22377051f, 0.05404368f, -0.02915351f, -0.01949974f, 0.01340144f, 0.03942944f, 
    0.09448314f, 0.11293294f, 0.12568165f, 0.39721271f, -0.01972993f, 0.00766051f, -0.01778273f, 0.10722432f, 
    0.10272779f, 0.09844914f, -0.00750996f, 0.03293154f, 0.04715253f, -0.15665391f, 0.08225175f, 0.00525130f, 
    0.00970726f, 0.10285008f, 0.01132306f, 0.24087708f, -0.02330460f, -0.02980590f, 0.04304471f, 0.03329834f, 
    -0.02112327f, 0.05005052f, 0.10905372f, -0.12940003f, -0.01476879f, -0.12968877f, 0.23202673f, -0.13958274f, 
    0.05201266f, 0.12878916f, 0.08694088f, -0.03798031f, 0.04854957f, 0.10258593f, -0.01192803f, 0.20272961f, 
    -0.06836472f, -0.14348607f, -0.14833120f, -0.14775756f, -0.19102317f, -0.12440584f, -0.11276009f, -0.19340909f, 
    0.39608443f, 0.18347307f, -0.00638021f, -0.13770124f, -0.07655153f, 0.03647715f, -0.05060341f, 0.07724903f, 
    0.04427871f, 0.08644651f, -0.03559633f, -0.06584220f, 0.12710685f, 0.25726038f, -0.17191301f, 0.14516233f, 
    0.04440061f, -0.12746464f, 0.04283355f, -0.06013785f, 0.33097976f, 0.10252685f, 0.01113683f, 0.16454057f, 
    -0.15250264f, -0.23320477f, -0.08324557f, 0.09258680f, 0.00522780f, 0.00821772f, 0.00318243f, -0.14408620f, 
    -0.02503917f, -0.11073446f, -0.04766962f, 0.06774419f, -0.34615839f, -0.03201509f, 0.47335836f, 0.10734003f, 
    0.06307470f, -0.12380716f, 0.06802717f, -0.09903255f, 0.13059953f, -0.00400837f, 0.07259472f, 0.04655921f, 
    0.22003919f, 0.23517296f, -0.04824513f, -0.22115900f, -0.04785572f, -0.22900857f, 0.07677382f, 0.20271631f, 
    0.19268458f, 0.11014723f, -0.07847919f, 0.00637313f, -0.45873502f, 0.00764101f, -0.16088191f, 0.28430790f, 
    -0.33752903f, 0.31116414f, -0.07655105f, -0.19599530f, 0.13990735f, -0.11500572f, -0.06303695f, 0.04870005f, 
    0.05532042f, -0.07374433f, 0.33838952f, 0.09041158f, -0.06235000f, 0.20866202f, -0.09862953f, 0.13248087f, 
    0.15111001f, 0.04584956f, -0.01574880f, -0.20176220f, -0.25550950f, -0.02465491f, -0.18980891f, -0.47605458f, 
    0.01369754f, 0.16209581f, -0.05272969f, 0.24056022f, 0.03155774f, 0.01866975f, 0.10539138f, 0.09279323f, 
    0.22493339f, 0.24419957f, 0.15202911f, 0.07033895f, -0.17190787f, -0.10091932f, -0.27876416f, -0.02994951f, 
    0.14889236f, -0.04634288f, 0.16557586f, 0.02488006f, 0.14154726f, 0.00828694f, -0.08878607f, 0.05118180f, 
    -0.04473859f, -0.02957471f, 0.19164336f, -0.11016776f, 0.06585710f, 0.16561721f, -0.12106802f, 0.07204551f, 
    0.11220664f, -0.45020095f, 0.12704813f, 0.12960808f, 0.00969597f, 0.13746673f, 0.11074932f, 0.16786282f, 
    -0.05859401f, -0.06551888f, 0.11473233f, 0.19457017f, 0.07913618f, 0.26782346f, -0.02201731f, 0.25588724f, 
    -0.00016681f, -0.20605884f, 0.13319477f, -0.12141559f, 0.07260141f, 0.12917727f, -0.01179851f, -0.08096381f, 
    -0.25001284f, -0.10489058f, 0.00181856f, -0.06549948f, 0.08187114f, -0.17335595f, 0.09439232f, -0.00920701f, 
    0.04484982f, -0.04301688f, -0.02326627f, 0.15214323f, -0.22575460f, 0.12811206f, -0.24846096f, -0.22240514f, 
    0.00790426f, -0.21999665f, 0.04175484f, 0.01628994f, -0.17515211f, 0.02803226f, 0.06475513f, -0.22912784f, 
    -0.36794689f, 0.10959237f, -0.34121400f, 0.22730884f, 0.05154385f, 0.04890690f, -0.08034384f, 0.08999498f, 
    0.07156900f, 0.04981007f, 0.07108873f, 0.11037719f, 0.13348180f, -0.36393940f, 0.06330179f, 0.18178134f, 
    0.19592749f, 0.14956389f, -0.03092525f, -0.12434839f, 0.13781199f, -0.08674141f, -0.12264077f, -0.12772620f, 
    0.35784963f, 0.23551357f, 0.13273966f, -0.19412941f, -0.03375562f, -0.23066787f, 0.08658028f, 0.16836342f, 
    0.07763272f, 0.04751491f, 0.06099280f, 0.11637340f, 0.58635664f, 0.11302406f, 0.05261212f, -0.12875231f, 
    -0.04595329f, 0.00637383f, -0.05470457f, -0.02828445f, 0.03966278f, 0.19848886f, 0.28284055f, -0.03223187f, 
    -0.33430907f, 0.04758548f, -0.28315574f, -0.07893438f, -0.15349601f, -0.14226726f, 0.25514936f, -0.15099248f, 
    0.00083739f, -0.00119354f, -0.05649260f, 0.06237296f, 0.05267021f, 0.40895239f, -0.04317170f, -0.04755362f, 
    -0.11573352f, -0.12303691f, -0.34212506f, -0.11961295f, 0.14136159f, 0.22740401f, 0.17870851f, -0.08268958f, 
    -0.20083737f, 0.15182993f, -0.13455456f, 0.28284457f, 0.24726714f, -0.18635026f, 0.37090948f, 0.16708660f, 
    -0.02377934f, 0.08503851f, 0.02609525f, 0.04421348f, 0.64843136f, 0.06379008f, 0.06608453f, -0.17401943f, 
    -0.21641262f, 0.07429875f, 0.07267829f, -0.19255574f, 0.01698798f, 0.07872159f, -0.18398206f, 0.00581965f, 
    -0.27797771f, -0.16566806f, -0.40765703f, -0.09971289f, 0.17524305f, 0.05488962f, -0.01720760f, -0.03970250f, 
    0.07562405f, 0.30816120f, 0.12527691f, 0.07309256f, -0.18995367f, -0.26996118f, -0.24735701f, 0.10103945f, 
    0.01534918f, 0.01469188f, -0.11194082f, -0.11091194f, -0.05024526f, 0.00074386f, 0.04507000f, 0.02954920f, 
    -0.16294563f, 0.46771073f, -0.11480614f, -0.25872824f, -0.00686809f, 0.12881757f, -0.05786911f, 0.01756801f, 
    -0.00486788f, 0.11510021f, 0.05895238f, 0.08550058f, -0.04008124f, -0.11262001f, -0.04105369f, -0.07805415f, 
    -0.10508644f, -0.05072334f, 0.01855186f, -0.13609703f, -0.02602363f, 0.16452563f, -0.13900582f, -0.06157127f, 
    -0.32240361f, 0.08141812f, 0.41228294f, 0.38041010f, 0.00033617f, 0.04654152f, -0.09064749f, -0.10265297f, 
    -0.03272976f, -0.09292521f, -0.02730699f, 0.12731157f, -0.26809064f, 0.25397235f, 0.03886272f, -0.01945502f, 
    -0.04250538f, -0.02587437f, -0.15048797f, -0.01753900f, -0.06412701f, 0.02795514f, 0.14347325f, 0.00378003f, 
    0.11480706f, 0.15912831f, -0.15685725f, -0.30840588f, 0.12984821f, -0.08629880f, 0.07472424f, 0.02905841f, 
    -0.00623290f, 0.07523150f, 0.09991734f, 0.03827681f, -0.14602463f, -0.10294950f, -0.07617999f, 0.05553637f, 
    -0.01256975f, -0.14544706f, -0.08182155f, -0.05489084f, 0.02868191f, -0.01071762f, 0.07041853f, -0.02409201f, 
    0.12224740f, 0.11172063f, -0.26076815f, 0.08258571f, 0.08535141f, 0.20966461f, 0.15253147f, 0.10473795f, 
    0.01986857f, -0.03323925f, 0.12951089f, 0.07135625f, -0.11446016f, -0.15312582f, 0.11395777f, -0.05332521f, 
    -0.08294983f, 0.00043114f, -0.03420256f, -0.01846780f, -0.09032919f, 0.01398114f, -0.04334957f, -0.01963720f, 
    -0.00436193f, 0.38179511f, 0.20222420f, 0.03774657f, -0.02830238f, 0.03278186f, -0.00363650f, 0.03791682f, 
    -0.02544910f, 0.12919924f, 0.02639025f, 0.12462705f, -0.36021656f, 0.26275444f, 0.14889680f, -0.12958838f, 
    -0.10040956f, -0.00897215f, -0.01212306f, -0.03904626f, -0.05357312f, 0.15428011f, 0.17683235f, -0.00103972f, 
    0.12051068f, -0.19664121f, -0.19839473f, 0.24630767f, -0.06252776f, 0.01197700f, -0.03134581f, 0.02569402f, 
    0.04149611f, -0.01169353f, 0.01757178f, 0.06740214f, 0.01018653f, -0.02426806f, 0.30366784f, 0.16560134f, 
    0.01438722f, 0.05416938f, -0.04852878f, 0.23849539f, 0.00609149f, 0.22486459f, 0.03712414f, 0.23418160f, 
    0.02658284f, -0.07061881f, 0.00628770f, 0.02226866f, -0.01498585f, 0.03862344f, 0.05234753f, -0.00929273f, 
    -0.06506356f, -0.04081432f, -0.02624159f, -0.03482035f, -0.03093274f, -0.05205633f, -0.01293113f, 0.03052103f, 
    -0.06159609f, 0.03023587f, 0.02258200f, -0.02417699f, -0.05626947f, -0.01903987f, -0.04919026f, -0.04307567f, 
    0.05361446f, -0.02708613f, -0.03113933f, -0.01035490f, 0.05086412f, 0.03120385f, 0.06759437f, -0.02747167f, 
    -0.00939136f, -0.05568660f, 0.03363533f, -0.01359300f, 0.02317903f, -0.07580360f, 0.02828092f, -0.07122846f, 
    -0.05946517f, 0.06603406f, 0.05577618f, -0.01641602f, -0.02484405f, -0.06154219f, -0.05142853f, -0.05918062f, 
    -0.01057748f, 0.05292146f, -0.01290422f, -0.02731569f, -0.06259859f, -0.06544989f, -0.03984359f, 0.03799330f, 
    0.01119089f, 0.00659709f, 0.01336060f, 0.05257403f, -0.02131912f, 0.06391726f, -0.04012478f, -0.04701121f, 
    0.02527355f, -0.05084023f, -0.03497688f, 0.00807136f, -0.03347213f, -0.02147400f, -0.03948791f, -0.06651685f, 
    0.05725074f, 0.01348145f, -0.00739719f, 0.04979846f, 0.02780179f, -0.03219299f, 0.02962136f, 0.06691805f, 
    0.05129975f, -0.05300022f, -0.06234057f, -0.04987820f, -0.04307827f, 0.00886654f, -0.06235441f, -0.05172843f, 
    -0.06461325f, -0.03227489f, -0.00296713f, 0.00315002f, 0.02222298f, -0.03256847f, -0.05416287f, -0.06726485f, 
    -0.01769644f, 0.03111799f, 0.02048373f, -0.00109166f, 0.05263317f, 0.05490891f, -0.02664388f, 0.03808538f, 
    -0.02170953f, 0.00464522f, 0.02081088f, 0.06054339f, -0.07649589f, 0.05626254f, -0.05120811f, -0.06712613f, 
    0.01834405f, 0.02399895f, -0.01590664f, -0.06340113f, 0.01811733f, -0.01921458f, 0.00061227f, 0.04080374f, 
    -0.00584701f, -0.04640553f, -0.06491519f, 0.05642560f, -0.02693001f, -0.03804189f, -0.03418327f, -0.07297374f, 
    0.02033894f, -0.01644193f, 0.02316198f, 0.03699566f, 0.03070139f, 0.01889808f, 0.01207458f, -0.04118294f, 
    0.04303121f, 0.02686696f, -0.07750027f, 0.00725710f, 0.02577940f, -0.02770439f, 0.01894522f, -0.04659519f, 
    0.02701515f, 0.05936086f, 0.07583611f, -0.02752968f, 0.06129498f, -0.01047295f, -0.02685331f, 0.00758598f, 
    -0.02449275f, -0.03321502f, -0.00453685f, 0.02922525f, -0.00098112f, 0.04182041f, -0.05134891f, 0.03453963f, 
    0.00693505f, 0.05090388f, -0.04890030f, -0.07216827f, -0.03748922f, -0.04747891f, -0.03567250f, 0.05744191f, 
    -0.05350860f, 0.01105517f, -0.04153547f, 0.01524593f, -0.06613439f, 0.02555353f, 0.01996918f, -0.06662583f, 
    0.03910346f, -0.05655370f, -0.00792647f, -0.02007492f, -0.01911792f, -0.07624073f, 0.00556472f, 0.03883992f, 
    0.00779159f, -0.07258392f, 0.01770357f, 0.03314517f, 0.06341193f, 0.04163381f, -0.07553475f, -0.02429055f, 
    -0.44718191f, 0.35518235f, 0.12870003f, -0.00458892f, 0.01540729f, 0.16197529f, 0.03243196f, -0.22779925f, 
    0.06968833f, 0.09253497f, 0.15465879f, -0.07401403f, 0.47497934f, 0.19796178f, 0.18316495f, -0.31831786f, 
    -0.03772395f, -0.03187376f, 0.03872258f, 0.04508351f, -0.07153885f, 0.07983340f, 0.02437783f, -0.14065857f, 
    0.00406930f, -0.03502653f, -0.27183604f, -0.00556834f, 0.10972175f, -0.04731449f, 0.10230795f, 0.03329607f, 
    -0.00757546f, 0.06117161f, 0.09051281f, -0.17083111f, -0.08401133f, -0.19752117f, 0.10523468f, 0.16637748f, 
    0.03706635f, -0.08474758f, 0.00301621f, 0.15032235f, 0.05128470f, 0.08075771f, -0.10100052f, 0.07613532f, 
    -0.04173049f, 0.09318595f, 0.01960888f, 0.02303444f, 0.00353785f, -0.00936942f, -0.00037232f, 0.02370762f, 
    0.11534834f, -0.09390391f, -0.00663366f, -0.04537703f, -0.16042508f, 0.15358871f, 0.37758186f, -0.18840413f, 
    0.00051920f, -0.08898912f, -0.21250702f, 0.03364754f, -0.03945801f, -0.12864260f, 0.10403912f, -0.00141459f, 
    0.01695590f, 0.47979474f, 0.06739829f, -0.09164973f, -0.05517675f, 0.04564852f, -0.08599064f, 0.09876154f, 
    -0.08155913f, -0.10312688f, 0.00560260f, -0.10210083f, -0.07522848f, 0.07821985f, 0.32256731f, 0.00085534f, 
    -0.05340802f, -0.08511607f, -0.03120691f, -0.10333618f, -0.02818848f, 0.04174427f, 0.04667589f, 0.18695317f, 
    0.08237130f, 0.11576825f, -0.05623540f, -0.09073286f, -0.09463588f, 0.03737766f, 0.08283877f, 0.02216575f, 
    0.01424832f, 0.15010513f, 0.10834400f, -0.01221432f, -0.16403326f, -0.17260699f, -0.12147982f, 0.16317698f, 
    -0.07676038f, 0.12353922f, 0.09830811f, -0.37677217f, 0.04495130f, 0.04294729f, -0.06911388f, 0.01220440f, 
    0.26632509f, 0.13394827f, -0.13687581f, 0.31023759f, 0.31378263f, 0.12857248f, 0.11825036f, 0.07603624f, 
    -0.06390122f, -0.03145256f, 0.06997107f, 0.00678192f, -0.15375875f, 0.17945859f, 0.17932376f, -0.58721900f, 
    -0.17254403f, -0.18383768f, -0.16348197f, -0.05133833f, -0.12614946f, -0.13292161f, -0.03086956f, -0.12635829f, 
    -0.17611809f, 0.11058971f, 0.02785281f, 0.33424285f, 0.02888057f, -0.04151481f, 0.03130303f, -0.05806626f, 
    0.08646027f, 0.18646915f, 0.08235931f, 0.13625263f, -0.32928255f, 0.30099601f, 0.23612513f, -0.17057672f, 
    0.00962680f, -0.14572223f, 0.00681729f, -0.08265762f, 0.01504787f, 0.04779870f, 0.03209589f, 0.19561653f, 
    -0.30359089f, -0.47284991f, -0.20592396f, 0.16675666f, 0.02037319f, 0.03291265f, -0.11131653f, 0.09420937f, 
    0.11121138f, -0.00070885f, 0.07393567f, -0.00773198f, 0.15591802f, 0.07140025f, 0.14074960f, 0.00009002f, 
    -0.18727513f, -0.06675938f, 0.15782325f, 0.13518330f, 0.07483470f, -0.02740444f, 0.07938682f, 0.09094395f, 
    0.08680689f, 0.14573233f, 0.19000500f, -0.16114618f, -0.16866320f, 0.07015458f, -0.02640773f, 0.15721312f, 
    -0.00331363f, -0.10331201f, 0.11974265f, -0.25085032f, -0.12017905f, -0.14076877f, -0.45517516f, 0.28482664f, 
    0.22592841f, 0.05243137f, 0.16956376f, -0.10745256f, -0.04647932f, -0.10063687f, -0.10195228f, 0.07468331f, 
    -0.30630043f, -0.26745147f, -0.06234394f, 0.21571344f, 0.08654845f, 0.06677826f, -0.00602558f, -0.07179571f, 
    0.00917850f, 0.15119232f, -0.01031898f, 0.14974847f, -0.09281569f, -0.24799594f, 0.13162321f, 0.29070851f, 
    -0.00585278f, 0.08787925f, -0.00392051f, -0.05600143f, 0.02246856f, 0.09079778f, 0.02253037f, 0.09706193f, 
    -0.16308351f, 0.04553216f, 0.17865099f, 0.09706829f, -0.06160054f, -0.03092361f, -0.00905004f, -0.11831764f, 
    0.04128874f, 0.05656366f, -0.01518450f, -0.08663403f, 0.13864040f, 0.00618756f, -0.02485467f, 0.10263642f, 
    0.02360592f, 0.09278958f, -0.01423296f, -0.02004382f, 0.01792572f, 0.04307723f, 0.01773406f, 0.11533552f, 
    0.29941401f, -0.15281211f, 0.17903170f, 0.07553922f, 0.01777640f, -0.08373684f, -0.11257967f, 0.05046796f, 
    -0.01148077f, -0.09546367f, -0.03930043f, 0.01346030f, 0.28821224f, -0.10547993f, 0.17329045f, 0.00855325f, 
    0.01233086f, 0.00772770f, 0.00198282f, -0.04534592f, -0.10739145f, -0.16726251f, -0.05603124f, -0.06169985f, 
    -0.12278158f, 0.08593512f, -0.04385221f, 0.11844556f, -0.04608519f, -0.00832060f, -0.00184522f, 0.04253221f, 
    0.13024727f, 0.08940673f, -0.27471960f, -0.30110529f, 0.02515565f, 0.04190928f, 0.12323241f, 0.17777868f, 
    -0.02101406f, 0.13322178f, 0.20566408f, 0.07514468f, -0.08096315f, -0.09468093f, 0.14263190f, -0.05748621f, 
    -0.25896007f, -0.12954667f, -0.03245240f, 0.15243292f, -0.01448231f, -0.06326147f, -0.08306412f, -0.06915251f, 
    -0.12872933f, 0.06150544f, 0.11908593f, 0.01466336f, -0.03144442f, -0.18409249f, -0.21720524f, 0.21180157f, 
    -0.04967136f, -0.02414985f, -0.03641445f, -0.15196861f, -0.11173470f, 0.02565735f, -0.03295683f, -0.13872752f, 
    0.12362838f, 0.29871720f, 0.32633737f, -0.04310888f, 0.04365737f, -0.00226840f, -0.13150732f, 0.01991554f, 
    0.03537777f, -0.19248232f, -0.00085595f, 0.09437142f, 0.09458660f, 0.26232502f, 0.00556323f, 0.01375803f, 
    -0.04287597f, -0.12077329f, 0.01372409f, -0.04875099f, 0.12703915f, 0.03751080f, 0.05757838f, 0.01812751f, 
    -0.24984339f, -0.02758373f, 0.04100343f, 0.36978155f, -0.08896943f, 0.06568102f, -0.01517255f, 0.19563228f, 
    0.01709562f, 0.08281773f, 0.06892237f, 0.06758752f, 0.30261800f, 0.51399946f, 0.32421583f, 0.05247933f, 
    -0.05559103f, -0.17541087f, 0.11840180f, -0.12401384f, 0.00792827f, -0.01451356f, -0.02602437f, -0.06136515f, 
    0.79402089f, -0.03962908f, 0.03866579f, -0.04124241f, 0.01939609f, 0.16633564f, -0.22557575f, -0.04939763f, 
    0.29777062f, 0.01372554f, 0.08143428f, 0.14539140f, -0.16753572f, -0.09240950f, 0.07072931f, 0.04580832f, 
    0.20388992f, -0.21606503f, 0.04184979f, 0.19439960f, 0.06175860f, -0.08486871f, 0.17102605f, -0.03939901f, 
    0.04198410f, -0.09726564f, -0.11363173f, 0.11191159f, 0.06276458f, -0.02295252f, 0.17725576f, 0.10790879f, 
    -0.08059314f, -0.20982060f, -0.02527673f, -0.02302762f, 0.21459173f, 0.16339405f, 0.25371367f, 0.02021521f, 
    -0.14748387f, 0.03398555f, 0.00988559f, 0.03140808f, -0.03529460f, 0.06241083f, 0.03516132f, 0.04469613f, 
    0.00890211f, -0.39363426f, -0.15189511f, 0.11313242f, -0.09428275f, 0.00939902f, 0.03525794f, -0.03148798f, 
    0.16934203f, -0.11748684f, 0.10440470f, 0.09959330f, 0.03119902f, 0.11546025f, 0.28058565f, 0.13763693f, 
    -0.02509452f, -0.01014301f, 0.01846459f, 0.06816222f, -0.11442354f, -0.08157706f, 0.07235482f, 0.09305244f, 
    0.10665279f, 0.22421300f, -0.21052262f, -0.31243262f, -0.06774718f, 0.04116409f, -0.02618793f, 0.11187717f, 
    -0.06776177f, 0.04732116f, 0.01573947f, 0.00924841f, 0.42530203f, -0.11059329f, 0.38287547f, 0.04490140f, 
    -0.10546844f, -0.07170976f, 0.01566095f, 0.11805559f, -0.02027190f, 0.06703147f, 0.07948380f, -0.03493170f, 
    0.06379916f, 0.04068381f, 0.11561684f, 0.28533736f, -0.00986794f, 0.02585385f, 0.00937605f, -0.10074919f, 
    0.34605536f, 0.01693048f, -0.07505604f, 0.07974385f, 0.00246703f, -0.10127067f, -0.11498864f, -0.15211584f, 
    -0.05457746f, 0.19118127f, 0.00850844f, 0.08042024f, -0.07274024f, -0.04243527f, -0.09762646f, 0.02817183f, 
    -0.24288985f, -0.16635729f, 0.24204238f, -0.09237830f, 0.10473559f, -0.10897520f, 0.07548561f, -0.14156573f, 
    0.06248009f, 0.11246222f, 0.14797114f, -0.13938411f, 0.10801612f, 0.27285379f, 0.04838625f, 0.19012837f, 
    -0.09274352f, -0.09430011f, -0.01664048f, -0.01783859f, -0.15766922f, -0.09490009f, 0.04774265f, -0.06205093f, 
    0.23903467f, -0.20652728f, 0.11346285f, 0.00164367f, 0.05965978f, 0.00465911f, -0.01139768f, 0.09245737f, 
    -0.19311260f, -0.02741445f, 0.02539701f, -0.28685170f, 0.09944692f, 0.08845837f, 0.02408762f, 0.27445623f, 
    -0.04384118f, -0.03843978f, 0.12043799f, 0.13036269f, 0.19536474f, 0.05154317f, -0.05020416f, 0.18708424f, 
    0.02859626f, 0.02936992f, 0.00413493f, -0.17196417f, 0.01922746f, -0.11492021f, -0.02776952f, -0.10398216f, 
    -0.01998100f, -0.05365835f, -0.03598760f, 0.06726204f, -0.47046942f, -0.33342651f, 0.00815407f, -0.26997072f, 
    -0.02079584f, 0.05642414f, 0.16878577f, -0.06536333f, 0.08630857f, -0.09866659f, 0.06045996f, -0.00053193f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.03474337f, 0.12725636f, -0.04712768f, -0.01524140f, -0.06553864f, 0.02986331f, 0.02519986f, -0.01831438f, 
    0.10764232f, 0.20468634f, 0.05494410f, 0.15094250f, -0.00089492f, 0.09321375f, 0.00006261f, -0.05629713f, 
    -0.05292477f, 0.00768891f, 0.06934694f, 0.09266540f, 0.00419331f, -0.00629924f, 0.22895783f, 0.02090832f, 
    0.18307033f, 0.03572080f, -0.00306687f, 0.24766591f, 0.05949714f, -0.10724755f, -0.05720438f, 0.11348089f, 
    0.06749583f, 0.02093044f, 0.08289891f, -0.04033915f, -0.02373010f, 0.15090494f, 0.06496113f, -0.01369284f, 
    -0.07522292f, 0.00713401f, 0.12791206f, 0.03572977f, -0.01037050f, -0.04892011f, 0.15249033f, 0.25007007f, 
    0.16201411f, -0.05474491f, 0.04659530f, 0.13785787f, 0.02413252f, -0.09641450f, -0.01563142f, -0.03116385f, 
    0.13299096f, 0.34929237f, 0.13656336f, -0.05619997f, -0.03342249f, 0.02200648f, 0.01791598f, 0.18031906f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.09455545f, 0.01202305f, 0.26131251f, -0.09827184f, 0.00393568f, 0.01093940f, -0.01842453f, 0.02227937f, 
    -0.46014601f, -0.75134742f, 0.08123995f, -0.59768558f, 0.15802252f, 0.11397916f, 0.02124837f, 0.32652375f, 
    0.10005998f, -0.08301400f, 0.20486416f, -0.37618110f, 0.12248468f, -0.07025328f, -0.45658588f, -0.08376638f, 
    -0.03512783f, -0.10743700f, -0.03710735f, -0.05942949f, 0.13545588f, 0.15790364f, 0.05289162f, -0.26329020f, 
    0.01247190f, 0.23044345f, -0.15434544f, -0.06384229f, 0.20442440f, -0.01944102f, -0.29837576f, 0.06976315f, 
    0.12161904f, -0.16571581f, -1.08480597f, -0.28313822f, 0.25740889f, -0.08256515f, -0.33639795f, -0.09124524f, 
    -0.34981957f, -0.15157962f, -0.10723976f, -0.27041361f, 0.14530489f, 0.23526055f, -0.22396019f, 0.04930402f, 
    -0.50926679f, -0.45351592f, 0.16232117f, -0.24313489f, -0.02718964f, -0.47850183f, -0.35847658f, 0.01535913f, 
    0.13663436f, 0.06910287f, -0.10528838f, 0.02988601f, 0.04588896f, -0.14146098f, -0.11562002f, 0.06857777f, 
    -0.11722406f, 0.23364314f, 0.23629516f, 0.21211103f, 0.06553847f, 0.11302202f, -0.05210620f, -0.13739488f, 
    0.01315058f, -0.26613718f, -0.05322195f, 0.58374715f, -0.63358253f, -0.02431218f, 0.14097673f, 0.07097871f, 
    0.06179406f, 0.27617151f, 0.08690061f, 0.09006389f, -0.13176204f, 0.02060920f, -0.00501496f, 0.13931452f, 
    0.06672878f, 0.25625116f, 0.17979394f, 0.09065570f, -0.09499775f, -0.11628936f, -0.16949502f, 0.11543307f, 
    -0.24069344f, -0.28631479f, -0.37256822f, -0.99779564f, 0.36336553f, -0.06996746f, -0.17181166f, 0.22922350f, 
    0.12806439f, 0.09058491f, 0.09627861f, 0.24059470f, 0.06219967f, 0.13871312f, -0.24957210f, -0.06374683f, 
    -0.04500815f, 0.15892929f, 0.10373361f, -0.32769394f, 0.02596181f, -0.07918055f, 0.14841874f, 0.32254285f, 
    0.02932813f, 0.09990045f, -0.22653627f, 0.15154976f, 0.10752561f, -0.09704782f, 0.07388783f, -0.08311827f, 
    -0.09535646f, 0.33057770f, 0.24357647f, -0.29506037f, -0.07898033f, 0.17053579f, -0.06669468f, -0.06413952f, 
    0.04786343f, 0.11934531f, 0.02481831f, -0.88236237f, 0.25818121f, 0.09703188f, 0.19559895f, 0.01168271f, 
    -0.13106678f, 0.41152814f, -0.03125441f, -0.39262268f, -0.14600822f, -0.60182935f, 0.00902935f, -0.17596634f, 
    0.16332020f, -0.15402320f, -0.04665764f, -0.09174130f, -0.16521056f, 0.06301131f, 0.09384872f, -0.03996856f, 
    0.17537151f, -0.05739919f, 0.36782753f, -0.19409685f, -0.66862535f, -0.04806814f, 0.06957683f, 0.03264602f, 
    0.16930020f, -0.05119282f, 0.05838111f, -0.26214847f, 0.17407480f, -0.17395732f, 0.03878450f, -0.01204673f, 
    0.18486795f, 0.30011842f, -0.25647229f, -0.10196712f, 0.00249432f, 0.46680576f, 0.08733877f, 0.10444213f, 
    -0.02119355f, 0.27321398f, 0.34555617f, 0.16059688f, 0.00314789f, 0.06934492f, -0.11062692f, 0.03517477f, 
    -0.30591518f, -0.27833357f, -0.33991072f, 0.54525900f, 0.13431782f, -0.16202092f, -0.00761095f, 0.06832517f, 
    0.03926024f, 0.26875636f, -0.14111401f, -0.11396675f, 0.21424457f, 0.02057640f, 0.21245725f, -0.03847778f, 
    -0.56313473f, 0.30903542f, -0.10149742f, -0.39175242f, -0.48511177f, 0.05766944f, -0.10848832f, -0.21426766f, 
    -0.66913754f, 0.07444361f, 0.06143412f, -0.10483001f, 0.03619841f, 0.16760394f, -0.07217826f, -0.43739256f, 
    0.15510379f, -0.37311852f, 0.11709635f, -0.03253572f, -0.10985103f, -0.10523788f, -0.12561648f, -0.70553917f, 
    -0.60773993f, -0.03524473f, -0.02085095f, -0.12206788f, -0.09761719f, 0.02002685f, 0.31183362f, -0.09689512f, 
    0.17322353f, -0.11747656f, -0.17793210f, 0.42452180f, -0.02090222f, 0.17489417f, 0.00027353f, -0.59735930f, 
    -0.02810502f, -0.36378011f, -0.21904007f, 0.06235275f, -0.06014291f, -0.04314309f, -0.00102136f, -0.10435206f, 
    0.15801623f, -0.37497222f, 0.10834480f, -0.29562151f, 0.17316256f, -0.24485467f, 0.07012201f, -0.22884002f, 
    -0.11178939f, 0.03718007f, 0.20252109f, -0.16644312f, 0.15862314f, -0.01437414f, -0.47514898f, 0.06528662f, 
    0.05258470f, -0.51873416f, -0.09534193f, -0.76319766f, 0.29115364f, 0.18613617f, -0.02436669f, -0.02198733f, 
    0.00863137f, 0.16705523f, -0.22155151f, 0.09448130f, 0.00168748f, -0.02774712f, 0.30338714f, -0.11984773f, 
    0.16901857f, -0.12137967f, 0.20069759f, 0.30602747f, 0.29358107f, 0.03086466f, -0.20341878f, -0.21119153f, 
    0.02754390f, 0.31630534f, 0.07478701f, -0.61518562f, -0.06143415f, -0.07861684f, -0.12181609f, -0.11433928f, 
    0.07048301f, 0.08627960f, -0.94606775f, -0.09954879f, 0.07161237f, -0.32104784f, 0.31982383f, -0.07987808f, 
    0.06480777f, 0.06422214f, 0.10430427f, -0.36397073f, 0.06398849f, 0.08048815f, -0.01112174f, -0.02950726f, 
    0.21966340f, 0.03673244f, -0.36593071f, -0.19384515f, 0.14333230f, -0.32122344f, -0.04360842f, 0.16245490f, 
    0.06906154f, -0.12793021f, 0.25687042f, -0.16597192f, -0.45964819f, -0.02116927f, 0.08805640f, -0.08564986f, 
    -0.24679784f, -0.39662769f, -0.09149008f, 0.15051864f, 0.32801765f, 0.11527476f, -0.11803322f, -0.28183338f, 
    0.13604246f, 0.12297492f, 0.09774868f, 0.05623951f, 0.03643528f, 0.25305220f, -0.39817727f, -0.27550402f, 
    -0.05995636f, 0.26717719f, 0.00913543f, 0.24547227f, -0.21822961f, 0.05481630f, 0.23134081f, 0.05646911f, 
    0.14778280f, 0.06885337f, 0.02738750f, 0.22480686f, -0.23920968f, -0.19637199f, 0.08614259f, 0.02880090f, 
    -0.32873210f, 0.14295037f, 0.05614735f, -0.31334877f, -0.10596200f, -0.20201522f, -0.26062050f, 0.13182585f, 
    -0.03208982f, -0.33873883f, -0.09560816f, 0.05716586f, -0.04280920f, -0.13433979f, 0.07818738f, 0.00245346f, 
    0.24084748f, -0.48114389f, -0.04853594f, 0.30981991f, -0.50945234f, 0.26794600f, -0.09426665f, -0.12403630f, 
    0.07404567f, -0.04033651f, -0.02409614f, 0.07636375f, -0.04270688f, 0.07311711f, -0.37020984f, 0.00233305f, 
    0.28051499f, -0.14176492f, 0.06942686f, 0.11622655f, 0.09359689f, -0.79047048f, 0.10772540f, 0.40919054f, 
    0.18973528f, -0.60211211f, -0.14540406f, -0.09597985f, -0.39192888f, 0.24009225f, -0.02827791f, -0.28957853f, 
    -0.00020046f, -0.27907011f, 0.17081232f, 0.15958992f, -0.45436510f, 0.06388137f, 0.03442517f, 0.20831655f, 
    0.28262615f, -0.27375600f, 0.10074772f, -0.33664146f, -0.24407603f, -0.57940733f, 0.30044201f, -0.06171538f, 
    0.32345191f, 0.30515525f, 0.28609005f, 0.18360451f, -0.11905537f, -0.16082323f, 0.13996319f, -0.04324021f, 
    0.22857207f, -0.36144257f, 0.09516592f, 0.20480569f, 0.02327050f, -0.39278886f, -0.07991503f, 0.09506783f, 
    0.16099027f, 0.23850651f, -0.48148823f, -0.06252981f, -0.10407692f, -0.05893212f, -0.00599910f, -0.16929944f, 
    0.01164614f, 0.01599615f, -0.25028330f, 0.14671952f, 0.26636934f, -0.02424615f, -0.43512958f, -0.00062022f, 
    -0.02327071f, 0.35443884f, 0.09375518f, -0.16015165f, 0.14469410f, 0.34174049f, -0.01008200f, -0.36214799f, 
    0.15298501f, -0.54167098f, 0.05965148f, 0.09969247f, -0.38906899f, -0.47013178f, 0.11623885f, 0.14513475f, 
    -0.16166033f, 0.31605089f, -0.05671807f, 0.44038174f, -0.32063058f, 0.02633950f, -0.05262182f, -0.30057693f, 
    -0.14961751f, -0.02254367f, 0.10280247f, 0.23058982f, -0.19587909f, -0.10942280f, 0.17904063f, -0.02417397f, 
    -0.08996353f, -0.58231801f, 0.09205926f, -0.02693929f, 0.04870510f, 0.23744649f, -0.32978529f, -0.19075990f, 
    -0.38642991f, 0.17878908f, 0.28866243f, -0.46422598f, -0.04117554f, -0.58867741f, -0.07294235f, -0.07554666f, 
    0.02738373f, 0.03553594f, 0.13288696f, 0.06678685f, -0.11764045f, 0.18495578f, 0.11429718f, 0.18875739f, 
    0.01708831f, 0.07113778f, -0.57390368f, -0.30976111f, -0.50858867f, 0.08247094f, 0.10543526f, 0.01014300f, 
    0.17481644f, 0.15520753f, -0.07832435f, 0.21820535f, 0.22069800f, 0.20096061f, 0.08243448f, 0.24165712f, 
    -0.15711284f, -0.66219157f, 0.13453020f, -0.01431872f, 0.27182874f, -0.32142350f, 0.05585601f, -0.24523327f, 
    -0.12674639f, 0.34868333f, 0.53237134f, -0.12129816f, -0.55939692f, 0.10188921f, -0.22952737f, 0.05280646f, 
    -0.46498129f, -0.23136120f, -0.04082301f, 0.31346723f, 0.14284702f, -0.30767462f, 0.05087044f, -0.04296860f, 
    0.06241164f, -0.01662095f, -0.52518934f, 0.34914264f, 0.10593096f, 0.20474198f, -0.46971664f, 0.13279893f, 
    -0.11343484f, 0.19954890f, -0.41364300f, 0.21334240f, -0.06507181f, 0.30687544f, -0.05830896f, 0.01364546f, 
    -0.21617234f, 0.05601806f, 0.47338912f, 0.04087524f, -0.38645130f, -0.19720827f, -0.02787883f, -0.36669868f, 
    0.03270872f, 0.23906013f, 0.28440633f, -0.14945143f, 0.20442255f, -0.00293525f, 0.08393326f, 0.06151989f, 
    0.12033749f, -0.19329822f, -0.05975682f, 0.25771704f, 0.00190824f, 0.02566030f, 0.07855630f, -0.54443240f, 
    -0.02647416f, -0.26576921f, -0.47080532f, 0.05240641f, -0.18669575f, -0.39989996f, 0.06891769f, 0.05987252f, 
    -0.07188902f, 0.32126328f, -0.08009770f, 0.37530780f, 0.25369471f, 0.02704891f, 0.25154579f, 0.30535343f, 
    0.06545146f, -0.17533164f, 0.09954045f, -0.44630709f, -0.70365977f, 0.37390137f, -0.36903819f, -0.02742659f, 
    0.16377935f, -0.19488448f, 0.31534255f, 0.05041187f, 0.07598253f, -0.10729056f, 0.19271113f, -0.33398482f, 
    -0.02284345f, 0.42690673f, -0.34893477f, 0.34248915f, -0.07954724f, 0.22607803f, -0.08929154f, -0.02977448f, 
    0.25636527f, 0.21692842f, -0.28528413f, 0.02543175f, 0.14537176f, 0.39131275f, -0.09945772f, 0.39650676f, 
    -0.08895458f, -0.26886243f, -0.02295704f, -0.18160687f, -0.78290170f, -0.02114950f, 0.38027263f, -0.07146597f, 
    -0.50239891f, -0.08434139f, 0.04556053f, 0.14373498f, -0.11564813f, -0.03465803f, -0.02378649f, 0.35158503f, 
    -0.84372890f, -0.35837856f, -0.50661218f, 0.01104905f, -0.30350640f, 0.25212514f, 0.37242648f, 0.32305586f, 
    -0.17046845f, -0.65914357f, 0.27355623f, -0.33880663f, -0.27776870f, 0.01688847f, -0.33063665f, -0.24727213f, 
    -0.17622142f, -0.60961902f, -0.01309379f, 0.18380414f, 0.26459122f, 0.31209549f, -0.01151184f, -0.02402353f, 
    -0.25548851f, 0.04409754f, 0.13037716f, -0.03002240f, 0.10658140f, -0.07012442f, 0.28766397f, -0.22212981f, 
    -0.74550927f, 0.07579070f, 0.13925400f, 0.13595870f, 0.07486337f, 0.13920842f, 0.08048517f, 0.06293287f, 
    0.19076358f, -0.31833437f, -0.39321041f, 0.27578884f, -0.05501948f, -0.34981868f, 0.07100190f, -0.56421399f, 
    -0.08492306f, -0.37488303f, -0.22085251f, -0.17034215f, 0.37795255f, -0.12769650f, 0.25211895f, -0.09379172f, 
    0.06413125f, -0.61121905f, 0.04059553f, 0.12058841f, -0.58052486f, 0.30575404f, 0.00248217f, 0.19355001f, 
    -0.04417282f, -0.13105144f, 0.06134913f, -0.12394095f, -0.53376728f, 0.10320050f, 0.39158010f, 0.37109512f, 
    0.03717808f, -0.16631477f, -0.31959802f, -0.32238743f, -0.73568964f, -0.03324625f, 0.34249049f, 0.22448958f, 
    0.06683283f, -0.28800529f, 0.08285303f, -0.22300781f, 0.40828344f, -0.29901129f, 0.28446984f, 0.00368276f, 
    -0.17648280f, 0.29778329f, -0.40044326f, -0.05134131f, 0.04025022f, 0.03472197f, -0.17128204f, 0.24701679f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.04029144f, 0.08714548f, 0.05565846f, -0.10762914f, 0.07143209f, 0.17047158f, 0.01343113f, -0.10325851f, 
    0.07698074f, -0.07704579f, -0.11778883f, -0.03016330f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
