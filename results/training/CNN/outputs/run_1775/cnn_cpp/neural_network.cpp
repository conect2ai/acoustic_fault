#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.03549907f, 0.32935208f, -0.00889376f, 0.11463664f, -0.45926550f, 0.57195562f, -0.15802957f, 0.06617749f, 
    0.09401021f, -0.17941362f, -0.60574383f, -0.20077311f, 0.16491649f, -0.20618288f, 0.02360727f, -0.21579127f, 
    -0.30817044f, -0.38411584f, -0.27297369f, 0.41955042f, 0.59995311f, -0.08626389f, -0.07368584f, -0.28099802f, 
    0.32914904f, 0.06748115f, 0.13585396f, -0.69389313f, -0.12545682f, 0.09523873f, -0.38645619f, 0.93842328f, 
    -0.58588797f, -0.23042546f, -0.17891926f, -0.09877757f, -0.57140779f, -0.66448915f, -0.41808748f, 0.39016238f, 
    0.37966534f, 0.10590988f, 0.40258890f, -0.50081569f, 0.15171748f, -0.46079594f, -0.38411754f, 0.22374368f, 
    0.46737361f, -0.19995178f, -0.51181847f, -0.06366701f, 0.22107708f, 0.42006522f, 0.94093406f, -0.72607410f, 
    -0.66590232f, 0.77493596f, -0.23540513f, 0.27896041f, -0.08848101f, 0.15580456f, -0.20076001f, 0.32094228f, 
    -0.72748166f, 0.50826299f, -0.32516825f, 0.04042300f, 0.36795774f, 0.09762604f, -0.05762045f, 0.22616845f, 
    -0.52182430f, -0.43355295f, 0.35160655f, -0.41261688f, -0.44398552f, 0.39689165f, -0.07551464f, -0.03072575f, 
    -0.06091585f, -0.11776459f, -0.00867895f, -0.28717726f, -0.67667073f, -0.01628042f, -0.55449700f, 0.20794658f, 
    -0.12579051f, 0.42000532f, 0.59320927f, 0.67680395f, -0.38018414f, -0.44205686f, -0.34504551f, -0.24585670f, 
    0.00708936f, 0.05422295f, 0.38264278f, 0.47375211f, 0.42486164f, -0.20773180f, 0.26193139f, -0.01688392f, 
    -0.37050998f, -0.27485251f, 0.08135266f, 0.41527215f, -0.40750653f, -0.30950466f, 0.29282293f, -0.43142724f, 
    -0.18802203f, -0.50049943f, 0.04098836f, -0.41354558f, 0.59571224f, 0.29777202f, 0.28128594f, 0.08632559f, 
    0.24635620f, -0.29766443f, 0.45280620f, -0.10931618f, -0.35565031f, -0.15672770f, -0.53304082f, 0.25192845f, 
    -0.12099776f, 0.54084325f, 0.29645300f, 0.70969206f, -0.39775541f, -0.14604822f, 0.10778097f, -0.24286366f, 
    1.03046024f, -0.78377283f, -0.21007839f, -0.02814316f, 0.20909029f, -0.10058348f, 0.39236850f, -0.10249794f, 
    0.19975640f, -0.33599797f, 0.28677711f, -0.20983118f, 0.02259404f, -0.06525203f, 0.30252993f, 0.43934229f, 
    0.25442147f, 0.15486643f, 0.48805991f, 0.13469712f, -0.22507979f, 0.12673534f, -0.15836419f, 0.32167897f, 
    -0.58583468f, 0.59389913f, -0.13542013f, -0.06762254f, 0.21348564f, -0.23786089f, -0.09084381f, -0.31444725f, 
    0.53573048f, -0.13321078f, -0.24388745f, -0.55531341f, 0.27056167f, 0.49630278f, -0.72701025f, 0.02625567f, 
    0.68759292f, -0.18054733f, 0.00657155f, 0.07924721f, -0.56324428f, -0.22569282f, -0.52185255f, 0.23403755f, 
    0.27221882f, 0.12610129f, 0.27897239f, 0.39598271f, 0.15349105f, -0.26374152f, 0.32556289f, 0.79578221f, 
    0.40353173f, -0.48883903f, -0.36561733f, -0.42657381f, -0.31840193f, 0.20811100f, -0.11986979f, 0.06332047f, 
    0.16461717f, 0.17561868f, 0.61849582f, -0.47113037f, -0.27926320f, -0.46774435f, -0.39584309f, -0.05027288f, 
    0.09693354f, 0.21195462f, 0.26103568f, 0.52425408f, 0.33725312f, -0.01599764f, -0.25996548f, 0.30143031f, 
    0.15338825f, 0.06139190f, -0.27618924f, -0.35891438f, -0.32248256f, -0.38009149f, -0.16977009f, -0.27225482f, 
    -0.10601790f, 0.14922760f, -0.19818507f, -0.19938467f, -0.15340823f, -0.35184526f, -0.14544196f, 0.01893238f, 
    0.61402345f, 0.32313457f, -0.58832240f, -0.35885212f, -0.47745287f, -0.13096152f, 0.56664890f, 0.22678766f, 
    0.11168512f, 0.38593966f, 0.04412581f, -0.13837227f, -0.46255913f, -0.04633128f, 0.26840612f, -0.07307876f, 
    -0.29450685f, 0.19606014f, 0.40038812f, 0.25154448f, -0.50116736f, -0.02512060f, 0.50981134f, 0.21853939f, 
    -0.76937294f, -0.69912338f, 0.15936351f, 0.23889010f, -0.01100638f, 0.30633217f, 0.05087344f, 0.14969023f, 
    0.29093519f, -0.18350084f, -0.23609237f, 0.52890545f, -0.39495021f, -0.29363075f, 0.13962170f, -0.03331748f, 
    0.27460319f, 0.61144131f, -0.27962771f, -0.21697263f, -0.36493373f, 0.74976337f, -0.52152026f, -0.11428680f, 
    -0.07455295f, 0.49579731f, 0.78230155f, -0.65672624f, -0.05696692f, -0.17728174f, -0.06463815f, -0.14379613f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.00866809f, 0.15790048f, -0.23135741f, -0.31459877f, -0.40359986f, 0.12522237f, 0.19445975f, 0.21903294f, 
    -0.16488710f, -0.19088183f, -0.03053173f, 0.19092546f, -0.33242598f, 0.11585104f, -0.18579039f, -0.09463273f, 
    0.15749578f, -0.28965044f, 0.18374144f, 0.10092910f, 0.10133626f, -0.33454955f, -0.25116289f, -0.04971406f, 
    0.02716051f, -0.23090395f, 0.25070253f, -0.41257545f, 0.15421101f, 0.21468766f, -0.27005461f, -0.14562245f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.06619628f, 0.10808492f, 0.13232338f, 0.11220028f, -0.03855811f, 0.10720322f, 0.03891932f, 0.04672157f, 
    -0.04329379f, -0.07852393f, -0.28024819f, 0.02371275f, -0.07518356f, 0.04149448f, 0.07308821f, 0.03568880f, 
    0.08210001f, 0.17188856f, -0.10002559f, 0.15942773f, -0.22794546f, -0.00273555f, 0.13178265f, -0.14974299f, 
    0.10121290f, -0.14659898f, -0.01136702f, -0.11521015f, 0.11295351f, 0.08533657f, -0.17007086f, -0.10290442f, 
    -0.07762663f, 0.02721639f, 0.10754609f, 0.14136370f, 0.07270165f, 0.05587639f, 0.19632280f, -0.18540986f, 
    0.05459451f, -0.10493753f, -0.17637058f, 0.18441290f, -0.02826529f, 0.05217921f, 0.11175346f, 0.04111990f, 
    -0.04137320f, -0.06422450f, -0.09043794f, 0.12579370f, -0.04377491f, -0.04500961f, 0.18301095f, -0.27575412f, 
    0.30011454f, -0.01066008f, -0.04358837f, 0.16142185f, 0.02555927f, 0.00534449f, 0.20734806f, -0.11106325f, 
    0.08022268f, 0.11029007f, 0.00870162f, 0.00416981f, -0.05036242f, 0.01986746f, -0.00257892f, -0.12920439f, 
    -0.16400287f, 0.13302527f, 0.04679805f, 0.04955563f, -0.06546129f, 0.02799142f, -0.01752380f, 0.03103448f, 
    0.04290865f, 0.07926334f, 0.18960086f, 0.22179666f, 0.00476800f, 0.08809183f, -0.42320469f, -0.09011464f, 
    0.05613626f, -0.13798438f, 0.03110990f, 0.36958566f, 0.07402933f, 0.02184553f, 0.07788316f, 0.07519639f, 
    -0.17815720f, 0.00249919f, -0.00270212f, 0.21676426f, 0.10055958f, -0.01403315f, 0.12169559f, 0.10462908f, 
    0.10566900f, 0.01176428f, 0.14088839f, -0.01491779f, -0.03452360f, 0.32998773f, 0.06496715f, -0.04327679f, 
    -0.14249884f, -0.23769894f, 0.00695090f, 0.02534055f, -0.10381095f, 0.05110182f, 0.10872216f, 0.17856582f, 
    -0.02637650f, 0.01546232f, 0.03947506f, 0.03263892f, 0.00057560f, -0.14943416f, -0.00845778f, 0.11305829f, 
    0.09011854f, -0.11439531f, -0.12500204f, -0.07228991f, -0.05970428f, -0.12960939f, -0.13714406f, -0.34228265f, 
    0.16751550f, 0.09314710f, 0.13927214f, 0.04041495f, 0.10106665f, 0.14232835f, 0.11465182f, -0.14761694f, 
    -0.01546742f, 0.03888170f, 0.03758690f, 0.07318229f, 0.05003102f, 0.02935900f, -0.03041450f, -0.11566375f, 
    -0.17546101f, -0.00937104f, 0.17413653f, 0.05030563f, -0.06772976f, -0.08107100f, -0.07078233f, -0.03986838f, 
    0.08420009f, 0.11518164f, -0.02084206f, -0.17902435f, -0.00355912f, -0.06736559f, -0.04074401f, 0.03870503f, 
    0.00638579f, -0.05757881f, 0.04524410f, -0.40609136f, 0.28236660f, -0.28290555f, 0.07440962f, -0.00541627f, 
    0.09100096f, -0.00241216f, -0.03448778f, -0.16377959f, -0.06503588f, 0.04464130f, 0.06010254f, 0.00783909f, 
    -0.05560400f, 0.04477266f, -0.05132817f, -0.07531735f, -0.10689645f, -0.29880199f, 0.44190267f, 0.00020299f, 
    -0.01575986f, 0.16827402f, 0.06050339f, 0.03928877f, -0.03131699f, -0.02426581f, 0.01490504f, 0.09114244f, 
    0.17363362f, -0.10072780f, 0.10888636f, -0.09758907f, -0.03029267f, 0.11579026f, 0.05814148f, -0.01806105f, 
    0.11871222f, 0.08653451f, -0.01371324f, -0.01081917f, -0.11703227f, 0.12561885f, 0.11752011f, -0.01859659f, 
    -0.00568311f, -0.09953879f, 0.04494665f, 0.15926644f, 0.02968121f, 0.06396665f, 0.06338011f, 0.04481212f, 
    0.11465407f, -0.24380521f, 0.06972754f, 0.08552063f, -0.05555169f, -0.01939296f, -0.16900538f, -0.14512876f, 
    -0.26606342f, -0.27980986f, -0.03523165f, 0.16048174f, 0.12820254f, 0.06832652f, -0.07423650f, 0.01488382f, 
    -0.01803383f, 0.08575585f, 0.02894614f, -0.02186397f, -0.18366700f, 0.00498265f, -0.13996348f, -0.11066312f, 
    -0.02573318f, -0.07427401f, -0.22898170f, -0.30003148f, -0.15230502f, -0.03665293f, 0.00880265f, -0.17040212f, 
    0.04045526f, -0.18855761f, -0.07663371f, -0.11447337f, 0.11554305f, 0.28253579f, -0.06421893f, 0.14428049f, 
    -0.08672727f, 0.12215295f, -0.02539659f, 0.02910497f, 0.13203591f, 0.00751027f, 0.12720831f, -0.05648388f, 
    0.21516389f, -0.17946304f, -0.02387562f, -0.03366451f, -0.01660354f, 0.20443422f, -0.00278302f, 0.06946851f, 
    -0.08297182f, 0.25224724f, -0.11449031f, 0.17378663f, 0.03224432f, 0.01356416f, 0.00062706f, -0.11880530f, 
    -0.15970364f, -0.05325867f, 0.06394217f, -0.04505720f, -0.20353998f, -0.02870026f, 0.02545892f, 0.00377674f, 
    0.08109954f, -0.14626200f, -0.09801653f, 0.11799521f, 0.06338099f, -0.03705196f, 0.03048899f, 0.08217607f, 
    -0.01993482f, 0.01311904f, -0.15503198f, 0.20407557f, -0.31603205f, 0.09477700f, 0.05337067f, -0.13645554f, 
    0.16335215f, 0.03861392f, 0.00301557f, -0.43109864f, 0.33077419f, 0.22293185f, 0.14398687f, -0.14476690f, 
    -0.23792547f, -0.00990376f, 0.03778989f, -0.03699267f, -0.02380051f, -0.06164443f, 0.30694103f, -0.10703832f, 
    -0.06368452f, -0.16883950f, 0.10767535f, 0.01740661f, 0.01907679f, 0.20476288f, -0.04681981f, 0.08706594f, 
    0.08238158f, 0.14224124f, -0.00834265f, -0.01362584f, 0.00366494f, 0.04936882f, -0.22310932f, -0.17611079f, 
    0.19675936f, -0.13451220f, -0.01666633f, 0.18208954f, 0.09765132f, -0.02994108f, 0.05278233f, -0.22709021f, 
    0.14896791f, -0.26170918f, 0.08113898f, 0.08228307f, -0.06035302f, -0.13573948f, -0.07812794f, 0.15342960f, 
    -0.13211548f, 0.13304736f, 0.12975712f, -0.09281985f, -0.26177767f, 0.05771770f, 0.08876693f, 0.02933192f, 
    0.11741430f, -0.06023598f, 0.25176707f, 0.34356123f, -0.04966953f, -0.19721106f, -0.19144326f, -0.02187470f, 
    0.07567170f, 0.06139392f, -0.41116881f, 0.04440083f, 0.17195779f, 0.13207375f, 0.11592831f, -0.06837601f, 
    -0.00193279f, 0.03538850f, -0.00426972f, -0.19232076f, 0.09687364f, -0.13312419f, -0.05738962f, -0.06041069f, 
    -0.03944394f, 0.10147759f, 0.08733066f, 0.03839086f, 0.06481863f, 0.29132190f, 0.20096898f, 0.04939898f, 
    -0.15309292f, -0.14384486f, 0.05909726f, 0.04818688f, 0.08316616f, -0.19157377f, -0.07196157f, 0.09883807f, 
    0.00876960f, -0.11156271f, -0.08302163f, 0.00597759f, -0.11828315f, 0.05904151f, 0.04439610f, 0.21820554f, 
    0.03882690f, -0.01294998f, 0.12324850f, 0.05592435f, -0.01847834f, 0.03243973f, 0.00828273f, -0.01399657f, 
    0.00712170f, -0.09851991f, 0.13298732f, 0.25444987f, 0.09229765f, -0.03522498f, -0.02676418f, -0.13656919f, 
    -0.17635074f, -0.01828802f, -0.12721783f, 0.05551851f, 0.11679626f, 0.09418939f, 0.08096872f, 0.02783892f, 
    0.04144998f, -0.26456752f, 0.18772329f, 0.27263695f, 0.22659253f, 0.14369638f, -0.25645235f, -0.02038017f, 
    -0.05034671f, 0.07750348f, -0.01478207f, -0.06294007f, 0.14767952f, -0.05542029f, -0.04823895f, 0.01354336f, 
    0.07872801f, 0.04379474f, 0.09836431f, -0.26893592f, 0.21999550f, -0.55251837f, -0.03238078f, 0.00802700f, 
    0.08030057f, -0.06465528f, 0.02681024f, 0.16595592f, 0.18388917f, -0.04898055f, 0.01506516f, -0.00997922f, 
    -0.13435374f, 0.01543348f, 0.16632091f, -0.04482383f, -0.02125252f, -0.38802341f, -0.10760050f, -0.00499548f, 
    -0.21025430f, -0.13094167f, -0.03716895f, 0.05015937f, 0.00633063f, -0.02613058f, -0.09595108f, 0.10419909f, 
    -0.06381445f, -0.04674512f, 0.06296226f, -0.11212838f, -0.04210110f, -0.10020021f, 0.01342468f, -0.02490629f, 
    0.13784935f, -0.12894596f, -0.01892755f, 0.11857912f, 0.06066642f, -0.02317224f, -0.10484951f, 0.02026486f, 
    0.11900453f, 0.10402136f, 0.25338954f, -0.00109385f, -0.06688247f, -0.04680602f, 0.05665923f, 0.04472794f, 
    0.04887614f, -0.13643657f, 0.16518249f, 0.07981335f, 0.01002313f, 0.00750457f, 0.24478664f, 0.07846876f, 
    -0.00741154f, 0.07459371f, 0.13707821f, 0.15927374f, 0.02091070f, -0.06919537f, -0.08879302f, -0.05711621f, 
    0.16750136f, -0.05745425f, -0.01703427f, -0.10810322f, 0.00159688f, 0.08334287f, 0.01688809f, 0.09767665f, 
    -0.00546137f, 0.05613321f, -0.13325833f, 0.06683876f, 0.12680349f, -0.12986284f, 0.12120498f, 0.01993712f, 
    -0.06144067f, -0.00788649f, 0.02080497f, 0.04704972f, 0.09024904f, -0.07147750f, -0.19371833f, 0.25576201f, 
    -0.04611466f, -0.04843406f, -0.08081608f, 0.09300867f, -0.14075577f, 0.00179297f, -0.12051475f, 0.29623377f, 
    0.32464746f, -0.20094346f, 0.05004597f, -0.25879040f, -0.16271687f, 0.02649925f, -0.06278124f, -0.47322631f, 
    -0.34279522f, 0.06472269f, -0.16896990f, 0.03723897f, -0.29602125f, 0.13224047f, -0.10065867f, -0.02151837f, 
    -0.06609510f, 0.03377640f, 0.02847438f, -0.04383475f, -0.11472057f, 0.10694735f, -0.00321608f, -0.11090879f, 
    -0.06597560f, -0.03046053f, -0.21037307f, -0.17476842f, 0.00519601f, -0.11803775f, 0.02820427f, -0.02586424f, 
    -0.00418606f, 0.02354922f, 0.00756385f, -0.02885040f, 0.23627646f, -0.02103711f, -0.09536517f, 0.10080086f, 
    0.00730856f, 0.05654840f, 0.08213174f, 0.31777972f, -0.17467855f, 0.00217904f, 0.02981581f, 0.08048473f, 
    -0.35245439f, 0.08009598f, 0.07596689f, -0.04308284f, 0.14717415f, -0.05929105f, -0.35149738f, -0.28600278f, 
    0.24222693f, -0.13417760f, 0.10635082f, -0.13305870f, -0.03697670f, 0.40692064f, 0.20247425f, -0.01288387f, 
    -0.11677646f, -0.00855934f, 0.00879605f, 0.01153539f, 0.04026189f, -0.13514070f, 0.35430047f, -0.29004705f, 
    -0.25010228f, -0.08639354f, -0.11296857f, 0.06203606f, -0.00369265f, 0.12732574f, 0.07624330f, 0.17147066f, 
    0.00422340f, -0.10728358f, 0.02624036f, -0.03239517f, -0.01438444f, 0.02452481f, 0.17169306f, -0.15308276f, 
    0.38089705f, -0.11784320f, -0.24996291f, 0.01711840f, -0.01952906f, -0.18756589f, 0.03068864f, 0.06716008f, 
    -0.13618068f, -0.11793663f, 0.05251626f, -0.31533217f, -0.01208718f, 0.05974815f, 0.01510152f, -0.01601838f, 
    -0.12103266f, -0.10711659f, -0.72519809f, -0.41694936f, 0.05616580f, 0.08601481f, 0.06846172f, 0.10477687f, 
    0.17240024f, -0.04772189f, 0.17953207f, -0.23837663f, 0.09157420f, 0.12901445f, -0.02943005f, -0.15412156f, 
    0.05033756f, -0.00550520f, 0.03814594f, 0.01371789f, 0.13647154f, 0.38532868f, 0.12167435f, 0.00753883f, 
    0.01522284f, -0.16576236f, -0.09171636f, 0.12643000f, 0.03789689f, -0.01614260f, 0.17319165f, 0.05080285f, 
    -0.11110654f, -0.06987406f, 0.03687194f, -0.02266035f, -0.00025525f, -0.01896456f, 0.08723022f, -0.00187314f, 
    -0.08642694f, -0.27436528f, 0.01599315f, -0.05880056f, 0.09441657f, -0.16747242f, -0.04431393f, 0.10667697f, 
    0.01322332f, -0.18452269f, 0.02741030f, 0.06898930f, 0.31095299f, 0.16317211f, -0.13339801f, -0.04764235f, 
    -0.07866013f, -0.05434760f, 0.09550931f, 0.07384890f, 0.07642934f, 0.06840601f, 0.07322916f, 0.03462407f, 
    0.10954162f, -0.00194081f, 0.04047026f, 0.10295771f, -0.09791007f, 0.00362557f, -0.13966112f, -0.15563925f, 
    0.02847026f, -0.20207550f, -0.07542570f, -0.09670339f, -0.02307396f, 0.11168171f, 0.06117442f, 0.15969908f, 
    0.01419939f, -0.03891638f, 0.04529896f, 0.22387291f, 0.01936253f, 0.10185605f, 0.02188753f, 0.00544441f, 
    0.06428394f, -0.02439031f, 0.12028071f, 0.05854519f, 0.36052564f, -0.00755420f, -0.55827600f, 0.00148623f, 
    0.00033260f, 0.11313915f, 0.22035575f, -0.04022727f, -0.11140592f, -0.14224932f, 0.04882039f, 0.02156659f, 
    -0.08810433f, 0.02541611f, 0.00517341f, 0.03027795f, 0.10612374f, 0.04152083f, -0.17076300f, -0.20403844f, 
    0.16098711f, -0.03761531f, 0.04675536f, -0.02287964f, -0.00662392f, -0.00990424f, -0.09796423f, 0.07548190f, 
    0.11636139f, -0.00703039f, -0.35536957f, 0.01988941f, -0.06228482f, 0.04811323f, -0.15898290f, -0.14065607f, 
    -0.13515633f, -0.27502528f, -0.22109191f, 0.07493700f, -0.01241267f, 0.07735895f, 0.04767277f, 0.01364734f, 
    -0.01423457f, 0.09328981f, -0.06648262f, -0.01680605f, 0.19511972f, 0.03539466f, 0.00493619f, -0.06452097f, 
    -0.19603577f, -0.02502911f, 0.35769686f, -0.08726569f, -0.51410156f, -0.07594496f, 0.03738092f, 0.08599732f, 
    0.21047719f, -0.08324319f, -0.03037400f, 0.17056482f, 0.24040601f, -0.16462465f, 0.15726067f, -0.04217674f, 
    0.08560588f, 0.04638803f, -0.05990102f, -0.04858194f, -0.32598960f, -0.15864903f, 0.20990585f, 0.06899071f, 
    0.08127512f, -0.00058125f, 0.04090806f, -0.05735717f, 0.08497910f, 0.01571028f, 0.05747111f, -0.00664898f, 
    -0.02483261f, 0.02221232f, -0.07131158f, -0.01230223f, 0.13450590f, 0.20022807f, -0.02998248f, -0.09161408f, 
    0.30810437f, 0.05197424f, -0.10168707f, -0.08814128f, -0.11023874f, -0.00267904f, -0.02035148f, -0.05342748f, 
    0.07634025f, 0.04813255f, -0.08935238f, 0.07206078f, -0.02200176f, -0.00558583f, 0.10822409f, -0.04637934f, 
    0.08746826f, 0.18728985f, 0.08961831f, -0.07772412f, -0.08203036f, 0.00319223f, 0.08476412f, -0.01487386f, 
    -0.02475051f, -0.25086689f, -0.33785239f, -0.23379523f, -0.05427827f, 0.05770455f, -0.08022132f, -0.02219428f, 
    0.03893139f, -0.05183952f, 0.07353975f, -0.02978901f, -0.00077317f, 0.01320577f, 0.10777373f, -0.01169717f, 
    -0.07090601f, -0.10754742f, -0.05018187f, 0.11696806f, -0.12445331f, 0.19881433f, 0.03656745f, 0.12913457f, 
    -0.07637128f, -0.11903945f, 0.07015552f, 0.07849261f, 0.12446291f, 0.14215626f, -0.24673857f, -0.25534111f, 
    -0.01711332f, -0.40234080f, -0.05491618f, -0.03923782f, 0.02857580f, -0.15474759f, -0.13204886f, 0.12943101f, 
    0.00603551f, -0.07832310f, -0.07789742f, -0.00758058f, -0.06424810f, 0.12165230f, 0.23970085f, -0.17921317f, 
    -0.02068984f, 0.09006693f, -0.00863394f, 0.07728916f, -0.09641179f, 0.14777568f, 0.11824414f, 0.06178972f, 
    0.10122548f, 0.01162495f, 0.07431883f, 0.09580284f, 0.20849220f, -0.01749365f, -0.05011430f, -0.17139728f, 
    -0.12004742f, -0.01388844f, -0.33071747f, -0.00784262f, 0.02026350f, -0.06404745f, 0.10061268f, -0.05388450f, 
    -0.01959866f, -0.51139516f, -0.32056579f, -0.47613275f, -0.09908723f, 0.02019460f, -0.15902844f, -0.01923517f, 
    -0.15734379f, -0.01147407f, -0.15493101f, -0.06763601f, -0.30242494f, 0.00463026f, 0.02476137f, 0.02413987f, 
    0.04883159f, -0.02574476f, 0.04491775f, 0.09917809f, 0.24929261f, 0.13223115f, -0.00465222f, -0.11067988f, 
    -0.04371611f, 0.14478494f, 0.15151188f, 0.10297640f, -0.28260514f, -0.13452075f, -0.15408833f, 0.14084274f, 
    0.05418846f, -0.07089347f, -0.07526170f, -0.11279354f, 0.15817407f, 0.14960732f, 0.13673018f, -0.03496016f, 
    0.02339753f, 0.00365210f, -0.01642158f, 0.06534605f, 0.12045010f, 0.10579107f, 0.15314151f, 0.09372031f, 
    -0.13342996f, -0.02257298f, 0.07463603f, 0.04020512f, -0.13917848f, -0.10731594f, -0.04702151f, 0.15065852f, 
    -0.06724036f, -0.14973068f, 0.16865189f, -0.07069127f, 0.43328324f, 0.19357313f, -0.15260285f, 0.02357441f, 
    -0.02809502f, -0.09702722f, -0.08321335f, 0.09964679f, 0.07391763f, 0.12736405f, -0.15972081f, 0.03564736f, 
    -0.00382418f, 0.13559094f, 0.17461850f, -0.03470946f, -0.21291374f, 0.00142054f, -0.08307834f, 0.04294191f, 
    -0.02429763f, 0.10868155f, -0.31822008f, -0.32422927f, 0.03217489f, 0.01892243f, 0.08095203f, -0.13850658f, 
    -0.11725407f, -0.01270482f, 0.09789587f, 0.03563102f, 0.17308158f, -0.08638754f, -0.10697433f, 0.02644969f, 
    0.05131460f, 0.01881222f, 0.03127808f, -0.14494450f, 0.10945465f, -0.01292115f, -0.22943932f, 0.00019580f, 
    -0.02973837f, -0.12023854f, 0.04960550f, -0.13993946f, -0.05480450f, 0.07637309f, 0.11824444f, -0.03661128f, 
    -0.17047863f, 0.04648307f, -0.04449325f, 0.11912403f, 0.06820316f, 0.10928870f, -0.05056827f, -0.01521425f, 
    0.00305627f, 0.00914808f, 0.05526613f, 0.06647629f, -0.06758019f, -0.09238099f, 0.19873518f, 0.15887669f, 
    0.07456230f, -0.00680160f, 0.05005953f, 0.14003052f, -0.03588694f, -0.02079606f, -0.09181810f, -0.09050916f, 
    -0.50144261f, -0.46090847f, -0.06243468f, 0.07553211f, 0.11560639f, 0.01338819f, 0.11766056f, -0.08283261f, 
    -0.00569785f, -0.17340297f, -0.31524339f, -0.14164957f, 0.09238584f, -0.18008156f, 0.00362590f, 0.05055408f, 
    -0.17264488f, 0.05853157f, -0.07022837f, -0.01071629f, -0.28208435f, -0.06941749f, -0.03255741f, -0.05937712f, 
    0.08896648f, 0.00471098f, -0.00912555f, -0.10358227f, -0.15730943f, -0.07158350f, 0.10701402f, -0.00665975f, 
    -0.06472702f, -0.07984896f, -0.13768862f, -0.04557322f, -0.83554178f, -0.48574099f, 0.08547410f, -0.02368505f, 
    0.06822276f, -0.14781992f, -0.04473471f, -0.08306878f, 0.02048530f, 0.14100017f, 0.02595258f, 0.11892549f, 
    0.09575351f, -0.04434023f, -0.14836836f, 0.05670279f, 0.08831389f, 0.24475576f, 0.17239419f, -0.00948264f, 
    0.30377105f, 0.01144106f, -0.12341289f, 0.00883847f, 0.11235683f, 0.18102944f, 0.00252883f, 0.30042079f, 
    0.13916698f, 0.22127029f, -0.04396965f, 0.12370874f, -0.01374608f, 0.04565636f, 0.12046590f, -0.03916358f, 
    -0.08327211f, -0.19185537f, -0.11151171f, -0.05112912f, -0.13790080f, -0.24906226f, 0.08383484f, -0.05905452f, 
    -0.06629600f, -0.03265313f, 0.01808242f, 0.06407477f, 0.03360227f, 0.07320698f, -0.04321658f, -0.11815408f, 
    -0.03450527f, 0.23048575f, 0.42891094f, 0.06361616f, 0.28233466f, -0.06476137f, -0.03439043f, -0.06096827f, 
    0.17689911f, 0.17803857f, -0.17545415f, 0.11350824f, -0.10075401f, 0.17102838f, -0.26089567f, 0.06700155f, 
    -0.13559994f, -0.16030739f, -0.04398974f, 0.28084540f, 0.40082169f, -0.09665937f, 0.05202780f, -0.05006909f, 
    -0.00342156f, 0.01433711f, 0.00363399f, 0.05486488f, -0.06866933f, 0.35043985f, 0.01966563f, -0.14534663f, 
    0.01014267f, -0.00989603f, -0.21950434f, 0.00980774f, 0.05578014f, -0.02746491f, -0.28419062f, -0.25002173f, 
    -0.05950880f, 0.04349966f, -0.04303839f, -0.21466959f, 0.00811532f, 0.01788337f, 0.07667480f, -0.33312204f, 
    -0.10452022f, -0.22217266f, -0.19981514f, 0.08333473f, -0.15137200f, 0.07786915f, 0.00130863f, -0.22188011f, 
    0.28270128f, 0.21140963f, -0.09087273f, -0.04727307f, 0.22161976f, -0.04557598f, 0.05315537f, 0.01579371f, 
    0.21391252f, 0.19810274f, 0.24540824f, 0.09256981f, -0.00532899f, -0.07258322f, -0.18799712f, 0.04289964f, 
    0.01856747f, -0.03238053f, -0.07243806f, 0.23310266f, -0.06462789f, 0.08768678f, 0.09326009f, -0.10096291f, 
    -0.03272318f, 0.00068109f, -0.08767892f, -0.30781522f, -0.18622723f, -0.07022344f, -0.01986726f, -0.14945060f, 
    0.00133383f, 0.14407483f, -0.05030248f, -0.28023389f, 0.36234546f, 0.20619632f, 0.02034577f, 0.14649944f, 
    0.05470030f, -0.21424209f, -0.05851443f, 0.04153554f, 0.09932172f, -0.19515711f, -0.21387553f, -0.16165428f, 
    -0.04438182f, -0.24539648f, -0.14201877f, 0.03407251f, 0.06733847f, 0.01394962f, 0.31109059f, 0.13724504f, 
    -0.11863995f, -0.42364684f, 0.01245488f, -0.00384185f, 0.02965370f, 0.08889003f, 0.13969959f, 0.02840166f, 
    -0.34599015f, -0.29532617f, -0.21276884f, 0.15724061f, 0.03004253f, 0.14384258f, 0.04927563f, -0.00391765f, 
    -0.09637579f, -0.00318407f, -0.02287896f, -0.08217859f, 0.09865221f, -0.15237758f, 0.10920484f, -0.05854458f, 
    -0.27015644f, 0.02827059f, 0.38582569f, 0.27982220f, 0.30779853f, 0.03882980f, -0.07492554f, 0.01528852f, 
    -0.19812679f, -0.10806503f, 0.20034862f, 0.11633918f, 0.14634073f, -0.05540163f, 0.06598544f, -0.02835913f, 
    0.02796017f, 0.19907585f, 0.05155456f, -0.17388730f, -0.06267104f, -0.34677055f, -0.19302233f, -0.04590885f, 
    0.12566480f, -0.01718614f, 0.02346309f, 0.06942974f, 0.25811699f, 0.07858124f, 0.08967733f, -0.16244908f, 
    -0.05384633f, -0.16905141f, 0.08520910f, -0.01687489f, -0.04991692f, -0.07402096f, -0.15087000f, -0.06213703f, 
    -0.18182689f, -0.08796449f, -0.08347556f, 0.14074962f, -0.06149116f, -0.15784940f, 0.14512815f, -0.11433075f, 
    -0.04209384f, -0.07342774f, -0.05289685f, -0.06278151f, 0.11703376f, -0.00205913f, 0.30504367f, 0.34007844f, 
    0.05408544f, -0.20902684f, -0.25918075f, -0.12006047f, -0.03234746f, 0.12474054f, 0.08127724f, -0.02226724f, 
    0.12163643f, 0.30623442f, 0.16213687f, 0.18171428f, 0.11779673f, 0.11027331f, -0.03698302f, -0.07447600f, 
    0.08744071f, 0.18180200f, 0.36910036f, 0.11133722f, -0.03023992f, -0.04980022f, -0.06384662f, 0.23923860f, 
    -0.04851403f, -0.18697049f, 0.18267079f, 0.10589047f, 0.05061651f, -0.18320005f, -0.04554704f, -0.10220373f, 
    -0.01857419f, 0.01480494f, -0.07408441f, 0.32505217f, 0.14205913f, -0.07325839f, 0.15760799f, -0.03940923f, 
    0.05875074f, -0.01978067f, -0.05629088f, 0.07252906f, 0.25181118f, 0.12762097f, -0.01016151f, -0.02571762f, 
    0.02610423f, -0.17207725f, -0.09324806f, 0.03623311f, 0.08224812f, 0.01108682f, -0.10725539f, 0.05815430f, 
    0.02379123f, 0.00301222f, 0.10568490f, -0.00547188f, -0.03274181f, -0.05948897f, 0.08956984f, -0.15314932f, 
    0.15351924f, -0.07379287f, 0.05330866f, -0.02496446f, 0.27024195f, -0.06072864f, -0.18506242f, -0.33507124f, 
    -0.20106293f, -0.09258984f, -0.15446874f, -0.02563410f, -0.17752863f, -0.00189124f, 0.03056558f, -0.03790610f, 
    -0.02861740f, -0.02493272f, 0.05363163f, -0.05431285f, 0.03772141f, -0.02680645f, -0.01679754f, -0.00574169f, 
    0.02016545f, -0.00844210f, -0.06508147f, 0.00241221f, -0.03936311f, 0.04675601f, 0.04553144f, 0.00468905f, 
    0.02044374f, 0.04463448f, -0.04500608f, -0.01986657f, -0.01290418f, -0.01641206f, -0.02731781f, -0.05749551f, 
    0.00961081f, 0.05770278f, 0.01856359f, 0.03472425f, -0.04731348f, -0.01304256f, -0.00688801f, 0.02737068f, 
    -0.06230809f, -0.04890988f, -0.03296411f, -0.00538436f, 0.00848223f, -0.05593275f, -0.01252463f, -0.04311196f, 
    -0.02450577f, -0.05710692f, 0.02764336f, 0.04102027f, -0.02674494f, -0.02699398f, 0.04625716f, -0.00751430f, 
    -0.05528112f, 0.02469620f, 0.03223366f, -0.06292793f, -0.03718553f, 0.02500658f, 0.00839020f, 0.03733029f, 
    -0.06022710f, 0.04798073f, -0.01115421f, 0.02167151f, 0.00243800f, -0.02686240f, 0.00000236f, 0.02138591f, 
    0.00322605f, 0.00348466f, -0.05126291f, 0.02409825f, 0.04756871f, -0.04414926f, -0.03142433f, -0.05819006f, 
    0.02030770f, -0.06618459f, -0.00699270f, 0.01731857f, -0.03139522f, -0.03757168f, -0.01582295f, 0.04156783f, 
    -0.00422481f, 0.04020889f, -0.01937399f, 0.04214880f, -0.02266382f, -0.06743180f, 0.04716877f, 0.00421899f, 
    -0.01158699f, 0.02100267f, -0.03453707f, -0.06508629f, -0.05739636f, 0.01989207f, -0.01097093f, -0.02328454f, 
    -0.05532592f, 0.00808358f, -0.02406478f, -0.05483877f, 0.02728423f, 0.03967857f, 0.04746554f, 0.04640738f, 
    -0.01259122f, -0.04054021f, -0.00348399f, -0.04028653f, 0.00575587f, 0.00776756f, -0.01528273f, 0.04469839f, 
    0.02209647f, 0.00463540f, -0.00446599f, 0.03890961f, -0.00947698f, -0.01242075f, -0.03302190f, -0.02465664f, 
    0.02442670f, 0.03919678f, 0.04135622f, -0.02624430f, 0.00428671f, -0.01291508f, -0.04516232f, 0.00699548f, 
    -0.04774111f, 0.02359271f, -0.05365824f, -0.00287465f, 0.01989515f, 0.05473435f, -0.03480631f, -0.06309377f, 
    0.01382605f, -0.02418021f, -0.02291464f, 0.01832729f, -0.02072098f, 0.00947149f, 0.04577752f, 0.03899453f, 
    0.04759656f, -0.04541153f, 0.00554583f, -0.01862090f, -0.01346151f, 0.02755127f, -0.03049054f, -0.01622550f, 
    -0.03674706f, 0.03336605f, 0.02007618f, 0.03888926f, 0.02665321f, -0.03510696f, -0.03923624f, -0.02887763f, 
    0.00333311f, -0.04410613f, 0.04824265f, -0.00864348f, -0.05630786f, 0.03019473f, -0.05766321f, 0.02698822f, 
    -0.06862249f, -0.04360702f, 0.04624276f, -0.00113119f, -0.03450115f, -0.04991730f, -0.02942502f, -0.02730701f, 
    -0.01826688f, 0.06268006f, 0.05131233f, -0.03935033f, 0.01442920f, -0.00775096f, -0.04092702f, -0.03941434f, 
    -0.02831830f, -0.04144021f, -0.04544407f, -0.02089991f, 0.03852632f, 0.05017535f, 0.01374317f, -0.02558308f, 
    -0.05345331f, -0.04075529f, -0.04002130f, 0.01074252f, -0.00396827f, -0.05388843f, -0.03007544f, 0.04441467f, 
    0.03888728f, 0.03459557f, 0.01907346f, 0.01387859f, -0.01141849f, 0.00349595f, -0.03773336f, 0.01407540f, 
    -0.03745573f, 0.05589288f, -0.01506719f, -0.04102058f, -0.01726997f, 0.00218596f, 0.02055559f, 0.04759367f, 
    0.02858685f, -0.04855427f, -0.01628990f, 0.00795591f, 0.02077605f, -0.04432034f, 0.02602741f, 0.00112582f, 
    -0.02465604f, -0.04673843f, -0.01332857f, 0.02418748f, 0.03401770f, 0.01602954f, -0.03597595f, -0.04168659f, 
    0.02529789f, -0.01492804f, -0.06115392f, -0.03086028f, -0.03207427f, -0.05411604f, 0.02211815f, -0.06799184f, 
    -0.04795589f, -0.05102373f, 0.03023213f, -0.03318913f, 0.01429631f, -0.03198363f, -0.06799300f, 0.01592015f, 
    -0.06580801f, 0.04406641f, 0.02237849f, -0.03269545f, -0.06324600f, 0.00521921f, 0.02489552f, -0.04937828f, 
    0.03687420f, 0.03249823f, -0.05233775f, -0.00725788f, -0.01801989f, -0.05082047f, -0.02486301f, -0.05545005f, 
    0.05135889f, -0.02822874f, -0.05327327f, -0.03748801f, -0.03390413f, -0.01264899f, -0.02023348f, -0.02174133f, 
    -0.00481021f, 0.00369509f, 0.01163407f, -0.06510425f, -0.02477540f, 0.01793647f, 0.02278410f, -0.02872236f, 
    0.00005751f, -0.00626760f, 0.04159428f, 0.03895851f, -0.02524009f, 0.02758095f, -0.04234580f, -0.02064274f, 
    -0.05719265f, -0.02005091f, 0.10923002f, 0.12286960f, -0.18935351f, -0.01343488f, -0.09832658f, 0.08427559f, 
    -0.05284067f, 0.02438121f, 0.00747806f, -0.06705296f, 0.09873602f, 0.06925133f, 0.03962555f, -0.12405895f, 
    -0.24813828f, -0.09404036f, 0.00027767f, -0.13361199f, -0.06079948f, -0.02915562f, -0.19843259f, -0.05541174f, 
    -0.03751996f, 0.01542113f, -0.09188234f, -0.07313301f, -0.28120208f, 0.25791460f, 0.05768850f, -0.02209916f, 
    -0.05513447f, -0.18780264f, -0.16434634f, -0.16004486f, -0.30523974f, 0.06017232f, 0.34745181f, -0.12505621f, 
    0.17795438f, -0.00080558f, 0.05412330f, 0.00293322f, 0.02084238f, 0.08751222f, -0.10759015f, 0.18065824f, 
    -0.12023014f, 0.10916623f, -0.05469282f, 0.05757125f, 0.00826468f, 0.00581157f, 0.22085118f, 0.09841344f, 
    0.08773792f, 0.11685543f, 0.05700053f, -0.11237933f, -0.06147610f, 0.01453659f, -0.01131427f, 0.12796482f, 
    0.13277042f, -0.07130298f, -0.01302117f, -0.00357395f, 0.18366972f, 0.01278025f, 0.11331860f, 0.07813035f, 
    -0.27424544f, -0.17031030f, -0.17774801f, -0.07064648f, 0.12257393f, 0.01044378f, -0.08908104f, -0.10474738f, 
    -0.06718761f, -0.24565497f, -0.38133904f, -0.23928827f, 0.04786650f, -0.02796009f, -0.12688489f, 0.02975680f, 
    0.04940930f, 0.00118608f, 0.09036639f, -0.44080263f, -0.02442524f, 0.02152048f, 0.07322700f, 0.04251894f, 
    0.10843946f, 0.14451490f, 0.05607063f, 0.00767144f, -0.13430256f, 0.09553274f, 0.01205926f, 0.13537729f, 
    0.02949858f, -0.04510881f, 0.11143188f, 0.01214089f, -0.16793002f, -0.17777023f, 0.04734061f, -0.00150399f, 
    -0.04244015f, -0.06971985f, 0.00167514f, -0.01387317f, 0.05595567f, -0.07015565f, -0.00394836f, 0.01191862f, 
    0.01882300f, -0.14671063f, -0.13367182f, 0.08362898f, 0.00034761f, 0.00055885f, -0.20347452f, -0.06695244f, 
    -0.04961596f, 0.11657510f, 0.04605418f, 0.06091982f, 0.09361994f, 0.11895372f, -0.05766114f, 0.20138486f, 
    -0.18314394f, -0.06027725f, 0.20985723f, -0.01583166f, 0.04127927f, 0.09045111f, 0.01988075f, 0.13829657f, 
    0.14050059f, -0.06432034f, -0.04675623f, -0.07066882f, 0.05480806f, 0.00151000f, -0.00255431f, 0.08331739f, 
    0.09375621f, 0.07967387f, -0.19041926f, 0.08951745f, -0.07674466f, -0.12674676f, -0.09238850f, -0.26224151f, 
    0.04671631f, -0.28976399f, -0.10713983f, -0.02074052f, -0.14611523f, 0.00219174f, -0.04261785f, 0.02603031f, 
    0.01241490f, 0.04934170f, 0.19722264f, -0.04707395f, 0.08488635f, 0.10823712f, -0.22197187f, 0.03200213f, 
    0.23442639f, 0.10878859f, 0.09444854f, 0.13662459f, -0.12711287f, 0.11373591f, 0.09918305f, -0.16738579f, 
    0.13243349f, -0.04057115f, 0.00755169f, 0.08051285f, -0.01637393f, -0.26743960f, 0.18131164f, -0.01945920f, 
    0.09709176f, -0.01884225f, 0.04689647f, 0.07483546f, 0.11728536f, 0.03201311f, -0.16700098f, -0.01009948f, 
    0.01520544f, -0.04511674f, -0.13138138f, -0.10083576f, -0.20880651f, 0.09478502f, 0.01140976f, -0.15817530f, 
    0.02947983f, 0.04114727f, 0.12745015f, 0.04830421f, 0.06635804f, -0.03896055f, 0.00852887f, 0.01397762f, 
    -0.18920723f, -0.13140930f, -0.23644860f, 0.09919382f, 0.07198294f, -0.12731586f, -0.15499562f, -0.12323277f, 
    -0.05737037f, -0.05122271f, -0.17112853f, -0.29666904f, -0.11195233f, -0.04958400f, -0.19771902f, -0.04802218f, 
    -0.04335625f, 0.09632501f, 0.00176868f, 0.14208823f, 0.23113620f, -0.16010606f, 0.20609824f, 0.00552493f, 
    0.10663988f, 0.05810697f, -0.00704315f, -0.01556707f, -0.11769570f, 0.04392620f, -0.16006535f, -0.00896072f, 
    -0.15597270f, -0.02360814f, -0.07306810f, 0.09144177f, -0.31596991f, -0.11691534f, -0.13953075f, 0.05072406f, 
    0.01723953f, 0.10225209f, 0.04584349f, 0.07773446f, 0.18671140f, 0.02976969f, 0.10717109f, -0.03270543f, 
    0.02375231f, 0.03053645f, -0.06055515f, -0.00564264f, 0.06243498f, 0.13271792f, -0.07520860f, -0.03973804f, 
    -0.11260624f, 0.09026168f, 0.08457541f, -0.09900388f, -0.02672795f, 0.04836811f, -0.01861802f, -0.13706800f, 
    0.05209000f, -0.11476348f, 0.07209046f, -0.01646828f, -0.05799307f, -0.00617696f, 0.00136752f, 0.01030672f, 
    -0.04684705f, 0.05017019f, 0.04513763f, -0.01052908f, 0.14803787f, 0.01858811f, -0.00481465f, 0.11845566f, 
    0.00162108f, 0.14923516f, 0.01171758f, -0.22821483f, 0.03038575f, -0.01860702f, 0.13242614f, 0.03506724f, 
    0.11043473f, 0.07279871f, 0.09938615f, 0.12852094f, -0.13119468f, -0.11143857f, -0.15056515f, -0.11205260f, 
    0.03876266f, 0.09936233f, -0.10527425f, 0.27856791f, 0.05652835f, -0.40645593f, 0.23664638f, -0.06195695f, 
    -0.03887040f, 0.05307930f, 0.01309596f, -0.00785629f, 0.19615008f, -0.45425698f, -0.55301136f, -0.01615575f, 
    0.00735620f, -0.08811678f, -0.06731977f, 0.00647035f, -0.08205708f, -0.05426496f, -0.07598392f, -0.34969708f, 
    0.02296687f, 0.00040913f, 0.11265080f, 0.03792122f, 0.09892234f, -0.12219564f, -0.63972217f, -0.25179738f, 
    -0.12270279f, 0.08800599f, 0.32879046f, -0.08802031f, 0.05856233f, 0.22893092f, 0.00401738f, 0.24575129f, 
    -0.18269971f, -0.17882554f, -0.01499406f, -0.02763380f, -0.03387033f, 0.15405813f, 0.00463893f, -0.03419561f, 
    0.35237482f, -0.16416618f, -0.17185898f, -0.01600203f, -0.11450466f, -0.07336154f, -0.03504887f, 0.02798611f, 
    0.08898022f, 0.02466089f, -0.03645452f, -0.00621734f, -0.00405128f, -0.04051593f, -0.26985672f, 0.07072002f, 
    0.07114479f, 0.07421152f, -0.23481321f, -0.00116888f, 0.15024620f, 0.04995044f, 0.02434269f, -0.04793454f, 
    -0.00629248f, 0.05107166f, 0.01075853f, -0.06600101f, 0.17331940f, 0.13406445f, -0.01625236f, -0.00553680f, 
    0.07451098f, 0.07045177f, 0.08852910f, 0.15163668f, 0.03379241f, -0.13040474f, -0.11427853f, 0.07294893f, 
    0.03805441f, -0.20494418f, -0.02907114f, 0.04386305f, 0.08480807f, -0.23760074f, 0.20584607f, 0.15849903f, 
    -0.02132561f, 0.05955729f, 0.04675760f, -0.04529560f, 0.10678090f, 0.00969042f, -0.07323935f, -0.25765458f, 
    -0.09022111f, 0.00689560f, 0.10514716f, 0.13466410f, -0.10097414f, -0.02813274f, -0.02457554f, -0.16031061f, 
    -0.10113266f, -0.26637539f, 0.04265285f, 0.03280485f, -0.13529210f, 0.10797311f, 0.17246903f, -0.03106707f, 
    0.01782876f, -0.14328417f, -0.01713939f, -0.05634008f, -0.01676605f, 0.11327134f, 0.05480137f, 0.12083603f, 
    -0.03271000f, 0.00051772f, 0.12666853f, -0.01333143f, 0.00973507f, -0.02174613f, -0.29345518f, -0.01130756f, 
    -0.02700749f, 0.14960495f, 0.04252028f, 0.10071301f, 0.16918081f, -0.07269460f, 0.15087174f, -0.10558546f, 
    0.13037193f, 0.23364162f, 0.05894791f, 0.46893129f, 0.06983647f, 0.06318659f, 0.03384681f, 0.07596247f, 
    0.05624998f, 0.06391375f, 0.08756936f, 0.06322956f, 0.01146141f, -0.37040290f, -0.30370405f, -0.02714674f, 
    0.10999852f, 0.06935953f, 0.03897564f, 0.00874645f, -0.01715298f, 0.01417449f, 0.18888064f, 0.02961254f, 
    -0.00916502f, -0.15981817f, -0.16734073f, -0.01010344f, -0.04319855f, 0.01075631f, -0.16005908f, -0.01308131f, 
    -0.08196583f, -0.09228006f, -0.10328865f, 0.01158458f, 0.00946170f, 0.01118239f, 0.10157862f, 0.14369181f, 
    0.00827158f, -0.02375104f, 0.00632272f, 0.01349926f, -0.06259798f, 0.23456378f, -0.12405101f, -0.06627475f, 
    -0.01122362f, 0.02825188f, 0.07870942f, -0.04776376f, -0.08378993f, -0.10737985f, -0.00588677f, 0.04498301f, 
    0.05244338f, -0.27666125f, -0.12090771f, -0.00934790f, -0.12594913f, -0.07034505f, -0.00583460f, 0.11419040f, 
    0.12384970f, -0.16277581f, 0.18230067f, -0.46457312f, -0.18890466f, -0.06835830f, 0.12606077f, 0.09021179f, 
    0.09558599f, -0.04945952f, 0.02650218f, -0.22633457f, -0.10683988f, -0.06095373f, -0.14265926f, 0.01700539f, 
    0.10957353f, 0.16400972f, 0.10626466f, -0.12019024f, 0.02346556f, 0.14875276f, -0.01704588f, 0.09646481f, 
    0.00359800f, -0.02516724f, 0.07575092f, 0.15118681f, 0.03379185f, -0.17383341f, 0.21649732f, 0.03758004f, 
    0.00015304f, 0.04283629f, -0.03546297f, 0.17579982f, 0.03004732f, 0.03102836f, -0.02280505f, 0.36989966f, 
    -0.07492759f, 0.00768176f, -0.14391774f, 0.02900269f, 0.16485584f, 0.07582502f, -0.05330625f, -0.33725378f, 
    0.15131974f, 0.07106306f, -0.05242656f, -0.18940093f, 0.01901862f, 0.05067673f, -0.02543280f, -0.08103908f, 
    0.06721475f, 0.06710231f, 0.03954957f, -0.08275381f, -0.01095612f, -0.13435040f, -0.00086265f, 0.05740254f, 
    0.04544149f, -0.04563259f, 0.03298837f, -0.02593613f, -0.06350411f, -0.00064157f, 0.02669194f, 0.09404332f, 
    -0.04907586f, 0.16478388f, 0.17492056f, -0.08214030f, -0.04960459f, -0.03410667f, -0.10228333f, 0.01442604f, 
    -0.07602367f, 0.06035852f, 0.10201062f, -0.28152177f, 0.07190392f, -0.32797480f, -0.12994109f, -0.21417965f, 
    0.03566826f, -0.10333868f, 0.18647347f, 0.08743719f, -0.17460431f, -0.01475675f, 0.11461931f, 0.22174925f, 
    -0.04478837f, 0.06550755f, -0.04344388f, -0.08326284f, 0.02253578f, -0.35181943f, -0.00181566f, -0.08503324f, 
    0.21558437f, 0.00099587f, -0.01217310f, -0.02532627f, 0.08996414f, -0.03223854f, -0.44380760f, 0.19143721f, 
    -0.01343377f, -0.08537877f, 0.18790905f, 0.04888732f, 0.09589547f, 0.04249164f, -0.05444766f, 0.16248257f, 
    -0.24934646f, -0.07625607f, -0.00075856f, -0.11987261f, 0.13161966f, 0.02070523f, -0.00502524f, 0.01578561f, 
    0.01189177f, 0.04910633f, 0.05811928f, -0.02702723f, 0.07983940f, 0.07605150f, -0.05045126f, -0.08370474f, 
    0.03409569f, -0.04188125f, -0.20316142f, 0.12247144f, 0.05751632f, 0.01745712f, -0.15711294f, 0.01578348f, 
    -0.08546219f, -0.18762511f, 0.03390465f, -0.21950646f, -0.06229559f, 0.19979042f, 0.01117955f, 0.00564060f, 
    0.03892946f, -0.15314353f, -0.06323142f, 0.09829851f, 0.16568053f, -0.08539112f, -0.05886785f, 0.04336614f, 
    0.09057210f, -0.03422885f, -0.15985601f, 0.11119131f, -0.11479226f, -0.11992140f, 0.07527725f, -0.05037531f, 
    -0.03908832f, -0.03000937f, 0.03086332f, -0.10707477f, -0.03129870f, 0.03052292f, 0.05843886f, 0.00350621f, 
    0.02894766f, -0.01673599f, -0.14619334f, -0.11095418f, -0.11707596f, 0.05337833f, 0.17695712f, -0.07621019f, 
    -0.03483443f, -0.13100922f, 0.04565115f, 0.29826203f, 0.02168123f, 0.10435445f, 0.06581900f, 0.37355375f, 
    -0.22097971f, -0.18349735f, -0.11037030f, 0.06378789f, 0.04223714f, 0.02870158f, 0.18852638f, 0.06298255f, 
    0.14390902f, -0.11066666f, -0.08419625f, -0.03774204f, -0.03546327f, 0.02301868f, 0.13418202f, 0.11080322f, 
    0.04945950f, 0.05219343f, 0.05277906f, -0.05707930f, -0.00818443f, -0.08963133f, 0.05851872f, 0.00317329f, 
    0.00862932f, 0.14724511f, -0.09070542f, -0.00807820f, 0.30801013f, -0.05871781f, -0.02189428f, 0.04205384f, 
    0.02143870f, -0.04804483f, 0.12716974f, 0.27221599f, -0.04135640f, 0.03181835f, 0.01171067f, 0.01664209f, 
    0.14064954f, -0.10639223f, -0.15350561f, -0.04309333f, 0.03796425f, -0.02143158f, 0.02173869f, -0.06388659f, 
    0.06762094f, 0.07753129f, -0.03175445f, 0.04601674f, 0.01234058f, 0.23910254f, -0.03072873f, 0.05225877f, 
    -0.20970076f, -0.10317691f, -0.15028599f, 0.01789299f, -0.04090024f, 0.15838736f, -0.05999611f, 0.10229317f, 
    -0.00933899f, -0.18008336f, -0.20851997f, -0.02255337f, -0.02840364f, 0.07278683f, 0.13125715f, 0.22322385f, 
    0.02027071f, 0.04352912f, -0.23383377f, -0.28117713f, 0.16796944f, -0.00298024f, 0.02253886f, -0.02304189f, 
    0.01619337f, 0.06140515f, 0.16798197f, -0.06283298f, -0.10126243f, -0.05332062f, 0.16051699f, -0.13505386f, 
    0.21478063f, -0.51078689f, -0.12866318f, 0.19216105f, -0.27893877f, -0.03872568f, -0.04653912f, -0.03177815f, 
    0.13562679f, -0.16057391f, 0.11816640f, -0.11257916f, 0.01839581f, -0.02838274f, 0.14473815f, 0.01824455f, 
    0.05349976f, 0.05313465f, 0.07320380f, -0.17828839f, -0.10233814f, 0.01818142f, -0.08421360f, -0.01022684f, 
    -0.02775781f, 0.08746425f, -0.01382909f, -0.06513919f, -0.10850543f, 0.10286065f, 0.16323791f, 0.00661272f, 
    -0.01579414f, 0.00563351f, -0.01638786f, 0.09987190f, 0.09946312f, 0.11088192f, 0.09062218f, -0.06930799f, 
    0.13019824f, -0.10765336f, -0.02526708f, 0.03641018f, -0.17663772f, -0.01084932f, 0.11000445f, 0.15585661f, 
    -0.06612939f, -0.05741170f, 0.01194651f, -0.05694951f, -0.23284726f, 0.02618572f, 0.12803802f, 0.21246476f, 
    -0.01269730f, -0.07117245f, -0.14856635f, -0.09990135f, -0.15055491f, -0.03326493f, -0.00479642f, 0.10298199f, 
    0.21832389f, 0.00145652f, -0.40473375f, -0.26692379f, 0.03691282f, -0.00624028f, 0.07930472f, 0.10450442f, 
    0.08832675f, 0.23392452f, 0.12458260f, 0.19386220f, 0.07062283f, 0.06875253f, -0.01265560f, 0.07111211f, 
    -0.00749546f, -0.11902069f, -0.19487463f, -0.26154247f, 0.03222569f, 0.04686356f, -0.12500329f, -0.02043762f, 
    -0.10555580f, 0.06626159f, 0.07217351f, 0.23596278f, -0.02805454f, 0.10758569f, 0.08490007f, -0.14729087f, 
    -0.00260413f, 0.01331010f, 0.17391604f, -0.00932777f, 0.10935336f, -0.19446205f, -0.26264229f, 0.12975891f, 
    0.00882877f, 0.08536471f, 0.10662153f, 0.09173429f, -0.00610134f, 0.06750314f, 0.19912209f, 0.22877991f, 
    -0.11177187f, 0.01275620f, -0.02482027f, 0.09076247f, 0.04644219f, 0.13445003f, 0.35178533f, 0.10401598f, 
    -0.32538694f, -0.04029735f, -0.00411769f, -0.12325748f, 0.13435856f, 0.06561749f, 0.02524261f, 0.07155292f, 
    -0.04087278f, -0.15724258f, -0.08138622f, 0.03747625f, 0.06961520f, 0.01738960f, 0.12587063f, 0.00122974f, 
    0.19196123f, 0.00598253f, 0.26585135f, 0.15078813f, 0.12908891f, -0.00113962f, 0.00006305f, 0.12402551f, 
    -0.17094524f, 0.05814627f, 0.24651009f, 0.31670806f, -0.03037740f, -0.13087045f, 0.06367394f, 0.00255813f, 
    -0.01297178f, 0.07879064f, 0.09091776f, -0.23638760f, -0.27045935f, -0.00567884f, -0.14903276f, 0.03554232f, 
    -0.00338332f, 0.05732324f, 0.01022051f, -0.04234361f, -0.24995887f, -0.24216774f, -0.11016051f, 0.09865308f, 
    -0.01582195f, 0.03712861f, -0.02740665f, -0.04688003f, 0.18667381f, 0.32628891f, 0.16430359f, 0.07216636f, 
    -0.02879749f, -0.05975382f, 0.02430339f, 0.08294089f, 0.05254764f, 0.14549161f, -0.08666266f, -0.20351541f, 
    0.00099400f, -0.01207452f, -0.00759471f, 0.01070296f, -0.03453944f, -0.01033067f, -0.12181061f, -0.23329800f, 
    -0.30682048f, 0.02325167f, -0.08289585f, -0.08071328f, -0.01516001f, -0.03779610f, 0.11367004f, -0.11428223f, 
    -0.01640992f, -0.61620194f, -0.12701149f, 0.00029552f, 0.12611827f, -0.02852753f, 0.12007486f, 0.00175892f, 
    -0.07476076f, -0.12611315f, -0.15631013f, 0.02132114f, 0.02181588f, -0.00703656f, -0.05562258f, 0.01835583f, 
    0.09931552f, 0.01668826f, -0.24493252f, -0.19802074f, 0.03254239f, 0.10954224f, 0.06089614f, -0.10457642f, 
    0.05833125f, 0.11204869f, 0.10574522f, 0.11617238f, 0.15234493f, 0.11532065f, 0.01345129f, -0.02294297f, 
    -0.03412798f, 0.08983006f, 0.12503049f, -0.29332244f, -0.52749300f, -0.02781202f, 0.09862532f, 0.00946492f, 
    0.03436648f, -0.07262698f, 0.13403028f, -0.01405469f, -0.09841520f, -0.05762709f, -0.21570705f, 0.14862643f, 
    0.06910190f, 0.16279311f, 0.09902020f, -0.04027633f, 0.01387797f, -0.26854897f, -0.33481064f, -0.33024928f, 
    0.00564970f, 0.05561908f, -0.18042654f, 0.03070426f, 0.08667017f, -0.11613139f, 0.11464848f, -0.02241848f, 
    0.06224120f, -0.00183488f, -0.06071670f, -0.19404390f, 0.00215255f, -0.00897997f, -0.10571083f, -0.20254794f, 
    -0.48592418f, -0.28495088f, -0.08876572f, -0.10370137f, -0.00845981f, -0.00044171f, 0.06062511f, -0.01322272f, 
    0.04396117f, 0.24718605f, 0.23495948f, 0.03642778f, 0.00025948f, 0.04330405f, -0.09376161f, -0.13792609f, 
    -0.05399457f, 0.24798203f, 0.20093511f, 0.20174929f, 0.01551018f, 0.00328860f, 0.04760428f, 0.00777292f, 
    -0.11084779f, 0.11062999f, -0.11269958f, -0.02778138f, -0.05099864f, 0.15453191f, -0.03035164f, 0.15633190f, 
    0.03080339f, 0.01112671f, 0.00256471f, -0.06043922f, 0.07688283f, 0.01013778f, -0.08951323f, -0.00122379f, 
    0.03834181f, 0.08779895f, -0.09524932f, -0.04887050f, 0.11987863f, 0.19463229f, 0.17744619f, -0.00242990f, 
    -0.00330849f, 0.01790127f, 0.06473278f, 0.01128129f, 0.15288877f, -0.05250686f, 0.08319148f, -0.00610150f, 
    -0.01894016f, 0.17263663f, 0.04810230f, 0.09499856f, 0.12546603f, 0.05026594f, -0.39645731f, -0.32777297f, 
    -0.01643979f, 0.02051631f, 0.00751053f, 0.12527205f, -0.10533274f, 0.08802716f, 0.14977008f, -0.25163370f, 
    -0.06742267f, -0.25473291f, -0.21204333f, 0.07442383f, 0.11174535f, 0.09142409f, 0.01445232f, -0.01784043f, 
    0.02528839f, -0.04996223f, 0.00593208f, -0.01986547f, 0.02358462f, 0.03139412f, -0.03441024f, 0.01541599f, 
    -0.05805201f, 0.06198203f, 0.03924360f, -0.00769615f, -0.00459631f, 0.05038581f, 0.00292985f, 0.02476023f, 
    0.03467905f, -0.01470146f, -0.17832878f, -0.06076273f, -0.11576606f, -0.03692969f, -0.05333877f, -0.06558681f, 
    -0.06164002f, 0.09408870f, -0.05827288f, -0.43869856f, -0.17365141f, -0.01966429f, -0.04385485f, 0.06233097f, 
    -0.29350057f, -0.03945886f, -0.13380520f, 0.02080188f, -0.10216623f, -0.04536304f, 0.17398793f, 0.08386197f, 
    -0.25348547f, -0.09735817f, -0.04720206f, -0.05180633f, -0.12700066f, 0.06596137f, -0.10071242f, 0.03649546f, 
    -0.09334812f, 0.15792681f, 0.02040622f, 0.11790807f, 0.12226453f, 0.01470340f, 0.61476195f, -0.16091700f, 
    0.17930843f, -0.03072615f, -0.19662100f, -0.06508102f, 0.11637495f, 0.06805953f, -0.19385549f, -0.03965395f, 
    0.01335463f, 0.06619450f, 0.05966982f, 0.08546183f, 0.13221720f, -0.02489006f, 0.11236673f, 0.08085112f, 
    -0.43486431f, -0.04374377f, 0.20893207f, -0.19736601f, -0.21413371f, 0.10194471f, 0.03174926f, -0.06724367f, 
    0.07944859f, -0.14397687f, -0.12074079f, -0.32436556f, 0.13016275f, -0.00722245f, -0.06659660f, 0.00209966f, 
    0.00999171f, 0.09991492f, 0.04942840f, -0.25157079f, -0.25732243f, 0.06103977f, 0.07628251f, 0.05057294f, 
    0.01283252f, -0.02024484f, 0.08058640f, 0.08972355f, -0.24301098f, -0.04130495f, 0.10864508f, 0.12627694f, 
    0.09853706f, 0.04013988f, 0.03579184f, -0.02926732f, -0.40698808f, -0.21278469f, -0.15834698f, -0.08347044f, 
    -0.19842251f, -0.01115805f, -0.07616464f, 0.00442894f, 0.09800372f, 0.08563028f, -0.11828677f, -0.07510152f, 
    -0.04137337f, -0.01439242f, -0.04976836f, 0.04888492f, 0.04177645f, 0.08683985f, -0.05698541f, 0.00851410f, 
    0.14425723f, -0.10848618f, -0.06485055f, 0.01098079f, 0.16187893f, -0.03854533f, -0.04401029f, -0.42727065f, 
    0.20547944f, -0.24248427f, 0.12956496f, 0.16786085f, 0.02887904f, -0.01547701f, -0.00557709f, -0.08702601f, 
    0.05660333f, 0.04048321f, 0.04819099f, 0.05151511f, 0.10547306f, 0.02849780f, 0.17344747f, 0.02746065f, 
    0.14683992f, -0.06824464f, -0.16805576f, -0.03422950f, -0.07526733f, -0.10477956f, 0.05289287f, -0.05275771f, 
    -0.04212327f, -0.18578309f, -0.01460778f, -0.11206748f, -0.06779170f, 0.05076639f, 0.00121855f, 0.10170268f, 
    0.07344220f, 0.14838386f, 0.11507981f, -0.29727781f, -0.15220350f, -0.02603336f, 0.16230989f, -0.05494954f, 
    0.13367647f, 0.13625555f, 0.18151110f, 0.16490163f, -0.02945371f, 0.04569505f, 0.25102150f, 0.04392678f, 
    -0.07956169f, -0.09064230f, -0.00476449f, 0.20177093f, 0.12210538f, -0.34623381f, -0.37016621f, 0.11423794f, 
    0.13053137f, -0.14079499f, 0.07660618f, -0.05009557f, -0.00755454f, 0.01960927f, -0.31563115f, -0.21459728f, 
    -0.01068712f, 0.02650208f, 0.05192936f, 0.02255413f, -0.00005658f, 0.03008274f, -0.05966413f, -0.00279386f, 
    0.01717180f, 0.18943188f, -0.09216389f, 0.02456691f, 0.02812972f, 0.16400497f, -0.02440859f, 0.06632052f, 
    0.21376677f, -0.00423504f, -0.17528149f, -0.03327022f, -0.06486998f, 0.04449238f, -0.05361599f, 0.06950697f, 
    0.10669473f, 0.00001673f, 0.00056291f, -0.04269727f, -0.12493388f, -0.04834893f, -0.03914388f, -0.07442421f, 
    -0.17983113f, 0.02202824f, -0.00528669f, 0.05733171f, 0.24827492f, 0.12588699f, 0.15323910f, -0.05769531f, 
    -0.02832506f, 0.13888767f, 0.12349448f, -0.05190200f, -0.11805989f, -0.11942749f, -0.17180246f, -0.08560685f, 
    -0.02780208f, -0.02051481f, -0.10104842f, -0.07430284f, -0.01762186f, -0.20634305f, -0.22374547f, 0.01565310f, 
    0.06574938f, 0.06105716f, 0.05089681f, -0.06615523f, 0.10599446f, 0.09088659f, -0.21078901f, 0.00391816f, 
    0.10747582f, 0.05526420f, 0.11796989f, 0.14758344f, 0.03634388f, 0.15019426f, -0.11835948f, -0.18930036f, 
    -0.19932677f, -0.05358849f, 0.01535808f, -0.12624829f, -0.02509850f, -0.07159759f, 0.06418182f, -0.24846508f, 
    -0.16393661f, -0.01682234f, 0.05051314f, -0.03669821f, 0.13134249f, 0.05879368f, -0.08218298f, 0.00353650f, 
    0.06614546f, 0.14021741f, 0.11784395f, 0.01666357f, 0.05774638f, 0.00192711f, 0.00035419f, -0.04245809f, 
    -0.14707141f, -0.19701912f, -0.17066546f, -0.07808472f, -0.02143675f, -0.15207879f, -0.04178064f, -0.05343803f, 
    -0.07178625f, -0.11083891f, 0.00270313f, -0.02863693f, -0.03805868f, -0.02564526f, -0.05966175f, -0.11257484f, 
    0.01322012f, 0.01682886f, -0.02122258f, 0.01591336f, -0.01319189f, 0.32781377f, -0.00104606f, 0.00829920f, 
    -0.07660761f, -0.05814126f, 0.06633368f, 0.23667499f, -0.08117849f, 0.06934991f, -0.17546639f, 0.02325042f, 
    0.04836668f, -0.17405255f, -0.07055580f, -0.13671558f, -0.06836218f, -0.12071797f, -0.04266156f, -0.12122502f, 
    -0.06778490f, 0.04477928f, -0.07053196f, 0.12302937f, -0.00766139f, 0.11146598f, 0.05990429f, -0.11612732f, 
    -0.00534592f, -0.09039349f, 0.22910315f, 0.10200835f, -0.01286375f, -0.08088684f, 0.03666382f, 0.08421792f, 
    0.16483384f, 0.02281318f, 0.05966362f, -0.04251970f, 0.00985076f, -0.01175393f, -0.01383760f, 0.10388187f, 
    0.15529068f, -0.11494201f, 0.19218789f, 0.03638801f, -0.07786081f, 0.04559272f, 0.05776422f, 0.10155733f, 
    -0.05829613f, 0.20853770f, -0.02428271f, -0.17750360f, -0.02886682f, 0.05796296f, -0.07555731f, 0.11931477f, 
    0.17465897f, 0.02539092f, 0.05749452f, -0.03930244f, 0.00426203f, -0.08743709f, -0.04612140f, 0.03741552f, 
    0.17513476f, 0.12626705f, -0.03358056f, -0.02015850f, 0.12962748f, 0.12680729f, 0.02143250f, -0.04068033f, 
    -0.11447331f, 0.18539874f, -0.01623831f, -0.00635171f, 0.07795370f, 0.02573324f, 0.03645022f, -0.04966493f, 
    0.04416329f, -0.03097904f, 0.18462324f, -0.03760820f, 0.19608288f, -0.09749267f, 0.03101951f, -0.01416689f, 
    -0.10482961f, -0.13792478f, 0.06020586f, -0.11139159f, -0.13337989f, -0.34980214f, -0.05504467f, 0.08535597f, 
    -0.06702393f, 0.09592686f, 0.13921715f, 0.08202239f, -0.02360615f, -0.06810135f, -0.21089020f, 0.07631028f, 
    0.29069152f, -0.06712043f, -0.10792026f, 0.27371171f, 0.06145602f, 0.04293752f, 0.20230012f, -0.04726456f, 
    0.05367634f, 0.08145737f, -0.01257242f, 0.01288576f, -0.05999366f, -0.19634007f, 0.14198172f, 0.13661337f, 
    0.24754970f, 0.04473980f, 0.17673457f, 0.02179554f, -0.01183696f, -0.10452460f, 0.12473063f, 0.15463519f, 
    0.20633890f, 0.07237365f, -0.13287517f, 0.07995314f, 0.03570322f, 0.00093023f, -0.01725757f, -0.10266951f, 
    -0.10631915f, 0.16149801f, -0.10323031f, 0.26907924f, 0.01231901f, 0.11475355f, 0.17476660f, 0.06526411f, 
    -0.00978955f, 0.05992015f, -0.11793792f, -0.02654543f, -0.11880150f, 0.03428409f, -0.17295937f, -0.01773667f, 
    -0.06583114f, -0.09598823f, 0.07218504f, -0.02315342f, 0.06738440f, 0.14032039f, -0.17460819f, 0.12001649f, 
    0.08027963f, -0.11396237f, 0.02872010f, -0.00533613f, -0.20327123f, -0.09399202f, -0.24632020f, -0.06736400f, 
    0.05879366f, -0.04546234f, -0.06018976f, 0.14378324f, -0.33986238f, -0.08738472f, -0.23582292f, 0.00396099f, 
    -0.03480432f, -0.07283573f, 0.14827070f, 0.10596611f, 0.05402276f, 0.10056834f, -0.15812682f, -0.14060888f, 
    -0.06146631f, -0.10256538f, -0.04051681f, -0.03949099f, -0.02285724f, -0.03027364f, 0.07630084f, 0.05736744f, 
    -0.06217789f, 0.01773191f, -0.03901243f, -0.02424005f, -0.22461212f, 0.07891885f, -0.00112693f, 0.21687302f, 
    -0.00603734f, 0.12605359f, 0.06649305f, -0.11569060f, -0.18127105f, -0.06185054f, 0.00762866f, 0.04226123f, 
    0.04517034f, -0.10661390f, 0.12057430f, -0.13492991f, 0.07666351f, -0.07315549f, -0.02311771f, 0.13868226f, 
    -0.13814248f, 0.09736884f, 0.01567424f, 0.06025409f, -0.05701320f, -0.06865667f, 0.00911975f, -0.02549216f, 
    0.01119524f, -0.06968995f, 0.09886731f, -0.03367533f, -0.09227480f, -0.18897279f, -0.07219448f, 0.10927401f, 
    -0.07106407f, 0.06541929f, 0.14329442f, -0.08768962f, 0.08555885f, -0.21754803f, -0.02706850f, -0.00872352f, 
    0.26889524f, 0.19781250f, 0.25806558f, -0.18133919f, -0.01694210f, 0.07169198f, -0.32232821f, 0.02211628f, 
    -0.01787832f, 0.15653932f, 0.08382622f, -0.06118149f, 0.16979344f, -0.17221576f, -0.12685812f, -0.15702325f, 
    -0.02065050f, -0.04711347f, 0.03983077f, -0.00732579f, -0.03399821f, -0.05241048f, -0.00312390f, -0.05487962f, 
    -0.00964085f, -0.02090253f, -0.03138868f, -0.04294754f, 0.02393290f, -0.04550900f, 0.01222182f, 0.04441898f, 
    -0.02590564f, -0.02813421f, 0.01072467f, 0.02990307f, -0.06466927f, 0.00932218f, -0.00200761f, 0.02065205f, 
    -0.00258185f, -0.05659436f, -0.03486690f, 0.03107537f, -0.01798787f, -0.02389254f, 0.02395867f, 0.01398870f, 
    0.00691435f, 0.00932968f, 0.00524976f, -0.01746927f, -0.05994760f, -0.03147485f, 0.02977195f, -0.02447245f, 
    0.03761134f, -0.01696496f, 0.00454189f, -0.04954702f, -0.06287999f, 0.00184226f, 0.02167379f, -0.02144391f, 
    -0.05365754f, 0.02984948f, -0.05189056f, 0.02289409f, -0.01282414f, -0.02348663f, -0.02527802f, -0.05873202f, 
    -0.05845523f, 0.05293980f, -0.05347835f, 0.00728817f, 0.01186249f, 0.01194788f, 0.02552607f, -0.01663502f, 
    0.04086929f, -0.04025564f, -0.01327832f, 0.03312075f, 0.05624394f, -0.01836736f, 0.02967519f, 0.04258644f, 
    -0.03877617f, -0.01167702f, -0.05424112f, 0.01991023f, 0.00103920f, -0.03446001f, -0.02539966f, -0.03626861f, 
    0.03085029f, -0.02534749f, 0.03359842f, 0.02355039f, 0.00679471f, -0.05024355f, -0.03178323f, -0.01116563f, 
    -0.03843502f, 0.04894616f, -0.00446107f, 0.01916560f, 0.01064059f, -0.03442072f, 0.02831500f, -0.00492848f, 
    -0.03878449f, 0.03653892f, 0.00898028f, -0.03821603f, -0.01549226f, -0.00827775f, -0.04863570f, -0.02275238f, 
    0.01738572f, -0.04057286f, 0.04792750f, -0.03486736f, 0.01159977f, 0.03696850f, 0.03554123f, -0.06593167f, 
    0.03524405f, -0.01979143f, -0.04454584f, -0.03227834f, 0.03996901f, -0.04199141f, 0.02895501f, 0.00768710f, 
    -0.04438947f, 0.04067969f, -0.05638334f, 0.04556871f, -0.00934055f, -0.04442179f, -0.02715028f, 0.00546295f, 
    -0.05389350f, -0.00422130f, -0.03154041f, 0.01805020f, -0.00890329f, -0.02255046f, 0.04774112f, -0.01053903f, 
    0.00085362f, -0.02006756f, -0.00674734f, -0.01143680f, 0.04688184f, -0.02891096f, -0.02563562f, 0.00809953f, 
    0.01014777f, 0.00195151f, -0.03607979f, 0.02280960f, -0.01499860f, 0.00977908f, -0.01939567f, -0.05513671f, 
    0.01996084f, -0.01910655f, -0.06000761f, -0.05071026f, -0.02017692f, -0.03323419f, 0.04668112f, 0.03470229f, 
    0.01768443f, 0.05341557f, -0.01698681f, 0.02515162f, 0.02190291f, -0.02742145f, -0.03897410f, -0.03107964f, 
    0.03852833f, 0.03859047f, -0.02647911f, -0.00062793f, -0.00165570f, -0.01343182f, -0.01303908f, 0.03368448f, 
    -0.06001623f, -0.06359292f, 0.05153278f, -0.03858031f, 0.03594286f, -0.00951598f, -0.02981396f, 0.00800561f, 
    0.00024651f, -0.03977704f, 0.01112165f, -0.04534691f, 0.05172237f, -0.06127021f, 0.04081359f, 0.02994705f, 
    -0.01009164f, 0.01163746f, 0.00164590f, -0.00074011f, 0.00868549f, 0.00422487f, 0.02648270f, 0.03210041f, 
    0.01122673f, -0.01454864f, -0.03453597f, -0.06189148f, 0.00988004f, -0.01731217f, -0.01018991f, -0.04886226f, 
    -0.00983932f, 0.04840625f, -0.01075695f, -0.04317865f, -0.03873609f, -0.00815426f, 0.00837388f, -0.03393651f, 
    -0.02848482f, 0.03566710f, -0.00266114f, -0.02038226f, -0.02683249f, 0.01813965f, 0.04671498f, -0.02338094f, 
    -0.00228436f, -0.03052159f, 0.00490197f, -0.01137602f, -0.01239030f, 0.02671626f, 0.05341208f, 0.00769359f, 
    0.03802946f, -0.05938496f, 0.04516681f, -0.05725554f, -0.04605815f, -0.06504149f, -0.00126897f, -0.00336486f, 
    -0.00021303f, 0.01272927f, -0.01274633f, -0.02718844f, 0.04471735f, -0.01774533f, -0.01833281f, -0.05587752f, 
    0.01894051f, -0.01670190f, 0.01977208f, -0.05056478f, -0.05079061f, -0.02961899f, 0.04616284f, -0.05587538f, 
    -0.00715482f, 0.04214353f, 0.01780324f, 0.00259685f, -0.00609871f, -0.04690740f, 0.02947848f, -0.01701521f, 
    0.05017376f, -0.01178215f, -0.00730339f, -0.05524051f, -0.01324906f, 0.04740536f, 0.01168367f, -0.02620240f, 
    0.03075141f, 0.04018003f, -0.02664580f, 0.01786992f, 0.00380795f, -0.02815920f, 0.01840464f, -0.04058707f, 
    0.02185780f, 0.03362281f, 0.02126423f, -0.02162698f, 0.01024825f, -0.00992013f, 0.01055852f, 0.03548821f, 
    0.00266872f, -0.00331529f, -0.04929021f, -0.01446228f, -0.01046190f, -0.00103352f, -0.07831322f, -0.02509241f, 
    -0.06006826f, 0.16512871f, 0.01610094f, -0.02740656f, -0.00601479f, 0.01255937f, -0.01831429f, 0.06317003f, 
    0.14445727f, 0.21225108f, 0.01025517f, -0.15117797f, -0.05120715f, -0.04505337f, 0.04411841f, -0.16684455f, 
    0.01260457f, -0.04740698f, -0.08629368f, -0.41112968f, -0.21067733f, -0.20544717f, -0.18134321f, -0.13291043f, 
    -0.00412365f, -0.16408794f, -0.05673029f, 0.13095227f, -0.33194622f, 0.10131538f, 0.20516597f, -0.06534851f, 
    0.02898036f, -0.03365016f, -0.03073928f, -0.03118872f, -0.04308218f, -0.15895911f, 0.04973524f, 0.16083601f, 
    -0.05768011f, 0.10318508f, -0.05349983f, 0.10840379f, -0.07443900f, 0.01302058f, 0.19885148f, 0.11243673f, 
    -0.19396552f, -0.05968703f, -0.03108737f, 0.19325361f, 0.05460605f, 0.13273661f, 0.09755045f, 0.06374543f, 
    -0.06090125f, -0.08181994f, -0.10892167f, -0.02650010f, -0.00123342f, 0.03256136f, 0.08005728f, -0.08241282f, 
    -0.21673484f, -0.56652743f, -0.01039085f, -0.17296581f, 0.06306276f, -0.00897620f, -0.12385395f, -0.19870301f, 
    0.05138165f, -0.23829073f, -0.27697715f, -0.49381137f, -0.02174979f, -0.08153506f, -0.02122595f, 0.03063397f, 
    -0.08689275f, -0.14986338f, 0.40006962f, -0.27161855f, -0.64428240f, 0.07508216f, 0.08834630f, 0.18476515f, 
    0.10236711f, -0.07383537f, -0.16511774f, 0.22309662f, -0.00575700f, 0.00983022f, 0.06577366f, -0.00888321f, 
    0.16748968f, 0.03457015f, 0.02135964f, 0.00611149f, -0.09601741f, -0.23293020f, -0.03413498f, 0.00583730f, 
    -0.10213806f, -0.03940998f, -0.04681630f, -0.13048048f, -0.01072331f, 0.01359725f, 0.05421404f, 0.06693894f, 
    0.02601145f, 0.04154771f, -0.00720587f, 0.02436647f, 0.19204168f, 0.12286382f, -0.00189242f, -0.03438461f, 
    -0.10703494f, -0.24476066f, -0.16830607f, -0.06283396f, -0.06755577f, 0.07693187f, 0.11483703f, 0.16880228f, 
    -0.09060664f, -0.38218373f, 0.03427941f, -0.05436395f, 0.17270797f, 0.17251995f, -0.14609274f, -0.05165288f, 
    0.09975217f, 0.07345477f, -0.05711108f, 0.02938002f, 0.00628052f, 0.02498563f, 0.00285005f, 0.11853305f, 
    0.03945525f, 0.17592537f, -0.28674138f, -0.15351968f, -0.06673893f, -0.01310294f, -0.04272405f, -0.03421662f, 
    0.04261601f, -0.14392367f, -0.17960764f, -0.29242665f, 0.04113026f, -0.04697536f, 0.10094475f, 0.10995895f, 
    0.00756414f, 0.07995714f, 0.13445032f, -0.13145462f, -0.10717738f, -0.13431849f, -0.20371762f, 0.00548631f, 
    0.02798385f, 0.01085496f, 0.01678014f, -0.02078944f, -0.01918919f, 0.15464513f, 0.10851085f, -0.01229543f, 
    -0.04720678f, 0.00235932f, -0.05270421f, 0.04526814f, 0.02031454f, -0.33163932f, -0.24900348f, -0.10298576f, 
    0.00161394f, -0.03372465f, -0.09416739f, 0.13055424f, 0.05753953f, -0.04452294f, -0.04628543f, -0.04111341f, 
    -0.02522308f, -0.02300381f, -0.00160170f, 0.05593814f, 0.03028436f, 0.20727862f, 0.29044279f, 0.10809340f, 
    0.03001617f, -0.12030477f, -0.11682601f, -0.03219475f, -0.09675854f, 0.05038182f, 0.02134440f, 0.03473919f, 
    -0.28802377f, -0.18962842f, -0.28488344f, 0.01920062f, 0.09647342f, -0.03445976f, 0.07311084f, -0.01052794f, 
    0.06704093f, 0.08064678f, 0.18104029f, -0.24484187f, -0.04129097f, 0.04008977f, 0.06787895f, -0.09128650f, 
    -0.12579066f, -0.09026953f, -0.10949210f, 0.13656554f, 0.16009429f, 0.05938531f, -0.09700579f, -0.02045082f, 
    0.06211181f, 0.04290684f, 0.07456593f, -0.13514934f, -0.02163863f, -0.07820806f, -0.04355851f, -0.01006671f, 
    -0.03748544f, 0.05270777f, -0.07191321f, -0.04431346f, -0.53067547f, -0.47057012f, 0.14079396f, -0.09826382f, 
    0.09370888f, -0.11349878f, 0.22022298f, 0.01531594f, 0.11670835f, 0.06649505f, -0.10140540f, 0.01459196f, 
    0.19679132f, -0.04661072f, 0.05389462f, -0.07165001f, 0.08397591f, 0.22004218f, -0.11771891f, -0.05255906f, 
    -0.05255290f, -0.00714750f, -0.03597278f, -0.00048359f, 0.08333346f, 0.26952374f, 0.13651101f, -0.10390315f, 
    0.00778217f, 0.09905671f, -0.09091309f, 0.04246205f, 0.00488165f, 0.13387878f, -0.06018692f, 0.09047644f, 
    0.17659320f, -0.04483158f, -0.10771764f, -0.00083389f, -0.10577599f, -0.07592717f, 0.08157071f, 0.09988365f, 
    -0.13443598f, -0.08729184f, 0.09976158f, 0.05213192f, 0.05811777f, 0.08399035f, 0.11975598f, 0.04929410f, 
    0.15201515f, 0.16290767f, 0.14944258f, 0.19690748f, -0.05146977f, 0.00914135f, -0.09184728f, 0.09650268f, 
    -0.07330273f, -0.10072030f, -0.04144406f, 0.13489231f, -0.09992924f, 0.10478339f, 0.11311220f, 0.12058163f, 
    0.09529112f, 0.07657990f, -0.01908636f, 0.09830188f, 0.20735428f, -0.37050274f, 0.05972757f, -0.11815932f, 
    0.15270802f, 0.10684682f, 0.22165710f, 0.08152248f, 0.00678137f, 0.12443979f, -0.10680493f, -0.11741917f, 
    0.03872382f, 0.06135910f, 0.09889255f, -0.09518915f, 0.02720515f, 0.00251475f, -0.13037108f, 0.00396308f, 
    0.28176808f, 0.01797569f, -0.12741765f, 0.16469328f, 0.08450278f, 0.09046053f, 0.26720032f, 0.07095163f, 
    -0.02803279f, 0.04909971f, 0.03485278f, -0.01886624f, -0.11788930f, 0.06674720f, -0.05737666f, -0.24338801f, 
    0.02994980f, -0.06807068f, -0.03239606f, -0.02635568f, 0.19672582f, 0.08488624f, 0.13836798f, 0.06296317f, 
    0.05949136f, -0.15494063f, 0.08620481f, 0.03201025f, 0.06517095f, 0.07288737f, -0.06668700f, -0.00595604f, 
    0.09497535f, -0.02707723f, 0.12257204f, 0.31890154f, 0.15583785f, 0.01395854f, -0.13034680f, -0.06829885f, 
    -0.04002260f, -0.25527164f, -0.19188204f, 0.07622980f, 0.01981746f, 0.09733914f, 0.08014633f, -0.12197389f, 
    -0.09487224f, -0.17808482f, -0.13893519f, -0.22227919f, 0.04678161f, 0.11946104f, -0.00874369f, 0.07971367f, 
    0.13952346f, -0.00385098f, 0.11916921f, 0.02666368f, -0.06954338f, -0.04750320f, 0.19796570f, -0.05880707f, 
    0.07615436f, 0.11758343f, -0.06361676f, 0.14363720f, 0.08540313f, -0.06002092f, -0.18808372f, -0.22637589f, 
    -0.14666644f, -0.03431329f, -0.08070374f, 0.04823834f, 0.12985671f, 0.06120587f, 0.02033811f, -0.03207768f, 
    0.10192172f, 0.05743280f, 0.14739965f, 0.02057246f, -0.03573777f, 0.14403655f, -0.05532734f, -0.09842142f, 
    -0.07371154f, 0.03602700f, 0.04153435f, -0.03768705f, -0.16122849f, -0.10639198f, -0.18806095f, -0.17282224f, 
    -0.37494600f, 0.01064264f, 0.07789113f, 0.08881736f, 0.00830841f, -0.05578357f, 0.01106660f, -0.00434068f, 
    -0.07813326f, 0.03351616f, -0.01669894f, 0.00039128f, 0.10155445f, 0.11915364f, 0.01319164f, -0.02468219f, 
    0.14533749f, -0.00785133f, -0.03902766f, 0.07316104f, 0.07031590f, -0.14636996f, -0.07436346f, -0.04884674f, 
    0.05192583f, -0.03937465f, -0.05946158f, -0.17548126f, 0.00277677f, -0.16064720f, -0.00243904f, -0.02232550f, 
    0.03138306f, 0.06351111f, -0.07547288f, -0.04071244f, -0.05784822f, 0.36885226f, 0.22178109f, 0.13193072f, 
    0.07226866f, -0.09745568f, 0.09399585f, -0.09386743f, -0.09492998f, 0.03187340f, 0.12350047f, 0.12630397f, 
    0.13254319f, -0.00720789f, 0.11888912f, 0.01145967f, 0.15269613f, 0.18598856f, 0.07334915f, -0.06855403f, 
    -0.10022577f, -0.14059430f, -0.06237473f, 0.09836125f, 0.03537896f, -0.02285681f, -0.00470403f, -0.10999171f, 
    -0.05273816f, 0.05920729f, 0.05056717f, 0.05537579f, 0.12582609f, 0.04137597f, 0.13926044f, 0.11750910f, 
    0.14866410f, -0.12845530f, -0.13209306f, 0.06949425f, -0.03589160f, 0.08072662f, 0.01197080f, 0.01183870f, 
    -0.05864650f, -0.33051941f, 0.08446474f, -0.20360525f, 0.09745042f, -0.02219834f, 0.10082797f, 0.00812526f, 
    -0.11278759f, 0.03942593f, -0.05104232f, -0.00098480f, -0.08212710f, -0.00686453f, -0.01777318f, 0.08945508f, 
    -0.01888960f, -0.16178378f, 0.02420990f, -0.12351482f, 0.08141685f, -0.00841983f, -0.04789865f, 0.08655450f, 
    -0.08449819f, 0.06894495f, -0.01837469f, -0.01815964f, 0.02196520f, 0.11322270f, 0.10448446f, 0.11029374f, 
    -0.02322249f, 0.02208063f, -0.03895243f, 0.01180284f, -0.06013326f, 0.00829121f, 0.19563444f, 0.24514976f, 
    -0.15500598f, -0.07008947f, -0.09981152f, 0.14684808f, 0.08045276f, 0.00190901f, 0.18234541f, 0.20648475f, 
    0.20686287f, -0.00483843f, 0.00624922f, -0.06631565f, 0.06408887f, 0.06980614f, 0.12214518f, 0.01946388f, 
    -0.05235326f, -0.05654131f, 0.12451003f, 0.02825596f, 0.01271960f, -0.21249837f, 0.03647893f, 0.12380133f, 
    0.08229904f, 0.07408967f, -0.07358877f, -0.00185051f, 0.02795210f, -0.08920241f, -0.00451196f, 0.03785550f, 
    0.01676488f, -0.12932010f, -0.19806860f, -0.23109834f, -0.25264844f, -0.27425140f, -0.33053327f, -0.10055324f, 
    0.07481167f, 0.12435014f, -0.01067123f, -0.25729626f, 0.18062623f, 0.17417465f, -0.01653217f, -0.11570971f, 
    -0.04386496f, -0.09032402f, 0.05955801f, 0.23839316f, -0.14324173f, -0.10064804f, -0.04217273f, 0.00289030f, 
    0.08305769f, -0.09004564f, 0.05441371f, 0.06603413f, -0.07419765f, 0.11039086f, -0.04042825f, 0.06041229f, 
    0.12833680f, 0.09658083f, -0.08281839f, 0.14916556f, 0.07974615f, 0.03114371f, 0.24745318f, 0.14329836f, 
    0.07653338f, 0.01768394f, 0.05987508f, 0.04703729f, 0.11175039f, 0.09754354f, 0.01601990f, 0.21916558f, 
    0.01237008f, -0.04887274f, 0.10337572f, -0.06266764f, 0.01744981f, 0.13587427f, 0.26642728f, 0.22487639f, 
    -0.06831271f, -0.10638150f, -0.12720683f, 0.04790450f, -0.03691340f, -0.03816287f, -0.00498770f, 0.01576112f, 
    0.08084967f, -0.22761995f, -0.20933703f, -0.18610884f, -0.03970503f, -0.04565162f, 0.10996262f, 0.05517039f, 
    0.16645244f, 0.15692726f, 0.02093342f, -0.09280996f, -0.23424032f, -0.07068598f, 0.04457024f, 0.03824188f, 
    0.05245305f, 0.29482660f, 0.07740104f, -0.16132952f, -0.02394801f, -0.05387830f, -0.12632293f, 0.10664151f, 
    -0.01765192f, 0.10793517f, 0.16137324f, 0.14923482f, -0.25513837f, -0.12628189f, -0.17617619f, -0.02434368f, 
    -0.00985575f, -0.01725076f, 0.07925683f, -0.00774909f, 0.09872942f, -0.09093593f, -0.00014511f, 0.02750024f, 
    -0.05435846f, -0.06459682f, -0.13084163f, -0.09346238f, -0.02828748f, -0.03154844f, -0.14810304f, -0.16363816f, 
    -0.14593343f, -0.12717475f, -0.09727171f, -0.11295813f, -0.12387662f, 0.08423878f, -0.00934651f, 0.24611019f, 
    0.33210838f, 0.06509884f, 0.02542020f, -0.01165365f, 0.01545340f, 0.12290962f, 0.22710462f, 0.33144131f, 
    -0.02979871f, -0.10006149f, -0.09420787f, 0.03336232f, 0.10284325f, -0.15201023f, 0.00618506f, 0.13692257f, 
    0.21807778f, -0.32180667f, -0.06463026f, -0.16884387f, -0.40386057f, -0.04062852f, -0.14635633f, -0.24936624f, 
    0.04256256f, 0.03044718f, 0.06583685f, 0.00451215f, 0.03886351f, 0.14484425f, -0.04975842f, 0.18237376f, 
    0.01002542f, 0.14421166f, 0.18803047f, 0.08125302f, 0.02411162f, -0.17155784f, 0.17826757f, -0.15418230f, 
    0.02129202f, 0.13112831f, 0.09399832f, 0.05013760f, -0.17947800f, 0.03691670f, -0.03045291f, 0.06393375f, 
    0.03647463f, -0.02549625f, 0.03548608f, 0.08439839f, 0.05591998f, -0.07442315f, -0.21367927f, -0.10808465f, 
    -0.10474434f, -0.09814014f, -0.19023153f, -0.04298005f, -0.02626793f, -0.29463467f, -0.11420520f, 0.01066941f, 
    -0.02111598f, -0.07693537f, -0.08782702f, 0.03288413f, -0.10221464f, -0.15972611f, -0.43049905f, -0.10213210f, 
    -0.06140405f, -0.11392391f, -0.15910822f, 0.05749556f, -0.23496525f, 0.07185474f, 0.02650721f, 0.04044063f, 
    -0.03745841f, -0.15807138f, 0.00827572f, -0.00447755f, 0.02645951f, 0.08050548f, 0.19039896f, 0.18661913f, 
    -0.15077333f, -0.28037286f, -0.23441172f, -0.46705449f, -0.02577480f, -0.06764128f, -0.07201093f, -0.01271138f, 
    0.02517870f, 0.05588409f, 0.02398491f, 0.12032187f, 0.00765550f, 0.10058309f, 0.02737388f, 0.07131525f, 
    0.09016812f, 0.07560436f, 0.16039579f, -0.26742914f, -0.16774401f, -0.34723291f, -0.10650676f, -0.11826249f, 
    -0.19044720f, -0.04316011f, -0.06790127f, -0.01307169f, 0.12302817f, -0.12627320f, 0.12845731f, 0.08197653f, 
    0.03034890f, 0.05689439f, 0.12339128f, 0.05085612f, 0.07915009f, 0.08422989f, 0.02855554f, -0.01398934f, 
    -0.00495101f, 0.04925254f, 0.13474913f, 0.15852955f, 0.19127701f, -0.00766412f, -0.21546483f, -0.03580475f, 
    -0.09809629f, -0.10385935f, 0.24474445f, -0.15895633f, 0.13471121f, -0.01128420f, 0.13168693f, -0.03472388f, 
    -0.08634312f, -0.07146244f, -0.13041563f, 0.02855119f, -0.14257109f, 0.13349961f, 0.13252555f, 0.03305740f, 
    -0.06020224f, 0.09442526f, 0.13995740f, -0.03168241f, -0.06745063f, 0.00105823f, 0.05462107f, -0.05712185f, 
    -0.06760111f, 0.19208068f, -0.09327101f, 0.14007764f, 0.04777497f, 0.06248573f, 0.10098439f, 0.16434820f, 
    0.16734047f, 0.08255686f, 0.21469316f, -0.14382954f, 0.04132902f, -0.09535806f, -0.17160146f, -0.12868698f, 
    -0.02528144f, -0.04499137f, -0.12986954f, -0.12903719f, -0.62203950f, -0.13261300f, -0.01078761f, -0.22639076f, 
    -0.09400456f, -0.06186713f, 0.05991925f, 0.12324968f, -0.16551009f, 0.00199452f, 0.63447475f, -0.18034562f, 
    -0.01983427f, -0.00218632f, -0.01168025f, -0.00598462f, 0.02376844f, 0.09366382f, -0.08785335f, 0.17871037f, 
    0.13041142f, -0.07075366f, -0.04743684f, 0.09171911f, 0.03542181f, 0.05042894f, -0.30951953f, 0.23912516f, 
    0.12037188f, -0.01059227f, 0.03022885f, 0.22028880f, 0.05290538f, 0.04422118f, 0.11320940f, 0.23941474f, 
    0.16593997f, -0.15270315f, 0.00134372f, 0.02431193f, -0.00498254f, 0.02549793f, -0.01547514f, 0.13584104f, 
    0.11296378f, -0.15058507f, -0.61160022f, -0.25591803f, 0.05534022f, 0.03657430f, -0.09951340f, -0.02626565f, 
    0.00050275f, -0.62407088f, -0.89409292f, -0.47330621f, -0.07202654f, 0.01050357f, -0.16863921f, -0.03156387f, 
    -0.14629334f, -0.03943530f, 0.10663825f, -0.18723306f, 0.02985361f, 0.06452833f, 0.04797047f, 0.08263342f, 
    0.01328785f, 0.07202758f, -0.08861231f, -0.07491742f, -0.00561279f, 0.17455488f, 0.02752448f, -0.05437406f, 
    0.14393654f, 0.11292963f, 0.05049629f, 0.09831396f, -0.13131666f, -0.58861774f, -0.28726968f, 0.06632459f, 
    -0.14944190f, -0.16284133f, -0.01932880f, -0.16715628f, 0.07781973f, -0.11925310f, 0.08701812f, 0.17595604f, 
    -0.03639550f, -0.01775535f, -0.03287851f, 0.04960840f, -0.00802071f, 0.05869577f, -0.15762532f, -0.09325443f, 
    -0.05162341f, -0.17518020f, -0.03251797f, -0.09216043f, -0.00701303f, 0.00624980f, 0.16365384f, 0.41898757f, 
    -0.29650044f, -0.08004190f, 0.13983062f, -0.21862479f, 0.08567840f, 0.07122809f, -0.00554234f, -0.03433451f, 
    0.04363393f, 0.02691263f, -0.13356802f, 0.00461063f, 0.06992951f, 0.00353506f, -0.01963855f, 0.06032711f, 
    -0.02597405f, 0.11305090f, -0.14050141f, -0.00869747f, -0.15288995f, -0.16153277f, -0.01892870f, -0.00416861f, 
    -0.05290024f, -0.05636733f, 0.04147970f, -0.00793822f, -0.14139681f, 0.08244874f, 0.18275514f, 0.07570529f, 
    0.03738873f, 0.07411230f, 0.00123538f, 0.28514883f, 0.26455984f, -0.14643835f, -0.09069423f, 0.09422502f, 
    0.00864197f, 0.05224876f, 0.07575506f, 0.04242685f, -0.12300140f, -0.03796774f, 0.18483683f, -0.07572426f, 
    0.07700983f, 0.01122768f, -0.14485282f, -0.02376441f, 0.03220694f, -0.13564037f, -0.08795892f, -0.05007619f, 
    -0.21973446f, -0.01931216f, -0.08256902f, 0.01968963f, 0.06852758f, 0.03188306f, -0.25962356f, -0.12337329f, 
    0.03767046f, -0.06062803f, -0.01228955f, 0.00100967f, 0.12490679f, 0.08278470f, 0.14640643f, -0.09354563f, 
    0.00679154f, -0.11647186f, -0.01581320f, 0.01722196f, -0.03515993f, 0.08165097f, -0.11347417f, 0.17561714f, 
    -0.32722896f, -0.17958581f, -0.12758116f, 0.02197154f, -0.05712726f, -0.06892302f, 0.17629960f, -0.02020221f, 
    0.04336765f, -0.30384997f, 0.07132712f, -0.33363608f, -0.09345079f, -0.00705756f, -0.09085428f, -0.04828936f, 
    -0.28682184f, -0.11756318f, -0.10998632f, 0.02995077f, 0.33955646f, -0.02900860f, 0.12884437f, -0.06103493f, 
    0.01419168f, -0.02989121f, 0.04533622f, -0.00634452f, -0.08731125f, -0.07447952f, -0.04437218f, -0.16242063f, 
    -0.08592454f, -0.02911904f, -0.09377343f, -0.13093224f, 0.12433479f, -0.27628613f, -0.08785843f, 0.05794432f, 
    0.10088450f, -0.07049254f, 0.11706972f, 0.07728133f, -0.03980425f, -0.00555109f, 0.09482108f, 0.05222221f, 
    0.04744821f, -0.04579360f, 0.05653470f, 0.04178467f, -0.04093542f, 0.17391804f, -0.22869015f, -0.14434987f, 
    -0.01872691f, 0.06379070f, -0.04208534f, 0.03476834f, 0.06016911f, -0.09952798f, -0.02430990f, -0.06374035f, 
    -0.12494514f, -0.07830090f, 0.00427678f, 0.01536639f, 0.05451941f, 0.11229740f, -0.08549388f, 0.02580232f, 
    -0.04045271f, 0.14535666f, 0.05300562f, 0.13330549f, 0.00652736f, 0.14197548f, 0.12390139f, 0.14088631f, 
    -0.00298332f, 0.07946446f, 0.07947481f, -0.08493020f, -0.08359513f, -0.03490908f, 0.00142957f, -0.02358099f, 
    -0.00976380f, -0.09867740f, -0.03725065f, 0.10514324f, -0.02580462f, 0.11320490f, -0.06723203f, -0.00457669f, 
    -0.22208880f, 0.00524635f, 0.04802093f, -0.03204457f, -0.15903632f, 0.14531681f, 0.00335081f, 0.07036968f, 
    -0.21662624f, 0.03333365f, 0.00389128f, -0.24787264f, -0.02080019f, -0.01814612f, -0.04177061f, -0.49172920f, 
    -0.13889664f, -0.07150717f, -0.28903642f, -0.20249154f, -0.17267844f, 0.18968903f, 0.04735763f, 0.03377418f, 
    -0.12571992f, -0.02514929f, 0.05371632f, -0.09121548f, 0.03528912f, 0.07216841f, 0.26517096f, -0.29554978f, 
    0.13457949f, -0.05425866f, -0.03928049f, 0.04378503f, -0.08228146f, -0.05658637f, -0.00716468f, 0.05395295f, 
    0.06874437f, 0.16922569f, 0.06883072f, 0.18789083f, -0.01247212f, -0.04516028f, 0.09271305f, 0.19138363f, 
    -0.01758525f, 0.18517733f, 0.09081480f, 0.15517488f, -0.09728017f, 0.18446833f, 0.03947349f, -0.00433974f, 
    -0.04540564f, 0.10745112f, -0.01157350f, -0.17393926f, 0.05663147f, 0.08520509f, 0.10653983f, 0.02924846f, 
    -0.02427269f, 0.01665161f, -0.49692520f, -0.09043987f, -0.17456846f, 0.10332589f, 0.08926549f, -0.04313833f, 
    -0.06548578f, -0.02831827f, 0.12788859f, -0.02646944f, -0.10141132f, -0.06193663f, 0.10177372f, 0.10013840f, 
    -0.01477904f, 0.12903136f, 0.02954747f, -0.00662790f, -0.02998791f, 0.03666844f, -0.19354038f, -0.22604927f, 
    -0.09111027f, 0.08539060f, 0.02439332f, 0.07204077f, -0.07139158f, -0.10296412f, -0.13793103f, 0.08904493f, 
    -0.08184932f, 0.04735968f, 0.20139150f, 0.16951974f, -0.03999292f, 0.00703347f, 0.04345580f, 0.12194818f, 
    0.17986272f, -0.12476467f, -0.15893947f, -0.22349805f, 0.06304711f, -0.18144262f, -0.08872116f, -0.41481230f, 
    0.14971760f, 0.00190017f, 0.27817613f, -0.14090788f, 0.10333006f, 0.12048663f, -0.10256422f, 0.11380199f, 
    0.03289675f, 0.02592425f, 0.14558354f, 0.04774614f, 0.00122802f, -0.07580589f, 0.19921383f, 0.16490544f, 
    0.23503783f, -0.32859951f, 0.01654394f, 0.07542926f, 0.04085177f, -0.04919286f, 0.00459088f, 0.01966909f, 
    -0.00690581f, -0.06522379f, 0.19238184f, 0.10827766f, -0.04357669f, 0.00799719f, -0.03793178f, 0.12640654f, 
    0.02443499f, 0.22106321f, 0.11233590f, -0.19656692f, 0.13559507f, 0.10472520f, 0.16150217f, -0.01876624f, 
    -0.12473901f, 0.11471846f, -0.04914407f, 0.05676469f, -0.00986023f, -0.14805484f, 0.04360104f, -0.01086448f, 
    -0.07335415f, -0.10843028f, 0.01963535f, -0.01326183f, 0.05975700f, -0.28316370f, -0.20694678f, 0.13502528f, 
    0.03580055f, -0.06970305f, 0.11552317f, 0.16770905f, 0.06560528f, -0.08867083f, -0.32200256f, -0.14228569f, 
    0.06104921f, -0.11481185f, -0.03920014f, -0.03762837f, 0.32873049f, 0.00040030f, -0.32356220f, 0.04234866f, 
    0.04386274f, 0.28478581f, -0.16110180f, 0.02352868f, -0.11314310f, -0.00149161f, 0.07465156f, -0.03635278f, 
    -0.03725478f, -0.22951826f, -0.59415418f, 0.02191904f, 0.03694151f, 0.04563120f, 0.02074154f, 0.05327572f, 
    -0.01679654f, 0.07693447f, -0.04596795f, 0.25658685f, 0.06899002f, 0.08906196f, -0.04683287f, 0.05486756f, 
    -0.00325956f, 0.05628954f, -0.03843872f, -0.21223231f, 0.07439348f, 0.02818950f, -0.03839933f, -0.09600691f, 
    -0.14702280f, -0.01602864f, 0.03736060f, 0.00891369f, -0.13993420f, 0.18276009f, -0.15364550f, -0.11698582f, 
    -0.05952225f, -0.09931086f, -0.06085099f, 0.06290713f, 0.41297087f, 0.12973334f, -0.15554358f, 0.02661640f, 
    0.03584583f, 0.16101004f, -0.03213491f, -0.07013055f, 0.08695411f, -0.24576528f, 0.06488685f, 0.07784598f, 
    -0.14176925f, 0.10382783f, 0.17162268f, -0.19224957f, 0.12334044f, 0.14581801f, 0.06211049f, -0.13853338f, 
    -0.13064326f, -0.09290019f, -0.03286131f, -0.02815589f, -0.00726295f, 0.04318840f, -0.04184692f, -0.30819157f, 
    -0.14122447f, -0.00938603f, -0.02714365f, 0.04975525f, 0.07991928f, 0.12978458f, 0.03362353f, -0.00217701f, 
    -0.33470616f, 0.06021519f, -0.20968264f, 0.00751122f, 0.06588201f, -0.11979652f, 0.01108634f, 0.11240475f, 
    -0.00508836f, 0.04206343f, 0.06207099f, 0.14877994f, 0.05116832f, -0.04152806f, 0.12202404f, 0.09848262f, 
    0.05964851f, 0.08572824f, 0.03444041f, -0.20035914f, -0.37242639f, -0.00733796f, -0.20460419f, 0.21583231f, 
    -0.04841339f, -0.09247927f, -0.05779017f, -0.04215771f, 0.27966306f, -0.25499782f, -0.02528225f, -0.18882632f, 
    -0.05199566f, 0.11742701f, -0.06434357f, 0.01715064f, -0.53041875f, 0.37788665f, 0.19313557f, 0.13146503f, 
    0.16126925f, -0.21164840f, -0.05895066f, -0.05698620f, 0.03262041f, -0.12455862f, -0.11103019f, 0.04775733f, 
    0.14833772f, 0.08020925f, 0.03198203f, 0.03399572f, 0.04453408f, 0.13084322f, 0.03233769f, 0.55048084f, 
    0.24919179f, 0.17760307f, 0.01948505f, 0.03101798f, 0.01596051f, -0.04594954f, 0.13288490f, 0.06963558f, 
    -0.21785003f, -0.30903870f, 0.02480914f, -0.06010545f, -0.01425750f, 0.05172573f, 0.14797927f, -0.04609176f, 
    -0.11845344f, -0.06610654f, -0.19344406f, 0.07643999f, -0.14656021f, 0.14606676f, -0.06466929f, 0.04308570f, 
    -0.03959813f, -0.02647433f, -0.10804848f, 0.15158570f, -0.04411333f, 0.01820292f, -0.11237655f, -0.03704270f, 
    -0.11134813f, 0.04898227f, -0.04985969f, 0.22282770f, 0.23212631f, 0.00890728f, 0.06620398f, -0.20234846f, 
    -0.03917353f, -0.12162716f, 0.00277057f, -0.09895214f, 0.09505106f, 0.15812241f, 0.00396519f, -0.01085516f, 
    -0.15827921f, 0.09437637f, -0.07637654f, 0.05421599f, -0.04068086f, -0.12406334f, 0.16726960f, -0.06659521f, 
    -0.04972097f, -0.11856684f, 0.03446620f, -0.17525971f, 0.05961511f, -0.42747703f, 0.09643979f, -0.24486147f, 
    0.10128614f, 0.03140678f, -0.16030286f, 0.05466761f, 0.20693095f, 0.14485162f, -0.12494148f, -0.20890069f, 
    -0.16873106f, -0.05838563f, 0.02512813f, 0.09781197f, -0.15141939f, -0.14292485f, 0.04441519f, 0.24065319f, 
    -0.03961040f, 0.01011670f, -0.09316239f, 0.06709294f, -0.14707816f, 0.04351184f, -0.06922838f, 0.03887806f, 
    0.01543074f, -0.31954476f, -0.27123922f, 0.02142607f, -0.02634762f, 0.05273368f, 0.03037953f, -0.10487303f, 
    0.00391281f, -0.35973161f, -0.04450117f, -0.26114905f, -0.22732797f, -0.10174257f, 0.08750480f, -0.02793651f, 
    0.06141586f, 0.10865156f, 0.08212968f, 0.00513727f, 0.07785054f, 0.05237155f, 0.00005614f, 0.10431719f, 
    0.02880879f, -0.04589397f, 0.11224360f, 0.50961059f, -0.13005370f, -0.24933603f, -0.17465653f, -0.24282803f, 
    -0.04359842f, 0.05263919f, -0.02367756f, -0.00180116f, -0.21822877f, 0.04407660f, 0.16750166f, 0.06127316f, 
    0.10504795f, -0.08236696f, -0.00804490f, 0.05702088f, 0.09390779f, 0.15155376f, 0.04588645f, 0.29552305f, 
    -0.01387950f, -0.03347618f, -0.12563825f, -0.13428816f, 0.03058363f, -0.10291430f, -0.02921821f, 0.09740704f, 
    -0.22494330f, 0.01543598f, -0.10154556f, -0.00276926f, 0.00327637f, -0.05358292f, -0.00745489f, 0.17358871f, 
    0.04381453f, -0.15967187f, -0.15875041f, -0.13650700f, -0.11551709f, -0.05246229f, 0.03272027f, 0.03144354f, 
    -0.03126410f, -0.06807529f, 0.31299141f, -0.08720841f, 0.03136468f, 0.02624919f, 0.08245897f, 0.10652639f, 
    0.01185031f, -0.16612342f, -0.02668080f, 0.13273606f, -0.01073947f, 0.02165032f, 0.02798966f, 0.08248725f, 
    -0.00008548f, -0.13103031f, -0.12926529f, 0.06082977f, 0.31171653f, 0.09408380f, 0.05033947f, -0.03265427f, 
    -0.06093943f, 0.07692406f, 0.12046259f, -0.50464523f, -0.37818396f, -0.04522461f, -0.03811298f, -0.00652568f, 
    -0.05904226f, -0.13016850f, -0.07877968f, 0.17188185f, -0.03309462f, -0.03717137f, 0.28540450f, 0.04773633f, 
    0.00560159f, 0.05912243f, -0.02806149f, -0.04802083f, -0.04150798f, -0.13255879f, 0.04504521f, 0.01162272f, 
    0.24140146f, -0.04453377f, -0.04670861f, 0.20180799f, 0.11818121f, 0.10501289f, -0.16578515f, 0.10642832f, 
    -0.18138868f, -0.14753319f, 0.04998733f, -0.27181861f, 0.07749791f, 0.10985794f, 0.10154062f, -0.04402494f, 
    -0.17878979f, 0.07335418f, 0.00060434f, 0.09154223f, -0.08192366f, 0.08714020f, 0.09335428f, -0.10349447f, 
    -0.20292991f, 0.03949925f, -0.15785715f, 0.00804028f, -0.07002490f, 0.04913048f, -0.09805015f, -0.04415832f, 
    -0.03379240f, 0.02428355f, -0.10704366f, -0.12574828f, -0.08920123f, 0.00867324f, 0.08314031f, -0.09677762f, 
    0.07502498f, 0.14165811f, -0.02909488f, 0.07379763f, -0.30944815f, 0.01108002f, 0.03807335f, 0.01011128f, 
    0.12613715f, -0.05629551f, -0.04911101f, -0.16850469f, -0.36792475f, 0.34323689f, -0.21117146f, 0.19361565f, 
    -0.39271742f, 0.04389127f, 0.01669196f, 0.01564664f, 0.21254030f, -0.10328081f, -0.28331479f, 0.06902514f, 
    -0.04010060f, -0.13041753f, -0.17694832f, 0.16088110f, 0.05076929f, -0.18973070f, -0.09867358f, 0.25504813f, 
    -0.00107113f, -0.11195178f, -0.03747129f, 0.00180078f, -0.05776219f, -0.03738698f, -0.39901385f, -0.42411822f, 
    0.00634202f, -0.01159445f, 0.15721080f, 0.24814883f, -0.14311367f, -0.04025805f, 0.10936946f, -0.10439982f, 
    -0.05616412f, -0.00325605f, 0.03179034f, 0.06952428f, -0.05366476f, 0.16041818f, 0.05671902f, -0.03626614f, 
    0.07598992f, 0.27122033f, -0.34192470f, -0.07852880f, -0.17573124f, 0.08983075f, 0.05598830f, -0.03795480f, 
    0.09727696f, 0.03934285f, -0.14611106f, 0.00243586f, -0.11212636f, 0.05164858f, -0.24069355f, -0.05435962f, 
    -0.03571200f, -0.04775579f, 0.06335820f, 0.37181741f, -0.15844797f, 0.15457733f, 0.01083947f, 0.12836313f, 
    0.15052286f, 0.02845674f, -0.07680984f, 0.11929269f, 0.17432460f, -0.02201130f, 0.06132388f, 0.01947899f, 
    0.01856864f, 0.22907533f, -0.03085168f, -0.08111163f, -0.18171009f, -0.15804766f, -0.08109308f, -0.11472981f, 
    -0.00447589f, 0.02266293f, 0.05120419f, 0.04784837f, 0.04953542f, -0.19156393f, -0.03894528f, 0.06298849f, 
    -0.12487622f, -0.02184844f, -0.02678371f, -0.01407159f, 0.09662317f, 0.08506812f, 0.06433510f, -0.18183719f, 
    -0.28957325f, 0.08241230f, -0.09823297f, -0.03861694f, -0.16533998f, -0.06484444f, 0.21622293f, -0.12643325f, 
    -0.33502051f, -0.09754593f, -0.06473987f, 0.00709045f, 0.09440614f, 0.17133558f, 0.17882390f, -0.03026114f, 
    -0.03704487f, -0.10978702f, -0.02738321f, 0.04281133f, 0.11507593f, -0.03843352f, 0.17543802f, 0.16663791f, 
    -0.04173716f, -0.10425816f, 0.34939823f, -0.26208749f, -0.03731130f, -0.26265725f, -0.05563411f, -0.04557331f, 
    0.02338047f, -0.15155989f, -0.14141534f, 0.01187460f, 0.21427181f, -0.11308394f, 0.06019573f, 0.00458157f, 
    0.10166054f, 0.17030415f, -0.08442099f, -0.24330206f, 0.18579388f, -0.18365788f, 0.12643255f, 0.04956704f, 
    -0.09041668f, -0.15488459f, 0.07363354f, 0.16799079f, -0.00026336f, 0.01567310f, 0.01095561f, 0.08438204f, 
    -0.00656830f, -0.11794052f, -0.00939845f, 0.02707456f, -0.14781639f, -0.20885773f, 0.28993267f, -0.04270938f, 
    0.04260521f, 0.00994755f, 0.12095001f, 0.13175216f, -0.02579364f, -0.03197421f, -0.06222737f, -0.20215121f, 
    0.12250288f, -0.02914672f, 0.11877571f, -0.28674829f, 0.14042571f, 0.02778538f, 0.36392507f, -0.05852948f, 
    -0.04831791f, -0.07215859f, 0.02704382f, -0.20391633f, -0.16516078f, -0.02378612f, 0.01863856f, 0.09988556f, 
    0.00067121f, -0.14597911f, 0.10516258f, -0.10392992f, -0.16100772f, 0.12421467f, 0.09445208f, 0.02572807f, 
    0.03460722f, -0.22470684f, -0.18261217f, 0.24739352f, -0.07985833f, -0.08674268f, 0.02718870f, 0.09411312f, 
    -0.02454063f, -0.07298733f, -0.04454586f, -0.07379349f, 0.04454667f, 0.10033333f, -0.07352644f, -0.03023425f, 
    0.07300279f, 0.00694555f, 0.05524025f, -0.30931854f, -0.09210964f, 0.16007176f, -0.04435494f, 0.02442017f, 
    -0.08049878f, -0.11871195f, 0.03747486f, -0.03546528f, -0.20420568f, -0.10093381f, 0.27943492f, 0.00698098f, 
    0.04232645f, -0.06137428f, 0.09706398f, 0.01681109f, 0.04238909f, -0.01999856f, 0.16061127f, 0.23654175f, 
    -0.06022254f, 0.05538952f, -0.11027709f, 0.06750853f, 0.25824618f, -0.02120439f, -0.07787561f, -0.11787632f, 
    0.31528124f, -0.02245389f, -0.04335089f, -0.27922297f, -0.10911338f, 0.07293475f, 0.15595810f, -0.18899706f, 
    -0.02076728f, 0.30983186f, -0.03084465f, 0.17672861f, -0.04660849f, -0.04239044f, -0.07654160f, 0.00022223f, 
    -0.18869360f, -0.03056190f, -0.01788721f, 0.11487269f, 0.12055077f, -0.01746226f, -0.20844933f, 0.04384395f, 
    -0.01123740f, 0.13806176f, 0.18221059f, 0.04320679f, -0.03463154f, -0.09610966f, -0.07119469f, 0.08951266f, 
    0.02795530f, -0.15593944f, -0.09549443f, 0.01573447f, -0.02479461f, -0.04906483f, 0.02184774f, 0.08328290f, 
    -0.08333800f, 0.12239240f, -0.05015661f, 0.11716181f, 0.32727087f, 0.41243851f, 0.18400931f, -0.01127678f, 
    -0.03149318f, 0.00322558f, 0.09890279f, 0.05250071f, 0.24944262f, -0.05307863f, -0.27037996f, 0.02321196f, 
    -0.16410239f, -0.10081534f, 0.02301602f, 0.00695121f, -0.00594887f, 0.29005456f, 0.11600731f, 0.10023489f, 
    -0.08792949f, 0.02400437f, -0.03541277f, 0.00444557f, 0.12593932f, 0.06807496f, -0.00794539f, -0.08047125f, 
    -0.10958635f, -0.03782568f, 0.15403867f, 0.07880510f, -0.04240616f, -0.11829247f, -0.18793038f, -0.07233106f, 
    0.12504421f, -0.00826903f, -0.10301288f, -0.00751919f, -0.02610088f, -0.01958189f, 0.05246818f, 0.23050517f, 
    0.11411575f, 0.28315464f, 0.36261487f, 0.02807154f, -0.08001372f, 0.16454624f, 0.14576958f, 0.00220303f, 
    -0.04282313f, 0.16423489f, 0.37649265f, 0.06432091f, 0.08186779f, 0.11222877f, 0.18292671f, 0.08448034f, 
    0.05499781f, 0.07884406f, -0.36003834f, -0.19877246f, -0.14088696f, 0.02643632f, 0.05047966f, 0.06340854f, 
    0.00000014f, -0.12955937f, -0.00686146f, -0.03227105f, -0.22117485f, -0.01653663f, -0.06825545f, 0.03835827f, 
    0.04911144f, 0.10514697f, -0.09693424f, 0.11564410f, 0.17999505f, 0.33192515f, 0.03441985f, 0.13890950f, 
    0.02330395f, 0.10655245f, 0.00600410f, -0.02725302f, 0.05167758f, -0.23999108f, -0.13508998f, -0.04256605f, 
    0.02904888f, 0.02913690f, 0.02334691f, -0.32257032f, -0.27943948f, -0.19838889f, -0.04742650f, 0.03732751f, 
    -0.01233817f, 0.16615805f, 0.17628567f, 0.02771652f, -0.07257899f, -0.13850772f, -0.07633761f, -0.19668768f, 
    0.24572746f, 0.12543477f, -0.14255857f, 0.40879217f, 0.19675715f, -0.05650028f, -0.04149005f, 0.10427564f, 
    0.05141887f, 0.07993007f, 0.00015532f, -0.14729416f, -0.03310316f, -0.05796999f, -0.08448867f, 0.14842470f, 
    0.18365835f, -0.21084946f, 0.07167057f, -0.00398228f, -0.00738911f, 0.19521357f, 0.09961054f, -0.20985481f, 
    -0.09779867f, 0.23154971f, 0.19290419f, 0.15771204f, -0.00147440f, 0.00447264f, -0.01771209f, 0.00853727f, 
    -0.03081889f, 0.10139816f, -0.17899245f, -0.23582457f, -0.03139518f, 0.21964350f, 0.14930597f, -0.10778186f, 
    -0.01721650f, -0.02322290f, -0.10004008f, 0.00391446f, 0.11699074f, 0.02312442f, -0.10538693f, -0.01932868f, 
    -0.04947200f, 0.04768724f, 0.02609837f, 0.03930002f, 0.05334843f, -0.18714352f, -0.34206250f, -0.10578671f, 
    0.08325388f, 0.06058607f, 0.10104442f, -0.10990311f, -0.25922245f, -0.17570868f, -0.11398917f, -0.10042962f, 
    0.00429711f, -0.01609847f, -0.00623253f, 0.04546808f, -0.20412284f, -0.19773492f, -0.36859536f, -0.08124255f, 
    -0.07319016f, -0.09884246f, 0.02522280f, -0.06986899f, 0.01382633f, -0.02104355f, -0.15049715f, -0.11656130f, 
    0.00082466f, 0.26450077f, 0.01265387f, 0.04273639f, 0.07770399f, 0.06912262f, 0.06158268f, -0.05373695f, 
    -0.26280421f, 0.09243891f, 0.24806117f, 0.15988742f, -0.01374128f, 0.22957017f, 0.00025365f, 0.13651817f, 
    0.02675488f, 0.17860143f, 0.17334796f, 0.06493582f, -0.08432356f, -0.05730404f, -0.12679663f, -0.01598190f, 
    0.07544091f, 0.06523796f, 0.03654955f, 0.20014691f, 0.11885667f, 0.10399239f, 0.04353638f, 0.12549840f, 
    0.01824799f, 0.05850170f, 0.13284388f, 0.15896688f, 0.09168695f, 0.10478461f, -0.03872100f, 0.00868149f, 
    0.08634634f, 0.08357646f, 0.01608360f, -0.03108595f, -0.33171710f, -0.20467411f, -0.07075085f, 0.05258278f, 
    -0.01112628f, -0.00034244f, -0.00463789f, -0.22559349f, 0.07121762f, -0.26035264f, -0.04574544f, 0.06169679f, 
    0.16475368f, -0.07030136f, 0.05515886f, -0.09204144f, -0.10765261f, 0.06067833f, -0.17010826f, -0.21920887f, 
    -0.21364185f, 0.06716458f, 0.01653312f, 0.01711995f, 0.02255485f, -0.15323541f, -0.23240907f, -0.17024598f, 
    -0.01387938f, 0.02335143f, 0.21219718f, -0.01381309f, -0.00054143f, -0.03709722f, -0.04643576f, -0.04684028f, 
    -0.02019657f, 0.06157382f, 0.06955752f, -0.16283247f, -0.02298477f, -0.00768023f, -0.01135982f, 0.01305264f, 
    -0.02631555f, -0.05185726f, 0.03770153f, 0.18438542f, 0.10271662f, 0.01008764f, -0.14463872f, 0.05514061f, 
    -0.00147458f, 0.04970624f, 0.05371371f, -0.48566535f, -0.04289950f, 0.54905915f, 0.08661455f, -0.01148438f, 
    -0.02666151f, -0.00499586f, -0.02281140f, -0.22223377f, -0.34236011f, 0.15586813f, 0.00936758f, -0.01196638f, 
    -0.03590574f, -0.16588241f, -0.15572894f, 0.03928896f, -0.13685678f, 0.03035302f, 0.03590627f, 0.15813370f, 
    -0.04940135f, 0.11329883f, 0.15857995f, 0.13652384f, -0.01978732f, -0.00673770f, 0.10057138f, -0.25559154f, 
    -0.12394971f, -0.00204888f, -0.06725258f, 0.16006181f, -0.08887453f, -0.17335442f, -0.17414449f, -0.08329210f, 
    0.16384594f, 0.12235016f, -0.07674173f, 0.12189506f, 0.06621433f, -0.01614679f, 0.08932228f, 0.00226689f, 
    -0.27884868f, 0.04907056f, 0.01437623f, -0.15454586f, -0.01883326f, 0.18833365f, -0.08969739f, 0.06366929f, 
    0.07220653f, -0.22253662f, 0.22136310f, 0.06571221f, 0.09289934f, 0.19152348f, -0.17583515f, 0.15855761f, 
    0.04860448f, 0.12578288f, -0.01477104f, -0.04191767f, -0.09876771f, 0.06404351f, -0.13640052f, 0.03375591f, 
    0.13596706f, 0.00089363f, 0.17650554f, -0.02668741f, -0.00413549f, -0.03602841f, -0.01644059f, 0.06962701f, 
    0.02934253f, 0.05992879f, -0.18718269f, 0.14305839f, -0.31112009f, 0.28273222f, 0.11635672f, -0.11774246f, 
    0.01765394f, 0.03386678f, 0.02008751f, 0.08110113f, 0.09683950f, 0.13053520f, 0.11015417f, 0.09140125f, 
    -0.07739185f, -0.04126270f, -0.16296086f, -0.10240687f, -0.00468146f, 0.06798362f, -0.15529582f, -0.03738163f, 
    0.03794168f, 0.09750564f, 0.07765426f, -0.08860677f, -0.08213532f, -0.14953275f, -0.06472620f, -0.37132591f, 
    -0.13723099f, 0.12229132f, 0.05725154f, 0.07023248f, 0.10562320f, 0.06735920f, -0.05690179f, -0.01527722f, 
    -0.01818273f, 0.01503183f, -0.01108890f, -0.04943154f, 0.01156576f, 0.07810576f, 0.19921803f, 0.05631892f, 
    0.09543256f, 0.15273257f, 0.20947473f, 0.21381249f, -0.12050795f, -0.06079873f, 0.04670087f, -0.09393142f, 
    -0.00123952f, -0.04370547f, -0.00886491f, 0.11868884f, 0.00122977f, -0.08254560f, 0.06936215f, -0.09492281f, 
    -0.09085640f, 0.09473701f, 0.03714419f, -0.38063118f, -0.02339969f, 0.14564599f, 0.10256645f, 0.07341322f, 
    0.06254443f, 0.00153672f, 0.11023326f, -0.06369661f, -0.16094528f, -0.22698076f, 0.02237510f, -0.03485432f, 
    0.05622708f, -0.03573735f, 0.03384829f, -0.01025431f, -0.00653388f, -0.15464552f, -0.17206189f, 0.29692259f, 
    0.02690662f, -0.15492450f, 0.02812722f, 0.01452592f, 0.07088075f, -0.05501176f, -0.21839531f, -0.28310531f, 
    0.18254025f, 0.10986642f, -0.14511772f, -0.05885014f, -0.05357798f, -0.02824531f, 0.01945089f, -0.13639261f, 
    0.03535121f, 0.14486748f, 0.06431030f, -0.02659584f, -0.05885290f, 0.01095892f, 0.01718290f, 0.00191804f, 
    0.04493950f, 0.08823988f, -0.14476600f, 0.05862239f, -0.04915600f, 0.01944399f, 0.07408360f, 0.01207453f, 
    0.07253711f, 0.10288914f, -0.01577415f, 0.03092034f, 0.06799785f, -0.16148724f, -0.00486326f, 0.15337580f, 
    -0.10170295f, 0.12633634f, -0.24323528f, -0.10064357f, 0.00214458f, 0.12611955f, 0.11335849f, -0.01821270f, 
    0.06476477f, -0.08677063f, 0.04708987f, -0.01472761f, 0.07599245f, -0.07885961f, -0.23923519f, -0.00314240f, 
    0.06196025f, 0.03579279f, 0.00299721f, -0.05859929f, -0.17552881f, 0.00118562f, 0.01006188f, -0.07047824f, 
    0.01451813f, 0.01539741f, 0.13050681f, 0.11566030f, 0.04408792f, 0.15306664f, 0.06514756f, 0.13766710f, 
    -0.05036415f, -0.06968633f, -0.05712818f, -0.03082907f, 0.00634871f, 0.05130592f, 0.01523770f, -0.07802366f, 
    0.41035613f, 0.01195040f, -0.07209405f, -0.15318628f, 0.04122438f, -0.20394327f, 0.03610168f, 0.05750819f, 
    -0.35481793f, 0.24525733f, 0.01931859f, 0.05488610f, -0.14087719f, 0.14197271f, -0.04910829f, -0.03285705f, 
    0.04342024f, -0.14117607f, 0.13013759f, -0.08518641f, -0.05750826f, 0.25627407f, 0.07481572f, 0.04787585f, 
    -0.07576045f, 0.19854234f, 0.20857064f, 0.40402082f, 0.14135182f, 0.13006540f, 0.13736746f, 0.15085424f, 
    0.08015303f, 0.01076526f, -0.12577906f, -0.10019305f, 0.02665230f, 0.14990056f, -0.22637658f, -0.08773439f, 
    -0.07897573f, -0.00580324f, 0.10767590f, 0.40086296f, -0.30807632f, 0.20583902f, 0.07784612f, 0.10899477f, 
    0.06059720f, 0.15965579f, 0.02743303f, 0.04452446f, 0.27102119f, -0.08436371f, 0.16213866f, -0.12583002f, 
    -0.01423624f, -0.00802158f, 0.11474166f, 0.01169852f, 0.05034355f, 0.10574038f, 0.14677097f, 0.21442936f, 
    -0.00149700f, -0.08539689f, 0.18057196f, -0.02268372f, -0.00721556f, 0.03058588f, 1.04871869f, -0.14487226f, 
    -0.39751074f, -0.07788529f, 0.09971509f, 0.07362235f, 0.04551187f, 0.07740910f, 0.05690014f, -0.15645376f, 
    0.06440807f, -0.40148276f, -0.23941083f, 0.26097831f, 0.06579275f, 0.06694162f, 0.08571509f, 0.03347211f, 
    0.08673675f, 0.07067385f, 0.24507269f, -0.08794742f, 0.05955054f, 0.05460786f, 0.07526352f, 0.01720586f, 
    -0.01129885f, -0.06273933f, 0.23661155f, 0.10580695f, -0.10319664f, -0.13640377f, 0.06414776f, 0.01018190f, 
    -0.09272411f, 0.01790405f, -0.03618881f, -0.20487009f, -0.18601134f, -0.01330673f, -0.18767202f, -0.11417679f, 
    -0.14884694f, -0.03789158f, 0.07362267f, 0.04245813f, -0.26725814f, -0.15694645f, 0.07280777f, -0.03025822f, 
    0.09957924f, -0.02337394f, 0.21028812f, 0.02861995f, 0.06842978f, 0.18340874f, 0.01871365f, 0.00122871f, 
    -0.10243586f, 0.00775794f, -0.01832912f, 0.02323710f, -0.00917263f, 0.12534915f, -0.09413576f, 0.02376030f, 
    -0.00743518f, -0.08057211f, 0.00392041f, -0.00643439f, 0.05503654f, 0.06464726f, -0.29247826f, -0.09530295f, 
    -0.15129183f, -0.00617803f, -0.04578950f, -0.17766103f, 0.07166953f, 0.13165125f, 0.12749946f, -0.38155851f, 
    -0.72032052f, -0.19661789f, -0.04986485f, -0.10270510f, -0.03506653f, 0.10585628f, 0.02239092f, -0.21806355f, 
    0.03058687f, 0.05999222f, -0.16852532f, -0.17407635f, 0.11814679f, -0.01955896f, 0.05781437f, 0.06450237f, 
    0.04350758f, 0.18905748f, 0.14215207f, -0.14072986f, 0.16105418f, -0.15190758f, 0.03405831f, -0.08753403f, 
    0.05132626f, 0.07054333f, -0.00595844f, 0.15975368f, 0.17989533f, -0.02756819f, 0.13389203f, -0.08915326f, 
    -0.03507303f, -0.07145806f, 0.04329036f, -0.19760650f, -0.40253115f, 0.05760122f, 0.08793960f, 0.06450053f, 
    -0.06165834f, 0.11312027f, 0.15346847f, 0.15860811f, -0.07008852f, -0.18886013f, -0.25129882f, 0.00755565f, 
    -0.02669341f, 0.13824373f, 0.05163303f, 0.09545691f, -0.01908264f, -0.55773228f, -0.18738367f, -0.61643201f, 
    0.02823546f, -0.03005835f, -0.11682049f, 0.09937336f, 0.11054596f, -0.04653833f, 0.01333087f, -0.17639986f, 
    0.06684559f, 0.03366431f, 0.04044155f, -0.07573069f, 0.06310477f, 0.06658223f, -0.08242671f, -0.27233037f, 
    -0.03764403f, 0.02690967f, -0.10344812f, -0.12114501f, -0.02679110f, 0.22184347f, 0.03171707f, 0.21847168f, 
    -0.11565127f, 0.18453977f, 0.07254428f, 0.08429240f, 0.01093153f, -0.01424733f, -0.07501308f, -0.07982486f, 
    0.05966821f, 0.08447868f, 0.12682070f, -0.13484275f, -0.00150998f, 0.02350452f, 0.07588989f, 0.08971273f, 
    -0.02726239f, 0.05223540f, -0.09089775f, -0.15448791f, -0.07082461f, 0.08775958f, 0.07201335f, 0.10958758f, 
    0.06660562f, 0.01403131f, 0.01230426f, -0.30296057f, -0.03124748f, -0.05504964f, -0.08845203f, -0.08397191f, 
    0.15846817f, -0.00221843f, 0.06970309f, -0.06600041f, -0.02513154f, 0.16400571f, 0.07625343f, -0.03583134f, 
    -0.09608575f, -0.00035691f, -0.03406023f, 0.05921111f, 0.11125329f, -0.10123426f, 0.13913551f, 0.04432665f, 
    -0.09947851f, 0.04224642f, 0.05684671f, 0.02356881f, 0.11935123f, 0.20268840f, -0.19723167f, -0.31065938f, 
    -0.07909372f, -0.00997329f, -0.07850520f, -0.09051521f, -0.14461938f, 0.03911470f, -0.02928685f, -0.41675422f, 
    -0.12665446f, -0.38785675f, -0.07564789f, 0.01253141f, -0.08215885f, -0.06551827f, 0.00244644f, 0.00419278f, 
    0.14517730f, -0.04219947f, 0.25028133f, -0.09000634f, 0.16009137f, -0.52721345f, 0.05051481f, -0.07818881f, 
    0.12584327f, 0.15659420f, 0.05786870f, -0.23387115f, -0.10876688f, 0.01761209f, 0.02523073f, 0.01362367f, 
    -0.00961799f, -0.05576091f, 0.10295699f, 0.01804131f, 0.18301423f, 0.07206208f, 0.20159377f, 0.02242409f, 
    0.01954735f, -0.07392674f, -0.07938703f, 0.08827675f, 0.13107316f, -0.14170524f, -0.16776393f, -0.05854249f, 
    0.07027101f, 0.04804124f, -0.02370829f, 0.12497149f, 0.39002106f, -0.06857863f, -0.08851153f, 0.01974992f, 
    -0.21615124f, 0.12297202f, 0.03962251f, 0.02908319f, -0.02698728f, 0.06488935f, 0.25623915f, -0.29711020f, 
    0.12897938f, -0.06354993f, -0.02883720f, -0.00211415f, 0.02411609f, 0.10958202f, -0.16252729f, 0.07901497f, 
    -0.57986575f, -0.09187640f, 0.17710039f, -0.13963045f, 0.06006870f, 0.05748455f, -0.06141664f, -0.14672096f, 
    -0.05496847f, 0.14545353f, -0.08054958f, -0.06320506f, -0.09178896f, 0.00565480f, -0.13521160f, -0.04989502f, 
    0.34378475f, 0.20698717f, 0.23836018f, -0.15471062f, -0.05263609f, 0.01333571f, 0.00831402f, -0.11894853f, 
    0.09905615f, 0.20432764f, 0.14343484f, -0.00711751f, -0.13802643f, -0.15991336f, -0.09027844f, -0.09178575f, 
    0.04584106f, -0.08141065f, 0.03373771f, -0.04244030f, -0.01706887f, -0.06273908f, 0.01055134f, -0.13157098f, 
    0.05185663f, 0.04199537f, -0.17238125f, 0.10700904f, 0.15315270f, -0.01733916f, -0.02762710f, -0.06473365f, 
    0.02631922f, 0.01562078f, -0.07029629f, -0.14896162f, 0.29238215f, 0.21132030f, 0.15114701f, -0.02240949f, 
    -0.13267125f, 0.03452602f, -0.02217562f, -0.11205591f, 0.03928601f, 0.04539805f, -0.08488302f, 0.19384366f, 
    0.06157453f, 0.12123148f, -0.09288223f, 0.08669540f, -0.00927609f, 0.09395400f, 0.21262024f, -0.00624015f, 
    0.27217296f, -0.18180384f, -0.39777932f, -0.31701943f, -0.02069981f, 0.02570806f, 0.02919810f, 0.02960047f, 
    -0.21125375f, -0.23396727f, -0.10873938f, 0.33872956f, 0.04743569f, -0.06722339f, -0.02352170f, -0.03069521f, 
    -0.06812830f, 0.06285466f, 0.07650689f, -0.05084165f, -0.04733312f, -0.03851675f, -0.04026847f, -0.10029450f, 
    -0.05115320f, 0.09645356f, 0.09513971f, 0.09496184f, 0.01986599f, -0.08512008f, 0.03903597f, -0.03722382f, 
    0.03816355f, 0.06431348f, -0.07833582f, 0.08017191f, 0.08843076f, 0.05238220f, -0.01948866f, -0.04562758f, 
    0.00468722f, -0.03608966f, 0.05394713f, -0.04708805f, -0.15185596f, 0.49778903f, -0.13597815f, -0.08408421f, 
    -0.32765126f, 0.02870709f, 0.04090203f, -0.03560897f, 0.17916374f, 0.02673257f, -0.04756168f, 0.03038490f, 
    -0.25145426f, 0.02831750f, 0.02309552f, -0.00444318f, 0.09360314f, 0.02075039f, 0.10555527f, 0.17216001f, 
    0.01582683f, -0.04156211f, 0.01671083f, 0.06461900f, -0.08542126f, 0.01330901f, 0.00024071f, 0.09466367f, 
    -0.04715722f, 0.08213213f, -0.08742913f, 0.04770771f, 0.00928700f, 0.15632723f, -0.02773921f, 0.16669683f, 
    0.08768230f, 0.21974464f, -0.09043008f, -0.53897893f, -0.27323917f, -0.00122536f, 0.10403391f, 0.02988260f, 
    -0.06741418f, 0.10480908f, 0.04500338f, -0.12488333f, -0.10383649f, -0.04433284f, 0.05126036f, -0.03313088f, 
    0.15823920f, -0.05120495f, 0.61086512f, -0.07179402f, -0.01011766f, 0.06175516f, 0.05483003f, -0.07428994f, 
    -0.02668534f, -0.01909144f, 0.17765410f, -0.08979557f, -0.17108777f, -0.04974519f, -0.19393998f, 0.08026543f, 
    0.00592365f, 0.06793299f, 0.09930914f, -0.04055128f, 0.21902359f, -0.12111068f, 0.17385425f, 0.06924830f, 
    0.04175266f, 0.02207673f, 0.03189630f, 0.15050800f, 0.00486883f, 0.24687691f, 0.06603024f, -0.04879609f, 
    -0.10349093f, -0.10256595f, 0.05823883f, -0.01938716f, -0.02462288f, -0.13331439f, 0.12453491f, -0.00947723f, 
    0.05168609f, 0.04803443f, -0.10240334f, 0.05192551f, -0.02206414f, -0.07679080f, 0.05296022f, 0.13635413f, 
    0.13406038f, -0.07411361f, -0.12752223f, 0.07869472f, -0.13375892f, -0.00008954f, -0.11328764f, -0.05380416f, 
    0.09103581f, 0.16749959f, -0.08161180f, -0.03962304f, -0.06014357f, 0.08390313f, 0.10241958f, 0.11206575f, 
    -0.10244302f, 0.06722401f, -0.14053035f, 0.09470438f, 0.05596357f, -0.07843347f, 0.03734554f, -0.00986702f, 
    0.06706636f, 0.07542219f, 0.13056853f, 0.04960856f, -0.02530471f, 0.00629054f, 0.06356177f, -0.07388414f, 
    0.06267688f, 0.05570421f, 0.06088734f, -0.09788903f, -0.19950105f, 0.01004117f, -0.16721059f, 0.04029763f, 
    0.03534865f, 0.05990281f, -0.01442439f, -0.04728398f, 0.12714992f, 0.25149038f, 0.14838210f, 0.03678893f, 
    -0.10535813f, -0.31842443f, -0.13521913f, -0.07175539f, -0.46539164f, 0.22978073f, 0.12456209f, 0.00904091f, 
    0.06680011f, -0.13441254f, 0.09374994f, 0.02801153f, 0.04003797f, -0.21587630f, -0.04359822f, 0.10757678f, 
    -0.04842402f, -0.07797239f, -0.00099997f, 0.08329158f, 0.08360272f, 0.00110373f, 0.02073752f, 0.35535827f, 
    0.16086189f, -0.04876306f, 0.03723727f, 0.21365263f, 0.08614660f, 0.12773490f, 0.13387625f, 0.14362712f, 
    -0.14528364f, -0.07440194f, 0.05896353f, 0.03156650f, 0.04386887f, 0.19657581f, 0.06804738f, 0.02876304f, 
    -0.01230535f, -0.04185895f, -0.08073315f, -0.08003484f, -0.01584437f, 0.08124606f, -0.10268092f, 0.11162015f, 
    0.10495496f, -0.05683304f, -0.26659712f, 0.07109340f, -0.06535518f, -0.04516851f, -0.12295884f, -0.10129039f, 
    0.04964730f, 0.05811410f, 0.29082486f, 0.12402164f, -0.06501443f, -0.14625479f, -0.10930149f, 0.05190436f, 
    -0.02520953f, 0.04610715f, -0.03089975f, 0.00546515f, 0.10798967f, 0.03864424f, 0.04575302f, -0.10408644f, 
    0.04208636f, 0.06146377f, 0.04214199f, 0.01336632f, -0.16202849f, -0.18696365f, 0.15050980f, -0.10488761f, 
    -0.10007730f, -0.13890047f, -0.09381697f, 0.02395907f, 0.12736867f, -0.10920002f, 0.02516965f, -0.06409181f, 
    -0.03891382f, 0.03427117f, -0.01087132f, 0.05075611f, 0.00833279f, 0.00406953f, -0.16062836f, -0.36829108f, 
    -0.33186606f, 0.11124421f, 0.11097737f, 0.03891326f, -0.04316792f, -0.05137680f, 0.00637619f, 0.12191703f, 
    -0.20704359f, 0.24988145f, -0.03169682f, -0.18811746f, 0.02505889f, 0.06528696f, 0.00857589f, -0.06464034f, 
    -0.06137582f, -0.17656356f, -0.07412554f, -0.02024357f, 0.08178949f, -0.02617764f, 0.19714345f, 0.08283928f, 
    -0.02696311f, -0.07901849f, 0.18643893f, -0.19218731f, -0.23971093f, -0.24671829f, 0.03924632f, -0.23785955f, 
    0.06357554f, 0.21540892f, 0.16088971f, 0.03543857f, 0.07105818f, -0.05008522f, 0.16551633f, -0.06505598f, 
    0.04536887f, 0.07270499f, 0.14128502f, 0.33048797f, -0.06311821f, -0.27730888f, -0.06502712f, -0.03110506f, 
    -0.04921737f, 0.13980237f, -0.02657810f, 0.00286164f, -0.43415663f, 0.03018695f, 0.19678561f, 0.01282996f, 
    0.07993524f, -0.00092158f, 0.17739800f, 0.13099252f, -0.03169471f, 0.06796690f, 0.10681040f, 0.19896486f, 
    -0.07018544f, -0.06297252f, -0.01667197f, -0.03289174f, -0.15086028f, -0.05014990f, -0.08109319f, -0.10226605f, 
    -0.01646074f, -0.01104078f, 0.03392738f, -0.04355709f, -0.06549210f, 0.02654711f, -0.30865279f, 0.04960617f, 
    0.02564569f, -0.20448783f, 0.03405146f, -0.03838263f, -0.05918500f, 0.01459709f, 0.02589704f, 0.09703860f, 
    -0.00593217f, -0.08233922f, 0.07662615f, -0.07473535f, -0.02355826f, 0.06892403f, 0.07987154f, 0.13763700f, 
    0.01411027f, -0.15789491f, -0.17027649f, -0.12417549f, 0.02095780f, -0.12823202f, -0.14862347f, 0.06435221f, 
    -0.08791646f, -0.13023436f, -0.23306350f, 0.08555306f, 0.24803680f, 0.02903502f, 0.06881534f, 0.05190741f, 
    0.12442511f, -0.01710142f, -0.06581017f, -0.35697633f, -0.15564519f, 0.06367496f, -0.16857000f, -0.07833871f, 
    -0.12585758f, 0.11988735f, 0.06273301f, -0.25436285f, 0.00509079f, -0.08568896f, 0.21861725f, 0.00346287f, 
    -0.05029055f, 0.00744286f, 0.04114678f, 0.07819299f, 0.02329024f, -0.07360061f, 0.12323554f, 0.16725482f, 
    -0.03035676f, 0.02672173f, -0.03111477f, 0.16176994f, 0.20705037f, 0.04632584f, -0.07693694f, -0.05225743f, 
    0.07990006f, -0.21757339f, -0.04857804f, -0.15005718f, 0.14789382f, 0.03596624f, 0.13509749f, -0.16040541f, 
    -0.01346193f, 0.13839847f, -0.17258121f, 0.03557968f, 0.01092658f, -0.01002957f, -0.07200019f, 0.02271181f, 
    0.03229374f, -0.11047858f, -0.01784740f, 0.10955956f, 0.00125714f, 0.04150332f, 0.07484292f, 0.11558618f, 
    0.02876870f, 0.18332624f, 0.12018360f, 0.04895720f, -0.03337684f, 0.17152041f, -0.04695387f, 0.02220592f, 
    0.11487648f, 0.10683175f, 0.07359929f, -0.08184135f, 0.04877233f, -0.01844235f, 0.03910319f, 0.06394583f, 
    0.01030315f, -0.03605920f, -0.06777962f, 0.21065573f, 0.15049411f, 0.03753261f, 0.02359217f, 0.19448942f, 
    -0.19680478f, -0.08187791f, -0.16916321f, 0.37225491f, -0.14411011f, 0.07974721f, 0.14347433f, 0.07805738f, 
    0.14828160f, 0.12627025f, 0.22670172f, 0.15068616f, 0.02940899f, -0.06207243f, 0.06676036f, -0.11940376f, 
    -0.00913097f, -0.06551737f, 0.09106847f, -0.07297990f, 0.00247212f, -0.07344243f, -0.19503036f, 0.21127316f, 
    0.14172064f, -0.04503960f, -0.04070580f, 0.03456473f, 0.00841113f, 0.07852427f, 0.25377929f, 0.02258633f, 
    -0.01962594f, 0.05304660f, -0.01960910f, 0.04238508f, 0.03116057f, 0.02177547f, 0.17261732f, 0.14139403f, 
    0.03929240f, 0.10221317f, -0.16712864f, -0.11166420f, 0.16006058f, -0.05247885f, -0.01078778f, 0.05460984f, 
    0.07675262f, -0.27142847f, -0.12080885f, -0.11708926f, 0.10674585f, 0.13930997f, 0.09084962f, -0.06021529f, 
    -0.25705373f, -0.25411889f, -0.17651983f, -0.04876385f, -0.00587253f, -0.10655091f, -0.04751462f, -0.07578198f, 
    0.07288621f, -0.14840531f, -0.07083597f, 0.02094102f, -0.04292358f, -0.10794406f, 0.07597683f, 0.04267221f, 
    0.02662423f, -0.03638185f, -0.02074230f, 0.07782704f, -0.27371153f, -0.00973779f, -0.40921900f, 0.03147890f, 
    0.13048632f, 0.07552998f, -0.07674135f, -0.09183948f, -0.24114025f, -0.13517684f, -0.14051768f, -0.33421341f, 
    0.12381246f, 0.07091708f, 0.06617538f, 0.05544060f, 0.09726249f, 0.01711698f, -0.03102368f, -0.07249380f, 
    0.00310745f, 0.09324877f, 0.05352443f, 0.05900246f, -0.10225344f, 0.03118822f, 0.09408094f, 0.14279664f, 
    -0.16984297f, -0.03769885f, -0.01607395f, 0.03389656f, -0.06374103f, -0.08773486f, -0.21459396f, 0.11986165f, 
    0.03267366f, -0.02667273f, 0.09623647f, 0.03881612f, -0.01077604f, 0.04380053f, -0.18744504f, -0.36052120f, 
    -0.22692113f, -0.18188253f, -0.18525288f, -0.00414411f, -0.01222512f, 0.06777294f, 0.03364301f, 0.08483268f, 
    0.10933398f, -0.14024544f, -0.15631935f, -0.06992707f, -0.10368206f, 0.16609921f, -0.03027587f, 0.22444732f, 
    -0.02886564f, 0.08516424f, -0.16510314f, 0.02818382f, -0.02893190f, 0.06436966f, 0.05190571f, 0.07649221f, 
    -0.06570084f, -0.06485365f, 0.06327517f, 0.08375490f, -0.09084164f, 0.07305928f, 0.15637417f, 0.06144950f, 
    0.00066247f, 0.06748363f, 0.07753582f, -0.08238549f, -0.01148990f, -0.05879537f, -0.15910178f, -0.19205174f, 
    0.01078153f, 0.07199182f, 0.03053882f, 0.08563772f, 0.03882847f, 0.04540782f, -0.05033861f, -0.07793882f, 
    0.03023125f, 0.25270054f, 0.07979672f, 0.00604214f, -0.14804576f, -0.06200645f, 0.13654339f, -0.11532763f, 
    -0.17120975f, -0.07204504f, 0.11729527f, 0.18848841f, 0.05175494f, -0.19848827f, -0.05185917f, -0.07004790f, 
    -0.10954545f, -0.04269679f, 0.07554163f, 0.10654279f, 0.08903328f, -0.11848000f, -0.04622986f, 0.08333398f, 
    0.00312853f, -0.17485237f, -0.09703389f, -0.03937804f, 0.02716418f, 0.06338453f, -0.10509358f, -0.24315046f, 
    -0.62905115f, -0.11206315f, -0.01671808f, 0.07730549f, 0.28454143f, -0.08367740f, 0.07036074f, -0.01113188f, 
    0.17905404f, -0.01765304f, 0.05060651f, -0.12341180f, -0.06244532f, 0.03770419f, 0.11427152f, -0.04679832f, 
    0.00586376f, -0.00363347f, -0.27987573f, -0.02600664f, -0.00325328f, -0.14280812f, -0.13758476f, 0.05796143f, 
    -0.04144676f, 0.05528041f, -0.13080397f, -0.01641970f, -0.10092364f, -0.17968500f, 0.06979526f, -0.04629437f, 
    0.03010240f, 0.06029037f, 0.11983627f, -0.00105790f, 0.10873440f, 0.04436402f, -0.02578282f, -0.26022300f, 
    -0.09594357f, -0.05816009f, 0.02147277f, 0.14232191f, -0.02782105f, 0.02751556f, 0.13279481f, 0.20726156f, 
    -0.23101956f, -0.15401268f, 0.03531208f, 0.16126817f, 0.07310618f, 0.09386760f, 0.13536209f, 0.19589329f, 
    -0.14958860f, -0.14003092f, 0.04544361f, -0.04196237f, -0.05399792f, -0.02066859f, -0.02786988f, 0.01838842f, 
    0.04244146f, 0.00731730f, -0.22924079f, 0.07009106f, -0.00465707f, 0.01920157f, 0.14003415f, 0.04095913f, 
    -0.00399038f, 0.17091070f, 0.09104422f, -0.42757902f, -0.39927059f, 0.06170933f, -0.06210195f, -0.11370878f, 
    0.06599328f, 0.04178326f, -0.07652971f, -0.66401708f, 0.06354044f, -0.07518695f, 0.04032855f, -0.14459193f, 
    0.06256314f, -0.02948200f, -0.12495293f, -0.07628077f, -0.27308869f, 0.09863271f, 0.28560960f, 0.10419901f, 
    -0.35501093f, -0.37811798f, -0.05483564f, 0.03009659f, -0.01663978f, -0.12005562f, -0.01617287f, -0.08274314f, 
    -0.00269590f, 0.10329429f, 0.01620744f, 0.11110839f, 0.17927113f, -0.00577984f, -0.08293690f, -0.11865018f, 
    -0.01656185f, -0.03128618f, 0.01695566f, 0.08719368f, 0.11690006f, 0.04766687f, 0.09924877f, -0.23387733f, 
    -0.11614138f, -0.08122538f, 0.13664354f, 0.01277268f, 0.09794445f, 0.05252372f, -0.06890740f, 0.01243293f, 
    -0.32013389f, -0.12201945f, 0.17519771f, -0.16183253f, -0.06591109f, 0.01287038f, 0.09204979f, 0.02426499f, 
    0.00239442f, -0.18985330f, 0.17641048f, 0.15213071f, -0.01114228f, -0.17893429f, -0.23705626f, 0.05838416f, 
    -0.01231805f, -0.10675628f, 0.35018605f, 0.06184237f, -0.33523041f, 0.14464933f, 0.06573551f, -0.05682230f, 
    -0.03606931f, -0.02861100f, -0.34121704f, 0.14853813f, -0.05538561f, -0.09668213f, 0.01546924f, 0.07486715f, 
    0.07690831f, 0.10723220f, 0.03165598f, 0.02035804f, -0.17540401f, 0.05734373f, 0.07684502f, -0.00182670f, 
    -0.08498060f, -0.17882934f, -0.00336276f, -0.05507557f, -0.00502093f, -0.04088910f, -0.14961700f, 0.00641876f, 
    -0.00255448f, -0.00976843f, -0.04384509f, -0.04491597f, 0.09773731f, 0.13258369f, 0.10951924f, 0.12098367f, 
    0.16587965f, -0.19347134f, -0.21131355f, -0.08567509f, 0.04346441f, 0.11109632f, 0.14624824f, 0.12060744f, 
    -0.17332068f, -0.42717022f, -0.08460217f, 0.15265167f, 0.04336281f, 0.05358506f, 0.05780084f, -0.21909818f, 
    0.07793396f, 0.03622315f, 0.01337090f, 0.12549461f, 0.04544871f, 0.13275371f, 0.03138321f, -0.07962140f, 
    -0.01193306f, -0.05092491f, -0.45633897f, 0.01552761f, 0.12669493f, 0.01851176f, -0.02619654f, 0.07638934f, 
    -0.21525715f, -0.03069488f, -0.00666514f, -0.07477210f, 0.17709318f, -0.02611713f, 0.09861113f, 0.04991556f, 
    0.14523241f, 0.00368952f, 0.13711190f, -0.41300982f, -0.13174213f, -0.26243117f, 0.04964366f, -0.07600591f, 
    -0.01884987f, -0.05553529f, 0.06380196f, 0.11892290f, -0.03531177f, 0.24669495f, 0.19316852f, 0.03538697f, 
    -0.04400610f, -0.18168709f, 0.10048898f, 0.05766844f, 0.07144498f, -0.65943086f, -0.44151843f, 0.19914043f, 
    -0.04066524f, 0.02057304f, -0.25580102f, -0.01478805f, 0.03761540f, 0.03808625f, -0.16211322f, 0.09946594f, 
    0.00200762f, -0.14839950f, 0.05599626f, -0.07201456f, -0.10245377f, -0.08478873f, 0.10016363f, 0.11352820f, 
    -0.00588875f, 0.21437994f, -0.23021416f, 0.12424476f, -0.06626883f, 0.16494119f, 0.00888968f, 0.10188390f, 
    0.15693453f, 0.06139738f, 0.05410152f, 0.06249972f, 0.13228470f, 0.11017133f, 0.07748038f, 0.05670637f, 
    0.09019762f, 0.03647842f, 0.21265548f, 0.13986680f, -0.16006896f, -0.05489791f, -0.06027541f, -0.02806864f, 
    -0.13604505f, -0.17796989f, -0.09625995f, 0.25670561f, 0.20844264f, 0.07021476f, -0.08065101f, -0.02616338f, 
    0.04381843f, 0.03762200f, 0.04651944f, -0.29533353f, -0.05387689f, -0.03040419f, -0.06213735f, 0.00470060f, 
    -0.26310438f, 0.04393550f, -0.15209685f, -0.00840819f, -0.06254456f, -0.07746834f, -0.03012688f, -0.03161575f, 
    0.14810677f, -0.06542363f, 0.13414037f, 0.10257266f, 0.03234006f, 0.16388610f, -0.28835446f, 0.04341631f, 
    0.01960270f, -0.00612948f, 0.02877192f, 0.05276171f, -0.04969461f, -0.09587304f, -0.31418791f, -0.10573827f, 
    -0.11058654f, -0.18402079f, 0.16255964f, -0.23301464f, -0.03276725f, 0.29975981f, -0.05093793f, -0.81591171f, 
    -0.29245174f, 0.17571303f, -0.05905315f, 0.00689837f, -0.05747283f, 0.03676900f, -0.06706192f, 0.06678972f, 
    -0.11059482f, -0.05476255f, -0.12583445f, -0.06002559f, -0.07916750f, -0.02208304f, 0.01270920f, -0.01739569f, 
    0.10626743f, -0.07384133f, 0.13007341f, 0.20841402f, -0.07114053f, 0.00663814f, 0.00837744f, 0.04271488f, 
    0.09771630f, -0.05439523f, -0.00276066f, 0.06871757f, -0.01187014f, 0.13791914f, -0.00141462f, -0.10783975f, 
    -0.06559501f, 0.04416483f, 0.08486854f, -0.73070365f, 0.05835833f, 0.42494762f, -0.02790125f, -0.04093324f, 
    0.05982936f, -0.03462534f, 0.10363276f, 0.18876153f, -0.24332266f, 0.18606846f, 0.31743288f, -0.04739370f, 
    -0.07698075f, -0.14647037f, 0.02595258f, -0.10920055f, -0.05313114f, 0.16997656f, -0.00049484f, 0.24265487f, 
    0.04035618f, 0.08181462f, 0.00983700f, 0.03539034f, 0.02316810f, 0.13419428f, 0.19378354f, 0.45576823f, 
    0.01506883f, 0.02933474f, 0.06017783f, 0.07939634f, -0.11901781f, 0.08150745f, -0.01006575f, 0.00960760f, 
    0.05919563f, -0.11702648f, -0.01513234f, 0.02171254f, 0.02424512f, 0.00162178f, 0.23786567f, 0.17086112f, 
    -0.09580620f, -0.07161096f, 0.30705842f, -0.08359347f, -0.13596150f, -0.07014804f, 0.18381754f, 0.09545280f, 
    -0.02540112f, -0.14047775f, 0.11227360f, 0.22419126f, 0.02967610f, 0.00162572f, -0.08048473f, -0.04064855f, 
    -0.08642864f, -0.03552847f, -0.05678409f, -0.12587501f, -0.32656711f, 0.15314296f, 0.17505464f, -0.05091073f, 
    -0.04508450f, -0.15723628f, 0.04801378f, -0.00306528f, -0.03658363f, -0.03796938f, -0.15227380f, 0.03806098f, 
    0.06742138f, 0.19568582f, 0.01790406f, 0.10925598f, -0.00223298f, 0.12916702f, 0.15194021f, -0.02016372f, 
    0.01952506f, -0.06314901f, -0.01188851f, -0.08297563f, -0.07766297f, -0.00222481f, -0.23453432f, -0.14621380f, 
    -0.05690262f, -0.19299984f, -0.19479369f, -0.00235463f, -0.08786222f, 0.05941262f, -0.11068720f, -0.01993230f, 
    0.08344196f, 0.03551390f, 0.09306386f, -0.14586109f, 0.03295697f, 0.01792496f, 0.10746387f, 0.32460260f, 
    0.37140337f, 0.01216628f, -0.13477793f, 0.20799612f, 0.15894306f, -0.16855460f, 0.11085773f, 0.28867778f, 
    -0.00637950f, -0.03335806f, -0.13105166f, 0.06411985f, -0.01272380f, 0.05745837f, -0.05209663f, 0.21751580f, 
    0.07056902f, -0.00688426f, -0.01187076f, 0.07404538f, 0.06282648f, 0.35129225f, -0.01134778f, -0.11998510f, 
    -0.15238464f, 0.09193757f, 0.13233043f, 0.14186680f, 0.16623047f, 0.00684727f, -0.05483581f, 0.12847605f, 
    0.06352810f, -0.00881287f, 0.04430623f, -0.18879670f, -0.13491485f, -0.11101495f, 0.06765328f, 0.03357359f, 
    -0.00204662f, 0.07317426f, -0.05545582f, -0.01445109f, 0.03077982f, 0.11674205f, 0.12753363f, 0.00731959f, 
    0.00185974f, -0.02996488f, 0.01218691f, -0.01994233f, 0.07395281f, -0.08982345f, -0.73439312f, -0.14439249f, 
    0.02278028f, -0.15918800f, -0.18210739f, 0.01298117f, -0.27377200f, -0.21293679f, -0.09406239f, -0.23391227f, 
    -0.00856996f, -0.02823303f, -0.07432745f, -0.08882836f, -0.16950786f, -0.21563362f, -0.15025021f, -0.08133629f, 
    -0.10959049f, -0.10650239f, -0.24717242f, 0.06667180f, -0.05200230f, 0.09996640f, 0.00535734f, 0.05316177f, 
    0.26344463f, 0.27465156f, -0.00736110f, 0.06006461f, 0.01072734f, -0.11107598f, -0.02190016f, -0.00329347f, 
    -0.15044597f, 0.04242919f, 0.11266813f, 0.06280520f, 0.03239488f, -0.04342262f, -0.02474689f, 0.01317168f, 
    -0.00795972f, 0.02282116f, 0.06933036f, 0.16572788f, 0.21585637f, 0.12882245f, 0.05258073f, 0.02390264f, 
    0.11492064f, 0.03875187f, -0.01390743f, 0.11346934f, 0.07951047f, 0.03947545f, 0.00534592f, -0.14548336f, 
    -0.09256728f, -0.03150978f, 0.03161703f, -0.06483418f, 0.05733760f, -0.05852225f, 0.30745393f, 0.19008917f, 
    0.05759766f, 0.13756686f, -0.05752837f, 0.01326968f, 0.05202945f, 0.12207147f, -0.08304625f, 0.04406081f, 
    -0.03229269f, 0.04817078f, 0.01520085f, 0.04412759f, -0.20459448f, -0.02946638f, -0.13150850f, -0.06851304f, 
    -0.16482100f, -0.12133360f, -0.00287029f, 0.08782974f, 0.12916185f, -0.06884948f, -0.22989345f, -0.15886731f, 
    -0.58825207f, -0.06808529f, -0.09421065f, 0.02291342f, -0.15715298f, 0.00292867f, -0.00393671f, -0.12660642f, 
    0.14261797f, -0.23897277f, 0.09185909f, -0.11804798f, 0.12954082f, -0.18825695f, 0.04714491f, 0.10137945f, 
    0.09503108f, 0.07451025f, -0.02497903f, 0.02858659f, 0.00918660f, -0.04263812f, -0.07906883f, -0.02866687f, 
    0.07168598f, 0.05089149f, 0.07703497f, 0.05028985f, 0.08278690f, -0.02031622f, -0.09953056f, -0.07181826f, 
    -0.00456452f, -0.08412418f, 0.16487302f, -0.70147616f, -0.22225654f, 0.08311713f, -0.25414866f, 0.05087657f, 
    -0.13033283f, 0.05710927f, -0.07112156f, 0.01775251f, -0.24347989f, -0.37972611f, -0.30360118f, -0.05089533f, 
    0.02735871f, 0.03323343f, -0.08271194f, 0.04137619f, 0.03265042f, 0.03537001f, -0.25893712f, 0.31997633f, 
    -0.17499919f, -0.01185665f, -0.12454037f, 0.20098838f, 0.05049751f, -0.06010185f, -0.39514109f, -0.21657088f, 
    -0.19458257f, -0.02163779f, 0.17876412f, 0.01138289f, -0.07257584f, 0.03033308f, -0.02888526f, 0.09151236f, 
    -0.21724302f, 0.04412935f, 0.13735640f, -0.03712592f, 0.13322145f, 0.07090940f, 0.09564221f, 0.00018298f, 
    0.37562853f, -0.30055887f, 0.30595002f, 0.08717102f, -0.04623228f, -0.18736424f, 0.07998277f, 0.04635851f, 
    0.01695704f, 0.08183386f, -0.08309217f, 0.15669666f, 0.04695008f, -0.09979931f, -0.08487204f, 0.02176905f, 
    0.02742610f, -0.04706791f, 0.67274928f, 0.00337024f, -0.18303108f, 0.06410877f, -0.00487974f, 0.11509421f, 
    0.00086106f, 0.08630027f, -0.03618038f, 0.46508473f, 0.09530595f, 0.03810788f, -0.16704215f, -0.03476984f, 
    0.03631617f, 0.16988593f, 0.07464130f, -0.05048836f, 0.17773482f, -0.25041965f, 0.17610268f, -0.00027796f, 
    -0.04288664f, -0.25523034f, -0.03470448f, 0.07533882f, 0.04042409f, 0.30299202f, -0.12010396f, 0.06583232f, 
    -0.06847762f, 0.04688660f, -0.07248058f, 0.08992471f, -0.15992655f, 0.00697464f, -0.13852389f, -0.15522850f, 
    -0.25135896f, 0.00537629f, -0.03851827f, -0.15391701f, -0.01846691f, -0.10143737f, 0.04397532f, 0.39480785f, 
    -0.02492998f, -0.47576353f, -0.04455271f, 0.01451472f, 0.04852856f, 0.01206271f, 0.08198442f, 0.10733025f, 
    -0.15480220f, -0.09972459f, -0.15044104f, 0.01810935f, 0.10384065f, -0.02985436f, 0.12268260f, 0.02783119f, 
    0.18778516f, 0.17500080f, 0.01808900f, 0.23129851f, -0.01096639f, -0.18673758f, -0.03106386f, -0.17850959f, 
    0.07807995f, 0.04062531f, 0.11370347f, 0.02444706f, 0.15386494f, 0.03346032f, -0.12436461f, -0.01668654f, 
    0.06097391f, 0.00524635f, 0.20041531f, -0.22619644f, -0.25319648f, 0.00030565f, 0.03263020f, -0.05067535f, 
    -0.31076097f, 0.00137050f, 0.07482584f, 0.06788997f, -0.06458396f, -0.02006331f, -0.17068389f, 0.05527739f, 
    0.03083220f, 0.03597105f, 0.05367429f, -0.06913619f, 0.08026848f, 0.14884326f, -0.20481777f, 0.25216880f, 
    -0.03052128f, -0.02942985f, 0.06371757f, -0.07961646f, 0.06538483f, -0.07955348f, -0.27475560f, -0.17244290f, 
    -0.14759679f, 0.03880887f, -0.12664157f, -0.04582904f, 0.01523419f, -0.07859077f, -0.00524651f, -0.02441788f, 
    -0.15795250f, 0.00576430f, -0.04474202f, -0.09035055f, -0.14454569f, -0.03977638f, 0.08780208f, 0.06412982f, 
    0.24070586f, 0.07101251f, 0.13355455f, 0.04033394f, 0.05113981f, -0.07997193f, 0.10968111f, 0.02745086f, 
    -0.03093814f, -0.10335629f, -0.05777259f, 0.14003259f, -0.08132202f, 0.07773814f, -0.05573128f, -0.15484369f, 
    0.02502808f, -0.13426454f, 0.04099440f, -0.08322702f, -0.26641732f, 0.07694493f, 0.08607447f, 0.06997585f, 
    0.03568931f, 0.01689439f, 0.05697080f, 0.12539278f, -0.30273008f, -0.00357546f, -0.16437280f, 0.14263807f, 
    -0.17101827f, 0.04323417f, -0.17384964f, -0.09528524f, -0.19110744f, -0.16455190f, 0.34348515f, 0.00015105f, 
    0.01484975f, 0.00428703f, 0.16566676f, 0.00675396f, -0.02353149f, 0.32621104f, 0.14351217f, 0.02228479f, 
    0.05790812f, -0.01483081f, -0.10872540f, 0.02636504f, 0.01813084f, 0.18026340f, -0.22827415f, -0.19993605f, 
    -0.11297279f, -0.05345652f, -0.26038805f, -0.09751844f, 0.01188747f, -0.02062242f, 0.02139659f, -0.07483050f, 
    -0.21962646f, 0.20747161f, -0.18737032f, 0.02004148f, 0.02363184f, 0.15208225f, -0.03075711f, -0.00441883f, 
    0.01744840f, 0.09673059f, 0.23712364f, -0.07834993f, 0.01982155f, -0.00573852f, 0.14478363f, 0.01923323f, 
    0.00493553f, 0.11306321f, -0.33687708f, -0.11906240f, -0.09191158f, -0.03371692f, 0.04903566f, 0.11412802f, 
    0.03920468f, -0.10231250f, -0.04380086f, -0.06371404f, -0.29282972f, -0.08957225f, -0.10304403f, -0.07137656f, 
    0.04503258f, -0.07267254f, -0.03681292f, -0.15936075f, 0.38791376f, 0.07106937f, -0.20405854f, -0.05042669f, 
    -0.05228280f, 0.13994919f, 0.03574898f, -0.16288404f, -0.03752957f, -0.46503577f, -0.17804100f, -0.27242845f, 
    -0.07326335f, -0.31169060f, 0.04582262f, -0.02696964f, 0.01899621f, -0.13163713f, -0.07466609f, -0.13183269f, 
    0.02576496f, 0.07421798f, -0.03413697f, 0.13671684f, 0.09429049f, 0.06406160f, 0.11064048f, -0.27382535f, 
    -0.02398242f, 0.00818637f, -0.03411295f, 0.12697473f, 0.11429301f, 0.04538334f, -0.07213703f, -0.00649875f, 
    0.05613303f, -0.09002576f, 0.04518691f, 0.09754957f, 0.20060661f, 0.01631621f, -0.07878705f, 0.04102984f, 
    -0.04671168f, 0.10017615f, -0.00214469f, -0.06779323f, -0.08874744f, 0.00014163f, 0.06993897f, -0.14867415f, 
    -0.02508744f, -0.10738465f, 0.22297542f, 0.17829588f, 0.05017954f, -0.13666570f, -0.14632666f, -0.00241610f, 
    0.10997277f, 0.04719016f, -0.05929581f, -0.07530727f, -0.00751726f, 0.03041085f, 0.04887513f, -0.01659454f, 
    0.00390662f, 0.01273232f, -0.00093034f, 0.19991499f, -0.05512060f, 0.08181099f, -0.03557534f, -0.07579400f, 
    0.06650435f, -0.05622393f, 0.13022366f, 0.10067465f, -0.22494073f, 0.38522568f, -0.05036665f, 0.00084880f, 
    -0.12819299f, -0.08238965f, 0.07390775f, 0.06029025f, 0.06995093f, -0.03762556f, 0.07755530f, 0.20938946f, 
    -0.02605955f, -0.05512650f, -0.01870618f, 0.11378920f, 0.04789335f, 0.13948026f, -0.10348032f, 0.20531368f, 
    -0.03133662f, -0.06728865f, -0.05571857f, -0.02449090f, 0.04222262f, -0.06637798f, -0.02680224f, -0.20885913f, 
    0.28238279f, -0.37884405f, 0.18304421f, 0.30592668f, 0.10193814f, 0.03709470f, -0.06319512f, 0.01710340f, 
    -0.00905474f, -0.01183363f, 0.00937446f, -0.02920387f, 0.15621762f, 0.14524578f, 0.08709212f, 0.11286428f, 
    0.07550363f, 0.05713953f, 0.21020252f, 0.11051092f, -0.00977288f, -0.03108656f, -0.27320859f, -0.12171441f, 
    0.00163310f, -0.11074573f, -0.05026470f, -0.08059422f, -0.01320814f, -0.02293845f, -0.03541447f, -0.04859858f, 
    0.06844436f, 0.04947231f, 0.18132736f, -0.40191796f, 0.22163703f, -0.05469748f, -0.05421934f, -0.00940290f, 
    0.12764482f, 0.12255830f, 0.00471362f, -0.04286284f, -0.15596515f, -0.16372952f, -0.32195050f, 0.01705066f, 
    0.03732083f, 0.04347907f, 0.02331853f, 0.05496457f, 0.07226544f, -0.34418917f, -0.00453975f, 0.12929340f, 
    -0.09324761f, -0.05956251f, -0.16594864f, -0.05271168f, -0.03389639f, 0.08552458f, -0.30109739f, 0.30057630f, 
    0.09748717f, 0.01283648f, -0.01796810f, -0.04709515f, -0.12479546f, -0.13133049f, 0.04887365f, -0.05533376f, 
    0.13295576f, 0.11250574f, -0.07095594f, -0.07830380f, -0.13933036f, -0.02477761f, 0.11347865f, 0.12781866f, 
    -0.07373535f, -0.12574343f, -0.10325252f, 0.05892447f, -0.01347674f, -0.04080043f, 0.09462019f, -0.09756841f, 
    -0.01154075f, 0.01274373f, -0.00286804f, -0.30618522f, -0.03890866f, 0.06696730f, -0.03603758f, -0.18051168f, 
    0.08768293f, 0.06022684f, -0.23351525f, -0.14423598f, -0.23557259f, 0.05977119f, -0.07903741f, 0.08596015f, 
    0.05377546f, 0.03274678f, 0.06650488f, -0.28572422f, -0.22535644f, -0.32530284f, -0.10973202f, 0.09597885f, 
    -0.04588729f, -0.09135532f, -0.06881667f, 0.02632697f, -0.11253332f, -0.18854979f, -0.00145554f, -0.05447963f, 
    0.03377337f, -0.20753941f, 0.04316247f, 0.06154902f, 0.18209253f, 0.12352701f, -0.08019898f, 0.16848484f, 
    0.06824299f, -0.04635507f, -0.13311340f, 0.12247237f, 0.02720645f, 0.07443734f, 0.12820926f, 0.27102205f, 
    0.24032481f, -0.07454769f, -0.07721445f, -0.17597090f, 0.01775466f, 0.13473807f, 0.16067824f, -0.09440029f, 
    0.05850596f, 0.27342430f, -0.06593034f, 0.03358248f, -0.03978398f, 0.03761816f, -0.18340416f, 0.03172860f, 
    0.13350911f, 0.22286262f, 0.15681234f, 0.05589948f, -0.06795722f, 0.07965879f, 0.01447188f, -0.07912704f, 
    0.03187903f, 0.14061929f, -0.24787433f, -0.24892975f, -0.21053761f, 0.00860826f, 0.02298235f, 0.07859457f, 
    -0.01872431f, -0.04281092f, 0.16369474f, -0.04076651f, -0.09646399f, -0.14566590f, -0.09299839f, 0.03756043f, 
    -0.16125865f, -0.01691152f, -0.09697305f, -0.06142457f, -0.21612374f, 0.04822727f, 0.07446406f, -0.12275942f, 
    0.09442782f, 0.09974445f, -0.06751904f, -0.26713154f, -0.45420817f, -0.09192626f, 0.09900111f, 0.03577962f, 
    0.24482606f, -0.08390000f, -0.25985920f, 0.02557267f, -0.07728471f, -0.08354785f, -0.11408898f, -0.02635935f, 
    0.03005348f, 0.08266496f, -0.00624265f, 0.02513126f, 0.03419603f, 0.13330165f, -0.40420604f, 0.05766447f, 
    -0.06439686f, -0.01074016f, 0.09891003f, 0.07316065f, -0.02159653f, -0.10617974f, 0.05352576f, 0.19142793f, 
    0.09143028f, -0.01761009f, -0.02443028f, 0.04494889f, 0.00689870f, -0.05551509f, 0.02717813f, 0.13444510f, 
    -0.19050135f, -0.29028296f, -0.53082824f, -0.25599486f, 0.01465690f, 0.16327469f, 0.00868453f, -0.10037113f, 
    0.09495336f, -0.64817512f, -0.39997578f, -0.13170861f, -0.08217556f, 0.14030540f, -0.32439801f, 0.02759114f, 
    -0.04708677f, 0.00433763f, 0.21763095f, -0.06324952f, -0.16171265f, 0.10466529f, 0.21856695f, 0.17424819f, 
    0.00566929f, -0.01261628f, -0.01624070f, 0.10680205f, 0.15881449f, 0.09839804f, 0.00530558f, 0.05945368f, 
    0.04488750f, 0.00478880f, -0.00004869f, -0.08737321f, -0.31449175f, -0.31040406f, -0.18056025f, -0.07674484f, 
    0.07023161f, -0.21385978f, 0.01345992f, -0.03028532f, 0.03039263f, 0.14936993f, 0.30542627f, 0.21250452f, 
    -0.09237528f, 0.00281294f, -0.03836115f, -0.03046791f, 0.01728063f, 0.07350197f, -0.21076311f, -0.02538658f, 
    -0.05940285f, -0.11085968f, 0.05757271f, -0.00121344f, -0.00680735f, -0.03321220f, 0.10392737f, -0.02375975f, 
    -0.10267466f, 0.01512342f, 0.16344057f, -0.10084604f, 0.19648059f, 0.19037050f, -0.10325743f, 0.14655529f, 
    0.11031288f, -0.05641858f, -0.00321698f, -0.06483915f, 0.01771117f, 0.04385583f, -0.02116159f, 0.00612289f, 
    0.03436152f, 0.18115063f, 0.00303253f, 0.01964317f, -0.11075942f, -0.07178255f, 0.06854478f, -0.13463530f, 
    -0.01539276f, -0.02609916f, 0.10697679f, -0.10239457f, -0.02239453f, -0.05031429f, 0.03005718f, -0.00133845f, 
    0.08789000f, 0.08829443f, 0.04017797f, 0.21501091f, 0.24150522f, -0.08277192f, 0.03616504f, -0.00759029f, 
    0.07477985f, -0.03863701f, 0.18845786f, 0.01439195f, -0.49990791f, 0.01076966f, 0.03271949f, -0.08173548f, 
    0.10975994f, 0.09646183f, -0.16112755f, 0.02928872f, 0.01161810f, -0.06537993f, 0.12884144f, -0.10616510f, 
    -0.09132575f, 0.14568830f, -0.03469161f, -0.04387194f, -0.01591167f, -0.03170524f, -0.18166576f, 0.16700119f, 
    0.09931663f, -0.05629766f, 0.00292522f, -0.08111694f, 0.09603740f, -0.04685743f, 0.24620564f, -0.01646093f, 
    0.12137398f, 0.00189555f, -0.01646416f, 0.04209940f, -0.11769265f, -0.03213628f, -0.08683200f, 0.11328521f, 
    -0.50525719f, -0.09949244f, -0.24097221f, -0.13928704f, -0.07326882f, -0.21878283f, 0.13723668f, -0.01738232f, 
    0.15135030f, -0.01635055f, -0.05373807f, -0.23546794f, -0.04116256f, -0.03520964f, 0.02404464f, -0.07764735f, 
    -0.12438827f, -0.03406269f, -0.42157707f, -0.18338080f, 0.15180466f, 0.06277953f, 0.10182036f, 0.08666227f, 
    -0.01976472f, 0.03257471f, -0.04468488f, -0.04525410f, 0.09024845f, 0.00402812f, -0.32597086f, -0.11398184f, 
    0.03528337f, 0.04430433f, -0.14570922f, -0.04121314f, -0.22720346f, -0.11845024f, -0.34800205f, -0.03366055f, 
    0.03179979f, -0.11227490f, 0.07125483f, 0.15094940f, 0.12565421f, 0.12023222f, 0.11914467f, 0.12920144f, 
    -0.04411373f, -0.00350238f, -0.04294343f, -0.03270352f, 0.09418499f, 0.03460843f, 0.00412076f, 0.01978241f, 
    0.21274084f, 0.17601980f, -0.18332514f, -0.06481953f, -0.00025912f, -0.08170301f, 0.08778752f, 0.04248749f, 
    0.14455555f, 0.11474575f, -0.02441742f, -0.04717198f, 0.13426535f, -0.01547768f, -0.02812666f, -0.02217051f, 
    0.02561386f, -0.17135450f, -0.24758612f, -0.10479870f, 0.01498600f, -0.00337128f, 0.02265411f, 0.12627202f, 
    -0.15589270f, 0.01067208f, 0.03159961f, 0.07039929f, -0.01904803f, -0.05971589f, 0.02678159f, -0.02466951f, 
    0.06303116f, 0.08554029f, -0.07826414f, -0.05968831f, -0.14698197f, 0.00108527f, 0.01600522f, -0.01436000f, 
    0.04990827f, 0.08500454f, -0.13469385f, 0.34250447f, 0.16556236f, -0.08132662f, 0.01790592f, -0.11709703f, 
    0.07961482f, -0.07995760f, 0.12219992f, 0.09113061f, -0.01744037f, -0.20217179f, 0.15845299f, 0.22541687f, 
    -0.00694229f, 0.00306451f, -0.05983511f, 0.26233378f, -0.02701444f, 0.02701716f, -0.05509906f, -0.10648775f, 
    0.11122234f, -0.09944502f, -0.01637655f, 0.04920728f, -0.08330948f, -0.19506444f, -0.24012922f, 0.25416446f, 
    0.17610556f, -0.08972126f, -0.02833840f, -0.05927613f, -0.02807420f, 0.06559158f, 0.02995946f, -0.06947516f, 
    -0.12512842f, -0.24909064f, 0.09740708f, -0.07910274f, 0.01371739f, -0.01450607f, -0.09479117f, -0.06812239f, 
    0.19295569f, 0.00358234f, 0.01755449f, 0.21599470f, 0.10879196f, -0.01512901f, -0.03510473f, -0.11498518f, 
    0.13820975f, 0.17566448f, 0.11059471f, 0.18458453f, 0.01770751f, -0.12800962f, 0.14934002f, -0.12054767f, 
    -0.09189369f, -0.20205247f, 0.06686105f, 0.26891774f, 0.17545635f, -0.01756349f, 0.02803351f, -0.09206624f, 
    0.11295700f, 0.02769588f, -0.18428646f, -0.16474509f, -0.09135275f, -0.03869725f, -0.05910205f, -0.03557720f, 
    -0.08149509f, 0.01600922f, 0.03285847f, -0.12253015f, 0.32566783f, 0.09794285f, 0.10081164f, 0.18672878f, 
    -0.13227503f, 0.06657862f, -0.01210559f, -0.10132663f, -0.13577202f, -0.11283233f, -0.08444314f, -0.23074803f, 
    -0.03967541f, 0.00126281f, 0.01349187f, 0.23702541f, 0.13806199f, 0.08337656f, 0.29924640f, -0.00236499f, 
    -0.18504342f, -0.00826804f, 0.10152101f, 0.15739965f, -0.00998240f, 0.15905459f, -0.09450185f, 0.00294572f, 
    0.20997837f, -0.02289269f, -0.11492252f, -0.02189094f, -0.05877842f, -0.06036444f, -0.04267084f, 0.16661511f, 
    -0.11314025f, -0.09705340f, -0.06742297f, 0.10737382f, 0.02223355f, -0.07492895f, -0.12335072f, -0.25529644f, 
    -0.22209767f, -0.15118890f, -0.11950350f, -0.14204916f, -0.04884631f, 0.06171646f, 0.03574213f, 0.22065374f, 
    0.11647912f, 0.02853273f, 0.08769229f, 0.01168462f, 0.01105052f, 0.15488574f, 0.07508450f, -0.01108786f, 
    0.01208895f, -0.06752840f, -0.01934114f, 0.33626726f, -0.11246932f, -0.24918292f, -0.01167430f, 0.01574987f, 
    -0.01496732f, -0.03364128f, 0.04062188f, 0.08138292f, -0.07966088f, -0.11658216f, 0.10244079f, 0.08860832f, 
    0.04881120f, -0.03771834f, -0.06233217f, -0.14648615f, 0.03732896f, 0.32885438f, 0.06669261f, 0.22393727f, 
    0.00553360f, -0.16544181f, -0.00468908f, 0.03538928f, 0.13976625f, -0.05234915f, 0.20268381f, 0.04728513f, 
    -0.20412193f, -0.03806360f, -0.04575976f, 0.00759664f, 0.14733553f, 0.08101665f, 0.11231865f, 0.04108169f, 
    0.02269992f, -0.34632698f, 0.04567136f, -0.04164131f, 0.04322029f, -0.03470368f, -0.03650464f, -0.04408181f, 
    0.17464441f, 0.07971659f, 0.14403924f, -0.01764358f, -0.06376214f, -0.18435983f, -0.01673294f, 0.03715572f, 
    0.07538601f, 0.06963551f, 0.18546252f, 0.13382006f, 0.10419804f, -0.01379296f, 0.02098605f, 0.01818194f, 
    0.07837813f, -0.16653076f, -0.10522898f, -0.09330096f, 0.16485995f, 0.14230864f, -0.01643371f, -0.07540967f, 
    -0.22950929f, -0.02366806f, -0.00736109f, -0.02985569f, -0.04949636f, -0.05629416f, 0.22677642f, 0.01548972f, 
    0.06285916f, -0.02048931f, 0.04654868f, 0.04422389f, 0.16083467f, 0.06045562f, 0.11578854f, 0.14752740f, 
    0.01819461f, -0.08517914f, -0.04023730f, -0.05022519f, -0.08401310f, -0.31295821f, -0.10504351f, -0.11254330f, 
    -0.13900055f, 0.09213562f, 0.05146940f, 0.11097738f, -0.00875002f, 0.05189867f, -0.00130461f, 0.00623445f, 
    -0.04333441f, -0.00107164f, 0.00281351f, 0.12389846f, 0.06594735f, -0.06649101f, 0.10388049f, 0.15997118f, 
    -0.06490818f, 0.14084491f, -0.05725204f, -0.14187238f, 0.16436726f, 0.10448708f, -0.00763309f, 0.06655333f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.16835402f, 0.00389820f, -0.01356380f, 0.04779926f, 0.01185971f, -0.06255957f, 0.16382557f, 0.10080396f, 
    0.00615853f, 0.07364586f, 0.36146390f, 0.02607891f, 0.02757803f, 0.16371845f, -0.00063668f, 0.23386739f, 
    0.17283969f, 0.20893851f, 0.12400570f, -0.01425402f, -0.02730934f, 0.09367610f, 0.10180345f, -0.05683067f, 
    0.12118493f, 0.00745081f, 0.22200432f, 0.10106563f, 0.11443781f, 0.12576714f, 0.10697279f, -0.11542028f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.05426601f, 0.34366629f, 0.02686562f, -0.22560729f, 0.29748565f, -0.17241640f, -0.22404662f, -0.28868750f, 
    -0.36184555f, 0.37045896f, -0.12339631f, -0.02804643f, 0.15487543f, -0.06264746f, 0.06259579f, 0.05650278f, 
    -0.48208758f, 0.02177992f, -0.18287224f, -0.16421087f, 0.19105600f, 0.16245069f, 0.30188185f, 0.16480669f, 
    -0.16944708f, -0.04749766f, -0.21919826f, 0.18730882f, 0.13326517f, 0.12574597f, -0.37431228f, -0.01405346f, 
    0.22273432f, -0.19777504f, -0.31489831f, -0.20650171f, -0.38872853f, 0.17131096f, 0.03120276f, 0.09308807f, 
    -0.05973963f, 0.10154788f, 0.18810432f, 0.04112565f, 0.11534385f, -0.24254730f, -0.02104271f, 0.15571915f, 
    0.03736638f, 0.35391432f, -0.07457648f, 0.12068411f, 0.12585048f, 0.02847557f, -0.00268928f, -0.10242425f, 
    0.28429317f, -0.20913981f, -0.13697684f, 0.02262609f, 0.03733252f, 0.00656604f, 0.11591946f, -0.16538350f, 
    0.13157909f, -0.13599306f, 0.16355057f, 0.09851661f, -0.31722316f, -0.00397417f, -0.15792464f, 0.40418184f, 
    -0.03228139f, 0.00322697f, -0.12891704f, -0.02656795f, -0.16611116f, -0.14589179f, -0.05962850f, -0.00655748f, 
    0.11547980f, 0.16919878f, -0.05303386f, 0.29778102f, -0.32607490f, -0.07916755f, -0.14448890f, 0.06584597f, 
    0.18554403f, -0.20144382f, -0.41219768f, -0.04040288f, 0.40713754f, 0.13209219f, 0.36693162f, 0.17471655f, 
    0.02799788f, -0.15671812f, -0.20099349f, -0.00116946f, -0.26122761f, 0.04493171f, 0.14392504f, -0.14610751f, 
    -0.09347133f, 0.00663127f, 0.00872347f, 0.14083804f, 0.05448745f, -0.06138746f, -0.15995248f, -0.05796335f, 
    0.21208805f, -0.18507877f, 0.00409095f, -0.00510144f, 0.16894479f, 0.21371731f, 0.20611742f, -0.31828716f, 
    0.29993165f, 0.07303663f, -0.20073020f, 0.04556560f, 0.53180653f, 0.06048299f, 0.28634587f, -0.13169205f, 
    -0.10931571f, -0.19968075f, 0.07608397f, -0.10911446f, 0.07407219f, 0.15297109f, -0.12446295f, 0.06110366f, 
    0.07959478f, 0.02204334f, 0.06257928f, 0.00732374f, -0.03183645f, -0.03462021f, -0.11118395f, 0.03770869f, 
    -0.12631702f, -0.09923296f, 0.08532066f, -0.05451882f, -0.05959020f, -0.08998555f, -0.14449370f, -0.03449747f, 
    -0.05171559f, -0.09040957f, 0.01956198f, 0.02184002f, 0.12268596f, -0.05505345f, -0.10672224f, -0.14747193f, 
    0.06509980f, 0.16281381f, 0.03601072f, 0.24473023f, 0.06298184f, -0.11900207f, -0.02541702f, -0.33352232f, 
    0.11548705f, 0.02839579f, 0.08572084f, -0.15408471f, 0.01796256f, 0.15565675f, 0.01165790f, 0.06981628f, 
    0.00661601f, -0.08113267f, -0.24012247f, -0.01296044f, 0.07229804f, 0.14388372f, 0.10452505f, -0.13524608f, 
    -0.00765393f, 0.01901690f, 0.51112926f, 0.16692701f, 0.31323758f, -0.15199819f, -0.07407799f, -0.26899469f, 
    0.11243954f, -0.17440836f, 0.01028025f, -0.05651186f, -0.12588508f, 0.03538873f, -0.18832012f, 0.02082999f, 
    -0.15968992f, -0.17094386f, 0.03093954f, 0.03051367f, -0.09660915f, 0.03260240f, 0.00458631f, 0.04271495f, 
    -0.15189749f, -0.22474544f, 0.02215994f, 0.10966792f, -0.12550183f, -0.13090789f, -0.14530419f, -0.17664661f, 
    -0.10142900f, -0.08057543f, -0.15262900f, -0.11903333f, -0.07404170f, -0.09516525f, -0.23350792f, -0.04058811f, 
    0.25960603f, 0.16512121f, -0.26476935f, 0.08603680f, 0.28808609f, -0.16488005f, 0.16506141f, -0.18374172f, 
    -0.03282238f, -0.18971322f, 0.10059152f, -0.00177838f, 0.15378809f, 0.04097335f, 0.35028487f, -0.11984872f, 
    0.18295486f, -0.02391758f, -0.03634625f, -0.01126455f, -0.18419050f, 0.17941281f, 0.18734822f, -0.31250077f, 
    -0.07007512f, 0.03436598f, 0.68558967f, -0.07950923f, -0.10767180f, 0.01553045f, 0.12057938f, -0.20014185f, 
    0.14192665f, 0.24433833f, -0.10943831f, 0.13599022f, 0.09100251f, 0.10739041f, -0.10222526f, 0.25393930f, 
    0.41616052f, -0.29129890f, -0.07722261f, -0.19759871f, 0.09976313f, -0.10357156f, 0.28396791f, 0.13829575f, 
    0.12929018f, -0.36128822f, 0.22197305f, 0.26302555f, -0.27850521f, -0.18754837f, -0.14876536f, -0.46315643f, 
    0.05716513f, -0.06996734f, 0.60312545f, 0.27131978f, -0.20968765f, -0.35430840f, 0.28836516f, 0.22243680f, 
    -0.08428539f, -0.01890367f, -0.33397183f, -0.04039278f, -0.19450703f, 0.10292342f, -0.06848761f, 0.36716512f, 
    0.36048076f, -0.09198719f, -0.15687723f, 0.12762333f, 0.14414763f, -0.26151356f, 0.14988066f, -0.00255737f, 
    0.27112022f, 0.03292103f, 0.40816033f, -0.09778194f, -0.20573284f, -0.30267614f, -0.03085301f, -0.29668838f, 
    0.26058865f, 0.15662763f, 0.43422177f, 0.18304561f, 0.08567259f, -0.43244249f, 0.33108267f, 0.17776576f, 
    0.04969732f, -0.04270973f, -0.10766309f, 0.00153783f, 0.00200308f, 0.05717472f, 0.00998424f, 0.13340850f, 
    -0.18583320f, -0.14193478f, 0.23018701f, 0.05535870f, -0.02618014f, -0.17815639f, 0.05820939f, -0.14317293f, 
    0.02114956f, -0.00812334f, 0.02594534f, 0.38576895f, -0.08409921f, -0.27682897f, 0.02611131f, -0.26540175f, 
    0.11791255f, 0.22383739f, 0.07100765f, 0.02225641f, -0.31801441f, -0.17169894f, 0.18803146f, 0.29146186f, 
    -0.09351862f, -0.07183729f, 0.01705579f, -0.17271429f, 0.11859411f, 0.10040939f, -0.24562493f, 0.32821292f, 
    0.28836659f, 0.14301684f, -0.13100883f, 0.15871716f, -0.17491831f, -0.46976045f, -0.08026458f, 0.14305596f, 
    -0.11484515f, 0.01753263f, 0.38579878f, -0.12439807f, -0.03628432f, 0.02706040f, -0.07694087f, 0.01427873f, 
    0.24900982f, 0.14827719f, -0.39427033f, 0.12586848f, 0.54414678f, -0.09073328f, -0.10305525f, 0.17505062f, 
    0.00246203f, 0.27079237f, 0.05777223f, 0.10953466f, 0.21237066f, 0.05426284f, 0.21469001f, -0.45716995f, 
    0.00059333f, 0.10505517f, 0.24125344f, -0.22968796f, 0.10649035f, 0.13027219f, -0.08705554f, 0.19391507f, 
    0.08208940f, -0.15773226f, -0.19639815f, -0.22326294f, -0.26537478f, 0.28265670f, 0.21423821f, -0.11576971f, 
    -0.21754968f, 0.09262026f, 0.39638823f, 0.19041912f, -0.15668297f, 0.18619289f, -0.24809441f, -0.25776911f, 
    0.20499270f, 0.05498693f, -0.14842984f, 0.14631264f, -0.27918074f, 0.08710583f, -0.07708904f, -0.14197184f, 
    -0.28161639f, -0.06239866f, -0.01992200f, -0.05654784f, -0.00502612f, -0.30135193f, 0.10291664f, -0.10567034f, 
    0.00746840f, 0.33872640f, 0.16540982f, 0.43979761f, 0.08041709f, 0.09750981f, -0.07624786f, -0.33489415f, 
    0.26495725f, 0.05290494f, -0.47586459f, 0.12841459f, -0.09277266f, 0.11213556f, 0.11720916f, 0.05772290f, 
    -0.34297594f, 0.33427522f, 0.05427190f, -0.16285799f, 0.10969365f, 0.08856975f, -0.11651150f, -0.18211213f, 
    -0.21776383f, 0.24124330f, -0.07991479f, -0.05803926f, 0.09826376f, -0.02364931f, -0.08614823f, -0.20396844f, 
    0.09150042f, -0.06166960f, -0.01276969f, -0.19091569f, 0.23016568f, -0.11077917f, 0.23355143f, 0.12905729f, 
    -0.06821677f, 0.13844714f, 0.05224969f, 0.29799896f, -0.31403276f, -0.47009671f, -0.11219678f, -0.07834446f, 
    0.12695967f, -0.42245415f, 0.05609113f, 0.21710272f, -0.22232163f, -0.07990330f, 0.21090038f, 0.15882166f, 
    -0.10880345f, -0.12976846f, 0.10656507f, -0.08857803f, 0.10510933f, 0.43866307f, 0.19127518f, 0.21043554f, 
    0.04528354f, -0.13808154f, 0.24223155f, -0.31894746f, -0.32909706f, -0.27184954f, -0.01249962f, -0.31918302f, 
    0.14256436f, -0.22184685f, 0.42781579f, 0.08648437f, -0.10580788f, 0.29003808f, 0.22014792f, 0.10300945f, 
    0.05595905f, 0.42521545f, -0.03228398f, -0.07555661f, -0.13230541f, -0.07240503f, 0.04620430f, -0.04765439f, 
    -0.20277727f, -0.20335945f, 0.01879113f, 0.03888693f, 0.01828008f, -0.37177762f, -0.08300451f, 0.07580643f, 
    0.06421186f, -0.20739999f, 0.23256959f, 0.00377642f, 0.07640769f, -0.01499903f, -0.25806955f, -0.06209880f, 
    0.21400191f, 0.04605633f, -0.19790737f, 0.23812367f, -0.14947169f, -0.00462542f, -0.16764313f, 0.18636183f, 
    -0.25673613f, 0.02277887f, 0.00595787f, -0.23135497f, 0.24212217f, -0.02100917f, -0.13690385f, -0.06463796f, 
    -0.19114214f, 0.37967715f, 0.06687598f, 0.06176144f, -0.16996366f, -0.05784321f, 0.03466483f, -0.24817385f, 
    -0.30079499f, -0.06822181f, 0.11285725f, -0.18241295f, 0.16564332f, 0.04064578f, 0.43325773f, 0.00128623f, 
    -0.10301714f, 0.13950272f, -0.19462296f, 0.11287436f, -0.35937768f, -0.50521725f, -0.34651792f, 0.06741632f, 
    -0.13725740f, 0.27310655f, 0.12289461f, 0.07473254f, 0.03543046f, -0.09133838f, -0.06163152f, -0.31754693f, 
    -0.11034726f, 0.28429309f, -0.16444650f, -0.26918381f, -0.08489965f, -0.31813076f, -0.05988810f, -0.17788330f, 
    -0.01601527f, 0.14592396f, -0.01120065f, 0.07841790f, -0.08092597f, 0.20919716f, 0.41716743f, -0.01881413f, 
    -0.25887781f, -0.01074155f, 0.18267338f, 0.09030046f, -0.30048281f, -0.23666048f, -0.08523931f, -0.09232724f, 
    0.00120393f, -0.19644150f, -0.11729257f, -0.09723597f, -0.11501829f, -0.04811529f, -0.07359980f, -0.14927146f, 
    0.09660102f, -0.02116608f, -0.16827686f, 0.00394184f, 0.00879088f, -0.12111194f, 0.01632264f, 0.01851488f, 
    -0.20638040f, 0.03870100f, -0.10247884f, 0.09661335f, -0.12895319f, -0.19997951f, -0.20311929f, -0.01165345f, 
    0.04110584f, 0.09221327f, -0.05587311f, -0.04524420f, -0.03360908f, 0.05679484f, -0.14832525f, -0.01705797f, 
    0.07310694f, 0.26859498f, 0.17860164f, -0.14107652f, -0.42560807f, -0.15908590f, 0.33496308f, -0.01680490f, 
    -0.12550735f, -0.12271998f, 0.06304582f, 0.12801388f, 0.15208791f, 0.20647846f, -0.12386260f, 0.16379693f, 
    0.42017764f, -0.25365129f, 0.00558262f, -0.02801473f, -0.24923250f, 0.01004702f, 0.07861912f, -0.49835020f, 
    0.19825234f, 0.00141543f, -0.20611736f, 0.14712182f, -0.32334092f, -0.06921698f, 0.30638170f, 0.11984777f, 
    -0.12879960f, 0.02604179f, 0.01279992f, -0.12505643f, -0.30515513f, 0.13043992f, 0.08949029f, -0.15186046f, 
    0.13265327f, -0.13102482f, 0.09589900f, -0.19107234f, 0.11824439f, -0.06106973f, -0.08329978f, 0.30916956f, 
    0.11109536f, -0.11909353f, 0.30550081f, 0.12208557f, -0.00547389f, -0.05731395f, 0.14371158f, -0.29461297f, 
    0.35538533f, -0.06331768f, 0.07682602f, -0.00879873f, -0.31322211f, 0.11236974f, 0.02860764f, -0.15802339f, 
    0.25995231f, -0.13974378f, -0.02924443f, 0.02430697f, -0.05934609f, -0.02615199f, -0.11444599f, 0.20408715f, 
    -0.01068421f, 0.13319531f, 0.06729568f, -0.19178596f, 0.01872162f, -0.04284787f, -0.03236774f, -0.12801021f, 
    0.01640011f, 0.07399649f, 0.04323904f, -0.06244472f, -0.24571742f, -0.04303245f, -0.25860018f, 0.04529789f, 
    0.07960051f, -0.07350731f, 0.05634516f, -0.26060364f, 0.26440728f, 0.08645739f, 0.13286641f, -0.10146433f, 
    0.23423764f, 0.02167184f, 0.01398636f, 0.11765385f, -0.27419171f, 0.01901887f, 0.04745048f, -0.01912374f, 
    -0.25188756f, 0.14987960f, 0.01624191f, 0.08163960f, -0.02981127f, 0.27240565f, -0.02317207f, 0.22297555f, 
    -0.32626376f, -0.14204241f, -0.09953963f, 0.28294545f, -0.04220262f, -0.15726028f, 0.12109434f, -0.06620977f, 
    0.10580556f, -0.28145638f, 0.34284952f, -0.03140647f, 0.56338233f, 0.42946455f, -0.06812436f, -0.26810443f, 
    -0.15511905f, 0.24146925f, 0.36474717f, 0.14080334f, 0.26836264f, 0.03319817f, -0.14032200f, 0.04954224f, 
    0.27360547f, 0.01703947f, 0.01391587f, -0.10595377f, -0.00124630f, 0.41176331f, -0.04410187f, -0.14767835f, 
    0.10891319f, -0.18754204f, 0.11951789f, -0.09583004f, -0.08362655f, -0.19120081f, 0.14290541f, 0.33260402f, 
    -0.27915546f, 0.20260046f, 0.23793596f, 0.18945174f, -0.27874556f, -0.09946219f, 0.00522307f, 0.19242889f, 
    0.07579061f, 0.25208035f, 0.06466170f, -0.33220273f, 0.26482815f, -0.01193059f, -0.11900832f, -0.14641500f, 
    -0.19267340f, 0.13016963f, 0.09232838f, -0.21808732f, 0.06361586f, -0.22076243f, -0.16907442f, 0.03701287f, 
    -0.50531942f, 0.14682120f, -0.21176429f, 0.19977790f, 0.10741201f, -0.16626963f, 0.46350515f, 0.00867293f, 
    -0.01793761f, 0.00794608f, -0.15434982f, 0.04819298f, -0.29841194f, -0.05002735f, -0.23652704f, -0.08245747f, 
    0.43548101f, 0.33213630f, -0.30471802f, 0.07618430f, 0.14300562f, 0.02717919f, -0.20179699f, 0.14688136f, 
    -0.18033022f, -0.21647461f, 0.12367179f, -0.09488928f, 0.07130612f, -0.24632558f, 0.01212275f, -0.03859329f, 
    -0.13484186f, 0.33947030f, 0.06355989f, 0.31456861f, -0.05099100f, -0.21318357f, -0.18571240f, 0.17251700f, 
    0.22912633f, 0.03015157f, 0.01789907f, -0.27104077f, 0.00169098f, 0.08529698f, -0.21367152f, 0.04648820f, 
    0.22317702f, -0.00350257f, 0.06341107f, 0.13559011f, -0.04961436f, 0.16657324f, 0.09527654f, 0.15844414f, 
    0.08132106f, 0.14008349f, 0.02997669f, 0.00417281f, 0.01913814f, 0.24256305f, 0.17445016f, -0.01369182f, 
    0.14422923f, -0.10117910f, 0.03043045f, -0.11724881f, -0.26918983f, -0.12264254f, -0.15996318f, -0.08341557f, 
    0.06182643f, -0.29034227f, -0.24579588f, -0.29877028f, 0.41624537f, 0.09070969f, 0.18769038f, 0.17812601f, 
    0.30271134f, -0.13934600f, -0.37955788f, -0.18403180f, 0.71835798f, 0.16113442f, -0.20193754f, 0.03628876f, 
    0.09258696f, -0.06315461f, -0.14690098f, -0.08842472f, -0.13841072f, 0.43501514f, 0.43607110f, 0.18048927f, 
    -0.14214757f, -0.25416273f, 0.26923174f, 0.27005345f, -0.12716927f, -0.47458920f, -0.04813706f, 0.34689385f, 
    0.00763001f, 0.00304739f, 0.58439738f, -0.00074836f, 0.16933675f, -0.07234023f, -0.24160370f, 0.26323295f, 
    0.16141310f, 0.00417698f, -0.39773089f, -0.20153993f, 0.01250750f, 0.16214460f, -0.17657655f, -0.30979842f, 
    0.09336450f, 0.03308871f, 0.08693209f, 0.11201446f, 0.14855702f, -0.02577762f, 0.03570710f, 0.28924668f, 
    -0.26468679f, -0.03885394f, 0.05793994f, 0.14846200f, 0.05748467f, 0.12359308f, -0.19489366f, 0.16132095f, 
    -0.11376385f, -0.23526545f, 0.60917354f, 0.13951598f, 0.50410885f, 0.18377626f, -0.34348655f, -0.13446715f, 
    0.15013914f, 0.17502503f, -0.62442952f, 0.07249276f, 0.02085949f, -0.12064202f, -0.14437866f, -0.14551184f, 
    0.23405181f, -0.04401483f, 0.02921060f, -0.25394022f, -0.07574638f, -0.12771063f, -0.01116977f, 0.20412765f, 
    -0.20930618f, 0.05381384f, 0.00524094f, -0.28936422f, -0.07853658f, -0.10768589f, -0.13938707f, -0.14030288f, 
    0.01767551f, 0.13155916f, 0.44070247f, 0.10971528f, 0.23180887f, 0.24291967f, -0.02334161f, 0.19221139f, 
    0.20757930f, -0.41747394f, 0.03440579f, 0.21619952f, 0.17398246f, 0.02316212f, 0.16223440f, -0.14395839f, 
    0.11790549f, -0.14232005f, 0.06617151f, -0.14926915f, -0.10882756f, 0.21827057f, -0.04851473f, -0.11651007f, 
    0.21368907f, -0.10771647f, 0.20726669f, 0.28337198f, -0.09448490f, 0.09314829f, -0.06521366f, -0.07782069f, 
    0.25444067f, 0.11443810f, 0.09149632f, -0.08866473f, 0.00402869f, -0.00050337f, -0.03642569f, -0.03251466f, 
    -0.01158179f, 0.29190633f, 0.13784131f, 0.04121848f, 0.26199889f, 0.08160795f, -0.12477977f, 0.20802492f, 
    0.34170923f, -0.09069046f, -0.26970488f, 0.14688903f, -0.16513126f, 0.19072212f, -0.04910709f, 0.09607820f, 
    0.21288453f, -0.25703889f, -0.16200313f, 0.36875021f, 0.10245780f, 0.02216922f, -0.09112648f, -0.01368384f, 
    -0.17501278f, -0.19600309f, 0.47081041f, 0.27520987f, 0.22862491f, -0.06131520f, 0.01357249f, -0.00813430f, 
    -0.18779901f, 0.14814979f, -0.15535241f, -0.15741774f, 0.11346663f, 0.12096686f, 0.16271882f, 0.07516918f, 
    -0.17604473f, 0.22367071f, -0.12941943f, -0.05671001f, 0.04948561f, -0.17370421f, -0.13447954f, 0.30286366f, 
    0.12677318f, 0.10112302f, 0.09080653f, -0.31598976f, 0.39141595f, 0.20416157f, 0.22533119f, -0.17434612f, 
    0.01508355f, -0.06967844f, 0.11947689f, 0.31267700f, 0.04438638f, 0.01578285f, 0.01025345f, -0.15902859f, 
    0.24213906f, -0.20323084f, 0.06850217f, 0.14379093f, 0.16348946f, 0.07614537f, -0.05544129f, -0.18079668f, 
    -0.15339291f, 0.05816270f, 0.17864336f, -0.21427652f, 0.09025844f, 0.07442324f, 0.23062953f, -0.14233786f, 
    -0.16517080f, -0.06278518f, 0.21640031f, 0.21455809f, -0.21486099f, 0.06362170f, 0.24281961f, 0.11799812f, 
    0.10396307f, 0.23142511f, 0.14622729f, -0.17580158f, 0.19616161f, -0.06068106f, -0.30675593f, 0.02672552f, 
    0.18953073f, -0.01747512f, -0.08089064f, -0.21332473f, -0.45013177f, -0.00334034f, 0.27496234f, 0.19146523f, 
    -0.17188412f, -0.14980870f, -0.20351976f, 0.04682923f, -0.06977214f, -0.33102465f, 0.03236486f, 0.29578274f, 
    0.07260820f, 0.12483019f, 0.29572895f, 0.29779437f, 0.23610979f, 0.22839756f, -0.02009041f, -0.35196698f, 
    0.38756251f, 0.03160648f, -0.49160102f, -0.03514728f, 0.11816973f, -0.13957277f, 0.28031126f, 0.01118278f, 
    0.29668513f, -0.20100968f, -0.08096699f, -0.01507564f, 0.33315709f, 0.10295997f, -0.13210584f, -0.05919274f, 
    -0.13727918f, 0.08179898f, 0.13035542f, -0.14298290f, -0.06786542f, -0.14814320f, 0.16015060f, -0.21011093f, 
    -0.22386509f, 0.03757919f, 0.10930524f, -0.22771153f, 0.07746187f, 0.14114764f, 0.01337989f, 0.00751684f, 
    -0.01960423f, 0.26434329f, -0.15314323f, 0.00420321f, 0.02963539f, -0.20480637f, 0.08967984f, 0.22435744f, 
    -0.20800851f, -0.26204231f, -0.08890763f, 0.06734391f, -0.11198058f, 0.16839893f, 0.08782518f, 0.24824803f, 
    0.18140911f, 0.08217258f, -0.10521709f, 0.01471954f, -0.14953551f, 0.10887344f, -0.22461602f, 0.25864667f, 
    0.25961888f, -0.22258247f, 0.07686156f, 0.41731727f, 0.04238206f, -0.09176355f, 0.18093799f, -0.14056341f, 
    0.05271249f, -0.04318060f, -0.28845918f, 0.19620560f, 0.35424331f, -0.13382252f, 0.17618695f, -0.06527377f, 
    -0.07128052f, 0.07037523f, -0.04819295f, -0.01484674f, -0.02870522f, -0.17051166f, -0.05723669f, 0.12409849f, 
    -0.07930260f, -0.39619157f, 0.20864643f, 0.20832880f, -0.12619272f, 0.14164190f, -0.28758106f, -0.31712902f, 
    -0.20279449f, 0.17720585f, -0.35182378f, 0.02657870f, -0.28569925f, 0.04870595f, -0.10456008f, 0.00307219f, 
    -0.07228293f, -0.03405296f, 0.03523200f, -0.13183752f, 0.12042467f, 0.04975991f, 0.11654770f, -0.17894229f, 
    -0.08934405f, -0.32697180f, -0.75772059f, -0.63090223f, 0.08626202f, 0.09984935f, -0.03876670f, -0.11235371f, 
    0.04903949f, 0.21454476f, -0.09072874f, -0.30673286f, 0.10924871f, 0.28335139f, 0.18004492f, 0.06126132f, 
    0.30851150f, 0.14790748f, 0.25515375f, -0.38511002f, -0.05892367f, -0.27843049f, -0.15357323f, 0.14783990f, 
    0.12627557f, 0.21434598f, 0.34936327f, 0.21950060f, 0.14428324f, -0.16262157f, -0.30845743f, 0.19072063f, 
    -0.08387382f, -0.12911415f, 0.23252967f, 0.07736800f, -0.24927542f, 0.08997662f, -0.06301462f, -0.12472091f, 
    -0.16518641f, 0.22438619f, 0.01855021f, -0.07217309f, -0.13336931f, -0.13067152f, -0.12177965f, -0.01719683f, 
    0.16474764f, 0.20600185f, 0.44699433f, -0.17585033f, -0.22756402f, -0.24156331f, 0.19025306f, -0.31458250f, 
    0.30096608f, 0.15914237f, -0.02775313f, -0.15525700f, -0.20511210f, -0.19457573f, -0.27060986f, 0.24893063f, 
    -0.09619330f, 0.00238652f, 0.18130763f, 0.06226763f, -0.14389423f, 0.08993800f, 0.06371566f, 0.39222386f, 
    -0.06827548f, 0.29961628f, -0.18903950f, 0.04783973f, -0.15640314f, -0.14809999f, -0.26199928f, 0.10694487f, 
    -0.09255538f, 0.11639667f, -0.04379008f, 0.10529180f, -0.00375700f, 0.12658516f, 0.40663916f, 0.01788569f, 
    0.13331388f, -0.23905061f, -0.53119498f, -0.00201683f, 0.09231543f, 0.21373427f, 0.29836744f, 0.02945891f, 
    -0.23597431f, -0.08092586f, 0.07934901f, 0.10771077f, 0.24645504f, 0.17210536f, -0.25359094f, 0.46902904f, 
    0.01442175f, 0.20398201f, -0.23970392f, 0.15963309f, 0.04702137f, 0.07724720f, 0.10342422f, -0.04801014f, 
    0.07445806f, -0.03609111f, -0.02946272f, 0.22822581f, 0.00558888f, -0.25430623f, -0.10794555f, 0.20398478f, 
    0.12681890f, -0.06172249f, -0.10688652f, 0.03021769f, 0.29332840f, -0.20991215f, 0.02729960f, 0.22320135f, 
    0.13581881f, 0.21404688f, -0.02963285f, 0.01700611f, 0.60719198f, -0.07012587f, -0.30401474f, 0.31435272f, 
    0.33027914f, 0.02783829f, -0.42760953f, -0.18497185f, 0.06968335f, -0.18397951f, 0.21392292f, -0.25279886f, 
    -0.18809880f, -0.13819742f, 0.29922825f, 0.47712815f, 0.03626812f, -0.31595340f, -0.11317958f, -0.00025780f, 
    0.20304225f, 0.19428851f, -0.11251267f, -0.06178887f, 0.45923513f, -0.24794313f, -0.31867227f, 0.37787038f, 
    -0.18889517f, -0.12935774f, -0.08186559f, 0.06653185f, 0.00805433f, 0.10567172f, -0.08429524f, -0.08001163f, 
    0.05425948f, -0.12311904f, -0.18244115f, -0.12358817f, 0.08264590f, 0.12425815f, -0.12304986f, -0.08369228f, 
    0.07154496f, -0.16853422f, 0.04291589f, -0.13610516f, -0.17513348f, -0.03949668f, -0.01560417f, -0.11160395f, 
    -0.00457765f, 0.01504483f, -0.12888411f, -0.17234431f, 0.11250517f, 0.04854966f, 0.00908105f, -0.12012655f, 
    0.12414255f, -0.05733492f, 0.01633207f, 0.11603968f, 0.66004819f, -0.17827593f, -0.12006958f, -0.25701699f, 
    -0.16510135f, 0.05897435f, -0.06402470f, -0.17481452f, 0.06707124f, 0.20750600f, 0.11721219f, 0.05749260f, 
    -0.09257441f, -0.24518445f, -0.10591583f, -0.17422579f, 0.10120006f, 0.04226496f, -0.31878605f, 0.23336424f, 
    -0.02390544f, 0.12858206f, 0.33802900f, 0.07029568f, 0.22360410f, 0.18552640f, -0.05815386f, 0.31809932f, 
    0.14704628f, 0.06539948f, -0.05333843f, -0.04099509f, -0.27085203f, -0.10940483f, -0.13746987f, -0.11053707f, 
    0.14392304f, -0.05059734f, -0.07293477f, -0.13005070f, -0.12538686f, 0.30410135f, 0.02475247f, 0.16439611f, 
    -0.04194146f, 0.05451125f, -0.12072860f, 0.00152471f, 0.02889227f, 0.16339560f, -0.15441161f, -0.06873296f, 
    0.19394724f, -0.10198940f, 0.08962448f, 0.05026807f, 0.40348214f, 0.00025292f, -0.35268924f, -0.09116613f, 
    -0.14712685f, 0.09671228f, 0.03367490f, -0.14009325f, -0.22311491f, 0.05965712f, 0.04027483f, 0.17823628f, 
    0.34560651f, -0.25321481f, 0.17334466f, 0.00527331f, -0.13365279f, 0.14579001f, -0.05481640f, 0.21286598f, 
    0.36434960f, -0.13736518f, 0.21859142f, 0.00914562f, 0.16974643f, 0.08753882f, 0.00498318f, -0.06085750f, 
    0.09979742f, -0.24721485f, 0.47279862f, 0.23426832f, -0.32233211f, -0.13681467f, 0.15071008f, 0.06330634f, 
    0.09802280f, 0.13777556f, 0.07741985f, -0.35923839f, -0.36915994f, -0.12331188f, -0.07604619f, -0.07834619f, 
    -0.15801811f, 0.18854120f, 0.03102759f, -0.10946231f, 0.00227502f, -0.13158350f, 0.14716482f, 0.35675985f, 
    0.02370219f, 0.47182035f, 0.09630108f, -0.44907749f, 0.32198939f, -0.15826090f, 0.26729423f, 0.10966882f, 
    -0.06111379f, -0.08881213f, -0.14174399f, -0.06429479f, -0.39974701f, -0.09333318f, 0.03770184f, 0.18298450f, 
    0.16852123f, -0.29482484f, 0.07965541f, 0.22912864f, 0.01478041f, -0.09622102f, 0.23151737f, 0.02359808f, 
    -0.03665692f, 0.29009739f, 0.03219147f, 0.19175479f, 0.10896807f, 0.14033182f, 0.01030123f, -0.04514821f, 
    0.15585014f, -0.28656530f, -0.25243974f, 0.27985817f, 0.04319439f, 0.35435936f, 0.27686468f, -0.02623216f, 
    0.13010213f, -0.21990667f, 0.22148201f, 0.02329465f, 0.69830316f, -0.14208557f, 0.09408125f, -0.18207756f, 
    -0.17351319f, 0.03096995f, 0.12577979f, -0.03102737f, -0.32822448f, 0.07051983f, -0.16035469f, 0.51419741f, 
    0.30161199f, -0.06782126f, 0.08421415f, -0.08888414f, 0.10288505f, 0.00641487f, 0.03024815f, 0.17240384f, 
    0.04595108f, 0.23101017f, 0.23586680f, -0.02387412f, 0.17779247f, -0.18092439f, 0.01310823f, 0.16457172f, 
    -0.05392576f, -0.28566819f, 0.03233009f, 0.09317277f, -0.14366707f, 0.19143629f, -0.19519281f, 0.14999110f, 
    0.13023083f, -0.01010398f, 0.08725157f, 0.24758445f, -0.44409677f, -0.14188738f, -0.06975555f, 0.05049205f, 
    -0.00705952f, 0.17282431f, 0.11172501f, -0.09383303f, -0.06066497f, -0.12680303f, -0.01427019f, -0.00248822f, 
    -0.38761425f, 0.34748033f, 0.13618225f, 0.23811826f, -0.03283054f, -0.01206635f, 0.22732775f, 0.06915990f, 
    0.16226877f, -0.18363008f, -0.27571133f, -0.01014743f, 0.53335321f, 0.20471911f, -0.11836064f, -0.07924841f, 
    0.23221967f, 0.04824128f, -0.70269012f, -0.33780247f, -0.07355089f, 0.11902657f, -0.11052939f, 0.07627846f, 
    0.38595638f, -0.18776619f, 0.04202745f, -0.17863910f, 0.09218985f, 0.12233388f, 0.26729700f, 0.16260971f, 
    0.36176580f, -0.06101629f, 0.09689187f, 0.10432302f, 0.01321436f, -0.25184268f, -0.21517389f, -0.15978567f, 
    0.16781643f, -0.06768243f, 0.74018210f, 0.12076999f, 0.33264643f, -0.15680347f, -0.05923254f, 0.23790246f, 
    -0.00245892f, -0.16208382f, -0.09973727f, -0.15902215f, -0.49666896f, 0.00873303f, 0.30434394f, -0.31542933f, 
    -0.06233165f, -0.19680387f, 0.23033230f, -0.11123870f, 0.11335950f, 0.25120157f, 0.25555906f, 0.32816505f, 
    0.27008283f, 0.27225363f, 0.00895869f, -0.11694861f, -0.11633556f, 0.05293633f, 0.23028281f, -0.10211167f, 
    0.09324972f, 0.25666058f, 0.25944242f, 0.06701835f, -0.42228779f, -0.04307928f, 0.18917817f, -0.26280460f, 
    -0.13355248f, 0.13764533f, -0.37395963f, -0.11673099f, -0.23724939f, -0.08431330f, 0.24146529f, -0.32751808f, 
    -0.02140201f, -0.11225522f, -0.06132734f, -0.37485641f, -0.18217696f, 0.37523884f, 0.23492256f, 0.28011599f, 
    0.34760854f, -0.21517767f, 0.49868768f, -0.44202533f, -0.20277235f, 0.18038094f, 0.09524915f, -0.73260337f, 
    0.24925530f, 0.23006828f, 0.33884394f, 0.27194443f, -0.07644125f, -0.37262401f, -0.13655829f, 0.04861860f, 
    -0.00260498f, -0.06450662f, -0.39444324f, -0.13362403f, 0.12750849f, -0.04268165f, 0.16965406f, -0.06731468f, 
    -0.06835987f, 0.14023532f, -0.08606240f, 0.20913598f, 0.02020366f, -0.23972242f, -0.07319663f, 0.24381755f, 
    -0.01152628f, -0.02937494f, -0.06386492f, 0.49573234f, 0.00359133f, 0.10598681f, -0.13144080f, -0.09320848f, 
    -0.05012357f, -0.05477348f, -0.16846293f, 0.22092023f, 0.69017047f, 0.16427888f, 0.03950282f, -0.02667259f, 
    0.00237717f, -0.13886744f, -0.13918877f, -0.03157836f, -0.14448589f, 0.15074694f, -0.12382724f, -0.14571269f, 
    -0.16163138f, 0.15039973f, -0.19610751f, -0.20739950f, 0.17115285f, -0.17372873f, -0.02609191f, 0.02470882f, 
    -0.02575581f, -0.11555054f, -0.18395649f, -0.07964438f, -0.13697025f, -0.19613032f, -0.17792463f, -0.09413216f, 
    0.12575309f, -0.00449418f, 0.06659678f, -0.08391255f, 0.15281112f, -0.03085409f, 0.06683899f, 0.13061576f, 
    0.24633753f, 0.41802511f, -0.26448178f, 0.10506005f, 0.24491148f, 0.04828735f, 0.00466414f, 0.14138152f, 
    0.28559810f, -0.25431368f, -0.12491427f, -0.20055461f, -0.00805895f, -0.20909385f, 0.00131073f, -0.20837574f, 
    0.10592034f, -0.28284195f, 0.10346276f, 0.53452843f, -0.17232707f, 0.16328157f, 0.00969374f, -0.39577147f, 
    0.17919704f, 0.19666064f, 0.20946828f, 0.10025766f, 0.01223641f, -0.18293025f, 0.05880627f, 0.11439361f, 
    -0.16326107f, 0.25122139f, -0.38366833f, 0.01784511f, -0.22932182f, 0.05856213f, 0.14330590f, -0.17665184f, 
    0.06720814f, 0.19454065f, 0.12814206f, 0.08311193f, -0.00667971f, -0.20673735f, -0.10509241f, 0.11719666f, 
    0.21630429f, -0.17428385f, -0.00621120f, 0.05282895f, 0.13206953f, 0.35361558f, 0.07397936f, -0.48588052f, 
    0.10347519f, -0.27349597f, 0.31337151f, 0.27245307f, 0.65806532f, -0.04061873f, 0.22182959f, -0.28591266f, 
    0.15293057f, 0.35599664f, -0.20116282f, 0.01777548f, 0.38531858f, -0.06275142f, 0.03156758f, -0.41097301f, 
    0.08730254f, 0.10359058f, -0.06877335f, -0.01737636f, -0.07995665f, -0.22602798f, -0.06169095f, 0.04237335f, 
    0.11644732f, -0.04874793f, -0.15393288f, 0.21917297f, -0.03217643f, 0.14161752f, -0.32235888f, 0.15734677f, 
    0.02807605f, 0.18677469f, 0.09669349f, 0.13982125f, 0.37477922f, 0.04610149f, -0.32760969f, -0.13004303f, 
    0.06868140f, 0.15974417f, 0.14976452f, -0.11188910f, -0.12134382f, 0.00840881f, -0.01909622f, 0.03081785f, 
    0.13527226f, -0.26397935f, 0.22414002f, -0.00936969f, 0.09202480f, 0.20268033f, 0.10394960f, 0.23798244f, 
    0.27437931f, -0.01631333f, 0.16660257f, 0.09487583f, -0.19199745f, -0.27018237f, 0.08402219f, 0.20088519f, 
    -0.10040456f, 0.07648906f, 0.38983673f, 0.02810003f, -0.23466153f, 0.13808356f, -0.29674283f, -0.29252869f, 
    0.04930880f, -0.13697881f, 0.24448283f, -0.19126476f, -0.14441293f, -0.08596066f, 0.19267987f, 0.28430197f, 
    0.09384441f, -0.19722147f, -0.02551475f, 0.17055574f, 0.11428687f, -0.11403374f, -0.25654724f, 0.20493804f, 
    0.23359752f, 0.03660129f, -0.15774079f, 0.21309918f, -0.17606014f, -0.04903511f, 0.26295978f, 0.01172161f, 
    0.00395782f, -0.13359544f, -0.16409177f, 0.03840105f, 0.00728960f, -0.08729193f, 0.01420829f, 0.00954779f, 
    -0.17562738f, -0.23584425f, 0.02801977f, -0.24691752f, 0.01187362f, -0.01694514f, 0.35518396f, 0.08363526f, 
    0.08190593f, 0.10163883f, 0.08506741f, 0.01005071f, -0.06179985f, 0.19712833f, -0.26139596f, 0.15309550f, 
    0.26491290f, -0.03593998f, 0.08952443f, -0.35307017f, -0.04640574f, 0.13182035f, 0.19582996f, 0.06827026f, 
    0.05437771f, 0.01751471f, -0.39501458f, 0.11366509f, -0.05968392f, -0.14174691f, 0.18220632f, 0.00591330f, 
    -0.20865837f, -0.13900352f, 0.02763123f, -0.08748688f, 0.00493319f, 0.08243746f, -0.20605631f, 0.05279183f, 
    -0.12124111f, -0.02526566f, -0.16289212f, -0.09817890f, 0.11577672f, 0.08199384f, -0.19709598f, -0.14414765f, 
    0.06693225f, -0.05314796f, -0.04153681f, -0.05408423f, 0.09103568f, 0.14133687f, 0.02013224f, -0.17239170f, 
    0.05509423f, -0.16684435f, -0.13839188f, -0.02927647f, -0.09533237f, -0.07815049f, 0.05870906f, 0.10346863f, 
    -0.01561363f, -0.30124602f, 0.01710096f, 0.19014068f, -0.05824459f, -0.11710449f, 0.11567415f, 0.22516136f, 
    0.07949827f, 0.16206367f, -0.08948642f, -0.02792090f, -0.12217090f, 0.05816553f, 0.15496039f, -0.27799475f, 
    -0.16430789f, -0.23084661f, -0.25371867f, 0.26911107f, 0.04147383f, 0.26811951f, -0.04152822f, 0.22534893f, 
    -0.01603570f, -0.13372695f, -0.31873521f, 0.03302186f, 0.63114625f, 0.07236183f, 0.04247312f, 0.10555619f, 
    0.44747707f, -0.43224180f, -0.27754036f, 0.24893183f, -0.16799787f, -0.02977372f, -0.14111194f, 0.15082730f, 
    0.15605593f, -0.14860438f, 0.07820660f, -0.00583789f, 0.00072697f, 0.16820526f, 0.11543440f, -0.07920361f, 
    -0.22548266f, 0.09312093f, 0.16576800f, 0.44293141f, -0.38444066f, -0.10521347f, 0.09676272f, 0.10223965f, 
    -0.06045679f, -0.19421214f, 0.40492183f, -0.17782435f, 0.28219905f, -0.04869983f, 0.19752660f, 0.04728807f, 
    0.26717660f, 0.11319455f, -0.47570902f, -0.22338627f, 0.36671451f, 0.05816663f, -0.20466608f, -0.02760674f, 
    -0.03434331f, 0.29875636f, 0.13611554f, -0.08282819f, 0.05529619f, -0.42752331f, -0.08158760f, -0.06669243f, 
    -0.17882080f, 0.25451070f, -0.16688396f, 0.30706525f, -0.06380172f, 0.14343096f, 0.19323511f, 0.22846091f, 
    0.18921527f, 0.05433754f, 0.02475635f, -0.00811618f, 0.62023026f, 0.25095478f, -0.09347510f, 0.05672320f, 
    0.09887440f, -0.01699146f, -0.04370811f, 0.28178445f, -0.18950012f, 0.02083283f, -0.20504640f, 0.30759463f, 
    -0.06047609f, 0.14064439f, -0.37339288f, -0.27721450f, 0.06300647f, -0.47525069f, 0.19539931f, 0.10519663f, 
    -0.09314140f, 0.15418148f, 0.20749556f, 0.53359097f, -0.08083058f, -0.32825702f, -0.11236802f, -0.11937260f, 
    0.18051264f, 0.15972044f, -0.72525269f, -0.17516311f, -0.06517255f, -0.04269417f, 0.08861677f, 0.24263568f, 
    0.03232712f, -0.25738779f, 0.22594897f, -0.15000080f, -0.15589753f, -0.04044903f, 0.03910146f, -0.23158176f, 
    -0.14086168f, 0.37036330f, -0.06447816f, -0.08195889f, 0.10258494f, 0.10457693f, -0.04286961f, 0.05643763f, 
    0.05359325f, 0.23556596f, 0.18539320f, -0.20175952f, -0.17215423f, -0.02002510f, 0.46143940f, 0.15774192f, 
    -0.10317486f, 0.20853749f, -0.09221223f, -0.10793763f, -0.02406180f, -0.37155291f, -0.09182011f, 0.13685992f, 
    0.19414991f, -0.05479430f, -0.03594041f, -0.10886920f, 0.57617581f, -0.15695056f, -0.04830637f, -0.13004185f, 
    0.32745868f, 0.08190323f, -0.15778631f, -0.09768005f, 0.08997079f, 0.15632425f, -0.01291046f, 0.04855401f, 
    0.20555712f, -0.23822774f, 0.08132836f, -0.07428293f, 0.00597139f, -0.23091872f, -0.22928986f, 0.16608343f, 
    -0.16885787f, 0.18642421f, 0.14605993f, 0.23649140f, 0.03843350f, 0.08098301f, -0.18597178f, 0.30489013f, 
    0.23359127f, -0.25604245f, -0.01957862f, 0.28630543f, -0.20423247f, -0.09397050f, 0.16777337f, 0.30817452f, 
    0.01573456f, 0.12424300f, -0.22946022f, 0.10374953f, 0.08013614f, 0.14967528f, 0.07605951f, -0.17831768f, 
    0.13849913f, 0.07936476f, -0.27625689f, 0.52206016f, -0.17094111f, -0.01080564f, -0.03362224f, 0.05488466f, 
    0.18912882f, 0.05836809f, -0.27639484f, -0.22058073f, 0.23484863f, 0.13244684f, 0.40957969f, -0.01751188f, 
    0.08118393f, -0.15636767f, 0.04605959f, -0.56976390f, -0.02132964f, -0.04111059f, 0.15264502f, 0.07461429f, 
    0.05591295f, -0.00666779f, -0.24033689f, -0.31223398f, -0.02635828f, -0.15332957f, 0.19148569f, 0.14503080f, 
    0.51266885f, -0.07285114f, 0.15620349f, 0.01165764f, -0.18155637f, -0.32439324f, -0.02650905f, -0.26223090f, 
    0.23920318f, 0.10508326f, -0.39175272f, -0.05772911f, -0.17706339f, -0.14570487f, -0.23684250f, 0.30537802f, 
    0.01905180f, -0.36328614f, 0.04382260f, -0.13605659f, -0.37944216f, 0.06273847f, -0.02829614f, -0.00041151f, 
    -0.14390121f, 0.19604129f, 0.02715909f, 0.30888095f, 0.15075712f, 0.25454599f, -0.19074927f, 0.40262118f, 
    0.22979592f, -0.20236318f, 0.33006632f, -0.40677109f, -0.04782746f, -0.05395465f, -0.02563773f, -0.35559559f, 
    0.26744765f, -0.04432042f, 0.00703274f, 0.26968670f, -0.08825181f, -0.00211575f, 0.23004188f, 0.11115586f, 
    -0.08770140f, 0.39279389f, 0.16811487f, 0.12176196f, -0.48237896f, 0.00210411f, -0.22888233f, 0.44980392f, 
    -0.16677381f, 0.05873749f, -0.38741776f, -0.01456228f, 0.11195044f, -0.00178518f, -0.21108148f, 0.16420673f, 
    -0.04597552f, -0.03005067f, 0.29436037f, 0.03983307f, 0.03775834f, 0.07000624f, 0.12922154f, -0.13428459f, 
    0.00647804f, -0.18811472f, -0.41405013f, 0.24681470f, 0.05400388f, 0.34839085f, -0.14866820f, -0.07638749f, 
    0.01770381f, -0.11805078f, 0.13884494f, -0.19127028f, -0.06066266f, 0.10630421f, -0.11176179f, 0.03571009f, 
    -0.18199462f, 0.08973628f, -0.06473606f, -0.00591864f, -0.14205745f, -0.09343727f, -0.00775634f, 0.06534615f, 
    0.00140164f, -0.17118172f, 0.02422927f, -0.11936555f, -0.16736786f, -0.02537589f, -0.17499276f, -0.06930806f, 
    -0.19953801f, 0.02331493f, -0.16331047f, 0.10502635f, 0.07250965f, -0.21405587f, -0.12170075f, -0.09480667f, 
    -0.18442895f, 0.10368567f, -0.09306665f, 0.11671579f, -0.09527855f, 0.10769487f, -0.12934043f, -0.02004656f, 
    -0.08096040f, -0.02542498f, -0.02070000f, -0.10796414f, -0.12265519f, 0.13125157f, -0.13721989f, -0.13208488f, 
    0.01003051f, -0.12591857f, -0.12274606f, 0.11019339f, -0.10605180f, 0.00814021f, 0.10456546f, -0.13100091f, 
    -0.01566442f, -0.07268760f, -0.10316902f, 0.00811344f, -0.14191346f, -0.20370154f, 0.13187432f, 0.10380876f, 
    0.22146420f, 0.25948167f, -0.32133314f, -0.39296648f, -0.06928442f, -0.03614136f, -0.03581243f, -0.36300176f, 
    -0.07510331f, -0.02937274f, 0.17499390f, -0.16759069f, -0.02432238f, -0.29742479f, 0.05769512f, 0.26669115f, 
    0.21898308f, 0.30727297f, 0.04464924f, -0.19568482f, -0.10802893f, 0.16679923f, 0.31511515f, 0.20190459f, 
    0.11713938f, 0.19785370f, -0.03552884f, 0.14426051f, -0.12352169f, -0.38434124f, -0.41028675f, -0.03707117f, 
    -0.04035273f, -0.31763613f, -0.24193805f, -0.33629632f, -0.40698946f, 0.08608207f, -0.01373346f, 0.13627467f, 
    0.24770963f, -0.29025412f, 0.22695814f, 0.08679581f, 0.01630788f, -0.05893716f, 0.08592441f, 0.36169860f, 
    0.26056242f, 0.26774925f, 0.15401810f, 0.04375751f, 0.00880773f, -0.07798418f, 0.35537881f, -0.25447565f, 
    0.26929691f, 0.12532531f, 0.22825602f, -0.04393110f, -0.39076638f, -0.27688381f, 0.31028393f, -0.20733494f, 
    -0.37301555f, -0.13445204f, 0.11095550f, -0.27518669f, -0.27467781f, 0.06445592f, 0.10117817f, 0.21295977f, 
    0.16212359f, 0.05457545f, 0.19561802f, 0.23481165f, -0.02311802f, -0.02587256f, -0.13953732f, 0.27660334f, 
    0.07538448f, -0.05683907f, 0.14341792f, -0.32587802f, -0.01496213f, -0.10325223f, 0.06530961f, -0.01338328f, 
    0.24480923f, 0.11505627f, -0.11784399f, 0.14035569f, -0.33556226f, -0.21148765f, -0.07403487f, -0.02875588f, 
    0.02464791f, -0.25042790f, -0.01688449f, -0.05335909f, -0.34876519f, -0.13122870f, 0.10120580f, 0.07471137f, 
    0.03302193f, 0.16642401f, -0.03670000f, 0.13853323f, -0.07574792f, 0.15863879f, 0.06569164f, 0.10992269f, 
    -0.07317299f, -0.16004668f, 0.24038690f, -0.21157765f, 0.02691599f, 0.01742046f, 0.11795163f, 0.02690573f, 
    0.05680185f, -0.12770300f, -0.06068668f, -0.14898588f, 0.42049611f, -0.04786966f, -0.06410111f, -0.05001098f, 
    0.43659803f, 0.20953654f, -0.32725173f, 0.07722996f, -0.16815014f, -0.13614455f, -0.07062741f, -0.21538095f, 
    -0.13590282f, 0.04797751f, 0.28038892f, -0.36633432f, 0.09030849f, 0.29035923f, 0.27868420f, -0.08829369f, 
    -0.05830920f, -0.16318831f, 0.29140437f, 0.03076963f, -0.36035067f, 0.04125118f, 0.03825273f, -0.46342006f, 
    0.15323296f, 0.26345336f, 0.48901796f, 0.04524832f, -0.04977126f, 0.15792453f, 0.04681615f, -0.13605253f, 
    -0.25151506f, 0.01669415f, 0.01187549f, -0.01307160f, 0.38085341f, -0.01465701f, 0.01358919f, 0.02130921f, 
    -0.12258159f, -0.20716339f, 0.12886250f, 0.11432245f, 0.05681195f, -0.17237024f, -0.21966468f, -0.07123493f, 
    -0.44861007f, 0.41893843f, 0.07742906f, -0.20364557f, 0.17304075f, -0.10240357f, -0.22648834f, -0.11348551f, 
    -0.09348688f, -0.00394277f, 0.33483645f, -0.00317177f, -0.10947424f, 0.32223797f, -0.14839542f, -0.02113167f, 
    0.22717810f, 0.19054130f, -0.59408796f, -0.26550999f, 0.07996130f, -0.00378075f, -0.05867608f, 0.02597629f, 
    0.26563129f, -0.31237221f, -0.02139818f, -0.27709538f, -0.13501112f, 0.07816564f, 0.30871090f, -0.00092426f, 
    0.29118150f, -0.16663900f, 0.34041399f, 0.21672998f, -0.11151559f, -0.19588244f, -0.15120539f, -0.35856360f, 
    0.13321017f, 0.11418588f, 0.69934529f, 0.11118832f, 0.26401779f, -0.08229618f, -0.04583593f, 0.22735207f, 
    0.13015100f, 0.25690058f, -0.14172800f, -0.08135122f, 0.33246788f, -0.07919361f, 0.02991892f, -0.31832042f, 
    -0.15299812f, 0.44910848f, 0.20005515f, -0.06473185f, -0.03576208f, 0.11388092f, -0.02261148f, 0.11960717f, 
    -0.57310808f, -0.03618075f, -0.29684034f, 0.17689188f, 0.00244556f, -0.02751620f, 0.39311022f, -0.00303589f, 
    -0.21188955f, -0.21382944f, 0.44502923f, 0.07820570f, 0.32812911f, 0.28529698f, -0.44043410f, 0.19350867f, 
    -0.26456895f, -0.14620133f, 0.18836796f, 0.15540342f, -0.02945997f, 0.04288962f, 0.13955033f, 0.47200403f, 
    0.37150717f, 0.00170404f, -0.17608482f, 0.12914366f, -0.17465463f, 0.13882224f, -0.13964818f, -0.02577502f, 
    0.17066443f, -0.20025311f, 0.29789439f, -0.10116912f, -0.12655805f, 0.15468709f, -0.12874064f, -0.18062109f, 
    0.27844805f, 0.11200306f, -0.18672344f, 0.11872049f, -0.18111163f, -0.31412360f, 0.15696391f, 0.39207658f, 
    0.00633785f, 0.22459778f, 0.23529424f, 0.07706232f, 0.51236761f, -0.10236617f, -0.40234923f, 0.42321643f, 
    0.19075073f, 0.15523350f, -0.65150648f, -0.67746288f, -0.13214892f, -0.26450017f, 0.23650847f, -0.08687393f, 
    0.10392004f, -0.48268473f, 0.09427390f, 0.24244589f, -0.15801205f, -0.42867610f, 0.06285099f, 0.23785028f, 
    -0.11065980f, 0.18982051f, -0.35235760f, 0.18039148f, 0.00140880f, -0.02913018f, -0.26652205f, 0.07141947f, 
    -0.10535235f, -0.30073231f, 0.00383119f, 0.22870420f, -0.11936728f, -0.09140235f, -0.07072162f, 0.07936965f, 
    0.02760068f, 0.49261627f, 0.02800070f, -0.17247865f, -0.11020526f, 0.14689755f, -0.06089431f, -0.02601160f, 
    -0.15090224f, -0.02695404f, 0.01635651f, -0.32096511f, 0.12210520f, 0.01343822f, 0.23900083f, 0.24112213f, 
    -0.08946328f, 0.07800973f, -0.27129948f, 0.00525673f, 0.33579639f, 0.10590472f, -0.02577921f, 0.03835789f, 
    -0.22852501f, -0.31842136f, 0.12034684f, -0.13163221f, -0.24242812f, -0.06007444f, -0.01569446f, -0.03151614f, 
    0.21198025f, 0.09621304f, 0.10529798f, -0.07889295f, 0.12428023f, 0.08515323f, -0.18920293f, 0.34401312f, 
    0.27158719f, -0.03066968f, 0.24461813f, -0.35074285f, -0.13287613f, -0.04704422f, 0.23020430f, -0.39195231f, 
    0.16390967f, 0.04372038f, 0.00020044f, 0.11563946f, 0.04630842f, -0.30678219f, 0.23776038f, 0.17084385f, 
    -0.09687020f, -0.03419613f, -0.06815390f, -0.08826149f, -0.05093000f, 0.13930763f, -0.12206669f, 0.13744052f, 
    -0.08571813f, 0.05204442f, 0.16531980f, 0.13984804f, -0.16450040f, 0.17067614f, 0.09988861f, 0.04599409f, 
    -0.08164477f, 0.01519655f, -0.07720835f, -0.21606784f, 0.29320318f, 0.04317793f, 0.21882799f, 0.09337936f, 
    -0.16792014f, -0.21271197f, 0.38847691f, 0.02161327f, 0.12525584f, 0.27593485f, -0.01929733f, 0.10148628f, 
    0.07446460f, -0.16477540f, 0.01991590f, 0.12889586f, -0.32080370f, -0.07342090f, 0.15274110f, -0.06711017f, 
    -0.06542522f, 0.03810382f, 0.15766618f, 0.00624826f, -0.03023665f, 0.25170603f, 0.15834054f, -0.00047155f, 
    0.10244682f, -0.17138597f, 0.14603545f, -0.29119205f, -0.15787280f, 0.04510156f, -0.11938292f, 0.00700588f, 
    -0.03573989f, -0.06344032f, 0.16221477f, -0.01615085f, 0.05527867f, 0.10413292f, -0.12236897f, 0.12291881f, 
    0.17630734f, 0.41547742f, -0.30788875f, -0.18119138f, -0.14167379f, -0.03009490f, 0.14438911f, 0.12856676f, 
    0.09134400f, -0.28044349f, -0.12207048f, -0.01231406f, 0.09047487f, -0.40239871f, 0.01103762f, 0.07321602f, 
    -0.05566630f, 0.04166032f, -0.09895988f, 0.56015480f, -0.05387880f, 0.17633015f, 0.02310266f, -0.33628842f, 
    0.20155801f, -0.10605483f, -0.26097402f, -0.14157884f, 0.19415337f, 0.19335699f, 0.18263540f, -0.07919019f, 
    0.03389964f, 0.35105345f, -0.18350068f, -0.01054775f, 0.18057288f, -0.16087095f, 0.09965037f, -0.01224637f, 
    0.18165894f, -0.08737466f, -0.24013607f, 0.06025249f, -0.14411651f, -0.12947346f, -0.14242241f, 0.17140752f, 
    0.31705180f, -0.34479290f, 0.07757295f, 0.50524527f, 0.10182336f, 0.11776416f, -0.34607664f, -0.10990597f, 
    0.21438994f, 0.11705253f, -0.11838968f, 0.20966338f, 0.11425140f, 0.04484098f, 0.07085653f, 0.04469747f, 
    -0.03234587f, -0.13726205f, -0.14036554f, 0.17340280f, -0.07811956f, -0.06121982f, -0.02198067f, -0.23328303f, 
    -0.12848012f, 0.06455283f, 0.23535526f, -0.12073383f, 0.02752347f, -0.06400716f, -0.05008833f, -0.11024898f, 
    0.15064125f, 0.08113240f, -0.06404833f, 0.16091548f, 0.09918283f, 0.01882992f, -0.20211372f, -0.06302878f, 
    -0.06139140f, -0.00187541f, 0.07028136f, 0.23254085f, -0.11133361f, -0.03714753f, 0.01690823f, -0.11716330f, 
    -0.13889222f, 0.10629370f, -0.07739548f, -0.14694649f, -0.02042904f, 0.03857762f, -0.27546775f, 0.14062254f, 
    0.12051523f, -0.20508441f, -0.22055884f, 0.07202736f, 0.05999372f, 0.14462313f, 0.24554147f, -0.08190216f, 
    -0.09359291f, -0.36771858f, -0.07103150f, -0.00595922f, 0.10595834f, 0.01138994f, -0.06931191f, 0.01234552f, 
    -0.29174313f, -0.04036633f, -0.15876077f, 0.12695128f, 0.28756964f, 0.32144043f, 0.18464446f, -0.19127601f, 
    -0.08564474f, -0.09472695f, -0.01544901f, 0.06507121f, -0.10891407f, -0.04883682f, -0.15262878f, -0.27341306f, 
    -0.15395544f, 0.11014600f, -0.01723889f, 0.01911316f, 0.05576241f, -0.01389703f, -0.15715343f, -0.10653862f, 
    -0.05754968f, 0.03501339f, -0.06849392f, 0.03819600f, 0.15511043f, 0.02129860f, 0.13227765f, -0.22277658f, 
    0.03364343f, -0.12607068f, 0.18227085f, -0.18343042f, -0.27038750f, 0.03344949f, 0.12589107f, -0.16177899f, 
    0.32395619f, -0.26235235f, -0.52696574f, -0.23256303f, 0.00202116f, -0.01149000f, -0.09214348f, -0.00611868f, 
    0.08362348f, -0.08271810f, -0.20842488f, -0.24054067f, -0.07498237f, -0.07400535f, 0.27581894f, 0.09186289f, 
    0.12288784f, 0.01336782f, 0.38038954f, 0.34470803f, -0.08481343f, -0.36358428f, 0.04216862f, 0.06557958f, 
    0.28740525f, 0.22178066f, -0.23806345f, -0.03958494f, 0.26951855f, -0.15926160f, -0.29323465f, 0.08668038f, 
    -0.27597022f, 0.38342065f, 0.23240703f, -0.14605559f, 0.38747355f, -0.06777532f, -0.09406805f, -0.16191664f, 
    -0.27340978f, 0.28385964f, -0.10239437f, -0.21356092f, -0.13293631f, -0.02086323f, -0.04999632f, -0.05920203f, 
    -0.15004931f, -0.08543933f, -0.28394535f, -0.10790341f, -0.03199638f, 0.24738519f, 0.27228558f, -0.16756429f, 
    -0.25956175f, -0.09832895f, 0.18674342f, 0.20180765f, -0.20419058f, -0.27061585f, -0.02120555f, 0.04879001f, 
    0.16060649f, 0.23885418f, 0.04718119f, 0.10182142f, 0.15699208f, 0.08960212f, 0.09422394f, -0.28815040f, 
    -0.23996019f, 0.12559286f, 0.09014437f, -0.11525216f, 0.10294275f, 0.29097250f, -0.05921228f, -0.02513537f, 
    0.14979082f, -0.12311981f, -0.35329941f, -0.31247211f, 0.08481856f, 0.28633121f, 0.19510958f, -0.01482621f, 
    -0.02775046f, -0.20283274f, 0.02355288f, 0.06663980f, 0.05771878f, 0.15235087f, 0.04693806f, -0.15845442f, 
    -0.09254789f, -0.02064129f, -0.17963751f, 0.04561027f, -0.09135949f, 0.16418450f, 0.03097445f, 0.04923544f, 
    0.00303791f, -0.08378789f, -0.11454994f, -0.04000643f, -0.04661932f, -0.18723494f, -0.04869514f, 0.09084589f, 
    -0.13062388f, 0.07014958f, -0.11295037f, -0.02965326f, -0.13310938f, 0.02434571f, -0.00830647f, -0.16815297f, 
    -0.08742733f, -0.04402365f, 0.05081645f, -0.16889110f, -0.11967353f, -0.20980175f, -0.08236559f, -0.10517119f, 
    0.01101819f, -0.23342744f, -0.32723626f, -0.07084215f, 0.18882306f, -0.04199741f, 0.00432885f, -0.36825642f, 
    0.03447757f, 0.21645854f, 0.17959058f, 0.13320118f, -0.01299212f, -0.08304096f, -0.09097382f, -0.02028665f, 
    0.04225955f, -0.09748845f, 0.02114548f, 0.02707454f, 0.27632457f, -0.11257007f, 0.31711882f, 0.12474475f, 
    -0.07183022f, -0.05968415f, -0.23065229f, 0.04245503f, 0.22011612f, -0.10928218f, 0.08643708f, -0.16801810f, 
    -0.21588175f, -0.36469990f, 0.10161996f, -0.18371786f, -0.45048830f, 0.01185906f, 0.06125014f, -0.10103245f, 
    -0.18047419f, 0.35106853f, 0.12778021f, 0.15667163f, -0.05529117f, 0.02759111f, -0.00582004f, 0.15867655f, 
    0.12782373f, 0.00645832f, 0.04432971f, -0.14898071f, -0.20255251f, -0.05976615f, 0.35919252f, -0.50436318f, 
    0.10222095f, -0.00712329f, -0.47093812f, 0.23011850f, 0.16978711f, -0.00362689f, -0.10264947f, -0.09153815f, 
    0.21063256f, 0.19082959f, -0.17064135f, -0.02084700f, 0.34539452f, 0.09498637f, 0.02421683f, 0.33676472f, 
    0.47512290f, 0.04965007f, -0.10122816f, -0.47166026f, -0.05527402f, 0.19019285f, 0.37164325f, -0.11115582f, 
    -0.05989897f, -0.40988564f, -0.01126739f, 0.45518216f, -0.21617028f, -0.18266562f, -0.06767076f, -0.05114446f, 
    -0.13760433f, 0.02146525f, 0.40318587f, -0.19790371f, -0.04437751f, -0.40070233f, -0.09577484f, 0.17431979f, 
    -0.15597726f, 0.10062654f, -0.03578163f, 0.01411841f, 0.24201192f, 0.16278495f, -0.03138819f, 0.20714180f, 
    0.13909313f, -0.02229065f, -0.06373177f, 0.12139051f, -0.11740320f, -0.09735803f, -0.06790373f, 0.01485087f, 
    0.29257122f, -0.03712545f, 0.06229274f, 0.09559912f, 0.03013037f, -0.01991211f, 0.15462266f, -0.10212762f, 
    -0.01278747f, -0.10799612f, -0.04530649f, 0.18301024f, 0.15156980f, -0.08061452f, -0.03089281f, 0.19528131f, 
    0.18895736f, -0.29599309f, 0.00463569f, 0.00708884f, -0.05362295f, 0.10060371f, -0.21632163f, -0.21291685f, 
    -0.01108987f, -0.15136670f, 0.05888453f, -0.06505867f, 0.13385591f, -0.00272472f, 0.08162269f, -0.06031560f, 
    -0.06838286f, -0.10188849f, -0.21921445f, -0.20174131f, -0.19703123f, 0.01431210f, -0.13024241f, 0.17099971f, 
    -0.24098998f, 0.08629204f, -0.03305198f, -0.15344048f, -0.12390068f, -0.35634273f, 0.04283993f, -0.16199806f, 
    0.08312134f, 0.23819630f, -0.40971702f, -0.35158074f, -0.00132232f, 0.14699973f, -0.08583791f, 0.33501574f, 
    -0.00791738f, 0.29963690f, 0.07376005f, 0.15218644f, 0.05800731f, -0.35035193f, -0.06114800f, 0.12764569f, 
    -0.18318561f, 0.36910668f, 0.02925557f, 0.10604142f, 0.19985147f, -0.09954960f, -0.07978744f, 0.11019202f, 
    0.20706896f, -0.20413275f, -0.00577343f, 0.30883837f, 0.59817284f, -0.04086637f, -0.02840602f, 0.05865162f, 
    0.06021874f, 0.04596367f, 0.01378820f, -0.09245605f, -0.15739572f, 0.00368199f, -0.09814350f, -0.18493935f, 
    -0.08693489f, -0.01437433f, -0.03175872f, -0.02454917f, -0.10274292f, 0.03519904f, -0.07892790f, -0.20799735f, 
    -0.00100716f, -0.20046028f, -0.07551613f, -0.19119219f, -0.09699395f, -0.09432822f, -0.11148017f, -0.17663585f, 
    0.08598915f, 0.05667238f, -0.20275855f, -0.16750354f, -0.08171902f, -0.11385317f, -0.09236109f, 0.00962632f, 
    0.09548067f, 0.20193130f, 0.28237349f, 0.21818806f, 0.42447242f, 0.10329573f, -0.24495070f, 0.21829131f, 
    0.24536441f, 0.14682600f, -0.19016463f, 0.04272288f, 0.06405095f, 0.02971359f, 0.02352232f, -0.27867848f, 
    -0.02165020f, 0.03907960f, 0.09515350f, 0.20967360f, -0.26789647f, -0.25981212f, -0.00901634f, 0.22625627f, 
    -0.25513795f, 0.14167039f, 0.21821372f, -0.09387025f, -0.23367803f, 0.02493563f, -0.05018499f, 0.21271122f, 
    -0.12682557f, -0.05324887f, 0.20407541f, 0.03109772f, 0.15534253f, 0.08896903f, 0.08562636f, 0.45520389f, 
    0.13409907f, 0.18091840f, -0.27296072f, 0.04569456f, -0.13973714f, -0.09979758f, -0.06554083f, -0.22456503f, 
    0.07166012f, -0.14743955f, -0.11246981f, 0.25293985f, 0.16337535f, -0.05592125f, 0.09378804f, -0.00022805f, 
    0.06903826f, -0.15792331f, -0.26056424f, 0.30742720f, 0.19102640f, -0.00169145f, 0.10542727f, 0.02870958f, 
    -0.06060349f, -0.13543706f, -0.20781446f, 0.08122616f, 0.04431517f, 0.15546849f, -0.07072159f, -0.05124733f, 
    0.06251805f, 0.02740646f, -0.04983170f, 0.03787735f, 0.10115079f, 0.05849282f, -0.00193689f, -0.23914410f, 
    -0.21775135f, -0.23925738f, -0.11583407f, -0.01157560f, 0.14216541f, -0.11547542f, 0.02795904f, -0.18744744f, 
    0.15031770f, -0.17423066f, 0.03004136f, 0.00250257f, -0.02681405f, -0.10064127f, -0.17288363f, -0.10857921f, 
    0.39313120f, -0.40904912f, 0.06524366f, 0.31190652f, -0.02989274f, 0.08346813f, 0.06142574f, 0.09884275f, 
    0.12665765f, -0.23482609f, 0.28273395f, 0.05726042f, 0.10618143f, 0.14277464f, 0.20652410f, 0.06910119f, 
    0.18557791f, 0.02084910f, -0.10771726f, 0.46891141f, -0.30138403f, -0.09147146f, -0.11633140f, 0.09853156f, 
    0.11520094f, -0.15543161f, 0.25514859f, -0.32420185f, 0.04606866f, -0.11509057f, 0.13238972f, 0.17939068f, 
    -0.10658876f, 0.34479120f, -0.11957180f, 0.26370865f, -0.24182589f, -0.15062308f, 0.00534457f, -0.14090484f, 
    0.11659484f, -0.09374283f, -0.11933615f, -0.13421656f, 0.11102932f, 0.10128444f, 0.05844316f, 0.20369308f, 
    0.05798966f, 0.10755374f, 0.17752662f, 0.38565969f, -0.04258060f, 0.10718261f, -0.14906026f, 0.03285640f, 
    0.14211445f, -0.01232341f, 0.18494698f, 0.13508049f, -0.08966783f, 0.11239755f, 0.07224719f, 0.03362421f, 
    0.05572896f, -0.19822484f, -0.06716271f, -0.15999997f, -0.25119519f, -0.05562214f, 0.15430243f, -0.10706605f, 
    0.07184348f, -0.14401875f, 0.33466208f, -0.07997977f, 0.10621364f, 0.04774855f, 0.24082106f, 0.18648510f, 
    0.20600396f, 0.21048766f, 0.04881559f, -0.36856070f, -0.28684846f, 0.03285913f, 0.24922694f, 0.09278391f, 
    0.12841658f, 0.05884958f, 0.12110859f, -0.16616608f, -0.08062949f, -0.16302703f, -0.28650463f, -0.12148414f, 
    -0.05667176f, 0.09420243f, 0.14214772f, 0.12268768f, -0.45097330f, -0.04739251f, 0.13268234f, 0.01862959f, 
    -0.18036290f, -0.15509391f, -0.15389894f, 0.12303617f, 0.12608320f, -0.04517448f, -0.09091818f, 0.23141386f, 
    -0.01707670f, -0.11313573f, 0.21303071f, -0.03769571f, -0.00284822f, -0.01884499f, 0.28136009f, -0.37627333f, 
    0.36308923f, -0.00550429f, -0.19657232f, 0.10346423f, -0.09870003f, 0.15732577f, 0.13461740f, -0.06041591f, 
    -0.12101095f, -0.16545710f, -0.00573010f, -0.11739119f, -0.14319271f, -0.16725494f, -0.09053059f, 0.02837758f, 
    -0.12390122f, -0.17379928f, -0.06222282f, -0.00850313f, -0.06951640f, -0.14302927f, -0.03559232f, -0.08066260f, 
    -0.04940293f, 0.09065294f, -0.14443678f, 0.14658326f, -0.02523644f, -0.09571183f, 0.06885682f, -0.11236250f, 
    -0.11752275f, -0.09621847f, -0.00140313f, -0.15629822f, 0.06048871f, 0.17640765f, -0.05150222f, -0.03467961f, 
    0.17696823f, -0.06012703f, -0.10237058f, 0.12986779f, -0.07222641f, -0.04568147f, 0.10533332f, -0.17333511f, 
    0.07129122f, -0.01733767f, 0.17654358f, 0.13972349f, -0.06062216f, 0.18746680f, 0.34500846f, 0.10245489f, 
    0.04696205f, -0.34522125f, 0.21031435f, 0.27811044f, -0.19682528f, 0.21077856f, -0.23873553f, -0.16002336f, 
    -0.08431635f, 0.07875665f, 0.61991704f, 0.13915846f, 0.54186964f, -0.04927293f, -0.15874782f, 0.03911798f, 
    0.13089602f, -0.20520665f, 0.08575377f, 0.06544486f, -0.49341705f, -0.15810870f, -0.17546156f, 0.17532834f, 
    -0.20218465f, 0.12495923f, -0.06556571f, 0.04792875f, -0.13672587f, 0.03807072f, 0.03575484f, -0.04885200f, 
    -0.18463646f, 0.18561728f, -0.09456049f, -0.04464434f, -0.20403580f, -0.04637792f, -0.03523461f, 0.09643775f, 
    0.14748044f, 0.07368851f, -0.12791485f, -0.32332519f, 0.45878068f, 0.25343704f, 0.14706935f, -0.03549343f, 
    -0.01451611f, -0.08828062f, -0.23899971f, -0.13175976f, 0.32454768f, -0.08419040f, -0.10095312f, 0.13268287f, 
    0.05819606f, 0.20046449f, 0.05442978f, -0.23331404f, 0.14090228f, 0.10471792f, 0.13233596f, -0.17700765f, 
    -0.22811103f, 0.29767808f, 0.10801534f, 0.21284865f, -0.00869976f, 0.01973174f, 0.26613629f, 0.27226657f, 
    0.06143439f, 0.26507843f, -0.23436753f, 0.18889679f, 0.48223463f, -0.30398446f, -0.29606172f, 0.19661339f, 
    0.09258135f, 0.21361524f, -0.03787024f, -0.22326437f, 0.10663765f, 0.11771739f, -0.12721008f, -0.37739301f, 
    -0.05491984f, 0.27781245f, 0.19087836f, -0.10623252f, 0.02405389f, -0.10004579f, 0.14528839f, 0.06774349f, 
    -0.24966592f, -0.05041378f, 0.23348081f, -0.47435805f, -0.02220685f, -0.05190128f, -0.03404544f, 0.08511250f, 
    0.07877955f, 0.13396922f, 0.29079571f, 0.26028225f, -0.13792066f, -0.25146490f, -0.61073381f, 0.15580368f, 
    0.22102387f, 0.48079398f, 0.19523586f, -0.06908336f, -0.35650757f, -0.04469722f, 0.00023475f, -0.02575317f, 
    -0.12761180f, -0.13825466f, -0.05635601f, -0.12710696f, -0.14330915f, -0.39001322f, 0.05630472f, 0.15340157f, 
    0.16314295f, 0.34200695f, -0.09410005f, 0.10759016f, -0.21040085f, 0.11499628f, 0.18775433f, -0.42669541f, 
    -0.04456283f, -0.12143567f, -0.20389970f, 0.22900201f, 0.04639622f, 0.13016593f, 0.05607993f, -0.22551586f, 
    0.09666446f, 0.10553244f, 0.01227102f, -0.34327662f, -0.14781213f, -0.06239004f, -0.07955978f, 0.06972934f, 
    -0.08201966f, 0.15452184f, 0.20514403f, 0.14523804f, 0.05308420f, -0.10284746f, -0.27342167f, 0.41483232f, 
    -0.00838069f, -0.09811141f, 0.05189917f, -0.13224705f, 0.14108460f, -0.13618305f, -0.16769107f, -0.17101090f, 
    -0.02216577f, -0.12955342f, 0.53769296f, 0.02147389f, 0.07720438f, 0.10350659f, -0.21847761f, -0.31106198f, 
    -0.24137983f, -0.00158442f, -0.16018900f, 0.19373789f, -0.20471017f, 0.12839337f, 0.16434158f, -0.25365928f, 
    0.19981752f, 0.16597338f, -0.18522438f, 0.05944710f, -0.14262444f, 0.22254702f, -0.12813127f, 0.26756275f, 
    0.08084909f, -0.01699710f, 0.10533815f, -0.35821182f, -0.01036581f, -0.00325579f, -0.08419669f, -0.06951380f, 
    0.06708787f, -0.03677996f, 0.24557875f, 0.25279820f, 0.51685423f, 0.18673746f, -0.07515944f, -0.04544295f, 
    -0.10892262f, 0.37774599f, -0.24340357f, -0.16205296f, -0.03903320f, -0.06921673f, -0.11397225f, -0.34176552f, 
    -0.09569953f, 0.15890338f, 0.14528596f, -0.20752864f, 0.03930632f, 0.16548096f, 0.06638265f, -0.01021474f, 
    -0.33641082f, 0.10233480f, -0.26426011f, 0.17757727f, 0.08855574f, 0.30683124f, 0.25865698f, -0.23447917f, 
    -0.06745301f, -0.27256501f, 0.29348886f, 0.24876656f, -0.24446452f, 0.37701184f, -0.18027234f, -0.29935753f, 
    0.23384024f, -0.10061538f, -0.00628900f, -0.19662850f, -0.17310156f, -0.09166988f, -0.06305640f, 0.24656665f, 
    0.00854823f, -0.13013160f, 0.04949435f, 0.06754924f, -0.14643250f, -0.12088042f, 0.21430205f, 0.25440538f, 
    -0.08341499f, 0.19980295f, 0.35309330f, -0.26548263f, 0.03169398f, -0.19055569f, -0.19432038f, -0.04069763f, 
    0.17491511f, -0.21243994f, 0.28425688f, -0.08425269f, -0.08650608f, 0.27050024f, -0.20356688f, 0.18882333f, 
    0.01578828f, -0.07830642f, -0.12431126f, 0.05720116f, -0.17006442f, -0.03156302f, 0.04316932f, -0.10541612f, 
    -0.07583519f, -0.07002763f, -0.17600653f, -0.17384051f, 0.09802664f, -0.13687643f, 0.03733123f, -0.16950050f, 
    -0.15297283f, -0.06520399f, -0.04073143f, 0.01308966f, 0.05549932f, -0.07364757f, 0.10833067f, -0.04058461f, 
    -0.01392736f, -0.08540227f, 0.04514861f, -0.11794069f, -0.01615196f, 0.04924981f, 0.04628423f, -0.09191191f, 
    0.32917610f, -0.12528777f, 0.06277677f, 0.17720988f, 0.58059621f, -0.09268707f, -0.04708020f, 0.16621839f, 
    -0.21864131f, -0.11929089f, 0.07506470f, -0.03697193f, -0.11618179f, -0.08395409f, 0.08599488f, 0.01625193f, 
    0.13255279f, -0.12307833f, -0.17291827f, 0.40391392f, -0.36804458f, 0.13783336f, 0.05875087f, -0.24921177f, 
    0.27314180f, -0.21750806f, -0.31997216f, -0.07767563f, 0.32788455f, 0.00375167f, 0.23951955f, -0.02894716f, 
    0.23186024f, 0.21336162f, -0.10409019f, -0.22187002f, 0.01694653f, -0.04767734f, -0.31525916f, 0.18306127f, 
    0.03225433f, 0.21069524f, 0.15202209f, -0.30272794f, 0.11251608f, -0.01286120f, 0.21917863f, -0.19155280f, 
    -0.20573094f, 0.47219989f, -0.09240734f, 0.14150912f, -0.02098014f, -0.30786592f, 0.25416106f, 0.20325314f, 
    -0.10862558f, -0.11989430f, 0.11231488f, 0.08639415f, -0.25378582f, -0.28841236f, -0.32232714f, 0.12596142f, 
    0.15128797f, 0.39822203f, -0.01666313f, -0.04269608f, 0.10821570f, -0.05043023f, 0.12126885f, -0.15980572f, 
    -0.10093892f, 0.03622353f, 0.03633116f, -0.05306796f, 0.12779826f, -0.24797131f, -0.24266712f, 0.20710413f, 
    -0.18902987f, -0.07393615f, 0.01830514f, 0.08530374f, 0.08984486f, 0.07030380f, -0.40829414f, 0.05032448f, 
    0.16182804f, -0.06296718f, -0.07093155f, 0.26331386f, 0.55532426f, 0.41239682f, -0.52451134f, 0.17613387f, 
    0.25055733f, -0.17939134f, -0.43836951f, -0.41937107f, 0.05826724f, 0.00424940f, 0.01227462f, 0.04770467f, 
    0.07925222f, 0.25813818f, 0.13365379f, 0.19277693f, 0.02307861f, -0.11659154f, -0.05710856f, 0.27933663f, 
    -0.21326391f, 0.29801702f, 0.12647910f, -0.31061718f, 0.10366889f, -0.18774353f, -0.16318999f, 0.12294328f, 
    -0.05114897f, 0.04542951f, 0.40701964f, 0.16221397f, 0.08735907f, 0.10711697f, -0.34497261f, -0.00034719f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.13113637f, 0.24627087f, 0.10804571f, 0.25469562f, 0.14336486f, -0.11794137f, -0.07240985f, 0.14666092f, 
    0.20180283f, 0.19274750f, 0.20347741f, 0.28140384f, 0.13403620f, -0.00447999f, -0.22868904f, 0.03917274f, 
    -0.02356336f, 0.12761652f, -0.12581058f, -0.19752841f, 0.10043687f, 0.27536121f, 0.15698552f, 0.13423435f, 
    -0.09528631f, -0.13520706f, 0.04367919f, -0.02230051f, 0.14417958f, 0.19918525f, 0.00382497f, 0.19152124f, 
    -0.02600118f, -0.10490089f, 0.06734830f, 0.25613368f, 0.10781730f, -0.18604535f, -0.07481720f, 0.24193296f, 
    0.03225538f, 0.04794137f, -0.22039911f, 0.11339272f, -0.06092138f, 0.10338736f, 0.03660471f, -0.06470127f, 
    0.08977658f, -0.06345124f, -0.01587995f, -0.10064270f, 0.09744435f, 0.20268629f, 0.18780467f, -0.13827126f, 
    0.05563165f, -0.08499598f, -0.00476878f, -0.16070092f, -0.05869873f, -0.11192565f, -0.00458275f, -0.12376705f, 
    -0.11295286f, 0.13346197f, 0.14868917f, -0.01930360f, 0.23278086f, 0.01940198f, 0.15382901f, 0.13397425f, 
    0.14910407f, 0.22930151f, -0.15495087f, -0.18981865f, 0.14198193f, 0.26793990f, 0.03233773f, 0.24150349f, 
    0.22213742f, 0.04388945f, 0.26000634f, 0.15772520f, -0.04453711f, -0.15334573f, 0.10136779f, 0.02435159f, 
    0.21485032f, -0.03852006f, -0.09288692f, 0.12153054f, -0.13829774f, 0.13499747f, -0.18277866f, 0.20039394f, 
    -0.11960497f, 0.16980875f, -0.09834547f, 0.07713991f, 0.04975815f, 0.07428068f, -0.00295926f, -0.00161625f, 
    0.16217329f, 0.10208939f, -0.10400729f, -0.04736621f, -0.14441997f, 0.12570773f, 0.08497540f, 0.19444045f, 
    0.28687492f, -0.10565387f, 0.10501818f, 0.06733110f, 0.12365342f, 0.19440997f, 0.08622306f, -0.07954447f, 
    0.10377412f, -0.07825997f, 0.18923017f, 0.13790864f, 0.00082218f, 0.06149858f, 0.22944695f, 0.03556081f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.19988222f, -0.08082184f, -0.53700697f, -0.26262552f, 0.00691370f, -0.07020270f, 0.05815264f, -0.19676250f, 
    -0.60226256f, -0.41412750f, -0.01517053f, -0.00716239f, 0.07980686f, -0.23171161f, 0.17928869f, -0.15280639f, 
    -0.10887002f, 0.21982671f, 0.20344648f, 0.04448483f, -0.01412047f, -0.42771325f, -0.10643090f, -0.06660432f, 
    0.20440432f, 0.28550148f, -0.03704841f, -0.10171992f, -0.03710299f, -0.24860375f, -0.32157609f, -0.01885980f, 
    -0.05540039f, 0.04116305f, 0.01315622f, -0.64946634f, 0.02912132f, -0.09574329f, -0.15619567f, -0.03247029f, 
    -0.30712089f, 0.15354122f, 0.07461617f, 0.02127971f, -0.08273686f, 0.08859704f, -0.01578664f, -0.23633201f, 
    0.07166760f, -0.09003498f, -0.07617587f, -0.07947802f, -0.54765302f, -0.06083483f, -0.82245570f, -0.02357734f, 
    -0.07403038f, -0.26548436f, -0.30895346f, 0.01954593f, 0.07421016f, 0.03145757f, 0.16611841f, -0.01725904f, 
    -0.17597532f, -0.28467596f, 0.15854222f, 0.06234685f, 0.22424394f, 0.07951997f, -0.29414245f, -0.05750477f, 
    -0.58906901f, -0.07021735f, -0.06775770f, -0.03625916f, 0.11191443f, -0.18990600f, -0.00039561f, -0.14591300f, 
    -0.42811424f, -0.01832099f, -0.70255429f, 0.23161976f, -0.10265123f, 0.29992741f, 0.09991695f, -0.39566758f, 
    0.06426837f, 0.02881898f, 0.01714319f, -0.15914930f, -0.09486182f, -0.17257002f, -0.10591535f, -0.11843541f, 
    0.25351760f, 0.08562715f, 0.08680565f, 0.19279458f, -0.09080994f, 0.01330045f, 0.23432463f, -0.09609640f, 
    0.07929465f, -0.08857343f, 0.10258134f, 0.10731512f, 0.00848613f, -0.10215217f, -0.31171533f, 0.01579512f, 
    -0.45881137f, 0.01981639f, -0.52472520f, -0.00808230f, 0.16821456f, -0.00214008f, -0.09502110f, -0.26084611f, 
    -0.42736414f, 0.09813801f, -0.35800761f, 0.05629555f, -0.08749099f, 0.15739474f, -0.09972626f, -0.03721189f, 
    0.11753615f, 0.05506599f, 0.22361247f, 0.13985814f, 0.00540708f, 0.09157422f, 0.04312441f, -0.02355145f, 
    -0.30764246f, -0.13672556f, -0.09186701f, -0.05566462f, 0.04743748f, 0.02084624f, 0.21856216f, 0.24515834f, 
    -0.08649643f, 0.30117637f, 0.38160360f, -0.08187357f, 0.08673429f, 0.09722967f, 0.22347750f, 0.20686103f, 
    -0.04871576f, 0.24557145f, -0.00217067f, 0.30603141f, -0.85363913f, -0.25844327f, -0.29504201f, 0.06769083f, 
    -0.13432524f, 0.04302587f, -0.01354990f, -0.08162688f, -0.02156168f, 0.00297822f, 0.05559855f, -0.36202973f, 
    0.24231425f, 0.25450626f, -0.09533832f, -0.70311505f, -0.05674642f, -0.10040757f, -0.24902588f, -0.07443094f, 
    0.08568346f, 0.11671011f, -0.04587662f, 0.20147891f, -0.60404730f, 0.09219802f, 0.05106635f, -0.13955274f, 
    -0.04975726f, -0.33424520f, 0.11901458f, -0.09436701f, -0.15365741f, -0.08442307f, 0.09760076f, 0.04174329f, 
    -0.02243281f, 0.17712936f, -0.03535920f, -0.16464329f, 0.21690781f, -0.36846459f, 0.06238304f, -0.56020731f, 
    0.15610991f, 0.10310378f, -0.03923055f, -0.05610069f, 0.15155812f, 0.06333964f, 0.00122163f, 0.10427212f, 
    0.12685142f, 0.01675124f, -0.58087981f, 0.11406504f, -0.02055485f, -0.50998056f, 0.13200232f, 0.20340832f, 
    0.04852276f, 0.00306273f, -0.31018671f, -0.23852141f, -0.14750358f, -0.14882979f, 0.01663844f, -0.47959772f, 
    0.23098303f, 0.10982188f, 0.01129017f, 0.12096146f, 0.33298072f, -0.42964792f, -0.20462203f, 0.00338656f, 
    -0.02581672f, 0.02491215f, -0.15940225f, -0.01095978f, -0.03982602f, 0.04319943f, -0.02497750f, 0.05410452f, 
    0.14361885f, 0.06103126f, -0.09617370f, 0.14739588f, 0.01756801f, 0.07705954f, 0.18302760f, -0.06751935f, 
    0.04898454f, 0.29926443f, -0.08769736f, 0.02464633f, 0.33315420f, 0.06681295f, -0.16801260f, -0.15679580f, 
    -0.31906334f, -0.01863601f, -0.52439183f, 0.10772737f, -0.05741965f, -0.04629891f, 0.04807261f, 0.03259986f, 
    0.05687465f, 0.11817902f, 0.01321728f, 0.08686692f, 0.10865223f, -0.11070985f, -0.21407638f, -0.04832716f, 
    0.12494362f, -0.25760442f, -0.21237807f, -0.05822273f, 0.22517791f, 0.11263503f, 0.07771029f, -0.49955362f, 
    0.06012637f, -0.74463689f, -0.10907967f, -0.33076030f, -0.15577284f, -0.32418272f, -0.00638322f, 0.04657697f, 
    -0.24096568f, 0.06131554f, 0.02241655f, 0.23526756f, 0.01618109f, -0.02865442f, -0.07415529f, 0.39146993f, 
    0.20324755f, -0.44022951f, -0.10405520f, -0.13005391f, -0.01635415f, -0.05821191f, -0.06520593f, 0.01412031f, 
    -0.06318727f, -0.20096679f, -0.14671104f, -0.27082068f, 0.16642810f, 0.18898511f, 0.53237838f, -0.08198752f, 
    -0.02082909f, 0.13019885f, 0.03557958f, 0.12456822f, 0.11332372f, 0.03551123f, 0.15205154f, 0.03247552f, 
    0.03723777f, -0.49708134f, -0.19077323f, -0.23393579f, 0.15040417f, 0.06788046f, -0.23969631f, 0.39205307f, 
    0.01614384f, -0.30313611f, 0.00542746f, -0.08735548f, 0.40274590f, 0.19104876f, 0.13213810f, 0.00083135f, 
    0.14883730f, -0.06775239f, 0.18754610f, -0.61361647f, 0.04744820f, -0.20297654f, -0.05472600f, 0.14301617f, 
    -0.21653812f, 0.02092378f, 0.01629403f, 0.05258778f, -0.16503651f, -0.22457036f, -0.12843625f, 0.23868214f, 
    -0.39043057f, -0.06161904f, 0.07995936f, -0.14252880f, 0.08728603f, -0.18168473f, -0.00908139f, 0.16765705f, 
    -0.12450638f, -0.03046904f, 0.00301604f, -0.27362618f, 0.01242378f, -0.16740748f, -0.00946319f, 0.17138594f, 
    -0.03598808f, 0.03920370f, -0.04102691f, 0.05037918f, 0.03977386f, 0.11226568f, 0.13399304f, -0.10562854f, 
    -0.01116677f, -0.43498099f, -0.11922385f, 0.07552695f, -0.24994262f, -0.28133392f, -0.02048570f, -0.04533304f, 
    0.01017354f, 0.00430657f, -0.47108564f, -0.26675355f, 0.05576058f, -0.68180728f, -0.08012269f, -0.27454582f, 
    0.10190886f, 0.08866296f, 0.28152350f, 0.22541860f, -0.37442550f, 0.18218079f, -0.08214830f, -0.20675254f, 
    0.14343445f, 0.06862430f, -0.07557378f, -0.02388532f, -0.38493803f, -0.00994247f, -0.04909816f, -0.30061811f, 
    0.01514573f, -0.10712922f, 0.51408881f, -0.76250041f, 0.08536179f, -0.31669509f, 0.09681973f, -0.47744948f, 
    -0.21021482f, -0.09154022f, 0.02386442f, 0.12001511f, 0.13271831f, -0.12564853f, 0.09950316f, 0.15371683f, 
    0.35492471f, 0.01052014f, 0.10716742f, 0.24107708f, 0.07897315f, 0.09441555f, 0.05425094f, -0.13799666f, 
    0.12850545f, -0.52629495f, 0.09096395f, 0.08958771f, -0.04433336f, -0.23242079f, -0.04989887f, -0.23522818f, 
    0.00664084f, 0.05497486f, -0.59006888f, -0.02311073f, -0.12680846f, -0.11595592f, -0.07125835f, -0.00052866f, 
    -0.77124029f, -0.25431454f, -0.02623277f, 0.53524268f, 0.13619345f, 0.06083644f, -0.50529897f, 0.22416289f, 
    0.01966393f, 0.11338935f, 0.11584861f, 0.08065186f, -0.01258560f, 0.00503098f, 0.13167831f, 0.00683844f, 
    0.04438009f, 0.56276608f, 0.08659764f, -0.10768482f, 0.22692345f, 0.21585901f, 0.00884497f, 0.00760001f, 
    -0.11425488f, -0.26744521f, 0.19384769f, 0.02377069f, 0.00189615f, -0.05912652f, -0.03180679f, 0.27890489f, 
    -0.16452467f, -0.41958478f, -0.04964169f, -0.14322643f, 0.00251642f, -0.01300966f, -0.03307394f, -0.04530273f, 
    0.07577167f, 0.05907489f, 0.17201826f, 0.00198094f, -0.08215444f, -0.65395534f, -0.05169402f, -0.02511889f, 
    -0.01580301f, 0.02366428f, -0.11686404f, -0.56464791f, 0.15277115f, 0.12355331f, -0.10574881f, -0.16799156f, 
    -0.18010564f, -0.30316490f, 0.14990784f, 0.02625617f, -0.39438081f, 0.09260899f, 0.11540461f, 0.07069200f, 
    0.04971424f, -0.31534657f, 0.02753534f, -0.09113542f, 0.04096857f, 0.12969363f, -0.04204874f, 0.16339891f, 
    0.18973814f, -0.03831454f, 0.06460141f, -0.03279210f, 0.08986245f, -0.05015080f, 0.04379367f, -0.54428482f, 
    -0.02564589f, 0.04181926f, 0.13845296f, -0.07324220f, 0.03921498f, -0.13291036f, -0.00035645f, -0.31254175f, 
    0.15030794f, -0.09024084f, -0.25780433f, -0.98698330f, 0.05184565f, 0.05747400f, 0.22025466f, 0.11881413f, 
    0.12992799f, 0.08118406f, 0.00151026f, -0.39616615f, 0.12059434f, -0.13675007f, -0.15032256f, 0.08837876f, 
    -0.29551047f, -0.12888788f, 0.04642379f, 0.11023399f, 0.02852430f, 0.16152659f, -0.29051700f, -0.06804164f, 
    -0.09321995f, -0.00443424f, -0.08937887f, -0.06656884f, 0.08127891f, -0.31843951f, 0.06225270f, 0.05442172f, 
    -0.05769201f, 0.28388992f, 0.09817691f, 0.13084552f, -0.26988438f, -0.14960973f, -0.21035089f, 0.09390341f, 
    0.05446260f, -0.00758036f, 0.04201147f, -0.40173233f, -0.12024065f, 0.15888128f, 0.13333102f, -0.23583375f, 
    -0.20408505f, -0.06861141f, 0.06353553f, 0.06671675f, -0.01442922f, -0.66514474f, -0.21302897f, -0.20334469f, 
    0.11151912f, -0.28437856f, 0.15270038f, 0.14453913f, 0.09334134f, 0.19234109f, 0.01887316f, -0.18881595f, 
    0.00863514f, 0.02605100f, -0.29983449f, 0.03288103f, -0.07877146f, -0.45571536f, -0.07045005f, -0.17915404f, 
    0.17711799f, 0.06270467f, 0.00072937f, -0.04862858f, -0.15872109f, 0.15311298f, -0.00696798f, -0.08351023f, 
    0.01609675f, 0.05370749f, 0.15272982f, 0.04825658f, -0.01232616f, 0.14757219f, 0.03774464f, -0.30554980f, 
    -0.23497772f, 0.00394109f, 0.10170756f, 0.01846273f, 0.11450452f, 0.13782474f, -0.13220115f, -0.09332966f, 
    0.07261080f, 0.13760076f, -0.21395883f, -0.01591817f, -0.12356754f, 0.00161836f, 0.13884224f, -0.04896952f, 
    0.08161865f, 0.01683750f, -0.13867843f, 0.19316833f, -0.07096453f, 0.00166493f, -0.06374800f, -0.10741890f, 
    -0.31743082f, -0.05075648f, -0.23851775f, 0.17341103f, -0.10259140f, -0.13388844f, -0.09919178f, -0.10478569f, 
    -0.02681325f, -0.06413475f, -0.20326352f, -0.00389495f, -0.34206921f, -0.01258959f, -0.06895176f, 0.21026900f, 
    -0.15342487f, -0.15943670f, -0.36375433f, -0.41933995f, 0.03507641f, 0.36976340f, 0.05449831f, -0.01855737f, 
    0.04173134f, 0.07068136f, -0.00108785f, -0.04177610f, 0.02699729f, 0.11905946f, -0.49460027f, 0.18738510f, 
    -0.04115239f, -0.01918702f, 0.07980564f, -0.10750726f, -0.00039194f, 0.12901559f, 0.12521179f, -0.06939925f, 
    -0.02857239f, 0.18385126f, -0.07556616f, 0.04259119f, 0.06832235f, -0.15923272f, -0.11600358f, 0.27434024f, 
    0.00348566f, -0.42328689f, 0.14587376f, 0.07649150f, -0.27974683f, -0.17926688f, 0.07873859f, -0.06356060f, 
    0.21264537f, -0.36985385f, 0.12834127f, -0.42672849f, 0.09282979f, 0.07774101f, 0.08519568f, -0.37594411f, 
    0.15604374f, -0.03082222f, 0.00678096f, 0.06664322f, -0.02351897f, -0.18366992f, 0.02210354f, 0.22381558f, 
    -0.17675203f, -0.34664541f, -0.17865101f, 0.12697156f, 0.04176809f, -0.38456592f, 0.11884183f, 0.06204724f, 
    0.09498008f, 0.04762466f, -0.17808795f, 0.02207392f, 0.03823781f, 0.37683046f, -0.07183995f, -0.05569556f, 
    -0.18486068f, 0.01323699f, 0.08389661f, 0.20787817f, 0.09680176f, -0.61790997f, -0.04426726f, -0.11145480f, 
    0.19009691f, -0.03130491f, -0.21623220f, 0.04250882f, 0.12106447f, -0.21178778f, -0.05318610f, -0.13037801f, 
    -0.09128311f, 0.08685762f, 0.13737676f, 0.10446112f, 0.06450806f, 0.07885358f, -0.31997266f, 0.14532198f, 
    0.24552919f, -0.04123782f, 0.04155710f, 0.03093579f, -0.41919473f, -0.10933781f, 0.20168521f, 0.23745129f, 
    -0.20358154f, -0.14113413f, -0.32814610f, 0.03489099f, 0.01145116f, 0.10344683f, 0.04224313f, 0.30784097f, 
    0.29451808f, 0.09232269f, 0.15325744f, -0.74236196f, 0.10845201f, -0.00247783f, -0.19793761f, 0.39294013f, 
    -0.07699600f, -0.17197630f, -0.01332070f, -0.00235787f, 0.30838391f, 0.18786718f, -0.08934562f, 0.11410011f, 
    0.04895348f, -0.23675108f, -0.18611342f, 0.03840005f, 0.27532125f, -0.14243031f, -0.07960459f, 0.19888245f, 
    0.10768801f, -0.55526245f, 0.04478184f, -0.19554685f, -0.17431216f, 0.04511949f, -0.27539763f, 0.04747473f, 
    -0.26453602f, -0.44497606f, -0.08664663f, -0.25876775f, 0.07116694f, 0.09325726f, -0.00067926f, 0.09413785f, 
    -0.42013460f, 0.10033982f, -0.09511835f, -0.45815057f, 0.19030908f, 0.24969809f, 0.33663952f, -0.27109820f, 
    0.00540790f, 0.08485284f, -0.09267673f, -0.07317497f, 0.08620055f, 0.03768805f, -0.01938110f, 0.00592792f, 
    -0.22915637f, 0.04037150f, -1.00014389f, -0.41751066f, -0.08422623f, 0.10796423f, 0.06326298f, -0.02115195f, 
    0.25941023f, -0.35758418f, -0.05957758f, 0.06770985f, -1.03874874f, 0.14774367f, -0.00516507f, 0.05580086f, 
    0.24431497f, -0.06498268f, 0.23345347f, -0.32813016f, 0.10066538f, -0.29128820f, -0.33856186f, 0.16352803f, 
    -0.13782412f, 0.08621106f, -0.20387834f, 0.06770188f, -0.18930398f, -0.02512682f, -0.07716966f, -0.05298413f, 
    -0.05946657f, 0.09080253f, -0.00508905f, -0.18912064f, -0.25506905f, 0.18842463f, 0.17130062f, -0.01900283f, 
    -0.69072485f, -0.00467580f, -0.02546444f, -0.16928042f, 0.01521387f, 0.15597333f, 0.02154295f, 0.08412769f, 
    0.11653088f, -0.00343279f, 0.18841116f, -0.18891987f, -0.78358674f, -0.57175761f, -0.14981100f, -0.25198534f, 
    -0.01984543f, -0.14982088f, 0.00792807f, -0.07451858f, -0.01195305f, -0.97651505f, -0.40174040f, -0.41313842f, 
    -0.39153087f, -0.29943472f, 0.15081823f, -0.21715729f, -0.05590080f, 0.06040144f, 0.02817120f, -0.49148577f, 
    0.14541952f, 0.05240878f, -0.18926783f, 0.10354520f, 0.00402623f, -0.06297524f, -0.33803964f, -0.12071831f, 
    -0.02226882f, -0.34084013f, 0.05238029f, -0.09899417f, 0.05253032f, -0.06118429f, -0.14935426f, 0.09656870f, 
    0.20384064f, -0.28139538f, -0.14580119f, -0.19520871f, 0.14198703f, -0.06512114f, -0.53914785f, 0.02811345f, 
    0.26621288f, -0.52761281f, -0.03680228f, -0.16755046f, -0.32048386f, 0.19554134f, -0.06881306f, -0.25190219f, 
    0.03545117f, 0.15381473f, 0.20763117f, 0.34179857f, -0.04843491f, -0.05066291f, 0.06441947f, 0.05081857f, 
    -0.28871569f, 0.03630774f, 0.13261139f, 0.13210143f, -0.15779793f, -0.34047335f, -0.40312445f, -0.09405528f, 
    -0.05172020f, 0.13121392f, -0.17809677f, -0.04064957f, 0.12377773f, 0.13624439f, -0.05092542f, -0.02527970f, 
    -0.06094864f, -0.07313406f, -0.31399721f, 0.07204871f, 0.09105614f, 0.10504724f, 0.08598556f, 0.16371070f, 
    -0.19530837f, 0.29428262f, -0.03654882f, -0.08015615f, -0.45405245f, -0.32048365f, -0.06396855f, 0.06191652f, 
    -0.36612663f, 0.01524007f, -0.01468436f, -0.62703794f, 0.14937221f, 0.62831604f, 0.04753449f, -0.07616753f, 
    -0.05831635f, -0.10651522f, -0.29929712f, 0.08836328f, -0.17355795f, -0.16228627f, 0.06136430f, 0.11312164f, 
    -0.09181996f, -0.03709712f, -0.04145203f, -0.21081005f, -0.49364305f, 0.15832938f, 0.07841960f, -0.05952832f, 
    -0.07555725f, -0.10762877f, 0.24950609f, 0.17950737f, -0.08003644f, -0.03899095f, 0.11124945f, -0.20287116f, 
    0.00765242f, -0.02966066f, -0.06841000f, -0.07487811f, -0.05138147f, -0.56652689f, 0.09683169f, -0.09131790f, 
    0.10883986f, -0.26308766f, -0.06273478f, -0.02215601f, -0.15784599f, -0.14811909f, 0.03445772f, -0.60136104f, 
    -0.30997232f, 0.21844780f, 0.17981496f, 0.07433861f, -0.06599183f, -0.16254701f, -0.08396398f, -0.07392577f, 
    0.15815139f, 0.18213832f, 0.11923207f, 0.11113584f, -0.27907041f, 0.09630694f, -0.14736268f, 0.03689570f, 
    0.06169463f, -0.26668563f, -0.25644535f, -0.03593889f, 0.18311806f, 0.13855922f, -0.26240692f, -0.13930424f, 
    -0.24945949f, -0.45964816f, -0.16888665f, 0.01375782f, -0.55579036f, -0.30736393f, -0.33967867f, -0.15202029f, 
    0.20909953f, 0.18721016f, -0.45280662f, 0.26604784f, -0.13235646f, 0.17077079f, -0.13851123f, -0.29397315f, 
    -0.17614937f, 0.18904309f, 0.10868271f, -0.36149803f, -0.00807298f, -0.21629556f, -0.38589877f, 0.25668535f, 
    0.20469059f, -0.04197345f, 0.15425025f, -0.12462931f, -0.00143660f, 0.02900484f, -0.62830049f, 0.13944528f, 
    -0.07715916f, -0.03410745f, 0.19172589f, -0.23060311f, -0.09865393f, 0.21895345f, 0.15214239f, 0.00422636f, 
    -0.17633632f, -0.17995933f, -0.17859395f, -0.02014311f, -0.25259486f, -0.20897460f, -0.07129307f, 0.15621302f, 
    0.18320972f, 0.13840295f, 0.07797175f, -0.06942877f, -0.34173897f, 0.36434337f, 0.22643526f, -0.00803265f, 
    -0.59464741f, -0.20270877f, -0.20607822f, -0.48687017f, 0.10213844f, -0.15401603f, -0.36326858f, 0.14288262f, 
    0.14013246f, -0.13204601f, 0.11931762f, 0.05387781f, -0.04373807f, 0.05982170f, 0.00043246f, -0.47773108f, 
    -0.45811972f, -0.08246604f, -0.03545614f, -0.12830041f, 0.00602253f, -0.39435196f, 0.15093805f, -0.15653248f, 
    0.27584395f, -0.00422313f, -0.37154579f, 0.22385208f, 0.02262205f, -0.17461509f, 0.02735261f, -0.06916622f, 
    0.12322601f, -0.05960388f, -0.08933755f, -0.24182844f, -0.27944872f, -0.50747353f, 0.14417911f, 0.17625618f, 
    -0.05296391f, -0.12907347f, 0.11265193f, 0.02012606f, -0.03647078f, -0.15034710f, -0.10246008f, -0.01440516f, 
    -0.31544596f, 0.03510299f, -0.05738518f, -0.32749009f, -0.02320844f, 0.15068993f, 0.01825840f, 0.16400146f, 
    0.14993981f, 0.10239915f, 0.05160433f, -0.29419866f, 0.04461877f, -0.08721872f, -0.39375195f, 0.09406633f, 
    -0.18385892f, -0.32240319f, -0.24810159f, 0.00067986f, -0.28710592f, -0.07222207f, 0.06233909f, 0.05044816f, 
    -0.02670261f, -0.28264561f, 0.18346772f, 0.08516159f, 0.35972705f, 0.29096559f, 0.17964070f, -0.04195669f, 
    -0.10156245f, -0.19292307f, 0.19378379f, -0.37535846f, -0.06396613f, -0.31478918f, -0.15897588f, 0.24643373f, 
    -0.22240074f, -0.56117427f, 0.00951498f, -0.00010775f, 0.04859174f, 0.05523058f, -0.05224650f, 0.02559020f, 
    0.13795258f, -0.15306316f, 0.09301041f, 0.06969547f, 0.22101457f, 0.14419031f, -0.15757105f, -0.24203567f, 
    -0.04200770f, -0.02771184f, -0.11807568f, -0.03803742f, 0.23711970f, -0.23822108f, -0.39394993f, 0.04735724f, 
    -0.25837019f, 0.27743721f, 0.01587797f, -0.07800432f, -0.03039846f, -0.03375807f, -0.10526075f, -0.17479666f, 
    -0.30097994f, -0.59694308f, -0.03215737f, 0.00976915f, -0.01916249f, 0.14085084f, 0.00334963f, 0.05814788f, 
    0.19867258f, -0.05819749f, 0.21983296f, 0.02851789f, -0.23105943f, -0.09743309f, -0.13703914f, -0.20216094f, 
    0.14527442f, 0.02225966f, -0.19834444f, -0.26648009f, 0.09522147f, -0.32558835f, -0.02491014f, 0.09958158f, 
    -0.47490621f, -0.15791361f, -0.08721147f, -0.16141270f, -0.39141983f, 0.29856664f, -0.11337224f, -0.11701541f, 
    -0.02603619f, 0.02865948f, 0.03945654f, -0.26669252f, 0.01184203f, 0.14535156f, -0.01256519f, 0.18958841f, 
    -0.28955939f, -0.08386531f, 0.04472492f, 0.05177762f, -0.05162209f, 0.04385809f, -0.11662296f, 0.18426593f, 
    -0.15888979f, -0.07564425f, 0.16547579f, -0.03225412f, -0.21552621f, 0.27006301f, -0.31600931f, 0.23208915f, 
    0.15223067f, 0.17753620f, -0.42152816f, -0.06762604f, -0.01116973f, 0.02390628f, 0.03948963f, 0.08816431f, 
    0.00321061f, -0.32066801f, -0.28738484f, -0.19099857f, 0.18846895f, 0.09542213f, -0.28066701f, 0.07408334f, 
    0.18904415f, -0.55900890f, -0.11761359f, -0.08335965f, 0.11484341f, 0.18325119f, -0.07206120f, 0.18654536f, 
    -0.27087948f, 0.05680031f, 0.14845781f, -0.27063897f, -0.33922833f, 0.35396624f, 0.09465281f, -0.10125351f, 
    0.09004631f, 0.09603853f, -0.37208438f, 0.02752995f, -0.18598396f, -0.24059004f, -0.20391384f, -0.66667449f, 
    -0.29103267f, -0.15044165f, -0.37861899f, -0.43605509f, 0.05288727f, 0.09321610f, 0.07008819f, 0.00930723f, 
    0.16134892f, -0.27024516f, 0.06612489f, 0.03749882f, -0.04399133f, -0.05975699f, -0.21552525f, 0.14913993f, 
    -0.07372328f, -0.01120600f, 0.10517416f, 0.20721802f, 0.14871208f, -0.13185187f, -0.17679618f, -0.08125074f, 
    -0.21361873f, -0.50411755f, 0.02745591f, -0.23247392f, -0.63602424f, -0.10246702f, -0.21033488f, -0.00197694f, 
    0.01080677f, 0.25115302f, -0.11255462f, -0.00205860f, 0.03847622f, -0.24509083f, -0.05337021f, -0.09972946f, 
    0.12270702f, 0.08640753f, -0.04985268f, 0.11595980f, -0.44321990f, -0.28590626f, -0.32103935f, -0.39563471f, 
    0.16572665f, 0.02541284f, 0.25055748f, 0.10992288f, -0.13247862f, 0.13255242f, -0.02173638f, -0.43275532f, 
    -0.19349104f, 0.23461749f, 0.01367291f, -0.09473041f, -0.20162183f, -0.14323430f, 0.01268354f, -0.13729978f, 
    0.12813330f, 0.06050593f, -0.29059547f, -0.21046355f, -0.08120629f, -0.34938273f, 0.12169426f, -0.11237500f, 
    0.06771710f, 0.05433899f, -0.03517348f, -0.45368794f, -0.42351604f, 0.00315919f, 0.31093454f, 0.26483348f, 
    -0.00631080f, 0.35895970f, 0.13737833f, -0.04320269f, -0.31395081f, -0.09508333f, 0.35996279f, 0.14950678f, 
    -0.28447062f, 0.10162473f, -0.00967132f, 0.22016156f, -0.05247883f, 0.03749829f, -0.09874371f, 0.13102645f, 
    0.06959954f, 0.05315021f, 0.18095028f, -0.05668697f, -0.18753663f, 0.32574520f, -0.23360758f, -0.16653894f, 
    0.03694753f, -0.37270671f, -0.08970999f, -0.00575673f, 0.07519732f, 0.02070527f, -0.18211856f, 0.06424061f, 
    -0.60039300f, -0.19469713f, 0.22772549f, -0.16658585f, -0.01220614f, 0.12180998f, -0.07078692f, 0.07625427f, 
    -0.08394495f, -0.39306596f, 0.05050054f, 0.31058344f, -0.05630836f, 0.10739669f, -0.20480353f, -0.15169595f, 
    -0.10983706f, -0.13450322f, -0.04399407f, 0.15383407f, 0.07327525f, -0.14784057f, 0.07230999f, -0.16836949f, 
    -0.45097876f, 0.11978452f, -0.23908526f, 0.13391021f, 0.04913916f, 0.01680714f, -0.18052724f, 0.31596342f, 
    -0.01433162f, 0.33002532f, 0.14815630f, 0.17281581f, -0.23856258f, -0.02845288f, -0.26560080f, -0.00759707f, 
    -0.16040285f, 0.03370006f, 0.21920349f, 0.32021999f, -0.26806059f, -0.22066316f, 0.12467635f, -0.24144757f, 
    -0.21828452f, -0.14320266f, -0.02267089f, 0.05736726f, -0.19400910f, 0.06418447f, -0.19740508f, -0.03845538f, 
    0.15726528f, -0.27720770f, 0.17186564f, -0.23813827f, -0.14134373f, -0.46158084f, -0.37736028f, -0.09820142f, 
    -0.44328591f, -0.16399290f, 0.50652117f, 0.14815083f, 0.07180254f, -0.12136886f, -0.17722405f, 0.27402994f, 
    -0.16788864f, -0.08307276f, -0.06818499f, -0.17293938f, -0.12567481f, 0.05308704f, -0.05218878f, -0.20464353f, 
    0.04070048f, -0.03098305f, -0.20218223f, -0.05616964f, -0.07617310f, 0.01846313f, 0.06341445f, -0.08854795f, 
    0.06296293f, -0.01672159f, 0.05056519f, -0.08920923f, 0.11521449f, -0.25547090f, 0.17905344f, -0.18676412f, 
    -0.11876319f, -0.50738156f, -0.15935899f, 0.04014186f, 0.24724382f, -0.12970908f, 0.06562003f, -0.25217775f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.21847545f, -0.00664102f, 0.09675466f, 0.07401270f, -0.00261943f, 0.10331604f, -0.05268450f, -0.08004672f, 
    0.09521101f, 0.04681576f, 0.11542966f, -0.00690761f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
