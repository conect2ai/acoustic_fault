#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.36368564f, 0.08824258f, -0.96839678f, -0.79274547f, -0.05813287f, -0.38533500f, -0.85965568f, -0.73370165f, 
    -0.45206243f, -0.14632221f, -0.30919379f, 0.23302564f, 0.23379071f, 0.10456488f, -0.40066969f, -0.36111426f, 
    0.07700264f, -0.08075543f, -0.15852197f, 0.44247803f, 0.08106396f, 0.24379627f, 0.23531307f, 0.22654445f, 
    0.23798229f, 0.40369174f, -0.10398056f, -0.38681501f, -0.00829192f, 0.68763208f, -0.00750896f, -0.73198438f, 
    0.69097650f, 0.80062747f, 0.08636761f, -0.46307251f, 0.07210416f, 0.13940945f, 0.11073945f, -0.44289994f, 
    0.24797137f, -0.20362604f, -0.28679439f, -0.11108762f, 0.03672048f, -0.62486589f, -0.16654696f, -0.14886034f, 
    0.32181841f, -0.02957512f, 0.95593554f, 1.35450053f, -0.23931246f, -0.67350847f, -0.58751011f, 0.53968602f, 
    0.06405054f, -0.49904770f, -0.00253662f, -0.46006814f, 0.38923603f, 0.52076709f, 0.00257554f, 0.64118677f, 
    -0.56339878f, 0.13604665f, -0.34461591f, 0.02356704f, 0.14373906f, -0.33685845f, -0.20674272f, -0.13605544f, 
    -0.00189040f, -0.05504224f, 0.36548653f, -1.59927201f, -0.37703320f, 0.71407151f, 0.06671289f, 0.41491109f, 
    1.18800652f, 0.87069124f, 0.04432804f, 0.19347641f, -0.23659582f, -0.33954263f, -0.38225621f, 0.03653713f, 
    -0.35674700f, 0.18263523f, -0.02087073f, 0.08269070f, -0.17874284f, -0.00649208f, 0.02694690f, 0.04216312f, 
    0.01071517f, -0.09198333f, -0.07634374f, -0.09987538f, 1.05735517f, 1.12843204f, 0.83940357f, 0.26833019f, 
    0.81142646f, -0.46465147f, -0.07167214f, -0.35322124f, -0.22757810f, 0.13141461f, -0.20382725f, -0.03872484f, 
    -0.06707281f, -0.26776513f, 0.06176257f, -0.35039380f, 0.18714359f, 0.09630356f, -0.52837855f, -0.05895279f, 
    0.02114209f, 0.34584954f, 0.38338315f, 0.36307320f, 0.25187629f, 0.44649634f, -1.06859756f, -0.17880943f, 
    0.98217869f, 0.49676710f, -1.00188017f, 0.27604696f, 0.18284093f, -1.01910889f, -0.09588485f, 0.08915222f, 
    0.44844228f, 0.22466800f, 0.47882685f, -0.12171625f, -0.19757223f, 0.28360087f, 0.16974735f, -0.00014788f, 
    -0.54746854f, -0.14452632f, -0.08136239f, -0.06197632f, -0.10890549f, 0.08052018f, -1.07814872f, 1.07354903f, 
    -0.38063851f, -0.58494335f, 0.92321247f, 0.44188717f, -0.32528278f, -0.90718633f, 0.72118586f, -0.27228540f, 
    -0.22752854f, 0.04816911f, -0.81282610f, 0.28093198f, -0.08818807f, -0.30967620f, -0.00958157f, 0.12250777f, 
    -0.10558912f, 0.16612776f, -0.00668474f, 0.05858148f, -0.14780274f, 0.08717643f, -0.22074263f, 0.47204101f, 
    0.88149571f, 0.53042638f, -0.22797729f, 0.85316217f, 0.07958595f, 0.10670397f, 0.61444592f, 0.35086972f, 
    -0.08259438f, -0.15813054f, 0.44298267f, 0.20497614f, -0.08644139f, -0.05097536f, 0.53246307f, 0.23285103f, 
    -0.06047979f, 0.15093365f, 0.30433235f, 0.39563477f, 0.01885159f, 0.24659644f, -0.07471305f, 0.56701678f, 
    0.53121418f, 1.19648659f, 0.82015187f, 0.67542815f, -0.61106223f, -1.12501502f, 0.27818906f, -0.63432807f, 
    -0.23227604f, -0.01192365f, 0.23847473f, -0.18809576f, -0.34934500f, 0.25683963f, -0.05481435f, -0.21245353f, 
    0.14650951f, 0.27700117f, -0.14550738f, -0.14153588f, -0.29863769f, 0.16759241f, 0.17112206f, -0.17526484f, 
    0.17726351f, 0.55356723f, -0.33264038f, -1.04597545f, -0.28071678f, 0.87669283f, 1.20277524f, 0.39345211f, 
    -0.16857748f, 0.55965996f, 0.22316432f, -0.34810567f, 0.32783693f, 0.26388144f, -0.08186146f, -0.17410401f, 
    -0.21709806f, -0.28141969f, 0.43092823f, 0.02349493f, -0.38957688f, 0.09376367f, -0.09428784f, -0.02471387f, 
    -0.23409437f, 0.04485736f, -0.42666855f, 0.64219272f, -0.14307599f, 1.04634929f, 0.76170433f, -0.14044096f, 
    0.75690174f, 0.78024971f, -0.33023044f, 0.62735188f, -0.66384476f, -0.07955996f, -0.02971682f, -0.17866701f, 
    0.44930387f, -0.08535971f, -0.09071632f, 0.02063873f, 0.24509642f, 0.23915826f, 0.60182339f, 0.03663307f, 
    -0.16310941f, 0.43848842f, -0.00488915f, -0.81548339f, 0.37719384f, -0.39500138f, -1.04312932f, -0.95279944f, 
    0.63486671f, 0.09853823f, -0.32491598f, -0.16114543f, -0.24812463f, -0.07350659f, 0.43503654f, 0.05674671f, 
    0.16767310f, 0.33064315f, 0.21385640f, 0.44989780f, 0.50106800f, 0.22451854f, 0.13227272f, 0.31578609f, 
    -0.27225265f, -0.26237437f, -0.16764930f, 0.05975351f, -1.01818311f, -0.19236238f, -0.10791073f, 0.15446317f, 
    -0.56904644f, 0.02279753f, -0.11499321f, -0.36873910f, 0.26640090f, 0.95236194f, -0.14515796f, 0.38860491f, 
    -0.66521406f, 0.30479524f, -0.66206944f, -0.43306497f, 0.22702710f, -0.48043433f, 0.08358112f, -0.40473434f, 
    -0.02497465f, 0.23058315f, -0.29066664f, 0.26416418f, -0.08311340f, -1.25823593f, -1.49518251f, -0.36283827f, 
    0.24980819f, 0.16111964f, 0.07009294f, 0.27087003f, 0.50364953f, -0.17332809f, -0.42527714f, 0.08806371f, 
    0.37772155f, 0.38913459f, 0.14106239f, 0.51491833f, -0.33757830f, 0.41196510f, -0.10487335f, 0.12177176f, 
    0.23114720f, 0.30146438f, 0.07246127f, -0.37897226f, -0.15978260f, 0.16228417f, 0.83876336f, 0.42451507f, 
    -0.25877246f, 1.29491460f, 0.05082900f, -0.67781621f, -0.49698028f, -0.82907927f, -0.39932728f, 0.31168872f, 
    -0.12872833f, 0.49687907f, -0.07691607f, -0.03574695f, -0.07503284f, -0.29353040f, -0.51682645f, -0.18710133f, 
    0.04840671f, -0.08077643f, 0.06609371f, 0.47863585f, 0.26050869f, 0.00049184f, -0.04762190f, 0.37906161f, 
    -0.64144480f, 0.95493621f, 0.66666096f, -0.61942273f, -0.79851735f, -0.22341669f, 0.04781200f, 0.23147936f, 
    -0.40868512f, -0.08506577f, 0.12550130f, -0.27650806f, -0.69456029f, -0.56520271f, -0.42940125f, -0.16784185f, 
    -0.25549507f, -0.13345590f, 0.06090569f, 0.24603444f, -0.13909014f, -0.15882075f, -0.15764439f, -0.21310960f, 
    -0.05179181f, -0.02758940f, 0.10228574f, 0.73632950f, -0.64277661f, -0.87399715f, -0.97547638f, -0.59324926f, 
    -0.09658804f, 0.04773652f, 0.38153452f, -0.17147802f, 0.53001666f, 0.38015214f, -0.61357605f, 0.27688310f, 
    -0.25892848f, -0.25161052f, 0.34832156f, 0.45353067f, -0.14370061f, 0.33431217f, 0.26810741f, -0.08867479f, 
    -0.13190582f, -0.80099505f, 0.93153363f, -0.15757401f, 0.38194826f, -0.64226794f, 0.64661795f, 0.70137554f, 
    -0.98367476f, 0.08211248f, -0.19052374f, 0.13521519f, -0.30549413f, 0.52777654f, -0.31545380f, -0.36259878f, 
    -0.47189498f, -0.21312644f, 0.33356029f, -0.42603406f, -0.30639881f, 0.09457418f, -0.36752528f, -0.13583770f, 
    -0.14083095f, -0.08271316f, 0.98989528f, -0.29523346f, 0.71355540f, 0.88493526f, 1.14967227f, 0.39320257f, 
    0.06487969f, 0.33099443f, -0.29153138f, -0.56616652f, 0.20927025f, -0.20410530f, -0.21119860f, 0.09269219f, 
    -0.29811594f, -0.14586100f, 0.14955485f, 0.37888008f, 0.36311534f, -0.18772395f, 0.45096004f, 0.70388311f, 
    0.29768416f, -0.09312076f, 0.24190365f, 1.52423573f, -0.42534420f, 0.32865322f, -0.72814441f, -0.14835559f, 
    0.43870568f, -0.51585281f, 0.27451813f, 0.46752799f, 0.26580432f, -0.36322442f, 0.20472743f, -0.58594072f, 
    0.29414126f, -0.29919723f, 0.54248023f, -0.03747382f, 0.37639964f, 0.28028277f, 0.25448701f, -0.23980930f, 
    0.33008552f, 0.07997882f, -0.27783436f, 0.08758500f, 0.02754424f, -0.55825198f, -0.73054749f, -0.58427632f, 
    -0.45557988f, -1.22651291f, 0.28430533f, 1.14190257f, -0.31585011f, 0.52299142f, 0.25891784f, 0.26075298f, 
    0.63340682f, -0.51038384f, 0.11853687f, -0.14552462f, -0.18211593f, -0.10796901f, -0.23557159f, -0.49399608f, 
    -0.04060299f, -0.01304905f, 0.19235939f, 0.21414436f, 0.32568491f, -0.98387015f, 0.65869713f, 1.15740728f, 
    -0.84285897f, -0.82018548f, -0.47040048f, 0.25031897f, 0.10548590f, -0.11268634f, -0.57365578f, -0.08747005f, 
    0.19486283f, -0.61699504f, -0.29334608f, 0.15255237f, -0.20373420f, -0.11440106f, -0.01053566f, -0.11893790f, 
    -0.31223112f, -0.03734117f, 0.33992770f, 0.34843603f, 0.34500605f, -0.00726122f, 0.47739857f, 0.93092036f, 
    -0.06433961f, 0.29211029f, -0.06853475f, 0.47354797f, -0.03608065f, 0.87594134f, 0.47757491f, 0.98606068f, 
    -0.47768947f, 0.42085651f, 0.17995289f, -0.30113390f, 0.06484252f, 0.33649319f, -0.06186755f, -0.33113816f, 
    -0.36196488f, 0.46057588f, -0.06319965f, -0.22410505f, -0.02871498f, -0.15567176f, -0.04856214f, -0.64197141f, 
    -1.14198065f, -0.90975904f, -0.68490219f, -0.19067138f, 0.02128825f, 0.85005790f, 0.68203765f, -0.19295391f, 
    0.71728909f, -0.20970120f, -0.11110020f, -0.23949338f, -0.32170460f, -0.07017507f, -0.04088950f, 0.27022249f, 
    -0.03784328f, -0.08038203f, -0.19887155f, -0.21906705f, -0.36803919f, 0.15176809f, 0.16765530f, 0.46431884f, 
    -0.30872804f, -0.85481477f, -0.68143266f, -0.03464071f, -0.61111903f, -0.10454704f, 1.02607238f, -0.32622424f, 
    0.47902557f, 0.70453852f, 0.14547169f, 0.01046888f, -0.43413562f, 0.05445256f, 0.16737254f, -0.07490200f, 
    0.12673247f, 0.00256366f, 0.26962301f, -0.00456776f, 0.30685997f, 0.31686196f, -0.07685713f, 0.05544005f, 
    -0.16641654f, 1.19677591f, 0.39231354f, 0.43289971f, 0.58988249f, 0.12265053f, 0.15176558f, 0.16866705f, 
    0.23274411f, 0.51526016f, 0.47522846f, -0.13631439f, 0.19635530f, -0.04522735f, -0.06825340f, 0.26918709f, 
    -0.15097483f, -0.22102299f, -0.32906437f, -0.30307743f, 0.53628230f, 0.15987512f, -0.62387192f, 0.66856235f, 
    -0.12562497f, -0.21328422f, 1.45106137f, 0.82628626f, 0.18449762f, 1.07523358f, 1.11696565f, 0.73783064f, 
    -0.10108089f, -0.45729947f, -0.11484860f, -0.14486811f, 0.05948881f, -0.01957690f, -0.10791551f, 0.07336435f, 
    0.02934970f, 0.25817609f, 0.00277019f, 0.25702456f, 0.04926896f, 0.34058309f, 0.13525677f, -0.21811825f, 
    -0.16540645f, -0.30143565f, -0.02763741f, 1.06621838f, -0.29671443f, -0.32443082f, 0.78575665f, 0.51381403f, 
    -0.66517115f, -0.00240979f, -0.18056789f, 0.66967160f, -0.54496962f, -0.40347433f, -0.39061600f, -0.54724950f, 
    -0.33713999f, -0.53815389f, 0.60828328f, -0.21032333f, -0.46880066f, -0.12519537f, -0.02461833f, 0.25324583f, 
    0.00125424f, 0.19740142f, -0.03102620f, 0.17579487f, -0.29020396f, -0.66011977f, -0.71402472f, -1.12109935f, 
    -0.54774153f, -0.35641438f, -0.10196897f, -0.15054810f, 0.22023481f, -0.64125252f, -0.08596996f, -0.45128220f, 
    0.28906697f, 0.08262258f, -0.05108332f, 0.28891006f, -0.17307454f, -0.31764263f, 0.25681999f, 0.46725178f, 
    -0.13633843f, 0.22037874f, 0.18990205f, -0.38468033f, -0.28309202f, -0.14784908f, -0.45120007f, -0.00629873f, 
    0.14059764f, 1.16010678f, 1.18803787f, -0.09135804f, -0.94757718f, -0.30614069f, -0.29854527f, -0.12408662f, 
    0.71244252f, 0.13509554f, 0.19340740f, 0.37328711f, 0.05273465f, -0.33249018f, 0.23853140f, -0.19745560f, 
    0.20075943f, 0.05695540f, -0.03955531f, 0.16891634f, -0.02268128f, 0.08358508f, -1.13214433f, 1.13922274f, 
    0.79429555f, 0.45227519f, 0.73416454f, -0.01442773f, -0.04023578f, 0.28177813f, 0.83102661f, -0.14888549f, 
    -0.31996316f, -0.46050563f, -0.00066585f, 0.00363712f, -0.01546411f, 0.10685080f, 0.06094554f, 0.24309513f, 
    0.02941396f, -0.10072094f, -0.34719825f, -0.22838233f, -0.31172329f, -0.01106875f, 0.01672728f, -0.89452887f, 
    0.18976146f, 0.82608682f, 0.65693557f, -0.39785910f, -0.25169075f, 0.61013657f, -0.13505009f, 0.41517752f, 
    0.37294796f, -0.12952781f, 0.20342736f, 0.63497472f, -0.15286744f, -0.16226350f, 0.11006998f, -0.11683487f, 
    0.19873898f, -0.20769383f, -0.40064183f, -0.10550591f, 0.20193768f, -0.22971769f, 0.19343112f, -0.59928638f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.48735118f, 0.20214555f, 0.29763567f, 0.21185845f, 0.15881881f, -0.02549739f, 0.08799410f, 0.39261627f, 
    0.26731572f, 0.17387326f, 0.29769593f, 0.56075549f, 0.29252535f, 0.41639125f, 0.17658441f, 0.15268143f, 
    0.28868592f, 0.10429543f, 0.08832406f, -0.09360204f, 0.10910300f, 0.13080388f, 0.16574870f, 0.16437703f, 
    0.15026984f, 0.33456326f, 0.07554859f, 0.03634700f, 0.10952315f, 0.42145643f, 0.21375972f, 0.07569733f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.13444817f, -0.36428872f, 0.15089571f, -0.09343617f, -0.03607614f, -0.02443969f, 0.15796833f, 0.01631459f, 
    -0.07442432f, -0.06557100f, -0.07920632f, -0.03869247f, 0.39462277f, 0.02128633f, 0.01294484f, 0.01523739f, 
    0.03204003f, 0.05975368f, -0.15877074f, 0.02368624f, -0.00273900f, -0.11448398f, 0.09526426f, -0.00858742f, 
    -0.32667601f, 0.21115157f, 0.11639973f, -0.62730783f, -0.23144253f, 0.13985363f, -0.00621607f, 0.05684312f, 
    0.00920509f, 0.14075589f, -0.11626078f, 0.10170270f, 0.12191200f, 0.02458654f, 0.44989544f, 0.11970039f, 
    -0.07002732f, -0.00556318f, 0.06740510f, 0.07918365f, -0.04499920f, -0.07351653f, 0.05967145f, -0.01136384f, 
    0.25637069f, 0.10587087f, 0.02292689f, -0.17726508f, -0.22500701f, -0.18761931f, -0.02427105f, 0.11834999f, 
    -0.10115647f, -0.03016619f, -0.05124897f, -0.12244748f, 0.18950537f, -0.05884797f, -0.08424202f, 0.25489172f, 
    -0.27171555f, -0.09176303f, -0.04497269f, -0.01053058f, -0.02421304f, 0.17365064f, 0.00829966f, 0.03311156f, 
    -0.26370698f, -0.04258049f, 0.31250250f, -0.18918981f, -0.01449402f, 0.01100114f, 0.18892501f, -0.09183736f, 
    -0.00581204f, -0.04512660f, -0.06524494f, 0.06935263f, -0.12022440f, -0.03490749f, -0.00316328f, -0.33456585f, 
    -0.12756109f, -0.04772814f, -0.03160123f, 0.07892618f, 0.09503026f, 0.01344983f, 0.16812088f, -0.05941248f, 
    0.04133678f, 0.03150699f, -0.23236392f, 0.04350187f, -0.22149645f, -0.10482793f, -0.08755146f, -0.06483047f, 
    -0.13346998f, 0.03253814f, -0.11045795f, -0.16188730f, 0.24617215f, 0.04384954f, 0.03841417f, -0.05067619f, 
    -0.10911568f, 0.03005888f, 0.15302499f, -0.10655236f, -0.08182907f, 0.04400267f, -0.04717061f, -0.10392264f, 
    0.06265266f, 0.09241538f, 0.11162692f, 0.12469878f, -0.03851373f, 0.05350581f, -0.06520922f, -0.03705138f, 
    0.07155543f, -0.07077092f, -0.11176784f, 0.06736911f, 0.24027094f, 0.11701147f, 0.11674540f, -0.43034443f, 
    -0.06144841f, -0.02656775f, 0.02749288f, 0.02859439f, -0.03835823f, -0.13209452f, -0.02808655f, -0.01994759f, 
    0.23772265f, -0.02659885f, -0.47511113f, -0.07448174f, -0.10001811f, -0.05097166f, -0.09315914f, 0.00638954f, 
    -0.13455082f, -0.01803810f, -0.14103839f, -0.15412830f, -0.50831336f, 0.17804199f, -0.02525520f, -0.04221650f, 
    0.24386366f, -0.03407410f, -0.19056761f, 0.19743216f, 0.08705866f, -0.17435794f, 0.01052875f, -0.05955302f, 
    0.22291037f, -0.02068664f, 0.03600741f, 0.16465439f, -0.06995566f, 0.15685248f, -0.19501926f, -0.00428712f, 
    -0.00197334f, 0.01652366f, -0.00356889f, 0.11566619f, 0.27305660f, -0.19121343f, -0.11295698f, 0.34670374f, 
    -0.05891330f, -0.13669203f, 0.17612037f, -0.32604274f, 0.00386022f, -0.02741124f, -0.11928118f, -0.01429364f, 
    -0.06259228f, -0.04230292f, -0.10624639f, 0.13442615f, -0.09221965f, -0.02393418f, -0.00661292f, 0.18840857f, 
    0.03514814f, -0.18630688f, 0.00569434f, 0.05676541f, 0.50549406f, 0.07399967f, -0.03120873f, -0.09447844f, 
    -0.16159722f, -0.03732597f, 0.08790492f, -0.19352116f, -0.04567434f, 0.12289643f, 0.03848282f, 0.05878704f, 
    0.41934687f, -0.01655210f, -0.11526031f, 0.14170977f, -0.06639036f, 0.02375821f, -0.03259528f, -0.06822998f, 
    -0.16901942f, 0.08208293f, -0.13305852f, -0.10425340f, 0.46455717f, -0.26146960f, 0.26045135f, -0.31883740f, 
    0.05312423f, 0.04907859f, -0.06682583f, 0.06622931f, -0.18482271f, 0.09143010f, -0.06062689f, 0.06319097f, 
    -0.83643544f, 0.04169374f, -0.20222969f, -0.25079808f, 0.00575725f, -0.09652527f, -0.06220873f, -0.00716218f, 
    0.09599855f, 0.00748112f, 0.14101611f, 0.07009966f, -0.54385734f, 0.14339459f, 0.09887616f, 0.24937457f, 
    0.10221375f, 0.13606153f, -0.23535356f, -0.02801203f, 0.09226573f, 0.10244120f, 0.02265319f, -0.07998127f, 
    0.10852668f, -0.07782570f, -0.21584620f, 0.05920742f, -0.01167903f, 0.06446031f, 0.12995486f, -0.04279604f, 
    -0.03594929f, 0.04503867f, 0.04238291f, 0.05203608f, 0.06265733f, 0.36051628f, 0.08081850f, -0.65954113f, 
    0.12342640f, -0.02471513f, -0.18395078f, 0.03789286f, 0.06979448f, 0.02266813f, -0.14660491f, 0.08470993f, 
    0.20780396f, 0.01257828f, -0.04179721f, -0.28447637f, 0.08143280f, 0.07374104f, 0.04786723f, 0.03901287f, 
    -0.01261861f, 0.03790829f, 0.08677435f, 0.06624951f, 0.19908795f, -0.18435848f, -0.33033237f, 0.25002930f, 
    -0.11492727f, -0.00814039f, -0.01052361f, 0.02628925f, -0.04703715f, -0.09849957f, 0.04123941f, -0.07922516f, 
    0.30398059f, -0.07393440f, 0.05137530f, 0.20663138f, -0.38209903f, 0.05186527f, 0.05804512f, 0.17265293f, 
    0.13304617f, 0.06221705f, 0.03715791f, -0.03029356f, 0.10808488f, 0.02970310f, -0.21064942f, 0.42566341f, 
    0.01949388f, 0.07005800f, 0.02625172f, 0.09973817f, 0.04677559f, -0.09628467f, 0.21329379f, -0.15626469f, 
    -0.27641502f, -0.39737380f, 0.10038302f, -0.38137883f, -0.05097044f, -0.07577030f, 0.14927703f, -0.02905913f, 
    -0.05094432f, -0.09950875f, -0.00542730f, -0.00324150f, -0.28816366f, -0.23269132f, 0.31191069f, -0.07942279f, 
    0.10978784f, -0.11287881f, 0.05141652f, -0.22708152f, 0.01523441f, 0.00883529f, 0.02633688f, -0.09247480f, 
    -0.21113510f, 0.09343356f, 0.07096811f, 0.06509358f, -0.43128839f, -0.12215246f, 0.06462046f, -0.01530283f, 
    0.04262697f, -0.00924431f, -0.11677171f, 0.09736408f, 0.20522901f, 0.13719466f, -0.15246245f, 0.33923864f, 
    -0.18385233f, 0.12046904f, 0.09013408f, 0.02929158f, 0.02181022f, 0.01277501f, -0.03238011f, -0.13623114f, 
    0.07233598f, -0.26192531f, 0.00400229f, -0.60955364f, 0.10371727f, -0.03108055f, 0.07745159f, -0.03504283f, 
    -0.14379020f, 0.07752665f, 0.28557479f, -0.03160550f, -0.02192729f, -0.08323445f, 0.08889204f, -0.03361262f, 
    0.00262117f, 0.01548781f, 0.02518632f, -0.01845087f, 0.02095031f, -0.04662749f, -0.05751510f, 0.01404451f, 
    0.22133487f, -0.08044837f, 0.12610509f, 0.03148365f, -0.04362307f, -0.09400291f, -0.03190646f, 0.04432813f, 
    -0.16278256f, 0.09724206f, -0.00378637f, 0.02314681f, -0.26708657f, 0.18118508f, -0.16319941f, -0.00768118f, 
    -0.04970734f, 0.04643721f, -0.01164758f, -0.14082322f, 0.00948699f, 0.40058655f, -0.15631767f, -0.06294208f, 
    0.21176861f, -0.02967815f, 0.14235580f, 0.16270401f, -0.06380048f, 0.06379729f, 0.19577269f, 0.00975646f, 
    0.02892447f, 0.04364275f, -0.01551853f, 0.02531404f, -0.31895965f, -0.39270049f, -0.02609280f, 0.28653947f, 
    -0.05444911f, -0.00152827f, -0.10831992f, 0.14269741f, 0.09418501f, -0.14622197f, 0.00646738f, -0.09911361f, 
    -0.15948392f, 0.01575430f, -0.38149887f, -0.33284247f, 0.01753777f, -0.10020236f, 0.01412078f, -0.02496966f, 
    0.06832696f, 0.04315047f, -0.07518922f, -0.13885565f, 0.16615163f, 0.15951324f, -0.02441881f, 0.18548386f, 
    -0.07023882f, -0.09366603f, 0.00854302f, 0.06525825f, -0.05572310f, -0.04180239f, -0.08668539f, 0.04876848f, 
    0.24357620f, 0.00615594f, -0.24761008f, -0.05460512f, -0.09550168f, 0.01195945f, 0.13463378f, 0.06733815f, 
    0.14685492f, -0.15125574f, 0.14448203f, 0.12327638f, 0.17963535f, -0.26204288f, 0.03354269f, -0.06923635f, 
    0.14310990f, -0.09519690f, -0.31916553f, 0.05241096f, -0.12216061f, -0.09694216f, -0.07753582f, 0.06782845f, 
    0.24397951f, 0.10611537f, -0.04970608f, 0.31002799f, 0.01700621f, 0.00131487f, -0.07759088f, -0.05651677f, 
    0.05589654f, 0.14268631f, 0.03511194f, 0.16052683f, -0.29721859f, -0.06958941f, 0.01574392f, -0.10698424f, 
    0.09346495f, 0.20324442f, 0.18076660f, -0.02402648f, 0.10443996f, 0.21027271f, 0.02221472f, -0.04489017f, 
    -0.28542155f, 0.06336495f, -0.07557333f, 0.04562013f, 0.12765422f, -0.00135445f, 0.07995662f, 0.18191029f, 
    0.05114706f, -0.11360286f, -0.09689070f, -0.10767187f, 0.32858881f, 0.17284976f, -0.12205426f, 0.21035917f, 
    -0.13887669f, -0.08407573f, 0.08199527f, -0.00967759f, -0.15402284f, 0.00101230f, 0.05093853f, 0.07832435f, 
    0.17211114f, -0.27838916f, 0.06018739f, 0.14915368f, 0.13002351f, -0.12227847f, 0.25044644f, 0.06518754f, 
    -0.02492939f, 0.10030705f, -0.20434253f, -0.00260889f, -0.37768924f, 0.08422814f, -0.29262438f, 0.02695337f, 
    -0.01273267f, -0.12146649f, -0.03246063f, -0.07586032f, -0.06357785f, -0.17012164f, -0.13789728f, -0.27842721f, 
    -0.48154163f, -0.18440916f, -0.16942792f, -0.05025600f, 0.19896315f, -0.04431346f, 0.08016135f, 0.16574469f, 
    -0.17629291f, 0.12123652f, 0.04891871f, 0.19632828f, -0.47726515f, -0.37686267f, 0.02699644f, 0.12416492f, 
    -0.01159729f, 0.08957954f, 0.10458910f, -0.03495888f, -0.12864715f, -0.26707521f, 0.10479137f, -0.11995003f, 
    -0.16784790f, -0.10695414f, 0.23693098f, 0.27025303f, -0.17391697f, 0.02417741f, -0.07559355f, 0.01741742f, 
    0.10028075f, 0.04007028f, 0.14547014f, 0.06171707f, 0.42530525f, -0.22215562f, 0.01615620f, -0.20380986f, 
    0.21918403f, -0.09747955f, 0.02627510f, -0.07059645f, -0.00052744f, -0.08810886f, 0.18163057f, -0.10305098f, 
    0.37210166f, -0.24254228f, -0.03115809f, -0.16807593f, 0.09689252f, 0.00324885f, -0.11202285f, 0.25057653f, 
    -0.01139605f, -0.18074836f, -0.07336065f, -0.14588632f, -0.69410306f, 0.07158355f, -0.41202706f, -0.40453410f, 
    -0.03078841f, 0.01999764f, 0.07798658f, 0.08453742f, 0.06509400f, -0.01199810f, -0.10767977f, 0.00956520f, 
    0.06457651f, 0.10083865f, 0.09030814f, 0.01126507f, 0.09314772f, -0.07699783f, -0.06627331f, -0.00065848f, 
    0.05085523f, 0.01702741f, 0.13987295f, -0.10929092f, 0.40103263f, -0.20585442f, -0.00150141f, -0.22614808f, 
    -0.04382801f, -0.04122857f, -0.09283732f, 0.04663113f, -0.03633932f, -0.04161733f, 0.07414166f, -0.00535777f, 
    0.26282319f, -0.15798441f, -0.38281727f, -0.12121952f, 0.05714402f, -0.14358462f, 0.03696227f, -0.01749335f, 
    0.06985511f, 0.21056630f, -0.22363581f, 0.05278472f, 0.23621215f, 0.21072511f, 0.26092198f, 0.23541713f, 
    -0.33125591f, -0.16189408f, 0.14368658f, 0.04195667f, -0.14174290f, 0.14090197f, -0.04930330f, 0.16697975f, 
    0.16365339f, -0.22619192f, 0.14308661f, 0.22293918f, -0.19685094f, -0.07565852f, -0.12603183f, -0.07300203f, 
    -0.06278719f, 0.05314179f, -0.16034655f, -0.00109363f, 0.40114611f, -0.23272088f, 0.14970918f, 0.32293579f, 
    -0.13253777f, 0.08771003f, -0.00637286f, 0.00526645f, -0.09257495f, -0.07198374f, -0.37628359f, -0.03651258f, 
    0.00483747f, -0.04023523f, 0.13709848f, -0.10200469f, 0.14752999f, 0.01139916f, 0.06883884f, 0.01326072f, 
    -0.02082692f, 0.20125295f, 0.01996222f, 0.08303500f, 0.21284534f, -0.18717772f, -0.09474450f, -0.15282664f, 
    -0.17569275f, -0.08739625f, -0.04857104f, 0.00792217f, -0.06789380f, -0.02438291f, -0.00089358f, 0.14128122f, 
    0.16560610f, 0.15071756f, -0.28574809f, -0.02298499f, 0.15354447f, 0.17705202f, -0.02592771f, -0.00033618f, 
    -0.14147903f, -0.06994659f, 0.03601345f, -0.05810856f, -0.27152434f, 0.02658922f, -0.12621573f, 0.01311980f, 
    -0.05147608f, -0.00326295f, -0.09664796f, -0.22047049f, -0.12711708f, -0.34841314f, 0.08800066f, 0.16108318f, 
    -0.71559185f, -0.20999032f, -0.07854383f, -0.36679965f, 0.17516603f, -0.14950347f, -0.00664168f, -0.09731535f, 
    -0.14918855f, 0.10343500f, -0.04407795f, -0.14709906f, -0.17018965f, 0.07086224f, -0.13380165f, 0.14532870f, 
    0.02229715f, 0.04477337f, 0.02682726f, 0.12298630f, 0.00360706f, 0.07446671f, -0.09538700f, -0.08242067f, 
    -0.03820220f, -0.10696516f, -0.11780457f, -0.32120317f, -0.03047827f, -0.04168490f, 0.20168331f, -0.21338238f, 
    -0.13650198f, 0.16235454f, 0.07395564f, -0.13482282f, 0.33435997f, -0.24071762f, 0.18055862f, 0.06593835f, 
    -0.11974124f, -0.04026185f, -0.02538265f, -0.03502343f, -0.02114233f, -0.10575035f, -0.08166167f, 0.04365446f, 
    -0.02014104f, 0.13081358f, -0.05418866f, -0.00621816f, 0.15611795f, 0.04708761f, -0.02322504f, -0.04071008f, 
    0.06977467f, 0.14693215f, 0.00872985f, 0.05205254f, 0.77116412f, 0.06708310f, -0.19173951f, -0.16044037f, 
    0.07885512f, 0.11292729f, 0.00620526f, 0.09972175f, -0.04255065f, 0.12666291f, -0.12230721f, -0.12422901f, 
    0.12750581f, -0.38374943f, -0.25452754f, -0.08357146f, -0.04702122f, 0.04487330f, 0.03849038f, -0.16259708f, 
    -0.11656211f, -0.02801225f, 0.00795986f, 0.09371210f, -0.02915550f, 0.09368108f, -0.12370068f, 0.11311395f, 
    0.07863671f, -0.03186418f, 0.06012134f, -0.09715475f, -0.10710183f, -0.04926477f, -0.07311867f, 0.08947486f, 
    -0.07875238f, 0.24015538f, -0.22383979f, -0.15715307f, -0.01663259f, 0.04945450f, 0.02782912f, -0.08157344f, 
    -0.14127977f, -0.00189505f, -0.17878906f, -0.02067407f, 0.02322292f, 0.02894030f, 0.13742536f, 0.10888251f, 
    -0.03112577f, 0.01032677f, -0.00692202f, 0.02173747f, -0.19566916f, 0.02895225f, -0.11432441f, 0.08242316f, 
    0.08497359f, -0.07672296f, -0.16486272f, -0.05886165f, 0.13107125f, 0.04346180f, 0.09332712f, -0.14228249f, 
    0.08437265f, -0.07754060f, 0.14707676f, -0.02794774f, 0.05534748f, 0.14466533f, -0.03511700f, -0.18270189f, 
    -0.01055430f, -0.25879434f, -0.01723217f, 0.08166925f, -0.16399474f, -0.17147087f, -0.05406644f, -0.05890874f, 
    0.30368710f, -0.32548079f, 0.16209087f, -0.15256016f, -0.10367387f, -0.06424922f, -0.05540822f, 0.04549917f, 
    -0.03948962f, 0.11302484f, 0.08393795f, -0.06559409f, 0.42221099f, -0.06088788f, 0.04956288f, -0.08963330f, 
    -0.11177349f, -0.01762603f, -0.01324850f, 0.11351783f, 0.03993808f, -0.12190017f, -0.13181253f, -0.14187954f, 
    0.03970549f, 0.13353552f, -0.09809193f, -0.25329724f, 0.14004369f, 0.08182436f, -0.01591237f, -0.07805946f, 
    -0.08749216f, 0.15416409f, 0.13496007f, -0.14829555f, -0.34279150f, 0.20154022f, -0.06146549f, -0.05814727f, 
    -0.05859011f, -0.02648741f, 0.04004499f, 0.04173654f, 0.09637429f, 0.09155016f, -0.02677550f, -0.04014141f, 
    -0.37142774f, 0.12322938f, -0.25104329f, -0.04382778f, 0.01601450f, 0.14846125f, -0.04601970f, -0.10167328f, 
    -0.11204924f, 0.01865051f, 0.02770155f, -0.09871623f, 0.14126652f, 0.08632727f, -0.11411667f, -0.18204057f, 
    0.07525111f, 0.03098510f, -0.06495178f, -0.01830585f, -0.04161793f, 0.15669137f, -0.00415905f, 0.07322674f, 
    -0.37978777f, 0.19652589f, 0.05225177f, -0.15607847f, 0.13992313f, -0.02889959f, 0.08960610f, -0.10101510f, 
    0.02342822f, 0.02402058f, -0.07392579f, -0.05132140f, -0.48193547f, -0.12306388f, -0.12831487f, 0.12800795f, 
    0.10659914f, -0.09075096f, 0.15130377f, 0.15687393f, -0.08689782f, 0.02571795f, -0.02034948f, -0.03909790f, 
    0.59244394f, 0.03391803f, 0.04347587f, 0.35788956f, -0.14528231f, -0.06786492f, -0.01899109f, -0.04508960f, 
    -0.05160008f, 0.04393935f, 0.04402585f, -0.05474815f, 0.38862643f, -0.16660568f, -0.73198277f, -0.47331157f, 
    -0.22445485f, 0.05570505f, -0.05580488f, 0.01582761f, -0.02968081f, -0.09790279f, 0.11925108f, -0.00560094f, 
    0.27084514f, 0.05395513f, 0.00887192f, 0.07749185f, -0.18464470f, -0.01902981f, 0.06558173f, -0.00041120f, 
    -0.08919836f, 0.02593542f, 0.05116473f, -0.08534978f, 0.48891169f, 0.16657127f, 0.14166200f, 0.51313144f, 
    -0.19943774f, -0.26805839f, -0.06468602f, 0.10219662f, 0.04077910f, 0.07947852f, -0.02676804f, 0.01982690f, 
    0.38034213f, -0.16119172f, 0.20636225f, 0.14971843f, -0.22282298f, -0.06146751f, 0.04050143f, 0.08053472f, 
    -0.06430360f, -0.05795859f, 0.11248888f, 0.05900209f, 0.04092545f, 0.06848630f, -0.01649773f, 0.00085367f, 
    -0.01590013f, -0.04514139f, 0.00352182f, 0.06904916f, 0.00545903f, 0.01300552f, -0.01026623f, -0.13028318f, 
    0.12058621f, -0.17201273f, 0.10230557f, -0.00775648f, 0.20482543f, -0.12863411f, -0.01255268f, -0.15822148f, 
    0.14832725f, -0.00556017f, -0.05376421f, 0.03572273f, -0.11409748f, -0.02298144f, -0.28144285f, -0.13409851f, 
    0.00859152f, -0.06171126f, -0.04171505f, 0.09277473f, 0.11455072f, 0.05714745f, 0.09764099f, -0.15492630f, 
    -0.30927670f, -0.08377394f, -0.15079999f, 0.15529741f, -0.07141958f, -0.06347214f, -0.07185740f, 0.04115314f, 
    0.06363977f, 0.03260325f, -0.10230251f, -0.02644259f, 0.07169956f, -0.32982415f, 0.09806295f, -0.06729320f, 
    0.05283280f, 0.06206652f, -0.04988660f, 0.03007127f, -0.24209572f, 0.04633284f, -0.01224162f, -0.01240707f, 
    0.24862659f, -0.13348916f, -0.34810027f, 0.08090686f, -0.08293743f, 0.00781143f, 0.08930584f, -0.08947153f, 
    -0.10468228f, -0.01862796f, -0.09354161f, -0.00498141f, 0.31876889f, -0.01927953f, -0.17498104f, -0.08198860f, 
    -0.18831167f, 0.11019878f, 0.08215243f, -0.02257695f, -0.00152257f, 0.04902248f, 0.09593637f, -0.12307874f, 
    0.20680380f, 0.25099567f, 0.11155941f, 0.16267277f, -0.08159061f, -0.02381954f, -0.15317121f, 0.00794712f, 
    -0.00703142f, 0.01035716f, -0.06232586f, 0.03232864f, -0.06570958f, 0.06369153f, -0.07195970f, 0.08503360f, 
    -0.17907648f, -0.07701041f, 0.06796641f, -0.10984107f, -0.04211458f, 0.10756388f, -0.05912764f, 0.01226657f, 
    0.30674371f, -0.10373434f, -0.09357675f, -0.03297708f, -0.22243519f, -0.08382130f, -0.04035959f, 0.28355303f, 
    -0.02096836f, 0.18708143f, -0.01942690f, -0.04847863f, -0.36428872f, -0.17578228f, 0.02857523f, 0.05559479f, 
    -0.06076353f, -0.23119181f, -0.03559392f, 0.23047407f, 0.02714251f, -0.12960672f, 0.03428135f, -0.13744104f, 
    -0.44254267f, -0.65942377f, -0.21846429f, 0.14290971f, -0.07678913f, 0.13403960f, -0.19192608f, -0.08141130f, 
    -0.05814537f, -0.06004955f, -0.06465427f, 0.03950548f, -0.22788730f, 0.13609733f, 0.46984875f, 0.07067297f, 
    0.06014967f, 0.11750380f, 0.18086515f, -0.06714673f, -0.04323939f, -0.01321557f, -0.17230015f, 0.01610644f, 
    0.91679341f, 0.25786069f, 0.03167895f, 0.00396657f, 0.07109011f, 0.07450930f, -0.04800947f, -0.08716524f, 
    -0.11315240f, -0.06048961f, 0.00314488f, -0.02551576f, -0.23462522f, -0.34559259f, -0.22632200f, -0.10011364f, 
    -0.16809110f, -0.05087832f, -0.01612381f, 0.08035415f, 0.00307139f, 0.12581922f, -0.11335348f, 0.02232703f, 
    -0.66148371f, -0.14034970f, -0.44669068f, 0.17301741f, -0.02574114f, 0.09431078f, 0.10926596f, 0.02937530f, 
    0.04553937f, -0.06955957f, 0.15989873f, -0.11886807f, 0.01541878f, 0.20205432f, -0.21798584f, -0.15321752f, 
    -0.07453788f, -0.01618663f, 0.02367993f, -0.08384995f, 0.03777203f, -0.03096294f, 0.06353035f, 0.09494998f, 
    -0.86935610f, -0.15714397f, 0.03389431f, -0.05322702f, -0.04419813f, 0.05365327f, 0.03141809f, -0.00339667f, 
    -0.05147565f, -0.14583881f, 0.03055180f, -0.00240660f, 0.00485913f, -0.01925123f, 0.03238847f, -0.24408433f, 
    -0.08724789f, -0.01590691f, -0.03660974f, 0.01805973f, -0.11662045f, -0.19170138f, -0.15944703f, 0.21848141f, 
    -0.03276853f, 0.08856340f, 0.22875549f, -0.12789831f, -0.05459515f, -0.01094891f, -0.00284738f, 0.08252022f, 
    0.10876039f, -0.02838741f, 0.30002111f, 0.20438884f, 0.18112841f, 0.00784933f, 0.00126896f, -0.10586824f, 
    -0.14378388f, -0.13164830f, 0.08060089f, -0.10581070f, -0.16274147f, -0.10911060f, -0.03402996f, 0.07303423f, 
    0.28874815f, -0.25581935f, -0.08382432f, 0.24233094f, -0.00513149f, 0.08888931f, -0.10001950f, -0.06719428f, 
    0.14744098f, 0.00557876f, 0.16480075f, -0.10098574f, -0.10482034f, 0.27895236f, 0.10803823f, 0.12779234f, 
    0.00564187f, -0.04063733f, -0.04243362f, 0.20362362f, -0.05928118f, 0.13298845f, 0.05192651f, 0.05792413f, 
    0.30469954f, -0.01276583f, -0.04014236f, 0.22425774f, 0.02202920f, 0.07354629f, 0.05556591f, -0.05019731f, 
    0.03118000f, -0.14473787f, 0.02179156f, -0.07206316f, 0.36115271f, 0.16058430f, -0.32638523f, 0.15698552f, 
    -0.01357283f, 0.11165366f, -0.04682595f, 0.16090810f, -0.03285549f, 0.05214949f, -0.01571921f, 0.12883148f, 
    -0.62564236f, -0.40396047f, 0.16727720f, 0.11149143f, -0.09370298f, 0.09878280f, -0.03860155f, -0.03526717f, 
    -0.04987618f, -0.16835196f, -0.12846661f, -0.06829759f, -0.14439008f, 0.06761013f, -0.13713911f, -0.05550868f, 
    -0.18932094f, -0.00233218f, 0.07255823f, 0.02909224f, 0.04460816f, 0.13568293f, -0.05667502f, -0.05313429f, 
    0.14062628f, -0.25803927f, 0.05666878f, -0.00135974f, 0.03215810f, -0.13904357f, -0.12900914f, -0.27059749f, 
    -0.05236930f, 0.09831369f, 0.04856101f, 0.05820559f, -0.16818599f, 0.29698789f, 0.19183934f, -0.23930109f, 
    0.04467548f, -0.04060207f, -0.06388386f, 0.07132994f, 0.03483442f, -0.00215176f, 0.11538329f, -0.04153378f, 
    -0.51026130f, -0.05804002f, -0.33407751f, -0.09927506f, -0.19565813f, 0.05744507f, 0.04145517f, 0.10968643f, 
    0.01395465f, 0.07664001f, -0.03750591f, 0.14760789f, 0.06873356f, -0.05053557f, 0.04976043f, -0.08892497f, 
    -0.03707796f, 0.01864037f, 0.04051294f, -0.04505977f, -0.16247451f, -0.01722106f, 0.03539168f, -0.07604436f, 
    0.08416016f, -0.02722813f, -0.02876627f, -0.01519618f, -0.25428709f, 0.01520135f, -0.03288451f, 0.01134752f, 
    0.05203798f, -0.18460217f, 0.01035334f, 0.04577231f, -0.29622194f, -0.53121519f, -0.38820782f, -0.14445394f, 
    -0.08811539f, 0.00072445f, -0.02146670f, 0.07439753f, 0.06570698f, 0.05290299f, 0.03576981f, 0.01198855f, 
    -0.16369590f, -0.35835356f, -0.08373968f, 0.38149539f, -0.05453967f, 0.14668448f, 0.04842551f, -0.10652998f, 
    0.07304377f, -0.10957773f, 0.07429267f, 0.06040884f, 0.19290209f, -0.12624507f, 0.21763635f, -0.16471200f, 
    0.02146689f, -0.03758580f, 0.01379939f, -0.02524810f, 0.03895287f, 0.08627934f, 0.05166803f, -0.08748513f, 
    0.03896819f, -0.12091929f, 0.00641696f, 0.05859130f, -0.23277923f, -0.03086259f, 0.06746812f, -0.01393583f, 
    0.06842076f, -0.09553029f, 0.08740412f, 0.14120378f, 0.41103765f, 0.11787619f, 0.02820097f, 0.22528183f, 
    0.09631274f, 0.09644018f, -0.10615376f, -0.01723285f, 0.03754150f, -0.03163016f, -0.09406784f, -0.12643024f, 
    0.26345581f, 0.36963546f, 0.02943154f, -0.01924319f, 0.04809261f, -0.14555508f, 0.01613395f, 0.13537583f, 
    0.05247930f, 0.04783637f, 0.05729959f, 0.01996976f, -0.72054690f, 0.18764310f, -0.03165784f, -0.07597630f, 
    0.09042826f, -0.02365164f, 0.07591323f, 0.04816179f, -0.02217207f, 0.02197576f, -0.13167360f, -0.00307969f, 
    0.07366817f, -0.15769303f, -0.01407262f, 0.23935029f, -0.08065950f, 0.09117322f, 0.16778852f, 0.06942283f, 
    -0.08577206f, -0.00318688f, -0.11043292f, 0.04040997f, 0.10107424f, -0.13394353f, -0.30245560f, 0.15329465f, 
    -0.11718388f, -0.11740210f, 0.06812268f, -0.02045694f, -0.06721377f, 0.08847646f, -0.06499150f, -0.02723990f, 
    -0.16113023f, -0.15575205f, 0.07606391f, -0.35364860f, -0.22939378f, 0.00242386f, 0.07075716f, 0.01439952f, 
    0.03961229f, -0.01391027f, 0.00116193f, -0.16070509f, -0.00164869f, 0.38454756f, -0.53464311f, -0.50068814f, 
    -0.00635709f, -0.05265491f, 0.15999565f, 0.02100930f, 0.11543413f, 0.02096007f, 0.04008489f, 0.03870071f, 
    -0.02144321f, 0.05275553f, 0.15201323f, 0.12066863f, -0.21193694f, 0.06894370f, -0.12240362f, 0.02778759f, 
    0.07844144f, 0.03328174f, -0.09887227f, -0.00105867f, -0.41358575f, 0.04829616f, 0.14724506f, 0.10200393f, 
    0.20993564f, -0.07578970f, -0.17941003f, -0.24389407f, 0.03530819f, 0.01086105f, -0.22058956f, 0.09681186f, 
    0.41659737f, 0.26571518f, -0.24784911f, -0.15463693f, -0.05344644f, 0.06676402f, -0.14287095f, -0.02307561f, 
    -0.00207799f, -0.11643993f, 0.01661475f, 0.11111948f, 0.20920900f, -0.07084368f, -0.28370550f, -0.14942607f, 
    -0.17247482f, -0.19154775f, 0.12655841f, -0.00673034f, 0.04829220f, -0.07828277f, -0.04945894f, -0.17213428f, 
    -0.63439482f, -0.37276283f, 0.30091378f, 0.07468988f, 0.04399605f, 0.09597232f, 0.06723469f, -0.07847991f, 
    0.12173548f, 0.01604252f, -0.07043550f, -0.03425027f, -0.24723482f, -0.19739236f, -0.28716815f, 0.18499190f, 
    -0.14343362f, -0.07346382f, 0.18922244f, -0.16353570f, -0.13369614f, -0.13698761f, -0.07463075f, -0.00238483f, 
    0.02574923f, 0.11660592f, 0.15129004f, 0.18688117f, -0.11503334f, 0.03060193f, 0.17659946f, -0.00798487f, 
    -0.05604432f, -0.00730533f, -0.05012548f, -0.13897978f, 0.02373975f, 0.07962380f, 0.26892951f, 0.00735842f, 
    0.11628903f, 0.02456090f, 0.15727642f, 0.11794396f, 0.08749714f, 0.08889420f, -0.14783795f, 0.08394910f, 
    0.30636656f, 0.08831599f, 0.10782453f, 0.00612195f, -0.00520773f, 0.06285287f, -0.29487142f, 0.10379607f, 
    -0.14254846f, 0.04255506f, 0.00863262f, 0.03069989f, -0.50421607f, 0.01962316f, 0.00697574f, -0.21064565f, 
    -0.00875799f, 0.06458794f, -0.06263982f, 0.08293041f, 0.01101462f, 0.05060516f, -0.03091799f, 0.00493866f, 
    -0.41563320f, -0.03835234f, 0.28658020f, 0.30102742f, -0.14775144f, 0.03596571f, 0.06761936f, -0.12045453f, 
    0.01465004f, -0.25934458f, -0.06047581f, 0.07762524f, -0.16911656f, -0.14313608f, 0.12419681f, -0.15131897f, 
    -0.00032873f, 0.09764652f, -0.06316428f, 0.12403011f, 0.03614391f, -0.02921620f, 0.19721580f, 0.03917626f, 
    -0.10514615f, -0.40533212f, 0.05201280f, 0.02766589f, -0.06958243f, 0.00067114f, -0.06692357f, -0.11931964f, 
    0.10824824f, 0.01844600f, -0.05786192f, -0.15993328f, -0.42265835f, 0.10119882f, -0.02332613f, -0.26762971f, 
    0.05583734f, 0.17597951f, 0.13232470f, 0.02185857f, 0.03623930f, 0.09709674f, -0.03800664f, 0.06512105f, 
    0.22578324f, 0.08157252f, -0.07201425f, 0.01505722f, 0.17133245f, 0.06758236f, -0.03284448f, 0.09559946f, 
    0.10077428f, -0.00128919f, 0.00729138f, -0.14316142f, -0.19361171f, -0.09587294f, 0.03759448f, -0.09889417f, 
    0.03380954f, 0.13093153f, 0.01161544f, 0.06264634f, 0.06420720f, -0.01385057f, 0.00152084f, 0.05851310f, 
    -0.02072781f, 0.09811582f, -0.12109154f, -0.09424139f, 0.03791600f, 0.01036404f, 0.20976451f, -0.05334147f, 
    -0.06502162f, 0.05792544f, 0.03192163f, 0.04242804f, 0.44872582f, 0.01685258f, 0.06136967f, -0.20953111f, 
    0.04220030f, -0.11697231f, 0.09391660f, -0.15382156f, -0.03287511f, -0.04957793f, -0.07838405f, 0.07835893f, 
    0.09620918f, -0.36439541f, 0.13673951f, 0.18114808f, -0.16131614f, 0.06212556f, -0.01334934f, 0.05953171f, 
    0.03613833f, 0.04908754f, 0.08948316f, -0.07312672f, -0.91757327f, -0.05044166f, -0.02293445f, 0.27889100f, 
    0.11960491f, -0.15316199f, 0.05937866f, 0.15781987f, -0.06727599f, -0.07070842f, 0.10970669f, 0.11133855f, 
    -0.68041587f, 0.21170346f, 0.18725093f, 0.25871611f, -0.08515927f, 0.03736955f, -0.08096717f, 0.09707798f, 
    -0.14411288f, 0.11478545f, 0.13367335f, 0.02517463f, -0.06744193f, -0.07945818f, 0.05138113f, -0.03773753f, 
    0.11136007f, 0.00410981f, -0.07137462f, -0.04988826f, -0.09755170f, -0.05199704f, 0.00062837f, 0.10523309f, 
    0.29892474f, 0.01978703f, -0.11406061f, 0.04884483f, -0.00880229f, 0.00965426f, 0.05410717f, 0.09028772f, 
    -0.05890886f, -0.13742831f, 0.08517351f, -0.09890734f, 0.39443725f, 0.17138302f, 0.08242144f, 0.08078658f, 
    0.02203330f, -0.06786913f, 0.03978290f, 0.00809409f, -0.03579272f, 0.02036855f, -0.00944796f, 0.07041337f, 
    0.23331437f, 0.01153484f, 0.02448160f, 0.23206300f, -0.07765845f, -0.09037246f, 0.21794425f, 0.11588476f, 
    0.09462248f, -0.02300896f, 0.03860996f, -0.04994767f, -0.37985483f, 0.17064464f, -0.05749537f, -0.18323271f, 
    0.00211555f, -0.05394831f, -0.05345604f, 0.00936185f, 0.00079609f, -0.19423246f, -0.04853154f, 0.01306580f, 
    0.17385042f, 0.27699617f, -0.13658832f, -0.06102919f, 0.01352813f, 0.05623478f, 0.09054641f, 0.09523243f, 
    -0.05176689f, 0.02777031f, -0.22295226f, 0.02271314f, -0.50467515f, 0.08759163f, 0.02582083f, -0.10786990f, 
    -0.03472074f, 0.02358478f, 0.03505687f, 0.18264586f, 0.07320596f, 0.08517550f, -0.03022461f, -0.04659297f, 
    -0.03197528f, 0.01150414f, 0.15869960f, 0.28249368f, 0.03066002f, -0.03068129f, -0.04264463f, 0.02086055f, 
    0.01417497f, -0.09894604f, 0.04486310f, 0.07080281f, -0.08104941f, 0.18062274f, 0.09067000f, -0.06578151f, 
    -0.03565968f, 0.19122700f, 0.02127784f, -0.31126255f, -0.04184226f, -0.23722316f, 0.05204254f, -0.13878872f, 
    -0.15875909f, 0.15881975f, -0.17767397f, 0.28123146f, -0.10104041f, 0.13045134f, -0.04792235f, -0.16597214f, 
    -0.06354173f, -0.28816500f, 0.06673750f, 0.04840113f, -0.47247985f, 0.17676421f, 0.28293002f, 0.03453204f, 
    0.14031197f, 0.11287200f, -0.07324174f, -0.16839851f, 0.01486007f, -0.15979098f, -0.00802494f, -0.03412960f, 
    0.01903994f, -0.02630086f, -0.01662507f, 0.19553870f, -0.00624106f, -0.19035904f, 0.09639467f, -0.03044503f, 
    -0.03374122f, -0.14104787f, 0.12616688f, 0.00489057f, 0.00631491f, 0.03562893f, -0.10537189f, -0.04547878f, 
    -0.01833615f, 0.08848689f, -0.07803448f, -0.00796805f, -0.07655156f, -0.27003828f, 0.16523722f, 0.12776998f, 
    0.07074837f, -0.37768382f, 0.28308120f, 0.00693619f, -0.10003614f, -0.14342016f, 0.00998282f, -0.02395316f, 
    -0.15056452f, 0.06712643f, -0.09100172f, -0.11932116f, 0.09291713f, -0.01427546f, 0.32837078f, -0.07382784f, 
    0.12963094f, 0.15840629f, -0.02099900f, -0.02153835f, 0.07901027f, 0.12798296f, -0.00576085f, 0.26276451f, 
    0.07538702f, 0.09689881f, 0.06274418f, 0.09477665f, -0.10570232f, -0.00193716f, -0.05176262f, -0.04409142f, 
    -0.24346803f, -0.06457466f, -0.04063008f, 0.12253556f, 0.06555004f, 0.10860709f, -0.07743903f, -0.43631810f, 
    -0.00506222f, 0.07410882f, -0.15238734f, -0.01115354f, 0.24220553f, -0.16350068f, 0.25314680f, -0.12176490f, 
    -0.18726058f, 0.15396889f, 0.28854823f, -0.59440768f, -0.13184372f, 0.05455031f, 0.09514114f, 0.11576974f, 
    -0.09031416f, 0.05072482f, 0.04965218f, -0.20430548f, -0.43162322f, -0.17944321f, -0.05294460f, 0.07806335f, 
    0.07561868f, -0.01864258f, -0.22638969f, -0.15368053f, 0.23151861f, 0.12427571f, 0.31670839f, 0.10741074f, 
    -0.08363095f, 0.07921872f, -0.17923772f, 0.13513681f, 0.21002601f, -0.01302153f, 0.15825857f, -0.22187379f, 
    -0.16268983f, 0.00375241f, -0.10844840f, -0.10260247f, -0.91469383f, -0.28038013f, -0.17858240f, -0.13120538f, 
    0.20650692f, 0.09462954f, -0.06406005f, -0.03697229f, 0.08377003f, 0.21516223f, 0.05357373f, 0.05602825f, 
    0.01876070f, -0.02921800f, 0.06126290f, -0.13694654f, -0.13321853f, -0.20217930f, 0.04588127f, 0.09694162f, 
    -0.08708171f, -0.06227859f, 0.04097896f, -0.14912218f, -0.07657899f, -0.14939018f, -0.00936276f, 0.22120421f, 
    -0.04509963f, -0.08880977f, -0.05197951f, 0.18107168f, 0.13910307f, 0.05792372f, 0.07256315f, 0.00541241f, 
    0.14478637f, 0.16743632f, 0.05712371f, 0.20747411f, -0.05460790f, -0.14261618f, 0.01644498f, -0.09433798f, 
    0.12130636f, -0.06252510f, 0.11349957f, 0.19900918f, -0.28120217f, 0.22774671f, 0.36627230f, 0.04848624f, 
    0.03708450f, -0.09522493f, 0.04554616f, 0.00291863f, -0.06085983f, -0.13606389f, -0.03143988f, -0.30230978f, 
    -0.14131552f, -0.05440336f, 0.22571675f, -0.01740846f, -0.17068307f, -0.06331892f, 0.00542634f, 0.01473063f, 
    0.18113787f, -0.08344597f, 0.02857803f, 0.17069499f, -0.23147038f, 0.08159421f, 0.00132874f, 0.01276426f, 
    -0.22006181f, -0.06234881f, -0.05967877f, -0.06822076f, 0.17728862f, -0.05274457f, 0.06513814f, 0.14389955f, 
    -0.32479033f, -0.15728365f, -0.00130600f, -0.06298034f, -0.01460814f, 0.06212939f, 0.02768825f, 0.01145384f, 
    0.08506639f, -0.12288699f, -0.11821111f, -0.02059008f, -0.14856794f, -0.16307525f, -0.12310578f, 0.27606696f, 
    -0.02704939f, -0.10438687f, 0.23886840f, 0.21155427f, 0.07678569f, 0.13081692f, -0.14817406f, -0.11489667f, 
    0.31198144f, 0.08283301f, 0.10266974f, -0.23596168f, -0.09936190f, -0.00593309f, -0.01666524f, -0.19240507f, 
    -0.17567591f, -0.02028669f, -0.21685137f, 0.11271466f, -0.32622033f, 0.19480503f, -0.41894713f, -0.15485282f, 
    0.16046001f, 0.30164942f, 0.08702634f, -0.11101816f, 0.08627219f, 0.00737205f, -0.12783697f, -0.00803348f, 
    -0.47041065f, -0.26216513f, -0.28532106f, -0.05931226f, 0.07298861f, -0.05003591f, -0.05826911f, 0.08056451f, 
    0.16340564f, -0.20090473f, 0.05803099f, 0.00443241f, 0.20767824f, 0.05946572f, -0.04302538f, -0.01552002f, 
    0.07821997f, -0.03719367f, 0.02803186f, -0.01422268f, 0.14573608f, -0.05955378f, -0.26204842f, -0.15071812f, 
    0.05313662f, 0.10851344f, 0.05943312f, -0.15153563f, 0.15212344f, 0.11092958f, 0.09046339f, -0.04447220f, 
    0.08669681f, 0.16834797f, -0.02391773f, 0.30299687f, -0.14143629f, -0.01616441f, -0.16370615f, -0.26966056f, 
    0.13499865f, 0.04150468f, -0.02135115f, -0.15696205f, 0.13003308f, -0.04728197f, -0.26184422f, 0.08709173f, 
    -0.04503680f, -0.28422356f, -0.21534841f, 0.23818786f, 0.17460953f, 0.14982767f, -0.13824925f, -0.03714978f, 
    -0.01027189f, 0.18741812f, -0.09180774f, -0.08251724f, -0.03957131f, -0.00757531f, 0.16613945f, -0.06200460f, 
    0.02033347f, 0.14001526f, -0.02724943f, 0.11471275f, 0.05500188f, 0.14066792f, 0.16983525f, 0.12724419f, 
    -0.17520413f, -0.17479868f, 0.44352239f, 0.19433281f, 0.05073117f, -0.00679785f, 0.01465198f, -0.17819278f, 
    0.12142733f, -0.03496018f, 0.18047963f, 0.00546523f, -0.14579526f, -0.01928909f, 0.01848301f, -0.00607894f, 
    0.16381018f, -0.17959458f, -0.11329584f, 0.09053717f, 0.04947085f, 0.00262641f, -0.01034751f, -0.13849112f, 
    0.00192058f, -0.11717304f, -0.36740723f, 0.01153915f, -0.06584769f, -0.09730662f, -0.20051374f, -0.02020374f, 
    -0.03742319f, -0.15530857f, 0.05932288f, 0.01666281f, -0.37154990f, -0.11023742f, 0.29624945f, -0.14927967f, 
    0.07991361f, -0.14909609f, 0.01876703f, 0.19549759f, 0.15937951f, 0.20378467f, -0.06341281f, 0.06865810f, 
    -0.02748747f, 0.01474134f, -0.12194195f, 0.50152534f, 0.11142556f, -0.01663260f, 0.02666517f, 0.07647330f, 
    0.04167646f, 0.17884468f, -0.14439392f, -0.06873667f, 0.42899874f, -0.73783571f, -0.38839582f, 0.21762083f, 
    0.00699052f, 0.17584370f, -0.09266299f, 0.15180133f, 0.01722422f, 0.02293786f, 0.00780778f, 0.12880105f, 
    -0.35770398f, 0.28435677f, 0.12057389f, -0.15031730f, -0.00806542f, -0.14744940f, -0.02458968f, 0.12841503f, 
    -0.03432214f, 0.11896840f, 0.00215452f, 0.12208555f, 0.45792285f, 0.10209662f, 0.05511528f, -0.21737023f, 
    0.02953388f, 0.15886395f, 0.18670695f, 0.06499632f, 0.05748858f, 0.17303623f, -0.09748878f, -0.11702715f, 
    -0.34162444f, -0.08490603f, 0.25563279f, 0.13221383f, 0.13839202f, 0.14084809f, 0.01748543f, -0.00239957f, 
    0.05531264f, 0.15054630f, -0.07346685f, 0.16431534f, -0.39448097f, 0.10240426f, 0.13108660f, 0.20786963f, 
    -0.09765214f, 0.09347075f, 0.02246922f, -0.09355331f, -0.05203740f, -0.01418319f, 0.01357920f, -0.31916741f, 
    -0.12269494f, 0.21455666f, 0.22207670f, -0.23991843f, 0.05466180f, -0.10097001f, 0.03642633f, 0.10475826f, 
    0.05796573f, 0.16028826f, -0.12688190f, -0.15780370f, -0.15653780f, -0.46369636f, 0.02382111f, -0.07089067f, 
    -0.08030090f, 0.05016534f, 0.08836251f, 0.16962108f, -0.09596217f, 0.21302032f, -0.15450078f, 0.22106037f, 
    -0.03548481f, 0.07157757f, 0.04832086f, -0.00859528f, 0.02808115f, 0.03470080f, -0.03908441f, -0.00354416f, 
    -0.03772450f, -0.06272463f, -0.13875388f, -0.03325126f, 0.17996533f, -0.07055373f, -0.48526561f, 0.38388589f, 
    -0.05029195f, -0.06300186f, 0.00760559f, 0.10914128f, -0.07014537f, -0.10033425f, -0.07553043f, -0.13058609f, 
    0.04603008f, -0.04421228f, -0.04279197f, -0.00443530f, -0.10993041f, -0.00475055f, -0.08279839f, -0.13817225f, 
    0.01132512f, 0.21159513f, 0.27042589f, 0.24066956f, 0.09855030f, -0.25279006f, 0.05565379f, -0.10005058f, 
    -0.09844609f, -0.00053767f, 0.09513005f, 0.09187965f, 0.06244192f, -0.05851788f, -0.05324377f, -0.13831075f, 
    -0.05551456f, 0.24199833f, -0.04352641f, -0.19734769f, -0.16738898f, 0.09196745f, -0.07131517f, 0.00493630f, 
    -0.08982411f, -0.00368644f, -0.05354391f, 0.04602738f, 0.29409930f, -0.17341310f, 0.11479645f, -0.36062035f, 
    0.08600149f, 0.16151208f, 0.08704664f, -0.12907052f, -0.13767105f, -0.01795874f, -0.02406115f, 0.11843193f, 
    -0.22831415f, 0.16738221f, 0.23279913f, -0.34125048f, -0.01521502f, 0.17066522f, -0.09109784f, 0.00020057f, 
    -0.10195699f, -0.09887075f, -0.04416637f, -0.16003188f, 0.41146475f, -0.02488880f, 0.16774014f, 0.23995726f, 
    -0.10653878f, -0.12585212f, -0.10380714f, 0.04726883f, 0.03526640f, 0.16437781f, -0.11085311f, 0.29742077f, 
    0.28603509f, 0.05228978f, 0.19296932f, -0.23309955f, 0.26631793f, 0.01031924f, 0.05136696f, 0.04709154f, 
    -0.16858053f, 0.09683246f, 0.01732561f, -0.01666856f, -0.32739708f, 0.08109629f, -0.16072649f, 0.31173232f, 
    0.01505378f, -0.06358504f, 0.16886753f, 0.06049651f, -0.07294328f, -0.06855468f, -0.09870450f, -0.03118769f, 
    -0.30201238f, -0.14454441f, 0.00260060f, -0.15994540f, -0.03847642f, 0.02189342f, -0.04711385f, -0.08167265f, 
    0.07618525f, -0.07675919f, 0.10217153f, -0.00162314f, 0.00297871f, -0.19538528f, -0.07537116f, 0.14702900f, 
    -0.04731431f, -0.09099323f, -0.17864399f, -0.15545547f, -0.13569741f, -0.07906344f, -0.07953545f, 0.03544055f, 
    -0.39007437f, 0.25588131f, 0.10409188f, 0.24417557f, 0.00763254f, -0.10459158f, 0.05158015f, 0.19241992f, 
    0.01056181f, 0.00959296f, 0.18425709f, -0.05465044f, -0.16280130f, -0.37179884f, -0.25119707f, -0.41427711f, 
    0.05290492f, 0.00282303f, -0.00387481f, -0.15751050f, -0.00452827f, -0.06442871f, 0.08430267f, 0.17815304f, 
    0.01400191f, -0.13366731f, -0.05872037f, -0.32130614f, -0.07197198f, 0.02637716f, 0.09295794f, -0.22529705f, 
    -0.27412438f, 0.04563325f, 0.12886576f, -0.09036396f, -0.36729026f, 0.15256977f, 0.28280684f, -0.20397493f, 
    -0.13501771f, -0.06125493f, -0.02951186f, 0.00268899f, 0.02853684f, 0.04281541f, 0.16703752f, 0.09761941f, 
    -0.06871341f, 0.16537644f, 0.11003546f, -0.55847049f, -0.19772616f, 0.00469307f, 0.06880654f, 0.11589283f, 
    -0.00959716f, -0.18024121f, 0.03476647f, -0.20009050f, -0.01642605f, 0.08423647f, 0.07844273f, -0.38831440f, 
    -0.06650901f, -0.01026429f, 0.05319493f, -0.01841735f, -0.20106371f, 0.05131977f, 0.26550022f, -0.06625470f, 
    -0.07896791f, 0.04245270f, -0.36780682f, -0.34505314f, -0.21403483f, -0.09053586f, -0.10089826f, 0.08592468f, 
    -0.00464483f, -0.07017945f, 0.17435777f, 0.13654496f, 0.11546516f, -0.20219868f, -0.06199464f, -0.11591474f, 
    -0.03294908f, 0.10830460f, 0.14271151f, 0.04925834f, -0.00376331f, -0.17413004f, -0.20284903f, -0.13466476f, 
    0.32450166f, -0.02830442f, 0.05617964f, -0.38711569f, -0.06205391f, -0.04204926f, -0.00568849f, 0.00184699f, 
    0.08643007f, 0.03759350f, -0.21868756f, -0.09776727f, 0.37313047f, -0.22470807f, 0.38483560f, -0.07577641f, 
    0.13660176f, -0.05007112f, 0.09986535f, -0.03626279f, 0.00448820f, 0.12595455f, 0.08455098f, 0.05459407f, 
    -0.01000607f, 0.19924550f, -0.12997569f, 0.23317234f, -0.06548518f, -0.06667796f, -0.16502395f, -0.05876423f, 
    -0.11056537f, 0.04527040f, -0.16773126f, -0.06179067f, 0.39443159f, -0.02463860f, -0.17065056f, -0.07281850f, 
    -0.01464047f, 0.02412900f, -0.08168714f, -0.08527552f, 0.01394657f, -0.10802309f, -0.02065475f, -0.11475852f, 
    -0.43431172f, 0.04158062f, -0.06336679f, 0.02788376f, -0.02325601f, -0.11195745f, 0.00756481f, 0.04993642f, 
    -0.01637197f, 0.01030031f, 0.02413480f, 0.03085188f, -0.12987368f, 0.07549480f, 0.24900503f, -0.05863441f, 
    0.02838310f, 0.04511194f, -0.03681329f, -0.07304683f, 0.02698608f, -0.05442576f, 0.14411981f, 0.05412395f, 
    -0.29641345f, -0.18770379f, -0.12700239f, -0.13217807f, -0.00344091f, -0.12410807f, -0.04740225f, -0.01366661f, 
    -0.07564569f, 0.00714485f, -0.05378215f, -0.02780644f, 0.38994595f, -0.00802004f, 0.11353676f, -0.13469253f, 
    -0.25856036f, 0.03152393f, 0.10704679f, -0.10006668f, -0.08998409f, 0.09387373f, -0.09484375f, -0.04301723f, 
    -0.27234477f, 0.18261738f, 0.01647274f, 0.09098978f, 0.17605504f, -0.11195583f, 0.05290633f, 0.03252412f, 
    0.05081807f, -0.11421426f, 0.10609627f, -0.00335669f, 0.00761250f, -0.01375277f, -0.06399088f, 0.01903350f, 
    -0.01833930f, -0.05641628f, -0.01199554f, -0.01763442f, 0.02615596f, -0.11248118f, 0.06683189f, 0.01983907f, 
    0.15007365f, -0.48126012f, -0.05612962f, -0.05757948f, -0.02746039f, -0.04425211f, -0.04256409f, -0.08927748f, 
    -0.09894834f, -0.03019846f, -0.01188497f, -0.04332573f, -0.00891150f, 0.13570784f, -0.08585054f, 0.02984136f, 
    -0.12279510f, -0.01643550f, 0.12864769f, -0.18224238f, 0.00445292f, 0.10347921f, -0.07267316f, -0.04859794f, 
    0.15691175f, -0.19171715f, -0.06191854f, -0.27552992f, -0.11671366f, -0.01704253f, -0.01452905f, -0.07144782f, 
    0.04209938f, 0.04383433f, -0.06141473f, -0.04527751f, 0.20010366f, 0.14723083f, 0.00055821f, 0.21933471f, 
    0.11324119f, -0.10437318f, 0.01693529f, -0.01313555f, -0.01805410f, -0.08537629f, -0.04184731f, -0.07342532f, 
    0.01050029f, 0.14900587f, 0.11916286f, 0.12803383f, 0.12039728f, 0.04672658f, 0.05921607f, 0.00173208f, 
    -0.01128116f, -0.00008355f, -0.04676289f, -0.15641755f, 0.09026568f, -0.14733809f, 0.20689848f, 0.09137974f, 
    0.04674283f, 0.00675018f, -0.07028756f, -0.00852433f, -0.04911479f, 0.06220521f, -0.15917501f, -0.04848611f, 
    -0.12453302f, 0.17401065f, -0.15943003f, -0.09467902f, -0.06621269f, 0.01440881f, -0.17717966f, -0.03329505f, 
    -0.30628514f, -0.07830273f, 0.03690126f, -0.04006817f, 0.26784065f, -0.09785504f, -0.06981746f, 0.14715604f, 
    0.04834749f, 0.00390543f, 0.00511702f, -0.10349900f, -0.12496775f, -0.05108250f, 0.00380029f, 0.03420874f, 
    0.25579232f, 0.03032581f, -0.13108706f, 0.05841226f, -0.12630731f, -0.08851077f, -0.21776706f, -0.21342887f, 
    0.01713087f, -0.02451305f, 0.00828621f, -0.11888563f, -0.28752801f, -0.03126511f, -0.12688327f, 0.09435195f, 
    -0.01291569f, -0.15401743f, -0.03841641f, 0.07190572f, -0.13001278f, 0.06416737f, -0.01751670f, -0.04607583f, 
    -0.13370343f, -0.26118657f, -0.29675499f, -0.12868734f, -0.12019400f, 0.05693046f, -0.01857878f, -0.13257477f, 
    -0.03090972f, 0.08869150f, 0.01772287f, -0.03636800f, -0.05940193f, 0.11631864f, -0.28182855f, 0.00974716f, 
    -0.06218617f, -0.03403636f, -0.01305821f, 0.06296216f, -0.11411141f, 0.00381520f, 0.02218620f, 0.01140615f, 
    0.35036674f, 0.11482716f, 0.28308123f, 0.05078759f, -0.02147464f, 0.03035979f, 0.00948468f, -0.04505731f, 
    -0.03817909f, 0.09073920f, -0.04501710f, 0.01614521f, 0.39343053f, 0.03191569f, 0.09508292f, 0.29586485f, 
    0.12652713f, 0.15383336f, 0.02003589f, -0.08072545f, -0.14800575f, -0.04287098f, 0.07220016f, -0.06373374f, 
    -0.10058463f, 0.09080527f, 0.03624750f, -0.04656305f, -0.00612205f, -0.00179893f, 0.02714215f, -0.00856628f, 
    -0.01261601f, -0.00594821f, -0.04889293f, -0.14513329f, 0.11005759f, 0.08553738f, 0.38018534f, 0.26886380f, 
    0.15177698f, 0.12870699f, 0.10425296f, 0.03878316f, 0.04148926f, 0.11790690f, 0.02874986f, -0.05646429f, 
    0.02025740f, 0.31028831f, 0.29967085f, 0.12791651f, 0.13511321f, -0.00288607f, 0.11516910f, 0.08890887f, 
    0.02997842f, -0.08105952f, 0.04876013f, -0.02530541f, -0.29521799f, 0.08671436f, -0.19605714f, -0.22845602f, 
    -0.11281811f, 0.12967518f, -0.06014942f, -0.08619248f, -0.03597375f, -0.09053284f, -0.06190291f, -0.17059535f, 
    -0.46986088f, 0.43634301f, -0.08832346f, -0.15732177f, -0.14023897f, 0.03673705f, 0.01642003f, -0.07338130f, 
    -0.02963649f, -0.02130632f, -0.00813526f, -0.06078763f, 0.02946226f, 0.01174416f, -0.01171937f, -0.04615362f, 
    -0.10902562f, 0.03426944f, 0.04115933f, -0.08155397f, 0.01849094f, 0.01280814f, 0.09883944f, -0.08017410f, 
    0.13779148f, 0.26906508f, 0.05101259f, 0.12565511f, 0.17646949f, 0.15512387f, -0.00218078f, -0.14263831f, 
    -0.01557941f, -0.11441613f, -0.01085880f, -0.11143646f, -0.44862118f, 0.10893649f, -0.03904028f, -0.07069272f, 
    -0.08179060f, -0.07294782f, -0.06548271f, -0.08684663f, -0.04988178f, 0.01070322f, -0.08640956f, -0.03816325f, 
    -0.39838070f, -0.09225333f, 0.08681551f, -0.21989305f, 0.08817986f, 0.00993684f, -0.12800787f, -0.09848627f, 
    -0.06835489f, -0.06383448f, -0.03280781f, 0.03325602f, 0.06178624f, -0.05225030f, -0.01546821f, -0.22677547f, 
    0.15902755f, -0.01602524f, -0.04928904f, -0.04748103f, 0.02216426f, 0.01279846f, -0.03141585f, -0.06793773f, 
    -0.30961731f, 0.21298268f, -0.16108263f, -0.48191461f, -0.06879923f, 0.08558670f, -0.06728758f, 0.03289855f, 
    0.15652530f, 0.03791179f, 0.03817139f, 0.08445437f, -0.20153800f, -0.06311398f, 0.04039073f, -0.08520667f, 
    -0.02199092f, -0.06570552f, 0.08915629f, -0.12678514f, -0.21722531f, 0.07033502f, 0.13630478f, 0.15727681f, 
    0.32008862f, 0.25695840f, -0.50848824f, -0.02526395f, 0.18813297f, -0.00579318f, -0.12076288f, -0.03270885f, 
    -0.07433923f, -0.24964641f, 0.07835349f, 0.12247061f, -0.02673000f, -0.17776118f, 0.03227623f, 0.09571173f, 
    -0.16481823f, -0.25080630f, -0.11471600f, 0.00917653f, 0.04902941f, -0.12013087f, -0.02001647f, -0.04329015f, 
    -0.14562373f, -0.29515776f, -0.06096065f, 0.18314527f, 0.19355300f, 0.05865790f, -0.02267828f, -0.02807340f, 
    0.03433113f, -0.06837676f, 0.05891756f, -0.01850970f, -0.03844041f, -0.25707504f, -0.23529249f, -0.24744639f, 
    -0.02139377f, -0.04781310f, 0.10156301f, 0.10912668f, -0.01229393f, -0.31905165f, 0.13120705f, 0.08139332f, 
    -0.29353034f, -0.08516222f, -0.22983555f, -0.03888519f, 0.12425931f, -0.08097973f, -0.31826827f, 0.10870837f, 
    0.12101948f, -0.01558912f, 0.07337589f, -0.00891183f, 0.13595219f, -0.06824610f, 0.02687083f, 0.01748092f, 
    0.03770809f, 0.00770915f, -0.12420909f, 0.00658189f, -0.04371590f, -0.02577530f, 0.03554277f, 0.12294613f, 
    0.13638760f, -0.50269812f, -0.32499468f, 0.13562930f, 0.19599110f, -0.16022491f, -0.03767574f, -0.05500841f, 
    0.04491614f, -0.02689584f, 0.06584159f, 0.00973026f, 0.07921923f, 0.10467890f, 0.10843063f, 0.12902556f, 
    -0.04839094f, -0.04104524f, -0.09547816f, -0.08996507f, 0.01335868f, -0.07829180f, 0.07155752f, -0.19558080f, 
    0.26441041f, 0.15833405f, -0.01008801f, 0.24837109f, 0.08324751f, -0.16179119f, -0.02961243f, -0.06481626f, 
    -0.02554667f, 0.09143261f, -0.12568992f, -0.11038987f, 0.13009332f, 0.20530741f, -0.13833740f, -0.07873709f, 
    -0.14661579f, -0.09765194f, -0.10470151f, -0.06802556f, -0.02364197f, 0.04996000f, 0.15246755f, 0.06542426f, 
    -0.04630131f, -0.42841896f, 0.09043146f, 0.02152106f, -0.01316347f, -0.16736872f, 0.08478890f, -0.06980734f, 
    0.07274593f, -0.37704098f, -0.12045022f, 0.05163665f, -0.30491978f, -0.19209081f, 0.26752836f, -0.09311228f, 
    -0.01834830f, -0.02106679f, 0.01466104f, 0.07976826f, 0.08296870f, 0.04230217f, 0.07961696f, 0.04650799f, 
    0.02140497f, -0.18779010f, -0.27543277f, 0.02867111f, 0.06107119f, -0.11062790f, -0.00631694f, 0.02984465f, 
    0.17053214f, 0.17118748f, 0.01231698f, -0.32406220f, -0.02838800f, -0.32962012f, -0.03260622f, -0.26736766f, 
    0.08901457f, -0.00025511f, -0.05293079f, 0.00648368f, 0.08058865f, 0.03628952f, -0.14121661f, 0.02758742f, 
    -0.05693174f, -0.27131715f, -0.05454121f, -0.24254905f, -0.06790414f, -0.20798472f, 0.03561654f, 0.09826142f, 
    -0.00151761f, 0.08859059f, 0.08450697f, 0.03896694f, 0.30394140f, -0.16202159f, -0.34019414f, -0.00795044f, 
    0.08818969f, -0.05467530f, -0.12381056f, 0.04667109f, 0.11085770f, -0.05949416f, 0.11436687f, -0.08467254f, 
    -0.02932996f, 0.19686726f, -0.07631508f, 0.35163468f, 0.00218369f, 0.03286934f, -0.02732921f, 0.01612317f, 
    0.13491130f, -0.18396737f, 0.06422744f, 0.13021499f, -0.12962817f, 0.39709285f, -0.10395775f, 0.05385237f, 
    -0.15048343f, 0.13957977f, -0.17700477f, -0.16516487f, 0.09352914f, 0.10728098f, 0.06400232f, -0.01912855f, 
    0.09814085f, 0.26018739f, 0.06982687f, -0.00899158f, 0.10389335f, 0.05888658f, 0.07639821f, -0.04748204f, 
    -0.00116490f, 0.05159392f, 0.10760394f, 0.25279611f, 0.12389697f, -0.17050266f, 0.03412266f, -0.35815713f, 
    0.00024383f, 0.00715437f, 0.18816103f, -0.05799372f, -0.06466510f, -0.11063112f, -0.17687906f, 0.01757720f, 
    0.24716151f, -0.00899766f, -0.05733878f, 0.15205523f, -0.02166143f, -0.13672723f, -0.20733118f, -0.16283154f, 
    -0.04720252f, 0.11278702f, -0.22962222f, 0.06942988f, -0.28831306f, 0.00162864f, 0.19418970f, 0.14708005f, 
    -0.20242225f, 0.07916094f, -0.02908375f, -0.33062455f, 0.05329519f, 0.08719692f, -0.26844910f, -0.00980744f, 
    -0.00098462f, 0.08597819f, 0.19277643f, 0.11166344f, -0.00607791f, 0.02985674f, -0.21702111f, 0.06765871f, 
    0.08377434f, -0.05739944f, -0.02087979f, -0.11044194f, 0.10417368f, -0.07975896f, 0.02851916f, 0.08119316f, 
    0.04223760f, 0.00035539f, 0.05711346f, -0.08058370f, -0.16520679f, 0.23968965f, -0.15465140f, -0.04666249f, 
    0.09346993f, -0.01445573f, 0.10150211f, 0.26007989f, 0.12629631f, -0.04040612f, 0.00786922f, -0.03200372f, 
    0.02264199f, 0.09405365f, 0.17981669f, -0.00341946f, -0.07344608f, -0.40938914f, 0.15222822f, 0.01380514f, 
    0.04113548f, 0.00519346f, -0.01912173f, 0.07599249f, 0.00066711f, 0.08811048f, -0.25361335f, 0.17868529f, 
    -0.32248256f, 0.19160503f, 0.06332891f, -0.24907589f, 0.14320187f, -0.01073639f, -0.16858044f, -0.02307171f, 
    -0.00357910f, -0.13288739f, 0.04726882f, -0.13841002f, -0.10114476f, -0.03330975f, -0.10290700f, 0.08211968f, 
    -0.13279437f, 0.07374002f, 0.02219517f, -0.32155988f, 0.17958649f, 0.11005403f, -0.02603327f, -0.00379581f, 
    0.06242394f, -0.05267770f, 0.08324821f, 0.20114808f, 0.06657211f, -0.09055067f, -0.09439927f, -0.09400053f, 
    0.07824717f, -0.00821105f, 0.05972818f, -0.04949958f, 0.14717953f, -0.25952002f, 0.12088673f, 0.06590711f, 
    -0.10625819f, -0.05926486f, 0.01374762f, -0.22258328f, 0.07053384f, -0.14987680f, -0.00064769f, -0.02744269f, 
    -0.02747776f, 0.07307509f, 0.16866241f, -0.08698954f, 0.06583938f, 0.14083676f, -0.02175195f, -0.02887104f, 
    0.01565252f, -0.09906173f, -0.23992105f, -0.01930032f, 0.08205056f, 0.12034526f, -0.13267545f, 0.07682656f, 
    -0.11786522f, -0.06317431f, -0.13591228f, 0.25808826f, 0.11636344f, 0.02217694f, 0.15845923f, 0.12392950f, 
    -0.05968012f, 0.18598878f, 0.57214004f, -0.18513642f, 0.21802914f, 0.02278611f, -0.08125524f, -0.04299097f, 
    0.05695261f, -0.00034919f, 0.07496586f, -0.00826426f, 0.26950017f, 0.03583456f, 0.06694568f, 0.18413916f, 
    0.17304264f, 0.10468753f, 0.07605743f, -0.19187272f, -0.03755026f, -0.29569116f, 0.04902404f, 0.03039832f, 
    -0.05642973f, -0.09151198f, -0.06006170f, -0.31662795f, 0.15151504f, 0.16332619f, -0.23998211f, -0.13238922f, 
    -0.20433167f, -0.12576552f, -0.11735561f, -0.10184481f, -0.32575932f, 0.24364477f, -0.25189015f, -0.15462197f, 
    -0.06422719f, -0.17174567f, 0.05999166f, 0.07410339f, 0.03790201f, 0.14715867f, 0.18300398f, 0.06582822f, 
    -0.41714615f, -0.11161903f, -0.08309149f, -0.04070648f, -0.23939717f, -0.01378502f, 0.05815216f, -0.01097390f, 
    -0.14249857f, -0.10409086f, 0.10944800f, -0.10040501f, 0.02640818f, 0.01321052f, 0.09794059f, -0.12863252f, 
    0.06479580f, -0.01708064f, -0.04772191f, 0.00850433f, -0.12075929f, -0.08571629f, 0.02730955f, -0.24685140f, 
    0.01698229f, -0.00865445f, 0.34679261f, 0.01995178f, -0.03283317f, -0.11276765f, -0.04904144f, 0.00245882f, 
    -0.03324967f, -0.02437488f, 0.03960603f, -0.13478401f, -0.58366525f, 0.59164780f, 0.22745578f, 0.35062277f, 
    0.17083102f, 0.05997343f, -0.02984223f, 0.07972638f, 0.08081134f, 0.04408813f, -0.11023750f, 0.02925827f, 
    0.40546292f, -0.44069690f, -0.04291452f, -0.11451450f, 0.14060676f, -0.06024314f, 0.06621021f, -0.11953773f, 
    -0.02573470f, -0.07498927f, 0.00419833f, 0.10076615f, -0.37117454f, -0.13086064f, 0.18052685f, -0.00023591f, 
    0.10140259f, -0.06944828f, 0.02253532f, -0.05474679f, -0.11876413f, -0.20397727f, -0.14283180f, -0.07126994f, 
    -0.20914403f, -0.39233208f, 0.06131595f, -0.12617691f, -0.07735733f, 0.03308399f, 0.07277562f, -0.05656401f, 
    0.24066934f, 0.09401373f, 0.01602378f, 0.00201954f, 0.38668144f, -0.08539327f, -0.23414792f, 0.34879038f, 
    0.12021448f, -0.04919042f, 0.00614644f, -0.19163096f, -0.05936986f, -0.11337710f, -0.10005347f, 0.00387095f, 
    -0.67834491f, 0.27884826f, -0.07192597f, -0.36999455f, -0.01384200f, 0.10652899f, 0.08006251f, -0.11615548f, 
    0.02377266f, 0.00534917f, 0.14695986f, 0.06991036f, 0.25583154f, 0.11891755f, 0.01291522f, 0.00635718f, 
    -0.20076936f, 0.01887555f, 0.02860918f, 0.00731369f, -0.03624436f, -0.08147379f, -0.05605945f, 0.11978476f, 
    -0.13579553f, 0.23193860f, 0.01521970f, -0.04877925f, 0.03356704f, 0.02893804f, 0.16193677f, -0.06360448f, 
    -0.06473453f, 0.00726789f, -0.21126585f, -0.08123232f, -0.17494853f, -0.00033609f, 0.00315847f, -0.04326280f, 
    -0.07324740f, 0.09101202f, 0.07296732f, -0.02254301f, 0.06942855f, 0.11801916f, 0.06807183f, 0.18808243f, 
    0.14326161f, 0.33580357f, -0.57508761f, -0.33692038f, 0.07474980f, -0.17242499f, 0.08265569f, -0.08262192f, 
    -0.20730612f, -0.04370784f, -0.13426147f, -0.17847675f, 0.55360860f, 0.11561404f, 0.11909945f, 0.01666283f, 
    -0.13539319f, 0.00632945f, 0.07002540f, 0.33403918f, -0.02015488f, 0.22990333f, -0.10332232f, 0.05814447f, 
    -0.05120721f, -0.17728744f, -0.12586477f, 0.30012438f, -0.12467010f, 0.02974394f, 0.02130480f, 0.08280594f, 
    -0.15111823f, 0.19696790f, -0.08392680f, 0.00107491f, 0.18748808f, -0.36050615f, 0.10495141f, 0.05985178f, 
    0.13886069f, 0.11524279f, -0.20233026f, -0.09742478f, -0.07734879f, -0.06868902f, 0.18521003f, 0.14570385f, 
    -0.14969380f, -0.09445675f, -0.03157249f, 0.05886362f, 0.13189030f, 0.01706850f, 0.08581588f, -0.17437750f, 
    0.11202325f, -0.04250709f, 0.02916685f, 0.06185964f, 0.10028385f, -0.37526700f, -0.10824910f, 0.01300505f, 
    0.05372653f, -0.15964670f, 0.02712640f, 0.06254150f, 0.02890493f, 0.08377399f, 0.08974010f, -0.17708278f, 
    -0.50043482f, -0.60735869f, -0.22304745f, -0.12839977f, 0.18275751f, 0.12285423f, -0.04725542f, -0.05315653f, 
    0.16570464f, 0.01878605f, -0.04265319f, 0.15225849f, -0.18771516f, 0.19109848f, -0.09963950f, 0.01655331f, 
    0.15406814f, 0.14288396f, 0.02024038f, -0.07298163f, 0.10657793f, -0.02425570f, 0.16236030f, -0.03856831f, 
    -0.71661061f, 0.47194305f, -0.23037191f, -0.27002829f, 0.09938889f, 0.02262066f, 0.00501503f, 0.04440847f, 
    -0.10139469f, 0.04749005f, -0.09314297f, -0.10665316f, -0.45395955f, 0.11615512f, -0.14722385f, -0.08755983f, 
    -0.05560739f, 0.03275525f, -0.15099744f, -0.04701062f, -0.09860086f, 0.03181710f, 0.20318738f, 0.18951809f, 
    -0.24924457f, -0.17945772f, 0.01715175f, 0.16460103f, 0.09261198f, 0.08538959f, -0.15622364f, -0.00702675f, 
    0.07848082f, -0.08366363f, -0.14425960f, 0.02739829f, -0.09518126f, 0.54265314f, -0.52529460f, -0.11496204f, 
    0.19162992f, -0.13214527f, -0.10644794f, 0.12561020f, -0.01443495f, 0.12093452f, 0.02701682f, -0.16712046f, 
    0.19386534f, -0.34289491f, 0.02699210f, 0.25194192f, -0.04894342f, -0.03021307f, 0.11276988f, 0.10096039f, 
    -0.04385501f, -0.06774405f, 0.16828837f, -0.06382413f, 0.27974719f, 0.00132073f, 0.07014625f, -0.02012263f, 
    0.00851493f, 0.03672143f, 0.12179545f, -0.01326959f, -0.00734205f, 0.03166876f, -0.16255690f, 0.05992427f, 
    0.20066078f, -0.05483219f, 0.09612206f, 0.04000296f, 0.05342826f, 0.33768997f, 0.11216347f, -0.09072077f, 
    0.09282537f, 0.05420983f, 0.07384057f, -0.01756949f, -0.08250149f, -0.42643118f, 0.08187547f, -0.05221571f, 
    0.04514090f, 0.10206903f, 0.12757936f, -0.01473931f, 0.00597860f, -0.18118808f, -0.04763840f, -0.08452357f, 
    -0.66366899f, -0.48735073f, -0.07433231f, 0.00887553f, 0.12250881f, 0.04024462f, 0.06236180f, -0.10980616f, 
    0.12439401f, -0.02056502f, 0.00131533f, 0.04272097f, 0.26901591f, 0.21183826f, -0.29223576f, -0.07476217f, 
    -0.00474193f, -0.14554471f, 0.00408719f, -0.01168106f, 0.14565790f, -0.04760523f, -0.07233522f, -0.05806359f, 
    -0.50721157f, 0.03652935f, -0.06091268f, -0.32771984f, 0.05740102f, 0.06452160f, 0.12031347f, 0.11454908f, 
    0.15292735f, 0.01097775f, 0.01204282f, 0.14964931f, 0.05842711f, -0.09399999f, -0.14316069f, -0.00613540f, 
    -0.04145699f, -0.02024006f, -0.12631716f, -0.00155826f, -0.11243004f, 0.02307410f, -0.00748912f, -0.08706495f, 
    -0.32589546f, -0.11811698f, -0.05911953f, 0.08347002f, 0.19554541f, -0.09780972f, -0.01081800f, 0.17491922f, 
    0.05281480f, 0.13252188f, -0.05562606f, 0.06660485f, -0.24209085f, -0.15775293f, 0.03078385f, -0.10291728f, 
    0.08550460f, 0.00656686f, 0.04682454f, 0.06604877f, 0.13789541f, 0.15378670f, 0.02687378f, 0.32991385f, 
    -0.66883695f, 0.00763269f, 0.36296669f, 0.04609755f, 0.17745978f, -0.04582071f, -0.10103996f, -0.08068704f, 
    -0.15386635f, 0.00601724f, 0.00205837f, 0.00563294f, 0.07310050f, -0.00599384f, -0.13663988f, 0.13800356f, 
    0.05362129f, -0.05859653f, 0.03485596f, 0.12855728f, -0.02703577f, -0.05100946f, 0.07604033f, -0.04621125f, 
    -0.27963585f, -0.00900857f, -0.22608441f, -0.05662065f, -0.00146277f, -0.00705694f, -0.16955292f, 0.17522097f, 
    0.12334633f, 0.14752325f, 0.05620876f, 0.16519998f, 0.15625390f, -0.02575652f, -0.16578084f, -0.09562818f, 
    -0.08357523f, 0.02279933f, 0.04765107f, -0.04840124f, 0.07190468f, 0.25644493f, 0.19201569f, -0.10497437f, 
    0.19283780f, 0.12778535f, 0.03889357f, 0.07900229f, 0.01578934f, -0.14514078f, 0.09050982f, 0.06573626f, 
    0.02444285f, -0.10275559f, -0.30591357f, -0.06250528f, 0.15967645f, 0.11274444f, -0.05284997f, 0.00579386f, 
    -0.06255087f, 0.05083434f, 0.02942987f, 0.04015306f, -0.03173119f, 0.05711968f, 0.15426371f, 0.05224702f, 
    0.12126841f, -0.28759620f, 0.20180178f, -0.05627716f, 0.11243334f, 0.01978133f, 0.15145491f, 0.09340462f, 
    0.14056532f, 0.23189941f, -0.17017092f, 0.05140020f, -0.12076153f, 0.21618509f, 0.14676395f, -0.16565944f, 
    0.15550858f, 0.11821771f, -0.16574106f, -0.03020912f, -0.08416295f, -0.10644700f, -0.11189315f, 0.07491098f, 
    0.38804838f, 0.20536067f, 0.29263228f, -0.03003395f, 0.09572641f, -0.05349220f, 0.09565160f, -0.08308931f, 
    -0.03853476f, 0.21132749f, 0.12370048f, 0.14485824f, -0.24293675f, 0.13352068f, -0.16714525f, 0.05191011f, 
    -0.01857754f, -0.08848391f, 0.00990950f, -0.06975091f, 0.01502394f, -0.15097886f, -0.00078579f, -0.18580008f, 
    -0.25621286f, -0.27898952f, -0.18280293f, -0.40658233f, -0.04598255f, -0.13909511f, 0.03551253f, 0.08948089f, 
    -0.07204521f, 0.19459580f, 0.19053300f, 0.08919401f, -0.68274647f, -0.39859146f, 0.30727622f, 0.11365100f, 
    0.17733712f, 0.03863017f, -0.12253563f, -0.26239622f, 0.10639733f, -0.01492369f, -0.01867083f, 0.02306308f, 
    0.07642436f, 0.07091438f, 0.02194921f, -0.15060340f, 0.01225889f, 0.29908574f, 0.10727621f, 0.07656453f, 
    -0.02109416f, -0.04744551f, 0.04369310f, -0.11359068f, -0.45775920f, 0.27366307f, -0.05189233f, 0.03166915f, 
    0.03529990f, 0.04417980f, 0.14367856f, -0.06868456f, 0.05613571f, 0.07418054f, -0.12254456f, 0.11924333f, 
    -0.37986949f, -0.18117936f, -0.20137915f, -0.07123144f, 0.13480292f, 0.08301549f, -0.04956846f, 0.03584476f, 
    -0.10918916f, -0.16106273f, -0.11073290f, 0.13707422f, 0.22274785f, 0.13111356f, -0.02112938f, -0.21968280f, 
    -0.25210619f, 0.15210357f, -0.02896609f, -0.03672213f, 0.10472842f, -0.03623503f, -0.19913404f, -0.09637468f, 
    0.34545809f, -0.01251892f, -0.16736247f, 0.03377608f, -0.08445872f, -0.07070934f, 0.03265524f, 0.01184173f, 
    0.06596731f, 0.15141970f, -0.08364587f, 0.04696028f, -0.53320205f, -0.36064178f, -0.01557374f, -0.09207147f, 
    0.21912313f, 0.05490702f, 0.03678461f, -0.03536610f, 0.17767872f, 0.07387847f, -0.03203993f, 0.12228315f, 
    -0.92018783f, -0.61146897f, -0.27253941f, -0.36025366f, -0.04870090f, -0.20747064f, -0.13572444f, -0.00600145f, 
    0.10626926f, 0.00880708f, 0.01412114f, 0.09105056f, -0.44079190f, -0.46199360f, 0.04315567f, 0.12728660f, 
    0.02715782f, 0.02781021f, 0.13594632f, 0.13244389f, -0.04060905f, -0.12667567f, -0.09085238f, 0.08915802f, 
    0.15749492f, -0.08448636f, 0.05583109f, -0.32607734f, 0.17308509f, 0.01614403f, -0.00412661f, -0.27592641f, 
    -0.21691664f, 0.03506280f, 0.04303763f, -0.03346800f, 0.22971286f, 0.15131263f, -0.00800752f, 0.01550725f, 
    0.14391328f, -0.05110437f, 0.22834679f, 0.07702579f, 0.07542625f, 0.06563085f, 0.16017964f, 0.18316659f, 
    -0.78916055f, -0.16418390f, -0.28541672f, -0.25305223f, 0.24237749f, -0.09781867f, -0.18584043f, -0.02498700f, 
    -0.01560978f, 0.04569741f, -0.08128937f, -0.07725079f, 0.05672838f, -0.11019217f, -0.08036851f, 0.05423698f, 
    0.00539248f, -0.13801765f, -0.13673122f, 0.00075273f, -0.07610291f, -0.01056547f, 0.04803569f, 0.07704298f, 
    0.18926358f, 0.16919629f, -0.26138377f, 0.18439122f, 0.01867723f, -0.20697296f, -0.02489886f, -0.01371832f, 
    0.07642310f, 0.11518004f, -0.12446418f, 0.05706679f, -0.01591205f, 0.13201001f, -0.09161884f, -0.09631576f, 
    0.08186629f, -0.06133895f, 0.01770384f, 0.15151913f, -0.00432184f, 0.17162615f, -0.01411731f, -0.14020360f, 
    0.35393885f, -0.27093813f, -0.16320799f, 0.20531282f, 0.14532617f, -0.17616245f, -0.08608305f, -0.04830553f, 
    0.12357484f, 0.01418230f, -0.05391571f, 0.11420029f, -0.21329363f, -0.33174476f, 0.18438667f, -0.04447129f, 
    -0.17463706f, 0.05528278f, -0.11723782f, 0.13060825f, -0.20799178f, 0.01964244f, 0.03867549f, 0.06263612f, 
    0.45670775f, 0.26078337f, -0.45957252f, 0.09957696f, -0.03201161f, -0.04714540f, 0.02423442f, 0.03410077f, 
    0.13927990f, 0.08020828f, -0.03054596f, -0.08044163f, -0.47843766f, 0.13659844f, -0.06688330f, -0.18470183f, 
    0.26887435f, -0.04598433f, 0.08985434f, -0.08972391f, -0.17965195f, 0.05056153f, -0.15699157f, -0.07482164f, 
    0.03950034f, 0.07974902f, 0.15436944f, 0.44961873f, -0.01518662f, 0.08154379f, -0.01531830f, 0.13103551f, 
    0.06366247f, -0.06441862f, 0.06961804f, 0.08066556f, -0.06098104f, 0.05867197f, -0.22656123f, 0.20738906f, 
    0.07949933f, 0.09801289f, 0.01170029f, 0.01057240f, -0.01587641f, -0.06647204f, -0.06542914f, -0.16469987f, 
    0.83914387f, 0.16246668f, -0.19476274f, -0.11511324f, 0.09133466f, -0.14338495f, -0.03503076f, -0.00262269f, 
    0.13736272f, 0.14314507f, 0.04515122f, 0.14885442f, 0.16406542f, -0.26677579f, 0.15331155f, 0.04657879f, 
    0.14668880f, 0.05515300f, 0.02140846f, -0.05462195f, 0.14172919f, 0.06919412f, -0.07401824f, 0.06762259f, 
    -0.30602041f, -0.01664845f, -0.11388076f, -0.02006667f, 0.08314154f, -0.15090814f, -0.04474238f, 0.09269039f, 
    0.01006937f, -0.09010848f, -0.04091357f, 0.00544187f, 0.04835965f, -0.18408588f, -0.21970442f, 0.12300064f, 
    -0.16433965f, 0.21404250f, -0.05450379f, -0.02825710f, -0.08353327f, -0.07574061f, 0.00984921f, -0.14252898f, 
    -0.23276424f, 0.02955872f, -0.07289465f, -0.25014421f, -0.08843846f, 0.06811389f, 0.04342715f, -0.04641486f, 
    -0.19179808f, 0.10152151f, -0.08393127f, -0.03587734f, 0.03535956f, 0.18987776f, 0.18708080f, -0.04605376f, 
    -0.10030109f, 0.00500789f, -0.00614480f, -0.21851340f, 0.04494536f, -0.07662519f, 0.09360359f, -0.06923901f, 
    0.32137960f, 0.09419394f, -0.11916810f, -0.20493230f, 0.23778071f, -0.04503031f, -0.03267334f, 0.02294695f, 
    0.11303538f, -0.07971197f, 0.14020787f, 0.04816303f, -0.03674586f, 0.09978000f, -0.01538462f, -0.28915110f, 
    0.16921894f, -0.08151338f, -0.23338139f, -0.01152007f, 0.13310330f, 0.03923808f, 0.15229018f, 0.00864769f, 
    0.22124706f, -0.06132123f, -0.21221013f, -0.08045159f, 0.04161659f, 0.06981179f, 0.01112240f, 0.14941600f, 
    0.07838891f, -0.11396432f, 0.03994779f, 0.02408261f, 0.08712995f, -0.27924031f, -0.23597302f, -0.04620688f, 
    0.04635571f, 0.02133812f, -0.12409071f, -0.07923437f, 0.06143946f, -0.05383882f, -0.02729231f, 0.10820380f, 
    0.00637141f, -0.26647720f, -0.03116394f, -0.08831733f, 0.04733993f, 0.18477996f, 0.05247727f, -0.09405569f, 
    -0.05557405f, 0.00712876f, -0.16009010f, -0.11771291f, -0.00180121f, 0.15702428f, -0.14603053f, 0.04936141f, 
    0.03191832f, -0.10106097f, -0.04328649f, -0.01064821f, -0.21736318f, -0.13718723f, -0.08449980f, -0.12450475f, 
    -0.64964014f, 0.41741505f, -0.08261032f, 0.07934471f, 0.09516417f, -0.15382464f, 0.01446866f, -0.14070389f, 
    -0.08617330f, 0.05845320f, 0.08442596f, -0.06288229f, 0.17358124f, 0.08126580f, 0.11853355f, 0.08970265f, 
    -0.33110934f, 0.11236178f, -0.14032687f, 0.14965996f, 0.02963043f, -0.06197890f, 0.19338831f, -0.07795168f, 
    -0.54273611f, 0.00773322f, -0.03165006f, -0.26879403f, 0.17301218f, 0.16277958f, 0.02304422f, -0.01068646f, 
    0.13634329f, -0.00046064f, -0.06912941f, -0.18494453f, -0.20595531f, -0.04131609f, -0.11993241f, 0.12643996f, 
    -0.24194448f, -0.09196503f, -0.00782051f, -0.01247891f, -0.17269710f, 0.00416879f, 0.04828767f, -0.25999263f, 
    0.01112512f, 0.04413762f, -0.00890621f, -0.00118279f, -0.02611636f, -0.13964783f, 0.08555282f, -0.00394021f, 
    -0.15406798f, 0.03408502f, -0.05698804f, -0.08487632f, 0.04358913f, 0.01286091f, -0.06933738f, -0.24660671f, 
    0.07038591f, 0.04309266f, -0.02912145f, 0.04981613f, -0.00083580f, -0.13886052f, 0.15036330f, -0.03850910f, 
    0.28012526f, -0.28979200f, -0.03516433f, -0.07240852f, 0.16549654f, 0.01321884f, 0.05164299f, -0.10917433f, 
    0.00882691f, -0.06925137f, -0.03712584f, -0.03040471f, -0.28883141f, 0.19293554f, -0.05477243f, -0.19437768f, 
    0.05356875f, -0.02527913f, -0.14812507f, 0.07802637f, 0.13923267f, -0.00920133f, -0.05585311f, -0.01274547f, 
    0.19295587f, 0.24398862f, -0.05108522f, -0.01756909f, -0.10444373f, -0.11017921f, -0.19790214f, -0.03110692f, 
    0.04063420f, -0.02167128f, -0.01144233f, -0.21541610f, 0.16450818f, -0.09977970f, 0.04985049f, 0.44677657f, 
    -0.02883667f, 0.01851042f, -0.01385659f, 0.00208788f, -0.05304630f, 0.01194943f, -0.03524334f, 0.05892994f, 
    -0.58400404f, -0.10988338f, -0.02915322f, -0.27113497f, -0.14341243f, 0.05650616f, -0.04689457f, 0.17377758f, 
    -0.01310416f, -0.00794689f, 0.03048308f, 0.13774469f, -0.18364008f, 0.27768853f, -0.02960863f, -0.12778589f, 
    -0.02477978f, 0.05033946f, 0.01723656f, -0.08083042f, -0.04791027f, 0.15162273f, 0.02661597f, 0.06696023f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.09965335f, 0.03816653f, -0.10229703f, -0.03179752f, -0.00421003f, 0.02561287f, -0.04247940f, -0.09238309f, 
    -0.01091428f, 0.00173370f, 0.16419379f, 0.00953558f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
