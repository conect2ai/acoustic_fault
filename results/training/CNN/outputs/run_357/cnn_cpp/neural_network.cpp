#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.30505961f, -0.49519911f, -0.34397405f, 0.41745308f, -0.14170563f, 0.45659995f, -0.10666820f, 0.24981612f, 
    0.17299807f, -0.19041699f, -0.18670581f, -0.19997382f, -0.08156830f, 0.20109464f, 0.10042918f, -0.32113171f, 
    0.16384129f, 0.04089277f, 0.02968575f, -0.34630564f, -0.23340052f, -0.27474400f, -0.30001760f, -0.30268186f, 
    -0.08307001f, -0.13291670f, 0.14252567f, -0.43881604f, -0.47929415f, -0.10263962f, 0.12688905f, -0.35174572f, 
    -0.37222159f, 0.04129066f, -0.42474884f, -0.26846448f, 0.10610519f, 0.34191170f, 0.15874191f, -0.09593721f, 
    0.26291591f, 0.30568504f, 0.15743102f, 0.14653344f, 0.25875127f, 0.16555390f, -0.09294140f, 0.18927468f, 
    0.20096032f, -0.11900073f, -0.49801794f, -0.92773569f, -0.36922362f, 0.34138706f, 0.40974948f, -0.44429663f, 
    0.67847359f, 0.40271747f, -0.24214646f, 0.03892787f, 0.18679407f, 0.00059050f, 0.02439736f, 0.00172292f, 
    0.17293639f, -0.04690805f, 0.10431303f, -0.08156905f, -0.03252151f, -0.02319043f, 0.06476050f, 0.04345051f, 
    0.02121801f, 0.02036000f, 0.04943106f, -0.39527124f, -0.42342523f, 0.29976496f, -0.31001911f, -0.56317031f, 
    -0.23475344f, -0.12606589f, 0.52567202f, 0.13351758f, -0.31240761f, 0.07437706f, 0.10351790f, -0.10571975f, 
    0.33319080f, -0.07991012f, 0.30422959f, -0.11718059f, 0.01920502f, 0.04369268f, -0.08322375f, -0.12056632f, 
    -0.25692600f, -0.06331161f, -0.17018324f, 0.06657922f, 0.51318634f, 0.51737773f, 0.72940886f, 0.52023679f, 
    0.10142981f, -0.48312947f, 0.00055947f, -0.42288896f, 0.39651984f, -0.06067833f, 0.31316081f, -0.03976337f, 
    -0.10748640f, 0.09980343f, 0.12603039f, 0.18424323f, -0.01270778f, -0.11041479f, 0.06854519f, -0.19213574f, 
    0.12772806f, 0.02528197f, 0.08770670f, 0.03331199f, 0.05929900f, 0.83289808f, 0.26584977f, 0.16748656f, 
    0.57109791f, 0.52545422f, 0.58188063f, 0.10568863f, 0.06159479f, 0.14109276f, -0.02785352f, 0.00355149f, 
    0.08443830f, -0.05301582f, -0.05799292f, -0.10738379f, -0.07857384f, -0.00731548f, 0.10045589f, -0.10833078f, 
    -0.08951763f, -0.00364501f, 0.19064194f, 0.24426685f, 0.04532426f, 0.11598226f, -0.31047943f, -0.40442723f, 
    -0.24507366f, 0.01779253f, -0.34164396f, -0.33080590f, 0.12726240f, 0.22700249f, -0.45475167f, 0.13478290f, 
    -0.35408753f, -0.18441811f, -0.36842617f, 0.07331336f, -0.39406830f, -0.17784035f, -0.17438047f, -0.01926981f, 
    -0.14502233f, 0.12827092f, -0.10066003f, 0.31806743f, -0.18201527f, 0.35950243f, 0.19790301f, 0.77218395f, 
    0.59535491f, 0.18802805f, -0.57401133f, -0.36931354f, 0.20840718f, 0.28331947f, 0.17452168f, -0.16343188f, 
    0.00930363f, 0.36909285f, 0.22127119f, -0.10768149f, 0.14757252f, -0.25398758f, 0.24460751f, 0.02326563f, 
    0.02544970f, 0.19507711f, 0.02421539f, 0.07175693f, 0.16738999f, 0.01096642f, -0.12596942f, 0.21847843f, 
    0.18617281f, 0.54484689f, 0.28472474f, -0.04598361f, 0.03158464f, 0.54696101f, 0.06603628f, -0.74814761f, 
    -0.67083675f, -0.34783241f, 0.00801020f, -0.01760174f, 0.01389979f, 0.09848658f, -0.36672306f, -0.12918004f, 
    -0.16794734f, 0.04068662f, -0.04136130f, -0.15540031f, 0.00699559f, 0.07209223f, 0.08553512f, -0.16412914f, 
    -0.01733404f, 0.68425971f, 0.61779326f, 0.05117833f, 0.02916046f, 0.09455526f, -0.14324158f, -0.10621079f, 
    -0.03351925f, -0.06433763f, -0.03232501f, -0.03803517f, 0.17124760f, 0.00588843f, 0.09185511f, 0.35273752f, 
    0.12035853f, 0.07000392f, 0.18067515f, 0.17152050f, 0.25182325f, -0.08955846f, -0.23365396f, -0.23493880f, 
    0.06501320f, 0.11176728f, 0.83044511f, 0.02550688f, 0.26159245f, -0.01449240f, -0.22509053f, 0.10488052f, 
    -0.59968638f, 0.38378391f, 0.53079849f, 0.23007710f, -0.22160850f, 0.03583396f, -0.15443876f, -0.24402015f, 
    -0.01680285f, -0.19099447f, 0.03799639f, 0.08901938f, -0.02033764f, -0.19088565f, 0.11902998f, 0.11510821f, 
    0.00652908f, 0.18321691f, 0.12035057f, 0.00431854f, 0.19858082f, 0.20038468f, 0.22294295f, -0.05975053f, 
    -0.56772107f, -0.28544143f, -0.60975516f, -0.19328383f, -0.25338241f, 0.35119489f, 0.23573302f, -0.07946793f, 
    0.23074394f, -0.34624657f, 0.00543546f, 0.14958273f, 0.17467132f, -0.05819520f, 0.03320830f, -0.06099825f, 
    -0.07595091f, -0.06773292f, 0.34817046f, -0.22284493f, 0.62157142f, 0.51215023f, 0.22118323f, 0.27441269f, 
    -0.39027867f, -0.39920986f, -0.70111585f, 0.15438950f, -0.18646017f, 0.07911235f, -0.12973668f, 0.13553338f, 
    0.20593084f, 0.06975367f, 0.08068513f, 0.06277221f, -0.21314853f, -0.13516672f, 0.07440752f, 0.24296658f, 
    0.15204944f, 0.39096245f, 0.05363448f, -0.09241610f, -0.08272770f, -0.64991015f, 0.75271314f, 0.42748183f, 
    -0.12288689f, 0.13949808f, -0.71187216f, 0.58975053f, -0.01862402f, -0.23370160f, -0.07097495f, -0.25265181f, 
    0.04094288f, 0.05189444f, -0.00385115f, 0.07292008f, 0.08560883f, -0.08269265f, 0.01164747f, -0.04544653f, 
    -0.04692404f, -0.03997255f, -0.00017450f, 0.04950647f, 0.11235844f, -0.02608756f, -0.34130916f, -0.69506413f, 
    -0.65230715f, -0.44541088f, -0.25304529f, 0.55394495f, 0.68627214f, 0.13770455f, 0.18750237f, 0.17406961f, 
    -0.04421519f, 0.06341299f, 0.17784515f, -0.03589501f, -0.14992875f, -0.19655086f, 0.11076041f, 0.32589683f, 
    -0.01566130f, -0.06701525f, -0.05473184f, -0.20897895f, 0.03338872f, 0.06587183f, 0.11365595f, 0.28816795f, 
    0.61805290f, -0.17478035f, -0.38920975f, -0.24340755f, -0.33864838f, -0.06528201f, -0.27810362f, -0.15701891f, 
    0.25071403f, -0.22109161f, -0.09089067f, -0.11044782f, 0.03635849f, 0.20830965f, -0.42776468f, -0.17806830f, 
    0.12339813f, -0.31527302f, -0.40064552f, 0.22199932f, 0.13561784f, 0.07951862f, 0.10640442f, -0.21003456f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.00890496f, 0.11349953f, 0.06687269f, 0.16163349f, 0.09033078f, 0.16846745f, 0.06531673f, -0.02667199f, 
    0.09066007f, -0.01824572f, 0.09319489f, 0.18763497f, 0.09148405f, -0.06265023f, 0.18008871f, 0.06627104f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.18263723f, 0.06806185f, -0.08020726f, 0.06189583f, -0.07485876f, 0.00814561f, 0.20556575f, 0.06296287f, 
    0.05011155f, 0.02079606f, 0.14236796f, 0.17263056f, 0.19561192f, 0.09703077f, -0.01439623f, 0.22634466f, 
    -0.01250083f, 0.05617565f, 0.06796703f, 0.08761547f, -0.05525642f, -0.08028484f, -0.09547258f, 0.01148233f, 
    -0.16821903f, 0.03981300f, 0.00993872f, 0.19749568f, 0.10475467f, 0.08851594f, 0.04896710f, 0.02165496f, 
    -0.00882727f, 0.02970986f, -0.09261750f, 0.01429224f, 0.34972969f, 0.00233384f, 0.15563492f, -0.07985464f, 
    -0.03403685f, -0.03188487f, 0.07782223f, -0.03114845f, -0.02467713f, 0.06015338f, -0.07900129f, -0.11390604f, 
    -0.16007899f, -0.04370419f, 0.08634069f, -0.10387383f, -0.05779838f, -0.01452230f, -0.06539937f, 0.02952641f, 
    0.03081843f, 0.11019509f, 0.07901496f, -0.10853020f, -0.05229358f, -0.00851027f, -0.29657254f, -0.22689177f, 
    0.05803556f, -0.08566786f, -0.01167669f, 0.06647328f, -0.09789672f, 0.00851585f, -0.01122130f, -0.00168077f, 
    0.04658417f, 0.03985639f, 0.02306043f, 0.15059398f, 0.12134511f, 0.01548262f, -0.04766064f, 0.12060701f, 
    -0.17700252f, -0.02643992f, -0.01893321f, 0.09983106f, -0.18808141f, -0.18543263f, 0.27547732f, -0.08802474f, 
    -0.04445217f, 0.02692639f, 0.01687106f, 0.06348814f, 0.14015329f, 0.14225808f, -0.07897756f, -0.06972989f, 
    0.02256510f, 0.20993470f, 0.00485505f, -0.15028125f, 0.04088009f, 0.09287383f, 0.01274816f, 0.07847174f, 
    -0.04734456f, 0.00216024f, 0.06804282f, -0.00107233f, -0.16307354f, -0.04209952f, -0.05647711f, 0.03399204f, 
    -0.05935493f, -0.07707270f, 0.03301838f, -0.02783806f, 0.17055883f, 0.01236879f, 0.01016614f, -0.19849612f, 
    -0.08726875f, -0.06661729f, 0.11763372f, -0.11834648f, -0.06658430f, 0.06114608f, 0.10433061f, 0.00449021f, 
    -0.05571721f, 0.14559899f, -0.05028694f, 0.07365452f, 0.00789626f, 0.01186049f, 0.27658829f, -0.00914821f, 
    0.04568239f, 0.10053242f, -0.07374678f, 0.08497182f, 0.08450009f, 0.10973943f, -0.05069323f, -0.15534477f, 
    -0.00332923f, -0.20444953f, 0.02941821f, 0.08869494f, -0.02792663f, 0.01222503f, -0.03970335f, -0.00282331f, 
    0.10140584f, 0.04065626f, -0.04953535f, 0.05317159f, -0.04406408f, 0.03146280f, 0.07965365f, 0.12461525f, 
    -0.03111808f, -0.07626420f, 0.09662602f, 0.03321233f, 0.05173712f, -0.01634182f, 0.06556784f, 0.01850832f, 
    -0.11530603f, 0.11925913f, 0.06888599f, 0.22601792f, 0.08155826f, -0.10738731f, 0.00978960f, 0.10600042f, 
    -0.06765821f, 0.07762291f, 0.06275897f, -0.01385426f, 0.04151994f, -0.04061518f, 0.17786434f, 0.14038749f, 
    -0.01575934f, -0.03239134f, -0.03043922f, -0.08387242f, 0.10987177f, 0.19627544f, -0.03469955f, 0.18843958f, 
    0.06211207f, -0.06853274f, -0.00966146f, 0.15625726f, 0.05341994f, -0.07200740f, -0.03502685f, -0.02554923f, 
    0.09773388f, 0.00644842f, 0.07141504f, 0.00552668f, -0.03947373f, 0.10702508f, 0.02521028f, 0.11251133f, 
    -0.03996210f, 0.17908491f, 0.16798940f, 0.12988022f, -0.02053152f, -0.05317561f, -0.02676144f, -0.00657407f, 
    0.40620172f, -0.08361137f, 0.08909772f, 0.21821788f, -0.07187954f, 0.08780420f, 0.03703326f, -0.00342100f, 
    0.07362208f, 0.01196361f, 0.13487166f, -0.06115858f, -0.18998483f, 0.25402689f, -0.13021199f, 0.05171303f, 
    0.02665577f, 0.01841601f, 0.03904932f, -0.04875363f, -0.00587486f, -0.09313545f, 0.08468312f, 0.09032378f, 
    0.19177583f, 0.22463508f, 0.21536872f, -0.22734685f, -0.02421815f, -0.12410177f, 0.01144958f, -0.00816315f, 
    0.05692794f, 0.03737520f, 0.05489783f, -0.00580080f, -0.07097118f, 0.06073591f, -0.07908276f, -0.07223905f, 
    -0.03971807f, 0.01067081f, -0.01618191f, 0.11739507f, -0.01100978f, 0.15674265f, 0.02968780f, 0.02613119f, 
    -0.10575642f, 0.06774491f, -0.07208145f, -0.07174014f, -0.16101561f, 0.09570213f, -0.15610246f, -0.15736938f, 
    0.03710444f, 0.14617015f, 0.13957411f, 0.01943805f, 0.06678548f, -0.16648042f, -0.04308264f, 0.11945986f, 
    0.06544928f, 0.04438426f, 0.07682573f, 0.02741581f, -0.02794608f, -0.04315835f, 0.02850348f, -0.05425268f, 
    0.05929039f, 0.00627376f, -0.16262889f, -0.23160009f, -0.08396670f, 0.02617750f, 0.02267251f, -0.00553598f, 
    0.07603581f, 0.12355418f, -0.02115831f, -0.05382440f, 0.21337330f, 0.15506715f, 0.01303471f, 0.17375693f, 
    0.09259942f, -0.12795718f, -0.05116466f, 0.09886957f, 0.17410007f, -0.03199574f, -0.14366353f, -0.05057402f, 
    -0.07667921f, 0.15944967f, 0.17044716f, 0.02651083f, 0.02199216f, 0.00459997f, -0.02296579f, 0.11865267f, 
    0.05570839f, -0.09672714f, -0.04443640f, -0.12358730f, -0.03193192f, 0.00660463f, -0.02692717f, -0.11112480f, 
    0.03682044f, -0.00565813f, -0.02435757f, 0.04786857f, -0.01650324f, 0.16647506f, -0.11969060f, -0.06721451f, 
    -0.34239346f, 0.12824982f, 0.09255624f, 0.01303569f, -0.06472855f, -0.06889232f, 0.08933912f, 0.12927042f, 
    -0.06038238f, -0.04406298f, 0.08534093f, 0.03334993f, 0.15629698f, -0.28304836f, -0.14525153f, -0.25736243f, 
    0.06311259f, 0.00195582f, 0.02428231f, -0.04424306f, 0.00048119f, 0.01122879f, 0.05950822f, -0.01748136f, 
    0.22165357f, -0.17884408f, 0.00126604f, 0.08959086f, 0.06239254f, 0.10224617f, -0.03318414f, 0.00489255f, 
    -0.07023859f, 0.13069430f, 0.01019754f, 0.11437738f, 0.13449137f, 0.11184993f, 0.02759493f, -0.03128525f, 
    -0.05587546f, -0.07697031f, 0.00296286f, 0.13815145f, 0.02151129f, 0.04386884f, -0.06163862f, 0.10385104f, 
    -0.19725987f, -0.05882331f, 0.05573721f, -0.12472443f, 0.02005515f, 0.12286222f, -0.01152250f, -0.02816731f, 
    0.07780407f, 0.00717765f, 0.13204555f, 0.10140367f, 0.04370326f, -0.10444972f, -0.03812366f, -0.06779261f, 
    -0.04493074f, 0.03712783f, -0.04182328f, -0.18678777f, 0.04887172f, -0.02763274f, -0.05214774f, -0.05633697f, 
    -0.51670921f, 0.00230354f, -0.08039404f, -0.02388872f, 0.04438777f, -0.03059058f, 0.07389313f, -0.08059914f, 
    0.08516239f, -0.11102659f, 0.10637328f, -0.03305537f, -0.08086350f, -0.15033355f, -0.02020757f, 0.08607063f, 
    0.03733409f, -0.03217975f, 0.04889528f, -0.06178831f, 0.09117439f, -0.02872166f, 0.08463753f, -0.03068553f, 
    0.09422922f, 0.14130075f, 0.23242852f, 0.20253733f, 0.02740539f, 0.01371003f, 0.01726105f, 0.00186511f, 
    0.02325143f, 0.03880507f, 0.05367325f, 0.07443035f, -0.00426646f, 0.12036455f, 0.05620558f, 0.09414776f, 
    -0.07113951f, -0.07811590f, -0.01717887f, -0.03010046f, 0.16113979f, 0.02770778f, 0.05609099f, 0.02869068f, 
    -0.18487726f, 0.04229919f, 0.12035386f, -0.16028975f, -0.00492842f, 0.14071386f, 0.23787203f, 0.03683456f, 
    -0.06653666f, -0.07993630f, -0.04818657f, 0.01389229f, 0.17244987f, 0.24593888f, -0.09332290f, 0.21051718f, 
    -0.00280516f, 0.02086127f, -0.05649771f, 0.02582226f, 0.06995225f, -0.09134274f, 0.00916549f, -0.04747256f, 
    0.22941767f, -0.07669716f, 0.01150752f, 0.24383296f, 0.11158486f, 0.09160078f, -0.01220856f, 0.00169585f, 
    0.06030981f, -0.07146443f, 0.14516419f, 0.12051076f, 0.10886522f, 0.15519103f, 0.05219203f, 0.06059814f, 
    -0.03769198f, 0.02406871f, -0.04824293f, 0.05110718f, -0.04620963f, -0.05035475f, 0.06431367f, 0.07225665f, 
    -0.05950242f, 0.00771073f, -0.00359798f, 0.05623572f, 0.11853422f, -0.08613090f, 0.01398423f, 0.04628475f, 
    -0.03666661f, -0.02127510f, 0.06045935f, -0.04233052f, 0.03052352f, -0.00095540f, -0.04331851f, -0.01025243f, 
    0.00697771f, -0.00801676f, 0.04066963f, 0.10065132f, 0.03919150f, -0.05750458f, 0.05226073f, 0.15063857f, 
    0.24613446f, 0.01881524f, 0.12800279f, 0.11305993f, 0.02134493f, 0.09584139f, -0.04094027f, 0.03813430f, 
    0.11331134f, -0.00796557f, 0.10369963f, -0.02695631f, -0.18818568f, 0.08613516f, 0.21945351f, 0.10618623f, 
    -0.01426564f, -0.02934288f, -0.03573376f, 0.08020317f, -0.03069972f, 0.09231251f, 0.10301656f, 0.00790692f, 
    -0.30670139f, -0.27283952f, -0.22175287f, -0.06797499f, -0.07182812f, 0.06853003f, 0.03194319f, -0.05878343f, 
    0.00322406f, 0.10592565f, 0.03391034f, 0.06548972f, -0.01757041f, 0.10637493f, -0.12973915f, 0.02530547f, 
    0.06812277f, 0.01373597f, -0.05005171f, 0.09369855f, -0.06822109f, 0.03790811f, 0.08542994f, -0.06269806f, 
    -0.17222440f, 0.16671972f, -0.12689053f, -0.11431118f, 0.06255333f, -0.05342673f, -0.15078241f, -0.14202607f, 
    -0.11344651f, -0.04459075f, -0.12185141f, -0.06897146f, -0.18812484f, -0.15192881f, 0.07034129f, 0.10595490f, 
    0.02302710f, 0.06737920f, -0.02412559f, -0.06580171f, 0.15722416f, 0.07268208f, 0.10490657f, 0.00163193f, 
    -0.13730051f, -0.01115481f, -0.35415268f, -0.25224930f, 0.14291340f, 0.05798427f, 0.04225492f, 0.10842562f, 
    0.04595723f, 0.05984503f, 0.01086741f, -0.01884362f, -0.07451719f, -0.02236043f, -0.03549610f, 0.03966603f, 
    0.13522430f, 0.08865132f, -0.02673183f, -0.05201359f, -0.09450777f, 0.08003011f, -0.00083455f, 0.00511270f, 
    0.19909813f, 0.05118235f, 0.20026729f, 0.10899805f, 0.04490678f, 0.04929453f, 0.04717019f, 0.02656593f, 
    -0.08198871f, -0.02494768f, -0.11170319f, 0.14721955f, -0.04512672f, -0.00591862f, 0.09240586f, -0.15301125f, 
    0.05480311f, -0.01998206f, 0.10754311f, 0.01194977f, 0.05921675f, -0.00350625f, 0.07096953f, 0.04566092f, 
    0.00842841f, 0.20561540f, -0.15396488f, 0.20442407f, 0.16826679f, 0.03835715f, 0.07182626f, 0.19332395f, 
    0.09889971f, 0.00970117f, 0.01259580f, -0.08297443f, 0.01770487f, 0.02186505f, -0.02451272f, 0.07080340f, 
    -0.10355321f, 0.05938084f, 0.06175621f, -0.01357346f, 0.04310706f, -0.06723009f, 0.02755373f, 0.09490550f, 
    -0.16449155f, -0.01703670f, 0.13002090f, 0.18118891f, 0.05742817f, 0.20414422f, 0.03402954f, 0.01710794f, 
    0.07038648f, -0.02540073f, 0.03566669f, -0.06974329f, 0.11158043f, 0.09727002f, 0.11302840f, 0.08621447f, 
    -0.02548441f, 0.01346620f, -0.12580299f, -0.13510813f, -0.13237087f, -0.06145446f, -0.01180972f, 0.15695465f, 
    0.04069522f, -0.06382927f, 0.08012012f, 0.14894900f, -0.08114491f, 0.00885368f, -0.00705332f, -0.02260030f, 
    0.03937327f, -0.17454694f, 0.11718368f, 0.00731793f, 0.17166620f, 0.10077124f, 0.11343902f, 0.00948236f, 
    -0.04221183f, -0.06184757f, -0.00423686f, -0.08328158f, -0.00424817f, -0.08830365f, -0.02114880f, 0.26421630f, 
    -0.09330415f, 0.32633185f, 0.22797248f, 0.08453877f, -0.07409950f, -0.11432131f, 0.14408088f, 0.02277690f, 
    -0.06191214f, -0.02389959f, 0.05571796f, 0.05178748f, 0.06568306f, -0.11171601f, -0.20121726f, -0.02353923f, 
    0.00039075f, 0.01680426f, -0.00991232f, -0.02318299f, 0.08980919f, -0.05445465f, 0.09210356f, 0.00442785f, 
    -0.04888223f, -0.15178555f, -0.24881408f, 0.03669913f, 0.10607867f, 0.12768872f, 0.08814766f, -0.13600004f, 
    0.14461762f, 0.04408019f, 0.07755072f, -0.13010655f, -0.01640331f, -0.05941695f, -0.02195051f, 0.05568686f, 
    0.05021975f, 0.01643055f, 0.10911512f, 0.16713892f, 0.08666915f, -0.07853080f, -0.00329751f, -0.18307206f, 
    0.29102838f, 0.14009142f, 0.15296775f, 0.10418793f, 0.01647535f, -0.19517551f, -0.02293181f, -0.09725887f, 
    -0.10372067f, 0.14661685f, -0.25010794f, -0.09650470f, 0.21498173f, 0.14467728f, 0.05677317f, -0.03461997f, 
    0.04833876f, 0.05535397f, 0.09007346f, 0.02482144f, -0.10739704f, 0.10033075f, 0.01758831f, 0.09037576f, 
    0.00842557f, 0.10232825f, 0.03616864f, 0.06534196f, -0.00971754f, -0.01070144f, 0.10792062f, 0.06982101f, 
    -0.01904357f, 0.12626068f, 0.01346261f, 0.05311068f, 0.06344955f, -0.00989938f, 0.18136680f, -0.09971919f, 
    -0.04828045f, 0.02060038f, -0.03654856f, -0.01664817f, 0.00405748f, -0.07310694f, 0.09075250f, 0.01593119f, 
    -0.28128093f, -0.31594703f, -0.16798678f, -0.13767870f, 0.11851093f, 0.11163746f, 0.03579816f, 0.06865285f, 
    -0.09639795f, -0.01093760f, 0.02350695f, 0.13169427f, -0.27609771f, -0.30250195f, -0.06220996f, -0.16677032f, 
    0.02750212f, 0.06165006f, 0.03763212f, -0.11889967f, -0.01377455f, -0.07481859f, 0.16450778f, 0.15354629f, 
    0.31194380f, -0.11420288f, 0.07681579f, 0.11254411f, 0.01732293f, -0.09442315f, -0.06572032f, 0.13060637f, 
    0.18507139f, -0.08111800f, -0.04538340f, -0.08414709f, -0.15375176f, -0.25763157f, -0.04648834f, 0.03125218f, 
    0.06217406f, 0.01752201f, -0.11704568f, 0.02372181f, 0.06447536f, 0.05881688f, -0.03510020f, 0.12892553f, 
    -0.07398812f, -0.10972334f, 0.07785202f, -0.11175455f, 0.06141899f, -0.09932853f, -0.02611200f, -0.05329524f, 
    0.06865583f, -0.07641276f, 0.06955839f, 0.02097040f, -0.33883849f, -0.53089780f, -0.03038366f, -0.10415117f, 
    -0.00609222f, 0.11863279f, -0.10992893f, -0.06142554f, 0.04457236f, 0.07988133f, 0.08134562f, 0.07538462f, 
    -0.12852609f, -0.22198425f, -0.07886744f, 0.17326397f, 0.06166105f, 0.01717710f, 0.14242305f, -0.11281892f, 
    0.15218294f, 0.09663483f, 0.03016483f, 0.07409254f, 0.04332083f, 0.05246015f, 0.04984253f, -0.00431489f, 
    -0.06615952f, -0.14988182f, 0.16294965f, 0.07130131f, -0.15621814f, -0.07622920f, 0.03948205f, 0.06231170f, 
    -0.04789790f, -0.05843358f, -0.10077666f, -0.11038785f, 0.13945800f, 0.11516146f, -0.04560665f, -0.05842871f, 
    0.03052633f, 0.16130348f, -0.01777806f, 0.16585220f, -0.36638770f, 0.07713771f, 0.03154990f, -0.03584548f, 
    0.01274266f, 0.01702493f, -0.04332054f, -0.01270196f, 0.08756305f, 0.06041966f, -0.05249651f, 0.11326829f, 
    0.23247731f, 0.32142594f, 0.00255562f, -0.08532860f, -0.15126011f, 0.00328055f, 0.07554127f, -0.11239438f, 
    -0.05334768f, -0.01836164f, 0.03444901f, -0.01610661f, -0.01391297f, 0.08675917f, 0.14772865f, 0.11827527f, 
    0.07956289f, 0.07249054f, -0.00018933f, 0.11880187f, -0.03616748f, 0.10593027f, 0.03494466f, 0.01362203f, 
    0.01150829f, -0.01687976f, -0.00742389f, 0.04697879f, -0.05588749f, 0.03450355f, -0.01723888f, -0.06188302f, 
    -0.05263603f, 0.04824173f, 0.02615157f, 0.05836588f, 0.06795728f, 0.05254915f, 0.07083757f, 0.03652585f, 
    0.00103900f, 0.03236824f, 0.00865667f, -0.00434766f, 0.04025896f, -0.05577694f, -0.00419530f, -0.07264896f, 
    0.00314202f, 0.00311511f, -0.02610613f, 0.04049113f, -0.03956430f, -0.04652083f, -0.04340420f, -0.07465868f, 
    0.01827092f, 0.00853609f, 0.00445312f, -0.00082997f, -0.06715312f, -0.02373230f, -0.00513719f, -0.06900944f, 
    0.05825789f, -0.07982340f, 0.01159563f, 0.04959332f, -0.07566296f, 0.03031744f, 0.00501688f, 0.03521663f, 
    -0.06081561f, -0.07562070f, 0.03044234f, -0.00157474f, -0.06755506f, 0.01476666f, 0.04190810f, -0.00914738f, 
    -0.03823335f, -0.07639495f, 0.00879975f, -0.04377694f, 0.05288327f, -0.06189906f, -0.04945983f, 0.01054936f, 
    -0.03766377f, 0.06560626f, 0.02581908f, 0.04156801f, 0.02443960f, -0.05347541f, -0.05922029f, 0.02524731f, 
    -0.01805986f, -0.01068421f, -0.06304166f, 0.02104102f, -0.02052546f, 0.01266456f, 0.01013625f, 0.05786366f, 
    -0.00221541f, 0.00015864f, -0.03458188f, -0.05853487f, 0.05082259f, -0.04270170f, -0.00592277f, -0.00228224f, 
    -0.02060726f, -0.05970129f, -0.04006421f, -0.00006935f, -0.06834419f, -0.00557704f, 0.00355204f, -0.07452083f, 
    -0.02831432f, -0.03885487f, 0.00696766f, -0.02458719f, -0.05719912f, 0.05681589f, -0.03694540f, 0.02773869f, 
    -0.00173290f, 0.05187298f, -0.05570583f, -0.05300524f, -0.00790147f, 0.02800716f, 0.04290970f, 0.00503073f, 
    0.02864155f, 0.04818833f, 0.00955070f, -0.04824120f, -0.04680753f, -0.06702675f, -0.01141583f, -0.02627611f, 
    0.03468113f, 0.05899804f, -0.04216418f, -0.00827828f, 0.06109738f, -0.02794479f, 0.03024378f, -0.00417169f, 
    -0.04888767f, -0.04190474f, 0.03094955f, -0.00568515f, -0.01571046f, 0.01049866f, -0.04718390f, -0.02561865f, 
    -0.07571728f, -0.03029047f, 0.01122629f, 0.01045628f, 0.04427922f, 0.05746923f, 0.05949059f, -0.07976183f, 
    -0.04860187f, 0.05571088f, 0.04191173f, -0.00378448f, 0.03883357f, -0.06877185f, -0.03250992f, 0.01247492f, 
    -0.03955615f, -0.04141582f, -0.00081831f, -0.03206619f, -0.03586077f, -0.00599442f, -0.04155130f, -0.01604678f, 
    0.04732338f, -0.07339644f, 0.01611318f, -0.01459136f, 0.00496877f, 0.00947154f, 0.00629771f, -0.01965946f, 
    -0.04030132f, -0.01978570f, -0.04939698f, 0.05822434f, -0.05365993f, 0.00276614f, -0.05644945f, 0.02707217f, 
    -0.04469979f, 0.00998084f, 0.05785812f, -0.02591058f, 0.04435424f, -0.06955414f, 0.01893169f, -0.03823771f, 
    -0.02472633f, 0.04702893f, -0.07749505f, 0.02248424f, 0.04391240f, -0.05968114f, -0.03788025f, -0.03539722f, 
    0.23012505f, -0.10062184f, -0.06725195f, -0.07289117f, -0.05534554f, -0.02954528f, 0.19268116f, 0.01388351f, 
    0.06565080f, 0.03321418f, 0.04694103f, 0.15767956f, 0.37514547f, 0.12577921f, -0.03045186f, 0.34812564f, 
    -0.00310306f, 0.04753790f, -0.00044995f, -0.01897707f, -0.11628099f, 0.05879118f, 0.00610350f, 0.08349720f, 
    -0.34373635f, 0.09797657f, 0.09199854f, -0.02443406f, 0.07019765f, -0.02276487f, -0.03092622f, 0.01350924f, 
    -0.07779956f, -0.00707345f, -0.01341087f, 0.03487203f, 0.20522913f, -0.02431639f, 0.15944488f, -0.03236694f, 
    -0.03126799f, -0.06030521f, 0.05096593f, -0.09058030f, 0.09637474f, 0.02667682f, -0.06455751f, -0.04641329f, 
    -0.16982697f, 0.12265490f, 0.08361429f, -0.24471574f, -0.05518057f, 0.03583615f, 0.00716101f, 0.03100484f, 
    0.03227210f, 0.11261473f, 0.02435672f, 0.09140113f, -0.24155064f, -0.03663932f, -0.22477987f, -0.32718733f, 
    -0.02627435f, 0.06887422f, 0.10200221f, 0.11746054f, 0.08997435f, 0.04631825f, 0.01573578f, 0.04493350f, 
    0.17585234f, 0.03712727f, 0.14400777f, 0.08925709f, 0.11318609f, 0.04695158f, 0.02975080f, 0.01199831f, 
    -0.13181278f, -0.02569770f, 0.02333966f, 0.08669692f, -0.28879678f, -0.23747055f, 0.07234509f, 0.07173534f, 
    0.07266241f, 0.02838524f, -0.00385802f, -0.00823770f, 0.12037199f, 0.09226563f, -0.07034474f, -0.02212690f, 
    0.08282014f, -0.09687279f, -0.00501718f, 0.08137378f, 0.01155291f, 0.01354270f, 0.03014194f, 0.04417377f, 
    -0.02293578f, -0.05773140f, 0.03605710f, 0.11845399f, -0.33276042f, -0.11172288f, 0.08066092f, 0.03567307f, 
    0.00222243f, -0.00404457f, 0.03678489f, 0.06082175f, 0.10790612f, 0.00053276f, 0.03168135f, -0.15799123f, 
    -0.14144993f, 0.03599360f, -0.03182194f, -0.17453842f, 0.06630758f, 0.01041146f, 0.00500118f, -0.03919498f, 
    -0.03017181f, 0.14689702f, -0.05070432f, 0.04728726f, 0.19597045f, 0.08762243f, 0.17199171f, 0.00102420f, 
    -0.04046748f, 0.11939819f, -0.06085232f, 0.11767188f, 0.00592992f, 0.02335433f, -0.07666387f, -0.02035248f, 
    0.19395742f, -0.10581399f, -0.00281104f, 0.06224481f, -0.07740364f, 0.12816772f, -0.05997156f, -0.02507013f, 
    0.03184673f, 0.09232423f, 0.02695204f, 0.03110181f, -0.07809150f, 0.17318590f, 0.16826579f, 0.25544223f, 
    -0.01630628f, -0.04143104f, -0.01030742f, 0.03795450f, -0.08707170f, 0.05888972f, -0.03960183f, 0.07396285f, 
    -0.04405573f, 0.00972694f, -0.06874786f, 0.15271831f, -0.00364886f, -0.09867512f, -0.00680378f, -0.12499599f, 
    -0.06589358f, 0.16313079f, -0.01483248f, 0.00080865f, 0.11618129f, -0.03085220f, 0.17507130f, 0.38393199f, 
    -0.00468316f, 0.00131990f, -0.07658707f, -0.08174683f, 0.12256968f, 0.22890075f, -0.02507699f, 0.01344786f, 
    0.30647966f, -0.11942419f, -0.10995205f, 0.05711404f, -0.03367454f, -0.02368988f, 0.19888078f, 0.10069254f, 
    -0.01656558f, -0.01514071f, 0.09423866f, 0.03674694f, 0.12063102f, 0.01422594f, -0.06544362f, 0.27395183f, 
    -0.07486505f, 0.07574912f, -0.09034350f, 0.11885972f, 0.01299279f, -0.05700831f, -0.15170987f, -0.05620141f, 
    0.26298782f, -0.09801102f, 0.10579179f, 0.22587693f, -0.04192794f, -0.04286932f, 0.02061740f, -0.08444729f, 
    -0.06904210f, -0.03001997f, 0.01437337f, -0.09000927f, 0.03620918f, 0.08337915f, -0.04022374f, 0.00984802f, 
    -0.02989989f, -0.03001492f, -0.03979599f, 0.08473315f, -0.07228093f, 0.01658019f, 0.02890006f, -0.06198511f, 
    0.04165686f, 0.12370923f, -0.01716073f, -0.24831662f, -0.11909836f, -0.02167250f, -0.06884354f, 0.02321438f, 
    -0.06280156f, -0.01439789f, 0.08517259f, -0.06864228f, -0.24175051f, 0.10918570f, -0.15940097f, -0.27809152f, 
    0.17488161f, 0.01114400f, 0.02927362f, 0.08890083f, -0.07227761f, -0.03100730f, -0.02319217f, 0.02826395f, 
    0.09374636f, 0.04065491f, 0.11206014f, -0.07584132f, -0.05178617f, -0.07937434f, -0.09486272f, -0.16245832f, 
    -0.03856320f, 0.11175566f, 0.13469690f, 0.26073545f, -0.03066969f, -0.17596789f, 0.07116799f, 0.06144162f, 
    0.05537546f, 0.12956527f, 0.03497890f, 0.09823936f, -0.07018845f, 0.11843029f, -0.01407199f, -0.05958981f, 
    0.18718153f, -0.17955960f, -0.02135076f, -0.12736215f, 0.06416734f, 0.02792136f, -0.06152612f, 0.07420797f, 
    0.00174137f, 0.01166534f, -0.00289935f, 0.08255750f, -0.07463664f, 0.17716441f, -0.09843391f, 0.07112529f, 
    0.18845631f, 0.02345559f, 0.10009216f, 0.01033226f, 0.13192415f, -0.06411155f, 0.02184429f, -0.18726037f, 
    -0.10527059f, 0.10677110f, 0.02438848f, -0.03108491f, -0.02822602f, 0.07751492f, 0.11663672f, -0.00599439f, 
    -0.02643798f, 0.11100306f, -0.07734245f, 0.04635002f, 0.07575516f, 0.07652848f, 0.09050012f, 0.00049554f, 
    0.04445856f, 0.09950186f, -0.10801951f, 0.09833407f, 0.01130514f, 0.10516765f, 0.01002187f, -0.09969356f, 
    -0.04151578f, 0.05676325f, -0.11508328f, -0.07245686f, -0.04724841f, 0.06043589f, 0.00603525f, 0.00690790f, 
    0.00748154f, -0.13283548f, 0.01468263f, 0.11355449f, 0.24167019f, -0.12373462f, 0.04739453f, -0.00210328f, 
    -0.08312277f, -0.00504667f, -0.09521955f, 0.08229526f, -0.09632435f, -0.04610093f, 0.05945581f, -0.07877972f, 
    0.04875712f, -0.13892642f, 0.15620902f, 0.10816590f, 0.00875824f, 0.02181797f, -0.05984184f, 0.11712919f, 
    -0.15112227f, 0.05024571f, -0.05678359f, 0.03421011f, 0.13138233f, 0.02842788f, 0.17254384f, 0.15674374f, 
    0.00933115f, 0.01137000f, -0.05612687f, -0.14460109f, 0.03669359f, 0.06405638f, 0.06630363f, 0.18601911f, 
    0.03999646f, 0.04713110f, -0.00967847f, 0.05138459f, 0.07003724f, -0.05454749f, 0.05104267f, 0.02928511f, 
    -0.01054311f, -0.00597238f, -0.06495199f, 0.00893186f, -0.07347035f, -0.05418266f, 0.00818379f, 0.02451589f, 
    -0.07181026f, -0.06949305f, 0.01460559f, 0.04957823f, -0.02535056f, -0.04787663f, -0.05088926f, -0.00394761f, 
    -0.03217611f, -0.03528981f, -0.02152478f, 0.01195634f, -0.00443228f, 0.02625370f, 0.03357209f, 0.04291256f, 
    0.02626008f, -0.03092607f, -0.04675641f, 0.02470888f, 0.03569023f, -0.03939689f, -0.01364748f, -0.06730333f, 
    0.04742318f, 0.04348553f, 0.04594675f, -0.02739770f, 0.00007590f, 0.06155275f, -0.00756954f, -0.02210978f, 
    -0.00086751f, -0.00487289f, -0.03003990f, -0.00983880f, 0.02473197f, -0.03995878f, 0.04925201f, -0.05056383f, 
    0.02200554f, -0.06161203f, 0.00905163f, 0.00028902f, -0.05196143f, -0.05538561f, 0.02473312f, -0.01453605f, 
    -0.00004430f, 0.04408878f, -0.05968943f, -0.01324121f, -0.00891242f, 0.04396522f, -0.06643234f, -0.01529917f, 
    0.06539854f, -0.02488191f, -0.04854899f, -0.06564621f, 0.05104455f, -0.01089814f, -0.03966862f, -0.07406112f, 
    -0.06426368f, -0.00928912f, 0.05773597f, -0.05897835f, 0.06460559f, -0.01738743f, 0.04738877f, 0.02035424f, 
    -0.03765875f, -0.05799731f, -0.02981107f, -0.04914851f, -0.06065098f, 0.02360743f, -0.08026759f, 0.03539330f, 
    -0.07554872f, -0.04606694f, 0.03911922f, 0.02900552f, 0.02918220f, -0.03161951f, -0.06854464f, 0.01996282f, 
    -0.02605464f, -0.00334561f, 0.01124921f, -0.04055295f, -0.06977250f, -0.02428119f, -0.04900755f, 0.01879269f, 
    -0.06319288f, -0.04563911f, 0.03463494f, 0.00946736f, 0.05153682f, -0.02132329f, -0.02808238f, 0.02970290f, 
    0.01477645f, -0.06877548f, 0.00689302f, -0.06241551f, -0.00883242f, -0.04150005f, -0.01550919f, -0.00942337f, 
    -0.00344386f, -0.06964266f, -0.00471417f, -0.03712216f, -0.00344674f, 0.05598692f, -0.05332156f, 0.02548143f, 
    -0.05661123f, -0.02964286f, -0.02298335f, 0.03872314f, 0.07066095f, 0.01116007f, -0.04180892f, -0.01346733f, 
    0.03893954f, -0.06752109f, 0.05697822f, -0.05180842f, -0.00708014f, -0.05507284f, 0.04822179f, -0.04097451f, 
    -0.03443763f, -0.03675875f, -0.02379251f, 0.06284841f, 0.05709419f, 0.04314219f, -0.01721270f, -0.06260058f, 
    -0.05024253f, -0.03253277f, 0.05202996f, -0.04376172f, -0.01454545f, -0.06640241f, -0.00600439f, -0.06155091f, 
    0.03386985f, 0.05852822f, 0.01003098f, -0.02305350f, 0.02688198f, -0.02030041f, 0.03615928f, -0.02805885f, 
    0.05492749f, -0.07466996f, 0.02420968f, -0.04681252f, 0.05261431f, -0.06831665f, -0.06341460f, 0.02304210f, 
    -0.06990764f, 0.02780129f, 0.03401717f, 0.04416438f, -0.06952391f, 0.00768602f, -0.01564097f, 0.01817882f, 
    0.04267167f, 0.15101092f, 0.05722756f, 0.06252490f, -0.05119702f, -0.16887477f, 0.07929306f, -0.03590585f, 
    -0.08249112f, -0.00679495f, 0.06341405f, -0.06147010f, -0.05795182f, 0.11843140f, -0.17119528f, 0.03183588f, 
    0.01783240f, 0.08979335f, 0.05873924f, 0.21105644f, 0.11474843f, 0.03786605f, 0.08997928f, 0.03695386f, 
    0.24301504f, -0.18805471f, -0.08614061f, 0.09474942f, 0.02229345f, -0.04081502f, -0.03777504f, 0.05096017f, 
    -0.02639825f, 0.03704992f, 0.03645923f, -0.09614775f, 0.35269737f, -0.03542970f, 0.03770750f, -0.00033504f, 
    0.13377352f, 0.01159474f, -0.07189160f, 0.04258095f, -0.13670546f, -0.04986179f, 0.10198681f, 0.07862224f, 
    0.08770518f, -0.18413301f, 0.12070828f, -0.22871138f, 0.02319870f, 0.05544067f, -0.15146716f, -0.03476011f, 
    -0.02944234f, -0.13589394f, 0.02455384f, 0.07441020f, -0.07995833f, 0.24649712f, -0.11565084f, -0.10182182f, 
    0.27480897f, 0.08833581f, -0.09896958f, -0.14501372f, -0.11150958f, 0.01976630f, 0.01187371f, -0.01246197f, 
    0.10010211f, 0.01591500f, 0.00990486f, 0.05780473f, 0.07690005f, -0.06027284f, -0.06355153f, 0.09604362f, 
    0.04436986f, 0.12309633f, 0.11900042f, -0.06188993f, 0.31616879f, 0.04455559f, 0.18628150f, -0.06609162f, 
    0.08218660f, 0.14774758f, -0.02454046f, -0.05120903f, 0.04193582f, 0.06624069f, 0.07315851f, 0.09592692f, 
    -0.30290967f, -0.03929157f, -0.10188130f, -0.13998882f, -0.04211977f, -0.04604040f, 0.04386925f, 0.05005547f, 
    -0.08990742f, 0.09467433f, -0.01025871f, -0.07186455f, -0.10070305f, -0.11337783f, -0.07112876f, 0.16454287f, 
    0.16043290f, 0.00308595f, -0.02501100f, -0.15607095f, -0.01250667f, -0.05117271f, -0.07584080f, -0.10674533f, 
    0.06043081f, 0.23140027f, 0.00362131f, -0.09758782f, -0.05936893f, -0.04151651f, 0.01983954f, 0.01400512f, 
    0.18027085f, -0.04999056f, -0.02115995f, -0.03286520f, -0.05622429f, -0.06041560f, -0.00749771f, -0.37588590f, 
    0.04321551f, 0.02065957f, -0.04973978f, 0.10047613f, 0.06541753f, -0.05701356f, 0.05844984f, 0.03286938f, 
    -0.16502061f, -0.12068622f, -0.10522234f, -0.22600795f, -0.00732267f, 0.01477537f, 0.21316177f, -0.13346696f, 
    0.04913999f, 0.06870808f, -0.03451497f, -0.06738523f, 0.32735091f, -0.30672562f, -0.09163975f, 0.01648820f, 
    -0.06523699f, 0.02615356f, -0.00673156f, -0.01660987f, -0.01466157f, -0.05086742f, 0.03473913f, 0.07615806f, 
    0.13141298f, 0.03952145f, 0.25484154f, 0.28067905f, 0.07835251f, 0.00392881f, 0.05617132f, 0.06156928f, 
    -0.01459253f, 0.04703667f, 0.02124072f, -0.09496287f, 0.15743119f, -0.00904243f, 0.10643771f, 0.10067841f, 
    -0.01486306f, -0.08075362f, 0.15122451f, -0.03320115f, 0.09726126f, 0.02741837f, 0.02144641f, 0.05943426f, 
    0.31492475f, -0.10073014f, 0.23317277f, -0.02791597f, -0.09464032f, -0.10196875f, 0.00000188f, 0.00422496f, 
    0.03048996f, 0.09143180f, -0.06642022f, -0.07370389f, -0.04299524f, 0.16995475f, -0.08067856f, -0.06245387f, 
    0.00956529f, 0.01759971f, -0.10938466f, 0.04761965f, 0.02077817f, 0.04286942f, -0.08674680f, -0.06297246f, 
    0.58125627f, -0.20950457f, 0.10792647f, 0.05756385f, -0.03395394f, 0.05873588f, 0.01065610f, -0.08261322f, 
    0.10576019f, -0.00167567f, 0.17976063f, -0.05052578f, -0.21906559f, -0.06329457f, -0.02900555f, -0.07620604f, 
    0.02757952f, -0.02060491f, 0.14765312f, 0.00575282f, -0.05836620f, -0.02381061f, 0.24049102f, -0.02766005f, 
    0.03965230f, -0.08267940f, -0.05490614f, -0.15691695f, 0.13826126f, 0.08870628f, -0.12712494f, -0.00903523f, 
    -0.03380151f, 0.01844168f, 0.05075293f, -0.01298726f, -0.24949661f, -0.06242264f, 0.03456235f, -0.15293223f, 
    0.00361178f, 0.04082832f, -0.04076584f, -0.08293052f, 0.04494612f, -0.07244959f, 0.05505738f, -0.03782320f, 
    0.18513857f, 0.00908976f, 0.06232221f, -0.05293274f, -0.03185468f, 0.05055870f, -0.04372415f, -0.19119409f, 
    0.16700794f, 0.01139725f, 0.01619281f, -0.00762921f, 0.03202551f, 0.06187742f, -0.22686715f, 0.22701454f, 
    0.09169407f, -0.06103746f, -0.02736415f, -0.04223537f, 0.06940534f, -0.01462869f, 0.02576390f, 0.10666801f, 
    0.33038452f, -0.20237984f, -0.19859350f, 0.11220276f, -0.00245139f, -0.08043075f, -0.14592299f, -0.03693227f, 
    0.18700086f, -0.05671969f, -0.01061284f, 0.00785189f, -0.17638947f, 0.07183211f, -0.06892864f, 0.11248095f, 
    0.10879760f, -0.00362525f, -0.12445843f, -0.00121396f, 0.08848328f, -0.03585777f, -0.00497468f, 0.01507806f, 
    -0.20944029f, 0.20247094f, -0.06861266f, -0.04743871f, 0.11121943f, 0.08342007f, 0.02646434f, 0.18666446f, 
    -0.01050489f, -0.00720979f, -0.06573621f, 0.03939939f, 0.22361028f, 0.05219197f, -0.04129736f, -0.16201383f, 
    0.14703545f, -0.08014027f, 0.06689894f, 0.09686701f, -0.08571954f, 0.03907602f, 0.10071093f, 0.03320672f, 
    -0.02028211f, 0.19416718f, -0.08568440f, -0.03692200f, 0.03660172f, 0.11196691f, 0.04684531f, 0.10466096f, 
    -0.02487526f, 0.03231471f, 0.07187024f, 0.12885176f, 0.14724457f, -0.05306171f, 0.02667461f, -0.12694734f, 
    0.02473403f, 0.19214380f, -0.14275752f, 0.11728507f, 0.01630891f, -0.03356495f, -0.03097399f, 0.12849648f, 
    0.33288619f, -0.00488772f, -0.02771733f, -0.09009495f, -0.11829606f, 0.05560854f, 0.01825082f, 0.04125634f, 
    -0.02944230f, 0.04126885f, -0.01994358f, 0.00239475f, 0.07575465f, 0.32680544f, -0.10229278f, 0.08816399f, 
    -0.02776331f, 0.11608993f, -0.00979193f, 0.08513720f, 0.03154962f, 0.06145061f, 0.04341956f, 0.06052164f, 
    -0.21356362f, -0.03450183f, -0.18110637f, -0.19705319f, -0.05859933f, 0.04330751f, 0.08568937f, -0.02481014f, 
    0.01215747f, 0.00191712f, -0.15460680f, 0.05337325f, 0.06334241f, -0.05304121f, 0.10116467f, 0.10158763f, 
    -0.09700499f, 0.07324316f, 0.06041629f, -0.15425810f, 0.16217421f, 0.18574536f, -0.01794912f, 0.00008362f, 
    -0.28894919f, -0.04814774f, -0.12022052f, -0.18182601f, 0.13855204f, 0.04354393f, 0.01272476f, -0.03622416f, 
    0.03263471f, -0.03041270f, 0.00559086f, -0.07278222f, 0.03813372f, -0.10990471f, -0.08822773f, 0.01670839f, 
    0.14044593f, 0.03676681f, 0.03947943f, 0.00583087f, -0.05508977f, 0.03623869f, -0.06355520f, 0.01783847f, 
    -0.09633610f, 0.24295065f, 0.24983175f, 0.05388179f, 0.09419084f, -0.06659103f, -0.09636636f, 0.01525244f, 
    0.10806626f, 0.11285572f, -0.03144061f, 0.06684434f, -0.05006036f, 0.10998260f, 0.20293607f, -0.22180259f, 
    -0.03521583f, 0.00292082f, 0.06017326f, 0.01589116f, 0.13554750f, -0.00529972f, 0.04261625f, 0.06801724f, 
    -0.03878080f, 0.12372224f, -0.00160648f, 0.14526010f, 0.02453592f, 0.09182583f, -0.06522107f, 0.04780403f, 
    -0.05021760f, 0.02143512f, 0.05724054f, 0.11519003f, -0.21451184f, 0.01593405f, -0.10330037f, 0.21163572f, 
    0.06440496f, 0.16469081f, -0.01518865f, 0.01646966f, 0.12519780f, -0.05727699f, -0.06504276f, -0.13238429f, 
    -0.13535470f, 0.07680520f, 0.11674260f, 0.02201080f, 0.00402118f, 0.11407067f, 0.08757287f, -0.02987278f, 
    0.00545783f, 0.06934889f, 0.05054858f, 0.10091726f, -0.09872413f, 0.16798891f, 0.15499264f, 0.15859674f, 
    0.01111281f, -0.03615319f, -0.03399164f, -0.04873089f, -0.04149106f, -0.10771036f, 0.06225365f, 0.00910846f, 
    -0.29476053f, -0.01719791f, 0.18869555f, 0.12627958f, 0.03690206f, -0.04581735f, 0.05103213f, -0.02799409f, 
    0.09347135f, 0.09525363f, 0.00512585f, -0.00459816f, 0.10455460f, 0.13683121f, 0.24161077f, -0.10004879f, 
    0.05568299f, 0.07072268f, -0.08089216f, -0.04839755f, -0.03479068f, 0.02420261f, 0.02652836f, 0.23293093f, 
    -0.25180709f, 0.09799110f, 0.19492950f, 0.15683335f, -0.07869355f, 0.00224594f, -0.07442331f, -0.07811748f, 
    -0.04548931f, 0.03846941f, -0.05478473f, -0.07884758f, -0.07795974f, -0.00829803f, -0.00767773f, 0.10752139f, 
    0.00573328f, 0.03343866f, 0.08315859f, -0.06223758f, 0.11454330f, 0.03313762f, 0.02943895f, 0.08652389f, 
    -0.14500342f, -0.12443764f, -0.20708872f, -0.01778289f, 0.09087088f, 0.03992007f, -0.06318591f, -0.19925211f, 
    -0.03391124f, 0.03965651f, 0.01827373f, -0.09587777f, -0.06042697f, 0.00906264f, 0.00615198f, 0.26167259f, 
    0.04525856f, -0.05505786f, 0.04855705f, -0.02883218f, -0.09643443f, -0.02548001f, 0.08374991f, -0.00460162f, 
    -0.14806527f, -0.00222268f, 0.16697955f, -0.01670244f, 0.00056714f, -0.04063729f, -0.15821999f, 0.08597766f, 
    -0.07384706f, -0.01294551f, 0.10014988f, -0.12786081f, -0.26160678f, 0.06341514f, -0.10238439f, -0.15762681f, 
    0.02381855f, -0.11053073f, -0.02109674f, -0.01798442f, 0.05557694f, -0.02767140f, 0.02991955f, 0.02913360f, 
    0.05692736f, -0.03684165f, 0.12960397f, -0.05034536f, -0.01958855f, -0.00544082f, -0.04150872f, 0.00580293f, 
    0.01391963f, -0.06913006f, 0.07766172f, -0.08454578f, -0.06376494f, 0.04149789f, 0.11928370f, -0.03915127f, 
    0.06632504f, 0.13523322f, -0.08564429f, -0.00606222f, -0.09083202f, -0.04398466f, 0.04269358f, 0.06370717f, 
    0.33305132f, -0.25112206f, 0.02887247f, 0.09432165f, 0.09068382f, 0.10061763f, 0.00661940f, 0.05133729f, 
    0.01230425f, -0.05163752f, -0.07099525f, 0.08272154f, 0.27117538f, -0.11936121f, 0.15621197f, 0.23705080f, 
    0.18305203f, -0.05432438f, 0.08955026f, -0.01722841f, 0.05025188f, -0.06816266f, 0.06090585f, 0.04443480f, 
    -0.04880090f, -0.01085727f, -0.02280291f, 0.04530100f, -0.03631726f, 0.01069926f, -0.00910533f, 0.07192992f, 
    0.16009648f, -0.01779958f, -0.07263581f, -0.27647156f, 0.42772654f, 0.14051948f, -0.11687351f, 0.02536154f, 
    0.04046553f, -0.10677437f, -0.03779873f, -0.05508166f, -0.03064658f, -0.11578042f, 0.09027094f, 0.13129064f, 
    0.13324496f, -0.15689987f, -0.12682182f, 0.18699369f, 0.05259819f, -0.02588294f, -0.04893259f, -0.02643615f, 
    0.13176745f, -0.03237195f, 0.06484587f, -0.01955486f, 0.13223127f, -0.06531812f, -0.00823559f, 0.04420606f, 
    0.04249077f, 0.13879028f, -0.03241923f, -0.14238204f, -0.07806646f, 0.07119541f, -0.06431622f, 0.21174881f, 
    0.03362441f, 0.07668108f, -0.07495880f, -0.00054852f, 0.09983280f, -0.02019265f, -0.05707662f, 0.11974691f, 
    -0.04205821f, -0.14852691f, 0.09877433f, -0.02957021f, 0.11423211f, -0.16929732f, -0.32995978f, -0.03282990f, 
    0.00822368f, -0.26841232f, 0.06265504f, 0.01487069f, 0.11027747f, -0.09828380f, 0.01215426f, 0.12323667f, 
    0.06096392f, -0.00346091f, -0.01393893f, -0.05149252f, -0.05167619f, -0.02571157f, 0.06206684f, 0.02358606f, 
    0.06702549f, 0.06113368f, 0.11200269f, 0.00655779f, -0.06866231f, -0.05420806f, -0.15385953f, -0.06953226f, 
    -0.11056712f, 0.14167598f, -0.13960339f, -0.02576882f, 0.08229376f, -0.04469746f, 0.11654627f, 0.03491763f, 
    -0.02921744f, -0.17616971f, 0.22081496f, 0.08374403f, -0.06106057f, -0.02996976f, 0.09615646f, 0.03653126f, 
    0.02176899f, -0.13908510f, -0.06023497f, -0.03706177f, 0.20726053f, 0.08332478f, -0.05471742f, -0.12004486f, 
    0.05131648f, 0.01394034f, -0.02363677f, 0.15047739f, 0.01555305f, -0.16980584f, 0.03367113f, -0.00587380f, 
    -0.07874427f, -0.03256437f, 0.10050558f, -0.20115849f, -0.02618692f, 0.15923426f, 0.11897886f, -0.08541660f, 
    -0.05214396f, 0.02976613f, -0.09666514f, 0.09365942f, 0.15856473f, -0.03805307f, 0.06843731f, 0.15645668f, 
    -0.00929501f, 0.02124063f, -0.08380664f, 0.04123900f, 0.12007465f, 0.01912704f, 0.15370423f, -0.08541445f, 
    -0.17580013f, -0.21089964f, 0.00553883f, -0.02181040f, -0.08026320f, 0.04138511f, 0.02840442f, 0.03604146f, 
    0.06645720f, 0.05660869f, -0.00581301f, -0.07150748f, 0.32211435f, -0.24060982f, 0.05346097f, 0.07828798f, 
    0.10146228f, -0.12214622f, 0.05347766f, -0.08018387f, -0.02276333f, -0.06887835f, 0.06568819f, -0.05019395f, 
    -0.30394265f, -0.00624040f, 0.25108767f, -0.22852138f, -0.08930288f, 0.03006582f, -0.03359086f, 0.00047366f, 
    -0.05401802f, 0.03324759f, 0.06944016f, 0.11864883f, -0.44437820f, 0.19775221f, -0.14920489f, -0.38003373f, 
    -0.05312132f, 0.05186602f, -0.03132714f, -0.00815599f, 0.08161040f, 0.00767576f, 0.01980679f, 0.12165397f, 
    0.16421609f, 0.09192400f, 0.20386365f, -0.09344558f, 0.16426970f, 0.12827563f, 0.23740815f, 0.02786925f, 
    0.06899317f, -0.02292527f, -0.01434674f, -0.12466388f, -0.23100370f, 0.05057331f, 0.10633386f, 0.33205822f, 
    -0.08058386f, 0.01295514f, -0.04907842f, 0.05041184f, 0.05313482f, 0.02011238f, 0.05510717f, -0.03862781f, 
    -0.17046604f, -0.06741501f, -0.06386327f, 0.08446408f, -0.03984774f, 0.05241841f, 0.01868447f, 0.18236122f, 
    -0.04172282f, 0.00598025f, 0.04966096f, 0.10638320f, -0.20564526f, 0.08970485f, 0.07199153f, 0.05009186f, 
    -0.08818615f, 0.06127071f, -0.11782833f, 0.09970272f, 0.00314138f, -0.13939373f, 0.10305571f, -0.07379036f, 
    -0.14911322f, 0.07487048f, 0.07915445f, 0.02593219f, -0.08059645f, -0.01961219f, 0.08359601f, 0.06600648f, 
    -0.06171558f, 0.02463956f, 0.11099532f, -0.04953913f, -0.01706594f, 0.07703902f, 0.31999943f, -0.08576813f, 
    0.08993454f, 0.05060074f, -0.10673083f, 0.04150425f, -0.04134499f, 0.05426755f, -0.05199403f, 0.08822968f, 
    -0.05337389f, -0.06084953f, 0.12775372f, -0.02355707f, -0.13975474f, 0.02760445f, 0.06346580f, -0.07869242f, 
    -0.16434102f, 0.04572080f, -0.01354860f, -0.14783517f, 0.13053507f, -0.16941051f, 0.15629926f, 0.01319952f, 
    0.00394967f, 0.01326970f, 0.04445516f, 0.04590707f, -0.02466229f, 0.06851558f, -0.08134929f, -0.03298354f, 
    -0.21575660f, -0.00960159f, -0.09902769f, 0.14548975f, -0.00858620f, 0.10902254f, 0.04453011f, 0.05958374f, 
    0.05633454f, 0.03953517f, -0.01233272f, 0.07821845f, -0.13131207f, 0.00363097f, 0.07186636f, 0.24571276f, 
    0.03379291f, 0.01857552f, -0.03012060f, -0.08336303f, -0.01631839f, 0.12502302f, 0.09818608f, 0.03419441f, 
    -0.05637550f, 0.10002670f, -0.11936624f, 0.05060212f, -0.02847531f, -0.06477851f, -0.01333341f, 0.02417108f, 
    -0.01010314f, 0.08399475f, 0.18487054f, 0.13960712f, -0.05300689f, -0.27040520f, -0.02427767f, -0.08999361f, 
    -0.08855329f, 0.14042890f, 0.04403500f, 0.04707137f, 0.15733953f, 0.02851823f, -0.00247165f, 0.04225179f, 
    -0.28316233f, 0.08969404f, -0.33682898f, 0.13193971f, -0.03379921f, -0.15292870f, -0.02800372f, 0.05323675f, 
    -0.01179565f, 0.04129459f, 0.01112806f, -0.08294917f, 0.24462429f, -0.14455281f, 0.01775968f, 0.03269744f, 
    -0.01831890f, -0.05571435f, 0.13939972f, 0.14191930f, -0.13458718f, -0.01183058f, -0.03657192f, 0.07033070f, 
    0.01948477f, -0.05482003f, 0.23440638f, 0.15614080f, 0.02321559f, 0.10903316f, 0.02910002f, 0.03341436f, 
    -0.01084639f, -0.00144804f, 0.00707528f, 0.04671488f, -0.01268593f, 0.18289946f, -0.01730731f, -0.12266327f, 
    0.00697337f, 0.01924076f, -0.01767661f, -0.03665717f, -0.00608232f, -0.14800233f, 0.00113791f, 0.09476170f, 
    -0.05550062f, -0.07095542f, -0.02610873f, 0.17454073f, 0.18252268f, -0.09788666f, 0.04156204f, 0.26339498f, 
    0.01587301f, -0.00271681f, 0.07345352f, 0.17938495f, 0.40644988f, -0.05209406f, 0.10537370f, 0.13499884f, 
    0.05995367f, -0.01790034f, -0.05222736f, -0.03756602f, 0.08992970f, 0.05460905f, 0.04182089f, -0.10010944f, 
    0.10058082f, -0.15892966f, 0.04814936f, 0.13354130f, 0.01619992f, 0.14108343f, -0.02026679f, 0.13094020f, 
    -0.14487244f, -0.04333175f, 0.07453285f, 0.13465907f, 0.17962348f, -0.06277300f, 0.10462119f, 0.13440780f, 
    0.11739020f, -0.03259233f, -0.05273957f, -0.06211227f, -0.01225704f, -0.17208113f, -0.02357401f, -0.08659901f, 
    -0.03663367f, -0.06102492f, 0.04984413f, -0.00731152f, -0.08627249f, 0.08420323f, 0.14116018f, -0.07401451f, 
    0.14505337f, -0.01483651f, 0.09635881f, -0.05516475f, -0.12715450f, -0.02860026f, 0.04007658f, -0.11720997f, 
    0.16552819f, 0.04482714f, 0.03032186f, 0.22498283f, 0.00245951f, -0.13779396f, -0.00800174f, 0.02318764f, 
    0.21338768f, -0.37393278f, -0.03293771f, 0.10229050f, -0.03751342f, 0.16807233f, 0.06788284f, -0.05374589f, 
    0.11533420f, 0.01334626f, 0.01213632f, 0.09840918f, -0.26304862f, 0.14865620f, 0.05255887f, -0.24919766f, 
    0.04207769f, 0.10120522f, 0.05771470f, 0.03998411f, 0.03129327f, -0.00967907f, 0.08895540f, 0.10919656f, 
    -0.06922281f, -0.18334450f, -0.23886667f, 0.10983977f, 0.04398732f, -0.00398093f, -0.04499300f, 0.10783998f, 
    0.06413136f, 0.03494814f, 0.07175220f, -0.07285375f, 0.19247583f, -0.26503310f, 0.15606661f, 0.13966216f, 
    0.02128154f, -0.03738790f, 0.00013437f, 0.10681186f, -0.01006449f, 0.08458075f, -0.03911960f, 0.13204335f, 
    0.11190458f, 0.07551420f, 0.04913559f, 0.08707025f, 0.12825561f, 0.06937362f, -0.05211324f, -0.05168908f, 
    -0.02792315f, -0.04237042f, 0.11342827f, -0.13097085f, 0.06598049f, 0.03449135f, 0.15468732f, -0.07669612f, 
    -0.02025745f, -0.10279479f, -0.08433282f, 0.00707361f, 0.02171980f, 0.03479311f, -0.05743327f, -0.09894118f, 
    -0.29388115f, 0.18521348f, 0.04642874f, -0.00055966f, 0.02420675f, 0.01548258f, 0.05143806f, -0.00902191f, 
    0.01207019f, 0.03542474f, -0.05008173f, -0.00986972f, -0.20885839f, 0.10232937f, 0.03673069f, 0.18361250f, 
    -0.07716924f, -0.02268175f, -0.04669330f, 0.05002353f, 0.10327199f, 0.11089781f, 0.05239493f, 0.00252500f, 
    0.27387443f, -0.12494015f, -0.17652592f, -0.03288602f, 0.05216577f, -0.06319977f, 0.06061589f, -0.04260360f, 
    -0.01307612f, -0.11382753f, -0.09939149f, 0.04629998f, 0.10320257f, -0.07678442f, 0.04295572f, 0.16139910f, 
    -0.05469787f, 0.07134629f, 0.02313487f, -0.02864062f, 0.04130376f, -0.06667183f, -0.03545400f, -0.02737154f, 
    0.05610619f, 0.01345238f, 0.00928950f, -0.07378631f, 0.01408251f, 0.04347467f, 0.10920304f, 0.09017479f, 
    0.06612807f, -0.00089716f, -0.06270154f, -0.11046508f, 0.23031737f, 0.09772351f, -0.02854682f, -0.07817859f, 
    0.00048527f, -0.09851519f, 0.00909386f, -0.01252648f, 0.00139655f, 0.03618791f, 0.03377156f, 0.18838781f, 
    0.15754142f, -0.01899780f, 0.04612290f, 0.21513593f, -0.06833743f, 0.00267476f, 0.02383258f, -0.04616918f, 
    0.13375048f, -0.09008268f, -0.02541374f, -0.05883026f, 0.10608855f, 0.04359433f, -0.06899024f, 0.03647282f, 
    0.02864384f, 0.11340764f, -0.01759073f, 0.09056424f, -0.06401941f, 0.04068839f, -0.08454147f, 0.20980045f, 
    0.21622862f, -0.07522114f, -0.08462827f, -0.01665997f, 0.02111897f, -0.07469989f, -0.11940753f, -0.02769199f, 
    -0.09399430f, -0.12549080f, 0.04965344f, 0.02409383f, 0.09479630f, -0.10379579f, -0.17399347f, 0.05294253f, 
    -0.13500206f, -0.21038258f, 0.10852786f, 0.05892836f, -0.00145966f, -0.06984786f, 0.11579059f, 0.01825651f, 
    0.24760555f, 0.24730593f, 0.00649447f, 0.01231968f, 0.18893553f, -0.08968919f, -0.11406898f, 0.06564910f, 
    -0.00843835f, -0.05250232f, -0.02882857f, 0.04951803f, 0.00582499f, -0.02738205f, 0.07823706f, 0.12362213f, 
    -0.09103270f, 0.01549205f, -0.04336939f, -0.02198249f, -0.06673247f, 0.09237648f, 0.07057527f, 0.04215612f, 
    0.00256741f, 0.09371553f, -0.07729348f, -0.17316686f, 0.03261216f, 0.16614217f, 0.05357638f, 0.05893407f, 
    -0.02390895f, -0.01668194f, 0.02234439f, -0.08238336f, 0.16533212f, 0.17164800f, -0.08100177f, -0.14040129f, 
    0.06945883f, -0.00744860f, -0.10170241f, 0.08535704f, -0.00109636f, -0.01386673f, 0.08535044f, -0.07334197f, 
    -0.03908869f, -0.09439067f, 0.07968607f, -0.13595068f, 0.00799888f, -0.00678112f, 0.06021010f, -0.05262683f, 
    -0.04077356f, -0.01014978f, -0.00032209f, 0.05361477f, 0.01091657f, -0.14604639f, 0.07325224f, -0.18151194f, 
    0.10745864f, -0.12553163f, 0.01301089f, -0.15355696f, 0.08290745f, 0.10877085f, 0.12692572f, 0.10745802f, 
    -0.40765601f, 0.19006342f, -0.09629729f, -0.05418759f, 0.05868748f, -0.03952672f, 0.10698868f, -0.00279651f, 
    0.00279907f, 0.01198423f, -0.10274583f, 0.13047959f, 0.12936620f, -0.18264253f, 0.06905738f, -0.14018056f, 
    -0.01940221f, 0.07087729f, -0.01670369f, -0.01191493f, 0.11452712f, 0.12906982f, 0.03505465f, 0.09065194f, 
    -0.22102788f, -0.04253353f, 0.07400804f, 0.27124712f, 0.11477702f, 0.13275282f, 0.13079016f, 0.04061906f, 
    0.08805922f, 0.15220928f, 0.05629461f, 0.04636883f, -0.05699605f, -0.03116009f, 0.06139020f, -0.01786286f, 
    -0.02201449f, -0.00823615f, 0.06556644f, -0.06000065f, 0.08414112f, -0.04326488f, -0.03262631f, 0.07565866f, 
    0.08558278f, -0.04390974f, 0.04365099f, -0.02732380f, 0.13515772f, 0.04886485f, 0.19187175f, 0.02211130f, 
    0.03323380f, -0.13638054f, -0.16785537f, -0.05868452f, -0.12821293f, 0.10506894f, -0.18166678f, 0.10184556f, 
    0.08977102f, -0.05502024f, -0.03429500f, -0.04337155f, 0.08549910f, -0.08912610f, 0.05801088f, 0.06815595f, 
    -0.02254783f, -0.05026792f, 0.09634127f, 0.04470636f, 0.05628567f, 0.08270922f, 0.04557058f, 0.06461032f, 
    0.09341597f, -0.05517329f, 0.07272623f, 0.15925980f, -0.11667223f, -0.09105778f, 0.10889069f, -0.13781340f, 
    -0.05082911f, -0.00639368f, -0.09597181f, 0.05984448f, 0.00175105f, 0.05143677f, 0.13809851f, 0.01298769f, 
    -0.03486174f, -0.21614641f, 0.02713501f, 0.09409618f, 0.12053084f, 0.08422422f, 0.02492239f, -0.03736910f, 
    0.08022235f, 0.13961695f, 0.05927425f, -0.03131939f, 0.07328508f, 0.11639857f, 0.13201931f, -0.03570737f, 
    0.10388045f, -0.02908579f, 0.10170802f, 0.03889670f, 0.05695669f, -0.01659852f, 0.14585030f, 0.24398735f, 
    0.24074452f, -0.06516094f, 0.10376628f, 0.09631157f, 0.10781822f, 0.10712821f, -0.03840526f, -0.04931316f, 
    0.07252538f, 0.05361664f, -0.00909286f, -0.03539749f, -0.23011918f, 0.24655120f, 0.25243193f, 0.17280075f, 
    0.10719966f, -0.00382493f, -0.00893065f, 0.07568579f, -0.00423292f, 0.12590328f, -0.04615663f, 0.04143050f, 
    -0.17054297f, 0.11105244f, -0.28144616f, -0.21119662f, -0.14453924f, -0.02154017f, 0.02969696f, -0.09642336f, 
    0.05827932f, 0.00897401f, 0.06718881f, 0.08159223f, -0.19888231f, 0.08731471f, -0.01710271f, 0.16166066f, 
    0.02828701f, 0.06974086f, -0.02711037f, 0.04827112f, -0.01614832f, 0.09059573f, -0.07052712f, -0.24890690f, 
    -0.09009393f, 0.00073248f, 0.02394056f, -0.06453494f, 0.01598363f, 0.04594903f, 0.10818601f, 0.02524647f, 
    0.07410713f, -0.01170613f, 0.07196488f, 0.20123094f, -0.05688316f, -0.21036558f, 0.17035408f, -0.14119507f, 
    -0.01167310f, -0.11507072f, 0.05977332f, -0.09181652f, 0.08804745f, -0.11189472f, -0.09284455f, -0.00184487f, 
    -0.31286466f, 0.12382057f, -0.12175194f, 0.01408743f, 0.06122093f, -0.08136216f, 0.01777118f, 0.00033372f, 
    0.03263823f, -0.12459496f, 0.10290806f, -0.05550358f, 0.13747740f, -0.14406687f, 0.05036833f, 0.03959372f, 
    -0.02574450f, -0.01254659f, 0.09190376f, -0.07113730f, 0.11562210f, 0.13435373f, 0.05128574f, 0.01576502f, 
    -0.08815730f, 0.05940777f, 0.09833938f, 0.27927485f, 0.08444225f, -0.06077927f, 0.02047645f, -0.04985448f, 
    0.16216102f, 0.08046249f, 0.15201999f, -0.12362909f, 0.11382423f, 0.27245221f, 0.07503500f, 0.16040589f, 
    -0.17839949f, 0.01593660f, -0.01813288f, -0.00244098f, -0.05579002f, 0.00413341f, -0.03657849f, -0.07039901f, 
    -0.17315690f, 0.05380953f, 0.01969821f, -0.13319825f, -0.03273498f, 0.07526945f, 0.13232028f, 0.01805374f, 
    -0.12837392f, -0.02224444f, -0.04896262f, 0.11697610f, 0.19420432f, 0.22944953f, -0.05334831f, 0.02282080f, 
    -0.05839860f, 0.02430599f, -0.06351808f, 0.05974404f, 0.03277589f, 0.00825600f, 0.03123622f, -0.00429635f, 
    0.02722421f, 0.13207430f, 0.06736313f, -0.08909868f, 0.07028905f, -0.02305056f, 0.00559852f, 0.13791370f, 
    -0.05715695f, 0.07249875f, 0.03670734f, 0.22793259f, 0.26303527f, 0.17308259f, 0.09164593f, 0.02815535f, 
    -0.07113929f, 0.03014306f, 0.06953052f, 0.09492049f, 0.08594561f, -0.08732312f, 0.07707840f, 0.04659927f, 
    0.20557469f, -0.03992838f, 0.06383625f, 0.09830854f, -0.01689320f, 0.05425282f, 0.05616758f, -0.05135024f, 
    0.03023992f, 0.06304371f, -0.00789522f, -0.03114023f, -0.18487522f, -0.16529092f, -0.00035354f, -0.12840527f, 
    0.05673008f, 0.15545571f, 0.06581308f, 0.02014655f, 0.04217656f, -0.05528378f, -0.04022089f, 0.06281787f, 
    0.22535951f, -0.11183491f, -0.00102801f, 0.11483150f, -0.01029558f, -0.01131726f, -0.05426126f, 0.02574616f, 
    0.12544683f, -0.02722857f, 0.04165881f, -0.04157671f, -0.07739207f, -0.12360689f, 0.31292257f, -0.05855937f, 
    0.13671942f, 0.01338254f, 0.14198442f, 0.05333680f, -0.02605790f, -0.03279716f, 0.00072860f, 0.08880331f, 
    -0.09492358f, -0.08218605f, -0.10794652f, -0.14807706f, 0.13393113f, -0.09605914f, -0.16793197f, -0.09500363f, 
    0.03232049f, 0.08718905f, -0.00333003f, 0.10321023f, -0.17944245f, -0.08371643f, -0.08985329f, -0.04889506f, 
    0.01384372f, -0.07250183f, -0.10811103f, -0.02070041f, -0.06646110f, -0.02386221f, 0.03657400f, 0.04895566f, 
    0.07816423f, 0.00212678f, -0.12237682f, -0.05008247f, 0.09763097f, -0.09103034f, -0.11794949f, 0.01628308f, 
    0.16523641f, -0.06256810f, -0.00141979f, 0.01648808f, -0.02022704f, -0.00807674f, 0.05231886f, -0.04821068f, 
    0.08888119f, 0.04953233f, 0.14479360f, -0.12229968f, -0.06186786f, 0.06184793f, 0.06895787f, -0.02300362f, 
    -0.18269120f, 0.06435239f, -0.05782521f, -0.19656502f, 0.04438012f, 0.01955537f, 0.05661052f, 0.02994788f, 
    0.10975721f, 0.11843020f, -0.01374432f, 0.07686669f, -0.39449853f, 0.14315052f, -0.13251315f, 0.03682599f, 
    -0.00317551f, 0.03014841f, -0.00778071f, -0.03853667f, 0.14113964f, 0.01167452f, -0.01873906f, 0.11010465f, 
    0.26094821f, 0.16654971f, -0.06852104f, 0.11875651f, 0.08322635f, -0.12049200f, 0.05214246f, 0.02889361f, 
    -0.06913925f, -0.04799142f, -0.04054601f, -0.06693947f, 0.12530951f, -0.03749089f, 0.27202925f, 0.04945811f, 
    -0.10627465f, -0.00468208f, -0.06270281f, -0.07576667f, 0.10994975f, -0.00547118f, -0.02483031f, -0.06327815f, 
    -0.03679660f, 0.19425544f, -0.17208511f, -0.13505676f, -0.01514317f, 0.13706733f, 0.16519837f, -0.01695137f, 
    0.11814241f, -0.09621300f, -0.00832838f, -0.05000594f, -0.12482885f, 0.01839392f, -0.07126785f, 0.13102584f, 
    -0.05248293f, -0.03736986f, 0.00012112f, -0.05141315f, -0.04560616f, 0.06775410f, -0.11695951f, 0.00998167f, 
    0.13725637f, 0.00658382f, 0.14780186f, 0.19043134f, -0.17990486f, 0.02533388f, 0.07352626f, -0.05268027f, 
    0.06488638f, -0.07615846f, 0.02405095f, 0.03523502f, 0.10277863f, 0.13799523f, 0.04512746f, 0.05693936f, 
    -0.18010755f, 0.02372277f, -0.04120519f, 0.05172073f, -0.13021210f, 0.05579850f, 0.00480545f, 0.12655167f, 
    0.10257091f, -0.04492326f, 0.02173860f, 0.12993608f, -0.00162477f, -0.16048901f, -0.12495687f, -0.01555901f, 
    -0.09492524f, -0.08108547f, -0.02715886f, 0.08019248f, 0.08893769f, 0.07059813f, -0.16245878f, 0.11990444f, 
    -0.03651882f, -0.09742098f, 0.10120942f, -0.04202869f, -0.14497359f, 0.00438561f, -0.01528879f, 0.13930914f, 
    0.07961295f, 0.38072458f, 0.07918470f, 0.03100088f, 0.06925514f, -0.04347436f, -0.04817548f, 0.08632313f, 
    -0.05171406f, -0.01052758f, -0.02697574f, 0.07541079f, -0.01253545f, -0.02357616f, -0.01231285f, 0.15570726f, 
    0.05240670f, 0.14408946f, -0.07232468f, -0.00073777f, 0.07789087f, 0.07869373f, 0.05642595f, 0.00986028f, 
    -0.07492483f, -0.05009118f, -0.24704443f, -0.47373316f, 0.01297977f, 0.05836189f, 0.06570650f, -0.07270464f, 
    0.00164750f, 0.10528091f, 0.13171497f, -0.09179018f, -0.05609967f, 0.29271948f, -0.24532464f, -0.09290440f, 
    0.03092390f, 0.07301365f, -0.00942707f, 0.11617424f, -0.10801999f, -0.01550837f, -0.06781614f, -0.17126009f, 
    0.02121622f, -0.28461340f, 0.08231143f, -0.01564498f, 0.02386586f, -0.11694632f, 0.03337928f, 0.15999725f, 
    0.08690092f, 0.06041056f, -0.02058642f, 0.13421348f, -0.14982265f, -0.06937397f, -0.07296214f, 0.07448833f, 
    -0.07150734f, 0.07193745f, 0.00408063f, -0.14008664f, -0.05967296f, -0.09000148f, 0.00711491f, -0.06674378f, 
    -0.05366878f, -0.02934971f, -0.07443623f, 0.00651559f, 0.18419212f, 0.05903201f, 0.05191116f, 0.06365019f, 
    0.02813050f, 0.01052182f, 0.13761698f, -0.01476355f, -0.29840949f, 0.04927593f, -0.12144906f, -0.22376022f, 
    -0.08742277f, 0.12294043f, 0.07153782f, -0.11949763f, -0.06682044f, -0.02604324f, -0.00047595f, -0.01327959f, 
    0.15059097f, 0.19694871f, 0.20269610f, -0.11096645f, 0.13955167f, -0.05524592f, -0.16904087f, -0.04999641f, 
    0.12307770f, 0.19339323f, 0.09385920f, 0.22225563f, 0.03697696f, 0.01674272f, 0.07103308f, -0.17150113f, 
    0.01199472f, -0.00195925f, 0.03761780f, -0.00686159f, 0.15295200f, 0.08891506f, 0.11274050f, 0.07141633f, 
    -0.10766502f, -0.05885779f, -0.11591069f, 0.01027186f, -0.00593174f, -0.05840624f, -0.05973032f, -0.22734949f, 
    0.16211234f, 0.04270452f, 0.01276878f, 0.00768351f, -0.00068709f, 0.08894327f, -0.25257018f, 0.30509463f, 
    0.08635360f, 0.07088405f, 0.01331803f, -0.20685792f, -0.05059839f, -0.11896820f, 0.06427585f, -0.00067134f, 
    0.11283679f, 0.08044448f, -0.06552413f, -0.14361741f, 0.09015658f, -0.00436767f, 0.11773869f, -0.17511924f, 
    0.15974563f, -0.07344433f, 0.15036270f, -0.00327268f, -0.01401674f, 0.17135110f, 0.05759255f, 0.11134266f, 
    0.07149847f, 0.02399855f, -0.08371754f, -0.07558580f, 0.16409868f, 0.04455876f, 0.02322871f, 0.04969243f, 
    -0.39818501f, 0.20127808f, 0.11219569f, 0.07069718f, 0.25296301f, -0.00924137f, -0.04618220f, 0.08991754f, 
    -0.07055029f, 0.12613769f, 0.12813389f, 0.03862986f, 0.16026562f, 0.32013100f, 0.10995778f, -0.04862278f, 
    0.13576126f, -0.02320935f, 0.01143750f, 0.02630689f, 0.08505113f, 0.06568614f, 0.05631547f, 0.00006915f, 
    -0.14456142f, 0.15921864f, 0.12256297f, 0.16250172f, 0.13283022f, 0.14406449f, -0.10899089f, -0.04937197f, 
    0.08283155f, 0.15454195f, -0.00462858f, 0.05993297f, -0.12611060f, 0.20615876f, -0.24718487f, -0.07445820f, 
    -0.09806955f, 0.03594958f, -0.01330925f, -0.03595667f, 0.03077969f, 0.23204522f, 0.03357400f, 0.11782595f, 
    -0.14354178f, -0.10168339f, -0.05900347f, -0.08386931f, -0.13644017f, -0.08301716f, 0.04711824f, -0.02122280f, 
    -0.03088439f, -0.07267454f, 0.10424387f, -0.02664749f, 0.00966574f, 0.25510249f, 0.01858200f, 0.16565208f, 
    0.02089072f, 0.10520500f, -0.05805582f, -0.05724813f, -0.01973356f, 0.12252960f, 0.04586259f, 0.03068170f, 
    -0.07161048f, 0.12748723f, -0.08749119f, 0.09891310f, 0.09272221f, -0.00819185f, 0.01076917f, 0.16690427f, 
    0.11319068f, 0.05793519f, -0.04627793f, 0.04619658f, -0.14122958f, -0.10824349f, 0.07864124f, -0.21827103f, 
    -0.04318117f, 0.05971547f, 0.09116843f, 0.04254574f, 0.10724380f, 0.05698575f, 0.03343541f, 0.08395146f, 
    0.19376044f, 0.04648684f, -0.10796531f, 0.02400933f, -0.00119561f, -0.05418992f, 0.05963823f, 0.05272388f, 
    -0.01447346f, -0.08228307f, -0.03699014f, 0.08038860f, -0.09304414f, 0.11337705f, -0.11300433f, -0.03618347f, 
    0.01067101f, -0.00627714f, 0.05668129f, 0.13892296f, -0.04664831f, 0.08427399f, 0.01664846f, 0.11202546f, 
    0.01128556f, 0.07654883f, -0.09130011f, 0.39464626f, 0.05354076f, -0.08890801f, 0.05752098f, 0.02315704f, 
    0.12194583f, 0.15028210f, 0.00735125f, 0.01007211f, 0.31906343f, -0.12274101f, 0.26380178f, 0.25703347f, 
    -0.17580494f, 0.06593359f, 0.03659882f, 0.04695413f, 0.00009672f, 0.06713950f, -0.01313163f, 0.01566874f, 
    -0.03769115f, -0.03588599f, -0.09105606f, 0.09148697f, -0.11485465f, 0.05652845f, -0.08494096f, 0.00978931f, 
    -0.03070168f, 0.06533768f, 0.07255611f, 0.01575218f, 0.12213427f, 0.16252895f, -0.16263442f, -0.14167468f, 
    -0.10168072f, -0.07862245f, 0.02910460f, 0.06980375f, -0.02227611f, 0.04117030f, -0.02706221f, 0.02717400f, 
    0.07885797f, 0.08529906f, 0.11896993f, -0.15004939f, 0.04129492f, 0.10227969f, -0.06767683f, 0.03855824f, 
    -0.02389555f, -0.03117277f, -0.01505909f, 0.00217166f, 0.27622071f, -0.05658016f, 0.04386347f, -0.00437678f, 
    -0.02521173f, -0.04580947f, 0.02189042f, 0.08524631f, -0.07319255f, -0.00018942f, -0.02110923f, 0.19061764f, 
    0.02214619f, -0.08102582f, 0.21185234f, 0.06890577f, -0.04595991f, 0.03804977f, -0.00875399f, -0.08848421f, 
    0.12209987f, -0.08858921f, 0.05153449f, 0.06070345f, -0.17726904f, 0.14829265f, 0.00702833f, 0.16572160f, 
    0.17016715f, 0.05417516f, 0.14022125f, -0.04877287f, 0.06312191f, -0.01684540f, 0.01899444f, -0.02311370f, 
    0.07198547f, -0.18676504f, 0.03389435f, 0.20830648f, 0.08359949f, 0.04833525f, -0.05378377f, 0.00657390f, 
    -0.00872992f, -0.03231086f, -0.06253409f, 0.01116772f, -0.33311200f, 0.30446112f, -0.16270418f, -0.22110452f, 
    0.04499653f, 0.15245445f, 0.04939046f, -0.00556767f, 0.08246937f, -0.07192045f, -0.00534979f, 0.07299097f, 
    0.15888928f, -0.05529941f, -0.10989922f, -0.17441010f, 0.05585403f, 0.03634609f, -0.00594331f, 0.04921571f, 
    0.02101638f, -0.06140961f, 0.05344801f, 0.06813080f, -0.09759052f, -0.03429744f, -0.08373003f, -0.22635350f, 
    -0.05711893f, 0.01118789f, 0.09428393f, 0.13927275f, -0.09279763f, -0.13577893f, -0.02000301f, -0.00994431f, 
    -0.06178683f, -0.15258984f, 0.02983255f, -0.04366176f, 0.00365746f, -0.01473895f, 0.00717952f, 0.03935934f, 
    0.00644479f, 0.05969904f, 0.00182587f, 0.15591921f, -0.25225127f, -0.14953010f, -0.03116607f, 0.08447275f, 
    -0.01960217f, 0.06378746f, 0.07404637f, 0.04988243f, 0.07803783f, -0.07716107f, 0.05978470f, -0.01090211f, 
    0.10002361f, -0.15848255f, -0.17012040f, 0.11943576f, -0.00155303f, -0.01768500f, -0.04758875f, -0.12163476f, 
    0.07588875f, 0.03937832f, 0.08961532f, -0.00771647f, -0.02594412f, -0.05465178f, -0.20881498f, -0.10120998f, 
    0.05541074f, 0.02789860f, -0.01239771f, 0.01037707f, 0.00318093f, -0.00058335f, 0.02514379f, -0.03593491f, 
    0.01797578f, 0.15718490f, 0.18708359f, -0.15894195f, 0.01966591f, -0.04451960f, -0.04765429f, 0.02992635f, 
    0.14251323f, -0.02409263f, -0.01875229f, 0.04457425f, 0.01177028f, 0.31121042f, -0.02306267f, -0.10847791f, 
    0.05841965f, -0.04072122f, -0.04132415f, 0.03080198f, -0.00523524f, -0.04878479f, 0.14426471f, 0.00577395f, 
    -0.18987235f, 0.07285215f, -0.14551911f, -0.10837345f, -0.05637135f, -0.01829349f, 0.03595096f, -0.12550195f, 
    -0.00838443f, 0.09962080f, 0.01617426f, 0.13001281f, 0.07783920f, 0.24144351f, 0.03515893f, 0.16844574f, 
    0.07350118f, 0.21167094f, 0.04600725f, -0.04201272f, -0.04479339f, 0.02198442f, 0.05519108f, -0.03770176f, 
    -0.22739296f, 0.08825035f, 0.08347171f, -0.25923148f, 0.14471862f, 0.00816790f, 0.03515350f, 0.08927692f, 
    0.05185285f, 0.09219351f, 0.01636687f, 0.02301702f, 0.10124289f, 0.16587314f, 0.03637635f, 0.06491726f, 
    0.14839698f, 0.07972309f, -0.01878107f, -0.02962502f, 0.06371575f, -0.06141692f, -0.04159758f, -0.12413717f, 
    0.03819348f, 0.20134620f, 0.05240403f, 0.09429944f, 0.06757180f, -0.01885383f, -0.01597513f, 0.11262646f, 
    0.00472914f, 0.06292319f, -0.03701323f, 0.01609094f, 0.00198212f, 0.18993804f, 0.13498530f, -0.12111971f, 
    0.12056757f, 0.06788152f, -0.13492407f, 0.03826509f, 0.07144094f, 0.02889515f, -0.06115709f, 0.02554475f, 
    -0.25677687f, 0.05485113f, 0.05498598f, 0.08247237f, -0.01564589f, -0.00595758f, 0.15814607f, -0.01262853f, 
    -0.00092874f, 0.03123461f, -0.05220686f, -0.02065286f, 0.28852800f, -0.34955594f, -0.00393633f, -0.02869612f, 
    0.10791279f, -0.03417965f, 0.10839313f, -0.02396479f, 0.10040115f, -0.04087877f, 0.02920446f, 0.09913740f, 
    -0.05925316f, -0.16549499f, 0.04048871f, 0.08878953f, -0.00732338f, 0.05916725f, 0.01258873f, 0.06762259f, 
    -0.02637640f, 0.00695837f, 0.01385364f, 0.10936850f, -0.07871376f, 0.03145184f, 0.12696920f, 0.09015600f, 
    0.05081255f, 0.13925086f, 0.10628396f, -0.06571357f, 0.04781303f, 0.02160574f, -0.06270760f, 0.00165470f, 
    -0.24730383f, 0.10026083f, 0.17952134f, -0.24369995f, -0.04827536f, -0.01469374f, -0.16487701f, -0.13599610f, 
    -0.15176818f, 0.05681089f, 0.02663569f, -0.16050576f, -0.08051854f, -0.03356789f, -0.02029018f, -0.14996050f, 
    0.10616023f, -0.09013594f, -0.19225590f, -0.10330810f, 0.04775742f, 0.08152452f, 0.11408603f, 0.08683231f, 
    -0.21386175f, 0.00777414f, -0.01764327f, -0.32440507f, -0.04447399f, -0.09103345f, 0.01659566f, 0.02988992f, 
    0.00105266f, -0.05668879f, -0.01678573f, -0.00733251f, 0.02964131f, -0.13436349f, 0.04185474f, 0.07997902f, 
    0.04742106f, 0.08931775f, 0.02406667f, -0.03538386f, -0.12980182f, -0.05296518f, 0.12577012f, 0.14794300f, 
    0.09379790f, -0.13422287f, -0.02898349f, 0.20627122f, 0.12955377f, 0.22694840f, 0.05288593f, 0.05648651f, 
    -0.01898723f, -0.05328508f, -0.01462753f, 0.13712202f, 0.00965444f, -0.00678931f, 0.23039882f, 0.10099680f, 
    0.12753731f, 0.07908320f, 0.08849256f, -0.15668231f, 0.10774812f, -0.03238821f, -0.09420598f, 0.02641612f, 
    0.10422915f, 0.00524902f, 0.13866363f, 0.09449248f, 0.24706924f, -0.04991599f, 0.15524082f, 0.09197079f, 
    0.16603169f, -0.03402672f, -0.05224521f, -0.30746350f, 0.25582770f, 0.22685137f, -0.02313351f, 0.06966246f, 
    0.05507476f, -0.03914857f, -0.07224273f, -0.15863509f, 0.06879158f, -0.03823201f, 0.09164805f, 0.08072092f, 
    -0.03023394f, -0.20096737f, 0.10206622f, 0.24701150f, 0.04065017f, 0.08149677f, 0.01925750f, 0.01052021f, 
    -0.00611464f, -0.09903368f, 0.11659186f, -0.04756614f, -0.05299045f, -0.07347417f, 0.01765540f, 0.00857022f, 
    0.07974250f, 0.19309975f, -0.03955930f, -0.18878174f, -0.19143371f, 0.03955487f, 0.02991423f, 0.14657076f, 
    0.02471345f, -0.01398095f, -0.12601955f, 0.06075649f, -0.03628684f, -0.04391478f, 0.00876676f, 0.10992575f, 
    0.08914832f, -0.06986430f, 0.15577756f, 0.07532415f, 0.14666033f, -0.14188853f, -0.20646968f, -0.13896538f, 
    -0.02948661f, -0.14784186f, 0.02360142f, -0.05738176f, 0.01741390f, -0.15912373f, 0.08900359f, 0.24884124f, 
    0.11092930f, 0.06105682f, 0.04879361f, -0.02353932f, -0.04408069f, -0.09186219f, 0.13609239f, 0.01069430f, 
    -0.02313211f, 0.10269483f, 0.07076669f, -0.00716947f, 0.01972198f, -0.05485273f, 0.04107929f, 0.10381278f, 
    0.03257180f, -0.01281625f, -0.00657109f, 0.10736658f, 0.09297814f, 0.13166775f, -0.06280053f, -0.03848133f, 
    -0.13910016f, -0.07237205f, 0.07760448f, 0.17413937f, -0.03299171f, 0.01998526f, -0.01076605f, -0.12804973f, 
    0.13746685f, -0.10635034f, 0.01834728f, -0.16873187f, 0.02325813f, 0.04810919f, -0.05134702f, -0.02068333f, 
    0.18996476f, 0.06963089f, 0.09055800f, 0.09438630f, 0.03245025f, -0.08321913f, 0.12643203f, -0.18849176f, 
    -0.04068847f, -0.05640987f, 0.07102803f, -0.09930978f, 0.03306534f, 0.00558628f, 0.08481751f, -0.05210692f, 
    0.00682686f, 0.01027644f, 0.08467951f, 0.00501130f, -0.26805943f, -0.05589999f, -0.06363075f, -0.04125647f, 
    -0.08091239f, 0.14974944f, -0.01491507f, 0.06647557f, 0.03365691f, -0.16356495f, -0.05502579f, -0.16949721f, 
    0.18794903f, -0.18306428f, -0.02344097f, 0.03825040f, 0.08455301f, -0.02546099f, -0.00769920f, -0.11436695f, 
    0.06419869f, 0.07432456f, 0.12195411f, -0.14209622f, -0.26947030f, -0.00730102f, -0.13176242f, 0.03061388f, 
    0.01656452f, 0.01513891f, 0.06724843f, 0.03767132f, 0.10635767f, -0.02100674f, 0.07900022f, -0.04408740f, 
    0.29061505f, 0.02967691f, 0.09235734f, -0.08069436f, 0.09811593f, 0.05581772f, -0.17046851f, -0.04733275f, 
    -0.04053692f, -0.11165589f, 0.00621287f, -0.01479788f, -0.10195667f, 0.29855210f, -0.09738364f, 0.06284187f, 
    0.07164647f, -0.00941203f, -0.09987628f, -0.20185474f, -0.05221147f, 0.00174118f, 0.02554863f, -0.10266566f, 
    -0.07286857f, 0.02697835f, 0.02845058f, -0.14267169f, -0.01206963f, 0.04230787f, 0.05610987f, -0.11066823f, 
    0.07069198f, 0.04737255f, 0.16801259f, 0.11930436f, 0.31582069f, 0.27513680f, -0.00052339f, 0.25193623f, 
    -0.03735160f, 0.15665181f, 0.04029053f, 0.04016593f, -0.07269602f, 0.06401620f, 0.12157091f, 0.10782567f, 
    0.11816578f, -0.07767520f, 0.06621394f, 0.07556178f, 0.01036723f, 0.01206966f, -0.02441580f, -0.01830629f, 
    0.10656410f, 0.02355231f, -0.01777804f, -0.00246305f, 0.25989464f, 0.31471339f, -0.02350815f, 0.02541560f, 
    0.17169169f, 0.01664855f, 0.00999445f, -0.07011358f, -0.00344279f, -0.10959978f, -0.11093260f, -0.03366534f, 
    0.36078694f, 0.20392171f, -0.17191026f, 0.03204766f, 0.01010111f, -0.03603097f, 0.08238225f, 0.10677236f, 
    -0.02839060f, -0.02535370f, 0.03396760f, -0.02325171f, 0.00518944f, 0.01333372f, -0.05835953f, -0.14731617f, 
    0.05717584f, -0.10701218f, -0.08454464f, 0.12158319f, -0.03327153f, 0.04477718f, -0.01960688f, -0.03243792f, 
    0.11675398f, 0.28584918f, 0.01341328f, -0.04339786f, 0.11494054f, 0.02510495f, 0.01849936f, 0.09472331f, 
    0.00112081f, -0.15260608f, -0.01654716f, 0.08824600f, 0.51086187f, -0.45702133f, 0.05866859f, -0.01713108f, 
    -0.02345260f, 0.09428524f, -0.00272945f, 0.06036192f, -0.07420044f, -0.01185312f, 0.11917306f, 0.01649023f, 
    0.09487127f, -0.12564358f, -0.02019375f, -0.15305384f, 0.12081838f, 0.21997216f, -0.03990676f, 0.15888445f, 
    -0.03532170f, 0.07422069f, -0.10056141f, 0.01381488f, 0.14177714f, 0.14619076f, 0.00257886f, 0.00354836f, 
    0.05961352f, 0.09368640f, -0.02599755f, 0.05539228f, -0.00812277f, -0.00593600f, 0.03826484f, 0.07670325f, 
    -0.40680531f, 0.20433339f, -0.20898756f, -0.11406066f, 0.01425389f, 0.05532631f, -0.02144939f, -0.04920195f, 
    0.00728491f, -0.01744613f, -0.04245662f, -0.04338597f, -0.26372397f, -0.16175388f, 0.10385237f, 0.11613715f, 
    0.11707362f, -0.02863532f, -0.03264668f, -0.10800356f, 0.15462130f, 0.05876458f, 0.11883819f, 0.02940295f, 
    -0.30818513f, -0.15510871f, -0.33171192f, -0.21150374f, 0.12015931f, 0.20892297f, -0.05739654f, 0.11693956f, 
    0.08608568f, -0.04713361f, 0.04388374f, 0.10268278f, 0.14556697f, -0.11969954f, -0.14594035f, 0.10698151f, 
    0.12394350f, 0.02182603f, 0.05541430f, 0.11992149f, 0.03962917f, -0.03897965f, -0.05765690f, -0.06648125f, 
    -0.03264286f, -0.04922582f, 0.13686202f, 0.25550580f, -0.05477129f, -0.11638266f, 0.07154748f, 0.04138720f, 
    -0.07160462f, 0.00371736f, 0.01075118f, 0.13212135f, 0.11409191f, 0.03688358f, 0.15937871f, -0.06270274f, 
    -0.00176226f, -0.03434270f, 0.16211727f, -0.01198777f, 0.07340343f, 0.01522558f, 0.07971519f, 0.20046268f, 
    0.06244507f, 0.16056529f, -0.11024491f, 0.23320033f, 0.13673255f, 0.13269222f, 0.02337917f, 0.15022007f, 
    -0.07902963f, 0.07476529f, -0.06513386f, -0.16540858f, -0.20269048f, 0.10136157f, 0.14228636f, -0.20264192f, 
    -0.06053651f, -0.00818201f, 0.05294535f, -0.08365718f, 0.08591995f, -0.18223684f, 0.04834877f, 0.11333764f, 
    -0.40950629f, 0.24590927f, 0.26169896f, 0.06875080f, -0.04034400f, 0.09915598f, 0.02586818f, 0.03291991f, 
    0.00253781f, 0.11677262f, 0.04845396f, -0.04480160f, -0.08138689f, -0.17964785f, 0.14244780f, 0.02268640f, 
    -0.16722760f, -0.00371762f, -0.02040411f, -0.09138365f, -0.11358682f, 0.20937429f, 0.10397052f, 0.17119806f, 
    0.01713215f, -0.18270186f, 0.12093947f, 0.00607763f, -0.09393992f, -0.08298608f, 0.09706892f, -0.11740525f, 
    0.13238253f, -0.00070271f, 0.22672811f, 0.15427183f, 0.03208070f, 0.15039887f, 0.10996550f, 0.11398376f, 
    -0.06675000f, -0.08628628f, 0.03992243f, -0.14912339f, -0.02343399f, -0.00600565f, 0.14389250f, 0.25284794f, 
    -0.11803591f, -0.02202014f, 0.13250507f, 0.04997536f, -0.10100179f, -0.08647036f, 0.05756278f, -0.09203100f, 
    -0.11023565f, 0.05880975f, 0.16742073f, 0.04383111f, -0.03228765f, 0.09954115f, -0.12977304f, 0.06666242f, 
    0.02970796f, 0.01597217f, 0.01291335f, -0.13834758f, -0.01786982f, 0.03565036f, 0.08495624f, -0.01684325f, 
    -0.44765285f, -0.12856996f, -0.11373035f, 0.10754876f, 0.11622714f, 0.03542964f, 0.01417717f, -0.10637001f, 
    0.10808792f, -0.07429038f, 0.04054982f, -0.14570262f, -0.06360589f, -0.18764456f, 0.14780690f, 0.03025036f, 
    0.12515174f, -0.02368126f, 0.04305914f, 0.02960758f, 0.04729078f, -0.04301475f, -0.08519774f, -0.18313174f, 
    0.03224993f, 0.28730440f, -0.12883186f, 0.10140952f, 0.15451941f, 0.07129136f, 0.03574532f, -0.05884523f, 
    -0.07249061f, -0.04914489f, -0.04400767f, -0.03977306f, -0.01709104f, 0.12981761f, 0.04825835f, 0.22267230f, 
    0.08782607f, 0.02015027f, 0.02937306f, 0.03095093f, 0.04623501f, 0.10364469f, 0.01484238f, -0.00328816f, 
    -0.44843805f, 0.08885176f, -0.19137385f, -0.02743805f, 0.10296283f, 0.11380897f, -0.01835698f, 0.09256320f, 
    0.02149438f, 0.03382570f, 0.01194788f, 0.08778921f, 0.32651550f, 0.04448921f, 0.02301033f, 0.12278045f, 
    -0.00784479f, 0.05264897f, 0.01615053f, 0.15487823f, 0.06957624f, 0.05686502f, -0.10044031f, -0.03512476f, 
    0.07714994f, -0.19259192f, 0.01766168f, -0.03748878f, -0.09962944f, -0.11662930f, -0.02511425f, -0.09927395f, 
    -0.02255680f, -0.05251489f, 0.02235860f, 0.06670380f, 0.24376996f, 0.02591920f, -0.11300224f, 0.12610854f, 
    0.11177395f, -0.12101150f, -0.03667752f, -0.10881816f, -0.09066515f, -0.04664164f, -0.01209363f, 0.02759702f, 
    -0.09461261f, 0.05554667f, -0.05425886f, 0.17655697f, 0.19303201f, 0.12310981f, -0.08524125f, 0.12499995f, 
    -0.13960542f, -0.01378808f, 0.06658278f, -0.06021494f, 0.05466038f, -0.00249465f, 0.34215891f, -0.23175274f, 
    0.05203134f, -0.00020831f, 0.02207489f, -0.03794336f, 0.06955234f, 0.00067325f, 0.02827255f, 0.05760233f, 
    -0.36060637f, 0.25310487f, 0.05772608f, -0.06786299f, -0.01228735f, 0.12074824f, -0.12790698f, -0.09291892f, 
    -0.04619942f, 0.13428542f, 0.11559203f, -0.02741432f, -0.11091326f, -0.00275846f, 0.12930447f, 0.05377511f, 
    -0.08077171f, -0.04829868f, -0.06676921f, -0.15230596f, -0.09206330f, 0.05282664f, 0.00892675f, 0.06010445f, 
    0.35053626f, -0.13197277f, 0.01552289f, -0.09472681f, 0.02632878f, -0.04714995f, -0.08300540f, -0.15320760f, 
    0.04223300f, 0.05500946f, 0.06071120f, 0.08653158f, 0.01775147f, -0.14964351f, 0.11567780f, -0.00260957f, 
    -0.11164320f, -0.14511873f, -0.08917162f, -0.04949085f, 0.12505639f, 0.10288546f, 0.08864362f, 0.07264010f, 
    0.07009932f, 0.08346539f, 0.11279490f, -0.06104147f, -0.06407565f, -0.21661273f, -0.01085288f, -0.20594415f, 
    -0.03662185f, 0.01136856f, 0.03194531f, 0.06515869f, 0.12909615f, -0.21913564f, 0.06826120f, 0.29297611f, 
    -0.01060152f, -0.05247588f, -0.12974443f, 0.03521968f, 0.02788262f, -0.04313318f, 0.10195579f, 0.01732591f, 
    -0.08197042f, 0.31309319f, 0.13846998f, 0.22794405f, 0.12381301f, -0.03737763f, 0.02408047f, 0.04069485f, 
    0.07334794f, -0.01167102f, -0.08231023f, -0.00582079f, 0.18713416f, -0.15605642f, 0.06468550f, 0.05867949f, 
    0.07738484f, -0.05124089f, 0.01335289f, -0.04242134f, -0.00447634f, -0.00070326f, -0.06245066f, 0.00605425f, 
    -0.09357128f, 0.10671746f, -0.02243761f, 0.12150078f, -0.06907729f, -0.10699264f, -0.01308321f, 0.19554986f, 
    -0.00841109f, 0.04647115f, -0.22859637f, -0.10124385f, -0.34382361f, -0.04232341f, -0.18767147f, -0.17841947f, 
    0.00330494f, 0.05710461f, 0.01466235f, 0.12165458f, -0.02535943f, 0.03408316f, 0.08736619f, -0.00455143f, 
    0.53337228f, -0.10821673f, 0.02089306f, 0.10918362f, -0.03108328f, -0.04315963f, -0.12103130f, -0.01716314f, 
    -0.04622510f, 0.01798442f, -0.02530780f, 0.05847436f, 0.04328100f, 0.13127865f, -0.19544476f, -0.11084300f, 
    0.06055199f, 0.03772568f, -0.06130864f, 0.07188108f, -0.04937525f, -0.03601212f, -0.04444541f, -0.03930341f, 
    0.13511483f, -0.10125540f, -0.02770869f, 0.03699030f, 0.08059054f, 0.08263542f, -0.01429221f, -0.05352878f, 
    -0.00586900f, -0.08392254f, 0.01183727f, 0.06513079f, 0.07626840f, 0.06905898f, -0.01151551f, 0.15947229f, 
    0.20471947f, 0.02642628f, 0.04787366f, -0.01813672f, -0.11515328f, -0.01680013f, 0.04646147f, 0.07407536f, 
    0.01968594f, -0.13719252f, -0.35278887f, -0.02048747f, -0.05688041f, -0.07437271f, -0.11382348f, 0.01016736f, 
    0.11152659f, 0.10072608f, 0.19292291f, 0.10459925f, -0.07859810f, 0.00475892f, 0.09670307f, -0.20636903f, 
    0.03498583f, 0.04968789f, 0.11778939f, -0.12458196f, -0.01045443f, -0.00454475f, 0.05643861f, 0.01865305f, 
    -0.19980255f, 0.17664248f, 0.08547144f, -0.31463599f, 0.15812746f, -0.09264820f, 0.02368202f, -0.03996149f, 
    0.11962303f, 0.07673672f, 0.06266247f, -0.08570296f, 0.02735093f, -0.05744362f, 0.05889206f, 0.09302426f, 
    0.05450613f, 0.03959755f, 0.04354943f, -0.11519688f, -0.04414121f, 0.05233111f, -0.04935121f, -0.08720700f, 
    -0.11091677f, 0.16751502f, 0.03678269f, 0.09852953f, -0.01957943f, 0.08563518f, 0.15685889f, 0.08405745f, 
    0.03235352f, 0.02900923f, 0.04316330f, 0.00499443f, -0.06421814f, 0.19385400f, 0.06894823f, -0.05869134f, 
    0.13657460f, 0.08611272f, -0.00758852f, -0.00416516f, -0.03798996f, 0.06324495f, 0.05239778f, -0.00395405f, 
    -0.35962844f, 0.01849798f, 0.00354400f, -0.07187425f, 0.11394571f, 0.15737581f, 0.05378571f, -0.04684357f, 
    0.00852038f, 0.04864790f, 0.04439067f, 0.00294334f, 0.10802440f, -0.02291927f, -0.39317462f, -0.09920597f, 
    0.09194753f, 0.00565491f, -0.05189018f, 0.00707129f, 0.03416609f, -0.02061551f, -0.13111889f, 0.04558821f, 
    0.16764762f, 0.12740308f, 0.33662754f, 0.09253563f, -0.03572048f, -0.07282650f, 0.00612891f, 0.22315370f, 
    0.03555700f, 0.00521552f, 0.07739293f, -0.03817147f, 0.03271301f, -0.17124581f, 0.16685130f, -0.07716845f, 
    -0.04346493f, 0.04580551f, 0.15112530f, -0.05204475f, -0.00283704f, -0.16015412f, 0.05045990f, 0.09699266f, 
    -0.08641123f, 0.10617464f, -0.01145035f, -0.05559744f, -0.01938020f, 0.11662611f, 0.04302674f, -0.09525225f, 
    0.03031424f, -0.02770781f, -0.05729840f, 0.09029873f, 0.04433573f, 0.01580153f, 0.19754444f, -0.01967270f, 
    0.07486560f, 0.03442707f, 0.02266705f, 0.07454246f, 0.16277978f, -0.00090118f, 0.02773265f, 0.00861762f, 
    0.55182004f, -0.32799166f, 0.09501228f, -0.16052365f, 0.02902753f, 0.09375323f, 0.00921949f, 0.05099136f, 
    0.01259768f, -0.02738914f, -0.03782519f, 0.08626606f, -0.14965320f, 0.01540680f, -0.20720305f, 0.31836873f, 
    0.06665455f, -0.04334702f, 0.14732353f, 0.00266723f, 0.09076371f, -0.05301834f, 0.01802017f, 0.06053001f, 
    -0.01348110f, 0.21924429f, 0.02482746f, 0.08591303f, -0.00369162f, -0.02772167f, 0.05839882f, -0.10008452f, 
    0.04968534f, 0.05757769f, -0.08169533f, -0.04104874f, -0.28507042f, 0.19225182f, 0.08275667f, 0.00081763f, 
    -0.11402956f, -0.00046220f, -0.01333886f, -0.01414725f, -0.01744122f, 0.07159366f, -0.01970301f, 0.06674121f, 
    0.12868313f, 0.08107335f, 0.03885955f, -0.01011441f, -0.06863984f, 0.04280294f, 0.08915253f, -0.00262836f, 
    -0.06249180f, 0.04408290f, 0.12189353f, 0.05232484f, -0.27767110f, 0.09904156f, -0.01172881f, 0.20024690f, 
    0.00671973f, 0.02575816f, 0.08698320f, 0.18153553f, -0.07143418f, -0.03717884f, -0.08657075f, -0.02627455f, 
    -0.09293585f, -0.03686625f, 0.12788545f, 0.00211766f, -0.07365842f, 0.04551749f, -0.01769019f, 0.09354227f, 
    0.03705934f, 0.03725550f, -0.00854476f, 0.16028640f, 0.04942931f, 0.25169048f, 0.07860202f, -0.04739821f, 
    0.01642808f, -0.02905010f, 0.15492640f, 0.15795994f, -0.00770416f, -0.08305286f, -0.04857312f, 0.00139834f, 
    0.02779949f, 0.15315162f, -0.04666714f, 0.07240146f, -0.06733850f, -0.04304316f, 0.15001296f, -0.09031993f, 
    -0.00432540f, -0.03246810f, -0.01728478f, -0.07582962f, -0.02984738f, -0.02407230f, 0.05869526f, 0.00484205f, 
    0.12176564f, 0.17825054f, 0.02548166f, 0.03385778f, -0.08544345f, 0.07565046f, -0.05345129f, 0.00956615f, 
    -0.16196913f, 0.26953387f, 0.08625574f, -0.03521224f, 0.04150680f, -0.06862610f, 0.01995791f, 0.07074901f, 
    -0.25658852f, -0.16027011f, -0.03020503f, -0.06873395f, 0.33207181f, -0.37366316f, 0.06718276f, 0.05757578f, 
    0.20873389f, 0.06259537f, 0.12092728f, 0.00604668f, -0.02602643f, -0.01379621f, 0.08010873f, 0.03733441f, 
    0.23478255f, 0.03076654f, -0.15491004f, -0.29276466f, 0.12213004f, 0.23569009f, -0.05077974f, 0.12125158f, 
    0.05934017f, 0.08385752f, 0.01562382f, 0.13259554f, -0.21050394f, 0.11228796f, -0.19387783f, 0.01154362f, 
    0.11888665f, 0.00454601f, 0.08346006f, -0.03229460f, -0.12044546f, -0.07128190f, -0.00731941f, 0.06434901f, 
    0.15604757f, -0.20378056f, -0.01875838f, -0.01504873f, 0.00593511f, 0.09593733f, 0.15543769f, 0.12687609f, 
    0.06090568f, 0.06841911f, 0.08348517f, 0.21939991f, 0.30008489f, -0.00399503f, -0.09077434f, 0.27050385f, 
    -0.00097693f, 0.01895011f, -0.12227781f, -0.09088463f, 0.01007991f, -0.01969610f, -0.10779499f, -0.04044732f, 
    -0.12102481f, 0.05792543f, 0.04617718f, 0.06892812f, 0.02826712f, -0.06611350f, -0.02561233f, -0.04390119f, 
    -0.14562972f, -0.00379715f, 0.00742253f, 0.05232834f, 0.11134338f, -0.08958875f, 0.05204991f, -0.09948176f, 
    0.02609889f, -0.06974743f, -0.03380761f, 0.09794021f, -0.08144286f, -0.00114513f, 0.07151313f, -0.05106787f, 
    0.01905814f, 0.02566750f, -0.01195102f, -0.05693099f, 0.05292842f, 0.11269931f, 0.01126452f, -0.15179047f, 
    -0.07040700f, -0.10705938f, 0.11679894f, -0.01496976f, -0.18218210f, 0.06426547f, -0.10815083f, -0.28930536f, 
    0.16493315f, -0.00955409f, -0.02636980f, -0.11349993f, 0.03868983f, 0.01549670f, -0.02075953f, -0.03818743f, 
    0.11117111f, 0.01447668f, 0.22034536f, 0.02386043f, 0.00853223f, 0.04079819f, -0.01192493f, -0.05091803f, 
    -0.07911845f, -0.12658067f, 0.03877662f, 0.19395721f, -0.13382003f, -0.18451107f, 0.02226446f, 0.09491937f, 
    -0.01312646f, -0.01895122f, 0.07754762f, -0.09967703f, 0.08113479f, -0.01183744f, 0.05836106f, -0.05189029f, 
    0.27936575f, -0.12710918f, 0.00971952f, 0.23564446f, 0.12874122f, 0.07234875f, -0.08427501f, 0.03870906f, 
    0.04281106f, -0.00498689f, 0.14083922f, 0.12189595f, -0.21412830f, 0.14251862f, -0.05848469f, 0.10644913f, 
    0.05950560f, 0.02547201f, 0.06706488f, 0.01633146f, 0.12970524f, -0.16570440f, 0.06796259f, -0.18945394f, 
    0.00365345f, -0.00906360f, -0.22651820f, -0.19145423f, -0.00073095f, 0.11144753f, 0.04225748f, 0.01835066f, 
    -0.04722173f, 0.17082433f, 0.06294453f, 0.09701184f, 0.06900357f, 0.03510780f, 0.15153785f, 0.18906741f, 
    0.02690931f, 0.17889306f, -0.07411188f, 0.08936767f, -0.04677321f, 0.00882032f, -0.01933171f, -0.07244191f, 
    0.31859514f, -0.06053513f, -0.10792985f, -0.00203550f, -0.01715642f, 0.21147871f, -0.07947664f, -0.12578736f, 
    0.08776490f, -0.04725538f, -0.03476256f, -0.00059093f, 0.19026685f, 0.09549881f, 0.19323215f, 0.23094241f, 
    -0.11290546f, -0.07590394f, -0.02739171f, 0.08462062f, -0.04048802f, 0.00777178f, 0.05610678f, 0.04274801f, 
    -0.17115328f, 0.04849603f, 0.15443720f, 0.15323973f, -0.18437178f, 0.01623517f, 0.12523581f, 0.10654010f, 
    -0.09811600f, -0.00849665f, -0.04238414f, 0.01230858f, -0.02096385f, 0.01446801f, 0.07818080f, 0.23614818f, 
    0.02391041f, 0.06537325f, -0.04934483f, -0.17340302f, 0.12816244f, 0.17030810f, 0.17017177f, 0.10591869f, 
    -0.01602795f, -0.06676800f, 0.06720389f, 0.02703414f, -0.02681184f, 0.06322047f, 0.11803122f, 0.23337613f, 
    0.06562611f, 0.06954309f, -0.00779790f, 0.02390024f, 0.02800315f, 0.11069406f, -0.21386610f, 0.06442160f, 
    0.21201177f, -0.17187090f, -0.11169513f, -0.09652417f, 0.02874498f, -0.12766986f, -0.04528747f, -0.08008679f, 
    -0.03498469f, -0.01994073f, 0.17150764f, -0.08085593f, -0.06928049f, -0.01222260f, 0.06580926f, 0.00447035f, 
    -0.00722559f, 0.00539297f, -0.04918358f, -0.04018428f, 0.30856013f, -0.18992662f, 0.06644184f, -0.13646811f, 
    0.01011601f, -0.00482093f, -0.01786810f, 0.03690302f, -0.07781708f, -0.10369809f, 0.03339625f, -0.09144256f, 
    0.00885504f, -0.15725666f, -0.10197791f, 0.25310591f, 0.06708032f, 0.20493303f, 0.07354321f, -0.11860370f, 
    0.04602003f, 0.02979991f, 0.13138464f, -0.15715630f, 0.19478828f, 0.07091554f, 0.00541499f, 0.14103866f, 
    0.20095585f, 0.01834302f, -0.11424877f, -0.01999652f, -0.01937653f, 0.09650424f, -0.03427852f, 0.02039910f, 
    0.12484880f, -0.22855993f, 0.12758455f, -0.07617007f, 0.13736403f, -0.16089416f, -0.04734508f, 0.09017600f, 
    -0.07714298f, -0.04605978f, -0.02921578f, -0.04697920f, 0.07611024f, 0.26575416f, 0.00863359f, -0.20009653f, 
    0.04916852f, -0.10926274f, -0.02153694f, -0.07985130f, -0.05480739f, 0.01396273f, 0.11051342f, 0.10212012f, 
    0.15550999f, 0.09343136f, -0.11584394f, 0.11016971f, 0.06999724f, -0.07224473f, -0.06184574f, -0.08915044f, 
    0.04092846f, 0.09856997f, 0.06755236f, 0.08016483f, -0.11588901f, -0.10717690f, -0.08600451f, 0.00642116f, 
    0.06827070f, 0.12689257f, 0.04239715f, -0.08658782f, -0.01696954f, 0.02290408f, 0.23495036f, -0.13620399f, 
    0.05096711f, 0.13504738f, -0.11451034f, -0.15537070f, 0.03191279f, 0.05386231f, -0.04920936f, 0.08274338f, 
    -0.04002978f, 0.15865019f, 0.16822371f, 0.08803813f, -0.09438541f, -0.19892359f, 0.01309076f, 0.14146501f, 
    0.03660950f, -0.00745202f, 0.06819480f, 0.02688610f, 0.17063421f, 0.04973301f, 0.06181948f, -0.11716855f, 
    0.22935165f, -0.13096264f, -0.13946019f, -0.00753168f, 0.06670399f, 0.07604770f, -0.10540603f, -0.16072686f, 
    0.18968654f, 0.08107390f, 0.17262909f, -0.07106271f, 0.10036398f, 0.31357187f, 0.07255559f, 0.25007588f, 
    0.03402294f, -0.16908006f, -0.06593577f, -0.05823168f, -0.02183627f, 0.03700348f, -0.09123621f, -0.00269064f, 
    -0.21246237f, 0.21409659f, 0.31293312f, 0.28409156f, -0.10203790f, -0.11264320f, 0.05753119f, 0.09844240f, 
    -0.09560963f, -0.01844685f, -0.02668924f, -0.01831287f, -0.07183561f, -0.16101058f, 0.00244885f, -0.05505128f, 
    0.05627823f, -0.03270862f, 0.02659623f, -0.19692646f, 0.08664534f, -0.08889195f, 0.06084275f, 0.12346441f, 
    -0.07797826f, 0.04044427f, -0.01031089f, 0.04906092f, 0.05569930f, -0.00688865f, -0.05891883f, -0.07403837f, 
    -0.01007151f, -0.05609905f, 0.01714779f, 0.03364918f, -0.03068438f, 0.02774392f, 0.05688961f, -0.03902310f, 
    0.04993142f, -0.04361026f, -0.00503455f, -0.04958629f, -0.06694713f, -0.07621753f, -0.04048372f, 0.00965782f, 
    0.01479816f, -0.03632469f, -0.04180647f, 0.05659841f, 0.01092694f, -0.06649257f, -0.05352373f, -0.04976703f, 
    -0.01444922f, -0.06634862f, 0.04658403f, 0.05005843f, -0.00704251f, -0.03614888f, -0.07338363f, -0.04210887f, 
    -0.06998359f, 0.06592157f, 0.01597326f, -0.05528687f, 0.04821961f, -0.07699051f, 0.05551480f, -0.06836607f, 
    -0.06564961f, -0.07160848f, -0.03081708f, -0.01439129f, 0.03935022f, 0.00836725f, -0.06843474f, -0.02774145f, 
    -0.07162252f, 0.06190989f, -0.01624709f, -0.01642712f, -0.00861229f, -0.01909489f, -0.06985126f, -0.05910289f, 
    -0.04357824f, -0.05145820f, 0.04443769f, 0.04595719f, 0.05910234f, 0.05461916f, -0.02899970f, -0.01122716f, 
    0.02146028f, -0.06704447f, -0.07808611f, -0.02839101f, 0.01642575f, -0.03428562f, -0.02139999f, 0.05473435f, 
    -0.00590502f, -0.02041502f, 0.01783150f, 0.03761804f, 0.05067458f, 0.03064577f, -0.04500208f, 0.04717410f, 
    0.00227920f, 0.06553884f, -0.00367017f, -0.07370634f, 0.06320950f, 0.01039118f, 0.06026886f, -0.01736305f, 
    0.04193591f, 0.01198910f, -0.05141603f, -0.00527974f, -0.02993548f, -0.00521461f, -0.01104784f, -0.07612663f, 
    0.03321337f, -0.00752534f, -0.00175143f, -0.03030019f, 0.05721893f, -0.06197719f, -0.06618363f, -0.06519029f, 
    -0.01727667f, -0.01230513f, 0.06133955f, -0.04462865f, -0.06620088f, -0.07692448f, 0.02480749f, -0.07710213f, 
    -0.02399308f, 0.00417248f, 0.02691784f, -0.03000575f, 0.00298024f, 0.06014464f, -0.03113364f, 0.03998693f, 
    -0.03759413f, -0.00063783f, 0.03515017f, -0.06208008f, -0.04691206f, 0.03965257f, -0.04989440f, -0.02603106f, 
    0.00941821f, -0.04619346f, -0.04468982f, 0.03103152f, -0.00515587f, -0.05661229f, -0.01300486f, 0.01041825f, 
    -0.06929987f, -0.06347026f, 0.07544275f, 0.02182370f, 0.00961371f, -0.02903932f, -0.05363215f, -0.05107078f, 
    0.04432123f, 0.03064333f, -0.05372367f, 0.05217736f, 0.03829542f, 0.01064328f, -0.04722882f, -0.03177019f, 
    -0.02738369f, -0.02909977f, 0.00950068f, -0.00709086f, 0.03471186f, 0.06044624f, -0.03011827f, -0.04089810f, 
    -0.06601518f, 0.02700657f, 0.02429362f, -0.07763477f, -0.01039036f, 0.05145019f, -0.00486682f, -0.07070653f, 
    -0.05799444f, 0.01208999f, 0.01097370f, 0.04030239f, -0.05854189f, -0.04763693f, 0.03516237f, -0.02438037f, 
    -0.02424970f, 0.01596560f, 0.02198016f, 0.03250333f, 0.00999789f, -0.01872354f, 0.03985996f, -0.03763836f, 
    0.06221823f, 0.05188681f, 0.03735737f, -0.00522832f, 0.03273797f, -0.07083861f, -0.00992665f, 0.02049751f, 
    0.02309382f, -0.02954807f, -0.01477702f, -0.05297231f, -0.06160621f, -0.04185716f, -0.05123640f, 0.01363233f, 
    -0.07362675f, 0.03640181f, -0.00632490f, -0.07242646f, 0.00264123f, 0.00577081f, 0.06105528f, 0.00188818f, 
    0.06573145f, -0.05685806f, -0.07234475f, -0.05298144f, -0.00439123f, -0.05601735f, -0.07042951f, -0.01611382f, 
    -0.03318763f, 0.04532647f, 0.04510007f, -0.06469332f, 0.06679831f, 0.03016728f, -0.01537355f, -0.03379733f, 
    0.03792739f, -0.00007839f, 0.00795007f, 0.01787525f, 0.01924038f, -0.02342635f, -0.05493828f, 0.03225977f, 
    0.03813319f, -0.04361957f, 0.06438705f, -0.06387391f, -0.00816667f, -0.05174818f, 0.03220551f, 0.03202970f, 
    -0.06324433f, -0.03735821f, -0.03576591f, -0.02560408f, -0.07002668f, 0.05988823f, -0.02367449f, -0.03285365f, 
    -0.00778296f, -0.06102036f, -0.00982750f, 0.06509382f, 0.02201297f, -0.04542285f, -0.03752409f, 0.03931563f, 
    0.03491315f, 0.00037519f, -0.04854503f, 0.02341093f, -0.00738361f, -0.07039945f, 0.01062861f, -0.03371124f, 
    0.00471534f, -0.01275994f, -0.05024777f, 0.00560311f, 0.04991305f, -0.06687836f, -0.07688817f, 0.03076902f, 
    -0.01073017f, 0.05974767f, -0.08413877f, 0.00790666f, -0.00813448f, -0.05327703f, -0.06138020f, 0.03734134f, 
    0.05930809f, 0.00770261f, 0.02768536f, -0.04291090f, 0.00846344f, -0.05294383f, -0.04336817f, -0.00237983f, 
    0.00346518f, -0.05482962f, 0.04675172f, -0.03440015f, -0.06814224f, 0.01558584f, -0.04565817f, -0.00344238f, 
    -0.05628036f, -0.01907121f, 0.05102520f, 0.03269543f, -0.03689182f, 0.00508768f, -0.03272629f, -0.04725670f, 
    0.02092771f, 0.00675306f, -0.05399077f, -0.06449550f, -0.07491048f, 0.01353826f, 0.03556582f, 0.06101511f, 
    0.04066462f, -0.04519113f, 0.06140734f, -0.02725448f, -0.04893060f, -0.01133987f, -0.02866785f, -0.04705141f, 
    0.03485618f, -0.02367577f, 0.03816409f, 0.02862355f, -0.03726897f, 0.02931919f, 0.05760528f, 0.03623559f, 
    0.06404185f, 0.03025888f, -0.02817583f, -0.07359565f, -0.05503822f, 0.01284155f, -0.05037148f, -0.04395448f, 
    0.04576296f, 0.06256954f, -0.07702506f, 0.03311836f, -0.03338739f, -0.00940836f, -0.05724537f, -0.08384908f, 
    0.05864549f, 0.00435492f, -0.01699895f, -0.02473097f, -0.04516139f, 0.01651902f, -0.06137378f, -0.02975675f, 
    -0.05961503f, -0.06858208f, -0.02338418f, 0.02093850f, -0.03709977f, 0.05378597f, 0.05457665f, -0.01451267f, 
    0.03879673f, 0.01058568f, -0.07112353f, -0.05337414f, -0.05132402f, -0.07422301f, 0.03313984f, -0.03024317f, 
    0.02163851f, -0.00550243f, -0.07379352f, -0.00100351f, 0.05058305f, 0.05573027f, -0.01529452f, 0.02278699f, 
    0.11613356f, 0.01450394f, 0.27221993f, 0.03647335f, -0.02257752f, 0.01251738f, 0.03442058f, -0.01063717f, 
    0.04481236f, 0.14683396f, 0.18452474f, -0.03850713f, 0.27893224f, 0.22728264f, -0.00444347f, 0.03757395f, 
    -0.08166815f, -0.04402602f, 0.00962915f, 0.03756025f, 0.00914446f, 0.11416992f, -0.00582984f, 0.01486872f, 
    -0.03379525f, 0.04910197f, 0.26207936f, 0.06375819f, -0.01731087f, 0.06512364f, 0.10435162f, 0.02904933f, 
    -0.04044727f, -0.07353995f, 0.03736671f, -0.04478996f, -0.10869448f, -0.05203946f, 0.25255993f, 0.03794164f, 
    -0.00038889f, -0.03708814f, 0.06720375f, 0.05903086f, -0.11614022f, -0.06225748f, 0.18897630f, 0.08848333f, 
    0.05888038f, -0.15009503f, -0.06945232f, 0.07234073f, 0.00615926f, 0.08012895f, 0.04379300f, 0.04661731f, 
    0.01998198f, 0.08078460f, 0.04346189f, -0.06228253f, 0.03769132f, -0.14456916f, 0.04139128f, 0.10795491f, 
    0.01227868f, 0.06694953f, 0.05503749f, -0.00944788f, 0.09493409f, 0.04876997f, -0.05564882f, -0.02290901f, 
    0.17834194f, -0.14614169f, 0.23637508f, 0.07597283f, 0.06319893f, 0.00402612f, -0.05694931f, 0.15095776f, 
    0.12526405f, 0.00332394f, -0.05158300f, -0.13627400f, 0.24958315f, -0.01642568f, -0.22342770f, 0.01695440f, 
    -0.05167166f, -0.16425402f, -0.05445017f, -0.04573496f, 0.11154575f, 0.14045639f, -0.01941456f, -0.05653836f, 
    0.41332492f, -0.09471784f, -0.08990343f, 0.26037040f, -0.03290067f, -0.03053657f, -0.11393642f, 0.05286243f, 
    0.04419670f, 0.01166329f, 0.01117472f, 0.08071592f, -0.06021925f, -0.14180677f, -0.05484879f, 0.01905563f, 
    -0.06910798f, -0.07022823f, 0.01964288f, -0.07800955f, -0.02376044f, 0.07714739f, -0.05191951f, 0.09183693f, 
    -0.19550888f, 0.03601079f, -0.04343395f, -0.08770042f, 0.09083706f, -0.00810666f, 0.04190965f, 0.01752413f, 
    0.02816434f, -0.04061146f, 0.01303673f, 0.11218866f, 0.05233710f, -0.19293869f, -0.18897003f, 0.03859340f, 
    0.14163934f, 0.00741987f, 0.14724408f, -0.03548769f, -0.02960382f, -0.06485713f, 0.03850178f, 0.02231139f, 
    0.24983555f, -0.13242878f, -0.03321750f, 0.05288953f, 0.00730214f, -0.00649721f, -0.06702636f, 0.04962091f, 
    0.07879833f, 0.01438630f, 0.06904240f, 0.08378238f, -0.23118207f, 0.34412327f, 0.06823681f, -0.12618841f, 
    -0.05827422f, 0.09969002f, -0.00764908f, 0.02518271f, 0.01273742f, 0.01369081f, -0.01235513f, 0.02631299f, 
    0.00934875f, -0.01572981f, 0.06700011f, 0.04232400f, -0.03242157f, 0.02115463f, 0.12693909f, -0.11664031f, 
    -0.06644898f, -0.04538931f, 0.15281579f, -0.02906438f, 0.14237246f, 0.04364321f, -0.13620311f, -0.02574537f, 
    -0.04107590f, -0.16719712f, -0.06317247f, 0.06822222f, -0.05701036f, -0.02405130f, 0.09651837f, 0.08389023f, 
    -0.03732688f, -0.05171555f, -0.01120854f, -0.07553237f, 0.06189998f, -0.07504518f, -0.04137829f, -0.01665018f, 
    -0.04222344f, 0.05228492f, 0.01262939f, -0.03896832f, -0.04229452f, 0.06493341f, 0.03606554f, 0.06100480f, 
    -0.01834711f, -0.04386308f, 0.03624513f, -0.02576316f, 0.05527613f, 0.00106469f, 0.02662836f, 0.00801470f, 
    -0.05077871f, -0.02941727f, 0.04212271f, -0.07122298f, 0.00902444f, -0.00021574f, -0.07852966f, -0.03277027f, 
    0.02629787f, 0.03009809f, 0.04721057f, 0.04177649f, 0.03301137f, -0.03316750f, -0.03688401f, -0.01235269f, 
    0.01828554f, 0.04276968f, 0.05189154f, 0.06345942f, 0.05730570f, -0.07329432f, 0.04237220f, 0.00294182f, 
    0.05417987f, 0.03745893f, -0.07361267f, -0.06521775f, -0.00914023f, -0.03364873f, 0.05339298f, -0.04290619f, 
    -0.06140971f, 0.01041349f, 0.00019034f, -0.01680906f, 0.02704800f, -0.06013485f, -0.02738373f, -0.07450482f, 
    0.06064256f, -0.03765475f, 0.01446973f, -0.03546839f, -0.04770752f, -0.06664703f, 0.05616848f, -0.05825205f, 
    0.02061391f, -0.03514228f, 0.03009461f, -0.03598734f, 0.03007120f, -0.07839539f, -0.01409758f, -0.02997740f, 
    0.04318846f, 0.06478242f, 0.04512937f, -0.00477754f, 0.03033277f, -0.00069921f, 0.03594331f, -0.05264160f, 
    -0.05215812f, -0.00649331f, -0.05687634f, 0.06221307f, 0.00168290f, 0.01689648f, -0.03216070f, -0.02273442f, 
    -0.06102401f, -0.04255036f, 0.02652319f, 0.00458371f, 0.05421590f, -0.02626165f, 0.01907506f, 0.00503347f, 
    -0.04914155f, 0.01932667f, -0.07251558f, -0.00185757f, 0.04322751f, -0.06148099f, -0.04904940f, 0.04132233f, 
    0.01909591f, -0.01481433f, -0.06290352f, 0.04090827f, -0.03499906f, -0.07054627f, -0.07127576f, 0.01173432f, 
    -0.05075660f, -0.07030563f, 0.01961203f, -0.07368007f, -0.00062869f, 0.04933321f, 0.00749398f, -0.02863356f, 
    0.01066465f, 0.00383631f, -0.05017871f, -0.02314444f, -0.01532533f, 0.01994943f, 0.03842228f, -0.06031191f, 
    0.01424091f, 0.05885379f, -0.01080995f, -0.02640494f, 0.06130740f, 0.03417051f, 0.00674564f, -0.06147705f, 
    0.06118669f, -0.04756276f, -0.06228453f, -0.04892492f, 0.04852690f, -0.01236986f, -0.00101732f, 0.00240899f, 
    -0.00991622f, -0.02902032f, -0.04959873f, -0.07216607f, 0.01815692f, -0.03499438f, 0.06093416f, -0.04753770f, 
    -0.01935673f, -0.07442537f, -0.03593075f, -0.02896822f, 0.02816987f, -0.00247213f, -0.06018678f, -0.02390536f, 
    -0.05974974f, -0.03381810f, -0.07487249f, 0.04968029f, 0.05616537f, -0.03211646f, -0.01169066f, -0.04851071f, 
    0.06149664f, -0.04244088f, 0.02294233f, -0.02329979f, 0.06487083f, -0.06715338f, -0.01271444f, -0.04333402f, 
    -0.05149419f, 0.05739192f, -0.07096713f, -0.07281767f, 0.04997901f, -0.04538080f, -0.04981093f, 0.02190775f, 
    0.04227577f, -0.07513849f, 0.06338289f, -0.02665958f, -0.01005555f, 0.04690707f, 0.01535631f, 0.04464966f, 
    -0.00879614f, -0.03439373f, 0.02764110f, 0.03633228f, 0.04786914f, -0.08478495f, -0.05052846f, 0.00169248f, 
    -0.08228961f, 0.00906713f, 0.03224020f, 0.02588364f, 0.04286344f, -0.03487964f, -0.04498134f, 0.02046429f, 
    -0.01630992f, -0.03219210f, -0.03721416f, 0.04141604f, 0.01716385f, -0.08133934f, -0.07027940f, -0.00363608f, 
    0.01915992f, 0.00091956f, -0.01036307f, 0.00345384f, 0.04785764f, -0.00872626f, 0.01787907f, -0.03289462f, 
    -0.08261061f, -0.05361008f, -0.06830909f, 0.07074411f, -0.04715385f, -0.05665386f, -0.06765489f, -0.05000677f, 
    0.04984952f, -0.06284977f, 0.05067249f, -0.05496743f, 0.02519897f, -0.00433059f, -0.01993347f, 0.00246084f, 
    0.05207792f, 0.02232113f, 0.04374107f, 0.01715127f, 0.05613262f, -0.00465444f, 0.01552253f, 0.03446581f, 
    0.00302004f, 0.00439311f, -0.06156432f, -0.00554151f, 0.00436326f, -0.07252867f, -0.03651496f, 0.03462455f, 
    -0.07056695f, -0.02545647f, 0.01193380f, 0.04245450f, 0.00944152f, -0.05852417f, -0.01551224f, -0.04222310f, 
    -0.06272899f, -0.04696557f, 0.04637435f, -0.03027114f, 0.01453065f, 0.00240589f, 0.01832027f, -0.02126205f, 
    -0.04837394f, -0.04772456f, 0.03873607f, -0.03765287f, -0.05693211f, -0.00688345f, 0.02595177f, -0.07481832f, 
    -0.02096882f, 0.02417546f, -0.01814498f, 0.03321193f, -0.03825346f, 0.03968596f, 0.05893581f, -0.04850569f, 
    -0.04923300f, 0.02955552f, 0.06240251f, -0.01018760f, -0.01528249f, -0.01234838f, 0.02018267f, 0.02630172f, 
    -0.06925163f, 0.07177860f, 0.04168166f, 0.01307440f, 0.02554996f, -0.04004908f, 0.03527229f, 0.01167938f, 
    -0.00821424f, -0.01574746f, 0.01821926f, -0.06907769f, -0.02371330f, -0.07635468f, -0.02479891f, -0.00262719f, 
    0.02112321f, -0.02706275f, -0.02259102f, -0.05299799f, -0.08620690f, -0.05447618f, -0.04099317f, -0.03756891f, 
    -0.03416630f, 0.01311547f, -0.01216617f, -0.06777243f, -0.03951879f, 0.06585196f, -0.01646273f, -0.02332347f, 
    -0.08128381f, -0.02931072f, -0.08509333f, -0.06294422f, -0.02668800f, 0.03132045f, -0.03474887f, -0.05603874f, 
    -0.05041208f, 0.01101235f, 0.01453044f, -0.05919829f, -0.04156750f, -0.06277616f, 0.01602565f, -0.06697401f, 
    -0.07218760f, -0.05638766f, -0.07351046f, -0.01443265f, 0.06533530f, 0.04469986f, -0.05066136f, -0.00803172f, 
    0.04423808f, 0.01477932f, -0.00471166f, -0.03912717f, 0.04815991f, 0.03978171f, 0.06639329f, 0.03432279f, 
    -0.03989555f, -0.03795604f, -0.03300073f, 0.03122577f, 0.06878924f, -0.04429930f, 0.01626690f, 0.01208661f, 
    -0.04130724f, -0.07299966f, -0.06676250f, -0.01053512f, 0.05230018f, 0.03991691f, -0.00286027f, -0.08422533f, 
    0.04916978f, 0.02566180f, -0.07778301f, 0.12945379f, -0.06704024f, -0.03330775f, 0.06662658f, 0.15780446f, 
    0.21095897f, 0.10144097f, 0.02368176f, 0.13650125f, 0.12701450f, 0.01081312f, -0.11018155f, -0.08378487f, 
    -0.06459466f, 0.02296019f, 0.06140846f, 0.02042199f, 0.00971578f, 0.01684563f, 0.02546357f, -0.00745069f, 
    0.26549929f, -0.02228134f, -0.02943687f, 0.20858142f, 0.00239820f, -0.02023358f, 0.00597596f, 0.01156912f, 
    0.01760684f, 0.00536075f, 0.03413178f, 0.03720832f, 0.10338949f, -0.04663476f, 0.05736154f, -0.17755228f, 
    0.02456409f, -0.02101599f, 0.00725419f, 0.06338093f, -0.12785594f, 0.09815769f, 0.11467578f, -0.02163104f, 
    -0.25194585f, 0.02728863f, 0.09696512f, 0.20082286f, 0.01309801f, 0.05705814f, 0.07694702f, -0.01147529f, 
    0.06896695f, 0.10937396f, 0.02974692f, -0.02550436f, 0.14423087f, -0.16137551f, 0.03744027f, -0.08529735f, 
    -0.01574993f, -0.00871886f, -0.08075463f, 0.13635769f, 0.02034359f, 0.01864869f, -0.01706387f, 0.18613043f, 
    -0.00167024f, -0.15224715f, 0.05022483f, 0.18187170f, -0.12429143f, -0.10052132f, -0.14743109f, 0.01445916f, 
    0.00301673f, 0.03968719f, -0.03757575f, 0.19193135f, -0.10781673f, -0.14102636f, -0.13554844f, -0.02366656f, 
    -0.03656889f, -0.11068916f, 0.03206778f, 0.00874594f, 0.01076099f, 0.05400420f, -0.01677638f, -0.22491336f, 
    0.22505489f, 0.01335012f, -0.06327970f, -0.07740586f, -0.00563502f, 0.07253582f, -0.07695614f, 0.09407401f, 
    -0.06417005f, -0.08315240f, 0.05581724f, 0.09653711f, -0.03273718f, -0.26585397f, 0.03628826f, 0.08176266f, 
    -0.09870113f, -0.05864732f, 0.00989094f, 0.05888372f, 0.17264332f, -0.03828492f, -0.11321295f, -0.03052895f, 
    -0.41851023f, -0.13116750f, 0.22650708f, -0.17259230f, -0.03473366f, 0.15288226f, 0.10843422f, -0.12367574f, 
    0.06810401f, 0.14963712f, -0.03349189f, 0.12195905f, -0.11753187f, 0.00481882f, 0.10773126f, 0.01726341f, 
    0.28218400f, 0.19733313f, -0.02643559f, 0.02301018f, 0.04715212f, 0.08418847f, -0.05982232f, -0.05321132f, 
    0.01252267f, -0.38551599f, -0.04967096f, 0.18541135f, 0.00639933f, 0.16188435f, -0.01528255f, -0.08957189f, 
    0.20241405f, 0.06669550f, -0.01300982f, 0.09362055f, -0.36387357f, 0.49574876f, 0.02752759f, -0.12115593f, 
    0.13353293f, 0.13978696f, -0.00685088f, -0.06322082f, 0.01041698f, 0.03791267f, 0.02285568f, 0.07162151f, 
    0.12433726f, -0.00185369f, -0.13309580f, -0.06146881f, -0.14916031f, -0.09878724f, 0.01751304f, 0.01969214f, 
    -0.06487604f, 0.06732977f, 0.06755114f, 0.10269183f, 0.06494846f, -0.07353421f, 0.04675651f, 0.09314712f, 
    -0.04316261f, 0.03632519f, 0.04222840f, -0.05936623f, 0.06113409f, 0.14753640f, -0.03390602f, 0.20680514f, 
    0.01111085f, 0.08485322f, 0.22719227f, 0.12473723f, 0.03190127f, -0.04282052f, -0.07345407f, 0.13977660f, 
    -0.04746137f, 0.09510046f, -0.03215167f, -0.15727961f, -0.28720012f, -0.01114145f, 0.11053286f, -0.27173460f, 
    0.08747434f, -0.04386322f, -0.02868868f, 0.10341751f, 0.00362822f, -0.07438990f, -0.02157199f, 0.02503823f, 
    -0.10243864f, 0.17772453f, -0.04907240f, 0.10437839f, -0.02521774f, -0.01300156f, -0.00135619f, -0.07911272f, 
    -0.02436760f, 0.10362695f, -0.17552197f, 0.13575232f, 0.11283465f, 0.01294630f, 0.11637277f, -0.09400777f, 
    -0.03905189f, 0.06417339f, -0.08776238f, 0.15744863f, 0.10379764f, 0.17920710f, 0.08786819f, 0.07585236f, 
    -0.00480557f, -0.31608564f, -0.20672670f, 0.07717533f, -0.00049744f, -0.06301276f, -0.02216497f, 0.00221130f, 
    -0.05370171f, -0.14152196f, 0.10532833f, 0.01762860f, 0.19895351f, -0.03230025f, 0.07879067f, 0.19741537f, 
    0.06034993f, 0.05926600f, -0.11932287f, -0.22089326f, -0.08160848f, -0.07714180f, 0.07862303f, -0.01939918f, 
    0.15633862f, 0.01274402f, 0.00645422f, -0.04951164f, 0.00744753f, 0.03403552f, 0.01449090f, 0.05308412f, 
    0.03859920f, 0.02874879f, -0.08007772f, -0.01989491f, 0.17851214f, 0.28112674f, 0.07282100f, -0.26995444f, 
    -0.08396545f, -0.01905978f, -0.14694999f, -0.08488172f, -0.10896561f, 0.00725878f, 0.12318759f, 0.29075557f, 
    0.01734620f, 0.13095284f, 0.13134341f, -0.10239423f, 0.10707781f, -0.03086558f, -0.16465993f, -0.02137475f, 
    0.01023624f, 0.05660230f, -0.01601895f, -0.02007603f, 0.07876063f, -0.08825521f, -0.08801633f, -0.02290841f, 
    -0.13744386f, 0.07088403f, -0.15732664f, -0.15268911f, -0.09290950f, 0.08801083f, 0.13182771f, 0.02814779f, 
    0.36767384f, -0.10121689f, -0.00261973f, 0.08610789f, 0.07127519f, 0.05684032f, 0.01723163f, -0.09231917f, 
    -0.11350437f, -0.03946859f, 0.01762885f, 0.01070739f, -0.05346636f, -0.01055496f, -0.10262244f, 0.10101251f, 
    -0.02504439f, -0.15156318f, 0.13200577f, 0.04557817f, 0.18680923f, -0.06541731f, 0.09417190f, -0.05546765f, 
    0.26833206f, 0.03070727f, -0.07023471f, -0.09507316f, 0.22993290f, -0.04359604f, -0.15368909f, -0.03791568f, 
    0.05568775f, 0.10560952f, -0.09151304f, 0.04951220f, 0.04842586f, -0.03480936f, -0.02263544f, 0.19314934f, 
    0.02223922f, 0.10986182f, -0.08953051f, -0.04290969f, -0.01524116f, 0.04071605f, -0.07252357f, 0.03153883f, 
    0.12269075f, 0.29936141f, 0.04741281f, -0.21641421f, -0.08844870f, 0.02970936f, 0.06277629f, 0.21624847f, 
    -0.00433209f, -0.09648883f, 0.04491473f, 0.04507962f, 0.03959384f, 0.05260844f, 0.15196486f, -0.07931434f, 
    0.07930855f, 0.24393296f, 0.04127038f, -0.04717259f, 0.06305329f, -0.03843093f, 0.02126535f, -0.17031996f, 
    -0.02954417f, 0.04291447f, 0.06614930f, 0.03751469f, -0.07188505f, -0.03746951f, -0.05301337f, 0.05645733f, 
    0.01098752f, -0.07074979f, 0.00947184f, 0.04972307f, -0.01702943f, 0.02794321f, -0.06023224f, 0.04645246f, 
    -0.05315256f, 0.01799254f, -0.04621710f, 0.06637515f, -0.04693458f, -0.00060724f, -0.03354610f, 0.03863703f, 
    -0.04166075f, -0.06187838f, 0.01460678f, 0.05008515f, 0.02143451f, -0.03505908f, 0.06029063f, 0.00592732f, 
    0.02551086f, -0.07422251f, -0.04751055f, 0.06517070f, 0.02851433f, 0.02303960f, 0.00616094f, -0.06566460f, 
    -0.00185303f, 0.01093906f, -0.05780606f, -0.05358832f, -0.01177758f, -0.00914457f, -0.00474947f, 0.00642395f, 
    -0.05308690f, -0.05748053f, 0.04497350f, 0.03371939f, 0.01331732f, 0.01503631f, 0.05145862f, -0.05339837f, 
    0.06485174f, -0.02256198f, 0.03257597f, 0.06447678f, 0.05907968f, -0.03111241f, -0.02930846f, 0.06032439f, 
    -0.07213044f, -0.06442461f, -0.06865811f, -0.03844966f, 0.04080621f, -0.07723094f, 0.00400090f, 0.04528056f, 
    0.03276812f, -0.01363667f, 0.06347342f, 0.00007596f, -0.06660098f, 0.05632568f, -0.01381722f, -0.05335607f, 
    -0.07039768f, 0.04991464f, -0.06824721f, -0.07497654f, -0.02544454f, 0.00862719f, -0.03856701f, -0.04046279f, 
    -0.05147967f, 0.03283348f, 0.06465369f, 0.05800735f, -0.06942026f, -0.05107142f, 0.00487352f, -0.03812182f, 
    -0.01679482f, 0.03594801f, 0.03769322f, -0.04158078f, -0.01618136f, -0.00476372f, -0.05911339f, 0.01729395f, 
    -0.05390292f, -0.07377871f, 0.06216780f, 0.02641054f, -0.05056626f, -0.06135868f, -0.05046110f, -0.00481871f, 
    -0.05420877f, -0.00665357f, -0.07396504f, -0.01187414f, -0.04061281f, -0.04633457f, 0.05174945f, -0.02116879f, 
    0.00104146f, 0.01912400f, -0.07194357f, 0.04760740f, 0.06284595f, 0.05175427f, -0.00129088f, 0.03148014f, 
    -0.06368087f, 0.03540425f, -0.00728027f, -0.06173054f, 0.03973011f, -0.05158651f, 0.01818449f, -0.05266491f, 
    0.03104684f, -0.04982641f, 0.02031577f, -0.02926297f, 0.03859262f, -0.04969591f, -0.03043840f, -0.06974754f, 
    -0.03299223f, 0.02083918f, -0.06119382f, 0.05807312f, -0.04484517f, -0.01847715f, 0.06312247f, -0.05754154f, 
    0.02213081f, 0.05905469f, -0.02465408f, -0.03544467f, -0.00934746f, -0.01074080f, -0.05826318f, 0.02657031f, 
    -0.03685392f, -0.02642186f, -0.03788314f, -0.04686869f, -0.05961199f, 0.05005325f, -0.05060029f, -0.02122452f, 
    -0.02172433f, -0.04518879f, -0.00073121f, -0.07027947f, -0.04711709f, 0.05441465f, -0.01436489f, 0.03629879f, 
    0.03526686f, -0.07158520f, -0.06190429f, 0.04540488f, 0.03987693f, -0.07677022f, -0.06433339f, -0.03093315f, 
    0.01854331f, 0.00191482f, -0.02262875f, -0.07632804f, 0.06174833f, -0.06552728f, -0.05820007f, 0.01754904f, 
    -0.02824541f, 0.15820739f, -0.03932410f, 0.19939339f, 0.09509964f, 0.04626576f, 0.06919660f, 0.04457983f, 
    0.06283801f, -0.03691012f, -0.09508226f, -0.01523632f, -0.08438552f, 0.15200935f, 0.05822364f, -0.22679867f, 
    0.15066920f, -0.04369414f, 0.02930962f, 0.09907707f, -0.02666207f, 0.00697697f, 0.02650801f, 0.09806163f, 
    0.18008462f, 0.05054697f, -0.13730618f, -0.00121239f, 0.05451903f, 0.06649379f, 0.00880209f, 0.02848646f, 
    0.07032334f, 0.04674314f, 0.04120526f, 0.16266605f, -0.04789283f, -0.03914277f, -0.11328664f, 0.12011545f, 
    -0.03570504f, 0.14205630f, 0.02064881f, 0.12755030f, 0.11015436f, 0.04928915f, 0.02257121f, 0.07899402f, 
    0.04866918f, -0.09760945f, -0.19317023f, 0.25351340f, -0.11766049f, -0.17503600f, 0.00013469f, -0.11206069f, 
    -0.02229473f, -0.01559518f, 0.00714717f, -0.04283042f, 0.24012117f, -0.19521019f, 0.05505017f, 0.28207657f, 
    -0.21452154f, -0.14235573f, -0.08195230f, -0.07576954f, -0.01720559f, 0.07999320f, -0.02511894f, 0.03622992f, 
    -0.00081132f, -0.02674921f, -0.10052476f, 0.12845823f, -0.06361957f, 0.02473358f, 0.02698186f, 0.03599755f, 
    0.03462953f, -0.03408296f, -0.08785907f, -0.06126907f, -0.38805959f, 0.01286610f, 0.04581087f, -0.31677452f, 
    0.11841813f, -0.21661888f, -0.02411194f, -0.06612477f, -0.08824514f, -0.00344395f, -0.03374528f, 0.19198623f, 
    -0.06599860f, 0.25505421f, 0.07346744f, -0.14670414f, -0.05859708f, 0.00268947f, -0.02851404f, -0.14615729f, 
    0.09282602f, 0.01865797f, -0.06800564f, -0.02884810f, -0.03438321f, -0.01990896f, 0.14901465f, -0.13201359f, 
    -0.22992338f, -0.12889476f, 0.05543279f, 0.03805738f, 0.03632247f, 0.08733474f, 0.08384879f, 0.21757932f, 
    0.05031992f, -0.23031743f, 0.09431712f, 0.19035955f, 0.00858438f, -0.11713891f, -0.11854730f, -0.17318325f, 
    -0.00088302f, 0.01255733f, 0.05497748f, 0.12662286f, 0.02939317f, 0.10900510f, 0.08143459f, 0.11643996f, 
    -0.11402966f, -0.00665948f, 0.04169101f, 0.06471514f, 0.03406386f, 0.02579472f, 0.07999380f, 0.00102694f, 
    0.02101342f, -0.02521100f, 0.14674994f, 0.12169726f, 0.09865668f, -0.06012821f, -0.09556960f, -0.01808796f, 
    -0.00031202f, 0.06583330f, 0.00573968f, 0.18564080f, -0.14589156f, 0.29352707f, -0.07287823f, 0.07456831f, 
    0.17201324f, 0.05715141f, -0.14155115f, 0.01174052f, -0.00456567f, 0.07616341f, 0.00556545f, -0.00877254f, 
    0.12306465f, 0.18488954f, -0.21460897f, -0.46536115f, 0.05878448f, 0.07193539f, 0.08547499f, 0.01611000f, 
    -0.02489578f, 0.02471240f, 0.09828707f, 0.11463099f, -0.12800354f, 0.03068363f, 0.03569844f, -0.04070950f, 
    0.07466065f, 0.09066322f, -0.03185125f, -0.11373265f, -0.11466745f, 0.05941948f, -0.10062195f, -0.12687491f, 
    -0.20818488f, -0.06323787f, 0.13799392f, -0.08795239f, -0.09462868f, 0.08525651f, -0.06122036f, -0.00406353f, 
    -0.03105264f, 0.05109546f, 0.06147333f, 0.09496473f, 0.06875602f, -0.12377723f, -0.13636160f, 0.13618958f, 
    0.06500965f, 0.05287999f, -0.04203551f, 0.02052545f, 0.07895590f, -0.02512361f, 0.07046428f, -0.11132172f, 
    0.36455822f, -0.29615512f, 0.18327489f, -0.27678183f, -0.11470486f, 0.06396094f, 0.04499847f, -0.05486204f, 
    0.02308940f, -0.06469700f, 0.09479969f, -0.09398837f, 0.00107194f, -0.26798233f, -0.05645477f, 0.05271086f, 
    0.21803725f, -0.01908580f, 0.07223088f, -0.04802765f, -0.16831276f, -0.19208226f, -0.02169953f, 0.08986042f, 
    -0.04336173f, 0.27316490f, 0.15159184f, 0.05540643f, 0.01736756f, 0.15451421f, 0.03961312f, -0.07070480f, 
    -0.08040800f, -0.05757954f, 0.06842647f, -0.00450589f, -0.12298188f, 0.20573796f, 0.18323089f, -0.10030365f, 
    -0.01034616f, -0.06272485f, 0.00103579f, -0.01454608f, 0.14958215f, -0.00498625f, 0.08248490f, -0.02452431f, 
    0.11227366f, -0.01548139f, 0.16027670f, -0.00594200f, 0.12168872f, 0.03479266f, 0.25291938f, -0.10486776f, 
    -0.00976605f, -0.04876077f, 0.10034785f, 0.09602645f, -0.08233269f, 0.24521345f, -0.14799461f, 0.27752909f, 
    -0.05024772f, 0.06409897f, 0.02239088f, -0.01903113f, 0.07083279f, -0.03459679f, -0.00761701f, -0.15701821f, 
    0.15267032f, -0.17952536f, 0.00074423f, 0.23996429f, 0.06504907f, -0.10412462f, -0.05628715f, -0.05495561f, 
    -0.06070756f, 0.11285806f, -0.03107559f, 0.04371314f, -0.03528491f, 0.01605725f, -0.00886796f, 0.05139832f, 
    0.01052075f, -0.07763284f, 0.10075208f, -0.08607490f, 0.00980362f, -0.12467024f, -0.02963984f, -0.15041730f, 
    -0.12820658f, 0.27319282f, 0.04464000f, 0.06570960f, -0.05277291f, -0.01798592f, 0.08007511f, 0.15470450f, 
    0.06204738f, -0.02870610f, 0.09603294f, -0.09204809f, 0.03123643f, 0.02886640f, -0.02309451f, -0.00250618f, 
    0.09271631f, 0.03390634f, -0.09516802f, -0.04205099f, -0.09220986f, 0.05659500f, -0.07196181f, 0.01733485f, 
    -0.05474935f, -0.02904264f, 0.08042895f, -0.04721793f, -0.12726113f, 0.04743762f, 0.09882328f, 0.01294123f, 
    0.01721759f, 0.02810288f, 0.11128630f, -0.05893273f, 0.32228452f, -0.05126643f, 0.07064399f, -0.10767192f, 
    -0.02667899f, -0.07885356f, 0.07956403f, -0.02798384f, -0.07960073f, 0.07692724f, -0.05715376f, -0.04392909f, 
    -0.11001734f, -0.06113826f, 0.19035421f, 0.37877527f, -0.08817665f, 0.05424216f, 0.08277579f, 0.03226731f, 
    -0.01123969f, -0.07940745f, 0.00408178f, -0.07221390f, -0.13268802f, 0.01003806f, -0.11516801f, 0.06433371f, 
    0.04216341f, -0.03334597f, -0.01963789f, 0.01153487f, -0.07243476f, -0.09959435f, -0.00846497f, 0.06391176f, 
    0.11605746f, 0.13374065f, -0.00621044f, 0.11622930f, -0.00971412f, 0.15099564f, 0.07573884f, 0.02990878f, 
    -0.02768325f, -0.13724308f, -0.02858620f, 0.12259880f, 0.30088809f, 0.20616525f, 0.19705385f, -0.06390703f, 
    0.07138108f, -0.04945500f, 0.03728129f, -0.00197218f, -0.06969232f, 0.04074381f, -0.01270600f, -0.02431353f, 
    -0.27750170f, 0.09505256f, 0.15235141f, -0.15956481f, 0.02086827f, 0.09305648f, 0.01897783f, 0.12213382f, 
    -0.02923381f, -0.06289998f, -0.10366621f, 0.09362754f, 0.06152564f, 0.04157653f, 0.05686751f, 0.26033658f, 
    -0.10713229f, -0.03710943f, -0.01120005f, 0.09106901f, 0.25806627f, 0.05274328f, -0.14499772f, 0.00150752f, 
    -0.15753153f, 0.12837832f, -0.24991456f, 0.04628072f, -0.02724792f, -0.16017656f, -0.04210511f, 0.03735285f, 
    0.03681896f, -0.12024457f, -0.00840793f, -0.07258526f, -0.07483316f, -0.00012646f, -0.11085960f, 0.04970952f, 
    -0.21272005f, -0.03986435f, -0.07416837f, -0.00154936f, 0.03537801f, -0.00567883f, -0.11691553f, -0.08296473f, 
    0.11839557f, 0.12975276f, 0.05162383f, 0.01237391f, -0.00588331f, 0.14955166f, 0.04364638f, 0.04747139f, 
    -0.21223314f, -0.03015699f, -0.08697792f, 0.04079795f, -0.27011868f, -0.14190626f, 0.04659390f, -0.11640094f, 
    -0.02744538f, 0.01095130f, 0.05031778f, 0.05534488f, 0.04838188f, 0.06870887f, -0.16112733f, 0.07282663f, 
    -0.10253539f, 0.03694177f, 0.17602398f, 0.11831240f, -0.14547513f, 0.06347306f, 0.06950316f, 0.09403805f, 
    -0.05209262f, 0.12974998f, -0.00050029f, 0.02073354f, -0.02777124f, 0.20488094f, 0.06183377f, -0.15819541f, 
    -0.16725136f, 0.04741953f, 0.08195549f, 0.16859539f, -0.03638594f, -0.04143429f, 0.06071877f, -0.02564950f, 
    0.27257243f, -0.10929170f, -0.16079500f, 0.08723064f, -0.06822526f, -0.02262527f, -0.02097934f, -0.13790022f, 
    -0.09109382f, 0.05638700f, -0.01990786f, -0.01716339f, -0.06807935f, -0.11886095f, 0.08982456f, 0.15730105f, 
    -0.09653655f, 0.06304896f, 0.14995156f, -0.02911302f, -0.01383712f, -0.00792620f, -0.00635979f, 0.00916469f, 
    0.17296109f, 0.18373747f, 0.00896846f, -0.11862890f, 0.04009698f, -0.10798024f, -0.09966448f, 0.11316314f, 
    -0.17439708f, -0.09264249f, -0.06762641f, 0.04463464f, 0.14674877f, -0.13446073f, 0.36950740f, 0.30851957f, 
    0.13564731f, -0.00560918f, 0.10406774f, 0.03736255f, 0.06055343f, -0.03211074f, -0.04554096f, -0.04840903f, 
    0.11652889f, 0.31358787f, -0.04837470f, -0.10623872f, 0.09762947f, 0.10231661f, 0.04059093f, -0.05296303f, 
    -0.09652264f, 0.13409746f, -0.03921331f, 0.01522358f, -0.19292368f, 0.12365655f, -0.06464306f, -0.04983502f, 
    0.12096855f, 0.05318286f, -0.00455372f, -0.08316696f, -0.05380360f, 0.11550537f, -0.04042343f, -0.12887770f, 
    0.04140360f, 0.02687749f, -0.21438400f, 0.07051188f, 0.16422629f, 0.01021791f, 0.09378969f, 0.09712166f, 
    0.08505916f, -0.02996189f, 0.06363145f, 0.10195617f, -0.25747123f, -0.19693826f, 0.05817655f, -0.00238474f, 
    -0.13988578f, 0.09452184f, 0.12523249f, 0.17392445f, -0.04569803f, -0.10833085f, -0.12621970f, -0.11723226f, 
    0.02158293f, 0.16178215f, -0.19075766f, 0.22399101f, 0.01506471f, 0.01964750f, -0.08555593f, -0.07912247f, 
    0.03272088f, 0.00466455f, 0.08475477f, -0.11812285f, -0.05614320f, 0.17746527f, -0.05706583f, -0.00218415f, 
    -0.14494690f, 0.04619815f, 0.03772034f, 0.11523674f, 0.16957663f, 0.11269076f, 0.01353581f, -0.06689046f, 
    0.16895996f, 0.09229352f, 0.12853104f, -0.16990711f, -0.01922571f, -0.21475789f, -0.05743223f, 0.07412477f, 
    0.11642997f, 0.03920888f, 0.03676144f, -0.05654396f, 0.12593004f, 0.07205793f, -0.17666399f, -0.00626084f, 
    -0.11086638f, -0.11238012f, -0.02750007f, 0.07887562f, -0.15343319f, 0.05397692f, 0.00547034f, -0.06458545f, 
    -0.31589279f, 0.12961510f, -0.17945024f, 0.00732216f, -0.15586974f, 0.02973696f, -0.13642196f, -0.01498950f, 
    -0.09816614f, 0.09950529f, 0.13395791f, 0.13319288f, 0.18082073f, 0.01204520f, 0.18520030f, -0.00780274f, 
    -0.00137060f, 0.10930283f, 0.07599787f, 0.08808742f, -0.15153871f, 0.01811343f, 0.07055976f, 0.03517284f, 
    -0.06592348f, 0.11898237f, 0.03440383f, -0.28243363f, -0.08619207f, 0.04837117f, -0.05844637f, -0.00942670f, 
    0.01000896f, 0.11654510f, 0.00350701f, 0.07351454f, 0.30470333f, 0.24287769f, 0.10385162f, 0.07401813f, 
    -0.01862844f, -0.03391073f, 0.02526556f, 0.02194588f, 0.10274491f, -0.05344623f, -0.09481464f, -0.05290616f, 
    0.34688401f, 0.03423421f, 0.20762181f, 0.05752430f, 0.04630681f, -0.03490457f, -0.02269251f, -0.09492246f, 
    -0.03376336f, 0.03996471f, -0.11393775f, -0.04443435f, -0.16075306f, 0.01095001f, -0.01321074f, -0.13169284f, 
    0.04985756f, 0.02958891f, -0.01480132f, 0.01439353f, 0.11783815f, 0.12883246f, 0.03777033f, -0.05777915f, 
    -0.03449678f, 0.08515772f, 0.06007541f, 0.02213570f, 0.05555077f, 0.00142721f, 0.06444603f, 0.15550976f, 
    0.01425649f, -0.16191980f, -0.09899060f, -0.00808361f, 0.09923075f, -0.22609541f, -0.09230543f, -0.25640491f, 
    -0.01569654f, 0.11172521f, 0.03368687f, 0.01106040f, 0.06987225f, -0.06393811f, 0.13364854f, -0.00075525f, 
    0.02971199f, -0.04614572f, -0.03095468f, -0.15822993f, 0.21139236f, 0.04922241f, -0.06459052f, 0.10334908f, 
    0.01998133f, -0.01805777f, -0.07687616f, 0.10586861f, 0.03911110f, -0.05428359f, 0.07358229f, 0.00119257f, 
    -0.04152863f, 0.06059909f, 0.04659075f, 0.06255355f, -0.04204804f, 0.11035027f, -0.02179700f, 0.05197885f, 
    0.04037549f, 0.10935893f, 0.04791832f, 0.14169060f, 0.02182093f, 0.05264748f, 0.00471618f, 0.01047133f, 
    -0.07471900f, -0.04425796f, 0.08716382f, -0.07682548f, 0.01409002f, 0.15792091f, 0.12218344f, -0.09305567f, 
    0.12842141f, -0.05390029f, 0.01706173f, -0.02424491f, 0.04198050f, 0.01613464f, 0.00223164f, 0.12810031f, 
    -0.21451804f, 0.30004549f, 0.01120649f, 0.00043250f, 0.03461650f, -0.03995648f, -0.04092520f, 0.08260850f, 
    -0.09981108f, 0.06073319f, -0.02354893f, 0.10705922f, 0.23902352f, 0.03062370f, 0.19371532f, 0.07502574f, 
    -0.08276816f, 0.03659459f, 0.00366666f, 0.17540722f, 0.07078731f, 0.10268103f, -0.01602558f, 0.06759801f, 
    0.15665105f, -0.19402796f, -0.23335692f, 0.19241536f, 0.01052749f, 0.03172326f, 0.11272856f, 0.01864876f, 
    -0.08811916f, -0.06845241f, 0.01912193f, -0.02693821f, 0.27704525f, -0.10311115f, 0.02363433f, 0.18080579f, 
    0.07244230f, 0.07816034f, 0.07617632f, -0.03820435f, -0.03696894f, 0.00280464f, -0.06109532f, 0.07913259f, 
    0.15456833f, 0.01750844f, -0.08106829f, 0.16695800f, 0.00633823f, -0.02622432f, -0.10001763f, 0.28944820f, 
    -0.05763022f, -0.00163868f, -0.03691548f, -0.16016342f, 0.07281841f, -0.04168857f, 0.14387585f, -0.23050530f, 
    0.00708789f, -0.12258130f, -0.02384652f, -0.02836986f, -0.01400850f, 0.06774671f, 0.08021615f, 0.08962842f, 
    0.01570690f, 0.13419029f, 0.06603740f, 0.07704788f, -0.04797589f, 0.06371833f, 0.03878022f, 0.00005281f, 
    -0.08318173f, -0.02979781f, -0.00351493f, -0.05668839f, -0.01984335f, -0.10610206f, -0.10892909f, -0.09241808f, 
    -0.01326791f, 0.04003470f, -0.02180102f, 0.01439376f, -0.07344572f, 0.11325761f, 0.10120215f, 0.03185005f, 
    0.27154189f, -0.20871353f, -0.09406537f, -0.07471461f, -0.03171707f, 0.00371474f, -0.01613208f, -0.03476316f, 
    0.06445320f, -0.01037059f, 0.02020184f, 0.08338230f, 0.01244149f, -0.08946242f, -0.02721042f, 0.21332774f, 
    -0.13166176f, -0.10214575f, 0.11773330f, -0.00181382f, 0.04763887f, 0.02115799f, 0.05402578f, 0.07441531f, 
    0.20661718f, -0.03628427f, -0.05725110f, -0.02399219f, 0.03401423f, -0.02432894f, -0.00244735f, -0.04157202f, 
    0.05982524f, 0.01658376f, -0.03828356f, 0.10978911f, -0.06611876f, 0.17270732f, 0.00834774f, 0.15833841f, 
    0.00530766f, 0.01048533f, 0.02493438f, -0.06614606f, -0.01071890f, -0.00396391f, 0.02951226f, 0.08898469f, 
    0.05893152f, 0.33447921f, 0.22776023f, 0.19768800f, 0.07610605f, 0.03211020f, 0.12256323f, 0.03881610f, 
    0.10605843f, -0.10608392f, -0.07751933f, -0.07846108f, 0.01845839f, -0.07539759f, 0.06343065f, -0.11454603f, 
    -0.03208828f, 0.03747925f, -0.04697580f, 0.09656158f, 0.05147696f, 0.01291130f, -0.07119807f, 0.01228389f, 
    -0.01926299f, 0.04539490f, -0.01224981f, -0.04238926f, -0.05067452f, 0.01996363f, 0.04711873f, -0.01146130f, 
    -0.03031917f, -0.06780282f, 0.00144045f, 0.04847334f, -0.00822938f, 0.02071441f, -0.04675077f, 0.02910167f, 
    -0.06008954f, -0.07662803f, -0.00410110f, 0.01594798f, -0.05777558f, 0.06118651f, -0.07812075f, -0.07066259f, 
    0.04646507f, 0.00655986f, -0.02251018f, 0.04088404f, 0.04233397f, -0.08260859f, 0.03040311f, -0.01847796f, 
    -0.01250983f, 0.04296546f, 0.05593690f, -0.01174099f, 0.00336080f, 0.05879176f, -0.00571799f, -0.01837587f, 
    0.04936484f, -0.06469402f, -0.05910232f, 0.06427944f, -0.04217138f, -0.02231561f, -0.00467412f, 0.00257664f, 
    -0.00416736f, -0.00219010f, -0.03306775f, -0.06749614f, -0.06859251f, -0.04194871f, -0.03261988f, -0.07875016f, 
    0.01016857f, -0.03759852f, -0.00598520f, -0.03216459f, -0.08440620f, -0.05458520f, -0.07146194f, -0.00876081f, 
    -0.07232382f, -0.06103425f, -0.05060352f, -0.04903931f, 0.02423283f, -0.03116030f, -0.05648304f, -0.01749826f, 
    -0.00797045f, -0.05471456f, -0.04711773f, 0.03341152f, 0.03334109f, 0.04436652f, 0.02981761f, -0.03744416f, 
    -0.03796085f, -0.07169712f, 0.00406075f, 0.01981791f, 0.02213208f, 0.00790517f, 0.05481361f, -0.04078155f, 
    -0.05170061f, 0.04813665f, 0.00719250f, -0.03304669f, 0.02793922f, -0.04241270f, -0.04123712f, 0.05375728f, 
    -0.01789967f, -0.04116764f, 0.04749830f, 0.02610314f, 0.03090724f, -0.07752922f, 0.00040621f, 0.02146894f, 
    0.05162203f, 0.00902459f, 0.05988288f, -0.05304699f, -0.00102971f, 0.04188565f, -0.07422768f, -0.07485033f, 
    -0.03340026f, -0.06629827f, -0.03326459f, 0.00436231f, 0.01975545f, -0.07310367f, 0.00442579f, -0.00717529f, 
    0.01648520f, -0.08892160f, 0.01974002f, 0.00239437f, -0.03555662f, 0.01085977f, -0.00394512f, 0.04643213f, 
    -0.04146975f, 0.00885431f, 0.03244416f, -0.06435995f, -0.01581706f, -0.00889007f, -0.00253245f, 0.04059510f, 
    0.00776656f, 0.04174827f, 0.05881998f, -0.02200924f, -0.06967982f, 0.05102646f, -0.01094127f, 0.01029554f, 
    -0.07875071f, -0.06322359f, -0.08707609f, 0.01391659f, -0.01358329f, 0.00286606f, -0.07075877f, -0.07083058f, 
    -0.01677723f, -0.01565329f, -0.01786242f, -0.06069020f, -0.01415653f, 0.07209761f, 0.03421843f, 0.01935484f, 
    -0.06883201f, 0.00846152f, 0.02397019f, -0.03975944f, 0.00823338f, 0.04198430f, 0.04059331f, -0.01880377f, 
    0.00421901f, 0.05941632f, -0.02349892f, -0.05325428f, -0.00980947f, 0.02882830f, -0.00529227f, -0.03663720f, 
    0.01527244f, 0.01533237f, 0.01827916f, 0.01879892f, -0.07248712f, -0.01181272f, -0.00432029f, -0.01998965f, 
    -0.06497250f, 0.03705986f, 0.06055823f, 0.00593755f, -0.00596595f, -0.05336230f, -0.03482160f, -0.04389937f, 
    -0.09260558f, 0.12857205f, 0.06865335f, -0.07495231f, -0.02690064f, -0.08323370f, -0.20362884f, -0.15427901f, 
    -0.13110003f, 0.06133398f, -0.11802536f, -0.24303767f, -0.09805222f, -0.09786131f, -0.02353374f, -0.02787793f, 
    -0.05839483f, 0.03500672f, -0.01130661f, -0.03820635f, 0.09539577f, 0.15493719f, 0.16874018f, 0.03938291f, 
    0.23237446f, -0.08317804f, -0.22051618f, -0.12097697f, 0.09103905f, 0.00156145f, -0.05159619f, 0.08592784f, 
    0.00302120f, 0.12272606f, 0.14004043f, -0.00889167f, -0.15859966f, 0.01907401f, -0.00553920f, -0.04356538f, 
    0.15661223f, 0.07585644f, 0.07832843f, -0.03925676f, -0.11129639f, -0.00184480f, 0.08446699f, 0.14111456f, 
    0.17519628f, -0.09815232f, 0.08595088f, -0.02343420f, 0.14363827f, 0.11200400f, 0.02602372f, 0.07686722f, 
    0.01770519f, -0.06786678f, -0.11021578f, 0.18456300f, -0.08794426f, -0.07285229f, 0.10089225f, -0.06852815f, 
    0.05468468f, 0.03543313f, 0.10196445f, -0.13364303f, 0.17378084f, -0.04031485f, 0.07631229f, 0.05331552f, 
    0.13402048f, 0.00571815f, -0.03902989f, 0.08676253f, 0.01596419f, 0.04951635f, 0.04901324f, 0.00163185f, 
    0.19226882f, 0.11401559f, -0.05866285f, -0.12861076f, 0.13788523f, -0.02821527f, -0.11210320f, 0.13504533f, 
    0.01118446f, 0.00291712f, -0.02130476f, -0.03928575f, 0.06411760f, -0.14050174f, 0.09512537f, 0.09900254f, 
    -0.12648948f, -0.13368215f, 0.03606422f, -0.01895916f, 0.07145499f, 0.05809073f, 0.06487091f, -0.05807323f, 
    0.12738097f, 0.01835677f, 0.04879233f, -0.13864957f, 0.00565545f, -0.11637592f, 0.05638642f, 0.04873132f, 
    0.07818256f, 0.05065307f, -0.13215186f, -0.21984936f, -0.04795748f, 0.11948991f, -0.10814940f, 0.15474586f, 
    -0.09845788f, 0.08523137f, -0.04338359f, 0.15162016f, 0.09462829f, -0.02383167f, -0.07585163f, 0.05107121f, 
    0.12094179f, -0.07771127f, 0.09422930f, -0.01102040f, 0.15811138f, 0.03257926f, -0.02604396f, -0.11931449f, 
    -0.03954158f, -0.13626374f, 0.03472849f, -0.05076641f, -0.06673461f, -0.09758817f, 0.05672652f, 0.22402370f, 
    -0.28438020f, 0.27860343f, 0.15211064f, -0.04181860f, 0.05617635f, 0.00657232f, 0.04348322f, 0.08527461f, 
    -0.04843849f, 0.13060489f, 0.08487428f, -0.01034404f, -0.01843970f, -0.04245516f, -0.33587655f, -0.16395095f, 
    -0.06392763f, 0.13050716f, -0.09304989f, 0.00400857f, 0.12927648f, 0.01159047f, 0.07277595f, 0.09494853f, 
    0.14242785f, -0.09136474f, -0.16973552f, 0.03841476f, 0.08052514f, 0.02731827f, 0.00911636f, -0.10259975f, 
    0.17663999f, -0.04181425f, 0.02624954f, -0.09902946f, 0.04161862f, 0.13492146f, 0.03441610f, 0.04253395f, 
    0.08234058f, 0.08113758f, 0.05610026f, 0.29499018f, 0.03862083f, -0.14330737f, -0.04950091f, -0.15315835f, 
    -0.12421315f, -0.05902141f, -0.03042389f, -0.00629716f, 0.13885655f, 0.03891418f, 0.15702420f, 0.11052359f, 
    0.08546288f, 0.04522966f, -0.07856943f, 0.21669742f, -0.23516683f, -0.14931962f, 0.06904054f, -0.04948295f, 
    -0.01413909f, -0.00356069f, 0.07006347f, -0.03759773f, 0.07836647f, -0.06389713f, 0.09258037f, 0.03365333f, 
    -0.27163652f, 0.03952803f, -0.05770841f, -0.05971671f, 0.08443219f, 0.00741340f, -0.04130115f, 0.01289728f, 
    0.11294626f, -0.01235822f, -0.04274893f, 0.07176053f, -0.03475516f, -0.04266983f, -0.09516510f, -0.02528654f, 
    -0.08740613f, 0.12695847f, 0.05936422f, -0.05547610f, 0.17460054f, 0.18539909f, -0.01838437f, -0.03916582f, 
    -0.10464121f, 0.17016204f, 0.13965340f, 0.15702802f, 0.00053841f, -0.08582675f, -0.02208594f, -0.01189332f, 
    0.02657367f, 0.12208396f, -0.03688709f, 0.05196331f, 0.15813835f, 0.12230863f, 0.04925548f, 0.11296760f, 
    -0.08761138f, -0.01368697f, -0.07313561f, 0.04179783f, 0.02404184f, 0.05782677f, 0.06156132f, 0.03329987f, 
    -0.22760913f, 0.04888236f, -0.14368920f, -0.12764299f, -0.04927999f, 0.16201921f, 0.06021812f, -0.01341886f, 
    -0.12274987f, -0.05204817f, -0.02958154f, 0.16910490f, -0.20864661f, 0.21658282f, -0.02469043f, 0.02467095f, 
    0.02964557f, 0.03696989f, 0.05622322f, -0.01923026f, -0.07668380f, -0.04801699f, -0.01832099f, -0.06617204f, 
    -0.04283378f, 0.24561228f, 0.14570346f, -0.25493506f, 0.06188147f, 0.09243038f, 0.06479341f, 0.01402640f, 
    0.08320126f, 0.04319264f, 0.05813889f, 0.20090708f, 0.17634377f, 0.13627154f, 0.17228380f, 0.00954889f, 
    -0.12458420f, -0.00678436f, 0.11124288f, 0.16199139f, 0.10106941f, -0.05203199f, 0.04872931f, 0.00902174f, 
    0.07798313f, -0.12564103f, 0.18646936f, 0.08894444f, 0.03879331f, 0.13807392f, -0.02137247f, -0.08647387f, 
    0.02667713f, 0.03491648f, 0.02551884f, -0.07924777f, -0.14116156f, 0.13602594f, 0.15629211f, -0.03542398f, 
    0.12413627f, 0.06578487f, -0.00598809f, 0.07681185f, 0.11843487f, 0.02257753f, 0.00784020f, 0.02043155f, 
    0.01341382f, -0.03723045f, 0.13347785f, 0.13432756f, 0.14873348f, 0.03076532f, 0.00756521f, 0.04583924f, 
    -0.07267761f, -0.04152619f, 0.00483674f, -0.09003132f, -0.01355077f, 0.06073815f, 0.06794145f, 0.10743321f, 
    0.11633541f, 0.09688827f, 0.18638490f, -0.07294966f, -0.05868436f, 0.02752983f, -0.07506588f, 0.00054462f, 
    -0.15260853f, 0.05437583f, -0.19790332f, -0.31556803f, 0.03816012f, -0.01390923f, -0.15584770f, 0.05060920f, 
    -0.01570765f, 0.12493607f, -0.01906453f, 0.19695802f, -0.30970648f, -0.00688598f, 0.00251934f, -0.05039592f, 
    0.06139797f, 0.16379304f, 0.01165840f, -0.10438720f, -0.02843356f, 0.02432034f, -0.02552900f, -0.02856056f, 
    -0.01028601f, 0.02230040f, 0.00717220f, -0.04717176f, 0.01657975f, -0.04708311f, -0.01551335f, 0.01191926f, 
    0.03059891f, -0.05254254f, -0.00496070f, -0.02621042f, -0.04690995f, -0.00298652f, 0.05782770f, 0.06325140f, 
    0.03367441f, -0.06657729f, 0.04896567f, -0.03694142f, 0.01667332f, -0.05889260f, 0.02945866f, -0.04830344f, 
    0.00131135f, 0.04963910f, -0.07105993f, -0.06153406f, -0.03708033f, -0.05818743f, 0.03732102f, -0.00191066f, 
    0.04928615f, -0.05562602f, -0.04529537f, -0.07346398f, -0.04570014f, -0.06416072f, -0.06243318f, -0.03095375f, 
    0.04392169f, -0.07551085f, -0.02494104f, 0.04395886f, 0.01084940f, -0.03227564f, -0.06562470f, -0.03572115f, 
    -0.01740898f, -0.03669508f, -0.07170940f, -0.01058867f, -0.04592490f, -0.04855196f, 0.00239683f, -0.04369939f, 
    0.06347129f, -0.07007776f, -0.03133708f, -0.07739367f, 0.01380763f, -0.07014681f, -0.00149770f, 0.00271003f, 
    0.03683722f, 0.03332047f, 0.01690967f, -0.02552591f, -0.07040831f, 0.05512862f, -0.06909179f, 0.01121863f, 
    -0.06501229f, 0.03052766f, -0.00842363f, 0.03431399f, -0.05726943f, 0.00321140f, -0.03638706f, -0.00525971f, 
    -0.02773608f, -0.06450206f, -0.04750349f, 0.00739326f, 0.04965131f, -0.05828631f, -0.02961973f, -0.06115181f, 
    0.06058325f, 0.03257490f, 0.05953928f, 0.06282132f, -0.03668385f, -0.05777582f, 0.02866407f, -0.04306632f, 
    0.02878873f, -0.05312207f, 0.04951550f, -0.00571930f, 0.01626898f, 0.05842202f, 0.00810714f, -0.00430919f, 
    0.02940839f, -0.06538603f, -0.02053346f, -0.06014853f, 0.00621531f, 0.01488531f, 0.03667868f, 0.03721808f, 
    -0.01335828f, -0.06376489f, -0.07749192f, -0.04605152f, -0.03837819f, 0.05207070f, 0.02292042f, 0.04308398f, 
    0.01572558f, -0.00874348f, 0.05720658f, -0.01656375f, -0.07979580f, -0.07639271f, 0.05187416f, 0.00571724f, 
    -0.00989501f, 0.05750425f, 0.02909751f, 0.04450933f, -0.05912541f, -0.01539464f, -0.03075399f, 0.06333341f, 
    -0.06626187f, -0.04729040f, -0.05116427f, -0.03682010f, -0.03276432f, 0.06311023f, -0.02414953f, 0.02064543f, 
    -0.05276343f, 0.02738596f, 0.00576291f, -0.00023632f, 0.05764172f, -0.03905562f, -0.02436947f, -0.00904079f, 
    -0.05899647f, -0.06187386f, 0.00743032f, 0.02163248f, -0.00058013f, -0.06351857f, 0.00238934f, -0.06813715f, 
    0.02324543f, -0.04674352f, -0.01961055f, 0.04350368f, 0.06008998f, 0.02887015f, -0.00028390f, 0.01522658f, 
    -0.07954949f, 0.05128553f, -0.05077953f, -0.04644243f, 0.05216805f, 0.01141748f, 0.05374849f, -0.04550375f, 
    0.01917929f, -0.06130655f, -0.03845880f, 0.00108372f, 0.04528882f, -0.06351138f, 0.05917346f, -0.06721889f, 
    -0.02745848f, -0.02920249f, -0.07891354f, 0.03734604f, 0.04595688f, -0.04221614f, -0.01657055f, -0.04711261f, 
    0.03324582f, 0.05437095f, 0.02263348f, 0.03879562f, 0.04025510f, 0.03099097f, 0.00271615f, -0.04985213f, 
    -0.03514483f, 0.01901277f, -0.03131415f, 0.05169415f, -0.05587151f, 0.03885464f, -0.05868319f, -0.01651497f, 
    -0.06902692f, 0.04004516f, -0.05268713f, -0.02536409f, 0.05611569f, -0.06742229f, -0.01460590f, -0.03354505f, 
    0.04289456f, 0.02998126f, 0.01172864f, -0.04213384f, -0.06571267f, -0.01186849f, 0.00466087f, -0.05761427f, 
    0.00841756f, -0.08036558f, -0.00253218f, -0.07943409f, -0.00035556f, -0.01700217f, 0.04969414f, 0.01799786f, 
    0.04493239f, -0.06294604f, 0.02546140f, 0.01911663f, -0.07334654f, -0.04801697f, 0.00750974f, -0.00977592f, 
    -0.08045904f, -0.04709037f, -0.00385397f, -0.05640953f, -0.08047763f, 0.04068849f, -0.05411352f, 0.00261581f, 
    -0.07661748f, 0.02923322f, 0.05241800f, -0.02325539f, 0.03287019f, 0.03101726f, -0.06861886f, -0.02970367f, 
    0.01442809f, -0.00289132f, 0.04861392f, 0.03455491f, -0.06998447f, 0.05339117f, -0.05667078f, 0.04377997f, 
    -0.02127508f, -0.06714814f, -0.03520538f, 0.03479894f, 0.06538140f, -0.02197745f, 0.02959944f, 0.04949949f, 
    -0.02431278f, 0.06835746f, -0.06359868f, -0.05432628f, -0.03417228f, 0.03621153f, 0.04825756f, -0.07901198f, 
    -0.01037180f, -0.05945730f, -0.00154052f, 0.05017904f, -0.04431510f, -0.01954506f, -0.03021799f, -0.08290360f, 
    -0.04400179f, 0.01911080f, -0.00569478f, 0.00813293f, -0.03135166f, -0.04103065f, 0.02619722f, -0.06596985f, 
    0.00425386f, -0.00087972f, -0.06932370f, -0.04015082f, -0.00262907f, -0.01278680f, -0.01018444f, 0.05732555f, 
    0.04648595f, 0.05482337f, -0.07596745f, -0.03133794f, -0.00443845f, -0.03067192f, 0.06277399f, -0.02866790f, 
    0.05821946f, -0.08138262f, -0.02998594f, 0.03222310f, -0.02307660f, 0.04525327f, 0.04905579f, -0.02969488f, 
    -0.00342459f, -0.08410612f, -0.01843134f, 0.03333198f, 0.04032930f, 0.03944411f, -0.05578176f, -0.01478550f, 
    -0.00904269f, -0.06487796f, -0.03034809f, -0.01790940f, -0.00292072f, -0.03354404f, 0.05391097f, 0.00642593f, 
    -0.03873535f, -0.04172614f, -0.01495760f, -0.00168444f, -0.07897688f, -0.05471282f, -0.01131257f, -0.03577008f, 
    -0.07503092f, -0.03703814f, -0.06473209f, 0.01830941f, 0.01769270f, -0.06468626f, -0.01523038f, 0.03094567f, 
    0.06253740f, -0.08494135f, -0.04471420f, -0.01220778f, -0.03966042f, 0.00256014f, -0.08396038f, 0.03245134f, 
    0.03089816f, -0.07707480f, -0.06844105f, 0.04938067f, 0.05565736f, 0.03285279f, 0.06093618f, 0.00799280f, 
    -0.06849573f, -0.04461005f, 0.03078981f, -0.04079587f, 0.00776776f, -0.00775460f, 0.04567654f, -0.06955684f, 
    0.05779512f, -0.07008278f, 0.04915773f, -0.02782581f, -0.00879923f, 0.01934483f, -0.00084362f, -0.01013543f, 
    -0.05242751f, -0.07906847f, 0.00008755f, 0.00738098f, -0.05476398f, -0.05041605f, -0.00540982f, -0.01075078f, 
    -0.00405768f, 0.03368416f, -0.04721795f, 0.00758011f, -0.07551073f, 0.04571683f, 0.03614667f, -0.01640816f, 
    0.03759931f, 0.01815764f, -0.01237111f, -0.05587699f, -0.05295792f, 0.02979469f, -0.00454458f, -0.03423201f, 
    -0.03722050f, -0.07206613f, -0.00962665f, 0.03750466f, -0.07102221f, -0.07854644f, -0.07280283f, 0.05177442f, 
    0.03506558f, 0.02790762f, 0.04832000f, -0.06531569f, -0.07505742f, 0.02006972f, 0.00542207f, -0.07053247f, 
    -0.04718863f, 0.02382179f, 0.04488676f, -0.05016247f, -0.02436134f, -0.02342445f, 0.05370351f, 0.02682230f, 
    -0.02376431f, 0.03110229f, -0.07339831f, -0.00142506f, -0.01483673f, 0.04385830f, -0.04019077f, -0.06726054f, 
    -0.04385649f, -0.07666133f, -0.04478987f, 0.05819760f, -0.02676300f, -0.01792655f, -0.02284624f, -0.02034729f, 
    -0.01158127f, -0.05922688f, -0.07576732f, -0.00189820f, 0.02271150f, 0.00609447f, -0.07643616f, -0.01997367f, 
    0.06102683f, -0.01961674f, -0.01865468f, -0.05365953f, -0.00910979f, 0.03025515f, 0.04350817f, 0.01411919f, 
    0.01456400f, 0.03288290f, 0.03177973f, 0.03044345f, -0.00390506f, 0.03478795f, -0.05934040f, 0.02763570f, 
    0.02623852f, 0.01053089f, 0.02331445f, -0.02016795f, -0.01753334f, -0.04186273f, 0.00801133f, -0.07537821f, 
    0.00531645f, -0.05413878f, 0.03566757f, 0.06874228f, 0.03967707f, 0.06142395f, -0.02055518f, 0.01312341f, 
    -0.08149670f, -0.07817961f, 0.02375853f, -0.06142452f, -0.01323514f, -0.04091508f, -0.01037368f, 0.01846438f, 
    0.00726813f, -0.02380351f, 0.04948719f, 0.00487344f, 0.02644165f, -0.03744169f, -0.05229774f, -0.05186423f, 
    0.00434364f, 0.02809717f, -0.07411346f, -0.02108832f, -0.03868659f, -0.04462548f, 0.02289215f, -0.05976706f, 
    -0.08672024f, 0.00071728f, -0.02702610f, 0.04981386f, -0.01914665f, 0.01679855f, -0.07234979f, -0.05759918f, 
    0.01661187f, -0.06043079f, -0.08239213f, -0.07358824f, -0.05285737f, 0.03646433f, 0.03790715f, 0.03659141f, 
    0.02992952f, -0.07234629f, -0.03335901f, 0.04491764f, 0.05020213f, -0.03362440f, -0.01915091f, 0.05648813f, 
    0.00349469f, -0.07339490f, 0.04420356f, 0.05712277f, -0.06076965f, -0.02538927f, 0.06212457f, 0.03309509f, 
    -0.00900614f, 0.02553332f, 0.02816289f, -0.05575458f, -0.02333175f, 0.05874113f, 0.05856565f, -0.03651337f, 
    0.00393678f, 0.04876556f, 0.02655936f, 0.05355184f, -0.02740869f, -0.04500902f, 0.05878426f, -0.06163951f, 
    -0.02713856f, -0.05154081f, -0.00296771f, -0.04129630f, -0.02584396f, -0.07404035f, -0.03212200f, 0.03522318f, 
    0.04036060f, 0.04317688f, -0.02461757f, 0.05687091f, -0.01870659f, -0.00360876f, -0.01453178f, 0.05315466f, 
    0.08076090f, 0.21560536f, -0.24455108f, 0.10849101f, 0.16197769f, 0.10499533f, -0.09237176f, 0.07422089f, 
    0.07715879f, 0.03749077f, 0.09386752f, 0.01117653f, 0.00678191f, -0.04214095f, 0.07412464f, -0.08097845f, 
    0.02608581f, 0.05662240f, 0.20982346f, -0.00385999f, -0.07633305f, -0.00911464f, -0.02684216f, 0.03150912f, 
    -0.24787420f, 0.27606997f, -0.14374457f, -0.01953141f, 0.09021851f, 0.06504820f, -0.03625432f, 0.04708191f, 
    -0.01464338f, 0.00758294f, -0.07883022f, 0.02655299f, -0.11644264f, 0.33216807f, -0.05316061f, 0.10202321f, 
    -0.18432936f, 0.07324646f, -0.06036263f, 0.12965319f, 0.14188167f, 0.13256432f, -0.01584271f, -0.02323818f, 
    0.25124586f, 0.08947624f, -0.11993963f, 0.16226494f, -0.05172972f, -0.09257416f, 0.08815016f, 0.09073889f, 
    0.07372386f, 0.00352878f, 0.05807687f, -0.03922220f, 0.28550079f, -0.17785086f, 0.10707214f, 0.28690934f, 
    -0.04222358f, -0.01370531f, 0.08516605f, 0.08409043f, 0.01203203f, 0.02799799f, -0.03623786f, 0.01074463f, 
    -0.18056783f, 0.08446673f, -0.23405062f, 0.15928055f, -0.06520706f, 0.03645130f, -0.09546730f, 0.08876496f, 
    0.00829119f, -0.02930860f, 0.02297777f, -0.06641949f, -0.01309614f, -0.16323413f, 0.18447876f, -0.21164358f, 
    -0.02362380f, -0.02756163f, 0.06568263f, 0.09783383f, 0.02849517f, 0.04320754f, -0.04385657f, -0.05251369f, 
    -0.01040935f, 0.11485775f, 0.19878130f, 0.01708608f, -0.12310758f, 0.15861124f, 0.09549490f, -0.06418719f, 
    0.00480597f, 0.13387489f, -0.03485207f, 0.01960286f, 0.22028309f, 0.13787384f, 0.15073040f, -0.04228657f, 
    -0.09024540f, 0.04755498f, 0.16293208f, 0.11852057f, -0.04256083f, 0.00153347f, -0.08240151f, 0.20131426f, 
    0.21512896f, -0.14572757f, 0.01887919f, -0.07886855f, -0.04387759f, -0.03415812f, -0.09532049f, -0.11841426f, 
    -0.00436863f, -0.02829551f, -0.05871407f, 0.05648984f, -0.07560676f, -0.12526463f, -0.03009402f, 0.23119348f, 
    -0.07699009f, -0.04071310f, 0.12049296f, -0.10299975f, 0.02365170f, 0.05174384f, 0.00580740f, 0.01094110f, 
    0.08201510f, 0.02738537f, 0.09657637f, 0.09536054f, -0.01977859f, -0.05308851f, -0.06765486f, 0.08025514f, 
    -0.03069576f, -0.02644722f, -0.06132235f, -0.00703349f, -0.25469452f, 0.16593859f, -0.07457797f, 0.02113918f, 
    -0.05215785f, 0.10139554f, 0.05317998f, -0.01114753f, -0.01725942f, -0.08631858f, 0.08046819f, -0.01771109f, 
    0.01897594f, 0.02515040f, 0.01507092f, -0.10283629f, 0.16409390f, 0.02413115f, 0.01574914f, -0.10577456f, 
    0.09497277f, 0.00498648f, 0.06610893f, -0.05369319f, 0.13090692f, -0.07511661f, -0.02938419f, -0.20825945f, 
    -0.11402787f, -0.07061229f, 0.05392641f, -0.00226359f, -0.02790987f, -0.03625532f, 0.00898230f, -0.00880455f, 
    0.25220528f, -0.19229144f, 0.11269463f, 0.02529373f, -0.02878817f, 0.00205032f, -0.04563311f, 0.04989949f, 
    -0.03361917f, 0.08183130f, -0.09318657f, -0.11012754f, 0.13690652f, 0.17545305f, -0.14092828f, 0.16311835f, 
    -0.08924289f, 0.05471621f, -0.14475814f, 0.09652209f, -0.07376061f, 0.05736631f, -0.05763501f, -0.05904018f, 
    0.33738810f, -0.09141400f, 0.04460540f, 0.02709783f, -0.04142730f, 0.08742277f, -0.07384418f, 0.00844987f, 
    0.06322322f, 0.10847458f, 0.00570929f, -0.03550474f, -0.18024035f, 0.11421177f, -0.05423496f, -0.07042791f, 
    -0.02985104f, 0.03874492f, 0.01902920f, -0.11757983f, 0.01296138f, -0.04906400f, 0.04528293f, 0.02358278f, 
    0.04429129f, 0.11724888f, 0.09791549f, -0.35912040f, 0.01596377f, 0.08446009f, -0.13111331f, 0.04119215f, 
    -0.01605809f, 0.02028179f, 0.05991733f, 0.19788641f, -0.30206931f, -0.05686565f, -0.12140547f, -0.31652045f, 
    0.08636072f, 0.08536975f, -0.01186046f, -0.08784331f, -0.00119073f, 0.00316795f, 0.07845222f, 0.05502395f, 
    0.12468390f, 0.08109717f, 0.00553210f, 0.05254662f, 0.05933117f, -0.07513279f, -0.09882046f, -0.12952077f, 
    0.14005533f, 0.02688573f, 0.01401676f, -0.08562938f, -0.18406962f, -0.24013078f, 0.01639108f, 0.14562424f, 
    0.09908417f, 0.05616291f, 0.11634595f, -0.08531959f, -0.04877629f, -0.04655340f, 0.04399752f, 0.08486453f, 
    -0.09201308f, -0.16387373f, -0.10055309f, -0.00132072f, 0.01930171f, -0.10397450f, 0.08482776f, -0.12313768f, 
    0.05254818f, -0.00691963f, 0.06114003f, -0.03942575f, -0.30545956f, 0.05064024f, -0.00488392f, 0.04832307f, 
    0.08680175f, -0.01470048f, 0.06528501f, -0.07988387f, 0.10308021f, -0.02817137f, 0.01084941f, -0.05196929f, 
    -0.13316397f, 0.23033074f, -0.06030591f, -0.06160903f, 0.11456145f, 0.09035107f, 0.00761400f, 0.16138130f, 
    -0.10131533f, -0.02948946f, 0.04408925f, -0.05216702f, 0.27954909f, 0.20884629f, 0.05222023f, -0.00362195f, 
    -0.03690040f, -0.02777494f, -0.11513435f, -0.00898232f, 0.01507883f, 0.13074593f, 0.01108560f, -0.04099556f, 
    -0.21716700f, 0.31127825f, -0.06409399f, -0.07239173f, 0.02105127f, 0.08688132f, 0.09825566f, 0.13068131f, 
    0.00788011f, 0.03473745f, -0.01343111f, 0.06408378f, 0.26816952f, -0.13811149f, -0.16996619f, 0.07631247f, 
    -0.11290295f, 0.03577429f, -0.10410538f, -0.01816780f, 0.01718819f, 0.13730335f, -0.04224911f, -0.01044585f, 
    0.17328921f, 0.12165470f, 0.16559978f, 0.05694212f, -0.11361651f, 0.08484468f, 0.01955272f, 0.09007715f, 
    -0.12969898f, 0.04623999f, -0.09081392f, -0.08862142f, 0.10627729f, 0.20253365f, -0.02141474f, 0.11142174f, 
    0.08184502f, 0.06062162f, -0.03106568f, -0.03830432f, 0.05168536f, -0.00019222f, 0.07230156f, -0.01084659f, 
    0.08230603f, -0.19719845f, 0.02653803f, -0.12426054f, 0.06770945f, -0.06624199f, -0.15138622f, -0.08671895f, 
    -0.13551040f, 0.10381794f, 0.02476059f, -0.19100685f, -0.11309393f, 0.02842096f, -0.11704803f, 0.06763612f, 
    -0.06535298f, -0.00553835f, -0.15119189f, -0.07332806f, -0.07571502f, 0.05434297f, -0.03125557f, -0.01972577f, 
    -0.20230436f, 0.01609223f, -0.07434336f, -0.15167445f, 0.05799332f, -0.00738048f, -0.02639940f, 0.08055858f, 
    0.07081424f, 0.02759831f, 0.19232790f, -0.08677822f, -0.47851723f, 0.09401470f, 0.05148055f, -0.03979909f, 
    -0.05271759f, 0.17417046f, -0.04200450f, -0.06835173f, 0.07620898f, -0.00146707f, 0.14525419f, 0.07751758f, 
    0.41573671f, -0.03456143f, 0.02107202f, -0.16463463f, 0.12411306f, 0.15614641f, 0.02840240f, 0.03995526f, 
    -0.06210133f, 0.08536956f, -0.02022204f, 0.21499701f, 0.10744018f, -0.15542838f, 0.12950107f, -0.11798318f, 
    0.15732072f, -0.01888240f, 0.09891602f, -0.16706687f, 0.15431829f, -0.06497690f, 0.03890472f, -0.02577877f, 
    -0.03551423f, -0.01347189f, -0.08990178f, 0.04790857f, 0.08741532f, 0.02158495f, 0.01788375f, -0.08622468f, 
    0.27153185f, 0.03771410f, 0.06225425f, -0.12915435f, 0.30764136f, -0.12495638f, -0.09662652f, 0.09628878f, 
    -0.00983271f, 0.01303870f, -0.04006380f, -0.07672182f, 0.07311247f, 0.01054896f, 0.04829964f, 0.08720043f, 
    0.17374098f, -0.18355694f, -0.10002586f, 0.27750978f, 0.05796108f, 0.07437323f, -0.00122077f, -0.11481203f, 
    0.16780919f, -0.09454007f, 0.03791535f, -0.11509682f, 0.00200079f, 0.07143322f, -0.07129584f, 0.10467776f, 
    0.06238991f, 0.09035194f, -0.15599498f, -0.14420255f, -0.06778293f, 0.12972920f, -0.06543649f, 0.12297405f, 
    -0.12489501f, 0.15428750f, -0.08782074f, -0.02120038f, 0.07190938f, -0.04554418f, -0.08194271f, 0.08452370f, 
    0.01634523f, -0.03515116f, 0.12318506f, 0.04662477f, 0.19245856f, 0.02488092f, -0.12249941f, -0.00896217f, 
    -0.05683435f, -0.18312998f, 0.00738484f, 0.00517574f, 0.07820345f, 0.01816146f, 0.07927517f, 0.23103262f, 
    0.07710960f, 0.27877152f, 0.09263333f, 0.00520981f, 0.01900203f, 0.02651551f, 0.06363493f, 0.07822335f, 
    0.04102506f, 0.05398100f, 0.16544031f, 0.05807496f, -0.14909232f, 0.02848524f, -0.16170810f, -0.09127844f, 
    -0.02129202f, 0.02726676f, -0.09881207f, 0.07780767f, 0.05500960f, 0.14135768f, 0.05606558f, 0.02903885f, 
    -0.09334015f, -0.22669570f, -0.07057105f, 0.02845630f, -0.02571670f, 0.02211294f, 0.05792078f, -0.12091067f, 
    -0.00426228f, -0.07420701f, 0.09351631f, -0.10080335f, 0.21165353f, 0.16939440f, -0.01408804f, 0.04726677f, 
    0.04277350f, 0.03080707f, -0.07619862f, 0.26586658f, 0.08981027f, -0.04212438f, 0.12419221f, -0.06714451f, 
    -0.08078799f, 0.01960386f, 0.10468023f, -0.01464409f, -0.04690463f, -0.06862094f, 0.05292129f, 0.16378853f, 
    0.03037456f, 0.10097334f, -0.12481570f, -0.01698332f, -0.11235059f, -0.05873334f, -0.02712494f, 0.13210674f, 
    0.02666501f, 0.05611286f, 0.12412307f, 0.11644801f, 0.00727367f, -0.01746397f, 0.03245986f, 0.03392368f, 
    0.28866768f, -0.19194624f, 0.04875880f, 0.02666237f, 0.00453026f, 0.02864805f, -0.00193454f, 0.00921834f, 
    -0.02967015f, 0.05955057f, 0.02786494f, 0.15093996f, 0.32116371f, -0.12421902f, -0.06411158f, -0.11963154f, 
    0.07882436f, 0.03042860f, 0.05865018f, -0.03412784f, 0.00360400f, -0.04914901f, -0.03000905f, 0.06001514f, 
    -0.20186439f, 0.02869560f, 0.08441740f, -0.00514297f, 0.02019738f, -0.02737490f, -0.05358620f, 0.04303444f, 
    -0.00395151f, 0.10938740f, 0.03559969f, 0.03796265f, -0.07980726f, 0.20979734f, -0.10863484f, -0.17204042f, 
    0.11219645f, -0.00751199f, 0.10706776f, 0.00539141f, -0.11477450f, 0.02644704f, 0.01687432f, 0.09338365f, 
    0.09682990f, -0.01356344f, 0.03708431f, 0.13782230f, 0.14503366f, -0.06653795f, -0.08748861f, -0.05676574f, 
    0.03171152f, 0.12051015f, -0.04798646f, 0.14028472f, -0.27907947f, 0.08989474f, 0.12314404f, -0.08311778f, 
    0.13955887f, 0.08720441f, 0.09073615f, 0.05128814f, 0.08084160f, 0.01249077f, 0.08528666f, 0.00178095f, 
    -0.33003065f, 0.24384853f, 0.02342273f, -0.32136041f, 0.13375564f, -0.09378358f, 0.09474161f, 0.02774195f, 
    0.04507837f, 0.04967530f, 0.03106412f, 0.03289266f, -0.18560727f, -0.12672071f, -0.00995819f, 0.00804432f, 
    0.06083341f, 0.00081376f, 0.09571137f, -0.03167701f, 0.06130421f, 0.00649629f, 0.09440063f, -0.13505270f, 
    -0.24366121f, 0.08989950f, 0.11885096f, 0.04682336f, 0.01335759f, 0.11675064f, 0.12668830f, 0.02727601f, 
    0.04135068f, 0.18589760f, 0.00237745f, -0.02917061f, 0.00061574f, 0.05214396f, 0.29254225f, -0.05924200f, 
    0.11021963f, 0.18726242f, -0.02605493f, 0.04490662f, 0.06172664f, -0.02357664f, -0.06150749f, 0.00626538f, 
    -0.42273194f, -0.07973405f, 0.05469383f, -0.03716266f, -0.04744769f, -0.01163291f, 0.06711385f, -0.11509363f, 
    0.05319509f, 0.07706290f, -0.05495422f, 0.00003485f, 0.19345303f, -0.14876136f, -0.05797457f, 0.02104328f, 
    0.08167507f, -0.05746837f, 0.01877336f, -0.04337661f, 0.00086039f, 0.01718055f, -0.01245584f, 0.00341849f, 
    0.05137014f, 0.23143017f, 0.18557778f, 0.20720898f, -0.05865246f, -0.05891663f, -0.05965145f, 0.02952997f, 
    0.06992055f, -0.00104273f, 0.02629510f, 0.02315705f, -0.21633606f, -0.06508274f, 0.09022159f, 0.12131672f, 
    0.06428982f, 0.08147785f, 0.16156557f, -0.08004275f, -0.06578974f, -0.00798521f, -0.03440053f, 0.09187807f, 
    0.04921058f, 0.00663611f, 0.09960375f, 0.09740420f, 0.01180907f, -0.03128615f, -0.06538386f, 0.25542375f, 
    0.17388144f, 0.13477893f, -0.08821595f, 0.04288232f, -0.10355216f, 0.14952308f, -0.23316427f, -0.11426674f, 
    0.04186397f, 0.10509027f, 0.12976316f, 0.05446511f, 0.02985971f, -0.11966398f, -0.10986155f, -0.07865758f, 
    0.81862968f, -0.14115885f, 0.19006927f, 0.16483180f, -0.16769512f, 0.04292732f, -0.01136827f, -0.02979796f, 
    0.00077842f, -0.08283973f, 0.07898790f, -0.01797662f, -0.32732332f, 0.13158070f, -0.11126682f, -0.08509899f, 
    -0.00720664f, -0.04494708f, 0.03096667f, 0.11020125f, -0.15183093f, -0.07675271f, 0.01282125f, -0.02802349f, 
    0.21061504f, 0.12675309f, -0.08103271f, 0.22480634f, 0.13668659f, -0.01676730f, 0.06373579f, -0.04427875f, 
    -0.01491148f, 0.00561754f, 0.01840304f, -0.18634585f, 0.15875760f, -0.08016323f, 0.17946415f, 0.19573960f, 
    0.03089535f, -0.07853797f, -0.05784282f, 0.04512516f, -0.08212411f, 0.12612055f, -0.00016162f, 0.05412351f, 
    0.05007767f, -0.12125517f, 0.00856902f, 0.00672769f, -0.16325292f, -0.09269786f, -0.09758148f, -0.06121007f, 
    0.03348438f, -0.01781786f, 0.19399753f, 0.21570353f, 0.00209169f, 0.13563938f, -0.10894241f, 0.05129871f, 
    -0.06554057f, -0.18155517f, 0.06466537f, -0.02167450f, -0.11230630f, -0.03574434f, -0.00430136f, -0.04289201f, 
    0.37869456f, -0.04205193f, -0.01478879f, -0.07126572f, -0.02068838f, -0.20811071f, -0.06524438f, -0.05298511f, 
    -0.03924318f, 0.07995162f, -0.05133952f, 0.05811167f, 0.13344502f, -0.00423285f, -0.02113595f, 0.04538055f, 
    -0.07799430f, -0.04337490f, 0.08741150f, 0.02399418f, 0.00521433f, -0.00469757f, -0.10240871f, -0.04326594f, 
    -0.24646044f, 0.12974542f, 0.05373188f, 0.01304086f, -0.02591185f, 0.00267867f, 0.13999708f, -0.05322552f, 
    0.01064299f, -0.03092032f, -0.02012122f, 0.01033268f, -0.04931789f, 0.11649044f, -0.20061059f, 0.22761412f, 
    0.13428535f, 0.01654787f, -0.00087146f, 0.07146372f, 0.00571694f, 0.11960004f, -0.00026717f, -0.11605026f, 
    -0.17107265f, -0.01205847f, -0.12029345f, 0.17882365f, 0.03928476f, 0.13759772f, 0.04576168f, 0.02103506f, 
    -0.06449261f, 0.03782974f, -0.02014640f, 0.11870899f, 0.14525802f, 0.28596562f, -0.14292063f, -0.19138603f, 
    0.08184709f, 0.17909363f, -0.02805711f, -0.08579665f, 0.01713322f, -0.04541543f, 0.05982156f, 0.02833025f, 
    0.39606571f, -0.03962084f, 0.09850321f, -0.11582864f, -0.07912076f, -0.04932228f, 0.07394592f, 0.02866421f, 
    -0.02495647f, -0.09291644f, 0.03764617f, 0.04392582f, -0.07738831f, 0.08371281f, -0.20349997f, -0.17156839f, 
    -0.05587266f, 0.01035491f, -0.00993099f, 0.04656849f, -0.06543824f, -0.04308620f, 0.00318373f, 0.19087097f, 
    0.22162192f, -0.18656924f, 0.00788101f, 0.02448565f, -0.06065791f, 0.03441547f, 0.08454745f, 0.03682248f, 
    0.08919888f, -0.00921822f, 0.03567645f, 0.02828589f, 0.12851395f, 0.19844455f, -0.05124916f, 0.25046623f, 
    0.07057047f, 0.02226079f, -0.06618266f, -0.16568650f, -0.13282666f, -0.06192295f, -0.06600511f, 0.00879016f, 
    0.04543904f, 0.13617390f, 0.09404427f, -0.10415643f, 0.08166583f, 0.01886734f, -0.10661551f, -0.02250391f, 
    0.03290236f, 0.00908294f, 0.11125028f, 0.03674045f, -0.09172081f, 0.07775866f, 0.02536755f, -0.10388491f, 
    -0.09151005f, 0.09516168f, -0.04551234f, -0.04557290f, 0.10492544f, 0.02509939f, 0.02687132f, 0.02560498f, 
    0.15628776f, 0.12569804f, -0.12749395f, -0.24216056f, 0.03442091f, 0.04215131f, -0.07431496f, -0.13029708f, 
    -0.08107423f, -0.02641206f, 0.03621606f, -0.03108465f, -0.09805486f, -0.05438355f, -0.07520386f, -0.17982227f, 
    0.22060172f, -0.01973931f, -0.03352186f, -0.07177023f, 0.10570675f, 0.13897026f, 0.04950222f, -0.06179421f, 
    0.09203040f, 0.09755574f, -0.00653884f, 0.04062665f, -0.11336862f, 0.11431303f, -0.08359760f, -0.05870817f, 
    -0.06888430f, -0.07804506f, 0.14018849f, -0.02665966f, -0.26163051f, -0.28094286f, -0.07056101f, 0.05113989f, 
    -0.01063194f, 0.11712178f, 0.10695854f, -0.09016645f, 0.05292320f, -0.01172223f, -0.01667511f, 0.04673863f, 
    -0.03139684f, -0.04430275f, -0.03030512f, 0.13870721f, -0.01324224f, 0.03927997f, 0.03203838f, -0.13849097f, 
    0.14030445f, -0.00975601f, 0.10705300f, 0.08230843f, -0.18858226f, 0.08229830f, -0.05058395f, 0.02837105f, 
    0.07965627f, 0.10887662f, 0.06406263f, -0.01120701f, 0.05554111f, -0.12082271f, 0.02168451f, -0.01169238f, 
    0.09762941f, -0.01101629f, -0.20579726f, -0.00645244f, 0.01924446f, -0.02163356f, -0.06980255f, -0.08468646f, 
    -0.14416213f, 0.09041355f, 0.09009922f, 0.03433720f, 0.15861692f, 0.11911633f, 0.08217080f, 0.16726086f, 
    -0.01173166f, 0.02885815f, -0.08927655f, -0.08460372f, -0.05267256f, 0.08437221f, 0.10482081f, 0.00005101f, 
    -0.05560313f, 0.22495648f, -0.00632842f, 0.03111678f, 0.15397106f, 0.07708766f, 0.02120664f, -0.02756220f, 
    0.00721456f, 0.01715026f, 0.04179639f, -0.01025788f, 0.10204582f, -0.05448665f, 0.03847190f, 0.22027913f, 
    -0.02059057f, -0.02490161f, -0.14104739f, 0.07331231f, -0.04523863f, 0.06347375f, -0.04486363f, -0.00659156f, 
    0.06044131f, 0.18904264f, 0.11538348f, -0.03566156f, -0.22429883f, 0.06308788f, 0.03091285f, 0.02848276f, 
    -0.07827845f, 0.03881922f, 0.01937310f, -0.00861807f, -0.03606902f, 0.20224713f, 0.02386971f, 0.08749264f, 
    0.08429770f, 0.06876034f, -0.07839141f, -0.09414064f, 0.02680943f, 0.02700217f, 0.03900887f, -0.04065105f, 
    0.06797495f, -0.09712643f, -0.13287948f, -0.14019148f, 0.00336318f, 0.06718658f, 0.03364408f, -0.04427859f, 
    0.10103642f, -0.02947037f, 0.26639554f, 0.12244034f, 0.21877797f, -0.07687235f, 0.11580144f, 0.12254668f, 
    -0.10033274f, -0.06446213f, -0.04470921f, 0.03470657f, 0.03919071f, -0.01596307f, -0.13602786f, -0.08414070f, 
    -0.56654876f, 0.20649733f, 0.00902574f, 0.12756658f, 0.12985539f, -0.13149895f, 0.01013619f, 0.05364621f, 
    -0.03015854f, 0.01449103f, 0.07849862f, -0.00282931f, 0.01567580f, 0.12030052f, 0.11628836f, 0.10562994f, 
    -0.27822813f, -0.03384956f, -0.04268997f, 0.02433291f, 0.06166589f, 0.13205633f, -0.01295726f, -0.06735851f, 
    0.20776835f, 0.07781034f, -0.00101613f, -0.16431642f, -0.08693679f, -0.07246740f, 0.06963123f, -0.03728315f, 
    0.02383809f, -0.02405331f, 0.08422252f, -0.02502560f, 0.13239117f, 0.10046127f, -0.22905569f, -0.01156816f, 
    0.05918030f, -0.00262768f, 0.01733113f, 0.04078491f, -0.00134466f, -0.02500179f, -0.02320313f, -0.00219856f, 
    -0.25521731f, 0.12095799f, 0.05504992f, -0.04471444f, -0.08495827f, 0.02060622f, -0.00948071f, 0.06858535f, 
    -0.10115849f, -0.07316218f, -0.02784908f, 0.00095794f, 0.13681135f, -0.10826317f, 0.14551809f, -0.00773766f, 
    -0.00825411f, 0.09483308f, 0.10847833f, 0.05877591f, 0.03772740f, 0.06176179f, -0.03992782f, -0.00600042f, 
    0.12689483f, -0.01238087f, -0.04218940f, 0.14843579f, -0.01722699f, 0.08795308f, 0.00593620f, 0.06673641f, 
    -0.04470256f, -0.04143044f, 0.08521113f, 0.06698518f, 0.24378970f, 0.26912963f, -0.09492732f, 0.02687162f, 
    0.06534144f, 0.09041206f, 0.02734501f, 0.16392970f, 0.06061848f, -0.15221184f, 0.00922615f, -0.01562487f, 
    0.37886110f, -0.10380167f, -0.06189635f, -0.16441427f, 0.03459973f, -0.02659826f, -0.01817790f, 0.02129601f, 
    -0.11725774f, 0.04708096f, -0.01816393f, 0.03410092f, -0.01279004f, -0.12989102f, -0.03294475f, 0.07349615f, 
    -0.07481407f, 0.00515691f, 0.04866989f, -0.00540417f, 0.09362106f, -0.01468704f, -0.01077696f, -0.08766049f, 
    0.44568259f, 0.00262650f, -0.03418000f, 0.06797226f, 0.00181755f, 0.08909663f, 0.01713846f, 0.05793228f, 
    0.16554920f, -0.02959838f, -0.01504051f, 0.05613103f, -0.05136209f, -0.15744522f, 0.22980699f, 0.03911921f, 
    0.03302196f, -0.03076156f, -0.05426948f, -0.00970202f, -0.07286273f, 0.06342539f, 0.03119920f, 0.00653985f, 
    -0.08154376f, -0.09569550f, -0.09360871f, -0.08360087f, 0.13675669f, 0.00016580f, -0.05156124f, -0.01546903f, 
    0.00586856f, -0.00312742f, -0.03772178f, 0.07280080f, 0.10661189f, -0.11022910f, -0.00775929f, -0.02440898f, 
    0.07668421f, -0.03366277f, -0.12076953f, -0.00382327f, 0.05682183f, 0.07147780f, 0.04830366f, 0.06040485f, 
    0.31611875f, -0.07520118f, -0.14098468f, 0.16207245f, 0.00020151f, 0.12549542f, 0.00604779f, 0.18583052f, 
    0.18779391f, 0.09402592f, 0.11240560f, 0.06692774f, 0.29093099f, 0.19221635f, -0.19934644f, 0.31883106f, 
    -0.02677796f, 0.01622778f, 0.09321022f, -0.08592921f, -0.05156495f, -0.01730864f, -0.06061471f, -0.07232955f, 
    0.04694056f, 0.19403704f, 0.04837559f, -0.03734982f, -0.01795156f, 0.02951814f, 0.02757928f, 0.13575138f, 
    -0.01294517f, 0.04150734f, 0.04880755f, -0.05600713f, -0.11183605f, 0.19558439f, 0.09009098f, -0.05054896f, 
    -0.12608598f, -0.04317043f, -0.03309273f, 0.11192272f, 0.00379471f, 0.01674478f, -0.00250045f, -0.18046731f, 
    0.30974078f, 0.20742503f, -0.02322622f, -0.11347850f, -0.07525216f, -0.08065143f, 0.00762845f, -0.00041169f, 
    0.00894700f, 0.07270962f, 0.02663013f, -0.04347578f, 0.19629312f, -0.30626565f, 0.01296481f, -0.01404905f, 
    -0.09932545f, -0.11750571f, 0.05844530f, 0.01008797f, 0.01090098f, 0.12085087f, 0.03819086f, 0.06460056f, 
    -0.00063662f, -0.06239143f, -0.10724252f, 0.18270975f, -0.16327605f, -0.05343612f, -0.10592046f, 0.01584964f, 
    0.09587424f, 0.06544743f, 0.08298778f, 0.06660619f, -0.10521245f, -0.41670245f, 0.12463360f, -0.06922207f, 
    -0.10345528f, -0.21175775f, 0.13415779f, -0.15472491f, 0.03030123f, -0.02597708f, 0.00986085f, -0.14930542f, 
    0.27481458f, 0.09185238f, 0.03534088f, 0.17252721f, -0.09448999f, -0.02843398f, -0.02966194f, -0.20752673f, 
    -0.01873296f, 0.02039014f, 0.05363697f, -0.02277162f, -0.05507567f, -0.02995280f, 0.04915829f, 0.07522245f, 
    -0.11520968f, -0.04713457f, 0.11082285f, -0.02569914f, 0.04988452f, -0.00774757f, -0.04704818f, 0.12968729f, 
    -0.14216538f, -0.11357323f, -0.01677783f, -0.16073507f, 0.07039622f, 0.03943276f, 0.05541735f, -0.11250836f, 
    -0.04207605f, 0.02397767f, 0.08004309f, 0.10365955f, 0.08359247f, 0.05505953f, 0.02529089f, 0.26426506f, 
    -0.08226828f, -0.04051590f, 0.01218460f, -0.05799123f, 0.01641596f, 0.08957005f, -0.04470798f, -0.08499616f, 
    0.14212117f, 0.04046261f, -0.04060826f, 0.21917203f, -0.03020515f, 0.09730866f, -0.13933340f, -0.05711937f, 
    0.15311517f, 0.04650798f, 0.09344326f, 0.03108673f, -0.31886283f, 0.45550683f, -0.12806703f, 0.02207850f, 
    -0.11664033f, 0.13817364f, -0.14825618f, 0.01881616f, -0.02935753f, 0.05072746f, 0.11389023f, 0.07059171f, 
    0.13365924f, 0.12458442f, 0.06508765f, 0.00496241f, 0.00154202f, -0.11323572f, 0.05767396f, -0.00331432f, 
    -0.03487446f, 0.03111874f, -0.03972013f, 0.04205227f, 0.23105583f, -0.06465197f, 0.05643961f, -0.00591929f, 
    -0.07376163f, -0.04258556f, -0.11721481f, -0.08911651f, 0.08390125f, 0.02883120f, 0.00633243f, 0.20514137f, 
    0.02955594f, -0.06680170f, -0.02213359f, 0.02185284f, 0.01617474f, -0.06459020f, -0.03849162f, 0.03366920f, 
    0.01411917f, -0.00784797f, 0.00520349f, -0.06880037f, -0.02214886f, -0.02069585f, -0.07944866f, 0.05396959f, 
    -0.02877842f, -0.04110084f, 0.05000691f, -0.07092667f, 0.03506159f, -0.08140372f, -0.03840749f, 0.03398092f, 
    0.00189522f, 0.02031771f, -0.01978580f, -0.02681619f, -0.02225851f, -0.07078479f, 0.00738047f, 0.06002985f, 
    0.02541394f, 0.04046296f, 0.04667701f, -0.07958805f, -0.03086384f, -0.01752144f, -0.01778481f, 0.00671807f, 
    0.03325745f, 0.05110335f, 0.01133213f, -0.04389424f, 0.02757986f, -0.00125731f, -0.07080698f, -0.00794353f, 
    -0.02963690f, -0.01736327f, 0.05964337f, 0.02184756f, 0.00780592f, 0.02161621f, -0.07693525f, -0.05572389f, 
    0.05716255f, -0.05281140f, -0.00159901f, 0.03665180f, -0.04953609f, -0.05657899f, 0.00000842f, -0.05836705f, 
    0.01903264f, -0.01018482f, -0.05389778f, -0.04420200f, 0.03665736f, -0.07994253f, -0.01252035f, -0.07862923f, 
    -0.06031711f, 0.05326648f, -0.06165397f, 0.00728859f, -0.00068980f, -0.06694300f, 0.00062292f, -0.03611589f, 
    0.01353154f, 0.04131643f, -0.02039653f, -0.04733699f, -0.07867889f, 0.01561675f, 0.05249214f, -0.03875158f, 
    0.04592582f, -0.04300977f, 0.05232621f, -0.07229469f, 0.05139611f, -0.06871364f, -0.07861733f, -0.01836636f, 
    -0.01329683f, 0.01547133f, -0.02480545f, -0.02503746f, 0.01784790f, -0.04250878f, 0.05655412f, -0.02332594f, 
    0.04186989f, 0.04883306f, -0.02569509f, -0.07866206f, 0.04207221f, 0.01064577f, -0.00744560f, 0.00400030f, 
    -0.00114132f, 0.01718704f, 0.01074264f, 0.04042782f, -0.05050317f, -0.01562473f, -0.05448362f, -0.04104578f, 
    -0.04040900f, 0.05982094f, 0.04806026f, -0.00868726f, -0.05485781f, 0.04666694f, 0.05758607f, 0.02363268f, 
    -0.00121385f, 0.03904648f, 0.05224526f, 0.02566830f, -0.01840767f, 0.05376612f, -0.07981682f, -0.02274079f, 
    -0.02040452f, -0.06606536f, 0.01115710f, 0.04829950f, -0.06703354f, 0.04098843f, -0.00354290f, 0.01120935f, 
    -0.04542309f, 0.05909991f, 0.00209631f, 0.04408192f, -0.02086272f, -0.02311720f, 0.03521087f, 0.01660635f, 
    0.01226289f, 0.02255075f, 0.02461565f, -0.02991837f, -0.06620158f, 0.04640840f, 0.00437765f, -0.03101686f, 
    -0.04707149f, 0.02306880f, -0.04550136f, 0.02654260f, -0.06802227f, -0.04058248f, -0.02332303f, 0.00453132f, 
    -0.07437146f, -0.04636973f, -0.00747667f, 0.02223462f, 0.01605082f, 0.05375651f, -0.07227077f, -0.07399118f, 
    -0.05950505f, -0.01593179f, -0.00862098f, -0.05143436f, -0.03866132f, -0.04278797f, -0.07312086f, -0.04480467f, 
    -0.07750561f, -0.04815404f, -0.05936081f, -0.02129812f, 0.05589898f, 0.05046311f, 0.00754197f, -0.06526490f, 
    -0.29659551f, 0.18738841f, -0.19873789f, -0.13692161f, 0.04163102f, 0.09553076f, -0.12701927f, -0.08338730f, 
    -0.02144188f, -0.08407266f, -0.04995414f, 0.01858816f, -0.13230561f, -0.10653313f, 0.15078594f, -0.05430747f, 
    -0.02681966f, 0.00533948f, -0.01325084f, -0.09085260f, 0.08497091f, 0.01812586f, 0.09928815f, -0.06230513f, 
    -0.11132435f, -0.08072937f, -0.18258512f, -0.34186459f, 0.10694931f, -0.01464919f, -0.11768056f, -0.03391851f, 
    0.02487089f, -0.01381065f, 0.04301376f, -0.06635369f, -0.11666611f, -0.10940646f, -0.15863007f, 0.16308658f, 
    0.07917149f, -0.00287567f, -0.03655447f, 0.02622721f, 0.18344611f, 0.09153413f, -0.13481824f, 0.04701072f, 
    0.07097246f, 0.17509815f, 0.10483827f, 0.25541073f, 0.04343396f, -0.04298856f, -0.00345430f, 0.02065188f, 
    0.01307447f, 0.00426301f, -0.03361551f, 0.09159445f, -0.02274161f, 0.15306307f, 0.24732880f, 0.05046578f, 
    -0.00923612f, 0.00535073f, 0.12438652f, -0.05020647f, 0.11997533f, -0.07803718f, -0.08432992f, 0.03579548f, 
    -0.17229888f, 0.20335303f, -0.08488200f, 0.00941486f, 0.01246529f, 0.11661815f, 0.22332457f, 0.00418831f, 
    -0.00244064f, -0.03237955f, -0.02844874f, -0.05342373f, -0.00290535f, 0.15514597f, -0.02244508f, 0.09649448f, 
    0.00038557f, 0.18698394f, 0.06036762f, 0.03378321f, 0.03573303f, -0.16412929f, -0.01554098f, 0.02353979f, 
    -0.17620353f, 0.04056701f, 0.24703664f, 0.22610922f, -0.02208875f, 0.21365239f, 0.14398539f, 0.11255779f, 
    -0.06756991f, -0.00579734f, 0.03213704f, 0.08407124f, 0.22823381f, 0.22783129f, 0.10220597f, -0.01394325f, 
    -0.08910228f, 0.13578227f, 0.02790752f, 0.03755594f, -0.13926581f, -0.06464323f, -0.03370094f, 0.04809493f, 
    0.26583371f, -0.05284677f, 0.03708860f, 0.12211277f, -0.13402306f, -0.02946314f, -0.01348845f, -0.01141704f, 
    -0.06494902f, -0.12004213f, -0.00193047f, -0.02162636f, 0.01502627f, 0.02548342f, 0.02807046f, 0.10529850f, 
    -0.00449069f, -0.00270798f, 0.05688898f, -0.07688163f, 0.06202058f, -0.09196750f, -0.01264764f, 0.21622536f, 
    -0.01313777f, 0.22996037f, 0.14603184f, 0.14132680f, -0.07984646f, -0.14487424f, 0.09201916f, -0.01604829f, 
    -0.11056904f, -0.08002772f, 0.00602212f, -0.05181994f, 0.05016317f, -0.19223525f, 0.00748225f, 0.08067776f, 
    0.07146977f, 0.06558884f, -0.03441916f, 0.07740606f, 0.06260556f, -0.10626109f, 0.11101072f, 0.04294055f, 
    -0.11875065f, -0.01979687f, -0.13760979f, -0.11851799f, 0.16175352f, 0.12204837f, 0.02444312f, -0.02751502f, 
    0.15986386f, 0.05213201f, -0.05788729f, -0.11037056f, -0.08092391f, -0.00295272f, -0.13300136f, -0.02784014f, 
    0.10067748f, 0.03037446f, 0.05525840f, 0.08643607f, -0.07737364f, -0.16826776f, 0.00686752f, -0.10115332f, 
    -0.11338208f, 0.01544579f, -0.01352125f, 0.04099076f, 0.03489725f, 0.01302169f, -0.12869486f, 0.06160058f, 
    0.05401565f, 0.06091289f, 0.02803957f, -0.10693163f, -0.08966874f, 0.00552617f, -0.04371060f, -0.08649164f, 
    -0.01190771f, 0.01330574f, 0.04156077f, -0.11424953f, -0.04441236f, 0.02849311f, 0.10034624f, 0.03251623f, 
    0.00108638f, 0.18604387f, -0.02063167f, -0.00332519f, 0.07063976f, -0.04634911f, 0.03124568f, 0.12447758f, 
    -0.03180227f, 0.00461524f, -0.01349605f, 0.03383063f, -0.12685427f, 0.06720079f, 0.06369989f, -0.05636049f, 
    0.07146817f, 0.06955300f, -0.03757147f, 0.04289746f, -0.02430663f, 0.07581514f, 0.11106145f, 0.09053762f, 
    0.11586096f, -0.06512536f, -0.14175841f, 0.34578222f, 0.09869440f, 0.01546338f, 0.03307606f, 0.05339536f, 
    -0.03431965f, 0.03320067f, -0.06689746f, 0.04365631f, 0.18061541f, -0.15221907f, 0.30790699f, 0.24380606f, 
    -0.04234555f, 0.00931961f, 0.07695435f, 0.03104921f, 0.10376412f, 0.03181950f, 0.00272269f, 0.07617395f, 
    -0.04648263f, -0.07818582f, -0.04290086f, 0.10472684f, -0.00455426f, 0.00296385f, 0.00851209f, 0.12427075f, 
    0.12897095f, 0.07424338f, -0.02692134f, -0.09215530f, 0.16849773f, -0.07345106f, -0.14801249f, -0.05834556f, 
    0.00091951f, -0.15413244f, -0.04774158f, -0.05516303f, 0.07232664f, 0.02759995f, 0.04788632f, -0.04226526f, 
    0.24079390f, 0.06262697f, -0.00321152f, 0.26831684f, -0.05411983f, 0.01904577f, 0.06939585f, -0.05611159f, 
    0.07553310f, -0.01527836f, 0.02654861f, -0.05501956f, 0.17660594f, -0.18972655f, 0.01922853f, 0.10153262f, 
    -0.13786641f, -0.01106464f, 0.05553153f, 0.04552294f, -0.03244808f, 0.12572204f, -0.09658226f, 0.24055913f, 
    -0.08737145f, -0.12123096f, -0.01832784f, -0.02037814f, 0.06207595f, -0.09444911f, 0.02959603f, -0.04425940f, 
    0.04447521f, -0.12965442f, 0.07963549f, 0.13874765f, 0.05815744f, 0.01398183f, -0.16526955f, 0.13866742f, 
    -0.01589156f, -0.04574918f, 0.11883116f, -0.08799669f, -0.03451615f, -0.00944346f, 0.08312006f, 0.07605563f, 
    0.07305831f, 0.03060626f, -0.00228306f, 0.13105720f, -0.00158402f, -0.01542024f, -0.06695660f, 0.01995163f, 
    0.10781346f, 0.06365628f, 0.06270491f, 0.04565502f, -0.38329825f, 0.36669222f, -0.07169569f, -0.12839192f, 
    0.00300478f, 0.08624537f, 0.02452297f, -0.04880902f, 0.02929283f, 0.08527550f, -0.04264064f, 0.02289337f, 
    0.10771838f, 0.03939200f, -0.05211434f, -0.01567335f, -0.00237840f, -0.08158337f, 0.04035507f, -0.09079739f, 
    -0.01432033f, -0.10869478f, 0.12083280f, -0.03152905f, 0.05910625f, -0.00972301f, -0.06926275f, -0.15736139f, 
    -0.07622312f, -0.08093272f, -0.00754745f, 0.10233710f, -0.00928185f, -0.04121378f, 0.00095584f, -0.00874153f, 
    0.03735729f, -0.01401498f, 0.02762129f, -0.02950452f, -0.06193580f, 0.00576571f, 0.05597599f, -0.02894987f, 
    -0.07338481f, -0.00721056f, 0.02356103f, -0.01338043f, -0.02176572f, -0.03903434f, -0.05187122f, 0.02613240f, 
    0.03157435f, -0.03052817f, -0.00738582f, 0.04913968f, -0.01415186f, -0.03556520f, -0.04992513f, 0.00789521f, 
    0.03565542f, 0.03541793f, 0.03808690f, -0.03619289f, -0.07972030f, -0.05392193f, -0.03017676f, 0.02407322f, 
    0.01079135f, 0.04572350f, -0.05987304f, 0.00102433f, -0.00722417f, 0.03433708f, 0.02908888f, 0.06139610f, 
    -0.03583335f, -0.00546346f, -0.01502464f, -0.05348566f, -0.05933424f, 0.02414916f, -0.00816337f, 0.00106600f, 
    -0.03006889f, -0.04011523f, -0.05294046f, 0.06012992f, 0.04630500f, -0.07468512f, 0.02581583f, 0.01926312f, 
    -0.03333804f, -0.04411516f, -0.01062739f, 0.04868815f, -0.01748636f, -0.03830180f, 0.00065853f, 0.00918491f, 
    -0.01898064f, -0.06796394f, 0.01032095f, -0.05655503f, -0.07707789f, 0.03852582f, -0.05851467f, 0.03760374f, 
    0.01864906f, -0.02510881f, -0.04517060f, -0.06848359f, -0.07343996f, 0.05152066f, 0.03729091f, -0.05846288f, 
    -0.04805424f, 0.04749912f, -0.05991270f, -0.02528695f, -0.07390191f, 0.02860766f, -0.04742150f, -0.01331834f, 
    -0.05214421f, -0.04062289f, -0.05528367f, 0.05652053f, 0.04017981f, -0.02804082f, -0.07075731f, 0.00221775f, 
    -0.04993997f, -0.05360742f, 0.03079769f, 0.05681797f, -0.03882377f, 0.02005147f, 0.06526338f, 0.03624436f, 
    0.05596513f, 0.01988882f, 0.03545295f, -0.00473825f, -0.07718600f, 0.02145067f, -0.03823820f, -0.00529716f, 
    -0.07039279f, 0.02711206f, -0.01670087f, 0.01449824f, 0.03941109f, 0.03342344f, 0.04284984f, 0.01405694f, 
    0.06234205f, -0.01453270f, -0.04700574f, -0.02677827f, -0.01595260f, -0.03146237f, -0.03768026f, -0.00807589f, 
    -0.07750428f, -0.05668940f, -0.02479840f, -0.06221205f, 0.05310137f, -0.03836126f, -0.04357378f, -0.03505157f, 
    -0.00094039f, -0.01544581f, -0.03964317f, 0.04892711f, 0.03204800f, -0.06817690f, -0.04039939f, -0.04241378f, 
    0.00287799f, -0.01111752f, -0.04769365f, 0.01830469f, -0.06491659f, 0.01127219f, -0.07674088f, 0.00360081f, 
    0.02759445f, -0.00929707f, -0.01513493f, -0.04237140f, -0.02769747f, 0.04049772f, -0.04571849f, 0.04457487f, 
    -0.03542268f, -0.00478177f, -0.07192913f, 0.03721396f, 0.06359975f, -0.01938669f, -0.07331966f, -0.03268292f, 
    -0.07658609f, 0.01687289f, -0.00037552f, 0.00615776f, 0.01707778f, -0.06137077f, -0.02597706f, 0.02176097f, 
    -0.02434689f, 0.04863241f, 0.01992166f, -0.03536054f, -0.03116776f, -0.04350783f, -0.02436027f, 0.01377401f, 
    -0.03792684f, 0.01741976f, 0.02686710f, -0.03699767f, -0.01749214f, -0.00615476f, -0.02988829f, -0.02336747f, 
    0.02047045f, 0.17397654f, -0.18779752f, -0.09036782f, 0.07859351f, 0.02317348f, 0.13364206f, -0.03679286f, 
    0.11317751f, -0.07312238f, 0.12890065f, 0.18371382f, 0.05782541f, -0.00591693f, 0.09524835f, 0.16524684f, 
    0.00851914f, 0.07392002f, -0.04191069f, 0.04896257f, 0.09584320f, -0.03300409f, -0.11289117f, -0.04399586f, 
    -0.41850394f, 0.04788345f, -0.21451911f, 0.01590730f, 0.08896448f, -0.06712981f, -0.05987447f, 0.08412517f, 
    -0.00232127f, 0.06672500f, -0.09393600f, 0.00189908f, 0.34060445f, -0.02779302f, -0.03329929f, 0.15191394f, 
    -0.02126913f, -0.02977425f, 0.03389399f, 0.10067046f, 0.14395881f, 0.11073673f, -0.14590369f, -0.11407008f, 
    -0.07342483f, 0.00638014f, 0.01864017f, -0.09971578f, -0.15413235f, -0.08845331f, -0.04119436f, -0.09414449f, 
    0.06582143f, -0.01196604f, 0.07873672f, 0.07393238f, -0.00242988f, 0.28191242f, -0.15715007f, -0.16138405f, 
    -0.02711868f, 0.02091677f, -0.06516656f, -0.04954035f, -0.04012895f, 0.02479719f, -0.04748853f, 0.05326083f, 
    -0.03415834f, 0.07044566f, 0.12595929f, 0.03088301f, 0.08322361f, 0.09644912f, 0.12404133f, 0.18287274f, 
    -0.12112746f, 0.05094383f, 0.12879686f, 0.13924247f, -0.11279426f, -0.04175713f, 0.27850059f, -0.11245485f, 
    0.02758434f, 0.00229118f, 0.04202380f, 0.01360551f, 0.01317421f, 0.08906665f, -0.01232865f, 0.03733950f, 
    -0.08880930f, 0.16979179f, 0.12837829f, -0.02186614f, -0.05757596f, 0.10245093f, 0.00988500f, 0.17889415f, 
    -0.10209011f, 0.04304994f, 0.07239061f, 0.09002286f, 0.10061622f, 0.16532955f, 0.01186034f, 0.02154670f, 
    0.05448734f, 0.03807708f, 0.01391359f, -0.03627737f, -0.02737707f, -0.17022504f, 0.15130863f, -0.13444124f, 
    0.37863562f, -0.01353289f, -0.01490495f, -0.13255545f, -0.08233849f, 0.00545015f, 0.04576102f, -0.03473948f, 
    -0.02594401f, 0.12247030f, 0.07199880f, 0.00390652f, -0.04157621f, 0.00564896f, 0.16886596f, 0.08817807f, 
    -0.06119053f, 0.16057472f, 0.02051769f, 0.02730391f, 0.06609472f, 0.05032905f, 0.03640620f, -0.02751130f, 
    0.24904996f, 0.07687145f, 0.04078011f, -0.03610621f, 0.02066614f, -0.01487034f, -0.02592550f, -0.10932688f, 
    -0.03527290f, -0.00421499f, -0.04325079f, -0.03069706f, 0.11036395f, -0.13293770f, 0.26734322f, 0.22272259f, 
    -0.01489579f, -0.03573397f, 0.04259160f, -0.01889720f, -0.02381460f, -0.05755267f, 0.11273360f, 0.07689845f, 
    -0.30336773f, 0.02562179f, 0.04209864f, 0.10214572f, 0.18031949f, 0.09641534f, -0.03554529f, 0.11906076f, 
    0.11598371f, 0.07078703f, -0.06853789f, 0.08516347f, 0.00794726f, -0.21053188f, 0.21085992f, 0.23582914f, 
    0.10678196f, 0.02824777f, 0.09481040f, -0.09250409f, -0.04466779f, 0.04692968f, -0.01954922f, -0.00003107f, 
    -0.02191256f, 0.05605693f, -0.02793683f, -0.00154921f, -0.08535405f, 0.10360946f, 0.08034685f, -0.03465044f, 
    -0.00208197f, 0.01858196f, 0.06809863f, 0.10942074f, 0.30015752f, 0.15906622f, 0.01938389f, 0.21551688f, 
    0.14067082f, -0.11805701f, -0.05976383f, -0.13050334f, 0.02371956f, 0.10749241f, -0.00622309f, -0.00803523f, 
    -0.22348101f, 0.02816058f, 0.15128753f, -0.22539873f, -0.06605369f, -0.02829442f, 0.00160106f, 0.16755801f, 
    -0.00458528f, 0.00269633f, -0.01527230f, 0.02021257f, 0.23419604f, -0.11703277f, 0.13319574f, 0.11492585f, 
    0.11613881f, -0.08496672f, -0.04419033f, 0.02083968f, 0.00468552f, -0.06910281f, -0.09195039f, -0.03849057f, 
    -0.13732676f, 0.08632290f, -0.05289361f, 0.13423257f, 0.06591021f, 0.20539045f, 0.08989052f, 0.02992445f, 
    -0.10098173f, -0.03080482f, -0.06359717f, -0.05093669f, -0.10075393f, -0.00240668f, 0.07309794f, -0.25326765f, 
    -0.00350428f, -0.07645508f, 0.06426009f, 0.00850492f, 0.02004422f, -0.00227439f, -0.03610760f, 0.09883787f, 
    0.21351266f, 0.06705809f, 0.16303375f, 0.22390334f, 0.17551622f, 0.05442414f, 0.04979423f, 0.11414587f, 
    -0.05020259f, -0.03793219f, 0.07912054f, -0.06166673f, -0.25863352f, -0.23312305f, -0.11921605f, 0.09946481f, 
    -0.09161331f, -0.14849903f, 0.06055197f, -0.07105298f, 0.12522374f, -0.03660503f, -0.21326286f, -0.08956315f, 
    0.13361238f, -0.17137776f, 0.05131360f, 0.31456733f, 0.05444741f, 0.00602086f, -0.01205592f, 0.03215298f, 
    -0.13388732f, 0.01422610f, 0.09515242f, 0.11529092f, -0.19366568f, -0.09940935f, -0.09021652f, 0.07001148f, 
    0.01908957f, 0.04321366f, 0.18660879f, -0.09659868f, -0.11038917f, -0.11967232f, 0.03199531f, -0.08057266f, 
    -0.18164788f, -0.02523763f, -0.02576366f, -0.01176083f, -0.05042078f, -0.02853433f, 0.05464570f, 0.01438647f, 
    -0.02227113f, 0.05763327f, 0.07545178f, 0.14190507f, 0.04550920f, -0.04551681f, 0.19018464f, 0.24876837f, 
    0.02627491f, 0.19429007f, 0.07630061f, 0.05825367f, -0.11758592f, 0.00347767f, -0.13883743f, 0.13344800f, 
    0.08917715f, 0.02399777f, 0.04027185f, 0.14665784f, -0.20983219f, 0.07729550f, 0.07544869f, -0.05605946f, 
    -0.11352886f, -0.03101799f, 0.08060992f, -0.12137681f, -0.02448364f, 0.27079010f, 0.20982201f, 0.14135312f, 
    0.04278008f, -0.05701372f, 0.03488105f, 0.08552706f, -0.08235160f, -0.02878249f, 0.03543941f, -0.07862292f, 
    -0.06716669f, 0.10158373f, -0.03292276f, 0.24159446f, -0.16622409f, -0.10369572f, 0.06856766f, -0.06523374f, 
    0.09746556f, -0.02398604f, 0.07084489f, -0.10904974f, -0.05718881f, -0.10500564f, 0.00926315f, 0.22255689f, 
    0.16567117f, -0.07479093f, -0.02434046f, -0.12116951f, -0.04788019f, 0.07988685f, 0.06878135f, 0.13781424f, 
    -0.02014532f, 0.03031398f, -0.03248198f, -0.07523627f, -0.07023832f, -0.05144734f, -0.05607091f, 0.01087608f, 
    0.02738988f, 0.05900529f, 0.05059063f, -0.04398149f, -0.06687351f, 0.04728330f, -0.03008395f, -0.05559803f, 
    -0.05284831f, -0.02147555f, 0.04708562f, 0.05428649f, 0.02936094f, 0.05112784f, -0.00637262f, -0.01972524f, 
    0.05251106f, 0.03942504f, 0.05631477f, 0.04195096f, -0.07144122f, -0.02377984f, 0.06210286f, 0.00276915f, 
    -0.03502766f, -0.03280795f, -0.07895137f, 0.03496140f, -0.03763140f, -0.01626368f, -0.05570496f, 0.00463287f, 
    -0.07023179f, -0.08076492f, -0.05734282f, -0.02777528f, -0.07643630f, 0.04600965f, -0.06549928f, 0.03649728f, 
    0.00310691f, 0.05249218f, -0.03959085f, -0.07696604f, -0.03436821f, -0.04108786f, 0.01954581f, 0.04657286f, 
    0.02263890f, -0.05442618f, -0.06863001f, 0.04456630f, -0.06504763f, -0.07078078f, 0.05652814f, 0.03446404f, 
    -0.08149648f, -0.00968956f, 0.02704409f, -0.06326912f, -0.06338402f, -0.07166240f, -0.05011173f, 0.04625983f, 
    0.00623095f, -0.06984768f, 0.04372948f, 0.05665311f, 0.01520321f, 0.03160729f, 0.06189219f, 0.05484616f, 
    -0.04016668f, 0.00261889f, -0.06511896f, -0.01299681f, -0.02964401f, 0.01831084f, -0.01554373f, -0.06743632f, 
    -0.03895319f, 0.03062754f, 0.01426672f, -0.02271138f, -0.06072110f, -0.02986866f, -0.03108749f, -0.00057361f, 
    -0.02525406f, -0.02502001f, 0.02723901f, 0.00357104f, 0.05985995f, -0.03764489f, 0.04312053f, -0.05236628f, 
    0.01191949f, 0.06116330f, 0.02235667f, -0.05279083f, 0.01109840f, 0.02984258f, -0.06177373f, 0.03478287f, 
    0.00818192f, 0.04143180f, -0.03702998f, 0.01761859f, -0.05620226f, 0.03819624f, 0.02769049f, 0.05477728f, 
    -0.06761942f, 0.00442919f, -0.01068299f, -0.00865321f, 0.03528632f, -0.08186662f, -0.02704580f, -0.03615236f, 
    -0.01665505f, 0.05028313f, -0.02482673f, -0.06005155f, -0.02163989f, 0.00807931f, -0.02548105f, 0.05601240f, 
    -0.05712038f, -0.00412234f, 0.04482049f, 0.06183380f, 0.05687945f, -0.01436990f, 0.03019393f, 0.01580401f, 
    -0.05447862f, 0.01799522f, -0.08044761f, -0.02397166f, 0.02104564f, -0.07180250f, -0.05995923f, -0.04534331f, 
    -0.04245626f, -0.04420105f, -0.03389473f, -0.05477657f, 0.00683092f, -0.02066571f, 0.02052185f, 0.05089064f, 
    -0.00124166f, -0.07456689f, 0.01160165f, -0.02817469f, 0.01001456f, -0.05464379f, 0.05479404f, -0.00590773f, 
    -0.06039813f, 0.06236725f, 0.00339650f, -0.02453190f, -0.05003487f, 0.02651264f, -0.01646583f, -0.07115878f, 
    -0.02726197f, -0.03728254f, -0.08047460f, 0.00215248f, -0.00293514f, -0.04527764f, -0.02684364f, -0.06946399f, 
    -0.07512500f, -0.04413119f, 0.01536869f, 0.03138300f, 0.05611935f, -0.06125037f, -0.08025628f, -0.00993228f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.14443943f, -0.01287827f, 0.07948282f, 0.01967397f, 0.05763391f, 0.03510999f, 0.11149444f, 0.04574990f, 
    -0.01286072f, 0.05826651f, 0.06619191f, 0.12053505f, -0.00883887f, 0.06232232f, 0.15195923f, -0.01558594f, 
    0.07791270f, 0.04415985f, -0.09191160f, 0.14168243f, 0.01545894f, 0.02971418f, -0.02611952f, -0.01142294f, 
    0.04839983f, -0.07563975f, 0.00044608f, -0.00471452f, 0.13807024f, 0.09162267f, 0.02738926f, -0.03205324f, 
    0.09013774f, -0.05730225f, 0.04063777f, 0.13856757f, -0.01584580f, -0.00942970f, 0.00600947f, 0.01781470f, 
    -0.12638463f, -0.07278853f, 0.03731395f, 0.00973189f, 0.12561744f, 0.04893883f, 0.05620431f, 0.01581183f, 
    0.06001699f, -0.06731948f, 0.06001736f, 0.04675126f, 0.06251546f, -0.03338216f, -0.02956530f, -0.00404856f, 
    0.10267264f, -0.07955991f, 0.00105818f, 0.08153677f, 0.05389140f, 0.03215249f, 0.07500371f, 0.03947569f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.05203156f, -0.14861704f, 0.14715157f, 0.12923634f, 0.06772152f, 0.12938377f, -0.20445728f, 0.20823240f, 
    -0.04882164f, 0.14401905f, 0.03973267f, 0.12302619f, 0.15615104f, 0.28994551f, 0.24483722f, -0.12790085f, 
    0.05188171f, 0.16786863f, -0.14042383f, -0.08146095f, 0.02297301f, 0.15838359f, 0.28739044f, 0.29078579f, 
    0.06198975f, -0.30007437f, 0.22317627f, 0.20344163f, 0.07578593f, 0.24104966f, 0.08798346f, -0.02211976f, 
    -0.12509449f, -0.11484726f, -0.00506031f, -0.00751253f, -0.00521786f, -0.03180286f, -0.26703635f, 0.37100965f, 
    -0.14764751f, -0.08436050f, -0.05264854f, 0.09558823f, 0.00378149f, 0.06264009f, 0.10261471f, -0.10415158f, 
    -0.02285952f, -0.21874797f, -0.10703450f, -0.13749506f, 0.11061025f, 0.19117756f, -0.23704351f, -0.15539639f, 
    -0.24950077f, 0.10800128f, 0.25157541f, 0.08148452f, 0.04256074f, 0.18928345f, 0.17651211f, -0.05293562f, 
    0.14627703f, 0.07658336f, -0.08902672f, 0.23575249f, -0.02834238f, 0.01964443f, 0.05543256f, -0.01191047f, 
    0.02108626f, -0.13306895f, 0.02127252f, 0.33550292f, -0.31614357f, 0.14587256f, 0.07574874f, -0.21525943f, 
    0.15571561f, -0.05995315f, 0.14428291f, 0.29503101f, 0.14651702f, 0.14910616f, -0.19731933f, -0.11571588f, 
    0.30710059f, -0.06361444f, 0.17956211f, 0.16737242f, -0.13370244f, -0.09882943f, -0.10406995f, 0.02701078f, 
    -0.25287920f, -0.11159809f, -0.02148399f, 0.20156239f, -0.05895361f, -0.03131669f, 0.07226522f, 0.03934882f, 
    0.00606757f, 0.17237924f, -0.16642591f, 0.01950297f, 0.12038594f, 0.16588147f, 0.04717364f, 0.00847523f, 
    -0.06342785f, -0.03546146f, 0.19572750f, -0.09690780f, 0.28679457f, 0.11174206f, 0.10412800f, -0.16217841f, 
    -0.05715141f, -0.05140099f, 0.01107127f, 0.06273719f, 0.11709210f, 0.02716986f, -0.09679782f, 0.04119425f, 
    -0.00388073f, -0.05525033f, -0.03786323f, 0.06996750f, -0.08649020f, 0.01422137f, -0.01407846f, 0.07393645f, 
    0.00289157f, -0.11649595f, 0.04040375f, 0.05418936f, -0.14854333f, 0.03779496f, -0.01051330f, -0.00092991f, 
    0.06098892f, -0.04116875f, -0.09027950f, 0.03922389f, 0.07451293f, -0.07107301f, 0.06923867f, -0.03911658f, 
    -0.07218338f, 0.07892742f, 0.02054958f, -0.06037106f, -0.02165975f, 0.11439297f, 0.05293642f, 0.09315887f, 
    -0.07757988f, 0.04221808f, 0.03234346f, 0.08912499f, 0.03682742f, -0.05401079f, 0.03520020f, -0.12076561f, 
    -0.09858931f, -0.02956069f, 0.04953989f, -0.02249798f, -0.10773341f, -0.06001027f, 0.07579657f, -0.06419156f, 
    0.10183054f, 0.01521962f, 0.09482925f, -0.02462626f, -0.13898000f, -0.11210741f, 0.09227477f, -0.12865491f, 
    -0.06803728f, 0.11965008f, -0.06102085f, -0.12154074f, -0.02552971f, 0.02392938f, -0.13860834f, 0.06202380f, 
    -0.03624467f, 0.22284316f, 0.01998919f, -0.00655202f, -0.42728493f, -0.09746830f, 0.07089654f, 0.22357710f, 
    0.10998951f, 0.18564525f, 0.21193780f, 0.11822259f, -0.04897403f, 0.14907289f, 0.06123739f, 0.03942266f, 
    -0.05566332f, -0.15085134f, 0.13314855f, 0.13672382f, -0.04629672f, 0.04127545f, -0.17392799f, 0.32706735f, 
    -0.14253291f, -0.04250057f, -0.05191931f, -0.03862359f, 0.23279078f, -0.23252271f, -0.01295369f, -0.11814938f, 
    -0.14266868f, 0.01389064f, 0.00705244f, -0.10331991f, 0.04630878f, 0.04056528f, -0.28393573f, -0.06210994f, 
    -0.02703045f, 0.22779405f, -0.09927811f, 0.08721235f, 0.11424508f, -0.08760892f, 0.05062410f, 0.04869676f, 
    0.05353702f, 0.04038912f, 0.23948479f, 0.06066917f, -0.11403211f, 0.15048426f, 0.19162624f, 0.04117206f, 
    -0.02012491f, -0.05293673f, 0.03516671f, -0.14227310f, 0.01245350f, 0.05460413f, -0.15509252f, -0.10355236f, 
    0.29145971f, -0.10696321f, 0.25719714f, -0.11260812f, 0.09454199f, 0.03841599f, 0.32197216f, 0.02708798f, 
    -0.12582050f, 0.15468706f, 0.11823719f, -0.02135761f, -0.07511872f, 0.39680901f, 0.14970367f, 0.08233222f, 
    0.17528090f, 0.28227618f, 0.07319464f, -0.01263081f, -0.23125336f, 0.06366926f, -0.04493273f, -0.00926352f, 
    -0.13619955f, 0.23030739f, -0.24648906f, -0.04144745f, 0.18558855f, 0.09736910f, -0.10332290f, 0.01492592f, 
    0.23003253f, 0.05191131f, 0.01423122f, 0.06512471f, 0.03449983f, 0.10173056f, -0.23494951f, 0.00565315f, 
    0.08488175f, 0.13651891f, 0.01571531f, -0.02228271f, -0.21173839f, 0.03686282f, 0.01899660f, -0.02673865f, 
    -0.08253920f, -0.07958996f, -0.08994037f, -0.14175831f, -0.06776802f, -0.17043376f, 0.09217855f, 0.37740934f, 
    0.05056915f, 0.01563426f, 0.02285168f, -0.05909304f, -0.04288814f, 0.23616715f, -0.06164423f, 0.04745958f, 
    0.07889500f, -0.00327028f, 0.05417651f, -0.09966051f, 0.19251673f, -0.12969755f, 0.23710486f, -0.03175595f, 
    -0.03612582f, -0.28206462f, -0.07190032f, 0.07588045f, -0.21696435f, -0.13584751f, 0.02761969f, -0.04983151f, 
    0.25663987f, 0.05851469f, 0.14684066f, 0.14646198f, 0.31075263f, -0.07638982f, -0.27187857f, -0.29358023f, 
    0.04609685f, -0.19302936f, -0.05253665f, -0.04363137f, -0.01116895f, 0.02679229f, -0.08884059f, -0.08445687f, 
    0.16577341f, 0.10701023f, 0.11115027f, 0.37632015f, 0.02542753f, -0.07266012f, 0.37631848f, -0.08010204f, 
    -0.06539684f, -0.05695273f, -0.06087863f, 0.06241864f, -0.06474873f, 0.10836610f, 0.11045704f, 0.06756653f, 
    -0.06898861f, 0.23497987f, -0.16527788f, 0.02314766f, -0.12099167f, 0.11082416f, 0.06389617f, 0.11309643f, 
    0.29109386f, -0.08516785f, -0.16686994f, 0.24591777f, -0.05218623f, 0.06529742f, 0.14139864f, -0.01324793f, 
    0.19886722f, 0.05230688f, 0.11633804f, 0.02216006f, -0.01091985f, -0.12207695f, 0.16781493f, 0.34610397f, 
    -0.03091529f, 0.23854566f, 0.15395547f, 0.07947893f, -0.01991037f, 0.30781418f, 0.22779542f, -0.21456198f, 
    -0.15213497f, 0.05508783f, -0.11745348f, 0.14956798f, -0.05391506f, 0.06448185f, -0.08175302f, 0.18505442f, 
    -0.31429359f, -0.23907810f, 0.07541553f, -0.10512430f, 0.34663424f, 0.19743295f, 0.07918735f, -0.09423132f, 
    0.05499141f, 0.05725574f, 0.03170846f, 0.37058023f, -0.27957609f, 0.01656511f, -0.34425572f, 0.24284479f, 
    -0.24988340f, -0.05740084f, -0.15869109f, -0.04250909f, -0.12068523f, 0.03667039f, 0.08063740f, 0.11589070f, 
    -0.09354313f, -0.23554327f, 0.27678111f, 0.18491647f, 0.00158683f, 0.27180842f, 0.19217454f, 0.03720633f, 
    0.23501091f, -0.10124370f, -0.12525511f, -0.03893125f, -0.00454281f, 0.02746346f, 0.11116702f, -0.01829821f, 
    -0.14510964f, 0.30727717f, 0.22984789f, 0.19490004f, -0.44353944f, 0.00984074f, -0.05243971f, 0.12483744f, 
    -0.00987415f, -0.07237175f, 0.17385288f, 0.20911369f, -0.19374408f, 0.07789522f, -0.06092029f, 0.17978768f, 
    -0.03736164f, 0.13384806f, 0.30746439f, 0.10393465f, 0.02318208f, 0.09355743f, -0.24347399f, 0.30490717f, 
    -0.19570470f, -0.20154773f, 0.06940327f, 0.39610302f, 0.14165084f, -0.18170069f, -0.12099306f, 0.10858791f, 
    -0.21848048f, 0.11071564f, -0.09394263f, -0.16119446f, -0.22367544f, 0.07263082f, -0.03345072f, 0.03853539f, 
    0.12616166f, 0.29366237f, -0.14372110f, -0.09400452f, -0.05359149f, 0.21269986f, 0.07234395f, -0.01655427f, 
    -0.00577388f, 0.12137301f, 0.18540658f, 0.00584879f, -0.12379626f, 0.14914402f, 0.16982748f, 0.22066799f, 
    0.02205100f, -0.12035705f, 0.25376785f, -0.15016708f, 0.06004646f, 0.07503406f, 0.02813695f, 0.08930224f, 
    0.00632364f, -0.04196022f, 0.09661084f, 0.00072359f, -0.07017953f, 0.03982982f, 0.03337330f, -0.07266010f, 
    -0.02447468f, -0.13892084f, -0.02964676f, 0.09561228f, 0.04065299f, -0.13979222f, 0.06910841f, -0.13425176f, 
    -0.04176781f, 0.06797601f, 0.04887320f, 0.07151043f, 0.03205230f, -0.07324556f, 0.05647076f, -0.13998060f, 
    0.03020558f, -0.15220334f, 0.03151816f, -0.13169284f, -0.11223022f, -0.03524750f, -0.07082059f, 0.09061243f, 
    -0.04147818f, -0.01529068f, 0.00093859f, -0.09173013f, -0.02144501f, -0.06677854f, -0.03074905f, -0.06006128f, 
    -0.15326557f, -0.01074242f, -0.09418423f, 0.07787217f, 0.06160713f, -0.11128182f, -0.03382481f, 0.00589113f, 
    0.06476890f, 0.07396565f, 0.07125862f, -0.06188176f, 0.08610649f, -0.12060051f, -0.01796421f, -0.03330755f, 
    -0.00141333f, -0.05846750f, -0.13741951f, -0.09018491f, 0.12568849f, -0.11141466f, 0.02034121f, 0.03819904f, 
    0.28709021f, 0.14574605f, -0.32237026f, 0.15312912f, 0.22859985f, -0.05296042f, 0.21562892f, 0.05471773f, 
    -0.06739409f, 0.30615893f, 0.22243814f, -0.07116683f, -0.24451520f, 0.35121235f, -0.18256475f, 0.01355346f, 
    -0.05608130f, -0.30911434f, -0.31489125f, -0.04170461f, -0.35866237f, -0.15748352f, -0.01910471f, -0.08655901f, 
    0.41864860f, 0.23368074f, 0.08912560f, 0.28331813f, 0.04017069f, -0.04064030f, 0.12108280f, -0.07228241f, 
    0.14884217f, -0.05201861f, -0.07570031f, -0.12543388f, -0.01284781f, 0.05941227f, 0.12517123f, -0.00206579f, 
    0.29222527f, -0.32476923f, 0.03515368f, -0.06285773f, -0.01346446f, -0.14959170f, 0.10781501f, 0.05710228f, 
    -0.08132934f, -0.22132140f, 0.24472982f, -0.20389427f, 0.34160209f, -0.19410411f, 0.03307101f, -0.21091203f, 
    -0.07550216f, 0.00486483f, -0.25273767f, -0.19582459f, -0.05228063f, 0.19417012f, 0.22827752f, 0.08766186f, 
    0.05190234f, -0.09015357f, -0.12964660f, -0.11454674f, 0.03992786f, -0.13212150f, -0.09217317f, 0.01563325f, 
    -0.06362901f, -0.10118619f, -0.01324460f, -0.10209685f, 0.00933300f, -0.05086135f, -0.10162535f, -0.10763073f, 
    -0.08666724f, 0.06354675f, -0.06355668f, -0.04825304f, 0.01089273f, -0.13833714f, -0.00469893f, -0.11609775f, 
    0.08002768f, -0.12620883f, -0.02964420f, 0.05103812f, 0.09887257f, 0.09289180f, -0.04330539f, -0.11123218f, 
    -0.11014630f, 0.03496918f, 0.10103944f, 0.11368636f, -0.04812244f, -0.00323612f, 0.03165945f, 0.08114282f, 
    0.00472421f, 0.08892880f, -0.04432023f, -0.07896727f, 0.07932612f, -0.03611804f, -0.03990347f, 0.07390845f, 
    0.00932525f, 0.08347690f, 0.08803144f, -0.00838365f, -0.04793117f, -0.01887886f, 0.00481489f, 0.12072699f, 
    -0.07358065f, 0.00977752f, 0.11211930f, 0.00471884f, 0.09439392f, -0.00828661f, -0.00869152f, 0.03444951f, 
    -0.05546761f, 0.09036668f, -0.06127091f, 0.09305476f, -0.11930812f, 0.02165959f, 0.04462249f, 0.04472393f, 
    0.02195539f, 0.00388631f, -0.11236046f, 0.03080639f, -0.08526911f, 0.06798496f, 0.09403843f, 0.01465950f, 
    -0.05926606f, -0.12153869f, 0.00024178f, 0.00510210f, -0.04993368f, -0.12022135f, -0.08371737f, -0.11658823f, 
    0.07791698f, -0.03385146f, -0.11388353f, -0.07073653f, 0.00959389f, 0.08370448f, 0.10820755f, 0.05107769f, 
    0.04779591f, -0.08559298f, 0.00760812f, 0.05461676f, 0.01943639f, -0.07548480f, 0.10439296f, 0.10832509f, 
    0.04612061f, -0.09732084f, -0.07558640f, 0.12348594f, -0.07441264f, 0.02153984f, -0.01196256f, 0.05735287f, 
    -0.04995788f, -0.06448995f, 0.00289458f, 0.10151694f, 0.01299699f, -0.08413853f, 0.06866147f, -0.12805250f, 
    -0.05455647f, -0.01872571f, 0.02832585f, -0.09026799f, 0.02626883f, -0.12415576f, -0.06870051f, 0.03726870f, 
    -0.13961489f, 0.06176398f, -0.10781723f, 0.10594512f, 0.33837622f, -0.03341324f, -0.00856296f, 0.01947472f, 
    -0.06720979f, 0.14315808f, 0.28664303f, 0.26924527f, 0.07168092f, 0.15111148f, 0.01798370f, -0.03477921f, 
    0.19308540f, -0.02008283f, 0.04192244f, 0.26019421f, 0.04641430f, 0.26428992f, 0.02835089f, 0.17367563f, 
    0.20673299f, -0.08301196f, 0.16904107f, 0.00795738f, -0.05171828f, -0.11447595f, 0.04258182f, -0.10832379f, 
    -0.05923548f, -0.02097993f, 0.06420562f, 0.02138123f, 0.07678135f, -0.00059411f, 0.10236778f, 0.21464841f, 
    -0.07802854f, -0.23590949f, -0.03635639f, -0.00570505f, 0.36142337f, 0.13775335f, -0.08431956f, 0.06429351f, 
    -0.04499773f, -0.33350956f, 0.25368914f, 0.24531509f, 0.27220738f, -0.12435271f, 0.09128756f, -0.34037229f, 
    -0.18054351f, -0.04172123f, 0.03084344f, -0.08020701f, -0.05204977f, -0.09491315f, -0.09522327f, 0.06007097f, 
    0.16367374f, 0.09639122f, -0.05614856f, -0.20294389f, 0.20160420f, -0.01008417f, 0.26110214f, 0.23148596f, 
    -0.11805561f, 0.13611929f, 0.27849731f, 0.00021996f, -0.23923236f, 0.11848468f, -0.14137228f, -0.28795829f, 
    0.06318656f, -0.08834743f, -0.04041439f, 0.09111603f, -0.01138555f, 0.04958268f, -0.23579757f, -0.10799089f, 
    -0.20510112f, -0.34551430f, 0.20030510f, 0.10098048f, 0.27410886f, 0.27918673f, 0.04067131f, 0.04517318f, 
    0.09310965f, 0.05171045f, -0.03049615f, 0.21299586f, -0.26062477f, -0.10754653f, -0.12986517f, 0.26276267f, 
    -0.08507237f, -0.12419484f, 0.01015708f, 0.10096263f, -0.01308212f, 0.08950109f, -0.00082264f, -0.12139482f, 
    -0.00398138f, -0.19483355f, 0.32411361f, 0.01961628f, 0.31517401f, 0.09678788f, 0.26005167f, -0.08127295f, 
    0.10132761f, 0.04140941f, -0.03297596f, -0.07964486f, -0.11231463f, -0.14051192f, 0.23859864f, 0.01709925f, 
    -0.06276052f, -0.09245395f, 0.11784808f, -0.14082870f, 0.21814661f, -0.08391801f, 0.08769576f, 0.13110009f, 
    -0.08105555f, -0.16968237f, 0.02143708f, -0.26694700f, -0.01833290f, 0.10790023f, 0.14211707f, -0.00436164f, 
    0.17035252f, -0.08287551f, 0.11209182f, -0.08042284f, 0.03361205f, -0.23695505f, 0.15781707f, 0.05647731f, 
    -0.15909263f, -0.32873219f, -0.02017710f, 0.00108189f, 0.10195494f, 0.22185183f, 0.00063592f, 0.05826917f, 
    0.13809407f, -0.02295999f, 0.08500285f, 0.03558370f, 0.31528059f, -0.05044222f, 0.18151245f, 0.02459176f, 
    0.11269441f, -0.25420031f, -0.01657660f, 0.06997535f, -0.05335800f, -0.05834783f, -0.12525560f, 0.10955530f, 
    -0.03459175f, -0.08542085f, -0.08922143f, -0.14165105f, -0.04727220f, 0.12956224f, -0.07462717f, 0.06218592f, 
    -0.12660667f, 0.06786437f, -0.08898231f, -0.01690494f, 0.00953266f, 0.01999485f, 0.16229741f, -0.08593846f, 
    0.11720654f, -0.07925583f, 0.08854545f, 0.16607231f, -0.34830239f, -0.12084384f, 0.18871002f, 0.15623012f, 
    -0.02061909f, 0.01493282f, -0.28432092f, 0.05776272f, 0.08591398f, 0.08288835f, -0.00159494f, -0.13903803f, 
    -0.03106476f, 0.11523249f, -0.06833700f, 0.13923618f, -0.03189667f, 0.19829546f, -0.02069522f, -0.00102746f, 
    -0.05748128f, 0.09052376f, 0.11363003f, -0.17930336f, 0.14897627f, 0.00470244f, 0.03322362f, 0.09554556f, 
    -0.16112165f, 0.08552073f, 0.09238207f, -0.15380652f, -0.11424101f, -0.05201473f, -0.30980834f, 0.02586438f, 
    -0.01763324f, 0.21037108f, 0.17100777f, 0.01539441f, -0.04331552f, 0.02795560f, -0.05676211f, 0.02611088f, 
    0.11045660f, 0.18848263f, -0.01324352f, -0.00456965f, 0.10117848f, -0.25675172f, 0.16013700f, 0.26011655f, 
    0.10610776f, -0.06108274f, 0.14493428f, -0.03736663f, -0.04746329f, 0.21546564f, 0.16096182f, -0.04341054f, 
    0.07379512f, -0.34055969f, 0.11344510f, -0.10386676f, -0.22122848f, 0.05551393f, 0.13196434f, 0.06480015f, 
    0.11481846f, -0.18053457f, 0.06151779f, -0.06205136f, -0.24390943f, 0.18604207f, 0.00607801f, 0.11840962f, 
    0.30742222f, 0.16282213f, 0.10271330f, -0.08153938f, -0.06404891f, 0.10149880f, 0.08273543f, 0.04488966f, 
    -0.07113563f, -0.00585087f, -0.21747953f, 0.09227748f, 0.28157353f, 0.19785990f, 0.08541118f, -0.06850674f, 
    -0.07871795f, -0.01710472f, -0.04865700f, -0.07165850f, 0.16828427f, -0.07527966f, 0.01916425f, 0.18036136f, 
    0.33553141f, -0.01843614f, -0.03627973f, -0.01557730f, -0.31892106f, 0.24751835f, 0.04654751f, 0.07671119f, 
    0.11299796f, -0.08985683f, -0.11961793f, -0.10135973f, 0.02005351f, -0.10232548f, 0.14838922f, 0.16983731f, 
    -0.08212677f, -0.11029590f, 0.12241061f, -0.08009048f, -0.02529516f, 0.24599540f, 0.19208370f, -0.00848054f, 
    0.07607474f, -0.11496156f, -0.06218600f, -0.01213176f, 0.10822099f, -0.08508868f, 0.00171558f, -0.09974893f, 
    -0.08340196f, -0.10095563f, -0.09363076f, 0.10604311f, -0.05941422f, -0.09336796f, 0.04901882f, 0.04477562f, 
    0.03592611f, -0.07638724f, -0.02970642f, -0.11197635f, -0.11012816f, 0.08836482f, 0.07797668f, 0.06303947f, 
    -0.03448987f, -0.03726538f, -0.08833994f, -0.02152391f, 0.01766668f, -0.01986065f, -0.01637968f, -0.02867512f, 
    0.10515929f, 0.11305839f, -0.04939604f, -0.07900474f, -0.01763056f, 0.04033689f, 0.01372977f, -0.09952054f, 
    -0.05624039f, 0.07687686f, -0.10065859f, -0.00279742f, -0.04475481f, -0.05010802f, 0.02277960f, -0.00301011f, 
    0.12034073f, -0.07207789f, 0.09761349f, -0.09679565f, -0.08030498f, 0.10796435f, -0.01421167f, -0.12132518f, 
    -0.07159241f, -0.06280807f, 0.05798555f, -0.12048327f, -0.04712017f, -0.02921773f, 0.08879422f, -0.09754618f, 
    0.18999329f, 0.00177013f, -0.00588756f, 0.26738840f, -0.26298022f, 0.08951404f, -0.14008555f, -0.09492693f, 
    -0.05037022f, 0.23790468f, -0.35060200f, 0.19978204f, -0.03915461f, 0.01916324f, 0.28578800f, -0.18152052f, 
    -0.13415810f, 0.12866403f, -0.12507373f, 0.01745880f, 0.17815685f, 0.16536961f, 0.05245718f, -0.13539454f, 
    0.56204528f, 0.38973343f, 0.06187654f, -0.00994491f, -0.12114463f, -0.14254536f, 0.00510622f, -0.06152383f, 
    -0.06440480f, -0.11632545f, -0.06667752f, 0.03327474f, -0.13408342f, 0.12595716f, -0.12808178f, -0.12916982f, 
    -0.09455945f, 0.25435808f, 0.00670150f, -0.10481849f, 0.02366008f, 0.08771624f, 0.09794401f, -0.08466174f, 
    0.08486637f, 0.30043936f, -0.31479603f, -0.05017217f, 0.16966429f, -0.12532142f, -0.14513622f, 0.15057585f, 
    0.05186575f, 0.04219402f, 0.26066431f, 0.04585529f, -0.02923247f, 0.21192686f, 0.08465353f, -0.02535210f, 
    0.08610591f, -0.04435347f, 0.07727400f, -0.05289015f, -0.17464133f, 0.04464591f, 0.14127809f, 0.00192533f, 
    -0.00134018f, 0.28265351f, -0.20851821f, -0.00037946f, 0.24898683f, 0.00202288f, 0.25865656f, 0.07362285f, 
    -0.03325967f, 0.03745257f, -0.24824500f, -0.03050209f, 0.04843859f, -0.09468804f, 0.17264278f, -0.00445385f, 
    0.30603817f, 0.28644440f, 0.19144668f, -0.19287500f, -0.01179413f, 0.28692031f, 0.02569653f, -0.01613808f, 
    0.12098544f, 0.05888335f, 0.01036965f, 0.18984522f, 0.28203097f, -0.04728695f, -0.13848577f, 0.11846881f, 
    -0.21224546f, -0.13353987f, 0.25202274f, 0.08587261f, -0.03559960f, 0.04961228f, -0.09857544f, 0.10251048f, 
    -0.04016369f, -0.00381023f, -0.21490411f, -0.04968704f, -0.06275792f, -0.00408689f, -0.18919969f, 0.12304983f, 
    0.09344893f, 0.01507442f, -0.11485072f, 0.03874866f, 0.09209176f, 0.09653293f, 0.09176756f, -0.10291380f, 
    -0.06986991f, -0.17479749f, 0.20379236f, 0.19920631f, 0.33475998f, 0.05047599f, 0.29528543f, 0.03465914f, 
    0.07726935f, -0.09306858f, 0.11990539f, 0.05986945f, -0.06141601f, 0.21058974f, 0.18968119f, 0.06645649f, 
    0.32698932f, -0.09978503f, 0.14866465f, 0.15196843f, -0.14058964f, -0.18809871f, 0.37086090f, -0.06795572f, 
    0.14318833f, -0.12433494f, -0.21316482f, -0.06266179f, 0.10486206f, 0.11986630f, -0.09017354f, -0.01091350f, 
    0.22479929f, -0.11378266f, -0.03077411f, 0.07174440f, -0.05171332f, -0.02540241f, -0.13377656f, -0.00142054f, 
    0.14077117f, -0.27280888f, 0.05523641f, 0.09959485f, 0.10553795f, 0.03297974f, 0.01633345f, -0.01207744f, 
    0.03148702f, -0.00237848f, 0.02173644f, 0.18338335f, -0.08021206f, -0.26140392f, 0.11182034f, 0.09813631f, 
    0.06453867f, -0.07182816f, 0.13876076f, 0.01964473f, 0.08082261f, 0.11895370f, 0.24527723f, -0.04435281f, 
    0.12085238f, 0.05046336f, -0.21487334f, 0.24657290f, 0.06639138f, -0.09771402f, -0.18519774f, -0.02425709f, 
    0.01537626f, 0.34692740f, -0.12165205f, -0.07644124f, 0.01368182f, 0.16810769f, -0.00157750f, -0.09450262f, 
    -0.20329864f, -0.07778208f, -0.19748677f, -0.16048650f, 0.00420155f, 0.26314256f, 0.18288535f, 0.19068968f, 
    0.42710474f, 0.27851859f, 0.41299194f, 0.31880561f, -0.13093181f, 0.09751555f, 0.09215884f, 0.06488079f, 
    -0.16999513f, -0.05955522f, -0.13148883f, -0.24560268f, 0.16336699f, 0.06586903f, -0.05568532f, 0.15479937f, 
    0.19961210f, 0.07391483f, 0.14870836f, 0.03978161f, 0.24142614f, -0.11903657f, -0.08360523f, 0.06302221f, 
    0.08002442f, -0.08023141f, 0.03509338f, -0.05063464f, 0.35248986f, -0.01414359f, -0.09976191f, -0.13329867f, 
    -0.05941684f, -0.06569678f, 0.24807447f, -0.16571055f, 0.10446013f, 0.22401105f, 0.14949028f, 0.08486559f, 
    -0.16360103f, -0.31322983f, 0.15776019f, 0.04244003f, 0.16258653f, -0.06127633f, -0.15973696f, -0.30155054f, 
    -0.08488971f, -0.33031642f, 0.02358557f, -0.04262597f, -0.10321087f, 0.06020346f, 0.01794814f, 0.19682789f, 
    0.22078773f, 0.16359803f, 0.40310314f, -0.03340599f, 0.23230071f, -0.21646357f, 0.17242360f, 0.09061576f, 
    0.16486323f, -0.29582316f, -0.22987770f, 0.25745350f, 0.01064675f, 0.04272849f, 0.06461829f, -0.09538596f, 
    0.05180319f, -0.07577412f, 0.03057976f, -0.04116248f, 0.05316940f, 0.09669020f, 0.30496743f, 0.07379689f, 
    0.31080401f, -0.23147717f, 0.10550995f, 0.06946337f, 0.06204230f, 0.20867957f, -0.03149593f, -0.03982982f, 
    0.10898407f, 0.00418452f, -0.10658430f, 0.08424787f, -0.08035724f, 0.04727842f, -0.00085658f, 0.04465289f, 
    0.02228699f, -0.02124283f, 0.19156580f, 0.22019017f, 0.05068036f, -0.01852531f, 0.15492287f, -0.11305063f, 
    -0.00228447f, 0.07096953f, -0.26861128f, -0.08083732f, 0.23507720f, -0.06409445f, -0.17793521f, 0.10317517f, 
    -0.05859452f, 0.13623525f, 0.19611219f, -0.10341995f, 0.11206785f, -0.31018505f, 0.04745111f, -0.15339071f, 
    0.08573963f, -0.05092350f, 0.02409972f, -0.00013090f, 0.32025716f, 0.13218619f, -0.28707656f, -0.07234844f, 
    0.04616643f, 0.06782358f, 0.42659038f, -0.03798128f, -0.28222847f, 0.00536980f, 0.12133499f, 0.06229080f, 
    -0.18208610f, -0.05597404f, 0.00871525f, 0.18918672f, 0.38330111f, -0.07543205f, 0.51262200f, -0.34861207f, 
    -0.18206765f, 0.27283615f, 0.10180822f, 0.11784360f, 0.22075275f, 0.19913019f, 0.10732364f, 0.02192364f, 
    0.11037065f, 0.09513913f, 0.17573275f, -0.14903244f, 0.33314961f, 0.23119754f, -0.02020632f, -0.34354350f, 
    0.15090787f, -0.10593775f, -0.11303640f, 0.01619054f, -0.07894168f, -0.09249660f, -0.27620211f, -0.03633199f, 
    -0.17695744f, 0.23167419f, 0.24527015f, 0.00808829f, -0.17202982f, 0.04218270f, -0.11281915f, 0.00245738f, 
    0.06322785f, -0.02301227f, 0.03991258f, 0.01386891f, 0.48263955f, -0.15481067f, -0.21280935f, 0.23485130f, 
    -0.19533509f, 0.01014635f, 0.22959334f, 0.14385670f, -0.12156090f, 0.23288961f, 0.07244170f, 0.30131423f, 
    -0.12744705f, -0.02308962f, 0.06671614f, -0.00122227f, -0.05158977f, 0.10517952f, -0.03289760f, 0.04076785f, 
    0.14296339f, 0.10117307f, -0.02410396f, -0.14302236f, -0.01967149f, -0.08726245f, -0.19761385f, 0.23449330f, 
    -0.03714818f, 0.01233580f, -0.14032520f, -0.03110713f, 0.15280281f, 0.08777356f, -0.09575913f, 0.06006860f, 
    0.00490957f, -0.03572190f, 0.24780041f, 0.26308849f, 0.08503747f, 0.10411408f, 0.01003091f, 0.06337548f, 
    0.16563280f, 0.08898587f, 0.14108084f, 0.04557840f, 0.05033833f, -0.05633337f, 0.01815261f, 0.06040897f, 
    -0.09463380f, -0.12657000f, 0.05516905f, 0.06938568f, 0.07485715f, -0.07902503f, -0.10453605f, -0.11883202f, 
    -0.07893504f, -0.16817829f, -0.12993851f, 0.06825223f, 0.28201717f, -0.20937069f, -0.02044782f, 0.25836372f, 
    -0.00975510f, -0.08210343f, 0.26160386f, -0.02920184f, 0.01146552f, -0.19627288f, 0.27029970f, -0.18683085f, 
    0.17622098f, 0.15492921f, -0.05056058f, -0.03555284f, -0.00391985f, 0.02607953f, -0.04225386f, 0.00675029f, 
    0.14549512f, -0.10048878f, 0.07884371f, -0.08509549f, 0.06360606f, 0.07150213f, 0.13563009f, -0.14177711f, 
    0.02797011f, -0.07001676f, 0.21648069f, 0.08812402f, 0.21364626f, -0.04325997f, 0.01808865f, -0.06016988f, 
    0.11774644f, 0.35489535f, 0.08126543f, 0.24477743f, -0.14253382f, -0.17018555f, 0.02351303f, 0.04188730f, 
    0.25837457f, -0.01644251f, 0.18939815f, 0.31802160f, 0.09809834f, 0.10711658f, 0.16265732f, 0.11758348f, 
    -0.06661034f, -0.04139446f, 0.19003010f, 0.11617795f, 0.19846587f, 0.08983970f, 0.12838888f, 0.04400364f, 
    0.02665299f, -0.05624143f, -0.12709181f, 0.39787018f, -0.19074914f, 0.15043603f, 0.22629917f, -0.29674610f, 
    0.12877329f, 0.09441018f, 0.03852138f, 0.12277635f, 0.07195111f, 0.02735250f, 0.04805340f, -0.26100022f, 
    0.29795519f, -0.23893777f, -0.14047615f, 0.12555709f, 0.09783814f, -0.06809063f, -0.11903413f, -0.09886383f, 
    -0.07060611f, 0.03225683f, -0.12586577f, 0.36346468f, -0.39757809f, -0.11213822f, -0.14612398f, 0.11260565f, 
    -0.16865182f, -0.14611343f, -0.14584611f, -0.05457332f, 0.12939046f, 0.05184303f, 0.00411591f, -0.10863663f, 
    0.09184112f, 0.01086929f, -0.09755330f, 0.00374726f, 0.08955044f, -0.06296801f, -0.08847939f, -0.17760876f, 
    0.06256595f, -0.11450487f, -0.00332816f, 0.09247200f, 0.07070137f, 0.08397648f, 0.30051643f, 0.07507737f, 
    -0.02217548f, 0.02279746f, 0.09739577f, -0.04523696f, -0.09852947f, 0.08819613f, -0.05076155f, -0.07513393f, 
    0.00324391f, -0.09687672f, 0.04598679f, -0.02000880f, 0.09947854f, -0.12278639f, -0.20738952f, 0.18208298f, 
    0.07230973f, 0.10608953f, -0.04926186f, -0.10041874f, -0.02784262f, -0.04909224f, 0.08404038f, 0.15006164f, 
    -0.10511224f, 0.06806737f, 0.00643057f, -0.07748972f, 0.11479681f, 0.04439363f, 0.07151197f, 0.06993054f, 
    0.03084226f, -0.08021189f, -0.05693959f, 0.05285386f, 0.11435205f, -0.08659254f, -0.15535457f, -0.08620351f, 
    0.04296967f, -0.18210471f, 0.01139903f, -0.02530895f, -0.00497051f, 0.02415718f, -0.07006623f, 0.07169415f, 
    -0.08940892f, 0.00996419f, -0.02468808f, 0.14050831f, 0.11683647f, -0.09753392f, 0.06127799f, -0.04201428f, 
    -0.12291699f, 0.03629893f, -0.04425262f, 0.11774755f, 0.12392585f, -0.12027965f, -0.05910211f, 0.06734359f, 
    0.05858097f, -0.02420843f, 0.07430885f, 0.23505440f, -0.04195732f, -0.04436056f, 0.07500096f, -0.04865931f, 
    -0.03776304f, 0.06241065f, -0.31315657f, 0.13880241f, 0.03548601f, -0.00940195f, 0.29272473f, -0.03976512f, 
    -0.01215051f, -0.04940023f, -0.08533724f, -0.16820537f, 0.10371842f, -0.11858571f, 0.18769878f, -0.01515141f, 
    0.20949206f, 0.14418030f, -0.07855657f, -0.04463208f, 0.08030205f, -0.01433536f, 0.11437845f, 0.03627745f, 
    0.07060084f, -0.02396379f, 0.08550507f, 0.14451556f, -0.13617481f, -0.09445793f, -0.01507813f, -0.04258044f, 
    0.04453176f, -0.00598153f, 0.07856365f, -0.00692594f, -0.01888905f, -0.11569059f, 0.08312125f, -0.06577244f, 
    -0.09380603f, 0.17668584f, -0.22858815f, 0.13342708f, -0.09673993f, -0.15540053f, -0.02922418f, 0.19427702f, 
    0.14289719f, -0.08136029f, 0.23733132f, 0.10093877f, -0.08440859f, 0.00039080f, 0.11848700f, 0.05423975f, 
    -0.22059567f, -0.07424892f, 0.06053061f, 0.13750014f, 0.46303293f, 0.10174382f, -0.13896433f, -0.11158041f, 
    -0.05258744f, 0.11257978f, 0.40416142f, 0.10277443f, 0.26225603f, -0.14407669f, 0.10027045f, 0.16411985f, 
    0.15501899f, -0.12290001f, 0.28403819f, 0.04738367f, 0.18624194f, 0.04990304f, 0.24163279f, 0.21564890f, 
    0.05576294f, -0.25639489f, -0.00658481f, 0.25048772f, -0.23073262f, -0.17024896f, 0.03506778f, 0.10437592f, 
    0.14306635f, -0.00992646f, -0.11628959f, 0.17833272f, 0.03378917f, 0.10319255f, 0.18478391f, 0.13869858f, 
    -0.04437057f, -0.11690250f, 0.05818544f, 0.07531631f, 0.26307529f, -0.00076516f, 0.07323329f, 0.04272209f, 
    -0.10544015f, -0.16600545f, -0.03723996f, 0.21028906f, -0.13067704f, 0.26204374f, -0.16949572f, -0.27651849f, 
    0.00491684f, -0.10679961f, 0.17710245f, 0.17352442f, -0.02518411f, -0.12591848f, -0.07606039f, 0.02206011f, 
    0.34448510f, -0.00851333f, -0.03340030f, 0.11517666f, 0.19163579f, 0.03633150f, 0.37349784f, 0.24777853f, 
    0.06091151f, 0.20446160f, -0.01023873f, 0.27354208f, -0.27876353f, 0.39273140f, 0.21791519f, -0.09796780f, 
    0.12901361f, 0.01967137f, -0.17756179f, 0.01473473f, -0.23151110f, 0.08419700f, -0.06771554f, -0.00688459f, 
    0.03852699f, 0.26724210f, -0.10300088f, -0.08392666f, 0.24193303f, -0.15308961f, -0.07925616f, 0.02183798f, 
    -0.13938417f, -0.06131883f, 0.10914233f, 0.04040291f, -0.07057942f, 0.11370968f, -0.23967505f, -0.12142784f, 
    -0.00062647f, -0.00862931f, 0.02886841f, -0.10477968f, 0.16499072f, 0.01316846f, -0.00538245f, 0.05919525f, 
    -0.04694285f, -0.12566809f, 0.35228866f, 0.21635360f, 0.19290724f, -0.39249319f, 0.13012178f, 0.23571914f, 
    0.09448716f, 0.06710744f, -0.05438738f, -0.17867397f, -0.10113943f, 0.22331484f, 0.18743791f, 0.00183145f, 
    0.08832391f, -0.10442290f, 0.04101374f, 0.15720953f, -0.14232026f, 0.05062894f, -0.12040548f, -0.32873872f, 
    0.06772465f, 0.05106274f, -0.40305880f, 0.11408181f, 0.07755253f, -0.10711805f, -0.07676752f, 0.08170091f, 
    0.22814049f, 0.03721539f, 0.06949315f, 0.17883128f, 0.03949212f, -0.11486373f, 0.27145833f, -0.18039645f, 
    0.25506356f, 0.30770010f, 0.08159781f, -0.19787127f, -0.18615483f, 0.24575683f, 0.02747967f, -0.03018017f, 
    -0.00430376f, 0.00992453f, 0.03193670f, 0.10363705f, -0.01072128f, 0.10452183f, 0.31234124f, -0.05195003f, 
    0.05806183f, -0.17502296f, 0.21535443f, -0.11863491f, -0.03745496f, 0.19395295f, 0.04006904f, -0.09431016f, 
    -0.09609941f, 0.13120845f, -0.29937229f, 0.16642976f, 0.08456867f, -0.22199441f, -0.10091227f, -0.04416361f, 
    0.13953348f, -0.04931390f, -0.05354830f, 0.27687824f, 0.07682350f, 0.06903391f, 0.03359570f, 0.01847828f, 
    0.23892038f, -0.20428671f, -0.07540232f, -0.07115111f, -0.16482201f, 0.11033056f, 0.07627893f, 0.15876444f, 
    0.00773767f, -0.06860084f, 0.05476655f, -0.11818831f, 0.15425035f, 0.03508825f, -0.12093993f, -0.02820133f, 
    -0.10208155f, -0.23793514f, -0.08717943f, -0.00008820f, -0.17011504f, -0.03553322f, -0.03346280f, -0.12402017f, 
    -0.11225478f, 0.25166571f, 0.13892759f, -0.12756561f, 0.20682383f, 0.38363215f, 0.12464105f, -0.00727980f, 
    0.08500944f, 0.00645202f, -0.08317329f, -0.06381748f, 0.03244472f, 0.06517643f, -0.02697491f, 0.20565198f, 
    -0.02253596f, -0.24127626f, 0.16254675f, 0.04366860f, -0.23192526f, -0.17172053f, -0.08651732f, 0.04097027f, 
    0.06353985f, -0.00652225f, 0.11599308f, 0.13028663f, 0.00792903f, 0.18625699f, 0.24673055f, 0.04794296f, 
    0.20731691f, 0.10778420f, -0.19441365f, 0.15722762f, 0.08718731f, 0.16227490f, 0.29437611f, 0.00519237f, 
    -0.05067009f, -0.28846186f, -0.01532562f, 0.17741121f, -0.07032830f, 0.06372728f, 0.20309086f, -0.06715091f, 
    0.05285366f, 0.02542638f, -0.09573343f, 0.18276988f, -0.07258632f, 0.13377227f, -0.10639291f, 0.14505787f, 
    0.13453399f, -0.05461010f, 0.17636730f, -0.14742927f, -0.11053658f, 0.03904049f, 0.20111653f, 0.03117545f, 
    0.17599528f, 0.37294385f, -0.08667836f, 0.12666844f, 0.15295681f, -0.12297507f, -0.06883556f, 0.08472840f, 
    -0.13071689f, 0.02424896f, -0.05949836f, -0.39603469f, 0.18673569f, -0.02410641f, 0.13634905f, -0.10759019f, 
    0.35661209f, -0.18665881f, 0.09157103f, -0.03308302f, 0.06906077f, 0.10314173f, 0.06713861f, 0.02094088f, 
    0.01091843f, 0.10556377f, 0.17240514f, -0.10279445f, -0.02977176f, -0.39128047f, 0.26575941f, -0.10132916f, 
    -0.08000127f, -0.08783799f, 0.19065970f, -0.07869247f, 0.11064509f, 0.18522628f, 0.23515296f, 0.05300024f, 
    -0.14284921f, -0.09331933f, 0.06187216f, -0.07430214f, -0.18473575f, -0.09052572f, -0.08612379f, 0.10144888f, 
    0.10852474f, 0.13337994f, -0.04139134f, -0.19183163f, 0.28789824f, -0.08754073f, 0.19409868f, 0.24402753f, 
    0.08583939f, 0.01487749f, -0.15773071f, 0.08216517f, -0.15432945f, 0.05002078f, 0.15320995f, 0.27661014f, 
    -0.16216141f, 0.21879379f, 0.19452794f, -0.26816925f, 0.14133045f, 0.17068261f, 0.11077315f, -0.09333409f, 
    -0.15854482f, -0.10056452f, -0.04615523f, -0.22491282f, 0.49275550f, -0.04806875f, -0.16072062f, -0.34908193f, 
    -0.10253510f, 0.23419845f, 0.04639189f, -0.02134681f, 0.04407807f, 0.08267318f, 0.07650807f, -0.00597628f, 
    -0.08039023f, -0.01721129f, 0.00408908f, 0.20607330f, -0.08365820f, -0.07017598f, -0.06045436f, 0.27303562f, 
    -0.05813836f, 0.06925443f, -0.16467349f, -0.05643421f, 0.07522880f, 0.18661448f, -0.33070934f, -0.04509080f, 
    -0.07738297f, -0.02250680f, 0.07940809f, -0.09662673f, -0.10491738f, -0.00290874f, 0.00841202f, -0.05678291f, 
    -0.07427630f, 0.11354918f, -0.09119832f, -0.08446629f, 0.05067456f, -0.07854347f, -0.13967760f, -0.03567790f, 
    -0.11649898f, 0.10401602f, -0.03069070f, -0.01017531f, 0.02461212f, -0.08278257f, -0.00066148f, -0.07167130f, 
    0.06170045f, 0.01057849f, -0.05929948f, -0.07802384f, 0.04057452f, -0.08272830f, -0.06201917f, 0.10901453f, 
    0.00153482f, 0.05141124f, 0.01731046f, 0.02724612f, 0.02439238f, -0.04807442f, 0.08931974f, -0.00669587f, 
    0.01124935f, -0.06607276f, 0.01904478f, 0.00209585f, -0.09243342f, -0.08768283f, -0.09357247f, -0.05000766f, 
    -0.04981084f, -0.09634688f, -0.03002919f, -0.02116741f, -0.07226561f, 0.03945564f, -0.08099431f, 0.03439559f, 
    -0.06363972f, -0.06286211f, -0.01686969f, 0.04011181f, -0.11622182f, -0.12582211f, -0.09245680f, -0.11586402f, 
    0.09928495f, 0.16332667f, -0.17385803f, 0.12554640f, 0.28707823f, -0.01650517f, -0.03824343f, 0.11864198f, 
    -0.09494176f, 0.26631916f, 0.31855232f, -0.16517240f, 0.06109630f, -0.05539109f, 0.00295287f, 0.05749542f, 
    -0.23321617f, -0.23217228f, -0.09356523f, 0.08358697f, -0.12889430f, 0.13126226f, 0.04913990f, 0.25166202f, 
    -0.06399815f, -0.02104968f, 0.24545451f, 0.19281445f, -0.05957239f, 0.02390809f, -0.06002739f, -0.12311905f, 
    0.08306195f, 0.10874839f, -0.11561958f, 0.01581061f, -0.03823182f, 0.06216503f, -0.09573721f, 0.05974678f, 
    -0.16331294f, -0.11929786f, 0.01925795f, 0.00439819f, 0.17072947f, -0.21643792f, -0.01903556f, -0.04853430f, 
    0.09941807f, 0.02250409f, 0.43308681f, 0.24313506f, 0.13611957f, 0.18991221f, 0.24490900f, -0.22410153f, 
    0.22911933f, 0.09673281f, -0.09360863f, 0.09756223f, -0.05213062f, -0.04198079f, -0.11972941f, 0.10475242f, 
    -0.05262087f, -0.01551084f, -0.12724571f, -0.10264388f, 0.03882174f, -0.00368793f, -0.13063847f, 0.00663835f, 
    -0.07679634f, 0.02580102f, -0.01047779f, -0.04102100f, -0.01896550f, -0.00851853f, 0.05542464f, -0.04934837f, 
    -0.04316200f, -0.08410988f, -0.07382014f, -0.12145463f, 0.09792984f, -0.12988821f, -0.10989189f, -0.03700511f, 
    -0.07216413f, -0.00185926f, -0.12349012f, 0.05257116f, 0.00816461f, -0.08357520f, 0.02864727f, -0.04522453f, 
    -0.09942602f, 0.00190003f, 0.05303018f, -0.04416616f, -0.03761648f, 0.03411101f, 0.06607249f, 0.00490403f, 
    0.04803539f, 0.09421933f, -0.07947797f, 0.02427183f, 0.04368346f, 0.05988948f, -0.07352030f, -0.04440637f, 
    0.09950890f, -0.14535177f, 0.09994208f, -0.05964405f, 0.01772999f, -0.10775808f, -0.13065106f, 0.04359624f, 
    -0.00654871f, 0.08635378f, 0.10192097f, 0.01075833f, -0.05168900f, -0.07329891f, -0.06444639f, -0.08283806f, 
    -0.04358678f, -0.06289766f, 0.02075482f, -0.08743277f, -0.08188487f, 0.11559210f, 0.01298123f, 0.04944928f, 
    0.03485907f, -0.01632912f, -0.06571190f, -0.05280041f, -0.01750638f, 0.03550464f, -0.11288521f, -0.14439481f, 
    0.08102493f, -0.08089995f, 0.10345960f, -0.06265240f, -0.12020727f, -0.00397213f, 0.02851165f, 0.08844582f, 
    0.06476533f, -0.13747507f, 0.00608930f, 0.04122481f, 0.09223227f, 0.08548392f, -0.03537081f, 0.02842630f, 
    0.02570159f, 0.08800451f, 0.00118028f, -0.11403641f, 0.02347052f, 0.02368851f, 0.06774730f, 0.05157374f, 
    0.04671928f, 0.12813705f, -0.11965946f, 0.09501309f, -0.09879663f, 0.00583698f, -0.03302799f, -0.09786068f, 
    -0.00734983f, 0.02924522f, -0.02352166f, -0.08489096f, -0.11939281f, -0.03580135f, 0.06753770f, -0.06904963f, 
    -0.00061240f, -0.06896137f, -0.11978829f, 0.07959964f, 0.05522454f, 0.01876661f, -0.04415453f, 0.04958366f, 
    -0.02176020f, 0.02965146f, -0.13262519f, -0.09365870f, 0.16243023f, 0.05104506f, -0.02181723f, 0.16797145f, 
    -0.03666195f, 0.16869852f, 0.02815547f, -0.17826359f, 0.10647666f, -0.05208087f, 0.05218561f, 0.11622415f, 
    -0.08900777f, 0.17578804f, -0.03966072f, -0.49534610f, -0.14790651f, -0.19249652f, -0.07265127f, 0.12089063f, 
    -0.44951439f, 0.18125418f, -0.01755959f, 0.08919841f, 0.03416486f, 0.20671502f, -0.04651797f, -0.01310222f, 
    0.22186948f, -0.03755191f, -0.11123332f, -0.02934510f, 0.09148207f, -0.11813214f, -0.15387106f, 0.12291549f, 
    0.28383800f, 0.04407573f, 0.30277336f, 0.07051698f, -0.12269903f, -0.27801242f, -0.00012872f, 0.05697643f, 
    -0.06423780f, -0.06374567f, -0.04551214f, -0.06353924f, -0.15566532f, -0.02532918f, 0.01505441f, 0.31349450f, 
    -0.07383089f, 0.07657945f, -0.12264072f, -0.07146473f, -0.11974664f, 0.05578946f, 0.22753605f, -0.08182494f, 
    0.19382718f, 0.09348016f, -0.08113955f, -0.00432883f, -0.29484949f, 0.12086828f, -0.01701392f, 0.24307135f, 
    -0.08144095f, -0.01214407f, 0.10364575f, 0.07474573f, -0.13226089f, -0.14824110f, 0.23555446f, -0.03652977f, 
    -0.12320547f, -0.05695513f, -0.12399515f, 0.10465452f, 0.16266809f, 0.07691350f, -0.27755454f, 0.09069119f, 
    -0.22067393f, -0.08194633f, 0.04261846f, 0.00140815f, 0.16292368f, -0.08452309f, 0.00234146f, -0.02549939f, 
    0.10170367f, -0.02035424f, 0.02923143f, 0.25831798f, -0.28110909f, 0.03081629f, -0.26610717f, 0.08009566f, 
    -0.09316438f, 0.36443138f, -0.04848065f, 0.10664219f, -0.12812254f, 0.16263229f, 0.03985158f, -0.06640554f, 
    -0.09504103f, 0.20326635f, -0.04214223f, 0.03151366f, 0.03536845f, 0.18290681f, -0.12231552f, 0.10329721f, 
    0.24479641f, 0.05689052f, 0.04924525f, -0.07934692f, -0.11165179f, 0.09616963f, -0.09174784f, -0.05172671f, 
    0.05081374f, 0.06682759f, 0.25911623f, 0.08883204f, -0.29114830f, -0.10011554f, -0.17842688f, 0.07847207f, 
    -0.09992954f, -0.02126671f, -0.14000075f, -0.00997757f, 0.09776193f, -0.14887114f, 0.14124671f, 0.22355379f, 
    0.07281960f, 0.21944742f, 0.14487877f, 0.00480427f, 0.20510988f, 0.01796760f, -0.06426670f, 0.27891636f, 
    -0.18264015f, 0.06308155f, -0.08174028f, 0.07540477f, -0.10969554f, 0.05144216f, 0.11446143f, 0.10645307f, 
    0.14835638f, -0.10276420f, -0.04631026f, 0.07514077f, 0.37903541f, 0.09521338f, 0.19787896f, -0.18992528f, 
    -0.04290212f, 0.32033730f, 0.15599668f, -0.01955922f, -0.06992730f, 0.12331255f, 0.07510017f, 0.05832242f, 
    -0.01999047f, 0.27184764f, -0.31907716f, 0.09816396f, -0.08037055f, -0.11575446f, -0.05244641f, 0.33199871f, 
    -0.04667010f, -0.04378932f, 0.04189481f, 0.21803348f, -0.10106123f, 0.19817944f, -0.31427410f, 0.07322821f, 
    0.03417009f, 0.09605040f, -0.11817900f, -0.09642407f, 0.04485944f, -0.04458296f, 0.12185460f, 0.24922910f, 
    -0.09482228f, -0.14567317f, 0.19790240f, -0.13375680f, -0.03703220f, -0.08410788f, -0.08891331f, 0.15220615f, 
    -0.11086380f, -0.09736746f, 0.17787257f, 0.17286579f, -0.16535984f, -0.07742020f, -0.08091622f, 0.22174153f, 
    -0.31216422f, 0.12276641f, -0.09663967f, 0.07323335f, 0.30514246f, 0.03887347f, 0.03376052f, 0.11333895f, 
    -0.03915973f, -0.02335393f, 0.04279614f, -0.00275828f, -0.10038747f, 0.07828546f, -0.12506954f, -0.17122158f, 
    0.17454079f, 0.20244391f, 0.06647973f, 0.08482661f, -0.11339995f, -0.05630562f, -0.00061951f, -0.01195506f, 
    -0.04128325f, 0.08543161f, 0.33077216f, 0.27766895f, -0.20610514f, -0.08801547f, 0.25487700f, 0.21130638f, 
    0.23765299f, 0.04097389f, -0.17225701f, 0.03102489f, 0.03928239f, 0.12477898f, 0.03791045f, 0.10586873f, 
    -0.10143354f, 0.45887858f, 0.02223912f, 0.04427467f, -0.27231205f, 0.06728880f, -0.16713147f, 0.15857579f, 
    0.04320716f, 0.10933512f, -0.15131855f, 0.30917120f, -0.09810945f, -0.03031199f, -0.05347103f, -0.10222000f, 
    -0.24150297f, 0.09837102f, 0.26531973f, -0.02183930f, -0.11254775f, 0.21731250f, -0.04323608f, 0.30273217f, 
    0.22070612f, 0.23763694f, 0.15899439f, 0.37509176f, -0.14644861f, -0.03869126f, -0.10191874f, -0.02418141f, 
    -0.13358022f, -0.02951070f, 0.12455710f, -0.17901711f, -0.26140907f, 0.03641577f, -0.06011264f, 0.18353830f, 
    0.25365052f, 0.36025712f, 0.02883169f, -0.10959630f, -0.00004464f, 0.23066178f, 0.01227287f, 0.00531396f, 
    -0.08642385f, 0.14341624f, 0.15981710f, 0.01739503f, 0.04483928f, 0.13587663f, 0.24586441f, 0.17243102f, 
    0.15202968f, -0.06700586f, 0.33662987f, -0.08576498f, -0.09963496f, 0.08166754f, -0.07895850f, 0.13281311f, 
    0.15369146f, -0.09979292f, 0.04187822f, 0.04000134f, -0.40509319f, -0.11375838f, -0.03972162f, 0.11677068f, 
    -0.02048992f, 0.11245219f, -0.02310329f, -0.14090417f, -0.28757563f, 0.02646293f, -0.03027409f, 0.15922812f, 
    -0.06034135f, 0.12757167f, 0.05772744f, -0.06372240f, -0.16570254f, -0.02208774f, -0.22340399f, 0.28579059f, 
    0.11371478f, 0.32866153f, 0.02889186f, 0.18489440f, 0.03355742f, 0.08247181f, 0.02150870f, 0.04594433f, 
    -0.33539245f, 0.07387159f, 0.04376179f, -0.21287635f, 0.39003661f, -0.00473926f, 0.15976697f, -0.31418422f, 
    0.22664563f, 0.17531231f, 0.10328165f, -0.04497558f, -0.18399857f, 0.17453593f, 0.05268032f, -0.08424731f, 
    -0.01412522f, 0.04855313f, 0.12180674f, -0.25865537f, 0.11433137f, -0.19565393f, 0.13899551f, 0.17780331f, 
    -0.09076153f, 0.05931549f, 0.17718667f, -0.29255062f, -0.03416266f, 0.26798937f, -0.27148569f, 0.01354353f, 
    -0.09115499f, -0.00190007f, -0.21633291f, -0.03620319f, 0.15070945f, 0.03353284f, -0.14469434f, 0.06377847f, 
    0.00005587f, 0.31756592f, 0.10108313f, -0.20105015f, 0.29322082f, -0.17383340f, -0.06043896f, -0.12454120f, 
    -0.08147483f, -0.01471964f, -0.22297022f, -0.04687029f, 0.15186691f, -0.06837612f, 0.30316892f, -0.12808961f, 
    0.04413006f, 0.07409389f, 0.40141657f, -0.08847669f, -0.00671552f, 0.35663703f, -0.10338288f, 0.09522120f, 
    0.19404636f, 0.11631344f, 0.06946693f, 0.14894079f, 0.19490594f, -0.04057030f, 0.14476436f, 0.34805745f, 
    -0.22342116f, -0.27988943f, 0.21934877f, 0.04721600f, 0.14629488f, -0.10927499f, 0.06920472f, 0.11675518f, 
    0.00660151f, -0.02276867f, 0.15785830f, 0.03950557f, 0.34493387f, 0.45917901f, -0.03465834f, -0.43769777f, 
    0.00784351f, -0.02401851f, -0.11060654f, 0.28300163f, 0.07330554f, -0.26646248f, 0.15671119f, -0.00772593f, 
    -0.14437957f, 0.19027144f, 0.18257286f, 0.22396877f, -0.24584828f, -0.04272303f, -0.14130113f, -0.17335200f, 
    0.05816993f, -0.03293821f, -0.17063771f, 0.08750199f, 0.43179566f, -0.25405779f, 0.11442999f, 0.16953868f, 
    0.15078807f, 0.07747732f, 0.24270539f, 0.19176888f, 0.17814511f, 0.18906794f, 0.23192625f, 0.21417174f, 
    0.31156287f, 0.33204228f, -0.06017978f, 0.03396577f, -0.16776250f, 0.09563500f, -0.05546649f, -0.04190091f, 
    -0.08449344f, -0.06688017f, -0.03861536f, -0.32099095f, 0.10179412f, -0.02290951f, -0.01754075f, 0.01569027f, 
    -0.07521056f, 0.22276446f, 0.01529551f, -0.04704105f, 0.13446249f, 0.08286881f, -0.03411835f, 0.00031161f, 
    0.11242848f, 0.28435472f, -0.03786253f, 0.29045707f, -0.20155202f, -0.19447853f, 0.02361996f, 0.22962004f, 
    0.01718553f, -0.06637353f, 0.34524050f, 0.03407720f, 0.05687469f, 0.02771571f, -0.05012869f, -0.01509876f, 
    0.21629302f, 0.07639267f, 0.16665690f, -0.07238561f, -0.01911588f, 0.03300750f, 0.19569626f, -0.07997463f, 
    0.05521446f, -0.11492696f, -0.20744064f, 0.13490967f, -0.17328703f, -0.18942732f, 0.08762079f, 0.07899248f, 
    0.10993443f, 0.16170670f, 0.09457967f, 0.15282071f, 0.16673765f, -0.06526816f, -0.20758927f, -0.29494414f, 
    0.02379534f, 0.06583972f, -0.20487556f, -0.10907399f, -0.08139668f, 0.05107629f, -0.08627106f, 0.06166527f, 
    -0.04630609f, 0.11338623f, 0.01993731f, 0.26710656f, -0.12655942f, 0.06707023f, 0.16341150f, -0.18050282f, 
    0.14402910f, 0.08449914f, 0.05033894f, -0.06111921f, -0.06810709f, 0.25478292f, 0.06001893f, -0.07452658f, 
    0.00284661f, 0.29540032f, -0.22658654f, -0.15142216f, -0.07967444f, 0.07009162f, -0.01823688f, 0.17205344f, 
    0.12344109f, -0.06885781f, 0.10859628f, 0.11638379f, -0.10103489f, -0.00767576f, 0.18264021f, 0.10892466f, 
    0.04750274f, 0.17730358f, 0.22523852f, 0.06696668f, -0.17881221f, -0.10129128f, -0.21344176f, 0.04721278f, 
    -0.09243746f, 0.07283261f, 0.12027284f, 0.04186418f, -0.06288718f, 0.09951318f, 0.13579017f, -0.04534493f, 
    -0.02855965f, 0.32489401f, -0.04482738f, 0.14756010f, 0.16406563f, 0.26187453f, 0.00810578f, 0.26925790f, 
    -0.01433268f, -0.03892075f, -0.15286259f, 0.20593522f, -0.21664999f, 0.06657198f, -0.04243919f, -0.10222448f, 
    0.12793703f, -0.04353715f, 0.09271774f, 0.06491260f, 0.16174880f, 0.08165284f, 0.08010660f, 0.11986040f, 
    0.03922787f, 0.11521047f, 0.01511121f, 0.01677478f, -0.13495198f, 0.24069899f, -0.11100056f, -0.04039960f, 
    0.10190312f, -0.14587374f, -0.31207719f, -0.17826441f, 0.18026848f, 0.11845362f, -0.29240635f, 0.03695159f, 
    -0.15726143f, -0.02217894f, -0.01715975f, -0.07850284f, -0.03809595f, 0.11319906f, -0.23694752f, 0.11019997f, 
    0.28177136f, -0.02966917f, -0.03738373f, -0.22351821f, -0.14323680f, -0.02431125f, 0.15323359f, 0.08217233f, 
    0.10658623f, 0.20302598f, -0.09003733f, 0.08027974f, -0.22430648f, 0.23781630f, 0.07932787f, -0.15746853f, 
    0.13254665f, 0.08557408f, -0.15460975f, -0.06879997f, 0.03212038f, 0.09749822f, -0.01585642f, 0.03867199f, 
    0.09484091f, 0.15801701f, 0.00818259f, 0.08320353f, 0.29289684f, 0.28461999f, 0.08135059f, -0.12395745f, 
    0.09976098f, 0.05313408f, 0.07389213f, 0.21147640f, 0.04729405f, 0.00451120f, -0.08599607f, 0.09494860f, 
    0.09845273f, -0.04277889f, -0.00017011f, -0.09753426f, -0.29619750f, 0.07112002f, 0.01900234f, 0.09794947f, 
    0.08421005f, -0.17807528f, -0.20321023f, -0.40104344f, 0.15254103f, -0.12341722f, -0.17249759f, 0.02660142f, 
    -0.04113344f, -0.04256510f, -0.14505364f, -0.22123525f, 0.03636926f, 0.26528642f, 0.10865608f, 0.09978414f, 
    0.12570781f, 0.29728231f, -0.12686579f, -0.07608466f, -0.06154954f, 0.08525842f, 0.18064925f, 0.33668020f, 
    0.05371989f, -0.08670484f, -0.02655490f, -0.08750867f, -0.27802688f, -0.09516262f, -0.09030002f, -0.05300618f, 
    -0.04349662f, 0.07296970f, 0.12755045f, -0.13347457f, 0.08161750f, 0.12109262f, -0.15869462f, 0.12342133f, 
    -0.45893669f, -0.08774640f, -0.06783317f, 0.30912083f, 0.21516404f, -0.03073049f, 0.07336918f, -0.05618415f, 
    -0.00889224f, 0.08498047f, -0.00750595f, 0.11687590f, -0.03867082f, -0.00970593f, 0.19437270f, -0.22491990f, 
    0.32662889f, 0.09424895f, 0.05024374f, -0.06134244f, -0.11941323f, 0.04334069f, 0.05763299f, 0.05729395f, 
    0.10786856f, 0.28016070f, 0.17607753f, -0.02671026f, 0.03095576f, 0.24137463f, 0.25145054f, 0.21643673f, 
    0.22325771f, 0.02118256f, -0.00923591f, -0.06885021f, 0.12069759f, 0.11862643f, -0.02243830f, -0.08934641f, 
    0.18801261f, -0.01606264f, -0.01933058f, 0.13130021f, 0.20302530f, -0.06678518f, 0.30132064f, 0.19610584f, 
    0.02117623f, 0.14199729f, 0.19499753f, -0.16728528f, -0.05201627f, -0.12408371f, 0.17565089f, 0.34044370f, 
    -0.09991986f, -0.26025406f, 0.08172812f, -0.11068583f, -0.07759710f, -0.19831042f, -0.00477022f, -0.00013579f, 
    -0.27670550f, 0.11239418f, -0.18307801f, -0.22265507f, 0.19782676f, -0.05233560f, -0.09592955f, 0.00951273f, 
    0.18681064f, 0.02237379f, -0.09364520f, -0.04888252f, 0.16385056f, -0.09678057f, -0.19901077f, -0.02485618f, 
    0.14358808f, -0.06612255f, 0.16617730f, 0.07924181f, 0.11316404f, -0.27744466f, -0.11780280f, -0.07049945f, 
    -0.01624997f, 0.06172537f, 0.17957525f, 0.11322206f, -0.31938156f, -0.02748942f, 0.02810752f, 0.10147302f, 
    0.32771045f, -0.10440603f, -0.20672129f, 0.12169818f, 0.02103461f, -0.02551375f, 0.19609667f, -0.13212353f, 
    -0.09497183f, 0.04054486f, 0.19141178f, 0.27757534f, -0.00043603f, -0.07552870f, -0.22596717f, -0.30992612f, 
    -0.08934049f, 0.19110683f, 0.11213268f, 0.17687552f, 0.39415491f, -0.12387456f, 0.12422226f, 0.03907909f, 
    -0.08235314f, 0.11889716f, 0.18616290f, 0.12195130f, 0.04325410f, -0.04875354f, 0.35152277f, -0.02497969f, 
    0.36066827f, 0.25883433f, 0.18895644f, -0.12830743f, -0.27791551f, 0.07618032f, -0.05515208f, 0.05279750f, 
    0.10966858f, 0.04388434f, 0.03154127f, -0.06405908f, 0.12031402f, 0.08393690f, 0.05717047f, -0.02827657f, 
    -0.17123090f, 0.09426670f, 0.03947477f, 0.09007461f, 0.25494295f, -0.06153098f, 0.08506197f, -0.07982326f, 
    -0.07503982f, 0.23034379f, -0.18638052f, 0.26518351f, -0.07007394f, 0.10633101f, -0.11366114f, -0.01567378f, 
    -0.03578368f, 0.03091851f, 0.20568202f, 0.26661205f, 0.01602776f, 0.00869527f, -0.07833961f, -0.11765566f, 
    0.25813589f, 0.08684678f, 0.09067190f, 0.14839312f, 0.15451522f, -0.00630107f, 0.33673078f, -0.03920177f, 
    0.01400317f, 0.07045972f, -0.12208502f, 0.21501419f, -0.02555957f, 0.37605169f, 0.01556862f, -0.14559692f, 
    0.18725310f, 0.05776083f, -0.08198209f, -0.05802439f, -0.29878542f, 0.12049058f, 0.14996886f, -0.12080003f, 
    0.24230561f, 0.21450618f, -0.02046859f, 0.02813452f, 0.23663238f, 0.07975180f, 0.02522331f, 0.08425991f, 
    -0.04496194f, -0.05299163f, 0.07561152f, -0.11603189f, -0.04995847f, 0.02381848f, -0.22259592f, 0.14027627f, 
    0.15706515f, -0.17666341f, -0.05061114f, -0.08394851f, 0.12119427f, -0.04648576f, 0.05297053f, 0.02164755f, 
    -0.07949916f, -0.12562133f, 0.28183126f, -0.07753003f, 0.30693230f, -0.29645622f, 0.13035433f, -0.03393695f, 
    -0.10371458f, -0.09398221f, 0.11333583f, -0.21478520f, 0.11863808f, 0.06276427f, 0.10442357f, 0.01523713f, 
    -0.03989916f, -0.24722441f, 0.02230410f, 0.02379551f, 0.00370635f, -0.09294155f, -0.15300179f, -0.33662835f, 
    0.07429530f, 0.05716221f, -0.04963676f, -0.05125889f, 0.15697807f, -0.08679088f, 0.02648983f, 0.24196897f, 
    0.17402673f, 0.13368885f, 0.25335065f, -0.01588079f, 0.16086568f, 0.04624456f, 0.24964564f, 0.07648374f, 
    0.28965637f, 0.18980277f, 0.00874441f, -0.25120124f, -0.10620207f, 0.11537340f, 0.05546356f, -0.09288285f, 
    0.10812742f, 0.09153104f, -0.01531908f, -0.10907300f, 0.28606057f, -0.09639166f, 0.24504898f, -0.25416005f, 
    -0.00378961f, 0.04508408f, 0.26914611f, -0.11919069f, 0.19364871f, 0.00313135f, 0.10901434f, 0.10692345f, 
    -0.01752320f, 0.17057826f, -0.16257605f, 0.29704991f, -0.24678637f, -0.23081282f, -0.00674273f, 0.23997886f, 
    -0.06290125f, 0.11683860f, 0.15634172f, 0.18315628f, 0.03054372f, -0.04788413f, -0.14270334f, 0.06187790f, 
    -0.07094251f, 0.04889875f, 0.11004291f, 0.07103014f, 0.45521459f, 0.03052478f, 0.01802789f, 0.01915509f, 
    -0.07451625f, -0.04421039f, 0.43793327f, 0.05200468f, 0.27083760f, 0.02854113f, 0.03990056f, -0.02519394f, 
    0.13818842f, -0.02683799f, 0.15342100f, 0.23229600f, -0.11212473f, -0.08110949f, 0.14244337f, 0.12828693f, 
    -0.33814004f, -0.49746087f, 0.11229704f, 0.02400385f, 0.30053478f, 0.14319101f, -0.11324783f, 0.08813456f, 
    0.23072928f, 0.02808157f, -0.01579660f, 0.13889472f, -0.07831401f, -0.12329191f, -0.04256571f, 0.16865966f, 
    -0.19071665f, -0.22873430f, -0.06408196f, 0.01307183f, 0.17484340f, -0.12495498f, 0.10056218f, -0.10553239f, 
    -0.04624876f, -0.28255931f, 0.39083749f, 0.13377190f, -0.08457337f, 0.35535327f, 0.22371468f, -0.05953221f, 
    0.14711869f, 0.02459059f, 0.00663924f, 0.06304505f, -0.06043595f, -0.17898419f, 0.21891914f, 0.05898038f, 
    0.35842526f, -0.15251091f, 0.01791926f, -0.07985665f, 0.29495859f, -0.06523000f, 0.18771216f, 0.23782989f, 
    0.00257436f, -0.00573426f, 0.05331822f, -0.01307539f, -0.31136337f, 0.32992071f, 0.08991419f, -0.05164678f, 
    0.06240205f, -0.08209684f, -0.36264640f, 0.08413672f, -0.05836221f, 0.06882989f, -0.19988453f, -0.27112967f, 
    0.16510054f, 0.22593737f, -0.07288409f, -0.26361385f, 0.20691292f, 0.01427782f, 0.05982347f, -0.04420145f, 
    0.02568879f, 0.09992934f, 0.03893731f, 0.36922452f, 0.04907066f, 0.11937139f, 0.00932636f, -0.13697894f, 
    -0.17038295f, -0.08951743f, 0.13387966f, -0.08113249f, -0.11969631f, 0.08150755f, 0.08653016f, -0.04611038f, 
    0.09916006f, -0.22145966f, 0.15833859f, 0.03849111f, 0.17840639f, -0.17922801f, -0.09154616f, -0.00609003f, 
    0.19339053f, 0.09357189f, -0.28460670f, 0.04534951f, -0.04015971f, 0.09170610f, 0.12269356f, 0.00477131f, 
    -0.04876012f, 0.10679943f, 0.13771191f, 0.13602185f, 0.08708646f, -0.00645835f, 0.03062027f, -0.15109517f, 
    -0.08868358f, -0.21506801f, 0.09158663f, -0.10971998f, 0.11318196f, -0.29894063f, -0.12249527f, 0.13386773f, 
    0.19061236f, -0.00111105f, 0.22135483f, 0.05382969f, 0.25218490f, 0.03781175f, 0.04005092f, -0.15278617f, 
    0.03471749f, -0.06968331f, 0.15657090f, 0.00373010f, 0.01585695f, 0.05940946f, 0.01247954f, 0.04285682f, 
    0.16054413f, -0.01491273f, -0.07308223f, 0.04790375f, 0.21755098f, -0.01282370f, 0.28642339f, -0.20314215f, 
    -0.03542855f, -0.04481370f, 0.15660410f, -0.06328341f, -0.01302061f, 0.14562696f, -0.10309348f, -0.02843754f, 
    0.01324206f, 0.12147329f, -0.06548356f, 0.06198916f, -0.02888444f, 0.17058508f, 0.12921529f, -0.13088422f, 
    0.21111749f, -0.00159058f, -0.11714210f, 0.31475309f, 0.11152946f, -0.10402221f, -0.13470981f, -0.10129650f, 
    0.07084326f, -0.17727740f, 0.03316196f, -0.08016318f, 0.26616412f, -0.02243771f, 0.11391297f, -0.09209921f, 
    0.09084284f, -0.15046087f, -0.21096399f, 0.03323165f, -0.08029439f, 0.07656310f, 0.12596506f, 0.08564460f, 
    0.10012749f, 0.21994409f, -0.07708942f, -0.14005186f, 0.00908862f, -0.20635746f, -0.01424295f, -0.30012175f, 
    0.00778815f, 0.14264570f, -0.14389612f, 0.02614383f, 0.21517068f, 0.13425072f, 0.11981925f, 0.07166148f, 
    0.24147193f, -0.05649227f, -0.07043208f, 0.17298196f, 0.24363142f, 0.01986510f, 0.35699627f, -0.15966094f, 
    0.27306202f, -0.19488373f, 0.21859585f, -0.03813412f, -0.24204008f, -0.05372910f, 0.08898720f, -0.04192540f, 
    0.11112543f, 0.24183279f, -0.30958322f, -0.20732772f, 0.07470449f, 0.10752793f, 0.10769203f, -0.00742859f, 
    0.27436531f, -0.04345949f, -0.10311716f, 0.24503632f, -0.04731397f, -0.05362730f, 0.29010150f, -0.01562518f, 
    -0.02846552f, 0.03196793f, -0.07367469f, 0.23213035f, -0.08518578f, 0.08866222f, -0.10354763f, -0.12093575f, 
    0.11861762f, -0.05638843f, 0.09953439f, 0.07736871f, -0.06869216f, -0.28820091f, 0.06719130f, 0.23027286f, 
    -0.02557780f, 0.05629544f, 0.23867276f, -0.04024870f, 0.13624248f, -0.06901553f, -0.18323918f, 0.05933316f, 
    0.20088837f, 0.20269726f, 0.03940949f, 0.12283657f, -0.34245843f, -0.29030648f, 0.11222994f, -0.03365840f, 
    0.05664601f, -0.12052170f, -0.08087314f, 0.13606273f, -0.01588465f, -0.12067828f, 0.38458204f, -0.16560285f, 
    0.13620025f, 0.14182301f, -0.04219506f, 0.01608419f, 0.11377615f, 0.07794324f, -0.11498726f, -0.07894386f, 
    0.11193575f, 0.31735280f, -0.31113809f, -0.01661503f, -0.20850427f, 0.20711872f, -0.22466588f, 0.10542540f, 
    0.12367531f, 0.03285243f, 0.14169991f, 0.13910352f, -0.10275891f, 0.09206904f, -0.05823974f, -0.08200408f, 
    -0.11069222f, -0.01356225f, 0.00556271f, -0.01736784f, -0.12155454f, 0.02592035f, -0.08648551f, -0.03076898f, 
    -0.03409144f, -0.01721810f, -0.09763813f, -0.02800184f, 0.09309043f, -0.05241875f, -0.08808239f, 0.09796683f, 
    0.03933501f, -0.11294377f, 0.01877099f, -0.08172341f, 0.06268437f, 0.07079062f, -0.08503504f, -0.09092498f, 
    0.02014589f, 0.12357917f, -0.11255671f, -0.00586778f, 0.06156412f, 0.03436196f, -0.10411271f, -0.07461385f, 
    0.01113592f, -0.04746468f, -0.10860369f, -0.00095198f, 0.09303074f, 0.05809040f, -0.05177896f, -0.10089323f, 
    -0.05382288f, -0.05592082f, -0.05192614f, 0.02213216f, -0.06751575f, 0.09767266f, 0.05619127f, -0.03121579f, 
    0.00127570f, -0.09542112f, 0.05689019f, -0.09922233f, 0.07375616f, -0.02245913f, -0.09625296f, 0.11517100f, 
    0.04708907f, -0.08442001f, -0.08755584f, -0.11101925f, 0.05081098f, -0.06839508f, -0.05224426f, -0.10198553f, 
    -0.06474862f, -0.04520714f, -0.11693433f, -0.13146706f, -0.06604348f, 0.07474120f, 0.05918247f, -0.08656447f, 
    0.01377034f, -0.13534123f, -0.01165905f, -0.11517522f, 0.04838840f, -0.10817815f, -0.06448998f, -0.04107208f, 
    0.01315645f, 0.01090697f, 0.01836581f, -0.10520785f, 0.03058616f, -0.10502215f, -0.09354182f, -0.01035065f, 
    -0.10935605f, 0.06436656f, 0.05161024f, 0.01654366f, 0.03688881f, -0.08887376f, -0.04834875f, 0.08822121f, 
    -0.04169334f, 0.12403855f, 0.07444476f, -0.00899626f, -0.00688939f, -0.07312806f, -0.12018003f, -0.07516772f, 
    -0.06792682f, 0.00379172f, -0.14334318f, 0.02856083f, 0.03724341f, -0.14558379f, -0.05789168f, -0.00151744f, 
    0.03554483f, 0.07987235f, -0.09252027f, 0.04159106f, 0.07895435f, 0.09456821f, 0.00243621f, -0.09084003f, 
    -0.05697274f, 0.09175089f, -0.09248021f, -0.03667839f, 0.04593711f, -0.04789393f, -0.03599969f, 0.01284440f, 
    0.17072710f, -0.29879710f, -0.24625966f, -0.13899191f, -0.10132786f, 0.05410766f, -0.07146978f, -0.04267075f, 
    0.09521120f, -0.33642706f, -0.25117964f, 0.00287269f, -0.28200275f, -0.24007107f, -0.02525987f, -0.07805380f, 
    -0.03234789f, -0.03128375f, -0.05982023f, 0.02180529f, 0.19320142f, -0.05880822f, -0.38874599f, -0.09790950f, 
    0.13136245f, 0.28269643f, 0.20225765f, -0.11243527f, 0.15345286f, 0.14502120f, 0.08110450f, 0.06437238f, 
    -0.08554156f, -0.07613269f, -0.00320358f, 0.19722126f, 0.26515949f, -0.05232568f, 0.35486302f, -0.15718094f, 
    0.22913009f, 0.10781638f, 0.23603521f, 0.04452063f, -0.34607363f, 0.15712944f, -0.05364364f, -0.10265176f, 
    0.09435642f, 0.24116269f, -0.10281788f, -0.24186699f, 0.13240461f, 0.26594719f, 0.20499282f, -0.00119257f, 
    0.20426713f, -0.08787683f, 0.02231593f, 0.09706979f, -0.09580515f, 0.11874358f, -0.01059254f, 0.10603145f, 
    -0.01673769f, -0.13099073f, 0.25779343f, 0.14871867f, -0.08603606f, 0.04574561f, 0.06481425f, 0.01639046f, 
    -0.06972733f, 0.04793970f, 0.19025363f, 0.13148621f, 0.21400873f, 0.24245830f, 0.11344398f, 0.17142785f, 
    0.15706471f, 0.13321069f, 0.09451568f, 0.29550898f, -0.11083237f, 0.20605549f, 0.17569247f, 0.25820974f, 
    0.07245880f, -0.32999623f, -0.13762531f, -0.14874296f, 0.07630064f, -0.08761986f, 0.00439159f, 0.12768075f, 
    0.11570957f, 0.08486845f, -0.01364864f, -0.16226478f, -0.02687901f, 0.03926025f, -0.43371093f, -0.08891688f, 
    -0.16577214f, 0.06536798f, 0.04385565f, -0.08817212f, 0.18596612f, 0.11976949f, -0.03432081f, -0.07157079f, 
    0.06987400f, -0.25272161f, 0.20693997f, 0.42656404f, -0.14765421f, -0.23201632f, 0.06145755f, 0.10405564f, 
    -0.15080291f, -0.10398460f, -0.03226401f, 0.05825748f, 0.02544932f, 0.00462423f, 0.04575439f, -0.00930633f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.03464681f, 0.15762076f, 0.06859426f, 0.01855799f, 0.02744459f, 0.04831144f, 0.02775030f, -0.04101067f, 
    -0.09671008f, 0.05737043f, -0.03961727f, 0.06753295f, 0.20291650f, 0.18351838f, -0.17969644f, -0.00940051f, 
    0.04709048f, 0.07535160f, 0.06429402f, 0.13682693f, 0.00602728f, 0.08914698f, -0.07017781f, 0.17739148f, 
    0.04189861f, 0.12678885f, 0.04327824f, -0.04181065f, 0.09591065f, 0.13521564f, 0.14474028f, -0.00846191f, 
    -0.03461679f, -0.12361865f, 0.11462587f, 0.02358854f, 0.07587913f, -0.07268818f, -0.06352590f, -0.10590111f, 
    0.01738023f, -0.08613396f, -0.01328034f, -0.06348939f, 0.06386623f, 0.13789862f, 0.13270545f, -0.03354672f, 
    0.16214341f, 0.14289618f, 0.00409272f, 0.17197241f, 0.17415282f, -0.08627295f, 0.08670644f, 0.21475685f, 
    0.13937859f, -0.02090144f, -0.07284372f, 0.11136694f, 0.04568531f, -0.02584585f, -0.02544036f, -0.01246949f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.39704773f, 0.05723263f, -0.10346632f, -0.16423559f, -0.02083245f, 0.12794293f, -0.59485078f, 0.11709344f, 
    0.05081058f, -0.49472654f, 0.06829540f, -0.02501685f, -0.25262693f, -0.28122342f, -0.06160960f, 0.01023670f, 
    0.08108681f, 0.05165131f, 0.01132647f, -0.15252683f, -0.16261837f, -0.11912680f, 0.13810086f, 0.14978248f, 
    -0.00773875f, 0.12461167f, -0.30709094f, -0.00795615f, -0.08009253f, -0.10674564f, -0.30356237f, 0.12869917f, 
    -0.15247245f, 0.03140589f, 0.08693413f, 0.02375317f, -0.37210092f, -0.02518081f, -0.06562536f, -0.33866364f, 
    -0.00788809f, 0.22188732f, -0.00531158f, 0.14766185f, 0.36128137f, -0.29051858f, 0.16270564f, 0.22878763f, 
    0.06916566f, -0.16086102f, 0.22938311f, -0.38283980f, -0.01488224f, -0.25275934f, 0.17291617f, -0.44134602f, 
    -0.37079602f, 0.21273774f, 0.16520925f, 0.17146276f, -0.09141505f, -0.05734742f, 0.40366307f, -0.14881963f, 
    0.06735669f, 0.03007641f, -0.01633635f, -0.17791343f, -0.22102791f, 0.03164340f, -0.15930563f, -0.02132585f, 
    -0.11121416f, -0.03536775f, 0.04311100f, 0.07665846f, -0.02188630f, -0.37024942f, -0.10035131f, -0.17945164f, 
    -0.57914174f, -0.10298057f, 0.15716471f, 0.08327700f, -0.18932994f, 0.08964819f, 0.04637356f, 0.25307670f, 
    0.06065560f, 0.19617765f, 0.07138012f, -0.24979669f, 0.12650737f, 0.27892798f, -0.41351649f, 0.01905214f, 
    -0.14017071f, -0.73157519f, -0.19550820f, -0.04950219f, 0.03644358f, 0.06330071f, -0.00687767f, 0.34933990f, 
    0.11665406f, 0.11016547f, -0.20669520f, 0.11060367f, -0.48152617f, 0.05106647f, 0.20499641f, 0.02886983f, 
    0.12785207f, -0.28924704f, -0.07141484f, 0.26582664f, 0.26032981f, -0.66214794f, 0.17775847f, -0.05592106f, 
    -0.01560145f, 0.04498110f, -0.06655186f, 0.33172271f, 0.07226187f, -0.00565374f, -0.13951476f, -0.03399111f, 
    0.21558906f, 0.15881966f, 0.04721887f, -0.08049414f, -0.60394359f, -0.19022305f, 0.18661399f, 0.07127468f, 
    0.11047252f, 0.00608447f, 0.07619168f, -0.07918987f, 0.07531390f, 0.27184725f, -0.11389321f, 0.06682454f, 
    -0.30500883f, 0.10536987f, -0.04956095f, 0.02533062f, -0.52620524f, 0.29233107f, -0.25882426f, 0.20733711f, 
    0.19067553f, -0.11246653f, -0.23007813f, -0.14608990f, -0.41133621f, 0.00868146f, -0.34864792f, -0.17568401f, 
    0.19817342f, -0.60287446f, -0.07930172f, -0.00765560f, 0.30410478f, 0.00561938f, 0.06189590f, -0.27342835f, 
    0.14211211f, -0.21375600f, -0.15710847f, 0.19883563f, -0.11803211f, 0.40064934f, -0.06825508f, -0.30834746f, 
    -0.05464568f, -0.14598612f, 0.12598687f, -0.38473746f, 0.00347197f, -0.08742411f, -0.24980444f, 0.15276971f, 
    -0.26660252f, 0.12740608f, -0.31210327f, -0.22364739f, 0.06619021f, 0.02257272f, 0.25103876f, -0.17014888f, 
    0.12453615f, -0.19450048f, -0.06107553f, -0.09729118f, 0.06201992f, 0.33405298f, 0.11972395f, -0.25506720f, 
    -0.09131512f, -0.04885433f, -0.06941552f, 0.11834830f, -0.37195542f, 0.11437789f, 0.41741073f, -0.18993197f, 
    0.28944844f, 0.06063166f, -0.30449969f, 0.17752279f, 0.15280472f, -0.34115192f, 0.29865637f, -0.34430707f, 
    -0.49347949f, 0.04154364f, 0.09392962f, -0.19863099f, 0.06099169f, 0.05103439f, -0.10819162f, -0.18891644f, 
    0.10923150f, -0.31603464f, -0.10819710f, -0.12466175f, -0.20464186f, -0.01902135f, 0.06660131f, 0.17520392f, 
    0.09884681f, -0.06260325f, -0.01835812f, -0.45567170f, -0.06944554f, 0.00610822f, -0.45928314f, 0.09889738f, 
    -0.01780644f, 0.20548144f, 0.16844273f, 0.16579388f, -0.45812955f, -0.21519378f, -0.13423307f, 0.15463579f, 
    0.16552588f, 0.08254157f, 0.29091132f, -0.11125621f, -0.06292407f, 0.09774781f, 0.23909217f, -0.13428292f, 
    0.03565820f, 0.08172826f, -0.01870543f, -0.33621040f, 0.11586447f, 0.07162670f, 0.04853473f, -0.17771563f, 
    -0.11319892f, 0.00153973f, 0.09454434f, -0.04832780f, -0.22641408f, -0.05277165f, -0.34246001f, 0.21994334f, 
    0.04547950f, 0.11006518f, 0.22598833f, 0.26685336f, -0.01984614f, 0.02194873f, -0.13158236f, -0.24028793f, 
    -0.13558458f, -0.03021528f, 0.27485117f, -0.04281501f, 0.23464902f, -0.31407300f, 0.08033300f, 0.27918971f, 
    0.07903754f, -0.04353275f, -0.14783940f, 0.05454894f, -0.42179489f, 0.10906758f, 0.07241146f, -0.11967584f, 
    0.11811802f, -0.05274313f, -0.21257618f, 0.02787972f, -0.11319477f, -0.04870013f, 0.02882402f, 0.23891245f, 
    0.03195136f, 0.27875987f, -0.06403357f, -0.14864595f, 0.00973582f, 0.17295367f, -0.00036504f, -0.33287343f, 
    0.14499266f, -0.14791918f, 0.08681635f, -0.13783729f, 0.04924880f, 0.03235797f, 0.18071371f, -0.04986284f, 
    0.11814641f, 0.09186678f, -0.01127248f, -0.11688247f, -0.08351111f, -0.15575360f, -0.23362887f, 0.04211430f, 
    -0.07506487f, -0.34889272f, 0.03018546f, 0.03166056f, 0.13607901f, -0.32415563f, 0.04179573f, 0.11858749f, 
    0.10839070f, -0.06094591f, 0.07901126f, -0.09615370f, 0.24110669f, 0.20849185f, 0.22688603f, -0.39712709f, 
    0.01808401f, 0.20076901f, 0.16666414f, -0.02958647f, 0.16063450f, 0.07302569f, -0.02745630f, 0.03667517f, 
    -0.28841886f, 0.51268941f, -0.00601037f, 0.06004103f, -0.18837042f, -0.12039655f, 0.01631436f, 0.07429331f, 
    -0.15863277f, -0.08642302f, -0.19220720f, 0.09241628f, -0.01560052f, -0.20777786f, 0.20084864f, -0.09987019f, 
    -0.09729645f, -0.28530625f, -0.13042335f, 0.03619323f, 0.14783558f, 0.15647420f, 0.20741506f, -0.11700489f, 
    -0.53223890f, -0.06121901f, -0.13826519f, -0.05062358f, 0.08826348f, -0.07846796f, -0.34163305f, 0.16180161f, 
    0.15961444f, 0.20615330f, -0.08251114f, 0.15786953f, 0.06947868f, -0.00757348f, 0.24882400f, 0.29760259f, 
    0.00274363f, -0.45016983f, 0.02000064f, -0.05323195f, 0.17921269f, 0.21759458f, 0.06117730f, -0.05187041f, 
    0.08312722f, 0.07450022f, -0.11488174f, -0.47191119f, 0.01201935f, -0.17431279f, 0.10821815f, -0.30346313f, 
    0.17307520f, -0.37119937f, 0.16757810f, 0.06968437f, -0.27101743f, 0.14382394f, -0.01378053f, -0.50064683f, 
    -0.44699180f, -0.31256613f, -0.66042131f, -0.12450639f, -0.07055694f, 0.02067409f, 0.08806347f, -0.03313882f, 
    0.15002705f, -0.06947996f, -0.03378872f, 0.19314632f, -0.21623431f, -0.47935694f, -0.01304138f, 0.00105178f, 
    0.22378743f, 0.04689793f, 0.15016243f, -0.52199280f, -0.12913327f, 0.00574904f, -0.32798260f, 0.25110430f, 
    -0.24471821f, -0.14727110f, -0.28445914f, -0.08625054f, 0.11049646f, 0.07781041f, -0.30247870f, 0.17679623f, 
    -0.06048308f, -0.45086890f, 0.05655171f, -0.20116790f, 0.13747215f, -0.44129929f, -0.03899806f, -0.09547763f, 
    0.07543548f, 0.38075787f, 0.08603577f, -0.05107144f, -0.11671653f, 0.08717399f, 0.04181288f, -0.20425875f, 
    0.13627301f, -0.11828140f, -0.22129838f, 0.00199473f, 0.07084089f, 0.30511189f, -0.11235414f, -0.23049340f, 
    0.07936615f, -0.01686826f, -0.13789497f, 0.17246263f, -0.09136513f, -0.08847250f, 0.10013723f, -0.28213346f, 
    0.19185556f, 0.39453965f, -0.02450406f, 0.11054063f, 0.21513180f, -0.08136265f, -0.07782029f, 0.24851137f, 
    -0.17680673f, -0.34984311f, 0.10916667f, 0.10442518f, 0.25098780f, 0.16962293f, -0.20023198f, -0.28035486f, 
    -0.24256057f, 0.17213257f, 0.06658205f, 0.08976521f, -0.15622836f, 0.28925428f, -0.28372526f, 0.02910347f, 
    -0.09483762f, -0.41272387f, 0.11768643f, -0.20514138f, -0.11913325f, -0.10047008f, -0.02309295f, -0.33043894f, 
    0.16202815f, -0.34437954f, -0.00805370f, -0.31435153f, 0.00116885f, -0.26088572f, -0.06304245f, -0.37489298f, 
    -0.08076577f, -0.02235564f, -0.00282963f, -0.00217194f, 0.23740867f, -0.09863273f, 0.29739287f, -0.25563383f, 
    0.04547174f, 0.06434644f, -0.29605970f, 0.21079023f, 0.13951962f, -0.12132987f, 0.12201618f, 0.04607827f, 
    0.20162241f, 0.06343747f, -0.46836618f, 0.09770437f, -0.30656153f, 0.22795926f, -0.37834719f, 0.18794328f, 
    0.01651396f, -0.11603329f, 0.35427305f, -0.01089173f, -0.03529680f, 0.03931387f, -0.08329982f, -0.10107686f, 
    -0.34597886f, 0.06762099f, -0.33747461f, -0.29247367f, -0.33305568f, 0.30624050f, 0.18252614f, -0.35253036f, 
    0.16655460f, 0.02496375f, -0.52574611f, -0.24572986f, 0.19021773f, -0.04727340f, 0.27291444f, 0.25043458f, 
    -0.26739091f, 0.16732146f, -0.05174861f, -0.38373393f, 0.09924839f, -0.02529906f, -0.39748186f, 0.23991665f, 
    0.18676803f, 0.06222035f, 0.10552306f, 0.24020241f, 0.16460656f, -0.49794948f, 0.10292734f, 0.08598411f, 
    -0.01284427f, 0.30561006f, -0.04168694f, 0.08898627f, 0.02168002f, -0.06256771f, 0.09093022f, 0.08864570f, 
    -0.04382631f, 0.01622096f, 0.11531087f, 0.07550088f, -0.26730379f, 0.24192469f, -0.53492987f, 0.15096748f, 
    -0.05946612f, -0.42807555f, -0.15964849f, -0.03953559f, -0.07042723f, -0.18554555f, 0.19056061f, -0.45291218f, 
    -0.22576661f, 0.00971449f, 0.53850198f, -0.03919592f, -0.02532407f, 0.12455194f, 0.09207157f, -0.09545082f, 
    0.13976759f, 0.11835232f, -0.04843076f, 0.10183689f, 0.35697141f, -0.34581161f, 0.07063623f, -0.24619333f, 
    0.20525515f, 0.24288025f, 0.05419178f, -0.03974025f, -0.09525222f, 0.11652352f, -0.03474120f, -0.27913374f, 
    0.06190861f, -0.35197580f, -0.57585859f, -0.10904958f, 0.08607645f, 0.09351340f, -0.10505433f, 0.11653312f, 
    -0.32786000f, 0.25658235f, -0.04734331f, -0.24424036f, -0.09345689f, 0.16357155f, 0.06962076f, -0.49874833f, 
    0.06184873f, 0.24953867f, 0.05466994f, 0.05226631f, 0.42182386f, 0.17272870f, -0.09556044f, -0.25635758f, 
    -0.31758648f, 0.10900809f, -0.14181390f, -0.04914030f, 0.13116734f, 0.00904968f, -0.22606529f, 0.28004479f, 
    -0.25043130f, -0.02346576f, 0.18842863f, -0.04880238f, -0.19405437f, 0.09309827f, 0.22416410f, 0.06815664f, 
    -0.03077061f, 0.03147015f, -0.23750308f, -0.08454680f, 0.23079647f, -0.05818619f, 0.00342141f, -0.43467769f, 
    -0.12258550f, -0.41596964f, -0.06204185f, -0.27987972f, -0.30668658f, 0.14316803f, -0.35374215f, -0.04147517f, 
    -0.30498415f, -0.11350617f, -0.02313418f, 0.05526124f, -0.01208090f, 0.17179359f, -0.04915455f, 0.16582203f, 
    0.29120523f, 0.07225891f, 0.03527668f, -0.19748309f, 0.06936114f, -0.04163961f, 0.05968653f, -0.04243243f, 
    -0.39394671f, -0.18688464f, -0.03510578f, 0.27834418f, 0.05180903f, -0.03055605f, 0.24315359f, 0.04116674f, 
    -0.00954164f, -0.50426400f, -0.07230242f, -0.00971286f, -0.19744837f, -0.04363664f, -0.18997565f, 0.15313041f, 
    -0.12983218f, -0.05683465f, -0.20556912f, -0.02572766f, 0.13434763f, -0.49846467f, -0.20443960f, -0.35585406f, 
    0.23831679f, 0.23837860f, -0.15942115f, 0.03250936f, 0.01325550f, -0.12898910f, 0.08522658f, -0.14243884f, 
    0.19661374f, -0.17295974f, 0.21897119f, 0.03015254f, 0.17493895f, -0.05646084f, 0.09564763f, -0.09910976f, 
    0.13433023f, -0.00503972f, 0.34494826f, 0.01645640f, -0.21157786f, -0.16152039f, 0.12073448f, -0.05917396f, 
    -0.34360152f, -0.37903994f, 0.12293234f, 0.35213074f, -0.02215190f, -0.05364869f, 0.07111774f, 0.20135465f, 
    -0.08050566f, 0.06377847f, -0.16900708f, -0.19632119f, 0.12386291f, 0.06802732f, -0.13221852f, 0.20975164f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.08744765f, -0.04507640f, 0.08346263f, -0.05485011f, -0.01040097f, -0.12835065f, -0.00600505f, -0.20187047f, 
    -0.00204762f, 0.07438913f, 0.07481363f, 0.10909355f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
